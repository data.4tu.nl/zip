12388, 1, 1.4666666666667, 0.022727272727273
12389, 1, 1.4833333333333, 0.45454545454545
12390, 1, 1.4833333333333, 0.40909090909091
12391, 1, 1.4833333333333, 0.36363636363636
12392, 1, 1.4833333333333, 0.31818181818182
12393, 1, 1.4833333333333, 0.27272727272727
12394, 1, 1.4833333333333, 0.22727272727273
12395, 1, 1.4833333333333, 0.18181818181818
12396, 1, 1.4833333333333, 0.13636363636364
12397, 1, 1.4833333333333, 0.090909090909091
12398, 1, 1.4833333333333, 0.045454545454545
12399, 0.95652173913043, 1.4333333333333, 0.5
12400, 0.91304347826087, 1.4333333333333, 0.5
12401, 0.8695652173913, 1.4333333333333, 0.5
12402, 0.82608695652174, 1.4333333333333, 0.5
12403, 0.78260869565217, 1.4333333333333, 0.5
12404, 0.73913043478261, 1.4333333333333, 0.5
12405, 0.69565217391304, 1.4333333333333, 0.5
12406, 0.65217391304348, 1.4333333333333, 0.5
12407, 0.60869565217391, 1.4333333333333, 0.5
12408, 0.56521739130435, 1.4333333333333, 0.5
12409, 0.52173913043478, 1.4333333333333, 0.5
12410, 0.47826086956522, 1.4333333333333, 0.5
12411, 0.43478260869565, 1.4333333333333, 0.5
12412, 0.39130434782609, 1.4333333333333, 0.5
12413, 0.34782608695652, 1.4333333333333, 0.5
12414, 0.30434782608696, 1.4333333333333, 0.5
12415, 0.26086956521739, 1.4333333333333, 0.5
12416, 0.21739130434783, 1.4333333333333, 0.5
12417, 0.17391304347826, 1.4333333333333, 0.5
12418, 0.1304347826087, 1.4333333333333, 0.5
12419, 0.08695652173913, 1.4333333333333, 0.5
12420, 0.043478260869565, 1.4333333333333, 0.5
12421, 0.95652173913043, 1.4666666666667, 0.5
12422, 0.91304347826087, 1.4666666666667, 0.5
12423, 0.8695652173913, 1.4666666666667, 0.5
12424, 0.82608695652174, 1.4666666666667, 0.5
12425, 0.78260869565217, 1.4666666666667, 0.5
12426, 0.73913043478261, 1.4666666666667, 0.5
12427, 0.69565217391304, 1.4666666666667, 0.5
12428, 0.65217391304348, 1.4666666666667, 0.5
12429, 0.60869565217391, 1.4666666666667, 0.5
12430, 0.56521739130435, 1.4666666666667, 0.5
12431, 0.52173913043478, 1.4666666666667, 0.5
12432, 0.47826086956522, 1.4666666666667, 0.5
12433, 0.43478260869565, 1.4666666666667, 0.5
12434, 0.39130434782609, 1.4666666666667, 0.5
12435, 0.34782608695652, 1.4666666666667, 0.5
12436, 0.30434782608696, 1.4666666666667, 0.5
12437, 0.26086956521739, 1.4666666666667, 0.5
12438, 0.21739130434783, 1.4666666666667, 0.5
12439, 0.17391304347826, 1.4666666666667, 0.5
12440, 0.1304347826087, 1.4666666666667, 0.5
12441, 0.08695652173913, 1.4666666666667, 0.5
12442, 0.043478260869565, 1.4666666666667, 0.5
12443, 0.97826086956522, 1.4333333333333, 0.5
12444, 0.95652173913043, 1.4166666666667, 0.5
12445, 0.93478260869565, 1.4333333333333, 0.5
12446, 0.91304347826087, 1.4166666666667, 0.5
12447, 0.89130434782609, 1.4333333333333, 0.5
12448, 0.8695652173913, 1.4166666666667, 0.5
12449, 0.84782608695652, 1.4333333333333, 0.5
12450, 0.82608695652174, 1.4166666666667, 0.5
12451, 0.80434782608696, 1.4333333333333, 0.5
12452, 0.78260869565217, 1.4166666666667, 0.5
12453, 0.76086956521739, 1.4333333333333, 0.5
12454, 0.73913043478261, 1.4166666666667, 0.5
12455, 0.71739130434783, 1.4333333333333, 0.5
12456, 0.69565217391304, 1.4166666666667, 0.5
12457, 0.67391304347826, 1.4333333333333, 0.5
12458, 0.65217391304348, 1.4166666666667, 0.5
12459, 0.6304347826087, 1.4333333333333, 0.5
12460, 0.60869565217391, 1.4166666666667, 0.5
12461, 0.58695652173913, 1.4333333333333, 0.5
12462, 0.56521739130435, 1.4166666666667, 0.5
12463, 0.54347826086957, 1.4333333333333, 0.5
12464, 0.52173913043478, 1.4166666666667, 0.5
12465, 0.5, 1.4333333333333, 0.5
12466, 0.47826086956522, 1.4166666666667, 0.5
12467, 0.45652173913043, 1.4333333333333, 0.5
12468, 0.43478260869565, 1.4166666666667, 0.5
12469, 0.41304347826087, 1.4333333333333, 0.5
12470, 0.39130434782609, 1.4166666666667, 0.5
12471, 0.3695652173913, 1.4333333333333, 0.5
12472, 0.34782608695652, 1.4166666666667, 0.5
12473, 0.32608695652174, 1.4333333333333, 0.5
12474, 0.30434782608696, 1.4166666666667, 0.5
12475, 0.28260869565217, 1.4333333333333, 0.5
12476, 0.26086956521739, 1.4166666666667, 0.5
12477, 0.23913043478261, 1.4333333333333, 0.5
12478, 0.21739130434783, 1.4166666666667, 0.5
12479, 0.19565217391304, 1.4333333333333, 0.5
12480, 0.17391304347826, 1.4166666666667, 0.5
12481, 0.15217391304348, 1.4333333333333, 0.5
12482, 0.1304347826087, 1.4166666666667, 0.5
12483, 0.10869565217391, 1.4333333333333, 0.5
12484, 0.08695652173913, 1.4166666666667, 0.5
12485, 0.065217391304348, 1.4333333333333, 0.5
12486, 0.043478260869565, 1.4166666666667, 0.5
12487, 0.021739130434783, 1.4333333333333, 0.5
12488, 0.97826086956522, 1.4666666666667, 0.5
12489, 0.95652173913043, 1.45, 0.5
12490, 0.93478260869565, 1.4666666666667, 0.5
12491, 0.91304347826087, 1.45, 0.5
12492, 0.89130434782609, 1.4666666666667, 0.5
12493, 0.8695652173913, 1.45, 0.5
12494, 0.84782608695652, 1.4666666666667, 0.5
12495, 0.82608695652174, 1.45, 0.5
12496, 0.80434782608696, 1.4666666666667, 0.5
12497, 0.78260869565217, 1.45, 0.5
12498, 0.76086956521739, 1.4666666666667, 0.5
12499, 0.73913043478261, 1.45, 0.5
12500, 0.71739130434783, 1.4666666666667, 0.5
12501, 0.69565217391304, 1.45, 0.5
12502, 0.67391304347826, 1.4666666666667, 0.5
12503, 0.65217391304348, 1.45, 0.5
12504, 0.6304347826087, 1.4666666666667, 0.5
12505, 0.60869565217391, 1.45, 0.5
12506, 0.58695652173913, 1.4666666666667, 0.5
12507, 0.56521739130435, 1.45, 0.5
12508, 0.54347826086957, 1.4666666666667, 0.5
12509, 0.52173913043478, 1.45, 0.5
12510, 0.5, 1.4666666666667, 0.5
12511, 0.47826086956522, 1.45, 0.5
12512, 0.45652173913043, 1.4666666666667, 0.5
12513, 0.43478260869565, 1.45, 0.5
12514, 0.41304347826087, 1.4666666666667, 0.5
12515, 0.39130434782609, 1.45, 0.5
12516, 0.3695652173913, 1.4666666666667, 0.5
12517, 0.34782608695652, 1.45, 0.5
12518, 0.32608695652174, 1.4666666666667, 0.5
12519, 0.30434782608696, 1.45, 0.5
12520, 0.28260869565217, 1.4666666666667, 0.5
12521, 0.26086956521739, 1.45, 0.5
12522, 0.23913043478261, 1.4666666666667, 0.5
12523, 0.21739130434783, 1.45, 0.5
12524, 0.19565217391304, 1.4666666666667, 0.5
12525, 0.17391304347826, 1.45, 0.5
12526, 0.15217391304348, 1.4666666666667, 0.5
12527, 0.1304347826087, 1.45, 0.5
12528, 0.10869565217391, 1.4666666666667, 0.5
12529, 0.08695652173913, 1.45, 0.5
12530, 0.065217391304348, 1.4666666666667, 0.5
12531, 0.043478260869565, 1.45, 0.5
12532, 0.021739130434783, 1.4666666666667, 0.5
12533, 0.95652173913043, 1.4833333333333, 0.5
12534, 0.91304347826087, 1.4833333333333, 0.5
12535, 0.8695652173913, 1.4833333333333, 0.5
12536, 0.82608695652174, 1.4833333333333, 0.5
12537, 0.78260869565217, 1.4833333333333, 0.5
12538, 0.73913043478261, 1.4833333333333, 0.5
12539, 0.69565217391304, 1.4833333333333, 0.5
12540, 0.65217391304348, 1.4833333333333, 0.5
12541, 0.60869565217391, 1.4833333333333, 0.5
12542, 0.56521739130435, 1.4833333333333, 0.5
12543, 0.52173913043478, 1.4833333333333, 0.5
12544, 0.47826086956522, 1.4833333333333, 0.5
12545, 0.43478260869565, 1.4833333333333, 0.5
12546, 0.39130434782609, 1.4833333333333, 0.5
12547, 0.34782608695652, 1.4833333333333, 0.5
12548, 0.30434782608696, 1.4833333333333, 0.5
12549, 0.26086956521739, 1.4833333333333, 0.5
12550, 0.21739130434783, 1.4833333333333, 0.5
12551, 0.17391304347826, 1.4833333333333, 0.5
12552, 0.1304347826087, 1.4833333333333, 0.5
12553, 0.08695652173913, 1.4833333333333, 0.5
12554, 0.043478260869565, 1.4833333333333, 0.5
12555, 0, 1.4333333333333, 0.45454545454545
12556, 0, 1.4333333333333, 0.40909090909091
12557, 0, 1.4333333333333, 0.36363636363636
12558, 0, 1.4333333333333, 0.31818181818182
12559, 0, 1.4333333333333, 0.27272727272727
12560, 0, 1.4333333333333, 0.22727272727273
12561, 0, 1.4333333333333, 0.18181818181818
12562, 0, 1.4333333333333, 0.13636363636364
12563, 0, 1.4333333333333, 0.090909090909091
12564, 0, 1.4333333333333, 0.045454545454545
12565, 0, 1.4666666666667, 0.45454545454545
12566, 0, 1.4666666666667, 0.40909090909091
12567, 0, 1.4666666666667, 0.36363636363636
12568, 0, 1.4666666666667, 0.31818181818182
12569, 0, 1.4666666666667, 0.27272727272727
12570, 0, 1.4666666666667, 0.22727272727273
12571, 0, 1.4666666666667, 0.18181818181818
12572, 0, 1.4666666666667, 0.13636363636364
12573, 0, 1.4666666666667, 0.090909090909091
12574, 0, 1.4666666666667, 0.045454545454545
12575, 0, 1.4333333333333, 0.47727272727273
12576, 0, 1.4166666666667, 0.45454545454545
12577, 0, 1.4333333333333, 0.43181818181818
12578, 0, 1.4166666666667, 0.40909090909091
12579, 0, 1.4333333333333, 0.38636363636364
12580, 0, 1.4166666666667, 0.36363636363636
12581, 0, 1.4333333333333, 0.34090909090909
12582, 0, 1.4166666666667, 0.31818181818182
12583, 0, 1.4333333333333, 0.29545454545455
12584, 0, 1.4166666666667, 0.27272727272727
12585, 0, 1.4333333333333, 0.25
12586, 0, 1.4166666666667, 0.22727272727273
12587, 0, 1.4333333333333, 0.20454545454545
12588, 0, 1.4166666666667, 0.18181818181818
12589, 0, 1.4333333333333, 0.15909090909091
12590, 0, 1.4166666666667, 0.13636363636364
12591, 0, 1.4333333333333, 0.11363636363636
12592, 0, 1.4166666666667, 0.090909090909091
12593, 0, 1.4333333333333, 0.068181818181818
12594, 0, 1.4166666666667, 0.045454545454545
12595, 0, 1.4333333333333, 0.022727272727273
12596, 0, 1.4666666666667, 0.47727272727273
12597, 0, 1.45, 0.45454545454545
12598, 0, 1.4666666666667, 0.43181818181818
12599, 0, 1.45, 0.40909090909091
12600, 0, 1.4666666666667, 0.38636363636364
12601, 0, 1.45, 0.36363636363636
12602, 0, 1.4666666666667, 0.34090909090909
12603, 0, 1.45, 0.31818181818182
12604, 0, 1.4666666666667, 0.29545454545455
12605, 0, 1.45, 0.27272727272727
12606, 0, 1.4666666666667, 0.25
12607, 0, 1.45, 0.22727272727273
12608, 0, 1.4666666666667, 0.20454545454545
12609, 0, 1.45, 0.18181818181818
12610, 0, 1.4666666666667, 0.15909090909091
12611, 0, 1.45, 0.13636363636364
12612, 0, 1.4666666666667, 0.11363636363636
12613, 0, 1.45, 0.090909090909091
12614, 0, 1.4666666666667, 0.068181818181818
12615, 0, 1.45, 0.045454545454545
12616, 0, 1.4666666666667, 0.022727272727273
12617, 0, 1.4833333333333, 0.45454545454545
12618, 0, 1.4833333333333, 0.40909090909091
12619, 0, 1.4833333333333, 0.36363636363636
12620, 0, 1.4833333333333, 0.31818181818182
12621, 0, 1.4833333333333, 0.27272727272727
12622, 0, 1.4833333333333, 0.22727272727273
12623, 0, 1.4833333333333, 0.18181818181818
12624, 0, 1.4833333333333, 0.13636363636364
12625, 0, 1.4833333333333, 0.090909090909091
12626, 0, 1.4833333333333, 0.045454545454545
12627, 0.043478260869565, 1.5, 0.045454545454545
12628, 0.043478260869565, 1.5, 0.090909090909091
12629, 0.043478260869565, 1.5, 0.13636363636364
12630, 0.043478260869565, 1.5, 0.18181818181818
12631, 0.043478260869565, 1.5, 0.22727272727273
12632, 0.043478260869565, 1.5, 0.27272727272727
12633, 0.043478260869565, 1.5, 0.31818181818182
12634, 0.043478260869565, 1.5, 0.36363636363636
12635, 0.043478260869565, 1.5, 0.40909090909091
12636, 0.043478260869565, 1.5, 0.45454545454545
12637, 0.08695652173913, 1.5, 0.045454545454545
12638, 0.08695652173913, 1.5, 0.090909090909091
12639, 0.08695652173913, 1.5, 0.13636363636364
12640, 0.08695652173913, 1.5, 0.18181818181818
12641, 0.08695652173913, 1.5, 0.22727272727273
12642, 0.08695652173913, 1.5, 0.27272727272727
12643, 0.08695652173913, 1.5, 0.31818181818182
12644, 0.08695652173913, 1.5, 0.36363636363636
12645, 0.08695652173913, 1.5, 0.40909090909091
12646, 0.08695652173913, 1.5, 0.45454545454545
12647, 0.1304347826087, 1.5, 0.045454545454545
12648, 0.1304347826087, 1.5, 0.090909090909091
12649, 0.1304347826087, 1.5, 0.13636363636364
12650, 0.1304347826087, 1.5, 0.18181818181818
12651, 0.1304347826087, 1.5, 0.22727272727273
12652, 0.1304347826087, 1.5, 0.27272727272727
12653, 0.1304347826087, 1.5, 0.31818181818182
12654, 0.1304347826087, 1.5, 0.36363636363636
12655, 0.1304347826087, 1.5, 0.40909090909091
12656, 0.1304347826087, 1.5, 0.45454545454545
12657, 0.17391304347826, 1.5, 0.045454545454545
12658, 0.17391304347826, 1.5, 0.090909090909091
12659, 0.17391304347826, 1.5, 0.13636363636364
12660, 0.17391304347826, 1.5, 0.18181818181818
12661, 0.17391304347826, 1.5, 0.22727272727273
12662, 0.17391304347826, 1.5, 0.27272727272727
12663, 0.17391304347826, 1.5, 0.31818181818182
12664, 0.17391304347826, 1.5, 0.36363636363636
12665, 0.17391304347826, 1.5, 0.40909090909091
12666, 0.17391304347826, 1.5, 0.45454545454545
12667, 0.21739130434783, 1.5, 0.045454545454545
12668, 0.21739130434783, 1.5, 0.090909090909091
12669, 0.21739130434783, 1.5, 0.13636363636364
12670, 0.21739130434783, 1.5, 0.18181818181818
12671, 0.21739130434783, 1.5, 0.22727272727273
12672, 0.21739130434783, 1.5, 0.27272727272727
12673, 0.21739130434783, 1.5, 0.31818181818182
12674, 0.21739130434783, 1.5, 0.36363636363636
12675, 0.21739130434783, 1.5, 0.40909090909091
12676, 0.21739130434783, 1.5, 0.45454545454545
12677, 0.26086956521739, 1.5, 0.045454545454545
12678, 0.26086956521739, 1.5, 0.090909090909091
12679, 0.26086956521739, 1.5, 0.13636363636364
12680, 0.26086956521739, 1.5, 0.18181818181818
12681, 0.26086956521739, 1.5, 0.22727272727273
12682, 0.26086956521739, 1.5, 0.27272727272727
12683, 0.26086956521739, 1.5, 0.31818181818182
12684, 0.26086956521739, 1.5, 0.36363636363636
12685, 0.26086956521739, 1.5, 0.40909090909091
12686, 0.26086956521739, 1.5, 0.45454545454545
12687, 0.30434782608696, 1.5, 0.045454545454545
12688, 0.30434782608696, 1.5, 0.090909090909091
12689, 0.30434782608696, 1.5, 0.13636363636364
12690, 0.30434782608696, 1.5, 0.18181818181818
12691, 0.30434782608696, 1.5, 0.22727272727273
12692, 0.30434782608696, 1.5, 0.27272727272727
12693, 0.30434782608696, 1.5, 0.31818181818182
12694, 0.30434782608696, 1.5, 0.36363636363636
12695, 0.30434782608696, 1.5, 0.40909090909091
12696, 0.30434782608696, 1.5, 0.45454545454545
12697, 0.34782608695652, 1.5, 0.045454545454545
12698, 0.34782608695652, 1.5, 0.090909090909091
12699, 0.34782608695652, 1.5, 0.13636363636364
12700, 0.34782608695652, 1.5, 0.18181818181818
12701, 0.34782608695652, 1.5, 0.22727272727273
12702, 0.34782608695652, 1.5, 0.27272727272727
12703, 0.34782608695652, 1.5, 0.31818181818182
12704, 0.34782608695652, 1.5, 0.36363636363636
12705, 0.34782608695652, 1.5, 0.40909090909091
12706, 0.34782608695652, 1.5, 0.45454545454545
12707, 0.39130434782609, 1.5, 0.045454545454545
12708, 0.39130434782609, 1.5, 0.090909090909091
12709, 0.39130434782609, 1.5, 0.13636363636364
12710, 0.39130434782609, 1.5, 0.18181818181818
12711, 0.39130434782609, 1.5, 0.22727272727273
12712, 0.39130434782609, 1.5, 0.27272727272727
12713, 0.39130434782609, 1.5, 0.31818181818182
12714, 0.39130434782609, 1.5, 0.36363636363636
12715, 0.39130434782609, 1.5, 0.40909090909091
12716, 0.39130434782609, 1.5, 0.45454545454545
12717, 0.43478260869565, 1.5, 0.045454545454545
12718, 0.43478260869565, 1.5, 0.090909090909091
12719, 0.43478260869565, 1.5, 0.13636363636364
12720, 0.43478260869565, 1.5, 0.18181818181818
12721, 0.43478260869565, 1.5, 0.22727272727273
12722, 0.43478260869565, 1.5, 0.27272727272727
12723, 0.43478260869565, 1.5, 0.31818181818182
12724, 0.43478260869565, 1.5, 0.36363636363636
12725, 0.43478260869565, 1.5, 0.40909090909091
12726, 0.43478260869565, 1.5, 0.45454545454545
12727, 0.47826086956522, 1.5, 0.045454545454545
12728, 0.47826086956522, 1.5, 0.090909090909091
12729, 0.47826086956522, 1.5, 0.13636363636364
12730, 0.47826086956522, 1.5, 0.18181818181818
12731, 0.47826086956522, 1.5, 0.22727272727273
12732, 0.47826086956522, 1.5, 0.27272727272727
12733, 0.47826086956522, 1.5, 0.31818181818182
12734, 0.47826086956522, 1.5, 0.36363636363636
12735, 0.47826086956522, 1.5, 0.40909090909091
12736, 0.47826086956522, 1.5, 0.45454545454545
12737, 0.52173913043478, 1.5, 0.045454545454545
12738, 0.52173913043478, 1.5, 0.090909090909091
12739, 0.52173913043478, 1.5, 0.13636363636364
12740, 0.52173913043478, 1.5, 0.18181818181818
12741, 0.52173913043478, 1.5, 0.22727272727273
12742, 0.52173913043478, 1.5, 0.27272727272727
12743, 0.52173913043478, 1.5, 0.31818181818182
12744, 0.52173913043478, 1.5, 0.36363636363636
12745, 0.52173913043478, 1.5, 0.40909090909091
12746, 0.52173913043478, 1.5, 0.45454545454545
12747, 0.56521739130435, 1.5, 0.045454545454545
12748, 0.56521739130435, 1.5, 0.090909090909091
12749, 0.56521739130435, 1.5, 0.13636363636364
12750, 0.56521739130435, 1.5, 0.18181818181818
12751, 0.56521739130435, 1.5, 0.22727272727273
12752, 0.56521739130435, 1.5, 0.27272727272727
12753, 0.56521739130435, 1.5, 0.31818181818182
12754, 0.56521739130435, 1.5, 0.36363636363636
12755, 0.56521739130435, 1.5, 0.40909090909091
12756, 0.56521739130435, 1.5, 0.45454545454545
12757, 0.60869565217391, 1.5, 0.045454545454545
12758, 0.60869565217391, 1.5, 0.090909090909091
12759, 0.60869565217391, 1.5, 0.13636363636364
12760, 0.60869565217391, 1.5, 0.18181818181818
12761, 0.60869565217391, 1.5, 0.22727272727273
12762, 0.60869565217391, 1.5, 0.27272727272727
12763, 0.60869565217391, 1.5, 0.31818181818182
12764, 0.60869565217391, 1.5, 0.36363636363636
12765, 0.60869565217391, 1.5, 0.40909090909091
12766, 0.60869565217391, 1.5, 0.45454545454545
12767, 0.65217391304348, 1.5, 0.045454545454545
12768, 0.65217391304348, 1.5, 0.090909090909091
12769, 0.65217391304348, 1.5, 0.13636363636364
12770, 0.65217391304348, 1.5, 0.18181818181818
12771, 0.65217391304348, 1.5, 0.22727272727273
12772, 0.65217391304348, 1.5, 0.27272727272727
12773, 0.65217391304348, 1.5, 0.31818181818182
12774, 0.65217391304348, 1.5, 0.36363636363636
12775, 0.65217391304348, 1.5, 0.40909090909091
12776, 0.65217391304348, 1.5, 0.45454545454545
12777, 0.69565217391304, 1.5, 0.045454545454545
12778, 0.69565217391304, 1.5, 0.090909090909091
12779, 0.69565217391304, 1.5, 0.13636363636364
12780, 0.69565217391304, 1.5, 0.18181818181818
12781, 0.69565217391304, 1.5, 0.22727272727273
12782, 0.69565217391304, 1.5, 0.27272727272727
12783, 0.69565217391304, 1.5, 0.31818181818182
12784, 0.69565217391304, 1.5, 0.36363636363636
12785, 0.69565217391304, 1.5, 0.40909090909091
12786, 0.69565217391304, 1.5, 0.45454545454545
12787, 0.73913043478261, 1.5, 0.045454545454545
12788, 0.73913043478261, 1.5, 0.090909090909091
12789, 0.73913043478261, 1.5, 0.13636363636364
12790, 0.73913043478261, 1.5, 0.18181818181818
12791, 0.73913043478261, 1.5, 0.22727272727273
12792, 0.73913043478261, 1.5, 0.27272727272727
12793, 0.73913043478261, 1.5, 0.31818181818182
12794, 0.73913043478261, 1.5, 0.36363636363636
12795, 0.73913043478261, 1.5, 0.40909090909091
12796, 0.73913043478261, 1.5, 0.45454545454545
12797, 0.78260869565217, 1.5, 0.045454545454545
12798, 0.78260869565217, 1.5, 0.090909090909091
12799, 0.78260869565217, 1.5, 0.13636363636364
12800, 0.78260869565217, 1.5, 0.18181818181818
12801, 0.78260869565217, 1.5, 0.22727272727273
12802, 0.78260869565217, 1.5, 0.27272727272727
12803, 0.78260869565217, 1.5, 0.31818181818182
12804, 0.78260869565217, 1.5, 0.36363636363636
12805, 0.78260869565217, 1.5, 0.40909090909091
12806, 0.78260869565217, 1.5, 0.45454545454545
12807, 0.82608695652174, 1.5, 0.045454545454545
12808, 0.82608695652174, 1.5, 0.090909090909091
12809, 0.82608695652174, 1.5, 0.13636363636364
12810, 0.82608695652174, 1.5, 0.18181818181818
12811, 0.82608695652174, 1.5, 0.22727272727273
12812, 0.82608695652174, 1.5, 0.27272727272727
12813, 0.82608695652174, 1.5, 0.31818181818182
12814, 0.82608695652174, 1.5, 0.36363636363636
12815, 0.82608695652174, 1.5, 0.40909090909091
12816, 0.82608695652174, 1.5, 0.45454545454545
12817, 0.8695652173913, 1.5, 0.045454545454545
12818, 0.8695652173913, 1.5, 0.090909090909091
12819, 0.8695652173913, 1.5, 0.13636363636364
12820, 0.8695652173913, 1.5, 0.18181818181818
12821, 0.8695652173913, 1.5, 0.22727272727273
12822, 0.8695652173913, 1.5, 0.27272727272727
12823, 0.8695652173913, 1.5, 0.31818181818182
12824, 0.8695652173913, 1.5, 0.36363636363636
12825, 0.8695652173913, 1.5, 0.40909090909091
12826, 0.8695652173913, 1.5, 0.45454545454545
12827, 0.91304347826087, 1.5, 0.045454545454545
12828, 0.91304347826087, 1.5, 0.090909090909091
12829, 0.91304347826087, 1.5, 0.13636363636364
12830, 0.91304347826087, 1.5, 0.18181818181818
12831, 0.91304347826087, 1.5, 0.22727272727273
12832, 0.91304347826087, 1.5, 0.27272727272727
12833, 0.91304347826087, 1.5, 0.31818181818182
12834, 0.91304347826087, 1.5, 0.36363636363636
12835, 0.91304347826087, 1.5, 0.40909090909091
12836, 0.91304347826087, 1.5, 0.45454545454545
12837, 0.95652173913043, 1.5, 0.045454545454545
12838, 0.95652173913043, 1.5, 0.090909090909091
12839, 0.95652173913044, 1.5, 0.13636363636364
12840, 0.95652173913043, 1.5, 0.18181818181818
12841, 0.95652173913043, 1.5, 0.22727272727273
12842, 0.95652173913043, 1.5, 0.27272727272727
12843, 0.95652173913043, 1.5, 0.31818181818182
12844, 0.95652173913043, 1.5, 0.36363636363636
12845, 0.95652173913043, 1.5, 0.40909090909091
12846, 0.95652173913043, 1.5, 0.45454545454545
12847, 0.021739130434783, 1.5, 0.045454545454545
12848, 0.043478260869565, 1.5, 0.022727272727273
12849, 0.021739130434783, 1.5, 0.090909090909091
12850, 0.043478260869565, 1.5, 0.068181818181818
12851, 0.021739130434783, 1.5, 0.13636363636364
12852, 0.043478260869565, 1.5, 0.11363636363636
12853, 0.021739130434783, 1.5, 0.18181818181818
12854, 0.043478260869565, 1.5, 0.15909090909091
12855, 0.021739130434783, 1.5, 0.22727272727273
12856, 0.043478260869565, 1.5, 0.20454545454545
12857, 0.021739130434783, 1.5, 0.27272727272727
12858, 0.043478260869565, 1.5, 0.25
12859, 0.021739130434783, 1.5, 0.31818181818182
12860, 0.043478260869565, 1.5, 0.29545454545455
12861, 0.021739130434783, 1.5, 0.36363636363636
12862, 0.043478260869565, 1.5, 0.34090909090909
12863, 0.021739130434783, 1.5, 0.40909090909091
12864, 0.043478260869565, 1.5, 0.38636363636364
12865, 0.021739130434783, 1.5, 0.45454545454545
12866, 0.043478260869565, 1.5, 0.43181818181818
12867, 0.043478260869565, 1.5, 0.47727272727273
12868, 0.065217391304348, 1.5, 0.045454545454545
12869, 0.08695652173913, 1.5, 0.022727272727273
12870, 0.065217391304348, 1.5, 0.090909090909091
12871, 0.08695652173913, 1.5, 0.068181818181818
12872, 0.065217391304348, 1.5, 0.13636363636364
12873, 0.08695652173913, 1.5, 0.11363636363636
12874, 0.065217391304348, 1.5, 0.18181818181818
12875, 0.08695652173913, 1.5, 0.15909090909091
12876, 0.065217391304348, 1.5, 0.22727272727273
12877, 0.08695652173913, 1.5, 0.20454545454545
12878, 0.065217391304348, 1.5, 0.27272727272727
12879, 0.08695652173913, 1.5, 0.25
12880, 0.065217391304348, 1.5, 0.31818181818182
12881, 0.08695652173913, 1.5, 0.29545454545455
12882, 0.065217391304348, 1.5, 0.36363636363636
12883, 0.08695652173913, 1.5, 0.34090909090909
12884, 0.065217391304348, 1.5, 0.40909090909091
12885, 0.08695652173913, 1.5, 0.38636363636364
12886, 0.065217391304348, 1.5, 0.45454545454545
12887, 0.08695652173913, 1.5, 0.43181818181818
12888, 0.08695652173913, 1.5, 0.47727272727273
12889, 0.10869565217391, 1.5, 0.045454545454545
12890, 0.1304347826087, 1.5, 0.022727272727273
12891, 0.10869565217391, 1.5, 0.090909090909091
12892, 0.1304347826087, 1.5, 0.068181818181818
12893, 0.10869565217391, 1.5, 0.13636363636364
12894, 0.1304347826087, 1.5, 0.11363636363636
12895, 0.10869565217391, 1.5, 0.18181818181818
12896, 0.1304347826087, 1.5, 0.15909090909091
12897, 0.10869565217391, 1.5, 0.22727272727273
12898, 0.1304347826087, 1.5, 0.20454545454545
12899, 0.10869565217391, 1.5, 0.27272727272727
12900, 0.1304347826087, 1.5, 0.25
12901, 0.10869565217391, 1.5, 0.31818181818182
12902, 0.1304347826087, 1.5, 0.29545454545455
12903, 0.10869565217391, 1.5, 0.36363636363636
12904, 0.1304347826087, 1.5, 0.34090909090909
12905, 0.10869565217391, 1.5, 0.40909090909091
12906, 0.1304347826087, 1.5, 0.38636363636364
12907, 0.10869565217391, 1.5, 0.45454545454545
12908, 0.1304347826087, 1.5, 0.43181818181818
12909, 0.1304347826087, 1.5, 0.47727272727273
12910, 0.15217391304348, 1.5, 0.045454545454545
12911, 0.17391304347826, 1.5, 0.022727272727273
12912, 0.15217391304348, 1.5, 0.090909090909091
12913, 0.17391304347826, 1.5, 0.068181818181818
12914, 0.15217391304348, 1.5, 0.13636363636364
12915, 0.17391304347826, 1.5, 0.11363636363636
12916, 0.15217391304348, 1.5, 0.18181818181818
12917, 0.17391304347826, 1.5, 0.15909090909091
12918, 0.15217391304348, 1.5, 0.22727272727273
12919, 0.17391304347826, 1.5, 0.20454545454545
12920, 0.15217391304348, 1.5, 0.27272727272727
12921, 0.17391304347826, 1.5, 0.25
12922, 0.15217391304348, 1.5, 0.31818181818182
12923, 0.17391304347826, 1.5, 0.29545454545455
12924, 0.15217391304348, 1.5, 0.36363636363636
12925, 0.17391304347826, 1.5, 0.34090909090909
12926, 0.15217391304348, 1.5, 0.40909090909091
12927, 0.17391304347826, 1.5, 0.38636363636364
12928, 0.15217391304348, 1.5, 0.45454545454545
12929, 0.17391304347826, 1.5, 0.43181818181818
12930, 0.17391304347826, 1.5, 0.47727272727273
12931, 0.19565217391304, 1.5, 0.045454545454545
12932, 0.21739130434783, 1.5, 0.022727272727273
12933, 0.19565217391304, 1.5, 0.090909090909091
12934, 0.21739130434783, 1.5, 0.068181818181818
12935, 0.19565217391304, 1.5, 0.13636363636364
12936, 0.21739130434783, 1.5, 0.11363636363636
12937, 0.19565217391304, 1.5, 0.18181818181818
12938, 0.21739130434783, 1.5, 0.15909090909091
12939, 0.19565217391304, 1.5, 0.22727272727273
12940, 0.21739130434783, 1.5, 0.20454545454545
12941, 0.19565217391304, 1.5, 0.27272727272727
12942, 0.21739130434783, 1.5, 0.25
12943, 0.19565217391304, 1.5, 0.31818181818182
12944, 0.21739130434783, 1.5, 0.29545454545455
12945, 0.19565217391304, 1.5, 0.36363636363636
12946, 0.21739130434783, 1.5, 0.34090909090909
12947, 0.19565217391304, 1.5, 0.40909090909091
12948, 0.21739130434783, 1.5, 0.38636363636364
12949, 0.19565217391304, 1.5, 0.45454545454545
12950, 0.21739130434783, 1.5, 0.43181818181818
12951, 0.21739130434783, 1.5, 0.47727272727273
12952, 0.23913043478261, 1.5, 0.045454545454545
12953, 0.26086956521739, 1.5, 0.022727272727273
12954, 0.23913043478261, 1.5, 0.090909090909091
12955, 0.26086956521739, 1.5, 0.068181818181818
12956, 0.23913043478261, 1.5, 0.13636363636364
12957, 0.26086956521739, 1.5, 0.11363636363636
12958, 0.23913043478261, 1.5, 0.18181818181818
12959, 0.26086956521739, 1.5, 0.15909090909091
12960, 0.23913043478261, 1.5, 0.22727272727273
12961, 0.26086956521739, 1.5, 0.20454545454545
12962, 0.23913043478261, 1.5, 0.27272727272727
12963, 0.26086956521739, 1.5, 0.25
12964, 0.23913043478261, 1.5, 0.31818181818182
12965, 0.26086956521739, 1.5, 0.29545454545455
12966, 0.23913043478261, 1.5, 0.36363636363636
12967, 0.26086956521739, 1.5, 0.34090909090909
12968, 0.23913043478261, 1.5, 0.40909090909091
12969, 0.26086956521739, 1.5, 0.38636363636364
12970, 0.23913043478261, 1.5, 0.45454545454545
12971, 0.26086956521739, 1.5, 0.43181818181818
12972, 0.26086956521739, 1.5, 0.47727272727273
12973, 0.28260869565217, 1.5, 0.045454545454545
12974, 0.30434782608696, 1.5, 0.022727272727273
12975, 0.28260869565217, 1.5, 0.090909090909091
12976, 0.30434782608696, 1.5, 0.068181818181818
12977, 0.28260869565217, 1.5, 0.13636363636364
12978, 0.30434782608696, 1.5, 0.11363636363636
12979, 0.28260869565217, 1.5, 0.18181818181818
12980, 0.30434782608696, 1.5, 0.15909090909091
12981, 0.28260869565217, 1.5, 0.22727272727273
12982, 0.30434782608696, 1.5, 0.20454545454545
12983, 0.28260869565217, 1.5, 0.27272727272727
12984, 0.30434782608696, 1.5, 0.25
12985, 0.28260869565217, 1.5, 0.31818181818182
12986, 0.30434782608696, 1.5, 0.29545454545455
12987, 0.28260869565217, 1.5, 0.36363636363636
12988, 0.30434782608696, 1.5, 0.34090909090909
12989, 0.28260869565217, 1.5, 0.40909090909091
12990, 0.30434782608696, 1.5, 0.38636363636364
12991, 0.28260869565217, 1.5, 0.45454545454545
12992, 0.30434782608696, 1.5, 0.43181818181818
12993, 0.30434782608696, 1.5, 0.47727272727273
12994, 0.32608695652174, 1.5, 0.045454545454545
12995, 0.34782608695652, 1.5, 0.022727272727273
12996, 0.32608695652174, 1.5, 0.090909090909091
12997, 0.34782608695652, 1.5, 0.068181818181818
12998, 0.32608695652174, 1.5, 0.13636363636364
12999, 0.34782608695652, 1.5, 0.11363636363636
13000, 0.32608695652174, 1.5, 0.18181818181818
13001, 0.34782608695652, 1.5, 0.15909090909091
13002, 0.32608695652174, 1.5, 0.22727272727273
13003, 0.34782608695652, 1.5, 0.20454545454545
13004, 0.32608695652174, 1.5, 0.27272727272727
13005, 0.34782608695652, 1.5, 0.25
13006, 0.32608695652174, 1.5, 0.31818181818182
13007, 0.34782608695652, 1.5, 0.29545454545455
13008, 0.32608695652174, 1.5, 0.36363636363636
13009, 0.34782608695652, 1.5, 0.34090909090909
13010, 0.32608695652174, 1.5, 0.40909090909091
13011, 0.34782608695652, 1.5, 0.38636363636364
13012, 0.32608695652174, 1.5, 0.45454545454545
13013, 0.34782608695652, 1.5, 0.43181818181818
13014, 0.34782608695652, 1.5, 0.47727272727273
13015, 0.3695652173913, 1.5, 0.045454545454545
13016, 0.39130434782609, 1.5, 0.022727272727273
13017, 0.3695652173913, 1.5, 0.090909090909091
13018, 0.39130434782609, 1.5, 0.068181818181818
13019, 0.3695652173913, 1.5, 0.13636363636364
13020, 0.39130434782609, 1.5, 0.11363636363636
13021, 0.3695652173913, 1.5, 0.18181818181818
13022, 0.39130434782609, 1.5, 0.15909090909091
13023, 0.3695652173913, 1.5, 0.22727272727273
13024, 0.39130434782609, 1.5, 0.20454545454545
13025, 0.3695652173913, 1.5, 0.27272727272727
13026, 0.39130434782609, 1.5, 0.25
13027, 0.3695652173913, 1.5, 0.31818181818182
13028, 0.39130434782609, 1.5, 0.29545454545455
13029, 0.3695652173913, 1.5, 0.36363636363636
13030, 0.39130434782609, 1.5, 0.34090909090909
13031, 0.3695652173913, 1.5, 0.40909090909091
13032, 0.39130434782609, 1.5, 0.38636363636364
13033, 0.3695652173913, 1.5, 0.45454545454545
13034, 0.39130434782609, 1.5, 0.43181818181818
13035, 0.39130434782609, 1.5, 0.47727272727273
13036, 0.41304347826087, 1.5, 0.045454545454545
13037, 0.43478260869565, 1.5, 0.022727272727273
13038, 0.41304347826087, 1.5, 0.090909090909091
13039, 0.43478260869565, 1.5, 0.068181818181818
13040, 0.41304347826087, 1.5, 0.13636363636364
13041, 0.43478260869565, 1.5, 0.11363636363636
13042, 0.41304347826087, 1.5, 0.18181818181818
13043, 0.43478260869565, 1.5, 0.15909090909091
13044, 0.41304347826087, 1.5, 0.22727272727273
13045, 0.43478260869565, 1.5, 0.20454545454545
13046, 0.41304347826087, 1.5, 0.27272727272727
13047, 0.43478260869565, 1.5, 0.25
13048, 0.41304347826087, 1.5, 0.31818181818182
13049, 0.43478260869565, 1.5, 0.29545454545455
13050, 0.41304347826087, 1.5, 0.36363636363636
13051, 0.43478260869565, 1.5, 0.34090909090909
13052, 0.41304347826087, 1.5, 0.40909090909091
13053, 0.43478260869565, 1.5, 0.38636363636364
13054, 0.41304347826087, 1.5, 0.45454545454545
13055, 0.43478260869565, 1.5, 0.43181818181818
13056, 0.43478260869565, 1.5, 0.47727272727273
13057, 0.45652173913043, 1.5, 0.045454545454545
13058, 0.47826086956522, 1.5, 0.022727272727273
13059, 0.45652173913043, 1.5, 0.090909090909091
13060, 0.47826086956522, 1.5, 0.068181818181818
13061, 0.45652173913043, 1.5, 0.13636363636364
13062, 0.47826086956522, 1.5, 0.11363636363636
13063, 0.45652173913043, 1.5, 0.18181818181818
13064, 0.47826086956522, 1.5, 0.15909090909091
13065, 0.45652173913043, 1.5, 0.22727272727273
13066, 0.47826086956522, 1.5, 0.20454545454545
13067, 0.45652173913043, 1.5, 0.27272727272727
13068, 0.47826086956522, 1.5, 0.25
13069, 0.45652173913043, 1.5, 0.31818181818182
13070, 0.47826086956522, 1.5, 0.29545454545455
13071, 0.45652173913043, 1.5, 0.36363636363636
13072, 0.47826086956522, 1.5, 0.34090909090909
13073, 0.45652173913043, 1.5, 0.40909090909091
13074, 0.47826086956522, 1.5, 0.38636363636364
13075, 0.45652173913043, 1.5, 0.45454545454545
13076, 0.47826086956522, 1.5, 0.43181818181818
13077, 0.47826086956522, 1.5, 0.47727272727273
13078, 0.5, 1.5, 0.045454545454545
13079, 0.52173913043478, 1.5, 0.022727272727273
13080, 0.5, 1.5, 0.090909090909091
13081, 0.52173913043478, 1.5, 0.068181818181818
13082, 0.5, 1.5, 0.13636363636364
13083, 0.52173913043478, 1.5, 0.11363636363636
13084, 0.5, 1.5, 0.18181818181818
13085, 0.52173913043478, 1.5, 0.15909090909091
13086, 0.5, 1.5, 0.22727272727273
13087, 0.52173913043478, 1.5, 0.20454545454545
13088, 0.5, 1.5, 0.27272727272727
13089, 0.52173913043478, 1.5, 0.25
13090, 0.5, 1.5, 0.31818181818182
13091, 0.52173913043478, 1.5, 0.29545454545455
13092, 0.5, 1.5, 0.36363636363636
13093, 0.52173913043478, 1.5, 0.34090909090909
13094, 0.5, 1.5, 0.40909090909091
13095, 0.52173913043478, 1.5, 0.38636363636364
13096, 0.5, 1.5, 0.45454545454545
13097, 0.52173913043478, 1.5, 0.43181818181818
13098, 0.52173913043478, 1.5, 0.47727272727273
13099, 0.54347826086957, 1.5, 0.045454545454545
13100, 0.56521739130435, 1.5, 0.022727272727273
13101, 0.54347826086957, 1.5, 0.090909090909091
13102, 0.56521739130435, 1.5, 0.068181818181818
13103, 0.54347826086957, 1.5, 0.13636363636364
13104, 0.56521739130435, 1.5, 0.11363636363636
13105, 0.54347826086957, 1.5, 0.18181818181818
13106, 0.56521739130435, 1.5, 0.15909090909091
13107, 0.54347826086957, 1.5, 0.22727272727273
13108, 0.56521739130435, 1.5, 0.20454545454545
13109, 0.54347826086957, 1.5, 0.27272727272727
13110, 0.56521739130435, 1.5, 0.25
13111, 0.54347826086957, 1.5, 0.31818181818182
13112, 0.56521739130435, 1.5, 0.29545454545455
13113, 0.54347826086957, 1.5, 0.36363636363636
13114, 0.56521739130435, 1.5, 0.34090909090909
13115, 0.54347826086957, 1.5, 0.40909090909091
13116, 0.56521739130435, 1.5, 0.38636363636364
13117, 0.54347826086957, 1.5, 0.45454545454545
13118, 0.56521739130435, 1.5, 0.43181818181818
13119, 0.56521739130435, 1.5, 0.47727272727273
13120, 0.58695652173913, 1.5, 0.045454545454545
13121, 0.60869565217391, 1.5, 0.022727272727273
13122, 0.58695652173913, 1.5, 0.090909090909091
13123, 0.60869565217391, 1.5, 0.068181818181818
13124, 0.58695652173913, 1.5, 0.13636363636364
13125, 0.60869565217391, 1.5, 0.11363636363636
13126, 0.58695652173913, 1.5, 0.18181818181818
13127, 0.60869565217391, 1.5, 0.15909090909091
13128, 0.58695652173913, 1.5, 0.22727272727273
13129, 0.60869565217391, 1.5, 0.20454545454545
13130, 0.58695652173913, 1.5, 0.27272727272727
13131, 0.60869565217391, 1.5, 0.25
13132, 0.58695652173913, 1.5, 0.31818181818182
13133, 0.60869565217391, 1.5, 0.29545454545455
13134, 0.58695652173913, 1.5, 0.36363636363636
13135, 0.60869565217391, 1.5, 0.34090909090909
13136, 0.58695652173913, 1.5, 0.40909090909091
13137, 0.60869565217391, 1.5, 0.38636363636364
13138, 0.58695652173913, 1.5, 0.45454545454545
13139, 0.60869565217391, 1.5, 0.43181818181818
13140, 0.60869565217391, 1.5, 0.47727272727273
13141, 0.6304347826087, 1.5, 0.045454545454545
13142, 0.65217391304348, 1.5, 0.022727272727273
13143, 0.6304347826087, 1.5, 0.090909090909091
13144, 0.65217391304348, 1.5, 0.068181818181818
13145, 0.6304347826087, 1.5, 0.13636363636364
13146, 0.65217391304348, 1.5, 0.11363636363636
13147, 0.6304347826087, 1.5, 0.18181818181818
13148, 0.65217391304348, 1.5, 0.15909090909091
13149, 0.6304347826087, 1.5, 0.22727272727273
13150, 0.65217391304348, 1.5, 0.20454545454545
13151, 0.6304347826087, 1.5, 0.27272727272727
13152, 0.65217391304348, 1.5, 0.25
13153, 0.6304347826087, 1.5, 0.31818181818182
13154, 0.65217391304348, 1.5, 0.29545454545455
13155, 0.6304347826087, 1.5, 0.36363636363636
13156, 0.65217391304348, 1.5, 0.34090909090909
13157, 0.6304347826087, 1.5, 0.40909090909091
13158, 0.65217391304348, 1.5, 0.38636363636364
13159, 0.6304347826087, 1.5, 0.45454545454545
13160, 0.65217391304348, 1.5, 0.43181818181818
13161, 0.65217391304348, 1.5, 0.47727272727273
13162, 0.67391304347826, 1.5, 0.045454545454545
13163, 0.69565217391304, 1.5, 0.022727272727273
13164, 0.67391304347826, 1.5, 0.090909090909091
13165, 0.69565217391304, 1.5, 0.068181818181818
13166, 0.67391304347826, 1.5, 0.13636363636364
13167, 0.69565217391304, 1.5, 0.11363636363636
13168, 0.67391304347826, 1.5, 0.18181818181818
13169, 0.69565217391304, 1.5, 0.15909090909091
13170, 0.67391304347826, 1.5, 0.22727272727273
13171, 0.69565217391304, 1.5, 0.20454545454545
13172, 0.67391304347826, 1.5, 0.27272727272727
13173, 0.69565217391304, 1.5, 0.25
13174, 0.67391304347826, 1.5, 0.31818181818182
13175, 0.69565217391304, 1.5, 0.29545454545455
13176, 0.67391304347826, 1.5, 0.36363636363636
13177, 0.69565217391304, 1.5, 0.34090909090909
13178, 0.67391304347826, 1.5, 0.40909090909091
13179, 0.69565217391304, 1.5, 0.38636363636364
13180, 0.67391304347826, 1.5, 0.45454545454545
13181, 0.69565217391304, 1.5, 0.43181818181818
13182, 0.69565217391304, 1.5, 0.47727272727273
13183, 0.71739130434783, 1.5, 0.045454545454545
13184, 0.73913043478261, 1.5, 0.022727272727273
13185, 0.71739130434783, 1.5, 0.090909090909091
13186, 0.73913043478261, 1.5, 0.068181818181818
13187, 0.71739130434783, 1.5, 0.13636363636364
13188, 0.73913043478261, 1.5, 0.11363636363636
13189, 0.71739130434783, 1.5, 0.18181818181818
13190, 0.73913043478261, 1.5, 0.15909090909091
13191, 0.71739130434783, 1.5, 0.22727272727273
13192, 0.73913043478261, 1.5, 0.20454545454545
13193, 0.71739130434783, 1.5, 0.27272727272727
13194, 0.73913043478261, 1.5, 0.25
13195, 0.71739130434783, 1.5, 0.31818181818182
13196, 0.73913043478261, 1.5, 0.29545454545455
13197, 0.71739130434783, 1.5, 0.36363636363636
13198, 0.73913043478261, 1.5, 0.34090909090909
13199, 0.71739130434783, 1.5, 0.40909090909091
13200, 0.73913043478261, 1.5, 0.38636363636364
13201, 0.71739130434783, 1.5, 0.45454545454545
13202, 0.73913043478261, 1.5, 0.43181818181818
13203, 0.73913043478261, 1.5, 0.47727272727273
13204, 0.76086956521739, 1.5, 0.045454545454545
13205, 0.78260869565217, 1.5, 0.022727272727273
13206, 0.76086956521739, 1.5, 0.090909090909091
13207, 0.78260869565217, 1.5, 0.068181818181818
13208, 0.76086956521739, 1.5, 0.13636363636364
13209, 0.78260869565217, 1.5, 0.11363636363636
13210, 0.76086956521739, 1.5, 0.18181818181818
13211, 0.78260869565217, 1.5, 0.15909090909091
13212, 0.76086956521739, 1.5, 0.22727272727273
13213, 0.78260869565217, 1.5, 0.20454545454545
13214, 0.76086956521739, 1.5, 0.27272727272727
13215, 0.78260869565217, 1.5, 0.25
13216, 0.76086956521739, 1.5, 0.31818181818182
13217, 0.78260869565217, 1.5, 0.29545454545455
13218, 0.76086956521739, 1.5, 0.36363636363636
13219, 0.78260869565217, 1.5, 0.34090909090909
13220, 0.76086956521739, 1.5, 0.40909090909091
13221, 0.78260869565217, 1.5, 0.38636363636364
13222, 0.76086956521739, 1.5, 0.45454545454545
13223, 0.78260869565217, 1.5, 0.43181818181818
13224, 0.78260869565217, 1.5, 0.47727272727273
13225, 0.80434782608696, 1.5, 0.045454545454545
13226, 0.82608695652174, 1.5, 0.022727272727273
13227, 0.80434782608696, 1.5, 0.090909090909091
13228, 0.82608695652174, 1.5, 0.068181818181818
13229, 0.80434782608696, 1.5, 0.13636363636364
13230, 0.82608695652174, 1.5, 0.11363636363636
13231, 0.80434782608696, 1.5, 0.18181818181818
13232, 0.82608695652174, 1.5, 0.15909090909091
13233, 0.80434782608696, 1.5, 0.22727272727273
13234, 0.82608695652174, 1.5, 0.20454545454545
13235, 0.80434782608696, 1.5, 0.27272727272727
13236, 0.82608695652174, 1.5, 0.25
13237, 0.80434782608696, 1.5, 0.31818181818182
13238, 0.82608695652174, 1.5, 0.29545454545455
13239, 0.80434782608696, 1.5, 0.36363636363636
13240, 0.82608695652174, 1.5, 0.34090909090909
13241, 0.80434782608696, 1.5, 0.40909090909091
13242, 0.82608695652174, 1.5, 0.38636363636364
13243, 0.80434782608696, 1.5, 0.45454545454545
13244, 0.82608695652174, 1.5, 0.43181818181818
13245, 0.82608695652174, 1.5, 0.47727272727273
13246, 0.84782608695652, 1.5, 0.045454545454545
13247, 0.8695652173913, 1.5, 0.022727272727273
13248, 0.84782608695652, 1.5, 0.090909090909091
13249, 0.8695652173913, 1.5, 0.068181818181818
13250, 0.84782608695652, 1.5, 0.13636363636364
13251, 0.8695652173913, 1.5, 0.11363636363636
13252, 0.84782608695652, 1.5, 0.18181818181818
13253, 0.8695652173913, 1.5, 0.15909090909091
13254, 0.84782608695652, 1.5, 0.22727272727273
13255, 0.8695652173913, 1.5, 0.20454545454545
13256, 0.84782608695652, 1.5, 0.27272727272727
13257, 0.8695652173913, 1.5, 0.25
13258, 0.84782608695652, 1.5, 0.31818181818182
13259, 0.8695652173913, 1.5, 0.29545454545455
13260, 0.84782608695652, 1.5, 0.36363636363636
13261, 0.8695652173913, 1.5, 0.34090909090909
13262, 0.84782608695652, 1.5, 0.40909090909091
13263, 0.8695652173913, 1.5, 0.38636363636364
13264, 0.84782608695652, 1.5, 0.45454545454545
13265, 0.8695652173913, 1.5, 0.43181818181818
13266, 0.8695652173913, 1.5, 0.47727272727273
13267, 0.89130434782609, 1.5, 0.045454545454545
13268, 0.91304347826087, 1.5, 0.022727272727273
13269, 0.89130434782609, 1.5, 0.090909090909091
13270, 0.91304347826087, 1.5, 0.068181818181818
13271, 0.89130434782609, 1.5, 0.13636363636364
13272, 0.91304347826087, 1.5, 0.11363636363636
13273, 0.89130434782609, 1.5, 0.18181818181818
13274, 0.91304347826087, 1.5, 0.15909090909091
13275, 0.89130434782609, 1.5, 0.22727272727273
13276, 0.91304347826087, 1.5, 0.20454545454545
13277, 0.89130434782609, 1.5, 0.27272727272727
13278, 0.91304347826087, 1.5, 0.25
13279, 0.89130434782609, 1.5, 0.31818181818182
13280, 0.91304347826087, 1.5, 0.29545454545455
13281, 0.89130434782609, 1.5, 0.36363636363636
13282, 0.91304347826087, 1.5, 0.34090909090909
13283, 0.89130434782609, 1.5, 0.40909090909091
13284, 0.91304347826087, 1.5, 0.38636363636364
13285, 0.89130434782609, 1.5, 0.45454545454545
13286, 0.91304347826087, 1.5, 0.43181818181818
13287, 0.91304347826087, 1.5, 0.47727272727273
13288, 0.93478260869565, 1.5, 0.045454545454545
13289, 0.95652173913043, 1.5, 0.022727272727273
13290, 0.93478260869565, 1.5, 0.090909090909091
13291, 0.95652173913043, 1.5, 0.068181818181818
13292, 0.93478260869565, 1.5, 0.13636363636364
13293, 0.95652173913044, 1.5, 0.11363636363636
13294, 0.93478260869565, 1.5, 0.18181818181818
13295, 0.95652173913043, 1.5, 0.15909090909091
13296, 0.93478260869565, 1.5, 0.22727272727273
13297, 0.95652173913043, 1.5, 0.20454545454545
13298, 0.93478260869565, 1.5, 0.27272727272727
13299, 0.95652173913043, 1.5, 0.25
13300, 0.93478260869565, 1.5, 0.31818181818182
13301, 0.95652173913043, 1.5, 0.29545454545455
13302, 0.93478260869565, 1.5, 0.36363636363636
13303, 0.95652173913043, 1.5, 0.34090909090909
13304, 0.93478260869565, 1.5, 0.40909090909091
13305, 0.95652173913043, 1.5, 0.38636363636364
13306, 0.93478260869565, 1.5, 0.45454545454545
13307, 0.95652173913043, 1.5, 0.43181818181818
13308, 0.95652173913043, 1.5, 0.47727272727273
13309, 0.97826086956522, 1.5, 0.045454545454545
13310, 0.97826086956522, 1.5, 0.090909090909091
13311, 0.97826086956522, 1.5, 0.13636363636364
13312, 0.97826086956522, 1.5, 0.18181818181818
13313, 0.97826086956522, 1.5, 0.22727272727273
13314, 0.97826086956522, 1.5, 0.27272727272727
13315, 0.97826086956522, 1.5, 0.31818181818182
13316, 0.97826086956522, 1.5, 0.36363636363636
13317, 0.97826086956522, 1.5, 0.40909090909091
13318, 0.97826086956522, 1.5, 0.45454545454545
13319, 1.04, 1.4333333333333, 0.5
13320, 1.04, 1.4666666666667, 0.5
13321, 1.08, 1.4333333333333, 0.5
13322, 1.08, 1.4666666666667, 0.5
13323, 1.12, 1.4333333333333, 0.5
13324, 1.12, 1.4666666666667, 0.5
13325, 1.16, 1.4333333333333, 0.5
13326, 1.16, 1.4666666666667, 0.5
13327, 1.04, 1.4166666666667, 0.5
13328, 1.02, 1.4333333333333, 0.5
13329, 1.04, 1.45, 0.5
13330, 1.02, 1.4666666666667, 0.5
13331, 1.04, 1.4833333333333, 0.5
13332, 1.08, 1.4166666666667, 0.5
13333, 1.06, 1.4333333333333, 0.5
13334, 1.08, 1.45, 0.5
13335, 1.06, 1.4666666666667, 0.5
13336, 1.08, 1.4833333333333, 0.5
13337, 1.12, 1.4166666666667, 0.5
13338, 1.1, 1.4333333333333, 0.5
13339, 1.12, 1.45, 0.5
13340, 1.1, 1.4666666666667, 0.5
13341, 1.12, 1.4833333333333, 0.5
13342, 1.16, 1.4166666666667, 0.5
13343, 1.14, 1.4333333333333, 0.5
13344, 1.16, 1.45, 0.5
13345, 1.14, 1.4666666666667, 0.5
13346, 1.16, 1.4833333333333, 0.5
13347, 1.18, 1.4333333333333, 0.5
13348, 1.18, 1.4666666666667, 0.5
13349, 1.04, 1.4333333333333, 0
13350, 1.04, 1.4666666666667, 0
13351, 1.08, 1.4333333333333, 0
13352, 1.08, 1.4666666666667, 0
13353, 1.12, 1.4333333333333, 0
13354, 1.12, 1.4666666666667, 0
13355, 1.16, 1.4333333333333, 0
13356, 1.16, 1.4666666666667, 0
13357, 1.02, 1.4333333333333, 0
13358, 1.04, 1.4166666666667, 0
13359, 1.02, 1.4666666666667, 0
13360, 1.04, 1.45, 0
13361, 1.04, 1.4833333333333, 0
13362, 1.06, 1.4333333333333, 0
13363, 1.08, 1.4166666666667, 0
13364, 1.06, 1.4666666666667, 0
13365, 1.08, 1.45, 0
13366, 1.08, 1.4833333333333, 0
13367, 1.1, 1.4333333333333, 0
13368, 1.12, 1.4166666666667, 0
13369, 1.1, 1.4666666666667, 0
13370, 1.12, 1.45, 0
13371, 1.12, 1.4833333333333, 0
13372, 1.14, 1.4333333333333, 0
13373, 1.16, 1.4166666666667, 0
13374, 1.14, 1.4666666666667, 0
13375, 1.16, 1.45, 0
13376, 1.16, 1.4833333333333, 0
13377, 1.18, 1.4333333333333, 0
13378, 1.18, 1.4666666666667, 0
13379, 1.04, 1.4, 0.45454545454545
13380, 1.04, 1.4, 0.40909090909091
13381, 1.04, 1.4, 0.36363636363636
13382, 1.04, 1.4, 0.31818181818182
13383, 1.04, 1.4, 0.27272727272727
13384, 1.04, 1.4, 0.22727272727273
13385, 1.04, 1.4, 0.18181818181818
13386, 1.04, 1.4, 0.13636363636364
13387, 1.04, 1.4, 0.090909090909091
13388, 1.04, 1.4, 0.045454545454545
13389, 1.08, 1.4, 0.45454545454545
13390, 1.08, 1.4, 0.40909090909091
13391, 1.08, 1.4, 0.36363636363636
13392, 1.08, 1.4, 0.31818181818182
13393, 1.08, 1.4, 0.27272727272727
13394, 1.08, 1.4, 0.22727272727273
13395, 1.08, 1.4, 0.18181818181818
13396, 1.08, 1.4, 0.13636363636364
13397, 1.08, 1.4, 0.090909090909091
13398, 1.08, 1.4, 0.045454545454545
13399, 1.12, 1.4, 0.45454545454545
13400, 1.12, 1.4, 0.40909090909091
13401, 1.12, 1.4, 0.36363636363636
13402, 1.12, 1.4, 0.31818181818182
13403, 1.12, 1.4, 0.27272727272727
13404, 1.12, 1.4, 0.22727272727273
13405, 1.12, 1.4, 0.18181818181818
13406, 1.12, 1.4, 0.13636363636364
13407, 1.12, 1.4, 0.090909090909091
13408, 1.12, 1.4, 0.045454545454545
13409, 1.16, 1.4, 0.45454545454545
13410, 1.16, 1.4, 0.40909090909091
13411, 1.16, 1.4, 0.36363636363636
13412, 1.16, 1.4, 0.31818181818182
13413, 1.16, 1.4, 0.27272727272727
13414, 1.16, 1.4, 0.22727272727273
13415, 1.16, 1.4, 0.18181818181818
13416, 1.16, 1.4, 0.13636363636364
13417, 1.16, 1.4, 0.090909090909091
13418, 1.16, 1.4, 0.045454545454545
13419, 1.02, 1.4, 0.45454545454545
13420, 1.04, 1.4, 0.47727272727273
13421, 1.02, 1.4, 0.40909090909091
13422, 1.04, 1.4, 0.43181818181818
13423, 1.02, 1.4, 0.36363636363636
13424, 1.04, 1.4, 0.38636363636364
13425, 1.02, 1.4, 0.31818181818182
13426, 1.04, 1.4, 0.34090909090909
13427, 1.02, 1.4, 0.27272727272727
13428, 1.04, 1.4, 0.29545454545455
13429, 1.02, 1.4, 0.22727272727273
13430, 1.04, 1.4, 0.25
13431, 1.02, 1.4, 0.18181818181818
13432, 1.04, 1.4, 0.20454545454545
13433, 1.02, 1.4, 0.13636363636364
13434, 1.04, 1.4, 0.15909090909091
13435, 1.02, 1.4, 0.090909090909091
13436, 1.04, 1.4, 0.11363636363636
13437, 1.02, 1.4, 0.045454545454545
13438, 1.04, 1.4, 0.068181818181818
13439, 1.04, 1.4, 0.022727272727273
13440, 1.06, 1.4, 0.45454545454545
13441, 1.08, 1.4, 0.47727272727273
13442, 1.06, 1.4, 0.40909090909091
13443, 1.08, 1.4, 0.43181818181818
13444, 1.06, 1.4, 0.36363636363636
13445, 1.08, 1.4, 0.38636363636364
13446, 1.06, 1.4, 0.31818181818182
13447, 1.08, 1.4, 0.34090909090909
13448, 1.06, 1.4, 0.27272727272727
13449, 1.08, 1.4, 0.29545454545455
13450, 1.06, 1.4, 0.22727272727273
13451, 1.08, 1.4, 0.25
13452, 1.06, 1.4, 0.18181818181818
13453, 1.08, 1.4, 0.20454545454545
13454, 1.06, 1.4, 0.13636363636364
13455, 1.08, 1.4, 0.15909090909091
13456, 1.06, 1.4, 0.090909090909091
13457, 1.08, 1.4, 0.11363636363636
13458, 1.06, 1.4, 0.045454545454545
13459, 1.08, 1.4, 0.068181818181818
13460, 1.08, 1.4, 0.022727272727273
13461, 1.1, 1.4, 0.45454545454545
13462, 1.12, 1.4, 0.47727272727273
13463, 1.1, 1.4, 0.40909090909091
13464, 1.12, 1.4, 0.43181818181818
13465, 1.1, 1.4, 0.36363636363636
13466, 1.12, 1.4, 0.38636363636364
13467, 1.1, 1.4, 0.31818181818182
13468, 1.12, 1.4, 0.34090909090909
13469, 1.1, 1.4, 0.27272727272727
13470, 1.12, 1.4, 0.29545454545455
13471, 1.1, 1.4, 0.22727272727273
13472, 1.12, 1.4, 0.25
13473, 1.1, 1.4, 0.18181818181818
13474, 1.12, 1.4, 0.20454545454545
13475, 1.1, 1.4, 0.13636363636364
13476, 1.12, 1.4, 0.15909090909091
13477, 1.1, 1.4, 0.090909090909091
13478, 1.12, 1.4, 0.11363636363636
13479, 1.1, 1.4, 0.045454545454545
13480, 1.12, 1.4, 0.068181818181818
13481, 1.12, 1.4, 0.022727272727273
13482, 1.14, 1.4, 0.45454545454545
13483, 1.16, 1.4, 0.47727272727273
13484, 1.14, 1.4, 0.40909090909091
13485, 1.16, 1.4, 0.43181818181818
13486, 1.14, 1.4, 0.36363636363636
13487, 1.16, 1.4, 0.38636363636364
13488, 1.14, 1.4, 0.31818181818182
13489, 1.16, 1.4, 0.34090909090909
13490, 1.14, 1.4, 0.27272727272727
13491, 1.16, 1.4, 0.29545454545455
13492, 1.14, 1.4, 0.22727272727273
13493, 1.16, 1.4, 0.25
13494, 1.14, 1.4, 0.18181818181818
13495, 1.16, 1.4, 0.20454545454545
13496, 1.14, 1.4, 0.13636363636364
13497, 1.16, 1.4, 0.15909090909091
13498, 1.14, 1.4, 0.090909090909091
13499, 1.16, 1.4, 0.11363636363636
13500, 1.14, 1.4, 0.045454545454545
13501, 1.16, 1.4, 0.068181818181818
13502, 1.16, 1.4, 0.022727272727273
13503, 1.18, 1.4, 0.45454545454545
13504, 1.18, 1.4, 0.40909090909091
13505, 1.18, 1.4, 0.36363636363636
13506, 1.18, 1.4, 0.31818181818182
13507, 1.18, 1.4, 0.27272727272727
13508, 1.18, 1.4, 0.22727272727273
13509, 1.18, 1.4, 0.18181818181818
13510, 1.18, 1.4, 0.13636363636364
13511, 1.18, 1.4, 0.090909090909091
13512, 1.18, 1.4, 0.045454545454545
13513, 1.04, 1.5, 0.45454545454545
13514, 1.04, 1.5, 0.40909090909091
13515, 1.04, 1.5, 0.36363636363636
13516, 1.04, 1.5, 0.31818181818182
13517, 1.04, 1.5, 0.27272727272727
13518, 1.04, 1.5, 0.22727272727273
13519, 1.04, 1.5, 0.18181818181818
13520, 1.04, 1.5, 0.13636363636364
13521, 1.04, 1.5, 0.090909090909091
13522, 1.04, 1.5, 0.045454545454545
13523, 1.08, 1.5, 0.45454545454545
13524, 1.08, 1.5, 0.40909090909091
13525, 1.08, 1.5, 0.36363636363636
13526, 1.08, 1.5, 0.31818181818182
13527, 1.08, 1.5, 0.27272727272727
13528, 1.08, 1.5, 0.22727272727273
13529, 1.08, 1.5, 0.18181818181818
13530, 1.08, 1.5, 0.13636363636364
13531, 1.08, 1.5, 0.090909090909091
13532, 1.08, 1.5, 0.045454545454545
13533, 1.12, 1.5, 0.45454545454545
13534, 1.12, 1.5, 0.40909090909091
13535, 1.12, 1.5, 0.36363636363636
13536, 1.12, 1.5, 0.31818181818182
13537, 1.12, 1.5, 0.27272727272727
13538, 1.12, 1.5, 0.22727272727273
13539, 1.12, 1.5, 0.18181818181818
13540, 1.12, 1.5, 0.13636363636364
13541, 1.12, 1.5, 0.090909090909091
13542, 1.12, 1.5, 0.045454545454545
13543, 1.16, 1.5, 0.45454545454545
13544, 1.16, 1.5, 0.40909090909091
13545, 1.16, 1.5, 0.36363636363636
13546, 1.16, 1.5, 0.31818181818182
13547, 1.16, 1.5, 0.27272727272727
13548, 1.16, 1.5, 0.22727272727273
13549, 1.16, 1.5, 0.18181818181818
13550, 1.16, 1.5, 0.13636363636364
13551, 1.16, 1.5, 0.090909090909091
13552, 1.16, 1.5, 0.045454545454545
13553, 1.04, 1.5, 0.47727272727273
13554, 1.02, 1.5, 0.45454545454545
13555, 1.04, 1.5, 0.43181818181818
13556, 1.02, 1.5, 0.40909090909091
13557, 1.04, 1.5, 0.38636363636364
13558, 1.02, 1.5, 0.36363636363636
13559, 1.04, 1.5, 0.34090909090909
13560, 1.02, 1.5, 0.31818181818182
13561, 1.04, 1.5, 0.29545454545455
13562, 1.02, 1.5, 0.27272727272727
13563, 1.04, 1.5, 0.25
13564, 1.02, 1.5, 0.22727272727273
13565, 1.04, 1.5, 0.20454545454545
13566, 1.02, 1.5, 0.18181818181818
13567, 1.04, 1.5, 0.15909090909091
13568, 1.02, 1.5, 0.13636363636364
13569, 1.04, 1.5, 0.11363636363636
13570, 1.02, 1.5, 0.090909090909091
13571, 1.04, 1.5, 0.068181818181818
13572, 1.02, 1.5, 0.045454545454545
13573, 1.04, 1.5, 0.022727272727273
13574, 1.08, 1.5, 0.47727272727273
13575, 1.06, 1.5, 0.45454545454545
13576, 1.08, 1.5, 0.43181818181818
13577, 1.06, 1.5, 0.40909090909091
13578, 1.08, 1.5, 0.38636363636364
13579, 1.06, 1.5, 0.36363636363636
13580, 1.08, 1.5, 0.34090909090909
13581, 1.06, 1.5, 0.31818181818182
13582, 1.08, 1.5, 0.29545454545455
13583, 1.06, 1.5, 0.27272727272727
13584, 1.08, 1.5, 0.25
13585, 1.06, 1.5, 0.22727272727273
13586, 1.08, 1.5, 0.20454545454545
13587, 1.06, 1.5, 0.18181818181818
13588, 1.08, 1.5, 0.15909090909091
13589, 1.06, 1.5, 0.13636363636364
13590, 1.08, 1.5, 0.11363636363636
13591, 1.06, 1.5, 0.090909090909091
13592, 1.08, 1.5, 0.068181818181818
13593, 1.06, 1.5, 0.045454545454545
13594, 1.08, 1.5, 0.022727272727273
13595, 1.12, 1.5, 0.47727272727273
13596, 1.1, 1.5, 0.45454545454545
13597, 1.12, 1.5, 0.43181818181818
13598, 1.1, 1.5, 0.40909090909091
13599, 1.12, 1.5, 0.38636363636364
13600, 1.1, 1.5, 0.36363636363636
13601, 1.12, 1.5, 0.34090909090909
13602, 1.1, 1.5, 0.31818181818182
13603, 1.12, 1.5, 0.29545454545455
13604, 1.1, 1.5, 0.27272727272727
13605, 1.12, 1.5, 0.25
13606, 1.1, 1.5, 0.22727272727273
13607, 1.12, 1.5, 0.20454545454545
13608, 1.1, 1.5, 0.18181818181818
13609, 1.12, 1.5, 0.15909090909091
13610, 1.1, 1.5, 0.13636363636364
13611, 1.12, 1.5, 0.11363636363636
13612, 1.1, 1.5, 0.090909090909091
13613, 1.12, 1.5, 0.068181818181818
13614, 1.1, 1.5, 0.045454545454545
13615, 1.12, 1.5, 0.022727272727273
13616, 1.16, 1.5, 0.47727272727273
13617, 1.14, 1.5, 0.45454545454545
13618, 1.16, 1.5, 0.43181818181818
13619, 1.14, 1.5, 0.40909090909091
13620, 1.16, 1.5, 0.38636363636364
13621, 1.14, 1.5, 0.36363636363636
13622, 1.16, 1.5, 0.34090909090909
13623, 1.14, 1.5, 0.31818181818182
13624, 1.16, 1.5, 0.29545454545455
13625, 1.14, 1.5, 0.27272727272727
13626, 1.16, 1.5, 0.25
13627, 1.14, 1.5, 0.22727272727273
13628, 1.16, 1.5, 0.20454545454545
13629, 1.14, 1.5, 0.18181818181818
13630, 1.16, 1.5, 0.15909090909091
13631, 1.14, 1.5, 0.13636363636364
13632, 1.16, 1.5, 0.11363636363636
13633, 1.14, 1.5, 0.090909090909091
13634, 1.16, 1.5, 0.068181818181818
13635, 1.14, 1.5, 0.045454545454545
13636, 1.16, 1.5, 0.022727272727273
13637, 1.18, 1.5, 0.45454545454545
13638, 1.18, 1.5, 0.40909090909091
13639, 1.18, 1.5, 0.36363636363636
13640, 1.18, 1.5, 0.31818181818182
13641, 1.18, 1.5, 0.27272727272727
13642, 1.18, 1.5, 0.22727272727273
13643, 1.18, 1.5, 0.18181818181818
13644, 1.18, 1.5, 0.13636363636364
13645, 1.18, 1.5, 0.090909090909091
13646, 1.18, 1.5, 0.045454545454545
13647, 1.2, 1.4333333333333, 0.45454545454545
13648, 1.2, 1.4333333333333, 0.40909090909091
13649, 1.2, 1.4333333333333, 0.36363636363636
13650, 1.2, 1.4333333333333, 0.31818181818182
13651, 1.2, 1.4333333333333, 0.27272727272727
13652, 1.2, 1.4333333333333, 0.22727272727273
13653, 1.2, 1.4333333333333, 0.18181818181818
13654, 1.2, 1.4333333333333, 0.13636363636364
13655, 1.2, 1.4333333333333, 0.090909090909091
13656, 1.2, 1.4333333333333, 0.045454545454545
13657, 1.2, 1.4666666666667, 0.45454545454545
13658, 1.2, 1.4666666666667, 0.40909090909091
13659, 1.2, 1.4666666666667, 0.36363636363636
13660, 1.2, 1.4666666666667, 0.31818181818182
13661, 1.2, 1.4666666666667, 0.27272727272727
13662, 1.2, 1.4666666666667, 0.22727272727273
13663, 1.2, 1.4666666666667, 0.18181818181818
13664, 1.2, 1.4666666666667, 0.13636363636364
13665, 1.2, 1.4666666666667, 0.090909090909091
13666, 1.2, 1.4666666666667, 0.045454545454545
13667, 1.2, 1.4166666666667, 0.45454545454545
13668, 1.2, 1.4333333333333, 0.47727272727273
13669, 1.2, 1.4166666666667, 0.40909090909091
13670, 1.2, 1.4333333333333, 0.43181818181818
13671, 1.2, 1.4166666666667, 0.36363636363636
13672, 1.2, 1.4333333333333, 0.38636363636364
13673, 1.2, 1.4166666666667, 0.31818181818182
13674, 1.2, 1.4333333333333, 0.34090909090909
13675, 1.2, 1.4166666666667, 0.27272727272727
13676, 1.2, 1.4333333333333, 0.29545454545455
13677, 1.2, 1.4166666666667, 0.22727272727273
13678, 1.2, 1.4333333333333, 0.25
13679, 1.2, 1.4166666666667, 0.18181818181818
13680, 1.2, 1.4333333333333, 0.20454545454545
13681, 1.2, 1.4166666666667, 0.13636363636364
13682, 1.2, 1.4333333333333, 0.15909090909091
13683, 1.2, 1.4166666666667, 0.090909090909091
13684, 1.2, 1.4333333333333, 0.11363636363636
13685, 1.2, 1.4166666666667, 0.045454545454545
13686, 1.2, 1.4333333333333, 0.068181818181818
13687, 1.2, 1.4333333333333, 0.022727272727273
13688, 1.2, 1.45, 0.45454545454545
13689, 1.2, 1.4666666666667, 0.47727272727273
13690, 1.2, 1.45, 0.40909090909091
13691, 1.2, 1.4666666666667, 0.43181818181818
13692, 1.2, 1.45, 0.36363636363636
13693, 1.2, 1.4666666666667, 0.38636363636364
13694, 1.2, 1.45, 0.31818181818182
13695, 1.2, 1.4666666666667, 0.34090909090909
13696, 1.2, 1.45, 0.27272727272727
13697, 1.2, 1.4666666666667, 0.29545454545455
13698, 1.2, 1.45, 0.22727272727273
13699, 1.2, 1.4666666666667, 0.25
13700, 1.2, 1.45, 0.18181818181818
13701, 1.2, 1.4666666666667, 0.20454545454545
13702, 1.2, 1.45, 0.13636363636364
13703, 1.2, 1.4666666666667, 0.15909090909091
13704, 1.2, 1.45, 0.090909090909091
13705, 1.2, 1.4666666666667, 0.11363636363636
13706, 1.2, 1.45, 0.045454545454545
13707, 1.2, 1.4666666666667, 0.068181818181818
13708, 1.2, 1.4666666666667, 0.022727272727273
13709, 1.2, 1.4833333333333, 0.45454545454545
13710, 1.2, 1.4833333333333, 0.40909090909091
13711, 1.2, 1.4833333333333, 0.36363636363636
13712, 1.2, 1.4833333333333, 0.31818181818182
13713, 1.2, 1.4833333333333, 0.27272727272727
13714, 1.2, 1.4833333333333, 0.22727272727273
13715, 1.2, 1.4833333333333, 0.18181818181818
13716, 1.2, 1.4833333333333, 0.13636363636364
13717, 1.2, 1.4833333333333, 0.090909090909091
13718, 1.2, 1.4833333333333, 0.045454545454545
13719, 1.2434782608696, 1.4333333333333, 0.5
13720, 1.2434782608696, 1.4666666666667, 0.5
13721, 1.2869565217391, 1.4333333333333, 0.5
13722, 1.2869565217391, 1.4666666666667, 0.5
13723, 1.3304347826087, 1.4333333333333, 0.5
13724, 1.3304347826087, 1.4666666666667, 0.5
13725, 1.3739130434783, 1.4333333333333, 0.5
13726, 1.3739130434783, 1.4666666666667, 0.5
13727, 1.4173913043478, 1.4333333333333, 0.5
13728, 1.4173913043478, 1.4666666666667, 0.5
13729, 1.4608695652174, 1.4333333333333, 0.5
13730, 1.4608695652174, 1.4666666666667, 0.5
13731, 1.504347826087, 1.4333333333333, 0.5
13732, 1.504347826087, 1.4666666666667, 0.5
13733, 1.5478260869565, 1.4333333333333, 0.5
13734, 1.5478260869565, 1.4666666666667, 0.5
13735, 1.5913043478261, 1.4333333333333, 0.5
13736, 1.5913043478261, 1.4666666666667, 0.5
13737, 1.6347826086957, 1.4333333333333, 0.5
13738, 1.6347826086957, 1.4666666666667, 0.5
13739, 1.6782608695652, 1.4333333333333, 0.5
13740, 1.6782608695652, 1.4666666666667, 0.5
13741, 1.7217391304348, 1.4333333333333, 0.5
13742, 1.7217391304348, 1.4666666666667, 0.5
13743, 1.7652173913043, 1.4333333333333, 0.5
13744, 1.7652173913043, 1.4666666666667, 0.5
13745, 1.8086956521739, 1.4333333333333, 0.5
13746, 1.8086956521739, 1.4666666666667, 0.5
13747, 1.8521739130435, 1.4333333333333, 0.5
13748, 1.8521739130435, 1.4666666666667, 0.5
13749, 1.895652173913, 1.4333333333333, 0.5
13750, 1.895652173913, 1.4666666666667, 0.5
13751, 1.9391304347826, 1.4333333333333, 0.5
13752, 1.9391304347826, 1.4666666666667, 0.5
13753, 1.9826086956522, 1.4333333333333, 0.5
13754, 1.9826086956522, 1.4666666666667, 0.5
13755, 2.0260869565217, 1.4333333333333, 0.5
13756, 2.0260869565217, 1.4666666666667, 0.5
13757, 2.0695652173913, 1.4333333333333, 0.5
13758, 2.0695652173913, 1.4666666666667, 0.5
13759, 2.1130434782609, 1.4333333333333, 0.5
13760, 2.1130434782609, 1.4666666666667, 0.5
13761, 2.1565217391304, 1.4333333333333, 0.5
13762, 2.1565217391304, 1.4666666666667, 0.5
13763, 1.2434782608696, 1.4166666666667, 0.5
13764, 1.2217391304348, 1.4333333333333, 0.5
13765, 1.2434782608696, 1.45, 0.5
13766, 1.2217391304348, 1.4666666666667, 0.5
13767, 1.2434782608696, 1.4833333333333, 0.5
13768, 1.2869565217391, 1.4166666666667, 0.5
13769, 1.2652173913043, 1.4333333333333, 0.5
13770, 1.2869565217391, 1.45, 0.5
13771, 1.2652173913043, 1.4666666666667, 0.5
13772, 1.2869565217391, 1.4833333333333, 0.5
13773, 1.3304347826087, 1.4166666666667, 0.5
13774, 1.3086956521739, 1.4333333333333, 0.5
13775, 1.3304347826087, 1.45, 0.5
13776, 1.3086956521739, 1.4666666666667, 0.5
13777, 1.3304347826087, 1.4833333333333, 0.5
13778, 1.3739130434783, 1.4166666666667, 0.5
13779, 1.3521739130435, 1.4333333333333, 0.5
13780, 1.3739130434783, 1.45, 0.5
13781, 1.3521739130435, 1.4666666666667, 0.5
13782, 1.3739130434783, 1.4833333333333, 0.5
13783, 1.4173913043478, 1.4166666666667, 0.5
13784, 1.395652173913, 1.4333333333333, 0.5
13785, 1.4173913043478, 1.45, 0.5
13786, 1.395652173913, 1.4666666666667, 0.5
13787, 1.4173913043478, 1.4833333333333, 0.5
13788, 1.4608695652174, 1.4166666666667, 0.5
13789, 1.4391304347826, 1.4333333333333, 0.5
13790, 1.4608695652174, 1.45, 0.5
13791, 1.4391304347826, 1.4666666666667, 0.5
13792, 1.4608695652174, 1.4833333333333, 0.5
13793, 1.504347826087, 1.4166666666667, 0.5
13794, 1.4826086956522, 1.4333333333333, 0.5
13795, 1.504347826087, 1.45, 0.5
13796, 1.4826086956522, 1.4666666666667, 0.5
13797, 1.504347826087, 1.4833333333333, 0.5
13798, 1.5478260869565, 1.4166666666667, 0.5
13799, 1.5260869565217, 1.4333333333333, 0.5
13800, 1.5478260869565, 1.45, 0.5
13801, 1.5260869565217, 1.4666666666667, 0.5
13802, 1.5478260869565, 1.4833333333333, 0.5
13803, 1.5913043478261, 1.4166666666667, 0.5
13804, 1.5695652173913, 1.4333333333333, 0.5
13805, 1.5913043478261, 1.45, 0.5
13806, 1.5695652173913, 1.4666666666667, 0.5
13807, 1.5913043478261, 1.4833333333333, 0.5
13808, 1.6347826086957, 1.4166666666667, 0.5
13809, 1.6130434782609, 1.4333333333333, 0.5
13810, 1.6347826086957, 1.45, 0.5
13811, 1.6130434782609, 1.4666666666667, 0.5
13812, 1.6347826086957, 1.4833333333333, 0.5
13813, 1.6782608695652, 1.4166666666667, 0.5
13814, 1.6565217391304, 1.4333333333333, 0.5
13815, 1.6782608695652, 1.45, 0.5
13816, 1.6565217391304, 1.4666666666667, 0.5
13817, 1.6782608695652, 1.4833333333333, 0.5
13818, 1.7217391304348, 1.4166666666667, 0.5
13819, 1.7, 1.4333333333333, 0.5
13820, 1.7217391304348, 1.45, 0.5
13821, 1.7, 1.4666666666667, 0.5
13822, 1.7217391304348, 1.4833333333333, 0.5
13823, 1.7652173913043, 1.4166666666667, 0.5
13824, 1.7434782608696, 1.4333333333333, 0.5
13825, 1.7652173913043, 1.45, 0.5
13826, 1.7434782608696, 1.4666666666667, 0.5
13827, 1.7652173913043, 1.4833333333333, 0.5
13828, 1.8086956521739, 1.4166666666667, 0.5
13829, 1.7869565217391, 1.4333333333333, 0.5
13830, 1.8086956521739, 1.45, 0.5
13831, 1.7869565217391, 1.4666666666667, 0.5
13832, 1.8086956521739, 1.4833333333333, 0.5
13833, 1.8521739130435, 1.4166666666667, 0.5
13834, 1.8304347826087, 1.4333333333333, 0.5
13835, 1.8521739130435, 1.45, 0.5
13836, 1.8304347826087, 1.4666666666667, 0.5
13837, 1.8521739130435, 1.4833333333333, 0.5
13838, 1.895652173913, 1.4166666666667, 0.5
13839, 1.8739130434783, 1.4333333333333, 0.5
13840, 1.895652173913, 1.45, 0.5
13841, 1.8739130434783, 1.4666666666667, 0.5
13842, 1.895652173913, 1.4833333333333, 0.5
13843, 1.9391304347826, 1.4166666666667, 0.5
13844, 1.9173913043478, 1.4333333333333, 0.5
13845, 1.9391304347826, 1.45, 0.5
13846, 1.9173913043478, 1.4666666666667, 0.5
13847, 1.9391304347826, 1.4833333333333, 0.5
13848, 1.9826086956522, 1.4166666666667, 0.5
13849, 1.9608695652174, 1.4333333333333, 0.5
13850, 1.9826086956522, 1.45, 0.5
13851, 1.9608695652174, 1.4666666666667, 0.5
13852, 1.9826086956522, 1.4833333333333, 0.5
13853, 2.0260869565217, 1.4166666666667, 0.5
13854, 2.004347826087, 1.4333333333333, 0.5
13855, 2.0260869565217, 1.45, 0.5
13856, 2.004347826087, 1.4666666666667, 0.5
13857, 2.0260869565217, 1.4833333333333, 0.5
13858, 2.0695652173913, 1.4166666666667, 0.5
13859, 2.0478260869565, 1.4333333333333, 0.5
13860, 2.0695652173913, 1.45, 0.5
13861, 2.0478260869565, 1.4666666666667, 0.5
13862, 2.0695652173913, 1.4833333333333, 0.5
13863, 2.1130434782609, 1.4166666666667, 0.5
13864, 2.0913043478261, 1.4333333333333, 0.5
13865, 2.1130434782609, 1.45, 0.5
13866, 2.0913043478261, 1.4666666666667, 0.5
13867, 2.1130434782609, 1.4833333333333, 0.5
13868, 2.1565217391304, 1.4166666666667, 0.5
13869, 2.1347826086957, 1.4333333333333, 0.5
13870, 2.1565217391304, 1.45, 0.5
13871, 2.1347826086957, 1.4666666666667, 0.5
13872, 2.1565217391304, 1.4833333333333, 0.5
13873, 2.1782608695652, 1.4333333333333, 0.5
13874, 2.1782608695652, 1.4666666666667, 0.5
13875, 1.2434782608696, 1.4333333333333, 0
13876, 1.2434782608696, 1.4666666666667, 0
13877, 1.2869565217391, 1.4333333333333, 0
13878, 1.2869565217391, 1.4666666666667, 0
13879, 1.3304347826087, 1.4333333333333, 0
13880, 1.3304347826087, 1.4666666666667, 0
13881, 1.3739130434783, 1.4333333333333, 0
13882, 1.3739130434783, 1.4666666666667, 0
13883, 1.4173913043478, 1.4333333333333, 0
13884, 1.4173913043478, 1.4666666666667, 0
13885, 1.4608695652174, 1.4333333333333, 0
13886, 1.4608695652174, 1.4666666666667, 0
13887, 1.504347826087, 1.4333333333333, 0
13888, 1.504347826087, 1.4666666666667, 0
13889, 1.5478260869565, 1.4333333333333, 0
13890, 1.5478260869565, 1.4666666666667, 0
13891, 1.5913043478261, 1.4333333333333, 0
13892, 1.5913043478261, 1.4666666666667, 0
13893, 1.6347826086957, 1.4333333333333, 0
13894, 1.6347826086957, 1.4666666666667, 0
13895, 1.6782608695652, 1.4333333333333, 0
13896, 1.6782608695652, 1.4666666666667, 0
13897, 1.7217391304348, 1.4333333333333, 0
13898, 1.7217391304348, 1.4666666666667, 0
13899, 1.7652173913043, 1.4333333333333, 0
13900, 1.7652173913043, 1.4666666666667, 0
13901, 1.8086956521739, 1.4333333333333, 0
13902, 1.8086956521739, 1.4666666666667, 0
13903, 1.8521739130435, 1.4333333333333, 0
13904, 1.8521739130435, 1.4666666666667, 0
13905, 1.895652173913, 1.4333333333333, 0
13906, 1.895652173913, 1.4666666666667, 0
13907, 1.9391304347826, 1.4333333333333, 0
13908, 1.9391304347826, 1.4666666666667, 0
13909, 1.9826086956522, 1.4333333333333, 0
13910, 1.9826086956522, 1.4666666666667, 0
13911, 2.0260869565217, 1.4333333333333, 0
13912, 2.0260869565217, 1.4666666666667, 0
13913, 2.0695652173913, 1.4333333333333, 0
13914, 2.0695652173913, 1.4666666666667, 0
13915, 2.1130434782609, 1.4333333333333, 0
13916, 2.1130434782609, 1.4666666666667, 0
13917, 2.1565217391304, 1.4333333333333, 0
13918, 2.1565217391304, 1.4666666666667, 0
13919, 1.2217391304348, 1.4333333333333, 0
13920, 1.2434782608696, 1.4166666666667, 0
13921, 1.2217391304348, 1.4666666666667, 0
13922, 1.2434782608696, 1.45, 0
13923, 1.2434782608696, 1.4833333333333, 0
13924, 1.2652173913043, 1.4333333333333, 0
13925, 1.2869565217391, 1.4166666666667, 0
13926, 1.2652173913043, 1.4666666666667, 0
13927, 1.2869565217391, 1.45, 0
13928, 1.2869565217391, 1.4833333333333, 0
13929, 1.3086956521739, 1.4333333333333, 0
13930, 1.3304347826087, 1.4166666666667, 0
13931, 1.3086956521739, 1.4666666666667, 0
13932, 1.3304347826087, 1.45, 0
13933, 1.3304347826087, 1.4833333333333, 0
13934, 1.3521739130435, 1.4333333333333, 0
13935, 1.3739130434783, 1.4166666666667, 0
13936, 1.3521739130435, 1.4666666666667, 0
13937, 1.3739130434783, 1.45, 0
13938, 1.3739130434783, 1.4833333333333, 0
13939, 1.395652173913, 1.4333333333333, 0
13940, 1.4173913043478, 1.4166666666667, 0
13941, 1.395652173913, 1.4666666666667, 0
13942, 1.4173913043478, 1.45, 0
13943, 1.4173913043478, 1.4833333333333, 0
13944, 1.4391304347826, 1.4333333333333, 0
13945, 1.4608695652174, 1.4166666666667, 0
13946, 1.4391304347826, 1.4666666666667, 0
13947, 1.4608695652174, 1.45, 0
13948, 1.4608695652174, 1.4833333333333, 0
13949, 1.4826086956522, 1.4333333333333, 0
13950, 1.504347826087, 1.4166666666667, 0
13951, 1.4826086956522, 1.4666666666667, 0
13952, 1.504347826087, 1.45, 0
13953, 1.504347826087, 1.4833333333333, 0
13954, 1.5260869565217, 1.4333333333333, 0
13955, 1.5478260869565, 1.4166666666667, 0
13956, 1.5260869565217, 1.4666666666667, 0
13957, 1.5478260869565, 1.45, 0
13958, 1.5478260869565, 1.4833333333333, 0
13959, 1.5695652173913, 1.4333333333333, 0
13960, 1.5913043478261, 1.4166666666667, 0
13961, 1.5695652173913, 1.4666666666667, 0
13962, 1.5913043478261, 1.45, 0
13963, 1.5913043478261, 1.4833333333333, 0
13964, 1.6130434782609, 1.4333333333333, 0
13965, 1.6347826086957, 1.4166666666667, 0
13966, 1.6130434782609, 1.4666666666667, 0
13967, 1.6347826086957, 1.45, 0
13968, 1.6347826086957, 1.4833333333333, 0
13969, 1.6565217391304, 1.4333333333333, 0
13970, 1.6782608695652, 1.4166666666667, 0
13971, 1.6565217391304, 1.4666666666667, 0
13972, 1.6782608695652, 1.45, 0
13973, 1.6782608695652, 1.4833333333333, 0
13974, 1.7, 1.4333333333333, 0
13975, 1.7217391304348, 1.4166666666667, 0
13976, 1.7, 1.4666666666667, 0
13977, 1.7217391304348, 1.45, 0
13978, 1.7217391304348, 1.4833333333333, 0
13979, 1.7434782608696, 1.4333333333333, 0
13980, 1.7652173913043, 1.4166666666667, 0
13981, 1.7434782608696, 1.4666666666667, 0
13982, 1.7652173913043, 1.45, 0
13983, 1.7652173913043, 1.4833333333333, 0
13984, 1.7869565217391, 1.4333333333333, 0
13985, 1.8086956521739, 1.4166666666667, 0
13986, 1.7869565217391, 1.4666666666667, 0
13987, 1.8086956521739, 1.45, 0
13988, 1.8086956521739, 1.4833333333333, 0
13989, 1.8304347826087, 1.4333333333333, 0
13990, 1.8521739130435, 1.4166666666667, 0
13991, 1.8304347826087, 1.4666666666667, 0
13992, 1.8521739130435, 1.45, 0
13993, 1.8521739130435, 1.4833333333333, 0
13994, 1.8739130434783, 1.4333333333333, 0
13995, 1.895652173913, 1.4166666666667, 0
13996, 1.8739130434783, 1.4666666666667, 0
13997, 1.895652173913, 1.45, 0
13998, 1.895652173913, 1.4833333333333, 0
13999, 1.9173913043478, 1.4333333333333, 0
14000, 1.9391304347826, 1.4166666666667, 0
14001, 1.9173913043478, 1.4666666666667, 0
14002, 1.9391304347826, 1.45, 0
14003, 1.9391304347826, 1.4833333333333, 0
14004, 1.9608695652174, 1.4333333333333, 0
14005, 1.9826086956522, 1.4166666666667, 0
14006, 1.9608695652174, 1.4666666666667, 0
14007, 1.9826086956522, 1.45, 0
14008, 1.9826086956522, 1.4833333333333, 0
14009, 2.004347826087, 1.4333333333333, 0
14010, 2.0260869565217, 1.4166666666667, 0
14011, 2.004347826087, 1.4666666666667, 0
14012, 2.0260869565217, 1.45, 0
14013, 2.0260869565217, 1.4833333333333, 0
14014, 2.0478260869565, 1.4333333333333, 0
14015, 2.0695652173913, 1.4166666666667, 0
14016, 2.0478260869565, 1.4666666666667, 0
14017, 2.0695652173913, 1.45, 0
14018, 2.0695652173913, 1.4833333333333, 0
14019, 2.0913043478261, 1.4333333333333, 0
14020, 2.1130434782609, 1.4166666666667, 0
14021, 2.0913043478261, 1.4666666666667, 0
14022, 2.1130434782609, 1.45, 0
14023, 2.1130434782609, 1.4833333333333, 0
14024, 2.1347826086957, 1.4333333333333, 0
14025, 2.1565217391304, 1.4166666666667, 0
14026, 2.1347826086957, 1.4666666666667, 0
14027, 2.1565217391304, 1.45, 0
14028, 2.1565217391304, 1.4833333333333, 0
14029, 2.1782608695652, 1.4333333333333, 0
14030, 2.1782608695652, 1.4666666666667, 0
14031, 1.2434782608696, 1.4, 0.45454545454545
14032, 1.2434782608696, 1.4, 0.40909090909091
14033, 1.2434782608696, 1.4, 0.36363636363636
14034, 1.2434782608696, 1.4, 0.31818181818182
14035, 1.2434782608696, 1.4, 0.27272727272727
14036, 1.2434782608696, 1.4, 0.22727272727273
14037, 1.2434782608696, 1.4, 0.18181818181818
14038, 1.2434782608696, 1.4, 0.13636363636364
14039, 1.2434782608696, 1.4, 0.090909090909091
14040, 1.2434782608696, 1.4, 0.045454545454545
14041, 1.2869565217391, 1.4, 0.45454545454545
14042, 1.2869565217391, 1.4, 0.40909090909091
14043, 1.2869565217391, 1.4, 0.36363636363636
14044, 1.2869565217391, 1.4, 0.31818181818182
14045, 1.2869565217391, 1.4, 0.27272727272727
14046, 1.2869565217391, 1.4, 0.22727272727273
14047, 1.2869565217391, 1.4, 0.18181818181818
14048, 1.2869565217391, 1.4, 0.13636363636364
14049, 1.2869565217391, 1.4, 0.090909090909091
14050, 1.2869565217391, 1.4, 0.045454545454545
14051, 1.3304347826087, 1.4, 0.45454545454545
14052, 1.3304347826087, 1.4, 0.40909090909091
14053, 1.3304347826087, 1.4, 0.36363636363636
14054, 1.3304347826087, 1.4, 0.31818181818182
14055, 1.3304347826087, 1.4, 0.27272727272727
14056, 1.3304347826087, 1.4, 0.22727272727273
14057, 1.3304347826087, 1.4, 0.18181818181818
14058, 1.3304347826087, 1.4, 0.13636363636364
14059, 1.3304347826087, 1.4, 0.090909090909091
14060, 1.3304347826087, 1.4, 0.045454545454545
14061, 1.3739130434783, 1.4, 0.45454545454545
14062, 1.3739130434783, 1.4, 0.40909090909091
14063, 1.3739130434783, 1.4, 0.36363636363636
14064, 1.3739130434783, 1.4, 0.31818181818182
14065, 1.3739130434783, 1.4, 0.27272727272727
14066, 1.3739130434783, 1.4, 0.22727272727273
14067, 1.3739130434783, 1.4, 0.18181818181818
14068, 1.3739130434783, 1.4, 0.13636363636364
14069, 1.3739130434783, 1.4, 0.090909090909091
14070, 1.3739130434783, 1.4, 0.045454545454545
14071, 1.4173913043478, 1.4, 0.45454545454545
14072, 1.4173913043478, 1.4, 0.40909090909091
14073, 1.4173913043478, 1.4, 0.36363636363636
14074, 1.4173913043478, 1.4, 0.31818181818182
14075, 1.4173913043478, 1.4, 0.27272727272727
14076, 1.4173913043478, 1.4, 0.22727272727273
14077, 1.4173913043478, 1.4, 0.18181818181818
14078, 1.4173913043478, 1.4, 0.13636363636364
14079, 1.4173913043478, 1.4, 0.090909090909091
14080, 1.4173913043478, 1.4, 0.045454545454545
14081, 1.4608695652174, 1.4, 0.45454545454545
14082, 1.4608695652174, 1.4, 0.40909090909091
14083, 1.4608695652174, 1.4, 0.36363636363636
14084, 1.4608695652174, 1.4, 0.31818181818182
14085, 1.4608695652174, 1.4, 0.27272727272727
14086, 1.4608695652174, 1.4, 0.22727272727273
14087, 1.4608695652174, 1.4, 0.18181818181818
14088, 1.4608695652174, 1.4, 0.13636363636364
14089, 1.4608695652174, 1.4, 0.090909090909091
14090, 1.4608695652174, 1.4, 0.045454545454545
14091, 1.504347826087, 1.4, 0.45454545454545
14092, 1.504347826087, 1.4, 0.40909090909091
14093, 1.504347826087, 1.4, 0.36363636363636
14094, 1.504347826087, 1.4, 0.31818181818182
14095, 1.504347826087, 1.4, 0.27272727272727
14096, 1.504347826087, 1.4, 0.22727272727273
14097, 1.504347826087, 1.4, 0.18181818181818
14098, 1.504347826087, 1.4, 0.13636363636364
14099, 1.504347826087, 1.4, 0.090909090909091
14100, 1.504347826087, 1.4, 0.045454545454545
14101, 1.5478260869565, 1.4, 0.45454545454545
14102, 1.5478260869565, 1.4, 0.40909090909091
14103, 1.5478260869565, 1.4, 0.36363636363636
14104, 1.5478260869565, 1.4, 0.31818181818182
14105, 1.5478260869565, 1.4, 0.27272727272727
14106, 1.5478260869565, 1.4, 0.22727272727273
14107, 1.5478260869565, 1.4, 0.18181818181818
14108, 1.5478260869565, 1.4, 0.13636363636364
14109, 1.5478260869565, 1.4, 0.090909090909091
14110, 1.5478260869565, 1.4, 0.045454545454545
14111, 1.5913043478261, 1.4, 0.45454545454545
14112, 1.5913043478261, 1.4, 0.40909090909091
14113, 1.5913043478261, 1.4, 0.36363636363636
14114, 1.5913043478261, 1.4, 0.31818181818182
14115, 1.5913043478261, 1.4, 0.27272727272727
14116, 1.5913043478261, 1.4, 0.22727272727273
14117, 1.5913043478261, 1.4, 0.18181818181818
14118, 1.5913043478261, 1.4, 0.13636363636364
14119, 1.5913043478261, 1.4, 0.090909090909091
14120, 1.5913043478261, 1.4, 0.045454545454545
14121, 1.6347826086957, 1.4, 0.45454545454545
14122, 1.6347826086957, 1.4, 0.40909090909091
14123, 1.6347826086957, 1.4, 0.36363636363636
14124, 1.6347826086957, 1.4, 0.31818181818182
14125, 1.6347826086957, 1.4, 0.27272727272727
14126, 1.6347826086957, 1.4, 0.22727272727273
14127, 1.6347826086957, 1.4, 0.18181818181818
14128, 1.6347826086957, 1.4, 0.13636363636364
14129, 1.6347826086957, 1.4, 0.090909090909091
14130, 1.6347826086957, 1.4, 0.045454545454545
14131, 1.6782608695652, 1.4, 0.45454545454545
14132, 1.6782608695652, 1.4, 0.40909090909091
14133, 1.6782608695652, 1.4, 0.36363636363636
14134, 1.6782608695652, 1.4, 0.31818181818182
14135, 1.6782608695652, 1.4, 0.27272727272727
14136, 1.6782608695652, 1.4, 0.22727272727273
14137, 1.6782608695652, 1.4, 0.18181818181818
14138, 1.6782608695652, 1.4, 0.13636363636364
14139, 1.6782608695652, 1.4, 0.090909090909091
14140, 1.6782608695652, 1.4, 0.045454545454545
14141, 1.7217391304348, 1.4, 0.45454545454545
14142, 1.7217391304348, 1.4, 0.40909090909091
14143, 1.7217391304348, 1.4, 0.36363636363636
14144, 1.7217391304348, 1.4, 0.31818181818182
14145, 1.7217391304348, 1.4, 0.27272727272727
14146, 1.7217391304348, 1.4, 0.22727272727273
14147, 1.7217391304348, 1.4, 0.18181818181818
14148, 1.7217391304348, 1.4, 0.13636363636364
14149, 1.7217391304348, 1.4, 0.090909090909091
14150, 1.7217391304348, 1.4, 0.045454545454545
14151, 1.7652173913043, 1.4, 0.45454545454545
14152, 1.7652173913043, 1.4, 0.40909090909091
14153, 1.7652173913043, 1.4, 0.36363636363636
14154, 1.7652173913043, 1.4, 0.31818181818182
14155, 1.7652173913043, 1.4, 0.27272727272727
14156, 1.7652173913043, 1.4, 0.22727272727273
14157, 1.7652173913043, 1.4, 0.18181818181818
14158, 1.7652173913043, 1.4, 0.13636363636364
14159, 1.7652173913043, 1.4, 0.090909090909091
14160, 1.7652173913043, 1.4, 0.045454545454545
14161, 1.8086956521739, 1.4, 0.45454545454545
14162, 1.8086956521739, 1.4, 0.40909090909091
14163, 1.8086956521739, 1.4, 0.36363636363636
14164, 1.8086956521739, 1.4, 0.31818181818182
14165, 1.8086956521739, 1.4, 0.27272727272727
14166, 1.8086956521739, 1.4, 0.22727272727273
14167, 1.8086956521739, 1.4, 0.18181818181818
14168, 1.8086956521739, 1.4, 0.13636363636364
14169, 1.8086956521739, 1.4, 0.090909090909091
14170, 1.8086956521739, 1.4, 0.045454545454545
14171, 1.8521739130435, 1.4, 0.45454545454545
14172, 1.8521739130435, 1.4, 0.40909090909091
14173, 1.8521739130435, 1.4, 0.36363636363636
14174, 1.8521739130435, 1.4, 0.31818181818182
14175, 1.8521739130435, 1.4, 0.27272727272727
14176, 1.8521739130435, 1.4, 0.22727272727273
14177, 1.8521739130435, 1.4, 0.18181818181818
14178, 1.8521739130435, 1.4, 0.13636363636364
14179, 1.8521739130435, 1.4, 0.090909090909091
14180, 1.8521739130435, 1.4, 0.045454545454545
14181, 1.895652173913, 1.4, 0.45454545454545
14182, 1.895652173913, 1.4, 0.40909090909091
14183, 1.895652173913, 1.4, 0.36363636363636
14184, 1.895652173913, 1.4, 0.31818181818182
14185, 1.895652173913, 1.4, 0.27272727272727
14186, 1.895652173913, 1.4, 0.22727272727273
14187, 1.895652173913, 1.4, 0.18181818181818
14188, 1.895652173913, 1.4, 0.13636363636364
14189, 1.895652173913, 1.4, 0.090909090909091
14190, 1.895652173913, 1.4, 0.045454545454545
14191, 1.9391304347826, 1.4, 0.45454545454545
14192, 1.9391304347826, 1.4, 0.40909090909091
14193, 1.9391304347826, 1.4, 0.36363636363636
14194, 1.9391304347826, 1.4, 0.31818181818182
14195, 1.9391304347826, 1.4, 0.27272727272727
14196, 1.9391304347826, 1.4, 0.22727272727273
14197, 1.9391304347826, 1.4, 0.18181818181818
14198, 1.9391304347826, 1.4, 0.13636363636364
14199, 1.9391304347826, 1.4, 0.090909090909091
14200, 1.9391304347826, 1.4, 0.045454545454545
14201, 1.9826086956522, 1.4, 0.45454545454545
14202, 1.9826086956522, 1.4, 0.40909090909091
14203, 1.9826086956522, 1.4, 0.36363636363636
14204, 1.9826086956522, 1.4, 0.31818181818182
14205, 1.9826086956522, 1.4, 0.27272727272727
14206, 1.9826086956522, 1.4, 0.22727272727273
14207, 1.9826086956522, 1.4, 0.18181818181818
14208, 1.9826086956522, 1.4, 0.13636363636364
14209, 1.9826086956522, 1.4, 0.090909090909091
14210, 1.9826086956522, 1.4, 0.045454545454545
14211, 2.0260869565217, 1.4, 0.45454545454545
14212, 2.0260869565217, 1.4, 0.40909090909091
14213, 2.0260869565217, 1.4, 0.36363636363636
14214, 2.0260869565217, 1.4, 0.31818181818182
14215, 2.0260869565217, 1.4, 0.27272727272727
14216, 2.0260869565217, 1.4, 0.22727272727273
14217, 2.0260869565217, 1.4, 0.18181818181818
14218, 2.0260869565217, 1.4, 0.13636363636364
14219, 2.0260869565217, 1.4, 0.090909090909091
14220, 2.0260869565217, 1.4, 0.045454545454545
14221, 2.0695652173913, 1.4, 0.45454545454545
14222, 2.0695652173913, 1.4, 0.40909090909091
14223, 2.0695652173913, 1.4, 0.36363636363636
14224, 2.0695652173913, 1.4, 0.31818181818182
14225, 2.0695652173913, 1.4, 0.27272727272727
14226, 2.0695652173913, 1.4, 0.22727272727273
14227, 2.0695652173913, 1.4, 0.18181818181818
14228, 2.0695652173913, 1.4, 0.13636363636364
14229, 2.0695652173913, 1.4, 0.090909090909091
14230, 2.0695652173913, 1.4, 0.045454545454545
14231, 2.1130434782609, 1.4, 0.45454545454545
14232, 2.1130434782609, 1.4, 0.40909090909091
14233, 2.1130434782609, 1.4, 0.36363636363636
14234, 2.1130434782609, 1.4, 0.31818181818182
14235, 2.1130434782609, 1.4, 0.27272727272727
14236, 2.1130434782609, 1.4, 0.22727272727273
14237, 2.1130434782609, 1.4, 0.18181818181818
14238, 2.1130434782609, 1.4, 0.13636363636364
14239, 2.1130434782609, 1.4, 0.090909090909091
14240, 2.1130434782609, 1.4, 0.045454545454545
14241, 2.1565217391304, 1.4, 0.45454545454545
14242, 2.1565217391304, 1.4, 0.40909090909091
14243, 2.1565217391304, 1.4, 0.36363636363636
14244, 2.1565217391304, 1.4, 0.31818181818182
14245, 2.1565217391304, 1.4, 0.27272727272727
14246, 2.1565217391304, 1.4, 0.22727272727273
14247, 2.1565217391304, 1.4, 0.18181818181818
14248, 2.1565217391304, 1.4, 0.13636363636364
14249, 2.1565217391304, 1.4, 0.090909090909091
14250, 2.1565217391304, 1.4, 0.045454545454545
14251, 1.2217391304348, 1.4, 0.45454545454545
14252, 1.2434782608696, 1.4, 0.47727272727273
14253, 1.2217391304348, 1.4, 0.40909090909091
14254, 1.2434782608696, 1.4, 0.43181818181818
14255, 1.2217391304348, 1.4, 0.36363636363636
14256, 1.2434782608696, 1.4, 0.38636363636364
14257, 1.2217391304348, 1.4, 0.31818181818182
14258, 1.2434782608696, 1.4, 0.34090909090909
14259, 1.2217391304348, 1.4, 0.27272727272727
14260, 1.2434782608696, 1.4, 0.29545454545455
14261, 1.2217391304348, 1.4, 0.22727272727273
14262, 1.2434782608696, 1.4, 0.25
14263, 1.2217391304348, 1.4, 0.18181818181818
14264, 1.2434782608696, 1.4, 0.20454545454545
14265, 1.2217391304348, 1.4, 0.13636363636364
14266, 1.2434782608696, 1.4, 0.15909090909091
14267, 1.2217391304348, 1.4, 0.090909090909091
14268, 1.2434782608696, 1.4, 0.11363636363636
14269, 1.2217391304348, 1.4, 0.045454545454545
14270, 1.2434782608696, 1.4, 0.068181818181818
14271, 1.2434782608696, 1.4, 0.022727272727273
14272, 1.2652173913043, 1.4, 0.45454545454545
14273, 1.2869565217391, 1.4, 0.47727272727273
14274, 1.2652173913043, 1.4, 0.40909090909091
14275, 1.2869565217391, 1.4, 0.43181818181818
14276, 1.2652173913043, 1.4, 0.36363636363636
14277, 1.2869565217391, 1.4, 0.38636363636364
14278, 1.2652173913043, 1.4, 0.31818181818182
14279, 1.2869565217391, 1.4, 0.34090909090909
14280, 1.2652173913043, 1.4, 0.27272727272727
14281, 1.2869565217391, 1.4, 0.29545454545455
14282, 1.2652173913043, 1.4, 0.22727272727273
14283, 1.2869565217391, 1.4, 0.25
14284, 1.2652173913043, 1.4, 0.18181818181818
14285, 1.2869565217391, 1.4, 0.20454545454545
14286, 1.2652173913043, 1.4, 0.13636363636364
14287, 1.2869565217391, 1.4, 0.15909090909091
14288, 1.2652173913043, 1.4, 0.090909090909091
14289, 1.2869565217391, 1.4, 0.11363636363636
14290, 1.2652173913043, 1.4, 0.045454545454545
14291, 1.2869565217391, 1.4, 0.068181818181818
14292, 1.2869565217391, 1.4, 0.022727272727273
14293, 1.3086956521739, 1.4, 0.45454545454545
14294, 1.3304347826087, 1.4, 0.47727272727273
14295, 1.3086956521739, 1.4, 0.40909090909091
14296, 1.3304347826087, 1.4, 0.43181818181818
14297, 1.3086956521739, 1.4, 0.36363636363636
14298, 1.3304347826087, 1.4, 0.38636363636364
14299, 1.3086956521739, 1.4, 0.31818181818182
14300, 1.3304347826087, 1.4, 0.34090909090909
14301, 1.3086956521739, 1.4, 0.27272727272727
14302, 1.3304347826087, 1.4, 0.29545454545455
14303, 1.3086956521739, 1.4, 0.22727272727273
14304, 1.3304347826087, 1.4, 0.25
14305, 1.3086956521739, 1.4, 0.18181818181818
14306, 1.3304347826087, 1.4, 0.20454545454545
14307, 1.3086956521739, 1.4, 0.13636363636364
14308, 1.3304347826087, 1.4, 0.15909090909091
14309, 1.3086956521739, 1.4, 0.090909090909091
14310, 1.3304347826087, 1.4, 0.11363636363636
14311, 1.3086956521739, 1.4, 0.045454545454545
14312, 1.3304347826087, 1.4, 0.068181818181818
14313, 1.3304347826087, 1.4, 0.022727272727273
14314, 1.3521739130435, 1.4, 0.45454545454545
14315, 1.3739130434783, 1.4, 0.47727272727273
14316, 1.3521739130435, 1.4, 0.40909090909091
14317, 1.3739130434783, 1.4, 0.43181818181818
14318, 1.3521739130435, 1.4, 0.36363636363636
14319, 1.3739130434783, 1.4, 0.38636363636364
14320, 1.3521739130435, 1.4, 0.31818181818182
14321, 1.3739130434783, 1.4, 0.34090909090909
14322, 1.3521739130435, 1.4, 0.27272727272727
14323, 1.3739130434783, 1.4, 0.29545454545455
14324, 1.3521739130435, 1.4, 0.22727272727273
14325, 1.3739130434783, 1.4, 0.25
14326, 1.3521739130435, 1.4, 0.18181818181818
14327, 1.3739130434783, 1.4, 0.20454545454545
14328, 1.3521739130435, 1.4, 0.13636363636364
14329, 1.3739130434783, 1.4, 0.15909090909091
14330, 1.3521739130435, 1.4, 0.090909090909091
14331, 1.3739130434783, 1.4, 0.11363636363636
14332, 1.3521739130435, 1.4, 0.045454545454545
14333, 1.3739130434783, 1.4, 0.068181818181818
14334, 1.3739130434783, 1.4, 0.022727272727273
14335, 1.395652173913, 1.4, 0.45454545454545
14336, 1.4173913043478, 1.4, 0.47727272727273
14337, 1.395652173913, 1.4, 0.40909090909091
14338, 1.4173913043478, 1.4, 0.43181818181818
14339, 1.395652173913, 1.4, 0.36363636363636
14340, 1.4173913043478, 1.4, 0.38636363636364
14341, 1.395652173913, 1.4, 0.31818181818182
14342, 1.4173913043478, 1.4, 0.34090909090909
14343, 1.395652173913, 1.4, 0.27272727272727
14344, 1.4173913043478, 1.4, 0.29545454545455
14345, 1.395652173913, 1.4, 0.22727272727273
14346, 1.4173913043478, 1.4, 0.25
14347, 1.395652173913, 1.4, 0.18181818181818
14348, 1.4173913043478, 1.4, 0.20454545454545
14349, 1.395652173913, 1.4, 0.13636363636364
14350, 1.4173913043478, 1.4, 0.15909090909091
14351, 1.395652173913, 1.4, 0.090909090909091
14352, 1.4173913043478, 1.4, 0.11363636363636
14353, 1.395652173913, 1.4, 0.045454545454545
14354, 1.4173913043478, 1.4, 0.068181818181818
14355, 1.4173913043478, 1.4, 0.022727272727273
14356, 1.4391304347826, 1.4, 0.45454545454545
14357, 1.4608695652174, 1.4, 0.47727272727273
14358, 1.4391304347826, 1.4, 0.40909090909091
14359, 1.4608695652174, 1.4, 0.43181818181818
14360, 1.4391304347826, 1.4, 0.36363636363636
14361, 1.4608695652174, 1.4, 0.38636363636364
14362, 1.4391304347826, 1.4, 0.31818181818182
14363, 1.4608695652174, 1.4, 0.34090909090909
14364, 1.4391304347826, 1.4, 0.27272727272727
14365, 1.4608695652174, 1.4, 0.29545454545455
14366, 1.4391304347826, 1.4, 0.22727272727273
14367, 1.4608695652174, 1.4, 0.25
14368, 1.4391304347826, 1.4, 0.18181818181818
14369, 1.4608695652174, 1.4, 0.20454545454545
14370, 1.4391304347826, 1.4, 0.13636363636364
14371, 1.4608695652174, 1.4, 0.15909090909091
14372, 1.4391304347826, 1.4, 0.090909090909091
14373, 1.4608695652174, 1.4, 0.11363636363636
14374, 1.4391304347826, 1.4, 0.045454545454545
14375, 1.4608695652174, 1.4, 0.068181818181818
14376, 1.4608695652174, 1.4, 0.022727272727273
14377, 1.4826086956522, 1.4, 0.45454545454545
14378, 1.504347826087, 1.4, 0.47727272727273
14379, 1.4826086956522, 1.4, 0.40909090909091
14380, 1.504347826087, 1.4, 0.43181818181818
14381, 1.4826086956522, 1.4, 0.36363636363636
14382, 1.504347826087, 1.4, 0.38636363636364
14383, 1.4826086956522, 1.4, 0.31818181818182
14384, 1.504347826087, 1.4, 0.34090909090909
14385, 1.4826086956522, 1.4, 0.27272727272727
14386, 1.504347826087, 1.4, 0.29545454545455
14387, 1.4826086956522, 1.4, 0.22727272727273
14388, 1.504347826087, 1.4, 0.25
14389, 1.4826086956522, 1.4, 0.18181818181818
14390, 1.504347826087, 1.4, 0.20454545454545
14391, 1.4826086956522, 1.4, 0.13636363636364
14392, 1.504347826087, 1.4, 0.15909090909091
14393, 1.4826086956522, 1.4, 0.090909090909091
14394, 1.504347826087, 1.4, 0.11363636363636
14395, 1.4826086956522, 1.4, 0.045454545454545
14396, 1.504347826087, 1.4, 0.068181818181818
14397, 1.504347826087, 1.4, 0.022727272727273
14398, 1.5260869565217, 1.4, 0.45454545454545
14399, 1.5478260869565, 1.4, 0.47727272727273
14400, 1.5260869565217, 1.4, 0.40909090909091
14401, 1.5478260869565, 1.4, 0.43181818181818
14402, 1.5260869565217, 1.4, 0.36363636363636
14403, 1.5478260869565, 1.4, 0.38636363636364
14404, 1.5260869565217, 1.4, 0.31818181818182
14405, 1.5478260869565, 1.4, 0.34090909090909
14406, 1.5260869565217, 1.4, 0.27272727272727
14407, 1.5478260869565, 1.4, 0.29545454545455
14408, 1.5260869565217, 1.4, 0.22727272727273
14409, 1.5478260869565, 1.4, 0.25
14410, 1.5260869565217, 1.4, 0.18181818181818
14411, 1.5478260869565, 1.4, 0.20454545454545
14412, 1.5260869565217, 1.4, 0.13636363636364
14413, 1.5478260869565, 1.4, 0.15909090909091
14414, 1.5260869565217, 1.4, 0.090909090909091
14415, 1.5478260869565, 1.4, 0.11363636363636
14416, 1.5260869565217, 1.4, 0.045454545454545
14417, 1.5478260869565, 1.4, 0.068181818181818
14418, 1.5478260869565, 1.4, 0.022727272727273
14419, 1.5695652173913, 1.4, 0.45454545454545
14420, 1.5913043478261, 1.4, 0.47727272727273
14421, 1.5695652173913, 1.4, 0.40909090909091
14422, 1.5913043478261, 1.4, 0.43181818181818
14423, 1.5695652173913, 1.4, 0.36363636363636
14424, 1.5913043478261, 1.4, 0.38636363636364
14425, 1.5695652173913, 1.4, 0.31818181818182
14426, 1.5913043478261, 1.4, 0.34090909090909
14427, 1.5695652173913, 1.4, 0.27272727272727
14428, 1.5913043478261, 1.4, 0.29545454545455
14429, 1.5695652173913, 1.4, 0.22727272727273
14430, 1.5913043478261, 1.4, 0.25
14431, 1.5695652173913, 1.4, 0.18181818181818
14432, 1.5913043478261, 1.4, 0.20454545454545
14433, 1.5695652173913, 1.4, 0.13636363636364
14434, 1.5913043478261, 1.4, 0.15909090909091
14435, 1.5695652173913, 1.4, 0.090909090909091
14436, 1.5913043478261, 1.4, 0.11363636363636
14437, 1.5695652173913, 1.4, 0.045454545454545
14438, 1.5913043478261, 1.4, 0.068181818181818
14439, 1.5913043478261, 1.4, 0.022727272727273
14440, 1.6130434782609, 1.4, 0.45454545454545
14441, 1.6347826086957, 1.4, 0.47727272727273
14442, 1.6130434782609, 1.4, 0.40909090909091
14443, 1.6347826086957, 1.4, 0.43181818181818
14444, 1.6130434782609, 1.4, 0.36363636363636
14445, 1.6347826086957, 1.4, 0.38636363636364
14446, 1.6130434782609, 1.4, 0.31818181818182
14447, 1.6347826086957, 1.4, 0.34090909090909
14448, 1.6130434782609, 1.4, 0.27272727272727
14449, 1.6347826086957, 1.4, 0.29545454545455
14450, 1.6130434782609, 1.4, 0.22727272727273
14451, 1.6347826086957, 1.4, 0.25
14452, 1.6130434782609, 1.4, 0.18181818181818
14453, 1.6347826086957, 1.4, 0.20454545454545
14454, 1.6130434782609, 1.4, 0.13636363636364
14455, 1.6347826086957, 1.4, 0.15909090909091
14456, 1.6130434782609, 1.4, 0.090909090909091
14457, 1.6347826086957, 1.4, 0.11363636363636
14458, 1.6130434782609, 1.4, 0.045454545454545
14459, 1.6347826086957, 1.4, 0.068181818181818
14460, 1.6347826086957, 1.4, 0.022727272727273
14461, 1.6565217391304, 1.4, 0.45454545454545
14462, 1.6782608695652, 1.4, 0.47727272727273
14463, 1.6565217391304, 1.4, 0.40909090909091
14464, 1.6782608695652, 1.4, 0.43181818181818
14465, 1.6565217391304, 1.4, 0.36363636363636
14466, 1.6782608695652, 1.4, 0.38636363636364
14467, 1.6565217391304, 1.4, 0.31818181818182
14468, 1.6782608695652, 1.4, 0.34090909090909
14469, 1.6565217391304, 1.4, 0.27272727272727
14470, 1.6782608695652, 1.4, 0.29545454545455
14471, 1.6565217391304, 1.4, 0.22727272727273
14472, 1.6782608695652, 1.4, 0.25
14473, 1.6565217391304, 1.4, 0.18181818181818
14474, 1.6782608695652, 1.4, 0.20454545454545
14475, 1.6565217391304, 1.4, 0.13636363636364
14476, 1.6782608695652, 1.4, 0.15909090909091
14477, 1.6565217391304, 1.4, 0.090909090909091
14478, 1.6782608695652, 1.4, 0.11363636363636
14479, 1.6565217391304, 1.4, 0.045454545454545
14480, 1.6782608695652, 1.4, 0.068181818181818
14481, 1.6782608695652, 1.4, 0.022727272727273
14482, 1.7, 1.4, 0.45454545454545
14483, 1.7217391304348, 1.4, 0.47727272727273
14484, 1.7, 1.4, 0.40909090909091
14485, 1.7217391304348, 1.4, 0.43181818181818
14486, 1.7, 1.4, 0.36363636363636
14487, 1.7217391304348, 1.4, 0.38636363636364
14488, 1.7, 1.4, 0.31818181818182
14489, 1.7217391304348, 1.4, 0.34090909090909
14490, 1.7, 1.4, 0.27272727272727
14491, 1.7217391304348, 1.4, 0.29545454545455
14492, 1.7, 1.4, 0.22727272727273
14493, 1.7217391304348, 1.4, 0.25
14494, 1.7, 1.4, 0.18181818181818
14495, 1.7217391304348, 1.4, 0.20454545454545
14496, 1.7, 1.4, 0.13636363636364
14497, 1.7217391304348, 1.4, 0.15909090909091
14498, 1.7, 1.4, 0.090909090909091
14499, 1.7217391304348, 1.4, 0.11363636363636
14500, 1.7, 1.4, 0.045454545454545
14501, 1.7217391304348, 1.4, 0.068181818181818
14502, 1.7217391304348, 1.4, 0.022727272727273
14503, 1.7434782608696, 1.4, 0.45454545454545
14504, 1.7652173913043, 1.4, 0.47727272727273
14505, 1.7434782608696, 1.4, 0.40909090909091
14506, 1.7652173913043, 1.4, 0.43181818181818
14507, 1.7434782608696, 1.4, 0.36363636363636
14508, 1.7652173913043, 1.4, 0.38636363636364
14509, 1.7434782608696, 1.4, 0.31818181818182
14510, 1.7652173913043, 1.4, 0.34090909090909
14511, 1.7434782608696, 1.4, 0.27272727272727
14512, 1.7652173913043, 1.4, 0.29545454545455
14513, 1.7434782608696, 1.4, 0.22727272727273
14514, 1.7652173913043, 1.4, 0.25
14515, 1.7434782608696, 1.4, 0.18181818181818
14516, 1.7652173913043, 1.4, 0.20454545454545
14517, 1.7434782608696, 1.4, 0.13636363636364
14518, 1.7652173913043, 1.4, 0.15909090909091
14519, 1.7434782608696, 1.4, 0.090909090909091
14520, 1.7652173913043, 1.4, 0.11363636363636
14521, 1.7434782608696, 1.4, 0.045454545454545
14522, 1.7652173913043, 1.4, 0.068181818181818
14523, 1.7652173913043, 1.4, 0.022727272727273
14524, 1.7869565217391, 1.4, 0.45454545454545
14525, 1.8086956521739, 1.4, 0.47727272727273
14526, 1.7869565217391, 1.4, 0.40909090909091
14527, 1.8086956521739, 1.4, 0.43181818181818
14528, 1.7869565217391, 1.4, 0.36363636363636
14529, 1.8086956521739, 1.4, 0.38636363636364
14530, 1.7869565217391, 1.4, 0.31818181818182
14531, 1.8086956521739, 1.4, 0.34090909090909
14532, 1.7869565217391, 1.4, 0.27272727272727
14533, 1.8086956521739, 1.4, 0.29545454545455
14534, 1.7869565217391, 1.4, 0.22727272727273
14535, 1.8086956521739, 1.4, 0.25
14536, 1.7869565217391, 1.4, 0.18181818181818
14537, 1.8086956521739, 1.4, 0.20454545454545
14538, 1.7869565217391, 1.4, 0.13636363636364
14539, 1.8086956521739, 1.4, 0.15909090909091
14540, 1.7869565217391, 1.4, 0.090909090909091
14541, 1.8086956521739, 1.4, 0.11363636363636
14542, 1.7869565217391, 1.4, 0.045454545454545
14543, 1.8086956521739, 1.4, 0.068181818181818
14544, 1.8086956521739, 1.4, 0.022727272727273
14545, 1.8304347826087, 1.4, 0.45454545454545
14546, 1.8521739130435, 1.4, 0.47727272727273
14547, 1.8304347826087, 1.4, 0.40909090909091
14548, 1.8521739130435, 1.4, 0.43181818181818
14549, 1.8304347826087, 1.4, 0.36363636363636
14550, 1.8521739130435, 1.4, 0.38636363636364
14551, 1.8304347826087, 1.4, 0.31818181818182
14552, 1.8521739130435, 1.4, 0.34090909090909
14553, 1.8304347826087, 1.4, 0.27272727272727
14554, 1.8521739130435, 1.4, 0.29545454545455
14555, 1.8304347826087, 1.4, 0.22727272727273
14556, 1.8521739130435, 1.4, 0.25
14557, 1.8304347826087, 1.4, 0.18181818181818
14558, 1.8521739130435, 1.4, 0.20454545454545
14559, 1.8304347826087, 1.4, 0.13636363636364
14560, 1.8521739130435, 1.4, 0.15909090909091
14561, 1.8304347826087, 1.4, 0.090909090909091
14562, 1.8521739130435, 1.4, 0.11363636363636
14563, 1.8304347826087, 1.4, 0.045454545454545
14564, 1.8521739130435, 1.4, 0.068181818181818
14565, 1.8521739130435, 1.4, 0.022727272727273
14566, 1.8739130434783, 1.4, 0.45454545454545
14567, 1.895652173913, 1.4, 0.47727272727273
14568, 1.8739130434783, 1.4, 0.40909090909091
14569, 1.895652173913, 1.4, 0.43181818181818
14570, 1.8739130434783, 1.4, 0.36363636363636
14571, 1.895652173913, 1.4, 0.38636363636364
14572, 1.8739130434783, 1.4, 0.31818181818182
14573, 1.895652173913, 1.4, 0.34090909090909
14574, 1.8739130434783, 1.4, 0.27272727272727
14575, 1.895652173913, 1.4, 0.29545454545455
14576, 1.8739130434783, 1.4, 0.22727272727273
14577, 1.895652173913, 1.4, 0.25
14578, 1.8739130434783, 1.4, 0.18181818181818
14579, 1.895652173913, 1.4, 0.20454545454545
14580, 1.8739130434783, 1.4, 0.13636363636364
14581, 1.895652173913, 1.4, 0.15909090909091
14582, 1.8739130434783, 1.4, 0.090909090909091
14583, 1.895652173913, 1.4, 0.11363636363636
14584, 1.8739130434783, 1.4, 0.045454545454545
14585, 1.895652173913, 1.4, 0.068181818181818
14586, 1.895652173913, 1.4, 0.022727272727273
14587, 1.9173913043478, 1.4, 0.45454545454545
14588, 1.9391304347826, 1.4, 0.47727272727273
14589, 1.9173913043478, 1.4, 0.40909090909091
14590, 1.9391304347826, 1.4, 0.43181818181818
14591, 1.9173913043478, 1.4, 0.36363636363636
14592, 1.9391304347826, 1.4, 0.38636363636364
14593, 1.9173913043478, 1.4, 0.31818181818182
14594, 1.9391304347826, 1.4, 0.34090909090909
14595, 1.9173913043478, 1.4, 0.27272727272727
14596, 1.9391304347826, 1.4, 0.29545454545455
14597, 1.9173913043478, 1.4, 0.22727272727273
14598, 1.9391304347826, 1.4, 0.25
14599, 1.9173913043478, 1.4, 0.18181818181818
14600, 1.9391304347826, 1.4, 0.20454545454545
14601, 1.9173913043478, 1.4, 0.13636363636364
14602, 1.9391304347826, 1.4, 0.15909090909091
14603, 1.9173913043478, 1.4, 0.090909090909091
14604, 1.9391304347826, 1.4, 0.11363636363636
14605, 1.9173913043478, 1.4, 0.045454545454545
14606, 1.9391304347826, 1.4, 0.068181818181818
14607, 1.9391304347826, 1.4, 0.022727272727273
14608, 1.9608695652174, 1.4, 0.45454545454545
14609, 1.9826086956522, 1.4, 0.47727272727273
14610, 1.9608695652174, 1.4, 0.40909090909091
14611, 1.9826086956522, 1.4, 0.43181818181818
14612, 1.9608695652174, 1.4, 0.36363636363636
14613, 1.9826086956522, 1.4, 0.38636363636364
14614, 1.9608695652174, 1.4, 0.31818181818182
14615, 1.9826086956522, 1.4, 0.34090909090909
14616, 1.9608695652174, 1.4, 0.27272727272727
14617, 1.9826086956522, 1.4, 0.29545454545455
14618, 1.9608695652174, 1.4, 0.22727272727273
14619, 1.9826086956522, 1.4, 0.25
14620, 1.9608695652174, 1.4, 0.18181818181818
14621, 1.9826086956522, 1.4, 0.20454545454545
14622, 1.9608695652174, 1.4, 0.13636363636364
14623, 1.9826086956522, 1.4, 0.15909090909091
14624, 1.9608695652174, 1.4, 0.090909090909091
14625, 1.9826086956522, 1.4, 0.11363636363636
14626, 1.9608695652174, 1.4, 0.045454545454545
14627, 1.9826086956522, 1.4, 0.068181818181818
14628, 1.9826086956522, 1.4, 0.022727272727273
14629, 2.004347826087, 1.4, 0.45454545454545
14630, 2.0260869565217, 1.4, 0.47727272727273
14631, 2.004347826087, 1.4, 0.40909090909091
14632, 2.0260869565217, 1.4, 0.43181818181818
14633, 2.004347826087, 1.4, 0.36363636363636
14634, 2.0260869565217, 1.4, 0.38636363636364
14635, 2.004347826087, 1.4, 0.31818181818182
14636, 2.0260869565217, 1.4, 0.34090909090909
14637, 2.004347826087, 1.4, 0.27272727272727
14638, 2.0260869565217, 1.4, 0.29545454545455
14639, 2.004347826087, 1.4, 0.22727272727273
14640, 2.0260869565217, 1.4, 0.25
14641, 2.004347826087, 1.4, 0.18181818181818
14642, 2.0260869565217, 1.4, 0.20454545454545
14643, 2.004347826087, 1.4, 0.13636363636364
14644, 2.0260869565217, 1.4, 0.15909090909091
14645, 2.004347826087, 1.4, 0.090909090909091
14646, 2.0260869565217, 1.4, 0.11363636363636
14647, 2.004347826087, 1.4, 0.045454545454545
14648, 2.0260869565217, 1.4, 0.068181818181818
14649, 2.0260869565217, 1.4, 0.022727272727273
14650, 2.0478260869565, 1.4, 0.45454545454545
14651, 2.0695652173913, 1.4, 0.47727272727273
14652, 2.0478260869565, 1.4, 0.40909090909091
14653, 2.0695652173913, 1.4, 0.43181818181818
14654, 2.0478260869565, 1.4, 0.36363636363636
14655, 2.0695652173913, 1.4, 0.38636363636364
14656, 2.0478260869565, 1.4, 0.31818181818182
14657, 2.0695652173913, 1.4, 0.34090909090909
14658, 2.0478260869565, 1.4, 0.27272727272727
14659, 2.0695652173913, 1.4, 0.29545454545455
14660, 2.0478260869565, 1.4, 0.22727272727273
14661, 2.0695652173913, 1.4, 0.25
14662, 2.0478260869565, 1.4, 0.18181818181818
14663, 2.0695652173913, 1.4, 0.20454545454545
14664, 2.0478260869565, 1.4, 0.13636363636364
14665, 2.0695652173913, 1.4, 0.15909090909091
14666, 2.0478260869565, 1.4, 0.090909090909091
14667, 2.0695652173913, 1.4, 0.11363636363636
14668, 2.0478260869565, 1.4, 0.045454545454545
14669, 2.0695652173913, 1.4, 0.068181818181818
14670, 2.0695652173913, 1.4, 0.022727272727273
14671, 2.0913043478261, 1.4, 0.45454545454545
14672, 2.1130434782609, 1.4, 0.47727272727273
14673, 2.0913043478261, 1.4, 0.40909090909091
14674, 2.1130434782609, 1.4, 0.43181818181818
14675, 2.0913043478261, 1.4, 0.36363636363636
14676, 2.1130434782609, 1.4, 0.38636363636364
14677, 2.0913043478261, 1.4, 0.31818181818182
14678, 2.1130434782609, 1.4, 0.34090909090909
14679, 2.0913043478261, 1.4, 0.27272727272727
14680, 2.1130434782609, 1.4, 0.29545454545455
14681, 2.0913043478261, 1.4, 0.22727272727273
14682, 2.1130434782609, 1.4, 0.25
14683, 2.0913043478261, 1.4, 0.18181818181818
