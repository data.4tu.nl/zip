7910, 1, 0.30652173913043, 0.47727272727273
7911, 1, 0.2804347826087, 0.40909090909091
7912, 1, 0.30652173913043, 0.43181818181818
7913, 1, 0.2804347826087, 0.36363636363636
7914, 1, 0.30652173913043, 0.38636363636364
7915, 1, 0.2804347826087, 0.31818181818182
7916, 1, 0.30652173913043, 0.34090909090909
7917, 1, 0.2804347826087, 0.27272727272727
7918, 1, 0.30652173913043, 0.29545454545455
7919, 1, 0.2804347826087, 0.22727272727273
7920, 1, 0.30652173913043, 0.25
7921, 1, 0.2804347826087, 0.18181818181818
7922, 1, 0.30652173913043, 0.20454545454545
7923, 1, 0.2804347826087, 0.13636363636364
7924, 1, 0.30652173913043, 0.15909090909091
7925, 1, 0.2804347826087, 0.090909090909091
7926, 1, 0.30652173913043, 0.11363636363636
7927, 1, 0.2804347826087, 0.045454545454545
7928, 1, 0.30652173913043, 0.068181818181818
7929, 1, 0.30652173913043, 0.022727272727273
7930, 1, 0.33260869565217, 0.45454545454545
7931, 1, 0.35869565217391, 0.47727272727273
7932, 1, 0.33260869565217, 0.40909090909091
7933, 1, 0.35869565217391, 0.43181818181818
7934, 1, 0.33260869565217, 0.36363636363636
7935, 1, 0.35869565217391, 0.38636363636364
7936, 1, 0.33260869565217, 0.31818181818182
7937, 1, 0.35869565217391, 0.34090909090909
7938, 1, 0.33260869565217, 0.27272727272727
7939, 1, 0.35869565217391, 0.29545454545455
7940, 1, 0.33260869565217, 0.22727272727273
7941, 1, 0.35869565217391, 0.25
7942, 1, 0.33260869565217, 0.18181818181818
7943, 1, 0.35869565217391, 0.20454545454545
7944, 1, 0.33260869565217, 0.13636363636364
7945, 1, 0.35869565217391, 0.15909090909091
7946, 1, 0.33260869565217, 0.090909090909091
7947, 1, 0.35869565217391, 0.11363636363636
7948, 1, 0.33260869565217, 0.045454545454545
7949, 1, 0.35869565217391, 0.068181818181818
7950, 1, 0.35869565217391, 0.022727272727273
7951, 1, 0.38478260869565, 0.45454545454545
7952, 1, 0.41086956521739, 0.47727272727273
7953, 1, 0.38478260869565, 0.40909090909091
7954, 1, 0.41086956521739, 0.43181818181818
7955, 1, 0.38478260869565, 0.36363636363636
7956, 1, 0.41086956521739, 0.38636363636364
7957, 1, 0.38478260869565, 0.31818181818182
7958, 1, 0.41086956521739, 0.34090909090909
7959, 1, 0.38478260869565, 0.27272727272727
7960, 1, 0.41086956521739, 0.29545454545455
7961, 1, 0.38478260869565, 0.22727272727273
7962, 1, 0.41086956521739, 0.25
7963, 1, 0.38478260869565, 0.18181818181818
7964, 1, 0.41086956521739, 0.20454545454545
7965, 1, 0.38478260869565, 0.13636363636364
7966, 1, 0.41086956521739, 0.15909090909091
7967, 1, 0.38478260869565, 0.090909090909091
7968, 1, 0.41086956521739, 0.11363636363636
7969, 1, 0.38478260869565, 0.045454545454545
7970, 1, 0.41086956521739, 0.068181818181818
7971, 1, 0.41086956521739, 0.022727272727273
7972, 1, 0.43695652173913, 0.45454545454545
7973, 1, 0.46304347826087, 0.47727272727273
7974, 1, 0.43695652173913, 0.40909090909091
7975, 1, 0.46304347826087, 0.43181818181818
7976, 1, 0.43695652173913, 0.36363636363636
7977, 1, 0.46304347826087, 0.38636363636364
7978, 1, 0.43695652173913, 0.31818181818182
7979, 1, 0.46304347826087, 0.34090909090909
7980, 1, 0.43695652173913, 0.27272727272727
7981, 1, 0.46304347826087, 0.29545454545455
7982, 1, 0.43695652173913, 0.22727272727273
7983, 1, 0.46304347826087, 0.25
7984, 1, 0.43695652173913, 0.18181818181818
7985, 1, 0.46304347826087, 0.20454545454545
7986, 1, 0.43695652173913, 0.13636363636364
7987, 1, 0.46304347826087, 0.15909090909091
7988, 1, 0.43695652173913, 0.090909090909091
7989, 1, 0.46304347826087, 0.11363636363636
7990, 1, 0.43695652173913, 0.045454545454545
7991, 1, 0.46304347826087, 0.068181818181818
7992, 1, 0.46304347826087, 0.022727272727273
7993, 1, 0.48913043478261, 0.45454545454545
7994, 1, 0.51521739130435, 0.47727272727273
7995, 1, 0.48913043478261, 0.40909090909091
7996, 1, 0.51521739130435, 0.43181818181818
7997, 1, 0.48913043478261, 0.36363636363636
7998, 1, 0.51521739130435, 0.38636363636364
7999, 1, 0.48913043478261, 0.31818181818182
8000, 1, 0.51521739130435, 0.34090909090909
8001, 1, 0.48913043478261, 0.27272727272727
8002, 1, 0.51521739130435, 0.29545454545455
8003, 1, 0.48913043478261, 0.22727272727273
8004, 1, 0.51521739130435, 0.25
8005, 1, 0.48913043478261, 0.18181818181818
8006, 1, 0.51521739130435, 0.20454545454545
8007, 1, 0.48913043478261, 0.13636363636364
8008, 1, 0.51521739130435, 0.15909090909091
8009, 1, 0.48913043478261, 0.090909090909091
8010, 1, 0.51521739130435, 0.11363636363636
8011, 1, 0.48913043478261, 0.045454545454545
8012, 1, 0.51521739130435, 0.068181818181818
8013, 1, 0.51521739130435, 0.022727272727273
8014, 1, 0.54130434782609, 0.45454545454545
8015, 1, 0.56739130434783, 0.47727272727273
8016, 1, 0.54130434782609, 0.40909090909091
8017, 1, 0.56739130434783, 0.43181818181818
8018, 1, 0.54130434782609, 0.36363636363636
8019, 1, 0.56739130434783, 0.38636363636364
8020, 1, 0.54130434782609, 0.31818181818182
8021, 1, 0.56739130434783, 0.34090909090909
8022, 1, 0.54130434782609, 0.27272727272727
8023, 1, 0.56739130434783, 0.29545454545455
8024, 1, 0.54130434782609, 0.22727272727273
8025, 1, 0.56739130434783, 0.25
8026, 1, 0.54130434782609, 0.18181818181818
8027, 1, 0.56739130434783, 0.20454545454545
8028, 1, 0.54130434782609, 0.13636363636364
8029, 1, 0.56739130434783, 0.15909090909091
8030, 1, 0.54130434782609, 0.090909090909091
8031, 1, 0.56739130434783, 0.11363636363636
8032, 1, 0.54130434782609, 0.045454545454545
8033, 1, 0.56739130434783, 0.068181818181818
8034, 1, 0.56739130434783, 0.022727272727273
8035, 1, 0.59347826086956, 0.45454545454545
8036, 1, 0.6195652173913, 0.47727272727273
8037, 1, 0.59347826086956, 0.40909090909091
8038, 1, 0.6195652173913, 0.43181818181818
8039, 1, 0.59347826086956, 0.36363636363636
8040, 1, 0.6195652173913, 0.38636363636364
8041, 1, 0.59347826086956, 0.31818181818182
8042, 1, 0.6195652173913, 0.34090909090909
8043, 1, 0.59347826086956, 0.27272727272727
8044, 1, 0.6195652173913, 0.29545454545455
8045, 1, 0.59347826086956, 0.22727272727273
8046, 1, 0.6195652173913, 0.25
8047, 1, 0.59347826086956, 0.18181818181818
8048, 1, 0.6195652173913, 0.20454545454545
8049, 1, 0.59347826086956, 0.13636363636364
8050, 1, 0.6195652173913, 0.15909090909091
8051, 1, 0.59347826086956, 0.090909090909091
8052, 1, 0.6195652173913, 0.11363636363636
8053, 1, 0.59347826086956, 0.045454545454545
8054, 1, 0.6195652173913, 0.068181818181818
8055, 1, 0.6195652173913, 0.022727272727273
8056, 1, 0.64565217391304, 0.45454545454545
8057, 1, 0.67173913043478, 0.47727272727273
8058, 1, 0.64565217391304, 0.40909090909091
8059, 1, 0.67173913043478, 0.43181818181818
8060, 1, 0.64565217391304, 0.36363636363636
8061, 1, 0.67173913043478, 0.38636363636364
8062, 1, 0.64565217391304, 0.31818181818182
8063, 1, 0.67173913043478, 0.34090909090909
8064, 1, 0.64565217391304, 0.27272727272727
8065, 1, 0.67173913043478, 0.29545454545455
8066, 1, 0.64565217391304, 0.22727272727273
8067, 1, 0.67173913043478, 0.25
8068, 1, 0.64565217391304, 0.18181818181818
8069, 1, 0.67173913043478, 0.20454545454545
8070, 1, 0.64565217391304, 0.13636363636364
8071, 1, 0.67173913043478, 0.15909090909091
8072, 1, 0.64565217391304, 0.090909090909091
8073, 1, 0.67173913043478, 0.11363636363636
8074, 1, 0.64565217391304, 0.045454545454545
8075, 1, 0.67173913043478, 0.068181818181818
8076, 1, 0.67173913043478, 0.022727272727273
8077, 1, 0.69782608695652, 0.45454545454545
8078, 1, 0.72391304347826, 0.47727272727273
8079, 1, 0.69782608695652, 0.40909090909091
8080, 1, 0.72391304347826, 0.43181818181818
8081, 1, 0.69782608695652, 0.36363636363636
8082, 1, 0.72391304347826, 0.38636363636364
8083, 1, 0.69782608695652, 0.31818181818182
8084, 1, 0.72391304347826, 0.34090909090909
8085, 1, 0.69782608695652, 0.27272727272727
8086, 1, 0.72391304347826, 0.29545454545455
8087, 1, 0.69782608695652, 0.22727272727273
8088, 1, 0.72391304347826, 0.25
8089, 1, 0.69782608695652, 0.18181818181818
8090, 1, 0.72391304347826, 0.20454545454545
8091, 1, 0.69782608695652, 0.13636363636364
8092, 1, 0.72391304347826, 0.15909090909091
8093, 1, 0.69782608695652, 0.090909090909091
8094, 1, 0.72391304347826, 0.11363636363636
8095, 1, 0.69782608695652, 0.045454545454545
8096, 1, 0.72391304347826, 0.068181818181818
8097, 1, 0.72391304347826, 0.022727272727273
8098, 1, 0.75, 0.45454545454545
8099, 1, 0.77608695652174, 0.47727272727273
8100, 1, 0.75, 0.40909090909091
8101, 1, 0.77608695652174, 0.43181818181818
8102, 1, 0.75, 0.36363636363636
8103, 1, 0.77608695652174, 0.38636363636364
8104, 1, 0.75, 0.31818181818182
8105, 1, 0.77608695652174, 0.34090909090909
8106, 1, 0.75, 0.27272727272727
8107, 1, 0.77608695652174, 0.29545454545455
8108, 1, 0.75, 0.22727272727273
8109, 1, 0.77608695652174, 0.25
8110, 1, 0.75, 0.18181818181818
8111, 1, 0.77608695652174, 0.20454545454545
8112, 1, 0.75, 0.13636363636364
8113, 1, 0.77608695652174, 0.15909090909091
8114, 1, 0.75, 0.090909090909091
8115, 1, 0.77608695652174, 0.11363636363636
8116, 1, 0.75, 0.045454545454545
8117, 1, 0.77608695652174, 0.068181818181818
8118, 1, 0.77608695652174, 0.022727272727273
8119, 1, 0.80217391304348, 0.45454545454545
8120, 1, 0.82826086956522, 0.47727272727273
8121, 1, 0.80217391304348, 0.40909090909091
8122, 1, 0.82826086956522, 0.43181818181818
8123, 1, 0.80217391304348, 0.36363636363636
8124, 1, 0.82826086956522, 0.38636363636364
8125, 1, 0.80217391304348, 0.31818181818182
8126, 1, 0.82826086956522, 0.34090909090909
8127, 1, 0.80217391304348, 0.27272727272727
8128, 1, 0.82826086956522, 0.29545454545455
8129, 1, 0.80217391304348, 0.22727272727273
8130, 1, 0.82826086956522, 0.25
8131, 1, 0.80217391304348, 0.18181818181818
8132, 1, 0.82826086956522, 0.20454545454545
8133, 1, 0.80217391304348, 0.13636363636364
8134, 1, 0.82826086956522, 0.15909090909091
8135, 1, 0.80217391304348, 0.090909090909091
8136, 1, 0.82826086956522, 0.11363636363636
8137, 1, 0.80217391304348, 0.045454545454545
8138, 1, 0.82826086956522, 0.068181818181818
8139, 1, 0.82826086956522, 0.022727272727273
8140, 1, 0.85434782608696, 0.45454545454545
8141, 1, 0.8804347826087, 0.47727272727273
8142, 1, 0.85434782608696, 0.40909090909091
8143, 1, 0.8804347826087, 0.43181818181818
8144, 1, 0.85434782608696, 0.36363636363636
8145, 1, 0.8804347826087, 0.38636363636364
8146, 1, 0.85434782608696, 0.31818181818182
8147, 1, 0.8804347826087, 0.34090909090909
8148, 1, 0.85434782608696, 0.27272727272727
8149, 1, 0.8804347826087, 0.29545454545455
8150, 1, 0.85434782608696, 0.22727272727273
8151, 1, 0.8804347826087, 0.25
8152, 1, 0.85434782608696, 0.18181818181818
8153, 1, 0.8804347826087, 0.20454545454545
8154, 1, 0.85434782608696, 0.13636363636364
8155, 1, 0.8804347826087, 0.15909090909091
8156, 1, 0.85434782608696, 0.090909090909091
8157, 1, 0.8804347826087, 0.11363636363636
8158, 1, 0.85434782608696, 0.045454545454545
8159, 1, 0.8804347826087, 0.068181818181818
8160, 1, 0.8804347826087, 0.022727272727273
8161, 1, 0.90652173913043, 0.45454545454545
8162, 1, 0.93260869565217, 0.47727272727273
8163, 1, 0.90652173913043, 0.40909090909091
8164, 1, 0.93260869565217, 0.43181818181818
8165, 1, 0.90652173913043, 0.36363636363636
8166, 1, 0.93260869565217, 0.38636363636364
8167, 1, 0.90652173913043, 0.31818181818182
8168, 1, 0.93260869565217, 0.34090909090909
8169, 1, 0.90652173913043, 0.27272727272727
8170, 1, 0.93260869565217, 0.29545454545455
8171, 1, 0.90652173913043, 0.22727272727273
8172, 1, 0.93260869565217, 0.25
8173, 1, 0.90652173913043, 0.18181818181818
8174, 1, 0.93260869565217, 0.20454545454545
8175, 1, 0.90652173913043, 0.13636363636364
8176, 1, 0.93260869565217, 0.15909090909091
8177, 1, 0.90652173913043, 0.090909090909091
8178, 1, 0.93260869565217, 0.11363636363636
8179, 1, 0.90652173913043, 0.045454545454545
8180, 1, 0.93260869565217, 0.068181818181818
8181, 1, 0.93260869565217, 0.022727272727273
8182, 1, 0.95869565217391, 0.45454545454545
8183, 1, 0.98478260869565, 0.47727272727273
8184, 1, 0.95869565217391, 0.40909090909091
8185, 1, 0.98478260869565, 0.43181818181818
8186, 1, 0.95869565217391, 0.36363636363636
8187, 1, 0.98478260869565, 0.38636363636364
8188, 1, 0.95869565217391, 0.31818181818182
8189, 1, 0.98478260869565, 0.34090909090909
8190, 1, 0.95869565217391, 0.27272727272727
8191, 1, 0.98478260869565, 0.29545454545455
8192, 1, 0.95869565217391, 0.22727272727273
8193, 1, 0.98478260869565, 0.25
8194, 1, 0.95869565217391, 0.18181818181818
8195, 1, 0.98478260869565, 0.20454545454545
8196, 1, 0.95869565217391, 0.13636363636364
8197, 1, 0.98478260869565, 0.15909090909091
8198, 1, 0.95869565217391, 0.090909090909091
8199, 1, 0.98478260869565, 0.11363636363636
8200, 1, 0.95869565217391, 0.045454545454545
8201, 1, 0.98478260869565, 0.068181818181818
8202, 1, 0.98478260869565, 0.022727272727273
8203, 1, 1.0108695652174, 0.45454545454545
8204, 1, 1.0369565217391, 0.47727272727273
8205, 1, 1.0108695652174, 0.40909090909091
8206, 1, 1.0369565217391, 0.43181818181818
8207, 1, 1.0108695652174, 0.36363636363636
8208, 1, 1.0369565217391, 0.38636363636364
8209, 1, 1.0108695652174, 0.31818181818182
8210, 1, 1.0369565217391, 0.34090909090909
8211, 1, 1.0108695652174, 0.27272727272727
8212, 1, 1.0369565217391, 0.29545454545455
8213, 1, 1.0108695652174, 0.22727272727273
8214, 1, 1.0369565217391, 0.25
8215, 1, 1.0108695652174, 0.18181818181818
8216, 1, 1.0369565217391, 0.20454545454545
8217, 1, 1.0108695652174, 0.13636363636364
8218, 1, 1.0369565217391, 0.15909090909091
8219, 1, 1.0108695652174, 0.090909090909091
8220, 1, 1.0369565217391, 0.11363636363636
8221, 1, 1.0108695652174, 0.045454545454545
8222, 1, 1.0369565217391, 0.068181818181818
8223, 1, 1.0369565217391, 0.022727272727273
8224, 1, 1.0630434782609, 0.45454545454545
8225, 1, 1.0891304347826, 0.47727272727273
8226, 1, 1.0630434782609, 0.40909090909091
8227, 1, 1.0891304347826, 0.43181818181818
8228, 1, 1.0630434782609, 0.36363636363636
8229, 1, 1.0891304347826, 0.38636363636364
8230, 1, 1.0630434782609, 0.31818181818182
8231, 1, 1.0891304347826, 0.34090909090909
8232, 1, 1.0630434782609, 0.27272727272727
8233, 1, 1.0891304347826, 0.29545454545455
8234, 1, 1.0630434782609, 0.22727272727273
8235, 1, 1.0891304347826, 0.25
8236, 1, 1.0630434782609, 0.18181818181818
8237, 1, 1.0891304347826, 0.20454545454545
8238, 1, 1.0630434782609, 0.13636363636364
8239, 1, 1.0891304347826, 0.15909090909091
8240, 1, 1.0630434782609, 0.090909090909091
8241, 1, 1.0891304347826, 0.11363636363636
8242, 1, 1.0630434782609, 0.045454545454545
8243, 1, 1.0891304347826, 0.068181818181818
8244, 1, 1.0891304347826, 0.022727272727273
8245, 1, 1.1152173913043, 0.45454545454545
8246, 1, 1.1413043478261, 0.47727272727273
8247, 1, 1.1152173913043, 0.40909090909091
8248, 1, 1.1413043478261, 0.43181818181818
8249, 1, 1.1152173913043, 0.36363636363636
8250, 1, 1.1413043478261, 0.38636363636364
8251, 1, 1.1152173913043, 0.31818181818182
8252, 1, 1.1413043478261, 0.34090909090909
8253, 1, 1.1152173913043, 0.27272727272727
8254, 1, 1.1413043478261, 0.29545454545455
8255, 1, 1.1152173913043, 0.22727272727273
8256, 1, 1.1413043478261, 0.25
8257, 1, 1.1152173913043, 0.18181818181818
8258, 1, 1.1413043478261, 0.20454545454545
8259, 1, 1.1152173913043, 0.13636363636364
8260, 1, 1.1413043478261, 0.15909090909091
8261, 1, 1.1152173913043, 0.090909090909091
8262, 1, 1.1413043478261, 0.11363636363636
8263, 1, 1.1152173913043, 0.045454545454545
8264, 1, 1.1413043478261, 0.068181818181818
8265, 1, 1.1413043478261, 0.022727272727273
8266, 1, 1.1673913043478, 0.45454545454545
8267, 1, 1.1934782608696, 0.47727272727273
8268, 1, 1.1673913043478, 0.40909090909091
8269, 1, 1.1934782608696, 0.43181818181818
8270, 1, 1.1673913043478, 0.36363636363636
8271, 1, 1.1934782608696, 0.38636363636364
8272, 1, 1.1673913043478, 0.31818181818182
8273, 1, 1.1934782608696, 0.34090909090909
8274, 1, 1.1673913043478, 0.27272727272727
8275, 1, 1.1934782608696, 0.29545454545455
8276, 1, 1.1673913043478, 0.22727272727273
8277, 1, 1.1934782608696, 0.25
8278, 1, 1.1673913043478, 0.18181818181818
8279, 1, 1.1934782608696, 0.20454545454545
8280, 1, 1.1673913043478, 0.13636363636364
8281, 1, 1.1934782608696, 0.15909090909091
8282, 1, 1.1673913043478, 0.090909090909091
8283, 1, 1.1934782608696, 0.11363636363636
8284, 1, 1.1673913043478, 0.045454545454545
8285, 1, 1.1934782608696, 0.068181818181818
8286, 1, 1.1934782608696, 0.022727272727273
8287, 1, 1.2195652173913, 0.45454545454545
8288, 1, 1.245652173913, 0.47727272727273
8289, 1, 1.2195652173913, 0.40909090909091
8290, 1, 1.245652173913, 0.43181818181818
8291, 1, 1.2195652173913, 0.36363636363636
8292, 1, 1.245652173913, 0.38636363636364
8293, 1, 1.2195652173913, 0.31818181818182
8294, 1, 1.245652173913, 0.34090909090909
8295, 1, 1.2195652173913, 0.27272727272727
8296, 1, 1.245652173913, 0.29545454545455
8297, 1, 1.2195652173913, 0.22727272727273
8298, 1, 1.245652173913, 0.25
8299, 1, 1.2195652173913, 0.18181818181818
8300, 1, 1.245652173913, 0.20454545454545
8301, 1, 1.2195652173913, 0.13636363636364
8302, 1, 1.245652173913, 0.15909090909091
8303, 1, 1.2195652173913, 0.090909090909091
8304, 1, 1.245652173913, 0.11363636363636
8305, 1, 1.2195652173913, 0.045454545454545
8306, 1, 1.245652173913, 0.068181818181818
8307, 1, 1.245652173913, 0.022727272727273
8308, 1, 1.2717391304348, 0.45454545454545
8309, 1, 1.2978260869565, 0.47727272727273
8310, 1, 1.2717391304348, 0.40909090909091
8311, 1, 1.2978260869565, 0.43181818181818
8312, 1, 1.2717391304348, 0.36363636363636
8313, 1, 1.2978260869565, 0.38636363636364
8314, 1, 1.2717391304348, 0.31818181818182
8315, 1, 1.2978260869565, 0.34090909090909
8316, 1, 1.2717391304348, 0.27272727272727
8317, 1, 1.2978260869565, 0.29545454545455
8318, 1, 1.2717391304348, 0.22727272727273
8319, 1, 1.2978260869565, 0.25
8320, 1, 1.2717391304348, 0.18181818181818
8321, 1, 1.2978260869565, 0.20454545454545
8322, 1, 1.2717391304348, 0.13636363636364
8323, 1, 1.2978260869565, 0.15909090909091
8324, 1, 1.2717391304348, 0.090909090909091
8325, 1, 1.2978260869565, 0.11363636363636
8326, 1, 1.2717391304348, 0.045454545454545
8327, 1, 1.2978260869565, 0.068181818181818
8328, 1, 1.2978260869565, 0.022727272727273
8329, 1, 1.3239130434783, 0.45454545454545
8330, 1, 1.3239130434783, 0.40909090909091
8331, 1, 1.3239130434783, 0.36363636363636
8332, 1, 1.3239130434783, 0.31818181818182
8333, 1, 1.3239130434783, 0.27272727272727
8334, 1, 1.3239130434783, 0.22727272727273
8335, 1, 1.3239130434783, 0.18181818181818
8336, 1, 1.3239130434783, 0.13636363636364
8337, 1, 1.3239130434783, 0.090909090909091
8338, 1, 1.3239130434783, 0.045454545454545
8339, 0.95652173913043, 0.20217391304348, 0.5
8340, 0.91304347826087, 0.20217391304348, 0.5
8341, 0.8695652173913, 0.20217391304348, 0.5
8342, 0.82608695652174, 0.20217391304348, 0.5
8343, 0.78260869565217, 0.20217391304348, 0.5
8344, 0.73913043478261, 0.20217391304348, 0.5
8345, 0.69565217391304, 0.20217391304348, 0.5
8346, 0.65217391304348, 0.20217391304348, 0.5
8347, 0.60869565217391, 0.20217391304348, 0.5
8348, 0.56521739130435, 0.20217391304348, 0.5
8349, 0.52173913043478, 0.20217391304348, 0.5
8350, 0.47826086956522, 0.20217391304348, 0.5
8351, 0.43478260869565, 0.20217391304348, 0.5
8352, 0.39130434782609, 0.20217391304348, 0.5
8353, 0.34782608695652, 0.20217391304348, 0.5
8354, 0.30434782608696, 0.20217391304348, 0.5
8355, 0.26086956521739, 0.20217391304348, 0.5
8356, 0.21739130434783, 0.20217391304348, 0.5
8357, 0.17391304347826, 0.20217391304348, 0.5
8358, 0.1304347826087, 0.20217391304348, 0.5
8359, 0.08695652173913, 0.20217391304348, 0.5
8360, 0.043478260869565, 0.20217391304348, 0.5
8361, 0.95652173913043, 0.25434782608696, 0.5
8362, 0.91304347826087, 0.25434782608696, 0.5
8363, 0.8695652173913, 0.25434782608696, 0.5
8364, 0.82608695652174, 0.25434782608696, 0.5
8365, 0.78260869565217, 0.25434782608696, 0.5
8366, 0.73913043478261, 0.25434782608696, 0.5
8367, 0.69565217391304, 0.25434782608696, 0.5
8368, 0.65217391304348, 0.25434782608696, 0.5
8369, 0.60869565217391, 0.25434782608696, 0.5
8370, 0.56521739130435, 0.25434782608696, 0.5
8371, 0.52173913043478, 0.25434782608696, 0.5
8372, 0.47826086956522, 0.25434782608696, 0.5
8373, 0.43478260869565, 0.25434782608696, 0.5
8374, 0.39130434782609, 0.25434782608696, 0.5
8375, 0.34782608695652, 0.25434782608696, 0.5
8376, 0.30434782608696, 0.25434782608696, 0.5
8377, 0.26086956521739, 0.25434782608696, 0.5
8378, 0.21739130434783, 0.25434782608696, 0.5
8379, 0.17391304347826, 0.25434782608696, 0.5
8380, 0.1304347826087, 0.25434782608696, 0.5
8381, 0.08695652173913, 0.25434782608696, 0.5
8382, 0.043478260869565, 0.25434782608696, 0.5
8383, 0.95652173913043, 0.30652173913043, 0.5
8384, 0.91304347826087, 0.30652173913043, 0.5
8385, 0.8695652173913, 0.30652173913043, 0.5
8386, 0.82608695652174, 0.30652173913043, 0.5
8387, 0.78260869565217, 0.30652173913043, 0.5
8388, 0.73913043478261, 0.30652173913043, 0.5
8389, 0.69565217391304, 0.30652173913043, 0.5
8390, 0.65217391304348, 0.30652173913043, 0.5
8391, 0.60869565217391, 0.30652173913043, 0.5
8392, 0.56521739130435, 0.30652173913043, 0.5
8393, 0.52173913043478, 0.30652173913043, 0.5
8394, 0.47826086956522, 0.30652173913043, 0.5
8395, 0.43478260869565, 0.30652173913043, 0.5
8396, 0.39130434782609, 0.30652173913043, 0.5
8397, 0.34782608695652, 0.30652173913043, 0.5
8398, 0.30434782608696, 0.30652173913043, 0.5
8399, 0.26086956521739, 0.30652173913043, 0.5
8400, 0.21739130434783, 0.30652173913043, 0.5
8401, 0.17391304347826, 0.30652173913043, 0.5
8402, 0.1304347826087, 0.30652173913043, 0.5
8403, 0.08695652173913, 0.30652173913043, 0.5
8404, 0.043478260869565, 0.30652173913043, 0.5
8405, 0.95652173913043, 0.35869565217391, 0.5
8406, 0.91304347826087, 0.35869565217391, 0.5
8407, 0.8695652173913, 0.35869565217391, 0.5
8408, 0.82608695652174, 0.35869565217391, 0.5
8409, 0.78260869565217, 0.35869565217391, 0.5
8410, 0.73913043478261, 0.35869565217391, 0.5
8411, 0.69565217391304, 0.35869565217391, 0.5
8412, 0.65217391304348, 0.35869565217391, 0.5
8413, 0.60869565217391, 0.35869565217391, 0.5
8414, 0.56521739130435, 0.35869565217391, 0.5
8415, 0.52173913043478, 0.35869565217391, 0.5
8416, 0.47826086956522, 0.35869565217391, 0.5
8417, 0.43478260869565, 0.35869565217391, 0.5
8418, 0.39130434782609, 0.35869565217391, 0.5
8419, 0.34782608695652, 0.35869565217391, 0.5
8420, 0.30434782608696, 0.35869565217391, 0.5
8421, 0.26086956521739, 0.35869565217391, 0.5
8422, 0.21739130434783, 0.35869565217391, 0.5
8423, 0.17391304347826, 0.35869565217391, 0.5
8424, 0.1304347826087, 0.35869565217391, 0.5
8425, 0.08695652173913, 0.35869565217391, 0.5
8426, 0.043478260869565, 0.35869565217391, 0.5
8427, 0.95652173913043, 0.41086956521739, 0.5
8428, 0.91304347826087, 0.41086956521739, 0.5
8429, 0.8695652173913, 0.41086956521739, 0.5
8430, 0.82608695652174, 0.41086956521739, 0.5
8431, 0.78260869565217, 0.41086956521739, 0.5
8432, 0.73913043478261, 0.41086956521739, 0.5
8433, 0.69565217391304, 0.41086956521739, 0.5
8434, 0.65217391304348, 0.41086956521739, 0.5
8435, 0.60869565217391, 0.41086956521739, 0.5
8436, 0.56521739130435, 0.41086956521739, 0.5
8437, 0.52173913043478, 0.41086956521739, 0.5
8438, 0.47826086956522, 0.41086956521739, 0.5
8439, 0.43478260869565, 0.41086956521739, 0.5
8440, 0.39130434782609, 0.41086956521739, 0.5
8441, 0.34782608695652, 0.41086956521739, 0.5
8442, 0.30434782608696, 0.41086956521739, 0.5
8443, 0.26086956521739, 0.41086956521739, 0.5
8444, 0.21739130434783, 0.41086956521739, 0.5
8445, 0.17391304347826, 0.41086956521739, 0.5
8446, 0.1304347826087, 0.41086956521739, 0.5
8447, 0.08695652173913, 0.41086956521739, 0.5
8448, 0.043478260869565, 0.41086956521739, 0.5
8449, 0.95652173913043, 0.46304347826087, 0.5
8450, 0.91304347826087, 0.46304347826087, 0.5
8451, 0.8695652173913, 0.46304347826087, 0.5
8452, 0.82608695652174, 0.46304347826087, 0.5
8453, 0.78260869565217, 0.46304347826087, 0.5
8454, 0.73913043478261, 0.46304347826087, 0.5
8455, 0.69565217391304, 0.46304347826087, 0.5
8456, 0.65217391304348, 0.46304347826087, 0.5
8457, 0.60869565217391, 0.46304347826087, 0.5
8458, 0.56521739130435, 0.46304347826087, 0.5
8459, 0.52173913043478, 0.46304347826087, 0.5
8460, 0.47826086956522, 0.46304347826087, 0.5
8461, 0.43478260869565, 0.46304347826087, 0.5
8462, 0.39130434782609, 0.46304347826087, 0.5
8463, 0.34782608695652, 0.46304347826087, 0.5
8464, 0.30434782608696, 0.46304347826087, 0.5
8465, 0.26086956521739, 0.46304347826087, 0.5
8466, 0.21739130434783, 0.46304347826087, 0.5
8467, 0.17391304347826, 0.46304347826087, 0.5
8468, 0.1304347826087, 0.46304347826087, 0.5
8469, 0.08695652173913, 0.46304347826087, 0.5
8470, 0.043478260869565, 0.46304347826087, 0.5
8471, 0.95652173913043, 0.51521739130435, 0.5
8472, 0.91304347826087, 0.51521739130435, 0.5
8473, 0.8695652173913, 0.51521739130435, 0.5
8474, 0.82608695652174, 0.51521739130435, 0.5
8475, 0.78260869565217, 0.51521739130435, 0.5
8476, 0.73913043478261, 0.51521739130435, 0.5
8477, 0.69565217391304, 0.51521739130435, 0.5
8478, 0.65217391304348, 0.51521739130435, 0.5
8479, 0.60869565217391, 0.51521739130435, 0.5
8480, 0.56521739130435, 0.51521739130435, 0.5
8481, 0.52173913043478, 0.51521739130435, 0.5
8482, 0.47826086956522, 0.51521739130435, 0.5
8483, 0.43478260869565, 0.51521739130435, 0.5
8484, 0.39130434782609, 0.51521739130435, 0.5
8485, 0.34782608695652, 0.51521739130435, 0.5
8486, 0.30434782608696, 0.51521739130435, 0.5
8487, 0.26086956521739, 0.51521739130435, 0.5
8488, 0.21739130434783, 0.51521739130435, 0.5
8489, 0.17391304347826, 0.51521739130435, 0.5
8490, 0.1304347826087, 0.51521739130435, 0.5
8491, 0.08695652173913, 0.51521739130435, 0.5
8492, 0.043478260869565, 0.51521739130435, 0.5
8493, 0.95652173913043, 0.56739130434783, 0.5
8494, 0.91304347826087, 0.56739130434783, 0.5
8495, 0.8695652173913, 0.56739130434783, 0.5
8496, 0.82608695652174, 0.56739130434783, 0.5
8497, 0.78260869565217, 0.56739130434783, 0.5
8498, 0.73913043478261, 0.56739130434783, 0.5
8499, 0.69565217391304, 0.56739130434783, 0.5
8500, 0.65217391304348, 0.56739130434783, 0.5
8501, 0.60869565217391, 0.56739130434783, 0.5
8502, 0.56521739130435, 0.56739130434783, 0.5
8503, 0.52173913043478, 0.56739130434783, 0.5
8504, 0.47826086956522, 0.56739130434783, 0.5
8505, 0.43478260869565, 0.56739130434783, 0.5
8506, 0.39130434782609, 0.56739130434783, 0.5
8507, 0.34782608695652, 0.56739130434783, 0.5
8508, 0.30434782608696, 0.56739130434783, 0.5
8509, 0.26086956521739, 0.56739130434783, 0.5
8510, 0.21739130434783, 0.56739130434783, 0.5
8511, 0.17391304347826, 0.56739130434783, 0.5
8512, 0.1304347826087, 0.56739130434783, 0.5
8513, 0.08695652173913, 0.56739130434783, 0.5
8514, 0.043478260869565, 0.56739130434783, 0.5
8515, 0.95652173913043, 0.6195652173913, 0.5
8516, 0.91304347826087, 0.6195652173913, 0.5
8517, 0.8695652173913, 0.6195652173913, 0.5
8518, 0.82608695652174, 0.6195652173913, 0.5
8519, 0.78260869565217, 0.6195652173913, 0.5
8520, 0.73913043478261, 0.6195652173913, 0.5
8521, 0.69565217391304, 0.6195652173913, 0.5
8522, 0.65217391304348, 0.6195652173913, 0.5
8523, 0.60869565217391, 0.6195652173913, 0.5
8524, 0.56521739130435, 0.6195652173913, 0.5
8525, 0.52173913043478, 0.6195652173913, 0.5
8526, 0.47826086956522, 0.6195652173913, 0.5
8527, 0.43478260869565, 0.6195652173913, 0.5
8528, 0.39130434782609, 0.6195652173913, 0.5
8529, 0.34782608695652, 0.6195652173913, 0.5
8530, 0.30434782608696, 0.6195652173913, 0.5
8531, 0.26086956521739, 0.6195652173913, 0.5
8532, 0.21739130434783, 0.6195652173913, 0.5
8533, 0.17391304347826, 0.6195652173913, 0.5
8534, 0.1304347826087, 0.6195652173913, 0.5
8535, 0.08695652173913, 0.6195652173913, 0.5
8536, 0.043478260869565, 0.6195652173913, 0.5
8537, 0.95652173913043, 0.67173913043478, 0.5
8538, 0.91304347826087, 0.67173913043478, 0.5
8539, 0.8695652173913, 0.67173913043478, 0.5
8540, 0.82608695652174, 0.67173913043478, 0.5
8541, 0.78260869565217, 0.67173913043478, 0.5
8542, 0.73913043478261, 0.67173913043478, 0.5
8543, 0.69565217391304, 0.67173913043478, 0.5
8544, 0.65217391304348, 0.67173913043478, 0.5
8545, 0.60869565217391, 0.67173913043478, 0.5
8546, 0.56521739130435, 0.67173913043478, 0.5
8547, 0.52173913043478, 0.67173913043478, 0.5
8548, 0.47826086956522, 0.67173913043478, 0.5
8549, 0.43478260869565, 0.67173913043478, 0.5
8550, 0.39130434782609, 0.67173913043478, 0.5
8551, 0.34782608695652, 0.67173913043478, 0.5
8552, 0.30434782608696, 0.67173913043478, 0.5
8553, 0.26086956521739, 0.67173913043478, 0.5
8554, 0.21739130434783, 0.67173913043478, 0.5
8555, 0.17391304347826, 0.67173913043478, 0.5
8556, 0.1304347826087, 0.67173913043478, 0.5
8557, 0.08695652173913, 0.67173913043478, 0.5
8558, 0.043478260869565, 0.67173913043478, 0.5
8559, 0.95652173913043, 0.72391304347826, 0.5
8560, 0.91304347826087, 0.72391304347826, 0.5
8561, 0.8695652173913, 0.72391304347826, 0.5
8562, 0.82608695652174, 0.72391304347826, 0.5
8563, 0.78260869565217, 0.72391304347826, 0.5
8564, 0.73913043478261, 0.72391304347826, 0.5
8565, 0.69565217391304, 0.72391304347826, 0.5
8566, 0.65217391304348, 0.72391304347826, 0.5
8567, 0.60869565217391, 0.72391304347826, 0.5
8568, 0.56521739130435, 0.72391304347826, 0.5
8569, 0.52173913043478, 0.72391304347826, 0.5
8570, 0.47826086956522, 0.72391304347826, 0.5
8571, 0.43478260869565, 0.72391304347826, 0.5
8572, 0.39130434782609, 0.72391304347826, 0.5
8573, 0.34782608695652, 0.72391304347826, 0.5
8574, 0.30434782608696, 0.72391304347826, 0.5
8575, 0.26086956521739, 0.72391304347826, 0.5
8576, 0.21739130434783, 0.72391304347826, 0.5
8577, 0.17391304347826, 0.72391304347826, 0.5
8578, 0.1304347826087, 0.72391304347826, 0.5
8579, 0.08695652173913, 0.72391304347826, 0.5
8580, 0.043478260869565, 0.72391304347826, 0.5
8581, 0.95652173913043, 0.77608695652174, 0.5
8582, 0.91304347826087, 0.77608695652174, 0.5
8583, 0.8695652173913, 0.77608695652174, 0.5
8584, 0.82608695652174, 0.77608695652174, 0.5
8585, 0.78260869565217, 0.77608695652174, 0.5
8586, 0.73913043478261, 0.77608695652174, 0.5
8587, 0.69565217391304, 0.77608695652174, 0.5
8588, 0.65217391304348, 0.77608695652174, 0.5
8589, 0.60869565217391, 0.77608695652174, 0.5
8590, 0.56521739130435, 0.77608695652174, 0.5
8591, 0.52173913043478, 0.77608695652174, 0.5
8592, 0.47826086956522, 0.77608695652174, 0.5
8593, 0.43478260869565, 0.77608695652174, 0.5
8594, 0.39130434782609, 0.77608695652174, 0.5
8595, 0.34782608695652, 0.77608695652174, 0.5
8596, 0.30434782608696, 0.77608695652174, 0.5
8597, 0.26086956521739, 0.77608695652174, 0.5
8598, 0.21739130434783, 0.77608695652174, 0.5
8599, 0.17391304347826, 0.77608695652174, 0.5
8600, 0.1304347826087, 0.77608695652174, 0.5
8601, 0.08695652173913, 0.77608695652174, 0.5
8602, 0.043478260869565, 0.77608695652174, 0.5
8603, 0.95652173913043, 0.82826086956522, 0.5
8604, 0.91304347826087, 0.82826086956522, 0.5
8605, 0.8695652173913, 0.82826086956522, 0.5
8606, 0.82608695652174, 0.82826086956522, 0.5
8607, 0.78260869565217, 0.82826086956522, 0.5
8608, 0.73913043478261, 0.82826086956522, 0.5
8609, 0.69565217391304, 0.82826086956522, 0.5
8610, 0.65217391304348, 0.82826086956522, 0.5
8611, 0.60869565217391, 0.82826086956522, 0.5
8612, 0.56521739130435, 0.82826086956522, 0.5
8613, 0.52173913043478, 0.82826086956522, 0.5
8614, 0.47826086956522, 0.82826086956522, 0.5
8615, 0.43478260869565, 0.82826086956522, 0.5
8616, 0.39130434782609, 0.82826086956522, 0.5
8617, 0.34782608695652, 0.82826086956522, 0.5
8618, 0.30434782608696, 0.82826086956522, 0.5
8619, 0.26086956521739, 0.82826086956522, 0.5
8620, 0.21739130434783, 0.82826086956522, 0.5
8621, 0.17391304347826, 0.82826086956522, 0.5
8622, 0.1304347826087, 0.82826086956522, 0.5
8623, 0.08695652173913, 0.82826086956522, 0.5
8624, 0.043478260869565, 0.82826086956522, 0.5
8625, 0.95652173913043, 0.8804347826087, 0.5
8626, 0.91304347826087, 0.8804347826087, 0.5
8627, 0.8695652173913, 0.88043478260869, 0.5
8628, 0.82608695652174, 0.8804347826087, 0.5
8629, 0.78260869565217, 0.8804347826087, 0.5
8630, 0.73913043478261, 0.8804347826087, 0.5
8631, 0.69565217391304, 0.8804347826087, 0.5
8632, 0.65217391304348, 0.8804347826087, 0.5
8633, 0.60869565217391, 0.8804347826087, 0.5
8634, 0.56521739130435, 0.8804347826087, 0.5
8635, 0.52173913043478, 0.88043478260869, 0.5
8636, 0.47826086956522, 0.8804347826087, 0.5
8637, 0.43478260869565, 0.8804347826087, 0.5
8638, 0.39130434782609, 0.88043478260869, 0.5
8639, 0.34782608695652, 0.8804347826087, 0.5
8640, 0.30434782608696, 0.8804347826087, 0.5
8641, 0.26086956521739, 0.8804347826087, 0.5
8642, 0.21739130434783, 0.8804347826087, 0.5
8643, 0.17391304347826, 0.8804347826087, 0.5
8644, 0.1304347826087, 0.8804347826087, 0.5
8645, 0.08695652173913, 0.8804347826087, 0.5
8646, 0.043478260869565, 0.8804347826087, 0.5
8647, 0.95652173913043, 0.93260869565217, 0.5
8648, 0.91304347826087, 0.93260869565217, 0.5
8649, 0.8695652173913, 0.93260869565217, 0.5
8650, 0.82608695652174, 0.93260869565217, 0.5
8651, 0.78260869565217, 0.93260869565217, 0.5
8652, 0.73913043478261, 0.93260869565217, 0.5
8653, 0.69565217391304, 0.93260869565217, 0.5
8654, 0.65217391304348, 0.93260869565217, 0.5
8655, 0.60869565217391, 0.93260869565217, 0.5
8656, 0.56521739130435, 0.93260869565217, 0.5
8657, 0.52173913043478, 0.93260869565217, 0.5
8658, 0.47826086956522, 0.93260869565217, 0.5
8659, 0.43478260869565, 0.93260869565217, 0.5
8660, 0.39130434782609, 0.93260869565217, 0.5
8661, 0.34782608695652, 0.93260869565217, 0.5
8662, 0.30434782608696, 0.93260869565217, 0.5
8663, 0.26086956521739, 0.93260869565217, 0.5
8664, 0.21739130434783, 0.93260869565217, 0.5
8665, 0.17391304347826, 0.93260869565217, 0.5
8666, 0.1304347826087, 0.93260869565217, 0.5
8667, 0.08695652173913, 0.93260869565217, 0.5
8668, 0.043478260869565, 0.93260869565217, 0.5
8669, 0.95652173913043, 0.98478260869565, 0.5
8670, 0.91304347826087, 0.98478260869565, 0.5
8671, 0.8695652173913, 0.98478260869565, 0.5
8672, 0.82608695652174, 0.98478260869565, 0.5
8673, 0.78260869565217, 0.98478260869565, 0.5
8674, 0.73913043478261, 0.98478260869565, 0.5
8675, 0.69565217391304, 0.98478260869565, 0.5
8676, 0.65217391304348, 0.98478260869565, 0.5
8677, 0.60869565217391, 0.98478260869565, 0.5
8678, 0.56521739130435, 0.98478260869565, 0.5
8679, 0.52173913043478, 0.98478260869565, 0.5
8680, 0.47826086956522, 0.98478260869565, 0.5
8681, 0.43478260869565, 0.98478260869565, 0.5
8682, 0.39130434782609, 0.98478260869565, 0.5
8683, 0.34782608695652, 0.98478260869565, 0.5
8684, 0.30434782608696, 0.98478260869565, 0.5
8685, 0.26086956521739, 0.98478260869565, 0.5
8686, 0.21739130434783, 0.98478260869565, 0.5
8687, 0.17391304347826, 0.98478260869565, 0.5
8688, 0.1304347826087, 0.98478260869565, 0.5
8689, 0.08695652173913, 0.98478260869565, 0.5
8690, 0.043478260869565, 0.98478260869565, 0.5
8691, 0.95652173913043, 1.0369565217391, 0.5
8692, 0.91304347826087, 1.0369565217391, 0.5
8693, 0.8695652173913, 1.0369565217391, 0.5
8694, 0.82608695652174, 1.0369565217391, 0.5
8695, 0.78260869565217, 1.0369565217391, 0.5
8696, 0.73913043478261, 1.0369565217391, 0.5
8697, 0.69565217391304, 1.0369565217391, 0.5
8698, 0.65217391304348, 1.0369565217391, 0.5
8699, 0.60869565217391, 1.0369565217391, 0.5
8700, 0.56521739130435, 1.0369565217391, 0.5
8701, 0.52173913043478, 1.0369565217391, 0.5
8702, 0.47826086956522, 1.0369565217391, 0.5
8703, 0.43478260869565, 1.0369565217391, 0.5
8704, 0.39130434782609, 1.0369565217391, 0.5
8705, 0.34782608695652, 1.0369565217391, 0.5
8706, 0.30434782608696, 1.0369565217391, 0.5
8707, 0.26086956521739, 1.0369565217391, 0.5
8708, 0.21739130434783, 1.0369565217391, 0.5
8709, 0.17391304347826, 1.0369565217391, 0.5
8710, 0.1304347826087, 1.0369565217391, 0.5
8711, 0.08695652173913, 1.0369565217391, 0.5
8712, 0.043478260869565, 1.0369565217391, 0.5
8713, 0.95652173913043, 1.0891304347826, 0.5
8714, 0.91304347826087, 1.0891304347826, 0.5
8715, 0.8695652173913, 1.0891304347826, 0.5
8716, 0.82608695652174, 1.0891304347826, 0.5
8717, 0.78260869565217, 1.0891304347826, 0.5
8718, 0.73913043478261, 1.0891304347826, 0.5
8719, 0.69565217391304, 1.0891304347826, 0.5
8720, 0.65217391304348, 1.0891304347826, 0.5
8721, 0.60869565217391, 1.0891304347826, 0.5
8722, 0.56521739130435, 1.0891304347826, 0.5
8723, 0.52173913043478, 1.0891304347826, 0.5
8724, 0.47826086956522, 1.0891304347826, 0.5
8725, 0.43478260869565, 1.0891304347826, 0.5
8726, 0.39130434782609, 1.0891304347826, 0.5
8727, 0.34782608695652, 1.0891304347826, 0.5
8728, 0.30434782608696, 1.0891304347826, 0.5
8729, 0.26086956521739, 1.0891304347826, 0.5
8730, 0.21739130434783, 1.0891304347826, 0.5
8731, 0.17391304347826, 1.0891304347826, 0.5
8732, 0.1304347826087, 1.0891304347826, 0.5
8733, 0.08695652173913, 1.0891304347826, 0.5
8734, 0.043478260869565, 1.0891304347826, 0.5
8735, 0.95652173913043, 1.1413043478261, 0.5
8736, 0.91304347826087, 1.1413043478261, 0.5
8737, 0.8695652173913, 1.1413043478261, 0.5
8738, 0.82608695652174, 1.1413043478261, 0.5
8739, 0.78260869565217, 1.1413043478261, 0.5
8740, 0.73913043478261, 1.1413043478261, 0.5
8741, 0.69565217391304, 1.1413043478261, 0.5
8742, 0.65217391304348, 1.1413043478261, 0.5
8743, 0.60869565217391, 1.1413043478261, 0.5
8744, 0.56521739130435, 1.1413043478261, 0.5
8745, 0.52173913043478, 1.1413043478261, 0.5
8746, 0.47826086956522, 1.1413043478261, 0.5
8747, 0.43478260869565, 1.1413043478261, 0.5
8748, 0.39130434782609, 1.1413043478261, 0.5
8749, 0.34782608695652, 1.1413043478261, 0.5
8750, 0.30434782608696, 1.1413043478261, 0.5
8751, 0.26086956521739, 1.1413043478261, 0.5
8752, 0.21739130434783, 1.1413043478261, 0.5
8753, 0.17391304347826, 1.1413043478261, 0.5
8754, 0.1304347826087, 1.1413043478261, 0.5
8755, 0.08695652173913, 1.1413043478261, 0.5
8756, 0.043478260869565, 1.1413043478261, 0.5
8757, 0.95652173913043, 1.1934782608696, 0.5
8758, 0.91304347826087, 1.1934782608696, 0.5
8759, 0.8695652173913, 1.1934782608696, 0.5
8760, 0.82608695652174, 1.1934782608696, 0.5
8761, 0.78260869565217, 1.1934782608696, 0.5
8762, 0.73913043478261, 1.1934782608696, 0.5
8763, 0.69565217391304, 1.1934782608696, 0.5
8764, 0.65217391304348, 1.1934782608696, 0.5
8765, 0.60869565217391, 1.1934782608696, 0.5
8766, 0.56521739130435, 1.1934782608696, 0.5
8767, 0.52173913043478, 1.1934782608696, 0.5
8768, 0.47826086956522, 1.1934782608696, 0.5
8769, 0.43478260869565, 1.1934782608696, 0.5
8770, 0.39130434782609, 1.1934782608696, 0.5
8771, 0.34782608695652, 1.1934782608696, 0.5
8772, 0.30434782608696, 1.1934782608696, 0.5
8773, 0.26086956521739, 1.1934782608696, 0.5
8774, 0.21739130434783, 1.1934782608696, 0.5
8775, 0.17391304347826, 1.1934782608696, 0.5
8776, 0.1304347826087, 1.1934782608696, 0.5
8777, 0.08695652173913, 1.1934782608696, 0.5
8778, 0.043478260869565, 1.1934782608696, 0.5
8779, 0.95652173913043, 1.245652173913, 0.5
8780, 0.91304347826087, 1.245652173913, 0.5
8781, 0.8695652173913, 1.245652173913, 0.5
8782, 0.82608695652174, 1.245652173913, 0.5
8783, 0.78260869565217, 1.245652173913, 0.5
8784, 0.73913043478261, 1.245652173913, 0.5
8785, 0.69565217391304, 1.245652173913, 0.5
8786, 0.65217391304348, 1.245652173913, 0.5
8787, 0.60869565217391, 1.245652173913, 0.5
8788, 0.56521739130435, 1.245652173913, 0.5
8789, 0.52173913043478, 1.245652173913, 0.5
8790, 0.47826086956522, 1.245652173913, 0.5
8791, 0.43478260869565, 1.245652173913, 0.5
8792, 0.39130434782609, 1.245652173913, 0.5
8793, 0.34782608695652, 1.245652173913, 0.5
8794, 0.30434782608696, 1.245652173913, 0.5
8795, 0.26086956521739, 1.245652173913, 0.5
8796, 0.21739130434783, 1.245652173913, 0.5
8797, 0.17391304347826, 1.245652173913, 0.5
8798, 0.1304347826087, 1.245652173913, 0.5
8799, 0.08695652173913, 1.245652173913, 0.5
8800, 0.043478260869565, 1.245652173913, 0.5
8801, 0.95652173913043, 1.2978260869565, 0.5
8802, 0.91304347826087, 1.2978260869565, 0.5
8803, 0.8695652173913, 1.2978260869565, 0.5
8804, 0.82608695652174, 1.2978260869565, 0.5
8805, 0.78260869565217, 1.2978260869565, 0.5
8806, 0.73913043478261, 1.2978260869565, 0.5
8807, 0.69565217391304, 1.2978260869565, 0.5
8808, 0.65217391304348, 1.2978260869565, 0.5
8809, 0.60869565217391, 1.2978260869565, 0.5
8810, 0.56521739130435, 1.2978260869565, 0.5
8811, 0.52173913043478, 1.2978260869565, 0.5
8812, 0.47826086956522, 1.2978260869565, 0.5
8813, 0.43478260869565, 1.2978260869565, 0.5
8814, 0.39130434782609, 1.2978260869565, 0.5
8815, 0.34782608695652, 1.2978260869565, 0.5
8816, 0.30434782608696, 1.2978260869565, 0.5
8817, 0.26086956521739, 1.2978260869565, 0.5
8818, 0.21739130434783, 1.2978260869565, 0.5
8819, 0.17391304347826, 1.2978260869565, 0.5
8820, 0.1304347826087, 1.2978260869565, 0.5
8821, 0.08695652173913, 1.2978260869565, 0.5
8822, 0.043478260869565, 1.2978260869565, 0.5
8823, 0.97826086956522, 0.20217391304348, 0.5
8824, 0.95652173913043, 0.17608695652174, 0.5
8825, 0.93478260869565, 0.20217391304348, 0.5
8826, 0.91304347826087, 0.17608695652174, 0.5
8827, 0.89130434782609, 0.20217391304348, 0.5
8828, 0.8695652173913, 0.17608695652174, 0.5
8829, 0.84782608695652, 0.20217391304348, 0.5
8830, 0.82608695652174, 0.17608695652174, 0.5
8831, 0.80434782608696, 0.20217391304348, 0.5
8832, 0.78260869565217, 0.17608695652174, 0.5
8833, 0.76086956521739, 0.20217391304348, 0.5
8834, 0.73913043478261, 0.17608695652174, 0.5
8835, 0.71739130434783, 0.20217391304348, 0.5
8836, 0.69565217391304, 0.17608695652174, 0.5
8837, 0.67391304347826, 0.20217391304348, 0.5
8838, 0.65217391304348, 0.17608695652174, 0.5
8839, 0.6304347826087, 0.20217391304348, 0.5
8840, 0.60869565217391, 0.17608695652174, 0.5
8841, 0.58695652173913, 0.20217391304348, 0.5
8842, 0.56521739130435, 0.17608695652174, 0.5
8843, 0.54347826086957, 0.20217391304348, 0.5
8844, 0.52173913043478, 0.17608695652174, 0.5
8845, 0.5, 0.20217391304348, 0.5
8846, 0.47826086956522, 0.17608695652174, 0.5
8847, 0.45652173913043, 0.20217391304348, 0.5
8848, 0.43478260869565, 0.17608695652174, 0.5
8849, 0.41304347826087, 0.20217391304348, 0.5
8850, 0.39130434782609, 0.17608695652174, 0.5
8851, 0.3695652173913, 0.20217391304348, 0.5
8852, 0.34782608695652, 0.17608695652174, 0.5
8853, 0.32608695652174, 0.20217391304348, 0.5
8854, 0.30434782608696, 0.17608695652174, 0.5
8855, 0.28260869565217, 0.20217391304348, 0.5
8856, 0.26086956521739, 0.17608695652174, 0.5
8857, 0.23913043478261, 0.20217391304348, 0.5
8858, 0.21739130434783, 0.17608695652174, 0.5
8859, 0.19565217391304, 0.20217391304348, 0.5
8860, 0.17391304347826, 0.17608695652174, 0.5
8861, 0.15217391304348, 0.20217391304348, 0.5
8862, 0.1304347826087, 0.17608695652174, 0.5
8863, 0.10869565217391, 0.20217391304348, 0.5
8864, 0.08695652173913, 0.17608695652174, 0.5
8865, 0.065217391304348, 0.20217391304348, 0.5
8866, 0.043478260869565, 0.17608695652174, 0.5
8867, 0.021739130434783, 0.20217391304348, 0.5
8868, 0.97826086956522, 0.25434782608696, 0.5
8869, 0.95652173913043, 0.22826086956522, 0.5
8870, 0.93478260869565, 0.25434782608696, 0.5
8871, 0.91304347826087, 0.22826086956522, 0.5
8872, 0.89130434782609, 0.25434782608696, 0.5
8873, 0.8695652173913, 0.22826086956522, 0.5
8874, 0.84782608695652, 0.25434782608696, 0.5
8875, 0.82608695652174, 0.22826086956522, 0.5
8876, 0.80434782608696, 0.25434782608696, 0.5
8877, 0.78260869565217, 0.22826086956522, 0.5
8878, 0.76086956521739, 0.25434782608696, 0.5
8879, 0.73913043478261, 0.22826086956522, 0.5
8880, 0.71739130434783, 0.25434782608696, 0.5
8881, 0.69565217391304, 0.22826086956522, 0.5
8882, 0.67391304347826, 0.25434782608696, 0.5
8883, 0.65217391304348, 0.22826086956522, 0.5
8884, 0.6304347826087, 0.25434782608696, 0.5
8885, 0.60869565217391, 0.22826086956522, 0.5
8886, 0.58695652173913, 0.25434782608696, 0.5
8887, 0.56521739130435, 0.22826086956522, 0.5
8888, 0.54347826086957, 0.25434782608696, 0.5
8889, 0.52173913043478, 0.22826086956522, 0.5
8890, 0.5, 0.25434782608696, 0.5
8891, 0.47826086956522, 0.22826086956522, 0.5
8892, 0.45652173913043, 0.25434782608696, 0.5
8893, 0.43478260869565, 0.22826086956522, 0.5
8894, 0.41304347826087, 0.25434782608696, 0.5
8895, 0.39130434782609, 0.22826086956522, 0.5
8896, 0.3695652173913, 0.25434782608696, 0.5
8897, 0.34782608695652, 0.22826086956522, 0.5
8898, 0.32608695652174, 0.25434782608696, 0.5
8899, 0.30434782608696, 0.22826086956522, 0.5
8900, 0.28260869565217, 0.25434782608696, 0.5
8901, 0.26086956521739, 0.22826086956522, 0.5
8902, 0.23913043478261, 0.25434782608696, 0.5
8903, 0.21739130434783, 0.22826086956522, 0.5
8904, 0.19565217391304, 0.25434782608696, 0.5
8905, 0.17391304347826, 0.22826086956522, 0.5
8906, 0.15217391304348, 0.25434782608696, 0.5
8907, 0.1304347826087, 0.22826086956522, 0.5
8908, 0.10869565217391, 0.25434782608696, 0.5
8909, 0.08695652173913, 0.22826086956522, 0.5
8910, 0.065217391304348, 0.25434782608696, 0.5
8911, 0.043478260869565, 0.22826086956522, 0.5
8912, 0.021739130434783, 0.25434782608696, 0.5
8913, 0.97826086956522, 0.30652173913043, 0.5
8914, 0.95652173913043, 0.2804347826087, 0.5
8915, 0.93478260869565, 0.30652173913043, 0.5
8916, 0.91304347826087, 0.2804347826087, 0.5
8917, 0.89130434782609, 0.30652173913043, 0.5
8918, 0.8695652173913, 0.2804347826087, 0.5
8919, 0.84782608695652, 0.30652173913043, 0.5
8920, 0.82608695652174, 0.2804347826087, 0.5
8921, 0.80434782608696, 0.30652173913043, 0.5
8922, 0.78260869565217, 0.2804347826087, 0.5
8923, 0.76086956521739, 0.30652173913043, 0.5
8924, 0.73913043478261, 0.2804347826087, 0.5
8925, 0.71739130434783, 0.30652173913043, 0.5
8926, 0.69565217391304, 0.2804347826087, 0.5
8927, 0.67391304347826, 0.30652173913043, 0.5
8928, 0.65217391304348, 0.2804347826087, 0.5
8929, 0.6304347826087, 0.30652173913043, 0.5
8930, 0.60869565217391, 0.2804347826087, 0.5
8931, 0.58695652173913, 0.30652173913043, 0.5
8932, 0.56521739130435, 0.2804347826087, 0.5
8933, 0.54347826086957, 0.30652173913043, 0.5
8934, 0.52173913043478, 0.2804347826087, 0.5
8935, 0.5, 0.30652173913043, 0.5
8936, 0.47826086956522, 0.2804347826087, 0.5
8937, 0.45652173913043, 0.30652173913043, 0.5
8938, 0.43478260869565, 0.2804347826087, 0.5
8939, 0.41304347826087, 0.30652173913043, 0.5
8940, 0.39130434782609, 0.2804347826087, 0.5
8941, 0.3695652173913, 0.30652173913043, 0.5
8942, 0.34782608695652, 0.2804347826087, 0.5
8943, 0.32608695652174, 0.30652173913043, 0.5
8944, 0.30434782608696, 0.2804347826087, 0.5
8945, 0.28260869565217, 0.30652173913043, 0.5
8946, 0.26086956521739, 0.2804347826087, 0.5
8947, 0.23913043478261, 0.30652173913043, 0.5
8948, 0.21739130434783, 0.2804347826087, 0.5
8949, 0.19565217391304, 0.30652173913043, 0.5
8950, 0.17391304347826, 0.2804347826087, 0.5
8951, 0.15217391304348, 0.30652173913043, 0.5
8952, 0.1304347826087, 0.2804347826087, 0.5
8953, 0.10869565217391, 0.30652173913043, 0.5
8954, 0.08695652173913, 0.2804347826087, 0.5
8955, 0.065217391304348, 0.30652173913043, 0.5
8956, 0.043478260869565, 0.2804347826087, 0.5
8957, 0.021739130434783, 0.30652173913043, 0.5
8958, 0.97826086956522, 0.35869565217391, 0.5
8959, 0.95652173913043, 0.33260869565217, 0.5
8960, 0.93478260869565, 0.35869565217391, 0.5
8961, 0.91304347826087, 0.33260869565217, 0.5
8962, 0.89130434782609, 0.35869565217391, 0.5
8963, 0.8695652173913, 0.33260869565217, 0.5
8964, 0.84782608695652, 0.35869565217391, 0.5
8965, 0.82608695652174, 0.33260869565217, 0.5
8966, 0.80434782608696, 0.35869565217391, 0.5
8967, 0.78260869565217, 0.33260869565217, 0.5
8968, 0.76086956521739, 0.35869565217391, 0.5
8969, 0.73913043478261, 0.33260869565217, 0.5
8970, 0.71739130434783, 0.35869565217391, 0.5
8971, 0.69565217391304, 0.33260869565217, 0.5
8972, 0.67391304347826, 0.35869565217391, 0.5
8973, 0.65217391304348, 0.33260869565217, 0.5
8974, 0.6304347826087, 0.35869565217391, 0.5
8975, 0.60869565217391, 0.33260869565217, 0.5
8976, 0.58695652173913, 0.35869565217391, 0.5
8977, 0.56521739130435, 0.33260869565217, 0.5
8978, 0.54347826086957, 0.35869565217391, 0.5
8979, 0.52173913043478, 0.33260869565217, 0.5
8980, 0.5, 0.35869565217391, 0.5
8981, 0.47826086956522, 0.33260869565217, 0.5
8982, 0.45652173913043, 0.35869565217391, 0.5
8983, 0.43478260869565, 0.33260869565217, 0.5
8984, 0.41304347826087, 0.35869565217391, 0.5
8985, 0.39130434782609, 0.33260869565217, 0.5
8986, 0.3695652173913, 0.35869565217391, 0.5
8987, 0.34782608695652, 0.33260869565217, 0.5
8988, 0.32608695652174, 0.35869565217391, 0.5
8989, 0.30434782608696, 0.33260869565217, 0.5
8990, 0.28260869565217, 0.35869565217391, 0.5
8991, 0.26086956521739, 0.33260869565217, 0.5
8992, 0.23913043478261, 0.35869565217391, 0.5
8993, 0.21739130434783, 0.33260869565217, 0.5
8994, 0.19565217391304, 0.35869565217391, 0.5
8995, 0.17391304347826, 0.33260869565217, 0.5
8996, 0.15217391304348, 0.35869565217391, 0.5
8997, 0.1304347826087, 0.33260869565217, 0.5
8998, 0.10869565217391, 0.35869565217391, 0.5
8999, 0.08695652173913, 0.33260869565217, 0.5
9000, 0.065217391304348, 0.35869565217391, 0.5
9001, 0.043478260869565, 0.33260869565217, 0.5
9002, 0.021739130434783, 0.35869565217391, 0.5
9003, 0.97826086956522, 0.41086956521739, 0.5
9004, 0.95652173913043, 0.38478260869565, 0.5
9005, 0.93478260869565, 0.41086956521739, 0.5
9006, 0.91304347826087, 0.38478260869565, 0.5
9007, 0.89130434782609, 0.41086956521739, 0.5
9008, 0.8695652173913, 0.38478260869565, 0.5
9009, 0.84782608695652, 0.41086956521739, 0.5
9010, 0.82608695652174, 0.38478260869565, 0.5
9011, 0.80434782608696, 0.41086956521739, 0.5
9012, 0.78260869565217, 0.38478260869565, 0.5
9013, 0.76086956521739, 0.41086956521739, 0.5
9014, 0.73913043478261, 0.38478260869565, 0.5
9015, 0.71739130434783, 0.41086956521739, 0.5
9016, 0.69565217391304, 0.38478260869565, 0.5
9017, 0.67391304347826, 0.41086956521739, 0.5
9018, 0.65217391304348, 0.38478260869565, 0.5
9019, 0.6304347826087, 0.41086956521739, 0.5
9020, 0.60869565217391, 0.38478260869565, 0.5
9021, 0.58695652173913, 0.41086956521739, 0.5
9022, 0.56521739130435, 0.38478260869565, 0.5
9023, 0.54347826086957, 0.41086956521739, 0.5
9024, 0.52173913043478, 0.38478260869565, 0.5
9025, 0.5, 0.41086956521739, 0.5
9026, 0.47826086956522, 0.38478260869565, 0.5
9027, 0.45652173913043, 0.41086956521739, 0.5
9028, 0.43478260869565, 0.38478260869565, 0.5
9029, 0.41304347826087, 0.41086956521739, 0.5
9030, 0.39130434782609, 0.38478260869565, 0.5
9031, 0.3695652173913, 0.41086956521739, 0.5
9032, 0.34782608695652, 0.38478260869565, 0.5
9033, 0.32608695652174, 0.41086956521739, 0.5
9034, 0.30434782608696, 0.38478260869565, 0.5
9035, 0.28260869565217, 0.41086956521739, 0.5
9036, 0.26086956521739, 0.38478260869565, 0.5
9037, 0.23913043478261, 0.41086956521739, 0.5
9038, 0.21739130434783, 0.38478260869565, 0.5
9039, 0.19565217391304, 0.41086956521739, 0.5
9040, 0.17391304347826, 0.38478260869565, 0.5
9041, 0.15217391304348, 0.41086956521739, 0.5
9042, 0.1304347826087, 0.38478260869565, 0.5
9043, 0.10869565217391, 0.41086956521739, 0.5
9044, 0.08695652173913, 0.38478260869565, 0.5
9045, 0.065217391304348, 0.41086956521739, 0.5
9046, 0.043478260869565, 0.38478260869565, 0.5
9047, 0.021739130434783, 0.41086956521739, 0.5
9048, 0.97826086956522, 0.46304347826087, 0.5
9049, 0.95652173913043, 0.43695652173913, 0.5
9050, 0.93478260869565, 0.46304347826087, 0.5
9051, 0.91304347826087, 0.43695652173913, 0.5
9052, 0.89130434782609, 0.46304347826087, 0.5
9053, 0.8695652173913, 0.43695652173913, 0.5
9054, 0.84782608695652, 0.46304347826087, 0.5
9055, 0.82608695652174, 0.43695652173913, 0.5
9056, 0.80434782608696, 0.46304347826087, 0.5
9057, 0.78260869565217, 0.43695652173913, 0.5
9058, 0.76086956521739, 0.46304347826087, 0.5
9059, 0.73913043478261, 0.43695652173913, 0.5
9060, 0.71739130434783, 0.46304347826087, 0.5
9061, 0.69565217391304, 0.43695652173913, 0.5
9062, 0.67391304347826, 0.46304347826087, 0.5
9063, 0.65217391304348, 0.43695652173913, 0.5
9064, 0.6304347826087, 0.46304347826087, 0.5
9065, 0.60869565217391, 0.43695652173913, 0.5
9066, 0.58695652173913, 0.46304347826087, 0.5
9067, 0.56521739130435, 0.43695652173913, 0.5
9068, 0.54347826086957, 0.46304347826087, 0.5
9069, 0.52173913043478, 0.43695652173913, 0.5
9070, 0.5, 0.46304347826087, 0.5
9071, 0.47826086956522, 0.43695652173913, 0.5
9072, 0.45652173913043, 0.46304347826087, 0.5
9073, 0.43478260869565, 0.43695652173913, 0.5
9074, 0.41304347826087, 0.46304347826087, 0.5
9075, 0.39130434782609, 0.43695652173913, 0.5
9076, 0.3695652173913, 0.46304347826087, 0.5
9077, 0.34782608695652, 0.43695652173913, 0.5
9078, 0.32608695652174, 0.46304347826087, 0.5
9079, 0.30434782608696, 0.43695652173913, 0.5
9080, 0.28260869565217, 0.46304347826087, 0.5
9081, 0.26086956521739, 0.43695652173913, 0.5
9082, 0.23913043478261, 0.46304347826087, 0.5
9083, 0.21739130434783, 0.43695652173913, 0.5
9084, 0.19565217391304, 0.46304347826087, 0.5
9085, 0.17391304347826, 0.43695652173913, 0.5
9086, 0.15217391304348, 0.46304347826087, 0.5
9087, 0.1304347826087, 0.43695652173913, 0.5
9088, 0.10869565217391, 0.46304347826087, 0.5
9089, 0.08695652173913, 0.43695652173913, 0.5
9090, 0.065217391304348, 0.46304347826087, 0.5
9091, 0.043478260869565, 0.43695652173913, 0.5
9092, 0.021739130434783, 0.46304347826087, 0.5
9093, 0.97826086956522, 0.51521739130435, 0.5
9094, 0.95652173913043, 0.48913043478261, 0.5
9095, 0.93478260869565, 0.51521739130435, 0.5
9096, 0.91304347826087, 0.48913043478261, 0.5
9097, 0.89130434782609, 0.51521739130435, 0.5
9098, 0.8695652173913, 0.48913043478261, 0.5
9099, 0.84782608695652, 0.51521739130435, 0.5
9100, 0.82608695652174, 0.48913043478261, 0.5
9101, 0.80434782608696, 0.51521739130435, 0.5
9102, 0.78260869565217, 0.48913043478261, 0.5
9103, 0.76086956521739, 0.51521739130435, 0.5
9104, 0.73913043478261, 0.48913043478261, 0.5
9105, 0.71739130434783, 0.51521739130435, 0.5
9106, 0.69565217391304, 0.48913043478261, 0.5
9107, 0.67391304347826, 0.51521739130435, 0.5
9108, 0.65217391304348, 0.48913043478261, 0.5
9109, 0.6304347826087, 0.51521739130435, 0.5
9110, 0.60869565217391, 0.48913043478261, 0.5
9111, 0.58695652173913, 0.51521739130435, 0.5
9112, 0.56521739130435, 0.48913043478261, 0.5
9113, 0.54347826086957, 0.51521739130435, 0.5
9114, 0.52173913043478, 0.48913043478261, 0.5
9115, 0.5, 0.51521739130435, 0.5
9116, 0.47826086956522, 0.48913043478261, 0.5
9117, 0.45652173913043, 0.51521739130435, 0.5
9118, 0.43478260869565, 0.48913043478261, 0.5
9119, 0.41304347826087, 0.51521739130435, 0.5
9120, 0.39130434782609, 0.48913043478261, 0.5
9121, 0.3695652173913, 0.51521739130435, 0.5
9122, 0.34782608695652, 0.48913043478261, 0.5
9123, 0.32608695652174, 0.51521739130435, 0.5
9124, 0.30434782608696, 0.48913043478261, 0.5
9125, 0.28260869565217, 0.51521739130435, 0.5
9126, 0.26086956521739, 0.48913043478261, 0.5
9127, 0.23913043478261, 0.51521739130435, 0.5
9128, 0.21739130434783, 0.48913043478261, 0.5
9129, 0.19565217391304, 0.51521739130435, 0.5
9130, 0.17391304347826, 0.48913043478261, 0.5
9131, 0.15217391304348, 0.51521739130435, 0.5
9132, 0.1304347826087, 0.48913043478261, 0.5
9133, 0.10869565217391, 0.51521739130435, 0.5
9134, 0.08695652173913, 0.48913043478261, 0.5
9135, 0.065217391304348, 0.51521739130435, 0.5
9136, 0.043478260869565, 0.48913043478261, 0.5
9137, 0.021739130434783, 0.51521739130435, 0.5
9138, 0.97826086956522, 0.56739130434783, 0.5
9139, 0.95652173913043, 0.54130434782609, 0.5
9140, 0.93478260869565, 0.56739130434783, 0.5
9141, 0.91304347826087, 0.54130434782609, 0.5
9142, 0.89130434782609, 0.56739130434783, 0.5
9143, 0.8695652173913, 0.54130434782609, 0.5
9144, 0.84782608695652, 0.56739130434783, 0.5
9145, 0.82608695652174, 0.54130434782609, 0.5
9146, 0.80434782608696, 0.56739130434783, 0.5
9147, 0.78260869565217, 0.54130434782609, 0.5
9148, 0.76086956521739, 0.56739130434783, 0.5
9149, 0.73913043478261, 0.54130434782609, 0.5
9150, 0.71739130434783, 0.56739130434783, 0.5
9151, 0.69565217391304, 0.54130434782609, 0.5
9152, 0.67391304347826, 0.56739130434783, 0.5
9153, 0.65217391304348, 0.54130434782609, 0.5
9154, 0.6304347826087, 0.56739130434783, 0.5
9155, 0.60869565217391, 0.54130434782609, 0.5
9156, 0.58695652173913, 0.56739130434783, 0.5
9157, 0.56521739130435, 0.54130434782609, 0.5
9158, 0.54347826086957, 0.56739130434783, 0.5
9159, 0.52173913043478, 0.54130434782609, 0.5
9160, 0.5, 0.56739130434783, 0.5
9161, 0.47826086956522, 0.54130434782609, 0.5
9162, 0.45652173913043, 0.56739130434783, 0.5
9163, 0.43478260869565, 0.54130434782609, 0.5
9164, 0.41304347826087, 0.56739130434783, 0.5
9165, 0.39130434782609, 0.54130434782609, 0.5
9166, 0.3695652173913, 0.56739130434783, 0.5
9167, 0.34782608695652, 0.54130434782609, 0.5
9168, 0.32608695652174, 0.56739130434783, 0.5
9169, 0.30434782608696, 0.54130434782609, 0.5
9170, 0.28260869565217, 0.56739130434783, 0.5
9171, 0.26086956521739, 0.54130434782609, 0.5
9172, 0.23913043478261, 0.56739130434783, 0.5
9173, 0.21739130434783, 0.54130434782609, 0.5
9174, 0.19565217391304, 0.56739130434783, 0.5
9175, 0.17391304347826, 0.54130434782609, 0.5
9176, 0.15217391304348, 0.56739130434783, 0.5
9177, 0.1304347826087, 0.54130434782609, 0.5
9178, 0.10869565217391, 0.56739130434783, 0.5
9179, 0.08695652173913, 0.54130434782609, 0.5
9180, 0.065217391304348, 0.56739130434783, 0.5
9181, 0.043478260869565, 0.54130434782609, 0.5
9182, 0.021739130434783, 0.56739130434783, 0.5
9183, 0.97826086956522, 0.6195652173913, 0.5
9184, 0.95652173913043, 0.59347826086956, 0.5
9185, 0.93478260869565, 0.6195652173913, 0.5
9186, 0.91304347826087, 0.59347826086956, 0.5
9187, 0.89130434782609, 0.6195652173913, 0.5
9188, 0.8695652173913, 0.59347826086956, 0.5
9189, 0.84782608695652, 0.6195652173913, 0.5
9190, 0.82608695652174, 0.59347826086956, 0.5
9191, 0.80434782608696, 0.6195652173913, 0.5
9192, 0.78260869565217, 0.59347826086956, 0.5
9193, 0.76086956521739, 0.6195652173913, 0.5
9194, 0.73913043478261, 0.59347826086956, 0.5
9195, 0.71739130434783, 0.6195652173913, 0.5
9196, 0.69565217391304, 0.59347826086956, 0.5
9197, 0.67391304347826, 0.6195652173913, 0.5
9198, 0.65217391304348, 0.59347826086956, 0.5
9199, 0.6304347826087, 0.6195652173913, 0.5
9200, 0.60869565217391, 0.59347826086956, 0.5
9201, 0.58695652173913, 0.6195652173913, 0.5
9202, 0.56521739130435, 0.59347826086956, 0.5
9203, 0.54347826086957, 0.6195652173913, 0.5
9204, 0.52173913043478, 0.59347826086956, 0.5
9205, 0.5, 0.6195652173913, 0.5
9206, 0.47826086956522, 0.59347826086956, 0.5
9207, 0.45652173913043, 0.6195652173913, 0.5
9208, 0.43478260869565, 0.59347826086956, 0.5
9209, 0.41304347826087, 0.6195652173913, 0.5
9210, 0.39130434782609, 0.59347826086956, 0.5
9211, 0.3695652173913, 0.6195652173913, 0.5
9212, 0.34782608695652, 0.59347826086956, 0.5
9213, 0.32608695652174, 0.6195652173913, 0.5
9214, 0.30434782608696, 0.59347826086956, 0.5
9215, 0.28260869565217, 0.6195652173913, 0.5
9216, 0.26086956521739, 0.59347826086956, 0.5
9217, 0.23913043478261, 0.6195652173913, 0.5
9218, 0.21739130434783, 0.59347826086956, 0.5
9219, 0.19565217391304, 0.6195652173913, 0.5
9220, 0.17391304347826, 0.59347826086956, 0.5
9221, 0.15217391304348, 0.6195652173913, 0.5
9222, 0.1304347826087, 0.59347826086956, 0.5
9223, 0.10869565217391, 0.6195652173913, 0.5
9224, 0.08695652173913, 0.59347826086956, 0.5
9225, 0.065217391304348, 0.6195652173913, 0.5
9226, 0.043478260869565, 0.59347826086956, 0.5
9227, 0.021739130434783, 0.6195652173913, 0.5
9228, 0.97826086956522, 0.67173913043478, 0.5
9229, 0.95652173913043, 0.64565217391304, 0.5
9230, 0.93478260869565, 0.67173913043478, 0.5
9231, 0.91304347826087, 0.64565217391304, 0.5
9232, 0.89130434782609, 0.67173913043478, 0.5
9233, 0.8695652173913, 0.64565217391304, 0.5
9234, 0.84782608695652, 0.67173913043478, 0.5
9235, 0.82608695652174, 0.64565217391304, 0.5
9236, 0.80434782608696, 0.67173913043478, 0.5
9237, 0.78260869565217, 0.64565217391304, 0.5
9238, 0.76086956521739, 0.67173913043478, 0.5
9239, 0.73913043478261, 0.64565217391304, 0.5
9240, 0.71739130434783, 0.67173913043478, 0.5
9241, 0.69565217391304, 0.64565217391304, 0.5
9242, 0.67391304347826, 0.67173913043478, 0.5
9243, 0.65217391304348, 0.64565217391304, 0.5
9244, 0.6304347826087, 0.67173913043478, 0.5
9245, 0.60869565217391, 0.64565217391304, 0.5
9246, 0.58695652173913, 0.67173913043478, 0.5
9247, 0.56521739130435, 0.64565217391304, 0.5
9248, 0.54347826086957, 0.67173913043478, 0.5
9249, 0.52173913043478, 0.64565217391304, 0.5
9250, 0.5, 0.67173913043478, 0.5
9251, 0.47826086956522, 0.64565217391304, 0.5
9252, 0.45652173913043, 0.67173913043478, 0.5
9253, 0.43478260869565, 0.64565217391304, 0.5
9254, 0.41304347826087, 0.67173913043478, 0.5
9255, 0.39130434782609, 0.64565217391304, 0.5
9256, 0.3695652173913, 0.67173913043478, 0.5
9257, 0.34782608695652, 0.64565217391304, 0.5
9258, 0.32608695652174, 0.67173913043478, 0.5
9259, 0.30434782608696, 0.64565217391304, 0.5
9260, 0.28260869565217, 0.67173913043478, 0.5
9261, 0.26086956521739, 0.64565217391304, 0.5
9262, 0.23913043478261, 0.67173913043478, 0.5
9263, 0.21739130434783, 0.64565217391304, 0.5
9264, 0.19565217391304, 0.67173913043478, 0.5
9265, 0.17391304347826, 0.64565217391304, 0.5
9266, 0.15217391304348, 0.67173913043478, 0.5
9267, 0.1304347826087, 0.64565217391304, 0.5
9268, 0.10869565217391, 0.67173913043478, 0.5
9269, 0.08695652173913, 0.64565217391304, 0.5
9270, 0.065217391304348, 0.67173913043478, 0.5
9271, 0.043478260869565, 0.64565217391304, 0.5
9272, 0.021739130434783, 0.67173913043478, 0.5
9273, 0.97826086956522, 0.72391304347826, 0.5
9274, 0.95652173913043, 0.69782608695652, 0.5
9275, 0.93478260869565, 0.72391304347826, 0.5
9276, 0.91304347826087, 0.69782608695652, 0.5
9277, 0.89130434782609, 0.72391304347826, 0.5
9278, 0.8695652173913, 0.69782608695652, 0.5
9279, 0.84782608695652, 0.72391304347826, 0.5
9280, 0.82608695652174, 0.69782608695652, 0.5
9281, 0.80434782608696, 0.72391304347826, 0.5
9282, 0.78260869565217, 0.69782608695652, 0.5
9283, 0.76086956521739, 0.72391304347826, 0.5
9284, 0.73913043478261, 0.69782608695652, 0.5
9285, 0.71739130434783, 0.72391304347826, 0.5
9286, 0.69565217391304, 0.69782608695652, 0.5
9287, 0.67391304347826, 0.72391304347826, 0.5
9288, 0.65217391304348, 0.69782608695652, 0.5
9289, 0.6304347826087, 0.72391304347826, 0.5
9290, 0.60869565217391, 0.69782608695652, 0.5
9291, 0.58695652173913, 0.72391304347826, 0.5
9292, 0.56521739130435, 0.69782608695652, 0.5
9293, 0.54347826086957, 0.72391304347826, 0.5
9294, 0.52173913043478, 0.69782608695652, 0.5
9295, 0.5, 0.72391304347826, 0.5
9296, 0.47826086956522, 0.69782608695652, 0.5
9297, 0.45652173913043, 0.72391304347826, 0.5
9298, 0.43478260869565, 0.69782608695652, 0.5
9299, 0.41304347826087, 0.72391304347826, 0.5
9300, 0.39130434782609, 0.69782608695652, 0.5
9301, 0.3695652173913, 0.72391304347826, 0.5
9302, 0.34782608695652, 0.69782608695652, 0.5
9303, 0.32608695652174, 0.72391304347826, 0.5
9304, 0.30434782608696, 0.69782608695652, 0.5
9305, 0.28260869565217, 0.72391304347826, 0.5
9306, 0.26086956521739, 0.69782608695652, 0.5
9307, 0.23913043478261, 0.72391304347826, 0.5
9308, 0.21739130434783, 0.69782608695652, 0.5
9309, 0.19565217391304, 0.72391304347826, 0.5
9310, 0.17391304347826, 0.69782608695652, 0.5
9311, 0.15217391304348, 0.72391304347826, 0.5
9312, 0.1304347826087, 0.69782608695652, 0.5
9313, 0.10869565217391, 0.72391304347826, 0.5
9314, 0.08695652173913, 0.69782608695652, 0.5
9315, 0.065217391304348, 0.72391304347826, 0.5
9316, 0.043478260869565, 0.69782608695652, 0.5
9317, 0.021739130434783, 0.72391304347826, 0.5
9318, 0.97826086956522, 0.77608695652174, 0.5
9319, 0.95652173913043, 0.75, 0.5
9320, 0.93478260869565, 0.77608695652174, 0.5
9321, 0.91304347826087, 0.75, 0.5
9322, 0.89130434782609, 0.77608695652174, 0.5
9323, 0.8695652173913, 0.75, 0.5
9324, 0.84782608695652, 0.77608695652174, 0.5
9325, 0.82608695652174, 0.75, 0.5
9326, 0.80434782608696, 0.77608695652174, 0.5
9327, 0.78260869565217, 0.75, 0.5
9328, 0.76086956521739, 0.77608695652174, 0.5
9329, 0.73913043478261, 0.75, 0.5
9330, 0.71739130434783, 0.77608695652174, 0.5
9331, 0.69565217391304, 0.75, 0.5
9332, 0.67391304347826, 0.77608695652174, 0.5
9333, 0.65217391304348, 0.75, 0.5
9334, 0.6304347826087, 0.77608695652174, 0.5
9335, 0.60869565217391, 0.75, 0.5
9336, 0.58695652173913, 0.77608695652174, 0.5
9337, 0.56521739130435, 0.75, 0.5
9338, 0.54347826086957, 0.77608695652174, 0.5
9339, 0.52173913043478, 0.75, 0.5
9340, 0.5, 0.77608695652174, 0.5
9341, 0.47826086956522, 0.75, 0.5
9342, 0.45652173913043, 0.77608695652174, 0.5
9343, 0.43478260869565, 0.75, 0.5
9344, 0.41304347826087, 0.77608695652174, 0.5
9345, 0.39130434782609, 0.75, 0.5
9346, 0.3695652173913, 0.77608695652174, 0.5
9347, 0.34782608695652, 0.75, 0.5
9348, 0.32608695652174, 0.77608695652174, 0.5
9349, 0.30434782608696, 0.75, 0.5
9350, 0.28260869565217, 0.77608695652174, 0.5
9351, 0.26086956521739, 0.75, 0.5
9352, 0.23913043478261, 0.77608695652174, 0.5
9353, 0.21739130434783, 0.75, 0.5
9354, 0.19565217391304, 0.77608695652174, 0.5
9355, 0.17391304347826, 0.75, 0.5
9356, 0.15217391304348, 0.77608695652174, 0.5
9357, 0.1304347826087, 0.75, 0.5
9358, 0.10869565217391, 0.77608695652174, 0.5
9359, 0.08695652173913, 0.75, 0.5
9360, 0.065217391304348, 0.77608695652174, 0.5
9361, 0.043478260869565, 0.75, 0.5
9362, 0.021739130434783, 0.77608695652174, 0.5
9363, 0.97826086956522, 0.82826086956522, 0.5
9364, 0.95652173913043, 0.80217391304348, 0.5
9365, 0.93478260869565, 0.82826086956522, 0.5
9366, 0.91304347826087, 0.80217391304348, 0.5
9367, 0.89130434782609, 0.82826086956522, 0.5
9368, 0.8695652173913, 0.80217391304348, 0.5
9369, 0.84782608695652, 0.82826086956522, 0.5
9370, 0.82608695652174, 0.80217391304348, 0.5
9371, 0.80434782608696, 0.82826086956522, 0.5
9372, 0.78260869565217, 0.80217391304348, 0.5
9373, 0.76086956521739, 0.82826086956522, 0.5
9374, 0.73913043478261, 0.80217391304348, 0.5
9375, 0.71739130434783, 0.82826086956522, 0.5
9376, 0.69565217391304, 0.80217391304348, 0.5
9377, 0.67391304347826, 0.82826086956522, 0.5
9378, 0.65217391304348, 0.80217391304348, 0.5
9379, 0.6304347826087, 0.82826086956522, 0.5
9380, 0.60869565217391, 0.80217391304348, 0.5
9381, 0.58695652173913, 0.82826086956522, 0.5
9382, 0.56521739130435, 0.80217391304348, 0.5
9383, 0.54347826086957, 0.82826086956522, 0.5
9384, 0.52173913043478, 0.80217391304348, 0.5
9385, 0.5, 0.82826086956522, 0.5
9386, 0.47826086956522, 0.80217391304348, 0.5
9387, 0.45652173913043, 0.82826086956522, 0.5
9388, 0.43478260869565, 0.80217391304348, 0.5
9389, 0.41304347826087, 0.82826086956522, 0.5
9390, 0.39130434782609, 0.80217391304348, 0.5
9391, 0.3695652173913, 0.82826086956522, 0.5
9392, 0.34782608695652, 0.80217391304348, 0.5
9393, 0.32608695652174, 0.82826086956522, 0.5
9394, 0.30434782608696, 0.80217391304348, 0.5
9395, 0.28260869565217, 0.82826086956522, 0.5
9396, 0.26086956521739, 0.80217391304348, 0.5
9397, 0.23913043478261, 0.82826086956522, 0.5
9398, 0.21739130434783, 0.80217391304348, 0.5
9399, 0.19565217391304, 0.82826086956522, 0.5
9400, 0.17391304347826, 0.80217391304348, 0.5
9401, 0.15217391304348, 0.82826086956522, 0.5
9402, 0.1304347826087, 0.80217391304348, 0.5
9403, 0.10869565217391, 0.82826086956522, 0.5
9404, 0.08695652173913, 0.80217391304348, 0.5
9405, 0.065217391304348, 0.82826086956522, 0.5
9406, 0.043478260869565, 0.80217391304348, 0.5
9407, 0.021739130434783, 0.82826086956522, 0.5
9408, 0.97826086956522, 0.8804347826087, 0.5
9409, 0.95652173913043, 0.85434782608696, 0.5
9410, 0.93478260869565, 0.8804347826087, 0.5
9411, 0.91304347826087, 0.85434782608696, 0.5
9412, 0.89130434782609, 0.8804347826087, 0.5
9413, 0.8695652173913, 0.85434782608696, 0.5
9414, 0.84782608695652, 0.8804347826087, 0.5
9415, 0.82608695652174, 0.85434782608696, 0.5
9416, 0.80434782608696, 0.8804347826087, 0.5
9417, 0.78260869565217, 0.85434782608696, 0.5
9418, 0.76086956521739, 0.8804347826087, 0.5
9419, 0.73913043478261, 0.85434782608696, 0.5
9420, 0.71739130434783, 0.8804347826087, 0.5
9421, 0.69565217391304, 0.85434782608696, 0.5
9422, 0.67391304347826, 0.8804347826087, 0.5
9423, 0.65217391304348, 0.85434782608696, 0.5
9424, 0.6304347826087, 0.8804347826087, 0.5
9425, 0.60869565217391, 0.85434782608696, 0.5
9426, 0.58695652173913, 0.8804347826087, 0.5
9427, 0.56521739130435, 0.85434782608696, 0.5
9428, 0.54347826086957, 0.88043478260869, 0.5
9429, 0.52173913043478, 0.85434782608696, 0.5
9430, 0.5, 0.88043478260869, 0.5
9431, 0.47826086956522, 0.85434782608696, 0.5
9432, 0.45652173913043, 0.8804347826087, 0.5
9433, 0.43478260869565, 0.85434782608696, 0.5
9434, 0.41304347826087, 0.88043478260869, 0.5
9435, 0.39130434782609, 0.85434782608696, 0.5
9436, 0.3695652173913, 0.8804347826087, 0.5
9437, 0.34782608695652, 0.85434782608696, 0.5
9438, 0.32608695652174, 0.8804347826087, 0.5
9439, 0.30434782608696, 0.85434782608696, 0.5
9440, 0.28260869565217, 0.8804347826087, 0.5
9441, 0.26086956521739, 0.85434782608696, 0.5
9442, 0.23913043478261, 0.8804347826087, 0.5
9443, 0.21739130434783, 0.85434782608696, 0.5
9444, 0.19565217391304, 0.8804347826087, 0.5
9445, 0.17391304347826, 0.85434782608696, 0.5
9446, 0.15217391304348, 0.8804347826087, 0.5
9447, 0.1304347826087, 0.85434782608696, 0.5
9448, 0.10869565217391, 0.8804347826087, 0.5
9449, 0.08695652173913, 0.85434782608696, 0.5
9450, 0.065217391304348, 0.8804347826087, 0.5
9451, 0.043478260869565, 0.85434782608696, 0.5
9452, 0.021739130434783, 0.8804347826087, 0.5
9453, 0.97826086956522, 0.93260869565217, 0.5
9454, 0.95652173913043, 0.90652173913043, 0.5
9455, 0.93478260869565, 0.93260869565217, 0.5
9456, 0.91304347826087, 0.90652173913043, 0.5
9457, 0.89130434782609, 0.93260869565217, 0.5
9458, 0.8695652173913, 0.90652173913043, 0.5
9459, 0.84782608695652, 0.93260869565217, 0.5
9460, 0.82608695652174, 0.90652173913043, 0.5
9461, 0.80434782608696, 0.93260869565217, 0.5
9462, 0.78260869565217, 0.90652173913043, 0.5
9463, 0.76086956521739, 0.93260869565217, 0.5
9464, 0.73913043478261, 0.90652173913043, 0.5
9465, 0.71739130434783, 0.93260869565217, 0.5
9466, 0.69565217391304, 0.90652173913043, 0.5
9467, 0.67391304347826, 0.93260869565217, 0.5
9468, 0.65217391304348, 0.90652173913043, 0.5
9469, 0.6304347826087, 0.93260869565217, 0.5
9470, 0.60869565217391, 0.90652173913043, 0.5
9471, 0.58695652173913, 0.93260869565217, 0.5
9472, 0.56521739130435, 0.90652173913043, 0.5
9473, 0.54347826086957, 0.93260869565217, 0.5
9474, 0.52173913043478, 0.90652173913043, 0.5
9475, 0.5, 0.93260869565217, 0.5
9476, 0.47826086956522, 0.90652173913043, 0.5
9477, 0.45652173913043, 0.93260869565217, 0.5
9478, 0.43478260869565, 0.90652173913043, 0.5
9479, 0.41304347826087, 0.93260869565217, 0.5
9480, 0.39130434782609, 0.90652173913043, 0.5
9481, 0.3695652173913, 0.93260869565217, 0.5
9482, 0.34782608695652, 0.90652173913043, 0.5
9483, 0.32608695652174, 0.93260869565217, 0.5
9484, 0.30434782608696, 0.90652173913043, 0.5
9485, 0.28260869565217, 0.93260869565217, 0.5
9486, 0.26086956521739, 0.90652173913043, 0.5
9487, 0.23913043478261, 0.93260869565217, 0.5
9488, 0.21739130434783, 0.90652173913043, 0.5
9489, 0.19565217391304, 0.93260869565217, 0.5
9490, 0.17391304347826, 0.90652173913043, 0.5
9491, 0.15217391304348, 0.93260869565217, 0.5
9492, 0.1304347826087, 0.90652173913043, 0.5
9493, 0.10869565217391, 0.93260869565217, 0.5
9494, 0.08695652173913, 0.90652173913043, 0.5
9495, 0.065217391304348, 0.93260869565217, 0.5
9496, 0.043478260869565, 0.90652173913043, 0.5
9497, 0.021739130434783, 0.93260869565217, 0.5
9498, 0.97826086956522, 0.98478260869565, 0.5
9499, 0.95652173913043, 0.95869565217391, 0.5
9500, 0.93478260869565, 0.98478260869565, 0.5
9501, 0.91304347826087, 0.95869565217391, 0.5
9502, 0.89130434782609, 0.98478260869565, 0.5
9503, 0.8695652173913, 0.95869565217391, 0.5
9504, 0.84782608695652, 0.98478260869565, 0.5
9505, 0.82608695652174, 0.95869565217391, 0.5
9506, 0.80434782608696, 0.98478260869565, 0.5
9507, 0.78260869565217, 0.95869565217391, 0.5
9508, 0.76086956521739, 0.98478260869565, 0.5
9509, 0.73913043478261, 0.95869565217391, 0.5
9510, 0.71739130434783, 0.98478260869565, 0.5
9511, 0.69565217391304, 0.95869565217391, 0.5
9512, 0.67391304347826, 0.98478260869565, 0.5
9513, 0.65217391304348, 0.95869565217391, 0.5
9514, 0.6304347826087, 0.98478260869565, 0.5
9515, 0.60869565217391, 0.95869565217391, 0.5
9516, 0.58695652173913, 0.98478260869565, 0.5
9517, 0.56521739130435, 0.95869565217391, 0.5
9518, 0.54347826086957, 0.98478260869565, 0.5
9519, 0.52173913043478, 0.95869565217391, 0.5
9520, 0.5, 0.98478260869565, 0.5
9521, 0.47826086956522, 0.95869565217391, 0.5
9522, 0.45652173913043, 0.98478260869565, 0.5
9523, 0.43478260869565, 0.95869565217391, 0.5
9524, 0.41304347826087, 0.98478260869565, 0.5
9525, 0.39130434782609, 0.95869565217391, 0.5
9526, 0.3695652173913, 0.98478260869565, 0.5
9527, 0.34782608695652, 0.95869565217391, 0.5
9528, 0.32608695652174, 0.98478260869565, 0.5
9529, 0.30434782608696, 0.95869565217391, 0.5
9530, 0.28260869565217, 0.98478260869565, 0.5
9531, 0.26086956521739, 0.95869565217391, 0.5
9532, 0.23913043478261, 0.98478260869565, 0.5
9533, 0.21739130434783, 0.95869565217391, 0.5
9534, 0.19565217391304, 0.98478260869565, 0.5
9535, 0.17391304347826, 0.95869565217391, 0.5
9536, 0.15217391304348, 0.98478260869565, 0.5
9537, 0.1304347826087, 0.95869565217391, 0.5
9538, 0.10869565217391, 0.98478260869565, 0.5
9539, 0.08695652173913, 0.95869565217391, 0.5
9540, 0.065217391304348, 0.98478260869565, 0.5
9541, 0.043478260869565, 0.95869565217391, 0.5
9542, 0.021739130434783, 0.98478260869565, 0.5
9543, 0.97826086956522, 1.0369565217391, 0.5
9544, 0.95652173913043, 1.0108695652174, 0.5
9545, 0.93478260869565, 1.0369565217391, 0.5
9546, 0.91304347826087, 1.0108695652174, 0.5
9547, 0.89130434782609, 1.0369565217391, 0.5
9548, 0.8695652173913, 1.0108695652174, 0.5
9549, 0.84782608695652, 1.0369565217391, 0.5
9550, 0.82608695652174, 1.0108695652174, 0.5
9551, 0.80434782608696, 1.0369565217391, 0.5
9552, 0.78260869565217, 1.0108695652174, 0.5
9553, 0.76086956521739, 1.0369565217391, 0.5
9554, 0.73913043478261, 1.0108695652174, 0.5
9555, 0.71739130434783, 1.0369565217391, 0.5
9556, 0.69565217391304, 1.0108695652174, 0.5
9557, 0.67391304347826, 1.0369565217391, 0.5
9558, 0.65217391304348, 1.0108695652174, 0.5
9559, 0.6304347826087, 1.0369565217391, 0.5
9560, 0.60869565217391, 1.0108695652174, 0.5
9561, 0.58695652173913, 1.0369565217391, 0.5
9562, 0.56521739130435, 1.0108695652174, 0.5
9563, 0.54347826086957, 1.0369565217391, 0.5
9564, 0.52173913043478, 1.0108695652174, 0.5
9565, 0.5, 1.0369565217391, 0.5
9566, 0.47826086956522, 1.0108695652174, 0.5
9567, 0.45652173913043, 1.0369565217391, 0.5
9568, 0.43478260869565, 1.0108695652174, 0.5
9569, 0.41304347826087, 1.0369565217391, 0.5
9570, 0.39130434782609, 1.0108695652174, 0.5
9571, 0.3695652173913, 1.0369565217391, 0.5
9572, 0.34782608695652, 1.0108695652174, 0.5
9573, 0.32608695652174, 1.0369565217391, 0.5
9574, 0.30434782608696, 1.0108695652174, 0.5
9575, 0.28260869565217, 1.0369565217391, 0.5
9576, 0.26086956521739, 1.0108695652174, 0.5
9577, 0.23913043478261, 1.0369565217391, 0.5
9578, 0.21739130434783, 1.0108695652174, 0.5
9579, 0.19565217391304, 1.0369565217391, 0.5
9580, 0.17391304347826, 1.0108695652174, 0.5
9581, 0.15217391304348, 1.0369565217391, 0.5
9582, 0.1304347826087, 1.0108695652174, 0.5
9583, 0.10869565217391, 1.0369565217391, 0.5
9584, 0.08695652173913, 1.0108695652174, 0.5
9585, 0.065217391304348, 1.0369565217391, 0.5
9586, 0.043478260869565, 1.0108695652174, 0.5
9587, 0.021739130434783, 1.0369565217391, 0.5
9588, 0.97826086956522, 1.0891304347826, 0.5
9589, 0.95652173913043, 1.0630434782609, 0.5
9590, 0.93478260869565, 1.0891304347826, 0.5
9591, 0.91304347826087, 1.0630434782609, 0.5
9592, 0.89130434782609, 1.0891304347826, 0.5
9593, 0.8695652173913, 1.0630434782609, 0.5
9594, 0.84782608695652, 1.0891304347826, 0.5
9595, 0.82608695652174, 1.0630434782609, 0.5
9596, 0.80434782608696, 1.0891304347826, 0.5
9597, 0.78260869565217, 1.0630434782609, 0.5
9598, 0.76086956521739, 1.0891304347826, 0.5
9599, 0.73913043478261, 1.0630434782609, 0.5
9600, 0.71739130434783, 1.0891304347826, 0.5
9601, 0.69565217391304, 1.0630434782609, 0.5
9602, 0.67391304347826, 1.0891304347826, 0.5
9603, 0.65217391304348, 1.0630434782609, 0.5
9604, 0.6304347826087, 1.0891304347826, 0.5
9605, 0.60869565217391, 1.0630434782609, 0.5
9606, 0.58695652173913, 1.0891304347826, 0.5
9607, 0.56521739130435, 1.0630434782609, 0.5
9608, 0.54347826086957, 1.0891304347826, 0.5
9609, 0.52173913043478, 1.0630434782609, 0.5
9610, 0.5, 1.0891304347826, 0.5
9611, 0.47826086956522, 1.0630434782609, 0.5
9612, 0.45652173913043, 1.0891304347826, 0.5
9613, 0.43478260869565, 1.0630434782609, 0.5
9614, 0.41304347826087, 1.0891304347826, 0.5
9615, 0.39130434782609, 1.0630434782609, 0.5
9616, 0.3695652173913, 1.0891304347826, 0.5
9617, 0.34782608695652, 1.0630434782609, 0.5
9618, 0.32608695652174, 1.0891304347826, 0.5
9619, 0.30434782608696, 1.0630434782609, 0.5
9620, 0.28260869565217, 1.0891304347826, 0.5
9621, 0.26086956521739, 1.0630434782609, 0.5
9622, 0.23913043478261, 1.0891304347826, 0.5
9623, 0.21739130434783, 1.0630434782609, 0.5
9624, 0.19565217391304, 1.0891304347826, 0.5
9625, 0.17391304347826, 1.0630434782609, 0.5
9626, 0.15217391304348, 1.0891304347826, 0.5
9627, 0.1304347826087, 1.0630434782609, 0.5
9628, 0.10869565217391, 1.0891304347826, 0.5
9629, 0.08695652173913, 1.0630434782609, 0.5
9630, 0.065217391304348, 1.0891304347826, 0.5
9631, 0.043478260869565, 1.0630434782609, 0.5
9632, 0.021739130434783, 1.0891304347826, 0.5
9633, 0.97826086956522, 1.1413043478261, 0.5
9634, 0.95652173913043, 1.1152173913043, 0.5
9635, 0.93478260869565, 1.1413043478261, 0.5
9636, 0.91304347826087, 1.1152173913043, 0.5
9637, 0.89130434782609, 1.1413043478261, 0.5
9638, 0.8695652173913, 1.1152173913043, 0.5
9639, 0.84782608695652, 1.1413043478261, 0.5
9640, 0.82608695652174, 1.1152173913043, 0.5
9641, 0.80434782608696, 1.1413043478261, 0.5
9642, 0.78260869565217, 1.1152173913043, 0.5
9643, 0.76086956521739, 1.1413043478261, 0.5
9644, 0.73913043478261, 1.1152173913043, 0.5
9645, 0.71739130434783, 1.1413043478261, 0.5
9646, 0.69565217391304, 1.1152173913043, 0.5
9647, 0.67391304347826, 1.1413043478261, 0.5
9648, 0.65217391304348, 1.1152173913043, 0.5
9649, 0.6304347826087, 1.1413043478261, 0.5
9650, 0.60869565217391, 1.1152173913043, 0.5
9651, 0.58695652173913, 1.1413043478261, 0.5
9652, 0.56521739130435, 1.1152173913043, 0.5
9653, 0.54347826086957, 1.1413043478261, 0.5
9654, 0.52173913043478, 1.1152173913043, 0.5
9655, 0.5, 1.1413043478261, 0.5
9656, 0.47826086956522, 1.1152173913043, 0.5
9657, 0.45652173913043, 1.1413043478261, 0.5
9658, 0.43478260869565, 1.1152173913043, 0.5
9659, 0.41304347826087, 1.1413043478261, 0.5
9660, 0.39130434782609, 1.1152173913043, 0.5
9661, 0.3695652173913, 1.1413043478261, 0.5
9662, 0.34782608695652, 1.1152173913043, 0.5
9663, 0.32608695652174, 1.1413043478261, 0.5
9664, 0.30434782608696, 1.1152173913043, 0.5
9665, 0.28260869565217, 1.1413043478261, 0.5
9666, 0.26086956521739, 1.1152173913043, 0.5
9667, 0.23913043478261, 1.1413043478261, 0.5
9668, 0.21739130434783, 1.1152173913043, 0.5
9669, 0.19565217391304, 1.1413043478261, 0.5
9670, 0.17391304347826, 1.1152173913043, 0.5
9671, 0.15217391304348, 1.1413043478261, 0.5
9672, 0.1304347826087, 1.1152173913043, 0.5
9673, 0.10869565217391, 1.1413043478261, 0.5
9674, 0.08695652173913, 1.1152173913043, 0.5
9675, 0.065217391304348, 1.1413043478261, 0.5
9676, 0.043478260869565, 1.1152173913043, 0.5
9677, 0.021739130434783, 1.1413043478261, 0.5
9678, 0.97826086956522, 1.1934782608696, 0.5
9679, 0.95652173913043, 1.1673913043478, 0.5
9680, 0.93478260869565, 1.1934782608696, 0.5
9681, 0.91304347826087, 1.1673913043478, 0.5
9682, 0.89130434782609, 1.1934782608696, 0.5
9683, 0.8695652173913, 1.1673913043478, 0.5
9684, 0.84782608695652, 1.1934782608696, 0.5
9685, 0.82608695652174, 1.1673913043478, 0.5
9686, 0.80434782608696, 1.1934782608696, 0.5
9687, 0.78260869565217, 1.1673913043478, 0.5
9688, 0.76086956521739, 1.1934782608696, 0.5
9689, 0.73913043478261, 1.1673913043478, 0.5
9690, 0.71739130434783, 1.1934782608696, 0.5
9691, 0.69565217391304, 1.1673913043478, 0.5
9692, 0.67391304347826, 1.1934782608696, 0.5
9693, 0.65217391304348, 1.1673913043478, 0.5
9694, 0.6304347826087, 1.1934782608696, 0.5
9695, 0.60869565217391, 1.1673913043478, 0.5
9696, 0.58695652173913, 1.1934782608696, 0.5
9697, 0.56521739130435, 1.1673913043478, 0.5
9698, 0.54347826086957, 1.1934782608696, 0.5
9699, 0.52173913043478, 1.1673913043478, 0.5
9700, 0.5, 1.1934782608696, 0.5
9701, 0.47826086956522, 1.1673913043478, 0.5
9702, 0.45652173913043, 1.1934782608696, 0.5
9703, 0.43478260869565, 1.1673913043478, 0.5
9704, 0.41304347826087, 1.1934782608696, 0.5
9705, 0.39130434782609, 1.1673913043478, 0.5
9706, 0.3695652173913, 1.1934782608696, 0.5
9707, 0.34782608695652, 1.1673913043478, 0.5
9708, 0.32608695652174, 1.1934782608696, 0.5
9709, 0.30434782608696, 1.1673913043478, 0.5
9710, 0.28260869565217, 1.1934782608696, 0.5
9711, 0.26086956521739, 1.1673913043478, 0.5
9712, 0.23913043478261, 1.1934782608696, 0.5
9713, 0.21739130434783, 1.1673913043478, 0.5
9714, 0.19565217391304, 1.1934782608696, 0.5
9715, 0.17391304347826, 1.1673913043478, 0.5
9716, 0.15217391304348, 1.1934782608696, 0.5
9717, 0.1304347826087, 1.1673913043478, 0.5
9718, 0.10869565217391, 1.1934782608696, 0.5
9719, 0.08695652173913, 1.1673913043478, 0.5
9720, 0.065217391304348, 1.1934782608696, 0.5
9721, 0.043478260869565, 1.1673913043478, 0.5
9722, 0.021739130434783, 1.1934782608696, 0.5
9723, 0.97826086956522, 1.245652173913, 0.5
9724, 0.95652173913043, 1.2195652173913, 0.5
9725, 0.93478260869565, 1.245652173913, 0.5
9726, 0.91304347826087, 1.2195652173913, 0.5
9727, 0.89130434782609, 1.245652173913, 0.5
9728, 0.8695652173913, 1.2195652173913, 0.5
9729, 0.84782608695652, 1.245652173913, 0.5
9730, 0.82608695652174, 1.2195652173913, 0.5
9731, 0.80434782608696, 1.245652173913, 0.5
9732, 0.78260869565217, 1.2195652173913, 0.5
9733, 0.76086956521739, 1.245652173913, 0.5
9734, 0.73913043478261, 1.2195652173913, 0.5
9735, 0.71739130434783, 1.245652173913, 0.5
9736, 0.69565217391304, 1.2195652173913, 0.5
9737, 0.67391304347826, 1.245652173913, 0.5
9738, 0.65217391304348, 1.2195652173913, 0.5
9739, 0.6304347826087, 1.245652173913, 0.5
9740, 0.60869565217391, 1.2195652173913, 0.5
9741, 0.58695652173913, 1.245652173913, 0.5
9742, 0.56521739130435, 1.2195652173913, 0.5
9743, 0.54347826086957, 1.245652173913, 0.5
9744, 0.52173913043478, 1.2195652173913, 0.5
9745, 0.5, 1.245652173913, 0.5
9746, 0.47826086956522, 1.2195652173913, 0.5
9747, 0.45652173913043, 1.245652173913, 0.5
9748, 0.43478260869565, 1.2195652173913, 0.5
9749, 0.41304347826087, 1.245652173913, 0.5
9750, 0.39130434782609, 1.2195652173913, 0.5
9751, 0.3695652173913, 1.245652173913, 0.5
9752, 0.34782608695652, 1.2195652173913, 0.5
9753, 0.32608695652174, 1.245652173913, 0.5
9754, 0.30434782608696, 1.2195652173913, 0.5
9755, 0.28260869565217, 1.245652173913, 0.5
9756, 0.26086956521739, 1.2195652173913, 0.5
9757, 0.23913043478261, 1.245652173913, 0.5
9758, 0.21739130434783, 1.2195652173913, 0.5
9759, 0.19565217391304, 1.245652173913, 0.5
9760, 0.17391304347826, 1.2195652173913, 0.5
9761, 0.15217391304348, 1.245652173913, 0.5
9762, 0.1304347826087, 1.2195652173913, 0.5
9763, 0.10869565217391, 1.245652173913, 0.5
9764, 0.08695652173913, 1.2195652173913, 0.5
9765, 0.065217391304348, 1.245652173913, 0.5
9766, 0.043478260869565, 1.2195652173913, 0.5
9767, 0.021739130434783, 1.245652173913, 0.5
9768, 0.97826086956522, 1.2978260869565, 0.5
9769, 0.95652173913043, 1.2717391304348, 0.5
9770, 0.93478260869565, 1.2978260869565, 0.5
9771, 0.91304347826087, 1.2717391304348, 0.5
9772, 0.89130434782609, 1.2978260869565, 0.5
9773, 0.8695652173913, 1.2717391304348, 0.5
9774, 0.84782608695652, 1.2978260869565, 0.5
9775, 0.82608695652174, 1.2717391304348, 0.5
9776, 0.80434782608696, 1.2978260869565, 0.5
9777, 0.78260869565217, 1.2717391304348, 0.5
9778, 0.76086956521739, 1.2978260869565, 0.5
9779, 0.73913043478261, 1.2717391304348, 0.5
9780, 0.71739130434783, 1.2978260869565, 0.5
9781, 0.69565217391304, 1.2717391304348, 0.5
9782, 0.67391304347826, 1.2978260869565, 0.5
9783, 0.65217391304348, 1.2717391304348, 0.5
9784, 0.6304347826087, 1.2978260869565, 0.5
9785, 0.60869565217391, 1.2717391304348, 0.5
9786, 0.58695652173913, 1.2978260869565, 0.5
9787, 0.56521739130435, 1.2717391304348, 0.5
9788, 0.54347826086957, 1.2978260869565, 0.5
9789, 0.52173913043478, 1.2717391304348, 0.5
9790, 0.5, 1.2978260869565, 0.5
9791, 0.47826086956522, 1.2717391304348, 0.5
9792, 0.45652173913043, 1.2978260869565, 0.5
9793, 0.43478260869565, 1.2717391304348, 0.5
9794, 0.41304347826087, 1.2978260869565, 0.5
9795, 0.39130434782609, 1.2717391304348, 0.5
9796, 0.3695652173913, 1.2978260869565, 0.5
9797, 0.34782608695652, 1.2717391304348, 0.5
9798, 0.32608695652174, 1.2978260869565, 0.5
9799, 0.30434782608696, 1.2717391304348, 0.5
9800, 0.28260869565217, 1.2978260869565, 0.5
9801, 0.26086956521739, 1.2717391304348, 0.5
9802, 0.23913043478261, 1.2978260869565, 0.5
9803, 0.21739130434783, 1.2717391304348, 0.5
9804, 0.19565217391304, 1.2978260869565, 0.5
9805, 0.17391304347826, 1.2717391304348, 0.5
9806, 0.15217391304348, 1.2978260869565, 0.5
9807, 0.1304347826087, 1.2717391304348, 0.5
9808, 0.10869565217391, 1.2978260869565, 0.5
9809, 0.08695652173913, 1.2717391304348, 0.5
9810, 0.065217391304348, 1.2978260869565, 0.5
9811, 0.043478260869565, 1.2717391304348, 0.5
9812, 0.021739130434783, 1.2978260869565, 0.5
9813, 0.95652173913043, 1.3239130434783, 0.5
9814, 0.91304347826087, 1.3239130434783, 0.5
9815, 0.8695652173913, 1.3239130434783, 0.5
9816, 0.82608695652174, 1.3239130434783, 0.5
9817, 0.78260869565217, 1.3239130434783, 0.5
9818, 0.73913043478261, 1.3239130434783, 0.5
9819, 0.69565217391304, 1.3239130434783, 0.5
9820, 0.65217391304348, 1.3239130434783, 0.5
9821, 0.60869565217391, 1.3239130434783, 0.5
9822, 0.56521739130435, 1.3239130434783, 0.5
9823, 0.52173913043478, 1.3239130434783, 0.5
9824, 0.47826086956522, 1.3239130434783, 0.5
9825, 0.43478260869565, 1.3239130434783, 0.5
9826, 0.39130434782609, 1.3239130434783, 0.5
9827, 0.34782608695652, 1.3239130434783, 0.5
9828, 0.30434782608696, 1.3239130434783, 0.5
9829, 0.26086956521739, 1.3239130434783, 0.5
9830, 0.21739130434783, 1.3239130434783, 0.5
9831, 0.17391304347826, 1.3239130434783, 0.5
9832, 0.1304347826087, 1.3239130434783, 0.5
9833, 0.08695652173913, 1.3239130434783, 0.5
9834, 0.043478260869565, 1.3239130434783, 0.5
9835, 0, 0.20217391304348, 0.45454545454545
9836, 0, 0.20217391304348, 0.40909090909091
9837, 0, 0.20217391304348, 0.36363636363636
9838, 0, 0.20217391304348, 0.31818181818182
9839, 0, 0.20217391304348, 0.27272727272727
9840, 0, 0.20217391304348, 0.22727272727273
9841, 0, 0.20217391304348, 0.18181818181818
9842, 0, 0.20217391304348, 0.13636363636364
9843, 0, 0.20217391304348, 0.090909090909091
9844, 0, 0.20217391304348, 0.045454545454545
9845, 0, 0.25434782608696, 0.45454545454545
9846, 0, 0.25434782608696, 0.40909090909091
9847, 0, 0.25434782608696, 0.36363636363636
9848, 0, 0.25434782608696, 0.31818181818182
9849, 0, 0.25434782608696, 0.27272727272727
9850, 0, 0.25434782608696, 0.22727272727273
9851, 0, 0.25434782608696, 0.18181818181818
9852, 0, 0.25434782608696, 0.13636363636364
9853, 0, 0.25434782608696, 0.090909090909091
9854, 0, 0.25434782608696, 0.045454545454545
9855, 0, 0.30652173913043, 0.45454545454545
9856, 0, 0.30652173913043, 0.40909090909091
9857, 0, 0.30652173913043, 0.36363636363636
9858, 0, 0.30652173913043, 0.31818181818182
9859, 0, 0.30652173913043, 0.27272727272727
9860, 0, 0.30652173913043, 0.22727272727273
9861, 0, 0.30652173913043, 0.18181818181818
9862, 0, 0.30652173913043, 0.13636363636364
9863, 0, 0.30652173913043, 0.090909090909091
9864, 0, 0.30652173913043, 0.045454545454545
9865, 0, 0.35869565217391, 0.45454545454545
9866, 0, 0.35869565217391, 0.40909090909091
9867, 0, 0.35869565217391, 0.36363636363636
9868, 0, 0.35869565217391, 0.31818181818182
9869, 0, 0.35869565217391, 0.27272727272727
9870, 0, 0.35869565217391, 0.22727272727273
9871, 0, 0.35869565217391, 0.18181818181818
9872, 0, 0.35869565217391, 0.13636363636364
9873, 0, 0.35869565217391, 0.090909090909091
9874, 0, 0.35869565217391, 0.045454545454545
9875, 0, 0.41086956521739, 0.45454545454545
9876, 0, 0.41086956521739, 0.40909090909091
9877, 0, 0.41086956521739, 0.36363636363636
9878, 0, 0.41086956521739, 0.31818181818182
9879, 0, 0.41086956521739, 0.27272727272727
9880, 0, 0.41086956521739, 0.22727272727273
9881, 0, 0.41086956521739, 0.18181818181818
9882, 0, 0.41086956521739, 0.13636363636364
9883, 0, 0.41086956521739, 0.090909090909091
9884, 0, 0.41086956521739, 0.045454545454545
9885, 0, 0.46304347826087, 0.45454545454545
9886, 0, 0.46304347826087, 0.40909090909091
9887, 0, 0.46304347826087, 0.36363636363636
9888, 0, 0.46304347826087, 0.31818181818182
9889, 0, 0.46304347826087, 0.27272727272727
9890, 0, 0.46304347826087, 0.22727272727273
9891, 0, 0.46304347826087, 0.18181818181818
9892, 0, 0.46304347826087, 0.13636363636364
9893, 0, 0.46304347826087, 0.090909090909091
9894, 0, 0.46304347826087, 0.045454545454545
9895, 0, 0.51521739130435, 0.45454545454545
9896, 0, 0.51521739130435, 0.40909090909091
9897, 0, 0.51521739130435, 0.36363636363636
9898, 0, 0.51521739130435, 0.31818181818182
9899, 0, 0.51521739130435, 0.27272727272727
9900, 0, 0.51521739130435, 0.22727272727273
9901, 0, 0.51521739130435, 0.18181818181818
9902, 0, 0.51521739130435, 0.13636363636364
9903, 0, 0.51521739130435, 0.090909090909091
9904, 0, 0.51521739130435, 0.045454545454545
9905, 0, 0.56739130434783, 0.45454545454545
9906, 0, 0.56739130434783, 0.40909090909091
9907, 0, 0.56739130434783, 0.36363636363636
9908, 0, 0.56739130434783, 0.31818181818182
9909, 0, 0.56739130434783, 0.27272727272727
9910, 0, 0.56739130434783, 0.22727272727273
9911, 0, 0.56739130434783, 0.18181818181818
9912, 0, 0.56739130434783, 0.13636363636364
9913, 0, 0.56739130434783, 0.090909090909091
9914, 0, 0.56739130434783, 0.045454545454545
9915, 0, 0.6195652173913, 0.45454545454545
9916, 0, 0.6195652173913, 0.40909090909091
9917, 0, 0.6195652173913, 0.36363636363636
9918, 0, 0.6195652173913, 0.31818181818182
9919, 0, 0.6195652173913, 0.27272727272727
9920, 0, 0.6195652173913, 0.22727272727273
9921, 0, 0.6195652173913, 0.18181818181818
9922, 0, 0.6195652173913, 0.13636363636364
9923, 0, 0.6195652173913, 0.090909090909091
9924, 0, 0.6195652173913, 0.045454545454545
9925, 0, 0.67173913043478, 0.45454545454545
9926, 0, 0.67173913043478, 0.40909090909091
9927, 0, 0.67173913043478, 0.36363636363636
9928, 0, 0.67173913043478, 0.31818181818182
9929, 0, 0.67173913043478, 0.27272727272727
9930, 0, 0.67173913043478, 0.22727272727273
9931, 0, 0.67173913043478, 0.18181818181818
9932, 0, 0.67173913043478, 0.13636363636364
9933, 0, 0.67173913043478, 0.090909090909091
9934, 0, 0.67173913043478, 0.045454545454545
9935, 0, 0.72391304347826, 0.45454545454545
9936, 0, 0.72391304347826, 0.40909090909091
9937, 0, 0.72391304347826, 0.36363636363636
9938, 0, 0.72391304347826, 0.31818181818182
9939, 0, 0.72391304347826, 0.27272727272727
9940, 0, 0.72391304347826, 0.22727272727273
9941, 0, 0.72391304347826, 0.18181818181818
9942, 0, 0.72391304347826, 0.13636363636364
9943, 0, 0.72391304347826, 0.090909090909091
9944, 0, 0.72391304347826, 0.045454545454545
9945, 0, 0.77608695652174, 0.45454545454545
9946, 0, 0.77608695652174, 0.40909090909091
9947, 0, 0.77608695652174, 0.36363636363636
9948, 0, 0.77608695652174, 0.31818181818182
9949, 0, 0.77608695652174, 0.27272727272727
9950, 0, 0.77608695652174, 0.22727272727273
9951, 0, 0.77608695652174, 0.18181818181818
9952, 0, 0.77608695652174, 0.13636363636364
9953, 0, 0.77608695652174, 0.090909090909091
9954, 0, 0.77608695652174, 0.045454545454545
9955, 0, 0.82826086956522, 0.45454545454545
9956, 0, 0.82826086956522, 0.40909090909091
9957, 0, 0.82826086956522, 0.36363636363636
9958, 0, 0.82826086956522, 0.31818181818182
9959, 0, 0.82826086956522, 0.27272727272727
9960, 0, 0.82826086956522, 0.22727272727273
9961, 0, 0.82826086956522, 0.18181818181818
9962, 0, 0.82826086956522, 0.13636363636364
9963, 0, 0.82826086956522, 0.090909090909091
9964, 0, 0.82826086956522, 0.045454545454545
9965, 0, 0.8804347826087, 0.45454545454545
9966, 0, 0.8804347826087, 0.40909090909091
9967, 0, 0.8804347826087, 0.36363636363636
9968, 0, 0.8804347826087, 0.31818181818182
9969, 0, 0.8804347826087, 0.27272727272727
9970, 0, 0.8804347826087, 0.22727272727273
9971, 0, 0.8804347826087, 0.18181818181818
9972, 0, 0.8804347826087, 0.13636363636364
9973, 0, 0.8804347826087, 0.090909090909091
9974, 0, 0.8804347826087, 0.045454545454545
9975, 0, 0.93260869565217, 0.45454545454545
9976, 0, 0.93260869565217, 0.40909090909091
9977, 0, 0.93260869565217, 0.36363636363636
9978, 0, 0.93260869565217, 0.31818181818182
9979, 0, 0.93260869565217, 0.27272727272727
9980, 0, 0.93260869565217, 0.22727272727273
9981, 0, 0.93260869565217, 0.18181818181818
9982, 0, 0.93260869565217, 0.13636363636364
9983, 0, 0.93260869565217, 0.090909090909091
9984, 0, 0.93260869565217, 0.045454545454545
9985, 0, 0.98478260869565, 0.45454545454545
9986, 0, 0.98478260869565, 0.40909090909091
9987, 0, 0.98478260869565, 0.36363636363636
9988, 0, 0.98478260869565, 0.31818181818182
9989, 0, 0.98478260869565, 0.27272727272727
9990, 0, 0.98478260869565, 0.22727272727273
9991, 0, 0.98478260869565, 0.18181818181818
9992, 0, 0.98478260869565, 0.13636363636364
9993, 0, 0.98478260869565, 0.090909090909091
9994, 0, 0.98478260869565, 0.045454545454545
9995, 0, 1.0369565217391, 0.45454545454545
9996, 0, 1.0369565217391, 0.40909090909091
9997, 0, 1.0369565217391, 0.36363636363636
9998, 0, 1.0369565217391, 0.31818181818182
9999, 0, 1.0369565217391, 0.27272727272727
10000, 0, 1.0369565217391, 0.22727272727273
10001, 0, 1.0369565217391, 0.18181818181818
10002, 0, 1.0369565217391, 0.13636363636364
10003, 0, 1.0369565217391, 0.090909090909091
10004, 0, 1.0369565217391, 0.045454545454545
10005, 0, 1.0891304347826, 0.45454545454545
10006, 0, 1.0891304347826, 0.40909090909091
10007, 0, 1.0891304347826, 0.36363636363636
10008, 0, 1.0891304347826, 0.31818181818182
10009, 0, 1.0891304347826, 0.27272727272727
10010, 0, 1.0891304347826, 0.22727272727273
10011, 0, 1.0891304347826, 0.18181818181818
10012, 0, 1.0891304347826, 0.13636363636364
10013, 0, 1.0891304347826, 0.090909090909091
10014, 0, 1.0891304347826, 0.045454545454545
10015, 0, 1.1413043478261, 0.45454545454545
10016, 0, 1.1413043478261, 0.40909090909091
10017, 0, 1.1413043478261, 0.36363636363636
10018, 0, 1.1413043478261, 0.31818181818182
10019, 0, 1.1413043478261, 0.27272727272727
10020, 0, 1.1413043478261, 0.22727272727273
10021, 0, 1.1413043478261, 0.18181818181818
10022, 0, 1.1413043478261, 0.13636363636364
10023, 0, 1.1413043478261, 0.090909090909091
10024, 0, 1.1413043478261, 0.045454545454545
10025, 0, 1.1934782608696, 0.45454545454545
10026, 0, 1.1934782608696, 0.40909090909091
10027, 0, 1.1934782608696, 0.36363636363636
10028, 0, 1.1934782608696, 0.31818181818182
10029, 0, 1.1934782608696, 0.27272727272727
10030, 0, 1.1934782608696, 0.22727272727273
10031, 0, 1.1934782608696, 0.18181818181818
10032, 0, 1.1934782608696, 0.13636363636364
10033, 0, 1.1934782608696, 0.090909090909091
10034, 0, 1.1934782608696, 0.045454545454545
10035, 0, 1.245652173913, 0.45454545454545
10036, 0, 1.245652173913, 0.40909090909091
10037, 0, 1.245652173913, 0.36363636363636
10038, 0, 1.245652173913, 0.31818181818182
10039, 0, 1.245652173913, 0.27272727272727
10040, 0, 1.245652173913, 0.22727272727273
10041, 0, 1.245652173913, 0.18181818181818
10042, 0, 1.245652173913, 0.13636363636364
10043, 0, 1.245652173913, 0.090909090909091
10044, 0, 1.245652173913, 0.045454545454545
10045, 0, 1.2978260869565, 0.45454545454545
10046, 0, 1.2978260869565, 0.40909090909091
10047, 0, 1.2978260869565, 0.36363636363636
10048, 0, 1.2978260869565, 0.31818181818182
10049, 0, 1.2978260869565, 0.27272727272727
10050, 0, 1.2978260869565, 0.22727272727273
10051, 0, 1.2978260869565, 0.18181818181818
10052, 0, 1.2978260869565, 0.13636363636364
10053, 0, 1.2978260869565, 0.090909090909091
10054, 0, 1.2978260869565, 0.045454545454545
10055, 0, 0.20217391304348, 0.47727272727273
10056, 0, 0.17608695652174, 0.45454545454545
10057, 0, 0.20217391304348, 0.43181818181818
10058, 0, 0.17608695652174, 0.40909090909091
10059, 0, 0.20217391304348, 0.38636363636364
10060, 0, 0.17608695652174, 0.36363636363636
10061, 0, 0.20217391304348, 0.34090909090909
10062, 0, 0.17608695652174, 0.31818181818182
10063, 0, 0.20217391304348, 0.29545454545455
10064, 0, 0.17608695652174, 0.27272727272727
10065, 0, 0.20217391304348, 0.25
10066, 0, 0.17608695652174, 0.22727272727273
10067, 0, 0.20217391304348, 0.20454545454545
10068, 0, 0.17608695652174, 0.18181818181818
10069, 0, 0.20217391304348, 0.15909090909091
10070, 0, 0.17608695652174, 0.13636363636364
10071, 0, 0.20217391304348, 0.11363636363636
10072, 0, 0.17608695652174, 0.090909090909091
10073, 0, 0.20217391304348, 0.068181818181818
10074, 0, 0.17608695652174, 0.045454545454545
10075, 0, 0.20217391304348, 0.022727272727273
10076, 0, 0.25434782608696, 0.47727272727273
10077, 0, 0.22826086956522, 0.45454545454545
10078, 0, 0.25434782608696, 0.43181818181818
10079, 0, 0.22826086956522, 0.40909090909091
10080, 0, 0.25434782608696, 0.38636363636364
10081, 0, 0.22826086956522, 0.36363636363636
10082, 0, 0.25434782608696, 0.34090909090909
10083, 0, 0.22826086956522, 0.31818181818182
10084, 0, 0.25434782608696, 0.29545454545455
10085, 0, 0.22826086956522, 0.27272727272727
10086, 0, 0.25434782608696, 0.25
10087, 0, 0.22826086956522, 0.22727272727273
10088, 0, 0.25434782608696, 0.20454545454545
10089, 0, 0.22826086956522, 0.18181818181818
10090, 0, 0.25434782608696, 0.15909090909091
10091, 0, 0.22826086956522, 0.13636363636364
10092, 0, 0.25434782608696, 0.11363636363636
10093, 0, 0.22826086956522, 0.090909090909091
10094, 0, 0.25434782608696, 0.068181818181818
10095, 0, 0.22826086956522, 0.045454545454545
10096, 0, 0.25434782608696, 0.022727272727273
10097, 0, 0.30652173913043, 0.47727272727273
10098, 0, 0.2804347826087, 0.45454545454545
10099, 0, 0.30652173913043, 0.43181818181818
10100, 0, 0.2804347826087, 0.40909090909091
10101, 0, 0.30652173913043, 0.38636363636364
10102, 0, 0.2804347826087, 0.36363636363636
10103, 0, 0.30652173913043, 0.34090909090909
10104, 0, 0.2804347826087, 0.31818181818182
10105, 0, 0.30652173913043, 0.29545454545455
10106, 0, 0.2804347826087, 0.27272727272727
10107, 0, 0.30652173913043, 0.25
10108, 0, 0.2804347826087, 0.22727272727273
10109, 0, 0.30652173913043, 0.20454545454545
10110, 0, 0.2804347826087, 0.18181818181818
10111, 0, 0.30652173913043, 0.15909090909091
10112, 0, 0.2804347826087, 0.13636363636364
10113, 0, 0.30652173913043, 0.11363636363636
10114, 0, 0.2804347826087, 0.090909090909091
10115, 0, 0.30652173913043, 0.068181818181818
10116, 0, 0.2804347826087, 0.045454545454545
10117, 0, 0.30652173913043, 0.022727272727273
10118, 0, 0.35869565217391, 0.47727272727273
10119, 0, 0.33260869565217, 0.45454545454545
10120, 0, 0.35869565217391, 0.43181818181818
10121, 0, 0.33260869565217, 0.40909090909091
10122, 0, 0.35869565217391, 0.38636363636364
10123, 0, 0.33260869565217, 0.36363636363636
10124, 0, 0.35869565217391, 0.34090909090909
10125, 0, 0.33260869565217, 0.31818181818182
10126, 0, 0.35869565217391, 0.29545454545455
10127, 0, 0.33260869565217, 0.27272727272727
10128, 0, 0.35869565217391, 0.25
10129, 0, 0.33260869565217, 0.22727272727273
10130, 0, 0.35869565217391, 0.20454545454545
10131, 0, 0.33260869565217, 0.18181818181818
10132, 0, 0.35869565217391, 0.15909090909091
10133, 0, 0.33260869565217, 0.13636363636364
10134, 0, 0.35869565217391, 0.11363636363636
10135, 0, 0.33260869565217, 0.090909090909091
10136, 0, 0.35869565217391, 0.068181818181818
10137, 0, 0.33260869565217, 0.045454545454545
10138, 0, 0.35869565217391, 0.022727272727273
10139, 0, 0.41086956521739, 0.47727272727273
10140, 0, 0.38478260869565, 0.45454545454545
10141, 0, 0.41086956521739, 0.43181818181818
10142, 0, 0.38478260869565, 0.40909090909091
10143, 0, 0.41086956521739, 0.38636363636364
10144, 0, 0.38478260869565, 0.36363636363636
10145, 0, 0.41086956521739, 0.34090909090909
10146, 0, 0.38478260869565, 0.31818181818182
10147, 0, 0.41086956521739, 0.29545454545455
10148, 0, 0.38478260869565, 0.27272727272727
10149, 0, 0.41086956521739, 0.25
