14684, 2.1130434782609, 1.4, 0.20454545454545
14685, 2.0913043478261, 1.4, 0.13636363636364
14686, 2.1130434782609, 1.4, 0.15909090909091
14687, 2.0913043478261, 1.4, 0.090909090909091
14688, 2.1130434782609, 1.4, 0.11363636363636
14689, 2.0913043478261, 1.4, 0.045454545454545
14690, 2.1130434782609, 1.4, 0.068181818181818
14691, 2.1130434782609, 1.4, 0.022727272727273
14692, 2.1347826086957, 1.4, 0.45454545454545
14693, 2.1565217391304, 1.4, 0.47727272727273
14694, 2.1347826086957, 1.4, 0.40909090909091
14695, 2.1565217391304, 1.4, 0.43181818181818
14696, 2.1347826086957, 1.4, 0.36363636363636
14697, 2.1565217391304, 1.4, 0.38636363636364
14698, 2.1347826086957, 1.4, 0.31818181818182
14699, 2.1565217391304, 1.4, 0.34090909090909
14700, 2.1347826086957, 1.4, 0.27272727272727
14701, 2.1565217391304, 1.4, 0.29545454545455
14702, 2.1347826086957, 1.4, 0.22727272727273
14703, 2.1565217391304, 1.4, 0.25
14704, 2.1347826086957, 1.4, 0.18181818181818
14705, 2.1565217391304, 1.4, 0.20454545454545
14706, 2.1347826086957, 1.4, 0.13636363636364
14707, 2.1565217391304, 1.4, 0.15909090909091
14708, 2.1347826086957, 1.4, 0.090909090909091
14709, 2.1565217391304, 1.4, 0.11363636363636
14710, 2.1347826086957, 1.4, 0.045454545454545
14711, 2.1565217391304, 1.4, 0.068181818181818
14712, 2.1565217391304, 1.4, 0.022727272727273
14713, 2.1782608695652, 1.4, 0.45454545454545
14714, 2.1782608695652, 1.4, 0.40909090909091
14715, 2.1782608695652, 1.4, 0.36363636363636
14716, 2.1782608695652, 1.4, 0.31818181818182
14717, 2.1782608695652, 1.4, 0.27272727272727
14718, 2.1782608695652, 1.4, 0.22727272727273
14719, 2.1782608695652, 1.4, 0.18181818181818
14720, 2.1782608695652, 1.4, 0.13636363636364
14721, 2.1782608695652, 1.4, 0.090909090909091
14722, 2.1782608695652, 1.4, 0.045454545454545
14723, 1.2434782608696, 1.5, 0.45454545454545
14724, 1.2434782608696, 1.5, 0.40909090909091
14725, 1.2434782608696, 1.5, 0.36363636363636
14726, 1.2434782608696, 1.5, 0.31818181818182
14727, 1.2434782608696, 1.5, 0.27272727272727
14728, 1.2434782608696, 1.5, 0.22727272727273
14729, 1.2434782608696, 1.5, 0.18181818181818
14730, 1.2434782608696, 1.5, 0.13636363636364
14731, 1.2434782608696, 1.5, 0.090909090909091
14732, 1.2434782608696, 1.5, 0.045454545454545
14733, 1.2869565217391, 1.5, 0.45454545454545
14734, 1.2869565217391, 1.5, 0.40909090909091
14735, 1.2869565217391, 1.5, 0.36363636363636
14736, 1.2869565217391, 1.5, 0.31818181818182
14737, 1.2869565217391, 1.5, 0.27272727272727
14738, 1.2869565217391, 1.5, 0.22727272727273
14739, 1.2869565217391, 1.5, 0.18181818181818
14740, 1.2869565217391, 1.5, 0.13636363636364
14741, 1.2869565217391, 1.5, 0.090909090909091
14742, 1.2869565217391, 1.5, 0.045454545454545
14743, 1.3304347826087, 1.5, 0.45454545454545
14744, 1.3304347826087, 1.5, 0.40909090909091
14745, 1.3304347826087, 1.5, 0.36363636363636
14746, 1.3304347826087, 1.5, 0.31818181818182
14747, 1.3304347826087, 1.5, 0.27272727272727
14748, 1.3304347826087, 1.5, 0.22727272727273
14749, 1.3304347826087, 1.5, 0.18181818181818
14750, 1.3304347826087, 1.5, 0.13636363636364
14751, 1.3304347826087, 1.5, 0.090909090909091
14752, 1.3304347826087, 1.5, 0.045454545454545
14753, 1.3739130434783, 1.5, 0.45454545454545
14754, 1.3739130434783, 1.5, 0.40909090909091
14755, 1.3739130434783, 1.5, 0.36363636363636
14756, 1.3739130434783, 1.5, 0.31818181818182
14757, 1.3739130434783, 1.5, 0.27272727272727
14758, 1.3739130434783, 1.5, 0.22727272727273
14759, 1.3739130434783, 1.5, 0.18181818181818
14760, 1.3739130434783, 1.5, 0.13636363636364
14761, 1.3739130434783, 1.5, 0.090909090909091
14762, 1.3739130434783, 1.5, 0.045454545454545
14763, 1.4173913043478, 1.5, 0.45454545454545
14764, 1.4173913043478, 1.5, 0.40909090909091
14765, 1.4173913043478, 1.5, 0.36363636363636
14766, 1.4173913043478, 1.5, 0.31818181818182
14767, 1.4173913043478, 1.5, 0.27272727272727
14768, 1.4173913043478, 1.5, 0.22727272727273
14769, 1.4173913043478, 1.5, 0.18181818181818
14770, 1.4173913043478, 1.5, 0.13636363636364
14771, 1.4173913043478, 1.5, 0.090909090909091
14772, 1.4173913043478, 1.5, 0.045454545454545
14773, 1.4608695652174, 1.5, 0.45454545454545
14774, 1.4608695652174, 1.5, 0.40909090909091
14775, 1.4608695652174, 1.5, 0.36363636363636
14776, 1.4608695652174, 1.5, 0.31818181818182
14777, 1.4608695652174, 1.5, 0.27272727272727
14778, 1.4608695652174, 1.5, 0.22727272727273
14779, 1.4608695652174, 1.5, 0.18181818181818
14780, 1.4608695652174, 1.5, 0.13636363636364
14781, 1.4608695652174, 1.5, 0.090909090909091
14782, 1.4608695652174, 1.5, 0.045454545454545
14783, 1.504347826087, 1.5, 0.45454545454545
14784, 1.504347826087, 1.5, 0.40909090909091
14785, 1.504347826087, 1.5, 0.36363636363636
14786, 1.504347826087, 1.5, 0.31818181818182
14787, 1.504347826087, 1.5, 0.27272727272727
14788, 1.504347826087, 1.5, 0.22727272727273
14789, 1.504347826087, 1.5, 0.18181818181818
14790, 1.504347826087, 1.5, 0.13636363636364
14791, 1.504347826087, 1.5, 0.090909090909091
14792, 1.504347826087, 1.5, 0.045454545454545
14793, 1.5478260869565, 1.5, 0.45454545454545
14794, 1.5478260869565, 1.5, 0.40909090909091
14795, 1.5478260869565, 1.5, 0.36363636363636
14796, 1.5478260869565, 1.5, 0.31818181818182
14797, 1.5478260869565, 1.5, 0.27272727272727
14798, 1.5478260869565, 1.5, 0.22727272727273
14799, 1.5478260869565, 1.5, 0.18181818181818
14800, 1.5478260869565, 1.5, 0.13636363636364
14801, 1.5478260869565, 1.5, 0.090909090909091
14802, 1.5478260869565, 1.5, 0.045454545454545
14803, 1.5913043478261, 1.5, 0.45454545454545
14804, 1.5913043478261, 1.5, 0.40909090909091
14805, 1.5913043478261, 1.5, 0.36363636363636
14806, 1.5913043478261, 1.5, 0.31818181818182
14807, 1.5913043478261, 1.5, 0.27272727272727
14808, 1.5913043478261, 1.5, 0.22727272727273
14809, 1.5913043478261, 1.5, 0.18181818181818
14810, 1.5913043478261, 1.5, 0.13636363636364
14811, 1.5913043478261, 1.5, 0.090909090909091
14812, 1.5913043478261, 1.5, 0.045454545454545
14813, 1.6347826086957, 1.5, 0.45454545454545
14814, 1.6347826086957, 1.5, 0.40909090909091
14815, 1.6347826086957, 1.5, 0.36363636363636
14816, 1.6347826086957, 1.5, 0.31818181818182
14817, 1.6347826086957, 1.5, 0.27272727272727
14818, 1.6347826086957, 1.5, 0.22727272727273
14819, 1.6347826086957, 1.5, 0.18181818181818
14820, 1.6347826086957, 1.5, 0.13636363636364
14821, 1.6347826086957, 1.5, 0.090909090909091
14822, 1.6347826086957, 1.5, 0.045454545454545
14823, 1.6782608695652, 1.5, 0.45454545454545
14824, 1.6782608695652, 1.5, 0.40909090909091
14825, 1.6782608695652, 1.5, 0.36363636363636
14826, 1.6782608695652, 1.5, 0.31818181818182
14827, 1.6782608695652, 1.5, 0.27272727272727
14828, 1.6782608695652, 1.5, 0.22727272727273
14829, 1.6782608695652, 1.5, 0.18181818181818
14830, 1.6782608695652, 1.5, 0.13636363636364
14831, 1.6782608695652, 1.5, 0.090909090909091
14832, 1.6782608695652, 1.5, 0.045454545454545
14833, 1.7217391304348, 1.5, 0.45454545454545
14834, 1.7217391304348, 1.5, 0.40909090909091
14835, 1.7217391304348, 1.5, 0.36363636363636
14836, 1.7217391304348, 1.5, 0.31818181818182
14837, 1.7217391304348, 1.5, 0.27272727272727
14838, 1.7217391304348, 1.5, 0.22727272727273
14839, 1.7217391304348, 1.5, 0.18181818181818
14840, 1.7217391304348, 1.5, 0.13636363636364
14841, 1.7217391304348, 1.5, 0.090909090909091
14842, 1.7217391304348, 1.5, 0.045454545454545
14843, 1.7652173913043, 1.5, 0.45454545454545
14844, 1.7652173913043, 1.5, 0.40909090909091
14845, 1.7652173913043, 1.5, 0.36363636363636
14846, 1.7652173913043, 1.5, 0.31818181818182
14847, 1.7652173913043, 1.5, 0.27272727272727
14848, 1.7652173913043, 1.5, 0.22727272727273
14849, 1.7652173913043, 1.5, 0.18181818181818
14850, 1.7652173913043, 1.5, 0.13636363636364
14851, 1.7652173913043, 1.5, 0.090909090909091
14852, 1.7652173913043, 1.5, 0.045454545454545
14853, 1.8086956521739, 1.5, 0.45454545454545
14854, 1.8086956521739, 1.5, 0.40909090909091
14855, 1.8086956521739, 1.5, 0.36363636363636
14856, 1.8086956521739, 1.5, 0.31818181818182
14857, 1.8086956521739, 1.5, 0.27272727272727
14858, 1.8086956521739, 1.5, 0.22727272727273
14859, 1.8086956521739, 1.5, 0.18181818181818
14860, 1.8086956521739, 1.5, 0.13636363636364
14861, 1.8086956521739, 1.5, 0.090909090909091
14862, 1.8086956521739, 1.5, 0.045454545454545
14863, 1.8521739130435, 1.5, 0.45454545454545
14864, 1.8521739130435, 1.5, 0.40909090909091
14865, 1.8521739130435, 1.5, 0.36363636363636
14866, 1.8521739130435, 1.5, 0.31818181818182
14867, 1.8521739130435, 1.5, 0.27272727272727
14868, 1.8521739130435, 1.5, 0.22727272727273
14869, 1.8521739130435, 1.5, 0.18181818181818
14870, 1.8521739130435, 1.5, 0.13636363636364
14871, 1.8521739130435, 1.5, 0.090909090909091
14872, 1.8521739130435, 1.5, 0.045454545454545
14873, 1.895652173913, 1.5, 0.45454545454545
14874, 1.895652173913, 1.5, 0.40909090909091
14875, 1.895652173913, 1.5, 0.36363636363636
14876, 1.895652173913, 1.5, 0.31818181818182
14877, 1.895652173913, 1.5, 0.27272727272727
14878, 1.895652173913, 1.5, 0.22727272727273
14879, 1.895652173913, 1.5, 0.18181818181818
14880, 1.895652173913, 1.5, 0.13636363636364
14881, 1.895652173913, 1.5, 0.090909090909091
14882, 1.895652173913, 1.5, 0.045454545454545
14883, 1.9391304347826, 1.5, 0.45454545454545
14884, 1.9391304347826, 1.5, 0.40909090909091
14885, 1.9391304347826, 1.5, 0.36363636363636
14886, 1.9391304347826, 1.5, 0.31818181818182
14887, 1.9391304347826, 1.5, 0.27272727272727
14888, 1.9391304347826, 1.5, 0.22727272727273
14889, 1.9391304347826, 1.5, 0.18181818181818
14890, 1.9391304347826, 1.5, 0.13636363636364
14891, 1.9391304347826, 1.5, 0.090909090909091
14892, 1.9391304347826, 1.5, 0.045454545454545
14893, 1.9826086956522, 1.5, 0.45454545454545
14894, 1.9826086956522, 1.5, 0.40909090909091
14895, 1.9826086956522, 1.5, 0.36363636363636
14896, 1.9826086956522, 1.5, 0.31818181818182
14897, 1.9826086956522, 1.5, 0.27272727272727
14898, 1.9826086956522, 1.5, 0.22727272727273
14899, 1.9826086956522, 1.5, 0.18181818181818
14900, 1.9826086956522, 1.5, 0.13636363636364
14901, 1.9826086956522, 1.5, 0.090909090909091
14902, 1.9826086956522, 1.5, 0.045454545454545
14903, 2.0260869565217, 1.5, 0.45454545454545
14904, 2.0260869565217, 1.5, 0.40909090909091
14905, 2.0260869565217, 1.5, 0.36363636363636
14906, 2.0260869565217, 1.5, 0.31818181818182
14907, 2.0260869565217, 1.5, 0.27272727272727
14908, 2.0260869565217, 1.5, 0.22727272727273
14909, 2.0260869565217, 1.5, 0.18181818181818
14910, 2.0260869565217, 1.5, 0.13636363636364
14911, 2.0260869565217, 1.5, 0.090909090909091
14912, 2.0260869565217, 1.5, 0.045454545454545
14913, 2.0695652173913, 1.5, 0.45454545454545
14914, 2.0695652173913, 1.5, 0.40909090909091
14915, 2.0695652173913, 1.5, 0.36363636363636
14916, 2.0695652173913, 1.5, 0.31818181818182
14917, 2.0695652173913, 1.5, 0.27272727272727
14918, 2.0695652173913, 1.5, 0.22727272727273
14919, 2.0695652173913, 1.5, 0.18181818181818
14920, 2.0695652173913, 1.5, 0.13636363636364
14921, 2.0695652173913, 1.5, 0.090909090909091
14922, 2.0695652173913, 1.5, 0.045454545454545
14923, 2.1130434782609, 1.5, 0.45454545454545
14924, 2.1130434782609, 1.5, 0.40909090909091
14925, 2.1130434782609, 1.5, 0.36363636363636
14926, 2.1130434782609, 1.5, 0.31818181818182
14927, 2.1130434782609, 1.5, 0.27272727272727
14928, 2.1130434782609, 1.5, 0.22727272727273
14929, 2.1130434782609, 1.5, 0.18181818181818
14930, 2.1130434782609, 1.5, 0.13636363636364
14931, 2.1130434782609, 1.5, 0.090909090909091
14932, 2.1130434782609, 1.5, 0.045454545454545
14933, 2.1565217391304, 1.5, 0.45454545454545
14934, 2.1565217391304, 1.5, 0.40909090909091
14935, 2.1565217391304, 1.5, 0.36363636363636
14936, 2.1565217391304, 1.5, 0.31818181818182
14937, 2.1565217391304, 1.5, 0.27272727272727
14938, 2.1565217391304, 1.5, 0.22727272727273
14939, 2.1565217391304, 1.5, 0.18181818181818
14940, 2.1565217391304, 1.5, 0.13636363636364
14941, 2.1565217391304, 1.5, 0.090909090909091
14942, 2.1565217391304, 1.5, 0.045454545454545
14943, 1.2434782608696, 1.5, 0.47727272727273
14944, 1.2217391304348, 1.5, 0.45454545454545
14945, 1.2434782608696, 1.5, 0.43181818181818
14946, 1.2217391304348, 1.5, 0.40909090909091
14947, 1.2434782608696, 1.5, 0.38636363636364
14948, 1.2217391304348, 1.5, 0.36363636363636
14949, 1.2434782608696, 1.5, 0.34090909090909
14950, 1.2217391304348, 1.5, 0.31818181818182
14951, 1.2434782608696, 1.5, 0.29545454545455
14952, 1.2217391304348, 1.5, 0.27272727272727
14953, 1.2434782608696, 1.5, 0.25
14954, 1.2217391304348, 1.5, 0.22727272727273
14955, 1.2434782608696, 1.5, 0.20454545454545
14956, 1.2217391304348, 1.5, 0.18181818181818
14957, 1.2434782608696, 1.5, 0.15909090909091
14958, 1.2217391304348, 1.5, 0.13636363636364
14959, 1.2434782608696, 1.5, 0.11363636363636
14960, 1.2217391304348, 1.5, 0.090909090909091
14961, 1.2434782608696, 1.5, 0.068181818181818
14962, 1.2217391304348, 1.5, 0.045454545454545
14963, 1.2434782608696, 1.5, 0.022727272727273
14964, 1.2869565217391, 1.5, 0.47727272727273
14965, 1.2652173913043, 1.5, 0.45454545454545
14966, 1.2869565217391, 1.5, 0.43181818181818
14967, 1.2652173913043, 1.5, 0.40909090909091
14968, 1.2869565217391, 1.5, 0.38636363636364
14969, 1.2652173913043, 1.5, 0.36363636363636
14970, 1.2869565217391, 1.5, 0.34090909090909
14971, 1.2652173913043, 1.5, 0.31818181818182
14972, 1.2869565217391, 1.5, 0.29545454545455
14973, 1.2652173913043, 1.5, 0.27272727272727
14974, 1.2869565217391, 1.5, 0.25
14975, 1.2652173913043, 1.5, 0.22727272727273
14976, 1.2869565217391, 1.5, 0.20454545454545
14977, 1.2652173913043, 1.5, 0.18181818181818
14978, 1.2869565217391, 1.5, 0.15909090909091
14979, 1.2652173913043, 1.5, 0.13636363636364
14980, 1.2869565217391, 1.5, 0.11363636363636
14981, 1.2652173913043, 1.5, 0.090909090909091
14982, 1.2869565217391, 1.5, 0.068181818181818
14983, 1.2652173913043, 1.5, 0.045454545454545
14984, 1.2869565217391, 1.5, 0.022727272727273
14985, 1.3304347826087, 1.5, 0.47727272727273
14986, 1.3086956521739, 1.5, 0.45454545454545
14987, 1.3304347826087, 1.5, 0.43181818181818
14988, 1.3086956521739, 1.5, 0.40909090909091
14989, 1.3304347826087, 1.5, 0.38636363636364
14990, 1.3086956521739, 1.5, 0.36363636363636
14991, 1.3304347826087, 1.5, 0.34090909090909
14992, 1.3086956521739, 1.5, 0.31818181818182
14993, 1.3304347826087, 1.5, 0.29545454545455
14994, 1.3086956521739, 1.5, 0.27272727272727
14995, 1.3304347826087, 1.5, 0.25
14996, 1.3086956521739, 1.5, 0.22727272727273
14997, 1.3304347826087, 1.5, 0.20454545454545
14998, 1.3086956521739, 1.5, 0.18181818181818
14999, 1.3304347826087, 1.5, 0.15909090909091
15000, 1.3086956521739, 1.5, 0.13636363636364
15001, 1.3304347826087, 1.5, 0.11363636363636
15002, 1.3086956521739, 1.5, 0.090909090909091
15003, 1.3304347826087, 1.5, 0.068181818181818
15004, 1.3086956521739, 1.5, 0.045454545454545
15005, 1.3304347826087, 1.5, 0.022727272727273
15006, 1.3739130434783, 1.5, 0.47727272727273
15007, 1.3521739130435, 1.5, 0.45454545454545
15008, 1.3739130434783, 1.5, 0.43181818181818
15009, 1.3521739130435, 1.5, 0.40909090909091
15010, 1.3739130434783, 1.5, 0.38636363636364
15011, 1.3521739130435, 1.5, 0.36363636363636
15012, 1.3739130434783, 1.5, 0.34090909090909
15013, 1.3521739130435, 1.5, 0.31818181818182
15014, 1.3739130434783, 1.5, 0.29545454545455
15015, 1.3521739130435, 1.5, 0.27272727272727
15016, 1.3739130434783, 1.5, 0.25
15017, 1.3521739130435, 1.5, 0.22727272727273
15018, 1.3739130434783, 1.5, 0.20454545454545
15019, 1.3521739130435, 1.5, 0.18181818181818
15020, 1.3739130434783, 1.5, 0.15909090909091
15021, 1.3521739130435, 1.5, 0.13636363636364
15022, 1.3739130434783, 1.5, 0.11363636363636
15023, 1.3521739130435, 1.5, 0.090909090909091
15024, 1.3739130434783, 1.5, 0.068181818181818
15025, 1.3521739130435, 1.5, 0.045454545454545
15026, 1.3739130434783, 1.5, 0.022727272727273
15027, 1.4173913043478, 1.5, 0.47727272727273
15028, 1.395652173913, 1.5, 0.45454545454545
15029, 1.4173913043478, 1.5, 0.43181818181818
15030, 1.395652173913, 1.5, 0.40909090909091
15031, 1.4173913043478, 1.5, 0.38636363636364
15032, 1.395652173913, 1.5, 0.36363636363636
15033, 1.4173913043478, 1.5, 0.34090909090909
15034, 1.395652173913, 1.5, 0.31818181818182
15035, 1.4173913043478, 1.5, 0.29545454545455
15036, 1.395652173913, 1.5, 0.27272727272727
15037, 1.4173913043478, 1.5, 0.25
15038, 1.395652173913, 1.5, 0.22727272727273
15039, 1.4173913043478, 1.5, 0.20454545454545
15040, 1.395652173913, 1.5, 0.18181818181818
15041, 1.4173913043478, 1.5, 0.15909090909091
15042, 1.395652173913, 1.5, 0.13636363636364
15043, 1.4173913043478, 1.5, 0.11363636363636
15044, 1.395652173913, 1.5, 0.090909090909091
15045, 1.4173913043478, 1.5, 0.068181818181818
15046, 1.395652173913, 1.5, 0.045454545454545
15047, 1.4173913043478, 1.5, 0.022727272727273
15048, 1.4608695652174, 1.5, 0.47727272727273
15049, 1.4391304347826, 1.5, 0.45454545454545
15050, 1.4608695652174, 1.5, 0.43181818181818
15051, 1.4391304347826, 1.5, 0.40909090909091
15052, 1.4608695652174, 1.5, 0.38636363636364
15053, 1.4391304347826, 1.5, 0.36363636363636
15054, 1.4608695652174, 1.5, 0.34090909090909
15055, 1.4391304347826, 1.5, 0.31818181818182
15056, 1.4608695652174, 1.5, 0.29545454545455
15057, 1.4391304347826, 1.5, 0.27272727272727
15058, 1.4608695652174, 1.5, 0.25
15059, 1.4391304347826, 1.5, 0.22727272727273
15060, 1.4608695652174, 1.5, 0.20454545454545
15061, 1.4391304347826, 1.5, 0.18181818181818
15062, 1.4608695652174, 1.5, 0.15909090909091
15063, 1.4391304347826, 1.5, 0.13636363636364
15064, 1.4608695652174, 1.5, 0.11363636363636
15065, 1.4391304347826, 1.5, 0.090909090909091
15066, 1.4608695652174, 1.5, 0.068181818181818
15067, 1.4391304347826, 1.5, 0.045454545454545
15068, 1.4608695652174, 1.5, 0.022727272727273
15069, 1.504347826087, 1.5, 0.47727272727273
15070, 1.4826086956522, 1.5, 0.45454545454545
15071, 1.504347826087, 1.5, 0.43181818181818
15072, 1.4826086956522, 1.5, 0.40909090909091
15073, 1.504347826087, 1.5, 0.38636363636364
15074, 1.4826086956522, 1.5, 0.36363636363636
15075, 1.504347826087, 1.5, 0.34090909090909
15076, 1.4826086956522, 1.5, 0.31818181818182
15077, 1.504347826087, 1.5, 0.29545454545455
15078, 1.4826086956522, 1.5, 0.27272727272727
15079, 1.504347826087, 1.5, 0.25
15080, 1.4826086956522, 1.5, 0.22727272727273
15081, 1.504347826087, 1.5, 0.20454545454545
15082, 1.4826086956522, 1.5, 0.18181818181818
15083, 1.504347826087, 1.5, 0.15909090909091
15084, 1.4826086956522, 1.5, 0.13636363636364
15085, 1.504347826087, 1.5, 0.11363636363636
15086, 1.4826086956522, 1.5, 0.090909090909091
15087, 1.504347826087, 1.5, 0.068181818181818
15088, 1.4826086956522, 1.5, 0.045454545454545
15089, 1.504347826087, 1.5, 0.022727272727273
15090, 1.5478260869565, 1.5, 0.47727272727273
15091, 1.5260869565217, 1.5, 0.45454545454545
15092, 1.5478260869565, 1.5, 0.43181818181818
15093, 1.5260869565217, 1.5, 0.40909090909091
15094, 1.5478260869565, 1.5, 0.38636363636364
15095, 1.5260869565217, 1.5, 0.36363636363636
15096, 1.5478260869565, 1.5, 0.34090909090909
15097, 1.5260869565217, 1.5, 0.31818181818182
15098, 1.5478260869565, 1.5, 0.29545454545455
15099, 1.5260869565217, 1.5, 0.27272727272727
15100, 1.5478260869565, 1.5, 0.25
15101, 1.5260869565217, 1.5, 0.22727272727273
15102, 1.5478260869565, 1.5, 0.20454545454545
15103, 1.5260869565217, 1.5, 0.18181818181818
15104, 1.5478260869565, 1.5, 0.15909090909091
15105, 1.5260869565217, 1.5, 0.13636363636364
15106, 1.5478260869565, 1.5, 0.11363636363636
15107, 1.5260869565217, 1.5, 0.090909090909091
15108, 1.5478260869565, 1.5, 0.068181818181818
15109, 1.5260869565217, 1.5, 0.045454545454545
15110, 1.5478260869565, 1.5, 0.022727272727273
15111, 1.5913043478261, 1.5, 0.47727272727273
15112, 1.5695652173913, 1.5, 0.45454545454545
15113, 1.5913043478261, 1.5, 0.43181818181818
15114, 1.5695652173913, 1.5, 0.40909090909091
15115, 1.5913043478261, 1.5, 0.38636363636364
15116, 1.5695652173913, 1.5, 0.36363636363636
15117, 1.5913043478261, 1.5, 0.34090909090909
15118, 1.5695652173913, 1.5, 0.31818181818182
15119, 1.5913043478261, 1.5, 0.29545454545455
15120, 1.5695652173913, 1.5, 0.27272727272727
15121, 1.5913043478261, 1.5, 0.25
15122, 1.5695652173913, 1.5, 0.22727272727273
15123, 1.5913043478261, 1.5, 0.20454545454545
15124, 1.5695652173913, 1.5, 0.18181818181818
15125, 1.5913043478261, 1.5, 0.15909090909091
15126, 1.5695652173913, 1.5, 0.13636363636364
15127, 1.5913043478261, 1.5, 0.11363636363636
15128, 1.5695652173913, 1.5, 0.090909090909091
15129, 1.5913043478261, 1.5, 0.068181818181818
15130, 1.5695652173913, 1.5, 0.045454545454545
15131, 1.5913043478261, 1.5, 0.022727272727273
15132, 1.6347826086957, 1.5, 0.47727272727273
15133, 1.6130434782609, 1.5, 0.45454545454545
15134, 1.6347826086957, 1.5, 0.43181818181818
15135, 1.6130434782609, 1.5, 0.40909090909091
15136, 1.6347826086957, 1.5, 0.38636363636364
15137, 1.6130434782609, 1.5, 0.36363636363636
15138, 1.6347826086957, 1.5, 0.34090909090909
15139, 1.6130434782609, 1.5, 0.31818181818182
15140, 1.6347826086957, 1.5, 0.29545454545455
15141, 1.6130434782609, 1.5, 0.27272727272727
15142, 1.6347826086957, 1.5, 0.25
15143, 1.6130434782609, 1.5, 0.22727272727273
15144, 1.6347826086957, 1.5, 0.20454545454545
15145, 1.6130434782609, 1.5, 0.18181818181818
15146, 1.6347826086957, 1.5, 0.15909090909091
15147, 1.6130434782609, 1.5, 0.13636363636364
15148, 1.6347826086957, 1.5, 0.11363636363636
15149, 1.6130434782609, 1.5, 0.090909090909091
15150, 1.6347826086957, 1.5, 0.068181818181818
15151, 1.6130434782609, 1.5, 0.045454545454545
15152, 1.6347826086957, 1.5, 0.022727272727273
15153, 1.6782608695652, 1.5, 0.47727272727273
15154, 1.6565217391304, 1.5, 0.45454545454545
15155, 1.6782608695652, 1.5, 0.43181818181818
15156, 1.6565217391304, 1.5, 0.40909090909091
15157, 1.6782608695652, 1.5, 0.38636363636364
15158, 1.6565217391304, 1.5, 0.36363636363636
15159, 1.6782608695652, 1.5, 0.34090909090909
15160, 1.6565217391304, 1.5, 0.31818181818182
15161, 1.6782608695652, 1.5, 0.29545454545455
15162, 1.6565217391304, 1.5, 0.27272727272727
15163, 1.6782608695652, 1.5, 0.25
15164, 1.6565217391304, 1.5, 0.22727272727273
15165, 1.6782608695652, 1.5, 0.20454545454545
15166, 1.6565217391304, 1.5, 0.18181818181818
15167, 1.6782608695652, 1.5, 0.15909090909091
15168, 1.6565217391304, 1.5, 0.13636363636364
15169, 1.6782608695652, 1.5, 0.11363636363636
15170, 1.6565217391304, 1.5, 0.090909090909091
15171, 1.6782608695652, 1.5, 0.068181818181818
15172, 1.6565217391304, 1.5, 0.045454545454545
15173, 1.6782608695652, 1.5, 0.022727272727273
15174, 1.7217391304348, 1.5, 0.47727272727273
15175, 1.7, 1.5, 0.45454545454545
15176, 1.7217391304348, 1.5, 0.43181818181818
15177, 1.7, 1.5, 0.40909090909091
15178, 1.7217391304348, 1.5, 0.38636363636364
15179, 1.7, 1.5, 0.36363636363636
15180, 1.7217391304348, 1.5, 0.34090909090909
15181, 1.7, 1.5, 0.31818181818182
15182, 1.7217391304348, 1.5, 0.29545454545455
15183, 1.7, 1.5, 0.27272727272727
15184, 1.7217391304348, 1.5, 0.25
15185, 1.7, 1.5, 0.22727272727273
15186, 1.7217391304348, 1.5, 0.20454545454545
15187, 1.7, 1.5, 0.18181818181818
15188, 1.7217391304348, 1.5, 0.15909090909091
15189, 1.7, 1.5, 0.13636363636364
15190, 1.7217391304348, 1.5, 0.11363636363636
15191, 1.7, 1.5, 0.090909090909091
15192, 1.7217391304348, 1.5, 0.068181818181818
15193, 1.7, 1.5, 0.045454545454545
15194, 1.7217391304348, 1.5, 0.022727272727273
15195, 1.7652173913043, 1.5, 0.47727272727273
15196, 1.7434782608696, 1.5, 0.45454545454545
15197, 1.7652173913043, 1.5, 0.43181818181818
15198, 1.7434782608696, 1.5, 0.40909090909091
15199, 1.7652173913043, 1.5, 0.38636363636364
15200, 1.7434782608696, 1.5, 0.36363636363636
15201, 1.7652173913043, 1.5, 0.34090909090909
15202, 1.7434782608696, 1.5, 0.31818181818182
15203, 1.7652173913043, 1.5, 0.29545454545455
15204, 1.7434782608696, 1.5, 0.27272727272727
15205, 1.7652173913043, 1.5, 0.25
15206, 1.7434782608696, 1.5, 0.22727272727273
15207, 1.7652173913043, 1.5, 0.20454545454545
15208, 1.7434782608696, 1.5, 0.18181818181818
15209, 1.7652173913043, 1.5, 0.15909090909091
15210, 1.7434782608696, 1.5, 0.13636363636364
15211, 1.7652173913043, 1.5, 0.11363636363636
15212, 1.7434782608696, 1.5, 0.090909090909091
15213, 1.7652173913043, 1.5, 0.068181818181818
15214, 1.7434782608696, 1.5, 0.045454545454545
15215, 1.7652173913043, 1.5, 0.022727272727273
15216, 1.8086956521739, 1.5, 0.47727272727273
15217, 1.7869565217391, 1.5, 0.45454545454545
15218, 1.8086956521739, 1.5, 0.43181818181818
15219, 1.7869565217391, 1.5, 0.40909090909091
15220, 1.8086956521739, 1.5, 0.38636363636364
15221, 1.7869565217391, 1.5, 0.36363636363636
15222, 1.8086956521739, 1.5, 0.34090909090909
15223, 1.7869565217391, 1.5, 0.31818181818182
15224, 1.8086956521739, 1.5, 0.29545454545455
15225, 1.7869565217391, 1.5, 0.27272727272727
15226, 1.8086956521739, 1.5, 0.25
15227, 1.7869565217391, 1.5, 0.22727272727273
15228, 1.8086956521739, 1.5, 0.20454545454545
15229, 1.7869565217391, 1.5, 0.18181818181818
15230, 1.8086956521739, 1.5, 0.15909090909091
15231, 1.7869565217391, 1.5, 0.13636363636364
15232, 1.8086956521739, 1.5, 0.11363636363636
15233, 1.7869565217391, 1.5, 0.090909090909091
15234, 1.8086956521739, 1.5, 0.068181818181818
15235, 1.7869565217391, 1.5, 0.045454545454545
15236, 1.8086956521739, 1.5, 0.022727272727273
15237, 1.8521739130435, 1.5, 0.47727272727273
15238, 1.8304347826087, 1.5, 0.45454545454545
15239, 1.8521739130435, 1.5, 0.43181818181818
15240, 1.8304347826087, 1.5, 0.40909090909091
15241, 1.8521739130435, 1.5, 0.38636363636364
15242, 1.8304347826087, 1.5, 0.36363636363636
15243, 1.8521739130435, 1.5, 0.34090909090909
15244, 1.8304347826087, 1.5, 0.31818181818182
15245, 1.8521739130435, 1.5, 0.29545454545455
15246, 1.8304347826087, 1.5, 0.27272727272727
15247, 1.8521739130435, 1.5, 0.25
15248, 1.8304347826087, 1.5, 0.22727272727273
15249, 1.8521739130435, 1.5, 0.20454545454545
15250, 1.8304347826087, 1.5, 0.18181818181818
15251, 1.8521739130435, 1.5, 0.15909090909091
15252, 1.8304347826087, 1.5, 0.13636363636364
15253, 1.8521739130435, 1.5, 0.11363636363636
15254, 1.8304347826087, 1.5, 0.090909090909091
15255, 1.8521739130435, 1.5, 0.068181818181818
15256, 1.8304347826087, 1.5, 0.045454545454545
15257, 1.8521739130435, 1.5, 0.022727272727273
15258, 1.895652173913, 1.5, 0.47727272727273
15259, 1.8739130434783, 1.5, 0.45454545454545
15260, 1.895652173913, 1.5, 0.43181818181818
15261, 1.8739130434783, 1.5, 0.40909090909091
15262, 1.895652173913, 1.5, 0.38636363636364
15263, 1.8739130434783, 1.5, 0.36363636363636
15264, 1.895652173913, 1.5, 0.34090909090909
15265, 1.8739130434783, 1.5, 0.31818181818182
15266, 1.895652173913, 1.5, 0.29545454545455
15267, 1.8739130434783, 1.5, 0.27272727272727
15268, 1.895652173913, 1.5, 0.25
15269, 1.8739130434783, 1.5, 0.22727272727273
15270, 1.895652173913, 1.5, 0.20454545454545
15271, 1.8739130434783, 1.5, 0.18181818181818
15272, 1.895652173913, 1.5, 0.15909090909091
15273, 1.8739130434783, 1.5, 0.13636363636364
15274, 1.895652173913, 1.5, 0.11363636363636
15275, 1.8739130434783, 1.5, 0.090909090909091
15276, 1.895652173913, 1.5, 0.068181818181818
15277, 1.8739130434783, 1.5, 0.045454545454545
15278, 1.895652173913, 1.5, 0.022727272727273
15279, 1.9391304347826, 1.5, 0.47727272727273
15280, 1.9173913043478, 1.5, 0.45454545454545
15281, 1.9391304347826, 1.5, 0.43181818181818
15282, 1.9173913043478, 1.5, 0.40909090909091
15283, 1.9391304347826, 1.5, 0.38636363636364
15284, 1.9173913043478, 1.5, 0.36363636363636
15285, 1.9391304347826, 1.5, 0.34090909090909
15286, 1.9173913043478, 1.5, 0.31818181818182
15287, 1.9391304347826, 1.5, 0.29545454545455
15288, 1.9173913043478, 1.5, 0.27272727272727
15289, 1.9391304347826, 1.5, 0.25
15290, 1.9173913043478, 1.5, 0.22727272727273
15291, 1.9391304347826, 1.5, 0.20454545454545
15292, 1.9173913043478, 1.5, 0.18181818181818
15293, 1.9391304347826, 1.5, 0.15909090909091
15294, 1.9173913043478, 1.5, 0.13636363636364
15295, 1.9391304347826, 1.5, 0.11363636363636
15296, 1.9173913043478, 1.5, 0.090909090909091
15297, 1.9391304347826, 1.5, 0.068181818181818
15298, 1.9173913043478, 1.5, 0.045454545454545
15299, 1.9391304347826, 1.5, 0.022727272727273
15300, 1.9826086956522, 1.5, 0.47727272727273
15301, 1.9608695652174, 1.5, 0.45454545454545
15302, 1.9826086956522, 1.5, 0.43181818181818
15303, 1.9608695652174, 1.5, 0.40909090909091
15304, 1.9826086956522, 1.5, 0.38636363636364
15305, 1.9608695652174, 1.5, 0.36363636363636
15306, 1.9826086956522, 1.5, 0.34090909090909
15307, 1.9608695652174, 1.5, 0.31818181818182
15308, 1.9826086956522, 1.5, 0.29545454545455
15309, 1.9608695652174, 1.5, 0.27272727272727
15310, 1.9826086956522, 1.5, 0.25
15311, 1.9608695652174, 1.5, 0.22727272727273
15312, 1.9826086956522, 1.5, 0.20454545454545
15313, 1.9608695652174, 1.5, 0.18181818181818
15314, 1.9826086956522, 1.5, 0.15909090909091
15315, 1.9608695652174, 1.5, 0.13636363636364
15316, 1.9826086956522, 1.5, 0.11363636363636
15317, 1.9608695652174, 1.5, 0.090909090909091
15318, 1.9826086956522, 1.5, 0.068181818181818
15319, 1.9608695652174, 1.5, 0.045454545454545
15320, 1.9826086956522, 1.5, 0.022727272727273
15321, 2.0260869565217, 1.5, 0.47727272727273
15322, 2.004347826087, 1.5, 0.45454545454545
15323, 2.0260869565217, 1.5, 0.43181818181818
15324, 2.004347826087, 1.5, 0.40909090909091
15325, 2.0260869565217, 1.5, 0.38636363636364
15326, 2.004347826087, 1.5, 0.36363636363636
15327, 2.0260869565217, 1.5, 0.34090909090909
15328, 2.004347826087, 1.5, 0.31818181818182
15329, 2.0260869565217, 1.5, 0.29545454545455
15330, 2.004347826087, 1.5, 0.27272727272727
15331, 2.0260869565217, 1.5, 0.25
15332, 2.004347826087, 1.5, 0.22727272727273
15333, 2.0260869565217, 1.5, 0.20454545454545
15334, 2.004347826087, 1.5, 0.18181818181818
15335, 2.0260869565217, 1.5, 0.15909090909091
15336, 2.004347826087, 1.5, 0.13636363636364
15337, 2.0260869565217, 1.5, 0.11363636363636
15338, 2.004347826087, 1.5, 0.090909090909091
15339, 2.0260869565217, 1.5, 0.068181818181818
15340, 2.004347826087, 1.5, 0.045454545454545
15341, 2.0260869565217, 1.5, 0.022727272727273
15342, 2.0695652173913, 1.5, 0.47727272727273
15343, 2.0478260869565, 1.5, 0.45454545454545
15344, 2.0695652173913, 1.5, 0.43181818181818
15345, 2.0478260869565, 1.5, 0.40909090909091
15346, 2.0695652173913, 1.5, 0.38636363636364
15347, 2.0478260869565, 1.5, 0.36363636363636
15348, 2.0695652173913, 1.5, 0.34090909090909
15349, 2.0478260869565, 1.5, 0.31818181818182
15350, 2.0695652173913, 1.5, 0.29545454545455
15351, 2.0478260869565, 1.5, 0.27272727272727
15352, 2.0695652173913, 1.5, 0.25
15353, 2.0478260869565, 1.5, 0.22727272727273
15354, 2.0695652173913, 1.5, 0.20454545454545
15355, 2.0478260869565, 1.5, 0.18181818181818
15356, 2.0695652173913, 1.5, 0.15909090909091
15357, 2.0478260869565, 1.5, 0.13636363636364
15358, 2.0695652173913, 1.5, 0.11363636363636
15359, 2.0478260869565, 1.5, 0.090909090909091
15360, 2.0695652173913, 1.5, 0.068181818181818
15361, 2.0478260869565, 1.5, 0.045454545454545
15362, 2.0695652173913, 1.5, 0.022727272727273
15363, 2.1130434782609, 1.5, 0.47727272727273
15364, 2.0913043478261, 1.5, 0.45454545454545
15365, 2.1130434782609, 1.5, 0.43181818181818
15366, 2.0913043478261, 1.5, 0.40909090909091
15367, 2.1130434782609, 1.5, 0.38636363636364
15368, 2.0913043478261, 1.5, 0.36363636363636
15369, 2.1130434782609, 1.5, 0.34090909090909
15370, 2.0913043478261, 1.5, 0.31818181818182
15371, 2.1130434782609, 1.5, 0.29545454545455
15372, 2.0913043478261, 1.5, 0.27272727272727
15373, 2.1130434782609, 1.5, 0.25
15374, 2.0913043478261, 1.5, 0.22727272727273
15375, 2.1130434782609, 1.5, 0.20454545454545
15376, 2.0913043478261, 1.5, 0.18181818181818
15377, 2.1130434782609, 1.5, 0.15909090909091
15378, 2.0913043478261, 1.5, 0.13636363636364
15379, 2.1130434782609, 1.5, 0.11363636363636
15380, 2.0913043478261, 1.5, 0.090909090909091
15381, 2.1130434782609, 1.5, 0.068181818181818
15382, 2.0913043478261, 1.5, 0.045454545454545
15383, 2.1130434782609, 1.5, 0.022727272727273
15384, 2.1565217391304, 1.5, 0.47727272727273
15385, 2.1347826086957, 1.5, 0.45454545454545
15386, 2.1565217391304, 1.5, 0.43181818181818
15387, 2.1347826086957, 1.5, 0.40909090909091
15388, 2.1565217391304, 1.5, 0.38636363636364
15389, 2.1347826086957, 1.5, 0.36363636363636
15390, 2.1565217391304, 1.5, 0.34090909090909
15391, 2.1347826086957, 1.5, 0.31818181818182
15392, 2.1565217391304, 1.5, 0.29545454545455
15393, 2.1347826086957, 1.5, 0.27272727272727
15394, 2.1565217391304, 1.5, 0.25
15395, 2.1347826086957, 1.5, 0.22727272727273
15396, 2.1565217391304, 1.5, 0.20454545454545
15397, 2.1347826086957, 1.5, 0.18181818181818
15398, 2.1565217391304, 1.5, 0.15909090909091
15399, 2.1347826086957, 1.5, 0.13636363636364
15400, 2.1565217391304, 1.5, 0.11363636363636
15401, 2.1347826086957, 1.5, 0.090909090909091
15402, 2.1565217391304, 1.5, 0.068181818181818
15403, 2.1347826086957, 1.5, 0.045454545454545
15404, 2.1565217391304, 1.5, 0.022727272727273
15405, 2.1782608695652, 1.5, 0.45454545454545
15406, 2.1782608695652, 1.5, 0.40909090909091
15407, 2.1782608695652, 1.5, 0.36363636363636
15408, 2.1782608695652, 1.5, 0.31818181818182
15409, 2.1782608695652, 1.5, 0.27272727272727
15410, 2.1782608695652, 1.5, 0.22727272727273
15411, 2.1782608695652, 1.5, 0.18181818181818
15412, 2.1782608695652, 1.5, 0.13636363636364
15413, 2.1782608695652, 1.5, 0.090909090909091
15414, 2.1782608695652, 1.5, 0.045454545454545
15415, 2.2, 1.4333333333333, 0.45454545454545
15416, 2.2, 1.4333333333333, 0.40909090909091
15417, 2.2, 1.4333333333333, 0.36363636363636
15418, 2.2, 1.4333333333333, 0.31818181818182
15419, 2.2, 1.4333333333333, 0.27272727272727
15420, 2.2, 1.4333333333333, 0.22727272727273
15421, 2.2, 1.4333333333333, 0.18181818181818
15422, 2.2, 1.4333333333333, 0.13636363636364
15423, 2.2, 1.4333333333333, 0.090909090909091
15424, 2.2, 1.4333333333333, 0.045454545454545
15425, 2.2, 1.4666666666667, 0.45454545454545
15426, 2.2, 1.4666666666667, 0.40909090909091
15427, 2.2, 1.4666666666667, 0.36363636363636
15428, 2.2, 1.4666666666667, 0.31818181818182
15429, 2.2, 1.4666666666667, 0.27272727272727
15430, 2.2, 1.4666666666667, 0.22727272727273
15431, 2.2, 1.4666666666667, 0.18181818181818
15432, 2.2, 1.4666666666667, 0.13636363636364
15433, 2.2, 1.4666666666667, 0.090909090909091
15434, 2.2, 1.4666666666667, 0.045454545454545
15435, 2.2, 1.4166666666667, 0.45454545454545
15436, 2.2, 1.4333333333333, 0.47727272727273
15437, 2.2, 1.4166666666667, 0.40909090909091
15438, 2.2, 1.4333333333333, 0.43181818181818
15439, 2.2, 1.4166666666667, 0.36363636363636
15440, 2.2, 1.4333333333333, 0.38636363636364
15441, 2.2, 1.4166666666667, 0.31818181818182
15442, 2.2, 1.4333333333333, 0.34090909090909
15443, 2.2, 1.4166666666667, 0.27272727272727
15444, 2.2, 1.4333333333333, 0.29545454545455
15445, 2.2, 1.4166666666667, 0.22727272727273
15446, 2.2, 1.4333333333333, 0.25
15447, 2.2, 1.4166666666667, 0.18181818181818
15448, 2.2, 1.4333333333333, 0.20454545454545
15449, 2.2, 1.4166666666667, 0.13636363636364
15450, 2.2, 1.4333333333333, 0.15909090909091
15451, 2.2, 1.4166666666667, 0.090909090909091
15452, 2.2, 1.4333333333333, 0.11363636363636
15453, 2.2, 1.4166666666667, 0.045454545454545
15454, 2.2, 1.4333333333333, 0.068181818181818
15455, 2.2, 1.4333333333333, 0.022727272727273
15456, 2.2, 1.45, 0.45454545454545
15457, 2.2, 1.4666666666667, 0.47727272727273
15458, 2.2, 1.45, 0.40909090909091
15459, 2.2, 1.4666666666667, 0.43181818181818
15460, 2.2, 1.45, 0.36363636363636
15461, 2.2, 1.4666666666667, 0.38636363636364
15462, 2.2, 1.45, 0.31818181818182
15463, 2.2, 1.4666666666667, 0.34090909090909
15464, 2.2, 1.45, 0.27272727272727
15465, 2.2, 1.4666666666667, 0.29545454545455
15466, 2.2, 1.45, 0.22727272727273
15467, 2.2, 1.4666666666667, 0.25
15468, 2.2, 1.45, 0.18181818181818
15469, 2.2, 1.4666666666667, 0.20454545454545
15470, 2.2, 1.45, 0.13636363636364
15471, 2.2, 1.4666666666667, 0.15909090909091
15472, 2.2, 1.45, 0.090909090909091
15473, 2.2, 1.4666666666667, 0.11363636363636
15474, 2.2, 1.45, 0.045454545454545
15475, 2.2, 1.4666666666667, 0.068181818181818
15476, 2.2, 1.4666666666667, 0.022727272727273
15477, 2.2, 1.4833333333333, 0.45454545454545
15478, 2.2, 1.4833333333333, 0.40909090909091
15479, 2.2, 1.4833333333333, 0.36363636363636
15480, 2.2, 1.4833333333333, 0.31818181818182
15481, 2.2, 1.4833333333333, 0.27272727272727
15482, 2.2, 1.4833333333333, 0.22727272727273
15483, 2.2, 1.4833333333333, 0.18181818181818
15484, 2.2, 1.4833333333333, 0.13636363636364
15485, 2.2, 1.4833333333333, 0.090909090909091
15486, 2.2, 1.4833333333333, 0.045454545454545
15487, 1.2434782608696, 1.375, 0.5
15488, 1.2869565217391, 1.375, 0.5
15489, 1.3304347826087, 1.375, 0.5
15490, 1.3739130434783, 1.375, 0.5
15491, 1.4173913043478, 1.375, 0.5
15492, 1.4608695652174, 1.375, 0.5
15493, 1.504347826087, 1.375, 0.5
15494, 1.5478260869565, 1.375, 0.5
15495, 1.5913043478261, 1.375, 0.5
15496, 1.6347826086957, 1.375, 0.5
15497, 1.6782608695652, 1.375, 0.5
15498, 1.7217391304348, 1.375, 0.5
15499, 1.7652173913043, 1.375, 0.5
15500, 1.8086956521739, 1.375, 0.5
15501, 1.8521739130435, 1.375, 0.5
15502, 1.895652173913, 1.375, 0.5
15503, 1.9391304347826, 1.375, 0.5
15504, 1.9826086956522, 1.375, 0.5
15505, 2.0260869565217, 1.375, 0.5
15506, 2.0695652173913, 1.375, 0.5
15507, 2.1130434782609, 1.375, 0.5
15508, 2.1565217391304, 1.375, 0.5
15509, 1.2217391304348, 1.375, 0.5
15510, 1.2434782608696, 1.3875, 0.5
15511, 1.2652173913043, 1.375, 0.5
15512, 1.2869565217391, 1.3875, 0.5
15513, 1.3086956521739, 1.375, 0.5
15514, 1.3304347826087, 1.3875, 0.5
15515, 1.3521739130435, 1.375, 0.5
15516, 1.3739130434783, 1.3875, 0.5
15517, 1.395652173913, 1.375, 0.5
15518, 1.4173913043478, 1.3875, 0.5
15519, 1.4391304347826, 1.375, 0.5
15520, 1.4608695652174, 1.3875, 0.5
15521, 1.4826086956522, 1.375, 0.5
15522, 1.504347826087, 1.3875, 0.5
15523, 1.5260869565217, 1.375, 0.5
15524, 1.5478260869565, 1.3875, 0.5
15525, 1.5695652173913, 1.375, 0.5
15526, 1.5913043478261, 1.3875, 0.5
15527, 1.6130434782609, 1.375, 0.5
15528, 1.6347826086957, 1.3875, 0.5
15529, 1.6565217391304, 1.375, 0.5
15530, 1.6782608695652, 1.3875, 0.5
15531, 1.7, 1.375, 0.5
15532, 1.7217391304348, 1.3875, 0.5
15533, 1.7434782608696, 1.375, 0.5
15534, 1.7652173913043, 1.3875, 0.5
15535, 1.7869565217391, 1.375, 0.5
15536, 1.8086956521739, 1.3875, 0.5
15537, 1.8304347826087, 1.375, 0.5
15538, 1.8521739130435, 1.3875, 0.5
15539, 1.8739130434783, 1.375, 0.5
15540, 1.895652173913, 1.3875, 0.5
15541, 1.9173913043478, 1.375, 0.5
15542, 1.9391304347826, 1.3875, 0.5
15543, 1.9608695652174, 1.375, 0.5
15544, 1.9826086956522, 1.3875, 0.5
15545, 2.004347826087, 1.375, 0.5
15546, 2.0260869565217, 1.3875, 0.5
15547, 2.0478260869565, 1.375, 0.5
15548, 2.0695652173913, 1.3875, 0.5
15549, 2.0913043478261, 1.375, 0.5
15550, 2.1130434782609, 1.3875, 0.5
15551, 2.1347826086957, 1.375, 0.5
15552, 2.1565217391304, 1.3875, 0.5
15553, 2.1782608695652, 1.375, 0.5
15554, 1.2434782608696, 1.3625, 0.5
15555, 1.2869565217391, 1.3625, 0.5
15556, 1.3304347826087, 1.3625, 0.5
15557, 1.3739130434783, 1.3625, 0.5
15558, 1.4173913043478, 1.3625, 0.5
15559, 1.4608695652174, 1.3625, 0.5
15560, 1.504347826087, 1.3625, 0.5
15561, 1.5478260869565, 1.3625, 0.5
15562, 1.5913043478261, 1.3625, 0.5
15563, 1.6347826086957, 1.3625, 0.5
15564, 1.6782608695652, 1.3625, 0.5
15565, 1.7217391304348, 1.3625, 0.5
15566, 1.7652173913043, 1.3625, 0.5
15567, 1.8086956521739, 1.3625, 0.5
15568, 1.8521739130435, 1.3625, 0.5
15569, 1.895652173913, 1.3625, 0.5
15570, 1.9391304347826, 1.3625, 0.5
15571, 1.9826086956522, 1.3625, 0.5
15572, 2.0260869565217, 1.3625, 0.5
15573, 2.0695652173913, 1.3625, 0.5
15574, 2.1130434782609, 1.3625, 0.5
15575, 2.1565217391304, 1.3625, 0.5
15576, 1.2434782608696, 1.375, 0
15577, 1.2869565217391, 1.375, 0
15578, 1.3304347826087, 1.375, 0
15579, 1.3739130434783, 1.375, 0
15580, 1.4173913043478, 1.375, 0
15581, 1.4608695652174, 1.375, 0
15582, 1.504347826087, 1.375, 0
15583, 1.5478260869565, 1.375, 0
15584, 1.5913043478261, 1.375, 0
15585, 1.6347826086957, 1.375, 0
15586, 1.6782608695652, 1.375, 0
15587, 1.7217391304348, 1.375, 0
15588, 1.7652173913043, 1.375, 0
15589, 1.8086956521739, 1.375, 0
15590, 1.8521739130435, 1.375, 0
15591, 1.895652173913, 1.375, 0
15592, 1.9391304347826, 1.375, 0
15593, 1.9826086956522, 1.375, 0
15594, 2.0260869565217, 1.375, 0
15595, 2.0695652173913, 1.375, 0
15596, 2.1130434782609, 1.375, 0
15597, 2.1565217391304, 1.375, 0
15598, 1.2434782608696, 1.3875, 0
15599, 1.2217391304348, 1.375, 0
15600, 1.2869565217391, 1.3875, 0
15601, 1.2652173913043, 1.375, 0
15602, 1.3304347826087, 1.3875, 0
15603, 1.3086956521739, 1.375, 0
15604, 1.3739130434783, 1.3875, 0
15605, 1.3521739130435, 1.375, 0
15606, 1.4173913043478, 1.3875, 0
15607, 1.395652173913, 1.375, 0
15608, 1.4608695652174, 1.3875, 0
15609, 1.4391304347826, 1.375, 0
15610, 1.504347826087, 1.3875, 0
15611, 1.4826086956522, 1.375, 0
15612, 1.5478260869565, 1.3875, 0
15613, 1.5260869565217, 1.375, 0
15614, 1.5913043478261, 1.3875, 0
15615, 1.5695652173913, 1.375, 0
15616, 1.6347826086957, 1.3875, 0
15617, 1.6130434782609, 1.375, 0
15618, 1.6782608695652, 1.3875, 0
15619, 1.6565217391304, 1.375, 0
15620, 1.7217391304348, 1.3875, 0
15621, 1.7, 1.375, 0
15622, 1.7652173913043, 1.3875, 0
15623, 1.7434782608696, 1.375, 0
15624, 1.8086956521739, 1.3875, 0
15625, 1.7869565217391, 1.375, 0
15626, 1.8521739130435, 1.3875, 0
15627, 1.8304347826087, 1.375, 0
15628, 1.895652173913, 1.3875, 0
15629, 1.8739130434783, 1.375, 0
15630, 1.9391304347826, 1.3875, 0
15631, 1.9173913043478, 1.375, 0
15632, 1.9826086956522, 1.3875, 0
15633, 1.9608695652174, 1.375, 0
15634, 2.0260869565217, 1.3875, 0
15635, 2.004347826087, 1.375, 0
15636, 2.0695652173913, 1.3875, 0
15637, 2.0478260869565, 1.375, 0
15638, 2.1130434782609, 1.3875, 0
15639, 2.0913043478261, 1.375, 0
15640, 2.1565217391304, 1.3875, 0
15641, 2.1347826086957, 1.375, 0
15642, 2.1782608695652, 1.375, 0
15643, 1.2434782608696, 1.3625, 0
15644, 1.2869565217391, 1.3625, 0
15645, 1.3304347826087, 1.3625, 0
15646, 1.3739130434783, 1.3625, 0
15647, 1.4173913043478, 1.3625, 0
15648, 1.4608695652174, 1.3625, 0
15649, 1.504347826087, 1.3625, 0
15650, 1.5478260869565, 1.3625, 0
15651, 1.5913043478261, 1.3625, 0
15652, 1.6347826086957, 1.3625, 0
15653, 1.6782608695652, 1.3625, 0
15654, 1.7217391304348, 1.3625, 0
15655, 1.7652173913043, 1.3625, 0
15656, 1.8086956521739, 1.3625, 0
15657, 1.8521739130435, 1.3625, 0
15658, 1.895652173913, 1.3625, 0
15659, 1.9391304347826, 1.3625, 0
15660, 1.9826086956522, 1.3625, 0
15661, 2.0260869565217, 1.3625, 0
15662, 2.0695652173913, 1.3625, 0
15663, 2.1130434782609, 1.3625, 0
15664, 2.1565217391304, 1.3625, 0
15665, 1.2, 1.375, 0.45454545454545
15666, 1.2, 1.375, 0.40909090909091
15667, 1.2, 1.375, 0.36363636363636
15668, 1.2, 1.375, 0.31818181818182
15669, 1.2, 1.375, 0.27272727272727
15670, 1.2, 1.375, 0.22727272727273
15671, 1.2, 1.375, 0.18181818181818
15672, 1.2, 1.375, 0.13636363636364
15673, 1.2, 1.375, 0.090909090909091
15674, 1.2, 1.375, 0.045454545454545
15675, 1.2, 1.3875, 0.45454545454545
15676, 1.2, 1.375, 0.47727272727273
15677, 1.2, 1.3875, 0.40909090909091
15678, 1.2, 1.375, 0.43181818181818
15679, 1.2, 1.3875, 0.36363636363636
15680, 1.2, 1.375, 0.38636363636364
15681, 1.2, 1.3875, 0.31818181818182
15682, 1.2, 1.375, 0.34090909090909
15683, 1.2, 1.3875, 0.27272727272727
15684, 1.2, 1.375, 0.29545454545455
15685, 1.2, 1.3875, 0.22727272727273
15686, 1.2, 1.375, 0.25
15687, 1.2, 1.3875, 0.18181818181818
15688, 1.2, 1.375, 0.20454545454545
15689, 1.2, 1.3875, 0.13636363636364
15690, 1.2, 1.375, 0.15909090909091
15691, 1.2, 1.3875, 0.090909090909091
15692, 1.2, 1.375, 0.11363636363636
15693, 1.2, 1.3875, 0.045454545454545
15694, 1.2, 1.375, 0.068181818181818
15695, 1.2, 1.375, 0.022727272727273
15696, 1.2, 1.3625, 0.45454545454545
15697, 1.2, 1.3625, 0.40909090909091
15698, 1.2, 1.3625, 0.36363636363636
15699, 1.2, 1.3625, 0.31818181818182
15700, 1.2, 1.3625, 0.27272727272727
15701, 1.2, 1.3625, 0.22727272727273
15702, 1.2, 1.3625, 0.18181818181818
15703, 1.2, 1.3625, 0.13636363636364
15704, 1.2, 1.3625, 0.090909090909091
15705, 1.2, 1.3625, 0.045454545454545
15706, 2.2, 1.375, 0.45454545454545
15707, 2.2, 1.375, 0.40909090909091
15708, 2.2, 1.375, 0.36363636363636
15709, 2.2, 1.375, 0.31818181818182
15710, 2.2, 1.375, 0.27272727272727
15711, 2.2, 1.375, 0.22727272727273
15712, 2.2, 1.375, 0.18181818181818
15713, 2.2, 1.375, 0.13636363636364
15714, 2.2, 1.375, 0.090909090909091
15715, 2.2, 1.375, 0.045454545454545
15716, 2.2, 1.375, 0.47727272727273
15717, 2.2, 1.3875, 0.45454545454545
15718, 2.2, 1.375, 0.43181818181818
15719, 2.2, 1.3875, 0.40909090909091
15720, 2.2, 1.375, 0.38636363636364
15721, 2.2, 1.3875, 0.36363636363636
15722, 2.2, 1.375, 0.34090909090909
15723, 2.2, 1.3875, 0.31818181818182
15724, 2.2, 1.375, 0.29545454545455
15725, 2.2, 1.3875, 0.27272727272727
15726, 2.2, 1.375, 0.25
15727, 2.2, 1.3875, 0.22727272727273
15728, 2.2, 1.375, 0.20454545454545
15729, 2.2, 1.3875, 0.18181818181818
15730, 2.2, 1.375, 0.15909090909091
15731, 2.2, 1.3875, 0.13636363636364
15732, 2.2, 1.375, 0.11363636363636
15733, 2.2, 1.3875, 0.090909090909091
15734, 2.2, 1.375, 0.068181818181818
15735, 2.2, 1.3875, 0.045454545454545
15736, 2.2, 1.375, 0.022727272727273
15737, 2.2, 1.3625, 0.45454545454545
15738, 2.2, 1.3625, 0.40909090909091
15739, 2.2, 1.3625, 0.36363636363636
15740, 2.2, 1.3625, 0.31818181818182
15741, 2.2, 1.3625, 0.27272727272727
15742, 2.2, 1.3625, 0.22727272727273
15743, 2.2, 1.3625, 0.18181818181818
15744, 2.2, 1.3625, 0.13636363636364
15745, 2.2, 1.3625, 0.090909090909091
15746, 2.2, 1.3625, 0.045454545454545
15747, 1.2434782608696, 1.35, 0.45454545454545
15748, 1.2434782608696, 1.35, 0.40909090909091
15749, 1.2434782608696, 1.35, 0.36363636363636
15750, 1.2434782608696, 1.35, 0.31818181818182
15751, 1.2434782608696, 1.35, 0.27272727272727
15752, 1.2434782608696, 1.35, 0.22727272727273
15753, 1.2434782608696, 1.35, 0.18181818181818
15754, 1.2434782608696, 1.35, 0.13636363636364
15755, 1.2434782608696, 1.35, 0.090909090909091
15756, 1.2434782608696, 1.35, 0.045454545454545
15757, 1.2869565217391, 1.35, 0.45454545454545
15758, 1.2869565217391, 1.35, 0.40909090909091
15759, 1.2869565217391, 1.35, 0.36363636363636
15760, 1.2869565217391, 1.35, 0.31818181818182
15761, 1.2869565217391, 1.35, 0.27272727272727
15762, 1.2869565217391, 1.35, 0.22727272727273
15763, 1.2869565217391, 1.35, 0.18181818181818
15764, 1.2869565217391, 1.35, 0.13636363636364
15765, 1.2869565217391, 1.35, 0.090909090909091
15766, 1.2869565217391, 1.35, 0.045454545454545
15767, 1.3304347826087, 1.35, 0.45454545454545
15768, 1.3304347826087, 1.35, 0.40909090909091
15769, 1.3304347826087, 1.35, 0.36363636363636
15770, 1.3304347826087, 1.35, 0.31818181818182
15771, 1.3304347826087, 1.35, 0.27272727272727
15772, 1.3304347826087, 1.35, 0.22727272727273
15773, 1.3304347826087, 1.35, 0.18181818181818
15774, 1.3304347826087, 1.35, 0.13636363636364
15775, 1.3304347826087, 1.35, 0.090909090909091
15776, 1.3304347826087, 1.35, 0.045454545454545
15777, 1.3739130434783, 1.35, 0.45454545454545
15778, 1.3739130434783, 1.35, 0.40909090909091
15779, 1.3739130434783, 1.35, 0.36363636363636
15780, 1.3739130434783, 1.35, 0.31818181818182
15781, 1.3739130434783, 1.35, 0.27272727272727
15782, 1.3739130434783, 1.35, 0.22727272727273
15783, 1.3739130434783, 1.35, 0.18181818181818
15784, 1.3739130434783, 1.35, 0.13636363636364
15785, 1.3739130434783, 1.35, 0.090909090909091
15786, 1.3739130434783, 1.35, 0.045454545454545
15787, 1.4173913043478, 1.35, 0.45454545454545
15788, 1.4173913043478, 1.35, 0.40909090909091
15789, 1.4173913043478, 1.35, 0.36363636363636
15790, 1.4173913043478, 1.35, 0.31818181818182
15791, 1.4173913043478, 1.35, 0.27272727272727
15792, 1.4173913043478, 1.35, 0.22727272727273
15793, 1.4173913043478, 1.35, 0.18181818181818
15794, 1.4173913043478, 1.35, 0.13636363636364
15795, 1.4173913043478, 1.35, 0.090909090909091
15796, 1.4173913043478, 1.35, 0.045454545454545
15797, 1.4608695652174, 1.35, 0.45454545454545
15798, 1.4608695652174, 1.35, 0.40909090909091
15799, 1.4608695652174, 1.35, 0.36363636363636
15800, 1.4608695652174, 1.35, 0.31818181818182
15801, 1.4608695652174, 1.35, 0.27272727272727
15802, 1.4608695652174, 1.35, 0.22727272727273
15803, 1.4608695652174, 1.35, 0.18181818181818
15804, 1.4608695652174, 1.35, 0.13636363636364
15805, 1.4608695652174, 1.35, 0.090909090909091
15806, 1.4608695652174, 1.35, 0.045454545454545
15807, 1.504347826087, 1.35, 0.45454545454545
15808, 1.504347826087, 1.35, 0.40909090909091
15809, 1.504347826087, 1.35, 0.36363636363636
15810, 1.504347826087, 1.35, 0.31818181818182
15811, 1.504347826087, 1.35, 0.27272727272727
15812, 1.504347826087, 1.35, 0.22727272727273
15813, 1.504347826087, 1.35, 0.18181818181818
15814, 1.504347826087, 1.35, 0.13636363636364
15815, 1.504347826087, 1.35, 0.090909090909091
15816, 1.504347826087, 1.35, 0.045454545454545
15817, 1.5478260869565, 1.35, 0.45454545454545
15818, 1.5478260869565, 1.35, 0.40909090909091
15819, 1.5478260869565, 1.35, 0.36363636363636
15820, 1.5478260869565, 1.35, 0.31818181818182
15821, 1.5478260869565, 1.35, 0.27272727272727
15822, 1.5478260869565, 1.35, 0.22727272727273
15823, 1.5478260869565, 1.35, 0.18181818181818
15824, 1.5478260869565, 1.35, 0.13636363636364
15825, 1.5478260869565, 1.35, 0.090909090909091
15826, 1.5478260869565, 1.35, 0.045454545454545
15827, 1.5913043478261, 1.35, 0.45454545454545
15828, 1.5913043478261, 1.35, 0.40909090909091
15829, 1.5913043478261, 1.35, 0.36363636363636
15830, 1.5913043478261, 1.35, 0.31818181818182
15831, 1.5913043478261, 1.35, 0.27272727272727
15832, 1.5913043478261, 1.35, 0.22727272727273
15833, 1.5913043478261, 1.35, 0.18181818181818
15834, 1.5913043478261, 1.35, 0.13636363636364
15835, 1.5913043478261, 1.35, 0.090909090909091
15836, 1.5913043478261, 1.35, 0.045454545454545
15837, 1.6347826086957, 1.35, 0.45454545454545
15838, 1.6347826086957, 1.35, 0.40909090909091
15839, 1.6347826086957, 1.35, 0.36363636363636
15840, 1.6347826086957, 1.35, 0.31818181818182
15841, 1.6347826086957, 1.35, 0.27272727272727
15842, 1.6347826086957, 1.35, 0.22727272727273
15843, 1.6347826086957, 1.35, 0.18181818181818
15844, 1.6347826086957, 1.35, 0.13636363636364
15845, 1.6347826086957, 1.35, 0.090909090909091
15846, 1.6347826086957, 1.35, 0.045454545454545
15847, 1.6782608695652, 1.35, 0.45454545454545
15848, 1.6782608695652, 1.35, 0.40909090909091
15849, 1.6782608695652, 1.35, 0.36363636363636
15850, 1.6782608695652, 1.35, 0.31818181818182
15851, 1.6782608695652, 1.35, 0.27272727272727
15852, 1.6782608695652, 1.35, 0.22727272727273
15853, 1.6782608695652, 1.35, 0.18181818181818
15854, 1.6782608695652, 1.35, 0.13636363636364
15855, 1.6782608695652, 1.35, 0.090909090909091
15856, 1.6782608695652, 1.35, 0.045454545454545
15857, 1.7217391304348, 1.35, 0.45454545454545
15858, 1.7217391304348, 1.35, 0.40909090909091
15859, 1.7217391304348, 1.35, 0.36363636363636
15860, 1.7217391304348, 1.35, 0.31818181818182
15861, 1.7217391304348, 1.35, 0.27272727272727
15862, 1.7217391304348, 1.35, 0.22727272727273
15863, 1.7217391304348, 1.35, 0.18181818181818
15864, 1.7217391304348, 1.35, 0.13636363636364
15865, 1.7217391304348, 1.35, 0.090909090909091
15866, 1.7217391304348, 1.35, 0.045454545454545
15867, 1.7652173913043, 1.35, 0.45454545454545
15868, 1.7652173913043, 1.35, 0.40909090909091
15869, 1.7652173913043, 1.35, 0.36363636363636
15870, 1.7652173913043, 1.35, 0.31818181818182
15871, 1.7652173913043, 1.35, 0.27272727272727
15872, 1.7652173913043, 1.35, 0.22727272727273
15873, 1.7652173913043, 1.35, 0.18181818181818
15874, 1.7652173913043, 1.35, 0.13636363636364
15875, 1.7652173913043, 1.35, 0.090909090909091
15876, 1.7652173913043, 1.35, 0.045454545454545
15877, 1.8086956521739, 1.35, 0.45454545454545
15878, 1.8086956521739, 1.35, 0.40909090909091
15879, 1.8086956521739, 1.35, 0.36363636363636
15880, 1.8086956521739, 1.35, 0.31818181818182
15881, 1.8086956521739, 1.35, 0.27272727272727
15882, 1.8086956521739, 1.35, 0.22727272727273
15883, 1.8086956521739, 1.35, 0.18181818181818
15884, 1.8086956521739, 1.35, 0.13636363636364
15885, 1.8086956521739, 1.35, 0.090909090909091
15886, 1.8086956521739, 1.35, 0.045454545454545
15887, 1.8521739130435, 1.35, 0.45454545454545
15888, 1.8521739130435, 1.35, 0.40909090909091
15889, 1.8521739130435, 1.35, 0.36363636363636
15890, 1.8521739130435, 1.35, 0.31818181818182
15891, 1.8521739130435, 1.35, 0.27272727272727
15892, 1.8521739130435, 1.35, 0.22727272727273
15893, 1.8521739130435, 1.35, 0.18181818181818
15894, 1.8521739130435, 1.35, 0.13636363636364
15895, 1.8521739130435, 1.35, 0.090909090909091
15896, 1.8521739130435, 1.35, 0.045454545454545
15897, 1.895652173913, 1.35, 0.45454545454545
15898, 1.895652173913, 1.35, 0.40909090909091
15899, 1.895652173913, 1.35, 0.36363636363636
15900, 1.895652173913, 1.35, 0.31818181818182
15901, 1.895652173913, 1.35, 0.27272727272727
15902, 1.895652173913, 1.35, 0.22727272727273
15903, 1.895652173913, 1.35, 0.18181818181818
15904, 1.895652173913, 1.35, 0.13636363636364
15905, 1.895652173913, 1.35, 0.090909090909091
15906, 1.895652173913, 1.35, 0.045454545454545
15907, 1.9391304347826, 1.35, 0.45454545454545
15908, 1.9391304347826, 1.35, 0.40909090909091
15909, 1.9391304347826, 1.35, 0.36363636363636
15910, 1.9391304347826, 1.35, 0.31818181818182
15911, 1.9391304347826, 1.35, 0.27272727272727
15912, 1.9391304347826, 1.35, 0.22727272727273
15913, 1.9391304347826, 1.35, 0.18181818181818
15914, 1.9391304347826, 1.35, 0.13636363636364
15915, 1.9391304347826, 1.35, 0.090909090909091
15916, 1.9391304347826, 1.35, 0.045454545454545
15917, 1.9826086956522, 1.35, 0.45454545454545
15918, 1.9826086956522, 1.35, 0.40909090909091
15919, 1.9826086956522, 1.35, 0.36363636363636
15920, 1.9826086956522, 1.35, 0.31818181818182
15921, 1.9826086956522, 1.35, 0.27272727272727
15922, 1.9826086956522, 1.35, 0.22727272727273
15923, 1.9826086956522, 1.35, 0.18181818181818
15924, 1.9826086956522, 1.35, 0.13636363636364
15925, 1.9826086956522, 1.35, 0.090909090909091
15926, 1.9826086956522, 1.35, 0.045454545454545
15927, 2.0260869565217, 1.35, 0.45454545454545
15928, 2.0260869565217, 1.35, 0.40909090909091
15929, 2.0260869565217, 1.35, 0.36363636363636
15930, 2.0260869565217, 1.35, 0.31818181818182
15931, 2.0260869565217, 1.35, 0.27272727272727
15932, 2.0260869565217, 1.35, 0.22727272727273
15933, 2.0260869565217, 1.35, 0.18181818181818
15934, 2.0260869565217, 1.35, 0.13636363636364
15935, 2.0260869565217, 1.35, 0.090909090909091
15936, 2.0260869565217, 1.35, 0.045454545454545
15937, 2.0695652173913, 1.35, 0.45454545454545
15938, 2.0695652173913, 1.35, 0.40909090909091
15939, 2.0695652173913, 1.35, 0.36363636363636
15940, 2.0695652173913, 1.35, 0.31818181818182
15941, 2.0695652173913, 1.35, 0.27272727272727
15942, 2.0695652173913, 1.35, 0.22727272727273
15943, 2.0695652173913, 1.35, 0.18181818181818
15944, 2.0695652173913, 1.35, 0.13636363636364
15945, 2.0695652173913, 1.35, 0.090909090909091
15946, 2.0695652173913, 1.35, 0.045454545454545
15947, 2.1130434782609, 1.35, 0.45454545454545
15948, 2.1130434782609, 1.35, 0.40909090909091
15949, 2.1130434782609, 1.35, 0.36363636363636
15950, 2.1130434782609, 1.35, 0.31818181818182
15951, 2.1130434782609, 1.35, 0.27272727272727
15952, 2.1130434782609, 1.35, 0.22727272727273
15953, 2.1130434782609, 1.35, 0.18181818181818
15954, 2.1130434782609, 1.35, 0.13636363636364
15955, 2.1130434782609, 1.35, 0.090909090909091
15956, 2.1130434782609, 1.35, 0.045454545454545
15957, 2.1565217391304, 1.35, 0.45454545454545
15958, 2.1565217391304, 1.35, 0.40909090909091
15959, 2.1565217391304, 1.35, 0.36363636363636
15960, 2.1565217391304, 1.35, 0.31818181818182
15961, 2.1565217391304, 1.35, 0.27272727272727
15962, 2.1565217391304, 1.35, 0.22727272727273
15963, 2.1565217391304, 1.35, 0.18181818181818
15964, 2.1565217391304, 1.35, 0.13636363636364
15965, 2.1565217391304, 1.35, 0.090909090909091
15966, 2.1565217391304, 1.35, 0.045454545454545
15967, 1.2217391304348, 1.35, 0.45454545454545
15968, 1.2434782608696, 1.35, 0.47727272727273
15969, 1.2217391304348, 1.35, 0.40909090909091
15970, 1.2434782608696, 1.35, 0.43181818181818
15971, 1.2217391304348, 1.35, 0.36363636363636
15972, 1.2434782608696, 1.35, 0.38636363636364
15973, 1.2217391304348, 1.35, 0.31818181818182
15974, 1.2434782608696, 1.35, 0.34090909090909
15975, 1.2217391304348, 1.35, 0.27272727272727
15976, 1.2434782608696, 1.35, 0.29545454545455
15977, 1.2217391304348, 1.35, 0.22727272727273
15978, 1.2434782608696, 1.35, 0.25
15979, 1.2217391304348, 1.35, 0.18181818181818
15980, 1.2434782608696, 1.35, 0.20454545454545
15981, 1.2217391304348, 1.35, 0.13636363636364
15982, 1.2434782608696, 1.35, 0.15909090909091
15983, 1.2217391304348, 1.35, 0.090909090909091
15984, 1.2434782608696, 1.35, 0.11363636363636
15985, 1.2217391304348, 1.35, 0.045454545454545
15986, 1.2434782608696, 1.35, 0.068181818181818
15987, 1.2434782608696, 1.35, 0.022727272727273
15988, 1.2652173913043, 1.35, 0.45454545454545
15989, 1.2869565217391, 1.35, 0.47727272727273
15990, 1.2652173913043, 1.35, 0.40909090909091
15991, 1.2869565217391, 1.35, 0.43181818181818
15992, 1.2652173913043, 1.35, 0.36363636363636
15993, 1.2869565217391, 1.35, 0.38636363636364
15994, 1.2652173913043, 1.35, 0.31818181818182
15995, 1.2869565217391, 1.35, 0.34090909090909
15996, 1.2652173913043, 1.35, 0.27272727272727
15997, 1.2869565217391, 1.35, 0.29545454545455
15998, 1.2652173913043, 1.35, 0.22727272727273
15999, 1.2869565217391, 1.35, 0.25
16000, 1.2652173913043, 1.35, 0.18181818181818
16001, 1.2869565217391, 1.35, 0.20454545454545
16002, 1.2652173913043, 1.35, 0.13636363636364
16003, 1.2869565217391, 1.35, 0.15909090909091
16004, 1.2652173913043, 1.35, 0.090909090909091
16005, 1.2869565217391, 1.35, 0.11363636363636
16006, 1.2652173913043, 1.35, 0.045454545454545
16007, 1.2869565217391, 1.35, 0.068181818181818
16008, 1.2869565217391, 1.35, 0.022727272727273
16009, 1.3086956521739, 1.35, 0.45454545454545
16010, 1.3304347826087, 1.35, 0.47727272727273
16011, 1.3086956521739, 1.35, 0.40909090909091
16012, 1.3304347826087, 1.35, 0.43181818181818
16013, 1.3086956521739, 1.35, 0.36363636363636
16014, 1.3304347826087, 1.35, 0.38636363636364
16015, 1.3086956521739, 1.35, 0.31818181818182
16016, 1.3304347826087, 1.35, 0.34090909090909
16017, 1.3086956521739, 1.35, 0.27272727272727
16018, 1.3304347826087, 1.35, 0.29545454545455
16019, 1.3086956521739, 1.35, 0.22727272727273
16020, 1.3304347826087, 1.35, 0.25
16021, 1.3086956521739, 1.35, 0.18181818181818
16022, 1.3304347826087, 1.35, 0.20454545454545
16023, 1.3086956521739, 1.35, 0.13636363636364
16024, 1.3304347826087, 1.35, 0.15909090909091
16025, 1.3086956521739, 1.35, 0.090909090909091
16026, 1.3304347826087, 1.35, 0.11363636363636
16027, 1.3086956521739, 1.35, 0.045454545454545
16028, 1.3304347826087, 1.35, 0.068181818181818
16029, 1.3304347826087, 1.35, 0.022727272727273
16030, 1.3521739130435, 1.35, 0.45454545454545
16031, 1.3739130434783, 1.35, 0.47727272727273
16032, 1.3521739130435, 1.35, 0.40909090909091
16033, 1.3739130434783, 1.35, 0.43181818181818
16034, 1.3521739130435, 1.35, 0.36363636363636
16035, 1.3739130434783, 1.35, 0.38636363636364
16036, 1.3521739130435, 1.35, 0.31818181818182
16037, 1.3739130434783, 1.35, 0.34090909090909
16038, 1.3521739130435, 1.35, 0.27272727272727
16039, 1.3739130434783, 1.35, 0.29545454545455
16040, 1.3521739130435, 1.35, 0.22727272727273
16041, 1.3739130434783, 1.35, 0.25
16042, 1.3521739130435, 1.35, 0.18181818181818
16043, 1.3739130434783, 1.35, 0.20454545454545
16044, 1.3521739130435, 1.35, 0.13636363636364
16045, 1.3739130434783, 1.35, 0.15909090909091
16046, 1.3521739130435, 1.35, 0.090909090909091
16047, 1.3739130434783, 1.35, 0.11363636363636
16048, 1.3521739130435, 1.35, 0.045454545454545
16049, 1.3739130434783, 1.35, 0.068181818181818
16050, 1.3739130434783, 1.35, 0.022727272727273
16051, 1.395652173913, 1.35, 0.45454545454545
16052, 1.4173913043478, 1.35, 0.47727272727273
16053, 1.395652173913, 1.35, 0.40909090909091
16054, 1.4173913043478, 1.35, 0.43181818181818
16055, 1.395652173913, 1.35, 0.36363636363636
16056, 1.4173913043478, 1.35, 0.38636363636364
16057, 1.395652173913, 1.35, 0.31818181818182
16058, 1.4173913043478, 1.35, 0.34090909090909
16059, 1.395652173913, 1.35, 0.27272727272727
16060, 1.4173913043478, 1.35, 0.29545454545455
16061, 1.395652173913, 1.35, 0.22727272727273
16062, 1.4173913043478, 1.35, 0.25
16063, 1.395652173913, 1.35, 0.18181818181818
16064, 1.4173913043478, 1.35, 0.20454545454545
16065, 1.395652173913, 1.35, 0.13636363636364
16066, 1.4173913043478, 1.35, 0.15909090909091
16067, 1.395652173913, 1.35, 0.090909090909091
16068, 1.4173913043478, 1.35, 0.11363636363636
16069, 1.395652173913, 1.35, 0.045454545454545
16070, 1.4173913043478, 1.35, 0.068181818181818
16071, 1.4173913043478, 1.35, 0.022727272727273
16072, 1.4391304347826, 1.35, 0.45454545454545
16073, 1.4608695652174, 1.35, 0.47727272727273
16074, 1.4391304347826, 1.35, 0.40909090909091
16075, 1.4608695652174, 1.35, 0.43181818181818
16076, 1.4391304347826, 1.35, 0.36363636363636
16077, 1.4608695652174, 1.35, 0.38636363636364
16078, 1.4391304347826, 1.35, 0.31818181818182
16079, 1.4608695652174, 1.35, 0.34090909090909
16080, 1.4391304347826, 1.35, 0.27272727272727
16081, 1.4608695652174, 1.35, 0.29545454545455
16082, 1.4391304347826, 1.35, 0.22727272727273
16083, 1.4608695652174, 1.35, 0.25
16084, 1.4391304347826, 1.35, 0.18181818181818
16085, 1.4608695652174, 1.35, 0.20454545454545
16086, 1.4391304347826, 1.35, 0.13636363636364
16087, 1.4608695652174, 1.35, 0.15909090909091
16088, 1.4391304347826, 1.35, 0.090909090909091
16089, 1.4608695652174, 1.35, 0.11363636363636
16090, 1.4391304347826, 1.35, 0.045454545454545
16091, 1.4608695652174, 1.35, 0.068181818181818
16092, 1.4608695652174, 1.35, 0.022727272727273
16093, 1.4826086956522, 1.35, 0.45454545454545
16094, 1.504347826087, 1.35, 0.47727272727273
16095, 1.4826086956522, 1.35, 0.40909090909091
16096, 1.504347826087, 1.35, 0.43181818181818
16097, 1.4826086956522, 1.35, 0.36363636363636
16098, 1.504347826087, 1.35, 0.38636363636364
16099, 1.4826086956522, 1.35, 0.31818181818182
16100, 1.504347826087, 1.35, 0.34090909090909
16101, 1.4826086956522, 1.35, 0.27272727272727
16102, 1.504347826087, 1.35, 0.29545454545455
16103, 1.4826086956522, 1.35, 0.22727272727273
16104, 1.504347826087, 1.35, 0.25
16105, 1.4826086956522, 1.35, 0.18181818181818
16106, 1.504347826087, 1.35, 0.20454545454545
16107, 1.4826086956522, 1.35, 0.13636363636364
16108, 1.504347826087, 1.35, 0.15909090909091
16109, 1.4826086956522, 1.35, 0.090909090909091
16110, 1.504347826087, 1.35, 0.11363636363636
16111, 1.4826086956522, 1.35, 0.045454545454545
16112, 1.504347826087, 1.35, 0.068181818181818
16113, 1.504347826087, 1.35, 0.022727272727273
16114, 1.5260869565217, 1.35, 0.45454545454545
16115, 1.5478260869565, 1.35, 0.47727272727273
16116, 1.5260869565217, 1.35, 0.40909090909091
16117, 1.5478260869565, 1.35, 0.43181818181818
16118, 1.5260869565217, 1.35, 0.36363636363636
16119, 1.5478260869565, 1.35, 0.38636363636364
16120, 1.5260869565217, 1.35, 0.31818181818182
16121, 1.5478260869565, 1.35, 0.34090909090909
16122, 1.5260869565217, 1.35, 0.27272727272727
16123, 1.5478260869565, 1.35, 0.29545454545455
16124, 1.5260869565217, 1.35, 0.22727272727273
16125, 1.5478260869565, 1.35, 0.25
16126, 1.5260869565217, 1.35, 0.18181818181818
16127, 1.5478260869565, 1.35, 0.20454545454545
16128, 1.5260869565217, 1.35, 0.13636363636364
16129, 1.5478260869565, 1.35, 0.15909090909091
16130, 1.5260869565217, 1.35, 0.090909090909091
16131, 1.5478260869565, 1.35, 0.11363636363636
16132, 1.5260869565217, 1.35, 0.045454545454545
16133, 1.5478260869565, 1.35, 0.068181818181818
16134, 1.5478260869565, 1.35, 0.022727272727273
16135, 1.5695652173913, 1.35, 0.45454545454545
16136, 1.5913043478261, 1.35, 0.47727272727273
16137, 1.5695652173913, 1.35, 0.40909090909091
16138, 1.5913043478261, 1.35, 0.43181818181818
16139, 1.5695652173913, 1.35, 0.36363636363636
16140, 1.5913043478261, 1.35, 0.38636363636364
16141, 1.5695652173913, 1.35, 0.31818181818182
16142, 1.5913043478261, 1.35, 0.34090909090909
16143, 1.5695652173913, 1.35, 0.27272727272727
16144, 1.5913043478261, 1.35, 0.29545454545455
16145, 1.5695652173913, 1.35, 0.22727272727273
16146, 1.5913043478261, 1.35, 0.25
16147, 1.5695652173913, 1.35, 0.18181818181818
16148, 1.5913043478261, 1.35, 0.20454545454545
16149, 1.5695652173913, 1.35, 0.13636363636364
16150, 1.5913043478261, 1.35, 0.15909090909091
16151, 1.5695652173913, 1.35, 0.090909090909091
16152, 1.5913043478261, 1.35, 0.11363636363636
16153, 1.5695652173913, 1.35, 0.045454545454545
16154, 1.5913043478261, 1.35, 0.068181818181818
16155, 1.5913043478261, 1.35, 0.022727272727273
16156, 1.6130434782609, 1.35, 0.45454545454545
16157, 1.6347826086957, 1.35, 0.47727272727273
16158, 1.6130434782609, 1.35, 0.40909090909091
16159, 1.6347826086957, 1.35, 0.43181818181818
16160, 1.6130434782609, 1.35, 0.36363636363636
16161, 1.6347826086957, 1.35, 0.38636363636364
16162, 1.6130434782609, 1.35, 0.31818181818182
16163, 1.6347826086957, 1.35, 0.34090909090909
16164, 1.6130434782609, 1.35, 0.27272727272727
16165, 1.6347826086957, 1.35, 0.29545454545455
16166, 1.6130434782609, 1.35, 0.22727272727273
16167, 1.6347826086957, 1.35, 0.25
16168, 1.6130434782609, 1.35, 0.18181818181818
16169, 1.6347826086957, 1.35, 0.20454545454545
16170, 1.6130434782609, 1.35, 0.13636363636364
16171, 1.6347826086957, 1.35, 0.15909090909091
16172, 1.6130434782609, 1.35, 0.090909090909091
16173, 1.6347826086957, 1.35, 0.11363636363636
16174, 1.6130434782609, 1.35, 0.045454545454545
16175, 1.6347826086957, 1.35, 0.068181818181818
16176, 1.6347826086957, 1.35, 0.022727272727273
16177, 1.6565217391304, 1.35, 0.45454545454545
16178, 1.6782608695652, 1.35, 0.47727272727273
16179, 1.6565217391304, 1.35, 0.40909090909091
16180, 1.6782608695652, 1.35, 0.43181818181818
16181, 1.6565217391304, 1.35, 0.36363636363636
16182, 1.6782608695652, 1.35, 0.38636363636364
16183, 1.6565217391304, 1.35, 0.31818181818182
16184, 1.6782608695652, 1.35, 0.34090909090909
16185, 1.6565217391304, 1.35, 0.27272727272727
16186, 1.6782608695652, 1.35, 0.29545454545455
16187, 1.6565217391304, 1.35, 0.22727272727273
16188, 1.6782608695652, 1.35, 0.25
16189, 1.6565217391304, 1.35, 0.18181818181818
16190, 1.6782608695652, 1.35, 0.20454545454545
16191, 1.6565217391304, 1.35, 0.13636363636364
16192, 1.6782608695652, 1.35, 0.15909090909091
16193, 1.6565217391304, 1.35, 0.090909090909091
16194, 1.6782608695652, 1.35, 0.11363636363636
16195, 1.6565217391304, 1.35, 0.045454545454545
16196, 1.6782608695652, 1.35, 0.068181818181818
16197, 1.6782608695652, 1.35, 0.022727272727273
16198, 1.7, 1.35, 0.45454545454545
16199, 1.7217391304348, 1.35, 0.47727272727273
16200, 1.7, 1.35, 0.40909090909091
16201, 1.7217391304348, 1.35, 0.43181818181818
16202, 1.7, 1.35, 0.36363636363636
16203, 1.7217391304348, 1.35, 0.38636363636364
16204, 1.7, 1.35, 0.31818181818182
16205, 1.7217391304348, 1.35, 0.34090909090909
16206, 1.7, 1.35, 0.27272727272727
16207, 1.7217391304348, 1.35, 0.29545454545455
16208, 1.7, 1.35, 0.22727272727273
16209, 1.7217391304348, 1.35, 0.25
16210, 1.7, 1.35, 0.18181818181818
16211, 1.7217391304348, 1.35, 0.20454545454545
16212, 1.7, 1.35, 0.13636363636364
16213, 1.7217391304348, 1.35, 0.15909090909091
16214, 1.7, 1.35, 0.090909090909091
16215, 1.7217391304348, 1.35, 0.11363636363636
16216, 1.7, 1.35, 0.045454545454545
16217, 1.7217391304348, 1.35, 0.068181818181818
16218, 1.7217391304348, 1.35, 0.022727272727273
16219, 1.7434782608696, 1.35, 0.45454545454545
16220, 1.7652173913043, 1.35, 0.47727272727273
16221, 1.7434782608696, 1.35, 0.40909090909091
16222, 1.7652173913043, 1.35, 0.43181818181818
16223, 1.7434782608696, 1.35, 0.36363636363636
16224, 1.7652173913043, 1.35, 0.38636363636364
16225, 1.7434782608696, 1.35, 0.31818181818182
16226, 1.7652173913043, 1.35, 0.34090909090909
16227, 1.7434782608696, 1.35, 0.27272727272727
16228, 1.7652173913043, 1.35, 0.29545454545455
16229, 1.7434782608696, 1.35, 0.22727272727273
16230, 1.7652173913043, 1.35, 0.25
16231, 1.7434782608696, 1.35, 0.18181818181818
16232, 1.7652173913043, 1.35, 0.20454545454545
16233, 1.7434782608696, 1.35, 0.13636363636364
16234, 1.7652173913043, 1.35, 0.15909090909091
16235, 1.7434782608696, 1.35, 0.090909090909091
16236, 1.7652173913043, 1.35, 0.11363636363636
16237, 1.7434782608696, 1.35, 0.045454545454545
16238, 1.7652173913043, 1.35, 0.068181818181818
16239, 1.7652173913043, 1.35, 0.022727272727273
16240, 1.7869565217391, 1.35, 0.45454545454545
16241, 1.8086956521739, 1.35, 0.47727272727273
16242, 1.7869565217391, 1.35, 0.40909090909091
16243, 1.8086956521739, 1.35, 0.43181818181818
16244, 1.7869565217391, 1.35, 0.36363636363636
16245, 1.8086956521739, 1.35, 0.38636363636364
16246, 1.7869565217391, 1.35, 0.31818181818182
16247, 1.8086956521739, 1.35, 0.34090909090909
16248, 1.7869565217391, 1.35, 0.27272727272727
16249, 1.8086956521739, 1.35, 0.29545454545455
16250, 1.7869565217391, 1.35, 0.22727272727273
16251, 1.8086956521739, 1.35, 0.25
16252, 1.7869565217391, 1.35, 0.18181818181818
16253, 1.8086956521739, 1.35, 0.20454545454545
16254, 1.7869565217391, 1.35, 0.13636363636364
16255, 1.8086956521739, 1.35, 0.15909090909091
16256, 1.7869565217391, 1.35, 0.090909090909091
16257, 1.8086956521739, 1.35, 0.11363636363636
16258, 1.7869565217391, 1.35, 0.045454545454545
16259, 1.8086956521739, 1.35, 0.068181818181818
16260, 1.8086956521739, 1.35, 0.022727272727273
16261, 1.8304347826087, 1.35, 0.45454545454545
16262, 1.8521739130435, 1.35, 0.47727272727273
16263, 1.8304347826087, 1.35, 0.40909090909091
16264, 1.8521739130435, 1.35, 0.43181818181818
16265, 1.8304347826087, 1.35, 0.36363636363636
16266, 1.8521739130435, 1.35, 0.38636363636364
16267, 1.8304347826087, 1.35, 0.31818181818182
16268, 1.8521739130435, 1.35, 0.34090909090909
16269, 1.8304347826087, 1.35, 0.27272727272727
16270, 1.8521739130435, 1.35, 0.29545454545455
16271, 1.8304347826087, 1.35, 0.22727272727273
16272, 1.8521739130435, 1.35, 0.25
16273, 1.8304347826087, 1.35, 0.18181818181818
16274, 1.8521739130435, 1.35, 0.20454545454545
16275, 1.8304347826087, 1.35, 0.13636363636364
16276, 1.8521739130435, 1.35, 0.15909090909091
16277, 1.8304347826087, 1.35, 0.090909090909091
16278, 1.8521739130435, 1.35, 0.11363636363636
16279, 1.8304347826087, 1.35, 0.045454545454545
16280, 1.8521739130435, 1.35, 0.068181818181818
16281, 1.8521739130435, 1.35, 0.022727272727273
16282, 1.8739130434783, 1.35, 0.45454545454545
16283, 1.895652173913, 1.35, 0.47727272727273
16284, 1.8739130434783, 1.35, 0.40909090909091
16285, 1.895652173913, 1.35, 0.43181818181818
16286, 1.8739130434783, 1.35, 0.36363636363636
16287, 1.895652173913, 1.35, 0.38636363636364
16288, 1.8739130434783, 1.35, 0.31818181818182
16289, 1.895652173913, 1.35, 0.34090909090909
16290, 1.8739130434783, 1.35, 0.27272727272727
16291, 1.895652173913, 1.35, 0.29545454545455
16292, 1.8739130434783, 1.35, 0.22727272727273
16293, 1.895652173913, 1.35, 0.25
16294, 1.8739130434783, 1.35, 0.18181818181818
16295, 1.895652173913, 1.35, 0.20454545454545
16296, 1.8739130434783, 1.35, 0.13636363636364
16297, 1.895652173913, 1.35, 0.15909090909091
16298, 1.8739130434783, 1.35, 0.090909090909091
16299, 1.895652173913, 1.35, 0.11363636363636
16300, 1.8739130434783, 1.35, 0.045454545454545
16301, 1.895652173913, 1.35, 0.068181818181818
16302, 1.895652173913, 1.35, 0.022727272727273
16303, 1.9173913043478, 1.35, 0.45454545454545
16304, 1.9391304347826, 1.35, 0.47727272727273
16305, 1.9173913043478, 1.35, 0.40909090909091
16306, 1.9391304347826, 1.35, 0.43181818181818
16307, 1.9173913043478, 1.35, 0.36363636363636
16308, 1.9391304347826, 1.35, 0.38636363636364
16309, 1.9173913043478, 1.35, 0.31818181818182
16310, 1.9391304347826, 1.35, 0.34090909090909
16311, 1.9173913043478, 1.35, 0.27272727272727
16312, 1.9391304347826, 1.35, 0.29545454545455
16313, 1.9173913043478, 1.35, 0.22727272727273
16314, 1.9391304347826, 1.35, 0.25
16315, 1.9173913043478, 1.35, 0.18181818181818
16316, 1.9391304347826, 1.35, 0.20454545454545
16317, 1.9173913043478, 1.35, 0.13636363636364
16318, 1.9391304347826, 1.35, 0.15909090909091
16319, 1.9173913043478, 1.35, 0.090909090909091
16320, 1.9391304347826, 1.35, 0.11363636363636
16321, 1.9173913043478, 1.35, 0.045454545454545
16322, 1.9391304347826, 1.35, 0.068181818181818
16323, 1.9391304347826, 1.35, 0.022727272727273
16324, 1.9608695652174, 1.35, 0.45454545454545
16325, 1.9826086956522, 1.35, 0.47727272727273
16326, 1.9608695652174, 1.35, 0.40909090909091
16327, 1.9826086956522, 1.35, 0.43181818181818
16328, 1.9608695652174, 1.35, 0.36363636363636
16329, 1.9826086956522, 1.35, 0.38636363636364
16330, 1.9608695652174, 1.35, 0.31818181818182
16331, 1.9826086956522, 1.35, 0.34090909090909
16332, 1.9608695652174, 1.35, 0.27272727272727
16333, 1.9826086956522, 1.35, 0.29545454545455
16334, 1.9608695652174, 1.35, 0.22727272727273
16335, 1.9826086956522, 1.35, 0.25
16336, 1.9608695652174, 1.35, 0.18181818181818
16337, 1.9826086956522, 1.35, 0.20454545454545
16338, 1.9608695652174, 1.35, 0.13636363636364
16339, 1.9826086956522, 1.35, 0.15909090909091
16340, 1.9608695652174, 1.35, 0.090909090909091
16341, 1.9826086956522, 1.35, 0.11363636363636
16342, 1.9608695652174, 1.35, 0.045454545454545
16343, 1.9826086956522, 1.35, 0.068181818181818
16344, 1.9826086956522, 1.35, 0.022727272727273
16345, 2.004347826087, 1.35, 0.45454545454545
16346, 2.0260869565217, 1.35, 0.47727272727273
16347, 2.004347826087, 1.35, 0.40909090909091
16348, 2.0260869565217, 1.35, 0.43181818181818
16349, 2.004347826087, 1.35, 0.36363636363636
16350, 2.0260869565217, 1.35, 0.38636363636364
16351, 2.004347826087, 1.35, 0.31818181818182
16352, 2.0260869565217, 1.35, 0.34090909090909
16353, 2.004347826087, 1.35, 0.27272727272727
16354, 2.0260869565217, 1.35, 0.29545454545455
16355, 2.004347826087, 1.35, 0.22727272727273
16356, 2.0260869565217, 1.35, 0.25
16357, 2.004347826087, 1.35, 0.18181818181818
16358, 2.0260869565217, 1.35, 0.20454545454545
16359, 2.004347826087, 1.35, 0.13636363636364
16360, 2.0260869565217, 1.35, 0.15909090909091
16361, 2.004347826087, 1.35, 0.090909090909091
16362, 2.0260869565217, 1.35, 0.11363636363636
16363, 2.004347826087, 1.35, 0.045454545454545
16364, 2.0260869565217, 1.35, 0.068181818181818
16365, 2.0260869565217, 1.35, 0.022727272727273
16366, 2.0478260869565, 1.35, 0.45454545454545
16367, 2.0695652173913, 1.35, 0.47727272727273
16368, 2.0478260869565, 1.35, 0.40909090909091
16369, 2.0695652173913, 1.35, 0.43181818181818
16370, 2.0478260869565, 1.35, 0.36363636363636
16371, 2.0695652173913, 1.35, 0.38636363636364
16372, 2.0478260869565, 1.35, 0.31818181818182
16373, 2.0695652173913, 1.35, 0.34090909090909
16374, 2.0478260869565, 1.35, 0.27272727272727
16375, 2.0695652173913, 1.35, 0.29545454545455
16376, 2.0478260869565, 1.35, 0.22727272727273
16377, 2.0695652173913, 1.35, 0.25
16378, 2.0478260869565, 1.35, 0.18181818181818
16379, 2.0695652173913, 1.35, 0.20454545454545
16380, 2.0478260869565, 1.35, 0.13636363636364
16381, 2.0695652173913, 1.35, 0.15909090909091
16382, 2.0478260869565, 1.35, 0.090909090909091
16383, 2.0695652173913, 1.35, 0.11363636363636
16384, 2.0478260869565, 1.35, 0.045454545454545
16385, 2.0695652173913, 1.35, 0.068181818181818
16386, 2.0695652173913, 1.35, 0.022727272727273
16387, 2.0913043478261, 1.35, 0.45454545454545
16388, 2.1130434782609, 1.35, 0.47727272727273
16389, 2.0913043478261, 1.35, 0.40909090909091
16390, 2.1130434782609, 1.35, 0.43181818181818
16391, 2.0913043478261, 1.35, 0.36363636363636
16392, 2.1130434782609, 1.35, 0.38636363636364
16393, 2.0913043478261, 1.35, 0.31818181818182
16394, 2.1130434782609, 1.35, 0.34090909090909
16395, 2.0913043478261, 1.35, 0.27272727272727
16396, 2.1130434782609, 1.35, 0.29545454545455
16397, 2.0913043478261, 1.35, 0.22727272727273
16398, 2.1130434782609, 1.35, 0.25
16399, 2.0913043478261, 1.35, 0.18181818181818
16400, 2.1130434782609, 1.35, 0.20454545454545
16401, 2.0913043478261, 1.35, 0.13636363636364
16402, 2.1130434782609, 1.35, 0.15909090909091
16403, 2.0913043478261, 1.35, 0.090909090909091
16404, 2.1130434782609, 1.35, 0.11363636363636
16405, 2.0913043478261, 1.35, 0.045454545454545
16406, 2.1130434782609, 1.35, 0.068181818181818
16407, 2.1130434782609, 1.35, 0.022727272727273
16408, 2.1347826086957, 1.35, 0.45454545454545
16409, 2.1565217391304, 1.35, 0.47727272727273
16410, 2.1347826086957, 1.35, 0.40909090909091
16411, 2.1565217391304, 1.35, 0.43181818181818
16412, 2.1347826086957, 1.35, 0.36363636363636
16413, 2.1565217391304, 1.35, 0.38636363636364
16414, 2.1347826086957, 1.35, 0.31818181818182
16415, 2.1565217391304, 1.35, 0.34090909090909
16416, 2.1347826086957, 1.35, 0.27272727272727
16417, 2.1565217391304, 1.35, 0.29545454545455
16418, 2.1347826086957, 1.35, 0.22727272727273
16419, 2.1565217391304, 1.35, 0.25
16420, 2.1347826086957, 1.35, 0.18181818181818
16421, 2.1565217391304, 1.35, 0.20454545454545
16422, 2.1347826086957, 1.35, 0.13636363636364
16423, 2.1565217391304, 1.35, 0.15909090909091
16424, 2.1347826086957, 1.35, 0.090909090909091
16425, 2.1565217391304, 1.35, 0.11363636363636
16426, 2.1347826086957, 1.35, 0.045454545454545
16427, 2.1565217391304, 1.35, 0.068181818181818
16428, 2.1565217391304, 1.35, 0.022727272727273
16429, 2.1782608695652, 1.35, 0.45454545454545
16430, 2.1782608695652, 1.35, 0.40909090909091
16431, 2.1782608695652, 1.35, 0.36363636363636
16432, 2.1782608695652, 1.35, 0.31818181818182
16433, 2.1782608695652, 1.35, 0.27272727272727
16434, 2.1782608695652, 1.35, 0.22727272727273
16435, 2.1782608695652, 1.35, 0.18181818181818
16436, 2.1782608695652, 1.35, 0.13636363636364
16437, 2.1782608695652, 1.35, 0.090909090909091
16438, 2.1782608695652, 1.35, 0.045454545454545
16439, 1.2434782608696, 1.2978260869565, 0.5
16440, 1.2869565217391, 1.2978260869565, 0.5
16441, 1.3304347826087, 1.2978260869565, 0.5
16442, 1.3739130434783, 1.2978260869565, 0.5
16443, 1.4173913043478, 1.2978260869565, 0.5
16444, 1.4608695652174, 1.2978260869565, 0.5
16445, 1.504347826087, 1.2978260869565, 0.5
16446, 1.5478260869565, 1.2978260869565, 0.5
16447, 1.5913043478261, 1.2978260869565, 0.5
16448, 1.6347826086957, 1.2978260869565, 0.5
16449, 1.6782608695652, 1.2978260869565, 0.5
16450, 1.7217391304348, 1.2978260869565, 0.5
16451, 1.7652173913043, 1.2978260869565, 0.5
16452, 1.8086956521739, 1.2978260869565, 0.5
16453, 1.8521739130435, 1.2978260869565, 0.5
16454, 1.895652173913, 1.2978260869565, 0.5
16455, 1.9391304347826, 1.2978260869565, 0.5
16456, 1.9826086956522, 1.2978260869565, 0.5
16457, 2.0260869565217, 1.2978260869565, 0.5
16458, 2.0695652173913, 1.2978260869565, 0.5
16459, 2.1130434782609, 1.2978260869565, 0.5
16460, 2.1565217391304, 1.2978260869565, 0.5
16461, 1.2434782608696, 1.245652173913, 0.5
16462, 1.2869565217391, 1.245652173913, 0.5
16463, 1.3304347826087, 1.245652173913, 0.5
16464, 1.3739130434783, 1.245652173913, 0.5
16465, 1.4173913043478, 1.245652173913, 0.5
16466, 1.4608695652174, 1.245652173913, 0.5
16467, 1.504347826087, 1.245652173913, 0.5
16468, 1.5478260869565, 1.245652173913, 0.5
16469, 1.5913043478261, 1.245652173913, 0.5
16470, 1.6347826086957, 1.245652173913, 0.5
16471, 1.6782608695652, 1.245652173913, 0.5
16472, 1.7217391304348, 1.245652173913, 0.5
16473, 1.7652173913043, 1.245652173913, 0.5
16474, 1.8086956521739, 1.245652173913, 0.5
16475, 1.8521739130435, 1.245652173913, 0.5
16476, 1.895652173913, 1.245652173913, 0.5
16477, 1.9391304347826, 1.245652173913, 0.5
16478, 1.9826086956522, 1.245652173913, 0.5
16479, 2.0260869565217, 1.245652173913, 0.5
16480, 2.0695652173913, 1.245652173913, 0.5
16481, 2.1130434782609, 1.245652173913, 0.5
16482, 2.1565217391304, 1.245652173913, 0.5
16483, 1.2434782608696, 1.1934782608696, 0.5
16484, 1.2869565217391, 1.1934782608696, 0.5
16485, 1.3304347826087, 1.1934782608696, 0.5
16486, 1.3739130434783, 1.1934782608696, 0.5
16487, 1.4173913043478, 1.1934782608696, 0.5
16488, 1.4608695652174, 1.1934782608696, 0.5
16489, 1.504347826087, 1.1934782608696, 0.5
16490, 1.5478260869565, 1.1934782608696, 0.5
16491, 1.5913043478261, 1.1934782608696, 0.5
16492, 1.6347826086957, 1.1934782608696, 0.5
16493, 1.6782608695652, 1.1934782608696, 0.5
16494, 1.7217391304348, 1.1934782608696, 0.5
16495, 1.7652173913043, 1.1934782608696, 0.5
16496, 1.8086956521739, 1.1934782608696, 0.5
16497, 1.8521739130435, 1.1934782608696, 0.5
16498, 1.895652173913, 1.1934782608696, 0.5
16499, 1.9391304347826, 1.1934782608696, 0.5
16500, 1.9826086956522, 1.1934782608696, 0.5
16501, 2.0260869565217, 1.1934782608696, 0.5
16502, 2.0695652173913, 1.1934782608696, 0.5
16503, 2.1130434782609, 1.1934782608696, 0.5
16504, 2.1565217391304, 1.1934782608696, 0.5
16505, 1.2434782608696, 1.1413043478261, 0.5
16506, 1.2869565217391, 1.1413043478261, 0.5
16507, 1.3304347826087, 1.1413043478261, 0.5
16508, 1.3739130434783, 1.1413043478261, 0.5
16509, 1.4173913043478, 1.1413043478261, 0.5
16510, 1.4608695652174, 1.1413043478261, 0.5
16511, 1.504347826087, 1.1413043478261, 0.5
16512, 1.5478260869565, 1.1413043478261, 0.5
16513, 1.5913043478261, 1.1413043478261, 0.5
16514, 1.6347826086957, 1.1413043478261, 0.5
16515, 1.6782608695652, 1.1413043478261, 0.5
16516, 1.7217391304348, 1.1413043478261, 0.5
16517, 1.7652173913043, 1.1413043478261, 0.5
16518, 1.8086956521739, 1.1413043478261, 0.5
16519, 1.8521739130435, 1.1413043478261, 0.5
16520, 1.895652173913, 1.1413043478261, 0.5
16521, 1.9391304347826, 1.1413043478261, 0.5
16522, 1.9826086956522, 1.1413043478261, 0.5
16523, 2.0260869565217, 1.1413043478261, 0.5
16524, 2.0695652173913, 1.1413043478261, 0.5
16525, 2.1130434782609, 1.1413043478261, 0.5
16526, 2.1565217391304, 1.1413043478261, 0.5
16527, 1.2434782608696, 1.0891304347826, 0.5
16528, 1.2869565217391, 1.0891304347826, 0.5
16529, 1.3304347826087, 1.0891304347826, 0.5
16530, 1.3739130434783, 1.0891304347826, 0.5
16531, 1.4173913043478, 1.0891304347826, 0.5
16532, 1.4608695652174, 1.0891304347826, 0.5
16533, 1.504347826087, 1.0891304347826, 0.5
16534, 1.5478260869565, 1.0891304347826, 0.5
16535, 1.5913043478261, 1.0891304347826, 0.5
16536, 1.6347826086957, 1.0891304347826, 0.5
16537, 1.6782608695652, 1.0891304347826, 0.5
16538, 1.7217391304348, 1.0891304347826, 0.5
16539, 1.7652173913043, 1.0891304347826, 0.5
16540, 1.8086956521739, 1.0891304347826, 0.5
16541, 1.8521739130435, 1.0891304347826, 0.5
16542, 1.895652173913, 1.0891304347826, 0.5
16543, 1.9391304347826, 1.0891304347826, 0.5
16544, 1.9826086956522, 1.0891304347826, 0.5
16545, 2.0260869565217, 1.0891304347826, 0.5
16546, 2.0695652173913, 1.0891304347826, 0.5
16547, 2.1130434782609, 1.0891304347826, 0.5
16548, 2.1565217391304, 1.0891304347826, 0.5
16549, 1.2434782608696, 1.0369565217391, 0.5
16550, 1.2869565217391, 1.0369565217391, 0.5
16551, 1.3304347826087, 1.0369565217391, 0.5
16552, 1.3739130434783, 1.0369565217391, 0.5
16553, 1.4173913043478, 1.0369565217391, 0.5
16554, 1.4608695652174, 1.0369565217391, 0.5
16555, 1.504347826087, 1.0369565217391, 0.5
16556, 1.5478260869565, 1.0369565217391, 0.5
16557, 1.5913043478261, 1.0369565217391, 0.5
16558, 1.6347826086957, 1.0369565217391, 0.5
16559, 1.6782608695652, 1.0369565217391, 0.5
16560, 1.7217391304348, 1.0369565217391, 0.5
16561, 1.7652173913043, 1.0369565217391, 0.5
16562, 1.8086956521739, 1.0369565217391, 0.5
16563, 1.8521739130435, 1.0369565217391, 0.5
16564, 1.895652173913, 1.0369565217391, 0.5
16565, 1.9391304347826, 1.0369565217391, 0.5
16566, 1.9826086956522, 1.0369565217391, 0.5
16567, 2.0260869565217, 1.0369565217391, 0.5
16568, 2.0695652173913, 1.0369565217391, 0.5
16569, 2.1130434782609, 1.0369565217391, 0.5
16570, 2.1565217391304, 1.0369565217391, 0.5
16571, 1.2434782608696, 0.98478260869565, 0.5
16572, 1.2869565217391, 0.98478260869565, 0.5
16573, 1.3304347826087, 0.98478260869565, 0.5
16574, 1.3739130434783, 0.98478260869565, 0.5
16575, 1.4173913043478, 0.98478260869565, 0.5
16576, 1.4608695652174, 0.98478260869565, 0.5
16577, 1.504347826087, 0.98478260869565, 0.5
16578, 1.5478260869565, 0.98478260869565, 0.5
16579, 1.5913043478261, 0.98478260869565, 0.5
16580, 1.6347826086957, 0.98478260869565, 0.5
16581, 1.6782608695652, 0.98478260869565, 0.5
16582, 1.7217391304348, 0.98478260869565, 0.5
16583, 1.7652173913043, 0.98478260869565, 0.5
16584, 1.8086956521739, 0.98478260869565, 0.5
16585, 1.8521739130435, 0.98478260869565, 0.5
16586, 1.895652173913, 0.98478260869565, 0.5
16587, 1.9391304347826, 0.98478260869565, 0.5
16588, 1.9826086956522, 0.98478260869565, 0.5
16589, 2.0260869565217, 0.98478260869565, 0.5
16590, 2.0695652173913, 0.98478260869565, 0.5
16591, 2.1130434782609, 0.98478260869565, 0.5
16592, 2.1565217391304, 0.98478260869565, 0.5
16593, 1.2434782608696, 0.93260869565217, 0.5
16594, 1.2869565217391, 0.93260869565217, 0.5
16595, 1.3304347826087, 0.93260869565217, 0.5
16596, 1.3739130434783, 0.93260869565217, 0.5
16597, 1.4173913043478, 0.93260869565217, 0.5
16598, 1.4608695652174, 0.93260869565217, 0.5
16599, 1.504347826087, 0.93260869565217, 0.5
16600, 1.5478260869565, 0.93260869565217, 0.5
16601, 1.5913043478261, 0.93260869565217, 0.5
16602, 1.6347826086957, 0.93260869565217, 0.5
16603, 1.6782608695652, 0.93260869565217, 0.5
16604, 1.7217391304348, 0.93260869565217, 0.5
16605, 1.7652173913043, 0.93260869565217, 0.5
16606, 1.8086956521739, 0.93260869565217, 0.5
16607, 1.8521739130435, 0.93260869565217, 0.5
16608, 1.895652173913, 0.93260869565217, 0.5
16609, 1.9391304347826, 0.93260869565217, 0.5
16610, 1.9826086956522, 0.93260869565217, 0.5
16611, 2.0260869565217, 0.93260869565217, 0.5
16612, 2.0695652173913, 0.93260869565217, 0.5
16613, 2.1130434782609, 0.93260869565217, 0.5
16614, 2.1565217391304, 0.93260869565217, 0.5
16615, 1.2434782608696, 0.8804347826087, 0.5
16616, 1.2869565217391, 0.8804347826087, 0.5
16617, 1.3304347826087, 0.8804347826087, 0.5
16618, 1.3739130434783, 0.8804347826087, 0.5
16619, 1.4173913043478, 0.8804347826087, 0.5
16620, 1.4608695652174, 0.8804347826087, 0.5
16621, 1.504347826087, 0.8804347826087, 0.5
16622, 1.5478260869565, 0.8804347826087, 0.5
16623, 1.5913043478261, 0.8804347826087, 0.5
16624, 1.6347826086957, 0.8804347826087, 0.5
16625, 1.6782608695652, 0.8804347826087, 0.5
16626, 1.7217391304348, 0.8804347826087, 0.5
16627, 1.7652173913043, 0.8804347826087, 0.5
16628, 1.8086956521739, 0.8804347826087, 0.5
16629, 1.8521739130435, 0.8804347826087, 0.5
16630, 1.895652173913, 0.8804347826087, 0.5
16631, 1.9391304347826, 0.8804347826087, 0.5
16632, 1.9826086956522, 0.8804347826087, 0.5
16633, 2.0260869565217, 0.8804347826087, 0.5
16634, 2.0695652173913, 0.8804347826087, 0.5
16635, 2.1130434782609, 0.8804347826087, 0.5
16636, 2.1565217391304, 0.8804347826087, 0.5
16637, 1.2434782608696, 0.82826086956522, 0.5
16638, 1.2869565217391, 0.82826086956522, 0.5
16639, 1.3304347826087, 0.82826086956522, 0.5
16640, 1.3739130434783, 0.82826086956522, 0.5
16641, 1.4173913043478, 0.82826086956522, 0.5
16642, 1.4608695652174, 0.82826086956522, 0.5
16643, 1.504347826087, 0.82826086956522, 0.5
16644, 1.5478260869565, 0.82826086956522, 0.5
16645, 1.5913043478261, 0.82826086956522, 0.5
16646, 1.6347826086957, 0.82826086956522, 0.5
16647, 1.6782608695652, 0.82826086956522, 0.5
16648, 1.7217391304348, 0.82826086956522, 0.5
16649, 1.7652173913043, 0.82826086956522, 0.5
16650, 1.8086956521739, 0.82826086956522, 0.5
16651, 1.8521739130435, 0.82826086956522, 0.5
16652, 1.895652173913, 0.82826086956522, 0.5
16653, 1.9391304347826, 0.82826086956522, 0.5
16654, 1.9826086956522, 0.82826086956522, 0.5
16655, 2.0260869565217, 0.82826086956522, 0.5
16656, 2.0695652173913, 0.82826086956522, 0.5
16657, 2.1130434782609, 0.82826086956522, 0.5
16658, 2.1565217391304, 0.82826086956522, 0.5
16659, 1.2434782608696, 0.77608695652174, 0.5
16660, 1.2869565217391, 0.77608695652174, 0.5
16661, 1.3304347826087, 0.77608695652174, 0.5
16662, 1.3739130434783, 0.77608695652174, 0.5
16663, 1.4173913043478, 0.77608695652174, 0.5
16664, 1.4608695652174, 0.77608695652174, 0.5
16665, 1.504347826087, 0.77608695652174, 0.5
16666, 1.5478260869565, 0.77608695652174, 0.5
16667, 1.5913043478261, 0.77608695652174, 0.5
16668, 1.6347826086957, 0.77608695652174, 0.5
16669, 1.6782608695652, 0.77608695652174, 0.5
16670, 1.7217391304348, 0.77608695652174, 0.5
16671, 1.7652173913043, 0.77608695652174, 0.5
16672, 1.8086956521739, 0.77608695652174, 0.5
16673, 1.8521739130435, 0.77608695652174, 0.5
16674, 1.895652173913, 0.77608695652174, 0.5
16675, 1.9391304347826, 0.77608695652174, 0.5
16676, 1.9826086956522, 0.77608695652174, 0.5
16677, 2.0260869565217, 0.77608695652174, 0.5
16678, 2.0695652173913, 0.77608695652174, 0.5
16679, 2.1130434782609, 0.77608695652174, 0.5
16680, 2.1565217391304, 0.77608695652174, 0.5
16681, 1.2434782608696, 0.72391304347826, 0.5
16682, 1.2869565217391, 0.72391304347826, 0.5
16683, 1.3304347826087, 0.72391304347826, 0.5
16684, 1.3739130434783, 0.72391304347826, 0.5
16685, 1.4173913043478, 0.72391304347826, 0.5
16686, 1.4608695652174, 0.72391304347826, 0.5
16687, 1.504347826087, 0.72391304347826, 0.5
16688, 1.5478260869565, 0.72391304347826, 0.5
16689, 1.5913043478261, 0.72391304347826, 0.5
16690, 1.6347826086957, 0.72391304347826, 0.5
16691, 1.6782608695652, 0.72391304347826, 0.5
16692, 1.7217391304348, 0.72391304347826, 0.5
16693, 1.7652173913043, 0.72391304347826, 0.5
16694, 1.8086956521739, 0.72391304347826, 0.5
16695, 1.8521739130435, 0.72391304347826, 0.5
16696, 1.895652173913, 0.72391304347826, 0.5
16697, 1.9391304347826, 0.72391304347826, 0.5
16698, 1.9826086956522, 0.72391304347826, 0.5
16699, 2.0260869565217, 0.72391304347826, 0.5
16700, 2.0695652173913, 0.72391304347826, 0.5
16701, 2.1130434782609, 0.72391304347826, 0.5
16702, 2.1565217391304, 0.72391304347826, 0.5
16703, 1.2434782608696, 0.67173913043478, 0.5
16704, 1.2869565217391, 0.67173913043478, 0.5
16705, 1.3304347826087, 0.67173913043478, 0.5
16706, 1.3739130434783, 0.67173913043478, 0.5
16707, 1.4173913043478, 0.67173913043478, 0.5
16708, 1.4608695652174, 0.67173913043478, 0.5
16709, 1.504347826087, 0.67173913043478, 0.5
16710, 1.5478260869565, 0.67173913043478, 0.5
16711, 1.5913043478261, 0.67173913043478, 0.5
16712, 1.6347826086957, 0.67173913043478, 0.5
16713, 1.6782608695652, 0.67173913043478, 0.5
16714, 1.7217391304348, 0.67173913043478, 0.5
16715, 1.7652173913043, 0.67173913043478, 0.5
16716, 1.8086956521739, 0.67173913043478, 0.5
16717, 1.8521739130435, 0.67173913043478, 0.5
16718, 1.895652173913, 0.67173913043478, 0.5
16719, 1.9391304347826, 0.67173913043478, 0.5
16720, 1.9826086956522, 0.67173913043478, 0.5
16721, 2.0260869565217, 0.67173913043478, 0.5
16722, 2.0695652173913, 0.67173913043478, 0.5
16723, 2.1130434782609, 0.67173913043478, 0.5
16724, 2.1565217391304, 0.67173913043478, 0.5
16725, 1.2434782608696, 0.61956521739131, 0.5
16726, 1.2869565217391, 0.61956521739131, 0.5
16727, 1.3304347826087, 0.61956521739131, 0.5
16728, 1.3739130434783, 0.61956521739131, 0.5
16729, 1.4173913043478, 0.61956521739131, 0.5
16730, 1.4608695652174, 0.61956521739131, 0.5
16731, 1.504347826087, 0.6195652173913, 0.5
16732, 1.5478260869565, 0.61956521739131, 0.5
16733, 1.5913043478261, 0.61956521739131, 0.5
16734, 1.6347826086957, 0.61956521739131, 0.5
16735, 1.6782608695652, 0.61956521739131, 0.5
16736, 1.7217391304348, 0.61956521739131, 0.5
16737, 1.7652173913043, 0.61956521739131, 0.5
16738, 1.8086956521739, 0.61956521739131, 0.5
16739, 1.8521739130435, 0.61956521739131, 0.5
16740, 1.895652173913, 0.61956521739131, 0.5
16741, 1.9391304347826, 0.61956521739131, 0.5
16742, 1.9826086956522, 0.61956521739131, 0.5
16743, 2.0260869565217, 0.61956521739131, 0.5
16744, 2.0695652173913, 0.61956521739131, 0.5
16745, 2.1130434782609, 0.61956521739131, 0.5
16746, 2.1565217391304, 0.61956521739131, 0.5
16747, 1.2434782608696, 0.56739130434783, 0.5
16748, 1.2869565217391, 0.56739130434783, 0.5
16749, 1.3304347826087, 0.56739130434783, 0.5
16750, 1.3739130434783, 0.56739130434783, 0.5
16751, 1.4173913043478, 0.56739130434783, 0.5
16752, 1.4608695652174, 0.56739130434783, 0.5
16753, 1.504347826087, 0.56739130434783, 0.5
16754, 1.5478260869565, 0.56739130434783, 0.5
16755, 1.5913043478261, 0.56739130434783, 0.5
16756, 1.6347826086957, 0.56739130434783, 0.5
16757, 1.6782608695652, 0.56739130434783, 0.5
16758, 1.7217391304348, 0.56739130434783, 0.5
16759, 1.7652173913043, 0.56739130434783, 0.5
16760, 1.8086956521739, 0.56739130434783, 0.5
16761, 1.8521739130435, 0.56739130434783, 0.5
16762, 1.895652173913, 0.56739130434783, 0.5
16763, 1.9391304347826, 0.56739130434783, 0.5
16764, 1.9826086956522, 0.56739130434783, 0.5
16765, 2.0260869565217, 0.56739130434783, 0.5
16766, 2.0695652173913, 0.56739130434783, 0.5
16767, 2.1130434782609, 0.56739130434783, 0.5
16768, 2.1565217391304, 0.56739130434783, 0.5
16769, 1.2434782608696, 0.51521739130435, 0.5
16770, 1.2869565217391, 0.51521739130435, 0.5
16771, 1.3304347826087, 0.51521739130435, 0.5
16772, 1.3739130434783, 0.51521739130435, 0.5
16773, 1.4173913043478, 0.51521739130435, 0.5
16774, 1.4608695652174, 0.51521739130435, 0.5
16775, 1.504347826087, 0.51521739130435, 0.5
16776, 1.5478260869565, 0.51521739130435, 0.5
16777, 1.5913043478261, 0.51521739130435, 0.5
16778, 1.6347826086957, 0.51521739130435, 0.5
16779, 1.6782608695652, 0.51521739130435, 0.5
16780, 1.7217391304348, 0.51521739130435, 0.5
16781, 1.7652173913043, 0.51521739130435, 0.5
16782, 1.8086956521739, 0.51521739130435, 0.5
16783, 1.8521739130435, 0.51521739130435, 0.5
16784, 1.895652173913, 0.51521739130435, 0.5
16785, 1.9391304347826, 0.51521739130435, 0.5
16786, 1.9826086956522, 0.51521739130435, 0.5
16787, 2.0260869565217, 0.51521739130435, 0.5
16788, 2.0695652173913, 0.51521739130435, 0.5
16789, 2.1130434782609, 0.51521739130435, 0.5
16790, 2.1565217391304, 0.51521739130435, 0.5
16791, 1.2434782608696, 0.46304347826087, 0.5
16792, 1.2869565217391, 0.46304347826087, 0.5
16793, 1.3304347826087, 0.46304347826087, 0.5
16794, 1.3739130434783, 0.46304347826087, 0.5
16795, 1.4173913043478, 0.46304347826087, 0.5
16796, 1.4608695652174, 0.46304347826087, 0.5
16797, 1.504347826087, 0.46304347826087, 0.5
16798, 1.5478260869565, 0.46304347826087, 0.5
16799, 1.5913043478261, 0.46304347826087, 0.5
16800, 1.6347826086957, 0.46304347826087, 0.5
16801, 1.6782608695652, 0.46304347826087, 0.5
16802, 1.7217391304348, 0.46304347826087, 0.5
16803, 1.7652173913043, 0.46304347826087, 0.5
16804, 1.8086956521739, 0.46304347826087, 0.5
16805, 1.8521739130435, 0.46304347826087, 0.5
16806, 1.895652173913, 0.46304347826087, 0.5
16807, 1.9391304347826, 0.46304347826087, 0.5
16808, 1.9826086956522, 0.46304347826087, 0.5
16809, 2.0260869565217, 0.46304347826087, 0.5
16810, 2.0695652173913, 0.46304347826087, 0.5
16811, 2.1130434782609, 0.46304347826087, 0.5
16812, 2.1565217391304, 0.46304347826087, 0.5
16813, 1.2434782608696, 0.41086956521739, 0.5
16814, 1.2869565217391, 0.41086956521739, 0.5
16815, 1.3304347826087, 0.41086956521739, 0.5
16816, 1.3739130434783, 0.41086956521739, 0.5
16817, 1.4173913043478, 0.41086956521739, 0.5
16818, 1.4608695652174, 0.41086956521739, 0.5
16819, 1.504347826087, 0.41086956521739, 0.5
16820, 1.5478260869565, 0.41086956521739, 0.5
16821, 1.5913043478261, 0.41086956521739, 0.5
16822, 1.6347826086957, 0.41086956521739, 0.5
16823, 1.6782608695652, 0.41086956521739, 0.5
16824, 1.7217391304348, 0.41086956521739, 0.5
16825, 1.7652173913043, 0.41086956521739, 0.5
16826, 1.8086956521739, 0.41086956521739, 0.5
16827, 1.8521739130435, 0.41086956521739, 0.5
16828, 1.895652173913, 0.41086956521739, 0.5
16829, 1.9391304347826, 0.41086956521739, 0.5
16830, 1.9826086956522, 0.41086956521739, 0.5
16831, 2.0260869565217, 0.41086956521739, 0.5
16832, 2.0695652173913, 0.41086956521739, 0.5
16833, 2.1130434782609, 0.41086956521739, 0.5
16834, 2.1565217391304, 0.41086956521739, 0.5
16835, 1.2434782608696, 0.35869565217391, 0.5
16836, 1.2869565217391, 0.35869565217391, 0.5
16837, 1.3304347826087, 0.35869565217391, 0.5
16838, 1.3739130434783, 0.35869565217391, 0.5
16839, 1.4173913043478, 0.35869565217391, 0.5
16840, 1.4608695652174, 0.35869565217391, 0.5
16841, 1.504347826087, 0.35869565217391, 0.5
16842, 1.5478260869565, 0.35869565217391, 0.5
16843, 1.5913043478261, 0.35869565217391, 0.5
16844, 1.6347826086957, 0.35869565217391, 0.5
16845, 1.6782608695652, 0.35869565217391, 0.5
16846, 1.7217391304348, 0.35869565217391, 0.5
16847, 1.7652173913043, 0.35869565217391, 0.5
16848, 1.8086956521739, 0.35869565217391, 0.5
16849, 1.8521739130435, 0.35869565217391, 0.5
16850, 1.895652173913, 0.35869565217391, 0.5
16851, 1.9391304347826, 0.35869565217391, 0.5
16852, 1.9826086956522, 0.35869565217391, 0.5
16853, 2.0260869565217, 0.35869565217391, 0.5
16854, 2.0695652173913, 0.35869565217391, 0.5
16855, 2.1130434782609, 0.35869565217391, 0.5
16856, 2.1565217391304, 0.35869565217391, 0.5
16857, 1.2434782608696, 0.30652173913044, 0.5
16858, 1.2869565217391, 0.30652173913043, 0.5
16859, 1.3304347826087, 0.30652173913043, 0.5
16860, 1.3739130434783, 0.30652173913044, 0.5
16861, 1.4173913043478, 0.30652173913044, 0.5
16862, 1.4608695652174, 0.30652173913043, 0.5
16863, 1.504347826087, 0.30652173913044, 0.5
16864, 1.5478260869565, 0.30652173913044, 0.5
16865, 1.5913043478261, 0.30652173913044, 0.5
16866, 1.6347826086957, 0.30652173913043, 0.5
16867, 1.6782608695652, 0.30652173913043, 0.5
16868, 1.7217391304348, 0.30652173913043, 0.5
16869, 1.7652173913043, 0.30652173913043, 0.5
16870, 1.8086956521739, 0.30652173913044, 0.5
16871, 1.8521739130435, 0.30652173913043, 0.5
16872, 1.895652173913, 0.30652173913044, 0.5
16873, 1.9391304347826, 0.30652173913043, 0.5
16874, 1.9826086956522, 0.30652173913044, 0.5
16875, 2.0260869565217, 0.30652173913044, 0.5
16876, 2.0695652173913, 0.30652173913043, 0.5
16877, 2.1130434782609, 0.30652173913043, 0.5
16878, 2.1565217391304, 0.30652173913043, 0.5
16879, 1.2434782608696, 0.25434782608696, 0.5
16880, 1.2869565217391, 0.25434782608696, 0.5
16881, 1.3304347826087, 0.25434782608696, 0.5
16882, 1.3739130434783, 0.25434782608696, 0.5
16883, 1.4173913043478, 0.25434782608696, 0.5
16884, 1.4608695652174, 0.25434782608696, 0.5
16885, 1.504347826087, 0.25434782608696, 0.5
16886, 1.5478260869565, 0.25434782608696, 0.5
16887, 1.5913043478261, 0.25434782608696, 0.5
16888, 1.6347826086957, 0.25434782608696, 0.5
16889, 1.6782608695652, 0.25434782608696, 0.5
16890, 1.7217391304348, 0.25434782608696, 0.5
16891, 1.7652173913043, 0.25434782608696, 0.5
16892, 1.8086956521739, 0.25434782608696, 0.5
16893, 1.8521739130435, 0.25434782608696, 0.5
16894, 1.895652173913, 0.25434782608696, 0.5
16895, 1.9391304347826, 0.25434782608696, 0.5
16896, 1.9826086956522, 0.25434782608696, 0.5
16897, 2.0260869565217, 0.25434782608696, 0.5
16898, 2.0695652173913, 0.25434782608696, 0.5
16899, 2.1130434782609, 0.25434782608696, 0.5
16900, 2.1565217391304, 0.25434782608696, 0.5
16901, 1.2434782608696, 0.20217391304348, 0.5
16902, 1.2869565217391, 0.20217391304348, 0.5
16903, 1.3304347826087, 0.20217391304348, 0.5
16904, 1.3739130434783, 0.20217391304348, 0.5
16905, 1.4173913043478, 0.20217391304348, 0.5
16906, 1.4608695652174, 0.20217391304348, 0.5
16907, 1.504347826087, 0.20217391304348, 0.5
16908, 1.5478260869565, 0.20217391304348, 0.5
16909, 1.5913043478261, 0.20217391304348, 0.5
16910, 1.6347826086957, 0.20217391304348, 0.5
16911, 1.6782608695652, 0.20217391304348, 0.5
16912, 1.7217391304348, 0.20217391304348, 0.5
16913, 1.7652173913043, 0.20217391304348, 0.5
16914, 1.8086956521739, 0.20217391304348, 0.5
16915, 1.8521739130435, 0.20217391304348, 0.5
16916, 1.895652173913, 0.20217391304348, 0.5
16917, 1.9391304347826, 0.20217391304348, 0.5
16918, 1.9826086956522, 0.20217391304348, 0.5
16919, 2.0260869565217, 0.20217391304348, 0.5
16920, 2.0695652173913, 0.20217391304348, 0.5
16921, 2.1130434782609, 0.20217391304348, 0.5
16922, 2.1565217391304, 0.20217391304348, 0.5
16923, 1.2217391304348, 1.2978260869565, 0.5
16924, 1.2434782608696, 1.3239130434783, 0.5
16925, 1.2652173913043, 1.2978260869565, 0.5
