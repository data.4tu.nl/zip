23762, 0.39130434782609, 1.7, 0.18181818181818
23763, 0.39130434782609, 1.7, 0.22727272727273
23764, 0.39130434782609, 1.7, 0.27272727272727
23765, 0.39130434782609, 1.7, 0.31818181818182
23766, 0.39130434782609, 1.7, 0.36363636363636
23767, 0.39130434782609, 1.7, 0.40909090909091
23768, 0.39130434782609, 1.7, 0.45454545454545
23769, 0.43478260869565, 1.7, 0.045454545454545
23770, 0.43478260869565, 1.7, 0.090909090909091
23771, 0.43478260869565, 1.7, 0.13636363636364
23772, 0.43478260869565, 1.7, 0.18181818181818
23773, 0.43478260869565, 1.7, 0.22727272727273
23774, 0.43478260869565, 1.7, 0.27272727272727
23775, 0.43478260869565, 1.7, 0.31818181818182
23776, 0.43478260869565, 1.7, 0.36363636363636
23777, 0.43478260869565, 1.7, 0.40909090909091
23778, 0.43478260869565, 1.7, 0.45454545454545
23779, 0.47826086956522, 1.7, 0.045454545454545
23780, 0.47826086956522, 1.7, 0.090909090909091
23781, 0.47826086956522, 1.7, 0.13636363636364
23782, 0.47826086956522, 1.7, 0.18181818181818
23783, 0.47826086956522, 1.7, 0.22727272727273
23784, 0.47826086956522, 1.7, 0.27272727272727
23785, 0.47826086956522, 1.7, 0.31818181818182
23786, 0.47826086956522, 1.7, 0.36363636363636
23787, 0.47826086956522, 1.7, 0.40909090909091
23788, 0.47826086956522, 1.7, 0.45454545454545
23789, 0.52173913043478, 1.7, 0.045454545454545
23790, 0.52173913043478, 1.7, 0.090909090909091
23791, 0.52173913043478, 1.7, 0.13636363636364
23792, 0.52173913043478, 1.7, 0.18181818181818
23793, 0.52173913043478, 1.7, 0.22727272727273
23794, 0.52173913043478, 1.7, 0.27272727272727
23795, 0.52173913043478, 1.7, 0.31818181818182
23796, 0.52173913043478, 1.7, 0.36363636363636
23797, 0.52173913043478, 1.7, 0.40909090909091
23798, 0.52173913043478, 1.7, 0.45454545454545
23799, 0.56521739130435, 1.7, 0.045454545454545
23800, 0.56521739130435, 1.7, 0.090909090909091
23801, 0.56521739130435, 1.7, 0.13636363636364
23802, 0.56521739130435, 1.7, 0.18181818181818
23803, 0.56521739130435, 1.7, 0.22727272727273
23804, 0.56521739130435, 1.7, 0.27272727272727
23805, 0.56521739130435, 1.7, 0.31818181818182
23806, 0.56521739130435, 1.7, 0.36363636363636
23807, 0.56521739130435, 1.7, 0.40909090909091
23808, 0.56521739130435, 1.7, 0.45454545454545
23809, 0.60869565217391, 1.7, 0.045454545454545
23810, 0.60869565217391, 1.7, 0.090909090909091
23811, 0.60869565217391, 1.7, 0.13636363636364
23812, 0.60869565217391, 1.7, 0.18181818181818
23813, 0.60869565217391, 1.7, 0.22727272727273
23814, 0.60869565217391, 1.7, 0.27272727272727
23815, 0.60869565217391, 1.7, 0.31818181818182
23816, 0.60869565217391, 1.7, 0.36363636363636
23817, 0.60869565217391, 1.7, 0.40909090909091
23818, 0.60869565217391, 1.7, 0.45454545454545
23819, 0.65217391304348, 1.7, 0.045454545454545
23820, 0.65217391304348, 1.7, 0.090909090909091
23821, 0.65217391304348, 1.7, 0.13636363636364
23822, 0.65217391304348, 1.7, 0.18181818181818
23823, 0.65217391304348, 1.7, 0.22727272727273
23824, 0.65217391304348, 1.7, 0.27272727272727
23825, 0.65217391304348, 1.7, 0.31818181818182
23826, 0.65217391304348, 1.7, 0.36363636363636
23827, 0.65217391304348, 1.7, 0.40909090909091
23828, 0.65217391304348, 1.7, 0.45454545454545
23829, 0.69565217391304, 1.7, 0.045454545454545
23830, 0.69565217391304, 1.7, 0.090909090909091
23831, 0.69565217391304, 1.7, 0.13636363636364
23832, 0.69565217391304, 1.7, 0.18181818181818
23833, 0.69565217391304, 1.7, 0.22727272727273
23834, 0.69565217391304, 1.7, 0.27272727272727
23835, 0.69565217391304, 1.7, 0.31818181818182
23836, 0.69565217391304, 1.7, 0.36363636363636
23837, 0.69565217391304, 1.7, 0.40909090909091
23838, 0.69565217391304, 1.7, 0.45454545454545
23839, 0.73913043478261, 1.7, 0.045454545454545
23840, 0.73913043478261, 1.7, 0.090909090909091
23841, 0.73913043478261, 1.7, 0.13636363636364
23842, 0.73913043478261, 1.7, 0.18181818181818
23843, 0.73913043478261, 1.7, 0.22727272727273
23844, 0.73913043478261, 1.7, 0.27272727272727
23845, 0.73913043478261, 1.7, 0.31818181818182
23846, 0.73913043478261, 1.7, 0.36363636363636
23847, 0.73913043478261, 1.7, 0.40909090909091
23848, 0.73913043478261, 1.7, 0.45454545454545
23849, 0.78260869565217, 1.7, 0.045454545454545
23850, 0.78260869565217, 1.7, 0.090909090909091
23851, 0.78260869565217, 1.7, 0.13636363636364
23852, 0.78260869565217, 1.7, 0.18181818181818
23853, 0.78260869565217, 1.7, 0.22727272727273
23854, 0.78260869565217, 1.7, 0.27272727272727
23855, 0.78260869565217, 1.7, 0.31818181818182
23856, 0.78260869565217, 1.7, 0.36363636363636
23857, 0.78260869565217, 1.7, 0.40909090909091
23858, 0.78260869565217, 1.7, 0.45454545454545
23859, 0.82608695652174, 1.7, 0.045454545454545
23860, 0.82608695652174, 1.7, 0.090909090909091
23861, 0.82608695652174, 1.7, 0.13636363636364
23862, 0.82608695652174, 1.7, 0.18181818181818
23863, 0.82608695652174, 1.7, 0.22727272727273
23864, 0.82608695652174, 1.7, 0.27272727272727
23865, 0.82608695652174, 1.7, 0.31818181818182
23866, 0.82608695652174, 1.7, 0.36363636363636
23867, 0.82608695652174, 1.7, 0.40909090909091
23868, 0.82608695652174, 1.7, 0.45454545454545
23869, 0.8695652173913, 1.7, 0.045454545454545
23870, 0.8695652173913, 1.7, 0.090909090909091
23871, 0.8695652173913, 1.7, 0.13636363636364
23872, 0.8695652173913, 1.7, 0.18181818181818
23873, 0.8695652173913, 1.7, 0.22727272727273
23874, 0.8695652173913, 1.7, 0.27272727272727
23875, 0.8695652173913, 1.7, 0.31818181818182
23876, 0.8695652173913, 1.7, 0.36363636363636
23877, 0.8695652173913, 1.7, 0.40909090909091
23878, 0.8695652173913, 1.7, 0.45454545454545
23879, 0.91304347826087, 1.7, 0.045454545454545
23880, 0.91304347826087, 1.7, 0.090909090909091
23881, 0.91304347826087, 1.7, 0.13636363636364
23882, 0.91304347826087, 1.7, 0.18181818181818
23883, 0.91304347826087, 1.7, 0.22727272727273
23884, 0.91304347826087, 1.7, 0.27272727272727
23885, 0.91304347826087, 1.7, 0.31818181818182
23886, 0.91304347826087, 1.7, 0.36363636363636
23887, 0.91304347826087, 1.7, 0.40909090909091
23888, 0.91304347826087, 1.7, 0.45454545454545
23889, 0.95652173913043, 1.7, 0.045454545454545
23890, 0.95652173913043, 1.7, 0.090909090909091
23891, 0.95652173913044, 1.7, 0.13636363636364
23892, 0.95652173913043, 1.7, 0.18181818181818
23893, 0.95652173913043, 1.7, 0.22727272727273
23894, 0.95652173913043, 1.7, 0.27272727272727
23895, 0.95652173913043, 1.7, 0.31818181818182
23896, 0.95652173913043, 1.7, 0.36363636363636
23897, 0.95652173913043, 1.7, 0.40909090909091
23898, 0.95652173913043, 1.7, 0.45454545454545
23899, 0.021739130434783, 1.7, 0.045454545454545
23900, 0.043478260869565, 1.7, 0.022727272727273
23901, 0.021739130434783, 1.7, 0.090909090909091
23902, 0.043478260869565, 1.7, 0.068181818181818
23903, 0.021739130434783, 1.7, 0.13636363636364
23904, 0.043478260869565, 1.7, 0.11363636363636
23905, 0.021739130434783, 1.7, 0.18181818181818
23906, 0.043478260869565, 1.7, 0.15909090909091
23907, 0.021739130434783, 1.7, 0.22727272727273
23908, 0.043478260869565, 1.7, 0.20454545454545
23909, 0.021739130434783, 1.7, 0.27272727272727
23910, 0.043478260869565, 1.7, 0.25
23911, 0.021739130434783, 1.7, 0.31818181818182
23912, 0.043478260869565, 1.7, 0.29545454545455
23913, 0.021739130434783, 1.7, 0.36363636363636
23914, 0.043478260869565, 1.7, 0.34090909090909
23915, 0.021739130434783, 1.7, 0.40909090909091
23916, 0.043478260869565, 1.7, 0.38636363636364
23917, 0.021739130434783, 1.7, 0.45454545454545
23918, 0.043478260869565, 1.7, 0.43181818181818
23919, 0.043478260869565, 1.7, 0.47727272727273
23920, 0.065217391304348, 1.7, 0.045454545454545
23921, 0.08695652173913, 1.7, 0.022727272727273
23922, 0.065217391304348, 1.7, 0.090909090909091
23923, 0.08695652173913, 1.7, 0.068181818181818
23924, 0.065217391304348, 1.7, 0.13636363636364
23925, 0.08695652173913, 1.7, 0.11363636363636
23926, 0.065217391304348, 1.7, 0.18181818181818
23927, 0.08695652173913, 1.7, 0.15909090909091
23928, 0.065217391304348, 1.7, 0.22727272727273
23929, 0.08695652173913, 1.7, 0.20454545454545
23930, 0.065217391304348, 1.7, 0.27272727272727
23931, 0.08695652173913, 1.7, 0.25
23932, 0.065217391304348, 1.7, 0.31818181818182
23933, 0.08695652173913, 1.7, 0.29545454545455
23934, 0.065217391304348, 1.7, 0.36363636363636
23935, 0.08695652173913, 1.7, 0.34090909090909
23936, 0.065217391304348, 1.7, 0.40909090909091
23937, 0.08695652173913, 1.7, 0.38636363636364
23938, 0.065217391304348, 1.7, 0.45454545454545
23939, 0.08695652173913, 1.7, 0.43181818181818
23940, 0.08695652173913, 1.7, 0.47727272727273
23941, 0.10869565217391, 1.7, 0.045454545454545
23942, 0.1304347826087, 1.7, 0.022727272727273
23943, 0.10869565217391, 1.7, 0.090909090909091
23944, 0.1304347826087, 1.7, 0.068181818181818
23945, 0.10869565217391, 1.7, 0.13636363636364
23946, 0.1304347826087, 1.7, 0.11363636363636
23947, 0.10869565217391, 1.7, 0.18181818181818
23948, 0.1304347826087, 1.7, 0.15909090909091
23949, 0.10869565217391, 1.7, 0.22727272727273
23950, 0.1304347826087, 1.7, 0.20454545454545
23951, 0.10869565217391, 1.7, 0.27272727272727
23952, 0.1304347826087, 1.7, 0.25
23953, 0.10869565217391, 1.7, 0.31818181818182
23954, 0.1304347826087, 1.7, 0.29545454545455
23955, 0.10869565217391, 1.7, 0.36363636363636
23956, 0.1304347826087, 1.7, 0.34090909090909
23957, 0.10869565217391, 1.7, 0.40909090909091
23958, 0.1304347826087, 1.7, 0.38636363636364
23959, 0.10869565217391, 1.7, 0.45454545454545
23960, 0.1304347826087, 1.7, 0.43181818181818
23961, 0.1304347826087, 1.7, 0.47727272727273
23962, 0.15217391304348, 1.7, 0.045454545454545
23963, 0.17391304347826, 1.7, 0.022727272727273
23964, 0.15217391304348, 1.7, 0.090909090909091
23965, 0.17391304347826, 1.7, 0.068181818181818
23966, 0.15217391304348, 1.7, 0.13636363636364
23967, 0.17391304347826, 1.7, 0.11363636363636
23968, 0.15217391304348, 1.7, 0.18181818181818
23969, 0.17391304347826, 1.7, 0.15909090909091
23970, 0.15217391304348, 1.7, 0.22727272727273
23971, 0.17391304347826, 1.7, 0.20454545454545
23972, 0.15217391304348, 1.7, 0.27272727272727
23973, 0.17391304347826, 1.7, 0.25
23974, 0.15217391304348, 1.7, 0.31818181818182
23975, 0.17391304347826, 1.7, 0.29545454545455
23976, 0.15217391304348, 1.7, 0.36363636363636
23977, 0.17391304347826, 1.7, 0.34090909090909
23978, 0.15217391304348, 1.7, 0.40909090909091
23979, 0.17391304347826, 1.7, 0.38636363636364
23980, 0.15217391304348, 1.7, 0.45454545454545
23981, 0.17391304347826, 1.7, 0.43181818181818
23982, 0.17391304347826, 1.7, 0.47727272727273
23983, 0.19565217391304, 1.7, 0.045454545454545
23984, 0.21739130434783, 1.7, 0.022727272727273
23985, 0.19565217391304, 1.7, 0.090909090909091
23986, 0.21739130434783, 1.7, 0.068181818181818
23987, 0.19565217391304, 1.7, 0.13636363636364
23988, 0.21739130434783, 1.7, 0.11363636363636
23989, 0.19565217391304, 1.7, 0.18181818181818
23990, 0.21739130434783, 1.7, 0.15909090909091
23991, 0.19565217391304, 1.7, 0.22727272727273
23992, 0.21739130434783, 1.7, 0.20454545454545
23993, 0.19565217391304, 1.7, 0.27272727272727
23994, 0.21739130434783, 1.7, 0.25
23995, 0.19565217391304, 1.7, 0.31818181818182
23996, 0.21739130434783, 1.7, 0.29545454545455
23997, 0.19565217391304, 1.7, 0.36363636363636
23998, 0.21739130434783, 1.7, 0.34090909090909
23999, 0.19565217391304, 1.7, 0.40909090909091
24000, 0.21739130434783, 1.7, 0.38636363636364
24001, 0.19565217391304, 1.7, 0.45454545454545
24002, 0.21739130434783, 1.7, 0.43181818181818
24003, 0.21739130434783, 1.7, 0.47727272727273
24004, 0.23913043478261, 1.7, 0.045454545454545
24005, 0.26086956521739, 1.7, 0.022727272727273
24006, 0.23913043478261, 1.7, 0.090909090909091
24007, 0.26086956521739, 1.7, 0.068181818181818
24008, 0.23913043478261, 1.7, 0.13636363636364
24009, 0.26086956521739, 1.7, 0.11363636363636
24010, 0.23913043478261, 1.7, 0.18181818181818
24011, 0.26086956521739, 1.7, 0.15909090909091
24012, 0.23913043478261, 1.7, 0.22727272727273
24013, 0.26086956521739, 1.7, 0.20454545454545
24014, 0.23913043478261, 1.7, 0.27272727272727
24015, 0.26086956521739, 1.7, 0.25
24016, 0.23913043478261, 1.7, 0.31818181818182
24017, 0.26086956521739, 1.7, 0.29545454545455
24018, 0.23913043478261, 1.7, 0.36363636363636
24019, 0.26086956521739, 1.7, 0.34090909090909
24020, 0.23913043478261, 1.7, 0.40909090909091
24021, 0.26086956521739, 1.7, 0.38636363636364
24022, 0.23913043478261, 1.7, 0.45454545454545
24023, 0.26086956521739, 1.7, 0.43181818181818
24024, 0.26086956521739, 1.7, 0.47727272727273
24025, 0.28260869565217, 1.7, 0.045454545454545
24026, 0.30434782608696, 1.7, 0.022727272727273
24027, 0.28260869565217, 1.7, 0.090909090909091
24028, 0.30434782608696, 1.7, 0.068181818181818
24029, 0.28260869565217, 1.7, 0.13636363636364
24030, 0.30434782608696, 1.7, 0.11363636363636
24031, 0.28260869565217, 1.7, 0.18181818181818
24032, 0.30434782608696, 1.7, 0.15909090909091
24033, 0.28260869565217, 1.7, 0.22727272727273
24034, 0.30434782608696, 1.7, 0.20454545454545
24035, 0.28260869565217, 1.7, 0.27272727272727
24036, 0.30434782608696, 1.7, 0.25
24037, 0.28260869565217, 1.7, 0.31818181818182
24038, 0.30434782608696, 1.7, 0.29545454545455
24039, 0.28260869565217, 1.7, 0.36363636363636
24040, 0.30434782608696, 1.7, 0.34090909090909
24041, 0.28260869565217, 1.7, 0.40909090909091
24042, 0.30434782608696, 1.7, 0.38636363636364
24043, 0.28260869565217, 1.7, 0.45454545454545
24044, 0.30434782608696, 1.7, 0.43181818181818
24045, 0.30434782608696, 1.7, 0.47727272727273
24046, 0.32608695652174, 1.7, 0.045454545454545
24047, 0.34782608695652, 1.7, 0.022727272727273
24048, 0.32608695652174, 1.7, 0.090909090909091
24049, 0.34782608695652, 1.7, 0.068181818181818
24050, 0.32608695652174, 1.7, 0.13636363636364
24051, 0.34782608695652, 1.7, 0.11363636363636
24052, 0.32608695652174, 1.7, 0.18181818181818
24053, 0.34782608695652, 1.7, 0.15909090909091
24054, 0.32608695652174, 1.7, 0.22727272727273
24055, 0.34782608695652, 1.7, 0.20454545454545
24056, 0.32608695652174, 1.7, 0.27272727272727
24057, 0.34782608695652, 1.7, 0.25
24058, 0.32608695652174, 1.7, 0.31818181818182
24059, 0.34782608695652, 1.7, 0.29545454545455
24060, 0.32608695652174, 1.7, 0.36363636363636
24061, 0.34782608695652, 1.7, 0.34090909090909
24062, 0.32608695652174, 1.7, 0.40909090909091
24063, 0.34782608695652, 1.7, 0.38636363636364
24064, 0.32608695652174, 1.7, 0.45454545454545
24065, 0.34782608695652, 1.7, 0.43181818181818
24066, 0.34782608695652, 1.7, 0.47727272727273
24067, 0.3695652173913, 1.7, 0.045454545454545
24068, 0.39130434782609, 1.7, 0.022727272727273
24069, 0.3695652173913, 1.7, 0.090909090909091
24070, 0.39130434782609, 1.7, 0.068181818181818
24071, 0.3695652173913, 1.7, 0.13636363636364
24072, 0.39130434782609, 1.7, 0.11363636363636
24073, 0.3695652173913, 1.7, 0.18181818181818
24074, 0.39130434782609, 1.7, 0.15909090909091
24075, 0.3695652173913, 1.7, 0.22727272727273
24076, 0.39130434782609, 1.7, 0.20454545454545
24077, 0.3695652173913, 1.7, 0.27272727272727
24078, 0.39130434782609, 1.7, 0.25
24079, 0.3695652173913, 1.7, 0.31818181818182
24080, 0.39130434782609, 1.7, 0.29545454545455
24081, 0.3695652173913, 1.7, 0.36363636363636
24082, 0.39130434782609, 1.7, 0.34090909090909
24083, 0.3695652173913, 1.7, 0.40909090909091
24084, 0.39130434782609, 1.7, 0.38636363636364
24085, 0.3695652173913, 1.7, 0.45454545454545
24086, 0.39130434782609, 1.7, 0.43181818181818
24087, 0.39130434782609, 1.7, 0.47727272727273
24088, 0.41304347826087, 1.7, 0.045454545454545
24089, 0.43478260869565, 1.7, 0.022727272727273
24090, 0.41304347826087, 1.7, 0.090909090909091
24091, 0.43478260869565, 1.7, 0.068181818181818
24092, 0.41304347826087, 1.7, 0.13636363636364
24093, 0.43478260869565, 1.7, 0.11363636363636
24094, 0.41304347826087, 1.7, 0.18181818181818
24095, 0.43478260869565, 1.7, 0.15909090909091
24096, 0.41304347826087, 1.7, 0.22727272727273
24097, 0.43478260869565, 1.7, 0.20454545454545
24098, 0.41304347826087, 1.7, 0.27272727272727
24099, 0.43478260869565, 1.7, 0.25
24100, 0.41304347826087, 1.7, 0.31818181818182
24101, 0.43478260869565, 1.7, 0.29545454545455
24102, 0.41304347826087, 1.7, 0.36363636363636
24103, 0.43478260869565, 1.7, 0.34090909090909
24104, 0.41304347826087, 1.7, 0.40909090909091
24105, 0.43478260869565, 1.7, 0.38636363636364
24106, 0.41304347826087, 1.7, 0.45454545454545
24107, 0.43478260869565, 1.7, 0.43181818181818
24108, 0.43478260869565, 1.7, 0.47727272727273
24109, 0.45652173913043, 1.7, 0.045454545454545
24110, 0.47826086956522, 1.7, 0.022727272727273
24111, 0.45652173913043, 1.7, 0.090909090909091
24112, 0.47826086956522, 1.7, 0.068181818181818
24113, 0.45652173913043, 1.7, 0.13636363636364
24114, 0.47826086956522, 1.7, 0.11363636363636
24115, 0.45652173913043, 1.7, 0.18181818181818
24116, 0.47826086956522, 1.7, 0.15909090909091
24117, 0.45652173913043, 1.7, 0.22727272727273
24118, 0.47826086956522, 1.7, 0.20454545454545
24119, 0.45652173913043, 1.7, 0.27272727272727
24120, 0.47826086956522, 1.7, 0.25
24121, 0.45652173913043, 1.7, 0.31818181818182
24122, 0.47826086956522, 1.7, 0.29545454545455
24123, 0.45652173913043, 1.7, 0.36363636363636
24124, 0.47826086956522, 1.7, 0.34090909090909
24125, 0.45652173913043, 1.7, 0.40909090909091
24126, 0.47826086956522, 1.7, 0.38636363636364
24127, 0.45652173913043, 1.7, 0.45454545454545
24128, 0.47826086956522, 1.7, 0.43181818181818
24129, 0.47826086956522, 1.7, 0.47727272727273
24130, 0.5, 1.7, 0.045454545454545
24131, 0.52173913043478, 1.7, 0.022727272727273
24132, 0.5, 1.7, 0.090909090909091
24133, 0.52173913043478, 1.7, 0.068181818181818
24134, 0.5, 1.7, 0.13636363636364
24135, 0.52173913043478, 1.7, 0.11363636363636
24136, 0.5, 1.7, 0.18181818181818
24137, 0.52173913043478, 1.7, 0.15909090909091
24138, 0.5, 1.7, 0.22727272727273
24139, 0.52173913043478, 1.7, 0.20454545454545
24140, 0.5, 1.7, 0.27272727272727
24141, 0.52173913043478, 1.7, 0.25
24142, 0.5, 1.7, 0.31818181818182
24143, 0.52173913043478, 1.7, 0.29545454545455
24144, 0.5, 1.7, 0.36363636363636
24145, 0.52173913043478, 1.7, 0.34090909090909
24146, 0.5, 1.7, 0.40909090909091
24147, 0.52173913043478, 1.7, 0.38636363636364
24148, 0.5, 1.7, 0.45454545454545
24149, 0.52173913043478, 1.7, 0.43181818181818
24150, 0.52173913043478, 1.7, 0.47727272727273
24151, 0.54347826086957, 1.7, 0.045454545454545
24152, 0.56521739130435, 1.7, 0.022727272727273
24153, 0.54347826086957, 1.7, 0.090909090909091
24154, 0.56521739130435, 1.7, 0.068181818181818
24155, 0.54347826086957, 1.7, 0.13636363636364
24156, 0.56521739130435, 1.7, 0.11363636363636
24157, 0.54347826086957, 1.7, 0.18181818181818
24158, 0.56521739130435, 1.7, 0.15909090909091
24159, 0.54347826086957, 1.7, 0.22727272727273
24160, 0.56521739130435, 1.7, 0.20454545454545
24161, 0.54347826086957, 1.7, 0.27272727272727
24162, 0.56521739130435, 1.7, 0.25
24163, 0.54347826086957, 1.7, 0.31818181818182
24164, 0.56521739130435, 1.7, 0.29545454545455
24165, 0.54347826086957, 1.7, 0.36363636363636
24166, 0.56521739130435, 1.7, 0.34090909090909
24167, 0.54347826086957, 1.7, 0.40909090909091
24168, 0.56521739130435, 1.7, 0.38636363636364
24169, 0.54347826086957, 1.7, 0.45454545454545
24170, 0.56521739130435, 1.7, 0.43181818181818
24171, 0.56521739130435, 1.7, 0.47727272727273
24172, 0.58695652173913, 1.7, 0.045454545454545
24173, 0.60869565217391, 1.7, 0.022727272727273
24174, 0.58695652173913, 1.7, 0.090909090909091
24175, 0.60869565217391, 1.7, 0.068181818181818
24176, 0.58695652173913, 1.7, 0.13636363636364
24177, 0.60869565217391, 1.7, 0.11363636363636
24178, 0.58695652173913, 1.7, 0.18181818181818
24179, 0.60869565217391, 1.7, 0.15909090909091
24180, 0.58695652173913, 1.7, 0.22727272727273
24181, 0.60869565217391, 1.7, 0.20454545454545
24182, 0.58695652173913, 1.7, 0.27272727272727
24183, 0.60869565217391, 1.7, 0.25
24184, 0.58695652173913, 1.7, 0.31818181818182
24185, 0.60869565217391, 1.7, 0.29545454545455
24186, 0.58695652173913, 1.7, 0.36363636363636
24187, 0.60869565217391, 1.7, 0.34090909090909
24188, 0.58695652173913, 1.7, 0.40909090909091
24189, 0.60869565217391, 1.7, 0.38636363636364
24190, 0.58695652173913, 1.7, 0.45454545454545
24191, 0.60869565217391, 1.7, 0.43181818181818
24192, 0.60869565217391, 1.7, 0.47727272727273
24193, 0.6304347826087, 1.7, 0.045454545454545
24194, 0.65217391304348, 1.7, 0.022727272727273
24195, 0.6304347826087, 1.7, 0.090909090909091
24196, 0.65217391304348, 1.7, 0.068181818181818
24197, 0.6304347826087, 1.7, 0.13636363636364
24198, 0.65217391304348, 1.7, 0.11363636363636
24199, 0.6304347826087, 1.7, 0.18181818181818
24200, 0.65217391304348, 1.7, 0.15909090909091
24201, 0.6304347826087, 1.7, 0.22727272727273
24202, 0.65217391304348, 1.7, 0.20454545454545
24203, 0.6304347826087, 1.7, 0.27272727272727
24204, 0.65217391304348, 1.7, 0.25
24205, 0.6304347826087, 1.7, 0.31818181818182
24206, 0.65217391304348, 1.7, 0.29545454545455
24207, 0.6304347826087, 1.7, 0.36363636363636
24208, 0.65217391304348, 1.7, 0.34090909090909
24209, 0.6304347826087, 1.7, 0.40909090909091
24210, 0.65217391304348, 1.7, 0.38636363636364
24211, 0.6304347826087, 1.7, 0.45454545454545
24212, 0.65217391304348, 1.7, 0.43181818181818
24213, 0.65217391304348, 1.7, 0.47727272727273
24214, 0.67391304347826, 1.7, 0.045454545454545
24215, 0.69565217391304, 1.7, 0.022727272727273
24216, 0.67391304347826, 1.7, 0.090909090909091
24217, 0.69565217391304, 1.7, 0.068181818181818
24218, 0.67391304347826, 1.7, 0.13636363636364
24219, 0.69565217391304, 1.7, 0.11363636363636
24220, 0.67391304347826, 1.7, 0.18181818181818
24221, 0.69565217391304, 1.7, 0.15909090909091
24222, 0.67391304347826, 1.7, 0.22727272727273
24223, 0.69565217391304, 1.7, 0.20454545454545
24224, 0.67391304347826, 1.7, 0.27272727272727
24225, 0.69565217391304, 1.7, 0.25
24226, 0.67391304347826, 1.7, 0.31818181818182
24227, 0.69565217391304, 1.7, 0.29545454545455
24228, 0.67391304347826, 1.7, 0.36363636363636
24229, 0.69565217391304, 1.7, 0.34090909090909
24230, 0.67391304347826, 1.7, 0.40909090909091
24231, 0.69565217391304, 1.7, 0.38636363636364
24232, 0.67391304347826, 1.7, 0.45454545454545
24233, 0.69565217391304, 1.7, 0.43181818181818
24234, 0.69565217391304, 1.7, 0.47727272727273
24235, 0.71739130434783, 1.7, 0.045454545454545
24236, 0.73913043478261, 1.7, 0.022727272727273
24237, 0.71739130434783, 1.7, 0.090909090909091
24238, 0.73913043478261, 1.7, 0.068181818181818
24239, 0.71739130434783, 1.7, 0.13636363636364
24240, 0.73913043478261, 1.7, 0.11363636363636
24241, 0.71739130434783, 1.7, 0.18181818181818
24242, 0.73913043478261, 1.7, 0.15909090909091
24243, 0.71739130434783, 1.7, 0.22727272727273
24244, 0.73913043478261, 1.7, 0.20454545454545
24245, 0.71739130434783, 1.7, 0.27272727272727
24246, 0.73913043478261, 1.7, 0.25
24247, 0.71739130434783, 1.7, 0.31818181818182
24248, 0.73913043478261, 1.7, 0.29545454545455
24249, 0.71739130434783, 1.7, 0.36363636363636
24250, 0.73913043478261, 1.7, 0.34090909090909
24251, 0.71739130434783, 1.7, 0.40909090909091
24252, 0.73913043478261, 1.7, 0.38636363636364
24253, 0.71739130434783, 1.7, 0.45454545454545
24254, 0.73913043478261, 1.7, 0.43181818181818
24255, 0.73913043478261, 1.7, 0.47727272727273
24256, 0.76086956521739, 1.7, 0.045454545454545
24257, 0.78260869565217, 1.7, 0.022727272727273
24258, 0.76086956521739, 1.7, 0.090909090909091
24259, 0.78260869565217, 1.7, 0.068181818181818
24260, 0.76086956521739, 1.7, 0.13636363636364
24261, 0.78260869565217, 1.7, 0.11363636363636
24262, 0.76086956521739, 1.7, 0.18181818181818
24263, 0.78260869565217, 1.7, 0.15909090909091
24264, 0.76086956521739, 1.7, 0.22727272727273
24265, 0.78260869565217, 1.7, 0.20454545454545
24266, 0.76086956521739, 1.7, 0.27272727272727
24267, 0.78260869565217, 1.7, 0.25
24268, 0.76086956521739, 1.7, 0.31818181818182
24269, 0.78260869565217, 1.7, 0.29545454545455
24270, 0.76086956521739, 1.7, 0.36363636363636
24271, 0.78260869565217, 1.7, 0.34090909090909
24272, 0.76086956521739, 1.7, 0.40909090909091
24273, 0.78260869565217, 1.7, 0.38636363636364
24274, 0.76086956521739, 1.7, 0.45454545454545
24275, 0.78260869565217, 1.7, 0.43181818181818
24276, 0.78260869565217, 1.7, 0.47727272727273
24277, 0.80434782608696, 1.7, 0.045454545454545
24278, 0.82608695652174, 1.7, 0.022727272727273
24279, 0.80434782608696, 1.7, 0.090909090909091
24280, 0.82608695652174, 1.7, 0.068181818181818
24281, 0.80434782608696, 1.7, 0.13636363636364
24282, 0.82608695652174, 1.7, 0.11363636363636
24283, 0.80434782608696, 1.7, 0.18181818181818
24284, 0.82608695652174, 1.7, 0.15909090909091
24285, 0.80434782608696, 1.7, 0.22727272727273
24286, 0.82608695652174, 1.7, 0.20454545454545
24287, 0.80434782608696, 1.7, 0.27272727272727
24288, 0.82608695652174, 1.7, 0.25
24289, 0.80434782608696, 1.7, 0.31818181818182
24290, 0.82608695652174, 1.7, 0.29545454545455
24291, 0.80434782608696, 1.7, 0.36363636363636
24292, 0.82608695652174, 1.7, 0.34090909090909
24293, 0.80434782608696, 1.7, 0.40909090909091
24294, 0.82608695652174, 1.7, 0.38636363636364
24295, 0.80434782608696, 1.7, 0.45454545454545
24296, 0.82608695652174, 1.7, 0.43181818181818
24297, 0.82608695652174, 1.7, 0.47727272727273
24298, 0.84782608695652, 1.7, 0.045454545454545
24299, 0.8695652173913, 1.7, 0.022727272727273
24300, 0.84782608695652, 1.7, 0.090909090909091
24301, 0.8695652173913, 1.7, 0.068181818181818
24302, 0.84782608695652, 1.7, 0.13636363636364
24303, 0.8695652173913, 1.7, 0.11363636363636
24304, 0.84782608695652, 1.7, 0.18181818181818
24305, 0.8695652173913, 1.7, 0.15909090909091
24306, 0.84782608695652, 1.7, 0.22727272727273
24307, 0.8695652173913, 1.7, 0.20454545454545
24308, 0.84782608695652, 1.7, 0.27272727272727
24309, 0.8695652173913, 1.7, 0.25
24310, 0.84782608695652, 1.7, 0.31818181818182
24311, 0.8695652173913, 1.7, 0.29545454545455
24312, 0.84782608695652, 1.7, 0.36363636363636
24313, 0.8695652173913, 1.7, 0.34090909090909
24314, 0.84782608695652, 1.7, 0.40909090909091
24315, 0.8695652173913, 1.7, 0.38636363636364
24316, 0.84782608695652, 1.7, 0.45454545454545
24317, 0.8695652173913, 1.7, 0.43181818181818
24318, 0.8695652173913, 1.7, 0.47727272727273
24319, 0.89130434782609, 1.7, 0.045454545454545
24320, 0.91304347826087, 1.7, 0.022727272727273
24321, 0.89130434782609, 1.7, 0.090909090909091
24322, 0.91304347826087, 1.7, 0.068181818181818
24323, 0.89130434782609, 1.7, 0.13636363636364
24324, 0.91304347826087, 1.7, 0.11363636363636
24325, 0.89130434782609, 1.7, 0.18181818181818
24326, 0.91304347826087, 1.7, 0.15909090909091
24327, 0.89130434782609, 1.7, 0.22727272727273
24328, 0.91304347826087, 1.7, 0.20454545454545
24329, 0.89130434782609, 1.7, 0.27272727272727
24330, 0.91304347826087, 1.7, 0.25
24331, 0.89130434782609, 1.7, 0.31818181818182
24332, 0.91304347826087, 1.7, 0.29545454545455
24333, 0.89130434782609, 1.7, 0.36363636363636
24334, 0.91304347826087, 1.7, 0.34090909090909
24335, 0.89130434782609, 1.7, 0.40909090909091
24336, 0.91304347826087, 1.7, 0.38636363636364
24337, 0.89130434782609, 1.7, 0.45454545454545
24338, 0.91304347826087, 1.7, 0.43181818181818
24339, 0.91304347826087, 1.7, 0.47727272727273
24340, 0.93478260869565, 1.7, 0.045454545454545
24341, 0.95652173913043, 1.7, 0.022727272727273
24342, 0.93478260869565, 1.7, 0.090909090909091
24343, 0.95652173913043, 1.7, 0.068181818181818
24344, 0.93478260869565, 1.7, 0.13636363636364
24345, 0.95652173913044, 1.7, 0.11363636363636
24346, 0.93478260869565, 1.7, 0.18181818181818
24347, 0.95652173913043, 1.7, 0.15909090909091
24348, 0.93478260869565, 1.7, 0.22727272727273
24349, 0.95652173913043, 1.7, 0.20454545454545
24350, 0.93478260869565, 1.7, 0.27272727272727
24351, 0.95652173913043, 1.7, 0.25
24352, 0.93478260869565, 1.7, 0.31818181818182
24353, 0.95652173913043, 1.7, 0.29545454545455
24354, 0.93478260869565, 1.7, 0.36363636363636
24355, 0.95652173913043, 1.7, 0.34090909090909
24356, 0.93478260869565, 1.7, 0.40909090909091
24357, 0.95652173913043, 1.7, 0.38636363636364
24358, 0.93478260869565, 1.7, 0.45454545454545
24359, 0.95652173913043, 1.7, 0.43181818181818
24360, 0.95652173913043, 1.7, 0.47727272727273
24361, 0.97826086956522, 1.7, 0.045454545454545
24362, 0.97826086956522, 1.7, 0.090909090909091
24363, 0.97826086956522, 1.7, 0.13636363636364
24364, 0.97826086956522, 1.7, 0.18181818181818
24365, 0.97826086956522, 1.7, 0.22727272727273
24366, 0.97826086956522, 1.7, 0.27272727272727
24367, 0.97826086956522, 1.7, 0.31818181818182
24368, 0.97826086956522, 1.7, 0.36363636363636
24369, 0.97826086956522, 1.7, 0.40909090909091
24370, 0.97826086956522, 1.7, 0.45454545454545
24371, 1.04, 1.55, 0.5
24372, 1.08, 1.55, 0.5
24373, 1.12, 1.55, 0.5
24374, 1.16, 1.55, 0.5
24375, 1.04, 1.6, 0.5
24376, 1.08, 1.6, 0.5
24377, 1.12, 1.6, 0.5
24378, 1.16, 1.6, 0.5
24379, 1.04, 1.65, 0.5
24380, 1.08, 1.65, 0.5
24381, 1.12, 1.65, 0.5
24382, 1.16, 1.65, 0.5
24383, 1.04, 1.525, 0.5
24384, 1.02, 1.55, 0.5
24385, 1.08, 1.525, 0.5
24386, 1.06, 1.55, 0.5
24387, 1.12, 1.525, 0.5
24388, 1.1, 1.55, 0.5
24389, 1.16, 1.525, 0.5
24390, 1.14, 1.55, 0.5
24391, 1.18, 1.55, 0.5
24392, 1.04, 1.575, 0.5
24393, 1.02, 1.6, 0.5
24394, 1.08, 1.575, 0.5
24395, 1.06, 1.6, 0.5
24396, 1.12, 1.575, 0.5
24397, 1.1, 1.6, 0.5
24398, 1.16, 1.575, 0.5
24399, 1.14, 1.6, 0.5
24400, 1.18, 1.6, 0.5
24401, 1.04, 1.625, 0.5
24402, 1.02, 1.65, 0.5
24403, 1.08, 1.625, 0.5
24404, 1.06, 1.65, 0.5
24405, 1.12, 1.625, 0.5
24406, 1.1, 1.65, 0.5
24407, 1.16, 1.625, 0.5
24408, 1.14, 1.65, 0.5
24409, 1.18, 1.65, 0.5
24410, 1.04, 1.675, 0.5
24411, 1.08, 1.675, 0.5
24412, 1.12, 1.675, 0.5
24413, 1.16, 1.675, 0.5
24414, 1.04, 1.55, 0
24415, 1.08, 1.55, 0
24416, 1.12, 1.55, 0
24417, 1.16, 1.55, 0
24418, 1.04, 1.6, 0
24419, 1.08, 1.6, 0
24420, 1.12, 1.6, 0
24421, 1.16, 1.6, 0
24422, 1.04, 1.65, 0
24423, 1.08, 1.65, 0
24424, 1.12, 1.65, 0
24425, 1.16, 1.65, 0
24426, 1.02, 1.55, 0
24427, 1.04, 1.525, 0
24428, 1.06, 1.55, 0
24429, 1.08, 1.525, 0
24430, 1.1, 1.55, 0
24431, 1.12, 1.525, 0
24432, 1.14, 1.55, 0
24433, 1.16, 1.525, 0
24434, 1.18, 1.55, 0
24435, 1.02, 1.6, 0
24436, 1.04, 1.575, 0
24437, 1.06, 1.6, 0
24438, 1.08, 1.575, 0
24439, 1.1, 1.6, 0
24440, 1.12, 1.575, 0
24441, 1.14, 1.6, 0
24442, 1.16, 1.575, 0
24443, 1.18, 1.6, 0
24444, 1.02, 1.65, 0
24445, 1.04, 1.625, 0
24446, 1.06, 1.65, 0
24447, 1.08, 1.625, 0
24448, 1.1, 1.65, 0
24449, 1.12, 1.625, 0
24450, 1.14, 1.65, 0
24451, 1.16, 1.625, 0
24452, 1.18, 1.65, 0
24453, 1.04, 1.675, 0
24454, 1.08, 1.675, 0
24455, 1.12, 1.675, 0
24456, 1.16, 1.675, 0
24457, 1.2, 1.55, 0.45454545454545
24458, 1.2, 1.55, 0.40909090909091
24459, 1.2, 1.55, 0.36363636363636
24460, 1.2, 1.55, 0.31818181818182
24461, 1.2, 1.55, 0.27272727272727
24462, 1.2, 1.55, 0.22727272727273
24463, 1.2, 1.55, 0.18181818181818
24464, 1.2, 1.55, 0.13636363636364
24465, 1.2, 1.55, 0.090909090909091
24466, 1.2, 1.55, 0.045454545454545
24467, 1.2, 1.6, 0.45454545454545
24468, 1.2, 1.6, 0.40909090909091
24469, 1.2, 1.6, 0.36363636363636
24470, 1.2, 1.6, 0.31818181818182
24471, 1.2, 1.6, 0.27272727272727
24472, 1.2, 1.6, 0.22727272727273
24473, 1.2, 1.6, 0.18181818181818
24474, 1.2, 1.6, 0.13636363636364
24475, 1.2, 1.6, 0.090909090909091
24476, 1.2, 1.6, 0.045454545454545
24477, 1.2, 1.65, 0.45454545454545
24478, 1.2, 1.65, 0.40909090909091
24479, 1.2, 1.65, 0.36363636363636
24480, 1.2, 1.65, 0.31818181818182
24481, 1.2, 1.65, 0.27272727272727
24482, 1.2, 1.65, 0.22727272727273
24483, 1.2, 1.65, 0.18181818181818
24484, 1.2, 1.65, 0.13636363636364
24485, 1.2, 1.65, 0.090909090909091
24486, 1.2, 1.65, 0.045454545454545
24487, 1.2, 1.525, 0.45454545454545
24488, 1.2, 1.55, 0.47727272727273
24489, 1.2, 1.525, 0.40909090909091
24490, 1.2, 1.55, 0.43181818181818
24491, 1.2, 1.525, 0.36363636363636
24492, 1.2, 1.55, 0.38636363636364
24493, 1.2, 1.525, 0.31818181818182
24494, 1.2, 1.55, 0.34090909090909
24495, 1.2, 1.525, 0.27272727272727
24496, 1.2, 1.55, 0.29545454545455
24497, 1.2, 1.525, 0.22727272727273
24498, 1.2, 1.55, 0.25
24499, 1.2, 1.525, 0.18181818181818
24500, 1.2, 1.55, 0.20454545454545
24501, 1.2, 1.525, 0.13636363636364
24502, 1.2, 1.55, 0.15909090909091
24503, 1.2, 1.525, 0.090909090909091
24504, 1.2, 1.55, 0.11363636363636
24505, 1.2, 1.525, 0.045454545454545
24506, 1.2, 1.55, 0.068181818181818
24507, 1.2, 1.55, 0.022727272727273
24508, 1.2, 1.575, 0.45454545454545
24509, 1.2, 1.6, 0.47727272727273
24510, 1.2, 1.575, 0.40909090909091
24511, 1.2, 1.6, 0.43181818181818
24512, 1.2, 1.575, 0.36363636363636
24513, 1.2, 1.6, 0.38636363636364
24514, 1.2, 1.575, 0.31818181818182
24515, 1.2, 1.6, 0.34090909090909
24516, 1.2, 1.575, 0.27272727272727
24517, 1.2, 1.6, 0.29545454545455
24518, 1.2, 1.575, 0.22727272727273
24519, 1.2, 1.6, 0.25
24520, 1.2, 1.575, 0.18181818181818
24521, 1.2, 1.6, 0.20454545454545
24522, 1.2, 1.575, 0.13636363636364
24523, 1.2, 1.6, 0.15909090909091
24524, 1.2, 1.575, 0.090909090909091
24525, 1.2, 1.6, 0.11363636363636
24526, 1.2, 1.575, 0.045454545454545
24527, 1.2, 1.6, 0.068181818181818
24528, 1.2, 1.6, 0.022727272727273
24529, 1.2, 1.625, 0.45454545454545
24530, 1.2, 1.65, 0.47727272727273
24531, 1.2, 1.625, 0.40909090909091
24532, 1.2, 1.65, 0.43181818181818
24533, 1.2, 1.625, 0.36363636363636
24534, 1.2, 1.65, 0.38636363636364
24535, 1.2, 1.625, 0.31818181818182
24536, 1.2, 1.65, 0.34090909090909
24537, 1.2, 1.625, 0.27272727272727
24538, 1.2, 1.65, 0.29545454545455
24539, 1.2, 1.625, 0.22727272727273
24540, 1.2, 1.65, 0.25
24541, 1.2, 1.625, 0.18181818181818
24542, 1.2, 1.65, 0.20454545454545
24543, 1.2, 1.625, 0.13636363636364
24544, 1.2, 1.65, 0.15909090909091
24545, 1.2, 1.625, 0.090909090909091
24546, 1.2, 1.65, 0.11363636363636
24547, 1.2, 1.625, 0.045454545454545
24548, 1.2, 1.65, 0.068181818181818
24549, 1.2, 1.65, 0.022727272727273
24550, 1.2, 1.675, 0.45454545454545
24551, 1.2, 1.675, 0.40909090909091
24552, 1.2, 1.675, 0.36363636363636
24553, 1.2, 1.675, 0.31818181818182
24554, 1.2, 1.675, 0.27272727272727
24555, 1.2, 1.675, 0.22727272727273
24556, 1.2, 1.675, 0.18181818181818
24557, 1.2, 1.675, 0.13636363636364
24558, 1.2, 1.675, 0.090909090909091
24559, 1.2, 1.675, 0.045454545454545
24560, 1.04, 1.7, 0.45454545454545
24561, 1.04, 1.7, 0.40909090909091
24562, 1.04, 1.7, 0.36363636363636
24563, 1.04, 1.7, 0.31818181818182
24564, 1.04, 1.7, 0.27272727272727
24565, 1.04, 1.7, 0.22727272727273
24566, 1.04, 1.7, 0.18181818181818
24567, 1.04, 1.7, 0.13636363636364
24568, 1.04, 1.7, 0.090909090909091
24569, 1.04, 1.7, 0.045454545454545
24570, 1.08, 1.7, 0.45454545454545
24571, 1.08, 1.7, 0.40909090909091
24572, 1.08, 1.7, 0.36363636363636
24573, 1.08, 1.7, 0.31818181818182
24574, 1.08, 1.7, 0.27272727272727
24575, 1.08, 1.7, 0.22727272727273
24576, 1.08, 1.7, 0.18181818181818
24577, 1.08, 1.7, 0.13636363636364
24578, 1.08, 1.7, 0.090909090909091
24579, 1.08, 1.7, 0.045454545454545
24580, 1.12, 1.7, 0.45454545454545
24581, 1.12, 1.7, 0.40909090909091
24582, 1.12, 1.7, 0.36363636363636
24583, 1.12, 1.7, 0.31818181818182
24584, 1.12, 1.7, 0.27272727272727
24585, 1.12, 1.7, 0.22727272727273
24586, 1.12, 1.7, 0.18181818181818
24587, 1.12, 1.7, 0.13636363636364
24588, 1.12, 1.7, 0.090909090909091
24589, 1.12, 1.7, 0.045454545454545
24590, 1.16, 1.7, 0.45454545454545
24591, 1.16, 1.7, 0.40909090909091
24592, 1.16, 1.7, 0.36363636363636
24593, 1.16, 1.7, 0.31818181818182
24594, 1.16, 1.7, 0.27272727272727
24595, 1.16, 1.7, 0.22727272727273
24596, 1.16, 1.7, 0.18181818181818
24597, 1.16, 1.7, 0.13636363636364
24598, 1.16, 1.7, 0.090909090909091
24599, 1.16, 1.7, 0.045454545454545
24600, 1.04, 1.7, 0.47727272727273
24601, 1.02, 1.7, 0.45454545454545
24602, 1.04, 1.7, 0.43181818181818
24603, 1.02, 1.7, 0.40909090909091
24604, 1.04, 1.7, 0.38636363636364
24605, 1.02, 1.7, 0.36363636363636
24606, 1.04, 1.7, 0.34090909090909
24607, 1.02, 1.7, 0.31818181818182
24608, 1.04, 1.7, 0.29545454545455
24609, 1.02, 1.7, 0.27272727272727
24610, 1.04, 1.7, 0.25
24611, 1.02, 1.7, 0.22727272727273
24612, 1.04, 1.7, 0.20454545454545
24613, 1.02, 1.7, 0.18181818181818
24614, 1.04, 1.7, 0.15909090909091
24615, 1.02, 1.7, 0.13636363636364
24616, 1.04, 1.7, 0.11363636363636
24617, 1.02, 1.7, 0.090909090909091
24618, 1.04, 1.7, 0.068181818181818
24619, 1.02, 1.7, 0.045454545454545
24620, 1.04, 1.7, 0.022727272727273
24621, 1.08, 1.7, 0.47727272727273
24622, 1.06, 1.7, 0.45454545454545
24623, 1.08, 1.7, 0.43181818181818
24624, 1.06, 1.7, 0.40909090909091
24625, 1.08, 1.7, 0.38636363636364
24626, 1.06, 1.7, 0.36363636363636
24627, 1.08, 1.7, 0.34090909090909
24628, 1.06, 1.7, 0.31818181818182
24629, 1.08, 1.7, 0.29545454545455
24630, 1.06, 1.7, 0.27272727272727
24631, 1.08, 1.7, 0.25
24632, 1.06, 1.7, 0.22727272727273
24633, 1.08, 1.7, 0.20454545454545
24634, 1.06, 1.7, 0.18181818181818
24635, 1.08, 1.7, 0.15909090909091
24636, 1.06, 1.7, 0.13636363636364
24637, 1.08, 1.7, 0.11363636363636
24638, 1.06, 1.7, 0.090909090909091
24639, 1.08, 1.7, 0.068181818181818
24640, 1.06, 1.7, 0.045454545454545
24641, 1.08, 1.7, 0.022727272727273
24642, 1.12, 1.7, 0.47727272727273
24643, 1.1, 1.7, 0.45454545454545
24644, 1.12, 1.7, 0.43181818181818
24645, 1.1, 1.7, 0.40909090909091
24646, 1.12, 1.7, 0.38636363636364
24647, 1.1, 1.7, 0.36363636363636
24648, 1.12, 1.7, 0.34090909090909
24649, 1.1, 1.7, 0.31818181818182
24650, 1.12, 1.7, 0.29545454545455
24651, 1.1, 1.7, 0.27272727272727
24652, 1.12, 1.7, 0.25
24653, 1.1, 1.7, 0.22727272727273
24654, 1.12, 1.7, 0.20454545454545
24655, 1.1, 1.7, 0.18181818181818
24656, 1.12, 1.7, 0.15909090909091
24657, 1.1, 1.7, 0.13636363636364
24658, 1.12, 1.7, 0.11363636363636
24659, 1.1, 1.7, 0.090909090909091
24660, 1.12, 1.7, 0.068181818181818
24661, 1.1, 1.7, 0.045454545454545
24662, 1.12, 1.7, 0.022727272727273
24663, 1.16, 1.7, 0.47727272727273
24664, 1.14, 1.7, 0.45454545454545
24665, 1.16, 1.7, 0.43181818181818
24666, 1.14, 1.7, 0.40909090909091
24667, 1.16, 1.7, 0.38636363636364
24668, 1.14, 1.7, 0.36363636363636
24669, 1.16, 1.7, 0.34090909090909
24670, 1.14, 1.7, 0.31818181818182
24671, 1.16, 1.7, 0.29545454545455
24672, 1.14, 1.7, 0.27272727272727
24673, 1.16, 1.7, 0.25
24674, 1.14, 1.7, 0.22727272727273
24675, 1.16, 1.7, 0.20454545454545
24676, 1.14, 1.7, 0.18181818181818
24677, 1.16, 1.7, 0.15909090909091
24678, 1.14, 1.7, 0.13636363636364
24679, 1.16, 1.7, 0.11363636363636
24680, 1.14, 1.7, 0.090909090909091
24681, 1.16, 1.7, 0.068181818181818
24682, 1.14, 1.7, 0.045454545454545
24683, 1.16, 1.7, 0.022727272727273
24684, 1.18, 1.7, 0.45454545454545
24685, 1.18, 1.7, 0.40909090909091
24686, 1.18, 1.7, 0.36363636363636
24687, 1.18, 1.7, 0.31818181818182
24688, 1.18, 1.7, 0.27272727272727
24689, 1.18, 1.7, 0.22727272727273
24690, 1.18, 1.7, 0.18181818181818
24691, 1.18, 1.7, 0.13636363636364
24692, 1.18, 1.7, 0.090909090909091
24693, 1.18, 1.7, 0.045454545454545
24694, 1.2434782608696, 1.55, 0.5
24695, 1.2869565217391, 1.55, 0.5
24696, 1.3304347826087, 1.55, 0.5
24697, 1.3739130434783, 1.55, 0.5
24698, 1.4173913043478, 1.55, 0.5
24699, 1.4608695652174, 1.55, 0.5
24700, 1.504347826087, 1.55, 0.5
24701, 1.5478260869565, 1.55, 0.5
24702, 1.5913043478261, 1.55, 0.5
24703, 1.6347826086957, 1.55, 0.5
24704, 1.6782608695652, 1.55, 0.5
24705, 1.7217391304348, 1.55, 0.5
24706, 1.7652173913043, 1.55, 0.5
24707, 1.8086956521739, 1.55, 0.5
24708, 1.8521739130435, 1.55, 0.5
24709, 1.895652173913, 1.55, 0.5
24710, 1.9391304347826, 1.55, 0.5
24711, 1.9826086956522, 1.55, 0.5
24712, 2.0260869565217, 1.55, 0.5
24713, 2.0695652173913, 1.55, 0.5
24714, 2.1130434782609, 1.55, 0.5
24715, 2.1565217391304, 1.55, 0.5
24716, 1.2434782608696, 1.6, 0.5
24717, 1.2869565217391, 1.6, 0.5
24718, 1.3304347826087, 1.6, 0.5
24719, 1.3739130434783, 1.6, 0.5
24720, 1.4173913043478, 1.6, 0.5
24721, 1.4608695652174, 1.6, 0.5
24722, 1.504347826087, 1.6, 0.5
24723, 1.5478260869565, 1.6, 0.5
24724, 1.5913043478261, 1.6, 0.5
24725, 1.6347826086957, 1.6, 0.5
24726, 1.6782608695652, 1.6, 0.5
24727, 1.7217391304348, 1.6, 0.5
24728, 1.7652173913043, 1.6, 0.5
24729, 1.8086956521739, 1.6, 0.5
24730, 1.8521739130435, 1.6, 0.5
24731, 1.895652173913, 1.6, 0.5
24732, 1.9391304347826, 1.6, 0.5
24733, 1.9826086956522, 1.6, 0.5
24734, 2.0260869565217, 1.6, 0.5
24735, 2.0695652173913, 1.6, 0.5
24736, 2.1130434782609, 1.6, 0.5
24737, 2.1565217391304, 1.6, 0.5
24738, 1.2434782608696, 1.65, 0.5
24739, 1.2869565217391, 1.65, 0.5
24740, 1.3304347826087, 1.65, 0.5
24741, 1.3739130434783, 1.65, 0.5
24742, 1.4173913043478, 1.65, 0.5
24743, 1.4608695652174, 1.65, 0.5
24744, 1.504347826087, 1.65, 0.5
24745, 1.5478260869565, 1.65, 0.5
24746, 1.5913043478261, 1.65, 0.5
24747, 1.6347826086957, 1.65, 0.5
24748, 1.6782608695652, 1.65, 0.5
24749, 1.7217391304348, 1.65, 0.5
24750, 1.7652173913043, 1.65, 0.5
24751, 1.8086956521739, 1.65, 0.5
24752, 1.8521739130435, 1.65, 0.5
24753, 1.895652173913, 1.65, 0.5
24754, 1.9391304347826, 1.65, 0.5
24755, 1.9826086956522, 1.65, 0.5
24756, 2.0260869565217, 1.65, 0.5
24757, 2.0695652173913, 1.65, 0.5
24758, 2.1130434782609, 1.65, 0.5
24759, 2.1565217391304, 1.65, 0.5
24760, 1.2434782608696, 1.525, 0.5
24761, 1.2217391304348, 1.55, 0.5
24762, 1.2869565217391, 1.525, 0.5
24763, 1.2652173913043, 1.55, 0.5
24764, 1.3304347826087, 1.525, 0.5
24765, 1.3086956521739, 1.55, 0.5
24766, 1.3739130434783, 1.525, 0.5
24767, 1.3521739130435, 1.55, 0.5
24768, 1.4173913043478, 1.525, 0.5
24769, 1.395652173913, 1.55, 0.5
24770, 1.4608695652174, 1.525, 0.5
24771, 1.4391304347826, 1.55, 0.5
24772, 1.504347826087, 1.525, 0.5
24773, 1.4826086956522, 1.55, 0.5
24774, 1.5478260869565, 1.525, 0.5
24775, 1.5260869565217, 1.55, 0.5
24776, 1.5913043478261, 1.525, 0.5
24777, 1.5695652173913, 1.55, 0.5
24778, 1.6347826086957, 1.525, 0.5
24779, 1.6130434782609, 1.55, 0.5
24780, 1.6782608695652, 1.525, 0.5
24781, 1.6565217391304, 1.55, 0.5
24782, 1.7217391304348, 1.525, 0.5
24783, 1.7, 1.55, 0.5
24784, 1.7652173913043, 1.525, 0.5
24785, 1.7434782608696, 1.55, 0.5
24786, 1.8086956521739, 1.525, 0.5
24787, 1.7869565217391, 1.55, 0.5
24788, 1.8521739130435, 1.525, 0.5
24789, 1.8304347826087, 1.55, 0.5
24790, 1.895652173913, 1.525, 0.5
24791, 1.8739130434783, 1.55, 0.5
24792, 1.9391304347826, 1.525, 0.5
24793, 1.9173913043478, 1.55, 0.5
24794, 1.9826086956522, 1.525, 0.5
24795, 1.9608695652174, 1.55, 0.5
24796, 2.0260869565217, 1.525, 0.5
24797, 2.004347826087, 1.55, 0.5
24798, 2.0695652173913, 1.525, 0.5
24799, 2.0478260869565, 1.55, 0.5
24800, 2.1130434782609, 1.525, 0.5
24801, 2.0913043478261, 1.55, 0.5
24802, 2.1565217391304, 1.525, 0.5
24803, 2.1347826086957, 1.55, 0.5
24804, 2.1782608695652, 1.55, 0.5
24805, 1.2434782608696, 1.575, 0.5
24806, 1.2217391304348, 1.6, 0.5
24807, 1.2869565217391, 1.575, 0.5
24808, 1.2652173913043, 1.6, 0.5
24809, 1.3304347826087, 1.575, 0.5
24810, 1.3086956521739, 1.6, 0.5
24811, 1.3739130434783, 1.575, 0.5
24812, 1.3521739130435, 1.6, 0.5
24813, 1.4173913043478, 1.575, 0.5
24814, 1.395652173913, 1.6, 0.5
24815, 1.4608695652174, 1.575, 0.5
24816, 1.4391304347826, 1.6, 0.5
24817, 1.504347826087, 1.575, 0.5
24818, 1.4826086956522, 1.6, 0.5
24819, 1.5478260869565, 1.575, 0.5
24820, 1.5260869565217, 1.6, 0.5
24821, 1.5913043478261, 1.575, 0.5
24822, 1.5695652173913, 1.6, 0.5
24823, 1.6347826086957, 1.575, 0.5
24824, 1.6130434782609, 1.6, 0.5
24825, 1.6782608695652, 1.575, 0.5
24826, 1.6565217391304, 1.6, 0.5
24827, 1.7217391304348, 1.575, 0.5
24828, 1.7, 1.6, 0.5
24829, 1.7652173913043, 1.575, 0.5
24830, 1.7434782608696, 1.6, 0.5
24831, 1.8086956521739, 1.575, 0.5
24832, 1.7869565217391, 1.6, 0.5
24833, 1.8521739130435, 1.575, 0.5
24834, 1.8304347826087, 1.6, 0.5
24835, 1.895652173913, 1.575, 0.5
24836, 1.8739130434783, 1.6, 0.5
24837, 1.9391304347826, 1.575, 0.5
24838, 1.9173913043478, 1.6, 0.5
24839, 1.9826086956522, 1.575, 0.5
24840, 1.9608695652174, 1.6, 0.5
24841, 2.0260869565217, 1.575, 0.5
24842, 2.004347826087, 1.6, 0.5
24843, 2.0695652173913, 1.575, 0.5
24844, 2.0478260869565, 1.6, 0.5
24845, 2.1130434782609, 1.575, 0.5
24846, 2.0913043478261, 1.6, 0.5
24847, 2.1565217391304, 1.575, 0.5
24848, 2.1347826086957, 1.6, 0.5
24849, 2.1782608695652, 1.6, 0.5
24850, 1.2434782608696, 1.625, 0.5
24851, 1.2217391304348, 1.65, 0.5
24852, 1.2869565217391, 1.625, 0.5
24853, 1.2652173913043, 1.65, 0.5
24854, 1.3304347826087, 1.625, 0.5
24855, 1.3086956521739, 1.65, 0.5
24856, 1.3739130434783, 1.625, 0.5
24857, 1.3521739130435, 1.65, 0.5
24858, 1.4173913043478, 1.625, 0.5
24859, 1.395652173913, 1.65, 0.5
24860, 1.4608695652174, 1.625, 0.5
24861, 1.4391304347826, 1.65, 0.5
24862, 1.504347826087, 1.625, 0.5
24863, 1.4826086956522, 1.65, 0.5
24864, 1.5478260869565, 1.625, 0.5
24865, 1.5260869565217, 1.65, 0.5
24866, 1.5913043478261, 1.625, 0.5
24867, 1.5695652173913, 1.65, 0.5
24868, 1.6347826086957, 1.625, 0.5
24869, 1.6130434782609, 1.65, 0.5
24870, 1.6782608695652, 1.625, 0.5
24871, 1.6565217391304, 1.65, 0.5
24872, 1.7217391304348, 1.625, 0.5
24873, 1.7, 1.65, 0.5
24874, 1.7652173913043, 1.625, 0.5
24875, 1.7434782608696, 1.65, 0.5
24876, 1.8086956521739, 1.625, 0.5
24877, 1.7869565217391, 1.65, 0.5
24878, 1.8521739130435, 1.625, 0.5
24879, 1.8304347826087, 1.65, 0.5
24880, 1.895652173913, 1.625, 0.5
24881, 1.8739130434783, 1.65, 0.5
24882, 1.9391304347826, 1.625, 0.5
24883, 1.9173913043478, 1.65, 0.5
24884, 1.9826086956522, 1.625, 0.5
24885, 1.9608695652174, 1.65, 0.5
24886, 2.0260869565217, 1.625, 0.5
24887, 2.004347826087, 1.65, 0.5
24888, 2.0695652173913, 1.625, 0.5
24889, 2.0478260869565, 1.65, 0.5
24890, 2.1130434782609, 1.625, 0.5
24891, 2.0913043478261, 1.65, 0.5
24892, 2.1565217391304, 1.625, 0.5
24893, 2.1347826086957, 1.65, 0.5
24894, 2.1782608695652, 1.65, 0.5
24895, 1.2434782608696, 1.675, 0.5
24896, 1.2869565217391, 1.675, 0.5
24897, 1.3304347826087, 1.675, 0.5
24898, 1.3739130434783, 1.675, 0.5
24899, 1.4173913043478, 1.675, 0.5
24900, 1.4608695652174, 1.675, 0.5
24901, 1.504347826087, 1.675, 0.5
24902, 1.5478260869565, 1.675, 0.5
24903, 1.5913043478261, 1.675, 0.5
24904, 1.6347826086957, 1.675, 0.5
24905, 1.6782608695652, 1.675, 0.5
24906, 1.7217391304348, 1.675, 0.5
24907, 1.7652173913043, 1.675, 0.5
24908, 1.8086956521739, 1.675, 0.5
24909, 1.8521739130435, 1.675, 0.5
24910, 1.895652173913, 1.675, 0.5
24911, 1.9391304347826, 1.675, 0.5
24912, 1.9826086956522, 1.675, 0.5
24913, 2.0260869565217, 1.675, 0.5
24914, 2.0695652173913, 1.675, 0.5
24915, 2.1130434782609, 1.675, 0.5
24916, 2.1565217391304, 1.675, 0.5
24917, 1.2434782608696, 1.55, 0
24918, 1.2869565217391, 1.55, 0
24919, 1.3304347826087, 1.55, 0
24920, 1.3739130434783, 1.55, 0
24921, 1.4173913043478, 1.55, 0
24922, 1.4608695652174, 1.55, 0
24923, 1.504347826087, 1.55, 0
24924, 1.5478260869565, 1.55, 0
24925, 1.5913043478261, 1.55, 0
24926, 1.6347826086957, 1.55, 0
24927, 1.6782608695652, 1.55, 0
24928, 1.7217391304348, 1.55, 0
24929, 1.7652173913043, 1.55, 0
24930, 1.8086956521739, 1.55, 0
24931, 1.8521739130435, 1.55, 0
24932, 1.895652173913, 1.55, 0
24933, 1.9391304347826, 1.55, 0
24934, 1.9826086956522, 1.55, 0
24935, 2.0260869565217, 1.55, 0
24936, 2.0695652173913, 1.55, 0
24937, 2.1130434782609, 1.55, 0
24938, 2.1565217391304, 1.55, 0
24939, 1.2434782608696, 1.6, 0
24940, 1.2869565217391, 1.6, 0
24941, 1.3304347826087, 1.6, 0
24942, 1.3739130434783, 1.6, 0
24943, 1.4173913043478, 1.6, 0
24944, 1.4608695652174, 1.6, 0
24945, 1.504347826087, 1.6, 0
24946, 1.5478260869565, 1.6, 0
24947, 1.5913043478261, 1.6, 0
24948, 1.6347826086957, 1.6, 0
24949, 1.6782608695652, 1.6, 0
24950, 1.7217391304348, 1.6, 0
24951, 1.7652173913043, 1.6, 0
24952, 1.8086956521739, 1.6, 0
24953, 1.8521739130435, 1.6, 0
24954, 1.895652173913, 1.6, 0
24955, 1.9391304347826, 1.6, 0
24956, 1.9826086956522, 1.6, 0
24957, 2.0260869565217, 1.6, 0
24958, 2.0695652173913, 1.6, 0
24959, 2.1130434782609, 1.6, 0
24960, 2.1565217391304, 1.6, 0
24961, 1.2434782608696, 1.65, 0
24962, 1.2869565217391, 1.65, 0
24963, 1.3304347826087, 1.65, 0
24964, 1.3739130434783, 1.65, 0
24965, 1.4173913043478, 1.65, 0
24966, 1.4608695652174, 1.65, 0
24967, 1.504347826087, 1.65, 0
24968, 1.5478260869565, 1.65, 0
24969, 1.5913043478261, 1.65, 0
24970, 1.6347826086957, 1.65, 0
24971, 1.6782608695652, 1.65, 0
24972, 1.7217391304348, 1.65, 0
24973, 1.7652173913043, 1.65, 0
24974, 1.8086956521739, 1.65, 0
24975, 1.8521739130435, 1.65, 0
24976, 1.895652173913, 1.65, 0
24977, 1.9391304347826, 1.65, 0
24978, 1.9826086956522, 1.65, 0
24979, 2.0260869565217, 1.65, 0
24980, 2.0695652173913, 1.65, 0
24981, 2.1130434782609, 1.65, 0
24982, 2.1565217391304, 1.65, 0
24983, 1.2217391304348, 1.55, 0
24984, 1.2434782608696, 1.525, 0
24985, 1.2652173913043, 1.55, 0
24986, 1.2869565217391, 1.525, 0
24987, 1.3086956521739, 1.55, 0
24988, 1.3304347826087, 1.525, 0
24989, 1.3521739130435, 1.55, 0
24990, 1.3739130434783, 1.525, 0
24991, 1.395652173913, 1.55, 0
24992, 1.4173913043478, 1.525, 0
24993, 1.4391304347826, 1.55, 0
24994, 1.4608695652174, 1.525, 0
24995, 1.4826086956522, 1.55, 0
24996, 1.504347826087, 1.525, 0
24997, 1.5260869565217, 1.55, 0
24998, 1.5478260869565, 1.525, 0
24999, 1.5695652173913, 1.55, 0
25000, 1.5913043478261, 1.525, 0
25001, 1.6130434782609, 1.55, 0
25002, 1.6347826086957, 1.525, 0
25003, 1.6565217391304, 1.55, 0
25004, 1.6782608695652, 1.525, 0
25005, 1.7, 1.55, 0
25006, 1.7217391304348, 1.525, 0
25007, 1.7434782608696, 1.55, 0
25008, 1.7652173913043, 1.525, 0
25009, 1.7869565217391, 1.55, 0
25010, 1.8086956521739, 1.525, 0
25011, 1.8304347826087, 1.55, 0
25012, 1.8521739130435, 1.525, 0
25013, 1.8739130434783, 1.55, 0
25014, 1.895652173913, 1.525, 0
25015, 1.9173913043478, 1.55, 0
25016, 1.9391304347826, 1.525, 0
25017, 1.9608695652174, 1.55, 0
25018, 1.9826086956522, 1.525, 0
25019, 2.004347826087, 1.55, 0
25020, 2.0260869565217, 1.525, 0
25021, 2.0478260869565, 1.55, 0
25022, 2.0695652173913, 1.525, 0
25023, 2.0913043478261, 1.55, 0
25024, 2.1130434782609, 1.525, 0
25025, 2.1347826086957, 1.55, 0
25026, 2.1565217391304, 1.525, 0
25027, 2.1782608695652, 1.55, 0
25028, 1.2217391304348, 1.6, 0
25029, 1.2434782608696, 1.575, 0
25030, 1.2652173913043, 1.6, 0
25031, 1.2869565217391, 1.575, 0
25032, 1.3086956521739, 1.6, 0
25033, 1.3304347826087, 1.575, 0
25034, 1.3521739130435, 1.6, 0
25035, 1.3739130434783, 1.575, 0
25036, 1.395652173913, 1.6, 0
25037, 1.4173913043478, 1.575, 0
25038, 1.4391304347826, 1.6, 0
25039, 1.4608695652174, 1.575, 0
25040, 1.4826086956522, 1.6, 0
25041, 1.504347826087, 1.575, 0
25042, 1.5260869565217, 1.6, 0
25043, 1.5478260869565, 1.575, 0
25044, 1.5695652173913, 1.6, 0
25045, 1.5913043478261, 1.575, 0
25046, 1.6130434782609, 1.6, 0
25047, 1.6347826086957, 1.575, 0
25048, 1.6565217391304, 1.6, 0
25049, 1.6782608695652, 1.575, 0
25050, 1.7, 1.6, 0
25051, 1.7217391304348, 1.575, 0
25052, 1.7434782608696, 1.6, 0
25053, 1.7652173913043, 1.575, 0
25054, 1.7869565217391, 1.6, 0
25055, 1.8086956521739, 1.575, 0
25056, 1.8304347826087, 1.6, 0
25057, 1.8521739130435, 1.575, 0
25058, 1.8739130434783, 1.6, 0
25059, 1.895652173913, 1.575, 0
25060, 1.9173913043478, 1.6, 0
25061, 1.9391304347826, 1.575, 0
25062, 1.9608695652174, 1.6, 0
25063, 1.9826086956522, 1.575, 0
25064, 2.004347826087, 1.6, 0
25065, 2.0260869565217, 1.575, 0
25066, 2.0478260869565, 1.6, 0
25067, 2.0695652173913, 1.575, 0
25068, 2.0913043478261, 1.6, 0
25069, 2.1130434782609, 1.575, 0
25070, 2.1347826086957, 1.6, 0
25071, 2.1565217391304, 1.575, 0
25072, 2.1782608695652, 1.6, 0
25073, 1.2217391304348, 1.65, 0
25074, 1.2434782608696, 1.625, 0
25075, 1.2652173913043, 1.65, 0
25076, 1.2869565217391, 1.625, 0
25077, 1.3086956521739, 1.65, 0
25078, 1.3304347826087, 1.625, 0
25079, 1.3521739130435, 1.65, 0
25080, 1.3739130434783, 1.625, 0
25081, 1.395652173913, 1.65, 0
25082, 1.4173913043478, 1.625, 0
25083, 1.4391304347826, 1.65, 0
25084, 1.4608695652174, 1.625, 0
25085, 1.4826086956522, 1.65, 0
25086, 1.504347826087, 1.625, 0
25087, 1.5260869565217, 1.65, 0
25088, 1.5478260869565, 1.625, 0
25089, 1.5695652173913, 1.65, 0
25090, 1.5913043478261, 1.625, 0
25091, 1.6130434782609, 1.65, 0
25092, 1.6347826086957, 1.625, 0
25093, 1.6565217391304, 1.65, 0
25094, 1.6782608695652, 1.625, 0
25095, 1.7, 1.65, 0
25096, 1.7217391304348, 1.625, 0
25097, 1.7434782608696, 1.65, 0
25098, 1.7652173913043, 1.625, 0
25099, 1.7869565217391, 1.65, 0
25100, 1.8086956521739, 1.625, 0
25101, 1.8304347826087, 1.65, 0
25102, 1.8521739130435, 1.625, 0
25103, 1.8739130434783, 1.65, 0
25104, 1.895652173913, 1.625, 0
25105, 1.9173913043478, 1.65, 0
25106, 1.9391304347826, 1.625, 0
25107, 1.9608695652174, 1.65, 0
25108, 1.9826086956522, 1.625, 0
25109, 2.004347826087, 1.65, 0
25110, 2.0260869565217, 1.625, 0
25111, 2.0478260869565, 1.65, 0
25112, 2.0695652173913, 1.625, 0
25113, 2.0913043478261, 1.65, 0
25114, 2.1130434782609, 1.625, 0
25115, 2.1347826086957, 1.65, 0
25116, 2.1565217391304, 1.625, 0
25117, 2.1782608695652, 1.65, 0
25118, 1.2434782608696, 1.675, 0
25119, 1.2869565217391, 1.675, 0
25120, 1.3304347826087, 1.675, 0
25121, 1.3739130434783, 1.675, 0
25122, 1.4173913043478, 1.675, 0
25123, 1.4608695652174, 1.675, 0
25124, 1.504347826087, 1.675, 0
25125, 1.5478260869565, 1.675, 0
25126, 1.5913043478261, 1.675, 0
25127, 1.6347826086957, 1.675, 0
25128, 1.6782608695652, 1.675, 0
25129, 1.7217391304348, 1.675, 0
25130, 1.7652173913043, 1.675, 0
25131, 1.8086956521739, 1.675, 0
25132, 1.8521739130435, 1.675, 0
25133, 1.895652173913, 1.675, 0
25134, 1.9391304347826, 1.675, 0
25135, 1.9826086956522, 1.675, 0
25136, 2.0260869565217, 1.675, 0
25137, 2.0695652173913, 1.675, 0
25138, 2.1130434782609, 1.675, 0
25139, 2.1565217391304, 1.675, 0
25140, 2.2, 1.55, 0.45454545454545
25141, 2.2, 1.55, 0.40909090909091
25142, 2.2, 1.55, 0.36363636363636
25143, 2.2, 1.55, 0.31818181818182
25144, 2.2, 1.55, 0.27272727272727
25145, 2.2, 1.55, 0.22727272727273
25146, 2.2, 1.55, 0.18181818181818
25147, 2.2, 1.55, 0.13636363636364
25148, 2.2, 1.55, 0.090909090909091
25149, 2.2, 1.55, 0.045454545454545
25150, 2.2, 1.6, 0.45454545454545
25151, 2.2, 1.6, 0.40909090909091
25152, 2.2, 1.6, 0.36363636363636
25153, 2.2, 1.6, 0.31818181818182
25154, 2.2, 1.6, 0.27272727272727
25155, 2.2, 1.6, 0.22727272727273
25156, 2.2, 1.6, 0.18181818181818
25157, 2.2, 1.6, 0.13636363636364
25158, 2.2, 1.6, 0.090909090909091
25159, 2.2, 1.6, 0.045454545454545
25160, 2.2, 1.65, 0.45454545454545
25161, 2.2, 1.65, 0.40909090909091
25162, 2.2, 1.65, 0.36363636363636
25163, 2.2, 1.65, 0.31818181818182
25164, 2.2, 1.65, 0.27272727272727
25165, 2.2, 1.65, 0.22727272727273
25166, 2.2, 1.65, 0.18181818181818
25167, 2.2, 1.65, 0.13636363636364
25168, 2.2, 1.65, 0.090909090909091
25169, 2.2, 1.65, 0.045454545454545
25170, 2.2, 1.525, 0.45454545454545
25171, 2.2, 1.55, 0.47727272727273
25172, 2.2, 1.525, 0.40909090909091
25173, 2.2, 1.55, 0.43181818181818
25174, 2.2, 1.525, 0.36363636363636
25175, 2.2, 1.55, 0.38636363636364
25176, 2.2, 1.525, 0.31818181818182
25177, 2.2, 1.55, 0.34090909090909
25178, 2.2, 1.525, 0.27272727272727
25179, 2.2, 1.55, 0.29545454545455
25180, 2.2, 1.525, 0.22727272727273
25181, 2.2, 1.55, 0.25
25182, 2.2, 1.525, 0.18181818181818
25183, 2.2, 1.55, 0.20454545454545
25184, 2.2, 1.525, 0.13636363636364
25185, 2.2, 1.55, 0.15909090909091
25186, 2.2, 1.525, 0.090909090909091
25187, 2.2, 1.55, 0.11363636363636
25188, 2.2, 1.525, 0.045454545454545
25189, 2.2, 1.55, 0.068181818181818
25190, 2.2, 1.55, 0.022727272727273
25191, 2.2, 1.575, 0.45454545454545
25192, 2.2, 1.6, 0.47727272727273
25193, 2.2, 1.575, 0.40909090909091
25194, 2.2, 1.6, 0.43181818181818
25195, 2.2, 1.575, 0.36363636363636
25196, 2.2, 1.6, 0.38636363636364
25197, 2.2, 1.575, 0.31818181818182
25198, 2.2, 1.6, 0.34090909090909
25199, 2.2, 1.575, 0.27272727272727
25200, 2.2, 1.6, 0.29545454545455
25201, 2.2, 1.575, 0.22727272727273
25202, 2.2, 1.6, 0.25
25203, 2.2, 1.575, 0.18181818181818
25204, 2.2, 1.6, 0.20454545454545
25205, 2.2, 1.575, 0.13636363636364
25206, 2.2, 1.6, 0.15909090909091
25207, 2.2, 1.575, 0.090909090909091
25208, 2.2, 1.6, 0.11363636363636
25209, 2.2, 1.575, 0.045454545454545
25210, 2.2, 1.6, 0.068181818181818
25211, 2.2, 1.6, 0.022727272727273
25212, 2.2, 1.625, 0.45454545454545
25213, 2.2, 1.65, 0.47727272727273
25214, 2.2, 1.625, 0.40909090909091
25215, 2.2, 1.65, 0.43181818181818
25216, 2.2, 1.625, 0.36363636363636
25217, 2.2, 1.65, 0.38636363636364
25218, 2.2, 1.625, 0.31818181818182
25219, 2.2, 1.65, 0.34090909090909
25220, 2.2, 1.625, 0.27272727272727
25221, 2.2, 1.65, 0.29545454545455
25222, 2.2, 1.625, 0.22727272727273
25223, 2.2, 1.65, 0.25
25224, 2.2, 1.625, 0.18181818181818
25225, 2.2, 1.65, 0.20454545454545
25226, 2.2, 1.625, 0.13636363636364
25227, 2.2, 1.65, 0.15909090909091
25228, 2.2, 1.625, 0.090909090909091
25229, 2.2, 1.65, 0.11363636363636
25230, 2.2, 1.625, 0.045454545454545
25231, 2.2, 1.65, 0.068181818181818
25232, 2.2, 1.65, 0.022727272727273
25233, 2.2, 1.675, 0.45454545454545
25234, 2.2, 1.675, 0.40909090909091
25235, 2.2, 1.675, 0.36363636363636
25236, 2.2, 1.675, 0.31818181818182
25237, 2.2, 1.675, 0.27272727272727
25238, 2.2, 1.675, 0.22727272727273
25239, 2.2, 1.675, 0.18181818181818
25240, 2.2, 1.675, 0.13636363636364
25241, 2.2, 1.675, 0.090909090909091
25242, 2.2, 1.675, 0.045454545454545
25243, 1.2434782608696, 1.7, 0.45454545454545
25244, 1.2434782608696, 1.7, 0.40909090909091
25245, 1.2434782608696, 1.7, 0.36363636363636
25246, 1.2434782608696, 1.7, 0.31818181818182
25247, 1.2434782608696, 1.7, 0.27272727272727
25248, 1.2434782608696, 1.7, 0.22727272727273
25249, 1.2434782608696, 1.7, 0.18181818181818
25250, 1.2434782608696, 1.7, 0.13636363636364
25251, 1.2434782608696, 1.7, 0.090909090909091
25252, 1.2434782608696, 1.7, 0.045454545454545
25253, 1.2869565217391, 1.7, 0.45454545454545
25254, 1.2869565217391, 1.7, 0.40909090909091
25255, 1.2869565217391, 1.7, 0.36363636363636
25256, 1.2869565217391, 1.7, 0.31818181818182
25257, 1.2869565217391, 1.7, 0.27272727272727
25258, 1.2869565217391, 1.7, 0.22727272727273
25259, 1.2869565217391, 1.7, 0.18181818181818
25260, 1.2869565217391, 1.7, 0.13636363636364
25261, 1.2869565217391, 1.7, 0.090909090909091
25262, 1.2869565217391, 1.7, 0.045454545454545
25263, 1.3304347826087, 1.7, 0.45454545454545
25264, 1.3304347826087, 1.7, 0.40909090909091
25265, 1.3304347826087, 1.7, 0.36363636363636
25266, 1.3304347826087, 1.7, 0.31818181818182
25267, 1.3304347826087, 1.7, 0.27272727272727
25268, 1.3304347826087, 1.7, 0.22727272727273
25269, 1.3304347826087, 1.7, 0.18181818181818
25270, 1.3304347826087, 1.7, 0.13636363636364
25271, 1.3304347826087, 1.7, 0.090909090909091
25272, 1.3304347826087, 1.7, 0.045454545454545
25273, 1.3739130434783, 1.7, 0.45454545454545
25274, 1.3739130434783, 1.7, 0.40909090909091
25275, 1.3739130434783, 1.7, 0.36363636363636
25276, 1.3739130434783, 1.7, 0.31818181818182
25277, 1.3739130434783, 1.7, 0.27272727272727
25278, 1.3739130434783, 1.7, 0.22727272727273
25279, 1.3739130434783, 1.7, 0.18181818181818
25280, 1.3739130434783, 1.7, 0.13636363636364
25281, 1.3739130434783, 1.7, 0.090909090909091
25282, 1.3739130434783, 1.7, 0.045454545454545
25283, 1.4173913043478, 1.7, 0.45454545454545
25284, 1.4173913043478, 1.7, 0.40909090909091
25285, 1.4173913043478, 1.7, 0.36363636363636
25286, 1.4173913043478, 1.7, 0.31818181818182
25287, 1.4173913043478, 1.7, 0.27272727272727
25288, 1.4173913043478, 1.7, 0.22727272727273
25289, 1.4173913043478, 1.7, 0.18181818181818
25290, 1.4173913043478, 1.7, 0.13636363636364
25291, 1.4173913043478, 1.7, 0.090909090909091
25292, 1.4173913043478, 1.7, 0.045454545454545
25293, 1.4608695652174, 1.7, 0.45454545454545
25294, 1.4608695652174, 1.7, 0.40909090909091
25295, 1.4608695652174, 1.7, 0.36363636363636
25296, 1.4608695652174, 1.7, 0.31818181818182
25297, 1.4608695652174, 1.7, 0.27272727272727
25298, 1.4608695652174, 1.7, 0.22727272727273
25299, 1.4608695652174, 1.7, 0.18181818181818
25300, 1.4608695652174, 1.7, 0.13636363636364
25301, 1.4608695652174, 1.7, 0.090909090909091
25302, 1.4608695652174, 1.7, 0.045454545454545
25303, 1.504347826087, 1.7, 0.45454545454545
25304, 1.504347826087, 1.7, 0.40909090909091
25305, 1.504347826087, 1.7, 0.36363636363636
25306, 1.504347826087, 1.7, 0.31818181818182
25307, 1.504347826087, 1.7, 0.27272727272727
25308, 1.504347826087, 1.7, 0.22727272727273
25309, 1.504347826087, 1.7, 0.18181818181818
25310, 1.504347826087, 1.7, 0.13636363636364
25311, 1.504347826087, 1.7, 0.090909090909091
25312, 1.504347826087, 1.7, 0.045454545454545
25313, 1.5478260869565, 1.7, 0.45454545454545
25314, 1.5478260869565, 1.7, 0.40909090909091
25315, 1.5478260869565, 1.7, 0.36363636363636
25316, 1.5478260869565, 1.7, 0.31818181818182
25317, 1.5478260869565, 1.7, 0.27272727272727
25318, 1.5478260869565, 1.7, 0.22727272727273
25319, 1.5478260869565, 1.7, 0.18181818181818
25320, 1.5478260869565, 1.7, 0.13636363636364
25321, 1.5478260869565, 1.7, 0.090909090909091
25322, 1.5478260869565, 1.7, 0.045454545454545
25323, 1.5913043478261, 1.7, 0.45454545454545
25324, 1.5913043478261, 1.7, 0.40909090909091
25325, 1.5913043478261, 1.7, 0.36363636363636
25326, 1.5913043478261, 1.7, 0.31818181818182
25327, 1.5913043478261, 1.7, 0.27272727272727
25328, 1.5913043478261, 1.7, 0.22727272727273
25329, 1.5913043478261, 1.7, 0.18181818181818
25330, 1.5913043478261, 1.7, 0.13636363636364
25331, 1.5913043478261, 1.7, 0.090909090909091
25332, 1.5913043478261, 1.7, 0.045454545454545
25333, 1.6347826086957, 1.7, 0.45454545454545
25334, 1.6347826086957, 1.7, 0.40909090909091
25335, 1.6347826086957, 1.7, 0.36363636363636
25336, 1.6347826086957, 1.7, 0.31818181818182
25337, 1.6347826086957, 1.7, 0.27272727272727
25338, 1.6347826086957, 1.7, 0.22727272727273
25339, 1.6347826086957, 1.7, 0.18181818181818
25340, 1.6347826086957, 1.7, 0.13636363636364
25341, 1.6347826086957, 1.7, 0.090909090909091
25342, 1.6347826086957, 1.7, 0.045454545454545
25343, 1.6782608695652, 1.7, 0.45454545454545
25344, 1.6782608695652, 1.7, 0.40909090909091
25345, 1.6782608695652, 1.7, 0.36363636363636
25346, 1.6782608695652, 1.7, 0.31818181818182
25347, 1.6782608695652, 1.7, 0.27272727272727
25348, 1.6782608695652, 1.7, 0.22727272727273
25349, 1.6782608695652, 1.7, 0.18181818181818
25350, 1.6782608695652, 1.7, 0.13636363636364
25351, 1.6782608695652, 1.7, 0.090909090909091
25352, 1.6782608695652, 1.7, 0.045454545454545
25353, 1.7217391304348, 1.7, 0.45454545454545
25354, 1.7217391304348, 1.7, 0.40909090909091
25355, 1.7217391304348, 1.7, 0.36363636363636
25356, 1.7217391304348, 1.7, 0.31818181818182
25357, 1.7217391304348, 1.7, 0.27272727272727
25358, 1.7217391304348, 1.7, 0.22727272727273
25359, 1.7217391304348, 1.7, 0.18181818181818
25360, 1.7217391304348, 1.7, 0.13636363636364
25361, 1.7217391304348, 1.7, 0.090909090909091
25362, 1.7217391304348, 1.7, 0.045454545454545
25363, 1.7652173913043, 1.7, 0.45454545454545
25364, 1.7652173913043, 1.7, 0.40909090909091
25365, 1.7652173913043, 1.7, 0.36363636363636
25366, 1.7652173913043, 1.7, 0.31818181818182
25367, 1.7652173913043, 1.7, 0.27272727272727
25368, 1.7652173913043, 1.7, 0.22727272727273
25369, 1.7652173913043, 1.7, 0.18181818181818
25370, 1.7652173913043, 1.7, 0.13636363636364
25371, 1.7652173913043, 1.7, 0.090909090909091
25372, 1.7652173913043, 1.7, 0.045454545454545
25373, 1.8086956521739, 1.7, 0.45454545454545
25374, 1.8086956521739, 1.7, 0.40909090909091
25375, 1.8086956521739, 1.7, 0.36363636363636
25376, 1.8086956521739, 1.7, 0.31818181818182
25377, 1.8086956521739, 1.7, 0.27272727272727
25378, 1.8086956521739, 1.7, 0.22727272727273
25379, 1.8086956521739, 1.7, 0.18181818181818
25380, 1.8086956521739, 1.7, 0.13636363636364
25381, 1.8086956521739, 1.7, 0.090909090909091
25382, 1.8086956521739, 1.7, 0.045454545454545
25383, 1.8521739130435, 1.7, 0.45454545454545
25384, 1.8521739130435, 1.7, 0.40909090909091
25385, 1.8521739130435, 1.7, 0.36363636363636
25386, 1.8521739130435, 1.7, 0.31818181818182
25387, 1.8521739130435, 1.7, 0.27272727272727
25388, 1.8521739130435, 1.7, 0.22727272727273
25389, 1.8521739130435, 1.7, 0.18181818181818
25390, 1.8521739130435, 1.7, 0.13636363636364
25391, 1.8521739130435, 1.7, 0.090909090909091
25392, 1.8521739130435, 1.7, 0.045454545454545
25393, 1.895652173913, 1.7, 0.45454545454545
25394, 1.895652173913, 1.7, 0.40909090909091
25395, 1.895652173913, 1.7, 0.36363636363636
25396, 1.895652173913, 1.7, 0.31818181818182
25397, 1.895652173913, 1.7, 0.27272727272727
25398, 1.895652173913, 1.7, 0.22727272727273
25399, 1.895652173913, 1.7, 0.18181818181818
25400, 1.895652173913, 1.7, 0.13636363636364
25401, 1.895652173913, 1.7, 0.090909090909091
25402, 1.895652173913, 1.7, 0.045454545454545
25403, 1.9391304347826, 1.7, 0.45454545454545
25404, 1.9391304347826, 1.7, 0.40909090909091
25405, 1.9391304347826, 1.7, 0.36363636363636
25406, 1.9391304347826, 1.7, 0.31818181818182
25407, 1.9391304347826, 1.7, 0.27272727272727
25408, 1.9391304347826, 1.7, 0.22727272727273
25409, 1.9391304347826, 1.7, 0.18181818181818
25410, 1.9391304347826, 1.7, 0.13636363636364
25411, 1.9391304347826, 1.7, 0.090909090909091
25412, 1.9391304347826, 1.7, 0.045454545454545
25413, 1.9826086956522, 1.7, 0.45454545454545
25414, 1.9826086956522, 1.7, 0.40909090909091
25415, 1.9826086956522, 1.7, 0.36363636363636
25416, 1.9826086956522, 1.7, 0.31818181818182
25417, 1.9826086956522, 1.7, 0.27272727272727
25418, 1.9826086956522, 1.7, 0.22727272727273
25419, 1.9826086956522, 1.7, 0.18181818181818
25420, 1.9826086956522, 1.7, 0.13636363636364
25421, 1.9826086956522, 1.7, 0.090909090909091
25422, 1.9826086956522, 1.7, 0.045454545454545
25423, 2.0260869565217, 1.7, 0.45454545454545
25424, 2.0260869565217, 1.7, 0.40909090909091
25425, 2.0260869565217, 1.7, 0.36363636363636
25426, 2.0260869565217, 1.7, 0.31818181818182
25427, 2.0260869565217, 1.7, 0.27272727272727
25428, 2.0260869565217, 1.7, 0.22727272727273
25429, 2.0260869565217, 1.7, 0.18181818181818
25430, 2.0260869565217, 1.7, 0.13636363636364
25431, 2.0260869565217, 1.7, 0.090909090909091
25432, 2.0260869565217, 1.7, 0.045454545454545
25433, 2.0695652173913, 1.7, 0.45454545454545
25434, 2.0695652173913, 1.7, 0.40909090909091
25435, 2.0695652173913, 1.7, 0.36363636363636
25436, 2.0695652173913, 1.7, 0.31818181818182
25437, 2.0695652173913, 1.7, 0.27272727272727
25438, 2.0695652173913, 1.7, 0.22727272727273
25439, 2.0695652173913, 1.7, 0.18181818181818
25440, 2.0695652173913, 1.7, 0.13636363636364
25441, 2.0695652173913, 1.7, 0.090909090909091
25442, 2.0695652173913, 1.7, 0.045454545454545
25443, 2.1130434782609, 1.7, 0.45454545454545
25444, 2.1130434782609, 1.7, 0.40909090909091
25445, 2.1130434782609, 1.7, 0.36363636363636
25446, 2.1130434782609, 1.7, 0.31818181818182
25447, 2.1130434782609, 1.7, 0.27272727272727
25448, 2.1130434782609, 1.7, 0.22727272727273
25449, 2.1130434782609, 1.7, 0.18181818181818
25450, 2.1130434782609, 1.7, 0.13636363636364
25451, 2.1130434782609, 1.7, 0.090909090909091
25452, 2.1130434782609, 1.7, 0.045454545454545
25453, 2.1565217391304, 1.7, 0.45454545454545
25454, 2.1565217391304, 1.7, 0.40909090909091
25455, 2.1565217391304, 1.7, 0.36363636363636
25456, 2.1565217391304, 1.7, 0.31818181818182
25457, 2.1565217391304, 1.7, 0.27272727272727
25458, 2.1565217391304, 1.7, 0.22727272727273
25459, 2.1565217391304, 1.7, 0.18181818181818
25460, 2.1565217391304, 1.7, 0.13636363636364
25461, 2.1565217391304, 1.7, 0.090909090909091
25462, 2.1565217391304, 1.7, 0.045454545454545
25463, 1.2434782608696, 1.7, 0.47727272727273
25464, 1.2217391304348, 1.7, 0.45454545454545
25465, 1.2434782608696, 1.7, 0.43181818181818
25466, 1.2217391304348, 1.7, 0.40909090909091
25467, 1.2434782608696, 1.7, 0.38636363636364
25468, 1.2217391304348, 1.7, 0.36363636363636
25469, 1.2434782608696, 1.7, 0.34090909090909
25470, 1.2217391304348, 1.7, 0.31818181818182
25471, 1.2434782608696, 1.7, 0.29545454545455
25472, 1.2217391304348, 1.7, 0.27272727272727
25473, 1.2434782608696, 1.7, 0.25
25474, 1.2217391304348, 1.7, 0.22727272727273
25475, 1.2434782608696, 1.7, 0.20454545454545
25476, 1.2217391304348, 1.7, 0.18181818181818
25477, 1.2434782608696, 1.7, 0.15909090909091
25478, 1.2217391304348, 1.7, 0.13636363636364
25479, 1.2434782608696, 1.7, 0.11363636363636
25480, 1.2217391304348, 1.7, 0.090909090909091
25481, 1.2434782608696, 1.7, 0.068181818181818
25482, 1.2217391304348, 1.7, 0.045454545454545
25483, 1.2434782608696, 1.7, 0.022727272727273
25484, 1.2869565217391, 1.7, 0.47727272727273
25485, 1.2652173913043, 1.7, 0.45454545454545
25486, 1.2869565217391, 1.7, 0.43181818181818
25487, 1.2652173913043, 1.7, 0.40909090909091
25488, 1.2869565217391, 1.7, 0.38636363636364
25489, 1.2652173913043, 1.7, 0.36363636363636
25490, 1.2869565217391, 1.7, 0.34090909090909
25491, 1.2652173913043, 1.7, 0.31818181818182
25492, 1.2869565217391, 1.7, 0.29545454545455
25493, 1.2652173913043, 1.7, 0.27272727272727
25494, 1.2869565217391, 1.7, 0.25
25495, 1.2652173913043, 1.7, 0.22727272727273
25496, 1.2869565217391, 1.7, 0.20454545454545
25497, 1.2652173913043, 1.7, 0.18181818181818
25498, 1.2869565217391, 1.7, 0.15909090909091
25499, 1.2652173913043, 1.7, 0.13636363636364
25500, 1.2869565217391, 1.7, 0.11363636363636
25501, 1.2652173913043, 1.7, 0.090909090909091
25502, 1.2869565217391, 1.7, 0.068181818181818
25503, 1.2652173913043, 1.7, 0.045454545454545
25504, 1.2869565217391, 1.7, 0.022727272727273
25505, 1.3304347826087, 1.7, 0.47727272727273
25506, 1.3086956521739, 1.7, 0.45454545454545
25507, 1.3304347826087, 1.7, 0.43181818181818
25508, 1.3086956521739, 1.7, 0.40909090909091
25509, 1.3304347826087, 1.7, 0.38636363636364
25510, 1.3086956521739, 1.7, 0.36363636363636
25511, 1.3304347826087, 1.7, 0.34090909090909
25512, 1.3086956521739, 1.7, 0.31818181818182
25513, 1.3304347826087, 1.7, 0.29545454545455
25514, 1.3086956521739, 1.7, 0.27272727272727
25515, 1.3304347826087, 1.7, 0.25
25516, 1.3086956521739, 1.7, 0.22727272727273
25517, 1.3304347826087, 1.7, 0.20454545454545
25518, 1.3086956521739, 1.7, 0.18181818181818
25519, 1.3304347826087, 1.7, 0.15909090909091
25520, 1.3086956521739, 1.7, 0.13636363636364
25521, 1.3304347826087, 1.7, 0.11363636363636
25522, 1.3086956521739, 1.7, 0.090909090909091
25523, 1.3304347826087, 1.7, 0.068181818181818
25524, 1.3086956521739, 1.7, 0.045454545454545
25525, 1.3304347826087, 1.7, 0.022727272727273
25526, 1.3739130434783, 1.7, 0.47727272727273
25527, 1.3521739130435, 1.7, 0.45454545454545
25528, 1.3739130434783, 1.7, 0.43181818181818
25529, 1.3521739130435, 1.7, 0.40909090909091
25530, 1.3739130434783, 1.7, 0.38636363636364
25531, 1.3521739130435, 1.7, 0.36363636363636
25532, 1.3739130434783, 1.7, 0.34090909090909
25533, 1.3521739130435, 1.7, 0.31818181818182
25534, 1.3739130434783, 1.7, 0.29545454545455
25535, 1.3521739130435, 1.7, 0.27272727272727
25536, 1.3739130434783, 1.7, 0.25
25537, 1.3521739130435, 1.7, 0.22727272727273
25538, 1.3739130434783, 1.7, 0.20454545454545
25539, 1.3521739130435, 1.7, 0.18181818181818
25540, 1.3739130434783, 1.7, 0.15909090909091
25541, 1.3521739130435, 1.7, 0.13636363636364
25542, 1.3739130434783, 1.7, 0.11363636363636
25543, 1.3521739130435, 1.7, 0.090909090909091
25544, 1.3739130434783, 1.7, 0.068181818181818
25545, 1.3521739130435, 1.7, 0.045454545454545
25546, 1.3739130434783, 1.7, 0.022727272727273
25547, 1.4173913043478, 1.7, 0.47727272727273
25548, 1.395652173913, 1.7, 0.45454545454545
25549, 1.4173913043478, 1.7, 0.43181818181818
25550, 1.395652173913, 1.7, 0.40909090909091
25551, 1.4173913043478, 1.7, 0.38636363636364
25552, 1.395652173913, 1.7, 0.36363636363636
25553, 1.4173913043478, 1.7, 0.34090909090909
25554, 1.395652173913, 1.7, 0.31818181818182
25555, 1.4173913043478, 1.7, 0.29545454545455
25556, 1.395652173913, 1.7, 0.27272727272727
25557, 1.4173913043478, 1.7, 0.25
25558, 1.395652173913, 1.7, 0.22727272727273
25559, 1.4173913043478, 1.7, 0.20454545454545
25560, 1.395652173913, 1.7, 0.18181818181818
25561, 1.4173913043478, 1.7, 0.15909090909091
25562, 1.395652173913, 1.7, 0.13636363636364
25563, 1.4173913043478, 1.7, 0.11363636363636
25564, 1.395652173913, 1.7, 0.090909090909091
25565, 1.4173913043478, 1.7, 0.068181818181818
25566, 1.395652173913, 1.7, 0.045454545454545
25567, 1.4173913043478, 1.7, 0.022727272727273
25568, 1.4608695652174, 1.7, 0.47727272727273
25569, 1.4391304347826, 1.7, 0.45454545454545
25570, 1.4608695652174, 1.7, 0.43181818181818
25571, 1.4391304347826, 1.7, 0.40909090909091
25572, 1.4608695652174, 1.7, 0.38636363636364
25573, 1.4391304347826, 1.7, 0.36363636363636
25574, 1.4608695652174, 1.7, 0.34090909090909
25575, 1.4391304347826, 1.7, 0.31818181818182
25576, 1.4608695652174, 1.7, 0.29545454545455
25577, 1.4391304347826, 1.7, 0.27272727272727
25578, 1.4608695652174, 1.7, 0.25
25579, 1.4391304347826, 1.7, 0.22727272727273
25580, 1.4608695652174, 1.7, 0.20454545454545
25581, 1.4391304347826, 1.7, 0.18181818181818
25582, 1.4608695652174, 1.7, 0.15909090909091
25583, 1.4391304347826, 1.7, 0.13636363636364
25584, 1.4608695652174, 1.7, 0.11363636363636
25585, 1.4391304347826, 1.7, 0.090909090909091
25586, 1.4608695652174, 1.7, 0.068181818181818
25587, 1.4391304347826, 1.7, 0.045454545454545
25588, 1.4608695652174, 1.7, 0.022727272727273
25589, 1.504347826087, 1.7, 0.47727272727273
25590, 1.4826086956522, 1.7, 0.45454545454545
25591, 1.504347826087, 1.7, 0.43181818181818
25592, 1.4826086956522, 1.7, 0.40909090909091
25593, 1.504347826087, 1.7, 0.38636363636364
25594, 1.4826086956522, 1.7, 0.36363636363636
25595, 1.504347826087, 1.7, 0.34090909090909
25596, 1.4826086956522, 1.7, 0.31818181818182
25597, 1.504347826087, 1.7, 0.29545454545455
25598, 1.4826086956522, 1.7, 0.27272727272727
25599, 1.504347826087, 1.7, 0.25
25600, 1.4826086956522, 1.7, 0.22727272727273
25601, 1.504347826087, 1.7, 0.20454545454545
25602, 1.4826086956522, 1.7, 0.18181818181818
25603, 1.504347826087, 1.7, 0.15909090909091
25604, 1.4826086956522, 1.7, 0.13636363636364
25605, 1.504347826087, 1.7, 0.11363636363636
25606, 1.4826086956522, 1.7, 0.090909090909091
25607, 1.504347826087, 1.7, 0.068181818181818
25608, 1.4826086956522, 1.7, 0.045454545454545
25609, 1.504347826087, 1.7, 0.022727272727273
25610, 1.5478260869565, 1.7, 0.47727272727273
25611, 1.5260869565217, 1.7, 0.45454545454545
25612, 1.5478260869565, 1.7, 0.43181818181818
25613, 1.5260869565217, 1.7, 0.40909090909091
25614, 1.5478260869565, 1.7, 0.38636363636364
25615, 1.5260869565217, 1.7, 0.36363636363636
25616, 1.5478260869565, 1.7, 0.34090909090909
25617, 1.5260869565217, 1.7, 0.31818181818182
25618, 1.5478260869565, 1.7, 0.29545454545455
25619, 1.5260869565217, 1.7, 0.27272727272727
25620, 1.5478260869565, 1.7, 0.25
25621, 1.5260869565217, 1.7, 0.22727272727273
25622, 1.5478260869565, 1.7, 0.20454545454545
25623, 1.5260869565217, 1.7, 0.18181818181818
25624, 1.5478260869565, 1.7, 0.15909090909091
25625, 1.5260869565217, 1.7, 0.13636363636364
25626, 1.5478260869565, 1.7, 0.11363636363636
25627, 1.5260869565217, 1.7, 0.090909090909091
25628, 1.5478260869565, 1.7, 0.068181818181818
25629, 1.5260869565217, 1.7, 0.045454545454545
25630, 1.5478260869565, 1.7, 0.022727272727273
25631, 1.5913043478261, 1.7, 0.47727272727273
25632, 1.5695652173913, 1.7, 0.45454545454545
25633, 1.5913043478261, 1.7, 0.43181818181818
25634, 1.5695652173913, 1.7, 0.40909090909091
25635, 1.5913043478261, 1.7, 0.38636363636364
25636, 1.5695652173913, 1.7, 0.36363636363636
25637, 1.5913043478261, 1.7, 0.34090909090909
25638, 1.5695652173913, 1.7, 0.31818181818182
25639, 1.5913043478261, 1.7, 0.29545454545455
25640, 1.5695652173913, 1.7, 0.27272727272727
25641, 1.5913043478261, 1.7, 0.25
25642, 1.5695652173913, 1.7, 0.22727272727273
25643, 1.5913043478261, 1.7, 0.20454545454545
25644, 1.5695652173913, 1.7, 0.18181818181818
25645, 1.5913043478261, 1.7, 0.15909090909091
25646, 1.5695652173913, 1.7, 0.13636363636364
25647, 1.5913043478261, 1.7, 0.11363636363636
25648, 1.5695652173913, 1.7, 0.090909090909091
25649, 1.5913043478261, 1.7, 0.068181818181818
25650, 1.5695652173913, 1.7, 0.045454545454545
25651, 1.5913043478261, 1.7, 0.022727272727273
25652, 1.6347826086957, 1.7, 0.47727272727273
25653, 1.6130434782609, 1.7, 0.45454545454545
25654, 1.6347826086957, 1.7, 0.43181818181818
25655, 1.6130434782609, 1.7, 0.40909090909091
25656, 1.6347826086957, 1.7, 0.38636363636364
25657, 1.6130434782609, 1.7, 0.36363636363636
25658, 1.6347826086957, 1.7, 0.34090909090909
25659, 1.6130434782609, 1.7, 0.31818181818182
25660, 1.6347826086957, 1.7, 0.29545454545455
25661, 1.6130434782609, 1.7, 0.27272727272727
25662, 1.6347826086957, 1.7, 0.25
25663, 1.6130434782609, 1.7, 0.22727272727273
25664, 1.6347826086957, 1.7, 0.20454545454545
25665, 1.6130434782609, 1.7, 0.18181818181818
25666, 1.6347826086957, 1.7, 0.15909090909091
25667, 1.6130434782609, 1.7, 0.13636363636364
25668, 1.6347826086957, 1.7, 0.11363636363636
25669, 1.6130434782609, 1.7, 0.090909090909091
25670, 1.6347826086957, 1.7, 0.068181818181818
25671, 1.6130434782609, 1.7, 0.045454545454545
25672, 1.6347826086957, 1.7, 0.022727272727273
25673, 1.6782608695652, 1.7, 0.47727272727273
25674, 1.6565217391304, 1.7, 0.45454545454545
25675, 1.6782608695652, 1.7, 0.43181818181818
25676, 1.6565217391304, 1.7, 0.40909090909091
25677, 1.6782608695652, 1.7, 0.38636363636364
25678, 1.6565217391304, 1.7, 0.36363636363636
25679, 1.6782608695652, 1.7, 0.34090909090909
25680, 1.6565217391304, 1.7, 0.31818181818182
25681, 1.6782608695652, 1.7, 0.29545454545455
25682, 1.6565217391304, 1.7, 0.27272727272727
25683, 1.6782608695652, 1.7, 0.25
25684, 1.6565217391304, 1.7, 0.22727272727273
25685, 1.6782608695652, 1.7, 0.20454545454545
25686, 1.6565217391304, 1.7, 0.18181818181818
25687, 1.6782608695652, 1.7, 0.15909090909091
25688, 1.6565217391304, 1.7, 0.13636363636364
25689, 1.6782608695652, 1.7, 0.11363636363636
25690, 1.6565217391304, 1.7, 0.090909090909091
25691, 1.6782608695652, 1.7, 0.068181818181818
25692, 1.6565217391304, 1.7, 0.045454545454545
25693, 1.6782608695652, 1.7, 0.022727272727273
25694, 1.7217391304348, 1.7, 0.47727272727273
25695, 1.7, 1.7, 0.45454545454545
25696, 1.7217391304348, 1.7, 0.43181818181818
25697, 1.7, 1.7, 0.40909090909091
25698, 1.7217391304348, 1.7, 0.38636363636364
25699, 1.7, 1.7, 0.36363636363636
25700, 1.7217391304348, 1.7, 0.34090909090909
25701, 1.7, 1.7, 0.31818181818182
25702, 1.7217391304348, 1.7, 0.29545454545455
25703, 1.7, 1.7, 0.27272727272727
25704, 1.7217391304348, 1.7, 0.25
25705, 1.7, 1.7, 0.22727272727273
25706, 1.7217391304348, 1.7, 0.20454545454545
25707, 1.7, 1.7, 0.18181818181818
25708, 1.7217391304348, 1.7, 0.15909090909091
25709, 1.7, 1.7, 0.13636363636364
25710, 1.7217391304348, 1.7, 0.11363636363636
25711, 1.7, 1.7, 0.090909090909091
25712, 1.7217391304348, 1.7, 0.068181818181818
25713, 1.7, 1.7, 0.045454545454545
25714, 1.7217391304348, 1.7, 0.022727272727273
25715, 1.7652173913043, 1.7, 0.47727272727273
25716, 1.7434782608696, 1.7, 0.45454545454545
25717, 1.7652173913043, 1.7, 0.43181818181818
25718, 1.7434782608696, 1.7, 0.40909090909091
25719, 1.7652173913043, 1.7, 0.38636363636364
25720, 1.7434782608696, 1.7, 0.36363636363636
25721, 1.7652173913043, 1.7, 0.34090909090909
25722, 1.7434782608696, 1.7, 0.31818181818182
25723, 1.7652173913043, 1.7, 0.29545454545455
25724, 1.7434782608696, 1.7, 0.27272727272727
25725, 1.7652173913043, 1.7, 0.25
25726, 1.7434782608696, 1.7, 0.22727272727273
25727, 1.7652173913043, 1.7, 0.20454545454545
25728, 1.7434782608696, 1.7, 0.18181818181818
25729, 1.7652173913043, 1.7, 0.15909090909091
25730, 1.7434782608696, 1.7, 0.13636363636364
25731, 1.7652173913043, 1.7, 0.11363636363636
25732, 1.7434782608696, 1.7, 0.090909090909091
25733, 1.7652173913043, 1.7, 0.068181818181818
25734, 1.7434782608696, 1.7, 0.045454545454545
25735, 1.7652173913043, 1.7, 0.022727272727273
25736, 1.8086956521739, 1.7, 0.47727272727273
25737, 1.7869565217391, 1.7, 0.45454545454545
25738, 1.8086956521739, 1.7, 0.43181818181818
25739, 1.7869565217391, 1.7, 0.40909090909091
25740, 1.8086956521739, 1.7, 0.38636363636364
25741, 1.7869565217391, 1.7, 0.36363636363636
25742, 1.8086956521739, 1.7, 0.34090909090909
25743, 1.7869565217391, 1.7, 0.31818181818182
25744, 1.8086956521739, 1.7, 0.29545454545455
25745, 1.7869565217391, 1.7, 0.27272727272727
25746, 1.8086956521739, 1.7, 0.25
25747, 1.7869565217391, 1.7, 0.22727272727273
25748, 1.8086956521739, 1.7, 0.20454545454545
25749, 1.7869565217391, 1.7, 0.18181818181818
25750, 1.8086956521739, 1.7, 0.15909090909091
25751, 1.7869565217391, 1.7, 0.13636363636364
25752, 1.8086956521739, 1.7, 0.11363636363636
25753, 1.7869565217391, 1.7, 0.090909090909091
25754, 1.8086956521739, 1.7, 0.068181818181818
25755, 1.7869565217391, 1.7, 0.045454545454545
25756, 1.8086956521739, 1.7, 0.022727272727273
25757, 1.8521739130435, 1.7, 0.47727272727273
25758, 1.8304347826087, 1.7, 0.45454545454545
25759, 1.8521739130435, 1.7, 0.43181818181818
25760, 1.8304347826087, 1.7, 0.40909090909091
25761, 1.8521739130435, 1.7, 0.38636363636364
25762, 1.8304347826087, 1.7, 0.36363636363636
25763, 1.8521739130435, 1.7, 0.34090909090909
25764, 1.8304347826087, 1.7, 0.31818181818182
25765, 1.8521739130435, 1.7, 0.29545454545455
25766, 1.8304347826087, 1.7, 0.27272727272727
25767, 1.8521739130435, 1.7, 0.25
25768, 1.8304347826087, 1.7, 0.22727272727273
25769, 1.8521739130435, 1.7, 0.20454545454545
25770, 1.8304347826087, 1.7, 0.18181818181818
25771, 1.8521739130435, 1.7, 0.15909090909091
25772, 1.8304347826087, 1.7, 0.13636363636364
25773, 1.8521739130435, 1.7, 0.11363636363636
25774, 1.8304347826087, 1.7, 0.090909090909091
25775, 1.8521739130435, 1.7, 0.068181818181818
25776, 1.8304347826087, 1.7, 0.045454545454545
25777, 1.8521739130435, 1.7, 0.022727272727273
25778, 1.895652173913, 1.7, 0.47727272727273
25779, 1.8739130434783, 1.7, 0.45454545454545
25780, 1.895652173913, 1.7, 0.43181818181818
25781, 1.8739130434783, 1.7, 0.40909090909091
25782, 1.895652173913, 1.7, 0.38636363636364
25783, 1.8739130434783, 1.7, 0.36363636363636
25784, 1.895652173913, 1.7, 0.34090909090909
25785, 1.8739130434783, 1.7, 0.31818181818182
25786, 1.895652173913, 1.7, 0.29545454545455
25787, 1.8739130434783, 1.7, 0.27272727272727
25788, 1.895652173913, 1.7, 0.25
25789, 1.8739130434783, 1.7, 0.22727272727273
25790, 1.895652173913, 1.7, 0.20454545454545
25791, 1.8739130434783, 1.7, 0.18181818181818
25792, 1.895652173913, 1.7, 0.15909090909091
25793, 1.8739130434783, 1.7, 0.13636363636364
25794, 1.895652173913, 1.7, 0.11363636363636
25795, 1.8739130434783, 1.7, 0.090909090909091
25796, 1.895652173913, 1.7, 0.068181818181818
25797, 1.8739130434783, 1.7, 0.045454545454545
25798, 1.895652173913, 1.7, 0.022727272727273
25799, 1.9391304347826, 1.7, 0.47727272727273
25800, 1.9173913043478, 1.7, 0.45454545454545
25801, 1.9391304347826, 1.7, 0.43181818181818
25802, 1.9173913043478, 1.7, 0.40909090909091
25803, 1.9391304347826, 1.7, 0.38636363636364
25804, 1.9173913043478, 1.7, 0.36363636363636
25805, 1.9391304347826, 1.7, 0.34090909090909
25806, 1.9173913043478, 1.7, 0.31818181818182
25807, 1.9391304347826, 1.7, 0.29545454545455
25808, 1.9173913043478, 1.7, 0.27272727272727
25809, 1.9391304347826, 1.7, 0.25
25810, 1.9173913043478, 1.7, 0.22727272727273
25811, 1.9391304347826, 1.7, 0.20454545454545
25812, 1.9173913043478, 1.7, 0.18181818181818
25813, 1.9391304347826, 1.7, 0.15909090909091
25814, 1.9173913043478, 1.7, 0.13636363636364
25815, 1.9391304347826, 1.7, 0.11363636363636
25816, 1.9173913043478, 1.7, 0.090909090909091
25817, 1.9391304347826, 1.7, 0.068181818181818
25818, 1.9173913043478, 1.7, 0.045454545454545
25819, 1.9391304347826, 1.7, 0.022727272727273
25820, 1.9826086956522, 1.7, 0.47727272727273
25821, 1.9608695652174, 1.7, 0.45454545454545
25822, 1.9826086956522, 1.7, 0.43181818181818
25823, 1.9608695652174, 1.7, 0.40909090909091
25824, 1.9826086956522, 1.7, 0.38636363636364
25825, 1.9608695652174, 1.7, 0.36363636363636
25826, 1.9826086956522, 1.7, 0.34090909090909
25827, 1.9608695652174, 1.7, 0.31818181818182
25828, 1.9826086956522, 1.7, 0.29545454545455
25829, 1.9608695652174, 1.7, 0.27272727272727
25830, 1.9826086956522, 1.7, 0.25
25831, 1.9608695652174, 1.7, 0.22727272727273
25832, 1.9826086956522, 1.7, 0.20454545454545
25833, 1.9608695652174, 1.7, 0.18181818181818
25834, 1.9826086956522, 1.7, 0.15909090909091
25835, 1.9608695652174, 1.7, 0.13636363636364
25836, 1.9826086956522, 1.7, 0.11363636363636
25837, 1.9608695652174, 1.7, 0.090909090909091
25838, 1.9826086956522, 1.7, 0.068181818181818
25839, 1.9608695652174, 1.7, 0.045454545454545
25840, 1.9826086956522, 1.7, 0.022727272727273
25841, 2.0260869565217, 1.7, 0.47727272727273
25842, 2.004347826087, 1.7, 0.45454545454545
25843, 2.0260869565217, 1.7, 0.43181818181818
25844, 2.004347826087, 1.7, 0.40909090909091
25845, 2.0260869565217, 1.7, 0.38636363636364
25846, 2.004347826087, 1.7, 0.36363636363636
25847, 2.0260869565217, 1.7, 0.34090909090909
25848, 2.004347826087, 1.7, 0.31818181818182
25849, 2.0260869565217, 1.7, 0.29545454545455
25850, 2.004347826087, 1.7, 0.27272727272727
25851, 2.0260869565217, 1.7, 0.25
25852, 2.004347826087, 1.7, 0.22727272727273
25853, 2.0260869565217, 1.7, 0.20454545454545
25854, 2.004347826087, 1.7, 0.18181818181818
25855, 2.0260869565217, 1.7, 0.15909090909091
25856, 2.004347826087, 1.7, 0.13636363636364
25857, 2.0260869565217, 1.7, 0.11363636363636
25858, 2.004347826087, 1.7, 0.090909090909091
25859, 2.0260869565217, 1.7, 0.068181818181818
25860, 2.004347826087, 1.7, 0.045454545454545
25861, 2.0260869565217, 1.7, 0.022727272727273
25862, 2.0695652173913, 1.7, 0.47727272727273
25863, 2.0478260869565, 1.7, 0.45454545454545
25864, 2.0695652173913, 1.7, 0.43181818181818
25865, 2.0478260869565, 1.7, 0.40909090909091
25866, 2.0695652173913, 1.7, 0.38636363636364
25867, 2.0478260869565, 1.7, 0.36363636363636
25868, 2.0695652173913, 1.7, 0.34090909090909
25869, 2.0478260869565, 1.7, 0.31818181818182
25870, 2.0695652173913, 1.7, 0.29545454545455
25871, 2.0478260869565, 1.7, 0.27272727272727
25872, 2.0695652173913, 1.7, 0.25
25873, 2.0478260869565, 1.7, 0.22727272727273
25874, 2.0695652173913, 1.7, 0.20454545454545
25875, 2.0478260869565, 1.7, 0.18181818181818
25876, 2.0695652173913, 1.7, 0.15909090909091
25877, 2.0478260869565, 1.7, 0.13636363636364
25878, 2.0695652173913, 1.7, 0.11363636363636
25879, 2.0478260869565, 1.7, 0.090909090909091
25880, 2.0695652173913, 1.7, 0.068181818181818
25881, 2.0478260869565, 1.7, 0.045454545454545
25882, 2.0695652173913, 1.7, 0.022727272727273
25883, 2.1130434782609, 1.7, 0.47727272727273
25884, 2.0913043478261, 1.7, 0.45454545454545
25885, 2.1130434782609, 1.7, 0.43181818181818
25886, 2.0913043478261, 1.7, 0.40909090909091
25887, 2.1130434782609, 1.7, 0.38636363636364
25888, 2.0913043478261, 1.7, 0.36363636363636
25889, 2.1130434782609, 1.7, 0.34090909090909
25890, 2.0913043478261, 1.7, 0.31818181818182
25891, 2.1130434782609, 1.7, 0.29545454545455
25892, 2.0913043478261, 1.7, 0.27272727272727
25893, 2.1130434782609, 1.7, 0.25
25894, 2.0913043478261, 1.7, 0.22727272727273
25895, 2.1130434782609, 1.7, 0.20454545454545
25896, 2.0913043478261, 1.7, 0.18181818181818
25897, 2.1130434782609, 1.7, 0.15909090909091
25898, 2.0913043478261, 1.7, 0.13636363636364
25899, 2.1130434782609, 1.7, 0.11363636363636
25900, 2.0913043478261, 1.7, 0.090909090909091
25901, 2.1130434782609, 1.7, 0.068181818181818
25902, 2.0913043478261, 1.7, 0.045454545454545
25903, 2.1130434782609, 1.7, 0.022727272727273
25904, 2.1565217391304, 1.7, 0.47727272727273
25905, 2.1347826086957, 1.7, 0.45454545454545
25906, 2.1565217391304, 1.7, 0.43181818181818
25907, 2.1347826086957, 1.7, 0.40909090909091
25908, 2.1565217391304, 1.7, 0.38636363636364
25909, 2.1347826086957, 1.7, 0.36363636363636
25910, 2.1565217391304, 1.7, 0.34090909090909
25911, 2.1347826086957, 1.7, 0.31818181818182
25912, 2.1565217391304, 1.7, 0.29545454545455
25913, 2.1347826086957, 1.7, 0.27272727272727
25914, 2.1565217391304, 1.7, 0.25
25915, 2.1347826086957, 1.7, 0.22727272727273
25916, 2.1565217391304, 1.7, 0.20454545454545
25917, 2.1347826086957, 1.7, 0.18181818181818
25918, 2.1565217391304, 1.7, 0.15909090909091
25919, 2.1347826086957, 1.7, 0.13636363636364
25920, 2.1565217391304, 1.7, 0.11363636363636
25921, 2.1347826086957, 1.7, 0.090909090909091
25922, 2.1565217391304, 1.7, 0.068181818181818
25923, 2.1347826086957, 1.7, 0.045454545454545
25924, 2.1565217391304, 1.7, 0.022727272727273
25925, 2.1782608695652, 1.7, 0.45454545454545
25926, 2.1782608695652, 1.7, 0.40909090909091
25927, 2.1782608695652, 1.7, 0.36363636363636
25928, 2.1782608695652, 1.7, 0.31818181818182
25929, 2.1782608695652, 1.7, 0.27272727272727
25930, 2.1782608695652, 1.7, 0.22727272727273
25931, 2.1782608695652, 1.7, 0.18181818181818
25932, 2.1782608695652, 1.7, 0.13636363636364
25933, 2.1782608695652, 1.7, 0.090909090909091
25934, 2.1782608695652, 1.7, 0.045454545454545
25935, 0.95652173913043, -0.05, 0
25936, 0.91304347826087, -0.05, 0
25937, 0.8695652173913, -0.05, 0
25938, 0.82608695652174, -0.05, 0
25939, 0.78260869565217, -0.05, 0
25940, 0.73913043478261, -0.05, 0
25941, 0.69565217391304, -0.05, 0
25942, 0.65217391304348, -0.05, 0
25943, 0.60869565217391, -0.05, 0
25944, 0.56521739130435, -0.05, 0
25945, 0.52173913043478, -0.05, 0
25946, 0.47826086956522, -0.05, 0
25947, 0.43478260869565, -0.05, 0
25948, 0.39130434782609, -0.05, 0
25949, 0.34782608695652, -0.05, 0
25950, 0.30434782608696, -0.05, 0
25951, 0.26086956521739, -0.05, 0
25952, 0.21739130434783, -0.05, 0
25953, 0.17391304347826, -0.05, 0
25954, 0.1304347826087, -0.05, 0
25955, 0.08695652173913, -0.05, 0
25956, 0.043478260869565, -0.05, 0
25957, 0.95652173913043, -0.1, 0
25958, 0.91304347826087, -0.1, 0
25959, 0.8695652173913, -0.1, 0
25960, 0.82608695652174, -0.1, 0
25961, 0.78260869565217, -0.1, 0
25962, 0.73913043478261, -0.1, 0
25963, 0.69565217391304, -0.1, 0
25964, 0.65217391304348, -0.1, 0
25965, 0.60869565217391, -0.1, 0
25966, 0.56521739130435, -0.1, 0
25967, 0.52173913043478, -0.1, 0
25968, 0.47826086956522, -0.1, 0
25969, 0.43478260869565, -0.1, 0
25970, 0.39130434782609, -0.1, 0
25971, 0.34782608695652, -0.1, 0
25972, 0.30434782608696, -0.1, 0
25973, 0.26086956521739, -0.1, 0
25974, 0.21739130434783, -0.1, 0
25975, 0.17391304347826, -0.1, 0
25976, 0.1304347826087, -0.1, 0
25977, 0.08695652173913, -0.1, 0
25978, 0.043478260869565, -0.1, 0
25979, 0.95652173913043, -0.15, 0
25980, 0.91304347826087, -0.15, 0
25981, 0.8695652173913, -0.15, 0
25982, 0.82608695652174, -0.15, 0
25983, 0.78260869565217, -0.15, 0
25984, 0.73913043478261, -0.15, 0
25985, 0.69565217391304, -0.15, 0
25986, 0.65217391304348, -0.15, 0
25987, 0.60869565217391, -0.15, 0
25988, 0.56521739130435, -0.15, 0
25989, 0.52173913043478, -0.15, 0
25990, 0.47826086956522, -0.15, 0
25991, 0.43478260869565, -0.15, 0
25992, 0.39130434782609, -0.15, 0
25993, 0.34782608695652, -0.15, 0
25994, 0.30434782608696, -0.15, 0
25995, 0.26086956521739, -0.15, 0
25996, 0.21739130434783, -0.15, 0
25997, 0.17391304347826, -0.15, 0
25998, 0.1304347826087, -0.15, 0
25999, 0.08695652173913, -0.15, 0
26000, 0.043478260869565, -0.15, 0
26001, 0.97826086956522, -0.05, 0
26002, 0.95652173913043, -0.025, 0
26003, 0.93478260869565, -0.05, 0
26004, 0.91304347826087, -0.025, 0
26005, 0.89130434782609, -0.05, 0
26006, 0.8695652173913, -0.025, 0
26007, 0.84782608695652, -0.05, 0
26008, 0.82608695652174, -0.025, 0
26009, 0.80434782608696, -0.05, 0
26010, 0.78260869565217, -0.025, 0
26011, 0.76086956521739, -0.05, 0
26012, 0.73913043478261, -0.025, 0
26013, 0.71739130434783, -0.05, 0
26014, 0.69565217391304, -0.025, 0
26015, 0.67391304347826, -0.05, 0
26016, 0.65217391304348, -0.025, 0
26017, 0.6304347826087, -0.05, 0
26018, 0.60869565217391, -0.025, 0
26019, 0.58695652173913, -0.05, 0
26020, 0.56521739130435, -0.025, 0
26021, 0.54347826086957, -0.05, 0
26022, 0.52173913043478, -0.025, 0
26023, 0.5, -0.05, 0
26024, 0.47826086956522, -0.025, 0
26025, 0.45652173913043, -0.05, 0
26026, 0.43478260869565, -0.025, 0
26027, 0.41304347826087, -0.05, 0
26028, 0.39130434782609, -0.025, 0
26029, 0.3695652173913, -0.05, 0
26030, 0.34782608695652, -0.025, 0
26031, 0.32608695652174, -0.05, 0
26032, 0.30434782608696, -0.025, 0
26033, 0.28260869565217, -0.05, 0
26034, 0.26086956521739, -0.025, 0
26035, 0.23913043478261, -0.05, 0
26036, 0.21739130434783, -0.025, 0
26037, 0.19565217391304, -0.05, 0
26038, 0.17391304347826, -0.025, 0
26039, 0.15217391304348, -0.05, 0
26040, 0.1304347826087, -0.025, 0
26041, 0.10869565217391, -0.05, 0
26042, 0.08695652173913, -0.025, 0
26043, 0.065217391304348, -0.05, 0
26044, 0.043478260869565, -0.025, 0
26045, 0.021739130434783, -0.05, 0
26046, 0.97826086956522, -0.1, 0
26047, 0.95652173913043, -0.075, 0
26048, 0.93478260869565, -0.1, 0
26049, 0.91304347826087, -0.075, 0
26050, 0.89130434782609, -0.1, 0
26051, 0.8695652173913, -0.075, 0
26052, 0.84782608695652, -0.1, 0
26053, 0.82608695652174, -0.075, 0
26054, 0.80434782608696, -0.1, 0
26055, 0.78260869565217, -0.075, 0
26056, 0.76086956521739, -0.1, 0
26057, 0.73913043478261, -0.075, 0
26058, 0.71739130434783, -0.1, 0
26059, 0.69565217391304, -0.075, 0
26060, 0.67391304347826, -0.1, 0
26061, 0.65217391304348, -0.075, 0
26062, 0.6304347826087, -0.1, 0
26063, 0.60869565217391, -0.075, 0
26064, 0.58695652173913, -0.1, 0
26065, 0.56521739130435, -0.075, 0
26066, 0.54347826086957, -0.1, 0
26067, 0.52173913043478, -0.075, 0
26068, 0.5, -0.1, 0
26069, 0.47826086956522, -0.075, 0
26070, 0.45652173913043, -0.1, 0
26071, 0.43478260869565, -0.075, 0
26072, 0.41304347826087, -0.1, 0
26073, 0.39130434782609, -0.075, 0
26074, 0.3695652173913, -0.1, 0
26075, 0.34782608695652, -0.075, 0
26076, 0.32608695652174, -0.1, 0
26077, 0.30434782608696, -0.075, 0
26078, 0.28260869565217, -0.1, 0
26079, 0.26086956521739, -0.075, 0
26080, 0.23913043478261, -0.1, 0
26081, 0.21739130434783, -0.075, 0
26082, 0.19565217391304, -0.1, 0
26083, 0.17391304347826, -0.075, 0
26084, 0.15217391304348, -0.1, 0
26085, 0.1304347826087, -0.075, 0
26086, 0.10869565217391, -0.1, 0
26087, 0.08695652173913, -0.075, 0
26088, 0.065217391304348, -0.1, 0
26089, 0.043478260869565, -0.075, 0
26090, 0.021739130434783, -0.1, 0
26091, 0.97826086956522, -0.15, 0
26092, 0.95652173913043, -0.125, 0
26093, 0.93478260869565, -0.15, 0
26094, 0.91304347826087, -0.125, 0
26095, 0.89130434782609, -0.15, 0
26096, 0.8695652173913, -0.125, 0
26097, 0.84782608695652, -0.15, 0
26098, 0.82608695652174, -0.125, 0
26099, 0.80434782608696, -0.15, 0
26100, 0.78260869565217, -0.125, 0
26101, 0.76086956521739, -0.15, 0
26102, 0.73913043478261, -0.125, 0
26103, 0.71739130434783, -0.15, 0
26104, 0.69565217391304, -0.125, 0
26105, 0.67391304347826, -0.15, 0
26106, 0.65217391304348, -0.125, 0
26107, 0.6304347826087, -0.15, 0
26108, 0.60869565217391, -0.125, 0
26109, 0.58695652173913, -0.15, 0
26110, 0.56521739130435, -0.125, 0
26111, 0.54347826086957, -0.15, 0
26112, 0.52173913043478, -0.125, 0
26113, 0.5, -0.15, 0
26114, 0.47826086956522, -0.125, 0
26115, 0.45652173913043, -0.15, 0
26116, 0.43478260869565, -0.125, 0
26117, 0.41304347826087, -0.15, 0
26118, 0.39130434782609, -0.125, 0
26119, 0.3695652173913, -0.15, 0
26120, 0.34782608695652, -0.125, 0
26121, 0.32608695652174, -0.15, 0
26122, 0.30434782608696, -0.125, 0
26123, 0.28260869565217, -0.15, 0
26124, 0.26086956521739, -0.125, 0
26125, 0.23913043478261, -0.15, 0
26126, 0.21739130434783, -0.125, 0
26127, 0.19565217391304, -0.15, 0
26128, 0.17391304347826, -0.125, 0
26129, 0.15217391304348, -0.15, 0
26130, 0.1304347826087, -0.125, 0
26131, 0.10869565217391, -0.15, 0
26132, 0.08695652173913, -0.125, 0
26133, 0.065217391304348, -0.15, 0
26134, 0.043478260869565, -0.125, 0
26135, 0.021739130434783, -0.15, 0
26136, 0.95652173913043, -0.175, 0
26137, 0.91304347826087, -0.175, 0
26138, 0.8695652173913, -0.175, 0
26139, 0.82608695652174, -0.175, 0
26140, 0.78260869565217, -0.175, 0
26141, 0.73913043478261, -0.175, 0
26142, 0.69565217391304, -0.175, 0
26143, 0.65217391304348, -0.175, 0
26144, 0.60869565217391, -0.175, 0
26145, 0.56521739130435, -0.175, 0
26146, 0.52173913043478, -0.175, 0
26147, 0.47826086956522, -0.175, 0
26148, 0.43478260869565, -0.175, 0
26149, 0.39130434782609, -0.175, 0
26150, 0.34782608695652, -0.175, 0
26151, 0.30434782608696, -0.175, 0
26152, 0.26086956521739, -0.175, 0
26153, 0.21739130434783, -0.175, 0
26154, 0.17391304347826, -0.175, 0
26155, 0.1304347826087, -0.175, 0
26156, 0.08695652173913, -0.175, 0
26157, 0.043478260869565, -0.175, 0
26158, 1, -0.05, 0.45454545454545
26159, 1, -0.05, 0.40909090909091
26160, 1, -0.05, 0.36363636363636
26161, 1, -0.05, 0.31818181818182
26162, 1, -0.05, 0.27272727272727
26163, 1, -0.05, 0.22727272727273
26164, 1, -0.05, 0.18181818181818
26165, 1, -0.05, 0.13636363636364
26166, 1, -0.05, 0.090909090909091
26167, 1, -0.05, 0.045454545454545
26168, 1, -0.1, 0.45454545454545
26169, 1, -0.1, 0.40909090909091
26170, 1, -0.1, 0.36363636363636
26171, 1, -0.1, 0.31818181818182
26172, 1, -0.1, 0.27272727272727
26173, 1, -0.1, 0.22727272727273
26174, 1, -0.1, 0.18181818181818
26175, 1, -0.1, 0.13636363636364
26176, 1, -0.1, 0.090909090909091
26177, 1, -0.1, 0.045454545454545
26178, 1, -0.15, 0.45454545454545
26179, 1, -0.15, 0.40909090909091
26180, 1, -0.15, 0.36363636363636
26181, 1, -0.15, 0.31818181818182
26182, 1, -0.15, 0.27272727272727
26183, 1, -0.15, 0.22727272727273
26184, 1, -0.15, 0.18181818181818
26185, 1, -0.15, 0.13636363636364
26186, 1, -0.15, 0.090909090909091
26187, 1, -0.15, 0.045454545454545
26188, 1, -0.05, 0.47727272727273
26189, 1, -0.025, 0.45454545454545
26190, 1, -0.05, 0.43181818181818
26191, 1, -0.025, 0.40909090909091
26192, 1, -0.05, 0.38636363636364
26193, 1, -0.025, 0.36363636363636
26194, 1, -0.05, 0.34090909090909
26195, 1, -0.025, 0.31818181818182
26196, 1, -0.05, 0.29545454545455
26197, 1, -0.025, 0.27272727272727
26198, 1, -0.05, 0.25
26199, 1, -0.025, 0.22727272727273
26200, 1, -0.05, 0.20454545454545
26201, 1, -0.025, 0.18181818181818
26202, 1, -0.05, 0.15909090909091
26203, 1, -0.025, 0.13636363636364
26204, 1, -0.05, 0.11363636363636
26205, 1, -0.025, 0.090909090909091
26206, 1, -0.05, 0.068181818181818
26207, 1, -0.025, 0.045454545454545
26208, 1, -0.05, 0.022727272727273
26209, 1, -0.1, 0.47727272727273
26210, 1, -0.075, 0.45454545454545
26211, 1, -0.1, 0.43181818181818
26212, 1, -0.075, 0.40909090909091
26213, 1, -0.1, 0.38636363636364
26214, 1, -0.075, 0.36363636363636
26215, 1, -0.1, 0.34090909090909
26216, 1, -0.075, 0.31818181818182
26217, 1, -0.1, 0.29545454545455
26218, 1, -0.075, 0.27272727272727
26219, 1, -0.1, 0.25
26220, 1, -0.075, 0.22727272727273
26221, 1, -0.1, 0.20454545454545
26222, 1, -0.075, 0.18181818181818
26223, 1, -0.1, 0.15909090909091
26224, 1, -0.075, 0.13636363636364
26225, 1, -0.1, 0.11363636363636
26226, 1, -0.075, 0.090909090909091
26227, 1, -0.1, 0.068181818181818
26228, 1, -0.075, 0.045454545454545
26229, 1, -0.1, 0.022727272727273
26230, 1, -0.15, 0.47727272727273
26231, 1, -0.125, 0.45454545454545
26232, 1, -0.15, 0.43181818181818
26233, 1, -0.125, 0.40909090909091
26234, 1, -0.15, 0.38636363636364
26235, 1, -0.125, 0.36363636363636
26236, 1, -0.15, 0.34090909090909
26237, 1, -0.125, 0.31818181818182
26238, 1, -0.15, 0.29545454545455
26239, 1, -0.125, 0.27272727272727
26240, 1, -0.15, 0.25
26241, 1, -0.125, 0.22727272727273
26242, 1, -0.15, 0.20454545454545
26243, 1, -0.125, 0.18181818181818
26244, 1, -0.15, 0.15909090909091
26245, 1, -0.125, 0.13636363636364
26246, 1, -0.15, 0.11363636363636
26247, 1, -0.125, 0.090909090909091
26248, 1, -0.15, 0.068181818181818
26249, 1, -0.125, 0.045454545454545
26250, 1, -0.15, 0.022727272727273
26251, 1, -0.175, 0.45454545454545
26252, 1, -0.175, 0.40909090909091
26253, 1, -0.175, 0.36363636363636
26254, 1, -0.175, 0.31818181818182
26255, 1, -0.175, 0.27272727272727
26256, 1, -0.175, 0.22727272727273
26257, 1, -0.175, 0.18181818181818
26258, 1, -0.175, 0.13636363636364
26259, 1, -0.175, 0.090909090909091
26260, 1, -0.175, 0.045454545454545
26261, 0.95652173913043, -0.05, 0.5
26262, 0.91304347826087, -0.05, 0.5
26263, 0.8695652173913, -0.05, 0.5
26264, 0.82608695652174, -0.05, 0.5
26265, 0.78260869565217, -0.05, 0.5
26266, 0.73913043478261, -0.05, 0.5
26267, 0.69565217391304, -0.05, 0.5
26268, 0.65217391304348, -0.05, 0.5
26269, 0.60869565217391, -0.05, 0.5
26270, 0.56521739130435, -0.05, 0.5
26271, 0.52173913043478, -0.05, 0.5
26272, 0.47826086956522, -0.05, 0.5
26273, 0.43478260869565, -0.05, 0.5
26274, 0.39130434782609, -0.05, 0.5
26275, 0.34782608695652, -0.05, 0.5
26276, 0.30434782608696, -0.05, 0.5
