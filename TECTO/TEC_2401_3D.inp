58739, 1.8521739130435, 1.4333333333333, 0.36363636363636
58740, 1.8521739130435, 1.4333333333333, 0.31818181818182
58741, 1.8521739130435, 1.4333333333333, 0.27272727272727
58742, 1.8521739130435, 1.4333333333333, 0.22727272727273
58743, 1.8521739130435, 1.4333333333333, 0.18181818181818
58744, 1.8521739130435, 1.4333333333333, 0.13636363636364
58745, 1.8521739130435, 1.4333333333333, 0.090909090909091
58746, 1.8521739130435, 1.4333333333333, 0.045454545454545
58747, 1.8521739130435, 1.4666666666667, 0.45454545454545
58748, 1.8521739130435, 1.4666666666667, 0.40909090909091
58749, 1.8521739130435, 1.4666666666667, 0.36363636363636
58750, 1.8521739130435, 1.4666666666667, 0.31818181818182
58751, 1.8521739130435, 1.4666666666667, 0.27272727272727
58752, 1.8521739130435, 1.4666666666667, 0.22727272727273
58753, 1.8521739130435, 1.4666666666667, 0.18181818181818
58754, 1.8521739130435, 1.4666666666667, 0.13636363636364
58755, 1.8521739130435, 1.4666666666667, 0.090909090909091
58756, 1.8521739130435, 1.4666666666667, 0.045454545454545
58757, 1.895652173913, 1.4333333333333, 0.45454545454545
58758, 1.895652173913, 1.4333333333333, 0.40909090909091
58759, 1.895652173913, 1.4333333333333, 0.36363636363636
58760, 1.895652173913, 1.4333333333333, 0.31818181818182
58761, 1.895652173913, 1.4333333333333, 0.27272727272727
58762, 1.895652173913, 1.4333333333333, 0.22727272727273
58763, 1.895652173913, 1.4333333333333, 0.18181818181818
58764, 1.895652173913, 1.4333333333333, 0.13636363636364
58765, 1.895652173913, 1.4333333333333, 0.090909090909091
58766, 1.895652173913, 1.4333333333333, 0.045454545454545
58767, 1.895652173913, 1.4666666666667, 0.45454545454545
58768, 1.895652173913, 1.4666666666667, 0.40909090909091
58769, 1.895652173913, 1.4666666666667, 0.36363636363636
58770, 1.895652173913, 1.4666666666667, 0.31818181818182
58771, 1.895652173913, 1.4666666666667, 0.27272727272727
58772, 1.895652173913, 1.4666666666667, 0.22727272727273
58773, 1.895652173913, 1.4666666666667, 0.18181818181818
58774, 1.895652173913, 1.4666666666667, 0.13636363636364
58775, 1.895652173913, 1.4666666666667, 0.090909090909091
58776, 1.895652173913, 1.4666666666667, 0.045454545454545
58777, 1.9391304347826, 1.4333333333333, 0.45454545454545
58778, 1.9391304347826, 1.4333333333333, 0.40909090909091
58779, 1.9391304347826, 1.4333333333333, 0.36363636363636
58780, 1.9391304347826, 1.4333333333333, 0.31818181818182
58781, 1.9391304347826, 1.4333333333333, 0.27272727272727
58782, 1.9391304347826, 1.4333333333333, 0.22727272727273
58783, 1.9391304347826, 1.4333333333333, 0.18181818181818
58784, 1.9391304347826, 1.4333333333333, 0.13636363636364
58785, 1.9391304347826, 1.4333333333333, 0.090909090909091
58786, 1.9391304347826, 1.4333333333333, 0.045454545454545
58787, 1.9391304347826, 1.4666666666667, 0.45454545454545
58788, 1.9391304347826, 1.4666666666667, 0.40909090909091
58789, 1.9391304347826, 1.4666666666667, 0.36363636363636
58790, 1.9391304347826, 1.4666666666667, 0.31818181818182
58791, 1.9391304347826, 1.4666666666667, 0.27272727272727
58792, 1.9391304347826, 1.4666666666667, 0.22727272727273
58793, 1.9391304347826, 1.4666666666667, 0.18181818181818
58794, 1.9391304347826, 1.4666666666667, 0.13636363636364
58795, 1.9391304347826, 1.4666666666667, 0.090909090909091
58796, 1.9391304347826, 1.4666666666667, 0.045454545454545
58797, 1.9826086956522, 1.4333333333333, 0.45454545454545
58798, 1.9826086956522, 1.4333333333333, 0.40909090909091
58799, 1.9826086956522, 1.4333333333333, 0.36363636363636
58800, 1.9826086956522, 1.4333333333333, 0.31818181818182
58801, 1.9826086956522, 1.4333333333333, 0.27272727272727
58802, 1.9826086956522, 1.4333333333333, 0.22727272727273
58803, 1.9826086956522, 1.4333333333333, 0.18181818181818
58804, 1.9826086956522, 1.4333333333333, 0.13636363636364
58805, 1.9826086956522, 1.4333333333333, 0.090909090909091
58806, 1.9826086956522, 1.4333333333333, 0.045454545454545
58807, 1.9826086956522, 1.4666666666667, 0.45454545454545
58808, 1.9826086956522, 1.4666666666667, 0.40909090909091
58809, 1.9826086956522, 1.4666666666667, 0.36363636363636
58810, 1.9826086956522, 1.4666666666667, 0.31818181818182
58811, 1.9826086956522, 1.4666666666667, 0.27272727272727
58812, 1.9826086956522, 1.4666666666667, 0.22727272727273
58813, 1.9826086956522, 1.4666666666667, 0.18181818181818
58814, 1.9826086956522, 1.4666666666667, 0.13636363636364
58815, 1.9826086956522, 1.4666666666667, 0.090909090909091
58816, 1.9826086956522, 1.4666666666667, 0.045454545454545
58817, 2.0260869565217, 1.4333333333333, 0.45454545454545
58818, 2.0260869565217, 1.4333333333333, 0.40909090909091
58819, 2.0260869565217, 1.4333333333333, 0.36363636363636
58820, 2.0260869565217, 1.4333333333333, 0.31818181818182
58821, 2.0260869565217, 1.4333333333333, 0.27272727272727
58822, 2.0260869565217, 1.4333333333333, 0.22727272727273
58823, 2.0260869565217, 1.4333333333333, 0.18181818181818
58824, 2.0260869565217, 1.4333333333333, 0.13636363636364
58825, 2.0260869565217, 1.4333333333333, 0.090909090909091
58826, 2.0260869565217, 1.4333333333333, 0.045454545454545
58827, 2.0260869565217, 1.4666666666667, 0.45454545454545
58828, 2.0260869565217, 1.4666666666667, 0.40909090909091
58829, 2.0260869565217, 1.4666666666667, 0.36363636363636
58830, 2.0260869565217, 1.4666666666667, 0.31818181818182
58831, 2.0260869565217, 1.4666666666667, 0.27272727272727
58832, 2.0260869565217, 1.4666666666667, 0.22727272727273
58833, 2.0260869565217, 1.4666666666667, 0.18181818181818
58834, 2.0260869565217, 1.4666666666667, 0.13636363636364
58835, 2.0260869565217, 1.4666666666667, 0.090909090909091
58836, 2.0260869565217, 1.4666666666667, 0.045454545454545
58837, 2.0695652173913, 1.4333333333333, 0.45454545454545
58838, 2.0695652173913, 1.4333333333333, 0.40909090909091
58839, 2.0695652173913, 1.4333333333333, 0.36363636363636
58840, 2.0695652173913, 1.4333333333333, 0.31818181818182
58841, 2.0695652173913, 1.4333333333333, 0.27272727272727
58842, 2.0695652173913, 1.4333333333333, 0.22727272727273
58843, 2.0695652173913, 1.4333333333333, 0.18181818181818
58844, 2.0695652173913, 1.4333333333333, 0.13636363636364
58845, 2.0695652173913, 1.4333333333333, 0.090909090909091
58846, 2.0695652173913, 1.4333333333333, 0.045454545454545
58847, 2.0695652173913, 1.4666666666667, 0.45454545454545
58848, 2.0695652173913, 1.4666666666667, 0.40909090909091
58849, 2.0695652173913, 1.4666666666667, 0.36363636363636
58850, 2.0695652173913, 1.4666666666667, 0.31818181818182
58851, 2.0695652173913, 1.4666666666667, 0.27272727272727
58852, 2.0695652173913, 1.4666666666667, 0.22727272727273
58853, 2.0695652173913, 1.4666666666667, 0.18181818181818
58854, 2.0695652173913, 1.4666666666667, 0.13636363636364
58855, 2.0695652173913, 1.4666666666667, 0.090909090909091
58856, 2.0695652173913, 1.4666666666667, 0.045454545454545
58857, 2.1130434782609, 1.4333333333333, 0.45454545454545
58858, 2.1130434782609, 1.4333333333333, 0.40909090909091
58859, 2.1130434782609, 1.4333333333333, 0.36363636363636
58860, 2.1130434782609, 1.4333333333333, 0.31818181818182
58861, 2.1130434782609, 1.4333333333333, 0.27272727272727
58862, 2.1130434782609, 1.4333333333333, 0.22727272727273
58863, 2.1130434782609, 1.4333333333333, 0.18181818181818
58864, 2.1130434782609, 1.4333333333333, 0.13636363636364
58865, 2.1130434782609, 1.4333333333333, 0.090909090909091
58866, 2.1130434782609, 1.4333333333333, 0.045454545454545
58867, 2.1130434782609, 1.4666666666667, 0.45454545454545
58868, 2.1130434782609, 1.4666666666667, 0.40909090909091
58869, 2.1130434782609, 1.4666666666667, 0.36363636363636
58870, 2.1130434782609, 1.4666666666667, 0.31818181818182
58871, 2.1130434782609, 1.4666666666667, 0.27272727272727
58872, 2.1130434782609, 1.4666666666667, 0.22727272727273
58873, 2.1130434782609, 1.4666666666667, 0.18181818181818
58874, 2.1130434782609, 1.4666666666667, 0.13636363636364
58875, 2.1130434782609, 1.4666666666667, 0.090909090909091
58876, 2.1130434782609, 1.4666666666667, 0.045454545454545
58877, 2.1565217391304, 1.4333333333333, 0.45454545454545
58878, 2.1565217391304, 1.4333333333333, 0.40909090909091
58879, 2.1565217391304, 1.4333333333333, 0.36363636363636
58880, 2.1565217391304, 1.4333333333333, 0.31818181818182
58881, 2.1565217391304, 1.4333333333333, 0.27272727272727
58882, 2.1565217391304, 1.4333333333333, 0.22727272727273
58883, 2.1565217391304, 1.4333333333333, 0.18181818181818
58884, 2.1565217391304, 1.4333333333333, 0.13636363636364
58885, 2.1565217391304, 1.4333333333333, 0.090909090909091
58886, 2.1565217391304, 1.4333333333333, 0.045454545454545
58887, 2.1565217391304, 1.4666666666667, 0.45454545454545
58888, 2.1565217391304, 1.4666666666667, 0.40909090909091
58889, 2.1565217391304, 1.4666666666667, 0.36363636363636
58890, 2.1565217391304, 1.4666666666667, 0.31818181818182
58891, 2.1565217391304, 1.4666666666667, 0.27272727272727
58892, 2.1565217391304, 1.4666666666667, 0.22727272727273
58893, 2.1565217391304, 1.4666666666667, 0.18181818181818
58894, 2.1565217391304, 1.4666666666667, 0.13636363636364
58895, 2.1565217391304, 1.4666666666667, 0.090909090909091
58896, 2.1565217391304, 1.4666666666667, 0.045454545454545
58897, 1.2434782608696, 1.4333333333333, 0.47727272727273
58898, 1.2434782608696, 1.4166666666667, 0.45454545454545
58899, 1.2217391304348, 1.4333333333333, 0.45454545454545
58900, 1.2434782608696, 1.4333333333333, 0.43181818181818
58901, 1.2434782608696, 1.4166666666667, 0.40909090909091
58902, 1.2217391304348, 1.4333333333333, 0.40909090909091
58903, 1.2434782608696, 1.4333333333333, 0.38636363636364
58904, 1.2434782608696, 1.4166666666667, 0.36363636363636
58905, 1.2217391304348, 1.4333333333333, 0.36363636363636
58906, 1.2434782608696, 1.4333333333333, 0.34090909090909
58907, 1.2434782608696, 1.4166666666667, 0.31818181818182
58908, 1.2217391304348, 1.4333333333333, 0.31818181818182
58909, 1.2434782608696, 1.4333333333333, 0.29545454545455
58910, 1.2434782608696, 1.4166666666667, 0.27272727272727
58911, 1.2217391304348, 1.4333333333333, 0.27272727272727
58912, 1.2434782608696, 1.4333333333333, 0.25
58913, 1.2434782608696, 1.4166666666667, 0.22727272727273
58914, 1.2217391304348, 1.4333333333333, 0.22727272727273
58915, 1.2434782608696, 1.4333333333333, 0.20454545454545
58916, 1.2434782608696, 1.4166666666667, 0.18181818181818
58917, 1.2217391304348, 1.4333333333333, 0.18181818181818
58918, 1.2434782608696, 1.4333333333333, 0.15909090909091
58919, 1.2434782608696, 1.4166666666667, 0.13636363636364
58920, 1.2217391304348, 1.4333333333333, 0.13636363636364
58921, 1.2434782608696, 1.4333333333333, 0.11363636363636
58922, 1.2434782608696, 1.4166666666667, 0.090909090909091
58923, 1.2217391304348, 1.4333333333333, 0.090909090909091
58924, 1.2434782608696, 1.4333333333333, 0.068181818181818
58925, 1.2434782608696, 1.4166666666667, 0.045454545454545
58926, 1.2217391304348, 1.4333333333333, 0.045454545454545
58927, 1.2434782608696, 1.4333333333333, 0.022727272727273
58928, 1.2434782608696, 1.4666666666667, 0.47727272727273
58929, 1.2434782608696, 1.45, 0.45454545454545
58930, 1.2217391304348, 1.4666666666667, 0.45454545454545
58931, 1.2434782608696, 1.4666666666667, 0.43181818181818
58932, 1.2434782608696, 1.45, 0.40909090909091
58933, 1.2217391304348, 1.4666666666667, 0.40909090909091
58934, 1.2434782608696, 1.4666666666667, 0.38636363636364
58935, 1.2434782608696, 1.45, 0.36363636363636
58936, 1.2217391304348, 1.4666666666667, 0.36363636363636
58937, 1.2434782608696, 1.4666666666667, 0.34090909090909
58938, 1.2434782608696, 1.45, 0.31818181818182
58939, 1.2217391304348, 1.4666666666667, 0.31818181818182
58940, 1.2434782608696, 1.4666666666667, 0.29545454545455
58941, 1.2434782608696, 1.45, 0.27272727272727
58942, 1.2217391304348, 1.4666666666667, 0.27272727272727
58943, 1.2434782608696, 1.4666666666667, 0.25
58944, 1.2434782608696, 1.45, 0.22727272727273
58945, 1.2217391304348, 1.4666666666667, 0.22727272727273
58946, 1.2434782608696, 1.4666666666667, 0.20454545454545
58947, 1.2434782608696, 1.45, 0.18181818181818
58948, 1.2217391304348, 1.4666666666667, 0.18181818181818
58949, 1.2434782608696, 1.4666666666667, 0.15909090909091
58950, 1.2434782608696, 1.45, 0.13636363636364
58951, 1.2217391304348, 1.4666666666667, 0.13636363636364
58952, 1.2434782608696, 1.4666666666667, 0.11363636363636
58953, 1.2434782608696, 1.45, 0.090909090909091
58954, 1.2217391304348, 1.4666666666667, 0.090909090909091
58955, 1.2434782608696, 1.4666666666667, 0.068181818181818
58956, 1.2434782608696, 1.45, 0.045454545454545
58957, 1.2217391304348, 1.4666666666667, 0.045454545454545
58958, 1.2434782608696, 1.4666666666667, 0.022727272727273
58959, 1.2434782608696, 1.4833333333333, 0.45454545454545
58960, 1.2434782608696, 1.4833333333333, 0.40909090909091
58961, 1.2434782608696, 1.4833333333333, 0.36363636363636
58962, 1.2434782608696, 1.4833333333333, 0.31818181818182
58963, 1.2434782608696, 1.4833333333333, 0.27272727272727
58964, 1.2434782608696, 1.4833333333333, 0.22727272727273
58965, 1.2434782608696, 1.4833333333333, 0.18181818181818
58966, 1.2434782608696, 1.4833333333333, 0.13636363636364
58967, 1.2434782608696, 1.4833333333333, 0.090909090909091
58968, 1.2434782608696, 1.4833333333333, 0.045454545454545
58969, 1.2869565217391, 1.4333333333333, 0.47727272727273
58970, 1.2869565217391, 1.4166666666667, 0.45454545454545
58971, 1.2652173913043, 1.4333333333333, 0.45454545454545
58972, 1.2869565217391, 1.4333333333333, 0.43181818181818
58973, 1.2869565217391, 1.4166666666667, 0.40909090909091
58974, 1.2652173913043, 1.4333333333333, 0.40909090909091
58975, 1.2869565217391, 1.4333333333333, 0.38636363636364
58976, 1.2869565217391, 1.4166666666667, 0.36363636363636
58977, 1.2652173913043, 1.4333333333333, 0.36363636363636
58978, 1.2869565217391, 1.4333333333333, 0.34090909090909
58979, 1.2869565217391, 1.4166666666667, 0.31818181818182
58980, 1.2652173913043, 1.4333333333333, 0.31818181818182
58981, 1.2869565217391, 1.4333333333333, 0.29545454545455
58982, 1.2869565217391, 1.4166666666667, 0.27272727272727
58983, 1.2652173913043, 1.4333333333333, 0.27272727272727
58984, 1.2869565217391, 1.4333333333333, 0.25
58985, 1.2869565217391, 1.4166666666667, 0.22727272727273
58986, 1.2652173913043, 1.4333333333333, 0.22727272727273
58987, 1.2869565217391, 1.4333333333333, 0.20454545454545
58988, 1.2869565217391, 1.4166666666667, 0.18181818181818
58989, 1.2652173913043, 1.4333333333333, 0.18181818181818
58990, 1.2869565217391, 1.4333333333333, 0.15909090909091
58991, 1.2869565217391, 1.4166666666667, 0.13636363636364
58992, 1.2652173913043, 1.4333333333333, 0.13636363636364
58993, 1.2869565217391, 1.4333333333333, 0.11363636363636
58994, 1.2869565217391, 1.4166666666667, 0.090909090909091
58995, 1.2652173913043, 1.4333333333333, 0.090909090909091
58996, 1.2869565217391, 1.4333333333333, 0.068181818181818
58997, 1.2869565217391, 1.4166666666667, 0.045454545454545
58998, 1.2652173913043, 1.4333333333333, 0.045454545454545
58999, 1.2869565217391, 1.4333333333333, 0.022727272727273
59000, 1.2869565217391, 1.4666666666667, 0.47727272727273
59001, 1.2869565217391, 1.45, 0.45454545454545
59002, 1.2652173913043, 1.4666666666667, 0.45454545454545
59003, 1.2869565217391, 1.4666666666667, 0.43181818181818
59004, 1.2869565217391, 1.45, 0.40909090909091
59005, 1.2652173913043, 1.4666666666667, 0.40909090909091
59006, 1.2869565217391, 1.4666666666667, 0.38636363636364
59007, 1.2869565217391, 1.45, 0.36363636363636
59008, 1.2652173913043, 1.4666666666667, 0.36363636363636
59009, 1.2869565217391, 1.4666666666667, 0.34090909090909
59010, 1.2869565217391, 1.45, 0.31818181818182
59011, 1.2652173913043, 1.4666666666667, 0.31818181818182
59012, 1.2869565217391, 1.4666666666667, 0.29545454545455
59013, 1.2869565217391, 1.45, 0.27272727272727
59014, 1.2652173913043, 1.4666666666667, 0.27272727272727
59015, 1.2869565217391, 1.4666666666667, 0.25
59016, 1.2869565217391, 1.45, 0.22727272727273
59017, 1.2652173913043, 1.4666666666667, 0.22727272727273
59018, 1.2869565217391, 1.4666666666667, 0.20454545454545
59019, 1.2869565217391, 1.45, 0.18181818181818
59020, 1.2652173913043, 1.4666666666667, 0.18181818181818
59021, 1.2869565217391, 1.4666666666667, 0.15909090909091
59022, 1.2869565217391, 1.45, 0.13636363636364
59023, 1.2652173913043, 1.4666666666667, 0.13636363636364
59024, 1.2869565217391, 1.4666666666667, 0.11363636363636
59025, 1.2869565217391, 1.45, 0.090909090909091
59026, 1.2652173913043, 1.4666666666667, 0.090909090909091
59027, 1.2869565217391, 1.4666666666667, 0.068181818181818
59028, 1.2869565217391, 1.45, 0.045454545454545
59029, 1.2652173913043, 1.4666666666667, 0.045454545454545
59030, 1.2869565217391, 1.4666666666667, 0.022727272727273
59031, 1.2869565217391, 1.4833333333333, 0.45454545454545
59032, 1.2869565217391, 1.4833333333333, 0.40909090909091
59033, 1.2869565217391, 1.4833333333333, 0.36363636363636
59034, 1.2869565217391, 1.4833333333333, 0.31818181818182
59035, 1.2869565217391, 1.4833333333333, 0.27272727272727
59036, 1.2869565217391, 1.4833333333333, 0.22727272727273
59037, 1.2869565217391, 1.4833333333333, 0.18181818181818
59038, 1.2869565217391, 1.4833333333333, 0.13636363636364
59039, 1.2869565217391, 1.4833333333333, 0.090909090909091
59040, 1.2869565217391, 1.4833333333333, 0.045454545454545
59041, 1.3304347826087, 1.4333333333333, 0.47727272727273
59042, 1.3304347826087, 1.4166666666667, 0.45454545454545
59043, 1.3086956521739, 1.4333333333333, 0.45454545454545
59044, 1.3304347826087, 1.4333333333333, 0.43181818181818
59045, 1.3304347826087, 1.4166666666667, 0.40909090909091
59046, 1.3086956521739, 1.4333333333333, 0.40909090909091
59047, 1.3304347826087, 1.4333333333333, 0.38636363636364
59048, 1.3304347826087, 1.4166666666667, 0.36363636363636
59049, 1.3086956521739, 1.4333333333333, 0.36363636363636
59050, 1.3304347826087, 1.4333333333333, 0.34090909090909
59051, 1.3304347826087, 1.4166666666667, 0.31818181818182
59052, 1.3086956521739, 1.4333333333333, 0.31818181818182
59053, 1.3304347826087, 1.4333333333333, 0.29545454545455
59054, 1.3304347826087, 1.4166666666667, 0.27272727272727
59055, 1.3086956521739, 1.4333333333333, 0.27272727272727
59056, 1.3304347826087, 1.4333333333333, 0.25
59057, 1.3304347826087, 1.4166666666667, 0.22727272727273
59058, 1.3086956521739, 1.4333333333333, 0.22727272727273
59059, 1.3304347826087, 1.4333333333333, 0.20454545454545
59060, 1.3304347826087, 1.4166666666667, 0.18181818181818
59061, 1.3086956521739, 1.4333333333333, 0.18181818181818
59062, 1.3304347826087, 1.4333333333333, 0.15909090909091
59063, 1.3304347826087, 1.4166666666667, 0.13636363636364
59064, 1.3086956521739, 1.4333333333333, 0.13636363636364
59065, 1.3304347826087, 1.4333333333333, 0.11363636363636
59066, 1.3304347826087, 1.4166666666667, 0.090909090909091
59067, 1.3086956521739, 1.4333333333333, 0.090909090909091
59068, 1.3304347826087, 1.4333333333333, 0.068181818181818
59069, 1.3304347826087, 1.4166666666667, 0.045454545454545
59070, 1.3086956521739, 1.4333333333333, 0.045454545454545
59071, 1.3304347826087, 1.4333333333333, 0.022727272727273
59072, 1.3304347826087, 1.4666666666667, 0.47727272727273
59073, 1.3304347826087, 1.45, 0.45454545454545
59074, 1.3086956521739, 1.4666666666667, 0.45454545454545
59075, 1.3304347826087, 1.4666666666667, 0.43181818181818
59076, 1.3304347826087, 1.45, 0.40909090909091
59077, 1.3086956521739, 1.4666666666667, 0.40909090909091
59078, 1.3304347826087, 1.4666666666667, 0.38636363636364
59079, 1.3304347826087, 1.45, 0.36363636363636
59080, 1.3086956521739, 1.4666666666667, 0.36363636363636
59081, 1.3304347826087, 1.4666666666667, 0.34090909090909
59082, 1.3304347826087, 1.45, 0.31818181818182
59083, 1.3086956521739, 1.4666666666667, 0.31818181818182
59084, 1.3304347826087, 1.4666666666667, 0.29545454545455
59085, 1.3304347826087, 1.45, 0.27272727272727
59086, 1.3086956521739, 1.4666666666667, 0.27272727272727
59087, 1.3304347826087, 1.4666666666667, 0.25
59088, 1.3304347826087, 1.45, 0.22727272727273
59089, 1.3086956521739, 1.4666666666667, 0.22727272727273
59090, 1.3304347826087, 1.4666666666667, 0.20454545454545
59091, 1.3304347826087, 1.45, 0.18181818181818
59092, 1.3086956521739, 1.4666666666667, 0.18181818181818
59093, 1.3304347826087, 1.4666666666667, 0.15909090909091
59094, 1.3304347826087, 1.45, 0.13636363636364
59095, 1.3086956521739, 1.4666666666667, 0.13636363636364
59096, 1.3304347826087, 1.4666666666667, 0.11363636363636
59097, 1.3304347826087, 1.45, 0.090909090909091
59098, 1.3086956521739, 1.4666666666667, 0.090909090909091
59099, 1.3304347826087, 1.4666666666667, 0.068181818181818
59100, 1.3304347826087, 1.45, 0.045454545454545
59101, 1.3086956521739, 1.4666666666667, 0.045454545454545
59102, 1.3304347826087, 1.4666666666667, 0.022727272727273
59103, 1.3304347826087, 1.4833333333333, 0.45454545454545
59104, 1.3304347826087, 1.4833333333333, 0.40909090909091
59105, 1.3304347826087, 1.4833333333333, 0.36363636363636
59106, 1.3304347826087, 1.4833333333333, 0.31818181818182
59107, 1.3304347826087, 1.4833333333333, 0.27272727272727
59108, 1.3304347826087, 1.4833333333333, 0.22727272727273
59109, 1.3304347826087, 1.4833333333333, 0.18181818181818
59110, 1.3304347826087, 1.4833333333333, 0.13636363636364
59111, 1.3304347826087, 1.4833333333333, 0.090909090909091
59112, 1.3304347826087, 1.4833333333333, 0.045454545454545
59113, 1.3739130434783, 1.4333333333333, 0.47727272727273
59114, 1.3739130434783, 1.4166666666667, 0.45454545454545
59115, 1.3521739130435, 1.4333333333333, 0.45454545454545
59116, 1.3739130434783, 1.4333333333333, 0.43181818181818
59117, 1.3739130434783, 1.4166666666667, 0.40909090909091
59118, 1.3521739130435, 1.4333333333333, 0.40909090909091
59119, 1.3739130434783, 1.4333333333333, 0.38636363636364
59120, 1.3739130434783, 1.4166666666667, 0.36363636363636
59121, 1.3521739130435, 1.4333333333333, 0.36363636363636
59122, 1.3739130434783, 1.4333333333333, 0.34090909090909
59123, 1.3739130434783, 1.4166666666667, 0.31818181818182
59124, 1.3521739130435, 1.4333333333333, 0.31818181818182
59125, 1.3739130434783, 1.4333333333333, 0.29545454545455
59126, 1.3739130434783, 1.4166666666667, 0.27272727272727
59127, 1.3521739130435, 1.4333333333333, 0.27272727272727
59128, 1.3739130434783, 1.4333333333333, 0.25
59129, 1.3739130434783, 1.4166666666667, 0.22727272727273
59130, 1.3521739130435, 1.4333333333333, 0.22727272727273
59131, 1.3739130434783, 1.4333333333333, 0.20454545454545
59132, 1.3739130434783, 1.4166666666667, 0.18181818181818
59133, 1.3521739130435, 1.4333333333333, 0.18181818181818
59134, 1.3739130434783, 1.4333333333333, 0.15909090909091
59135, 1.3739130434783, 1.4166666666667, 0.13636363636364
59136, 1.3521739130435, 1.4333333333333, 0.13636363636364
59137, 1.3739130434783, 1.4333333333333, 0.11363636363636
59138, 1.3739130434783, 1.4166666666667, 0.090909090909091
59139, 1.3521739130435, 1.4333333333333, 0.090909090909091
59140, 1.3739130434783, 1.4333333333333, 0.068181818181818
59141, 1.3739130434783, 1.4166666666667, 0.045454545454545
59142, 1.3521739130435, 1.4333333333333, 0.045454545454545
59143, 1.3739130434783, 1.4333333333333, 0.022727272727273
59144, 1.3739130434783, 1.4666666666667, 0.47727272727273
59145, 1.3739130434783, 1.45, 0.45454545454545
59146, 1.3521739130435, 1.4666666666667, 0.45454545454545
59147, 1.3739130434783, 1.4666666666667, 0.43181818181818
59148, 1.3739130434783, 1.45, 0.40909090909091
59149, 1.3521739130435, 1.4666666666667, 0.40909090909091
59150, 1.3739130434783, 1.4666666666667, 0.38636363636364
59151, 1.3739130434783, 1.45, 0.36363636363636
59152, 1.3521739130435, 1.4666666666667, 0.36363636363636
59153, 1.3739130434783, 1.4666666666667, 0.34090909090909
59154, 1.3739130434783, 1.45, 0.31818181818182
59155, 1.3521739130435, 1.4666666666667, 0.31818181818182
59156, 1.3739130434783, 1.4666666666667, 0.29545454545455
59157, 1.3739130434783, 1.45, 0.27272727272727
59158, 1.3521739130435, 1.4666666666667, 0.27272727272727
59159, 1.3739130434783, 1.4666666666667, 0.25
59160, 1.3739130434783, 1.45, 0.22727272727273
59161, 1.3521739130435, 1.4666666666667, 0.22727272727273
59162, 1.3739130434783, 1.4666666666667, 0.20454545454545
59163, 1.3739130434783, 1.45, 0.18181818181818
59164, 1.3521739130435, 1.4666666666667, 0.18181818181818
59165, 1.3739130434783, 1.4666666666667, 0.15909090909091
59166, 1.3739130434783, 1.45, 0.13636363636364
59167, 1.3521739130435, 1.4666666666667, 0.13636363636364
59168, 1.3739130434783, 1.4666666666667, 0.11363636363636
59169, 1.3739130434783, 1.45, 0.090909090909091
59170, 1.3521739130435, 1.4666666666667, 0.090909090909091
59171, 1.3739130434783, 1.4666666666667, 0.068181818181818
59172, 1.3739130434783, 1.45, 0.045454545454545
59173, 1.3521739130435, 1.4666666666667, 0.045454545454545
59174, 1.3739130434783, 1.4666666666667, 0.022727272727273
59175, 1.3739130434783, 1.4833333333333, 0.45454545454545
59176, 1.3739130434783, 1.4833333333333, 0.40909090909091
59177, 1.3739130434783, 1.4833333333333, 0.36363636363636
59178, 1.3739130434783, 1.4833333333333, 0.31818181818182
59179, 1.3739130434783, 1.4833333333333, 0.27272727272727
59180, 1.3739130434783, 1.4833333333333, 0.22727272727273
59181, 1.3739130434783, 1.4833333333333, 0.18181818181818
59182, 1.3739130434783, 1.4833333333333, 0.13636363636364
59183, 1.3739130434783, 1.4833333333333, 0.090909090909091
59184, 1.3739130434783, 1.4833333333333, 0.045454545454545
59185, 1.4173913043478, 1.4333333333333, 0.47727272727273
59186, 1.4173913043478, 1.4166666666667, 0.45454545454545
59187, 1.395652173913, 1.4333333333333, 0.45454545454545
59188, 1.4173913043478, 1.4333333333333, 0.43181818181818
59189, 1.4173913043478, 1.4166666666667, 0.40909090909091
59190, 1.395652173913, 1.4333333333333, 0.40909090909091
59191, 1.4173913043478, 1.4333333333333, 0.38636363636364
59192, 1.4173913043478, 1.4166666666667, 0.36363636363636
59193, 1.395652173913, 1.4333333333333, 0.36363636363636
59194, 1.4173913043478, 1.4333333333333, 0.34090909090909
59195, 1.4173913043478, 1.4166666666667, 0.31818181818182
59196, 1.395652173913, 1.4333333333333, 0.31818181818182
59197, 1.4173913043478, 1.4333333333333, 0.29545454545455
59198, 1.4173913043478, 1.4166666666667, 0.27272727272727
59199, 1.395652173913, 1.4333333333333, 0.27272727272727
59200, 1.4173913043478, 1.4333333333333, 0.25
59201, 1.4173913043478, 1.4166666666667, 0.22727272727273
59202, 1.395652173913, 1.4333333333333, 0.22727272727273
59203, 1.4173913043478, 1.4333333333333, 0.20454545454545
59204, 1.4173913043478, 1.4166666666667, 0.18181818181818
59205, 1.395652173913, 1.4333333333333, 0.18181818181818
59206, 1.4173913043478, 1.4333333333333, 0.15909090909091
59207, 1.4173913043478, 1.4166666666667, 0.13636363636364
59208, 1.395652173913, 1.4333333333333, 0.13636363636364
59209, 1.4173913043478, 1.4333333333333, 0.11363636363636
59210, 1.4173913043478, 1.4166666666667, 0.090909090909091
59211, 1.395652173913, 1.4333333333333, 0.090909090909091
59212, 1.4173913043478, 1.4333333333333, 0.068181818181818
59213, 1.4173913043478, 1.4166666666667, 0.045454545454545
59214, 1.395652173913, 1.4333333333333, 0.045454545454545
59215, 1.4173913043478, 1.4333333333333, 0.022727272727273
59216, 1.4173913043478, 1.4666666666667, 0.47727272727273
59217, 1.4173913043478, 1.45, 0.45454545454545
59218, 1.395652173913, 1.4666666666667, 0.45454545454545
59219, 1.4173913043478, 1.4666666666667, 0.43181818181818
59220, 1.4173913043478, 1.45, 0.40909090909091
59221, 1.395652173913, 1.4666666666667, 0.40909090909091
59222, 1.4173913043478, 1.4666666666667, 0.38636363636364
59223, 1.4173913043478, 1.45, 0.36363636363636
59224, 1.395652173913, 1.4666666666667, 0.36363636363636
59225, 1.4173913043478, 1.4666666666667, 0.34090909090909
59226, 1.4173913043478, 1.45, 0.31818181818182
59227, 1.395652173913, 1.4666666666667, 0.31818181818182
59228, 1.4173913043478, 1.4666666666667, 0.29545454545455
59229, 1.4173913043478, 1.45, 0.27272727272727
59230, 1.395652173913, 1.4666666666667, 0.27272727272727
59231, 1.4173913043478, 1.4666666666667, 0.25
59232, 1.4173913043478, 1.45, 0.22727272727273
59233, 1.395652173913, 1.4666666666667, 0.22727272727273
59234, 1.4173913043478, 1.4666666666667, 0.20454545454545
59235, 1.4173913043478, 1.45, 0.18181818181818
59236, 1.395652173913, 1.4666666666667, 0.18181818181818
59237, 1.4173913043478, 1.4666666666667, 0.15909090909091
59238, 1.4173913043478, 1.45, 0.13636363636364
59239, 1.395652173913, 1.4666666666667, 0.13636363636364
59240, 1.4173913043478, 1.4666666666667, 0.11363636363636
59241, 1.4173913043478, 1.45, 0.090909090909091
59242, 1.395652173913, 1.4666666666667, 0.090909090909091
59243, 1.4173913043478, 1.4666666666667, 0.068181818181818
59244, 1.4173913043478, 1.45, 0.045454545454545
59245, 1.395652173913, 1.4666666666667, 0.045454545454545
59246, 1.4173913043478, 1.4666666666667, 0.022727272727273
59247, 1.4173913043478, 1.4833333333333, 0.45454545454545
59248, 1.4173913043478, 1.4833333333333, 0.40909090909091
59249, 1.4173913043478, 1.4833333333333, 0.36363636363636
59250, 1.4173913043478, 1.4833333333333, 0.31818181818182
59251, 1.4173913043478, 1.4833333333333, 0.27272727272727
59252, 1.4173913043478, 1.4833333333333, 0.22727272727273
59253, 1.4173913043478, 1.4833333333333, 0.18181818181818
59254, 1.4173913043478, 1.4833333333333, 0.13636363636364
59255, 1.4173913043478, 1.4833333333333, 0.090909090909091
59256, 1.4173913043478, 1.4833333333333, 0.045454545454545
59257, 1.4608695652174, 1.4333333333333, 0.47727272727273
59258, 1.4608695652174, 1.4166666666667, 0.45454545454545
59259, 1.4391304347826, 1.4333333333333, 0.45454545454545
59260, 1.4608695652174, 1.4333333333333, 0.43181818181818
59261, 1.4608695652174, 1.4166666666667, 0.40909090909091
59262, 1.4391304347826, 1.4333333333333, 0.40909090909091
59263, 1.4608695652174, 1.4333333333333, 0.38636363636364
59264, 1.4608695652174, 1.4166666666667, 0.36363636363636
59265, 1.4391304347826, 1.4333333333333, 0.36363636363636
59266, 1.4608695652174, 1.4333333333333, 0.34090909090909
59267, 1.4608695652174, 1.4166666666667, 0.31818181818182
59268, 1.4391304347826, 1.4333333333333, 0.31818181818182
59269, 1.4608695652174, 1.4333333333333, 0.29545454545455
59270, 1.4608695652174, 1.4166666666667, 0.27272727272727
59271, 1.4391304347826, 1.4333333333333, 0.27272727272727
59272, 1.4608695652174, 1.4333333333333, 0.25
59273, 1.4608695652174, 1.4166666666667, 0.22727272727273
59274, 1.4391304347826, 1.4333333333333, 0.22727272727273
59275, 1.4608695652174, 1.4333333333333, 0.20454545454545
59276, 1.4608695652174, 1.4166666666667, 0.18181818181818
59277, 1.4391304347826, 1.4333333333333, 0.18181818181818
59278, 1.4608695652174, 1.4333333333333, 0.15909090909091
59279, 1.4608695652174, 1.4166666666667, 0.13636363636364
59280, 1.4391304347826, 1.4333333333333, 0.13636363636364
59281, 1.4608695652174, 1.4333333333333, 0.11363636363636
59282, 1.4608695652174, 1.4166666666667, 0.090909090909091
59283, 1.4391304347826, 1.4333333333333, 0.090909090909091
59284, 1.4608695652174, 1.4333333333333, 0.068181818181818
59285, 1.4608695652174, 1.4166666666667, 0.045454545454545
59286, 1.4391304347826, 1.4333333333333, 0.045454545454545
59287, 1.4608695652174, 1.4333333333333, 0.022727272727273
59288, 1.4608695652174, 1.4666666666667, 0.47727272727273
59289, 1.4608695652174, 1.45, 0.45454545454545
59290, 1.4391304347826, 1.4666666666667, 0.45454545454545
59291, 1.4608695652174, 1.4666666666667, 0.43181818181818
59292, 1.4608695652174, 1.45, 0.40909090909091
59293, 1.4391304347826, 1.4666666666667, 0.40909090909091
59294, 1.4608695652174, 1.4666666666667, 0.38636363636364
59295, 1.4608695652174, 1.45, 0.36363636363636
59296, 1.4391304347826, 1.4666666666667, 0.36363636363636
59297, 1.4608695652174, 1.4666666666667, 0.34090909090909
59298, 1.4608695652174, 1.45, 0.31818181818182
59299, 1.4391304347826, 1.4666666666667, 0.31818181818182
59300, 1.4608695652174, 1.4666666666667, 0.29545454545455
59301, 1.4608695652174, 1.45, 0.27272727272727
59302, 1.4391304347826, 1.4666666666667, 0.27272727272727
59303, 1.4608695652174, 1.4666666666667, 0.25
59304, 1.4608695652174, 1.45, 0.22727272727273
59305, 1.4391304347826, 1.4666666666667, 0.22727272727273
59306, 1.4608695652174, 1.4666666666667, 0.20454545454545
59307, 1.4608695652174, 1.45, 0.18181818181818
59308, 1.4391304347826, 1.4666666666667, 0.18181818181818
59309, 1.4608695652174, 1.4666666666667, 0.15909090909091
59310, 1.4608695652174, 1.45, 0.13636363636364
59311, 1.4391304347826, 1.4666666666667, 0.13636363636364
59312, 1.4608695652174, 1.4666666666667, 0.11363636363636
59313, 1.4608695652174, 1.45, 0.090909090909091
59314, 1.4391304347826, 1.4666666666667, 0.090909090909091
59315, 1.4608695652174, 1.4666666666667, 0.068181818181818
59316, 1.4608695652174, 1.45, 0.045454545454545
59317, 1.4391304347826, 1.4666666666667, 0.045454545454545
59318, 1.4608695652174, 1.4666666666667, 0.022727272727273
59319, 1.4608695652174, 1.4833333333333, 0.45454545454545
59320, 1.4608695652174, 1.4833333333333, 0.40909090909091
59321, 1.4608695652174, 1.4833333333333, 0.36363636363636
59322, 1.4608695652174, 1.4833333333333, 0.31818181818182
59323, 1.4608695652174, 1.4833333333333, 0.27272727272727
59324, 1.4608695652174, 1.4833333333333, 0.22727272727273
59325, 1.4608695652174, 1.4833333333333, 0.18181818181818
59326, 1.4608695652174, 1.4833333333333, 0.13636363636364
59327, 1.4608695652174, 1.4833333333333, 0.090909090909091
59328, 1.4608695652174, 1.4833333333333, 0.045454545454545
59329, 1.504347826087, 1.4333333333333, 0.47727272727273
59330, 1.504347826087, 1.4166666666667, 0.45454545454545
59331, 1.4826086956522, 1.4333333333333, 0.45454545454545
59332, 1.504347826087, 1.4333333333333, 0.43181818181818
59333, 1.504347826087, 1.4166666666667, 0.40909090909091
59334, 1.4826086956522, 1.4333333333333, 0.40909090909091
59335, 1.504347826087, 1.4333333333333, 0.38636363636364
59336, 1.504347826087, 1.4166666666667, 0.36363636363636
59337, 1.4826086956522, 1.4333333333333, 0.36363636363636
59338, 1.504347826087, 1.4333333333333, 0.34090909090909
59339, 1.504347826087, 1.4166666666667, 0.31818181818182
59340, 1.4826086956522, 1.4333333333333, 0.31818181818182
59341, 1.504347826087, 1.4333333333333, 0.29545454545455
59342, 1.504347826087, 1.4166666666667, 0.27272727272727
59343, 1.4826086956522, 1.4333333333333, 0.27272727272727
59344, 1.504347826087, 1.4333333333333, 0.25
59345, 1.504347826087, 1.4166666666667, 0.22727272727273
59346, 1.4826086956522, 1.4333333333333, 0.22727272727273
59347, 1.504347826087, 1.4333333333333, 0.20454545454545
59348, 1.504347826087, 1.4166666666667, 0.18181818181818
59349, 1.4826086956522, 1.4333333333333, 0.18181818181818
59350, 1.504347826087, 1.4333333333333, 0.15909090909091
59351, 1.504347826087, 1.4166666666667, 0.13636363636364
59352, 1.4826086956522, 1.4333333333333, 0.13636363636364
59353, 1.504347826087, 1.4333333333333, 0.11363636363636
59354, 1.504347826087, 1.4166666666667, 0.090909090909091
59355, 1.4826086956522, 1.4333333333333, 0.090909090909091
59356, 1.504347826087, 1.4333333333333, 0.068181818181818
59357, 1.504347826087, 1.4166666666667, 0.045454545454545
59358, 1.4826086956522, 1.4333333333333, 0.045454545454545
59359, 1.504347826087, 1.4333333333333, 0.022727272727273
59360, 1.504347826087, 1.4666666666667, 0.47727272727273
59361, 1.504347826087, 1.45, 0.45454545454545
59362, 1.4826086956522, 1.4666666666667, 0.45454545454545
59363, 1.504347826087, 1.4666666666667, 0.43181818181818
59364, 1.504347826087, 1.45, 0.40909090909091
59365, 1.4826086956522, 1.4666666666667, 0.40909090909091
59366, 1.504347826087, 1.4666666666667, 0.38636363636364
59367, 1.504347826087, 1.45, 0.36363636363636
59368, 1.4826086956522, 1.4666666666667, 0.36363636363636
59369, 1.504347826087, 1.4666666666667, 0.34090909090909
59370, 1.504347826087, 1.45, 0.31818181818182
59371, 1.4826086956522, 1.4666666666667, 0.31818181818182
59372, 1.504347826087, 1.4666666666667, 0.29545454545455
59373, 1.504347826087, 1.45, 0.27272727272727
59374, 1.4826086956522, 1.4666666666667, 0.27272727272727
59375, 1.504347826087, 1.4666666666667, 0.25
59376, 1.504347826087, 1.45, 0.22727272727273
59377, 1.4826086956522, 1.4666666666667, 0.22727272727273
59378, 1.504347826087, 1.4666666666667, 0.20454545454545
59379, 1.504347826087, 1.45, 0.18181818181818
59380, 1.4826086956522, 1.4666666666667, 0.18181818181818
59381, 1.504347826087, 1.4666666666667, 0.15909090909091
59382, 1.504347826087, 1.45, 0.13636363636364
59383, 1.4826086956522, 1.4666666666667, 0.13636363636364
59384, 1.504347826087, 1.4666666666667, 0.11363636363636
59385, 1.504347826087, 1.45, 0.090909090909091
59386, 1.4826086956522, 1.4666666666667, 0.090909090909091
59387, 1.504347826087, 1.4666666666667, 0.068181818181818
59388, 1.504347826087, 1.45, 0.045454545454545
59389, 1.4826086956522, 1.4666666666667, 0.045454545454545
59390, 1.504347826087, 1.4666666666667, 0.022727272727273
59391, 1.504347826087, 1.4833333333333, 0.45454545454545
59392, 1.504347826087, 1.4833333333333, 0.40909090909091
59393, 1.504347826087, 1.4833333333333, 0.36363636363636
59394, 1.504347826087, 1.4833333333333, 0.31818181818182
59395, 1.504347826087, 1.4833333333333, 0.27272727272727
59396, 1.504347826087, 1.4833333333333, 0.22727272727273
59397, 1.504347826087, 1.4833333333333, 0.18181818181818
59398, 1.504347826087, 1.4833333333333, 0.13636363636364
59399, 1.504347826087, 1.4833333333333, 0.090909090909091
59400, 1.504347826087, 1.4833333333333, 0.045454545454545
59401, 1.5478260869565, 1.4333333333333, 0.47727272727273
59402, 1.5478260869565, 1.4166666666667, 0.45454545454545
59403, 1.5260869565217, 1.4333333333333, 0.45454545454545
59404, 1.5478260869565, 1.4333333333333, 0.43181818181818
59405, 1.5478260869565, 1.4166666666667, 0.40909090909091
59406, 1.5260869565217, 1.4333333333333, 0.40909090909091
59407, 1.5478260869565, 1.4333333333333, 0.38636363636364
59408, 1.5478260869565, 1.4166666666667, 0.36363636363636
59409, 1.5260869565217, 1.4333333333333, 0.36363636363636
59410, 1.5478260869565, 1.4333333333333, 0.34090909090909
59411, 1.5478260869565, 1.4166666666667, 0.31818181818182
59412, 1.5260869565217, 1.4333333333333, 0.31818181818182
59413, 1.5478260869565, 1.4333333333333, 0.29545454545455
59414, 1.5478260869565, 1.4166666666667, 0.27272727272727
59415, 1.5260869565217, 1.4333333333333, 0.27272727272727
59416, 1.5478260869565, 1.4333333333333, 0.25
59417, 1.5478260869565, 1.4166666666667, 0.22727272727273
59418, 1.5260869565217, 1.4333333333333, 0.22727272727273
59419, 1.5478260869565, 1.4333333333333, 0.20454545454545
59420, 1.5478260869565, 1.4166666666667, 0.18181818181818
59421, 1.5260869565217, 1.4333333333333, 0.18181818181818
59422, 1.5478260869565, 1.4333333333333, 0.15909090909091
59423, 1.5478260869565, 1.4166666666667, 0.13636363636364
59424, 1.5260869565217, 1.4333333333333, 0.13636363636364
59425, 1.5478260869565, 1.4333333333333, 0.11363636363636
59426, 1.5478260869565, 1.4166666666667, 0.090909090909091
59427, 1.5260869565217, 1.4333333333333, 0.090909090909091
59428, 1.5478260869565, 1.4333333333333, 0.068181818181818
59429, 1.5478260869565, 1.4166666666667, 0.045454545454545
59430, 1.5260869565217, 1.4333333333333, 0.045454545454545
59431, 1.5478260869565, 1.4333333333333, 0.022727272727273
59432, 1.5478260869565, 1.4666666666667, 0.47727272727273
59433, 1.5478260869565, 1.45, 0.45454545454545
59434, 1.5260869565217, 1.4666666666667, 0.45454545454545
59435, 1.5478260869565, 1.4666666666667, 0.43181818181818
59436, 1.5478260869565, 1.45, 0.40909090909091
59437, 1.5260869565217, 1.4666666666667, 0.40909090909091
59438, 1.5478260869565, 1.4666666666667, 0.38636363636364
59439, 1.5478260869565, 1.45, 0.36363636363636
59440, 1.5260869565217, 1.4666666666667, 0.36363636363636
59441, 1.5478260869565, 1.4666666666667, 0.34090909090909
59442, 1.5478260869565, 1.45, 0.31818181818182
59443, 1.5260869565217, 1.4666666666667, 0.31818181818182
59444, 1.5478260869565, 1.4666666666667, 0.29545454545455
59445, 1.5478260869565, 1.45, 0.27272727272727
59446, 1.5260869565217, 1.4666666666667, 0.27272727272727
59447, 1.5478260869565, 1.4666666666667, 0.25
59448, 1.5478260869565, 1.45, 0.22727272727273
59449, 1.5260869565217, 1.4666666666667, 0.22727272727273
59450, 1.5478260869565, 1.4666666666667, 0.20454545454545
59451, 1.5478260869565, 1.45, 0.18181818181818
59452, 1.5260869565217, 1.4666666666667, 0.18181818181818
59453, 1.5478260869565, 1.4666666666667, 0.15909090909091
59454, 1.5478260869565, 1.45, 0.13636363636364
59455, 1.5260869565217, 1.4666666666667, 0.13636363636364
59456, 1.5478260869565, 1.4666666666667, 0.11363636363636
59457, 1.5478260869565, 1.45, 0.090909090909091
59458, 1.5260869565217, 1.4666666666667, 0.090909090909091
59459, 1.5478260869565, 1.4666666666667, 0.068181818181818
59460, 1.5478260869565, 1.45, 0.045454545454545
59461, 1.5260869565217, 1.4666666666667, 0.045454545454545
59462, 1.5478260869565, 1.4666666666667, 0.022727272727273
59463, 1.5478260869565, 1.4833333333333, 0.45454545454545
59464, 1.5478260869565, 1.4833333333333, 0.40909090909091
59465, 1.5478260869565, 1.4833333333333, 0.36363636363636
59466, 1.5478260869565, 1.4833333333333, 0.31818181818182
59467, 1.5478260869565, 1.4833333333333, 0.27272727272727
59468, 1.5478260869565, 1.4833333333333, 0.22727272727273
59469, 1.5478260869565, 1.4833333333333, 0.18181818181818
59470, 1.5478260869565, 1.4833333333333, 0.13636363636364
59471, 1.5478260869565, 1.4833333333333, 0.090909090909091
59472, 1.5478260869565, 1.4833333333333, 0.045454545454545
59473, 1.5913043478261, 1.4333333333333, 0.47727272727273
59474, 1.5913043478261, 1.4166666666667, 0.45454545454545
59475, 1.5695652173913, 1.4333333333333, 0.45454545454545
59476, 1.5913043478261, 1.4333333333333, 0.43181818181818
59477, 1.5913043478261, 1.4166666666667, 0.40909090909091
59478, 1.5695652173913, 1.4333333333333, 0.40909090909091
59479, 1.5913043478261, 1.4333333333333, 0.38636363636364
59480, 1.5913043478261, 1.4166666666667, 0.36363636363636
59481, 1.5695652173913, 1.4333333333333, 0.36363636363636
59482, 1.5913043478261, 1.4333333333333, 0.34090909090909
59483, 1.5913043478261, 1.4166666666667, 0.31818181818182
59484, 1.5695652173913, 1.4333333333333, 0.31818181818182
59485, 1.5913043478261, 1.4333333333333, 0.29545454545455
59486, 1.5913043478261, 1.4166666666667, 0.27272727272727
59487, 1.5695652173913, 1.4333333333333, 0.27272727272727
59488, 1.5913043478261, 1.4333333333333, 0.25
59489, 1.5913043478261, 1.4166666666667, 0.22727272727273
59490, 1.5695652173913, 1.4333333333333, 0.22727272727273
59491, 1.5913043478261, 1.4333333333333, 0.20454545454545
59492, 1.5913043478261, 1.4166666666667, 0.18181818181818
59493, 1.5695652173913, 1.4333333333333, 0.18181818181818
59494, 1.5913043478261, 1.4333333333333, 0.15909090909091
59495, 1.5913043478261, 1.4166666666667, 0.13636363636364
59496, 1.5695652173913, 1.4333333333333, 0.13636363636364
59497, 1.5913043478261, 1.4333333333333, 0.11363636363636
59498, 1.5913043478261, 1.4166666666667, 0.090909090909091
59499, 1.5695652173913, 1.4333333333333, 0.090909090909091
59500, 1.5913043478261, 1.4333333333333, 0.068181818181818
59501, 1.5913043478261, 1.4166666666667, 0.045454545454545
59502, 1.5695652173913, 1.4333333333333, 0.045454545454545
59503, 1.5913043478261, 1.4333333333333, 0.022727272727273
59504, 1.5913043478261, 1.4666666666667, 0.47727272727273
59505, 1.5913043478261, 1.45, 0.45454545454545
59506, 1.5695652173913, 1.4666666666667, 0.45454545454545
59507, 1.5913043478261, 1.4666666666667, 0.43181818181818
59508, 1.5913043478261, 1.45, 0.40909090909091
59509, 1.5695652173913, 1.4666666666667, 0.40909090909091
59510, 1.5913043478261, 1.4666666666667, 0.38636363636364
59511, 1.5913043478261, 1.45, 0.36363636363636
59512, 1.5695652173913, 1.4666666666667, 0.36363636363636
59513, 1.5913043478261, 1.4666666666667, 0.34090909090909
59514, 1.5913043478261, 1.45, 0.31818181818182
59515, 1.5695652173913, 1.4666666666667, 0.31818181818182
59516, 1.5913043478261, 1.4666666666667, 0.29545454545455
59517, 1.5913043478261, 1.45, 0.27272727272727
59518, 1.5695652173913, 1.4666666666667, 0.27272727272727
59519, 1.5913043478261, 1.4666666666667, 0.25
59520, 1.5913043478261, 1.45, 0.22727272727273
59521, 1.5695652173913, 1.4666666666667, 0.22727272727273
59522, 1.5913043478261, 1.4666666666667, 0.20454545454545
59523, 1.5913043478261, 1.45, 0.18181818181818
59524, 1.5695652173913, 1.4666666666667, 0.18181818181818
59525, 1.5913043478261, 1.4666666666667, 0.15909090909091
59526, 1.5913043478261, 1.45, 0.13636363636364
59527, 1.5695652173913, 1.4666666666667, 0.13636363636364
59528, 1.5913043478261, 1.4666666666667, 0.11363636363636
59529, 1.5913043478261, 1.45, 0.090909090909091
59530, 1.5695652173913, 1.4666666666667, 0.090909090909091
59531, 1.5913043478261, 1.4666666666667, 0.068181818181818
59532, 1.5913043478261, 1.45, 0.045454545454545
59533, 1.5695652173913, 1.4666666666667, 0.045454545454545
59534, 1.5913043478261, 1.4666666666667, 0.022727272727273
59535, 1.5913043478261, 1.4833333333333, 0.45454545454545
59536, 1.5913043478261, 1.4833333333333, 0.40909090909091
59537, 1.5913043478261, 1.4833333333333, 0.36363636363636
59538, 1.5913043478261, 1.4833333333333, 0.31818181818182
59539, 1.5913043478261, 1.4833333333333, 0.27272727272727
59540, 1.5913043478261, 1.4833333333333, 0.22727272727273
59541, 1.5913043478261, 1.4833333333333, 0.18181818181818
59542, 1.5913043478261, 1.4833333333333, 0.13636363636364
59543, 1.5913043478261, 1.4833333333333, 0.090909090909091
59544, 1.5913043478261, 1.4833333333333, 0.045454545454545
59545, 1.6347826086957, 1.4333333333333, 0.47727272727273
59546, 1.6347826086957, 1.4166666666667, 0.45454545454545
59547, 1.6130434782609, 1.4333333333333, 0.45454545454545
59548, 1.6347826086957, 1.4333333333333, 0.43181818181818
59549, 1.6347826086957, 1.4166666666667, 0.40909090909091
59550, 1.6130434782609, 1.4333333333333, 0.40909090909091
59551, 1.6347826086957, 1.4333333333333, 0.38636363636364
59552, 1.6347826086957, 1.4166666666667, 0.36363636363636
59553, 1.6130434782609, 1.4333333333333, 0.36363636363636
59554, 1.6347826086957, 1.4333333333333, 0.34090909090909
59555, 1.6347826086957, 1.4166666666667, 0.31818181818182
59556, 1.6130434782609, 1.4333333333333, 0.31818181818182
59557, 1.6347826086957, 1.4333333333333, 0.29545454545455
59558, 1.6347826086957, 1.4166666666667, 0.27272727272727
59559, 1.6130434782609, 1.4333333333333, 0.27272727272727
59560, 1.6347826086957, 1.4333333333333, 0.25
59561, 1.6347826086957, 1.4166666666667, 0.22727272727273
59562, 1.6130434782609, 1.4333333333333, 0.22727272727273
59563, 1.6347826086957, 1.4333333333333, 0.20454545454545
59564, 1.6347826086957, 1.4166666666667, 0.18181818181818
59565, 1.6130434782609, 1.4333333333333, 0.18181818181818
59566, 1.6347826086957, 1.4333333333333, 0.15909090909091
59567, 1.6347826086957, 1.4166666666667, 0.13636363636364
59568, 1.6130434782609, 1.4333333333333, 0.13636363636364
59569, 1.6347826086957, 1.4333333333333, 0.11363636363636
59570, 1.6347826086957, 1.4166666666667, 0.090909090909091
59571, 1.6130434782609, 1.4333333333333, 0.090909090909091
59572, 1.6347826086957, 1.4333333333333, 0.068181818181818
59573, 1.6347826086957, 1.4166666666667, 0.045454545454545
59574, 1.6130434782609, 1.4333333333333, 0.045454545454545
59575, 1.6347826086957, 1.4333333333333, 0.022727272727273
59576, 1.6347826086957, 1.4666666666667, 0.47727272727273
59577, 1.6347826086957, 1.45, 0.45454545454545
59578, 1.6130434782609, 1.4666666666667, 0.45454545454545
59579, 1.6347826086957, 1.4666666666667, 0.43181818181818
59580, 1.6347826086957, 1.45, 0.40909090909091
59581, 1.6130434782609, 1.4666666666667, 0.40909090909091
59582, 1.6347826086957, 1.4666666666667, 0.38636363636364
59583, 1.6347826086957, 1.45, 0.36363636363636
59584, 1.6130434782609, 1.4666666666667, 0.36363636363636
59585, 1.6347826086957, 1.4666666666667, 0.34090909090909
59586, 1.6347826086957, 1.45, 0.31818181818182
59587, 1.6130434782609, 1.4666666666667, 0.31818181818182
59588, 1.6347826086957, 1.4666666666667, 0.29545454545455
59589, 1.6347826086957, 1.45, 0.27272727272727
59590, 1.6130434782609, 1.4666666666667, 0.27272727272727
59591, 1.6347826086957, 1.4666666666667, 0.25
59592, 1.6347826086957, 1.45, 0.22727272727273
59593, 1.6130434782609, 1.4666666666667, 0.22727272727273
59594, 1.6347826086957, 1.4666666666667, 0.20454545454545
59595, 1.6347826086957, 1.45, 0.18181818181818
59596, 1.6130434782609, 1.4666666666667, 0.18181818181818
59597, 1.6347826086957, 1.4666666666667, 0.15909090909091
59598, 1.6347826086957, 1.45, 0.13636363636364
59599, 1.6130434782609, 1.4666666666667, 0.13636363636364
59600, 1.6347826086957, 1.4666666666667, 0.11363636363636
59601, 1.6347826086957, 1.45, 0.090909090909091
59602, 1.6130434782609, 1.4666666666667, 0.090909090909091
59603, 1.6347826086957, 1.4666666666667, 0.068181818181818
59604, 1.6347826086957, 1.45, 0.045454545454545
59605, 1.6130434782609, 1.4666666666667, 0.045454545454545
59606, 1.6347826086957, 1.4666666666667, 0.022727272727273
59607, 1.6347826086957, 1.4833333333333, 0.45454545454545
59608, 1.6347826086957, 1.4833333333333, 0.40909090909091
59609, 1.6347826086957, 1.4833333333333, 0.36363636363636
59610, 1.6347826086957, 1.4833333333333, 0.31818181818182
59611, 1.6347826086957, 1.4833333333333, 0.27272727272727
59612, 1.6347826086957, 1.4833333333333, 0.22727272727273
59613, 1.6347826086957, 1.4833333333333, 0.18181818181818
59614, 1.6347826086957, 1.4833333333333, 0.13636363636364
59615, 1.6347826086957, 1.4833333333333, 0.090909090909091
59616, 1.6347826086957, 1.4833333333333, 0.045454545454545
59617, 1.6782608695652, 1.4333333333333, 0.47727272727273
59618, 1.6782608695652, 1.4166666666667, 0.45454545454545
59619, 1.6565217391304, 1.4333333333333, 0.45454545454545
59620, 1.6782608695652, 1.4333333333333, 0.43181818181818
59621, 1.6782608695652, 1.4166666666667, 0.40909090909091
59622, 1.6565217391304, 1.4333333333333, 0.40909090909091
59623, 1.6782608695652, 1.4333333333333, 0.38636363636364
59624, 1.6782608695652, 1.4166666666667, 0.36363636363636
59625, 1.6565217391304, 1.4333333333333, 0.36363636363636
59626, 1.6782608695652, 1.4333333333333, 0.34090909090909
59627, 1.6782608695652, 1.4166666666667, 0.31818181818182
59628, 1.6565217391304, 1.4333333333333, 0.31818181818182
59629, 1.6782608695652, 1.4333333333333, 0.29545454545455
59630, 1.6782608695652, 1.4166666666667, 0.27272727272727
59631, 1.6565217391304, 1.4333333333333, 0.27272727272727
59632, 1.6782608695652, 1.4333333333333, 0.25
59633, 1.6782608695652, 1.4166666666667, 0.22727272727273
59634, 1.6565217391304, 1.4333333333333, 0.22727272727273
59635, 1.6782608695652, 1.4333333333333, 0.20454545454545
59636, 1.6782608695652, 1.4166666666667, 0.18181818181818
59637, 1.6565217391304, 1.4333333333333, 0.18181818181818
59638, 1.6782608695652, 1.4333333333333, 0.15909090909091
59639, 1.6782608695652, 1.4166666666667, 0.13636363636364
59640, 1.6565217391304, 1.4333333333333, 0.13636363636364
59641, 1.6782608695652, 1.4333333333333, 0.11363636363636
59642, 1.6782608695652, 1.4166666666667, 0.090909090909091
59643, 1.6565217391304, 1.4333333333333, 0.090909090909091
59644, 1.6782608695652, 1.4333333333333, 0.068181818181818
59645, 1.6782608695652, 1.4166666666667, 0.045454545454545
59646, 1.6565217391304, 1.4333333333333, 0.045454545454545
59647, 1.6782608695652, 1.4333333333333, 0.022727272727273
59648, 1.6782608695652, 1.4666666666667, 0.47727272727273
59649, 1.6782608695652, 1.45, 0.45454545454545
59650, 1.6565217391304, 1.4666666666667, 0.45454545454545
59651, 1.6782608695652, 1.4666666666667, 0.43181818181818
59652, 1.6782608695652, 1.45, 0.40909090909091
59653, 1.6565217391304, 1.4666666666667, 0.40909090909091
59654, 1.6782608695652, 1.4666666666667, 0.38636363636364
59655, 1.6782608695652, 1.45, 0.36363636363636
59656, 1.6565217391304, 1.4666666666667, 0.36363636363636
59657, 1.6782608695652, 1.4666666666667, 0.34090909090909
59658, 1.6782608695652, 1.45, 0.31818181818182
59659, 1.6565217391304, 1.4666666666667, 0.31818181818182
59660, 1.6782608695652, 1.4666666666667, 0.29545454545455
59661, 1.6782608695652, 1.45, 0.27272727272727
59662, 1.6565217391304, 1.4666666666667, 0.27272727272727
59663, 1.6782608695652, 1.4666666666667, 0.25
59664, 1.6782608695652, 1.45, 0.22727272727273
59665, 1.6565217391304, 1.4666666666667, 0.22727272727273
59666, 1.6782608695652, 1.4666666666667, 0.20454545454545
59667, 1.6782608695652, 1.45, 0.18181818181818
59668, 1.6565217391304, 1.4666666666667, 0.18181818181818
59669, 1.6782608695652, 1.4666666666667, 0.15909090909091
59670, 1.6782608695652, 1.45, 0.13636363636364
59671, 1.6565217391304, 1.4666666666667, 0.13636363636364
59672, 1.6782608695652, 1.4666666666667, 0.11363636363636
59673, 1.6782608695652, 1.45, 0.090909090909091
59674, 1.6565217391304, 1.4666666666667, 0.090909090909091
59675, 1.6782608695652, 1.4666666666667, 0.068181818181818
59676, 1.6782608695652, 1.45, 0.045454545454545
59677, 1.6565217391304, 1.4666666666667, 0.045454545454545
59678, 1.6782608695652, 1.4666666666667, 0.022727272727273
59679, 1.6782608695652, 1.4833333333333, 0.45454545454545
59680, 1.6782608695652, 1.4833333333333, 0.40909090909091
59681, 1.6782608695652, 1.4833333333333, 0.36363636363636
59682, 1.6782608695652, 1.4833333333333, 0.31818181818182
59683, 1.6782608695652, 1.4833333333333, 0.27272727272727
59684, 1.6782608695652, 1.4833333333333, 0.22727272727273
59685, 1.6782608695652, 1.4833333333333, 0.18181818181818
59686, 1.6782608695652, 1.4833333333333, 0.13636363636364
59687, 1.6782608695652, 1.4833333333333, 0.090909090909091
59688, 1.6782608695652, 1.4833333333333, 0.045454545454545
59689, 1.7217391304348, 1.4333333333333, 0.47727272727273
59690, 1.7217391304348, 1.4166666666667, 0.45454545454545
59691, 1.7, 1.4333333333333, 0.45454545454545
59692, 1.7217391304348, 1.4333333333333, 0.43181818181818
59693, 1.7217391304348, 1.4166666666667, 0.40909090909091
59694, 1.7, 1.4333333333333, 0.40909090909091
59695, 1.7217391304348, 1.4333333333333, 0.38636363636364
59696, 1.7217391304348, 1.4166666666667, 0.36363636363636
59697, 1.7, 1.4333333333333, 0.36363636363636
59698, 1.7217391304348, 1.4333333333333, 0.34090909090909
59699, 1.7217391304348, 1.4166666666667, 0.31818181818182
59700, 1.7, 1.4333333333333, 0.31818181818182
59701, 1.7217391304348, 1.4333333333333, 0.29545454545455
59702, 1.7217391304348, 1.4166666666667, 0.27272727272727
59703, 1.7, 1.4333333333333, 0.27272727272727
59704, 1.7217391304348, 1.4333333333333, 0.25
59705, 1.7217391304348, 1.4166666666667, 0.22727272727273
59706, 1.7, 1.4333333333333, 0.22727272727273
59707, 1.7217391304348, 1.4333333333333, 0.20454545454545
59708, 1.7217391304348, 1.4166666666667, 0.18181818181818
59709, 1.7, 1.4333333333333, 0.18181818181818
59710, 1.7217391304348, 1.4333333333333, 0.15909090909091
59711, 1.7217391304348, 1.4166666666667, 0.13636363636364
59712, 1.7, 1.4333333333333, 0.13636363636364
59713, 1.7217391304348, 1.4333333333333, 0.11363636363636
59714, 1.7217391304348, 1.4166666666667, 0.090909090909091
59715, 1.7, 1.4333333333333, 0.090909090909091
59716, 1.7217391304348, 1.4333333333333, 0.068181818181818
59717, 1.7217391304348, 1.4166666666667, 0.045454545454545
59718, 1.7, 1.4333333333333, 0.045454545454545
59719, 1.7217391304348, 1.4333333333333, 0.022727272727273
59720, 1.7217391304348, 1.4666666666667, 0.47727272727273
59721, 1.7217391304348, 1.45, 0.45454545454545
59722, 1.7, 1.4666666666667, 0.45454545454545
59723, 1.7217391304348, 1.4666666666667, 0.43181818181818
59724, 1.7217391304348, 1.45, 0.40909090909091
59725, 1.7, 1.4666666666667, 0.40909090909091
59726, 1.7217391304348, 1.4666666666667, 0.38636363636364
59727, 1.7217391304348, 1.45, 0.36363636363636
59728, 1.7, 1.4666666666667, 0.36363636363636
59729, 1.7217391304348, 1.4666666666667, 0.34090909090909
59730, 1.7217391304348, 1.45, 0.31818181818182
59731, 1.7, 1.4666666666667, 0.31818181818182
59732, 1.7217391304348, 1.4666666666667, 0.29545454545455
59733, 1.7217391304348, 1.45, 0.27272727272727
59734, 1.7, 1.4666666666667, 0.27272727272727
59735, 1.7217391304348, 1.4666666666667, 0.25
59736, 1.7217391304348, 1.45, 0.22727272727273
59737, 1.7, 1.4666666666667, 0.22727272727273
59738, 1.7217391304348, 1.4666666666667, 0.20454545454545
59739, 1.7217391304348, 1.45, 0.18181818181818
59740, 1.7, 1.4666666666667, 0.18181818181818
59741, 1.7217391304348, 1.4666666666667, 0.15909090909091
59742, 1.7217391304348, 1.45, 0.13636363636364
59743, 1.7, 1.4666666666667, 0.13636363636364
59744, 1.7217391304348, 1.4666666666667, 0.11363636363636
59745, 1.7217391304348, 1.45, 0.090909090909091
59746, 1.7, 1.4666666666667, 0.090909090909091
59747, 1.7217391304348, 1.4666666666667, 0.068181818181818
59748, 1.7217391304348, 1.45, 0.045454545454545
59749, 1.7, 1.4666666666667, 0.045454545454545
59750, 1.7217391304348, 1.4666666666667, 0.022727272727273
59751, 1.7217391304348, 1.4833333333333, 0.45454545454545
59752, 1.7217391304348, 1.4833333333333, 0.40909090909091
59753, 1.7217391304348, 1.4833333333333, 0.36363636363636
59754, 1.7217391304348, 1.4833333333333, 0.31818181818182
59755, 1.7217391304348, 1.4833333333333, 0.27272727272727
59756, 1.7217391304348, 1.4833333333333, 0.22727272727273
59757, 1.7217391304348, 1.4833333333333, 0.18181818181818
59758, 1.7217391304348, 1.4833333333333, 0.13636363636364
59759, 1.7217391304348, 1.4833333333333, 0.090909090909091
59760, 1.7217391304348, 1.4833333333333, 0.045454545454545
59761, 1.7652173913043, 1.4333333333333, 0.47727272727273
59762, 1.7652173913043, 1.4166666666667, 0.45454545454545
59763, 1.7434782608696, 1.4333333333333, 0.45454545454545
59764, 1.7652173913043, 1.4333333333333, 0.43181818181818
59765, 1.7652173913043, 1.4166666666667, 0.40909090909091
59766, 1.7434782608696, 1.4333333333333, 0.40909090909091
59767, 1.7652173913043, 1.4333333333333, 0.38636363636364
59768, 1.7652173913043, 1.4166666666667, 0.36363636363636
59769, 1.7434782608696, 1.4333333333333, 0.36363636363636
59770, 1.7652173913043, 1.4333333333333, 0.34090909090909
59771, 1.7652173913043, 1.4166666666667, 0.31818181818182
59772, 1.7434782608696, 1.4333333333333, 0.31818181818182
59773, 1.7652173913043, 1.4333333333333, 0.29545454545455
59774, 1.7652173913043, 1.4166666666667, 0.27272727272727
59775, 1.7434782608696, 1.4333333333333, 0.27272727272727
59776, 1.7652173913043, 1.4333333333333, 0.25
59777, 1.7652173913043, 1.4166666666667, 0.22727272727273
59778, 1.7434782608696, 1.4333333333333, 0.22727272727273
59779, 1.7652173913043, 1.4333333333333, 0.20454545454545
59780, 1.7652173913043, 1.4166666666667, 0.18181818181818
59781, 1.7434782608696, 1.4333333333333, 0.18181818181818
59782, 1.7652173913043, 1.4333333333333, 0.15909090909091
59783, 1.7652173913043, 1.4166666666667, 0.13636363636364
59784, 1.7434782608696, 1.4333333333333, 0.13636363636364
59785, 1.7652173913043, 1.4333333333333, 0.11363636363636
59786, 1.7652173913043, 1.4166666666667, 0.090909090909091
59787, 1.7434782608696, 1.4333333333333, 0.090909090909091
59788, 1.7652173913043, 1.4333333333333, 0.068181818181818
59789, 1.7652173913043, 1.4166666666667, 0.045454545454545
59790, 1.7434782608696, 1.4333333333333, 0.045454545454545
59791, 1.7652173913043, 1.4333333333333, 0.022727272727273
59792, 1.7652173913043, 1.4666666666667, 0.47727272727273
59793, 1.7652173913043, 1.45, 0.45454545454545
59794, 1.7434782608696, 1.4666666666667, 0.45454545454545
59795, 1.7652173913043, 1.4666666666667, 0.43181818181818
59796, 1.7652173913043, 1.45, 0.40909090909091
59797, 1.7434782608696, 1.4666666666667, 0.40909090909091
59798, 1.7652173913043, 1.4666666666667, 0.38636363636364
59799, 1.7652173913043, 1.45, 0.36363636363636
59800, 1.7434782608696, 1.4666666666667, 0.36363636363636
59801, 1.7652173913043, 1.4666666666667, 0.34090909090909
59802, 1.7652173913043, 1.45, 0.31818181818182
59803, 1.7434782608696, 1.4666666666667, 0.31818181818182
59804, 1.7652173913043, 1.4666666666667, 0.29545454545455
59805, 1.7652173913043, 1.45, 0.27272727272727
59806, 1.7434782608696, 1.4666666666667, 0.27272727272727
59807, 1.7652173913043, 1.4666666666667, 0.25
59808, 1.7652173913043, 1.45, 0.22727272727273
59809, 1.7434782608696, 1.4666666666667, 0.22727272727273
59810, 1.7652173913043, 1.4666666666667, 0.20454545454545
59811, 1.7652173913043, 1.45, 0.18181818181818
59812, 1.7434782608696, 1.4666666666667, 0.18181818181818
59813, 1.7652173913043, 1.4666666666667, 0.15909090909091
59814, 1.7652173913043, 1.45, 0.13636363636364
59815, 1.7434782608696, 1.4666666666667, 0.13636363636364
59816, 1.7652173913043, 1.4666666666667, 0.11363636363636
59817, 1.7652173913043, 1.45, 0.090909090909091
59818, 1.7434782608696, 1.4666666666667, 0.090909090909091
59819, 1.7652173913043, 1.4666666666667, 0.068181818181818
59820, 1.7652173913043, 1.45, 0.045454545454545
59821, 1.7434782608696, 1.4666666666667, 0.045454545454545
59822, 1.7652173913043, 1.4666666666667, 0.022727272727273
59823, 1.7652173913043, 1.4833333333333, 0.45454545454545
59824, 1.7652173913043, 1.4833333333333, 0.40909090909091
59825, 1.7652173913043, 1.4833333333333, 0.36363636363636
59826, 1.7652173913043, 1.4833333333333, 0.31818181818182
59827, 1.7652173913043, 1.4833333333333, 0.27272727272727
59828, 1.7652173913043, 1.4833333333333, 0.22727272727273
59829, 1.7652173913043, 1.4833333333333, 0.18181818181818
59830, 1.7652173913043, 1.4833333333333, 0.13636363636364
59831, 1.7652173913043, 1.4833333333333, 0.090909090909091
59832, 1.7652173913043, 1.4833333333333, 0.045454545454545
59833, 1.8086956521739, 1.4333333333333, 0.47727272727273
59834, 1.8086956521739, 1.4166666666667, 0.45454545454545
59835, 1.7869565217391, 1.4333333333333, 0.45454545454545
59836, 1.8086956521739, 1.4333333333333, 0.43181818181818
59837, 1.8086956521739, 1.4166666666667, 0.40909090909091
59838, 1.7869565217391, 1.4333333333333, 0.40909090909091
59839, 1.8086956521739, 1.4333333333333, 0.38636363636364
59840, 1.8086956521739, 1.4166666666667, 0.36363636363636
59841, 1.7869565217391, 1.4333333333333, 0.36363636363636
59842, 1.8086956521739, 1.4333333333333, 0.34090909090909
59843, 1.8086956521739, 1.4166666666667, 0.31818181818182
59844, 1.7869565217391, 1.4333333333333, 0.31818181818182
59845, 1.8086956521739, 1.4333333333333, 0.29545454545455
59846, 1.8086956521739, 1.4166666666667, 0.27272727272727
59847, 1.7869565217391, 1.4333333333333, 0.27272727272727
59848, 1.8086956521739, 1.4333333333333, 0.25
59849, 1.8086956521739, 1.4166666666667, 0.22727272727273
59850, 1.7869565217391, 1.4333333333333, 0.22727272727273
59851, 1.8086956521739, 1.4333333333333, 0.20454545454545
59852, 1.8086956521739, 1.4166666666667, 0.18181818181818
59853, 1.7869565217391, 1.4333333333333, 0.18181818181818
59854, 1.8086956521739, 1.4333333333333, 0.15909090909091
59855, 1.8086956521739, 1.4166666666667, 0.13636363636364
59856, 1.7869565217391, 1.4333333333333, 0.13636363636364
59857, 1.8086956521739, 1.4333333333333, 0.11363636363636
59858, 1.8086956521739, 1.4166666666667, 0.090909090909091
59859, 1.7869565217391, 1.4333333333333, 0.090909090909091
59860, 1.8086956521739, 1.4333333333333, 0.068181818181818
59861, 1.8086956521739, 1.4166666666667, 0.045454545454545
59862, 1.7869565217391, 1.4333333333333, 0.045454545454545
59863, 1.8086956521739, 1.4333333333333, 0.022727272727273
59864, 1.8086956521739, 1.4666666666667, 0.47727272727273
59865, 1.8086956521739, 1.45, 0.45454545454545
59866, 1.7869565217391, 1.4666666666667, 0.45454545454545
59867, 1.8086956521739, 1.4666666666667, 0.43181818181818
59868, 1.8086956521739, 1.45, 0.40909090909091
59869, 1.7869565217391, 1.4666666666667, 0.40909090909091
59870, 1.8086956521739, 1.4666666666667, 0.38636363636364
59871, 1.8086956521739, 1.45, 0.36363636363636
59872, 1.7869565217391, 1.4666666666667, 0.36363636363636
59873, 1.8086956521739, 1.4666666666667, 0.34090909090909
59874, 1.8086956521739, 1.45, 0.31818181818182
59875, 1.7869565217391, 1.4666666666667, 0.31818181818182
59876, 1.8086956521739, 1.4666666666667, 0.29545454545455
59877, 1.8086956521739, 1.45, 0.27272727272727
59878, 1.7869565217391, 1.4666666666667, 0.27272727272727
59879, 1.8086956521739, 1.4666666666667, 0.25
59880, 1.8086956521739, 1.45, 0.22727272727273
59881, 1.7869565217391, 1.4666666666667, 0.22727272727273
59882, 1.8086956521739, 1.4666666666667, 0.20454545454545
59883, 1.8086956521739, 1.45, 0.18181818181818
59884, 1.7869565217391, 1.4666666666667, 0.18181818181818
59885, 1.8086956521739, 1.4666666666667, 0.15909090909091
59886, 1.8086956521739, 1.45, 0.13636363636364
59887, 1.7869565217391, 1.4666666666667, 0.13636363636364
59888, 1.8086956521739, 1.4666666666667, 0.11363636363636
59889, 1.8086956521739, 1.45, 0.090909090909091
59890, 1.7869565217391, 1.4666666666667, 0.090909090909091
59891, 1.8086956521739, 1.4666666666667, 0.068181818181818
59892, 1.8086956521739, 1.45, 0.045454545454545
59893, 1.7869565217391, 1.4666666666667, 0.045454545454545
59894, 1.8086956521739, 1.4666666666667, 0.022727272727273
59895, 1.8086956521739, 1.4833333333333, 0.45454545454545
59896, 1.8086956521739, 1.4833333333333, 0.40909090909091
59897, 1.8086956521739, 1.4833333333333, 0.36363636363636
59898, 1.8086956521739, 1.4833333333333, 0.31818181818182
59899, 1.8086956521739, 1.4833333333333, 0.27272727272727
59900, 1.8086956521739, 1.4833333333333, 0.22727272727273
59901, 1.8086956521739, 1.4833333333333, 0.18181818181818
59902, 1.8086956521739, 1.4833333333333, 0.13636363636364
59903, 1.8086956521739, 1.4833333333333, 0.090909090909091
59904, 1.8086956521739, 1.4833333333333, 0.045454545454545
59905, 1.8521739130435, 1.4333333333333, 0.47727272727273
59906, 1.8521739130435, 1.4166666666667, 0.45454545454545
59907, 1.8304347826087, 1.4333333333333, 0.45454545454545
59908, 1.8521739130435, 1.4333333333333, 0.43181818181818
59909, 1.8521739130435, 1.4166666666667, 0.40909090909091
59910, 1.8304347826087, 1.4333333333333, 0.40909090909091
59911, 1.8521739130435, 1.4333333333333, 0.38636363636364
59912, 1.8521739130435, 1.4166666666667, 0.36363636363636
59913, 1.8304347826087, 1.4333333333333, 0.36363636363636
59914, 1.8521739130435, 1.4333333333333, 0.34090909090909
59915, 1.8521739130435, 1.4166666666667, 0.31818181818182
59916, 1.8304347826087, 1.4333333333333, 0.31818181818182
59917, 1.8521739130435, 1.4333333333333, 0.29545454545455
59918, 1.8521739130435, 1.4166666666667, 0.27272727272727
59919, 1.8304347826087, 1.4333333333333, 0.27272727272727
59920, 1.8521739130435, 1.4333333333333, 0.25
59921, 1.8521739130435, 1.4166666666667, 0.22727272727273
59922, 1.8304347826087, 1.4333333333333, 0.22727272727273
59923, 1.8521739130435, 1.4333333333333, 0.20454545454545
59924, 1.8521739130435, 1.4166666666667, 0.18181818181818
59925, 1.8304347826087, 1.4333333333333, 0.18181818181818
59926, 1.8521739130435, 1.4333333333333, 0.15909090909091
59927, 1.8521739130435, 1.4166666666667, 0.13636363636364
59928, 1.8304347826087, 1.4333333333333, 0.13636363636364
59929, 1.8521739130435, 1.4333333333333, 0.11363636363636
59930, 1.8521739130435, 1.4166666666667, 0.090909090909091
59931, 1.8304347826087, 1.4333333333333, 0.090909090909091
59932, 1.8521739130435, 1.4333333333333, 0.068181818181818
59933, 1.8521739130435, 1.4166666666667, 0.045454545454545
59934, 1.8304347826087, 1.4333333333333, 0.045454545454545
59935, 1.8521739130435, 1.4333333333333, 0.022727272727273
59936, 1.8521739130435, 1.4666666666667, 0.47727272727273
59937, 1.8521739130435, 1.45, 0.45454545454545
59938, 1.8304347826087, 1.4666666666667, 0.45454545454545
59939, 1.8521739130435, 1.4666666666667, 0.43181818181818
59940, 1.8521739130435, 1.45, 0.40909090909091
59941, 1.8304347826087, 1.4666666666667, 0.40909090909091
59942, 1.8521739130435, 1.4666666666667, 0.38636363636364
59943, 1.8521739130435, 1.45, 0.36363636363636
59944, 1.8304347826087, 1.4666666666667, 0.36363636363636
59945, 1.8521739130435, 1.4666666666667, 0.34090909090909
59946, 1.8521739130435, 1.45, 0.31818181818182
59947, 1.8304347826087, 1.4666666666667, 0.31818181818182
59948, 1.8521739130435, 1.4666666666667, 0.29545454545455
59949, 1.8521739130435, 1.45, 0.27272727272727
59950, 1.8304347826087, 1.4666666666667, 0.27272727272727
59951, 1.8521739130435, 1.4666666666667, 0.25
59952, 1.8521739130435, 1.45, 0.22727272727273
59953, 1.8304347826087, 1.4666666666667, 0.22727272727273
59954, 1.8521739130435, 1.4666666666667, 0.20454545454545
59955, 1.8521739130435, 1.45, 0.18181818181818
59956, 1.8304347826087, 1.4666666666667, 0.18181818181818
59957, 1.8521739130435, 1.4666666666667, 0.15909090909091
59958, 1.8521739130435, 1.45, 0.13636363636364
59959, 1.8304347826087, 1.4666666666667, 0.13636363636364
59960, 1.8521739130435, 1.4666666666667, 0.11363636363636
59961, 1.8521739130435, 1.45, 0.090909090909091
59962, 1.8304347826087, 1.4666666666667, 0.090909090909091
59963, 1.8521739130435, 1.4666666666667, 0.068181818181818
59964, 1.8521739130435, 1.45, 0.045454545454545
59965, 1.8304347826087, 1.4666666666667, 0.045454545454545
59966, 1.8521739130435, 1.4666666666667, 0.022727272727273
59967, 1.8521739130435, 1.4833333333333, 0.45454545454545
59968, 1.8521739130435, 1.4833333333333, 0.40909090909091
59969, 1.8521739130435, 1.4833333333333, 0.36363636363636
59970, 1.8521739130435, 1.4833333333333, 0.31818181818182
59971, 1.8521739130435, 1.4833333333333, 0.27272727272727
59972, 1.8521739130435, 1.4833333333333, 0.22727272727273
59973, 1.8521739130435, 1.4833333333333, 0.18181818181818
59974, 1.8521739130435, 1.4833333333333, 0.13636363636364
59975, 1.8521739130435, 1.4833333333333, 0.090909090909091
59976, 1.8521739130435, 1.4833333333333, 0.045454545454545
59977, 1.895652173913, 1.4333333333333, 0.47727272727273
59978, 1.895652173913, 1.4166666666667, 0.45454545454545
59979, 1.8739130434783, 1.4333333333333, 0.45454545454545
59980, 1.895652173913, 1.4333333333333, 0.43181818181818
59981, 1.895652173913, 1.4166666666667, 0.40909090909091
59982, 1.8739130434783, 1.4333333333333, 0.40909090909091
59983, 1.895652173913, 1.4333333333333, 0.38636363636364
59984, 1.895652173913, 1.4166666666667, 0.36363636363636
59985, 1.8739130434783, 1.4333333333333, 0.36363636363636
59986, 1.895652173913, 1.4333333333333, 0.34090909090909
59987, 1.895652173913, 1.4166666666667, 0.31818181818182
59988, 1.8739130434783, 1.4333333333333, 0.31818181818182
59989, 1.895652173913, 1.4333333333333, 0.29545454545455
59990, 1.895652173913, 1.4166666666667, 0.27272727272727
59991, 1.8739130434783, 1.4333333333333, 0.27272727272727
59992, 1.895652173913, 1.4333333333333, 0.25
59993, 1.895652173913, 1.4166666666667, 0.22727272727273
59994, 1.8739130434783, 1.4333333333333, 0.22727272727273
59995, 1.895652173913, 1.4333333333333, 0.20454545454545
59996, 1.895652173913, 1.4166666666667, 0.18181818181818
59997, 1.8739130434783, 1.4333333333333, 0.18181818181818
59998, 1.895652173913, 1.4333333333333, 0.15909090909091
59999, 1.895652173913, 1.4166666666667, 0.13636363636364
60000, 1.8739130434783, 1.4333333333333, 0.13636363636364
60001, 1.895652173913, 1.4333333333333, 0.11363636363636
60002, 1.895652173913, 1.4166666666667, 0.090909090909091
60003, 1.8739130434783, 1.4333333333333, 0.090909090909091
60004, 1.895652173913, 1.4333333333333, 0.068181818181818
60005, 1.895652173913, 1.4166666666667, 0.045454545454545
60006, 1.8739130434783, 1.4333333333333, 0.045454545454545
60007, 1.895652173913, 1.4333333333333, 0.022727272727273
60008, 1.895652173913, 1.4666666666667, 0.47727272727273
60009, 1.895652173913, 1.45, 0.45454545454545
60010, 1.8739130434783, 1.4666666666667, 0.45454545454545
60011, 1.895652173913, 1.4666666666667, 0.43181818181818
60012, 1.895652173913, 1.45, 0.40909090909091
60013, 1.8739130434783, 1.4666666666667, 0.40909090909091
60014, 1.895652173913, 1.4666666666667, 0.38636363636364
60015, 1.895652173913, 1.45, 0.36363636363636
60016, 1.8739130434783, 1.4666666666667, 0.36363636363636
60017, 1.895652173913, 1.4666666666667, 0.34090909090909
60018, 1.895652173913, 1.45, 0.31818181818182
60019, 1.8739130434783, 1.4666666666667, 0.31818181818182
60020, 1.895652173913, 1.4666666666667, 0.29545454545455
60021, 1.895652173913, 1.45, 0.27272727272727
60022, 1.8739130434783, 1.4666666666667, 0.27272727272727
60023, 1.895652173913, 1.4666666666667, 0.25
60024, 1.895652173913, 1.45, 0.22727272727273
60025, 1.8739130434783, 1.4666666666667, 0.22727272727273
60026, 1.895652173913, 1.4666666666667, 0.20454545454545
60027, 1.895652173913, 1.45, 0.18181818181818
60028, 1.8739130434783, 1.4666666666667, 0.18181818181818
60029, 1.895652173913, 1.4666666666667, 0.15909090909091
60030, 1.895652173913, 1.45, 0.13636363636364
60031, 1.8739130434783, 1.4666666666667, 0.13636363636364
60032, 1.895652173913, 1.4666666666667, 0.11363636363636
60033, 1.895652173913, 1.45, 0.090909090909091
60034, 1.8739130434783, 1.4666666666667, 0.090909090909091
60035, 1.895652173913, 1.4666666666667, 0.068181818181818
60036, 1.895652173913, 1.45, 0.045454545454545
60037, 1.8739130434783, 1.4666666666667, 0.045454545454545
60038, 1.895652173913, 1.4666666666667, 0.022727272727273
60039, 1.895652173913, 1.4833333333333, 0.45454545454545
60040, 1.895652173913, 1.4833333333333, 0.40909090909091
60041, 1.895652173913, 1.4833333333333, 0.36363636363636
60042, 1.895652173913, 1.4833333333333, 0.31818181818182
60043, 1.895652173913, 1.4833333333333, 0.27272727272727
60044, 1.895652173913, 1.4833333333333, 0.22727272727273
60045, 1.895652173913, 1.4833333333333, 0.18181818181818
60046, 1.895652173913, 1.4833333333333, 0.13636363636364
60047, 1.895652173913, 1.4833333333333, 0.090909090909091
60048, 1.895652173913, 1.4833333333333, 0.045454545454545
60049, 1.9391304347826, 1.4333333333333, 0.47727272727273
60050, 1.9391304347826, 1.4166666666667, 0.45454545454545
60051, 1.9173913043478, 1.4333333333333, 0.45454545454545
60052, 1.9391304347826, 1.4333333333333, 0.43181818181818
60053, 1.9391304347826, 1.4166666666667, 0.40909090909091
60054, 1.9173913043478, 1.4333333333333, 0.40909090909091
60055, 1.9391304347826, 1.4333333333333, 0.38636363636364
60056, 1.9391304347826, 1.4166666666667, 0.36363636363636
60057, 1.9173913043478, 1.4333333333333, 0.36363636363636
60058, 1.9391304347826, 1.4333333333333, 0.34090909090909
60059, 1.9391304347826, 1.4166666666667, 0.31818181818182
60060, 1.9173913043478, 1.4333333333333, 0.31818181818182
60061, 1.9391304347826, 1.4333333333333, 0.29545454545455
60062, 1.9391304347826, 1.4166666666667, 0.27272727272727
60063, 1.9173913043478, 1.4333333333333, 0.27272727272727
60064, 1.9391304347826, 1.4333333333333, 0.25
60065, 1.9391304347826, 1.4166666666667, 0.22727272727273
60066, 1.9173913043478, 1.4333333333333, 0.22727272727273
60067, 1.9391304347826, 1.4333333333333, 0.20454545454545
60068, 1.9391304347826, 1.4166666666667, 0.18181818181818
60069, 1.9173913043478, 1.4333333333333, 0.18181818181818
60070, 1.9391304347826, 1.4333333333333, 0.15909090909091
60071, 1.9391304347826, 1.4166666666667, 0.13636363636364
60072, 1.9173913043478, 1.4333333333333, 0.13636363636364
60073, 1.9391304347826, 1.4333333333333, 0.11363636363636
60074, 1.9391304347826, 1.4166666666667, 0.090909090909091
60075, 1.9173913043478, 1.4333333333333, 0.090909090909091
60076, 1.9391304347826, 1.4333333333333, 0.068181818181818
60077, 1.9391304347826, 1.4166666666667, 0.045454545454545
60078, 1.9173913043478, 1.4333333333333, 0.045454545454545
60079, 1.9391304347826, 1.4333333333333, 0.022727272727273
60080, 1.9391304347826, 1.4666666666667, 0.47727272727273
60081, 1.9391304347826, 1.45, 0.45454545454545
60082, 1.9173913043478, 1.4666666666667, 0.45454545454545
60083, 1.9391304347826, 1.4666666666667, 0.43181818181818
60084, 1.9391304347826, 1.45, 0.40909090909091
60085, 1.9173913043478, 1.4666666666667, 0.40909090909091
60086, 1.9391304347826, 1.4666666666667, 0.38636363636364
60087, 1.9391304347826, 1.45, 0.36363636363636
60088, 1.9173913043478, 1.4666666666667, 0.36363636363636
60089, 1.9391304347826, 1.4666666666667, 0.34090909090909
60090, 1.9391304347826, 1.45, 0.31818181818182
60091, 1.9173913043478, 1.4666666666667, 0.31818181818182
60092, 1.9391304347826, 1.4666666666667, 0.29545454545455
60093, 1.9391304347826, 1.45, 0.27272727272727
60094, 1.9173913043478, 1.4666666666667, 0.27272727272727
60095, 1.9391304347826, 1.4666666666667, 0.25
60096, 1.9391304347826, 1.45, 0.22727272727273
60097, 1.9173913043478, 1.4666666666667, 0.22727272727273
60098, 1.9391304347826, 1.4666666666667, 0.20454545454545
60099, 1.9391304347826, 1.45, 0.18181818181818
60100, 1.9173913043478, 1.4666666666667, 0.18181818181818
60101, 1.9391304347826, 1.4666666666667, 0.15909090909091
60102, 1.9391304347826, 1.45, 0.13636363636364
60103, 1.9173913043478, 1.4666666666667, 0.13636363636364
60104, 1.9391304347826, 1.4666666666667, 0.11363636363636
60105, 1.9391304347826, 1.45, 0.090909090909091
60106, 1.9173913043478, 1.4666666666667, 0.090909090909091
60107, 1.9391304347826, 1.4666666666667, 0.068181818181818
60108, 1.9391304347826, 1.45, 0.045454545454545
60109, 1.9173913043478, 1.4666666666667, 0.045454545454545
60110, 1.9391304347826, 1.4666666666667, 0.022727272727273
60111, 1.9391304347826, 1.4833333333333, 0.45454545454545
60112, 1.9391304347826, 1.4833333333333, 0.40909090909091
60113, 1.9391304347826, 1.4833333333333, 0.36363636363636
60114, 1.9391304347826, 1.4833333333333, 0.31818181818182
60115, 1.9391304347826, 1.4833333333333, 0.27272727272727
60116, 1.9391304347826, 1.4833333333333, 0.22727272727273
60117, 1.9391304347826, 1.4833333333333, 0.18181818181818
60118, 1.9391304347826, 1.4833333333333, 0.13636363636364
60119, 1.9391304347826, 1.4833333333333, 0.090909090909091
60120, 1.9391304347826, 1.4833333333333, 0.045454545454545
60121, 1.9826086956522, 1.4333333333333, 0.47727272727273
60122, 1.9826086956522, 1.4166666666667, 0.45454545454545
60123, 1.9608695652174, 1.4333333333333, 0.45454545454545
60124, 1.9826086956522, 1.4333333333333, 0.43181818181818
60125, 1.9826086956522, 1.4166666666667, 0.40909090909091
60126, 1.9608695652174, 1.4333333333333, 0.40909090909091
60127, 1.9826086956522, 1.4333333333333, 0.38636363636364
60128, 1.9826086956522, 1.4166666666667, 0.36363636363636
60129, 1.9608695652174, 1.4333333333333, 0.36363636363636
60130, 1.9826086956522, 1.4333333333333, 0.34090909090909
60131, 1.9826086956522, 1.4166666666667, 0.31818181818182
60132, 1.9608695652174, 1.4333333333333, 0.31818181818182
60133, 1.9826086956522, 1.4333333333333, 0.29545454545455
60134, 1.9826086956522, 1.4166666666667, 0.27272727272727
60135, 1.9608695652174, 1.4333333333333, 0.27272727272727
60136, 1.9826086956522, 1.4333333333333, 0.25
60137, 1.9826086956522, 1.4166666666667, 0.22727272727273
60138, 1.9608695652174, 1.4333333333333, 0.22727272727273
60139, 1.9826086956522, 1.4333333333333, 0.20454545454545
60140, 1.9826086956522, 1.4166666666667, 0.18181818181818
60141, 1.9608695652174, 1.4333333333333, 0.18181818181818
60142, 1.9826086956522, 1.4333333333333, 0.15909090909091
60143, 1.9826086956522, 1.4166666666667, 0.13636363636364
60144, 1.9608695652174, 1.4333333333333, 0.13636363636364
60145, 1.9826086956522, 1.4333333333333, 0.11363636363636
60146, 1.9826086956522, 1.4166666666667, 0.090909090909091
60147, 1.9608695652174, 1.4333333333333, 0.090909090909091
60148, 1.9826086956522, 1.4333333333333, 0.068181818181818
60149, 1.9826086956522, 1.4166666666667, 0.045454545454545
60150, 1.9608695652174, 1.4333333333333, 0.045454545454545
60151, 1.9826086956522, 1.4333333333333, 0.022727272727273
60152, 1.9826086956522, 1.4666666666667, 0.47727272727273
60153, 1.9826086956522, 1.45, 0.45454545454545
60154, 1.9608695652174, 1.4666666666667, 0.45454545454545
60155, 1.9826086956522, 1.4666666666667, 0.43181818181818
60156, 1.9826086956522, 1.45, 0.40909090909091
60157, 1.9608695652174, 1.4666666666667, 0.40909090909091
60158, 1.9826086956522, 1.4666666666667, 0.38636363636364
60159, 1.9826086956522, 1.45, 0.36363636363636
60160, 1.9608695652174, 1.4666666666667, 0.36363636363636
60161, 1.9826086956522, 1.4666666666667, 0.34090909090909
60162, 1.9826086956522, 1.45, 0.31818181818182
60163, 1.9608695652174, 1.4666666666667, 0.31818181818182
60164, 1.9826086956522, 1.4666666666667, 0.29545454545455
60165, 1.9826086956522, 1.45, 0.27272727272727
60166, 1.9608695652174, 1.4666666666667, 0.27272727272727
60167, 1.9826086956522, 1.4666666666667, 0.25
60168, 1.9826086956522, 1.45, 0.22727272727273
60169, 1.9608695652174, 1.4666666666667, 0.22727272727273
60170, 1.9826086956522, 1.4666666666667, 0.20454545454545
60171, 1.9826086956522, 1.45, 0.18181818181818
60172, 1.9608695652174, 1.4666666666667, 0.18181818181818
60173, 1.9826086956522, 1.4666666666667, 0.15909090909091
60174, 1.9826086956522, 1.45, 0.13636363636364
60175, 1.9608695652174, 1.4666666666667, 0.13636363636364
60176, 1.9826086956522, 1.4666666666667, 0.11363636363636
60177, 1.9826086956522, 1.45, 0.090909090909091
60178, 1.9608695652174, 1.4666666666667, 0.090909090909091
60179, 1.9826086956522, 1.4666666666667, 0.068181818181818
60180, 1.9826086956522, 1.45, 0.045454545454545
60181, 1.9608695652174, 1.4666666666667, 0.045454545454545
60182, 1.9826086956522, 1.4666666666667, 0.022727272727273
60183, 1.9826086956522, 1.4833333333333, 0.45454545454545
60184, 1.9826086956522, 1.4833333333333, 0.40909090909091
60185, 1.9826086956522, 1.4833333333333, 0.36363636363636
60186, 1.9826086956522, 1.4833333333333, 0.31818181818182
60187, 1.9826086956522, 1.4833333333333, 0.27272727272727
60188, 1.9826086956522, 1.4833333333333, 0.22727272727273
60189, 1.9826086956522, 1.4833333333333, 0.18181818181818
60190, 1.9826086956522, 1.4833333333333, 0.13636363636364
60191, 1.9826086956522, 1.4833333333333, 0.090909090909091
60192, 1.9826086956522, 1.4833333333333, 0.045454545454545
60193, 2.0260869565217, 1.4333333333333, 0.47727272727273
60194, 2.0260869565217, 1.4166666666667, 0.45454545454545
60195, 2.004347826087, 1.4333333333333, 0.45454545454545
60196, 2.0260869565217, 1.4333333333333, 0.43181818181818
60197, 2.0260869565217, 1.4166666666667, 0.40909090909091
60198, 2.004347826087, 1.4333333333333, 0.40909090909091
60199, 2.0260869565217, 1.4333333333333, 0.38636363636364
60200, 2.0260869565217, 1.4166666666667, 0.36363636363636
60201, 2.004347826087, 1.4333333333333, 0.36363636363636
60202, 2.0260869565217, 1.4333333333333, 0.34090909090909
60203, 2.0260869565217, 1.4166666666667, 0.31818181818182
60204, 2.004347826087, 1.4333333333333, 0.31818181818182
60205, 2.0260869565217, 1.4333333333333, 0.29545454545455
60206, 2.0260869565217, 1.4166666666667, 0.27272727272727
60207, 2.004347826087, 1.4333333333333, 0.27272727272727
60208, 2.0260869565217, 1.4333333333333, 0.25
60209, 2.0260869565217, 1.4166666666667, 0.22727272727273
60210, 2.004347826087, 1.4333333333333, 0.22727272727273
60211, 2.0260869565217, 1.4333333333333, 0.20454545454545
60212, 2.0260869565217, 1.4166666666667, 0.18181818181818
60213, 2.004347826087, 1.4333333333333, 0.18181818181818
60214, 2.0260869565217, 1.4333333333333, 0.15909090909091
60215, 2.0260869565217, 1.4166666666667, 0.13636363636364
60216, 2.004347826087, 1.4333333333333, 0.13636363636364
60217, 2.0260869565217, 1.4333333333333, 0.11363636363636
60218, 2.0260869565217, 1.4166666666667, 0.090909090909091
60219, 2.004347826087, 1.4333333333333, 0.090909090909091
60220, 2.0260869565217, 1.4333333333333, 0.068181818181818
60221, 2.0260869565217, 1.4166666666667, 0.045454545454545
60222, 2.004347826087, 1.4333333333333, 0.045454545454545
60223, 2.0260869565217, 1.4333333333333, 0.022727272727273
60224, 2.0260869565217, 1.4666666666667, 0.47727272727273
60225, 2.0260869565217, 1.45, 0.45454545454545
60226, 2.004347826087, 1.4666666666667, 0.45454545454545
60227, 2.0260869565217, 1.4666666666667, 0.43181818181818
60228, 2.0260869565217, 1.45, 0.40909090909091
60229, 2.004347826087, 1.4666666666667, 0.40909090909091
60230, 2.0260869565217, 1.4666666666667, 0.38636363636364
60231, 2.0260869565217, 1.45, 0.36363636363636
60232, 2.004347826087, 1.4666666666667, 0.36363636363636
60233, 2.0260869565217, 1.4666666666667, 0.34090909090909
60234, 2.0260869565217, 1.45, 0.31818181818182
60235, 2.004347826087, 1.4666666666667, 0.31818181818182
60236, 2.0260869565217, 1.4666666666667, 0.29545454545455
60237, 2.0260869565217, 1.45, 0.27272727272727
60238, 2.004347826087, 1.4666666666667, 0.27272727272727
60239, 2.0260869565217, 1.4666666666667, 0.25
60240, 2.0260869565217, 1.45, 0.22727272727273
60241, 2.004347826087, 1.4666666666667, 0.22727272727273
60242, 2.0260869565217, 1.4666666666667, 0.20454545454545
60243, 2.0260869565217, 1.45, 0.18181818181818
60244, 2.004347826087, 1.4666666666667, 0.18181818181818
60245, 2.0260869565217, 1.4666666666667, 0.15909090909091
60246, 2.0260869565217, 1.45, 0.13636363636364
60247, 2.004347826087, 1.4666666666667, 0.13636363636364
60248, 2.0260869565217, 1.4666666666667, 0.11363636363636
60249, 2.0260869565217, 1.45, 0.090909090909091
60250, 2.004347826087, 1.4666666666667, 0.090909090909091
60251, 2.0260869565217, 1.4666666666667, 0.068181818181818
60252, 2.0260869565217, 1.45, 0.045454545454545
60253, 2.004347826087, 1.4666666666667, 0.045454545454545
60254, 2.0260869565217, 1.4666666666667, 0.022727272727273
60255, 2.0260869565217, 1.4833333333333, 0.45454545454545
60256, 2.0260869565217, 1.4833333333333, 0.40909090909091
60257, 2.0260869565217, 1.4833333333333, 0.36363636363636
60258, 2.0260869565217, 1.4833333333333, 0.31818181818182
60259, 2.0260869565217, 1.4833333333333, 0.27272727272727
60260, 2.0260869565217, 1.4833333333333, 0.22727272727273
60261, 2.0260869565217, 1.4833333333333, 0.18181818181818
60262, 2.0260869565217, 1.4833333333333, 0.13636363636364
60263, 2.0260869565217, 1.4833333333333, 0.090909090909091
60264, 2.0260869565217, 1.4833333333333, 0.045454545454545
60265, 2.0695652173913, 1.4333333333333, 0.47727272727273
60266, 2.0695652173913, 1.4166666666667, 0.45454545454545
60267, 2.0478260869565, 1.4333333333333, 0.45454545454545
60268, 2.0695652173913, 1.4333333333333, 0.43181818181818
60269, 2.0695652173913, 1.4166666666667, 0.40909090909091
60270, 2.0478260869565, 1.4333333333333, 0.40909090909091
60271, 2.0695652173913, 1.4333333333333, 0.38636363636364
60272, 2.0695652173913, 1.4166666666667, 0.36363636363636
60273, 2.0478260869565, 1.4333333333333, 0.36363636363636
60274, 2.0695652173913, 1.4333333333333, 0.34090909090909
60275, 2.0695652173913, 1.4166666666667, 0.31818181818182
60276, 2.0478260869565, 1.4333333333333, 0.31818181818182
60277, 2.0695652173913, 1.4333333333333, 0.29545454545455
60278, 2.0695652173913, 1.4166666666667, 0.27272727272727
60279, 2.0478260869565, 1.4333333333333, 0.27272727272727
60280, 2.0695652173913, 1.4333333333333, 0.25
60281, 2.0695652173913, 1.4166666666667, 0.22727272727273
60282, 2.0478260869565, 1.4333333333333, 0.22727272727273
60283, 2.0695652173913, 1.4333333333333, 0.20454545454545
60284, 2.0695652173913, 1.4166666666667, 0.18181818181818
60285, 2.0478260869565, 1.4333333333333, 0.18181818181818
60286, 2.0695652173913, 1.4333333333333, 0.15909090909091
60287, 2.0695652173913, 1.4166666666667, 0.13636363636364
60288, 2.0478260869565, 1.4333333333333, 0.13636363636364
60289, 2.0695652173913, 1.4333333333333, 0.11363636363636
60290, 2.0695652173913, 1.4166666666667, 0.090909090909091
60291, 2.0478260869565, 1.4333333333333, 0.090909090909091
60292, 2.0695652173913, 1.4333333333333, 0.068181818181818
60293, 2.0695652173913, 1.4166666666667, 0.045454545454545
60294, 2.0478260869565, 1.4333333333333, 0.045454545454545
60295, 2.0695652173913, 1.4333333333333, 0.022727272727273
60296, 2.0695652173913, 1.4666666666667, 0.47727272727273
60297, 2.0695652173913, 1.45, 0.45454545454545
60298, 2.0478260869565, 1.4666666666667, 0.45454545454545
60299, 2.0695652173913, 1.4666666666667, 0.43181818181818
60300, 2.0695652173913, 1.45, 0.40909090909091
60301, 2.0478260869565, 1.4666666666667, 0.40909090909091
60302, 2.0695652173913, 1.4666666666667, 0.38636363636364
60303, 2.0695652173913, 1.45, 0.36363636363636
60304, 2.0478260869565, 1.4666666666667, 0.36363636363636
60305, 2.0695652173913, 1.4666666666667, 0.34090909090909
60306, 2.0695652173913, 1.45, 0.31818181818182
60307, 2.0478260869565, 1.4666666666667, 0.31818181818182
60308, 2.0695652173913, 1.4666666666667, 0.29545454545455
60309, 2.0695652173913, 1.45, 0.27272727272727
60310, 2.0478260869565, 1.4666666666667, 0.27272727272727
60311, 2.0695652173913, 1.4666666666667, 0.25
60312, 2.0695652173913, 1.45, 0.22727272727273
60313, 2.0478260869565, 1.4666666666667, 0.22727272727273
60314, 2.0695652173913, 1.4666666666667, 0.20454545454545
60315, 2.0695652173913, 1.45, 0.18181818181818
60316, 2.0478260869565, 1.4666666666667, 0.18181818181818
60317, 2.0695652173913, 1.4666666666667, 0.15909090909091
60318, 2.0695652173913, 1.45, 0.13636363636364
60319, 2.0478260869565, 1.4666666666667, 0.13636363636364
60320, 2.0695652173913, 1.4666666666667, 0.11363636363636
60321, 2.0695652173913, 1.45, 0.090909090909091
60322, 2.0478260869565, 1.4666666666667, 0.090909090909091
60323, 2.0695652173913, 1.4666666666667, 0.068181818181818
60324, 2.0695652173913, 1.45, 0.045454545454545
60325, 2.0478260869565, 1.4666666666667, 0.045454545454545
60326, 2.0695652173913, 1.4666666666667, 0.022727272727273
60327, 2.0695652173913, 1.4833333333333, 0.45454545454545
60328, 2.0695652173913, 1.4833333333333, 0.40909090909091
60329, 2.0695652173913, 1.4833333333333, 0.36363636363636
60330, 2.0695652173913, 1.4833333333333, 0.31818181818182
60331, 2.0695652173913, 1.4833333333333, 0.27272727272727
60332, 2.0695652173913, 1.4833333333333, 0.22727272727273
60333, 2.0695652173913, 1.4833333333333, 0.18181818181818
60334, 2.0695652173913, 1.4833333333333, 0.13636363636364
60335, 2.0695652173913, 1.4833333333333, 0.090909090909091
60336, 2.0695652173913, 1.4833333333333, 0.045454545454545
60337, 2.1130434782609, 1.4333333333333, 0.47727272727273
60338, 2.1130434782609, 1.4166666666667, 0.45454545454545
60339, 2.0913043478261, 1.4333333333333, 0.45454545454545
60340, 2.1130434782609, 1.4333333333333, 0.43181818181818
60341, 2.1130434782609, 1.4166666666667, 0.40909090909091
60342, 2.0913043478261, 1.4333333333333, 0.40909090909091
60343, 2.1130434782609, 1.4333333333333, 0.38636363636364
60344, 2.1130434782609, 1.4166666666667, 0.36363636363636
60345, 2.0913043478261, 1.4333333333333, 0.36363636363636
60346, 2.1130434782609, 1.4333333333333, 0.34090909090909
60347, 2.1130434782609, 1.4166666666667, 0.31818181818182
60348, 2.0913043478261, 1.4333333333333, 0.31818181818182
60349, 2.1130434782609, 1.4333333333333, 0.29545454545455
60350, 2.1130434782609, 1.4166666666667, 0.27272727272727
60351, 2.0913043478261, 1.4333333333333, 0.27272727272727
60352, 2.1130434782609, 1.4333333333333, 0.25
60353, 2.1130434782609, 1.4166666666667, 0.22727272727273
60354, 2.0913043478261, 1.4333333333333, 0.22727272727273
60355, 2.1130434782609, 1.4333333333333, 0.20454545454545
60356, 2.1130434782609, 1.4166666666667, 0.18181818181818
60357, 2.0913043478261, 1.4333333333333, 0.18181818181818
60358, 2.1130434782609, 1.4333333333333, 0.15909090909091
60359, 2.1130434782609, 1.4166666666667, 0.13636363636364
60360, 2.0913043478261, 1.4333333333333, 0.13636363636364
60361, 2.1130434782609, 1.4333333333333, 0.11363636363636
60362, 2.1130434782609, 1.4166666666667, 0.090909090909091
60363, 2.0913043478261, 1.4333333333333, 0.090909090909091
60364, 2.1130434782609, 1.4333333333333, 0.068181818181818
60365, 2.1130434782609, 1.4166666666667, 0.045454545454545
60366, 2.0913043478261, 1.4333333333333, 0.045454545454545
60367, 2.1130434782609, 1.4333333333333, 0.022727272727273
60368, 2.1130434782609, 1.4666666666667, 0.47727272727273
60369, 2.1130434782609, 1.45, 0.45454545454545
60370, 2.0913043478261, 1.4666666666667, 0.45454545454545
60371, 2.1130434782609, 1.4666666666667, 0.43181818181818
60372, 2.1130434782609, 1.45, 0.40909090909091
60373, 2.0913043478261, 1.4666666666667, 0.40909090909091
60374, 2.1130434782609, 1.4666666666667, 0.38636363636364
60375, 2.1130434782609, 1.45, 0.36363636363636
60376, 2.0913043478261, 1.4666666666667, 0.36363636363636
60377, 2.1130434782609, 1.4666666666667, 0.34090909090909
60378, 2.1130434782609, 1.45, 0.31818181818182
60379, 2.0913043478261, 1.4666666666667, 0.31818181818182
60380, 2.1130434782609, 1.4666666666667, 0.29545454545455
60381, 2.1130434782609, 1.45, 0.27272727272727
60382, 2.0913043478261, 1.4666666666667, 0.27272727272727
60383, 2.1130434782609, 1.4666666666667, 0.25
60384, 2.1130434782609, 1.45, 0.22727272727273
60385, 2.0913043478261, 1.4666666666667, 0.22727272727273
60386, 2.1130434782609, 1.4666666666667, 0.20454545454545
60387, 2.1130434782609, 1.45, 0.18181818181818
60388, 2.0913043478261, 1.4666666666667, 0.18181818181818
60389, 2.1130434782609, 1.4666666666667, 0.15909090909091
60390, 2.1130434782609, 1.45, 0.13636363636364
60391, 2.0913043478261, 1.4666666666667, 0.13636363636364
60392, 2.1130434782609, 1.4666666666667, 0.11363636363636
60393, 2.1130434782609, 1.45, 0.090909090909091
60394, 2.0913043478261, 1.4666666666667, 0.090909090909091
60395, 2.1130434782609, 1.4666666666667, 0.068181818181818
60396, 2.1130434782609, 1.45, 0.045454545454545
60397, 2.0913043478261, 1.4666666666667, 0.045454545454545
60398, 2.1130434782609, 1.4666666666667, 0.022727272727273
60399, 2.1130434782609, 1.4833333333333, 0.45454545454545
60400, 2.1130434782609, 1.4833333333333, 0.40909090909091
60401, 2.1130434782609, 1.4833333333333, 0.36363636363636
60402, 2.1130434782609, 1.4833333333333, 0.31818181818182
60403, 2.1130434782609, 1.4833333333333, 0.27272727272727
60404, 2.1130434782609, 1.4833333333333, 0.22727272727273
60405, 2.1130434782609, 1.4833333333333, 0.18181818181818
60406, 2.1130434782609, 1.4833333333333, 0.13636363636364
60407, 2.1130434782609, 1.4833333333333, 0.090909090909091
60408, 2.1130434782609, 1.4833333333333, 0.045454545454545
60409, 2.1565217391304, 1.4333333333333, 0.47727272727273
60410, 2.1565217391304, 1.4166666666667, 0.45454545454545
60411, 2.1347826086957, 1.4333333333333, 0.45454545454545
60412, 2.1565217391304, 1.4333333333333, 0.43181818181818
60413, 2.1565217391304, 1.4166666666667, 0.40909090909091
60414, 2.1347826086957, 1.4333333333333, 0.40909090909091
60415, 2.1565217391304, 1.4333333333333, 0.38636363636364
60416, 2.1565217391304, 1.4166666666667, 0.36363636363636
60417, 2.1347826086957, 1.4333333333333, 0.36363636363636
60418, 2.1565217391304, 1.4333333333333, 0.34090909090909
60419, 2.1565217391304, 1.4166666666667, 0.31818181818182
60420, 2.1347826086957, 1.4333333333333, 0.31818181818182
60421, 2.1565217391304, 1.4333333333333, 0.29545454545455
60422, 2.1565217391304, 1.4166666666667, 0.27272727272727
60423, 2.1347826086957, 1.4333333333333, 0.27272727272727
60424, 2.1565217391304, 1.4333333333333, 0.25
60425, 2.1565217391304, 1.4166666666667, 0.22727272727273
60426, 2.1347826086957, 1.4333333333333, 0.22727272727273
60427, 2.1565217391304, 1.4333333333333, 0.20454545454545
60428, 2.1565217391304, 1.4166666666667, 0.18181818181818
60429, 2.1347826086957, 1.4333333333333, 0.18181818181818
60430, 2.1565217391304, 1.4333333333333, 0.15909090909091
60431, 2.1565217391304, 1.4166666666667, 0.13636363636364
60432, 2.1347826086957, 1.4333333333333, 0.13636363636364
60433, 2.1565217391304, 1.4333333333333, 0.11363636363636
60434, 2.1565217391304, 1.4166666666667, 0.090909090909091
60435, 2.1347826086957, 1.4333333333333, 0.090909090909091
60436, 2.1565217391304, 1.4333333333333, 0.068181818181818
60437, 2.1565217391304, 1.4166666666667, 0.045454545454545
60438, 2.1347826086957, 1.4333333333333, 0.045454545454545
60439, 2.1565217391304, 1.4333333333333, 0.022727272727273
60440, 2.1565217391304, 1.4666666666667, 0.47727272727273
60441, 2.1565217391304, 1.45, 0.45454545454545
60442, 2.1347826086957, 1.4666666666667, 0.45454545454545
60443, 2.1565217391304, 1.4666666666667, 0.43181818181818
60444, 2.1565217391304, 1.45, 0.40909090909091
60445, 2.1347826086957, 1.4666666666667, 0.40909090909091
60446, 2.1565217391304, 1.4666666666667, 0.38636363636364
60447, 2.1565217391304, 1.45, 0.36363636363636
60448, 2.1347826086957, 1.4666666666667, 0.36363636363636
60449, 2.1565217391304, 1.4666666666667, 0.34090909090909
60450, 2.1565217391304, 1.45, 0.31818181818182
60451, 2.1347826086957, 1.4666666666667, 0.31818181818182
60452, 2.1565217391304, 1.4666666666667, 0.29545454545455
60453, 2.1565217391304, 1.45, 0.27272727272727
60454, 2.1347826086957, 1.4666666666667, 0.27272727272727
60455, 2.1565217391304, 1.4666666666667, 0.25
60456, 2.1565217391304, 1.45, 0.22727272727273
60457, 2.1347826086957, 1.4666666666667, 0.22727272727273
60458, 2.1565217391304, 1.4666666666667, 0.20454545454545
60459, 2.1565217391304, 1.45, 0.18181818181818
60460, 2.1347826086957, 1.4666666666667, 0.18181818181818
60461, 2.1565217391304, 1.4666666666667, 0.15909090909091
60462, 2.1565217391304, 1.45, 0.13636363636364
60463, 2.1347826086957, 1.4666666666667, 0.13636363636364
60464, 2.1565217391304, 1.4666666666667, 0.11363636363636
60465, 2.1565217391304, 1.45, 0.090909090909091
60466, 2.1347826086957, 1.4666666666667, 0.090909090909091
60467, 2.1565217391304, 1.4666666666667, 0.068181818181818
60468, 2.1565217391304, 1.45, 0.045454545454545
60469, 2.1347826086957, 1.4666666666667, 0.045454545454545
60470, 2.1565217391304, 1.4666666666667, 0.022727272727273
60471, 2.1565217391304, 1.4833333333333, 0.45454545454545
60472, 2.1565217391304, 1.4833333333333, 0.40909090909091
60473, 2.1565217391304, 1.4833333333333, 0.36363636363636
60474, 2.1565217391304, 1.4833333333333, 0.31818181818182
60475, 2.1565217391304, 1.4833333333333, 0.27272727272727
60476, 2.1565217391304, 1.4833333333333, 0.22727272727273
60477, 2.1565217391304, 1.4833333333333, 0.18181818181818
60478, 2.1565217391304, 1.4833333333333, 0.13636363636364
60479, 2.1565217391304, 1.4833333333333, 0.090909090909091
60480, 2.1565217391304, 1.4833333333333, 0.045454545454545
60481, 2.1782608695652, 1.4333333333333, 0.45454545454545
60482, 2.1782608695652, 1.4333333333333, 0.40909090909091
60483, 2.1782608695652, 1.4333333333333, 0.36363636363636
60484, 2.1782608695652, 1.4333333333333, 0.31818181818182
60485, 2.1782608695652, 1.4333333333333, 0.27272727272727
60486, 2.1782608695652, 1.4333333333333, 0.22727272727273
60487, 2.1782608695652, 1.4333333333333, 0.18181818181818
60488, 2.1782608695652, 1.4333333333333, 0.13636363636364
60489, 2.1782608695652, 1.4333333333333, 0.090909090909091
60490, 2.1782608695652, 1.4333333333333, 0.045454545454545
60491, 2.1782608695652, 1.4666666666667, 0.45454545454545
60492, 2.1782608695652, 1.4666666666667, 0.40909090909091
60493, 2.1782608695652, 1.4666666666667, 0.36363636363636
60494, 2.1782608695652, 1.4666666666667, 0.31818181818182
60495, 2.1782608695652, 1.4666666666667, 0.27272727272727
60496, 2.1782608695652, 1.4666666666667, 0.22727272727273
60497, 2.1782608695652, 1.4666666666667, 0.18181818181818
60498, 2.1782608695652, 1.4666666666667, 0.13636363636364
60499, 2.1782608695652, 1.4666666666667, 0.090909090909091
60500, 2.1782608695652, 1.4666666666667, 0.045454545454545
60501, 1.2434782608696, 1.375, 0.45454545454545
60502, 1.2434782608696, 1.375, 0.40909090909091
60503, 1.2434782608696, 1.375, 0.36363636363636
60504, 1.2434782608696, 1.375, 0.31818181818182
60505, 1.2434782608696, 1.375, 0.27272727272727
60506, 1.2434782608696, 1.375, 0.22727272727273
60507, 1.2434782608696, 1.375, 0.18181818181818
60508, 1.2434782608696, 1.375, 0.13636363636364
60509, 1.2434782608696, 1.375, 0.090909090909091
60510, 1.2434782608696, 1.375, 0.045454545454545
60511, 1.2869565217391, 1.375, 0.45454545454545
60512, 1.2869565217391, 1.375, 0.40909090909091
60513, 1.2869565217391, 1.375, 0.36363636363636
60514, 1.2869565217391, 1.375, 0.31818181818182
60515, 1.2869565217391, 1.375, 0.27272727272727
60516, 1.2869565217391, 1.375, 0.22727272727273
