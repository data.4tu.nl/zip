34762, 0.30434782608696, 0.20217391304348, 0.18181818181818
34763, 0.30434782608696, 0.20217391304348, 0.22727272727273
34764, 0.30434782608696, 0.20217391304348, 0.27272727272727
34765, 0.30434782608696, 0.20217391304348, 0.31818181818182
34766, 0.30434782608696, 0.20217391304348, 0.36363636363636
34767, 0.30434782608696, 0.20217391304348, 0.40909090909091
34768, 0.30434782608696, 0.20217391304348, 0.45454545454545
34769, 0.26086956521739, 0.20217391304348, 0.045454545454545
34770, 0.26086956521739, 0.20217391304348, 0.090909090909091
34771, 0.26086956521739, 0.20217391304348, 0.13636363636364
34772, 0.26086956521739, 0.20217391304348, 0.18181818181818
34773, 0.26086956521739, 0.20217391304348, 0.22727272727273
34774, 0.26086956521739, 0.20217391304348, 0.27272727272727
34775, 0.26086956521739, 0.20217391304348, 0.31818181818182
34776, 0.26086956521739, 0.20217391304348, 0.36363636363636
34777, 0.26086956521739, 0.20217391304348, 0.40909090909091
34778, 0.26086956521739, 0.20217391304348, 0.45454545454545
34779, 0.21739130434783, 0.20217391304348, 0.045454545454545
34780, 0.21739130434783, 0.20217391304348, 0.090909090909091
34781, 0.21739130434783, 0.20217391304348, 0.13636363636364
34782, 0.21739130434783, 0.20217391304348, 0.18181818181818
34783, 0.21739130434783, 0.20217391304348, 0.22727272727273
34784, 0.21739130434783, 0.20217391304348, 0.27272727272727
34785, 0.21739130434783, 0.20217391304348, 0.31818181818182
34786, 0.21739130434783, 0.20217391304348, 0.36363636363636
34787, 0.21739130434783, 0.20217391304348, 0.40909090909091
34788, 0.21739130434783, 0.20217391304348, 0.45454545454545
34789, 0.17391304347826, 0.20217391304348, 0.045454545454545
34790, 0.17391304347826, 0.20217391304348, 0.090909090909091
34791, 0.17391304347826, 0.20217391304348, 0.13636363636364
34792, 0.17391304347826, 0.20217391304348, 0.18181818181818
34793, 0.17391304347826, 0.20217391304348, 0.22727272727273
34794, 0.17391304347826, 0.20217391304348, 0.27272727272727
34795, 0.17391304347826, 0.20217391304348, 0.31818181818182
34796, 0.17391304347826, 0.20217391304348, 0.36363636363636
34797, 0.17391304347826, 0.20217391304348, 0.40909090909091
34798, 0.17391304347826, 0.20217391304348, 0.45454545454545
34799, 0.1304347826087, 0.20217391304348, 0.045454545454545
34800, 0.1304347826087, 0.20217391304348, 0.090909090909091
34801, 0.1304347826087, 0.20217391304348, 0.13636363636364
34802, 0.1304347826087, 0.20217391304348, 0.18181818181818
34803, 0.1304347826087, 0.20217391304348, 0.22727272727273
34804, 0.1304347826087, 0.20217391304348, 0.27272727272727
34805, 0.1304347826087, 0.20217391304348, 0.31818181818182
34806, 0.1304347826087, 0.20217391304348, 0.36363636363636
34807, 0.1304347826087, 0.20217391304348, 0.40909090909091
34808, 0.1304347826087, 0.20217391304348, 0.45454545454545
34809, 0.08695652173913, 0.20217391304348, 0.045454545454545
34810, 0.08695652173913, 0.20217391304348, 0.090909090909091
34811, 0.08695652173913, 0.20217391304348, 0.13636363636364
34812, 0.08695652173913, 0.20217391304348, 0.18181818181818
34813, 0.08695652173913, 0.20217391304348, 0.22727272727273
34814, 0.08695652173913, 0.20217391304348, 0.27272727272727
34815, 0.08695652173913, 0.20217391304348, 0.31818181818182
34816, 0.08695652173913, 0.20217391304348, 0.36363636363636
34817, 0.08695652173913, 0.20217391304348, 0.40909090909091
34818, 0.08695652173913, 0.20217391304348, 0.45454545454545
34819, 0.043478260869565, 0.20217391304348, 0.045454545454545
34820, 0.043478260869565, 0.20217391304348, 0.090909090909091
34821, 0.043478260869565, 0.20217391304348, 0.13636363636364
34822, 0.043478260869565, 0.20217391304348, 0.18181818181818
34823, 0.043478260869565, 0.20217391304348, 0.22727272727273
34824, 0.043478260869565, 0.20217391304348, 0.27272727272727
34825, 0.043478260869565, 0.20217391304348, 0.31818181818182
34826, 0.043478260869565, 0.20217391304348, 0.36363636363636
34827, 0.043478260869565, 0.20217391304348, 0.40909090909091
34828, 0.043478260869565, 0.20217391304348, 0.45454545454545
34829, 0.95652173913043, 0.25434782608696, 0.045454545454545
34830, 0.95652173913043, 0.25434782608696, 0.090909090909091
34831, 0.95652173913043, 0.25434782608696, 0.13636363636364
34832, 0.95652173913043, 0.25434782608696, 0.18181818181818
34833, 0.95652173913043, 0.25434782608696, 0.22727272727273
34834, 0.95652173913043, 0.25434782608696, 0.27272727272727
34835, 0.95652173913043, 0.25434782608696, 0.31818181818182
34836, 0.95652173913043, 0.25434782608696, 0.36363636363636
34837, 0.95652173913043, 0.25434782608696, 0.40909090909091
34838, 0.95652173913043, 0.25434782608696, 0.45454545454545
34839, 0.91304347826087, 0.25434782608696, 0.045454545454545
34840, 0.91304347826087, 0.25434782608696, 0.090909090909091
34841, 0.91304347826087, 0.25434782608696, 0.13636363636364
34842, 0.91304347826087, 0.25434782608696, 0.18181818181818
34843, 0.91304347826087, 0.25434782608696, 0.22727272727273
34844, 0.91304347826087, 0.25434782608696, 0.27272727272727
34845, 0.91304347826087, 0.25434782608696, 0.31818181818182
34846, 0.91304347826087, 0.25434782608696, 0.36363636363636
34847, 0.91304347826087, 0.25434782608696, 0.40909090909091
34848, 0.91304347826087, 0.25434782608696, 0.45454545454545
34849, 0.8695652173913, 0.25434782608696, 0.045454545454545
34850, 0.8695652173913, 0.25434782608696, 0.090909090909091
34851, 0.8695652173913, 0.25434782608696, 0.13636363636364
34852, 0.8695652173913, 0.25434782608696, 0.18181818181818
34853, 0.8695652173913, 0.25434782608696, 0.22727272727273
34854, 0.8695652173913, 0.25434782608696, 0.27272727272727
34855, 0.8695652173913, 0.25434782608696, 0.31818181818182
34856, 0.8695652173913, 0.25434782608696, 0.36363636363636
34857, 0.8695652173913, 0.25434782608696, 0.40909090909091
34858, 0.8695652173913, 0.25434782608696, 0.45454545454545
34859, 0.82608695652174, 0.25434782608696, 0.045454545454545
34860, 0.82608695652174, 0.25434782608696, 0.090909090909091
34861, 0.82608695652174, 0.25434782608696, 0.13636363636364
34862, 0.82608695652174, 0.25434782608696, 0.18181818181818
34863, 0.82608695652174, 0.25434782608696, 0.22727272727273
34864, 0.82608695652174, 0.25434782608696, 0.27272727272727
34865, 0.82608695652174, 0.25434782608696, 0.31818181818182
34866, 0.82608695652174, 0.25434782608696, 0.36363636363636
34867, 0.82608695652174, 0.25434782608696, 0.40909090909091
34868, 0.82608695652174, 0.25434782608696, 0.45454545454545
34869, 0.78260869565217, 0.25434782608696, 0.045454545454545
34870, 0.78260869565217, 0.25434782608696, 0.090909090909091
34871, 0.78260869565217, 0.25434782608696, 0.13636363636364
34872, 0.78260869565217, 0.25434782608696, 0.18181818181818
34873, 0.78260869565217, 0.25434782608696, 0.22727272727273
34874, 0.78260869565217, 0.25434782608696, 0.27272727272727
34875, 0.78260869565217, 0.25434782608696, 0.31818181818182
34876, 0.78260869565217, 0.25434782608696, 0.36363636363636
34877, 0.78260869565217, 0.25434782608696, 0.40909090909091
34878, 0.78260869565217, 0.25434782608696, 0.45454545454545
34879, 0.73913043478261, 0.25434782608696, 0.045454545454545
34880, 0.73913043478261, 0.25434782608696, 0.090909090909091
34881, 0.73913043478261, 0.25434782608696, 0.13636363636364
34882, 0.73913043478261, 0.25434782608696, 0.18181818181818
34883, 0.73913043478261, 0.25434782608696, 0.22727272727273
34884, 0.73913043478261, 0.25434782608696, 0.27272727272727
34885, 0.73913043478261, 0.25434782608696, 0.31818181818182
34886, 0.73913043478261, 0.25434782608696, 0.36363636363636
34887, 0.73913043478261, 0.25434782608696, 0.40909090909091
34888, 0.73913043478261, 0.25434782608696, 0.45454545454545
34889, 0.69565217391304, 0.25434782608696, 0.045454545454545
34890, 0.69565217391304, 0.25434782608696, 0.090909090909091
34891, 0.69565217391304, 0.25434782608696, 0.13636363636364
34892, 0.69565217391304, 0.25434782608696, 0.18181818181818
34893, 0.69565217391304, 0.25434782608696, 0.22727272727273
34894, 0.69565217391304, 0.25434782608696, 0.27272727272727
34895, 0.69565217391304, 0.25434782608696, 0.31818181818182
34896, 0.69565217391304, 0.25434782608696, 0.36363636363636
34897, 0.69565217391304, 0.25434782608696, 0.40909090909091
34898, 0.69565217391304, 0.25434782608696, 0.45454545454545
34899, 0.65217391304348, 0.25434782608696, 0.045454545454545
34900, 0.65217391304348, 0.25434782608696, 0.090909090909091
34901, 0.65217391304348, 0.25434782608696, 0.13636363636364
34902, 0.65217391304348, 0.25434782608696, 0.18181818181818
34903, 0.65217391304348, 0.25434782608696, 0.22727272727273
34904, 0.65217391304348, 0.25434782608696, 0.27272727272727
34905, 0.65217391304348, 0.25434782608696, 0.31818181818182
34906, 0.65217391304348, 0.25434782608696, 0.36363636363636
34907, 0.65217391304348, 0.25434782608696, 0.40909090909091
34908, 0.65217391304348, 0.25434782608696, 0.45454545454545
34909, 0.60869565217391, 0.25434782608696, 0.045454545454545
34910, 0.60869565217391, 0.25434782608696, 0.090909090909091
34911, 0.60869565217391, 0.25434782608696, 0.13636363636364
34912, 0.60869565217391, 0.25434782608696, 0.18181818181818
34913, 0.60869565217391, 0.25434782608696, 0.22727272727273
34914, 0.60869565217391, 0.25434782608696, 0.27272727272727
34915, 0.60869565217391, 0.25434782608696, 0.31818181818182
34916, 0.60869565217391, 0.25434782608696, 0.36363636363636
34917, 0.60869565217391, 0.25434782608696, 0.40909090909091
34918, 0.60869565217391, 0.25434782608696, 0.45454545454545
34919, 0.56521739130435, 0.25434782608696, 0.045454545454545
34920, 0.56521739130435, 0.25434782608696, 0.090909090909091
34921, 0.56521739130435, 0.25434782608696, 0.13636363636364
34922, 0.56521739130435, 0.25434782608696, 0.18181818181818
34923, 0.56521739130435, 0.25434782608696, 0.22727272727273
34924, 0.56521739130435, 0.25434782608696, 0.27272727272727
34925, 0.56521739130435, 0.25434782608696, 0.31818181818182
34926, 0.56521739130435, 0.25434782608696, 0.36363636363636
34927, 0.56521739130435, 0.25434782608696, 0.40909090909091
34928, 0.56521739130435, 0.25434782608696, 0.45454545454545
34929, 0.52173913043478, 0.25434782608696, 0.045454545454545
34930, 0.52173913043478, 0.25434782608696, 0.090909090909091
34931, 0.52173913043478, 0.25434782608696, 0.13636363636364
34932, 0.52173913043478, 0.25434782608696, 0.18181818181818
34933, 0.52173913043478, 0.25434782608696, 0.22727272727273
34934, 0.52173913043478, 0.25434782608696, 0.27272727272727
34935, 0.52173913043478, 0.25434782608696, 0.31818181818182
34936, 0.52173913043478, 0.25434782608696, 0.36363636363636
34937, 0.52173913043478, 0.25434782608696, 0.40909090909091
34938, 0.52173913043478, 0.25434782608696, 0.45454545454545
34939, 0.47826086956522, 0.25434782608696, 0.045454545454545
34940, 0.47826086956522, 0.25434782608696, 0.090909090909091
34941, 0.47826086956522, 0.25434782608696, 0.13636363636364
34942, 0.47826086956522, 0.25434782608696, 0.18181818181818
34943, 0.47826086956522, 0.25434782608696, 0.22727272727273
34944, 0.47826086956522, 0.25434782608696, 0.27272727272727
34945, 0.47826086956522, 0.25434782608696, 0.31818181818182
34946, 0.47826086956522, 0.25434782608696, 0.36363636363636
34947, 0.47826086956522, 0.25434782608696, 0.40909090909091
34948, 0.47826086956522, 0.25434782608696, 0.45454545454545
34949, 0.43478260869565, 0.25434782608696, 0.045454545454545
34950, 0.43478260869565, 0.25434782608696, 0.090909090909091
34951, 0.43478260869565, 0.25434782608696, 0.13636363636364
34952, 0.43478260869565, 0.25434782608696, 0.18181818181818
34953, 0.43478260869565, 0.25434782608696, 0.22727272727273
34954, 0.43478260869565, 0.25434782608696, 0.27272727272727
34955, 0.43478260869565, 0.25434782608696, 0.31818181818182
34956, 0.43478260869565, 0.25434782608696, 0.36363636363636
34957, 0.43478260869565, 0.25434782608696, 0.40909090909091
34958, 0.43478260869565, 0.25434782608696, 0.45454545454545
34959, 0.39130434782609, 0.25434782608696, 0.045454545454545
34960, 0.39130434782609, 0.25434782608696, 0.090909090909091
34961, 0.39130434782609, 0.25434782608696, 0.13636363636364
34962, 0.39130434782609, 0.25434782608696, 0.18181818181818
34963, 0.39130434782609, 0.25434782608696, 0.22727272727273
34964, 0.39130434782609, 0.25434782608696, 0.27272727272727
34965, 0.39130434782609, 0.25434782608696, 0.31818181818182
34966, 0.39130434782609, 0.25434782608696, 0.36363636363636
34967, 0.39130434782609, 0.25434782608696, 0.40909090909091
34968, 0.39130434782609, 0.25434782608696, 0.45454545454545
34969, 0.34782608695652, 0.25434782608696, 0.045454545454545
34970, 0.34782608695652, 0.25434782608696, 0.090909090909091
34971, 0.34782608695652, 0.25434782608696, 0.13636363636364
34972, 0.34782608695652, 0.25434782608696, 0.18181818181818
34973, 0.34782608695652, 0.25434782608696, 0.22727272727273
34974, 0.34782608695652, 0.25434782608696, 0.27272727272727
34975, 0.34782608695652, 0.25434782608696, 0.31818181818182
34976, 0.34782608695652, 0.25434782608696, 0.36363636363636
34977, 0.34782608695652, 0.25434782608696, 0.40909090909091
34978, 0.34782608695652, 0.25434782608696, 0.45454545454545
34979, 0.30434782608696, 0.25434782608696, 0.045454545454545
34980, 0.30434782608696, 0.25434782608696, 0.090909090909091
34981, 0.30434782608696, 0.25434782608696, 0.13636363636364
34982, 0.30434782608696, 0.25434782608696, 0.18181818181818
34983, 0.30434782608696, 0.25434782608696, 0.22727272727273
34984, 0.30434782608696, 0.25434782608696, 0.27272727272727
34985, 0.30434782608696, 0.25434782608696, 0.31818181818182
34986, 0.30434782608696, 0.25434782608696, 0.36363636363636
34987, 0.30434782608696, 0.25434782608696, 0.40909090909091
34988, 0.30434782608696, 0.25434782608696, 0.45454545454545
34989, 0.26086956521739, 0.25434782608696, 0.045454545454545
34990, 0.26086956521739, 0.25434782608696, 0.090909090909091
34991, 0.26086956521739, 0.25434782608696, 0.13636363636364
34992, 0.26086956521739, 0.25434782608696, 0.18181818181818
34993, 0.26086956521739, 0.25434782608696, 0.22727272727273
34994, 0.26086956521739, 0.25434782608696, 0.27272727272727
34995, 0.26086956521739, 0.25434782608696, 0.31818181818182
34996, 0.26086956521739, 0.25434782608696, 0.36363636363636
34997, 0.26086956521739, 0.25434782608696, 0.40909090909091
34998, 0.26086956521739, 0.25434782608696, 0.45454545454545
34999, 0.21739130434783, 0.25434782608696, 0.045454545454545
35000, 0.21739130434783, 0.25434782608696, 0.090909090909091
35001, 0.21739130434783, 0.25434782608696, 0.13636363636364
35002, 0.21739130434783, 0.25434782608696, 0.18181818181818
35003, 0.21739130434783, 0.25434782608696, 0.22727272727273
35004, 0.21739130434783, 0.25434782608696, 0.27272727272727
35005, 0.21739130434783, 0.25434782608696, 0.31818181818182
35006, 0.21739130434783, 0.25434782608696, 0.36363636363636
35007, 0.21739130434783, 0.25434782608696, 0.40909090909091
35008, 0.21739130434783, 0.25434782608696, 0.45454545454545
35009, 0.17391304347826, 0.25434782608696, 0.045454545454545
35010, 0.17391304347826, 0.25434782608696, 0.090909090909091
35011, 0.17391304347826, 0.25434782608696, 0.13636363636364
35012, 0.17391304347826, 0.25434782608696, 0.18181818181818
35013, 0.17391304347826, 0.25434782608696, 0.22727272727273
35014, 0.17391304347826, 0.25434782608696, 0.27272727272727
35015, 0.17391304347826, 0.25434782608696, 0.31818181818182
35016, 0.17391304347826, 0.25434782608696, 0.36363636363636
35017, 0.17391304347826, 0.25434782608696, 0.40909090909091
35018, 0.17391304347826, 0.25434782608696, 0.45454545454545
35019, 0.1304347826087, 0.25434782608696, 0.045454545454545
35020, 0.1304347826087, 0.25434782608696, 0.090909090909091
35021, 0.1304347826087, 0.25434782608696, 0.13636363636364
35022, 0.1304347826087, 0.25434782608696, 0.18181818181818
35023, 0.1304347826087, 0.25434782608696, 0.22727272727273
35024, 0.1304347826087, 0.25434782608696, 0.27272727272727
35025, 0.1304347826087, 0.25434782608696, 0.31818181818182
35026, 0.1304347826087, 0.25434782608696, 0.36363636363636
35027, 0.1304347826087, 0.25434782608696, 0.40909090909091
35028, 0.1304347826087, 0.25434782608696, 0.45454545454545
35029, 0.08695652173913, 0.25434782608696, 0.045454545454545
35030, 0.08695652173913, 0.25434782608696, 0.090909090909091
35031, 0.08695652173913, 0.25434782608696, 0.13636363636364
35032, 0.08695652173913, 0.25434782608696, 0.18181818181818
35033, 0.08695652173913, 0.25434782608696, 0.22727272727273
35034, 0.08695652173913, 0.25434782608696, 0.27272727272727
35035, 0.08695652173913, 0.25434782608696, 0.31818181818182
35036, 0.08695652173913, 0.25434782608696, 0.36363636363636
35037, 0.08695652173913, 0.25434782608696, 0.40909090909091
35038, 0.08695652173913, 0.25434782608696, 0.45454545454545
35039, 0.043478260869565, 0.25434782608696, 0.045454545454545
35040, 0.043478260869565, 0.25434782608696, 0.090909090909091
35041, 0.043478260869565, 0.25434782608696, 0.13636363636364
35042, 0.043478260869565, 0.25434782608696, 0.18181818181818
35043, 0.043478260869565, 0.25434782608696, 0.22727272727273
35044, 0.043478260869565, 0.25434782608696, 0.27272727272727
35045, 0.043478260869565, 0.25434782608696, 0.31818181818182
35046, 0.043478260869565, 0.25434782608696, 0.36363636363636
35047, 0.043478260869565, 0.25434782608696, 0.40909090909091
35048, 0.043478260869565, 0.25434782608696, 0.45454545454545
35049, 0.95652173913043, 0.30652173913043, 0.045454545454545
35050, 0.95652173913043, 0.30652173913043, 0.090909090909091
35051, 0.95652173913044, 0.30652173913043, 0.13636363636364
35052, 0.95652173913044, 0.30652173913043, 0.18181818181818
35053, 0.95652173913044, 0.30652173913043, 0.22727272727273
35054, 0.95652173913044, 0.30652173913043, 0.27272727272727
35055, 0.95652173913044, 0.30652173913043, 0.31818181818182
35056, 0.95652173913043, 0.30652173913043, 0.36363636363636
35057, 0.95652173913044, 0.30652173913043, 0.40909090909091
35058, 0.95652173913044, 0.30652173913043, 0.45454545454545
35059, 0.91304347826087, 0.30652173913043, 0.045454545454545
35060, 0.91304347826087, 0.30652173913043, 0.090909090909091
35061, 0.91304347826087, 0.30652173913043, 0.13636363636364
35062, 0.91304347826087, 0.30652173913043, 0.18181818181818
35063, 0.91304347826087, 0.30652173913043, 0.22727272727273
35064, 0.91304347826087, 0.30652173913043, 0.27272727272727
35065, 0.91304347826087, 0.30652173913043, 0.31818181818182
35066, 0.91304347826087, 0.30652173913043, 0.36363636363636
35067, 0.91304347826087, 0.30652173913043, 0.40909090909091
35068, 0.91304347826087, 0.30652173913043, 0.45454545454545
35069, 0.8695652173913, 0.30652173913043, 0.045454545454545
35070, 0.8695652173913, 0.30652173913043, 0.090909090909091
35071, 0.8695652173913, 0.30652173913043, 0.13636363636364
35072, 0.8695652173913, 0.30652173913043, 0.18181818181818
35073, 0.8695652173913, 0.30652173913043, 0.22727272727273
35074, 0.8695652173913, 0.30652173913043, 0.27272727272727
35075, 0.8695652173913, 0.30652173913043, 0.31818181818182
35076, 0.8695652173913, 0.30652173913043, 0.36363636363636
35077, 0.8695652173913, 0.30652173913043, 0.40909090909091
35078, 0.8695652173913, 0.30652173913043, 0.45454545454545
35079, 0.82608695652174, 0.30652173913043, 0.045454545454545
35080, 0.82608695652174, 0.30652173913043, 0.090909090909091
35081, 0.82608695652174, 0.30652173913043, 0.13636363636364
35082, 0.82608695652174, 0.30652173913043, 0.18181818181818
35083, 0.82608695652174, 0.30652173913043, 0.22727272727273
35084, 0.82608695652174, 0.30652173913043, 0.27272727272727
35085, 0.82608695652174, 0.30652173913043, 0.31818181818182
35086, 0.82608695652174, 0.30652173913043, 0.36363636363636
35087, 0.82608695652174, 0.30652173913043, 0.40909090909091
35088, 0.82608695652174, 0.30652173913043, 0.45454545454545
35089, 0.78260869565217, 0.30652173913043, 0.045454545454545
35090, 0.78260869565217, 0.30652173913043, 0.090909090909091
35091, 0.78260869565217, 0.30652173913043, 0.13636363636364
35092, 0.78260869565217, 0.30652173913043, 0.18181818181818
35093, 0.78260869565217, 0.30652173913043, 0.22727272727273
35094, 0.78260869565217, 0.30652173913043, 0.27272727272727
35095, 0.78260869565217, 0.30652173913043, 0.31818181818182
35096, 0.78260869565217, 0.30652173913043, 0.36363636363636
35097, 0.78260869565217, 0.30652173913043, 0.40909090909091
35098, 0.78260869565217, 0.30652173913043, 0.45454545454545
35099, 0.73913043478261, 0.30652173913043, 0.045454545454545
35100, 0.73913043478261, 0.30652173913043, 0.090909090909091
35101, 0.73913043478261, 0.30652173913043, 0.13636363636364
35102, 0.73913043478261, 0.30652173913043, 0.18181818181818
35103, 0.73913043478261, 0.30652173913043, 0.22727272727273
35104, 0.73913043478261, 0.30652173913043, 0.27272727272727
35105, 0.73913043478261, 0.30652173913043, 0.31818181818182
35106, 0.73913043478261, 0.30652173913043, 0.36363636363636
35107, 0.73913043478261, 0.30652173913043, 0.40909090909091
35108, 0.73913043478261, 0.30652173913043, 0.45454545454545
35109, 0.69565217391304, 0.30652173913043, 0.045454545454545
35110, 0.69565217391304, 0.30652173913043, 0.090909090909091
35111, 0.69565217391304, 0.30652173913043, 0.13636363636364
35112, 0.69565217391304, 0.30652173913043, 0.18181818181818
35113, 0.69565217391304, 0.30652173913043, 0.22727272727273
35114, 0.69565217391304, 0.30652173913043, 0.27272727272727
35115, 0.69565217391304, 0.30652173913043, 0.31818181818182
35116, 0.69565217391304, 0.30652173913043, 0.36363636363636
35117, 0.69565217391304, 0.30652173913043, 0.40909090909091
35118, 0.69565217391304, 0.30652173913043, 0.45454545454545
35119, 0.65217391304348, 0.30652173913043, 0.045454545454545
35120, 0.65217391304348, 0.30652173913043, 0.090909090909091
35121, 0.65217391304348, 0.30652173913043, 0.13636363636364
35122, 0.65217391304348, 0.30652173913043, 0.18181818181818
35123, 0.65217391304348, 0.30652173913043, 0.22727272727273
35124, 0.65217391304348, 0.30652173913043, 0.27272727272727
35125, 0.65217391304348, 0.30652173913043, 0.31818181818182
35126, 0.65217391304348, 0.30652173913043, 0.36363636363636
35127, 0.65217391304348, 0.30652173913043, 0.40909090909091
35128, 0.65217391304348, 0.30652173913043, 0.45454545454545
35129, 0.60869565217391, 0.30652173913043, 0.045454545454545
35130, 0.60869565217391, 0.30652173913043, 0.090909090909091
35131, 0.60869565217391, 0.30652173913043, 0.13636363636364
35132, 0.60869565217391, 0.30652173913043, 0.18181818181818
35133, 0.60869565217391, 0.30652173913043, 0.22727272727273
35134, 0.60869565217391, 0.30652173913043, 0.27272727272727
35135, 0.60869565217391, 0.30652173913043, 0.31818181818182
35136, 0.60869565217391, 0.30652173913043, 0.36363636363636
35137, 0.60869565217391, 0.30652173913043, 0.40909090909091
35138, 0.60869565217391, 0.30652173913043, 0.45454545454545
35139, 0.56521739130435, 0.30652173913043, 0.045454545454545
35140, 0.56521739130435, 0.30652173913043, 0.090909090909091
35141, 0.56521739130435, 0.30652173913043, 0.13636363636364
35142, 0.56521739130435, 0.30652173913043, 0.18181818181818
35143, 0.56521739130435, 0.30652173913043, 0.22727272727273
35144, 0.56521739130435, 0.30652173913043, 0.27272727272727
35145, 0.56521739130435, 0.30652173913043, 0.31818181818182
35146, 0.56521739130435, 0.30652173913043, 0.36363636363636
35147, 0.56521739130435, 0.30652173913043, 0.40909090909091
35148, 0.56521739130435, 0.30652173913043, 0.45454545454545
35149, 0.52173913043478, 0.30652173913043, 0.045454545454545
35150, 0.52173913043478, 0.30652173913043, 0.090909090909091
35151, 0.52173913043478, 0.30652173913043, 0.13636363636364
35152, 0.52173913043478, 0.30652173913043, 0.18181818181818
35153, 0.52173913043478, 0.30652173913043, 0.22727272727273
35154, 0.52173913043478, 0.30652173913043, 0.27272727272727
35155, 0.52173913043478, 0.30652173913043, 0.31818181818182
35156, 0.52173913043478, 0.30652173913043, 0.36363636363636
35157, 0.52173913043478, 0.30652173913043, 0.40909090909091
35158, 0.52173913043478, 0.30652173913043, 0.45454545454545
35159, 0.47826086956522, 0.30652173913043, 0.045454545454545
35160, 0.47826086956522, 0.30652173913043, 0.090909090909091
35161, 0.47826086956522, 0.30652173913043, 0.13636363636364
35162, 0.47826086956522, 0.30652173913043, 0.18181818181818
35163, 0.47826086956522, 0.30652173913043, 0.22727272727273
35164, 0.47826086956522, 0.30652173913043, 0.27272727272727
35165, 0.47826086956522, 0.30652173913043, 0.31818181818182
35166, 0.47826086956522, 0.30652173913043, 0.36363636363636
35167, 0.47826086956522, 0.30652173913043, 0.40909090909091
35168, 0.47826086956522, 0.30652173913043, 0.45454545454545
35169, 0.43478260869565, 0.30652173913043, 0.045454545454545
35170, 0.43478260869565, 0.30652173913043, 0.090909090909091
35171, 0.43478260869565, 0.30652173913043, 0.13636363636364
35172, 0.43478260869565, 0.30652173913043, 0.18181818181818
35173, 0.43478260869565, 0.30652173913043, 0.22727272727273
35174, 0.43478260869565, 0.30652173913043, 0.27272727272727
35175, 0.43478260869565, 0.30652173913043, 0.31818181818182
35176, 0.43478260869565, 0.30652173913043, 0.36363636363636
35177, 0.43478260869565, 0.30652173913043, 0.40909090909091
35178, 0.43478260869565, 0.30652173913043, 0.45454545454545
35179, 0.39130434782609, 0.30652173913043, 0.045454545454545
35180, 0.39130434782609, 0.30652173913043, 0.090909090909091
35181, 0.39130434782609, 0.30652173913043, 0.13636363636364
35182, 0.39130434782609, 0.30652173913043, 0.18181818181818
35183, 0.39130434782609, 0.30652173913043, 0.22727272727273
35184, 0.39130434782609, 0.30652173913043, 0.27272727272727
35185, 0.39130434782609, 0.30652173913043, 0.31818181818182
35186, 0.39130434782609, 0.30652173913043, 0.36363636363636
35187, 0.39130434782609, 0.30652173913043, 0.40909090909091
35188, 0.39130434782609, 0.30652173913043, 0.45454545454545
35189, 0.34782608695652, 0.30652173913043, 0.045454545454545
35190, 0.34782608695652, 0.30652173913043, 0.090909090909091
35191, 0.34782608695652, 0.30652173913043, 0.13636363636364
35192, 0.34782608695652, 0.30652173913043, 0.18181818181818
35193, 0.34782608695652, 0.30652173913043, 0.22727272727273
35194, 0.34782608695652, 0.30652173913043, 0.27272727272727
35195, 0.34782608695652, 0.30652173913043, 0.31818181818182
35196, 0.34782608695652, 0.30652173913043, 0.36363636363636
35197, 0.34782608695652, 0.30652173913043, 0.40909090909091
35198, 0.34782608695652, 0.30652173913043, 0.45454545454545
35199, 0.30434782608696, 0.30652173913043, 0.045454545454545
35200, 0.30434782608696, 0.30652173913043, 0.090909090909091
35201, 0.30434782608696, 0.30652173913043, 0.13636363636364
35202, 0.30434782608696, 0.30652173913043, 0.18181818181818
35203, 0.30434782608696, 0.30652173913043, 0.22727272727273
35204, 0.30434782608696, 0.30652173913043, 0.27272727272727
35205, 0.30434782608696, 0.30652173913043, 0.31818181818182
35206, 0.30434782608696, 0.30652173913043, 0.36363636363636
35207, 0.30434782608696, 0.30652173913043, 0.40909090909091
35208, 0.30434782608696, 0.30652173913043, 0.45454545454545
35209, 0.26086956521739, 0.30652173913043, 0.045454545454545
35210, 0.26086956521739, 0.30652173913043, 0.090909090909091
35211, 0.26086956521739, 0.30652173913043, 0.13636363636364
35212, 0.26086956521739, 0.30652173913043, 0.18181818181818
35213, 0.26086956521739, 0.30652173913043, 0.22727272727273
35214, 0.26086956521739, 0.30652173913043, 0.27272727272727
35215, 0.26086956521739, 0.30652173913043, 0.31818181818182
35216, 0.26086956521739, 0.30652173913043, 0.36363636363636
35217, 0.26086956521739, 0.30652173913043, 0.40909090909091
35218, 0.26086956521739, 0.30652173913043, 0.45454545454545
35219, 0.21739130434783, 0.30652173913043, 0.045454545454545
35220, 0.21739130434783, 0.30652173913043, 0.090909090909091
35221, 0.21739130434783, 0.30652173913043, 0.13636363636364
35222, 0.21739130434783, 0.30652173913043, 0.18181818181818
35223, 0.21739130434783, 0.30652173913043, 0.22727272727273
35224, 0.21739130434783, 0.30652173913043, 0.27272727272727
35225, 0.21739130434783, 0.30652173913043, 0.31818181818182
35226, 0.21739130434783, 0.30652173913043, 0.36363636363636
35227, 0.21739130434783, 0.30652173913043, 0.40909090909091
35228, 0.21739130434783, 0.30652173913043, 0.45454545454545
35229, 0.17391304347826, 0.30652173913043, 0.045454545454545
35230, 0.17391304347826, 0.30652173913043, 0.090909090909091
35231, 0.17391304347826, 0.30652173913043, 0.13636363636364
35232, 0.17391304347826, 0.30652173913043, 0.18181818181818
35233, 0.17391304347826, 0.30652173913043, 0.22727272727273
35234, 0.17391304347826, 0.30652173913043, 0.27272727272727
35235, 0.17391304347826, 0.30652173913043, 0.31818181818182
35236, 0.17391304347826, 0.30652173913043, 0.36363636363636
35237, 0.17391304347826, 0.30652173913043, 0.40909090909091
35238, 0.17391304347826, 0.30652173913043, 0.45454545454545
35239, 0.1304347826087, 0.30652173913043, 0.045454545454545
35240, 0.1304347826087, 0.30652173913043, 0.090909090909091
35241, 0.1304347826087, 0.30652173913043, 0.13636363636364
35242, 0.1304347826087, 0.30652173913043, 0.18181818181818
35243, 0.1304347826087, 0.30652173913043, 0.22727272727273
35244, 0.1304347826087, 0.30652173913043, 0.27272727272727
35245, 0.1304347826087, 0.30652173913043, 0.31818181818182
35246, 0.1304347826087, 0.30652173913043, 0.36363636363636
35247, 0.1304347826087, 0.30652173913043, 0.40909090909091
35248, 0.1304347826087, 0.30652173913043, 0.45454545454545
35249, 0.08695652173913, 0.30652173913043, 0.045454545454545
35250, 0.08695652173913, 0.30652173913043, 0.090909090909091
35251, 0.08695652173913, 0.30652173913043, 0.13636363636364
35252, 0.08695652173913, 0.30652173913043, 0.18181818181818
35253, 0.08695652173913, 0.30652173913043, 0.22727272727273
35254, 0.08695652173913, 0.30652173913043, 0.27272727272727
35255, 0.08695652173913, 0.30652173913043, 0.31818181818182
35256, 0.08695652173913, 0.30652173913043, 0.36363636363636
35257, 0.08695652173913, 0.30652173913043, 0.40909090909091
35258, 0.08695652173913, 0.30652173913043, 0.45454545454545
35259, 0.043478260869565, 0.30652173913043, 0.045454545454545
35260, 0.043478260869565, 0.30652173913043, 0.090909090909091
35261, 0.043478260869565, 0.30652173913043, 0.13636363636364
35262, 0.043478260869565, 0.30652173913043, 0.18181818181818
35263, 0.043478260869565, 0.30652173913043, 0.22727272727273
35264, 0.043478260869565, 0.30652173913043, 0.27272727272727
35265, 0.043478260869565, 0.30652173913043, 0.31818181818182
35266, 0.043478260869565, 0.30652173913043, 0.36363636363636
35267, 0.043478260869565, 0.30652173913043, 0.40909090909091
35268, 0.043478260869565, 0.30652173913043, 0.45454545454545
35269, 0.95652173913043, 0.35869565217391, 0.045454545454545
35270, 0.95652173913044, 0.35869565217391, 0.090909090909091
35271, 0.95652173913044, 0.35869565217391, 0.13636363636364
35272, 0.95652173913044, 0.35869565217391, 0.18181818181818
35273, 0.95652173913044, 0.35869565217391, 0.22727272727273
35274, 0.95652173913043, 0.35869565217391, 0.27272727272727
35275, 0.95652173913044, 0.35869565217391, 0.31818181818182
35276, 0.95652173913043, 0.35869565217391, 0.36363636363636
35277, 0.95652173913043, 0.35869565217391, 0.40909090909091
35278, 0.95652173913044, 0.35869565217391, 0.45454545454545
35279, 0.91304347826087, 0.35869565217391, 0.045454545454545
35280, 0.91304347826087, 0.35869565217391, 0.090909090909091
35281, 0.91304347826087, 0.35869565217391, 0.13636363636364
35282, 0.91304347826087, 0.35869565217391, 0.18181818181818
35283, 0.91304347826087, 0.35869565217391, 0.22727272727273
35284, 0.91304347826087, 0.35869565217391, 0.27272727272727
35285, 0.91304347826087, 0.35869565217391, 0.31818181818182
35286, 0.91304347826087, 0.35869565217391, 0.36363636363636
35287, 0.91304347826087, 0.35869565217391, 0.40909090909091
35288, 0.91304347826087, 0.35869565217391, 0.45454545454545
35289, 0.8695652173913, 0.35869565217391, 0.045454545454545
35290, 0.8695652173913, 0.35869565217391, 0.090909090909091
35291, 0.8695652173913, 0.35869565217391, 0.13636363636364
35292, 0.8695652173913, 0.35869565217391, 0.18181818181818
35293, 0.8695652173913, 0.35869565217391, 0.22727272727273
35294, 0.8695652173913, 0.35869565217391, 0.27272727272727
35295, 0.8695652173913, 0.35869565217391, 0.31818181818182
35296, 0.8695652173913, 0.35869565217391, 0.36363636363636
35297, 0.8695652173913, 0.35869565217391, 0.40909090909091
35298, 0.8695652173913, 0.35869565217391, 0.45454545454545
35299, 0.82608695652174, 0.35869565217391, 0.045454545454545
35300, 0.82608695652174, 0.35869565217391, 0.090909090909091
35301, 0.82608695652174, 0.35869565217391, 0.13636363636364
35302, 0.82608695652174, 0.35869565217391, 0.18181818181818
35303, 0.82608695652174, 0.35869565217391, 0.22727272727273
35304, 0.82608695652174, 0.35869565217391, 0.27272727272727
35305, 0.82608695652174, 0.35869565217391, 0.31818181818182
35306, 0.82608695652174, 0.35869565217391, 0.36363636363636
35307, 0.82608695652174, 0.35869565217391, 0.40909090909091
35308, 0.82608695652174, 0.35869565217391, 0.45454545454545
35309, 0.78260869565217, 0.35869565217391, 0.045454545454545
35310, 0.78260869565217, 0.35869565217391, 0.090909090909091
35311, 0.78260869565217, 0.35869565217391, 0.13636363636364
35312, 0.78260869565217, 0.35869565217391, 0.18181818181818
35313, 0.78260869565217, 0.35869565217391, 0.22727272727273
35314, 0.78260869565217, 0.35869565217391, 0.27272727272727
35315, 0.78260869565217, 0.35869565217391, 0.31818181818182
35316, 0.78260869565217, 0.35869565217391, 0.36363636363636
35317, 0.78260869565217, 0.35869565217391, 0.40909090909091
35318, 0.78260869565217, 0.35869565217391, 0.45454545454545
35319, 0.73913043478261, 0.35869565217391, 0.045454545454545
35320, 0.73913043478261, 0.35869565217391, 0.090909090909091
35321, 0.73913043478261, 0.35869565217391, 0.13636363636364
35322, 0.73913043478261, 0.35869565217391, 0.18181818181818
35323, 0.73913043478261, 0.35869565217391, 0.22727272727273
35324, 0.73913043478261, 0.35869565217391, 0.27272727272727
35325, 0.73913043478261, 0.35869565217391, 0.31818181818182
35326, 0.73913043478261, 0.35869565217391, 0.36363636363636
35327, 0.73913043478261, 0.35869565217391, 0.40909090909091
35328, 0.73913043478261, 0.35869565217391, 0.45454545454545
35329, 0.69565217391304, 0.35869565217391, 0.045454545454545
35330, 0.69565217391304, 0.35869565217391, 0.090909090909091
35331, 0.69565217391304, 0.35869565217391, 0.13636363636364
35332, 0.69565217391304, 0.35869565217391, 0.18181818181818
35333, 0.69565217391304, 0.35869565217391, 0.22727272727273
35334, 0.69565217391304, 0.35869565217391, 0.27272727272727
35335, 0.69565217391304, 0.35869565217391, 0.31818181818182
35336, 0.69565217391304, 0.35869565217391, 0.36363636363636
35337, 0.69565217391304, 0.35869565217391, 0.40909090909091
35338, 0.69565217391304, 0.35869565217391, 0.45454545454545
35339, 0.65217391304348, 0.35869565217391, 0.045454545454545
35340, 0.65217391304348, 0.35869565217391, 0.090909090909091
35341, 0.65217391304348, 0.35869565217391, 0.13636363636364
35342, 0.65217391304348, 0.35869565217391, 0.18181818181818
35343, 0.65217391304348, 0.35869565217391, 0.22727272727273
35344, 0.65217391304348, 0.35869565217391, 0.27272727272727
35345, 0.65217391304348, 0.35869565217391, 0.31818181818182
35346, 0.65217391304348, 0.35869565217391, 0.36363636363636
35347, 0.65217391304348, 0.35869565217391, 0.40909090909091
35348, 0.65217391304348, 0.35869565217391, 0.45454545454545
35349, 0.60869565217391, 0.35869565217391, 0.045454545454545
35350, 0.60869565217391, 0.35869565217391, 0.090909090909091
35351, 0.60869565217391, 0.35869565217391, 0.13636363636364
35352, 0.60869565217391, 0.35869565217391, 0.18181818181818
35353, 0.60869565217391, 0.35869565217391, 0.22727272727273
35354, 0.60869565217391, 0.35869565217391, 0.27272727272727
35355, 0.60869565217391, 0.35869565217391, 0.31818181818182
35356, 0.60869565217391, 0.35869565217391, 0.36363636363636
35357, 0.60869565217391, 0.35869565217391, 0.40909090909091
35358, 0.60869565217391, 0.35869565217391, 0.45454545454545
35359, 0.56521739130435, 0.35869565217391, 0.045454545454545
35360, 0.56521739130435, 0.35869565217391, 0.090909090909091
35361, 0.56521739130435, 0.35869565217391, 0.13636363636364
35362, 0.56521739130435, 0.35869565217391, 0.18181818181818
35363, 0.56521739130435, 0.35869565217391, 0.22727272727273
35364, 0.56521739130435, 0.35869565217391, 0.27272727272727
35365, 0.56521739130435, 0.35869565217391, 0.31818181818182
35366, 0.56521739130435, 0.35869565217391, 0.36363636363636
35367, 0.56521739130435, 0.35869565217391, 0.40909090909091
35368, 0.56521739130435, 0.35869565217391, 0.45454545454545
35369, 0.52173913043478, 0.35869565217391, 0.045454545454545
35370, 0.52173913043478, 0.35869565217391, 0.090909090909091
35371, 0.52173913043478, 0.35869565217391, 0.13636363636364
35372, 0.52173913043478, 0.35869565217391, 0.18181818181818
35373, 0.52173913043478, 0.35869565217391, 0.22727272727273
35374, 0.52173913043478, 0.35869565217391, 0.27272727272727
35375, 0.52173913043478, 0.35869565217391, 0.31818181818182
35376, 0.52173913043478, 0.35869565217391, 0.36363636363636
35377, 0.52173913043478, 0.35869565217391, 0.40909090909091
35378, 0.52173913043478, 0.35869565217391, 0.45454545454545
35379, 0.47826086956522, 0.35869565217391, 0.045454545454545
35380, 0.47826086956522, 0.35869565217391, 0.090909090909091
35381, 0.47826086956522, 0.35869565217391, 0.13636363636364
35382, 0.47826086956522, 0.35869565217391, 0.18181818181818
35383, 0.47826086956522, 0.35869565217391, 0.22727272727273
35384, 0.47826086956522, 0.35869565217391, 0.27272727272727
35385, 0.47826086956522, 0.35869565217391, 0.31818181818182
35386, 0.47826086956522, 0.35869565217391, 0.36363636363636
35387, 0.47826086956522, 0.35869565217391, 0.40909090909091
35388, 0.47826086956522, 0.35869565217391, 0.45454545454545
35389, 0.43478260869565, 0.35869565217391, 0.045454545454545
35390, 0.43478260869565, 0.35869565217391, 0.090909090909091
35391, 0.43478260869565, 0.35869565217391, 0.13636363636364
35392, 0.43478260869565, 0.35869565217391, 0.18181818181818
35393, 0.43478260869565, 0.35869565217391, 0.22727272727273
35394, 0.43478260869565, 0.35869565217391, 0.27272727272727
35395, 0.43478260869565, 0.35869565217391, 0.31818181818182
35396, 0.43478260869565, 0.35869565217391, 0.36363636363636
35397, 0.43478260869565, 0.35869565217391, 0.40909090909091
35398, 0.43478260869565, 0.35869565217391, 0.45454545454545
35399, 0.39130434782609, 0.35869565217391, 0.045454545454545
35400, 0.39130434782609, 0.35869565217391, 0.090909090909091
35401, 0.39130434782609, 0.35869565217391, 0.13636363636364
35402, 0.39130434782609, 0.35869565217391, 0.18181818181818
35403, 0.39130434782609, 0.35869565217391, 0.22727272727273
35404, 0.39130434782609, 0.35869565217391, 0.27272727272727
35405, 0.39130434782609, 0.35869565217391, 0.31818181818182
35406, 0.39130434782609, 0.35869565217391, 0.36363636363636
35407, 0.39130434782609, 0.35869565217391, 0.40909090909091
35408, 0.39130434782609, 0.35869565217391, 0.45454545454545
35409, 0.34782608695652, 0.35869565217391, 0.045454545454545
35410, 0.34782608695652, 0.35869565217391, 0.090909090909091
35411, 0.34782608695652, 0.35869565217391, 0.13636363636364
35412, 0.34782608695652, 0.35869565217391, 0.18181818181818
35413, 0.34782608695652, 0.35869565217391, 0.22727272727273
35414, 0.34782608695652, 0.35869565217391, 0.27272727272727
35415, 0.34782608695652, 0.35869565217391, 0.31818181818182
35416, 0.34782608695652, 0.35869565217391, 0.36363636363636
35417, 0.34782608695652, 0.35869565217391, 0.40909090909091
35418, 0.34782608695652, 0.35869565217391, 0.45454545454545
35419, 0.30434782608696, 0.35869565217391, 0.045454545454545
35420, 0.30434782608696, 0.35869565217391, 0.090909090909091
35421, 0.30434782608696, 0.35869565217391, 0.13636363636364
35422, 0.30434782608696, 0.35869565217391, 0.18181818181818
35423, 0.30434782608696, 0.35869565217391, 0.22727272727273
35424, 0.30434782608696, 0.35869565217391, 0.27272727272727
35425, 0.30434782608696, 0.35869565217391, 0.31818181818182
35426, 0.30434782608696, 0.35869565217391, 0.36363636363636
35427, 0.30434782608696, 0.35869565217391, 0.40909090909091
35428, 0.30434782608696, 0.35869565217391, 0.45454545454545
35429, 0.26086956521739, 0.35869565217391, 0.045454545454545
35430, 0.26086956521739, 0.35869565217391, 0.090909090909091
35431, 0.26086956521739, 0.35869565217391, 0.13636363636364
35432, 0.26086956521739, 0.35869565217391, 0.18181818181818
35433, 0.26086956521739, 0.35869565217391, 0.22727272727273
35434, 0.26086956521739, 0.35869565217391, 0.27272727272727
35435, 0.26086956521739, 0.35869565217391, 0.31818181818182
35436, 0.26086956521739, 0.35869565217391, 0.36363636363636
35437, 0.26086956521739, 0.35869565217391, 0.40909090909091
35438, 0.26086956521739, 0.35869565217391, 0.45454545454545
35439, 0.21739130434783, 0.35869565217391, 0.045454545454545
35440, 0.21739130434783, 0.35869565217391, 0.090909090909091
35441, 0.21739130434783, 0.35869565217391, 0.13636363636364
35442, 0.21739130434783, 0.35869565217391, 0.18181818181818
35443, 0.21739130434783, 0.35869565217391, 0.22727272727273
35444, 0.21739130434783, 0.35869565217391, 0.27272727272727
35445, 0.21739130434783, 0.35869565217391, 0.31818181818182
35446, 0.21739130434783, 0.35869565217391, 0.36363636363636
35447, 0.21739130434783, 0.35869565217391, 0.40909090909091
35448, 0.21739130434783, 0.35869565217391, 0.45454545454545
35449, 0.17391304347826, 0.35869565217391, 0.045454545454545
35450, 0.17391304347826, 0.35869565217391, 0.090909090909091
35451, 0.17391304347826, 0.35869565217391, 0.13636363636364
35452, 0.17391304347826, 0.35869565217391, 0.18181818181818
35453, 0.17391304347826, 0.35869565217391, 0.22727272727273
35454, 0.17391304347826, 0.35869565217391, 0.27272727272727
35455, 0.17391304347826, 0.35869565217391, 0.31818181818182
35456, 0.17391304347826, 0.35869565217391, 0.36363636363636
35457, 0.17391304347826, 0.35869565217391, 0.40909090909091
35458, 0.17391304347826, 0.35869565217391, 0.45454545454545
35459, 0.1304347826087, 0.35869565217391, 0.045454545454545
35460, 0.1304347826087, 0.35869565217391, 0.090909090909091
35461, 0.1304347826087, 0.35869565217391, 0.13636363636364
35462, 0.1304347826087, 0.35869565217391, 0.18181818181818
35463, 0.1304347826087, 0.35869565217391, 0.22727272727273
35464, 0.1304347826087, 0.35869565217391, 0.27272727272727
35465, 0.1304347826087, 0.35869565217391, 0.31818181818182
35466, 0.1304347826087, 0.35869565217391, 0.36363636363636
35467, 0.1304347826087, 0.35869565217391, 0.40909090909091
35468, 0.1304347826087, 0.35869565217391, 0.45454545454545
35469, 0.08695652173913, 0.35869565217391, 0.045454545454545
35470, 0.08695652173913, 0.35869565217391, 0.090909090909091
35471, 0.08695652173913, 0.35869565217391, 0.13636363636364
35472, 0.08695652173913, 0.35869565217391, 0.18181818181818
35473, 0.08695652173913, 0.35869565217391, 0.22727272727273
35474, 0.08695652173913, 0.35869565217391, 0.27272727272727
35475, 0.08695652173913, 0.35869565217391, 0.31818181818182
35476, 0.08695652173913, 0.35869565217391, 0.36363636363636
35477, 0.08695652173913, 0.35869565217391, 0.40909090909091
35478, 0.08695652173913, 0.35869565217391, 0.45454545454545
35479, 0.043478260869565, 0.35869565217391, 0.045454545454545
35480, 0.043478260869565, 0.35869565217391, 0.090909090909091
35481, 0.043478260869565, 0.35869565217391, 0.13636363636364
35482, 0.043478260869565, 0.35869565217391, 0.18181818181818
35483, 0.043478260869565, 0.35869565217391, 0.22727272727273
35484, 0.043478260869565, 0.35869565217391, 0.27272727272727
35485, 0.043478260869565, 0.35869565217391, 0.31818181818182
35486, 0.043478260869565, 0.35869565217391, 0.36363636363636
35487, 0.043478260869565, 0.35869565217391, 0.40909090909091
35488, 0.043478260869565, 0.35869565217391, 0.45454545454545
35489, 0.95652173913043, 0.41086956521739, 0.045454545454545
35490, 0.95652173913043, 0.41086956521739, 0.090909090909091
35491, 0.95652173913044, 0.41086956521739, 0.13636363636364
35492, 0.95652173913044, 0.41086956521739, 0.18181818181818
35493, 0.95652173913044, 0.41086956521739, 0.22727272727273
35494, 0.95652173913044, 0.41086956521739, 0.27272727272727
35495, 0.95652173913044, 0.41086956521739, 0.31818181818182
35496, 0.95652173913043, 0.41086956521739, 0.36363636363636
35497, 0.95652173913043, 0.41086956521739, 0.40909090909091
35498, 0.95652173913044, 0.41086956521739, 0.45454545454545
35499, 0.91304347826087, 0.41086956521739, 0.045454545454545
35500, 0.91304347826087, 0.41086956521739, 0.090909090909091
35501, 0.91304347826087, 0.41086956521739, 0.13636363636364
35502, 0.91304347826087, 0.41086956521739, 0.18181818181818
35503, 0.91304347826087, 0.41086956521739, 0.22727272727273
35504, 0.91304347826087, 0.41086956521739, 0.27272727272727
35505, 0.91304347826087, 0.41086956521739, 0.31818181818182
35506, 0.91304347826087, 0.41086956521739, 0.36363636363636
35507, 0.91304347826087, 0.41086956521739, 0.40909090909091
35508, 0.91304347826087, 0.41086956521739, 0.45454545454545
35509, 0.8695652173913, 0.41086956521739, 0.045454545454545
35510, 0.8695652173913, 0.41086956521739, 0.090909090909091
35511, 0.8695652173913, 0.41086956521739, 0.13636363636364
35512, 0.8695652173913, 0.41086956521739, 0.18181818181818
35513, 0.8695652173913, 0.41086956521739, 0.22727272727273
35514, 0.8695652173913, 0.41086956521739, 0.27272727272727
35515, 0.8695652173913, 0.41086956521739, 0.31818181818182
35516, 0.8695652173913, 0.41086956521739, 0.36363636363636
35517, 0.8695652173913, 0.41086956521739, 0.40909090909091
35518, 0.8695652173913, 0.41086956521739, 0.45454545454545
35519, 0.82608695652174, 0.41086956521739, 0.045454545454545
35520, 0.82608695652174, 0.41086956521739, 0.090909090909091
35521, 0.82608695652174, 0.41086956521739, 0.13636363636364
35522, 0.82608695652174, 0.41086956521739, 0.18181818181818
35523, 0.82608695652174, 0.41086956521739, 0.22727272727273
35524, 0.82608695652174, 0.41086956521739, 0.27272727272727
35525, 0.82608695652174, 0.41086956521739, 0.31818181818182
35526, 0.82608695652174, 0.41086956521739, 0.36363636363636
35527, 0.82608695652174, 0.41086956521739, 0.40909090909091
35528, 0.82608695652174, 0.41086956521739, 0.45454545454545
35529, 0.78260869565217, 0.41086956521739, 0.045454545454545
35530, 0.78260869565217, 0.41086956521739, 0.090909090909091
35531, 0.78260869565217, 0.41086956521739, 0.13636363636364
35532, 0.78260869565217, 0.41086956521739, 0.18181818181818
35533, 0.78260869565217, 0.41086956521739, 0.22727272727273
35534, 0.78260869565217, 0.41086956521739, 0.27272727272727
35535, 0.78260869565217, 0.41086956521739, 0.31818181818182
35536, 0.78260869565217, 0.41086956521739, 0.36363636363636
35537, 0.78260869565217, 0.41086956521739, 0.40909090909091
35538, 0.78260869565217, 0.41086956521739, 0.45454545454545
35539, 0.73913043478261, 0.41086956521739, 0.045454545454545
35540, 0.73913043478261, 0.41086956521739, 0.090909090909091
35541, 0.73913043478261, 0.41086956521739, 0.13636363636364
35542, 0.73913043478261, 0.41086956521739, 0.18181818181818
35543, 0.73913043478261, 0.41086956521739, 0.22727272727273
35544, 0.73913043478261, 0.41086956521739, 0.27272727272727
35545, 0.73913043478261, 0.41086956521739, 0.31818181818182
35546, 0.73913043478261, 0.41086956521739, 0.36363636363636
35547, 0.73913043478261, 0.41086956521739, 0.40909090909091
35548, 0.73913043478261, 0.41086956521739, 0.45454545454545
35549, 0.69565217391304, 0.41086956521739, 0.045454545454545
35550, 0.69565217391304, 0.41086956521739, 0.090909090909091
35551, 0.69565217391304, 0.41086956521739, 0.13636363636364
35552, 0.69565217391304, 0.41086956521739, 0.18181818181818
35553, 0.69565217391304, 0.41086956521739, 0.22727272727273
35554, 0.69565217391304, 0.41086956521739, 0.27272727272727
35555, 0.69565217391304, 0.41086956521739, 0.31818181818182
35556, 0.69565217391304, 0.41086956521739, 0.36363636363636
35557, 0.69565217391304, 0.41086956521739, 0.40909090909091
35558, 0.69565217391304, 0.41086956521739, 0.45454545454545
35559, 0.65217391304348, 0.41086956521739, 0.045454545454545
35560, 0.65217391304348, 0.41086956521739, 0.090909090909091
35561, 0.65217391304348, 0.41086956521739, 0.13636363636364
35562, 0.65217391304348, 0.41086956521739, 0.18181818181818
35563, 0.65217391304348, 0.41086956521739, 0.22727272727273
35564, 0.65217391304348, 0.41086956521739, 0.27272727272727
35565, 0.65217391304348, 0.41086956521739, 0.31818181818182
35566, 0.65217391304348, 0.41086956521739, 0.36363636363636
35567, 0.65217391304348, 0.41086956521739, 0.40909090909091
35568, 0.65217391304348, 0.41086956521739, 0.45454545454545
35569, 0.60869565217391, 0.41086956521739, 0.045454545454545
35570, 0.60869565217391, 0.41086956521739, 0.090909090909091
35571, 0.60869565217391, 0.41086956521739, 0.13636363636364
35572, 0.60869565217391, 0.41086956521739, 0.18181818181818
35573, 0.60869565217391, 0.41086956521739, 0.22727272727273
35574, 0.60869565217391, 0.41086956521739, 0.27272727272727
35575, 0.60869565217391, 0.41086956521739, 0.31818181818182
35576, 0.60869565217391, 0.41086956521739, 0.36363636363636
35577, 0.60869565217391, 0.41086956521739, 0.40909090909091
35578, 0.60869565217391, 0.41086956521739, 0.45454545454545
35579, 0.56521739130435, 0.41086956521739, 0.045454545454545
35580, 0.56521739130435, 0.41086956521739, 0.090909090909091
35581, 0.56521739130435, 0.41086956521739, 0.13636363636364
35582, 0.56521739130435, 0.41086956521739, 0.18181818181818
35583, 0.56521739130435, 0.41086956521739, 0.22727272727273
35584, 0.56521739130435, 0.41086956521739, 0.27272727272727
35585, 0.56521739130435, 0.41086956521739, 0.31818181818182
35586, 0.56521739130435, 0.41086956521739, 0.36363636363636
35587, 0.56521739130435, 0.41086956521739, 0.40909090909091
35588, 0.56521739130435, 0.41086956521739, 0.45454545454545
35589, 0.52173913043478, 0.41086956521739, 0.045454545454545
35590, 0.52173913043478, 0.41086956521739, 0.090909090909091
35591, 0.52173913043478, 0.41086956521739, 0.13636363636364
35592, 0.52173913043478, 0.41086956521739, 0.18181818181818
35593, 0.52173913043478, 0.41086956521739, 0.22727272727273
35594, 0.52173913043478, 0.41086956521739, 0.27272727272727
35595, 0.52173913043478, 0.41086956521739, 0.31818181818182
35596, 0.52173913043478, 0.41086956521739, 0.36363636363636
35597, 0.52173913043478, 0.41086956521739, 0.40909090909091
35598, 0.52173913043478, 0.41086956521739, 0.45454545454545
35599, 0.47826086956522, 0.41086956521739, 0.045454545454545
35600, 0.47826086956522, 0.41086956521739, 0.090909090909091
35601, 0.47826086956522, 0.41086956521739, 0.13636363636364
35602, 0.47826086956522, 0.41086956521739, 0.18181818181818
35603, 0.47826086956522, 0.41086956521739, 0.22727272727273
35604, 0.47826086956522, 0.41086956521739, 0.27272727272727
35605, 0.47826086956522, 0.41086956521739, 0.31818181818182
35606, 0.47826086956522, 0.41086956521739, 0.36363636363636
35607, 0.47826086956522, 0.41086956521739, 0.40909090909091
35608, 0.47826086956522, 0.41086956521739, 0.45454545454545
35609, 0.43478260869565, 0.41086956521739, 0.045454545454545
35610, 0.43478260869565, 0.41086956521739, 0.090909090909091
35611, 0.43478260869565, 0.41086956521739, 0.13636363636364
35612, 0.43478260869565, 0.41086956521739, 0.18181818181818
35613, 0.43478260869565, 0.41086956521739, 0.22727272727273
35614, 0.43478260869565, 0.41086956521739, 0.27272727272727
35615, 0.43478260869565, 0.41086956521739, 0.31818181818182
35616, 0.43478260869565, 0.41086956521739, 0.36363636363636
35617, 0.43478260869565, 0.41086956521739, 0.40909090909091
35618, 0.43478260869565, 0.41086956521739, 0.45454545454545
35619, 0.39130434782609, 0.41086956521739, 0.045454545454545
35620, 0.39130434782609, 0.41086956521739, 0.090909090909091
35621, 0.39130434782609, 0.41086956521739, 0.13636363636364
35622, 0.39130434782609, 0.41086956521739, 0.18181818181818
35623, 0.39130434782609, 0.41086956521739, 0.22727272727273
35624, 0.39130434782609, 0.41086956521739, 0.27272727272727
35625, 0.39130434782609, 0.41086956521739, 0.31818181818182
35626, 0.39130434782609, 0.41086956521739, 0.36363636363636
35627, 0.39130434782609, 0.41086956521739, 0.40909090909091
35628, 0.39130434782609, 0.41086956521739, 0.45454545454545
35629, 0.34782608695652, 0.41086956521739, 0.045454545454545
35630, 0.34782608695652, 0.41086956521739, 0.090909090909091
35631, 0.34782608695652, 0.41086956521739, 0.13636363636364
35632, 0.34782608695652, 0.41086956521739, 0.18181818181818
35633, 0.34782608695652, 0.41086956521739, 0.22727272727273
35634, 0.34782608695652, 0.41086956521739, 0.27272727272727
35635, 0.34782608695652, 0.41086956521739, 0.31818181818182
35636, 0.34782608695652, 0.41086956521739, 0.36363636363636
35637, 0.34782608695652, 0.41086956521739, 0.40909090909091
35638, 0.34782608695652, 0.41086956521739, 0.45454545454545
35639, 0.30434782608696, 0.41086956521739, 0.045454545454545
35640, 0.30434782608696, 0.41086956521739, 0.090909090909091
35641, 0.30434782608696, 0.41086956521739, 0.13636363636364
35642, 0.30434782608696, 0.41086956521739, 0.18181818181818
35643, 0.30434782608696, 0.41086956521739, 0.22727272727273
35644, 0.30434782608696, 0.41086956521739, 0.27272727272727
35645, 0.30434782608696, 0.41086956521739, 0.31818181818182
35646, 0.30434782608696, 0.41086956521739, 0.36363636363636
35647, 0.30434782608696, 0.41086956521739, 0.40909090909091
35648, 0.30434782608696, 0.41086956521739, 0.45454545454545
35649, 0.26086956521739, 0.41086956521739, 0.045454545454545
35650, 0.26086956521739, 0.41086956521739, 0.090909090909091
35651, 0.26086956521739, 0.41086956521739, 0.13636363636364
35652, 0.26086956521739, 0.41086956521739, 0.18181818181818
35653, 0.26086956521739, 0.41086956521739, 0.22727272727273
35654, 0.26086956521739, 0.41086956521739, 0.27272727272727
35655, 0.26086956521739, 0.41086956521739, 0.31818181818182
35656, 0.26086956521739, 0.41086956521739, 0.36363636363636
35657, 0.26086956521739, 0.41086956521739, 0.40909090909091
35658, 0.26086956521739, 0.41086956521739, 0.45454545454545
35659, 0.21739130434783, 0.41086956521739, 0.045454545454545
35660, 0.21739130434783, 0.41086956521739, 0.090909090909091
35661, 0.21739130434783, 0.41086956521739, 0.13636363636364
35662, 0.21739130434783, 0.41086956521739, 0.18181818181818
35663, 0.21739130434783, 0.41086956521739, 0.22727272727273
35664, 0.21739130434783, 0.41086956521739, 0.27272727272727
35665, 0.21739130434783, 0.41086956521739, 0.31818181818182
35666, 0.21739130434783, 0.41086956521739, 0.36363636363636
35667, 0.21739130434783, 0.41086956521739, 0.40909090909091
35668, 0.21739130434783, 0.41086956521739, 0.45454545454545
35669, 0.17391304347826, 0.41086956521739, 0.045454545454545
35670, 0.17391304347826, 0.41086956521739, 0.090909090909091
35671, 0.17391304347826, 0.41086956521739, 0.13636363636364
35672, 0.17391304347826, 0.41086956521739, 0.18181818181818
35673, 0.17391304347826, 0.41086956521739, 0.22727272727273
35674, 0.17391304347826, 0.41086956521739, 0.27272727272727
35675, 0.17391304347826, 0.41086956521739, 0.31818181818182
35676, 0.17391304347826, 0.41086956521739, 0.36363636363636
35677, 0.17391304347826, 0.41086956521739, 0.40909090909091
35678, 0.17391304347826, 0.41086956521739, 0.45454545454545
35679, 0.1304347826087, 0.41086956521739, 0.045454545454545
35680, 0.1304347826087, 0.41086956521739, 0.090909090909091
35681, 0.1304347826087, 0.41086956521739, 0.13636363636364
35682, 0.1304347826087, 0.41086956521739, 0.18181818181818
35683, 0.1304347826087, 0.41086956521739, 0.22727272727273
35684, 0.1304347826087, 0.41086956521739, 0.27272727272727
35685, 0.1304347826087, 0.41086956521739, 0.31818181818182
35686, 0.1304347826087, 0.41086956521739, 0.36363636363636
35687, 0.1304347826087, 0.41086956521739, 0.40909090909091
35688, 0.1304347826087, 0.41086956521739, 0.45454545454545
35689, 0.08695652173913, 0.41086956521739, 0.045454545454545
35690, 0.08695652173913, 0.41086956521739, 0.090909090909091
35691, 0.08695652173913, 0.41086956521739, 0.13636363636364
35692, 0.08695652173913, 0.41086956521739, 0.18181818181818
35693, 0.08695652173913, 0.41086956521739, 0.22727272727273
35694, 0.08695652173913, 0.41086956521739, 0.27272727272727
35695, 0.08695652173913, 0.41086956521739, 0.31818181818182
35696, 0.08695652173913, 0.41086956521739, 0.36363636363636
35697, 0.08695652173913, 0.41086956521739, 0.40909090909091
35698, 0.08695652173913, 0.41086956521739, 0.45454545454545
35699, 0.043478260869565, 0.41086956521739, 0.045454545454545
35700, 0.043478260869565, 0.41086956521739, 0.090909090909091
35701, 0.043478260869565, 0.41086956521739, 0.13636363636364
35702, 0.043478260869565, 0.41086956521739, 0.18181818181818
35703, 0.043478260869565, 0.41086956521739, 0.22727272727273
35704, 0.043478260869565, 0.41086956521739, 0.27272727272727
35705, 0.043478260869565, 0.41086956521739, 0.31818181818182
35706, 0.043478260869565, 0.41086956521739, 0.36363636363636
35707, 0.043478260869565, 0.41086956521739, 0.40909090909091
35708, 0.043478260869565, 0.41086956521739, 0.45454545454545
35709, 0.95652173913043, 0.46304347826087, 0.045454545454545
35710, 0.95652173913043, 0.46304347826087, 0.090909090909091
35711, 0.95652173913044, 0.46304347826087, 0.13636363636364
35712, 0.95652173913043, 0.46304347826087, 0.18181818181818
35713, 0.95652173913044, 0.46304347826087, 0.22727272727273
35714, 0.95652173913044, 0.46304347826087, 0.27272727272727
35715, 0.95652173913044, 0.46304347826087, 0.31818181818182
35716, 0.95652173913043, 0.46304347826087, 0.36363636363636
35717, 0.95652173913043, 0.46304347826087, 0.40909090909091
35718, 0.95652173913044, 0.46304347826087, 0.45454545454545
35719, 0.91304347826087, 0.46304347826087, 0.045454545454545
35720, 0.91304347826087, 0.46304347826087, 0.090909090909091
35721, 0.91304347826087, 0.46304347826087, 0.13636363636364
35722, 0.91304347826087, 0.46304347826087, 0.18181818181818
35723, 0.91304347826087, 0.46304347826087, 0.22727272727273
35724, 0.91304347826087, 0.46304347826087, 0.27272727272727
35725, 0.91304347826087, 0.46304347826087, 0.31818181818182
35726, 0.91304347826087, 0.46304347826087, 0.36363636363636
35727, 0.91304347826087, 0.46304347826087, 0.40909090909091
35728, 0.91304347826087, 0.46304347826087, 0.45454545454545
35729, 0.8695652173913, 0.46304347826087, 0.045454545454545
35730, 0.8695652173913, 0.46304347826087, 0.090909090909091
35731, 0.8695652173913, 0.46304347826087, 0.13636363636364
35732, 0.8695652173913, 0.46304347826087, 0.18181818181818
35733, 0.8695652173913, 0.46304347826087, 0.22727272727273
35734, 0.8695652173913, 0.46304347826087, 0.27272727272727
35735, 0.8695652173913, 0.46304347826087, 0.31818181818182
35736, 0.8695652173913, 0.46304347826087, 0.36363636363636
35737, 0.8695652173913, 0.46304347826087, 0.40909090909091
35738, 0.8695652173913, 0.46304347826087, 0.45454545454545
35739, 0.82608695652174, 0.46304347826087, 0.045454545454545
35740, 0.82608695652174, 0.46304347826087, 0.090909090909091
35741, 0.82608695652174, 0.46304347826087, 0.13636363636364
35742, 0.82608695652174, 0.46304347826087, 0.18181818181818
35743, 0.82608695652174, 0.46304347826087, 0.22727272727273
35744, 0.82608695652174, 0.46304347826087, 0.27272727272727
35745, 0.82608695652174, 0.46304347826087, 0.31818181818182
35746, 0.82608695652174, 0.46304347826087, 0.36363636363636
35747, 0.82608695652174, 0.46304347826087, 0.40909090909091
35748, 0.82608695652174, 0.46304347826087, 0.45454545454545
35749, 0.78260869565217, 0.46304347826087, 0.045454545454545
35750, 0.78260869565217, 0.46304347826087, 0.090909090909091
35751, 0.78260869565217, 0.46304347826087, 0.13636363636364
35752, 0.78260869565217, 0.46304347826087, 0.18181818181818
35753, 0.78260869565217, 0.46304347826087, 0.22727272727273
35754, 0.78260869565217, 0.46304347826087, 0.27272727272727
35755, 0.78260869565217, 0.46304347826087, 0.31818181818182
35756, 0.78260869565217, 0.46304347826087, 0.36363636363636
35757, 0.78260869565217, 0.46304347826087, 0.40909090909091
35758, 0.78260869565217, 0.46304347826087, 0.45454545454545
35759, 0.73913043478261, 0.46304347826087, 0.045454545454545
35760, 0.73913043478261, 0.46304347826087, 0.090909090909091
35761, 0.73913043478261, 0.46304347826087, 0.13636363636364
35762, 0.73913043478261, 0.46304347826087, 0.18181818181818
35763, 0.73913043478261, 0.46304347826087, 0.22727272727273
35764, 0.73913043478261, 0.46304347826087, 0.27272727272727
35765, 0.73913043478261, 0.46304347826087, 0.31818181818182
35766, 0.73913043478261, 0.46304347826087, 0.36363636363636
35767, 0.73913043478261, 0.46304347826087, 0.40909090909091
35768, 0.73913043478261, 0.46304347826087, 0.45454545454545
35769, 0.69565217391304, 0.46304347826087, 0.045454545454545
35770, 0.69565217391304, 0.46304347826087, 0.090909090909091
35771, 0.69565217391304, 0.46304347826087, 0.13636363636364
35772, 0.69565217391304, 0.46304347826087, 0.18181818181818
35773, 0.69565217391304, 0.46304347826087, 0.22727272727273
35774, 0.69565217391304, 0.46304347826087, 0.27272727272727
35775, 0.69565217391304, 0.46304347826087, 0.31818181818182
35776, 0.69565217391304, 0.46304347826087, 0.36363636363636
35777, 0.69565217391304, 0.46304347826087, 0.40909090909091
35778, 0.69565217391304, 0.46304347826087, 0.45454545454545
35779, 0.65217391304348, 0.46304347826087, 0.045454545454545
35780, 0.65217391304348, 0.46304347826087, 0.090909090909091
35781, 0.65217391304348, 0.46304347826087, 0.13636363636364
35782, 0.65217391304348, 0.46304347826087, 0.18181818181818
35783, 0.65217391304348, 0.46304347826087, 0.22727272727273
35784, 0.65217391304348, 0.46304347826087, 0.27272727272727
35785, 0.65217391304348, 0.46304347826087, 0.31818181818182
35786, 0.65217391304348, 0.46304347826087, 0.36363636363636
35787, 0.65217391304348, 0.46304347826087, 0.40909090909091
35788, 0.65217391304348, 0.46304347826087, 0.45454545454545
35789, 0.60869565217391, 0.46304347826087, 0.045454545454545
35790, 0.60869565217391, 0.46304347826087, 0.090909090909091
35791, 0.60869565217391, 0.46304347826087, 0.13636363636364
35792, 0.60869565217391, 0.46304347826087, 0.18181818181818
35793, 0.60869565217391, 0.46304347826087, 0.22727272727273
35794, 0.60869565217391, 0.46304347826087, 0.27272727272727
35795, 0.60869565217391, 0.46304347826087, 0.31818181818182
35796, 0.60869565217391, 0.46304347826087, 0.36363636363636
35797, 0.60869565217391, 0.46304347826087, 0.40909090909091
35798, 0.60869565217391, 0.46304347826087, 0.45454545454545
35799, 0.56521739130435, 0.46304347826087, 0.045454545454545
35800, 0.56521739130435, 0.46304347826087, 0.090909090909091
35801, 0.56521739130435, 0.46304347826087, 0.13636363636364
35802, 0.56521739130435, 0.46304347826087, 0.18181818181818
35803, 0.56521739130435, 0.46304347826087, 0.22727272727273
35804, 0.56521739130435, 0.46304347826087, 0.27272727272727
35805, 0.56521739130435, 0.46304347826087, 0.31818181818182
35806, 0.56521739130435, 0.46304347826087, 0.36363636363636
35807, 0.56521739130435, 0.46304347826087, 0.40909090909091
35808, 0.56521739130435, 0.46304347826087, 0.45454545454545
35809, 0.52173913043478, 0.46304347826087, 0.045454545454545
35810, 0.52173913043478, 0.46304347826087, 0.090909090909091
35811, 0.52173913043478, 0.46304347826087, 0.13636363636364
35812, 0.52173913043478, 0.46304347826087, 0.18181818181818
35813, 0.52173913043478, 0.46304347826087, 0.22727272727273
35814, 0.52173913043478, 0.46304347826087, 0.27272727272727
35815, 0.52173913043478, 0.46304347826087, 0.31818181818182
35816, 0.52173913043478, 0.46304347826087, 0.36363636363636
35817, 0.52173913043478, 0.46304347826087, 0.40909090909091
35818, 0.52173913043478, 0.46304347826087, 0.45454545454545
35819, 0.47826086956522, 0.46304347826087, 0.045454545454545
35820, 0.47826086956522, 0.46304347826087, 0.090909090909091
35821, 0.47826086956522, 0.46304347826087, 0.13636363636364
35822, 0.47826086956522, 0.46304347826087, 0.18181818181818
35823, 0.47826086956522, 0.46304347826087, 0.22727272727273
35824, 0.47826086956522, 0.46304347826087, 0.27272727272727
35825, 0.47826086956522, 0.46304347826087, 0.31818181818182
35826, 0.47826086956522, 0.46304347826087, 0.36363636363636
35827, 0.47826086956522, 0.46304347826087, 0.40909090909091
35828, 0.47826086956522, 0.46304347826087, 0.45454545454545
35829, 0.43478260869565, 0.46304347826087, 0.045454545454545
35830, 0.43478260869565, 0.46304347826087, 0.090909090909091
35831, 0.43478260869565, 0.46304347826087, 0.13636363636364
35832, 0.43478260869565, 0.46304347826087, 0.18181818181818
35833, 0.43478260869565, 0.46304347826087, 0.22727272727273
35834, 0.43478260869565, 0.46304347826087, 0.27272727272727
35835, 0.43478260869565, 0.46304347826087, 0.31818181818182
35836, 0.43478260869565, 0.46304347826087, 0.36363636363636
35837, 0.43478260869565, 0.46304347826087, 0.40909090909091
35838, 0.43478260869565, 0.46304347826087, 0.45454545454545
35839, 0.39130434782609, 0.46304347826087, 0.045454545454545
35840, 0.39130434782609, 0.46304347826087, 0.090909090909091
35841, 0.39130434782609, 0.46304347826087, 0.13636363636364
35842, 0.39130434782609, 0.46304347826087, 0.18181818181818
35843, 0.39130434782609, 0.46304347826087, 0.22727272727273
35844, 0.39130434782609, 0.46304347826087, 0.27272727272727
35845, 0.39130434782609, 0.46304347826087, 0.31818181818182
35846, 0.39130434782609, 0.46304347826087, 0.36363636363636
35847, 0.39130434782609, 0.46304347826087, 0.40909090909091
35848, 0.39130434782609, 0.46304347826087, 0.45454545454545
35849, 0.34782608695652, 0.46304347826087, 0.045454545454545
35850, 0.34782608695652, 0.46304347826087, 0.090909090909091
35851, 0.34782608695652, 0.46304347826087, 0.13636363636364
35852, 0.34782608695652, 0.46304347826087, 0.18181818181818
35853, 0.34782608695652, 0.46304347826087, 0.22727272727273
35854, 0.34782608695652, 0.46304347826087, 0.27272727272727
35855, 0.34782608695652, 0.46304347826087, 0.31818181818182
35856, 0.34782608695652, 0.46304347826087, 0.36363636363636
35857, 0.34782608695652, 0.46304347826087, 0.40909090909091
35858, 0.34782608695652, 0.46304347826087, 0.45454545454545
35859, 0.30434782608696, 0.46304347826087, 0.045454545454545
35860, 0.30434782608696, 0.46304347826087, 0.090909090909091
35861, 0.30434782608696, 0.46304347826087, 0.13636363636364
35862, 0.30434782608696, 0.46304347826087, 0.18181818181818
35863, 0.30434782608696, 0.46304347826087, 0.22727272727273
35864, 0.30434782608696, 0.46304347826087, 0.27272727272727
35865, 0.30434782608696, 0.46304347826087, 0.31818181818182
35866, 0.30434782608696, 0.46304347826087, 0.36363636363636
35867, 0.30434782608696, 0.46304347826087, 0.40909090909091
35868, 0.30434782608696, 0.46304347826087, 0.45454545454545
35869, 0.26086956521739, 0.46304347826087, 0.045454545454545
35870, 0.26086956521739, 0.46304347826087, 0.090909090909091
35871, 0.26086956521739, 0.46304347826087, 0.13636363636364
35872, 0.26086956521739, 0.46304347826087, 0.18181818181818
35873, 0.26086956521739, 0.46304347826087, 0.22727272727273
35874, 0.26086956521739, 0.46304347826087, 0.27272727272727
35875, 0.26086956521739, 0.46304347826087, 0.31818181818182
35876, 0.26086956521739, 0.46304347826087, 0.36363636363636
35877, 0.26086956521739, 0.46304347826087, 0.40909090909091
35878, 0.26086956521739, 0.46304347826087, 0.45454545454545
35879, 0.21739130434783, 0.46304347826087, 0.045454545454545
35880, 0.21739130434783, 0.46304347826087, 0.090909090909091
35881, 0.21739130434783, 0.46304347826087, 0.13636363636364
35882, 0.21739130434783, 0.46304347826087, 0.18181818181818
35883, 0.21739130434783, 0.46304347826087, 0.22727272727273
35884, 0.21739130434783, 0.46304347826087, 0.27272727272727
35885, 0.21739130434783, 0.46304347826087, 0.31818181818182
35886, 0.21739130434783, 0.46304347826087, 0.36363636363636
35887, 0.21739130434783, 0.46304347826087, 0.40909090909091
35888, 0.21739130434783, 0.46304347826087, 0.45454545454545
35889, 0.17391304347826, 0.46304347826087, 0.045454545454545
35890, 0.17391304347826, 0.46304347826087, 0.090909090909091
35891, 0.17391304347826, 0.46304347826087, 0.13636363636364
35892, 0.17391304347826, 0.46304347826087, 0.18181818181818
35893, 0.17391304347826, 0.46304347826087, 0.22727272727273
35894, 0.17391304347826, 0.46304347826087, 0.27272727272727
35895, 0.17391304347826, 0.46304347826087, 0.31818181818182
35896, 0.17391304347826, 0.46304347826087, 0.36363636363636
35897, 0.17391304347826, 0.46304347826087, 0.40909090909091
35898, 0.17391304347826, 0.46304347826087, 0.45454545454545
35899, 0.1304347826087, 0.46304347826087, 0.045454545454545
35900, 0.1304347826087, 0.46304347826087, 0.090909090909091
35901, 0.1304347826087, 0.46304347826087, 0.13636363636364
35902, 0.1304347826087, 0.46304347826087, 0.18181818181818
35903, 0.1304347826087, 0.46304347826087, 0.22727272727273
35904, 0.1304347826087, 0.46304347826087, 0.27272727272727
35905, 0.1304347826087, 0.46304347826087, 0.31818181818182
35906, 0.1304347826087, 0.46304347826087, 0.36363636363636
35907, 0.1304347826087, 0.46304347826087, 0.40909090909091
35908, 0.1304347826087, 0.46304347826087, 0.45454545454545
35909, 0.08695652173913, 0.46304347826087, 0.045454545454545
35910, 0.08695652173913, 0.46304347826087, 0.090909090909091
35911, 0.08695652173913, 0.46304347826087, 0.13636363636364
35912, 0.08695652173913, 0.46304347826087, 0.18181818181818
35913, 0.08695652173913, 0.46304347826087, 0.22727272727273
35914, 0.08695652173913, 0.46304347826087, 0.27272727272727
35915, 0.08695652173913, 0.46304347826087, 0.31818181818182
35916, 0.08695652173913, 0.46304347826087, 0.36363636363636
35917, 0.08695652173913, 0.46304347826087, 0.40909090909091
35918, 0.08695652173913, 0.46304347826087, 0.45454545454545
35919, 0.043478260869565, 0.46304347826087, 0.045454545454545
35920, 0.043478260869565, 0.46304347826087, 0.090909090909091
35921, 0.043478260869565, 0.46304347826087, 0.13636363636364
35922, 0.043478260869565, 0.46304347826087, 0.18181818181818
35923, 0.043478260869565, 0.46304347826087, 0.22727272727273
35924, 0.043478260869565, 0.46304347826087, 0.27272727272727
35925, 0.043478260869565, 0.46304347826087, 0.31818181818182
35926, 0.043478260869565, 0.46304347826087, 0.36363636363636
35927, 0.043478260869565, 0.46304347826087, 0.40909090909091
35928, 0.043478260869565, 0.46304347826087, 0.45454545454545
35929, 0.95652173913043, 0.51521739130435, 0.045454545454545
35930, 0.95652173913043, 0.51521739130435, 0.090909090909091
35931, 0.95652173913043, 0.51521739130435, 0.13636363636364
35932, 0.95652173913043, 0.51521739130435, 0.18181818181818
35933, 0.95652173913044, 0.51521739130435, 0.22727272727273
35934, 0.95652173913044, 0.51521739130435, 0.27272727272727
35935, 0.95652173913043, 0.51521739130435, 0.31818181818182
35936, 0.95652173913043, 0.51521739130435, 0.36363636363636
35937, 0.95652173913043, 0.51521739130435, 0.40909090909091
35938, 0.95652173913043, 0.51521739130435, 0.45454545454545
35939, 0.91304347826087, 0.51521739130435, 0.045454545454545
35940, 0.91304347826087, 0.51521739130435, 0.090909090909091
35941, 0.91304347826087, 0.51521739130435, 0.13636363636364
35942, 0.91304347826087, 0.51521739130435, 0.18181818181818
35943, 0.91304347826087, 0.51521739130435, 0.22727272727273
35944, 0.91304347826087, 0.51521739130435, 0.27272727272727
35945, 0.91304347826087, 0.51521739130435, 0.31818181818182
35946, 0.91304347826087, 0.51521739130435, 0.36363636363636
35947, 0.91304347826087, 0.51521739130435, 0.40909090909091
35948, 0.91304347826087, 0.51521739130435, 0.45454545454545
35949, 0.8695652173913, 0.51521739130435, 0.045454545454545
35950, 0.8695652173913, 0.51521739130435, 0.090909090909091
35951, 0.8695652173913, 0.51521739130435, 0.13636363636364
35952, 0.8695652173913, 0.51521739130435, 0.18181818181818
35953, 0.8695652173913, 0.51521739130435, 0.22727272727273
35954, 0.8695652173913, 0.51521739130435, 0.27272727272727
35955, 0.8695652173913, 0.51521739130435, 0.31818181818182
35956, 0.8695652173913, 0.51521739130435, 0.36363636363636
35957, 0.8695652173913, 0.51521739130435, 0.40909090909091
35958, 0.8695652173913, 0.51521739130435, 0.45454545454545
35959, 0.82608695652174, 0.51521739130435, 0.045454545454545
35960, 0.82608695652174, 0.51521739130435, 0.090909090909091
35961, 0.82608695652174, 0.51521739130435, 0.13636363636364
35962, 0.82608695652174, 0.51521739130435, 0.18181818181818
35963, 0.82608695652174, 0.51521739130435, 0.22727272727273
35964, 0.82608695652174, 0.51521739130435, 0.27272727272727
35965, 0.82608695652174, 0.51521739130435, 0.31818181818182
35966, 0.82608695652174, 0.51521739130435, 0.36363636363636
35967, 0.82608695652174, 0.51521739130435, 0.40909090909091
35968, 0.82608695652174, 0.51521739130435, 0.45454545454545
35969, 0.78260869565217, 0.51521739130435, 0.045454545454545
35970, 0.78260869565217, 0.51521739130435, 0.090909090909091
35971, 0.78260869565217, 0.51521739130435, 0.13636363636364
35972, 0.78260869565217, 0.51521739130435, 0.18181818181818
35973, 0.78260869565217, 0.51521739130435, 0.22727272727273
35974, 0.78260869565217, 0.51521739130435, 0.27272727272727
35975, 0.78260869565217, 0.51521739130435, 0.31818181818182
35976, 0.78260869565217, 0.51521739130435, 0.36363636363636
35977, 0.78260869565217, 0.51521739130435, 0.40909090909091
35978, 0.78260869565217, 0.51521739130435, 0.45454545454545
35979, 0.73913043478261, 0.51521739130435, 0.045454545454545
35980, 0.73913043478261, 0.51521739130435, 0.090909090909091
35981, 0.73913043478261, 0.51521739130435, 0.13636363636364
35982, 0.73913043478261, 0.51521739130435, 0.18181818181818
35983, 0.73913043478261, 0.51521739130435, 0.22727272727273
35984, 0.73913043478261, 0.51521739130435, 0.27272727272727
35985, 0.73913043478261, 0.51521739130435, 0.31818181818182
35986, 0.73913043478261, 0.51521739130435, 0.36363636363636
35987, 0.73913043478261, 0.51521739130435, 0.40909090909091
35988, 0.73913043478261, 0.51521739130435, 0.45454545454545
35989, 0.69565217391304, 0.51521739130435, 0.045454545454545
35990, 0.69565217391304, 0.51521739130435, 0.090909090909091
35991, 0.69565217391304, 0.51521739130435, 0.13636363636364
35992, 0.69565217391304, 0.51521739130435, 0.18181818181818
35993, 0.69565217391304, 0.51521739130435, 0.22727272727273
35994, 0.69565217391304, 0.51521739130435, 0.27272727272727
35995, 0.69565217391304, 0.51521739130435, 0.31818181818182
35996, 0.69565217391304, 0.51521739130435, 0.36363636363636
35997, 0.69565217391304, 0.51521739130435, 0.40909090909091
35998, 0.69565217391304, 0.51521739130435, 0.45454545454545
35999, 0.65217391304348, 0.51521739130435, 0.045454545454545
36000, 0.65217391304348, 0.51521739130435, 0.090909090909091
36001, 0.65217391304348, 0.51521739130435, 0.13636363636364
36002, 0.65217391304348, 0.51521739130435, 0.18181818181818
36003, 0.65217391304348, 0.51521739130435, 0.22727272727273
36004, 0.65217391304348, 0.51521739130435, 0.27272727272727
36005, 0.65217391304348, 0.51521739130435, 0.31818181818182
36006, 0.65217391304348, 0.51521739130435, 0.36363636363636
36007, 0.65217391304348, 0.51521739130435, 0.40909090909091
36008, 0.65217391304348, 0.51521739130435, 0.45454545454545
36009, 0.60869565217391, 0.51521739130435, 0.045454545454545
36010, 0.60869565217391, 0.51521739130435, 0.090909090909091
36011, 0.60869565217391, 0.51521739130435, 0.13636363636364
36012, 0.60869565217391, 0.51521739130435, 0.18181818181818
36013, 0.60869565217391, 0.51521739130435, 0.22727272727273
36014, 0.60869565217391, 0.51521739130435, 0.27272727272727
36015, 0.60869565217391, 0.51521739130435, 0.31818181818182
36016, 0.60869565217391, 0.51521739130435, 0.36363636363636
36017, 0.60869565217391, 0.51521739130435, 0.40909090909091
36018, 0.60869565217391, 0.51521739130435, 0.45454545454545
36019, 0.56521739130435, 0.51521739130435, 0.045454545454545
36020, 0.56521739130435, 0.51521739130435, 0.090909090909091
36021, 0.56521739130435, 0.51521739130435, 0.13636363636364
36022, 0.56521739130435, 0.51521739130435, 0.18181818181818
36023, 0.56521739130435, 0.51521739130435, 0.22727272727273
36024, 0.56521739130435, 0.51521739130435, 0.27272727272727
36025, 0.56521739130435, 0.51521739130435, 0.31818181818182
36026, 0.56521739130435, 0.51521739130435, 0.36363636363636
36027, 0.56521739130435, 0.51521739130435, 0.40909090909091
36028, 0.56521739130435, 0.51521739130435, 0.45454545454545
36029, 0.52173913043478, 0.51521739130435, 0.045454545454545
36030, 0.52173913043478, 0.51521739130435, 0.090909090909091
36031, 0.52173913043478, 0.51521739130435, 0.13636363636364
36032, 0.52173913043478, 0.51521739130435, 0.18181818181818
36033, 0.52173913043478, 0.51521739130435, 0.22727272727273
36034, 0.52173913043478, 0.51521739130435, 0.27272727272727
36035, 0.52173913043478, 0.51521739130435, 0.31818181818182
36036, 0.52173913043478, 0.51521739130435, 0.36363636363636
36037, 0.52173913043478, 0.51521739130435, 0.40909090909091
36038, 0.52173913043478, 0.51521739130435, 0.45454545454545
36039, 0.47826086956522, 0.51521739130435, 0.045454545454545
36040, 0.47826086956522, 0.51521739130435, 0.090909090909091
36041, 0.47826086956522, 0.51521739130435, 0.13636363636364
36042, 0.47826086956522, 0.51521739130435, 0.18181818181818
36043, 0.47826086956522, 0.51521739130435, 0.22727272727273
36044, 0.47826086956522, 0.51521739130435, 0.27272727272727
36045, 0.47826086956522, 0.51521739130435, 0.31818181818182
36046, 0.47826086956522, 0.51521739130435, 0.36363636363636
36047, 0.47826086956522, 0.51521739130435, 0.40909090909091
36048, 0.47826086956522, 0.51521739130435, 0.45454545454545
36049, 0.43478260869565, 0.51521739130435, 0.045454545454545
36050, 0.43478260869565, 0.51521739130435, 0.090909090909091
36051, 0.43478260869565, 0.51521739130435, 0.13636363636364
36052, 0.43478260869565, 0.51521739130435, 0.18181818181818
36053, 0.43478260869565, 0.51521739130435, 0.22727272727273
36054, 0.43478260869565, 0.51521739130435, 0.27272727272727
36055, 0.43478260869565, 0.51521739130435, 0.31818181818182
36056, 0.43478260869565, 0.51521739130435, 0.36363636363636
36057, 0.43478260869565, 0.51521739130435, 0.40909090909091
36058, 0.43478260869565, 0.51521739130435, 0.45454545454545
36059, 0.39130434782609, 0.51521739130435, 0.045454545454545
36060, 0.39130434782609, 0.51521739130435, 0.090909090909091
36061, 0.39130434782609, 0.51521739130435, 0.13636363636364
36062, 0.39130434782609, 0.51521739130435, 0.18181818181818
36063, 0.39130434782609, 0.51521739130435, 0.22727272727273
36064, 0.39130434782609, 0.51521739130435, 0.27272727272727
36065, 0.39130434782609, 0.51521739130435, 0.31818181818182
36066, 0.39130434782609, 0.51521739130435, 0.36363636363636
36067, 0.39130434782609, 0.51521739130435, 0.40909090909091
36068, 0.39130434782609, 0.51521739130435, 0.45454545454545
36069, 0.34782608695652, 0.51521739130435, 0.045454545454545
36070, 0.34782608695652, 0.51521739130435, 0.090909090909091
36071, 0.34782608695652, 0.51521739130435, 0.13636363636364
36072, 0.34782608695652, 0.51521739130435, 0.18181818181818
36073, 0.34782608695652, 0.51521739130435, 0.22727272727273
36074, 0.34782608695652, 0.51521739130435, 0.27272727272727
36075, 0.34782608695652, 0.51521739130435, 0.31818181818182
36076, 0.34782608695652, 0.51521739130435, 0.36363636363636
36077, 0.34782608695652, 0.51521739130435, 0.40909090909091
36078, 0.34782608695652, 0.51521739130435, 0.45454545454545
36079, 0.30434782608696, 0.51521739130435, 0.045454545454545
36080, 0.30434782608696, 0.51521739130435, 0.090909090909091
36081, 0.30434782608696, 0.51521739130435, 0.13636363636364
36082, 0.30434782608696, 0.51521739130435, 0.18181818181818
36083, 0.30434782608696, 0.51521739130435, 0.22727272727273
36084, 0.30434782608696, 0.51521739130435, 0.27272727272727
36085, 0.30434782608696, 0.51521739130435, 0.31818181818182
36086, 0.30434782608696, 0.51521739130435, 0.36363636363636
36087, 0.30434782608696, 0.51521739130435, 0.40909090909091
36088, 0.30434782608696, 0.51521739130435, 0.45454545454545
36089, 0.26086956521739, 0.51521739130435, 0.045454545454545
36090, 0.26086956521739, 0.51521739130435, 0.090909090909091
36091, 0.26086956521739, 0.51521739130435, 0.13636363636364
36092, 0.26086956521739, 0.51521739130435, 0.18181818181818
36093, 0.26086956521739, 0.51521739130435, 0.22727272727273
36094, 0.26086956521739, 0.51521739130435, 0.27272727272727
36095, 0.26086956521739, 0.51521739130435, 0.31818181818182
36096, 0.26086956521739, 0.51521739130435, 0.36363636363636
36097, 0.26086956521739, 0.51521739130435, 0.40909090909091
36098, 0.26086956521739, 0.51521739130435, 0.45454545454545
36099, 0.21739130434783, 0.51521739130435, 0.045454545454545
36100, 0.21739130434783, 0.51521739130435, 0.090909090909091
36101, 0.21739130434783, 0.51521739130435, 0.13636363636364
36102, 0.21739130434783, 0.51521739130435, 0.18181818181818
36103, 0.21739130434783, 0.51521739130435, 0.22727272727273
36104, 0.21739130434783, 0.51521739130435, 0.27272727272727
36105, 0.21739130434783, 0.51521739130435, 0.31818181818182
36106, 0.21739130434783, 0.51521739130435, 0.36363636363636
36107, 0.21739130434783, 0.51521739130435, 0.40909090909091
36108, 0.21739130434783, 0.51521739130435, 0.45454545454545
36109, 0.17391304347826, 0.51521739130435, 0.045454545454545
36110, 0.17391304347826, 0.51521739130435, 0.090909090909091
36111, 0.17391304347826, 0.51521739130435, 0.13636363636364
36112, 0.17391304347826, 0.51521739130435, 0.18181818181818
36113, 0.17391304347826, 0.51521739130435, 0.22727272727273
36114, 0.17391304347826, 0.51521739130435, 0.27272727272727
36115, 0.17391304347826, 0.51521739130435, 0.31818181818182
36116, 0.17391304347826, 0.51521739130435, 0.36363636363636
36117, 0.17391304347826, 0.51521739130435, 0.40909090909091
36118, 0.17391304347826, 0.51521739130435, 0.45454545454545
36119, 0.1304347826087, 0.51521739130435, 0.045454545454545
36120, 0.1304347826087, 0.51521739130435, 0.090909090909091
36121, 0.1304347826087, 0.51521739130435, 0.13636363636364
36122, 0.1304347826087, 0.51521739130435, 0.18181818181818
36123, 0.1304347826087, 0.51521739130435, 0.22727272727273
36124, 0.1304347826087, 0.51521739130435, 0.27272727272727
36125, 0.1304347826087, 0.51521739130435, 0.31818181818182
36126, 0.1304347826087, 0.51521739130435, 0.36363636363636
36127, 0.1304347826087, 0.51521739130435, 0.40909090909091
36128, 0.1304347826087, 0.51521739130435, 0.45454545454545
36129, 0.08695652173913, 0.51521739130435, 0.045454545454545
36130, 0.08695652173913, 0.51521739130435, 0.090909090909091
36131, 0.08695652173913, 0.51521739130435, 0.13636363636364
36132, 0.08695652173913, 0.51521739130435, 0.18181818181818
36133, 0.08695652173913, 0.51521739130435, 0.22727272727273
36134, 0.08695652173913, 0.51521739130435, 0.27272727272727
36135, 0.08695652173913, 0.51521739130435, 0.31818181818182
36136, 0.08695652173913, 0.51521739130435, 0.36363636363636
36137, 0.08695652173913, 0.51521739130435, 0.40909090909091
36138, 0.08695652173913, 0.51521739130435, 0.45454545454545
36139, 0.043478260869565, 0.51521739130435, 0.045454545454545
36140, 0.043478260869565, 0.51521739130435, 0.090909090909091
36141, 0.043478260869565, 0.51521739130435, 0.13636363636364
36142, 0.043478260869565, 0.51521739130435, 0.18181818181818
36143, 0.043478260869565, 0.51521739130435, 0.22727272727273
36144, 0.043478260869565, 0.51521739130435, 0.27272727272727
36145, 0.043478260869565, 0.51521739130435, 0.31818181818182
36146, 0.043478260869565, 0.51521739130435, 0.36363636363636
36147, 0.043478260869565, 0.51521739130435, 0.40909090909091
36148, 0.043478260869565, 0.51521739130435, 0.45454545454545
36149, 0.95652173913043, 0.56739130434783, 0.045454545454545
36150, 0.95652173913043, 0.56739130434783, 0.090909090909091
36151, 0.95652173913043, 0.56739130434783, 0.13636363636364
36152, 0.95652173913043, 0.56739130434783, 0.18181818181818
36153, 0.95652173913043, 0.56739130434783, 0.22727272727273
36154, 0.95652173913044, 0.56739130434783, 0.27272727272727
36155, 0.95652173913044, 0.56739130434783, 0.31818181818182
36156, 0.95652173913043, 0.56739130434783, 0.36363636363636
36157, 0.95652173913043, 0.56739130434783, 0.40909090909091
36158, 0.95652173913044, 0.56739130434783, 0.45454545454545
36159, 0.91304347826087, 0.56739130434783, 0.045454545454545
36160, 0.91304347826087, 0.56739130434783, 0.090909090909091
36161, 0.91304347826087, 0.56739130434783, 0.13636363636364
36162, 0.91304347826087, 0.56739130434783, 0.18181818181818
36163, 0.91304347826087, 0.56739130434783, 0.22727272727273
36164, 0.91304347826087, 0.56739130434783, 0.27272727272727
36165, 0.91304347826087, 0.56739130434783, 0.31818181818182
36166, 0.91304347826087, 0.56739130434783, 0.36363636363636
36167, 0.91304347826087, 0.56739130434783, 0.40909090909091
36168, 0.91304347826087, 0.56739130434783, 0.45454545454545
36169, 0.8695652173913, 0.56739130434783, 0.045454545454545
36170, 0.8695652173913, 0.56739130434783, 0.090909090909091
36171, 0.8695652173913, 0.56739130434783, 0.13636363636364
36172, 0.8695652173913, 0.56739130434783, 0.18181818181818
36173, 0.8695652173913, 0.56739130434783, 0.22727272727273
36174, 0.8695652173913, 0.56739130434783, 0.27272727272727
36175, 0.8695652173913, 0.56739130434783, 0.31818181818182
36176, 0.8695652173913, 0.56739130434783, 0.36363636363636
36177, 0.8695652173913, 0.56739130434783, 0.40909090909091
36178, 0.8695652173913, 0.56739130434783, 0.45454545454545
36179, 0.82608695652174, 0.56739130434783, 0.045454545454545
36180, 0.82608695652174, 0.56739130434783, 0.090909090909091
36181, 0.82608695652174, 0.56739130434783, 0.13636363636364
36182, 0.82608695652174, 0.56739130434783, 0.18181818181818
36183, 0.82608695652174, 0.56739130434783, 0.22727272727273
36184, 0.82608695652174, 0.56739130434783, 0.27272727272727
36185, 0.82608695652174, 0.56739130434783, 0.31818181818182
36186, 0.82608695652174, 0.56739130434783, 0.36363636363636
36187, 0.82608695652174, 0.56739130434783, 0.40909090909091
36188, 0.82608695652174, 0.56739130434783, 0.45454545454545
36189, 0.78260869565217, 0.56739130434783, 0.045454545454545
36190, 0.78260869565217, 0.56739130434783, 0.090909090909091
36191, 0.78260869565217, 0.56739130434783, 0.13636363636364
36192, 0.78260869565217, 0.56739130434783, 0.18181818181818
36193, 0.78260869565217, 0.56739130434783, 0.22727272727273
36194, 0.78260869565217, 0.56739130434783, 0.27272727272727
36195, 0.78260869565217, 0.56739130434783, 0.31818181818182
36196, 0.78260869565217, 0.56739130434783, 0.36363636363636
36197, 0.78260869565217, 0.56739130434783, 0.40909090909091
36198, 0.78260869565217, 0.56739130434783, 0.45454545454545
36199, 0.73913043478261, 0.56739130434783, 0.045454545454545
36200, 0.73913043478261, 0.56739130434783, 0.090909090909091
36201, 0.73913043478261, 0.56739130434783, 0.13636363636364
36202, 0.73913043478261, 0.56739130434783, 0.18181818181818
36203, 0.73913043478261, 0.56739130434783, 0.22727272727273
36204, 0.73913043478261, 0.56739130434783, 0.27272727272727
36205, 0.73913043478261, 0.56739130434783, 0.31818181818182
36206, 0.73913043478261, 0.56739130434783, 0.36363636363636
36207, 0.73913043478261, 0.56739130434783, 0.40909090909091
36208, 0.73913043478261, 0.56739130434783, 0.45454545454545
36209, 0.69565217391304, 0.56739130434783, 0.045454545454545
36210, 0.69565217391304, 0.56739130434783, 0.090909090909091
36211, 0.69565217391304, 0.56739130434783, 0.13636363636364
36212, 0.69565217391304, 0.56739130434783, 0.18181818181818
36213, 0.69565217391304, 0.56739130434783, 0.22727272727273
36214, 0.69565217391304, 0.56739130434783, 0.27272727272727
36215, 0.69565217391304, 0.56739130434783, 0.31818181818182
36216, 0.69565217391304, 0.56739130434783, 0.36363636363636
36217, 0.69565217391304, 0.56739130434783, 0.40909090909091
36218, 0.69565217391304, 0.56739130434783, 0.45454545454545
36219, 0.65217391304348, 0.56739130434783, 0.045454545454545
36220, 0.65217391304348, 0.56739130434783, 0.090909090909091
36221, 0.65217391304348, 0.56739130434783, 0.13636363636364
36222, 0.65217391304348, 0.56739130434783, 0.18181818181818
36223, 0.65217391304348, 0.56739130434783, 0.22727272727273
36224, 0.65217391304348, 0.56739130434783, 0.27272727272727
36225, 0.65217391304348, 0.56739130434783, 0.31818181818182
36226, 0.65217391304348, 0.56739130434783, 0.36363636363636
36227, 0.65217391304348, 0.56739130434783, 0.40909090909091
36228, 0.65217391304348, 0.56739130434783, 0.45454545454545
36229, 0.60869565217391, 0.56739130434783, 0.045454545454545
36230, 0.60869565217391, 0.56739130434783, 0.090909090909091
36231, 0.60869565217391, 0.56739130434783, 0.13636363636364
36232, 0.60869565217391, 0.56739130434783, 0.18181818181818
36233, 0.60869565217391, 0.56739130434783, 0.22727272727273
36234, 0.60869565217391, 0.56739130434783, 0.27272727272727
36235, 0.60869565217391, 0.56739130434783, 0.31818181818182
36236, 0.60869565217391, 0.56739130434783, 0.36363636363636
36237, 0.60869565217391, 0.56739130434783, 0.40909090909091
36238, 0.60869565217391, 0.56739130434783, 0.45454545454545
36239, 0.56521739130435, 0.56739130434783, 0.045454545454545
36240, 0.56521739130435, 0.56739130434783, 0.090909090909091
36241, 0.56521739130435, 0.56739130434783, 0.13636363636364
36242, 0.56521739130435, 0.56739130434783, 0.18181818181818
36243, 0.56521739130435, 0.56739130434783, 0.22727272727273
36244, 0.56521739130435, 0.56739130434783, 0.27272727272727
36245, 0.56521739130435, 0.56739130434783, 0.31818181818182
36246, 0.56521739130435, 0.56739130434783, 0.36363636363636
36247, 0.56521739130435, 0.56739130434783, 0.40909090909091
36248, 0.56521739130435, 0.56739130434783, 0.45454545454545
36249, 0.52173913043478, 0.56739130434783, 0.045454545454545
36250, 0.52173913043478, 0.56739130434783, 0.090909090909091
36251, 0.52173913043478, 0.56739130434783, 0.13636363636364
36252, 0.52173913043478, 0.56739130434783, 0.18181818181818
36253, 0.52173913043478, 0.56739130434783, 0.22727272727273
36254, 0.52173913043478, 0.56739130434783, 0.27272727272727
36255, 0.52173913043478, 0.56739130434783, 0.31818181818182
36256, 0.52173913043478, 0.56739130434783, 0.36363636363636
36257, 0.52173913043478, 0.56739130434783, 0.40909090909091
36258, 0.52173913043478, 0.56739130434783, 0.45454545454545
36259, 0.47826086956522, 0.56739130434783, 0.045454545454545
36260, 0.47826086956522, 0.56739130434783, 0.090909090909091
36261, 0.47826086956522, 0.56739130434783, 0.13636363636364
36262, 0.47826086956522, 0.56739130434783, 0.18181818181818
36263, 0.47826086956522, 0.56739130434783, 0.22727272727273
36264, 0.47826086956522, 0.56739130434783, 0.27272727272727
36265, 0.47826086956522, 0.56739130434783, 0.31818181818182
36266, 0.47826086956522, 0.56739130434783, 0.36363636363636
36267, 0.47826086956522, 0.56739130434783, 0.40909090909091
36268, 0.47826086956522, 0.56739130434783, 0.45454545454545
36269, 0.43478260869565, 0.56739130434783, 0.045454545454545
36270, 0.43478260869565, 0.56739130434783, 0.090909090909091
36271, 0.43478260869565, 0.56739130434783, 0.13636363636364
36272, 0.43478260869565, 0.56739130434783, 0.18181818181818
36273, 0.43478260869565, 0.56739130434783, 0.22727272727273
36274, 0.43478260869565, 0.56739130434783, 0.27272727272727
36275, 0.43478260869565, 0.56739130434783, 0.31818181818182
36276, 0.43478260869565, 0.56739130434783, 0.36363636363636
36277, 0.43478260869565, 0.56739130434783, 0.40909090909091
36278, 0.43478260869565, 0.56739130434783, 0.45454545454545
36279, 0.39130434782609, 0.56739130434783, 0.045454545454545
36280, 0.39130434782609, 0.56739130434783, 0.090909090909091
36281, 0.39130434782609, 0.56739130434783, 0.13636363636364
36282, 0.39130434782609, 0.56739130434783, 0.18181818181818
36283, 0.39130434782609, 0.56739130434783, 0.22727272727273
36284, 0.39130434782609, 0.56739130434783, 0.27272727272727
36285, 0.39130434782609, 0.56739130434783, 0.31818181818182
36286, 0.39130434782609, 0.56739130434783, 0.36363636363636
36287, 0.39130434782609, 0.56739130434783, 0.40909090909091
36288, 0.39130434782609, 0.56739130434783, 0.45454545454545
36289, 0.34782608695652, 0.56739130434783, 0.045454545454545
36290, 0.34782608695652, 0.56739130434783, 0.090909090909091
36291, 0.34782608695652, 0.56739130434783, 0.13636363636364
36292, 0.34782608695652, 0.56739130434783, 0.18181818181818
36293, 0.34782608695652, 0.56739130434783, 0.22727272727273
36294, 0.34782608695652, 0.56739130434783, 0.27272727272727
36295, 0.34782608695652, 0.56739130434783, 0.31818181818182
36296, 0.34782608695652, 0.56739130434783, 0.36363636363636
36297, 0.34782608695652, 0.56739130434783, 0.40909090909091
36298, 0.34782608695652, 0.56739130434783, 0.45454545454545
36299, 0.30434782608696, 0.56739130434783, 0.045454545454545
36300, 0.30434782608696, 0.56739130434783, 0.090909090909091
36301, 0.30434782608696, 0.56739130434783, 0.13636363636364
36302, 0.30434782608696, 0.56739130434783, 0.18181818181818
36303, 0.30434782608696, 0.56739130434783, 0.22727272727273
36304, 0.30434782608696, 0.56739130434783, 0.27272727272727
36305, 0.30434782608696, 0.56739130434783, 0.31818181818182
36306, 0.30434782608696, 0.56739130434783, 0.36363636363636
36307, 0.30434782608696, 0.56739130434783, 0.40909090909091
36308, 0.30434782608696, 0.56739130434783, 0.45454545454545
36309, 0.26086956521739, 0.56739130434783, 0.045454545454545
36310, 0.26086956521739, 0.56739130434783, 0.090909090909091
36311, 0.26086956521739, 0.56739130434783, 0.13636363636364
36312, 0.26086956521739, 0.56739130434783, 0.18181818181818
36313, 0.26086956521739, 0.56739130434783, 0.22727272727273
36314, 0.26086956521739, 0.56739130434783, 0.27272727272727
36315, 0.26086956521739, 0.56739130434783, 0.31818181818182
36316, 0.26086956521739, 0.56739130434783, 0.36363636363636
36317, 0.26086956521739, 0.56739130434783, 0.40909090909091
36318, 0.26086956521739, 0.56739130434783, 0.45454545454545
36319, 0.21739130434783, 0.56739130434783, 0.045454545454545
36320, 0.21739130434783, 0.56739130434783, 0.090909090909091
36321, 0.21739130434783, 0.56739130434783, 0.13636363636364
36322, 0.21739130434783, 0.56739130434783, 0.18181818181818
36323, 0.21739130434783, 0.56739130434783, 0.22727272727273
36324, 0.21739130434783, 0.56739130434783, 0.27272727272727
36325, 0.21739130434783, 0.56739130434783, 0.31818181818182
36326, 0.21739130434783, 0.56739130434783, 0.36363636363636
36327, 0.21739130434783, 0.56739130434783, 0.40909090909091
36328, 0.21739130434783, 0.56739130434783, 0.45454545454545
36329, 0.17391304347826, 0.56739130434783, 0.045454545454545
36330, 0.17391304347826, 0.56739130434783, 0.090909090909091
36331, 0.17391304347826, 0.56739130434783, 0.13636363636364
36332, 0.17391304347826, 0.56739130434783, 0.18181818181818
36333, 0.17391304347826, 0.56739130434783, 0.22727272727273
36334, 0.17391304347826, 0.56739130434783, 0.27272727272727
36335, 0.17391304347826, 0.56739130434783, 0.31818181818182
36336, 0.17391304347826, 0.56739130434783, 0.36363636363636
36337, 0.17391304347826, 0.56739130434783, 0.40909090909091
36338, 0.17391304347826, 0.56739130434783, 0.45454545454545
36339, 0.1304347826087, 0.56739130434783, 0.045454545454545
36340, 0.1304347826087, 0.56739130434783, 0.090909090909091
36341, 0.1304347826087, 0.56739130434783, 0.13636363636364
36342, 0.1304347826087, 0.56739130434783, 0.18181818181818
36343, 0.1304347826087, 0.56739130434783, 0.22727272727273
36344, 0.1304347826087, 0.56739130434783, 0.27272727272727
36345, 0.1304347826087, 0.56739130434783, 0.31818181818182
36346, 0.1304347826087, 0.56739130434783, 0.36363636363636
36347, 0.1304347826087, 0.56739130434783, 0.40909090909091
36348, 0.1304347826087, 0.56739130434783, 0.45454545454545
36349, 0.08695652173913, 0.56739130434783, 0.045454545454545
36350, 0.08695652173913, 0.56739130434783, 0.090909090909091
36351, 0.08695652173913, 0.56739130434783, 0.13636363636364
36352, 0.08695652173913, 0.56739130434783, 0.18181818181818
36353, 0.08695652173913, 0.56739130434783, 0.22727272727273
36354, 0.08695652173913, 0.56739130434783, 0.27272727272727
36355, 0.08695652173913, 0.56739130434783, 0.31818181818182
36356, 0.08695652173913, 0.56739130434783, 0.36363636363636
36357, 0.08695652173913, 0.56739130434783, 0.40909090909091
36358, 0.08695652173913, 0.56739130434783, 0.45454545454545
36359, 0.043478260869565, 0.56739130434783, 0.045454545454545
36360, 0.043478260869565, 0.56739130434783, 0.090909090909091
36361, 0.043478260869565, 0.56739130434783, 0.13636363636364
36362, 0.043478260869565, 0.56739130434783, 0.18181818181818
36363, 0.043478260869565, 0.56739130434783, 0.22727272727273
36364, 0.043478260869565, 0.56739130434783, 0.27272727272727
36365, 0.043478260869565, 0.56739130434783, 0.31818181818182
36366, 0.043478260869565, 0.56739130434783, 0.36363636363636
36367, 0.043478260869565, 0.56739130434783, 0.40909090909091
36368, 0.043478260869565, 0.56739130434783, 0.45454545454545
36369, 0.95652173913043, 0.6195652173913, 0.045454545454545
36370, 0.95652173913043, 0.6195652173913, 0.090909090909091
36371, 0.95652173913043, 0.6195652173913, 0.13636363636364
36372, 0.95652173913044, 0.6195652173913, 0.18181818181818
36373, 0.95652173913044, 0.6195652173913, 0.22727272727273
36374, 0.95652173913044, 0.6195652173913, 0.27272727272727
36375, 0.95652173913044, 0.6195652173913, 0.31818181818182
36376, 0.95652173913043, 0.6195652173913, 0.36363636363636
36377, 0.95652173913043, 0.6195652173913, 0.40909090909091
36378, 0.95652173913044, 0.6195652173913, 0.45454545454545
36379, 0.91304347826087, 0.6195652173913, 0.045454545454545
36380, 0.91304347826087, 0.6195652173913, 0.090909090909091
36381, 0.91304347826087, 0.6195652173913, 0.13636363636364
36382, 0.91304347826087, 0.6195652173913, 0.18181818181818
36383, 0.91304347826087, 0.6195652173913, 0.22727272727273
36384, 0.91304347826087, 0.6195652173913, 0.27272727272727
36385, 0.91304347826087, 0.6195652173913, 0.31818181818182
36386, 0.91304347826087, 0.6195652173913, 0.36363636363636
36387, 0.91304347826087, 0.6195652173913, 0.40909090909091
36388, 0.91304347826087, 0.6195652173913, 0.45454545454545
36389, 0.8695652173913, 0.6195652173913, 0.045454545454545
36390, 0.8695652173913, 0.6195652173913, 0.090909090909091
36391, 0.8695652173913, 0.6195652173913, 0.13636363636364
36392, 0.8695652173913, 0.6195652173913, 0.18181818181818
36393, 0.8695652173913, 0.6195652173913, 0.22727272727273
36394, 0.8695652173913, 0.6195652173913, 0.27272727272727
36395, 0.8695652173913, 0.6195652173913, 0.31818181818182
36396, 0.8695652173913, 0.6195652173913, 0.36363636363636
36397, 0.8695652173913, 0.6195652173913, 0.40909090909091
36398, 0.8695652173913, 0.6195652173913, 0.45454545454545
36399, 0.82608695652174, 0.6195652173913, 0.045454545454545
36400, 0.82608695652174, 0.6195652173913, 0.090909090909091
36401, 0.82608695652174, 0.6195652173913, 0.13636363636364
36402, 0.82608695652174, 0.6195652173913, 0.18181818181818
36403, 0.82608695652174, 0.6195652173913, 0.22727272727273
36404, 0.82608695652174, 0.6195652173913, 0.27272727272727
36405, 0.82608695652174, 0.6195652173913, 0.31818181818182
36406, 0.82608695652174, 0.6195652173913, 0.36363636363636
36407, 0.82608695652174, 0.6195652173913, 0.40909090909091
36408, 0.82608695652174, 0.6195652173913, 0.45454545454545
36409, 0.78260869565217, 0.6195652173913, 0.045454545454545
36410, 0.78260869565217, 0.6195652173913, 0.090909090909091
36411, 0.78260869565217, 0.6195652173913, 0.13636363636364
36412, 0.78260869565217, 0.6195652173913, 0.18181818181818
36413, 0.78260869565217, 0.6195652173913, 0.22727272727273
36414, 0.78260869565217, 0.6195652173913, 0.27272727272727
36415, 0.78260869565217, 0.6195652173913, 0.31818181818182
36416, 0.78260869565217, 0.6195652173913, 0.36363636363636
36417, 0.78260869565217, 0.6195652173913, 0.40909090909091
36418, 0.78260869565217, 0.6195652173913, 0.45454545454545
36419, 0.73913043478261, 0.6195652173913, 0.045454545454545
36420, 0.73913043478261, 0.6195652173913, 0.090909090909091
36421, 0.73913043478261, 0.6195652173913, 0.13636363636364
36422, 0.73913043478261, 0.6195652173913, 0.18181818181818
36423, 0.73913043478261, 0.6195652173913, 0.22727272727273
36424, 0.73913043478261, 0.6195652173913, 0.27272727272727
