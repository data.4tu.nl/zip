2557, 5207, 5208, 391, 392, 5240, 5275, 414, 5274
2558, 5208, 5209, 390, 391, 5242, 5276, 413, 5275
2559, 5209, 5210, 389, 390, 5244, 5277, 412, 5276
2560, 5210, 5211, 388, 389, 5246, 5278, 411, 5277
2561, 5211, 5212, 387, 388, 5248, 5279, 410, 5278
2562, 5212, 5213, 386, 387, 5250, 5280, 409, 5279
2563, 5213, 5214, 385, 386, 5252, 5281, 408, 5280
2564, 5214, 5215, 384, 385, 5254, 5282, 407, 5281
2565, 5215, 5216, 383, 384, 5256, 5283, 406, 5282
2566, 5216, 5217, 382, 383, 5258, 5284, 405, 5283
2567, 5217, 5218, 381, 382, 5260, 5285, 404, 5284
2568, 5218, 5219, 380, 381, 5262, 5286, 403, 5285
2569, 5219, 5220, 379, 380, 5264, 5287, 402, 5286
2570, 5220, 376, 10, 379, 5265, 378, 401, 5287
*ELEMENT, type=CPS8, ELSET=Surface8
2571, 7, 176, 5288, 424, 187, 5298, 5299, 425
2572, 176, 175, 5289, 5288, 186, 5300, 5301, 5298
2573, 175, 174, 5290, 5289, 185, 5302, 5303, 5300
2574, 174, 173, 5291, 5290, 184, 5304, 5305, 5302
2575, 173, 172, 5292, 5291, 183, 5306, 5307, 5304
2576, 172, 171, 5293, 5292, 182, 5308, 5309, 5306
2577, 171, 170, 5294, 5293, 181, 5310, 5311, 5308
2578, 170, 169, 5295, 5294, 180, 5312, 5313, 5310
2579, 169, 168, 5296, 5295, 179, 5314, 5315, 5312
2580, 168, 167, 5297, 5296, 178, 5316, 5317, 5314
2581, 167, 8, 373, 5297, 177, 374, 5318, 5316
2582, 424, 5288, 436, 11, 5299, 5319, 447, 426
2583, 5288, 5289, 435, 436, 5301, 5320, 446, 5319
2584, 5289, 5290, 434, 435, 5303, 5321, 445, 5320
2585, 5290, 5291, 433, 434, 5305, 5322, 444, 5321
2586, 5291, 5292, 432, 433, 5307, 5323, 443, 5322
2587, 5292, 5293, 431, 432, 5309, 5324, 442, 5323
2588, 5293, 5294, 430, 431, 5311, 5325, 441, 5324
2589, 5294, 5295, 429, 430, 5313, 5326, 440, 5325
2590, 5295, 5296, 428, 429, 5315, 5327, 439, 5326
2591, 5296, 5297, 427, 428, 5317, 5328, 438, 5327
2592, 5297, 373, 9, 427, 5318, 375, 437, 5328
*ELEMENT, type=CPS8, ELSET=Surface9
2593, 7, 424, 5329, 349, 425, 5351, 5352, 372
2594, 349, 5329, 5330, 348, 5352, 5353, 5354, 371
2595, 348, 5330, 5331, 347, 5354, 5355, 5356, 370
2596, 347, 5331, 5332, 346, 5356, 5357, 5358, 369
2597, 346, 5332, 5333, 345, 5358, 5359, 5360, 368
2598, 345, 5333, 5334, 344, 5360, 5361, 5362, 367
2599, 344, 5334, 5335, 343, 5362, 5363, 5364, 366
2600, 343, 5335, 5336, 342, 5364, 5365, 5366, 365
2601, 342, 5336, 5337, 341, 5366, 5367, 5368, 364
2602, 341, 5337, 5338, 340, 5368, 5369, 5370, 363
2603, 340, 5338, 5339, 339, 5370, 5371, 5372, 362
2604, 339, 5339, 5340, 338, 5372, 5373, 5374, 361
2605, 338, 5340, 5341, 337, 5374, 5375, 5376, 360
2606, 337, 5341, 5342, 336, 5376, 5377, 5378, 359
2607, 336, 5342, 5343, 335, 5378, 5379, 5380, 358
2608, 335, 5343, 5344, 334, 5380, 5381, 5382, 357
2609, 334, 5344, 5345, 333, 5382, 5383, 5384, 356
2610, 333, 5345, 5346, 332, 5384, 5385, 5386, 355
2611, 332, 5346, 5347, 331, 5386, 5387, 5388, 354
2612, 331, 5347, 5348, 330, 5388, 5389, 5390, 353
2613, 330, 5348, 5349, 329, 5390, 5391, 5392, 352
2614, 329, 5349, 5350, 328, 5392, 5393, 5394, 351
2615, 328, 5350, 448, 3, 5394, 5395, 449, 350
2616, 424, 11, 472, 5329, 426, 495, 5396, 5351
2617, 5329, 472, 471, 5330, 5396, 494, 5397, 5353
2618, 5330, 471, 470, 5331, 5397, 493, 5398, 5355
2619, 5331, 470, 469, 5332, 5398, 492, 5399, 5357
2620, 5332, 469, 468, 5333, 5399, 491, 5400, 5359
2621, 5333, 468, 467, 5334, 5400, 490, 5401, 5361
2622, 5334, 467, 466, 5335, 5401, 489, 5402, 5363
2623, 5335, 466, 465, 5336, 5402, 488, 5403, 5365
2624, 5336, 465, 464, 5337, 5403, 487, 5404, 5367
2625, 5337, 464, 463, 5338, 5404, 486, 5405, 5369
2626, 5338, 463, 462, 5339, 5405, 485, 5406, 5371
2627, 5339, 462, 461, 5340, 5406, 484, 5407, 5373
2628, 5340, 461, 460, 5341, 5407, 483, 5408, 5375
2629, 5341, 460, 459, 5342, 5408, 482, 5409, 5377
2630, 5342, 459, 458, 5343, 5409, 481, 5410, 5379
2631, 5343, 458, 457, 5344, 5410, 480, 5411, 5381
2632, 5344, 457, 456, 5345, 5411, 479, 5412, 5383
2633, 5345, 456, 455, 5346, 5412, 478, 5413, 5385
2634, 5346, 455, 454, 5347, 5413, 477, 5414, 5387
2635, 5347, 454, 453, 5348, 5414, 476, 5415, 5389
2636, 5348, 453, 452, 5349, 5415, 475, 5416, 5391
2637, 5349, 452, 451, 5350, 5416, 474, 5417, 5393
2638, 5350, 451, 12, 448, 5417, 473, 450, 5395
*ELEMENT, type=CPS8, ELSET=Surface10
2639, 3, 448, 5418, 124, 449, 5428, 5429, 135
2640, 124, 5418, 5419, 123, 5429, 5430, 5431, 134
2641, 123, 5419, 5420, 122, 5431, 5432, 5433, 133
2642, 122, 5420, 5421, 121, 5433, 5434, 5435, 132
2643, 121, 5421, 5422, 120, 5435, 5436, 5437, 131
2644, 120, 5422, 5423, 119, 5437, 5438, 5439, 130
2645, 119, 5423, 5424, 118, 5439, 5440, 5441, 129
2646, 118, 5424, 5425, 117, 5441, 5442, 5443, 128
2647, 117, 5425, 5426, 116, 5443, 5444, 5445, 127
2648, 116, 5426, 5427, 115, 5445, 5446, 5447, 126
2649, 115, 5427, 376, 4, 5447, 5448, 377, 125
2650, 448, 12, 505, 5418, 450, 516, 5449, 5428
2651, 5418, 505, 504, 5419, 5449, 515, 5450, 5430
2652, 5419, 504, 503, 5420, 5450, 514, 5451, 5432
2653, 5420, 503, 502, 5421, 5451, 513, 5452, 5434
2654, 5421, 502, 501, 5422, 5452, 512, 5453, 5436
2655, 5422, 501, 500, 5423, 5453, 511, 5454, 5438
2656, 5423, 500, 499, 5424, 5454, 510, 5455, 5440
2657, 5424, 499, 498, 5425, 5455, 509, 5456, 5442
2658, 5425, 498, 497, 5426, 5456, 508, 5457, 5444
2659, 5426, 497, 496, 5427, 5457, 507, 5458, 5446
2660, 5427, 496, 10, 376, 5458, 506, 378, 5448
*ELEMENT, type=CPS8, ELSET=Surface11
2661, 10, 496, 5459, 379, 506, 5679, 5680, 401
2662, 496, 497, 5460, 5459, 507, 5681, 5682, 5679
2663, 497, 498, 5461, 5460, 508, 5683, 5684, 5681
2664, 498, 499, 5462, 5461, 509, 5685, 5686, 5683
2665, 499, 500, 5463, 5462, 510, 5687, 5688, 5685
2666, 500, 501, 5464, 5463, 511, 5689, 5690, 5687
2667, 501, 502, 5465, 5464, 512, 5691, 5692, 5689
2668, 502, 503, 5466, 5465, 513, 5693, 5694, 5691
2669, 503, 504, 5467, 5466, 514, 5695, 5696, 5693
2670, 504, 505, 5468, 5467, 515, 5697, 5698, 5695
2671, 505, 12, 451, 5468, 516, 473, 5699, 5697
2672, 379, 5459, 5469, 380, 5680, 5700, 5701, 402
2673, 5459, 5460, 5470, 5469, 5682, 5702, 5703, 5700
2674, 5460, 5461, 5471, 5470, 5684, 5704, 5705, 5702
2675, 5461, 5462, 5472, 5471, 5686, 5706, 5707, 5704
2676, 5462, 5463, 5473, 5472, 5688, 5708, 5709, 5706
2677, 5463, 5464, 5474, 5473, 5690, 5710, 5711, 5708
2678, 5464, 5465, 5475, 5474, 5692, 5712, 5713, 5710
2679, 5465, 5466, 5476, 5475, 5694, 5714, 5715, 5712
2680, 5466, 5467, 5477, 5476, 5696, 5716, 5717, 5714
2681, 5467, 5468, 5478, 5477, 5698, 5718, 5719, 5716
2682, 5468, 451, 452, 5478, 5699, 474, 5720, 5718
2683, 380, 5469, 5479, 381, 5701, 5721, 5722, 403
2684, 5469, 5470, 5480, 5479, 5703, 5723, 5724, 5721
2685, 5470, 5471, 5481, 5480, 5705, 5725, 5726, 5723
2686, 5471, 5472, 5482, 5481, 5707, 5727, 5728, 5725
2687, 5472, 5473, 5483, 5482, 5709, 5729, 5730, 5727
2688, 5473, 5474, 5484, 5483, 5711, 5731, 5732, 5729
2689, 5474, 5475, 5485, 5484, 5713, 5733, 5734, 5731
2690, 5475, 5476, 5486, 5485, 5715, 5735, 5736, 5733
2691, 5476, 5477, 5487, 5486, 5717, 5737, 5738, 5735
2692, 5477, 5478, 5488, 5487, 5719, 5739, 5740, 5737
2693, 5478, 452, 453, 5488, 5720, 475, 5741, 5739
2694, 381, 5479, 5489, 382, 5722, 5742, 5743, 404
2695, 5479, 5480, 5490, 5489, 5724, 5744, 5745, 5742
2696, 5480, 5481, 5491, 5490, 5726, 5746, 5747, 5744
2697, 5481, 5482, 5492, 5491, 5728, 5748, 5749, 5746
2698, 5482, 5483, 5493, 5492, 5730, 5750, 5751, 5748
2699, 5483, 5484, 5494, 5493, 5732, 5752, 5753, 5750
2700, 5484, 5485, 5495, 5494, 5734, 5754, 5755, 5752
2701, 5485, 5486, 5496, 5495, 5736, 5756, 5757, 5754
2702, 5486, 5487, 5497, 5496, 5738, 5758, 5759, 5756
2703, 5487, 5488, 5498, 5497, 5740, 5760, 5761, 5758
2704, 5488, 453, 454, 5498, 5741, 476, 5762, 5760
2705, 382, 5489, 5499, 383, 5743, 5763, 5764, 405
2706, 5489, 5490, 5500, 5499, 5745, 5765, 5766, 5763
2707, 5490, 5491, 5501, 5500, 5747, 5767, 5768, 5765
2708, 5491, 5492, 5502, 5501, 5749, 5769, 5770, 5767
2709, 5492, 5493, 5503, 5502, 5751, 5771, 5772, 5769
2710, 5493, 5494, 5504, 5503, 5753, 5773, 5774, 5771
2711, 5494, 5495, 5505, 5504, 5755, 5775, 5776, 5773
2712, 5495, 5496, 5506, 5505, 5757, 5777, 5778, 5775
2713, 5496, 5497, 5507, 5506, 5759, 5779, 5780, 5777
2714, 5497, 5498, 5508, 5507, 5761, 5781, 5782, 5779
2715, 5498, 454, 455, 5508, 5762, 477, 5783, 5781
2716, 383, 5499, 5509, 384, 5764, 5784, 5785, 406
2717, 5499, 5500, 5510, 5509, 5766, 5786, 5787, 5784
2718, 5500, 5501, 5511, 5510, 5768, 5788, 5789, 5786
2719, 5501, 5502, 5512, 5511, 5770, 5790, 5791, 5788
2720, 5502, 5503, 5513, 5512, 5772, 5792, 5793, 5790
2721, 5503, 5504, 5514, 5513, 5774, 5794, 5795, 5792
2722, 5504, 5505, 5515, 5514, 5776, 5796, 5797, 5794
2723, 5505, 5506, 5516, 5515, 5778, 5798, 5799, 5796
2724, 5506, 5507, 5517, 5516, 5780, 5800, 5801, 5798
2725, 5507, 5508, 5518, 5517, 5782, 5802, 5803, 5800
2726, 5508, 455, 456, 5518, 5783, 478, 5804, 5802
2727, 384, 5509, 5519, 385, 5785, 5805, 5806, 407
2728, 5509, 5510, 5520, 5519, 5787, 5807, 5808, 5805
2729, 5510, 5511, 5521, 5520, 5789, 5809, 5810, 5807
2730, 5511, 5512, 5522, 5521, 5791, 5811, 5812, 5809
2731, 5512, 5513, 5523, 5522, 5793, 5813, 5814, 5811
2732, 5513, 5514, 5524, 5523, 5795, 5815, 5816, 5813
2733, 5514, 5515, 5525, 5524, 5797, 5817, 5818, 5815
2734, 5515, 5516, 5526, 5525, 5799, 5819, 5820, 5817
2735, 5516, 5517, 5527, 5526, 5801, 5821, 5822, 5819
2736, 5517, 5518, 5528, 5527, 5803, 5823, 5824, 5821
2737, 5518, 456, 457, 5528, 5804, 479, 5825, 5823
2738, 385, 5519, 5529, 386, 5806, 5826, 5827, 408
2739, 5519, 5520, 5530, 5529, 5808, 5828, 5829, 5826
2740, 5520, 5521, 5531, 5530, 5810, 5830, 5831, 5828
2741, 5521, 5522, 5532, 5531, 5812, 5832, 5833, 5830
2742, 5522, 5523, 5533, 5532, 5814, 5834, 5835, 5832
2743, 5523, 5524, 5534, 5533, 5816, 5836, 5837, 5834
2744, 5524, 5525, 5535, 5534, 5818, 5838, 5839, 5836
2745, 5525, 5526, 5536, 5535, 5820, 5840, 5841, 5838
2746, 5526, 5527, 5537, 5536, 5822, 5842, 5843, 5840
2747, 5527, 5528, 5538, 5537, 5824, 5844, 5845, 5842
2748, 5528, 457, 458, 5538, 5825, 480, 5846, 5844
2749, 386, 5529, 5539, 387, 5827, 5847, 5848, 409
2750, 5529, 5530, 5540, 5539, 5829, 5849, 5850, 5847
2751, 5530, 5531, 5541, 5540, 5831, 5851, 5852, 5849
2752, 5531, 5532, 5542, 5541, 5833, 5853, 5854, 5851
2753, 5532, 5533, 5543, 5542, 5835, 5855, 5856, 5853
2754, 5533, 5534, 5544, 5543, 5837, 5857, 5858, 5855
2755, 5534, 5535, 5545, 5544, 5839, 5859, 5860, 5857
2756, 5535, 5536, 5546, 5545, 5841, 5861, 5862, 5859
2757, 5536, 5537, 5547, 5546, 5843, 5863, 5864, 5861
2758, 5537, 5538, 5548, 5547, 5845, 5865, 5866, 5863
2759, 5538, 458, 459, 5548, 5846, 481, 5867, 5865
2760, 387, 5539, 5549, 388, 5848, 5868, 5869, 410
2761, 5539, 5540, 5550, 5549, 5850, 5870, 5871, 5868
2762, 5540, 5541, 5551, 5550, 5852, 5872, 5873, 5870
2763, 5541, 5542, 5552, 5551, 5854, 5874, 5875, 5872
2764, 5542, 5543, 5553, 5552, 5856, 5876, 5877, 5874
2765, 5543, 5544, 5554, 5553, 5858, 5878, 5879, 5876
2766, 5544, 5545, 5555, 5554, 5860, 5880, 5881, 5878
2767, 5545, 5546, 5556, 5555, 5862, 5882, 5883, 5880
2768, 5546, 5547, 5557, 5556, 5864, 5884, 5885, 5882
2769, 5547, 5548, 5558, 5557, 5866, 5886, 5887, 5884
2770, 5548, 459, 460, 5558, 5867, 482, 5888, 5886
2771, 388, 5549, 5559, 389, 5869, 5889, 5890, 411
2772, 5549, 5550, 5560, 5559, 5871, 5891, 5892, 5889
2773, 5550, 5551, 5561, 5560, 5873, 5893, 5894, 5891
2774, 5551, 5552, 5562, 5561, 5875, 5895, 5896, 5893
2775, 5552, 5553, 5563, 5562, 5877, 5897, 5898, 5895
2776, 5553, 5554, 5564, 5563, 5879, 5899, 5900, 5897
2777, 5554, 5555, 5565, 5564, 5881, 5901, 5902, 5899
2778, 5555, 5556, 5566, 5565, 5883, 5903, 5904, 5901
2779, 5556, 5557, 5567, 5566, 5885, 5905, 5906, 5903
2780, 5557, 5558, 5568, 5567, 5887, 5907, 5908, 5905
2781, 5558, 460, 461, 5568, 5888, 483, 5909, 5907
2782, 389, 5559, 5569, 390, 5890, 5910, 5911, 412
2783, 5559, 5560, 5570, 5569, 5892, 5912, 5913, 5910
2784, 5560, 5561, 5571, 5570, 5894, 5914, 5915, 5912
2785, 5561, 5562, 5572, 5571, 5896, 5916, 5917, 5914
2786, 5562, 5563, 5573, 5572, 5898, 5918, 5919, 5916
2787, 5563, 5564, 5574, 5573, 5900, 5920, 5921, 5918
2788, 5564, 5565, 5575, 5574, 5902, 5922, 5923, 5920
2789, 5565, 5566, 5576, 5575, 5904, 5924, 5925, 5922
2790, 5566, 5567, 5577, 5576, 5906, 5926, 5927, 5924
2791, 5567, 5568, 5578, 5577, 5908, 5928, 5929, 5926
2792, 5568, 461, 462, 5578, 5909, 484, 5930, 5928
2793, 390, 5569, 5579, 391, 5911, 5931, 5932, 413
2794, 5569, 5570, 5580, 5579, 5913, 5933, 5934, 5931
2795, 5570, 5571, 5581, 5580, 5915, 5935, 5936, 5933
2796, 5571, 5572, 5582, 5581, 5917, 5937, 5938, 5935
2797, 5572, 5573, 5583, 5582, 5919, 5939, 5940, 5937
2798, 5573, 5574, 5584, 5583, 5921, 5941, 5942, 5939
2799, 5574, 5575, 5585, 5584, 5923, 5943, 5944, 5941
2800, 5575, 5576, 5586, 5585, 5925, 5945, 5946, 5943
2801, 5576, 5577, 5587, 5586, 5927, 5947, 5948, 5945
2802, 5577, 5578, 5588, 5587, 5929, 5949, 5950, 5947
2803, 5578, 462, 463, 5588, 5930, 485, 5951, 5949
2804, 391, 5579, 5589, 392, 5932, 5952, 5953, 414
2805, 5579, 5580, 5590, 5589, 5934, 5954, 5955, 5952
2806, 5580, 5581, 5591, 5590, 5936, 5956, 5957, 5954
2807, 5581, 5582, 5592, 5591, 5938, 5958, 5959, 5956
2808, 5582, 5583, 5593, 5592, 5940, 5960, 5961, 5958
2809, 5583, 5584, 5594, 5593, 5942, 5962, 5963, 5960
2810, 5584, 5585, 5595, 5594, 5944, 5964, 5965, 5962
2811, 5585, 5586, 5596, 5595, 5946, 5966, 5967, 5964
2812, 5586, 5587, 5597, 5596, 5948, 5968, 5969, 5966
2813, 5587, 5588, 5598, 5597, 5950, 5970, 5971, 5968
2814, 5588, 463, 464, 5598, 5951, 486, 5972, 5970
2815, 392, 5589, 5599, 393, 5953, 5973, 5974, 415
2816, 5589, 5590, 5600, 5599, 5955, 5975, 5976, 5973
2817, 5590, 5591, 5601, 5600, 5957, 5977, 5978, 5975
2818, 5591, 5592, 5602, 5601, 5959, 5979, 5980, 5977
2819, 5592, 5593, 5603, 5602, 5961, 5981, 5982, 5979
2820, 5593, 5594, 5604, 5603, 5963, 5983, 5984, 5981
2821, 5594, 5595, 5605, 5604, 5965, 5985, 5986, 5983
2822, 5595, 5596, 5606, 5605, 5967, 5987, 5988, 5985
2823, 5596, 5597, 5607, 5606, 5969, 5989, 5990, 5987
2824, 5597, 5598, 5608, 5607, 5971, 5991, 5992, 5989
2825, 5598, 464, 465, 5608, 5972, 487, 5993, 5991
2826, 393, 5599, 5609, 394, 5974, 5994, 5995, 416
2827, 5599, 5600, 5610, 5609, 5976, 5996, 5997, 5994
2828, 5600, 5601, 5611, 5610, 5978, 5998, 5999, 5996
2829, 5601, 5602, 5612, 5611, 5980, 6000, 6001, 5998
2830, 5602, 5603, 5613, 5612, 5982, 6002, 6003, 6000
2831, 5603, 5604, 5614, 5613, 5984, 6004, 6005, 6002
2832, 5604, 5605, 5615, 5614, 5986, 6006, 6007, 6004
2833, 5605, 5606, 5616, 5615, 5988, 6008, 6009, 6006
2834, 5606, 5607, 5617, 5616, 5990, 6010, 6011, 6008
2835, 5607, 5608, 5618, 5617, 5992, 6012, 6013, 6010
2836, 5608, 465, 466, 5618, 5993, 488, 6014, 6012
2837, 394, 5609, 5619, 395, 5995, 6015, 6016, 417
2838, 5609, 5610, 5620, 5619, 5997, 6017, 6018, 6015
2839, 5610, 5611, 5621, 5620, 5999, 6019, 6020, 6017
2840, 5611, 5612, 5622, 5621, 6001, 6021, 6022, 6019
2841, 5612, 5613, 5623, 5622, 6003, 6023, 6024, 6021
2842, 5613, 5614, 5624, 5623, 6005, 6025, 6026, 6023
2843, 5614, 5615, 5625, 5624, 6007, 6027, 6028, 6025
2844, 5615, 5616, 5626, 5625, 6009, 6029, 6030, 6027
2845, 5616, 5617, 5627, 5626, 6011, 6031, 6032, 6029
2846, 5617, 5618, 5628, 5627, 6013, 6033, 6034, 6031
2847, 5618, 466, 467, 5628, 6014, 489, 6035, 6033
2848, 395, 5619, 5629, 396, 6016, 6036, 6037, 418
2849, 5619, 5620, 5630, 5629, 6018, 6038, 6039, 6036
2850, 5620, 5621, 5631, 5630, 6020, 6040, 6041, 6038
2851, 5621, 5622, 5632, 5631, 6022, 6042, 6043, 6040
2852, 5622, 5623, 5633, 5632, 6024, 6044, 6045, 6042
2853, 5623, 5624, 5634, 5633, 6026, 6046, 6047, 6044
2854, 5624, 5625, 5635, 5634, 6028, 6048, 6049, 6046
2855, 5625, 5626, 5636, 5635, 6030, 6050, 6051, 6048
2856, 5626, 5627, 5637, 5636, 6032, 6052, 6053, 6050
2857, 5627, 5628, 5638, 5637, 6034, 6054, 6055, 6052
2858, 5628, 467, 468, 5638, 6035, 490, 6056, 6054
2859, 396, 5629, 5639, 397, 6037, 6057, 6058, 419
2860, 5629, 5630, 5640, 5639, 6039, 6059, 6060, 6057
2861, 5630, 5631, 5641, 5640, 6041, 6061, 6062, 6059
2862, 5631, 5632, 5642, 5641, 6043, 6063, 6064, 6061
2863, 5632, 5633, 5643, 5642, 6045, 6065, 6066, 6063
2864, 5633, 5634, 5644, 5643, 6047, 6067, 6068, 6065
2865, 5634, 5635, 5645, 5644, 6049, 6069, 6070, 6067
2866, 5635, 5636, 5646, 5645, 6051, 6071, 6072, 6069
2867, 5636, 5637, 5647, 5646, 6053, 6073, 6074, 6071
2868, 5637, 5638, 5648, 5647, 6055, 6075, 6076, 6073
2869, 5638, 468, 469, 5648, 6056, 491, 6077, 6075
2870, 397, 5639, 5649, 398, 6058, 6078, 6079, 420
2871, 5639, 5640, 5650, 5649, 6060, 6080, 6081, 6078
2872, 5640, 5641, 5651, 5650, 6062, 6082, 6083, 6080
2873, 5641, 5642, 5652, 5651, 6064, 6084, 6085, 6082
2874, 5642, 5643, 5653, 5652, 6066, 6086, 6087, 6084
2875, 5643, 5644, 5654, 5653, 6068, 6088, 6089, 6086
2876, 5644, 5645, 5655, 5654, 6070, 6090, 6091, 6088
2877, 5645, 5646, 5656, 5655, 6072, 6092, 6093, 6090
2878, 5646, 5647, 5657, 5656, 6074, 6094, 6095, 6092
2879, 5647, 5648, 5658, 5657, 6076, 6096, 6097, 6094
2880, 5648, 469, 470, 5658, 6077, 492, 6098, 6096
2881, 398, 5649, 5659, 399, 6079, 6099, 6100, 421
2882, 5649, 5650, 5660, 5659, 6081, 6101, 6102, 6099
2883, 5650, 5651, 5661, 5660, 6083, 6103, 6104, 6101
2884, 5651, 5652, 5662, 5661, 6085, 6105, 6106, 6103
2885, 5652, 5653, 5663, 5662, 6087, 6107, 6108, 6105
2886, 5653, 5654, 5664, 5663, 6089, 6109, 6110, 6107
2887, 5654, 5655, 5665, 5664, 6091, 6111, 6112, 6109
2888, 5655, 5656, 5666, 5665, 6093, 6113, 6114, 6111
2889, 5656, 5657, 5667, 5666, 6095, 6115, 6116, 6113
2890, 5657, 5658, 5668, 5667, 6097, 6117, 6118, 6115
2891, 5658, 470, 471, 5668, 6098, 493, 6119, 6117
2892, 399, 5659, 5669, 400, 6100, 6120, 6121, 422
2893, 5659, 5660, 5670, 5669, 6102, 6122, 6123, 6120
2894, 5660, 5661, 5671, 5670, 6104, 6124, 6125, 6122
2895, 5661, 5662, 5672, 5671, 6106, 6126, 6127, 6124
2896, 5662, 5663, 5673, 5672, 6108, 6128, 6129, 6126
2897, 5663, 5664, 5674, 5673, 6110, 6130, 6131, 6128
2898, 5664, 5665, 5675, 5674, 6112, 6132, 6133, 6130
2899, 5665, 5666, 5676, 5675, 6114, 6134, 6135, 6132
2900, 5666, 5667, 5677, 5676, 6116, 6136, 6137, 6134
2901, 5667, 5668, 5678, 5677, 6118, 6138, 6139, 6136
2902, 5668, 471, 472, 5678, 6119, 494, 6140, 6138
2903, 400, 5669, 427, 9, 6121, 6141, 437, 423
2904, 5669, 5670, 428, 427, 6123, 6142, 438, 6141
2905, 5670, 5671, 429, 428, 6125, 6143, 439, 6142
2906, 5671, 5672, 430, 429, 6127, 6144, 440, 6143
2907, 5672, 5673, 431, 430, 6129, 6145, 441, 6144
2908, 5673, 5674, 432, 431, 6131, 6146, 442, 6145
2909, 5674, 5675, 433, 432, 6133, 6147, 443, 6146
2910, 5675, 5676, 434, 433, 6135, 6148, 444, 6147
2911, 5676, 5677, 435, 434, 6137, 6149, 445, 6148
2912, 5677, 5678, 436, 435, 6139, 6150, 446, 6149
2913, 5678, 472, 11, 436, 6140, 495, 447, 6150
*ELEMENT, type=CPS8, ELSET=Surface12
2914, 9, 400, 6151, 517, 423, 6635, 6636, 539
2915, 400, 399, 6152, 6151, 422, 6637, 6638, 6635
2916, 399, 398, 6153, 6152, 421, 6639, 6640, 6637
2917, 398, 397, 6154, 6153, 420, 6641, 6642, 6639
2918, 397, 396, 6155, 6154, 419, 6643, 6644, 6641
2919, 396, 395, 6156, 6155, 418, 6645, 6646, 6643
2920, 395, 394, 6157, 6156, 417, 6647, 6648, 6645
2921, 394, 393, 6158, 6157, 416, 6649, 6650, 6647
2922, 393, 392, 6159, 6158, 415, 6651, 6652, 6649
2923, 392, 391, 6160, 6159, 414, 6653, 6654, 6651
2924, 391, 390, 6161, 6160, 413, 6655, 6656, 6653
2925, 390, 389, 6162, 6161, 412, 6657, 6658, 6655
2926, 389, 388, 6163, 6162, 411, 6659, 6660, 6657
2927, 388, 387, 6164, 6163, 410, 6661, 6662, 6659
2928, 387, 386, 6165, 6164, 409, 6663, 6664, 6661
2929, 386, 385, 6166, 6165, 408, 6665, 6666, 6663
2930, 385, 384, 6167, 6166, 407, 6667, 6668, 6665
2931, 384, 383, 6168, 6167, 406, 6669, 6670, 6667
2932, 383, 382, 6169, 6168, 405, 6671, 6672, 6669
2933, 382, 381, 6170, 6169, 404, 6673, 6674, 6671
2934, 381, 380, 6171, 6170, 403, 6675, 6676, 6673
2935, 380, 379, 6172, 6171, 402, 6677, 6678, 6675
2936, 379, 10, 562, 6172, 401, 584, 6679, 6677
2937, 517, 6151, 6173, 518, 6636, 6680, 6681, 540
2938, 6151, 6152, 6174, 6173, 6638, 6682, 6683, 6680
2939, 6152, 6153, 6175, 6174, 6640, 6684, 6685, 6682
2940, 6153, 6154, 6176, 6175, 6642, 6686, 6687, 6684
2941, 6154, 6155, 6177, 6176, 6644, 6688, 6689, 6686
2942, 6155, 6156, 6178, 6177, 6646, 6690, 6691, 6688
2943, 6156, 6157, 6179, 6178, 6648, 6692, 6693, 6690
2944, 6157, 6158, 6180, 6179, 6650, 6694, 6695, 6692
2945, 6158, 6159, 6181, 6180, 6652, 6696, 6697, 6694
2946, 6159, 6160, 6182, 6181, 6654, 6698, 6699, 6696
2947, 6160, 6161, 6183, 6182, 6656, 6700, 6701, 6698
2948, 6161, 6162, 6184, 6183, 6658, 6702, 6703, 6700
2949, 6162, 6163, 6185, 6184, 6660, 6704, 6705, 6702
2950, 6163, 6164, 6186, 6185, 6662, 6706, 6707, 6704
2951, 6164, 6165, 6187, 6186, 6664, 6708, 6709, 6706
2952, 6165, 6166, 6188, 6187, 6666, 6710, 6711, 6708
2953, 6166, 6167, 6189, 6188, 6668, 6712, 6713, 6710
2954, 6167, 6168, 6190, 6189, 6670, 6714, 6715, 6712
2955, 6168, 6169, 6191, 6190, 6672, 6716, 6717, 6714
2956, 6169, 6170, 6192, 6191, 6674, 6718, 6719, 6716
2957, 6170, 6171, 6193, 6192, 6676, 6720, 6721, 6718
2958, 6171, 6172, 6194, 6193, 6678, 6722, 6723, 6720
2959, 6172, 562, 563, 6194, 6679, 585, 6724, 6722
2960, 518, 6173, 6195, 519, 6681, 6725, 6726, 541
2961, 6173, 6174, 6196, 6195, 6683, 6727, 6728, 6725
2962, 6174, 6175, 6197, 6196, 6685, 6729, 6730, 6727
2963, 6175, 6176, 6198, 6197, 6687, 6731, 6732, 6729
2964, 6176, 6177, 6199, 6198, 6689, 6733, 6734, 6731
2965, 6177, 6178, 6200, 6199, 6691, 6735, 6736, 6733
2966, 6178, 6179, 6201, 6200, 6693, 6737, 6738, 6735
2967, 6179, 6180, 6202, 6201, 6695, 6739, 6740, 6737
2968, 6180, 6181, 6203, 6202, 6697, 6741, 6742, 6739
2969, 6181, 6182, 6204, 6203, 6699, 6743, 6744, 6741
2970, 6182, 6183, 6205, 6204, 6701, 6745, 6746, 6743
2971, 6183, 6184, 6206, 6205, 6703, 6747, 6748, 6745
2972, 6184, 6185, 6207, 6206, 6705, 6749, 6750, 6747
2973, 6185, 6186, 6208, 6207, 6707, 6751, 6752, 6749
2974, 6186, 6187, 6209, 6208, 6709, 6753, 6754, 6751
2975, 6187, 6188, 6210, 6209, 6711, 6755, 6756, 6753
2976, 6188, 6189, 6211, 6210, 6713, 6757, 6758, 6755
2977, 6189, 6190, 6212, 6211, 6715, 6759, 6760, 6757
2978, 6190, 6191, 6213, 6212, 6717, 6761, 6762, 6759
2979, 6191, 6192, 6214, 6213, 6719, 6763, 6764, 6761
2980, 6192, 6193, 6215, 6214, 6721, 6765, 6766, 6763
2981, 6193, 6194, 6216, 6215, 6723, 6767, 6768, 6765
2982, 6194, 563, 564, 6216, 6724, 586, 6769, 6767
2983, 519, 6195, 6217, 520, 6726, 6770, 6771, 542
2984, 6195, 6196, 6218, 6217, 6728, 6772, 6773, 6770
2985, 6196, 6197, 6219, 6218, 6730, 6774, 6775, 6772
2986, 6197, 6198, 6220, 6219, 6732, 6776, 6777, 6774
2987, 6198, 6199, 6221, 6220, 6734, 6778, 6779, 6776
2988, 6199, 6200, 6222, 6221, 6736, 6780, 6781, 6778
2989, 6200, 6201, 6223, 6222, 6738, 6782, 6783, 6780
2990, 6201, 6202, 6224, 6223, 6740, 6784, 6785, 6782
2991, 6202, 6203, 6225, 6224, 6742, 6786, 6787, 6784
2992, 6203, 6204, 6226, 6225, 6744, 6788, 6789, 6786
2993, 6204, 6205, 6227, 6226, 6746, 6790, 6791, 6788
2994, 6205, 6206, 6228, 6227, 6748, 6792, 6793, 6790
2995, 6206, 6207, 6229, 6228, 6750, 6794, 6795, 6792
2996, 6207, 6208, 6230, 6229, 6752, 6796, 6797, 6794
2997, 6208, 6209, 6231, 6230, 6754, 6798, 6799, 6796
2998, 6209, 6210, 6232, 6231, 6756, 6800, 6801, 6798
2999, 6210, 6211, 6233, 6232, 6758, 6802, 6803, 6800
3000, 6211, 6212, 6234, 6233, 6760, 6804, 6805, 6802
3001, 6212, 6213, 6235, 6234, 6762, 6806, 6807, 6804
3002, 6213, 6214, 6236, 6235, 6764, 6808, 6809, 6806
3003, 6214, 6215, 6237, 6236, 6766, 6810, 6811, 6808
3004, 6215, 6216, 6238, 6237, 6768, 6812, 6813, 6810
3005, 6216, 564, 565, 6238, 6769, 587, 6814, 6812
3006, 520, 6217, 6239, 521, 6771, 6815, 6816, 543
3007, 6217, 6218, 6240, 6239, 6773, 6817, 6818, 6815
3008, 6218, 6219, 6241, 6240, 6775, 6819, 6820, 6817
3009, 6219, 6220, 6242, 6241, 6777, 6821, 6822, 6819
3010, 6220, 6221, 6243, 6242, 6779, 6823, 6824, 6821
3011, 6221, 6222, 6244, 6243, 6781, 6825, 6826, 6823
3012, 6222, 6223, 6245, 6244, 6783, 6827, 6828, 6825
3013, 6223, 6224, 6246, 6245, 6785, 6829, 6830, 6827
3014, 6224, 6225, 6247, 6246, 6787, 6831, 6832, 6829
3015, 6225, 6226, 6248, 6247, 6789, 6833, 6834, 6831
3016, 6226, 6227, 6249, 6248, 6791, 6835, 6836, 6833
3017, 6227, 6228, 6250, 6249, 6793, 6837, 6838, 6835
3018, 6228, 6229, 6251, 6250, 6795, 6839, 6840, 6837
3019, 6229, 6230, 6252, 6251, 6797, 6841, 6842, 6839
3020, 6230, 6231, 6253, 6252, 6799, 6843, 6844, 6841
3021, 6231, 6232, 6254, 6253, 6801, 6845, 6846, 6843
3022, 6232, 6233, 6255, 6254, 6803, 6847, 6848, 6845
3023, 6233, 6234, 6256, 6255, 6805, 6849, 6850, 6847
3024, 6234, 6235, 6257, 6256, 6807, 6851, 6852, 6849
3025, 6235, 6236, 6258, 6257, 6809, 6853, 6854, 6851
3026, 6236, 6237, 6259, 6258, 6811, 6855, 6856, 6853
3027, 6237, 6238, 6260, 6259, 6813, 6857, 6858, 6855
3028, 6238, 565, 566, 6260, 6814, 588, 6859, 6857
3029, 521, 6239, 6261, 522, 6816, 6860, 6861, 544
3030, 6239, 6240, 6262, 6261, 6818, 6862, 6863, 6860
3031, 6240, 6241, 6263, 6262, 6820, 6864, 6865, 6862
3032, 6241, 6242, 6264, 6263, 6822, 6866, 6867, 6864
3033, 6242, 6243, 6265, 6264, 6824, 6868, 6869, 6866
3034, 6243, 6244, 6266, 6265, 6826, 6870, 6871, 6868
3035, 6244, 6245, 6267, 6266, 6828, 6872, 6873, 6870
3036, 6245, 6246, 6268, 6267, 6830, 6874, 6875, 6872
3037, 6246, 6247, 6269, 6268, 6832, 6876, 6877, 6874
3038, 6247, 6248, 6270, 6269, 6834, 6878, 6879, 6876
3039, 6248, 6249, 6271, 6270, 6836, 6880, 6881, 6878
3040, 6249, 6250, 6272, 6271, 6838, 6882, 6883, 6880
3041, 6250, 6251, 6273, 6272, 6840, 6884, 6885, 6882
3042, 6251, 6252, 6274, 6273, 6842, 6886, 6887, 6884
3043, 6252, 6253, 6275, 6274, 6844, 6888, 6889, 6886
3044, 6253, 6254, 6276, 6275, 6846, 6890, 6891, 6888
3045, 6254, 6255, 6277, 6276, 6848, 6892, 6893, 6890
3046, 6255, 6256, 6278, 6277, 6850, 6894, 6895, 6892
3047, 6256, 6257, 6279, 6278, 6852, 6896, 6897, 6894
3048, 6257, 6258, 6280, 6279, 6854, 6898, 6899, 6896
3049, 6258, 6259, 6281, 6280, 6856, 6900, 6901, 6898
3050, 6259, 6260, 6282, 6281, 6858, 6902, 6903, 6900
3051, 6260, 566, 567, 6282, 6859, 589, 6904, 6902
3052, 522, 6261, 6283, 523, 6861, 6905, 6906, 545
3053, 6261, 6262, 6284, 6283, 6863, 6907, 6908, 6905
3054, 6262, 6263, 6285, 6284, 6865, 6909, 6910, 6907
3055, 6263, 6264, 6286, 6285, 6867, 6911, 6912, 6909
3056, 6264, 6265, 6287, 6286, 6869, 6913, 6914, 6911
3057, 6265, 6266, 6288, 6287, 6871, 6915, 6916, 6913
3058, 6266, 6267, 6289, 6288, 6873, 6917, 6918, 6915
3059, 6267, 6268, 6290, 6289, 6875, 6919, 6920, 6917
3060, 6268, 6269, 6291, 6290, 6877, 6921, 6922, 6919
3061, 6269, 6270, 6292, 6291, 6879, 6923, 6924, 6921
3062, 6270, 6271, 6293, 6292, 6881, 6925, 6926, 6923
3063, 6271, 6272, 6294, 6293, 6883, 6927, 6928, 6925
3064, 6272, 6273, 6295, 6294, 6885, 6929, 6930, 6927
3065, 6273, 6274, 6296, 6295, 6887, 6931, 6932, 6929
3066, 6274, 6275, 6297, 6296, 6889, 6933, 6934, 6931
3067, 6275, 6276, 6298, 6297, 6891, 6935, 6936, 6933
3068, 6276, 6277, 6299, 6298, 6893, 6937, 6938, 6935
3069, 6277, 6278, 6300, 6299, 6895, 6939, 6940, 6937
3070, 6278, 6279, 6301, 6300, 6897, 6941, 6942, 6939
3071, 6279, 6280, 6302, 6301, 6899, 6943, 6944, 6941
3072, 6280, 6281, 6303, 6302, 6901, 6945, 6946, 6943
3073, 6281, 6282, 6304, 6303, 6903, 6947, 6948, 6945
3074, 6282, 567, 568, 6304, 6904, 590, 6949, 6947
3075, 523, 6283, 6305, 524, 6906, 6950, 6951, 546
3076, 6283, 6284, 6306, 6305, 6908, 6952, 6953, 6950
3077, 6284, 6285, 6307, 6306, 6910, 6954, 6955, 6952
3078, 6285, 6286, 6308, 6307, 6912, 6956, 6957, 6954
3079, 6286, 6287, 6309, 6308, 6914, 6958, 6959, 6956
3080, 6287, 6288, 6310, 6309, 6916, 6960, 6961, 6958
3081, 6288, 6289, 6311, 6310, 6918, 6962, 6963, 6960
3082, 6289, 6290, 6312, 6311, 6920, 6964, 6965, 6962
3083, 6290, 6291, 6313, 6312, 6922, 6966, 6967, 6964
3084, 6291, 6292, 6314, 6313, 6924, 6968, 6969, 6966
3085, 6292, 6293, 6315, 6314, 6926, 6970, 6971, 6968
3086, 6293, 6294, 6316, 6315, 6928, 6972, 6973, 6970
3087, 6294, 6295, 6317, 6316, 6930, 6974, 6975, 6972
3088, 6295, 6296, 6318, 6317, 6932, 6976, 6977, 6974
3089, 6296, 6297, 6319, 6318, 6934, 6978, 6979, 6976
3090, 6297, 6298, 6320, 6319, 6936, 6980, 6981, 6978
3091, 6298, 6299, 6321, 6320, 6938, 6982, 6983, 6980
3092, 6299, 6300, 6322, 6321, 6940, 6984, 6985, 6982
3093, 6300, 6301, 6323, 6322, 6942, 6986, 6987, 6984
3094, 6301, 6302, 6324, 6323, 6944, 6988, 6989, 6986
3095, 6302, 6303, 6325, 6324, 6946, 6990, 6991, 6988
3096, 6303, 6304, 6326, 6325, 6948, 6992, 6993, 6990
3097, 6304, 568, 569, 6326, 6949, 591, 6994, 6992
3098, 524, 6305, 6327, 525, 6951, 6995, 6996, 547
3099, 6305, 6306, 6328, 6327, 6953, 6997, 6998, 6995
3100, 6306, 6307, 6329, 6328, 6955, 6999, 7000, 6997
3101, 6307, 6308, 6330, 6329, 6957, 7001, 7002, 6999
3102, 6308, 6309, 6331, 6330, 6959, 7003, 7004, 7001
3103, 6309, 6310, 6332, 6331, 6961, 7005, 7006, 7003
3104, 6310, 6311, 6333, 6332, 6963, 7007, 7008, 7005
3105, 6311, 6312, 6334, 6333, 6965, 7009, 7010, 7007
3106, 6312, 6313, 6335, 6334, 6967, 7011, 7012, 7009
3107, 6313, 6314, 6336, 6335, 6969, 7013, 7014, 7011
3108, 6314, 6315, 6337, 6336, 6971, 7015, 7016, 7013
3109, 6315, 6316, 6338, 6337, 6973, 7017, 7018, 7015
3110, 6316, 6317, 6339, 6338, 6975, 7019, 7020, 7017
3111, 6317, 6318, 6340, 6339, 6977, 7021, 7022, 7019
3112, 6318, 6319, 6341, 6340, 6979, 7023, 7024, 7021
3113, 6319, 6320, 6342, 6341, 6981, 7025, 7026, 7023
3114, 6320, 6321, 6343, 6342, 6983, 7027, 7028, 7025
3115, 6321, 6322, 6344, 6343, 6985, 7029, 7030, 7027
3116, 6322, 6323, 6345, 6344, 6987, 7031, 7032, 7029
3117, 6323, 6324, 6346, 6345, 6989, 7033, 7034, 7031
3118, 6324, 6325, 6347, 6346, 6991, 7035, 7036, 7033
3119, 6325, 6326, 6348, 6347, 6993, 7037, 7038, 7035
3120, 6326, 569, 570, 6348, 6994, 592, 7039, 7037
3121, 525, 6327, 6349, 526, 6996, 7040, 7041, 548
3122, 6327, 6328, 6350, 6349, 6998, 7042, 7043, 7040
3123, 6328, 6329, 6351, 6350, 7000, 7044, 7045, 7042
3124, 6329, 6330, 6352, 6351, 7002, 7046, 7047, 7044
3125, 6330, 6331, 6353, 6352, 7004, 7048, 7049, 7046
3126, 6331, 6332, 6354, 6353, 7006, 7050, 7051, 7048
3127, 6332, 6333, 6355, 6354, 7008, 7052, 7053, 7050
3128, 6333, 6334, 6356, 6355, 7010, 7054, 7055, 7052
3129, 6334, 6335, 6357, 6356, 7012, 7056, 7057, 7054
3130, 6335, 6336, 6358, 6357, 7014, 7058, 7059, 7056
3131, 6336, 6337, 6359, 6358, 7016, 7060, 7061, 7058
3132, 6337, 6338, 6360, 6359, 7018, 7062, 7063, 7060
3133, 6338, 6339, 6361, 6360, 7020, 7064, 7065, 7062
3134, 6339, 6340, 6362, 6361, 7022, 7066, 7067, 7064
3135, 6340, 6341, 6363, 6362, 7024, 7068, 7069, 7066
3136, 6341, 6342, 6364, 6363, 7026, 7070, 7071, 7068
3137, 6342, 6343, 6365, 6364, 7028, 7072, 7073, 7070
3138, 6343, 6344, 6366, 6365, 7030, 7074, 7075, 7072
3139, 6344, 6345, 6367, 6366, 7032, 7076, 7077, 7074
3140, 6345, 6346, 6368, 6367, 7034, 7078, 7079, 7076
3141, 6346, 6347, 6369, 6368, 7036, 7080, 7081, 7078
3142, 6347, 6348, 6370, 6369, 7038, 7082, 7083, 7080
3143, 6348, 570, 571, 6370, 7039, 593, 7084, 7082
3144, 526, 6349, 6371, 527, 7041, 7085, 7086, 549
3145, 6349, 6350, 6372, 6371, 7043, 7087, 7088, 7085
3146, 6350, 6351, 6373, 6372, 7045, 7089, 7090, 7087
3147, 6351, 6352, 6374, 6373, 7047, 7091, 7092, 7089
3148, 6352, 6353, 6375, 6374, 7049, 7093, 7094, 7091
3149, 6353, 6354, 6376, 6375, 7051, 7095, 7096, 7093
3150, 6354, 6355, 6377, 6376, 7053, 7097, 7098, 7095
3151, 6355, 6356, 6378, 6377, 7055, 7099, 7100, 7097
3152, 6356, 6357, 6379, 6378, 7057, 7101, 7102, 7099
3153, 6357, 6358, 6380, 6379, 7059, 7103, 7104, 7101
3154, 6358, 6359, 6381, 6380, 7061, 7105, 7106, 7103
3155, 6359, 6360, 6382, 6381, 7063, 7107, 7108, 7105
3156, 6360, 6361, 6383, 6382, 7065, 7109, 7110, 7107
3157, 6361, 6362, 6384, 6383, 7067, 7111, 7112, 7109
3158, 6362, 6363, 6385, 6384, 7069, 7113, 7114, 7111
3159, 6363, 6364, 6386, 6385, 7071, 7115, 7116, 7113
3160, 6364, 6365, 6387, 6386, 7073, 7117, 7118, 7115
3161, 6365, 6366, 6388, 6387, 7075, 7119, 7120, 7117
3162, 6366, 6367, 6389, 6388, 7077, 7121, 7122, 7119
3163, 6367, 6368, 6390, 6389, 7079, 7123, 7124, 7121
3164, 6368, 6369, 6391, 6390, 7081, 7125, 7126, 7123
3165, 6369, 6370, 6392, 6391, 7083, 7127, 7128, 7125
3166, 6370, 571, 572, 6392, 7084, 594, 7129, 7127
3167, 527, 6371, 6393, 528, 7086, 7130, 7131, 550
3168, 6371, 6372, 6394, 6393, 7088, 7132, 7133, 7130
3169, 6372, 6373, 6395, 6394, 7090, 7134, 7135, 7132
3170, 6373, 6374, 6396, 6395, 7092, 7136, 7137, 7134
3171, 6374, 6375, 6397, 6396, 7094, 7138, 7139, 7136
3172, 6375, 6376, 6398, 6397, 7096, 7140, 7141, 7138
3173, 6376, 6377, 6399, 6398, 7098, 7142, 7143, 7140
3174, 6377, 6378, 6400, 6399, 7100, 7144, 7145, 7142
3175, 6378, 6379, 6401, 6400, 7102, 7146, 7147, 7144
3176, 6379, 6380, 6402, 6401, 7104, 7148, 7149, 7146
3177, 6380, 6381, 6403, 6402, 7106, 7150, 7151, 7148
3178, 6381, 6382, 6404, 6403, 7108, 7152, 7153, 7150
3179, 6382, 6383, 6405, 6404, 7110, 7154, 7155, 7152
3180, 6383, 6384, 6406, 6405, 7112, 7156, 7157, 7154
3181, 6384, 6385, 6407, 6406, 7114, 7158, 7159, 7156
3182, 6385, 6386, 6408, 6407, 7116, 7160, 7161, 7158
3183, 6386, 6387, 6409, 6408, 7118, 7162, 7163, 7160
3184, 6387, 6388, 6410, 6409, 7120, 7164, 7165, 7162
3185, 6388, 6389, 6411, 6410, 7122, 7166, 7167, 7164
3186, 6389, 6390, 6412, 6411, 7124, 7168, 7169, 7166
3187, 6390, 6391, 6413, 6412, 7126, 7170, 7171, 7168
3188, 6391, 6392, 6414, 6413, 7128, 7172, 7173, 7170
3189, 6392, 572, 573, 6414, 7129, 595, 7174, 7172
3190, 528, 6393, 6415, 529, 7131, 7175, 7176, 551
3191, 6393, 6394, 6416, 6415, 7133, 7177, 7178, 7175
3192, 6394, 6395, 6417, 6416, 7135, 7179, 7180, 7177
3193, 6395, 6396, 6418, 6417, 7137, 7181, 7182, 7179
3194, 6396, 6397, 6419, 6418, 7139, 7183, 7184, 7181
3195, 6397, 6398, 6420, 6419, 7141, 7185, 7186, 7183
3196, 6398, 6399, 6421, 6420, 7143, 7187, 7188, 7185
3197, 6399, 6400, 6422, 6421, 7145, 7189, 7190, 7187
3198, 6400, 6401, 6423, 6422, 7147, 7191, 7192, 7189
3199, 6401, 6402, 6424, 6423, 7149, 7193, 7194, 7191
3200, 6402, 6403, 6425, 6424, 7151, 7195, 7196, 7193
3201, 6403, 6404, 6426, 6425, 7153, 7197, 7198, 7195
3202, 6404, 6405, 6427, 6426, 7155, 7199, 7200, 7197
3203, 6405, 6406, 6428, 6427, 7157, 7201, 7202, 7199
3204, 6406, 6407, 6429, 6428, 7159, 7203, 7204, 7201
3205, 6407, 6408, 6430, 6429, 7161, 7205, 7206, 7203
3206, 6408, 6409, 6431, 6430, 7163, 7207, 7208, 7205
3207, 6409, 6410, 6432, 6431, 7165, 7209, 7210, 7207
3208, 6410, 6411, 6433, 6432, 7167, 7211, 7212, 7209
3209, 6411, 6412, 6434, 6433, 7169, 7213, 7214, 7211
3210, 6412, 6413, 6435, 6434, 7171, 7215, 7216, 7213
3211, 6413, 6414, 6436, 6435, 7173, 7217, 7218, 7215
3212, 6414, 573, 574, 6436, 7174, 596, 7219, 7217
3213, 529, 6415, 6437, 530, 7176, 7220, 7221, 552
3214, 6415, 6416, 6438, 6437, 7178, 7222, 7223, 7220
3215, 6416, 6417, 6439, 6438, 7180, 7224, 7225, 7222
3216, 6417, 6418, 6440, 6439, 7182, 7226, 7227, 7224
3217, 6418, 6419, 6441, 6440, 7184, 7228, 7229, 7226
3218, 6419, 6420, 6442, 6441, 7186, 7230, 7231, 7228
3219, 6420, 6421, 6443, 6442, 7188, 7232, 7233, 7230
3220, 6421, 6422, 6444, 6443, 7190, 7234, 7235, 7232
3221, 6422, 6423, 6445, 6444, 7192, 7236, 7237, 7234
3222, 6423, 6424, 6446, 6445, 7194, 7238, 7239, 7236
3223, 6424, 6425, 6447, 6446, 7196, 7240, 7241, 7238
3224, 6425, 6426, 6448, 6447, 7198, 7242, 7243, 7240
3225, 6426, 6427, 6449, 6448, 7200, 7244, 7245, 7242
3226, 6427, 6428, 6450, 6449, 7202, 7246, 7247, 7244
3227, 6428, 6429, 6451, 6450, 7204, 7248, 7249, 7246
3228, 6429, 6430, 6452, 6451, 7206, 7250, 7251, 7248
3229, 6430, 6431, 6453, 6452, 7208, 7252, 7253, 7250
3230, 6431, 6432, 6454, 6453, 7210, 7254, 7255, 7252
3231, 6432, 6433, 6455, 6454, 7212, 7256, 7257, 7254
3232, 6433, 6434, 6456, 6455, 7214, 7258, 7259, 7256
3233, 6434, 6435, 6457, 6456, 7216, 7260, 7261, 7258
3234, 6435, 6436, 6458, 6457, 7218, 7262, 7263, 7260
3235, 6436, 574, 575, 6458, 7219, 597, 7264, 7262
3236, 530, 6437, 6459, 531, 7221, 7265, 7266, 553
3237, 6437, 6438, 6460, 6459, 7223, 7267, 7268, 7265
3238, 6438, 6439, 6461, 6460, 7225, 7269, 7270, 7267
3239, 6439, 6440, 6462, 6461, 7227, 7271, 7272, 7269
3240, 6440, 6441, 6463, 6462, 7229, 7273, 7274, 7271
3241, 6441, 6442, 6464, 6463, 7231, 7275, 7276, 7273
3242, 6442, 6443, 6465, 6464, 7233, 7277, 7278, 7275
3243, 6443, 6444, 6466, 6465, 7235, 7279, 7280, 7277
3244, 6444, 6445, 6467, 6466, 7237, 7281, 7282, 7279
3245, 6445, 6446, 6468, 6467, 7239, 7283, 7284, 7281
3246, 6446, 6447, 6469, 6468, 7241, 7285, 7286, 7283
3247, 6447, 6448, 6470, 6469, 7243, 7287, 7288, 7285
3248, 6448, 6449, 6471, 6470, 7245, 7289, 7290, 7287
3249, 6449, 6450, 6472, 6471, 7247, 7291, 7292, 7289
3250, 6450, 6451, 6473, 6472, 7249, 7293, 7294, 7291
3251, 6451, 6452, 6474, 6473, 7251, 7295, 7296, 7293
3252, 6452, 6453, 6475, 6474, 7253, 7297, 7298, 7295
3253, 6453, 6454, 6476, 6475, 7255, 7299, 7300, 7297
3254, 6454, 6455, 6477, 6476, 7257, 7301, 7302, 7299
3255, 6455, 6456, 6478, 6477, 7259, 7303, 7304, 7301
3256, 6456, 6457, 6479, 6478, 7261, 7305, 7306, 7303
3257, 6457, 6458, 6480, 6479, 7263, 7307, 7308, 7305
3258, 6458, 575, 576, 6480, 7264, 598, 7309, 7307
3259, 531, 6459, 6481, 532, 7266, 7310, 7311, 554
3260, 6459, 6460, 6482, 6481, 7268, 7312, 7313, 7310
3261, 6460, 6461, 6483, 6482, 7270, 7314, 7315, 7312
3262, 6461, 6462, 6484, 6483, 7272, 7316, 7317, 7314
3263, 6462, 6463, 6485, 6484, 7274, 7318, 7319, 7316
3264, 6463, 6464, 6486, 6485, 7276, 7320, 7321, 7318
3265, 6464, 6465, 6487, 6486, 7278, 7322, 7323, 7320
3266, 6465, 6466, 6488, 6487, 7280, 7324, 7325, 7322
3267, 6466, 6467, 6489, 6488, 7282, 7326, 7327, 7324
3268, 6467, 6468, 6490, 6489, 7284, 7328, 7329, 7326
3269, 6468, 6469, 6491, 6490, 7286, 7330, 7331, 7328
3270, 6469, 6470, 6492, 6491, 7288, 7332, 7333, 7330
3271, 6470, 6471, 6493, 6492, 7290, 7334, 7335, 7332
3272, 6471, 6472, 6494, 6493, 7292, 7336, 7337, 7334
3273, 6472, 6473, 6495, 6494, 7294, 7338, 7339, 7336
3274, 6473, 6474, 6496, 6495, 7296, 7340, 7341, 7338
3275, 6474, 6475, 6497, 6496, 7298, 7342, 7343, 7340
3276, 6475, 6476, 6498, 6497, 7300, 7344, 7345, 7342
3277, 6476, 6477, 6499, 6498, 7302, 7346, 7347, 7344
3278, 6477, 6478, 6500, 6499, 7304, 7348, 7349, 7346
3279, 6478, 6479, 6501, 6500, 7306, 7350, 7351, 7348
3280, 6479, 6480, 6502, 6501, 7308, 7352, 7353, 7350
3281, 6480, 576, 577, 6502, 7309, 599, 7354, 7352
3282, 532, 6481, 6503, 533, 7311, 7355, 7356, 555
3283, 6481, 6482, 6504, 6503, 7313, 7357, 7358, 7355
3284, 6482, 6483, 6505, 6504, 7315, 7359, 7360, 7357
3285, 6483, 6484, 6506, 6505, 7317, 7361, 7362, 7359
3286, 6484, 6485, 6507, 6506, 7319, 7363, 7364, 7361
3287, 6485, 6486, 6508, 6507, 7321, 7365, 7366, 7363
3288, 6486, 6487, 6509, 6508, 7323, 7367, 7368, 7365
3289, 6487, 6488, 6510, 6509, 7325, 7369, 7370, 7367
3290, 6488, 6489, 6511, 6510, 7327, 7371, 7372, 7369
3291, 6489, 6490, 6512, 6511, 7329, 7373, 7374, 7371
3292, 6490, 6491, 6513, 6512, 7331, 7375, 7376, 7373
3293, 6491, 6492, 6514, 6513, 7333, 7377, 7378, 7375
3294, 6492, 6493, 6515, 6514, 7335, 7379, 7380, 7377
3295, 6493, 6494, 6516, 6515, 7337, 7381, 7382, 7379
3296, 6494, 6495, 6517, 6516, 7339, 7383, 7384, 7381
3297, 6495, 6496, 6518, 6517, 7341, 7385, 7386, 7383
3298, 6496, 6497, 6519, 6518, 7343, 7387, 7388, 7385
3299, 6497, 6498, 6520, 6519, 7345, 7389, 7390, 7387
3300, 6498, 6499, 6521, 6520, 7347, 7391, 7392, 7389
3301, 6499, 6500, 6522, 6521, 7349, 7393, 7394, 7391
3302, 6500, 6501, 6523, 6522, 7351, 7395, 7396, 7393
3303, 6501, 6502, 6524, 6523, 7353, 7397, 7398, 7395
3304, 6502, 577, 578, 6524, 7354, 600, 7399, 7397
3305, 533, 6503, 6525, 534, 7356, 7400, 7401, 556
3306, 6503, 6504, 6526, 6525, 7358, 7402, 7403, 7400
3307, 6504, 6505, 6527, 6526, 7360, 7404, 7405, 7402
3308, 6505, 6506, 6528, 6527, 7362, 7406, 7407, 7404
3309, 6506, 6507, 6529, 6528, 7364, 7408, 7409, 7406
3310, 6507, 6508, 6530, 6529, 7366, 7410, 7411, 7408
3311, 6508, 6509, 6531, 6530, 7368, 7412, 7413, 7410
3312, 6509, 6510, 6532, 6531, 7370, 7414, 7415, 7412
3313, 6510, 6511, 6533, 6532, 7372, 7416, 7417, 7414
3314, 6511, 6512, 6534, 6533, 7374, 7418, 7419, 7416
3315, 6512, 6513, 6535, 6534, 7376, 7420, 7421, 7418
3316, 6513, 6514, 6536, 6535, 7378, 7422, 7423, 7420
3317, 6514, 6515, 6537, 6536, 7380, 7424, 7425, 7422
3318, 6515, 6516, 6538, 6537, 7382, 7426, 7427, 7424
3319, 6516, 6517, 6539, 6538, 7384, 7428, 7429, 7426
3320, 6517, 6518, 6540, 6539, 7386, 7430, 7431, 7428
3321, 6518, 6519, 6541, 6540, 7388, 7432, 7433, 7430
3322, 6519, 6520, 6542, 6541, 7390, 7434, 7435, 7432
3323, 6520, 6521, 6543, 6542, 7392, 7436, 7437, 7434
3324, 6521, 6522, 6544, 6543, 7394, 7438, 7439, 7436
3325, 6522, 6523, 6545, 6544, 7396, 7440, 7441, 7438
3326, 6523, 6524, 6546, 6545, 7398, 7442, 7443, 7440
3327, 6524, 578, 579, 6546, 7399, 601, 7444, 7442
3328, 534, 6525, 6547, 535, 7401, 7445, 7446, 557
3329, 6525, 6526, 6548, 6547, 7403, 7447, 7448, 7445
3330, 6526, 6527, 6549, 6548, 7405, 7449, 7450, 7447
3331, 6527, 6528, 6550, 6549, 7407, 7451, 7452, 7449
3332, 6528, 6529, 6551, 6550, 7409, 7453, 7454, 7451
3333, 6529, 6530, 6552, 6551, 7411, 7455, 7456, 7453
3334, 6530, 6531, 6553, 6552, 7413, 7457, 7458, 7455
3335, 6531, 6532, 6554, 6553, 7415, 7459, 7460, 7457
3336, 6532, 6533, 6555, 6554, 7417, 7461, 7462, 7459
3337, 6533, 6534, 6556, 6555, 7419, 7463, 7464, 7461
3338, 6534, 6535, 6557, 6556, 7421, 7465, 7466, 7463
3339, 6535, 6536, 6558, 6557, 7423, 7467, 7468, 7465
3340, 6536, 6537, 6559, 6558, 7425, 7469, 7470, 7467
3341, 6537, 6538, 6560, 6559, 7427, 7471, 7472, 7469
3342, 6538, 6539, 6561, 6560, 7429, 7473, 7474, 7471
3343, 6539, 6540, 6562, 6561, 7431, 7475, 7476, 7473
3344, 6540, 6541, 6563, 6562, 7433, 7477, 7478, 7475
3345, 6541, 6542, 6564, 6563, 7435, 7479, 7480, 7477
3346, 6542, 6543, 6565, 6564, 7437, 7481, 7482, 7479
3347, 6543, 6544, 6566, 6565, 7439, 7483, 7484, 7481
3348, 6544, 6545, 6567, 6566, 7441, 7485, 7486, 7483
3349, 6545, 6546, 6568, 6567, 7443, 7487, 7488, 7485
3350, 6546, 579, 580, 6568, 7444, 602, 7489, 7487
3351, 535, 6547, 6569, 536, 7446, 7490, 7491, 558
3352, 6547, 6548, 6570, 6569, 7448, 7492, 7493, 7490
3353, 6548, 6549, 6571, 6570, 7450, 7494, 7495, 7492
3354, 6549, 6550, 6572, 6571, 7452, 7496, 7497, 7494
3355, 6550, 6551, 6573, 6572, 7454, 7498, 7499, 7496
3356, 6551, 6552, 6574, 6573, 7456, 7500, 7501, 7498
3357, 6552, 6553, 6575, 6574, 7458, 7502, 7503, 7500
3358, 6553, 6554, 6576, 6575, 7460, 7504, 7505, 7502
3359, 6554, 6555, 6577, 6576, 7462, 7506, 7507, 7504
3360, 6555, 6556, 6578, 6577, 7464, 7508, 7509, 7506
3361, 6556, 6557, 6579, 6578, 7466, 7510, 7511, 7508
3362, 6557, 6558, 6580, 6579, 7468, 7512, 7513, 7510
3363, 6558, 6559, 6581, 6580, 7470, 7514, 7515, 7512
3364, 6559, 6560, 6582, 6581, 7472, 7516, 7517, 7514
3365, 6560, 6561, 6583, 6582, 7474, 7518, 7519, 7516
3366, 6561, 6562, 6584, 6583, 7476, 7520, 7521, 7518
3367, 6562, 6563, 6585, 6584, 7478, 7522, 7523, 7520
3368, 6563, 6564, 6586, 6585, 7480, 7524, 7525, 7522
3369, 6564, 6565, 6587, 6586, 7482, 7526, 7527, 7524
3370, 6565, 6566, 6588, 6587, 7484, 7528, 7529, 7526
3371, 6566, 6567, 6589, 6588, 7486, 7530, 7531, 7528
3372, 6567, 6568, 6590, 6589, 7488, 7532, 7533, 7530
3373, 6568, 580, 581, 6590, 7489, 603, 7534, 7532
3374, 536, 6569, 6591, 537, 7491, 7535, 7536, 559
3375, 6569, 6570, 6592, 6591, 7493, 7537, 7538, 7535
3376, 6570, 6571, 6593, 6592, 7495, 7539, 7540, 7537
3377, 6571, 6572, 6594, 6593, 7497, 7541, 7542, 7539
3378, 6572, 6573, 6595, 6594, 7499, 7543, 7544, 7541
3379, 6573, 6574, 6596, 6595, 7501, 7545, 7546, 7543
3380, 6574, 6575, 6597, 6596, 7503, 7547, 7548, 7545
3381, 6575, 6576, 6598, 6597, 7505, 7549, 7550, 7547
3382, 6576, 6577, 6599, 6598, 7507, 7551, 7552, 7549
3383, 6577, 6578, 6600, 6599, 7509, 7553, 7554, 7551
3384, 6578, 6579, 6601, 6600, 7511, 7555, 7556, 7553
3385, 6579, 6580, 6602, 6601, 7513, 7557, 7558, 7555
3386, 6580, 6581, 6603, 6602, 7515, 7559, 7560, 7557
3387, 6581, 6582, 6604, 6603, 7517, 7561, 7562, 7559
3388, 6582, 6583, 6605, 6604, 7519, 7563, 7564, 7561
3389, 6583, 6584, 6606, 6605, 7521, 7565, 7566, 7563
3390, 6584, 6585, 6607, 6606, 7523, 7567, 7568, 7565
3391, 6585, 6586, 6608, 6607, 7525, 7569, 7570, 7567
3392, 6586, 6587, 6609, 6608, 7527, 7571, 7572, 7569
3393, 6587, 6588, 6610, 6609, 7529, 7573, 7574, 7571
3394, 6588, 6589, 6611, 6610, 7531, 7575, 7576, 7573
3395, 6589, 6590, 6612, 6611, 7533, 7577, 7578, 7575
3396, 6590, 581, 582, 6612, 7534, 604, 7579, 7577
3397, 537, 6591, 6613, 538, 7536, 7580, 7581, 560
3398, 6591, 6592, 6614, 6613, 7538, 7582, 7583, 7580
3399, 6592, 6593, 6615, 6614, 7540, 7584, 7585, 7582
3400, 6593, 6594, 6616, 6615, 7542, 7586, 7587, 7584
3401, 6594, 6595, 6617, 6616, 7544, 7588, 7589, 7586
3402, 6595, 6596, 6618, 6617, 7546, 7590, 7591, 7588
3403, 6596, 6597, 6619, 6618, 7548, 7592, 7593, 7590
3404, 6597, 6598, 6620, 6619, 7550, 7594, 7595, 7592
3405, 6598, 6599, 6621, 6620, 7552, 7596, 7597, 7594
3406, 6599, 6600, 6622, 6621, 7554, 7598, 7599, 7596
3407, 6600, 6601, 6623, 6622, 7556, 7600, 7601, 7598
3408, 6601, 6602, 6624, 6623, 7558, 7602, 7603, 7600
3409, 6602, 6603, 6625, 6624, 7560, 7604, 7605, 7602
3410, 6603, 6604, 6626, 6625, 7562, 7606, 7607, 7604
3411, 6604, 6605, 6627, 6626, 7564, 7608, 7609, 7606
3412, 6605, 6606, 6628, 6627, 7566, 7610, 7611, 7608
3413, 6606, 6607, 6629, 6628, 7568, 7612, 7613, 7610
3414, 6607, 6608, 6630, 6629, 7570, 7614, 7615, 7612
3415, 6608, 6609, 6631, 6630, 7572, 7616, 7617, 7614
3416, 6609, 6610, 6632, 6631, 7574, 7618, 7619, 7616
3417, 6610, 6611, 6633, 6632, 7576, 7620, 7621, 7618
3418, 6611, 6612, 6634, 6633, 7578, 7622, 7623, 7620
3419, 6612, 582, 583, 6634, 7579, 605, 7624, 7622
3420, 538, 6613, 628, 13, 7581, 7625, 651, 561
3421, 6613, 6614, 627, 628, 7583, 7626, 650, 7625
3422, 6614, 6615, 626, 627, 7585, 7627, 649, 7626
3423, 6615, 6616, 625, 626, 7587, 7628, 648, 7627
3424, 6616, 6617, 624, 625, 7589, 7629, 647, 7628
3425, 6617, 6618, 623, 624, 7591, 7630, 646, 7629
3426, 6618, 6619, 622, 623, 7593, 7631, 645, 7630
3427, 6619, 6620, 621, 622, 7595, 7632, 644, 7631
3428, 6620, 6621, 620, 621, 7597, 7633, 643, 7632
3429, 6621, 6622, 619, 620, 7599, 7634, 642, 7633
3430, 6622, 6623, 618, 619, 7601, 7635, 641, 7634
3431, 6623, 6624, 617, 618, 7603, 7636, 640, 7635
3432, 6624, 6625, 616, 617, 7605, 7637, 639, 7636
3433, 6625, 6626, 615, 616, 7607, 7638, 638, 7637
3434, 6626, 6627, 614, 615, 7609, 7639, 637, 7638
3435, 6627, 6628, 613, 614, 7611, 7640, 636, 7639
3436, 6628, 6629, 612, 613, 7613, 7641, 635, 7640
3437, 6629, 6630, 611, 612, 7615, 7642, 634, 7641
3438, 6630, 6631, 610, 611, 7617, 7643, 633, 7642
3439, 6631, 6632, 609, 610, 7619, 7644, 632, 7643
3440, 6632, 6633, 608, 609, 7621, 7645, 631, 7644
3441, 6633, 6634, 607, 608, 7623, 7646, 630, 7645
3442, 6634, 583, 14, 607, 7624, 606, 629, 7646
*ELEMENT, type=CPS8, ELSET=Surface13
3443, 11, 436, 7647, 652, 447, 7867, 7868, 674
3444, 436, 435, 7648, 7647, 446, 7869, 7870, 7867
3445, 435, 434, 7649, 7648, 445, 7871, 7872, 7869
3446, 434, 433, 7650, 7649, 444, 7873, 7874, 7871
3447, 433, 432, 7651, 7650, 443, 7875, 7876, 7873
3448, 432, 431, 7652, 7651, 442, 7877, 7878, 7875
3449, 431, 430, 7653, 7652, 441, 7879, 7880, 7877
3450, 430, 429, 7654, 7653, 440, 7881, 7882, 7879
3451, 429, 428, 7655, 7654, 439, 7883, 7884, 7881
3452, 428, 427, 7656, 7655, 438, 7885, 7886, 7883
3453, 427, 9, 517, 7656, 437, 539, 7887, 7885
3454, 652, 7647, 7657, 653, 7868, 7888, 7889, 675
3455, 7647, 7648, 7658, 7657, 7870, 7890, 7891, 7888
3456, 7648, 7649, 7659, 7658, 7872, 7892, 7893, 7890
3457, 7649, 7650, 7660, 7659, 7874, 7894, 7895, 7892
3458, 7650, 7651, 7661, 7660, 7876, 7896, 7897, 7894
3459, 7651, 7652, 7662, 7661, 7878, 7898, 7899, 7896
3460, 7652, 7653, 7663, 7662, 7880, 7900, 7901, 7898
3461, 7653, 7654, 7664, 7663, 7882, 7902, 7903, 7900
3462, 7654, 7655, 7665, 7664, 7884, 7904, 7905, 7902
3463, 7655, 7656, 7666, 7665, 7886, 7906, 7907, 7904
3464, 7656, 517, 518, 7666, 7887, 540, 7908, 7906
3465, 653, 7657, 7667, 654, 7889, 7909, 7910, 676
3466, 7657, 7658, 7668, 7667, 7891, 7911, 7912, 7909
3467, 7658, 7659, 7669, 7668, 7893, 7913, 7914, 7911
3468, 7659, 7660, 7670, 7669, 7895, 7915, 7916, 7913
3469, 7660, 7661, 7671, 7670, 7897, 7917, 7918, 7915
3470, 7661, 7662, 7672, 7671, 7899, 7919, 7920, 7917
3471, 7662, 7663, 7673, 7672, 7901, 7921, 7922, 7919
3472, 7663, 7664, 7674, 7673, 7903, 7923, 7924, 7921
3473, 7664, 7665, 7675, 7674, 7905, 7925, 7926, 7923
3474, 7665, 7666, 7676, 7675, 7907, 7927, 7928, 7925
3475, 7666, 518, 519, 7676, 7908, 541, 7929, 7927
3476, 654, 7667, 7677, 655, 7910, 7930, 7931, 677
3477, 7667, 7668, 7678, 7677, 7912, 7932, 7933, 7930
3478, 7668, 7669, 7679, 7678, 7914, 7934, 7935, 7932
3479, 7669, 7670, 7680, 7679, 7916, 7936, 7937, 7934
3480, 7670, 7671, 7681, 7680, 7918, 7938, 7939, 7936
3481, 7671, 7672, 7682, 7681, 7920, 7940, 7941, 7938
3482, 7672, 7673, 7683, 7682, 7922, 7942, 7943, 7940
3483, 7673, 7674, 7684, 7683, 7924, 7944, 7945, 7942
3484, 7674, 7675, 7685, 7684, 7926, 7946, 7947, 7944
3485, 7675, 7676, 7686, 7685, 7928, 7948, 7949, 7946
3486, 7676, 519, 520, 7686, 7929, 542, 7950, 7948
3487, 655, 7677, 7687, 656, 7931, 7951, 7952, 678
3488, 7677, 7678, 7688, 7687, 7933, 7953, 7954, 7951
3489, 7678, 7679, 7689, 7688, 7935, 7955, 7956, 7953
3490, 7679, 7680, 7690, 7689, 7937, 7957, 7958, 7955
3491, 7680, 7681, 7691, 7690, 7939, 7959, 7960, 7957
3492, 7681, 7682, 7692, 7691, 7941, 7961, 7962, 7959
3493, 7682, 7683, 7693, 7692, 7943, 7963, 7964, 7961
3494, 7683, 7684, 7694, 7693, 7945, 7965, 7966, 7963
3495, 7684, 7685, 7695, 7694, 7947, 7967, 7968, 7965
3496, 7685, 7686, 7696, 7695, 7949, 7969, 7970, 7967
3497, 7686, 520, 521, 7696, 7950, 543, 7971, 7969
3498, 656, 7687, 7697, 657, 7952, 7972, 7973, 679
3499, 7687, 7688, 7698, 7697, 7954, 7974, 7975, 7972
3500, 7688, 7689, 7699, 7698, 7956, 7976, 7977, 7974
3501, 7689, 7690, 7700, 7699, 7958, 7978, 7979, 7976
3502, 7690, 7691, 7701, 7700, 7960, 7980, 7981, 7978
3503, 7691, 7692, 7702, 7701, 7962, 7982, 7983, 7980
3504, 7692, 7693, 7703, 7702, 7964, 7984, 7985, 7982
3505, 7693, 7694, 7704, 7703, 7966, 7986, 7987, 7984
3506, 7694, 7695, 7705, 7704, 7968, 7988, 7989, 7986
3507, 7695, 7696, 7706, 7705, 7970, 7990, 7991, 7988
3508, 7696, 521, 522, 7706, 7971, 544, 7992, 7990
3509, 657, 7697, 7707, 658, 7973, 7993, 7994, 680
3510, 7697, 7698, 7708, 7707, 7975, 7995, 7996, 7993
3511, 7698, 7699, 7709, 7708, 7977, 7997, 7998, 7995
3512, 7699, 7700, 7710, 7709, 7979, 7999, 8000, 7997
3513, 7700, 7701, 7711, 7710, 7981, 8001, 8002, 7999
3514, 7701, 7702, 7712, 7711, 7983, 8003, 8004, 8001
3515, 7702, 7703, 7713, 7712, 7985, 8005, 8006, 8003
3516, 7703, 7704, 7714, 7713, 7987, 8007, 8008, 8005
3517, 7704, 7705, 7715, 7714, 7989, 8009, 8010, 8007
3518, 7705, 7706, 7716, 7715, 7991, 8011, 8012, 8009
3519, 7706, 522, 523, 7716, 7992, 545, 8013, 8011
3520, 658, 7707, 7717, 659, 7994, 8014, 8015, 681
3521, 7707, 7708, 7718, 7717, 7996, 8016, 8017, 8014
3522, 7708, 7709, 7719, 7718, 7998, 8018, 8019, 8016
3523, 7709, 7710, 7720, 7719, 8000, 8020, 8021, 8018
3524, 7710, 7711, 7721, 7720, 8002, 8022, 8023, 8020
3525, 7711, 7712, 7722, 7721, 8004, 8024, 8025, 8022
3526, 7712, 7713, 7723, 7722, 8006, 8026, 8027, 8024
3527, 7713, 7714, 7724, 7723, 8008, 8028, 8029, 8026
3528, 7714, 7715, 7725, 7724, 8010, 8030, 8031, 8028
3529, 7715, 7716, 7726, 7725, 8012, 8032, 8033, 8030
3530, 7716, 523, 524, 7726, 8013, 546, 8034, 8032
3531, 659, 7717, 7727, 660, 8015, 8035, 8036, 682
3532, 7717, 7718, 7728, 7727, 8017, 8037, 8038, 8035
3533, 7718, 7719, 7729, 7728, 8019, 8039, 8040, 8037
3534, 7719, 7720, 7730, 7729, 8021, 8041, 8042, 8039
3535, 7720, 7721, 7731, 7730, 8023, 8043, 8044, 8041
3536, 7721, 7722, 7732, 7731, 8025, 8045, 8046, 8043
3537, 7722, 7723, 7733, 7732, 8027, 8047, 8048, 8045
3538, 7723, 7724, 7734, 7733, 8029, 8049, 8050, 8047
3539, 7724, 7725, 7735, 7734, 8031, 8051, 8052, 8049
3540, 7725, 7726, 7736, 7735, 8033, 8053, 8054, 8051
3541, 7726, 524, 525, 7736, 8034, 547, 8055, 8053
3542, 660, 7727, 7737, 661, 8036, 8056, 8057, 683
3543, 7727, 7728, 7738, 7737, 8038, 8058, 8059, 8056
3544, 7728, 7729, 7739, 7738, 8040, 8060, 8061, 8058
3545, 7729, 7730, 7740, 7739, 8042, 8062, 8063, 8060
3546, 7730, 7731, 7741, 7740, 8044, 8064, 8065, 8062
3547, 7731, 7732, 7742, 7741, 8046, 8066, 8067, 8064
3548, 7732, 7733, 7743, 7742, 8048, 8068, 8069, 8066
3549, 7733, 7734, 7744, 7743, 8050, 8070, 8071, 8068
3550, 7734, 7735, 7745, 7744, 8052, 8072, 8073, 8070
3551, 7735, 7736, 7746, 7745, 8054, 8074, 8075, 8072
3552, 7736, 525, 526, 7746, 8055, 548, 8076, 8074
3553, 661, 7737, 7747, 662, 8057, 8077, 8078, 684
3554, 7737, 7738, 7748, 7747, 8059, 8079, 8080, 8077
3555, 7738, 7739, 7749, 7748, 8061, 8081, 8082, 8079
3556, 7739, 7740, 7750, 7749, 8063, 8083, 8084, 8081
3557, 7740, 7741, 7751, 7750, 8065, 8085, 8086, 8083
3558, 7741, 7742, 7752, 7751, 8067, 8087, 8088, 8085
3559, 7742, 7743, 7753, 7752, 8069, 8089, 8090, 8087
3560, 7743, 7744, 7754, 7753, 8071, 8091, 8092, 8089
3561, 7744, 7745, 7755, 7754, 8073, 8093, 8094, 8091
3562, 7745, 7746, 7756, 7755, 8075, 8095, 8096, 8093
3563, 7746, 526, 527, 7756, 8076, 549, 8097, 8095
3564, 662, 7747, 7757, 663, 8078, 8098, 8099, 685
3565, 7747, 7748, 7758, 7757, 8080, 8100, 8101, 8098
3566, 7748, 7749, 7759, 7758, 8082, 8102, 8103, 8100
3567, 7749, 7750, 7760, 7759, 8084, 8104, 8105, 8102
3568, 7750, 7751, 7761, 7760, 8086, 8106, 8107, 8104
3569, 7751, 7752, 7762, 7761, 8088, 8108, 8109, 8106
3570, 7752, 7753, 7763, 7762, 8090, 8110, 8111, 8108
3571, 7753, 7754, 7764, 7763, 8092, 8112, 8113, 8110
3572, 7754, 7755, 7765, 7764, 8094, 8114, 8115, 8112
3573, 7755, 7756, 7766, 7765, 8096, 8116, 8117, 8114
3574, 7756, 527, 528, 7766, 8097, 550, 8118, 8116
3575, 663, 7757, 7767, 664, 8099, 8119, 8120, 686
3576, 7757, 7758, 7768, 7767, 8101, 8121, 8122, 8119
3577, 7758, 7759, 7769, 7768, 8103, 8123, 8124, 8121
3578, 7759, 7760, 7770, 7769, 8105, 8125, 8126, 8123
3579, 7760, 7761, 7771, 7770, 8107, 8127, 8128, 8125
3580, 7761, 7762, 7772, 7771, 8109, 8129, 8130, 8127
3581, 7762, 7763, 7773, 7772, 8111, 8131, 8132, 8129
3582, 7763, 7764, 7774, 7773, 8113, 8133, 8134, 8131
3583, 7764, 7765, 7775, 7774, 8115, 8135, 8136, 8133
3584, 7765, 7766, 7776, 7775, 8117, 8137, 8138, 8135
3585, 7766, 528, 529, 7776, 8118, 551, 8139, 8137
3586, 664, 7767, 7777, 665, 8120, 8140, 8141, 687
3587, 7767, 7768, 7778, 7777, 8122, 8142, 8143, 8140
3588, 7768, 7769, 7779, 7778, 8124, 8144, 8145, 8142
3589, 7769, 7770, 7780, 7779, 8126, 8146, 8147, 8144
3590, 7770, 7771, 7781, 7780, 8128, 8148, 8149, 8146
3591, 7771, 7772, 7782, 7781, 8130, 8150, 8151, 8148
3592, 7772, 7773, 7783, 7782, 8132, 8152, 8153, 8150
3593, 7773, 7774, 7784, 7783, 8134, 8154, 8155, 8152
3594, 7774, 7775, 7785, 7784, 8136, 8156, 8157, 8154
3595, 7775, 7776, 7786, 7785, 8138, 8158, 8159, 8156
3596, 7776, 529, 530, 7786, 8139, 552, 8160, 8158
3597, 665, 7777, 7787, 666, 8141, 8161, 8162, 688
3598, 7777, 7778, 7788, 7787, 8143, 8163, 8164, 8161
3599, 7778, 7779, 7789, 7788, 8145, 8165, 8166, 8163
3600, 7779, 7780, 7790, 7789, 8147, 8167, 8168, 8165
3601, 7780, 7781, 7791, 7790, 8149, 8169, 8170, 8167
3602, 7781, 7782, 7792, 7791, 8151, 8171, 8172, 8169
3603, 7782, 7783, 7793, 7792, 8153, 8173, 8174, 8171
3604, 7783, 7784, 7794, 7793, 8155, 8175, 8176, 8173
3605, 7784, 7785, 7795, 7794, 8157, 8177, 8178, 8175
3606, 7785, 7786, 7796, 7795, 8159, 8179, 8180, 8177
3607, 7786, 530, 531, 7796, 8160, 553, 8181, 8179
3608, 666, 7787, 7797, 667, 8162, 8182, 8183, 689
3609, 7787, 7788, 7798, 7797, 8164, 8184, 8185, 8182
3610, 7788, 7789, 7799, 7798, 8166, 8186, 8187, 8184
3611, 7789, 7790, 7800, 7799, 8168, 8188, 8189, 8186
3612, 7790, 7791, 7801, 7800, 8170, 8190, 8191, 8188
3613, 7791, 7792, 7802, 7801, 8172, 8192, 8193, 8190
3614, 7792, 7793, 7803, 7802, 8174, 8194, 8195, 8192
3615, 7793, 7794, 7804, 7803, 8176, 8196, 8197, 8194
3616, 7794, 7795, 7805, 7804, 8178, 8198, 8199, 8196
3617, 7795, 7796, 7806, 7805, 8180, 8200, 8201, 8198
3618, 7796, 531, 532, 7806, 8181, 554, 8202, 8200
3619, 667, 7797, 7807, 668, 8183, 8203, 8204, 690
3620, 7797, 7798, 7808, 7807, 8185, 8205, 8206, 8203
3621, 7798, 7799, 7809, 7808, 8187, 8207, 8208, 8205
3622, 7799, 7800, 7810, 7809, 8189, 8209, 8210, 8207
3623, 7800, 7801, 7811, 7810, 8191, 8211, 8212, 8209
3624, 7801, 7802, 7812, 7811, 8193, 8213, 8214, 8211
3625, 7802, 7803, 7813, 7812, 8195, 8215, 8216, 8213
3626, 7803, 7804, 7814, 7813, 8197, 8217, 8218, 8215
3627, 7804, 7805, 7815, 7814, 8199, 8219, 8220, 8217
3628, 7805, 7806, 7816, 7815, 8201, 8221, 8222, 8219
3629, 7806, 532, 533, 7816, 8202, 555, 8223, 8221
3630, 668, 7807, 7817, 669, 8204, 8224, 8225, 691
3631, 7807, 7808, 7818, 7817, 8206, 8226, 8227, 8224
3632, 7808, 7809, 7819, 7818, 8208, 8228, 8229, 8226
3633, 7809, 7810, 7820, 7819, 8210, 8230, 8231, 8228
3634, 7810, 7811, 7821, 7820, 8212, 8232, 8233, 8230
3635, 7811, 7812, 7822, 7821, 8214, 8234, 8235, 8232
3636, 7812, 7813, 7823, 7822, 8216, 8236, 8237, 8234
3637, 7813, 7814, 7824, 7823, 8218, 8238, 8239, 8236
3638, 7814, 7815, 7825, 7824, 8220, 8240, 8241, 8238
3639, 7815, 7816, 7826, 7825, 8222, 8242, 8243, 8240
3640, 7816, 533, 534, 7826, 8223, 556, 8244, 8242
3641, 669, 7817, 7827, 670, 8225, 8245, 8246, 692
3642, 7817, 7818, 7828, 7827, 8227, 8247, 8248, 8245
3643, 7818, 7819, 7829, 7828, 8229, 8249, 8250, 8247
3644, 7819, 7820, 7830, 7829, 8231, 8251, 8252, 8249
3645, 7820, 7821, 7831, 7830, 8233, 8253, 8254, 8251
3646, 7821, 7822, 7832, 7831, 8235, 8255, 8256, 8253
3647, 7822, 7823, 7833, 7832, 8237, 8257, 8258, 8255
3648, 7823, 7824, 7834, 7833, 8239, 8259, 8260, 8257
3649, 7824, 7825, 7835, 7834, 8241, 8261, 8262, 8259
3650, 7825, 7826, 7836, 7835, 8243, 8263, 8264, 8261
3651, 7826, 534, 535, 7836, 8244, 557, 8265, 8263
3652, 670, 7827, 7837, 671, 8246, 8266, 8267, 693
3653, 7827, 7828, 7838, 7837, 8248, 8268, 8269, 8266
3654, 7828, 7829, 7839, 7838, 8250, 8270, 8271, 8268
3655, 7829, 7830, 7840, 7839, 8252, 8272, 8273, 8270
3656, 7830, 7831, 7841, 7840, 8254, 8274, 8275, 8272
3657, 7831, 7832, 7842, 7841, 8256, 8276, 8277, 8274
3658, 7832, 7833, 7843, 7842, 8258, 8278, 8279, 8276
3659, 7833, 7834, 7844, 7843, 8260, 8280, 8281, 8278
3660, 7834, 7835, 7845, 7844, 8262, 8282, 8283, 8280
3661, 7835, 7836, 7846, 7845, 8264, 8284, 8285, 8282
3662, 7836, 535, 536, 7846, 8265, 558, 8286, 8284
3663, 671, 7837, 7847, 672, 8267, 8287, 8288, 694
3664, 7837, 7838, 7848, 7847, 8269, 8289, 8290, 8287
3665, 7838, 7839, 7849, 7848, 8271, 8291, 8292, 8289
3666, 7839, 7840, 7850, 7849, 8273, 8293, 8294, 8291
3667, 7840, 7841, 7851, 7850, 8275, 8295, 8296, 8293
3668, 7841, 7842, 7852, 7851, 8277, 8297, 8298, 8295
3669, 7842, 7843, 7853, 7852, 8279, 8299, 8300, 8297
3670, 7843, 7844, 7854, 7853, 8281, 8301, 8302, 8299
3671, 7844, 7845, 7855, 7854, 8283, 8303, 8304, 8301
3672, 7845, 7846, 7856, 7855, 8285, 8305, 8306, 8303
3673, 7846, 536, 537, 7856, 8286, 559, 8307, 8305
3674, 672, 7847, 7857, 673, 8288, 8308, 8309, 695
3675, 7847, 7848, 7858, 7857, 8290, 8310, 8311, 8308
3676, 7848, 7849, 7859, 7858, 8292, 8312, 8313, 8310
3677, 7849, 7850, 7860, 7859, 8294, 8314, 8315, 8312
3678, 7850, 7851, 7861, 7860, 8296, 8316, 8317, 8314
3679, 7851, 7852, 7862, 7861, 8298, 8318, 8319, 8316
3680, 7852, 7853, 7863, 7862, 8300, 8320, 8321, 8318
3681, 7853, 7854, 7864, 7863, 8302, 8322, 8323, 8320
3682, 7854, 7855, 7865, 7864, 8304, 8324, 8325, 8322
3683, 7855, 7856, 7866, 7865, 8306, 8326, 8327, 8324
3684, 7856, 537, 538, 7866, 8307, 560, 8328, 8326
3685, 673, 7857, 706, 15, 8309, 8329, 717, 696
3686, 7857, 7858, 705, 706, 8311, 8330, 716, 8329
3687, 7858, 7859, 704, 705, 8313, 8331, 715, 8330
3688, 7859, 7860, 703, 704, 8315, 8332, 714, 8331
3689, 7860, 7861, 702, 703, 8317, 8333, 713, 8332
3690, 7861, 7862, 701, 702, 8319, 8334, 712, 8333
3691, 7862, 7863, 700, 701, 8321, 8335, 711, 8334
3692, 7863, 7864, 699, 700, 8323, 8336, 710, 8335
3693, 7864, 7865, 698, 699, 8325, 8337, 709, 8336
3694, 7865, 7866, 697, 698, 8327, 8338, 708, 8337
3695, 7866, 538, 13, 697, 8328, 561, 707, 8338
*ELEMENT, type=CPS8, ELSET=Surface14
3696, 11, 652, 8339, 472, 674, 8823, 8824, 495
3697, 472, 8339, 8340, 471, 8824, 8825, 8826, 494
3698, 471, 8340, 8341, 470, 8826, 8827, 8828, 493
3699, 470, 8341, 8342, 469, 8828, 8829, 8830, 492
3700, 469, 8342, 8343, 468, 8830, 8831, 8832, 491
3701, 468, 8343, 8344, 467, 8832, 8833, 8834, 490
3702, 467, 8344, 8345, 466, 8834, 8835, 8836, 489
3703, 466, 8345, 8346, 465, 8836, 8837, 8838, 488
3704, 465, 8346, 8347, 464, 8838, 8839, 8840, 487
3705, 464, 8347, 8348, 463, 8840, 8841, 8842, 486
3706, 463, 8348, 8349, 462, 8842, 8843, 8844, 485
3707, 462, 8349, 8350, 461, 8844, 8845, 8846, 484
3708, 461, 8350, 8351, 460, 8846, 8847, 8848, 483
3709, 460, 8351, 8352, 459, 8848, 8849, 8850, 482
3710, 459, 8352, 8353, 458, 8850, 8851, 8852, 481
3711, 458, 8353, 8354, 457, 8852, 8853, 8854, 480
3712, 457, 8354, 8355, 456, 8854, 8855, 8856, 479
3713, 456, 8355, 8356, 455, 8856, 8857, 8858, 478
3714, 455, 8356, 8357, 454, 8858, 8859, 8860, 477
3715, 454, 8357, 8358, 453, 8860, 8861, 8862, 476
3716, 453, 8358, 8359, 452, 8862, 8863, 8864, 475
3717, 452, 8359, 8360, 451, 8864, 8865, 8866, 474
3718, 451, 8360, 718, 12, 8866, 8867, 740, 473
3719, 652, 653, 8361, 8339, 675, 8868, 8869, 8823
3720, 8339, 8361, 8362, 8340, 8869, 8870, 8871, 8825
3721, 8340, 8362, 8363, 8341, 8871, 8872, 8873, 8827
3722, 8341, 8363, 8364, 8342, 8873, 8874, 8875, 8829
3723, 8342, 8364, 8365, 8343, 8875, 8876, 8877, 8831
3724, 8343, 8365, 8366, 8344, 8877, 8878, 8879, 8833
3725, 8344, 8366, 8367, 8345, 8879, 8880, 8881, 8835
3726, 8345, 8367, 8368, 8346, 8881, 8882, 8883, 8837
3727, 8346, 8368, 8369, 8347, 8883, 8884, 8885, 8839
3728, 8347, 8369, 8370, 8348, 8885, 8886, 8887, 8841
3729, 8348, 8370, 8371, 8349, 8887, 8888, 8889, 8843
3730, 8349, 8371, 8372, 8350, 8889, 8890, 8891, 8845
3731, 8350, 8372, 8373, 8351, 8891, 8892, 8893, 8847
3732, 8351, 8373, 8374, 8352, 8893, 8894, 8895, 8849
3733, 8352, 8374, 8375, 8353, 8895, 8896, 8897, 8851
3734, 8353, 8375, 8376, 8354, 8897, 8898, 8899, 8853
3735, 8354, 8376, 8377, 8355, 8899, 8900, 8901, 8855
3736, 8355, 8377, 8378, 8356, 8901, 8902, 8903, 8857
3737, 8356, 8378, 8379, 8357, 8903, 8904, 8905, 8859
3738, 8357, 8379, 8380, 8358, 8905, 8906, 8907, 8861
3739, 8358, 8380, 8381, 8359, 8907, 8908, 8909, 8863
3740, 8359, 8381, 8382, 8360, 8909, 8910, 8911, 8865
3741, 8360, 8382, 719, 718, 8911, 8912, 741, 8867
3742, 653, 654, 8383, 8361, 676, 8913, 8914, 8868
3743, 8361, 8383, 8384, 8362, 8914, 8915, 8916, 8870
3744, 8362, 8384, 8385, 8363, 8916, 8917, 8918, 8872
3745, 8363, 8385, 8386, 8364, 8918, 8919, 8920, 8874
3746, 8364, 8386, 8387, 8365, 8920, 8921, 8922, 8876
3747, 8365, 8387, 8388, 8366, 8922, 8923, 8924, 8878
3748, 8366, 8388, 8389, 8367, 8924, 8925, 8926, 8880
3749, 8367, 8389, 8390, 8368, 8926, 8927, 8928, 8882
3750, 8368, 8390, 8391, 8369, 8928, 8929, 8930, 8884
3751, 8369, 8391, 8392, 8370, 8930, 8931, 8932, 8886
3752, 8370, 8392, 8393, 8371, 8932, 8933, 8934, 8888
3753, 8371, 8393, 8394, 8372, 8934, 8935, 8936, 8890
3754, 8372, 8394, 8395, 8373, 8936, 8937, 8938, 8892
3755, 8373, 8395, 8396, 8374, 8938, 8939, 8940, 8894
3756, 8374, 8396, 8397, 8375, 8940, 8941, 8942, 8896
3757, 8375, 8397, 8398, 8376, 8942, 8943, 8944, 8898
3758, 8376, 8398, 8399, 8377, 8944, 8945, 8946, 8900
3759, 8377, 8399, 8400, 8378, 8946, 8947, 8948, 8902
3760, 8378, 8400, 8401, 8379, 8948, 8949, 8950, 8904
3761, 8379, 8401, 8402, 8380, 8950, 8951, 8952, 8906
3762, 8380, 8402, 8403, 8381, 8952, 8953, 8954, 8908
3763, 8381, 8403, 8404, 8382, 8954, 8955, 8956, 8910
3764, 8382, 8404, 720, 719, 8956, 8957, 742, 8912
3765, 654, 655, 8405, 8383, 677, 8958, 8959, 8913
3766, 8383, 8405, 8406, 8384, 8959, 8960, 8961, 8915
3767, 8384, 8406, 8407, 8385, 8961, 8962, 8963, 8917
3768, 8385, 8407, 8408, 8386, 8963, 8964, 8965, 8919
3769, 8386, 8408, 8409, 8387, 8965, 8966, 8967, 8921
3770, 8387, 8409, 8410, 8388, 8967, 8968, 8969, 8923
3771, 8388, 8410, 8411, 8389, 8969, 8970, 8971, 8925
3772, 8389, 8411, 8412, 8390, 8971, 8972, 8973, 8927
3773, 8390, 8412, 8413, 8391, 8973, 8974, 8975, 8929
3774, 8391, 8413, 8414, 8392, 8975, 8976, 8977, 8931
3775, 8392, 8414, 8415, 8393, 8977, 8978, 8979, 8933
3776, 8393, 8415, 8416, 8394, 8979, 8980, 8981, 8935
3777, 8394, 8416, 8417, 8395, 8981, 8982, 8983, 8937
3778, 8395, 8417, 8418, 8396, 8983, 8984, 8985, 8939
3779, 8396, 8418, 8419, 8397, 8985, 8986, 8987, 8941
3780, 8397, 8419, 8420, 8398, 8987, 8988, 8989, 8943
3781, 8398, 8420, 8421, 8399, 8989, 8990, 8991, 8945
3782, 8399, 8421, 8422, 8400, 8991, 8992, 8993, 8947
3783, 8400, 8422, 8423, 8401, 8993, 8994, 8995, 8949
3784, 8401, 8423, 8424, 8402, 8995, 8996, 8997, 8951
3785, 8402, 8424, 8425, 8403, 8997, 8998, 8999, 8953
3786, 8403, 8425, 8426, 8404, 8999, 9000, 9001, 8955
3787, 8404, 8426, 721, 720, 9001, 9002, 743, 8957
3788, 655, 656, 8427, 8405, 678, 9003, 9004, 8958
3789, 8405, 8427, 8428, 8406, 9004, 9005, 9006, 8960
3790, 8406, 8428, 8429, 8407, 9006, 9007, 9008, 8962
3791, 8407, 8429, 8430, 8408, 9008, 9009, 9010, 8964
3792, 8408, 8430, 8431, 8409, 9010, 9011, 9012, 8966
3793, 8409, 8431, 8432, 8410, 9012, 9013, 9014, 8968
3794, 8410, 8432, 8433, 8411, 9014, 9015, 9016, 8970
3795, 8411, 8433, 8434, 8412, 9016, 9017, 9018, 8972
3796, 8412, 8434, 8435, 8413, 9018, 9019, 9020, 8974
3797, 8413, 8435, 8436, 8414, 9020, 9021, 9022, 8976
3798, 8414, 8436, 8437, 8415, 9022, 9023, 9024, 8978
3799, 8415, 8437, 8438, 8416, 9024, 9025, 9026, 8980
3800, 8416, 8438, 8439, 8417, 9026, 9027, 9028, 8982
3801, 8417, 8439, 8440, 8418, 9028, 9029, 9030, 8984
3802, 8418, 8440, 8441, 8419, 9030, 9031, 9032, 8986
3803, 8419, 8441, 8442, 8420, 9032, 9033, 9034, 8988
3804, 8420, 8442, 8443, 8421, 9034, 9035, 9036, 8990
3805, 8421, 8443, 8444, 8422, 9036, 9037, 9038, 8992
3806, 8422, 8444, 8445, 8423, 9038, 9039, 9040, 8994
3807, 8423, 8445, 8446, 8424, 9040, 9041, 9042, 8996
3808, 8424, 8446, 8447, 8425, 9042, 9043, 9044, 8998
3809, 8425, 8447, 8448, 8426, 9044, 9045, 9046, 9000
3810, 8426, 8448, 722, 721, 9046, 9047, 744, 9002
3811, 656, 657, 8449, 8427, 679, 9048, 9049, 9003
3812, 8427, 8449, 8450, 8428, 9049, 9050, 9051, 9005
3813, 8428, 8450, 8451, 8429, 9051, 9052, 9053, 9007
3814, 8429, 8451, 8452, 8430, 9053, 9054, 9055, 9009
3815, 8430, 8452, 8453, 8431, 9055, 9056, 9057, 9011
3816, 8431, 8453, 8454, 8432, 9057, 9058, 9059, 9013
3817, 8432, 8454, 8455, 8433, 9059, 9060, 9061, 9015
3818, 8433, 8455, 8456, 8434, 9061, 9062, 9063, 9017
3819, 8434, 8456, 8457, 8435, 9063, 9064, 9065, 9019
3820, 8435, 8457, 8458, 8436, 9065, 9066, 9067, 9021
3821, 8436, 8458, 8459, 8437, 9067, 9068, 9069, 9023
3822, 8437, 8459, 8460, 8438, 9069, 9070, 9071, 9025
3823, 8438, 8460, 8461, 8439, 9071, 9072, 9073, 9027
3824, 8439, 8461, 8462, 8440, 9073, 9074, 9075, 9029
3825, 8440, 8462, 8463, 8441, 9075, 9076, 9077, 9031
3826, 8441, 8463, 8464, 8442, 9077, 9078, 9079, 9033
3827, 8442, 8464, 8465, 8443, 9079, 9080, 9081, 9035
3828, 8443, 8465, 8466, 8444, 9081, 9082, 9083, 9037
3829, 8444, 8466, 8467, 8445, 9083, 9084, 9085, 9039
3830, 8445, 8467, 8468, 8446, 9085, 9086, 9087, 9041
3831, 8446, 8468, 8469, 8447, 9087, 9088, 9089, 9043
3832, 8447, 8469, 8470, 8448, 9089, 9090, 9091, 9045
3833, 8448, 8470, 723, 722, 9091, 9092, 745, 9047
3834, 657, 658, 8471, 8449, 680, 9093, 9094, 9048
3835, 8449, 8471, 8472, 8450, 9094, 9095, 9096, 9050
3836, 8450, 8472, 8473, 8451, 9096, 9097, 9098, 9052
3837, 8451, 8473, 8474, 8452, 9098, 9099, 9100, 9054
3838, 8452, 8474, 8475, 8453, 9100, 9101, 9102, 9056
3839, 8453, 8475, 8476, 8454, 9102, 9103, 9104, 9058
3840, 8454, 8476, 8477, 8455, 9104, 9105, 9106, 9060
3841, 8455, 8477, 8478, 8456, 9106, 9107, 9108, 9062
3842, 8456, 8478, 8479, 8457, 9108, 9109, 9110, 9064
3843, 8457, 8479, 8480, 8458, 9110, 9111, 9112, 9066
3844, 8458, 8480, 8481, 8459, 9112, 9113, 9114, 9068
3845, 8459, 8481, 8482, 8460, 9114, 9115, 9116, 9070
3846, 8460, 8482, 8483, 8461, 9116, 9117, 9118, 9072
3847, 8461, 8483, 8484, 8462, 9118, 9119, 9120, 9074
3848, 8462, 8484, 8485, 8463, 9120, 9121, 9122, 9076
3849, 8463, 8485, 8486, 8464, 9122, 9123, 9124, 9078
3850, 8464, 8486, 8487, 8465, 9124, 9125, 9126, 9080
3851, 8465, 8487, 8488, 8466, 9126, 9127, 9128, 9082
3852, 8466, 8488, 8489, 8467, 9128, 9129, 9130, 9084
3853, 8467, 8489, 8490, 8468, 9130, 9131, 9132, 9086
3854, 8468, 8490, 8491, 8469, 9132, 9133, 9134, 9088
3855, 8469, 8491, 8492, 8470, 9134, 9135, 9136, 9090
3856, 8470, 8492, 724, 723, 9136, 9137, 746, 9092
3857, 658, 659, 8493, 8471, 681, 9138, 9139, 9093
3858, 8471, 8493, 8494, 8472, 9139, 9140, 9141, 9095
3859, 8472, 8494, 8495, 8473, 9141, 9142, 9143, 9097
3860, 8473, 8495, 8496, 8474, 9143, 9144, 9145, 9099
3861, 8474, 8496, 8497, 8475, 9145, 9146, 9147, 9101
3862, 8475, 8497, 8498, 8476, 9147, 9148, 9149, 9103
3863, 8476, 8498, 8499, 8477, 9149, 9150, 9151, 9105
3864, 8477, 8499, 8500, 8478, 9151, 9152, 9153, 9107
3865, 8478, 8500, 8501, 8479, 9153, 9154, 9155, 9109
3866, 8479, 8501, 8502, 8480, 9155, 9156, 9157, 9111
3867, 8480, 8502, 8503, 8481, 9157, 9158, 9159, 9113
3868, 8481, 8503, 8504, 8482, 9159, 9160, 9161, 9115
3869, 8482, 8504, 8505, 8483, 9161, 9162, 9163, 9117
3870, 8483, 8505, 8506, 8484, 9163, 9164, 9165, 9119
3871, 8484, 8506, 8507, 8485, 9165, 9166, 9167, 9121
3872, 8485, 8507, 8508, 8486, 9167, 9168, 9169, 9123
3873, 8486, 8508, 8509, 8487, 9169, 9170, 9171, 9125
3874, 8487, 8509, 8510, 8488, 9171, 9172, 9173, 9127
3875, 8488, 8510, 8511, 8489, 9173, 9174, 9175, 9129
3876, 8489, 8511, 8512, 8490, 9175, 9176, 9177, 9131
3877, 8490, 8512, 8513, 8491, 9177, 9178, 9179, 9133
3878, 8491, 8513, 8514, 8492, 9179, 9180, 9181, 9135
3879, 8492, 8514, 725, 724, 9181, 9182, 747, 9137
3880, 659, 660, 8515, 8493, 682, 9183, 9184, 9138
3881, 8493, 8515, 8516, 8494, 9184, 9185, 9186, 9140
3882, 8494, 8516, 8517, 8495, 9186, 9187, 9188, 9142
3883, 8495, 8517, 8518, 8496, 9188, 9189, 9190, 9144
3884, 8496, 8518, 8519, 8497, 9190, 9191, 9192, 9146
3885, 8497, 8519, 8520, 8498, 9192, 9193, 9194, 9148
3886, 8498, 8520, 8521, 8499, 9194, 9195, 9196, 9150
3887, 8499, 8521, 8522, 8500, 9196, 9197, 9198, 9152
3888, 8500, 8522, 8523, 8501, 9198, 9199, 9200, 9154
3889, 8501, 8523, 8524, 8502, 9200, 9201, 9202, 9156
3890, 8502, 8524, 8525, 8503, 9202, 9203, 9204, 9158
3891, 8503, 8525, 8526, 8504, 9204, 9205, 9206, 9160
3892, 8504, 8526, 8527, 8505, 9206, 9207, 9208, 9162
3893, 8505, 8527, 8528, 8506, 9208, 9209, 9210, 9164
3894, 8506, 8528, 8529, 8507, 9210, 9211, 9212, 9166
3895, 8507, 8529, 8530, 8508, 9212, 9213, 9214, 9168
3896, 8508, 8530, 8531, 8509, 9214, 9215, 9216, 9170
3897, 8509, 8531, 8532, 8510, 9216, 9217, 9218, 9172
3898, 8510, 8532, 8533, 8511, 9218, 9219, 9220, 9174
3899, 8511, 8533, 8534, 8512, 9220, 9221, 9222, 9176
3900, 8512, 8534, 8535, 8513, 9222, 9223, 9224, 9178
3901, 8513, 8535, 8536, 8514, 9224, 9225, 9226, 9180
3902, 8514, 8536, 726, 725, 9226, 9227, 748, 9182
3903, 660, 661, 8537, 8515, 683, 9228, 9229, 9183
3904, 8515, 8537, 8538, 8516, 9229, 9230, 9231, 9185
3905, 8516, 8538, 8539, 8517, 9231, 9232, 9233, 9187
3906, 8517, 8539, 8540, 8518, 9233, 9234, 9235, 9189
3907, 8518, 8540, 8541, 8519, 9235, 9236, 9237, 9191
3908, 8519, 8541, 8542, 8520, 9237, 9238, 9239, 9193
3909, 8520, 8542, 8543, 8521, 9239, 9240, 9241, 9195
3910, 8521, 8543, 8544, 8522, 9241, 9242, 9243, 9197
3911, 8522, 8544, 8545, 8523, 9243, 9244, 9245, 9199
3912, 8523, 8545, 8546, 8524, 9245, 9246, 9247, 9201
3913, 8524, 8546, 8547, 8525, 9247, 9248, 9249, 9203
3914, 8525, 8547, 8548, 8526, 9249, 9250, 9251, 9205
3915, 8526, 8548, 8549, 8527, 9251, 9252, 9253, 9207
3916, 8527, 8549, 8550, 8528, 9253, 9254, 9255, 9209
3917, 8528, 8550, 8551, 8529, 9255, 9256, 9257, 9211
3918, 8529, 8551, 8552, 8530, 9257, 9258, 9259, 9213
3919, 8530, 8552, 8553, 8531, 9259, 9260, 9261, 9215
3920, 8531, 8553, 8554, 8532, 9261, 9262, 9263, 9217
3921, 8532, 8554, 8555, 8533, 9263, 9264, 9265, 9219
3922, 8533, 8555, 8556, 8534, 9265, 9266, 9267, 9221
3923, 8534, 8556, 8557, 8535, 9267, 9268, 9269, 9223
3924, 8535, 8557, 8558, 8536, 9269, 9270, 9271, 9225
3925, 8536, 8558, 727, 726, 9271, 9272, 749, 9227
3926, 661, 662, 8559, 8537, 684, 9273, 9274, 9228
3927, 8537, 8559, 8560, 8538, 9274, 9275, 9276, 9230
3928, 8538, 8560, 8561, 8539, 9276, 9277, 9278, 9232
3929, 8539, 8561, 8562, 8540, 9278, 9279, 9280, 9234
3930, 8540, 8562, 8563, 8541, 9280, 9281, 9282, 9236
3931, 8541, 8563, 8564, 8542, 9282, 9283, 9284, 9238
3932, 8542, 8564, 8565, 8543, 9284, 9285, 9286, 9240
3933, 8543, 8565, 8566, 8544, 9286, 9287, 9288, 9242
3934, 8544, 8566, 8567, 8545, 9288, 9289, 9290, 9244
3935, 8545, 8567, 8568, 8546, 9290, 9291, 9292, 9246
3936, 8546, 8568, 8569, 8547, 9292, 9293, 9294, 9248
3937, 8547, 8569, 8570, 8548, 9294, 9295, 9296, 9250
3938, 8548, 8570, 8571, 8549, 9296, 9297, 9298, 9252
3939, 8549, 8571, 8572, 8550, 9298, 9299, 9300, 9254
3940, 8550, 8572, 8573, 8551, 9300, 9301, 9302, 9256
3941, 8551, 8573, 8574, 8552, 9302, 9303, 9304, 9258
3942, 8552, 8574, 8575, 8553, 9304, 9305, 9306, 9260
3943, 8553, 8575, 8576, 8554, 9306, 9307, 9308, 9262
3944, 8554, 8576, 8577, 8555, 9308, 9309, 9310, 9264
3945, 8555, 8577, 8578, 8556, 9310, 9311, 9312, 9266
3946, 8556, 8578, 8579, 8557, 9312, 9313, 9314, 9268
3947, 8557, 8579, 8580, 8558, 9314, 9315, 9316, 9270
3948, 8558, 8580, 728, 727, 9316, 9317, 750, 9272
3949, 662, 663, 8581, 8559, 685, 9318, 9319, 9273
3950, 8559, 8581, 8582, 8560, 9319, 9320, 9321, 9275
3951, 8560, 8582, 8583, 8561, 9321, 9322, 9323, 9277
3952, 8561, 8583, 8584, 8562, 9323, 9324, 9325, 9279
3953, 8562, 8584, 8585, 8563, 9325, 9326, 9327, 9281
3954, 8563, 8585, 8586, 8564, 9327, 9328, 9329, 9283
3955, 8564, 8586, 8587, 8565, 9329, 9330, 9331, 9285
3956, 8565, 8587, 8588, 8566, 9331, 9332, 9333, 9287
3957, 8566, 8588, 8589, 8567, 9333, 9334, 9335, 9289
3958, 8567, 8589, 8590, 8568, 9335, 9336, 9337, 9291
3959, 8568, 8590, 8591, 8569, 9337, 9338, 9339, 9293
3960, 8569, 8591, 8592, 8570, 9339, 9340, 9341, 9295
3961, 8570, 8592, 8593, 8571, 9341, 9342, 9343, 9297
3962, 8571, 8593, 8594, 8572, 9343, 9344, 9345, 9299
3963, 8572, 8594, 8595, 8573, 9345, 9346, 9347, 9301
3964, 8573, 8595, 8596, 8574, 9347, 9348, 9349, 9303
3965, 8574, 8596, 8597, 8575, 9349, 9350, 9351, 9305
3966, 8575, 8597, 8598, 8576, 9351, 9352, 9353, 9307
3967, 8576, 8598, 8599, 8577, 9353, 9354, 9355, 9309
3968, 8577, 8599, 8600, 8578, 9355, 9356, 9357, 9311
3969, 8578, 8600, 8601, 8579, 9357, 9358, 9359, 9313
3970, 8579, 8601, 8602, 8580, 9359, 9360, 9361, 9315
3971, 8580, 8602, 729, 728, 9361, 9362, 751, 9317
3972, 663, 664, 8603, 8581, 686, 9363, 9364, 9318
3973, 8581, 8603, 8604, 8582, 9364, 9365, 9366, 9320
3974, 8582, 8604, 8605, 8583, 9366, 9367, 9368, 9322
3975, 8583, 8605, 8606, 8584, 9368, 9369, 9370, 9324
3976, 8584, 8606, 8607, 8585, 9370, 9371, 9372, 9326
3977, 8585, 8607, 8608, 8586, 9372, 9373, 9374, 9328
3978, 8586, 8608, 8609, 8587, 9374, 9375, 9376, 9330
3979, 8587, 8609, 8610, 8588, 9376, 9377, 9378, 9332
3980, 8588, 8610, 8611, 8589, 9378, 9379, 9380, 9334
3981, 8589, 8611, 8612, 8590, 9380, 9381, 9382, 9336
3982, 8590, 8612, 8613, 8591, 9382, 9383, 9384, 9338
3983, 8591, 8613, 8614, 8592, 9384, 9385, 9386, 9340
3984, 8592, 8614, 8615, 8593, 9386, 9387, 9388, 9342
3985, 8593, 8615, 8616, 8594, 9388, 9389, 9390, 9344
3986, 8594, 8616, 8617, 8595, 9390, 9391, 9392, 9346
3987, 8595, 8617, 8618, 8596, 9392, 9393, 9394, 9348
3988, 8596, 8618, 8619, 8597, 9394, 9395, 9396, 9350
3989, 8597, 8619, 8620, 8598, 9396, 9397, 9398, 9352
3990, 8598, 8620, 8621, 8599, 9398, 9399, 9400, 9354
3991, 8599, 8621, 8622, 8600, 9400, 9401, 9402, 9356
3992, 8600, 8622, 8623, 8601, 9402, 9403, 9404, 9358
3993, 8601, 8623, 8624, 8602, 9404, 9405, 9406, 9360
3994, 8602, 8624, 730, 729, 9406, 9407, 752, 9362
3995, 664, 665, 8625, 8603, 687, 9408, 9409, 9363
3996, 8603, 8625, 8626, 8604, 9409, 9410, 9411, 9365
3997, 8604, 8626, 8627, 8605, 9411, 9412, 9413, 9367
3998, 8605, 8627, 8628, 8606, 9413, 9414, 9415, 9369
3999, 8606, 8628, 8629, 8607, 9415, 9416, 9417, 9371
4000, 8607, 8629, 8630, 8608, 9417, 9418, 9419, 9373
4001, 8608, 8630, 8631, 8609, 9419, 9420, 9421, 9375
4002, 8609, 8631, 8632, 8610, 9421, 9422, 9423, 9377
4003, 8610, 8632, 8633, 8611, 9423, 9424, 9425, 9379
4004, 8611, 8633, 8634, 8612, 9425, 9426, 9427, 9381
4005, 8612, 8634, 8635, 8613, 9427, 9428, 9429, 9383
4006, 8613, 8635, 8636, 8614, 9429, 9430, 9431, 9385
4007, 8614, 8636, 8637, 8615, 9431, 9432, 9433, 9387
4008, 8615, 8637, 8638, 8616, 9433, 9434, 9435, 9389
4009, 8616, 8638, 8639, 8617, 9435, 9436, 9437, 9391
4010, 8617, 8639, 8640, 8618, 9437, 9438, 9439, 9393
4011, 8618, 8640, 8641, 8619, 9439, 9440, 9441, 9395
4012, 8619, 8641, 8642, 8620, 9441, 9442, 9443, 9397
4013, 8620, 8642, 8643, 8621, 9443, 9444, 9445, 9399
4014, 8621, 8643, 8644, 8622, 9445, 9446, 9447, 9401
4015, 8622, 8644, 8645, 8623, 9447, 9448, 9449, 9403
4016, 8623, 8645, 8646, 8624, 9449, 9450, 9451, 9405
4017, 8624, 8646, 731, 730, 9451, 9452, 753, 9407
4018, 665, 666, 8647, 8625, 688, 9453, 9454, 9408
4019, 8625, 8647, 8648, 8626, 9454, 9455, 9456, 9410
4020, 8626, 8648, 8649, 8627, 9456, 9457, 9458, 9412
4021, 8627, 8649, 8650, 8628, 9458, 9459, 9460, 9414
4022, 8628, 8650, 8651, 8629, 9460, 9461, 9462, 9416
4023, 8629, 8651, 8652, 8630, 9462, 9463, 9464, 9418
4024, 8630, 8652, 8653, 8631, 9464, 9465, 9466, 9420
4025, 8631, 8653, 8654, 8632, 9466, 9467, 9468, 9422
4026, 8632, 8654, 8655, 8633, 9468, 9469, 9470, 9424
4027, 8633, 8655, 8656, 8634, 9470, 9471, 9472, 9426
4028, 8634, 8656, 8657, 8635, 9472, 9473, 9474, 9428
4029, 8635, 8657, 8658, 8636, 9474, 9475, 9476, 9430
4030, 8636, 8658, 8659, 8637, 9476, 9477, 9478, 9432
4031, 8637, 8659, 8660, 8638, 9478, 9479, 9480, 9434
4032, 8638, 8660, 8661, 8639, 9480, 9481, 9482, 9436
4033, 8639, 8661, 8662, 8640, 9482, 9483, 9484, 9438
4034, 8640, 8662, 8663, 8641, 9484, 9485, 9486, 9440
4035, 8641, 8663, 8664, 8642, 9486, 9487, 9488, 9442
4036, 8642, 8664, 8665, 8643, 9488, 9489, 9490, 9444
4037, 8643, 8665, 8666, 8644, 9490, 9491, 9492, 9446
4038, 8644, 8666, 8667, 8645, 9492, 9493, 9494, 9448
4039, 8645, 8667, 8668, 8646, 9494, 9495, 9496, 9450
4040, 8646, 8668, 732, 731, 9496, 9497, 754, 9452
4041, 666, 667, 8669, 8647, 689, 9498, 9499, 9453
4042, 8647, 8669, 8670, 8648, 9499, 9500, 9501, 9455
4043, 8648, 8670, 8671, 8649, 9501, 9502, 9503, 9457
4044, 8649, 8671, 8672, 8650, 9503, 9504, 9505, 9459
4045, 8650, 8672, 8673, 8651, 9505, 9506, 9507, 9461
4046, 8651, 8673, 8674, 8652, 9507, 9508, 9509, 9463
4047, 8652, 8674, 8675, 8653, 9509, 9510, 9511, 9465
4048, 8653, 8675, 8676, 8654, 9511, 9512, 9513, 9467
4049, 8654, 8676, 8677, 8655, 9513, 9514, 9515, 9469
4050, 8655, 8677, 8678, 8656, 9515, 9516, 9517, 9471
4051, 8656, 8678, 8679, 8657, 9517, 9518, 9519, 9473
4052, 8657, 8679, 8680, 8658, 9519, 9520, 9521, 9475
4053, 8658, 8680, 8681, 8659, 9521, 9522, 9523, 9477
4054, 8659, 8681, 8682, 8660, 9523, 9524, 9525, 9479
4055, 8660, 8682, 8683, 8661, 9525, 9526, 9527, 9481
4056, 8661, 8683, 8684, 8662, 9527, 9528, 9529, 9483
4057, 8662, 8684, 8685, 8663, 9529, 9530, 9531, 9485
4058, 8663, 8685, 8686, 8664, 9531, 9532, 9533, 9487
4059, 8664, 8686, 8687, 8665, 9533, 9534, 9535, 9489
4060, 8665, 8687, 8688, 8666, 9535, 9536, 9537, 9491
4061, 8666, 8688, 8689, 8667, 9537, 9538, 9539, 9493
4062, 8667, 8689, 8690, 8668, 9539, 9540, 9541, 9495
4063, 8668, 8690, 733, 732, 9541, 9542, 755, 9497
4064, 667, 668, 8691, 8669, 690, 9543, 9544, 9498
4065, 8669, 8691, 8692, 8670, 9544, 9545, 9546, 9500
4066, 8670, 8692, 8693, 8671, 9546, 9547, 9548, 9502
4067, 8671, 8693, 8694, 8672, 9548, 9549, 9550, 9504
4068, 8672, 8694, 8695, 8673, 9550, 9551, 9552, 9506
4069, 8673, 8695, 8696, 8674, 9552, 9553, 9554, 9508
4070, 8674, 8696, 8697, 8675, 9554, 9555, 9556, 9510
4071, 8675, 8697, 8698, 8676, 9556, 9557, 9558, 9512
4072, 8676, 8698, 8699, 8677, 9558, 9559, 9560, 9514
4073, 8677, 8699, 8700, 8678, 9560, 9561, 9562, 9516
4074, 8678, 8700, 8701, 8679, 9562, 9563, 9564, 9518
4075, 8679, 8701, 8702, 8680, 9564, 9565, 9566, 9520
4076, 8680, 8702, 8703, 8681, 9566, 9567, 9568, 9522
4077, 8681, 8703, 8704, 8682, 9568, 9569, 9570, 9524
4078, 8682, 8704, 8705, 8683, 9570, 9571, 9572, 9526
4079, 8683, 8705, 8706, 8684, 9572, 9573, 9574, 9528
4080, 8684, 8706, 8707, 8685, 9574, 9575, 9576, 9530
4081, 8685, 8707, 8708, 8686, 9576, 9577, 9578, 9532
4082, 8686, 8708, 8709, 8687, 9578, 9579, 9580, 9534
4083, 8687, 8709, 8710, 8688, 9580, 9581, 9582, 9536
4084, 8688, 8710, 8711, 8689, 9582, 9583, 9584, 9538
4085, 8689, 8711, 8712, 8690, 9584, 9585, 9586, 9540
4086, 8690, 8712, 734, 733, 9586, 9587, 756, 9542
4087, 668, 669, 8713, 8691, 691, 9588, 9589, 9543
4088, 8691, 8713, 8714, 8692, 9589, 9590, 9591, 9545
4089, 8692, 8714, 8715, 8693, 9591, 9592, 9593, 9547
4090, 8693, 8715, 8716, 8694, 9593, 9594, 9595, 9549
4091, 8694, 8716, 8717, 8695, 9595, 9596, 9597, 9551
4092, 8695, 8717, 8718, 8696, 9597, 9598, 9599, 9553
4093, 8696, 8718, 8719, 8697, 9599, 9600, 9601, 9555
4094, 8697, 8719, 8720, 8698, 9601, 9602, 9603, 9557
4095, 8698, 8720, 8721, 8699, 9603, 9604, 9605, 9559
4096, 8699, 8721, 8722, 8700, 9605, 9606, 9607, 9561
4097, 8700, 8722, 8723, 8701, 9607, 9608, 9609, 9563
4098, 8701, 8723, 8724, 8702, 9609, 9610, 9611, 9565
4099, 8702, 8724, 8725, 8703, 9611, 9612, 9613, 9567
4100, 8703, 8725, 8726, 8704, 9613, 9614, 9615, 9569
4101, 8704, 8726, 8727, 8705, 9615, 9616, 9617, 9571
4102, 8705, 8727, 8728, 8706, 9617, 9618, 9619, 9573
4103, 8706, 8728, 8729, 8707, 9619, 9620, 9621, 9575
4104, 8707, 8729, 8730, 8708, 9621, 9622, 9623, 9577
4105, 8708, 8730, 8731, 8709, 9623, 9624, 9625, 9579
4106, 8709, 8731, 8732, 8710, 9625, 9626, 9627, 9581
4107, 8710, 8732, 8733, 8711, 9627, 9628, 9629, 9583
4108, 8711, 8733, 8734, 8712, 9629, 9630, 9631, 9585
4109, 8712, 8734, 735, 734, 9631, 9632, 757, 9587
4110, 669, 670, 8735, 8713, 692, 9633, 9634, 9588
4111, 8713, 8735, 8736, 8714, 9634, 9635, 9636, 9590
4112, 8714, 8736, 8737, 8715, 9636, 9637, 9638, 9592
4113, 8715, 8737, 8738, 8716, 9638, 9639, 9640, 9594
4114, 8716, 8738, 8739, 8717, 9640, 9641, 9642, 9596
4115, 8717, 8739, 8740, 8718, 9642, 9643, 9644, 9598
4116, 8718, 8740, 8741, 8719, 9644, 9645, 9646, 9600
4117, 8719, 8741, 8742, 8720, 9646, 9647, 9648, 9602
4118, 8720, 8742, 8743, 8721, 9648, 9649, 9650, 9604
4119, 8721, 8743, 8744, 8722, 9650, 9651, 9652, 9606
4120, 8722, 8744, 8745, 8723, 9652, 9653, 9654, 9608
4121, 8723, 8745, 8746, 8724, 9654, 9655, 9656, 9610
4122, 8724, 8746, 8747, 8725, 9656, 9657, 9658, 9612
4123, 8725, 8747, 8748, 8726, 9658, 9659, 9660, 9614
4124, 8726, 8748, 8749, 8727, 9660, 9661, 9662, 9616
4125, 8727, 8749, 8750, 8728, 9662, 9663, 9664, 9618
4126, 8728, 8750, 8751, 8729, 9664, 9665, 9666, 9620
4127, 8729, 8751, 8752, 8730, 9666, 9667, 9668, 9622
4128, 8730, 8752, 8753, 8731, 9668, 9669, 9670, 9624
4129, 8731, 8753, 8754, 8732, 9670, 9671, 9672, 9626
4130, 8732, 8754, 8755, 8733, 9672, 9673, 9674, 9628
4131, 8733, 8755, 8756, 8734, 9674, 9675, 9676, 9630
4132, 8734, 8756, 736, 735, 9676, 9677, 758, 9632
4133, 670, 671, 8757, 8735, 693, 9678, 9679, 9633
4134, 8735, 8757, 8758, 8736, 9679, 9680, 9681, 9635
4135, 8736, 8758, 8759, 8737, 9681, 9682, 9683, 9637
4136, 8737, 8759, 8760, 8738, 9683, 9684, 9685, 9639
4137, 8738, 8760, 8761, 8739, 9685, 9686, 9687, 9641
4138, 8739, 8761, 8762, 8740, 9687, 9688, 9689, 9643
4139, 8740, 8762, 8763, 8741, 9689, 9690, 9691, 9645
4140, 8741, 8763, 8764, 8742, 9691, 9692, 9693, 9647
4141, 8742, 8764, 8765, 8743, 9693, 9694, 9695, 9649
4142, 8743, 8765, 8766, 8744, 9695, 9696, 9697, 9651
4143, 8744, 8766, 8767, 8745, 9697, 9698, 9699, 9653
4144, 8745, 8767, 8768, 8746, 9699, 9700, 9701, 9655
4145, 8746, 8768, 8769, 8747, 9701, 9702, 9703, 9657
4146, 8747, 8769, 8770, 8748, 9703, 9704, 9705, 9659
4147, 8748, 8770, 8771, 8749, 9705, 9706, 9707, 9661
4148, 8749, 8771, 8772, 8750, 9707, 9708, 9709, 9663
4149, 8750, 8772, 8773, 8751, 9709, 9710, 9711, 9665
4150, 8751, 8773, 8774, 8752, 9711, 9712, 9713, 9667
4151, 8752, 8774, 8775, 8753, 9713, 9714, 9715, 9669
4152, 8753, 8775, 8776, 8754, 9715, 9716, 9717, 9671
4153, 8754, 8776, 8777, 8755, 9717, 9718, 9719, 9673
4154, 8755, 8777, 8778, 8756, 9719, 9720, 9721, 9675
4155, 8756, 8778, 737, 736, 9721, 9722, 759, 9677
4156, 671, 672, 8779, 8757, 694, 9723, 9724, 9678
4157, 8757, 8779, 8780, 8758, 9724, 9725, 9726, 9680
4158, 8758, 8780, 8781, 8759, 9726, 9727, 9728, 9682
4159, 8759, 8781, 8782, 8760, 9728, 9729, 9730, 9684
4160, 8760, 8782, 8783, 8761, 9730, 9731, 9732, 9686
4161, 8761, 8783, 8784, 8762, 9732, 9733, 9734, 9688
4162, 8762, 8784, 8785, 8763, 9734, 9735, 9736, 9690
4163, 8763, 8785, 8786, 8764, 9736, 9737, 9738, 9692
4164, 8764, 8786, 8787, 8765, 9738, 9739, 9740, 9694
4165, 8765, 8787, 8788, 8766, 9740, 9741, 9742, 9696
4166, 8766, 8788, 8789, 8767, 9742, 9743, 9744, 9698
4167, 8767, 8789, 8790, 8768, 9744, 9745, 9746, 9700
4168, 8768, 8790, 8791, 8769, 9746, 9747, 9748, 9702
4169, 8769, 8791, 8792, 8770, 9748, 9749, 9750, 9704
4170, 8770, 8792, 8793, 8771, 9750, 9751, 9752, 9706
4171, 8771, 8793, 8794, 8772, 9752, 9753, 9754, 9708
4172, 8772, 8794, 8795, 8773, 9754, 9755, 9756, 9710
4173, 8773, 8795, 8796, 8774, 9756, 9757, 9758, 9712
4174, 8774, 8796, 8797, 8775, 9758, 9759, 9760, 9714
4175, 8775, 8797, 8798, 8776, 9760, 9761, 9762, 9716
4176, 8776, 8798, 8799, 8777, 9762, 9763, 9764, 9718
4177, 8777, 8799, 8800, 8778, 9764, 9765, 9766, 9720
4178, 8778, 8800, 738, 737, 9766, 9767, 760, 9722
4179, 672, 673, 8801, 8779, 695, 9768, 9769, 9723
4180, 8779, 8801, 8802, 8780, 9769, 9770, 9771, 9725
4181, 8780, 8802, 8803, 8781, 9771, 9772, 9773, 9727
4182, 8781, 8803, 8804, 8782, 9773, 9774, 9775, 9729
4183, 8782, 8804, 8805, 8783, 9775, 9776, 9777, 9731
4184, 8783, 8805, 8806, 8784, 9777, 9778, 9779, 9733
4185, 8784, 8806, 8807, 8785, 9779, 9780, 9781, 9735
4186, 8785, 8807, 8808, 8786, 9781, 9782, 9783, 9737
4187, 8786, 8808, 8809, 8787, 9783, 9784, 9785, 9739
4188, 8787, 8809, 8810, 8788, 9785, 9786, 9787, 9741
4189, 8788, 8810, 8811, 8789, 9787, 9788, 9789, 9743
4190, 8789, 8811, 8812, 8790, 9789, 9790, 9791, 9745
4191, 8790, 8812, 8813, 8791, 9791, 9792, 9793, 9747
4192, 8791, 8813, 8814, 8792, 9793, 9794, 9795, 9749
4193, 8792, 8814, 8815, 8793, 9795, 9796, 9797, 9751
4194, 8793, 8815, 8816, 8794, 9797, 9798, 9799, 9753
4195, 8794, 8816, 8817, 8795, 9799, 9800, 9801, 9755
4196, 8795, 8817, 8818, 8796, 9801, 9802, 9803, 9757
4197, 8796, 8818, 8819, 8797, 9803, 9804, 9805, 9759
4198, 8797, 8819, 8820, 8798, 9805, 9806, 9807, 9761
4199, 8798, 8820, 8821, 8799, 9807, 9808, 9809, 9763
4200, 8799, 8821, 8822, 8800, 9809, 9810, 9811, 9765
4201, 8800, 8822, 739, 738, 9811, 9812, 761, 9767
4202, 673, 15, 784, 8801, 696, 807, 9813, 9768
4203, 8801, 784, 783, 8802, 9813, 806, 9814, 9770
4204, 8802, 783, 782, 8803, 9814, 805, 9815, 9772
4205, 8803, 782, 781, 8804, 9815, 804, 9816, 9774
4206, 8804, 781, 780, 8805, 9816, 803, 9817, 9776
4207, 8805, 780, 779, 8806, 9817, 802, 9818, 9778
4208, 8806, 779, 778, 8807, 9818, 801, 9819, 9780
4209, 8807, 778, 777, 8808, 9819, 800, 9820, 9782
4210, 8808, 777, 776, 8809, 9820, 799, 9821, 9784
4211, 8809, 776, 775, 8810, 9821, 798, 9822, 9786
4212, 8810, 775, 774, 8811, 9822, 797, 9823, 9788
4213, 8811, 774, 773, 8812, 9823, 796, 9824, 9790
4214, 8812, 773, 772, 8813, 9824, 795, 9825, 9792
4215, 8813, 772, 771, 8814, 9825, 794, 9826, 9794
4216, 8814, 771, 770, 8815, 9826, 793, 9827, 9796
4217, 8815, 770, 769, 8816, 9827, 792, 9828, 9798
4218, 8816, 769, 768, 8817, 9828, 791, 9829, 9800
4219, 8817, 768, 767, 8818, 9829, 790, 9830, 9802
4220, 8818, 767, 766, 8819, 9830, 789, 9831, 9804
4221, 8819, 766, 765, 8820, 9831, 788, 9832, 9806
4222, 8820, 765, 764, 8821, 9832, 787, 9833, 9808
4223, 8821, 764, 763, 8822, 9833, 786, 9834, 9810
4224, 8822, 763, 16, 739, 9834, 785, 762, 9812
*ELEMENT, type=CPS8, ELSET=Surface15
4225, 12, 718, 9835, 505, 740, 10055, 10056, 516
4226, 505, 9835, 9836, 504, 10056, 10057, 10058, 515
4227, 504, 9836, 9837, 503, 10058, 10059, 10060, 514
4228, 503, 9837, 9838, 502, 10060, 10061, 10062, 513
4229, 502, 9838, 9839, 501, 10062, 10063, 10064, 512
4230, 501, 9839, 9840, 500, 10064, 10065, 10066, 511
4231, 500, 9840, 9841, 499, 10066, 10067, 10068, 510
4232, 499, 9841, 9842, 498, 10068, 10069, 10070, 509
4233, 498, 9842, 9843, 497, 10070, 10071, 10072, 508
4234, 497, 9843, 9844, 496, 10072, 10073, 10074, 507
4235, 496, 9844, 562, 10, 10074, 10075, 584, 506
4236, 718, 719, 9845, 9835, 741, 10076, 10077, 10055
4237, 9835, 9845, 9846, 9836, 10077, 10078, 10079, 10057
4238, 9836, 9846, 9847, 9837, 10079, 10080, 10081, 10059
4239, 9837, 9847, 9848, 9838, 10081, 10082, 10083, 10061
4240, 9838, 9848, 9849, 9839, 10083, 10084, 10085, 10063
4241, 9839, 9849, 9850, 9840, 10085, 10086, 10087, 10065
4242, 9840, 9850, 9851, 9841, 10087, 10088, 10089, 10067
4243, 9841, 9851, 9852, 9842, 10089, 10090, 10091, 10069
4244, 9842, 9852, 9853, 9843, 10091, 10092, 10093, 10071
4245, 9843, 9853, 9854, 9844, 10093, 10094, 10095, 10073
4246, 9844, 9854, 563, 562, 10095, 10096, 585, 10075
4247, 719, 720, 9855, 9845, 742, 10097, 10098, 10076
4248, 9845, 9855, 9856, 9846, 10098, 10099, 10100, 10078
4249, 9846, 9856, 9857, 9847, 10100, 10101, 10102, 10080
4250, 9847, 9857, 9858, 9848, 10102, 10103, 10104, 10082
4251, 9848, 9858, 9859, 9849, 10104, 10105, 10106, 10084
4252, 9849, 9859, 9860, 9850, 10106, 10107, 10108, 10086
4253, 9850, 9860, 9861, 9851, 10108, 10109, 10110, 10088
4254, 9851, 9861, 9862, 9852, 10110, 10111, 10112, 10090
4255, 9852, 9862, 9863, 9853, 10112, 10113, 10114, 10092
4256, 9853, 9863, 9864, 9854, 10114, 10115, 10116, 10094
4257, 9854, 9864, 564, 563, 10116, 10117, 586, 10096
4258, 720, 721, 9865, 9855, 743, 10118, 10119, 10097
4259, 9855, 9865, 9866, 9856, 10119, 10120, 10121, 10099
4260, 9856, 9866, 9867, 9857, 10121, 10122, 10123, 10101
4261, 9857, 9867, 9868, 9858, 10123, 10124, 10125, 10103
4262, 9858, 9868, 9869, 9859, 10125, 10126, 10127, 10105
4263, 9859, 9869, 9870, 9860, 10127, 10128, 10129, 10107
4264, 9860, 9870, 9871, 9861, 10129, 10130, 10131, 10109
4265, 9861, 9871, 9872, 9862, 10131, 10132, 10133, 10111
4266, 9862, 9872, 9873, 9863, 10133, 10134, 10135, 10113
4267, 9863, 9873, 9874, 9864, 10135, 10136, 10137, 10115
4268, 9864, 9874, 565, 564, 10137, 10138, 587, 10117
4269, 721, 722, 9875, 9865, 744, 10139, 10140, 10118
4270, 9865, 9875, 9876, 9866, 10140, 10141, 10142, 10120
4271, 9866, 9876, 9877, 9867, 10142, 10143, 10144, 10122
4272, 9867, 9877, 9878, 9868, 10144, 10145, 10146, 10124
4273, 9868, 9878, 9879, 9869, 10146, 10147, 10148, 10126
4274, 9869, 9879, 9880, 9870, 10148, 10149, 10150, 10128
4275, 9870, 9880, 9881, 9871, 10150, 10151, 10152, 10130
4276, 9871, 9881, 9882, 9872, 10152, 10153, 10154, 10132
4277, 9872, 9882, 9883, 9873, 10154, 10155, 10156, 10134
4278, 9873, 9883, 9884, 9874, 10156, 10157, 10158, 10136
4279, 9874, 9884, 566, 565, 10158, 10159, 588, 10138
4280, 722, 723, 9885, 9875, 745, 10160, 10161, 10139
4281, 9875, 9885, 9886, 9876, 10161, 10162, 10163, 10141
4282, 9876, 9886, 9887, 9877, 10163, 10164, 10165, 10143
4283, 9877, 9887, 9888, 9878, 10165, 10166, 10167, 10145
4284, 9878, 9888, 9889, 9879, 10167, 10168, 10169, 10147
4285, 9879, 9889, 9890, 9880, 10169, 10170, 10171, 10149
4286, 9880, 9890, 9891, 9881, 10171, 10172, 10173, 10151
4287, 9881, 9891, 9892, 9882, 10173, 10174, 10175, 10153
4288, 9882, 9892, 9893, 9883, 10175, 10176, 10177, 10155
4289, 9883, 9893, 9894, 9884, 10177, 10178, 10179, 10157
4290, 9884, 9894, 567, 566, 10179, 10180, 589, 10159
4291, 723, 724, 9895, 9885, 746, 10181, 10182, 10160
4292, 9885, 9895, 9896, 9886, 10182, 10183, 10184, 10162
4293, 9886, 9896, 9897, 9887, 10184, 10185, 10186, 10164
4294, 9887, 9897, 9898, 9888, 10186, 10187, 10188, 10166
4295, 9888, 9898, 9899, 9889, 10188, 10189, 10190, 10168
4296, 9889, 9899, 9900, 9890, 10190, 10191, 10192, 10170
4297, 9890, 9900, 9901, 9891, 10192, 10193, 10194, 10172
4298, 9891, 9901, 9902, 9892, 10194, 10195, 10196, 10174
4299, 9892, 9902, 9903, 9893, 10196, 10197, 10198, 10176
4300, 9893, 9903, 9904, 9894, 10198, 10199, 10200, 10178
4301, 9894, 9904, 568, 567, 10200, 10201, 590, 10180
4302, 724, 725, 9905, 9895, 747, 10202, 10203, 10181
4303, 9895, 9905, 9906, 9896, 10203, 10204, 10205, 10183
4304, 9896, 9906, 9907, 9897, 10205, 10206, 10207, 10185
4305, 9897, 9907, 9908, 9898, 10207, 10208, 10209, 10187
4306, 9898, 9908, 9909, 9899, 10209, 10210, 10211, 10189
4307, 9899, 9909, 9910, 9900, 10211, 10212, 10213, 10191
4308, 9900, 9910, 9911, 9901, 10213, 10214, 10215, 10193
4309, 9901, 9911, 9912, 9902, 10215, 10216, 10217, 10195
4310, 9902, 9912, 9913, 9903, 10217, 10218, 10219, 10197
4311, 9903, 9913, 9914, 9904, 10219, 10220, 10221, 10199
4312, 9904, 9914, 569, 568, 10221, 10222, 591, 10201
4313, 725, 726, 9915, 9905, 748, 10223, 10224, 10202
4314, 9905, 9915, 9916, 9906, 10224, 10225, 10226, 10204
4315, 9906, 9916, 9917, 9907, 10226, 10227, 10228, 10206
4316, 9907, 9917, 9918, 9908, 10228, 10229, 10230, 10208
4317, 9908, 9918, 9919, 9909, 10230, 10231, 10232, 10210
4318, 9909, 9919, 9920, 9910, 10232, 10233, 10234, 10212
4319, 9910, 9920, 9921, 9911, 10234, 10235, 10236, 10214
4320, 9911, 9921, 9922, 9912, 10236, 10237, 10238, 10216
4321, 9912, 9922, 9923, 9913, 10238, 10239, 10240, 10218
4322, 9913, 9923, 9924, 9914, 10240, 10241, 10242, 10220
4323, 9914, 9924, 570, 569, 10242, 10243, 592, 10222
4324, 726, 727, 9925, 9915, 749, 10244, 10245, 10223
4325, 9915, 9925, 9926, 9916, 10245, 10246, 10247, 10225
4326, 9916, 9926, 9927, 9917, 10247, 10248, 10249, 10227
4327, 9917, 9927, 9928, 9918, 10249, 10250, 10251, 10229
4328, 9918, 9928, 9929, 9919, 10251, 10252, 10253, 10231
4329, 9919, 9929, 9930, 9920, 10253, 10254, 10255, 10233
4330, 9920, 9930, 9931, 9921, 10255, 10256, 10257, 10235
4331, 9921, 9931, 9932, 9922, 10257, 10258, 10259, 10237
4332, 9922, 9932, 9933, 9923, 10259, 10260, 10261, 10239
4333, 9923, 9933, 9934, 9924, 10261, 10262, 10263, 10241
4334, 9924, 9934, 571, 570, 10263, 10264, 593, 10243
4335, 727, 728, 9935, 9925, 750, 10265, 10266, 10244
4336, 9925, 9935, 9936, 9926, 10266, 10267, 10268, 10246
4337, 9926, 9936, 9937, 9927, 10268, 10269, 10270, 10248
4338, 9927, 9937, 9938, 9928, 10270, 10271, 10272, 10250
4339, 9928, 9938, 9939, 9929, 10272, 10273, 10274, 10252
4340, 9929, 9939, 9940, 9930, 10274, 10275, 10276, 10254
4341, 9930, 9940, 9941, 9931, 10276, 10277, 10278, 10256
4342, 9931, 9941, 9942, 9932, 10278, 10279, 10280, 10258
4343, 9932, 9942, 9943, 9933, 10280, 10281, 10282, 10260
4344, 9933, 9943, 9944, 9934, 10282, 10283, 10284, 10262
4345, 9934, 9944, 572, 571, 10284, 10285, 594, 10264
4346, 728, 729, 9945, 9935, 751, 10286, 10287, 10265
4347, 9935, 9945, 9946, 9936, 10287, 10288, 10289, 10267
4348, 9936, 9946, 9947, 9937, 10289, 10290, 10291, 10269
4349, 9937, 9947, 9948, 9938, 10291, 10292, 10293, 10271
4350, 9938, 9948, 9949, 9939, 10293, 10294, 10295, 10273
4351, 9939, 9949, 9950, 9940, 10295, 10296, 10297, 10275
4352, 9940, 9950, 9951, 9941, 10297, 10298, 10299, 10277
4353, 9941, 9951, 9952, 9942, 10299, 10300, 10301, 10279
4354, 9942, 9952, 9953, 9943, 10301, 10302, 10303, 10281
4355, 9943, 9953, 9954, 9944, 10303, 10304, 10305, 10283
4356, 9944, 9954, 573, 572, 10305, 10306, 595, 10285
4357, 729, 730, 9955, 9945, 752, 10307, 10308, 10286
4358, 9945, 9955, 9956, 9946, 10308, 10309, 10310, 10288
4359, 9946, 9956, 9957, 9947, 10310, 10311, 10312, 10290
4360, 9947, 9957, 9958, 9948, 10312, 10313, 10314, 10292
4361, 9948, 9958, 9959, 9949, 10314, 10315, 10316, 10294
4362, 9949, 9959, 9960, 9950, 10316, 10317, 10318, 10296
4363, 9950, 9960, 9961, 9951, 10318, 10319, 10320, 10298
4364, 9951, 9961, 9962, 9952, 10320, 10321, 10322, 10300
4365, 9952, 9962, 9963, 9953, 10322, 10323, 10324, 10302
4366, 9953, 9963, 9964, 9954, 10324, 10325, 10326, 10304
4367, 9954, 9964, 574, 573, 10326, 10327, 596, 10306
4368, 730, 731, 9965, 9955, 753, 10328, 10329, 10307
4369, 9955, 9965, 9966, 9956, 10329, 10330, 10331, 10309
4370, 9956, 9966, 9967, 9957, 10331, 10332, 10333, 10311
4371, 9957, 9967, 9968, 9958, 10333, 10334, 10335, 10313
4372, 9958, 9968, 9969, 9959, 10335, 10336, 10337, 10315
4373, 9959, 9969, 9970, 9960, 10337, 10338, 10339, 10317
4374, 9960, 9970, 9971, 9961, 10339, 10340, 10341, 10319
4375, 9961, 9971, 9972, 9962, 10341, 10342, 10343, 10321
4376, 9962, 9972, 9973, 9963, 10343, 10344, 10345, 10323
4377, 9963, 9973, 9974, 9964, 10345, 10346, 10347, 10325
4378, 9964, 9974, 575, 574, 10347, 10348, 597, 10327
4379, 731, 732, 9975, 9965, 754, 10349, 10350, 10328
4380, 9965, 9975, 9976, 9966, 10350, 10351, 10352, 10330
4381, 9966, 9976, 9977, 9967, 10352, 10353, 10354, 10332
4382, 9967, 9977, 9978, 9968, 10354, 10355, 10356, 10334
4383, 9968, 9978, 9979, 9969, 10356, 10357, 10358, 10336
4384, 9969, 9979, 9980, 9970, 10358, 10359, 10360, 10338
4385, 9970, 9980, 9981, 9971, 10360, 10361, 10362, 10340
4386, 9971, 9981, 9982, 9972, 10362, 10363, 10364, 10342
4387, 9972, 9982, 9983, 9973, 10364, 10365, 10366, 10344
4388, 9973, 9983, 9984, 9974, 10366, 10367, 10368, 10346
4389, 9974, 9984, 576, 575, 10368, 10369, 598, 10348
4390, 732, 733, 9985, 9975, 755, 10370, 10371, 10349
4391, 9975, 9985, 9986, 9976, 10371, 10372, 10373, 10351
4392, 9976, 9986, 9987, 9977, 10373, 10374, 10375, 10353
4393, 9977, 9987, 9988, 9978, 10375, 10376, 10377, 10355
4394, 9978, 9988, 9989, 9979, 10377, 10378, 10379, 10357
4395, 9979, 9989, 9990, 9980, 10379, 10380, 10381, 10359
4396, 9980, 9990, 9991, 9981, 10381, 10382, 10383, 10361
4397, 9981, 9991, 9992, 9982, 10383, 10384, 10385, 10363
4398, 9982, 9992, 9993, 9983, 10385, 10386, 10387, 10365
4399, 9983, 9993, 9994, 9984, 10387, 10388, 10389, 10367
4400, 9984, 9994, 577, 576, 10389, 10390, 599, 10369
4401, 733, 734, 9995, 9985, 756, 10391, 10392, 10370
4402, 9985, 9995, 9996, 9986, 10392, 10393, 10394, 10372
4403, 9986, 9996, 9997, 9987, 10394, 10395, 10396, 10374
4404, 9987, 9997, 9998, 9988, 10396, 10397, 10398, 10376
4405, 9988, 9998, 9999, 9989, 10398, 10399, 10400, 10378
4406, 9989, 9999, 10000, 9990, 10400, 10401, 10402, 10380
4407, 9990, 10000, 10001, 9991, 10402, 10403, 10404, 10382
4408, 9991, 10001, 10002, 9992, 10404, 10405, 10406, 10384
4409, 9992, 10002, 10003, 9993, 10406, 10407, 10408, 10386
4410, 9993, 10003, 10004, 9994, 10408, 10409, 10410, 10388
4411, 9994, 10004, 578, 577, 10410, 10411, 600, 10390
4412, 734, 735, 10005, 9995, 757, 10412, 10413, 10391
4413, 9995, 10005, 10006, 9996, 10413, 10414, 10415, 10393
4414, 9996, 10006, 10007, 9997, 10415, 10416, 10417, 10395
4415, 9997, 10007, 10008, 9998, 10417, 10418, 10419, 10397
4416, 9998, 10008, 10009, 9999, 10419, 10420, 10421, 10399
4417, 9999, 10009, 10010, 10000, 10421, 10422, 10423, 10401
4418, 10000, 10010, 10011, 10001, 10423, 10424, 10425, 10403
4419, 10001, 10011, 10012, 10002, 10425, 10426, 10427, 10405
4420, 10002, 10012, 10013, 10003, 10427, 10428, 10429, 10407
4421, 10003, 10013, 10014, 10004, 10429, 10430, 10431, 10409
4422, 10004, 10014, 579, 578, 10431, 10432, 601, 10411
4423, 735, 736, 10015, 10005, 758, 10433, 10434, 10412
4424, 10005, 10015, 10016, 10006, 10434, 10435, 10436, 10414
4425, 10006, 10016, 10017, 10007, 10436, 10437, 10438, 10416
4426, 10007, 10017, 10018, 10008, 10438, 10439, 10440, 10418
4427, 10008, 10018, 10019, 10009, 10440, 10441, 10442, 10420
4428, 10009, 10019, 10020, 10010, 10442, 10443, 10444, 10422
4429, 10010, 10020, 10021, 10011, 10444, 10445, 10446, 10424
4430, 10011, 10021, 10022, 10012, 10446, 10447, 10448, 10426
4431, 10012, 10022, 10023, 10013, 10448, 10449, 10450, 10428
4432, 10013, 10023, 10024, 10014, 10450, 10451, 10452, 10430
4433, 10014, 10024, 580, 579, 10452, 10453, 602, 10432
4434, 736, 737, 10025, 10015, 759, 10454, 10455, 10433
4435, 10015, 10025, 10026, 10016, 10455, 10456, 10457, 10435
4436, 10016, 10026, 10027, 10017, 10457, 10458, 10459, 10437
4437, 10017, 10027, 10028, 10018, 10459, 10460, 10461, 10439
4438, 10018, 10028, 10029, 10019, 10461, 10462, 10463, 10441
4439, 10019, 10029, 10030, 10020, 10463, 10464, 10465, 10443
4440, 10020, 10030, 10031, 10021, 10465, 10466, 10467, 10445
4441, 10021, 10031, 10032, 10022, 10467, 10468, 10469, 10447
4442, 10022, 10032, 10033, 10023, 10469, 10470, 10471, 10449
4443, 10023, 10033, 10034, 10024, 10471, 10472, 10473, 10451
4444, 10024, 10034, 581, 580, 10473, 10474, 603, 10453
4445, 737, 738, 10035, 10025, 760, 10475, 10476, 10454
4446, 10025, 10035, 10036, 10026, 10476, 10477, 10478, 10456
