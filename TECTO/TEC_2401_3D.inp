64136, 1.5913043478261, 0.72391304347826, 0.31818181818182
64137, 1.5913043478261, 0.72391304347826, 0.27272727272727
64138, 1.5913043478261, 0.72391304347826, 0.22727272727273
64139, 1.5913043478261, 0.72391304347826, 0.18181818181818
64140, 1.5913043478261, 0.72391304347826, 0.13636363636364
64141, 1.5913043478261, 0.72391304347826, 0.090909090909091
64142, 1.5913043478261, 0.72391304347826, 0.045454545454545
64143, 1.6347826086957, 0.72391304347826, 0.45454545454545
64144, 1.6347826086957, 0.72391304347826, 0.40909090909091
64145, 1.6347826086957, 0.72391304347826, 0.36363636363636
64146, 1.6347826086957, 0.72391304347826, 0.31818181818182
64147, 1.6347826086957, 0.72391304347826, 0.27272727272727
64148, 1.6347826086957, 0.72391304347826, 0.22727272727273
64149, 1.6347826086957, 0.72391304347826, 0.18181818181818
64150, 1.6347826086957, 0.72391304347826, 0.13636363636364
64151, 1.6347826086957, 0.72391304347826, 0.090909090909091
64152, 1.6347826086957, 0.72391304347826, 0.045454545454545
64153, 1.6782608695652, 0.72391304347826, 0.45454545454545
64154, 1.6782608695652, 0.72391304347826, 0.40909090909091
64155, 1.6782608695652, 0.72391304347826, 0.36363636363636
64156, 1.6782608695652, 0.72391304347826, 0.31818181818182
64157, 1.6782608695652, 0.72391304347826, 0.27272727272727
64158, 1.6782608695652, 0.72391304347826, 0.22727272727273
64159, 1.6782608695652, 0.72391304347826, 0.18181818181818
64160, 1.6782608695652, 0.72391304347826, 0.13636363636364
64161, 1.6782608695652, 0.72391304347826, 0.090909090909091
64162, 1.6782608695652, 0.72391304347826, 0.045454545454545
64163, 1.7217391304348, 0.72391304347826, 0.45454545454545
64164, 1.7217391304348, 0.72391304347826, 0.40909090909091
64165, 1.7217391304348, 0.72391304347826, 0.36363636363636
64166, 1.7217391304348, 0.72391304347826, 0.31818181818182
64167, 1.7217391304348, 0.72391304347826, 0.27272727272727
64168, 1.7217391304348, 0.72391304347826, 0.22727272727273
64169, 1.7217391304348, 0.72391304347826, 0.18181818181818
64170, 1.7217391304348, 0.72391304347826, 0.13636363636364
64171, 1.7217391304348, 0.72391304347826, 0.090909090909091
64172, 1.7217391304348, 0.72391304347826, 0.045454545454545
64173, 1.7652173913043, 0.72391304347826, 0.45454545454545
64174, 1.7652173913043, 0.72391304347826, 0.40909090909091
64175, 1.7652173913043, 0.72391304347826, 0.36363636363636
64176, 1.7652173913043, 0.72391304347826, 0.31818181818182
64177, 1.7652173913043, 0.72391304347826, 0.27272727272727
64178, 1.7652173913043, 0.72391304347826, 0.22727272727273
64179, 1.7652173913043, 0.72391304347826, 0.18181818181818
64180, 1.7652173913043, 0.72391304347826, 0.13636363636364
64181, 1.7652173913043, 0.72391304347826, 0.090909090909091
64182, 1.7652173913043, 0.72391304347826, 0.045454545454545
64183, 1.8086956521739, 0.72391304347826, 0.45454545454545
64184, 1.8086956521739, 0.72391304347826, 0.40909090909091
64185, 1.8086956521739, 0.72391304347826, 0.36363636363636
64186, 1.8086956521739, 0.72391304347826, 0.31818181818182
64187, 1.8086956521739, 0.72391304347826, 0.27272727272727
64188, 1.8086956521739, 0.72391304347826, 0.22727272727273
64189, 1.8086956521739, 0.72391304347826, 0.18181818181818
64190, 1.8086956521739, 0.72391304347826, 0.13636363636364
64191, 1.8086956521739, 0.72391304347826, 0.090909090909091
64192, 1.8086956521739, 0.72391304347826, 0.045454545454545
64193, 1.8521739130435, 0.72391304347826, 0.45454545454545
64194, 1.8521739130435, 0.72391304347826, 0.40909090909091
64195, 1.8521739130435, 0.72391304347826, 0.36363636363636
64196, 1.8521739130435, 0.72391304347826, 0.31818181818182
64197, 1.8521739130435, 0.72391304347826, 0.27272727272727
64198, 1.8521739130435, 0.72391304347826, 0.22727272727273
64199, 1.8521739130435, 0.72391304347826, 0.18181818181818
64200, 1.8521739130435, 0.72391304347826, 0.13636363636364
64201, 1.8521739130435, 0.72391304347826, 0.090909090909091
64202, 1.8521739130435, 0.72391304347826, 0.045454545454545
64203, 1.895652173913, 0.72391304347826, 0.45454545454545
64204, 1.895652173913, 0.72391304347826, 0.40909090909091
64205, 1.895652173913, 0.72391304347826, 0.36363636363636
64206, 1.895652173913, 0.72391304347826, 0.31818181818182
64207, 1.895652173913, 0.72391304347826, 0.27272727272727
64208, 1.895652173913, 0.72391304347826, 0.22727272727273
64209, 1.895652173913, 0.72391304347826, 0.18181818181818
64210, 1.895652173913, 0.72391304347826, 0.13636363636364
64211, 1.895652173913, 0.72391304347826, 0.090909090909091
64212, 1.895652173913, 0.72391304347826, 0.045454545454545
64213, 1.9391304347826, 0.72391304347826, 0.45454545454545
64214, 1.9391304347826, 0.72391304347826, 0.40909090909091
64215, 1.9391304347826, 0.72391304347826, 0.36363636363636
64216, 1.9391304347826, 0.72391304347826, 0.31818181818182
64217, 1.9391304347826, 0.72391304347826, 0.27272727272727
64218, 1.9391304347826, 0.72391304347826, 0.22727272727273
64219, 1.9391304347826, 0.72391304347826, 0.18181818181818
64220, 1.9391304347826, 0.72391304347826, 0.13636363636364
64221, 1.9391304347826, 0.72391304347826, 0.090909090909091
64222, 1.9391304347826, 0.72391304347826, 0.045454545454545
64223, 1.9826086956522, 0.72391304347826, 0.45454545454545
64224, 1.9826086956522, 0.72391304347826, 0.40909090909091
64225, 1.9826086956522, 0.72391304347826, 0.36363636363636
64226, 1.9826086956522, 0.72391304347826, 0.31818181818182
64227, 1.9826086956522, 0.72391304347826, 0.27272727272727
64228, 1.9826086956522, 0.72391304347826, 0.22727272727273
64229, 1.9826086956522, 0.72391304347826, 0.18181818181818
64230, 1.9826086956522, 0.72391304347826, 0.13636363636364
64231, 1.9826086956522, 0.72391304347826, 0.090909090909091
64232, 1.9826086956522, 0.72391304347826, 0.045454545454545
64233, 2.0260869565217, 0.72391304347826, 0.45454545454545
64234, 2.0260869565217, 0.72391304347826, 0.40909090909091
64235, 2.0260869565217, 0.72391304347826, 0.36363636363636
64236, 2.0260869565217, 0.72391304347826, 0.31818181818182
64237, 2.0260869565217, 0.72391304347826, 0.27272727272727
64238, 2.0260869565217, 0.72391304347826, 0.22727272727273
64239, 2.0260869565217, 0.72391304347826, 0.18181818181818
64240, 2.0260869565217, 0.72391304347826, 0.13636363636364
64241, 2.0260869565217, 0.72391304347826, 0.090909090909091
64242, 2.0260869565217, 0.72391304347826, 0.045454545454545
64243, 2.0695652173913, 0.72391304347826, 0.45454545454545
64244, 2.0695652173913, 0.72391304347826, 0.40909090909091
64245, 2.0695652173913, 0.72391304347826, 0.36363636363636
64246, 2.0695652173913, 0.72391304347826, 0.31818181818182
64247, 2.0695652173913, 0.72391304347826, 0.27272727272727
64248, 2.0695652173913, 0.72391304347826, 0.22727272727273
64249, 2.0695652173913, 0.72391304347826, 0.18181818181818
64250, 2.0695652173913, 0.72391304347826, 0.13636363636364
64251, 2.0695652173913, 0.72391304347826, 0.090909090909091
64252, 2.0695652173913, 0.72391304347826, 0.045454545454545
64253, 2.1130434782609, 0.72391304347826, 0.45454545454545
64254, 2.1130434782609, 0.72391304347826, 0.40909090909091
64255, 2.1130434782609, 0.72391304347826, 0.36363636363636
64256, 2.1130434782609, 0.72391304347826, 0.31818181818182
64257, 2.1130434782609, 0.72391304347826, 0.27272727272727
64258, 2.1130434782609, 0.72391304347826, 0.22727272727273
64259, 2.1130434782609, 0.72391304347826, 0.18181818181818
64260, 2.1130434782609, 0.72391304347826, 0.13636363636364
64261, 2.1130434782609, 0.72391304347826, 0.090909090909091
64262, 2.1130434782609, 0.72391304347826, 0.045454545454545
64263, 2.1565217391304, 0.72391304347826, 0.45454545454545
64264, 2.1565217391304, 0.72391304347826, 0.40909090909091
64265, 2.1565217391304, 0.72391304347826, 0.36363636363636
64266, 2.1565217391304, 0.72391304347826, 0.31818181818182
64267, 2.1565217391304, 0.72391304347826, 0.27272727272727
64268, 2.1565217391304, 0.72391304347826, 0.22727272727273
64269, 2.1565217391304, 0.72391304347826, 0.18181818181818
64270, 2.1565217391304, 0.72391304347826, 0.13636363636364
64271, 2.1565217391304, 0.72391304347826, 0.090909090909091
64272, 2.1565217391304, 0.72391304347826, 0.045454545454545
64273, 1.2434782608696, 0.67173913043478, 0.45454545454545
64274, 1.2434782608696, 0.67173913043478, 0.40909090909091
64275, 1.2434782608696, 0.67173913043478, 0.36363636363636
64276, 1.2434782608696, 0.67173913043478, 0.31818181818182
64277, 1.2434782608696, 0.67173913043478, 0.27272727272727
64278, 1.2434782608696, 0.67173913043478, 0.22727272727273
64279, 1.2434782608696, 0.67173913043478, 0.18181818181818
64280, 1.2434782608696, 0.67173913043478, 0.13636363636364
64281, 1.2434782608696, 0.67173913043478, 0.090909090909091
64282, 1.2434782608696, 0.67173913043478, 0.045454545454545
64283, 1.2869565217391, 0.67173913043478, 0.45454545454545
64284, 1.2869565217391, 0.67173913043478, 0.40909090909091
64285, 1.2869565217391, 0.67173913043478, 0.36363636363636
64286, 1.2869565217391, 0.67173913043478, 0.31818181818182
64287, 1.2869565217391, 0.67173913043478, 0.27272727272727
64288, 1.2869565217391, 0.67173913043478, 0.22727272727273
64289, 1.2869565217391, 0.67173913043478, 0.18181818181818
64290, 1.2869565217391, 0.67173913043478, 0.13636363636364
64291, 1.2869565217391, 0.67173913043478, 0.090909090909091
64292, 1.2869565217391, 0.67173913043478, 0.045454545454545
64293, 1.3304347826087, 0.67173913043478, 0.45454545454545
64294, 1.3304347826087, 0.67173913043478, 0.40909090909091
64295, 1.3304347826087, 0.67173913043478, 0.36363636363636
64296, 1.3304347826087, 0.67173913043478, 0.31818181818182
64297, 1.3304347826087, 0.67173913043478, 0.27272727272727
64298, 1.3304347826087, 0.67173913043478, 0.22727272727273
64299, 1.3304347826087, 0.67173913043478, 0.18181818181818
64300, 1.3304347826087, 0.67173913043478, 0.13636363636364
64301, 1.3304347826087, 0.67173913043478, 0.090909090909091
64302, 1.3304347826087, 0.67173913043478, 0.045454545454545
64303, 1.3739130434783, 0.67173913043478, 0.45454545454545
64304, 1.3739130434783, 0.67173913043478, 0.40909090909091
64305, 1.3739130434783, 0.67173913043478, 0.36363636363636
64306, 1.3739130434783, 0.67173913043478, 0.31818181818182
64307, 1.3739130434783, 0.67173913043478, 0.27272727272727
64308, 1.3739130434783, 0.67173913043478, 0.22727272727273
64309, 1.3739130434783, 0.67173913043478, 0.18181818181818
64310, 1.3739130434783, 0.67173913043478, 0.13636363636364
64311, 1.3739130434783, 0.67173913043478, 0.090909090909091
64312, 1.3739130434783, 0.67173913043478, 0.045454545454545
64313, 1.4173913043478, 0.67173913043478, 0.45454545454545
64314, 1.4173913043478, 0.67173913043478, 0.40909090909091
64315, 1.4173913043478, 0.67173913043478, 0.36363636363636
64316, 1.4173913043478, 0.67173913043478, 0.31818181818182
64317, 1.4173913043478, 0.67173913043478, 0.27272727272727
64318, 1.4173913043478, 0.67173913043478, 0.22727272727273
64319, 1.4173913043478, 0.67173913043478, 0.18181818181818
64320, 1.4173913043478, 0.67173913043478, 0.13636363636364
64321, 1.4173913043478, 0.67173913043478, 0.090909090909091
64322, 1.4173913043478, 0.67173913043478, 0.045454545454545
64323, 1.4608695652174, 0.67173913043478, 0.45454545454545
64324, 1.4608695652174, 0.67173913043478, 0.40909090909091
64325, 1.4608695652174, 0.67173913043478, 0.36363636363636
64326, 1.4608695652174, 0.67173913043478, 0.31818181818182
64327, 1.4608695652174, 0.67173913043478, 0.27272727272727
64328, 1.4608695652174, 0.67173913043478, 0.22727272727273
64329, 1.4608695652174, 0.67173913043478, 0.18181818181818
64330, 1.4608695652174, 0.67173913043478, 0.13636363636364
64331, 1.4608695652174, 0.67173913043478, 0.090909090909091
64332, 1.4608695652174, 0.67173913043478, 0.045454545454545
64333, 1.504347826087, 0.67173913043478, 0.45454545454545
64334, 1.504347826087, 0.67173913043478, 0.40909090909091
64335, 1.504347826087, 0.67173913043478, 0.36363636363636
64336, 1.504347826087, 0.67173913043478, 0.31818181818182
64337, 1.504347826087, 0.67173913043478, 0.27272727272727
64338, 1.504347826087, 0.67173913043478, 0.22727272727273
64339, 1.504347826087, 0.67173913043478, 0.18181818181818
64340, 1.504347826087, 0.67173913043478, 0.13636363636364
64341, 1.504347826087, 0.67173913043478, 0.090909090909091
64342, 1.504347826087, 0.67173913043478, 0.045454545454545
64343, 1.5478260869565, 0.67173913043478, 0.45454545454545
64344, 1.5478260869565, 0.67173913043478, 0.40909090909091
64345, 1.5478260869565, 0.67173913043478, 0.36363636363636
64346, 1.5478260869565, 0.67173913043478, 0.31818181818182
64347, 1.5478260869565, 0.67173913043478, 0.27272727272727
64348, 1.5478260869565, 0.67173913043478, 0.22727272727273
64349, 1.5478260869565, 0.67173913043478, 0.18181818181818
64350, 1.5478260869565, 0.67173913043478, 0.13636363636364
64351, 1.5478260869565, 0.67173913043478, 0.090909090909091
64352, 1.5478260869565, 0.67173913043478, 0.045454545454545
64353, 1.5913043478261, 0.67173913043478, 0.45454545454545
64354, 1.5913043478261, 0.67173913043478, 0.40909090909091
64355, 1.5913043478261, 0.67173913043478, 0.36363636363636
64356, 1.5913043478261, 0.67173913043478, 0.31818181818182
64357, 1.5913043478261, 0.67173913043478, 0.27272727272727
64358, 1.5913043478261, 0.67173913043478, 0.22727272727273
64359, 1.5913043478261, 0.67173913043478, 0.18181818181818
64360, 1.5913043478261, 0.67173913043478, 0.13636363636364
64361, 1.5913043478261, 0.67173913043478, 0.090909090909091
64362, 1.5913043478261, 0.67173913043478, 0.045454545454545
64363, 1.6347826086957, 0.67173913043478, 0.45454545454545
64364, 1.6347826086957, 0.67173913043478, 0.40909090909091
64365, 1.6347826086957, 0.67173913043478, 0.36363636363636
64366, 1.6347826086957, 0.67173913043478, 0.31818181818182
64367, 1.6347826086957, 0.67173913043478, 0.27272727272727
64368, 1.6347826086957, 0.67173913043478, 0.22727272727273
64369, 1.6347826086957, 0.67173913043478, 0.18181818181818
64370, 1.6347826086957, 0.67173913043478, 0.13636363636364
64371, 1.6347826086957, 0.67173913043478, 0.090909090909091
64372, 1.6347826086957, 0.67173913043478, 0.045454545454545
64373, 1.6782608695652, 0.67173913043478, 0.45454545454545
64374, 1.6782608695652, 0.67173913043478, 0.40909090909091
64375, 1.6782608695652, 0.67173913043478, 0.36363636363636
64376, 1.6782608695652, 0.67173913043478, 0.31818181818182
64377, 1.6782608695652, 0.67173913043478, 0.27272727272727
64378, 1.6782608695652, 0.67173913043478, 0.22727272727273
64379, 1.6782608695652, 0.67173913043478, 0.18181818181818
64380, 1.6782608695652, 0.67173913043478, 0.13636363636364
64381, 1.6782608695652, 0.67173913043478, 0.090909090909091
64382, 1.6782608695652, 0.67173913043478, 0.045454545454545
64383, 1.7217391304348, 0.67173913043478, 0.45454545454545
64384, 1.7217391304348, 0.67173913043478, 0.40909090909091
64385, 1.7217391304348, 0.67173913043478, 0.36363636363636
64386, 1.7217391304348, 0.67173913043478, 0.31818181818182
64387, 1.7217391304348, 0.67173913043478, 0.27272727272727
64388, 1.7217391304348, 0.67173913043478, 0.22727272727273
64389, 1.7217391304348, 0.67173913043478, 0.18181818181818
64390, 1.7217391304348, 0.67173913043478, 0.13636363636364
64391, 1.7217391304348, 0.67173913043478, 0.090909090909091
64392, 1.7217391304348, 0.67173913043478, 0.045454545454545
64393, 1.7652173913043, 0.67173913043478, 0.45454545454545
64394, 1.7652173913043, 0.67173913043478, 0.40909090909091
64395, 1.7652173913043, 0.67173913043478, 0.36363636363636
64396, 1.7652173913043, 0.67173913043478, 0.31818181818182
64397, 1.7652173913043, 0.67173913043478, 0.27272727272727
64398, 1.7652173913043, 0.67173913043478, 0.22727272727273
64399, 1.7652173913043, 0.67173913043478, 0.18181818181818
64400, 1.7652173913043, 0.67173913043478, 0.13636363636364
64401, 1.7652173913043, 0.67173913043478, 0.090909090909091
64402, 1.7652173913043, 0.67173913043478, 0.045454545454545
64403, 1.8086956521739, 0.67173913043478, 0.45454545454545
64404, 1.8086956521739, 0.67173913043478, 0.40909090909091
64405, 1.8086956521739, 0.67173913043478, 0.36363636363636
64406, 1.8086956521739, 0.67173913043478, 0.31818181818182
64407, 1.8086956521739, 0.67173913043478, 0.27272727272727
64408, 1.8086956521739, 0.67173913043478, 0.22727272727273
64409, 1.8086956521739, 0.67173913043478, 0.18181818181818
64410, 1.8086956521739, 0.67173913043478, 0.13636363636364
64411, 1.8086956521739, 0.67173913043478, 0.090909090909091
64412, 1.8086956521739, 0.67173913043478, 0.045454545454545
64413, 1.8521739130435, 0.67173913043478, 0.45454545454545
64414, 1.8521739130435, 0.67173913043478, 0.40909090909091
64415, 1.8521739130435, 0.67173913043478, 0.36363636363636
64416, 1.8521739130435, 0.67173913043478, 0.31818181818182
64417, 1.8521739130435, 0.67173913043478, 0.27272727272727
64418, 1.8521739130435, 0.67173913043478, 0.22727272727273
64419, 1.8521739130435, 0.67173913043478, 0.18181818181818
64420, 1.8521739130435, 0.67173913043478, 0.13636363636364
64421, 1.8521739130435, 0.67173913043478, 0.090909090909091
64422, 1.8521739130435, 0.67173913043478, 0.045454545454545
64423, 1.895652173913, 0.67173913043478, 0.45454545454545
64424, 1.895652173913, 0.67173913043478, 0.40909090909091
64425, 1.895652173913, 0.67173913043478, 0.36363636363636
64426, 1.895652173913, 0.67173913043478, 0.31818181818182
64427, 1.895652173913, 0.67173913043478, 0.27272727272727
64428, 1.895652173913, 0.67173913043478, 0.22727272727273
64429, 1.895652173913, 0.67173913043478, 0.18181818181818
64430, 1.895652173913, 0.67173913043478, 0.13636363636364
64431, 1.895652173913, 0.67173913043478, 0.090909090909091
64432, 1.895652173913, 0.67173913043478, 0.045454545454545
64433, 1.9391304347826, 0.67173913043478, 0.45454545454545
64434, 1.9391304347826, 0.67173913043478, 0.40909090909091
64435, 1.9391304347826, 0.67173913043478, 0.36363636363636
64436, 1.9391304347826, 0.67173913043478, 0.31818181818182
64437, 1.9391304347826, 0.67173913043478, 0.27272727272727
64438, 1.9391304347826, 0.67173913043478, 0.22727272727273
64439, 1.9391304347826, 0.67173913043478, 0.18181818181818
64440, 1.9391304347826, 0.67173913043478, 0.13636363636364
64441, 1.9391304347826, 0.67173913043478, 0.090909090909091
64442, 1.9391304347826, 0.67173913043478, 0.045454545454545
64443, 1.9826086956522, 0.67173913043478, 0.45454545454545
64444, 1.9826086956522, 0.67173913043478, 0.40909090909091
64445, 1.9826086956522, 0.67173913043478, 0.36363636363636
64446, 1.9826086956522, 0.67173913043478, 0.31818181818182
64447, 1.9826086956522, 0.67173913043478, 0.27272727272727
64448, 1.9826086956522, 0.67173913043478, 0.22727272727273
64449, 1.9826086956522, 0.67173913043478, 0.18181818181818
64450, 1.9826086956522, 0.67173913043478, 0.13636363636364
64451, 1.9826086956522, 0.67173913043478, 0.090909090909091
64452, 1.9826086956522, 0.67173913043478, 0.045454545454545
64453, 2.0260869565217, 0.67173913043478, 0.45454545454545
64454, 2.0260869565217, 0.67173913043478, 0.40909090909091
64455, 2.0260869565217, 0.67173913043478, 0.36363636363636
64456, 2.0260869565217, 0.67173913043478, 0.31818181818182
64457, 2.0260869565217, 0.67173913043478, 0.27272727272727
64458, 2.0260869565217, 0.67173913043478, 0.22727272727273
64459, 2.0260869565217, 0.67173913043478, 0.18181818181818
64460, 2.0260869565217, 0.67173913043478, 0.13636363636364
64461, 2.0260869565217, 0.67173913043478, 0.090909090909091
64462, 2.0260869565217, 0.67173913043478, 0.045454545454545
64463, 2.0695652173913, 0.67173913043478, 0.45454545454545
64464, 2.0695652173913, 0.67173913043478, 0.40909090909091
64465, 2.0695652173913, 0.67173913043478, 0.36363636363636
64466, 2.0695652173913, 0.67173913043478, 0.31818181818182
64467, 2.0695652173913, 0.67173913043478, 0.27272727272727
64468, 2.0695652173913, 0.67173913043478, 0.22727272727273
64469, 2.0695652173913, 0.67173913043478, 0.18181818181818
64470, 2.0695652173913, 0.67173913043478, 0.13636363636364
64471, 2.0695652173913, 0.67173913043478, 0.090909090909091
64472, 2.0695652173913, 0.67173913043478, 0.045454545454545
64473, 2.1130434782609, 0.67173913043478, 0.45454545454545
64474, 2.1130434782609, 0.67173913043478, 0.40909090909091
64475, 2.1130434782609, 0.67173913043478, 0.36363636363636
64476, 2.1130434782609, 0.67173913043478, 0.31818181818182
64477, 2.1130434782609, 0.67173913043478, 0.27272727272727
64478, 2.1130434782609, 0.67173913043478, 0.22727272727273
64479, 2.1130434782609, 0.67173913043478, 0.18181818181818
64480, 2.1130434782609, 0.67173913043478, 0.13636363636364
64481, 2.1130434782609, 0.67173913043478, 0.090909090909091
64482, 2.1130434782609, 0.67173913043478, 0.045454545454545
64483, 2.1565217391304, 0.67173913043478, 0.45454545454545
64484, 2.1565217391304, 0.67173913043478, 0.40909090909091
64485, 2.1565217391304, 0.67173913043478, 0.36363636363636
64486, 2.1565217391304, 0.67173913043478, 0.31818181818182
64487, 2.1565217391304, 0.67173913043478, 0.27272727272727
64488, 2.1565217391304, 0.67173913043478, 0.22727272727273
64489, 2.1565217391304, 0.67173913043478, 0.18181818181818
64490, 2.1565217391304, 0.67173913043478, 0.13636363636364
64491, 2.1565217391304, 0.67173913043478, 0.090909090909091
64492, 2.1565217391304, 0.67173913043478, 0.045454545454545
64493, 1.2434782608696, 0.6195652173913, 0.45454545454545
64494, 1.2434782608696, 0.6195652173913, 0.40909090909091
64495, 1.2434782608696, 0.61956521739131, 0.36363636363636
64496, 1.2434782608696, 0.61956521739131, 0.31818181818182
64497, 1.2434782608696, 0.61956521739131, 0.27272727272727
64498, 1.2434782608696, 0.61956521739131, 0.22727272727273
64499, 1.2434782608696, 0.61956521739131, 0.18181818181818
64500, 1.2434782608696, 0.61956521739131, 0.13636363636364
64501, 1.2434782608696, 0.61956521739131, 0.090909090909091
64502, 1.2434782608696, 0.61956521739131, 0.045454545454545
64503, 1.2869565217391, 0.6195652173913, 0.45454545454545
64504, 1.2869565217391, 0.6195652173913, 0.40909090909091
64505, 1.2869565217391, 0.61956521739131, 0.36363636363636
64506, 1.2869565217391, 0.61956521739131, 0.31818181818182
64507, 1.2869565217391, 0.61956521739131, 0.27272727272727
64508, 1.2869565217391, 0.61956521739131, 0.22727272727273
64509, 1.2869565217391, 0.61956521739131, 0.18181818181818
64510, 1.2869565217391, 0.61956521739131, 0.13636363636364
64511, 1.2869565217391, 0.61956521739131, 0.090909090909091
64512, 1.2869565217391, 0.61956521739131, 0.045454545454545
64513, 1.3304347826087, 0.61956521739131, 0.45454545454545
64514, 1.3304347826087, 0.61956521739131, 0.40909090909091
64515, 1.3304347826087, 0.61956521739131, 0.36363636363636
64516, 1.3304347826087, 0.61956521739131, 0.31818181818182
64517, 1.3304347826087, 0.61956521739131, 0.27272727272727
64518, 1.3304347826087, 0.61956521739131, 0.22727272727273
64519, 1.3304347826087, 0.61956521739131, 0.18181818181818
64520, 1.3304347826087, 0.61956521739131, 0.13636363636364
64521, 1.3304347826087, 0.61956521739131, 0.090909090909091
64522, 1.3304347826087, 0.61956521739131, 0.045454545454545
64523, 1.3739130434783, 0.61956521739131, 0.45454545454545
64524, 1.3739130434783, 0.61956521739131, 0.40909090909091
64525, 1.3739130434783, 0.61956521739131, 0.36363636363636
64526, 1.3739130434783, 0.61956521739131, 0.31818181818182
64527, 1.3739130434783, 0.61956521739131, 0.27272727272727
64528, 1.3739130434783, 0.61956521739131, 0.22727272727273
64529, 1.3739130434783, 0.61956521739131, 0.18181818181818
64530, 1.3739130434783, 0.61956521739131, 0.13636363636364
64531, 1.3739130434783, 0.61956521739131, 0.090909090909091
64532, 1.3739130434783, 0.61956521739131, 0.045454545454545
64533, 1.4173913043478, 0.61956521739131, 0.45454545454545
64534, 1.4173913043478, 0.61956521739131, 0.40909090909091
64535, 1.4173913043478, 0.61956521739131, 0.36363636363636
64536, 1.4173913043478, 0.61956521739131, 0.31818181818182
64537, 1.4173913043478, 0.61956521739131, 0.27272727272727
64538, 1.4173913043478, 0.61956521739131, 0.22727272727273
64539, 1.4173913043478, 0.61956521739131, 0.18181818181818
64540, 1.4173913043478, 0.61956521739131, 0.13636363636364
64541, 1.4173913043478, 0.61956521739131, 0.090909090909091
64542, 1.4173913043478, 0.61956521739131, 0.045454545454545
64543, 1.4608695652174, 0.6195652173913, 0.45454545454545
64544, 1.4608695652174, 0.6195652173913, 0.40909090909091
64545, 1.4608695652174, 0.6195652173913, 0.36363636363636
64546, 1.4608695652174, 0.6195652173913, 0.31818181818182
64547, 1.4608695652174, 0.6195652173913, 0.27272727272727
64548, 1.4608695652174, 0.6195652173913, 0.22727272727273
64549, 1.4608695652174, 0.6195652173913, 0.18181818181818
64550, 1.4608695652174, 0.6195652173913, 0.13636363636364
64551, 1.4608695652174, 0.6195652173913, 0.090909090909091
64552, 1.4608695652174, 0.6195652173913, 0.045454545454545
64553, 1.504347826087, 0.6195652173913, 0.45454545454545
64554, 1.504347826087, 0.6195652173913, 0.40909090909091
64555, 1.504347826087, 0.61956521739131, 0.36363636363636
64556, 1.504347826087, 0.6195652173913, 0.31818181818182
64557, 1.504347826087, 0.6195652173913, 0.27272727272727
64558, 1.504347826087, 0.6195652173913, 0.22727272727273
64559, 1.504347826087, 0.6195652173913, 0.18181818181818
64560, 1.504347826087, 0.61956521739131, 0.13636363636364
64561, 1.504347826087, 0.6195652173913, 0.090909090909091
64562, 1.504347826087, 0.6195652173913, 0.045454545454545
64563, 1.5478260869565, 0.6195652173913, 0.45454545454545
64564, 1.5478260869565, 0.6195652173913, 0.40909090909091
64565, 1.5478260869565, 0.61956521739131, 0.36363636363636
64566, 1.5478260869565, 0.6195652173913, 0.31818181818182
64567, 1.5478260869565, 0.61956521739131, 0.27272727272727
64568, 1.5478260869565, 0.61956521739131, 0.22727272727273
64569, 1.5478260869565, 0.6195652173913, 0.18181818181818
64570, 1.5478260869565, 0.61956521739131, 0.13636363636364
64571, 1.5478260869565, 0.61956521739131, 0.090909090909091
64572, 1.5478260869565, 0.6195652173913, 0.045454545454545
64573, 1.5913043478261, 0.6195652173913, 0.45454545454545
64574, 1.5913043478261, 0.6195652173913, 0.40909090909091
64575, 1.5913043478261, 0.6195652173913, 0.36363636363636
64576, 1.5913043478261, 0.6195652173913, 0.31818181818182
64577, 1.5913043478261, 0.6195652173913, 0.27272727272727
64578, 1.5913043478261, 0.61956521739131, 0.22727272727273
64579, 1.5913043478261, 0.6195652173913, 0.18181818181818
64580, 1.5913043478261, 0.6195652173913, 0.13636363636364
64581, 1.5913043478261, 0.6195652173913, 0.090909090909091
64582, 1.5913043478261, 0.6195652173913, 0.045454545454545
64583, 1.6347826086957, 0.61956521739131, 0.45454545454545
64584, 1.6347826086957, 0.61956521739131, 0.40909090909091
64585, 1.6347826086957, 0.61956521739131, 0.36363636363636
64586, 1.6347826086957, 0.6195652173913, 0.31818181818182
64587, 1.6347826086957, 0.61956521739131, 0.27272727272727
64588, 1.6347826086957, 0.61956521739131, 0.22727272727273
64589, 1.6347826086957, 0.6195652173913, 0.18181818181818
64590, 1.6347826086957, 0.61956521739131, 0.13636363636364
64591, 1.6347826086957, 0.6195652173913, 0.090909090909091
64592, 1.6347826086957, 0.61956521739131, 0.045454545454545
64593, 1.6782608695652, 0.6195652173913, 0.45454545454545
64594, 1.6782608695652, 0.6195652173913, 0.40909090909091
64595, 1.6782608695652, 0.61956521739131, 0.36363636363636
64596, 1.6782608695652, 0.61956521739131, 0.31818181818182
64597, 1.6782608695652, 0.61956521739131, 0.27272727272727
64598, 1.6782608695652, 0.61956521739131, 0.22727272727273
64599, 1.6782608695652, 0.61956521739131, 0.18181818181818
64600, 1.6782608695652, 0.61956521739131, 0.13636363636364
64601, 1.6782608695652, 0.61956521739131, 0.090909090909091
64602, 1.6782608695652, 0.61956521739131, 0.045454545454545
64603, 1.7217391304348, 0.6195652173913, 0.45454545454545
64604, 1.7217391304348, 0.6195652173913, 0.40909090909091
64605, 1.7217391304348, 0.61956521739131, 0.36363636363636
64606, 1.7217391304348, 0.61956521739131, 0.31818181818182
64607, 1.7217391304348, 0.61956521739131, 0.27272727272727
64608, 1.7217391304348, 0.61956521739131, 0.22727272727273
64609, 1.7217391304348, 0.61956521739131, 0.18181818181818
64610, 1.7217391304348, 0.61956521739131, 0.13636363636364
64611, 1.7217391304348, 0.61956521739131, 0.090909090909091
64612, 1.7217391304348, 0.61956521739131, 0.045454545454545
64613, 1.7652173913043, 0.61956521739131, 0.45454545454545
64614, 1.7652173913043, 0.6195652173913, 0.40909090909091
64615, 1.7652173913043, 0.61956521739131, 0.36363636363636
64616, 1.7652173913043, 0.61956521739131, 0.31818181818182
64617, 1.7652173913043, 0.61956521739131, 0.27272727272727
64618, 1.7652173913043, 0.61956521739131, 0.22727272727273
64619, 1.7652173913043, 0.61956521739131, 0.18181818181818
64620, 1.7652173913043, 0.61956521739131, 0.13636363636364
64621, 1.7652173913043, 0.61956521739131, 0.090909090909091
64622, 1.7652173913043, 0.61956521739131, 0.045454545454545
64623, 1.8086956521739, 0.6195652173913, 0.45454545454545
64624, 1.8086956521739, 0.61956521739131, 0.40909090909091
64625, 1.8086956521739, 0.6195652173913, 0.36363636363636
64626, 1.8086956521739, 0.6195652173913, 0.31818181818182
64627, 1.8086956521739, 0.6195652173913, 0.27272727272727
64628, 1.8086956521739, 0.61956521739131, 0.22727272727273
64629, 1.8086956521739, 0.6195652173913, 0.18181818181818
64630, 1.8086956521739, 0.61956521739131, 0.13636363636364
64631, 1.8086956521739, 0.61956521739131, 0.090909090909091
64632, 1.8086956521739, 0.6195652173913, 0.045454545454545
64633, 1.8521739130435, 0.6195652173913, 0.45454545454545
64634, 1.8521739130435, 0.6195652173913, 0.40909090909091
64635, 1.8521739130435, 0.6195652173913, 0.36363636363636
64636, 1.8521739130435, 0.6195652173913, 0.31818181818182
64637, 1.8521739130435, 0.61956521739131, 0.27272727272727
64638, 1.8521739130435, 0.61956521739131, 0.22727272727273
64639, 1.8521739130435, 0.6195652173913, 0.18181818181818
64640, 1.8521739130435, 0.61956521739131, 0.13636363636364
64641, 1.8521739130435, 0.61956521739131, 0.090909090909091
64642, 1.8521739130435, 0.61956521739131, 0.045454545454545
64643, 1.895652173913, 0.6195652173913, 0.45454545454545
64644, 1.895652173913, 0.6195652173913, 0.40909090909091
64645, 1.895652173913, 0.61956521739131, 0.36363636363636
64646, 1.895652173913, 0.61956521739131, 0.31818181818182
64647, 1.895652173913, 0.61956521739131, 0.27272727272727
64648, 1.895652173913, 0.61956521739131, 0.22727272727273
64649, 1.895652173913, 0.61956521739131, 0.18181818181818
64650, 1.895652173913, 0.61956521739131, 0.13636363636364
64651, 1.895652173913, 0.61956521739131, 0.090909090909091
64652, 1.895652173913, 0.61956521739131, 0.045454545454545
64653, 1.9391304347826, 0.61956521739131, 0.45454545454545
64654, 1.9391304347826, 0.61956521739131, 0.40909090909091
64655, 1.9391304347826, 0.61956521739131, 0.36363636363636
64656, 1.9391304347826, 0.61956521739131, 0.31818181818182
64657, 1.9391304347826, 0.61956521739131, 0.27272727272727
64658, 1.9391304347826, 0.61956521739131, 0.22727272727273
64659, 1.9391304347826, 0.61956521739131, 0.18181818181818
64660, 1.9391304347826, 0.61956521739131, 0.13636363636364
64661, 1.9391304347826, 0.6195652173913, 0.090909090909091
64662, 1.9391304347826, 0.61956521739131, 0.045454545454545
64663, 1.9826086956522, 0.6195652173913, 0.45454545454545
64664, 1.9826086956522, 0.6195652173913, 0.40909090909091
64665, 1.9826086956522, 0.6195652173913, 0.36363636363636
64666, 1.9826086956522, 0.6195652173913, 0.31818181818182
64667, 1.9826086956522, 0.61956521739131, 0.27272727272727
64668, 1.9826086956522, 0.61956521739131, 0.22727272727273
64669, 1.9826086956522, 0.6195652173913, 0.18181818181818
64670, 1.9826086956522, 0.61956521739131, 0.13636363636364
64671, 1.9826086956522, 0.61956521739131, 0.090909090909091
64672, 1.9826086956522, 0.61956521739131, 0.045454545454545
64673, 2.0260869565217, 0.6195652173913, 0.45454545454545
64674, 2.0260869565217, 0.6195652173913, 0.40909090909091
64675, 2.0260869565217, 0.61956521739131, 0.36363636363636
64676, 2.0260869565217, 0.6195652173913, 0.31818181818182
64677, 2.0260869565217, 0.61956521739131, 0.27272727272727
64678, 2.0260869565217, 0.61956521739131, 0.22727272727273
64679, 2.0260869565217, 0.6195652173913, 0.18181818181818
64680, 2.0260869565217, 0.61956521739131, 0.13636363636364
64681, 2.0260869565217, 0.61956521739131, 0.090909090909091
64682, 2.0260869565217, 0.6195652173913, 0.045454545454545
64683, 2.0695652173913, 0.6195652173913, 0.45454545454545
64684, 2.0695652173913, 0.6195652173913, 0.40909090909091
64685, 2.0695652173913, 0.61956521739131, 0.36363636363636
64686, 2.0695652173913, 0.6195652173913, 0.31818181818182
64687, 2.0695652173913, 0.61956521739131, 0.27272727272727
64688, 2.0695652173913, 0.61956521739131, 0.22727272727273
64689, 2.0695652173913, 0.6195652173913, 0.18181818181818
64690, 2.0695652173913, 0.61956521739131, 0.13636363636364
64691, 2.0695652173913, 0.61956521739131, 0.090909090909091
64692, 2.0695652173913, 0.6195652173913, 0.045454545454545
64693, 2.1130434782609, 0.6195652173913, 0.45454545454545
64694, 2.1130434782609, 0.6195652173913, 0.40909090909091
64695, 2.1130434782609, 0.61956521739131, 0.36363636363636
64696, 2.1130434782609, 0.6195652173913, 0.31818181818182
64697, 2.1130434782609, 0.61956521739131, 0.27272727272727
64698, 2.1130434782609, 0.61956521739131, 0.22727272727273
64699, 2.1130434782609, 0.61956521739131, 0.18181818181818
64700, 2.1130434782609, 0.61956521739131, 0.13636363636364
64701, 2.1130434782609, 0.6195652173913, 0.090909090909091
64702, 2.1130434782609, 0.6195652173913, 0.045454545454545
64703, 2.1565217391304, 0.6195652173913, 0.45454545454545
64704, 2.1565217391304, 0.6195652173913, 0.40909090909091
64705, 2.1565217391304, 0.61956521739131, 0.36363636363636
64706, 2.1565217391304, 0.61956521739131, 0.31818181818182
64707, 2.1565217391304, 0.61956521739131, 0.27272727272727
64708, 2.1565217391304, 0.61956521739131, 0.22727272727273
64709, 2.1565217391304, 0.61956521739131, 0.18181818181818
64710, 2.1565217391304, 0.61956521739131, 0.13636363636364
64711, 2.1565217391304, 0.6195652173913, 0.090909090909091
64712, 2.1565217391304, 0.61956521739131, 0.045454545454545
64713, 1.2434782608696, 0.56739130434783, 0.45454545454545
64714, 1.2434782608696, 0.56739130434783, 0.40909090909091
64715, 1.2434782608696, 0.56739130434783, 0.36363636363636
64716, 1.2434782608696, 0.56739130434783, 0.31818181818182
64717, 1.2434782608696, 0.56739130434783, 0.27272727272727
64718, 1.2434782608696, 0.56739130434783, 0.22727272727273
64719, 1.2434782608696, 0.56739130434783, 0.18181818181818
64720, 1.2434782608696, 0.56739130434783, 0.13636363636364
64721, 1.2434782608696, 0.56739130434783, 0.090909090909091
64722, 1.2434782608696, 0.56739130434783, 0.045454545454545
64723, 1.2869565217391, 0.56739130434783, 0.45454545454545
64724, 1.2869565217391, 0.56739130434783, 0.40909090909091
64725, 1.2869565217391, 0.56739130434783, 0.36363636363636
64726, 1.2869565217391, 0.56739130434783, 0.31818181818182
64727, 1.2869565217391, 0.56739130434783, 0.27272727272727
64728, 1.2869565217391, 0.56739130434783, 0.22727272727273
64729, 1.2869565217391, 0.56739130434783, 0.18181818181818
64730, 1.2869565217391, 0.56739130434783, 0.13636363636364
64731, 1.2869565217391, 0.56739130434783, 0.090909090909091
64732, 1.2869565217391, 0.56739130434783, 0.045454545454545
64733, 1.3304347826087, 0.56739130434783, 0.45454545454545
64734, 1.3304347826087, 0.56739130434783, 0.40909090909091
64735, 1.3304347826087, 0.56739130434783, 0.36363636363636
64736, 1.3304347826087, 0.56739130434783, 0.31818181818182
64737, 1.3304347826087, 0.56739130434783, 0.27272727272727
64738, 1.3304347826087, 0.56739130434783, 0.22727272727273
64739, 1.3304347826087, 0.56739130434783, 0.18181818181818
64740, 1.3304347826087, 0.56739130434783, 0.13636363636364
64741, 1.3304347826087, 0.56739130434783, 0.090909090909091
64742, 1.3304347826087, 0.56739130434783, 0.045454545454545
64743, 1.3739130434783, 0.56739130434783, 0.45454545454545
64744, 1.3739130434783, 0.56739130434783, 0.40909090909091
64745, 1.3739130434783, 0.56739130434783, 0.36363636363636
64746, 1.3739130434783, 0.56739130434783, 0.31818181818182
64747, 1.3739130434783, 0.56739130434783, 0.27272727272727
64748, 1.3739130434783, 0.56739130434783, 0.22727272727273
64749, 1.3739130434783, 0.56739130434783, 0.18181818181818
64750, 1.3739130434783, 0.56739130434783, 0.13636363636364
64751, 1.3739130434783, 0.56739130434783, 0.090909090909091
64752, 1.3739130434783, 0.56739130434783, 0.045454545454545
64753, 1.4173913043478, 0.56739130434783, 0.45454545454545
64754, 1.4173913043478, 0.56739130434783, 0.40909090909091
64755, 1.4173913043478, 0.56739130434783, 0.36363636363636
64756, 1.4173913043478, 0.56739130434783, 0.31818181818182
64757, 1.4173913043478, 0.56739130434783, 0.27272727272727
64758, 1.4173913043478, 0.56739130434783, 0.22727272727273
64759, 1.4173913043478, 0.56739130434783, 0.18181818181818
64760, 1.4173913043478, 0.56739130434783, 0.13636363636364
64761, 1.4173913043478, 0.56739130434783, 0.090909090909091
64762, 1.4173913043478, 0.56739130434783, 0.045454545454545
64763, 1.4608695652174, 0.56739130434783, 0.45454545454545
64764, 1.4608695652174, 0.56739130434783, 0.40909090909091
64765, 1.4608695652174, 0.56739130434783, 0.36363636363636
64766, 1.4608695652174, 0.56739130434783, 0.31818181818182
64767, 1.4608695652174, 0.56739130434783, 0.27272727272727
64768, 1.4608695652174, 0.56739130434783, 0.22727272727273
64769, 1.4608695652174, 0.56739130434783, 0.18181818181818
64770, 1.4608695652174, 0.56739130434783, 0.13636363636364
64771, 1.4608695652174, 0.56739130434783, 0.090909090909091
64772, 1.4608695652174, 0.56739130434783, 0.045454545454545
64773, 1.504347826087, 0.56739130434783, 0.45454545454545
64774, 1.504347826087, 0.56739130434783, 0.40909090909091
64775, 1.504347826087, 0.56739130434783, 0.36363636363636
64776, 1.504347826087, 0.56739130434783, 0.31818181818182
64777, 1.504347826087, 0.56739130434783, 0.27272727272727
64778, 1.504347826087, 0.56739130434783, 0.22727272727273
64779, 1.504347826087, 0.56739130434783, 0.18181818181818
64780, 1.504347826087, 0.56739130434783, 0.13636363636364
64781, 1.504347826087, 0.56739130434783, 0.090909090909091
64782, 1.504347826087, 0.56739130434783, 0.045454545454545
64783, 1.5478260869565, 0.56739130434783, 0.45454545454545
64784, 1.5478260869565, 0.56739130434783, 0.40909090909091
64785, 1.5478260869565, 0.56739130434783, 0.36363636363636
64786, 1.5478260869565, 0.56739130434783, 0.31818181818182
64787, 1.5478260869565, 0.56739130434783, 0.27272727272727
64788, 1.5478260869565, 0.56739130434783, 0.22727272727273
64789, 1.5478260869565, 0.56739130434783, 0.18181818181818
64790, 1.5478260869565, 0.56739130434783, 0.13636363636364
64791, 1.5478260869565, 0.56739130434783, 0.090909090909091
64792, 1.5478260869565, 0.56739130434783, 0.045454545454545
64793, 1.5913043478261, 0.56739130434783, 0.45454545454545
64794, 1.5913043478261, 0.56739130434783, 0.40909090909091
64795, 1.5913043478261, 0.56739130434783, 0.36363636363636
64796, 1.5913043478261, 0.56739130434783, 0.31818181818182
64797, 1.5913043478261, 0.56739130434783, 0.27272727272727
64798, 1.5913043478261, 0.56739130434783, 0.22727272727273
64799, 1.5913043478261, 0.56739130434783, 0.18181818181818
64800, 1.5913043478261, 0.56739130434783, 0.13636363636364
64801, 1.5913043478261, 0.56739130434783, 0.090909090909091
64802, 1.5913043478261, 0.56739130434783, 0.045454545454545
64803, 1.6347826086957, 0.56739130434783, 0.45454545454545
64804, 1.6347826086957, 0.56739130434783, 0.40909090909091
64805, 1.6347826086957, 0.56739130434783, 0.36363636363636
64806, 1.6347826086957, 0.56739130434783, 0.31818181818182
64807, 1.6347826086957, 0.56739130434783, 0.27272727272727
64808, 1.6347826086957, 0.56739130434783, 0.22727272727273
64809, 1.6347826086957, 0.56739130434783, 0.18181818181818
64810, 1.6347826086957, 0.56739130434783, 0.13636363636364
64811, 1.6347826086957, 0.56739130434783, 0.090909090909091
64812, 1.6347826086957, 0.56739130434783, 0.045454545454545
64813, 1.6782608695652, 0.56739130434783, 0.45454545454545
64814, 1.6782608695652, 0.56739130434783, 0.40909090909091
64815, 1.6782608695652, 0.56739130434783, 0.36363636363636
64816, 1.6782608695652, 0.56739130434783, 0.31818181818182
64817, 1.6782608695652, 0.56739130434783, 0.27272727272727
64818, 1.6782608695652, 0.56739130434783, 0.22727272727273
64819, 1.6782608695652, 0.56739130434783, 0.18181818181818
64820, 1.6782608695652, 0.56739130434783, 0.13636363636364
64821, 1.6782608695652, 0.56739130434783, 0.090909090909091
64822, 1.6782608695652, 0.56739130434783, 0.045454545454545
64823, 1.7217391304348, 0.56739130434783, 0.45454545454545
64824, 1.7217391304348, 0.56739130434783, 0.40909090909091
64825, 1.7217391304348, 0.56739130434783, 0.36363636363636
64826, 1.7217391304348, 0.56739130434783, 0.31818181818182
64827, 1.7217391304348, 0.56739130434783, 0.27272727272727
64828, 1.7217391304348, 0.56739130434783, 0.22727272727273
64829, 1.7217391304348, 0.56739130434783, 0.18181818181818
64830, 1.7217391304348, 0.56739130434783, 0.13636363636364
64831, 1.7217391304348, 0.56739130434783, 0.090909090909091
64832, 1.7217391304348, 0.56739130434783, 0.045454545454545
64833, 1.7652173913043, 0.56739130434783, 0.45454545454545
64834, 1.7652173913043, 0.56739130434783, 0.40909090909091
64835, 1.7652173913043, 0.56739130434783, 0.36363636363636
64836, 1.7652173913043, 0.56739130434783, 0.31818181818182
64837, 1.7652173913043, 0.56739130434783, 0.27272727272727
64838, 1.7652173913043, 0.56739130434783, 0.22727272727273
64839, 1.7652173913043, 0.56739130434783, 0.18181818181818
64840, 1.7652173913043, 0.56739130434783, 0.13636363636364
64841, 1.7652173913043, 0.56739130434783, 0.090909090909091
64842, 1.7652173913043, 0.56739130434783, 0.045454545454545
64843, 1.8086956521739, 0.56739130434783, 0.45454545454545
64844, 1.8086956521739, 0.56739130434783, 0.40909090909091
64845, 1.8086956521739, 0.56739130434783, 0.36363636363636
64846, 1.8086956521739, 0.56739130434783, 0.31818181818182
64847, 1.8086956521739, 0.56739130434783, 0.27272727272727
64848, 1.8086956521739, 0.56739130434783, 0.22727272727273
64849, 1.8086956521739, 0.56739130434783, 0.18181818181818
64850, 1.8086956521739, 0.56739130434783, 0.13636363636364
64851, 1.8086956521739, 0.56739130434783, 0.090909090909091
64852, 1.8086956521739, 0.56739130434783, 0.045454545454545
64853, 1.8521739130435, 0.56739130434783, 0.45454545454545
64854, 1.8521739130435, 0.56739130434783, 0.40909090909091
64855, 1.8521739130435, 0.56739130434783, 0.36363636363636
64856, 1.8521739130435, 0.56739130434783, 0.31818181818182
64857, 1.8521739130435, 0.56739130434783, 0.27272727272727
64858, 1.8521739130435, 0.56739130434783, 0.22727272727273
64859, 1.8521739130435, 0.56739130434783, 0.18181818181818
64860, 1.8521739130435, 0.56739130434783, 0.13636363636364
64861, 1.8521739130435, 0.56739130434783, 0.090909090909091
64862, 1.8521739130435, 0.56739130434783, 0.045454545454545
64863, 1.895652173913, 0.56739130434783, 0.45454545454545
64864, 1.895652173913, 0.56739130434783, 0.40909090909091
64865, 1.895652173913, 0.56739130434783, 0.36363636363636
64866, 1.895652173913, 0.56739130434783, 0.31818181818182
64867, 1.895652173913, 0.56739130434783, 0.27272727272727
64868, 1.895652173913, 0.56739130434783, 0.22727272727273
64869, 1.895652173913, 0.56739130434783, 0.18181818181818
64870, 1.895652173913, 0.56739130434783, 0.13636363636364
64871, 1.895652173913, 0.56739130434783, 0.090909090909091
64872, 1.895652173913, 0.56739130434783, 0.045454545454545
64873, 1.9391304347826, 0.56739130434783, 0.45454545454545
64874, 1.9391304347826, 0.56739130434783, 0.40909090909091
64875, 1.9391304347826, 0.56739130434783, 0.36363636363636
64876, 1.9391304347826, 0.56739130434783, 0.31818181818182
64877, 1.9391304347826, 0.56739130434783, 0.27272727272727
64878, 1.9391304347826, 0.56739130434783, 0.22727272727273
64879, 1.9391304347826, 0.56739130434783, 0.18181818181818
64880, 1.9391304347826, 0.56739130434783, 0.13636363636364
64881, 1.9391304347826, 0.56739130434783, 0.090909090909091
64882, 1.9391304347826, 0.56739130434783, 0.045454545454545
64883, 1.9826086956522, 0.56739130434783, 0.45454545454545
64884, 1.9826086956522, 0.56739130434783, 0.40909090909091
64885, 1.9826086956522, 0.56739130434783, 0.36363636363636
64886, 1.9826086956522, 0.56739130434783, 0.31818181818182
64887, 1.9826086956522, 0.56739130434783, 0.27272727272727
64888, 1.9826086956522, 0.56739130434783, 0.22727272727273
64889, 1.9826086956522, 0.56739130434783, 0.18181818181818
64890, 1.9826086956522, 0.56739130434783, 0.13636363636364
64891, 1.9826086956522, 0.56739130434783, 0.090909090909091
64892, 1.9826086956522, 0.56739130434783, 0.045454545454545
64893, 2.0260869565217, 0.56739130434783, 0.45454545454545
64894, 2.0260869565217, 0.56739130434783, 0.40909090909091
64895, 2.0260869565217, 0.56739130434783, 0.36363636363636
64896, 2.0260869565217, 0.56739130434783, 0.31818181818182
64897, 2.0260869565217, 0.56739130434783, 0.27272727272727
64898, 2.0260869565217, 0.56739130434783, 0.22727272727273
64899, 2.0260869565217, 0.56739130434783, 0.18181818181818
64900, 2.0260869565217, 0.56739130434783, 0.13636363636364
64901, 2.0260869565217, 0.56739130434783, 0.090909090909091
64902, 2.0260869565217, 0.56739130434783, 0.045454545454545
64903, 2.0695652173913, 0.56739130434783, 0.45454545454545
64904, 2.0695652173913, 0.56739130434783, 0.40909090909091
64905, 2.0695652173913, 0.56739130434783, 0.36363636363636
64906, 2.0695652173913, 0.56739130434783, 0.31818181818182
64907, 2.0695652173913, 0.56739130434783, 0.27272727272727
64908, 2.0695652173913, 0.56739130434783, 0.22727272727273
64909, 2.0695652173913, 0.56739130434783, 0.18181818181818
64910, 2.0695652173913, 0.56739130434783, 0.13636363636364
64911, 2.0695652173913, 0.56739130434783, 0.090909090909091
64912, 2.0695652173913, 0.56739130434783, 0.045454545454545
64913, 2.1130434782609, 0.56739130434783, 0.45454545454545
64914, 2.1130434782609, 0.56739130434783, 0.40909090909091
64915, 2.1130434782609, 0.56739130434783, 0.36363636363636
64916, 2.1130434782609, 0.56739130434783, 0.31818181818182
64917, 2.1130434782609, 0.56739130434783, 0.27272727272727
64918, 2.1130434782609, 0.56739130434783, 0.22727272727273
64919, 2.1130434782609, 0.56739130434783, 0.18181818181818
64920, 2.1130434782609, 0.56739130434783, 0.13636363636364
64921, 2.1130434782609, 0.56739130434783, 0.090909090909091
64922, 2.1130434782609, 0.56739130434783, 0.045454545454545
64923, 2.1565217391304, 0.56739130434783, 0.45454545454545
64924, 2.1565217391304, 0.56739130434783, 0.40909090909091
64925, 2.1565217391304, 0.56739130434783, 0.36363636363636
64926, 2.1565217391304, 0.56739130434783, 0.31818181818182
64927, 2.1565217391304, 0.56739130434783, 0.27272727272727
64928, 2.1565217391304, 0.56739130434783, 0.22727272727273
64929, 2.1565217391304, 0.56739130434783, 0.18181818181818
64930, 2.1565217391304, 0.56739130434783, 0.13636363636364
64931, 2.1565217391304, 0.56739130434783, 0.090909090909091
64932, 2.1565217391304, 0.56739130434783, 0.045454545454545
64933, 1.2434782608696, 0.51521739130435, 0.45454545454545
64934, 1.2434782608696, 0.51521739130435, 0.40909090909091
64935, 1.2434782608696, 0.51521739130435, 0.36363636363636
64936, 1.2434782608696, 0.51521739130435, 0.31818181818182
64937, 1.2434782608696, 0.51521739130435, 0.27272727272727
64938, 1.2434782608696, 0.51521739130435, 0.22727272727273
64939, 1.2434782608696, 0.51521739130435, 0.18181818181818
64940, 1.2434782608696, 0.51521739130435, 0.13636363636364
64941, 1.2434782608696, 0.51521739130435, 0.090909090909091
64942, 1.2434782608696, 0.51521739130435, 0.045454545454545
64943, 1.2869565217391, 0.51521739130435, 0.45454545454545
64944, 1.2869565217391, 0.51521739130435, 0.40909090909091
64945, 1.2869565217391, 0.51521739130435, 0.36363636363636
64946, 1.2869565217391, 0.51521739130435, 0.31818181818182
64947, 1.2869565217391, 0.51521739130435, 0.27272727272727
64948, 1.2869565217391, 0.51521739130435, 0.22727272727273
64949, 1.2869565217391, 0.51521739130435, 0.18181818181818
64950, 1.2869565217391, 0.51521739130435, 0.13636363636364
64951, 1.2869565217391, 0.51521739130435, 0.090909090909091
64952, 1.2869565217391, 0.51521739130435, 0.045454545454545
64953, 1.3304347826087, 0.51521739130435, 0.45454545454545
64954, 1.3304347826087, 0.51521739130435, 0.40909090909091
64955, 1.3304347826087, 0.51521739130435, 0.36363636363636
64956, 1.3304347826087, 0.51521739130435, 0.31818181818182
64957, 1.3304347826087, 0.51521739130435, 0.27272727272727
64958, 1.3304347826087, 0.51521739130435, 0.22727272727273
64959, 1.3304347826087, 0.51521739130435, 0.18181818181818
64960, 1.3304347826087, 0.51521739130435, 0.13636363636364
64961, 1.3304347826087, 0.51521739130435, 0.090909090909091
64962, 1.3304347826087, 0.51521739130435, 0.045454545454545
64963, 1.3739130434783, 0.51521739130435, 0.45454545454545
64964, 1.3739130434783, 0.51521739130435, 0.40909090909091
64965, 1.3739130434783, 0.51521739130435, 0.36363636363636
64966, 1.3739130434783, 0.51521739130435, 0.31818181818182
64967, 1.3739130434783, 0.51521739130435, 0.27272727272727
64968, 1.3739130434783, 0.51521739130435, 0.22727272727273
64969, 1.3739130434783, 0.51521739130435, 0.18181818181818
64970, 1.3739130434783, 0.51521739130435, 0.13636363636364
64971, 1.3739130434783, 0.51521739130435, 0.090909090909091
64972, 1.3739130434783, 0.51521739130435, 0.045454545454545
64973, 1.4173913043478, 0.51521739130435, 0.45454545454545
64974, 1.4173913043478, 0.51521739130435, 0.40909090909091
64975, 1.4173913043478, 0.51521739130435, 0.36363636363636
64976, 1.4173913043478, 0.51521739130435, 0.31818181818182
64977, 1.4173913043478, 0.51521739130435, 0.27272727272727
64978, 1.4173913043478, 0.51521739130435, 0.22727272727273
64979, 1.4173913043478, 0.51521739130435, 0.18181818181818
64980, 1.4173913043478, 0.51521739130435, 0.13636363636364
64981, 1.4173913043478, 0.51521739130435, 0.090909090909091
64982, 1.4173913043478, 0.51521739130435, 0.045454545454545
64983, 1.4608695652174, 0.51521739130435, 0.45454545454545
64984, 1.4608695652174, 0.51521739130435, 0.40909090909091
64985, 1.4608695652174, 0.51521739130435, 0.36363636363636
64986, 1.4608695652174, 0.51521739130435, 0.31818181818182
64987, 1.4608695652174, 0.51521739130435, 0.27272727272727
64988, 1.4608695652174, 0.51521739130435, 0.22727272727273
64989, 1.4608695652174, 0.51521739130435, 0.18181818181818
64990, 1.4608695652174, 0.51521739130435, 0.13636363636364
64991, 1.4608695652174, 0.51521739130435, 0.090909090909091
64992, 1.4608695652174, 0.51521739130435, 0.045454545454545
64993, 1.504347826087, 0.51521739130435, 0.45454545454545
64994, 1.504347826087, 0.51521739130435, 0.40909090909091
64995, 1.504347826087, 0.51521739130435, 0.36363636363636
64996, 1.504347826087, 0.51521739130435, 0.31818181818182
64997, 1.504347826087, 0.51521739130435, 0.27272727272727
64998, 1.504347826087, 0.51521739130435, 0.22727272727273
64999, 1.504347826087, 0.51521739130435, 0.18181818181818
65000, 1.504347826087, 0.51521739130435, 0.13636363636364
65001, 1.504347826087, 0.51521739130435, 0.090909090909091
65002, 1.504347826087, 0.51521739130435, 0.045454545454545
65003, 1.5478260869565, 0.51521739130435, 0.45454545454545
65004, 1.5478260869565, 0.51521739130435, 0.40909090909091
65005, 1.5478260869565, 0.51521739130435, 0.36363636363636
65006, 1.5478260869565, 0.51521739130435, 0.31818181818182
65007, 1.5478260869565, 0.51521739130435, 0.27272727272727
65008, 1.5478260869565, 0.51521739130435, 0.22727272727273
65009, 1.5478260869565, 0.51521739130435, 0.18181818181818
65010, 1.5478260869565, 0.51521739130435, 0.13636363636364
65011, 1.5478260869565, 0.51521739130435, 0.090909090909091
65012, 1.5478260869565, 0.51521739130435, 0.045454545454545
65013, 1.5913043478261, 0.51521739130435, 0.45454545454545
65014, 1.5913043478261, 0.51521739130435, 0.40909090909091
65015, 1.5913043478261, 0.51521739130435, 0.36363636363636
65016, 1.5913043478261, 0.51521739130435, 0.31818181818182
65017, 1.5913043478261, 0.51521739130435, 0.27272727272727
65018, 1.5913043478261, 0.51521739130435, 0.22727272727273
65019, 1.5913043478261, 0.51521739130435, 0.18181818181818
65020, 1.5913043478261, 0.51521739130435, 0.13636363636364
65021, 1.5913043478261, 0.51521739130435, 0.090909090909091
65022, 1.5913043478261, 0.51521739130435, 0.045454545454545
65023, 1.6347826086957, 0.51521739130435, 0.45454545454545
65024, 1.6347826086957, 0.51521739130435, 0.40909090909091
65025, 1.6347826086957, 0.51521739130435, 0.36363636363636
65026, 1.6347826086957, 0.51521739130435, 0.31818181818182
65027, 1.6347826086957, 0.51521739130435, 0.27272727272727
65028, 1.6347826086957, 0.51521739130435, 0.22727272727273
65029, 1.6347826086957, 0.51521739130435, 0.18181818181818
65030, 1.6347826086957, 0.51521739130435, 0.13636363636364
65031, 1.6347826086957, 0.51521739130435, 0.090909090909091
65032, 1.6347826086957, 0.51521739130435, 0.045454545454545
65033, 1.6782608695652, 0.51521739130435, 0.45454545454545
65034, 1.6782608695652, 0.51521739130435, 0.40909090909091
65035, 1.6782608695652, 0.51521739130435, 0.36363636363636
65036, 1.6782608695652, 0.51521739130435, 0.31818181818182
65037, 1.6782608695652, 0.51521739130435, 0.27272727272727
65038, 1.6782608695652, 0.51521739130435, 0.22727272727273
65039, 1.6782608695652, 0.51521739130435, 0.18181818181818
65040, 1.6782608695652, 0.51521739130435, 0.13636363636364
65041, 1.6782608695652, 0.51521739130435, 0.090909090909091
65042, 1.6782608695652, 0.51521739130435, 0.045454545454545
65043, 1.7217391304348, 0.51521739130435, 0.45454545454545
65044, 1.7217391304348, 0.51521739130435, 0.40909090909091
65045, 1.7217391304348, 0.51521739130435, 0.36363636363636
65046, 1.7217391304348, 0.51521739130435, 0.31818181818182
65047, 1.7217391304348, 0.51521739130435, 0.27272727272727
65048, 1.7217391304348, 0.51521739130435, 0.22727272727273
65049, 1.7217391304348, 0.51521739130435, 0.18181818181818
65050, 1.7217391304348, 0.51521739130435, 0.13636363636364
65051, 1.7217391304348, 0.51521739130435, 0.090909090909091
65052, 1.7217391304348, 0.51521739130435, 0.045454545454545
65053, 1.7652173913043, 0.51521739130435, 0.45454545454545
65054, 1.7652173913043, 0.51521739130435, 0.40909090909091
65055, 1.7652173913043, 0.51521739130435, 0.36363636363636
65056, 1.7652173913043, 0.51521739130435, 0.31818181818182
65057, 1.7652173913043, 0.51521739130435, 0.27272727272727
65058, 1.7652173913043, 0.51521739130435, 0.22727272727273
65059, 1.7652173913043, 0.51521739130435, 0.18181818181818
65060, 1.7652173913043, 0.51521739130435, 0.13636363636364
65061, 1.7652173913043, 0.51521739130435, 0.090909090909091
65062, 1.7652173913043, 0.51521739130435, 0.045454545454545
65063, 1.8086956521739, 0.51521739130435, 0.45454545454545
65064, 1.8086956521739, 0.51521739130435, 0.40909090909091
65065, 1.8086956521739, 0.51521739130435, 0.36363636363636
65066, 1.8086956521739, 0.51521739130435, 0.31818181818182
65067, 1.8086956521739, 0.51521739130435, 0.27272727272727
65068, 1.8086956521739, 0.51521739130435, 0.22727272727273
65069, 1.8086956521739, 0.51521739130435, 0.18181818181818
65070, 1.8086956521739, 0.51521739130435, 0.13636363636364
65071, 1.8086956521739, 0.51521739130435, 0.090909090909091
65072, 1.8086956521739, 0.51521739130435, 0.045454545454545
65073, 1.8521739130435, 0.51521739130435, 0.45454545454545
65074, 1.8521739130435, 0.51521739130435, 0.40909090909091
65075, 1.8521739130435, 0.51521739130435, 0.36363636363636
65076, 1.8521739130435, 0.51521739130435, 0.31818181818182
65077, 1.8521739130435, 0.51521739130435, 0.27272727272727
65078, 1.8521739130435, 0.51521739130435, 0.22727272727273
65079, 1.8521739130435, 0.51521739130435, 0.18181818181818
65080, 1.8521739130435, 0.51521739130435, 0.13636363636364
65081, 1.8521739130435, 0.51521739130435, 0.090909090909091
65082, 1.8521739130435, 0.51521739130435, 0.045454545454545
65083, 1.895652173913, 0.51521739130435, 0.45454545454545
65084, 1.895652173913, 0.51521739130435, 0.40909090909091
65085, 1.895652173913, 0.51521739130435, 0.36363636363636
65086, 1.895652173913, 0.51521739130435, 0.31818181818182
65087, 1.895652173913, 0.51521739130435, 0.27272727272727
65088, 1.895652173913, 0.51521739130435, 0.22727272727273
65089, 1.895652173913, 0.51521739130435, 0.18181818181818
65090, 1.895652173913, 0.51521739130435, 0.13636363636364
65091, 1.895652173913, 0.51521739130435, 0.090909090909091
65092, 1.895652173913, 0.51521739130435, 0.045454545454545
65093, 1.9391304347826, 0.51521739130435, 0.45454545454545
65094, 1.9391304347826, 0.51521739130435, 0.40909090909091
65095, 1.9391304347826, 0.51521739130435, 0.36363636363636
65096, 1.9391304347826, 0.51521739130435, 0.31818181818182
65097, 1.9391304347826, 0.51521739130435, 0.27272727272727
65098, 1.9391304347826, 0.51521739130435, 0.22727272727273
65099, 1.9391304347826, 0.51521739130435, 0.18181818181818
65100, 1.9391304347826, 0.51521739130435, 0.13636363636364
65101, 1.9391304347826, 0.51521739130435, 0.090909090909091
65102, 1.9391304347826, 0.51521739130435, 0.045454545454545
65103, 1.9826086956522, 0.51521739130435, 0.45454545454545
65104, 1.9826086956522, 0.51521739130435, 0.40909090909091
65105, 1.9826086956522, 0.51521739130435, 0.36363636363636
65106, 1.9826086956522, 0.51521739130435, 0.31818181818182
65107, 1.9826086956522, 0.51521739130435, 0.27272727272727
65108, 1.9826086956522, 0.51521739130435, 0.22727272727273
65109, 1.9826086956522, 0.51521739130435, 0.18181818181818
65110, 1.9826086956522, 0.51521739130435, 0.13636363636364
65111, 1.9826086956522, 0.51521739130435, 0.090909090909091
65112, 1.9826086956522, 0.51521739130435, 0.045454545454545
65113, 2.0260869565217, 0.51521739130435, 0.45454545454545
65114, 2.0260869565217, 0.51521739130435, 0.40909090909091
65115, 2.0260869565217, 0.51521739130435, 0.36363636363636
65116, 2.0260869565217, 0.51521739130435, 0.31818181818182
65117, 2.0260869565217, 0.51521739130435, 0.27272727272727
65118, 2.0260869565217, 0.51521739130435, 0.22727272727273
65119, 2.0260869565217, 0.51521739130435, 0.18181818181818
65120, 2.0260869565217, 0.51521739130435, 0.13636363636364
65121, 2.0260869565217, 0.51521739130435, 0.090909090909091
65122, 2.0260869565217, 0.51521739130435, 0.045454545454545
65123, 2.0695652173913, 0.51521739130435, 0.45454545454545
65124, 2.0695652173913, 0.51521739130435, 0.40909090909091
65125, 2.0695652173913, 0.51521739130435, 0.36363636363636
65126, 2.0695652173913, 0.51521739130435, 0.31818181818182
65127, 2.0695652173913, 0.51521739130435, 0.27272727272727
65128, 2.0695652173913, 0.51521739130435, 0.22727272727273
65129, 2.0695652173913, 0.51521739130435, 0.18181818181818
65130, 2.0695652173913, 0.51521739130435, 0.13636363636364
65131, 2.0695652173913, 0.51521739130435, 0.090909090909091
65132, 2.0695652173913, 0.51521739130435, 0.045454545454545
65133, 2.1130434782609, 0.51521739130435, 0.45454545454545
65134, 2.1130434782609, 0.51521739130435, 0.40909090909091
65135, 2.1130434782609, 0.51521739130435, 0.36363636363636
65136, 2.1130434782609, 0.51521739130435, 0.31818181818182
65137, 2.1130434782609, 0.51521739130435, 0.27272727272727
65138, 2.1130434782609, 0.51521739130435, 0.22727272727273
65139, 2.1130434782609, 0.51521739130435, 0.18181818181818
65140, 2.1130434782609, 0.51521739130435, 0.13636363636364
65141, 2.1130434782609, 0.51521739130435, 0.090909090909091
65142, 2.1130434782609, 0.51521739130435, 0.045454545454545
65143, 2.1565217391304, 0.51521739130435, 0.45454545454545
65144, 2.1565217391304, 0.51521739130435, 0.40909090909091
65145, 2.1565217391304, 0.51521739130435, 0.36363636363636
65146, 2.1565217391304, 0.51521739130435, 0.31818181818182
65147, 2.1565217391304, 0.51521739130435, 0.27272727272727
65148, 2.1565217391304, 0.51521739130435, 0.22727272727273
65149, 2.1565217391304, 0.51521739130435, 0.18181818181818
65150, 2.1565217391304, 0.51521739130435, 0.13636363636364
65151, 2.1565217391304, 0.51521739130435, 0.090909090909091
65152, 2.1565217391304, 0.51521739130435, 0.045454545454545
65153, 1.2434782608696, 0.46304347826087, 0.45454545454545
65154, 1.2434782608696, 0.46304347826087, 0.40909090909091
65155, 1.2434782608696, 0.46304347826087, 0.36363636363636
65156, 1.2434782608696, 0.46304347826087, 0.31818181818182
65157, 1.2434782608696, 0.46304347826087, 0.27272727272727
65158, 1.2434782608696, 0.46304347826087, 0.22727272727273
65159, 1.2434782608696, 0.46304347826087, 0.18181818181818
65160, 1.2434782608696, 0.46304347826087, 0.13636363636364
65161, 1.2434782608696, 0.46304347826087, 0.090909090909091
65162, 1.2434782608696, 0.46304347826087, 0.045454545454545
65163, 1.2869565217391, 0.46304347826087, 0.45454545454545
65164, 1.2869565217391, 0.46304347826087, 0.40909090909091
65165, 1.2869565217391, 0.46304347826087, 0.36363636363636
65166, 1.2869565217391, 0.46304347826087, 0.31818181818182
65167, 1.2869565217391, 0.46304347826087, 0.27272727272727
65168, 1.2869565217391, 0.46304347826087, 0.22727272727273
65169, 1.2869565217391, 0.46304347826087, 0.18181818181818
65170, 1.2869565217391, 0.46304347826087, 0.13636363636364
65171, 1.2869565217391, 0.46304347826087, 0.090909090909091
65172, 1.2869565217391, 0.46304347826087, 0.045454545454545
65173, 1.3304347826087, 0.46304347826087, 0.45454545454545
65174, 1.3304347826087, 0.46304347826087, 0.40909090909091
65175, 1.3304347826087, 0.46304347826087, 0.36363636363636
65176, 1.3304347826087, 0.46304347826087, 0.31818181818182
65177, 1.3304347826087, 0.46304347826087, 0.27272727272727
65178, 1.3304347826087, 0.46304347826087, 0.22727272727273
65179, 1.3304347826087, 0.46304347826087, 0.18181818181818
65180, 1.3304347826087, 0.46304347826087, 0.13636363636364
65181, 1.3304347826087, 0.46304347826087, 0.090909090909091
65182, 1.3304347826087, 0.46304347826087, 0.045454545454545
65183, 1.3739130434783, 0.46304347826087, 0.45454545454545
65184, 1.3739130434783, 0.46304347826087, 0.40909090909091
65185, 1.3739130434783, 0.46304347826087, 0.36363636363636
65186, 1.3739130434783, 0.46304347826087, 0.31818181818182
65187, 1.3739130434783, 0.46304347826087, 0.27272727272727
65188, 1.3739130434783, 0.46304347826087, 0.22727272727273
65189, 1.3739130434783, 0.46304347826087, 0.18181818181818
65190, 1.3739130434783, 0.46304347826087, 0.13636363636364
65191, 1.3739130434783, 0.46304347826087, 0.090909090909091
65192, 1.3739130434783, 0.46304347826087, 0.045454545454545
65193, 1.4173913043478, 0.46304347826087, 0.45454545454545
65194, 1.4173913043478, 0.46304347826087, 0.40909090909091
65195, 1.4173913043478, 0.46304347826087, 0.36363636363636
65196, 1.4173913043478, 0.46304347826087, 0.31818181818182
65197, 1.4173913043478, 0.46304347826087, 0.27272727272727
65198, 1.4173913043478, 0.46304347826087, 0.22727272727273
65199, 1.4173913043478, 0.46304347826087, 0.18181818181818
65200, 1.4173913043478, 0.46304347826087, 0.13636363636364
65201, 1.4173913043478, 0.46304347826087, 0.090909090909091
65202, 1.4173913043478, 0.46304347826087, 0.045454545454545
65203, 1.4608695652174, 0.46304347826087, 0.45454545454545
65204, 1.4608695652174, 0.46304347826087, 0.40909090909091
65205, 1.4608695652174, 0.46304347826087, 0.36363636363636
65206, 1.4608695652174, 0.46304347826087, 0.31818181818182
65207, 1.4608695652174, 0.46304347826087, 0.27272727272727
65208, 1.4608695652174, 0.46304347826087, 0.22727272727273
65209, 1.4608695652174, 0.46304347826087, 0.18181818181818
65210, 1.4608695652174, 0.46304347826087, 0.13636363636364
65211, 1.4608695652174, 0.46304347826087, 0.090909090909091
65212, 1.4608695652174, 0.46304347826087, 0.045454545454545
65213, 1.504347826087, 0.46304347826087, 0.45454545454545
65214, 1.504347826087, 0.46304347826087, 0.40909090909091
65215, 1.504347826087, 0.46304347826087, 0.36363636363636
65216, 1.504347826087, 0.46304347826087, 0.31818181818182
65217, 1.504347826087, 0.46304347826087, 0.27272727272727
65218, 1.504347826087, 0.46304347826087, 0.22727272727273
65219, 1.504347826087, 0.46304347826087, 0.18181818181818
65220, 1.504347826087, 0.46304347826087, 0.13636363636364
65221, 1.504347826087, 0.46304347826087, 0.090909090909091
65222, 1.504347826087, 0.46304347826087, 0.045454545454545
65223, 1.5478260869565, 0.46304347826087, 0.45454545454545
65224, 1.5478260869565, 0.46304347826087, 0.40909090909091
65225, 1.5478260869565, 0.46304347826087, 0.36363636363636
65226, 1.5478260869565, 0.46304347826087, 0.31818181818182
65227, 1.5478260869565, 0.46304347826087, 0.27272727272727
65228, 1.5478260869565, 0.46304347826087, 0.22727272727273
65229, 1.5478260869565, 0.46304347826087, 0.18181818181818
65230, 1.5478260869565, 0.46304347826087, 0.13636363636364
65231, 1.5478260869565, 0.46304347826087, 0.090909090909091
65232, 1.5478260869565, 0.46304347826087, 0.045454545454545
65233, 1.5913043478261, 0.46304347826087, 0.45454545454545
65234, 1.5913043478261, 0.46304347826087, 0.40909090909091
65235, 1.5913043478261, 0.46304347826087, 0.36363636363636
65236, 1.5913043478261, 0.46304347826087, 0.31818181818182
65237, 1.5913043478261, 0.46304347826087, 0.27272727272727
65238, 1.5913043478261, 0.46304347826087, 0.22727272727273
65239, 1.5913043478261, 0.46304347826087, 0.18181818181818
65240, 1.5913043478261, 0.46304347826087, 0.13636363636364
65241, 1.5913043478261, 0.46304347826087, 0.090909090909091
65242, 1.5913043478261, 0.46304347826087, 0.045454545454545
65243, 1.6347826086957, 0.46304347826087, 0.45454545454545
65244, 1.6347826086957, 0.46304347826087, 0.40909090909091
65245, 1.6347826086957, 0.46304347826087, 0.36363636363636
65246, 1.6347826086957, 0.46304347826087, 0.31818181818182
65247, 1.6347826086957, 0.46304347826087, 0.27272727272727
65248, 1.6347826086957, 0.46304347826087, 0.22727272727273
65249, 1.6347826086957, 0.46304347826087, 0.18181818181818
65250, 1.6347826086957, 0.46304347826087, 0.13636363636364
65251, 1.6347826086957, 0.46304347826087, 0.090909090909091
65252, 1.6347826086957, 0.46304347826087, 0.045454545454545
65253, 1.6782608695652, 0.46304347826087, 0.45454545454545
65254, 1.6782608695652, 0.46304347826087, 0.40909090909091
65255, 1.6782608695652, 0.46304347826087, 0.36363636363636
65256, 1.6782608695652, 0.46304347826087, 0.31818181818182
65257, 1.6782608695652, 0.46304347826087, 0.27272727272727
65258, 1.6782608695652, 0.46304347826087, 0.22727272727273
65259, 1.6782608695652, 0.46304347826087, 0.18181818181818
65260, 1.6782608695652, 0.46304347826087, 0.13636363636364
65261, 1.6782608695652, 0.46304347826087, 0.090909090909091
65262, 1.6782608695652, 0.46304347826087, 0.045454545454545
65263, 1.7217391304348, 0.46304347826087, 0.45454545454545
65264, 1.7217391304348, 0.46304347826087, 0.40909090909091
65265, 1.7217391304348, 0.46304347826087, 0.36363636363636
65266, 1.7217391304348, 0.46304347826087, 0.31818181818182
65267, 1.7217391304348, 0.46304347826087, 0.27272727272727
65268, 1.7217391304348, 0.46304347826087, 0.22727272727273
65269, 1.7217391304348, 0.46304347826087, 0.18181818181818
65270, 1.7217391304348, 0.46304347826087, 0.13636363636364
65271, 1.7217391304348, 0.46304347826087, 0.090909090909091
65272, 1.7217391304348, 0.46304347826087, 0.045454545454545
65273, 1.7652173913043, 0.46304347826087, 0.45454545454545
65274, 1.7652173913043, 0.46304347826087, 0.40909090909091
65275, 1.7652173913043, 0.46304347826087, 0.36363636363636
65276, 1.7652173913043, 0.46304347826087, 0.31818181818182
65277, 1.7652173913043, 0.46304347826087, 0.27272727272727
65278, 1.7652173913043, 0.46304347826087, 0.22727272727273
65279, 1.7652173913043, 0.46304347826087, 0.18181818181818
65280, 1.7652173913043, 0.46304347826087, 0.13636363636364
65281, 1.7652173913043, 0.46304347826087, 0.090909090909091
65282, 1.7652173913043, 0.46304347826087, 0.045454545454545
65283, 1.8086956521739, 0.46304347826087, 0.45454545454545
65284, 1.8086956521739, 0.46304347826087, 0.40909090909091
65285, 1.8086956521739, 0.46304347826087, 0.36363636363636
65286, 1.8086956521739, 0.46304347826087, 0.31818181818182
65287, 1.8086956521739, 0.46304347826087, 0.27272727272727
65288, 1.8086956521739, 0.46304347826087, 0.22727272727273
65289, 1.8086956521739, 0.46304347826087, 0.18181818181818
65290, 1.8086956521739, 0.46304347826087, 0.13636363636364
65291, 1.8086956521739, 0.46304347826087, 0.090909090909091
65292, 1.8086956521739, 0.46304347826087, 0.045454545454545
65293, 1.8521739130435, 0.46304347826087, 0.45454545454545
65294, 1.8521739130435, 0.46304347826087, 0.40909090909091
65295, 1.8521739130435, 0.46304347826087, 0.36363636363636
65296, 1.8521739130435, 0.46304347826087, 0.31818181818182
65297, 1.8521739130435, 0.46304347826087, 0.27272727272727
65298, 1.8521739130435, 0.46304347826087, 0.22727272727273
65299, 1.8521739130435, 0.46304347826087, 0.18181818181818
65300, 1.8521739130435, 0.46304347826087, 0.13636363636364
65301, 1.8521739130435, 0.46304347826087, 0.090909090909091
65302, 1.8521739130435, 0.46304347826087, 0.045454545454545
65303, 1.895652173913, 0.46304347826087, 0.45454545454545
65304, 1.895652173913, 0.46304347826087, 0.40909090909091
65305, 1.895652173913, 0.46304347826087, 0.36363636363636
65306, 1.895652173913, 0.46304347826087, 0.31818181818182
65307, 1.895652173913, 0.46304347826087, 0.27272727272727
65308, 1.895652173913, 0.46304347826087, 0.22727272727273
65309, 1.895652173913, 0.46304347826087, 0.18181818181818
65310, 1.895652173913, 0.46304347826087, 0.13636363636364
65311, 1.895652173913, 0.46304347826087, 0.090909090909091
65312, 1.895652173913, 0.46304347826087, 0.045454545454545
65313, 1.9391304347826, 0.46304347826087, 0.45454545454545
65314, 1.9391304347826, 0.46304347826087, 0.40909090909091
65315, 1.9391304347826, 0.46304347826087, 0.36363636363636
65316, 1.9391304347826, 0.46304347826087, 0.31818181818182
65317, 1.9391304347826, 0.46304347826087, 0.27272727272727
65318, 1.9391304347826, 0.46304347826087, 0.22727272727273
65319, 1.9391304347826, 0.46304347826087, 0.18181818181818
65320, 1.9391304347826, 0.46304347826087, 0.13636363636364
65321, 1.9391304347826, 0.46304347826087, 0.090909090909091
65322, 1.9391304347826, 0.46304347826087, 0.045454545454545
65323, 1.9826086956522, 0.46304347826087, 0.45454545454545
65324, 1.9826086956522, 0.46304347826087, 0.40909090909091
65325, 1.9826086956522, 0.46304347826087, 0.36363636363636
65326, 1.9826086956522, 0.46304347826087, 0.31818181818182
65327, 1.9826086956522, 0.46304347826087, 0.27272727272727
65328, 1.9826086956522, 0.46304347826087, 0.22727272727273
65329, 1.9826086956522, 0.46304347826087, 0.18181818181818
65330, 1.9826086956522, 0.46304347826087, 0.13636363636364
65331, 1.9826086956522, 0.46304347826087, 0.090909090909091
65332, 1.9826086956522, 0.46304347826087, 0.045454545454545
65333, 2.0260869565217, 0.46304347826087, 0.45454545454545
65334, 2.0260869565217, 0.46304347826087, 0.40909090909091
65335, 2.0260869565217, 0.46304347826087, 0.36363636363636
65336, 2.0260869565217, 0.46304347826087, 0.31818181818182
65337, 2.0260869565217, 0.46304347826087, 0.27272727272727
65338, 2.0260869565217, 0.46304347826087, 0.22727272727273
65339, 2.0260869565217, 0.46304347826087, 0.18181818181818
65340, 2.0260869565217, 0.46304347826087, 0.13636363636364
65341, 2.0260869565217, 0.46304347826087, 0.090909090909091
65342, 2.0260869565217, 0.46304347826087, 0.045454545454545
65343, 2.0695652173913, 0.46304347826087, 0.45454545454545
65344, 2.0695652173913, 0.46304347826087, 0.40909090909091
65345, 2.0695652173913, 0.46304347826087, 0.36363636363636
65346, 2.0695652173913, 0.46304347826087, 0.31818181818182
65347, 2.0695652173913, 0.46304347826087, 0.27272727272727
65348, 2.0695652173913, 0.46304347826087, 0.22727272727273
65349, 2.0695652173913, 0.46304347826087, 0.18181818181818
65350, 2.0695652173913, 0.46304347826087, 0.13636363636364
65351, 2.0695652173913, 0.46304347826087, 0.090909090909091
65352, 2.0695652173913, 0.46304347826087, 0.045454545454545
65353, 2.1130434782609, 0.46304347826087, 0.45454545454545
65354, 2.1130434782609, 0.46304347826087, 0.40909090909091
65355, 2.1130434782609, 0.46304347826087, 0.36363636363636
65356, 2.1130434782609, 0.46304347826087, 0.31818181818182
65357, 2.1130434782609, 0.46304347826087, 0.27272727272727
65358, 2.1130434782609, 0.46304347826087, 0.22727272727273
65359, 2.1130434782609, 0.46304347826087, 0.18181818181818
65360, 2.1130434782609, 0.46304347826087, 0.13636363636364
65361, 2.1130434782609, 0.46304347826087, 0.090909090909091
65362, 2.1130434782609, 0.46304347826087, 0.045454545454545
65363, 2.1565217391304, 0.46304347826087, 0.45454545454545
65364, 2.1565217391304, 0.46304347826087, 0.40909090909091
65365, 2.1565217391304, 0.46304347826087, 0.36363636363636
65366, 2.1565217391304, 0.46304347826087, 0.31818181818182
65367, 2.1565217391304, 0.46304347826087, 0.27272727272727
65368, 2.1565217391304, 0.46304347826087, 0.22727272727273
65369, 2.1565217391304, 0.46304347826087, 0.18181818181818
65370, 2.1565217391304, 0.46304347826087, 0.13636363636364
65371, 2.1565217391304, 0.46304347826087, 0.090909090909091
65372, 2.1565217391304, 0.46304347826087, 0.045454545454545
65373, 1.2434782608696, 0.41086956521739, 0.45454545454545
65374, 1.2434782608696, 0.41086956521739, 0.40909090909091
65375, 1.2434782608696, 0.41086956521739, 0.36363636363636
65376, 1.2434782608696, 0.41086956521739, 0.31818181818182
65377, 1.2434782608696, 0.41086956521739, 0.27272727272727
65378, 1.2434782608696, 0.41086956521739, 0.22727272727273
65379, 1.2434782608696, 0.41086956521739, 0.18181818181818
65380, 1.2434782608696, 0.41086956521739, 0.13636363636364
65381, 1.2434782608696, 0.41086956521739, 0.090909090909091
65382, 1.2434782608696, 0.41086956521739, 0.045454545454545
65383, 1.2869565217391, 0.41086956521739, 0.45454545454545
65384, 1.2869565217391, 0.41086956521739, 0.40909090909091
65385, 1.2869565217391, 0.41086956521739, 0.36363636363636
65386, 1.2869565217391, 0.41086956521739, 0.31818181818182
65387, 1.2869565217391, 0.41086956521739, 0.27272727272727
65388, 1.2869565217391, 0.41086956521739, 0.22727272727273
65389, 1.2869565217391, 0.41086956521739, 0.18181818181818
65390, 1.2869565217391, 0.41086956521739, 0.13636363636364
65391, 1.2869565217391, 0.41086956521739, 0.090909090909091
65392, 1.2869565217391, 0.41086956521739, 0.045454545454545
65393, 1.3304347826087, 0.41086956521739, 0.45454545454545
65394, 1.3304347826087, 0.41086956521739, 0.40909090909091
65395, 1.3304347826087, 0.41086956521739, 0.36363636363636
65396, 1.3304347826087, 0.41086956521739, 0.31818181818182
65397, 1.3304347826087, 0.41086956521739, 0.27272727272727
65398, 1.3304347826087, 0.41086956521739, 0.22727272727273
65399, 1.3304347826087, 0.41086956521739, 0.18181818181818
65400, 1.3304347826087, 0.41086956521739, 0.13636363636364
65401, 1.3304347826087, 0.41086956521739, 0.090909090909091
65402, 1.3304347826087, 0.41086956521739, 0.045454545454545
65403, 1.3739130434783, 0.41086956521739, 0.45454545454545
65404, 1.3739130434783, 0.41086956521739, 0.40909090909091
65405, 1.3739130434783, 0.41086956521739, 0.36363636363636
65406, 1.3739130434783, 0.41086956521739, 0.31818181818182
65407, 1.3739130434783, 0.41086956521739, 0.27272727272727
65408, 1.3739130434783, 0.41086956521739, 0.22727272727273
65409, 1.3739130434783, 0.41086956521739, 0.18181818181818
65410, 1.3739130434783, 0.41086956521739, 0.13636363636364
65411, 1.3739130434783, 0.41086956521739, 0.090909090909091
65412, 1.3739130434783, 0.41086956521739, 0.045454545454545
65413, 1.4173913043478, 0.41086956521739, 0.45454545454545
65414, 1.4173913043478, 0.41086956521739, 0.40909090909091
65415, 1.4173913043478, 0.41086956521739, 0.36363636363636
65416, 1.4173913043478, 0.41086956521739, 0.31818181818182
65417, 1.4173913043478, 0.41086956521739, 0.27272727272727
65418, 1.4173913043478, 0.41086956521739, 0.22727272727273
65419, 1.4173913043478, 0.41086956521739, 0.18181818181818
65420, 1.4173913043478, 0.41086956521739, 0.13636363636364
65421, 1.4173913043478, 0.41086956521739, 0.090909090909091
65422, 1.4173913043478, 0.41086956521739, 0.045454545454545
65423, 1.4608695652174, 0.41086956521739, 0.45454545454545
65424, 1.4608695652174, 0.41086956521739, 0.40909090909091
65425, 1.4608695652174, 0.41086956521739, 0.36363636363636
65426, 1.4608695652174, 0.41086956521739, 0.31818181818182
65427, 1.4608695652174, 0.41086956521739, 0.27272727272727
65428, 1.4608695652174, 0.41086956521739, 0.22727272727273
65429, 1.4608695652174, 0.41086956521739, 0.18181818181818
65430, 1.4608695652174, 0.41086956521739, 0.13636363636364
65431, 1.4608695652174, 0.41086956521739, 0.090909090909091
65432, 1.4608695652174, 0.41086956521739, 0.045454545454545
65433, 1.504347826087, 0.41086956521739, 0.45454545454545
65434, 1.504347826087, 0.41086956521739, 0.40909090909091
65435, 1.504347826087, 0.41086956521739, 0.36363636363636
65436, 1.504347826087, 0.41086956521739, 0.31818181818182
65437, 1.504347826087, 0.41086956521739, 0.27272727272727
65438, 1.504347826087, 0.41086956521739, 0.22727272727273
65439, 1.504347826087, 0.41086956521739, 0.18181818181818
65440, 1.504347826087, 0.41086956521739, 0.13636363636364
65441, 1.504347826087, 0.41086956521739, 0.090909090909091
65442, 1.504347826087, 0.41086956521739, 0.045454545454545
65443, 1.5478260869565, 0.41086956521739, 0.45454545454545
65444, 1.5478260869565, 0.41086956521739, 0.40909090909091
65445, 1.5478260869565, 0.41086956521739, 0.36363636363636
65446, 1.5478260869565, 0.41086956521739, 0.31818181818182
65447, 1.5478260869565, 0.41086956521739, 0.27272727272727
65448, 1.5478260869565, 0.41086956521739, 0.22727272727273
65449, 1.5478260869565, 0.41086956521739, 0.18181818181818
65450, 1.5478260869565, 0.41086956521739, 0.13636363636364
65451, 1.5478260869565, 0.41086956521739, 0.090909090909091
65452, 1.5478260869565, 0.41086956521739, 0.045454545454545
65453, 1.5913043478261, 0.41086956521739, 0.45454545454545
65454, 1.5913043478261, 0.41086956521739, 0.40909090909091
65455, 1.5913043478261, 0.41086956521739, 0.36363636363636
65456, 1.5913043478261, 0.41086956521739, 0.31818181818182
65457, 1.5913043478261, 0.41086956521739, 0.27272727272727
65458, 1.5913043478261, 0.41086956521739, 0.22727272727273
65459, 1.5913043478261, 0.41086956521739, 0.18181818181818
65460, 1.5913043478261, 0.41086956521739, 0.13636363636364
65461, 1.5913043478261, 0.41086956521739, 0.090909090909091
65462, 1.5913043478261, 0.41086956521739, 0.045454545454545
65463, 1.6347826086957, 0.41086956521739, 0.45454545454545
65464, 1.6347826086957, 0.41086956521739, 0.40909090909091
65465, 1.6347826086957, 0.41086956521739, 0.36363636363636
65466, 1.6347826086957, 0.41086956521739, 0.31818181818182
65467, 1.6347826086957, 0.41086956521739, 0.27272727272727
65468, 1.6347826086957, 0.41086956521739, 0.22727272727273
65469, 1.6347826086957, 0.41086956521739, 0.18181818181818
65470, 1.6347826086957, 0.41086956521739, 0.13636363636364
65471, 1.6347826086957, 0.41086956521739, 0.090909090909091
65472, 1.6347826086957, 0.41086956521739, 0.045454545454545
65473, 1.6782608695652, 0.41086956521739, 0.45454545454545
65474, 1.6782608695652, 0.41086956521739, 0.40909090909091
65475, 1.6782608695652, 0.41086956521739, 0.36363636363636
65476, 1.6782608695652, 0.41086956521739, 0.31818181818182
65477, 1.6782608695652, 0.41086956521739, 0.27272727272727
65478, 1.6782608695652, 0.41086956521739, 0.22727272727273
65479, 1.6782608695652, 0.41086956521739, 0.18181818181818
65480, 1.6782608695652, 0.41086956521739, 0.13636363636364
65481, 1.6782608695652, 0.41086956521739, 0.090909090909091
65482, 1.6782608695652, 0.41086956521739, 0.045454545454545
65483, 1.7217391304348, 0.41086956521739, 0.45454545454545
65484, 1.7217391304348, 0.41086956521739, 0.40909090909091
65485, 1.7217391304348, 0.41086956521739, 0.36363636363636
65486, 1.7217391304348, 0.41086956521739, 0.31818181818182
65487, 1.7217391304348, 0.41086956521739, 0.27272727272727
65488, 1.7217391304348, 0.41086956521739, 0.22727272727273
65489, 1.7217391304348, 0.41086956521739, 0.18181818181818
65490, 1.7217391304348, 0.41086956521739, 0.13636363636364
65491, 1.7217391304348, 0.41086956521739, 0.090909090909091
65492, 1.7217391304348, 0.41086956521739, 0.045454545454545
65493, 1.7652173913043, 0.41086956521739, 0.45454545454545
65494, 1.7652173913043, 0.41086956521739, 0.40909090909091
65495, 1.7652173913043, 0.41086956521739, 0.36363636363636
65496, 1.7652173913043, 0.41086956521739, 0.31818181818182
65497, 1.7652173913043, 0.41086956521739, 0.27272727272727
65498, 1.7652173913043, 0.41086956521739, 0.22727272727273
65499, 1.7652173913043, 0.41086956521739, 0.18181818181818
65500, 1.7652173913043, 0.41086956521739, 0.13636363636364
65501, 1.7652173913043, 0.41086956521739, 0.090909090909091
65502, 1.7652173913043, 0.41086956521739, 0.045454545454545
65503, 1.8086956521739, 0.41086956521739, 0.45454545454545
65504, 1.8086956521739, 0.41086956521739, 0.40909090909091
65505, 1.8086956521739, 0.41086956521739, 0.36363636363636
65506, 1.8086956521739, 0.41086956521739, 0.31818181818182
65507, 1.8086956521739, 0.41086956521739, 0.27272727272727
65508, 1.8086956521739, 0.41086956521739, 0.22727272727273
65509, 1.8086956521739, 0.41086956521739, 0.18181818181818
65510, 1.8086956521739, 0.41086956521739, 0.13636363636364
65511, 1.8086956521739, 0.41086956521739, 0.090909090909091
65512, 1.8086956521739, 0.41086956521739, 0.045454545454545
65513, 1.8521739130435, 0.41086956521739, 0.45454545454545
65514, 1.8521739130435, 0.41086956521739, 0.40909090909091
65515, 1.8521739130435, 0.41086956521739, 0.36363636363636
65516, 1.8521739130435, 0.41086956521739, 0.31818181818182
65517, 1.8521739130435, 0.41086956521739, 0.27272727272727
65518, 1.8521739130435, 0.41086956521739, 0.22727272727273
65519, 1.8521739130435, 0.41086956521739, 0.18181818181818
65520, 1.8521739130435, 0.41086956521739, 0.13636363636364
65521, 1.8521739130435, 0.41086956521739, 0.090909090909091
65522, 1.8521739130435, 0.41086956521739, 0.045454545454545
65523, 1.895652173913, 0.41086956521739, 0.45454545454545
65524, 1.895652173913, 0.41086956521739, 0.40909090909091
65525, 1.895652173913, 0.41086956521739, 0.36363636363636
65526, 1.895652173913, 0.41086956521739, 0.31818181818182
65527, 1.895652173913, 0.41086956521739, 0.27272727272727
65528, 1.895652173913, 0.41086956521739, 0.22727272727273
65529, 1.895652173913, 0.41086956521739, 0.18181818181818
65530, 1.895652173913, 0.41086956521739, 0.13636363636364
65531, 1.895652173913, 0.41086956521739, 0.090909090909091
65532, 1.895652173913, 0.41086956521739, 0.045454545454545
65533, 1.9391304347826, 0.41086956521739, 0.45454545454545
65534, 1.9391304347826, 0.41086956521739, 0.40909090909091
65535, 1.9391304347826, 0.41086956521739, 0.36363636363636
65536, 1.9391304347826, 0.41086956521739, 0.31818181818182
65537, 1.9391304347826, 0.41086956521739, 0.27272727272727
65538, 1.9391304347826, 0.41086956521739, 0.22727272727273
65539, 1.9391304347826, 0.41086956521739, 0.18181818181818
65540, 1.9391304347826, 0.41086956521739, 0.13636363636364
65541, 1.9391304347826, 0.41086956521739, 0.090909090909091
65542, 1.9391304347826, 0.41086956521739, 0.045454545454545
65543, 1.9826086956522, 0.41086956521739, 0.45454545454545
65544, 1.9826086956522, 0.41086956521739, 0.40909090909091
65545, 1.9826086956522, 0.41086956521739, 0.36363636363636
65546, 1.9826086956522, 0.41086956521739, 0.31818181818182
65547, 1.9826086956522, 0.41086956521739, 0.27272727272727
65548, 1.9826086956522, 0.41086956521739, 0.22727272727273
65549, 1.9826086956522, 0.41086956521739, 0.18181818181818
65550, 1.9826086956522, 0.41086956521739, 0.13636363636364
65551, 1.9826086956522, 0.41086956521739, 0.090909090909091
65552, 1.9826086956522, 0.41086956521739, 0.045454545454545
65553, 2.0260869565217, 0.41086956521739, 0.45454545454545
65554, 2.0260869565217, 0.41086956521739, 0.40909090909091
65555, 2.0260869565217, 0.41086956521739, 0.36363636363636
65556, 2.0260869565217, 0.41086956521739, 0.31818181818182
65557, 2.0260869565217, 0.41086956521739, 0.27272727272727
65558, 2.0260869565217, 0.41086956521739, 0.22727272727273
65559, 2.0260869565217, 0.41086956521739, 0.18181818181818
65560, 2.0260869565217, 0.41086956521739, 0.13636363636364
65561, 2.0260869565217, 0.41086956521739, 0.090909090909091
65562, 2.0260869565217, 0.41086956521739, 0.045454545454545
65563, 2.0695652173913, 0.41086956521739, 0.45454545454545
65564, 2.0695652173913, 0.41086956521739, 0.40909090909091
65565, 2.0695652173913, 0.41086956521739, 0.36363636363636
65566, 2.0695652173913, 0.41086956521739, 0.31818181818182
65567, 2.0695652173913, 0.41086956521739, 0.27272727272727
65568, 2.0695652173913, 0.41086956521739, 0.22727272727273
65569, 2.0695652173913, 0.41086956521739, 0.18181818181818
65570, 2.0695652173913, 0.41086956521739, 0.13636363636364
65571, 2.0695652173913, 0.41086956521739, 0.090909090909091
65572, 2.0695652173913, 0.41086956521739, 0.045454545454545
65573, 2.1130434782609, 0.41086956521739, 0.45454545454545
65574, 2.1130434782609, 0.41086956521739, 0.40909090909091
65575, 2.1130434782609, 0.41086956521739, 0.36363636363636
65576, 2.1130434782609, 0.41086956521739, 0.31818181818182
65577, 2.1130434782609, 0.41086956521739, 0.27272727272727
65578, 2.1130434782609, 0.41086956521739, 0.22727272727273
65579, 2.1130434782609, 0.41086956521739, 0.18181818181818
65580, 2.1130434782609, 0.41086956521739, 0.13636363636364
65581, 2.1130434782609, 0.41086956521739, 0.090909090909091
65582, 2.1130434782609, 0.41086956521739, 0.045454545454545
65583, 2.1565217391304, 0.41086956521739, 0.45454545454545
65584, 2.1565217391304, 0.41086956521739, 0.40909090909091
65585, 2.1565217391304, 0.41086956521739, 0.36363636363636
65586, 2.1565217391304, 0.41086956521739, 0.31818181818182
65587, 2.1565217391304, 0.41086956521739, 0.27272727272727
65588, 2.1565217391304, 0.41086956521739, 0.22727272727273
65589, 2.1565217391304, 0.41086956521739, 0.18181818181818
65590, 2.1565217391304, 0.41086956521739, 0.13636363636364
65591, 2.1565217391304, 0.41086956521739, 0.090909090909091
65592, 2.1565217391304, 0.41086956521739, 0.045454545454545
65593, 1.2434782608696, 0.35869565217391, 0.45454545454545
65594, 1.2434782608696, 0.35869565217391, 0.40909090909091
65595, 1.2434782608696, 0.35869565217391, 0.36363636363636
65596, 1.2434782608696, 0.35869565217391, 0.31818181818182
65597, 1.2434782608696, 0.35869565217391, 0.27272727272727
65598, 1.2434782608696, 0.35869565217391, 0.22727272727273
65599, 1.2434782608696, 0.35869565217391, 0.18181818181818
65600, 1.2434782608696, 0.35869565217391, 0.13636363636364
65601, 1.2434782608696, 0.35869565217391, 0.090909090909091
65602, 1.2434782608696, 0.35869565217391, 0.045454545454545
65603, 1.2869565217391, 0.35869565217391, 0.45454545454545
65604, 1.2869565217391, 0.35869565217391, 0.40909090909091
65605, 1.2869565217391, 0.35869565217391, 0.36363636363636
65606, 1.2869565217391, 0.35869565217391, 0.31818181818182
65607, 1.2869565217391, 0.35869565217391, 0.27272727272727
65608, 1.2869565217391, 0.35869565217391, 0.22727272727273
65609, 1.2869565217391, 0.35869565217391, 0.18181818181818
65610, 1.2869565217391, 0.35869565217391, 0.13636363636364
65611, 1.2869565217391, 0.35869565217391, 0.090909090909091
65612, 1.2869565217391, 0.35869565217391, 0.045454545454545
65613, 1.3304347826087, 0.35869565217391, 0.45454545454545
65614, 1.3304347826087, 0.35869565217391, 0.40909090909091
65615, 1.3304347826087, 0.35869565217391, 0.36363636363636
65616, 1.3304347826087, 0.35869565217391, 0.31818181818182
65617, 1.3304347826087, 0.35869565217391, 0.27272727272727
65618, 1.3304347826087, 0.35869565217391, 0.22727272727273
65619, 1.3304347826087, 0.35869565217391, 0.18181818181818
65620, 1.3304347826087, 0.35869565217391, 0.13636363636364
65621, 1.3304347826087, 0.35869565217391, 0.090909090909091
65622, 1.3304347826087, 0.35869565217391, 0.045454545454545
65623, 1.3739130434783, 0.35869565217391, 0.45454545454545
65624, 1.3739130434783, 0.35869565217391, 0.40909090909091
65625, 1.3739130434783, 0.35869565217391, 0.36363636363636
65626, 1.3739130434783, 0.35869565217391, 0.31818181818182
65627, 1.3739130434783, 0.35869565217391, 0.27272727272727
65628, 1.3739130434783, 0.35869565217391, 0.22727272727273
65629, 1.3739130434783, 0.35869565217391, 0.18181818181818
65630, 1.3739130434783, 0.35869565217391, 0.13636363636364
65631, 1.3739130434783, 0.35869565217391, 0.090909090909091
65632, 1.3739130434783, 0.35869565217391, 0.045454545454545
65633, 1.4173913043478, 0.35869565217391, 0.45454545454545
65634, 1.4173913043478, 0.35869565217391, 0.40909090909091
65635, 1.4173913043478, 0.35869565217391, 0.36363636363636
65636, 1.4173913043478, 0.35869565217391, 0.31818181818182
65637, 1.4173913043478, 0.35869565217391, 0.27272727272727
65638, 1.4173913043478, 0.35869565217391, 0.22727272727273
65639, 1.4173913043478, 0.35869565217391, 0.18181818181818
65640, 1.4173913043478, 0.35869565217391, 0.13636363636364
65641, 1.4173913043478, 0.35869565217391, 0.090909090909091
65642, 1.4173913043478, 0.35869565217391, 0.045454545454545
65643, 1.4608695652174, 0.35869565217391, 0.45454545454545
65644, 1.4608695652174, 0.35869565217391, 0.40909090909091
65645, 1.4608695652174, 0.35869565217391, 0.36363636363636
65646, 1.4608695652174, 0.35869565217391, 0.31818181818182
65647, 1.4608695652174, 0.35869565217391, 0.27272727272727
65648, 1.4608695652174, 0.35869565217391, 0.22727272727273
65649, 1.4608695652174, 0.35869565217391, 0.18181818181818
65650, 1.4608695652174, 0.35869565217391, 0.13636363636364
65651, 1.4608695652174, 0.35869565217391, 0.090909090909091
65652, 1.4608695652174, 0.35869565217391, 0.045454545454545
65653, 1.504347826087, 0.35869565217391, 0.45454545454545
65654, 1.504347826087, 0.35869565217391, 0.40909090909091
65655, 1.504347826087, 0.35869565217391, 0.36363636363636
65656, 1.504347826087, 0.35869565217391, 0.31818181818182
65657, 1.504347826087, 0.35869565217391, 0.27272727272727
65658, 1.504347826087, 0.35869565217391, 0.22727272727273
65659, 1.504347826087, 0.35869565217391, 0.18181818181818
65660, 1.504347826087, 0.35869565217391, 0.13636363636364
65661, 1.504347826087, 0.35869565217391, 0.090909090909091
65662, 1.504347826087, 0.35869565217391, 0.045454545454545
65663, 1.5478260869565, 0.35869565217391, 0.45454545454545
65664, 1.5478260869565, 0.35869565217391, 0.40909090909091
65665, 1.5478260869565, 0.35869565217391, 0.36363636363636
65666, 1.5478260869565, 0.35869565217391, 0.31818181818182
65667, 1.5478260869565, 0.35869565217391, 0.27272727272727
65668, 1.5478260869565, 0.35869565217391, 0.22727272727273
65669, 1.5478260869565, 0.35869565217391, 0.18181818181818
65670, 1.5478260869565, 0.35869565217391, 0.13636363636364
65671, 1.5478260869565, 0.35869565217391, 0.090909090909091
65672, 1.5478260869565, 0.35869565217391, 0.045454545454545
65673, 1.5913043478261, 0.35869565217391, 0.45454545454545
65674, 1.5913043478261, 0.35869565217391, 0.40909090909091
65675, 1.5913043478261, 0.35869565217391, 0.36363636363636
65676, 1.5913043478261, 0.35869565217391, 0.31818181818182
65677, 1.5913043478261, 0.35869565217391, 0.27272727272727
65678, 1.5913043478261, 0.35869565217391, 0.22727272727273
65679, 1.5913043478261, 0.35869565217391, 0.18181818181818
65680, 1.5913043478261, 0.35869565217391, 0.13636363636364
65681, 1.5913043478261, 0.35869565217391, 0.090909090909091
65682, 1.5913043478261, 0.35869565217391, 0.045454545454545
65683, 1.6347826086957, 0.35869565217391, 0.45454545454545
65684, 1.6347826086957, 0.35869565217391, 0.40909090909091
65685, 1.6347826086957, 0.35869565217391, 0.36363636363636
65686, 1.6347826086957, 0.35869565217391, 0.31818181818182
65687, 1.6347826086957, 0.35869565217391, 0.27272727272727
65688, 1.6347826086957, 0.35869565217391, 0.22727272727273
65689, 1.6347826086957, 0.35869565217391, 0.18181818181818
65690, 1.6347826086957, 0.35869565217391, 0.13636363636364
65691, 1.6347826086957, 0.35869565217391, 0.090909090909091
65692, 1.6347826086957, 0.35869565217391, 0.045454545454545
65693, 1.6782608695652, 0.35869565217391, 0.45454545454545
65694, 1.6782608695652, 0.35869565217391, 0.40909090909091
65695, 1.6782608695652, 0.35869565217391, 0.36363636363636
65696, 1.6782608695652, 0.35869565217391, 0.31818181818182
65697, 1.6782608695652, 0.35869565217391, 0.27272727272727
65698, 1.6782608695652, 0.35869565217391, 0.22727272727273
65699, 1.6782608695652, 0.35869565217391, 0.18181818181818
65700, 1.6782608695652, 0.35869565217391, 0.13636363636364
65701, 1.6782608695652, 0.35869565217391, 0.090909090909091
65702, 1.6782608695652, 0.35869565217391, 0.045454545454545
65703, 1.7217391304348, 0.35869565217391, 0.45454545454545
65704, 1.7217391304348, 0.35869565217391, 0.40909090909091
65705, 1.7217391304348, 0.35869565217391, 0.36363636363636
65706, 1.7217391304348, 0.35869565217391, 0.31818181818182
65707, 1.7217391304348, 0.35869565217391, 0.27272727272727
65708, 1.7217391304348, 0.35869565217391, 0.22727272727273
65709, 1.7217391304348, 0.35869565217391, 0.18181818181818
65710, 1.7217391304348, 0.35869565217391, 0.13636363636364
65711, 1.7217391304348, 0.35869565217391, 0.090909090909091
65712, 1.7217391304348, 0.35869565217391, 0.045454545454545
65713, 1.7652173913043, 0.35869565217391, 0.45454545454545
65714, 1.7652173913043, 0.35869565217391, 0.40909090909091
65715, 1.7652173913043, 0.35869565217391, 0.36363636363636
65716, 1.7652173913043, 0.35869565217391, 0.31818181818182
65717, 1.7652173913043, 0.35869565217391, 0.27272727272727
65718, 1.7652173913043, 0.35869565217391, 0.22727272727273
65719, 1.7652173913043, 0.35869565217391, 0.18181818181818
65720, 1.7652173913043, 0.35869565217391, 0.13636363636364
65721, 1.7652173913043, 0.35869565217391, 0.090909090909091
65722, 1.7652173913043, 0.35869565217391, 0.045454545454545
65723, 1.8086956521739, 0.35869565217391, 0.45454545454545
65724, 1.8086956521739, 0.35869565217391, 0.40909090909091
65725, 1.8086956521739, 0.35869565217391, 0.36363636363636
65726, 1.8086956521739, 0.35869565217391, 0.31818181818182
65727, 1.8086956521739, 0.35869565217391, 0.27272727272727
65728, 1.8086956521739, 0.35869565217391, 0.22727272727273
65729, 1.8086956521739, 0.35869565217391, 0.18181818181818
65730, 1.8086956521739, 0.35869565217391, 0.13636363636364
65731, 1.8086956521739, 0.35869565217391, 0.090909090909091
65732, 1.8086956521739, 0.35869565217391, 0.045454545454545
65733, 1.8521739130435, 0.35869565217391, 0.45454545454545
65734, 1.8521739130435, 0.35869565217391, 0.40909090909091
65735, 1.8521739130435, 0.35869565217391, 0.36363636363636
65736, 1.8521739130435, 0.35869565217391, 0.31818181818182
65737, 1.8521739130435, 0.35869565217391, 0.27272727272727
65738, 1.8521739130435, 0.35869565217391, 0.22727272727273
65739, 1.8521739130435, 0.35869565217391, 0.18181818181818
65740, 1.8521739130435, 0.35869565217391, 0.13636363636364
65741, 1.8521739130435, 0.35869565217391, 0.090909090909091
65742, 1.8521739130435, 0.35869565217391, 0.045454545454545
65743, 1.895652173913, 0.35869565217391, 0.45454545454545
65744, 1.895652173913, 0.35869565217391, 0.40909090909091
65745, 1.895652173913, 0.35869565217391, 0.36363636363636
65746, 1.895652173913, 0.35869565217391, 0.31818181818182
65747, 1.895652173913, 0.35869565217391, 0.27272727272727
65748, 1.895652173913, 0.35869565217391, 0.22727272727273
65749, 1.895652173913, 0.35869565217391, 0.18181818181818
65750, 1.895652173913, 0.35869565217391, 0.13636363636364
65751, 1.895652173913, 0.35869565217391, 0.090909090909091
65752, 1.895652173913, 0.35869565217391, 0.045454545454545
65753, 1.9391304347826, 0.35869565217391, 0.45454545454545
65754, 1.9391304347826, 0.35869565217391, 0.40909090909091
65755, 1.9391304347826, 0.35869565217391, 0.36363636363636
65756, 1.9391304347826, 0.35869565217391, 0.31818181818182
65757, 1.9391304347826, 0.35869565217391, 0.27272727272727
65758, 1.9391304347826, 0.35869565217391, 0.22727272727273
65759, 1.9391304347826, 0.35869565217391, 0.18181818181818
65760, 1.9391304347826, 0.35869565217391, 0.13636363636364
65761, 1.9391304347826, 0.35869565217391, 0.090909090909091
65762, 1.9391304347826, 0.35869565217391, 0.045454545454545
65763, 1.9826086956522, 0.35869565217391, 0.45454545454545
65764, 1.9826086956522, 0.35869565217391, 0.40909090909091
65765, 1.9826086956522, 0.35869565217391, 0.36363636363636
65766, 1.9826086956522, 0.35869565217391, 0.31818181818182
65767, 1.9826086956522, 0.35869565217391, 0.27272727272727
65768, 1.9826086956522, 0.35869565217391, 0.22727272727273
65769, 1.9826086956522, 0.35869565217391, 0.18181818181818
65770, 1.9826086956522, 0.35869565217391, 0.13636363636364
65771, 1.9826086956522, 0.35869565217391, 0.090909090909091
65772, 1.9826086956522, 0.35869565217391, 0.045454545454545
65773, 2.0260869565217, 0.35869565217391, 0.45454545454545
65774, 2.0260869565217, 0.35869565217391, 0.40909090909091
65775, 2.0260869565217, 0.35869565217391, 0.36363636363636
65776, 2.0260869565217, 0.35869565217391, 0.31818181818182
65777, 2.0260869565217, 0.35869565217391, 0.27272727272727
65778, 2.0260869565217, 0.35869565217391, 0.22727272727273
65779, 2.0260869565217, 0.35869565217391, 0.18181818181818
65780, 2.0260869565217, 0.35869565217391, 0.13636363636364
65781, 2.0260869565217, 0.35869565217391, 0.090909090909091
65782, 2.0260869565217, 0.35869565217391, 0.045454545454545
65783, 2.0695652173913, 0.35869565217391, 0.45454545454545
65784, 2.0695652173913, 0.35869565217391, 0.40909090909091
65785, 2.0695652173913, 0.35869565217391, 0.36363636363636
65786, 2.0695652173913, 0.35869565217391, 0.31818181818182
65787, 2.0695652173913, 0.35869565217391, 0.27272727272727
65788, 2.0695652173913, 0.35869565217391, 0.22727272727273
65789, 2.0695652173913, 0.35869565217391, 0.18181818181818
65790, 2.0695652173913, 0.35869565217391, 0.13636363636364
65791, 2.0695652173913, 0.35869565217391, 0.090909090909091
65792, 2.0695652173913, 0.35869565217391, 0.045454545454545
65793, 2.1130434782609, 0.35869565217391, 0.45454545454545
65794, 2.1130434782609, 0.35869565217391, 0.40909090909091
65795, 2.1130434782609, 0.35869565217391, 0.36363636363636
65796, 2.1130434782609, 0.35869565217391, 0.31818181818182
65797, 2.1130434782609, 0.35869565217391, 0.27272727272727
65798, 2.1130434782609, 0.35869565217391, 0.22727272727273
65799, 2.1130434782609, 0.35869565217391, 0.18181818181818
65800, 2.1130434782609, 0.35869565217391, 0.13636363636364
65801, 2.1130434782609, 0.35869565217391, 0.090909090909091
65802, 2.1130434782609, 0.35869565217391, 0.045454545454545
65803, 2.1565217391304, 0.35869565217391, 0.45454545454545
65804, 2.1565217391304, 0.35869565217391, 0.40909090909091
65805, 2.1565217391304, 0.35869565217391, 0.36363636363636
65806, 2.1565217391304, 0.35869565217391, 0.31818181818182
65807, 2.1565217391304, 0.35869565217391, 0.27272727272727
65808, 2.1565217391304, 0.35869565217391, 0.22727272727273
65809, 2.1565217391304, 0.35869565217391, 0.18181818181818
65810, 2.1565217391304, 0.35869565217391, 0.13636363636364
65811, 2.1565217391304, 0.35869565217391, 0.090909090909091
65812, 2.1565217391304, 0.35869565217391, 0.045454545454545
65813, 1.2434782608696, 0.30652173913044, 0.45454545454545
65814, 1.2434782608696, 0.30652173913044, 0.40909090909091
65815, 1.2434782608696, 0.30652173913044, 0.36363636363636
65816, 1.2434782608696, 0.30652173913044, 0.31818181818182
65817, 1.2434782608696, 0.30652173913044, 0.27272727272727
65818, 1.2434782608696, 0.30652173913044, 0.22727272727273
65819, 1.2434782608696, 0.30652173913044, 0.18181818181818
65820, 1.2434782608696, 0.30652173913044, 0.13636363636364
65821, 1.2434782608696, 0.30652173913044, 0.090909090909091
65822, 1.2434782608696, 0.30652173913044, 0.045454545454545
65823, 1.2869565217391, 0.30652173913043, 0.45454545454545
65824, 1.2869565217391, 0.30652173913043, 0.40909090909091
65825, 1.2869565217391, 0.30652173913043, 0.36363636363636
65826, 1.2869565217391, 0.30652173913043, 0.31818181818182
65827, 1.2869565217391, 0.30652173913043, 0.27272727272727
65828, 1.2869565217391, 0.30652173913043, 0.22727272727273
