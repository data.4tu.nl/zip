74478, 1.7652173913043, 0.72391304347826, 0.15909090909091
74479, 1.7434782608696, 0.72391304347826, 0.13636363636364
74480, 1.7652173913043, 0.75, 0.13636363636364
74481, 1.7652173913043, 0.72391304347826, 0.11363636363636
74482, 1.7434782608696, 0.72391304347826, 0.090909090909091
74483, 1.7652173913043, 0.75, 0.090909090909091
74484, 1.7652173913043, 0.72391304347826, 0.068181818181818
74485, 1.7434782608696, 0.72391304347826, 0.045454545454545
74486, 1.7652173913043, 0.75, 0.045454545454545
74487, 1.7652173913043, 0.72391304347826, 0.022727272727273
74488, 1.8086956521739, 0.72391304347826, 0.47727272727273
74489, 1.7869565217391, 0.72391304347826, 0.45454545454545
74490, 1.8086956521739, 0.75, 0.45454545454545
74491, 1.8086956521739, 0.72391304347826, 0.43181818181818
74492, 1.7869565217391, 0.72391304347826, 0.40909090909091
74493, 1.8086956521739, 0.75, 0.40909090909091
74494, 1.8086956521739, 0.72391304347826, 0.38636363636364
74495, 1.7869565217391, 0.72391304347826, 0.36363636363636
74496, 1.8086956521739, 0.75, 0.36363636363636
74497, 1.8086956521739, 0.72391304347826, 0.34090909090909
74498, 1.7869565217391, 0.72391304347826, 0.31818181818182
74499, 1.8086956521739, 0.75, 0.31818181818182
74500, 1.8086956521739, 0.72391304347826, 0.29545454545455
74501, 1.7869565217391, 0.72391304347826, 0.27272727272727
74502, 1.8086956521739, 0.75, 0.27272727272727
74503, 1.8086956521739, 0.72391304347826, 0.25
74504, 1.7869565217391, 0.72391304347826, 0.22727272727273
74505, 1.8086956521739, 0.75, 0.22727272727273
74506, 1.8086956521739, 0.72391304347826, 0.20454545454545
74507, 1.7869565217391, 0.72391304347826, 0.18181818181818
74508, 1.8086956521739, 0.75, 0.18181818181818
74509, 1.8086956521739, 0.72391304347826, 0.15909090909091
74510, 1.7869565217391, 0.72391304347826, 0.13636363636364
74511, 1.8086956521739, 0.75, 0.13636363636364
74512, 1.8086956521739, 0.72391304347826, 0.11363636363636
74513, 1.7869565217391, 0.72391304347826, 0.090909090909091
74514, 1.8086956521739, 0.75, 0.090909090909091
74515, 1.8086956521739, 0.72391304347826, 0.068181818181818
74516, 1.7869565217391, 0.72391304347826, 0.045454545454545
74517, 1.8086956521739, 0.75, 0.045454545454545
74518, 1.8086956521739, 0.72391304347826, 0.022727272727273
74519, 1.8521739130435, 0.72391304347826, 0.47727272727273
74520, 1.8304347826087, 0.72391304347826, 0.45454545454545
74521, 1.8521739130435, 0.75, 0.45454545454545
74522, 1.8521739130435, 0.72391304347826, 0.43181818181818
74523, 1.8304347826087, 0.72391304347826, 0.40909090909091
74524, 1.8521739130435, 0.75, 0.40909090909091
74525, 1.8521739130435, 0.72391304347826, 0.38636363636364
74526, 1.8304347826087, 0.72391304347826, 0.36363636363636
74527, 1.8521739130435, 0.75, 0.36363636363636
74528, 1.8521739130435, 0.72391304347826, 0.34090909090909
74529, 1.8304347826087, 0.72391304347826, 0.31818181818182
74530, 1.8521739130435, 0.75, 0.31818181818182
74531, 1.8521739130435, 0.72391304347826, 0.29545454545455
74532, 1.8304347826087, 0.72391304347826, 0.27272727272727
74533, 1.8521739130435, 0.75, 0.27272727272727
74534, 1.8521739130435, 0.72391304347826, 0.25
74535, 1.8304347826087, 0.72391304347826, 0.22727272727273
74536, 1.8521739130435, 0.75, 0.22727272727273
74537, 1.8521739130435, 0.72391304347826, 0.20454545454545
74538, 1.8304347826087, 0.72391304347826, 0.18181818181818
74539, 1.8521739130435, 0.75, 0.18181818181818
74540, 1.8521739130435, 0.72391304347826, 0.15909090909091
74541, 1.8304347826087, 0.72391304347826, 0.13636363636364
74542, 1.8521739130435, 0.75, 0.13636363636364
74543, 1.8521739130435, 0.72391304347826, 0.11363636363636
74544, 1.8304347826087, 0.72391304347826, 0.090909090909091
74545, 1.8521739130435, 0.75, 0.090909090909091
74546, 1.8521739130435, 0.72391304347826, 0.068181818181818
74547, 1.8304347826087, 0.72391304347826, 0.045454545454545
74548, 1.8521739130435, 0.75, 0.045454545454545
74549, 1.8521739130435, 0.72391304347826, 0.022727272727273
74550, 1.895652173913, 0.72391304347826, 0.47727272727273
74551, 1.8739130434783, 0.72391304347826, 0.45454545454545
74552, 1.895652173913, 0.75, 0.45454545454545
74553, 1.895652173913, 0.72391304347826, 0.43181818181818
74554, 1.8739130434783, 0.72391304347826, 0.40909090909091
74555, 1.895652173913, 0.75, 0.40909090909091
74556, 1.895652173913, 0.72391304347826, 0.38636363636364
74557, 1.8739130434783, 0.72391304347826, 0.36363636363636
74558, 1.895652173913, 0.75, 0.36363636363636
74559, 1.895652173913, 0.72391304347826, 0.34090909090909
74560, 1.8739130434783, 0.72391304347826, 0.31818181818182
74561, 1.895652173913, 0.75, 0.31818181818182
74562, 1.895652173913, 0.72391304347826, 0.29545454545455
74563, 1.8739130434783, 0.72391304347826, 0.27272727272727
74564, 1.895652173913, 0.75, 0.27272727272727
74565, 1.895652173913, 0.72391304347826, 0.25
74566, 1.8739130434783, 0.72391304347826, 0.22727272727273
74567, 1.895652173913, 0.75, 0.22727272727273
74568, 1.895652173913, 0.72391304347826, 0.20454545454545
74569, 1.8739130434783, 0.72391304347826, 0.18181818181818
74570, 1.895652173913, 0.75, 0.18181818181818
74571, 1.895652173913, 0.72391304347826, 0.15909090909091
74572, 1.8739130434783, 0.72391304347826, 0.13636363636364
74573, 1.895652173913, 0.75, 0.13636363636364
74574, 1.895652173913, 0.72391304347826, 0.11363636363636
74575, 1.8739130434783, 0.72391304347826, 0.090909090909091
74576, 1.895652173913, 0.75, 0.090909090909091
74577, 1.895652173913, 0.72391304347826, 0.068181818181818
74578, 1.8739130434783, 0.72391304347826, 0.045454545454545
74579, 1.895652173913, 0.75, 0.045454545454545
74580, 1.895652173913, 0.72391304347826, 0.022727272727273
74581, 1.9391304347826, 0.72391304347826, 0.47727272727273
74582, 1.9173913043478, 0.72391304347826, 0.45454545454545
74583, 1.9391304347826, 0.75, 0.45454545454545
74584, 1.9391304347826, 0.72391304347826, 0.43181818181818
74585, 1.9173913043478, 0.72391304347826, 0.40909090909091
74586, 1.9391304347826, 0.75, 0.40909090909091
74587, 1.9391304347826, 0.72391304347826, 0.38636363636364
74588, 1.9173913043478, 0.72391304347826, 0.36363636363636
74589, 1.9391304347826, 0.75, 0.36363636363636
74590, 1.9391304347826, 0.72391304347826, 0.34090909090909
74591, 1.9173913043478, 0.72391304347826, 0.31818181818182
74592, 1.9391304347826, 0.75, 0.31818181818182
74593, 1.9391304347826, 0.72391304347826, 0.29545454545455
74594, 1.9173913043478, 0.72391304347826, 0.27272727272727
74595, 1.9391304347826, 0.75, 0.27272727272727
74596, 1.9391304347826, 0.72391304347826, 0.25
74597, 1.9173913043478, 0.72391304347826, 0.22727272727273
74598, 1.9391304347826, 0.75, 0.22727272727273
74599, 1.9391304347826, 0.72391304347826, 0.20454545454545
74600, 1.9173913043478, 0.72391304347826, 0.18181818181818
74601, 1.9391304347826, 0.75, 0.18181818181818
74602, 1.9391304347826, 0.72391304347826, 0.15909090909091
74603, 1.9173913043478, 0.72391304347826, 0.13636363636364
74604, 1.9391304347826, 0.75, 0.13636363636364
74605, 1.9391304347826, 0.72391304347826, 0.11363636363636
74606, 1.9173913043478, 0.72391304347826, 0.090909090909091
74607, 1.9391304347826, 0.75, 0.090909090909091
74608, 1.9391304347826, 0.72391304347826, 0.068181818181818
74609, 1.9173913043478, 0.72391304347826, 0.045454545454545
74610, 1.9391304347826, 0.75, 0.045454545454545
74611, 1.9391304347826, 0.72391304347826, 0.022727272727273
74612, 1.9826086956522, 0.72391304347826, 0.47727272727273
74613, 1.9608695652174, 0.72391304347826, 0.45454545454545
74614, 1.9826086956522, 0.75, 0.45454545454545
74615, 1.9826086956522, 0.72391304347826, 0.43181818181818
74616, 1.9608695652174, 0.72391304347826, 0.40909090909091
74617, 1.9826086956522, 0.75, 0.40909090909091
74618, 1.9826086956522, 0.72391304347826, 0.38636363636364
74619, 1.9608695652174, 0.72391304347826, 0.36363636363636
74620, 1.9826086956522, 0.75, 0.36363636363636
74621, 1.9826086956522, 0.72391304347826, 0.34090909090909
74622, 1.9608695652174, 0.72391304347826, 0.31818181818182
74623, 1.9826086956522, 0.75, 0.31818181818182
74624, 1.9826086956522, 0.72391304347826, 0.29545454545455
74625, 1.9608695652174, 0.72391304347826, 0.27272727272727
74626, 1.9826086956522, 0.75, 0.27272727272727
74627, 1.9826086956522, 0.72391304347826, 0.25
74628, 1.9608695652174, 0.72391304347826, 0.22727272727273
74629, 1.9826086956522, 0.75, 0.22727272727273
74630, 1.9826086956522, 0.72391304347826, 0.20454545454545
74631, 1.9608695652174, 0.72391304347826, 0.18181818181818
74632, 1.9826086956522, 0.75, 0.18181818181818
74633, 1.9826086956522, 0.72391304347826, 0.15909090909091
74634, 1.9608695652174, 0.72391304347826, 0.13636363636364
74635, 1.9826086956522, 0.75, 0.13636363636364
74636, 1.9826086956522, 0.72391304347826, 0.11363636363636
74637, 1.9608695652174, 0.72391304347826, 0.090909090909091
74638, 1.9826086956522, 0.75, 0.090909090909091
74639, 1.9826086956522, 0.72391304347826, 0.068181818181818
74640, 1.9608695652174, 0.72391304347826, 0.045454545454545
74641, 1.9826086956522, 0.75, 0.045454545454545
74642, 1.9826086956522, 0.72391304347826, 0.022727272727273
74643, 2.0260869565217, 0.72391304347826, 0.47727272727273
74644, 2.004347826087, 0.72391304347826, 0.45454545454545
74645, 2.0260869565217, 0.75, 0.45454545454545
74646, 2.0260869565217, 0.72391304347826, 0.43181818181818
74647, 2.004347826087, 0.72391304347826, 0.40909090909091
74648, 2.0260869565217, 0.75, 0.40909090909091
74649, 2.0260869565217, 0.72391304347826, 0.38636363636364
74650, 2.004347826087, 0.72391304347826, 0.36363636363636
74651, 2.0260869565217, 0.75, 0.36363636363636
74652, 2.0260869565217, 0.72391304347826, 0.34090909090909
74653, 2.004347826087, 0.72391304347826, 0.31818181818182
74654, 2.0260869565217, 0.75, 0.31818181818182
74655, 2.0260869565217, 0.72391304347826, 0.29545454545455
74656, 2.004347826087, 0.72391304347826, 0.27272727272727
74657, 2.0260869565217, 0.75, 0.27272727272727
74658, 2.0260869565217, 0.72391304347826, 0.25
74659, 2.004347826087, 0.72391304347826, 0.22727272727273
74660, 2.0260869565217, 0.75, 0.22727272727273
74661, 2.0260869565217, 0.72391304347826, 0.20454545454545
74662, 2.004347826087, 0.72391304347826, 0.18181818181818
74663, 2.0260869565217, 0.75, 0.18181818181818
74664, 2.0260869565217, 0.72391304347826, 0.15909090909091
74665, 2.004347826087, 0.72391304347826, 0.13636363636364
74666, 2.0260869565217, 0.75, 0.13636363636364
74667, 2.0260869565217, 0.72391304347826, 0.11363636363636
74668, 2.004347826087, 0.72391304347826, 0.090909090909091
74669, 2.0260869565217, 0.75, 0.090909090909091
74670, 2.0260869565217, 0.72391304347826, 0.068181818181818
74671, 2.004347826087, 0.72391304347826, 0.045454545454545
74672, 2.0260869565217, 0.75, 0.045454545454545
74673, 2.0260869565217, 0.72391304347826, 0.022727272727273
74674, 2.0695652173913, 0.72391304347826, 0.47727272727273
74675, 2.0478260869565, 0.72391304347826, 0.45454545454545
74676, 2.0695652173913, 0.75, 0.45454545454545
74677, 2.0695652173913, 0.72391304347826, 0.43181818181818
74678, 2.0478260869565, 0.72391304347826, 0.40909090909091
74679, 2.0695652173913, 0.75, 0.40909090909091
74680, 2.0695652173913, 0.72391304347826, 0.38636363636364
74681, 2.0478260869565, 0.72391304347826, 0.36363636363636
74682, 2.0695652173913, 0.75, 0.36363636363636
74683, 2.0695652173913, 0.72391304347826, 0.34090909090909
74684, 2.0478260869565, 0.72391304347826, 0.31818181818182
74685, 2.0695652173913, 0.75, 0.31818181818182
74686, 2.0695652173913, 0.72391304347826, 0.29545454545455
74687, 2.0478260869565, 0.72391304347826, 0.27272727272727
74688, 2.0695652173913, 0.75, 0.27272727272727
74689, 2.0695652173913, 0.72391304347826, 0.25
74690, 2.0478260869565, 0.72391304347826, 0.22727272727273
74691, 2.0695652173913, 0.75, 0.22727272727273
74692, 2.0695652173913, 0.72391304347826, 0.20454545454545
74693, 2.0478260869565, 0.72391304347826, 0.18181818181818
74694, 2.0695652173913, 0.75, 0.18181818181818
74695, 2.0695652173913, 0.72391304347826, 0.15909090909091
74696, 2.0478260869565, 0.72391304347826, 0.13636363636364
74697, 2.0695652173913, 0.75, 0.13636363636364
74698, 2.0695652173913, 0.72391304347826, 0.11363636363636
74699, 2.0478260869565, 0.72391304347826, 0.090909090909091
74700, 2.0695652173913, 0.75, 0.090909090909091
74701, 2.0695652173913, 0.72391304347826, 0.068181818181818
74702, 2.0478260869565, 0.72391304347826, 0.045454545454545
74703, 2.0695652173913, 0.75, 0.045454545454545
74704, 2.0695652173913, 0.72391304347826, 0.022727272727273
74705, 2.1130434782609, 0.72391304347826, 0.47727272727273
74706, 2.0913043478261, 0.72391304347826, 0.45454545454545
74707, 2.1130434782609, 0.75, 0.45454545454545
74708, 2.1130434782609, 0.72391304347826, 0.43181818181818
74709, 2.0913043478261, 0.72391304347826, 0.40909090909091
74710, 2.1130434782609, 0.75, 0.40909090909091
74711, 2.1130434782609, 0.72391304347826, 0.38636363636364
74712, 2.0913043478261, 0.72391304347826, 0.36363636363636
74713, 2.1130434782609, 0.75, 0.36363636363636
74714, 2.1130434782609, 0.72391304347826, 0.34090909090909
74715, 2.0913043478261, 0.72391304347826, 0.31818181818182
74716, 2.1130434782609, 0.75, 0.31818181818182
74717, 2.1130434782609, 0.72391304347826, 0.29545454545455
74718, 2.0913043478261, 0.72391304347826, 0.27272727272727
74719, 2.1130434782609, 0.75, 0.27272727272727
74720, 2.1130434782609, 0.72391304347826, 0.25
74721, 2.0913043478261, 0.72391304347826, 0.22727272727273
74722, 2.1130434782609, 0.75, 0.22727272727273
74723, 2.1130434782609, 0.72391304347826, 0.20454545454545
74724, 2.0913043478261, 0.72391304347826, 0.18181818181818
74725, 2.1130434782609, 0.75, 0.18181818181818
74726, 2.1130434782609, 0.72391304347826, 0.15909090909091
74727, 2.0913043478261, 0.72391304347826, 0.13636363636364
74728, 2.1130434782609, 0.75, 0.13636363636364
74729, 2.1130434782609, 0.72391304347826, 0.11363636363636
74730, 2.0913043478261, 0.72391304347826, 0.090909090909091
74731, 2.1130434782609, 0.75, 0.090909090909091
74732, 2.1130434782609, 0.72391304347826, 0.068181818181818
74733, 2.0913043478261, 0.72391304347826, 0.045454545454545
74734, 2.1130434782609, 0.75, 0.045454545454545
74735, 2.1130434782609, 0.72391304347826, 0.022727272727273
74736, 2.1565217391304, 0.72391304347826, 0.47727272727273
74737, 2.1347826086957, 0.72391304347826, 0.45454545454545
74738, 2.1565217391304, 0.75, 0.45454545454545
74739, 2.1565217391304, 0.72391304347826, 0.43181818181818
74740, 2.1347826086957, 0.72391304347826, 0.40909090909091
74741, 2.1565217391304, 0.75, 0.40909090909091
74742, 2.1565217391304, 0.72391304347826, 0.38636363636364
74743, 2.1347826086957, 0.72391304347826, 0.36363636363636
74744, 2.1565217391304, 0.75, 0.36363636363636
74745, 2.1565217391304, 0.72391304347826, 0.34090909090909
74746, 2.1347826086957, 0.72391304347826, 0.31818181818182
74747, 2.1565217391304, 0.75, 0.31818181818182
74748, 2.1565217391304, 0.72391304347826, 0.29545454545455
74749, 2.1347826086957, 0.72391304347826, 0.27272727272727
74750, 2.1565217391304, 0.75, 0.27272727272727
74751, 2.1565217391304, 0.72391304347826, 0.25
74752, 2.1347826086957, 0.72391304347826, 0.22727272727273
74753, 2.1565217391304, 0.75, 0.22727272727273
74754, 2.1565217391304, 0.72391304347826, 0.20454545454545
74755, 2.1347826086957, 0.72391304347826, 0.18181818181818
74756, 2.1565217391304, 0.75, 0.18181818181818
74757, 2.1565217391304, 0.72391304347826, 0.15909090909091
74758, 2.1347826086957, 0.72391304347826, 0.13636363636364
74759, 2.1565217391304, 0.75, 0.13636363636364
74760, 2.1565217391304, 0.72391304347826, 0.11363636363636
74761, 2.1347826086957, 0.72391304347826, 0.090909090909091
74762, 2.1565217391304, 0.75, 0.090909090909091
74763, 2.1565217391304, 0.72391304347826, 0.068181818181818
74764, 2.1347826086957, 0.72391304347826, 0.045454545454545
74765, 2.1565217391304, 0.75, 0.045454545454545
74766, 2.1565217391304, 0.72391304347826, 0.022727272727273
74767, 2.1782608695652, 0.72391304347826, 0.45454545454545
74768, 2.1782608695652, 0.72391304347826, 0.40909090909091
74769, 2.1782608695652, 0.72391304347826, 0.36363636363636
74770, 2.1782608695652, 0.72391304347826, 0.31818181818182
74771, 2.1782608695652, 0.72391304347826, 0.27272727272727
74772, 2.1782608695652, 0.72391304347826, 0.22727272727273
74773, 2.1782608695652, 0.72391304347826, 0.18181818181818
74774, 2.1782608695652, 0.72391304347826, 0.13636363636364
74775, 2.1782608695652, 0.72391304347826, 0.090909090909091
74776, 2.1782608695652, 0.72391304347826, 0.045454545454545
74777, 1.2434782608696, 0.67173913043478, 0.47727272727273
74778, 1.2217391304348, 0.67173913043478, 0.45454545454545
74779, 1.2434782608696, 0.69782608695652, 0.45454545454545
74780, 1.2434782608696, 0.67173913043478, 0.43181818181818
74781, 1.2217391304348, 0.67173913043478, 0.40909090909091
74782, 1.2434782608696, 0.69782608695652, 0.40909090909091
74783, 1.2434782608696, 0.67173913043478, 0.38636363636364
74784, 1.2217391304348, 0.67173913043478, 0.36363636363636
74785, 1.2434782608696, 0.69782608695652, 0.36363636363636
74786, 1.2434782608696, 0.67173913043478, 0.34090909090909
74787, 1.2217391304348, 0.67173913043478, 0.31818181818182
74788, 1.2434782608696, 0.69782608695652, 0.31818181818182
74789, 1.2434782608696, 0.67173913043478, 0.29545454545455
74790, 1.2217391304348, 0.67173913043478, 0.27272727272727
74791, 1.2434782608696, 0.69782608695652, 0.27272727272727
74792, 1.2434782608696, 0.67173913043478, 0.25
74793, 1.2217391304348, 0.67173913043478, 0.22727272727273
74794, 1.2434782608696, 0.69782608695652, 0.22727272727273
74795, 1.2434782608696, 0.67173913043478, 0.20454545454545
74796, 1.2217391304348, 0.67173913043478, 0.18181818181818
74797, 1.2434782608696, 0.69782608695652, 0.18181818181818
74798, 1.2434782608696, 0.67173913043478, 0.15909090909091
74799, 1.2217391304348, 0.67173913043478, 0.13636363636364
74800, 1.2434782608696, 0.69782608695652, 0.13636363636364
74801, 1.2434782608696, 0.67173913043478, 0.11363636363636
74802, 1.2217391304348, 0.67173913043478, 0.090909090909091
74803, 1.2434782608696, 0.69782608695652, 0.090909090909091
74804, 1.2434782608696, 0.67173913043478, 0.068181818181818
74805, 1.2217391304348, 0.67173913043478, 0.045454545454545
74806, 1.2434782608696, 0.69782608695652, 0.045454545454545
74807, 1.2434782608696, 0.67173913043478, 0.022727272727273
74808, 1.2869565217391, 0.67173913043478, 0.47727272727273
74809, 1.2652173913043, 0.67173913043478, 0.45454545454545
74810, 1.2869565217391, 0.69782608695652, 0.45454545454545
74811, 1.2869565217391, 0.67173913043478, 0.43181818181818
74812, 1.2652173913043, 0.67173913043478, 0.40909090909091
74813, 1.2869565217391, 0.69782608695652, 0.40909090909091
74814, 1.2869565217391, 0.67173913043478, 0.38636363636364
74815, 1.2652173913043, 0.67173913043478, 0.36363636363636
74816, 1.2869565217391, 0.69782608695652, 0.36363636363636
74817, 1.2869565217391, 0.67173913043478, 0.34090909090909
74818, 1.2652173913043, 0.67173913043478, 0.31818181818182
74819, 1.2869565217391, 0.69782608695652, 0.31818181818182
74820, 1.2869565217391, 0.67173913043478, 0.29545454545455
74821, 1.2652173913043, 0.67173913043478, 0.27272727272727
74822, 1.2869565217391, 0.69782608695652, 0.27272727272727
74823, 1.2869565217391, 0.67173913043478, 0.25
74824, 1.2652173913043, 0.67173913043478, 0.22727272727273
74825, 1.2869565217391, 0.69782608695652, 0.22727272727273
74826, 1.2869565217391, 0.67173913043478, 0.20454545454545
74827, 1.2652173913043, 0.67173913043478, 0.18181818181818
74828, 1.2869565217391, 0.69782608695652, 0.18181818181818
74829, 1.2869565217391, 0.67173913043478, 0.15909090909091
74830, 1.2652173913043, 0.67173913043478, 0.13636363636364
74831, 1.2869565217391, 0.69782608695652, 0.13636363636364
74832, 1.2869565217391, 0.67173913043478, 0.11363636363636
74833, 1.2652173913043, 0.67173913043478, 0.090909090909091
74834, 1.2869565217391, 0.69782608695652, 0.090909090909091
74835, 1.2869565217391, 0.67173913043478, 0.068181818181818
74836, 1.2652173913043, 0.67173913043478, 0.045454545454545
74837, 1.2869565217391, 0.69782608695652, 0.045454545454545
74838, 1.2869565217391, 0.67173913043478, 0.022727272727273
74839, 1.3304347826087, 0.67173913043478, 0.47727272727273
74840, 1.3086956521739, 0.67173913043478, 0.45454545454545
74841, 1.3304347826087, 0.69782608695652, 0.45454545454545
74842, 1.3304347826087, 0.67173913043478, 0.43181818181818
74843, 1.3086956521739, 0.67173913043478, 0.40909090909091
74844, 1.3304347826087, 0.69782608695652, 0.40909090909091
74845, 1.3304347826087, 0.67173913043478, 0.38636363636364
74846, 1.3086956521739, 0.67173913043478, 0.36363636363636
74847, 1.3304347826087, 0.69782608695652, 0.36363636363636
74848, 1.3304347826087, 0.67173913043478, 0.34090909090909
74849, 1.3086956521739, 0.67173913043478, 0.31818181818182
74850, 1.3304347826087, 0.69782608695652, 0.31818181818182
74851, 1.3304347826087, 0.67173913043478, 0.29545454545455
74852, 1.3086956521739, 0.67173913043478, 0.27272727272727
74853, 1.3304347826087, 0.69782608695652, 0.27272727272727
74854, 1.3304347826087, 0.67173913043478, 0.25
74855, 1.3086956521739, 0.67173913043478, 0.22727272727273
74856, 1.3304347826087, 0.69782608695652, 0.22727272727273
74857, 1.3304347826087, 0.67173913043478, 0.20454545454545
74858, 1.3086956521739, 0.67173913043478, 0.18181818181818
74859, 1.3304347826087, 0.69782608695652, 0.18181818181818
74860, 1.3304347826087, 0.67173913043478, 0.15909090909091
74861, 1.3086956521739, 0.67173913043478, 0.13636363636364
74862, 1.3304347826087, 0.69782608695652, 0.13636363636364
74863, 1.3304347826087, 0.67173913043478, 0.11363636363636
74864, 1.3086956521739, 0.67173913043478, 0.090909090909091
74865, 1.3304347826087, 0.69782608695652, 0.090909090909091
74866, 1.3304347826087, 0.67173913043478, 0.068181818181818
74867, 1.3086956521739, 0.67173913043478, 0.045454545454545
74868, 1.3304347826087, 0.69782608695652, 0.045454545454545
74869, 1.3304347826087, 0.67173913043478, 0.022727272727273
74870, 1.3739130434783, 0.67173913043478, 0.47727272727273
74871, 1.3521739130435, 0.67173913043478, 0.45454545454545
74872, 1.3739130434783, 0.69782608695652, 0.45454545454545
74873, 1.3739130434783, 0.67173913043478, 0.43181818181818
74874, 1.3521739130435, 0.67173913043478, 0.40909090909091
74875, 1.3739130434783, 0.69782608695652, 0.40909090909091
74876, 1.3739130434783, 0.67173913043478, 0.38636363636364
74877, 1.3521739130435, 0.67173913043478, 0.36363636363636
74878, 1.3739130434783, 0.69782608695652, 0.36363636363636
74879, 1.3739130434783, 0.67173913043478, 0.34090909090909
74880, 1.3521739130435, 0.67173913043478, 0.31818181818182
74881, 1.3739130434783, 0.69782608695652, 0.31818181818182
74882, 1.3739130434783, 0.67173913043478, 0.29545454545455
74883, 1.3521739130435, 0.67173913043478, 0.27272727272727
74884, 1.3739130434783, 0.69782608695652, 0.27272727272727
74885, 1.3739130434783, 0.67173913043478, 0.25
74886, 1.3521739130435, 0.67173913043478, 0.22727272727273
74887, 1.3739130434783, 0.69782608695652, 0.22727272727273
74888, 1.3739130434783, 0.67173913043478, 0.20454545454545
74889, 1.3521739130435, 0.67173913043478, 0.18181818181818
74890, 1.3739130434783, 0.69782608695652, 0.18181818181818
74891, 1.3739130434783, 0.67173913043478, 0.15909090909091
74892, 1.3521739130435, 0.67173913043478, 0.13636363636364
74893, 1.3739130434783, 0.69782608695652, 0.13636363636364
74894, 1.3739130434783, 0.67173913043478, 0.11363636363636
74895, 1.3521739130435, 0.67173913043478, 0.090909090909091
74896, 1.3739130434783, 0.69782608695652, 0.090909090909091
74897, 1.3739130434783, 0.67173913043478, 0.068181818181818
74898, 1.3521739130435, 0.67173913043478, 0.045454545454545
74899, 1.3739130434783, 0.69782608695652, 0.045454545454545
74900, 1.3739130434783, 0.67173913043478, 0.022727272727273
74901, 1.4173913043478, 0.67173913043478, 0.47727272727273
74902, 1.395652173913, 0.67173913043478, 0.45454545454545
74903, 1.4173913043478, 0.69782608695652, 0.45454545454545
74904, 1.4173913043478, 0.67173913043478, 0.43181818181818
74905, 1.395652173913, 0.67173913043478, 0.40909090909091
74906, 1.4173913043478, 0.69782608695652, 0.40909090909091
74907, 1.4173913043478, 0.67173913043478, 0.38636363636364
74908, 1.395652173913, 0.67173913043478, 0.36363636363636
74909, 1.4173913043478, 0.69782608695652, 0.36363636363636
74910, 1.4173913043478, 0.67173913043478, 0.34090909090909
74911, 1.395652173913, 0.67173913043478, 0.31818181818182
74912, 1.4173913043478, 0.69782608695652, 0.31818181818182
74913, 1.4173913043478, 0.67173913043478, 0.29545454545455
74914, 1.395652173913, 0.67173913043478, 0.27272727272727
74915, 1.4173913043478, 0.69782608695652, 0.27272727272727
74916, 1.4173913043478, 0.67173913043478, 0.25
74917, 1.395652173913, 0.67173913043478, 0.22727272727273
74918, 1.4173913043478, 0.69782608695652, 0.22727272727273
74919, 1.4173913043478, 0.67173913043478, 0.20454545454545
74920, 1.395652173913, 0.67173913043478, 0.18181818181818
74921, 1.4173913043478, 0.69782608695652, 0.18181818181818
74922, 1.4173913043478, 0.67173913043478, 0.15909090909091
74923, 1.395652173913, 0.67173913043478, 0.13636363636364
74924, 1.4173913043478, 0.69782608695652, 0.13636363636364
74925, 1.4173913043478, 0.67173913043478, 0.11363636363636
74926, 1.395652173913, 0.67173913043478, 0.090909090909091
74927, 1.4173913043478, 0.69782608695652, 0.090909090909091
74928, 1.4173913043478, 0.67173913043478, 0.068181818181818
74929, 1.395652173913, 0.67173913043478, 0.045454545454545
74930, 1.4173913043478, 0.69782608695652, 0.045454545454545
74931, 1.4173913043478, 0.67173913043478, 0.022727272727273
74932, 1.4608695652174, 0.67173913043478, 0.47727272727273
74933, 1.4391304347826, 0.67173913043478, 0.45454545454545
74934, 1.4608695652174, 0.69782608695652, 0.45454545454545
74935, 1.4608695652174, 0.67173913043478, 0.43181818181818
74936, 1.4391304347826, 0.67173913043478, 0.40909090909091
74937, 1.4608695652174, 0.69782608695652, 0.40909090909091
74938, 1.4608695652174, 0.67173913043478, 0.38636363636364
74939, 1.4391304347826, 0.67173913043478, 0.36363636363636
74940, 1.4608695652174, 0.69782608695652, 0.36363636363636
74941, 1.4608695652174, 0.67173913043478, 0.34090909090909
74942, 1.4391304347826, 0.67173913043478, 0.31818181818182
74943, 1.4608695652174, 0.69782608695652, 0.31818181818182
74944, 1.4608695652174, 0.67173913043478, 0.29545454545455
74945, 1.4391304347826, 0.67173913043478, 0.27272727272727
74946, 1.4608695652174, 0.69782608695652, 0.27272727272727
74947, 1.4608695652174, 0.67173913043478, 0.25
74948, 1.4391304347826, 0.67173913043478, 0.22727272727273
74949, 1.4608695652174, 0.69782608695652, 0.22727272727273
74950, 1.4608695652174, 0.67173913043478, 0.20454545454545
74951, 1.4391304347826, 0.67173913043478, 0.18181818181818
74952, 1.4608695652174, 0.69782608695652, 0.18181818181818
74953, 1.4608695652174, 0.67173913043478, 0.15909090909091
74954, 1.4391304347826, 0.67173913043478, 0.13636363636364
74955, 1.4608695652174, 0.69782608695652, 0.13636363636364
74956, 1.4608695652174, 0.67173913043478, 0.11363636363636
74957, 1.4391304347826, 0.67173913043478, 0.090909090909091
74958, 1.4608695652174, 0.69782608695652, 0.090909090909091
74959, 1.4608695652174, 0.67173913043478, 0.068181818181818
74960, 1.4391304347826, 0.67173913043478, 0.045454545454545
74961, 1.4608695652174, 0.69782608695652, 0.045454545454545
74962, 1.4608695652174, 0.67173913043478, 0.022727272727273
74963, 1.504347826087, 0.67173913043478, 0.47727272727273
74964, 1.4826086956522, 0.67173913043478, 0.45454545454545
74965, 1.504347826087, 0.69782608695652, 0.45454545454545
74966, 1.504347826087, 0.67173913043478, 0.43181818181818
74967, 1.4826086956522, 0.67173913043478, 0.40909090909091
74968, 1.504347826087, 0.69782608695652, 0.40909090909091
74969, 1.504347826087, 0.67173913043478, 0.38636363636364
74970, 1.4826086956522, 0.67173913043478, 0.36363636363636
74971, 1.504347826087, 0.69782608695652, 0.36363636363636
74972, 1.504347826087, 0.67173913043478, 0.34090909090909
74973, 1.4826086956522, 0.67173913043478, 0.31818181818182
74974, 1.504347826087, 0.69782608695652, 0.31818181818182
74975, 1.504347826087, 0.67173913043478, 0.29545454545455
74976, 1.4826086956522, 0.67173913043478, 0.27272727272727
74977, 1.504347826087, 0.69782608695652, 0.27272727272727
74978, 1.504347826087, 0.67173913043478, 0.25
74979, 1.4826086956522, 0.67173913043478, 0.22727272727273
74980, 1.504347826087, 0.69782608695652, 0.22727272727273
74981, 1.504347826087, 0.67173913043478, 0.20454545454545
74982, 1.4826086956522, 0.67173913043478, 0.18181818181818
74983, 1.504347826087, 0.69782608695652, 0.18181818181818
74984, 1.504347826087, 0.67173913043478, 0.15909090909091
74985, 1.4826086956522, 0.67173913043478, 0.13636363636364
74986, 1.504347826087, 0.69782608695652, 0.13636363636364
74987, 1.504347826087, 0.67173913043478, 0.11363636363636
74988, 1.4826086956522, 0.67173913043478, 0.090909090909091
74989, 1.504347826087, 0.69782608695652, 0.090909090909091
74990, 1.504347826087, 0.67173913043478, 0.068181818181818
74991, 1.4826086956522, 0.67173913043478, 0.045454545454545
74992, 1.504347826087, 0.69782608695652, 0.045454545454545
74993, 1.504347826087, 0.67173913043478, 0.022727272727273
74994, 1.5478260869565, 0.67173913043478, 0.47727272727273
74995, 1.5260869565217, 0.67173913043478, 0.45454545454545
74996, 1.5478260869565, 0.69782608695652, 0.45454545454545
74997, 1.5478260869565, 0.67173913043478, 0.43181818181818
74998, 1.5260869565217, 0.67173913043478, 0.40909090909091
74999, 1.5478260869565, 0.69782608695652, 0.40909090909091
75000, 1.5478260869565, 0.67173913043478, 0.38636363636364
75001, 1.5260869565217, 0.67173913043478, 0.36363636363636
75002, 1.5478260869565, 0.69782608695652, 0.36363636363636
75003, 1.5478260869565, 0.67173913043478, 0.34090909090909
75004, 1.5260869565217, 0.67173913043478, 0.31818181818182
75005, 1.5478260869565, 0.69782608695652, 0.31818181818182
75006, 1.5478260869565, 0.67173913043478, 0.29545454545455
75007, 1.5260869565217, 0.67173913043478, 0.27272727272727
75008, 1.5478260869565, 0.69782608695652, 0.27272727272727
75009, 1.5478260869565, 0.67173913043478, 0.25
75010, 1.5260869565217, 0.67173913043478, 0.22727272727273
75011, 1.5478260869565, 0.69782608695652, 0.22727272727273
75012, 1.5478260869565, 0.67173913043478, 0.20454545454545
75013, 1.5260869565217, 0.67173913043478, 0.18181818181818
75014, 1.5478260869565, 0.69782608695652, 0.18181818181818
75015, 1.5478260869565, 0.67173913043478, 0.15909090909091
75016, 1.5260869565217, 0.67173913043478, 0.13636363636364
75017, 1.5478260869565, 0.69782608695652, 0.13636363636364
75018, 1.5478260869565, 0.67173913043478, 0.11363636363636
75019, 1.5260869565217, 0.67173913043478, 0.090909090909091
75020, 1.5478260869565, 0.69782608695652, 0.090909090909091
75021, 1.5478260869565, 0.67173913043478, 0.068181818181818
75022, 1.5260869565217, 0.67173913043478, 0.045454545454545
75023, 1.5478260869565, 0.69782608695652, 0.045454545454545
75024, 1.5478260869565, 0.67173913043478, 0.022727272727273
75025, 1.5913043478261, 0.67173913043478, 0.47727272727273
75026, 1.5695652173913, 0.67173913043478, 0.45454545454545
75027, 1.5913043478261, 0.69782608695652, 0.45454545454545
75028, 1.5913043478261, 0.67173913043478, 0.43181818181818
75029, 1.5695652173913, 0.67173913043478, 0.40909090909091
75030, 1.5913043478261, 0.69782608695652, 0.40909090909091
75031, 1.5913043478261, 0.67173913043478, 0.38636363636364
75032, 1.5695652173913, 0.67173913043478, 0.36363636363636
75033, 1.5913043478261, 0.69782608695652, 0.36363636363636
75034, 1.5913043478261, 0.67173913043478, 0.34090909090909
75035, 1.5695652173913, 0.67173913043478, 0.31818181818182
75036, 1.5913043478261, 0.69782608695652, 0.31818181818182
75037, 1.5913043478261, 0.67173913043478, 0.29545454545455
75038, 1.5695652173913, 0.67173913043478, 0.27272727272727
75039, 1.5913043478261, 0.69782608695652, 0.27272727272727
75040, 1.5913043478261, 0.67173913043478, 0.25
75041, 1.5695652173913, 0.67173913043478, 0.22727272727273
75042, 1.5913043478261, 0.69782608695652, 0.22727272727273
75043, 1.5913043478261, 0.67173913043478, 0.20454545454545
75044, 1.5695652173913, 0.67173913043478, 0.18181818181818
75045, 1.5913043478261, 0.69782608695652, 0.18181818181818
75046, 1.5913043478261, 0.67173913043478, 0.15909090909091
75047, 1.5695652173913, 0.67173913043478, 0.13636363636364
75048, 1.5913043478261, 0.69782608695652, 0.13636363636364
75049, 1.5913043478261, 0.67173913043478, 0.11363636363636
75050, 1.5695652173913, 0.67173913043478, 0.090909090909091
75051, 1.5913043478261, 0.69782608695652, 0.090909090909091
75052, 1.5913043478261, 0.67173913043478, 0.068181818181818
75053, 1.5695652173913, 0.67173913043478, 0.045454545454545
75054, 1.5913043478261, 0.69782608695652, 0.045454545454545
75055, 1.5913043478261, 0.67173913043478, 0.022727272727273
75056, 1.6347826086957, 0.67173913043478, 0.47727272727273
75057, 1.6130434782609, 0.67173913043478, 0.45454545454545
75058, 1.6347826086957, 0.69782608695652, 0.45454545454545
75059, 1.6347826086957, 0.67173913043478, 0.43181818181818
75060, 1.6130434782609, 0.67173913043478, 0.40909090909091
75061, 1.6347826086957, 0.69782608695652, 0.40909090909091
75062, 1.6347826086957, 0.67173913043478, 0.38636363636364
75063, 1.6130434782609, 0.67173913043478, 0.36363636363636
75064, 1.6347826086957, 0.69782608695652, 0.36363636363636
75065, 1.6347826086957, 0.67173913043478, 0.34090909090909
75066, 1.6130434782609, 0.67173913043478, 0.31818181818182
75067, 1.6347826086957, 0.69782608695652, 0.31818181818182
75068, 1.6347826086957, 0.67173913043478, 0.29545454545455
75069, 1.6130434782609, 0.67173913043478, 0.27272727272727
75070, 1.6347826086957, 0.69782608695652, 0.27272727272727
75071, 1.6347826086957, 0.67173913043478, 0.25
75072, 1.6130434782609, 0.67173913043478, 0.22727272727273
75073, 1.6347826086957, 0.69782608695652, 0.22727272727273
75074, 1.6347826086957, 0.67173913043478, 0.20454545454545
75075, 1.6130434782609, 0.67173913043478, 0.18181818181818
75076, 1.6347826086957, 0.69782608695652, 0.18181818181818
75077, 1.6347826086957, 0.67173913043478, 0.15909090909091
75078, 1.6130434782609, 0.67173913043478, 0.13636363636364
75079, 1.6347826086957, 0.69782608695652, 0.13636363636364
75080, 1.6347826086957, 0.67173913043478, 0.11363636363636
75081, 1.6130434782609, 0.67173913043478, 0.090909090909091
75082, 1.6347826086957, 0.69782608695652, 0.090909090909091
75083, 1.6347826086957, 0.67173913043478, 0.068181818181818
75084, 1.6130434782609, 0.67173913043478, 0.045454545454545
75085, 1.6347826086957, 0.69782608695652, 0.045454545454545
75086, 1.6347826086957, 0.67173913043478, 0.022727272727273
75087, 1.6782608695652, 0.67173913043478, 0.47727272727273
75088, 1.6565217391304, 0.67173913043478, 0.45454545454545
75089, 1.6782608695652, 0.69782608695652, 0.45454545454545
75090, 1.6782608695652, 0.67173913043478, 0.43181818181818
75091, 1.6565217391304, 0.67173913043478, 0.40909090909091
75092, 1.6782608695652, 0.69782608695652, 0.40909090909091
75093, 1.6782608695652, 0.67173913043478, 0.38636363636364
75094, 1.6565217391304, 0.67173913043478, 0.36363636363636
75095, 1.6782608695652, 0.69782608695652, 0.36363636363636
75096, 1.6782608695652, 0.67173913043478, 0.34090909090909
75097, 1.6565217391304, 0.67173913043478, 0.31818181818182
75098, 1.6782608695652, 0.69782608695652, 0.31818181818182
75099, 1.6782608695652, 0.67173913043478, 0.29545454545455
75100, 1.6565217391304, 0.67173913043478, 0.27272727272727
75101, 1.6782608695652, 0.69782608695652, 0.27272727272727
75102, 1.6782608695652, 0.67173913043478, 0.25
75103, 1.6565217391304, 0.67173913043478, 0.22727272727273
75104, 1.6782608695652, 0.69782608695652, 0.22727272727273
75105, 1.6782608695652, 0.67173913043478, 0.20454545454545
75106, 1.6565217391304, 0.67173913043478, 0.18181818181818
75107, 1.6782608695652, 0.69782608695652, 0.18181818181818
75108, 1.6782608695652, 0.67173913043478, 0.15909090909091
75109, 1.6565217391304, 0.67173913043478, 0.13636363636364
75110, 1.6782608695652, 0.69782608695652, 0.13636363636364
75111, 1.6782608695652, 0.67173913043478, 0.11363636363636
75112, 1.6565217391304, 0.67173913043478, 0.090909090909091
75113, 1.6782608695652, 0.69782608695652, 0.090909090909091
75114, 1.6782608695652, 0.67173913043478, 0.068181818181818
75115, 1.6565217391304, 0.67173913043478, 0.045454545454545
75116, 1.6782608695652, 0.69782608695652, 0.045454545454545
75117, 1.6782608695652, 0.67173913043478, 0.022727272727273
75118, 1.7217391304348, 0.67173913043478, 0.47727272727273
75119, 1.7, 0.67173913043478, 0.45454545454545
75120, 1.7217391304348, 0.69782608695652, 0.45454545454545
75121, 1.7217391304348, 0.67173913043478, 0.43181818181818
75122, 1.7, 0.67173913043478, 0.40909090909091
75123, 1.7217391304348, 0.69782608695652, 0.40909090909091
75124, 1.7217391304348, 0.67173913043478, 0.38636363636364
75125, 1.7, 0.67173913043478, 0.36363636363636
75126, 1.7217391304348, 0.69782608695652, 0.36363636363636
75127, 1.7217391304348, 0.67173913043478, 0.34090909090909
75128, 1.7, 0.67173913043478, 0.31818181818182
75129, 1.7217391304348, 0.69782608695652, 0.31818181818182
75130, 1.7217391304348, 0.67173913043478, 0.29545454545455
75131, 1.7, 0.67173913043478, 0.27272727272727
75132, 1.7217391304348, 0.69782608695652, 0.27272727272727
75133, 1.7217391304348, 0.67173913043478, 0.25
75134, 1.7, 0.67173913043478, 0.22727272727273
75135, 1.7217391304348, 0.69782608695652, 0.22727272727273
75136, 1.7217391304348, 0.67173913043478, 0.20454545454545
75137, 1.7, 0.67173913043478, 0.18181818181818
75138, 1.7217391304348, 0.69782608695652, 0.18181818181818
75139, 1.7217391304348, 0.67173913043478, 0.15909090909091
75140, 1.7, 0.67173913043478, 0.13636363636364
75141, 1.7217391304348, 0.69782608695652, 0.13636363636364
75142, 1.7217391304348, 0.67173913043478, 0.11363636363636
75143, 1.7, 0.67173913043478, 0.090909090909091
75144, 1.7217391304348, 0.69782608695652, 0.090909090909091
75145, 1.7217391304348, 0.67173913043478, 0.068181818181818
75146, 1.7, 0.67173913043478, 0.045454545454545
75147, 1.7217391304348, 0.69782608695652, 0.045454545454545
75148, 1.7217391304348, 0.67173913043478, 0.022727272727273
75149, 1.7652173913043, 0.67173913043478, 0.47727272727273
75150, 1.7434782608696, 0.67173913043478, 0.45454545454545
75151, 1.7652173913043, 0.69782608695652, 0.45454545454545
75152, 1.7652173913043, 0.67173913043478, 0.43181818181818
75153, 1.7434782608696, 0.67173913043478, 0.40909090909091
75154, 1.7652173913043, 0.69782608695652, 0.40909090909091
75155, 1.7652173913043, 0.67173913043478, 0.38636363636364
75156, 1.7434782608696, 0.67173913043478, 0.36363636363636
75157, 1.7652173913043, 0.69782608695652, 0.36363636363636
75158, 1.7652173913043, 0.67173913043478, 0.34090909090909
75159, 1.7434782608696, 0.67173913043478, 0.31818181818182
75160, 1.7652173913043, 0.69782608695652, 0.31818181818182
75161, 1.7652173913043, 0.67173913043478, 0.29545454545455
75162, 1.7434782608696, 0.67173913043478, 0.27272727272727
75163, 1.7652173913043, 0.69782608695652, 0.27272727272727
75164, 1.7652173913043, 0.67173913043478, 0.25
75165, 1.7434782608696, 0.67173913043478, 0.22727272727273
75166, 1.7652173913043, 0.69782608695652, 0.22727272727273
75167, 1.7652173913043, 0.67173913043478, 0.20454545454545
75168, 1.7434782608696, 0.67173913043478, 0.18181818181818
75169, 1.7652173913043, 0.69782608695652, 0.18181818181818
75170, 1.7652173913043, 0.67173913043478, 0.15909090909091
75171, 1.7434782608696, 0.67173913043478, 0.13636363636364
75172, 1.7652173913043, 0.69782608695652, 0.13636363636364
75173, 1.7652173913043, 0.67173913043478, 0.11363636363636
75174, 1.7434782608696, 0.67173913043478, 0.090909090909091
75175, 1.7652173913043, 0.69782608695652, 0.090909090909091
75176, 1.7652173913043, 0.67173913043478, 0.068181818181818
75177, 1.7434782608696, 0.67173913043478, 0.045454545454545
75178, 1.7652173913043, 0.69782608695652, 0.045454545454545
75179, 1.7652173913043, 0.67173913043478, 0.022727272727273
75180, 1.8086956521739, 0.67173913043478, 0.47727272727273
75181, 1.7869565217391, 0.67173913043478, 0.45454545454545
75182, 1.8086956521739, 0.69782608695652, 0.45454545454545
75183, 1.8086956521739, 0.67173913043478, 0.43181818181818
75184, 1.7869565217391, 0.67173913043478, 0.40909090909091
75185, 1.8086956521739, 0.69782608695652, 0.40909090909091
75186, 1.8086956521739, 0.67173913043478, 0.38636363636364
75187, 1.7869565217391, 0.67173913043478, 0.36363636363636
75188, 1.8086956521739, 0.69782608695652, 0.36363636363636
75189, 1.8086956521739, 0.67173913043478, 0.34090909090909
75190, 1.7869565217391, 0.67173913043478, 0.31818181818182
75191, 1.8086956521739, 0.69782608695652, 0.31818181818182
75192, 1.8086956521739, 0.67173913043478, 0.29545454545455
75193, 1.7869565217391, 0.67173913043478, 0.27272727272727
75194, 1.8086956521739, 0.69782608695652, 0.27272727272727
75195, 1.8086956521739, 0.67173913043478, 0.25
75196, 1.7869565217391, 0.67173913043478, 0.22727272727273
75197, 1.8086956521739, 0.69782608695652, 0.22727272727273
75198, 1.8086956521739, 0.67173913043478, 0.20454545454545
75199, 1.7869565217391, 0.67173913043478, 0.18181818181818
75200, 1.8086956521739, 0.69782608695652, 0.18181818181818
75201, 1.8086956521739, 0.67173913043478, 0.15909090909091
75202, 1.7869565217391, 0.67173913043478, 0.13636363636364
75203, 1.8086956521739, 0.69782608695652, 0.13636363636364
75204, 1.8086956521739, 0.67173913043478, 0.11363636363636
75205, 1.7869565217391, 0.67173913043478, 0.090909090909091
75206, 1.8086956521739, 0.69782608695652, 0.090909090909091
75207, 1.8086956521739, 0.67173913043478, 0.068181818181818
75208, 1.7869565217391, 0.67173913043478, 0.045454545454545
75209, 1.8086956521739, 0.69782608695652, 0.045454545454545
75210, 1.8086956521739, 0.67173913043478, 0.022727272727273
75211, 1.8521739130435, 0.67173913043478, 0.47727272727273
75212, 1.8304347826087, 0.67173913043478, 0.45454545454545
75213, 1.8521739130435, 0.69782608695652, 0.45454545454545
75214, 1.8521739130435, 0.67173913043478, 0.43181818181818
75215, 1.8304347826087, 0.67173913043478, 0.40909090909091
75216, 1.8521739130435, 0.69782608695652, 0.40909090909091
75217, 1.8521739130435, 0.67173913043478, 0.38636363636364
75218, 1.8304347826087, 0.67173913043478, 0.36363636363636
75219, 1.8521739130435, 0.69782608695652, 0.36363636363636
75220, 1.8521739130435, 0.67173913043478, 0.34090909090909
75221, 1.8304347826087, 0.67173913043478, 0.31818181818182
75222, 1.8521739130435, 0.69782608695652, 0.31818181818182
75223, 1.8521739130435, 0.67173913043478, 0.29545454545455
75224, 1.8304347826087, 0.67173913043478, 0.27272727272727
75225, 1.8521739130435, 0.69782608695652, 0.27272727272727
75226, 1.8521739130435, 0.67173913043478, 0.25
75227, 1.8304347826087, 0.67173913043478, 0.22727272727273
75228, 1.8521739130435, 0.69782608695652, 0.22727272727273
75229, 1.8521739130435, 0.67173913043478, 0.20454545454545
75230, 1.8304347826087, 0.67173913043478, 0.18181818181818
75231, 1.8521739130435, 0.69782608695652, 0.18181818181818
75232, 1.8521739130435, 0.67173913043478, 0.15909090909091
75233, 1.8304347826087, 0.67173913043478, 0.13636363636364
75234, 1.8521739130435, 0.69782608695652, 0.13636363636364
75235, 1.8521739130435, 0.67173913043478, 0.11363636363636
75236, 1.8304347826087, 0.67173913043478, 0.090909090909091
75237, 1.8521739130435, 0.69782608695652, 0.090909090909091
75238, 1.8521739130435, 0.67173913043478, 0.068181818181818
75239, 1.8304347826087, 0.67173913043478, 0.045454545454545
75240, 1.8521739130435, 0.69782608695652, 0.045454545454545
75241, 1.8521739130435, 0.67173913043478, 0.022727272727273
75242, 1.895652173913, 0.67173913043478, 0.47727272727273
75243, 1.8739130434783, 0.67173913043478, 0.45454545454545
75244, 1.895652173913, 0.69782608695652, 0.45454545454545
75245, 1.895652173913, 0.67173913043478, 0.43181818181818
75246, 1.8739130434783, 0.67173913043478, 0.40909090909091
75247, 1.895652173913, 0.69782608695652, 0.40909090909091
75248, 1.895652173913, 0.67173913043478, 0.38636363636364
75249, 1.8739130434783, 0.67173913043478, 0.36363636363636
75250, 1.895652173913, 0.69782608695652, 0.36363636363636
75251, 1.895652173913, 0.67173913043478, 0.34090909090909
75252, 1.8739130434783, 0.67173913043478, 0.31818181818182
75253, 1.895652173913, 0.69782608695652, 0.31818181818182
75254, 1.895652173913, 0.67173913043478, 0.29545454545455
75255, 1.8739130434783, 0.67173913043478, 0.27272727272727
75256, 1.895652173913, 0.69782608695652, 0.27272727272727
75257, 1.895652173913, 0.67173913043478, 0.25
75258, 1.8739130434783, 0.67173913043478, 0.22727272727273
75259, 1.895652173913, 0.69782608695652, 0.22727272727273
75260, 1.895652173913, 0.67173913043478, 0.20454545454545
75261, 1.8739130434783, 0.67173913043478, 0.18181818181818
75262, 1.895652173913, 0.69782608695652, 0.18181818181818
75263, 1.895652173913, 0.67173913043478, 0.15909090909091
75264, 1.8739130434783, 0.67173913043478, 0.13636363636364
75265, 1.895652173913, 0.69782608695652, 0.13636363636364
75266, 1.895652173913, 0.67173913043478, 0.11363636363636
75267, 1.8739130434783, 0.67173913043478, 0.090909090909091
75268, 1.895652173913, 0.69782608695652, 0.090909090909091
75269, 1.895652173913, 0.67173913043478, 0.068181818181818
75270, 1.8739130434783, 0.67173913043478, 0.045454545454545
75271, 1.895652173913, 0.69782608695652, 0.045454545454545
75272, 1.895652173913, 0.67173913043478, 0.022727272727273
75273, 1.9391304347826, 0.67173913043478, 0.47727272727273
75274, 1.9173913043478, 0.67173913043478, 0.45454545454545
75275, 1.9391304347826, 0.69782608695652, 0.45454545454545
75276, 1.9391304347826, 0.67173913043478, 0.43181818181818
75277, 1.9173913043478, 0.67173913043478, 0.40909090909091
75278, 1.9391304347826, 0.69782608695652, 0.40909090909091
75279, 1.9391304347826, 0.67173913043478, 0.38636363636364
75280, 1.9173913043478, 0.67173913043478, 0.36363636363636
75281, 1.9391304347826, 0.69782608695652, 0.36363636363636
75282, 1.9391304347826, 0.67173913043478, 0.34090909090909
75283, 1.9173913043478, 0.67173913043478, 0.31818181818182
75284, 1.9391304347826, 0.69782608695652, 0.31818181818182
75285, 1.9391304347826, 0.67173913043478, 0.29545454545455
75286, 1.9173913043478, 0.67173913043478, 0.27272727272727
75287, 1.9391304347826, 0.69782608695652, 0.27272727272727
75288, 1.9391304347826, 0.67173913043478, 0.25
75289, 1.9173913043478, 0.67173913043478, 0.22727272727273
75290, 1.9391304347826, 0.69782608695652, 0.22727272727273
75291, 1.9391304347826, 0.67173913043478, 0.20454545454545
75292, 1.9173913043478, 0.67173913043478, 0.18181818181818
75293, 1.9391304347826, 0.69782608695652, 0.18181818181818
75294, 1.9391304347826, 0.67173913043478, 0.15909090909091
75295, 1.9173913043478, 0.67173913043478, 0.13636363636364
75296, 1.9391304347826, 0.69782608695652, 0.13636363636364
75297, 1.9391304347826, 0.67173913043478, 0.11363636363636
75298, 1.9173913043478, 0.67173913043478, 0.090909090909091
75299, 1.9391304347826, 0.69782608695652, 0.090909090909091
75300, 1.9391304347826, 0.67173913043478, 0.068181818181818
75301, 1.9173913043478, 0.67173913043478, 0.045454545454545
75302, 1.9391304347826, 0.69782608695652, 0.045454545454545
75303, 1.9391304347826, 0.67173913043478, 0.022727272727273
75304, 1.9826086956522, 0.67173913043478, 0.47727272727273
75305, 1.9608695652174, 0.67173913043478, 0.45454545454545
75306, 1.9826086956522, 0.69782608695652, 0.45454545454545
75307, 1.9826086956522, 0.67173913043478, 0.43181818181818
75308, 1.9608695652174, 0.67173913043478, 0.40909090909091
75309, 1.9826086956522, 0.69782608695652, 0.40909090909091
75310, 1.9826086956522, 0.67173913043478, 0.38636363636364
75311, 1.9608695652174, 0.67173913043478, 0.36363636363636
75312, 1.9826086956522, 0.69782608695652, 0.36363636363636
75313, 1.9826086956522, 0.67173913043478, 0.34090909090909
75314, 1.9608695652174, 0.67173913043478, 0.31818181818182
75315, 1.9826086956522, 0.69782608695652, 0.31818181818182
75316, 1.9826086956522, 0.67173913043478, 0.29545454545455
75317, 1.9608695652174, 0.67173913043478, 0.27272727272727
75318, 1.9826086956522, 0.69782608695652, 0.27272727272727
75319, 1.9826086956522, 0.67173913043478, 0.25
75320, 1.9608695652174, 0.67173913043478, 0.22727272727273
75321, 1.9826086956522, 0.69782608695652, 0.22727272727273
75322, 1.9826086956522, 0.67173913043478, 0.20454545454545
75323, 1.9608695652174, 0.67173913043478, 0.18181818181818
75324, 1.9826086956522, 0.69782608695652, 0.18181818181818
75325, 1.9826086956522, 0.67173913043478, 0.15909090909091
75326, 1.9608695652174, 0.67173913043478, 0.13636363636364
75327, 1.9826086956522, 0.69782608695652, 0.13636363636364
75328, 1.9826086956522, 0.67173913043478, 0.11363636363636
75329, 1.9608695652174, 0.67173913043478, 0.090909090909091
75330, 1.9826086956522, 0.69782608695652, 0.090909090909091
75331, 1.9826086956522, 0.67173913043478, 0.068181818181818
75332, 1.9608695652174, 0.67173913043478, 0.045454545454545
75333, 1.9826086956522, 0.69782608695652, 0.045454545454545
75334, 1.9826086956522, 0.67173913043478, 0.022727272727273
75335, 2.0260869565217, 0.67173913043478, 0.47727272727273
75336, 2.004347826087, 0.67173913043478, 0.45454545454545
75337, 2.0260869565217, 0.69782608695652, 0.45454545454545
75338, 2.0260869565217, 0.67173913043478, 0.43181818181818
75339, 2.004347826087, 0.67173913043478, 0.40909090909091
75340, 2.0260869565217, 0.69782608695652, 0.40909090909091
75341, 2.0260869565217, 0.67173913043478, 0.38636363636364
75342, 2.004347826087, 0.67173913043478, 0.36363636363636
75343, 2.0260869565217, 0.69782608695652, 0.36363636363636
75344, 2.0260869565217, 0.67173913043478, 0.34090909090909
75345, 2.004347826087, 0.67173913043478, 0.31818181818182
75346, 2.0260869565217, 0.69782608695652, 0.31818181818182
75347, 2.0260869565217, 0.67173913043478, 0.29545454545455
75348, 2.004347826087, 0.67173913043478, 0.27272727272727
75349, 2.0260869565217, 0.69782608695652, 0.27272727272727
75350, 2.0260869565217, 0.67173913043478, 0.25
75351, 2.004347826087, 0.67173913043478, 0.22727272727273
75352, 2.0260869565217, 0.69782608695652, 0.22727272727273
75353, 2.0260869565217, 0.67173913043478, 0.20454545454545
75354, 2.004347826087, 0.67173913043478, 0.18181818181818
75355, 2.0260869565217, 0.69782608695652, 0.18181818181818
75356, 2.0260869565217, 0.67173913043478, 0.15909090909091
75357, 2.004347826087, 0.67173913043478, 0.13636363636364
75358, 2.0260869565217, 0.69782608695652, 0.13636363636364
75359, 2.0260869565217, 0.67173913043478, 0.11363636363636
75360, 2.004347826087, 0.67173913043478, 0.090909090909091
75361, 2.0260869565217, 0.69782608695652, 0.090909090909091
75362, 2.0260869565217, 0.67173913043478, 0.068181818181818
75363, 2.004347826087, 0.67173913043478, 0.045454545454545
75364, 2.0260869565217, 0.69782608695652, 0.045454545454545
75365, 2.0260869565217, 0.67173913043478, 0.022727272727273
75366, 2.0695652173913, 0.67173913043478, 0.47727272727273
75367, 2.0478260869565, 0.67173913043478, 0.45454545454545
75368, 2.0695652173913, 0.69782608695652, 0.45454545454545
75369, 2.0695652173913, 0.67173913043478, 0.43181818181818
75370, 2.0478260869565, 0.67173913043478, 0.40909090909091
75371, 2.0695652173913, 0.69782608695652, 0.40909090909091
75372, 2.0695652173913, 0.67173913043478, 0.38636363636364
75373, 2.0478260869565, 0.67173913043478, 0.36363636363636
75374, 2.0695652173913, 0.69782608695652, 0.36363636363636
75375, 2.0695652173913, 0.67173913043478, 0.34090909090909
75376, 2.0478260869565, 0.67173913043478, 0.31818181818182
75377, 2.0695652173913, 0.69782608695652, 0.31818181818182
75378, 2.0695652173913, 0.67173913043478, 0.29545454545455
75379, 2.0478260869565, 0.67173913043478, 0.27272727272727
75380, 2.0695652173913, 0.69782608695652, 0.27272727272727
75381, 2.0695652173913, 0.67173913043478, 0.25
75382, 2.0478260869565, 0.67173913043478, 0.22727272727273
75383, 2.0695652173913, 0.69782608695652, 0.22727272727273
75384, 2.0695652173913, 0.67173913043478, 0.20454545454545
75385, 2.0478260869565, 0.67173913043478, 0.18181818181818
75386, 2.0695652173913, 0.69782608695652, 0.18181818181818
75387, 2.0695652173913, 0.67173913043478, 0.15909090909091
75388, 2.0478260869565, 0.67173913043478, 0.13636363636364
75389, 2.0695652173913, 0.69782608695652, 0.13636363636364
75390, 2.0695652173913, 0.67173913043478, 0.11363636363636
75391, 2.0478260869565, 0.67173913043478, 0.090909090909091
75392, 2.0695652173913, 0.69782608695652, 0.090909090909091
75393, 2.0695652173913, 0.67173913043478, 0.068181818181818
75394, 2.0478260869565, 0.67173913043478, 0.045454545454545
75395, 2.0695652173913, 0.69782608695652, 0.045454545454545
75396, 2.0695652173913, 0.67173913043478, 0.022727272727273
75397, 2.1130434782609, 0.67173913043478, 0.47727272727273
75398, 2.0913043478261, 0.67173913043478, 0.45454545454545
75399, 2.1130434782609, 0.69782608695652, 0.45454545454545
75400, 2.1130434782609, 0.67173913043478, 0.43181818181818
75401, 2.0913043478261, 0.67173913043478, 0.40909090909091
75402, 2.1130434782609, 0.69782608695652, 0.40909090909091
75403, 2.1130434782609, 0.67173913043478, 0.38636363636364
75404, 2.0913043478261, 0.67173913043478, 0.36363636363636
75405, 2.1130434782609, 0.69782608695652, 0.36363636363636
75406, 2.1130434782609, 0.67173913043478, 0.34090909090909
75407, 2.0913043478261, 0.67173913043478, 0.31818181818182
75408, 2.1130434782609, 0.69782608695652, 0.31818181818182
75409, 2.1130434782609, 0.67173913043478, 0.29545454545455
75410, 2.0913043478261, 0.67173913043478, 0.27272727272727
75411, 2.1130434782609, 0.69782608695652, 0.27272727272727
75412, 2.1130434782609, 0.67173913043478, 0.25
75413, 2.0913043478261, 0.67173913043478, 0.22727272727273
75414, 2.1130434782609, 0.69782608695652, 0.22727272727273
75415, 2.1130434782609, 0.67173913043478, 0.20454545454545
75416, 2.0913043478261, 0.67173913043478, 0.18181818181818
75417, 2.1130434782609, 0.69782608695652, 0.18181818181818
75418, 2.1130434782609, 0.67173913043478, 0.15909090909091
75419, 2.0913043478261, 0.67173913043478, 0.13636363636364
75420, 2.1130434782609, 0.69782608695652, 0.13636363636364
75421, 2.1130434782609, 0.67173913043478, 0.11363636363636
75422, 2.0913043478261, 0.67173913043478, 0.090909090909091
75423, 2.1130434782609, 0.69782608695652, 0.090909090909091
75424, 2.1130434782609, 0.67173913043478, 0.068181818181818
75425, 2.0913043478261, 0.67173913043478, 0.045454545454545
75426, 2.1130434782609, 0.69782608695652, 0.045454545454545
75427, 2.1130434782609, 0.67173913043478, 0.022727272727273
75428, 2.1565217391304, 0.67173913043478, 0.47727272727273
75429, 2.1347826086957, 0.67173913043478, 0.45454545454545
75430, 2.1565217391304, 0.69782608695652, 0.45454545454545
75431, 2.1565217391304, 0.67173913043478, 0.43181818181818
75432, 2.1347826086957, 0.67173913043478, 0.40909090909091
75433, 2.1565217391304, 0.69782608695652, 0.40909090909091
75434, 2.1565217391304, 0.67173913043478, 0.38636363636364
75435, 2.1347826086957, 0.67173913043478, 0.36363636363636
75436, 2.1565217391304, 0.69782608695652, 0.36363636363636
75437, 2.1565217391304, 0.67173913043478, 0.34090909090909
75438, 2.1347826086957, 0.67173913043478, 0.31818181818182
75439, 2.1565217391304, 0.69782608695652, 0.31818181818182
75440, 2.1565217391304, 0.67173913043478, 0.29545454545455
75441, 2.1347826086957, 0.67173913043478, 0.27272727272727
75442, 2.1565217391304, 0.69782608695652, 0.27272727272727
75443, 2.1565217391304, 0.67173913043478, 0.25
75444, 2.1347826086957, 0.67173913043478, 0.22727272727273
75445, 2.1565217391304, 0.69782608695652, 0.22727272727273
75446, 2.1565217391304, 0.67173913043478, 0.20454545454545
75447, 2.1347826086957, 0.67173913043478, 0.18181818181818
75448, 2.1565217391304, 0.69782608695652, 0.18181818181818
75449, 2.1565217391304, 0.67173913043478, 0.15909090909091
75450, 2.1347826086957, 0.67173913043478, 0.13636363636364
75451, 2.1565217391304, 0.69782608695652, 0.13636363636364
75452, 2.1565217391304, 0.67173913043478, 0.11363636363636
75453, 2.1347826086957, 0.67173913043478, 0.090909090909091
75454, 2.1565217391304, 0.69782608695652, 0.090909090909091
75455, 2.1565217391304, 0.67173913043478, 0.068181818181818
75456, 2.1347826086957, 0.67173913043478, 0.045454545454545
75457, 2.1565217391304, 0.69782608695652, 0.045454545454545
75458, 2.1565217391304, 0.67173913043478, 0.022727272727273
75459, 2.1782608695652, 0.67173913043478, 0.45454545454545
75460, 2.1782608695652, 0.67173913043478, 0.40909090909091
75461, 2.1782608695652, 0.67173913043478, 0.36363636363636
75462, 2.1782608695652, 0.67173913043478, 0.31818181818182
75463, 2.1782608695652, 0.67173913043478, 0.27272727272727
75464, 2.1782608695652, 0.67173913043478, 0.22727272727273
75465, 2.1782608695652, 0.67173913043478, 0.18181818181818
75466, 2.1782608695652, 0.67173913043478, 0.13636363636364
75467, 2.1782608695652, 0.67173913043478, 0.090909090909091
75468, 2.1782608695652, 0.67173913043478, 0.045454545454545
75469, 1.2434782608696, 0.61956521739131, 0.47727272727273
75470, 1.2217391304348, 0.6195652173913, 0.45454545454545
75471, 1.2434782608696, 0.64565217391304, 0.45454545454545
75472, 1.2434782608696, 0.6195652173913, 0.43181818181818
75473, 1.2217391304348, 0.6195652173913, 0.40909090909091
75474, 1.2434782608696, 0.64565217391304, 0.40909090909091
75475, 1.2434782608696, 0.6195652173913, 0.38636363636364
75476, 1.2217391304348, 0.61956521739131, 0.36363636363636
75477, 1.2434782608696, 0.64565217391304, 0.36363636363636
75478, 1.2434782608696, 0.61956521739131, 0.34090909090909
75479, 1.2217391304348, 0.61956521739131, 0.31818181818182
75480, 1.2434782608696, 0.64565217391304, 0.31818181818182
75481, 1.2434782608696, 0.61956521739131, 0.29545454545455
75482, 1.2217391304348, 0.61956521739131, 0.27272727272727
75483, 1.2434782608696, 0.64565217391304, 0.27272727272727
75484, 1.2434782608696, 0.61956521739131, 0.25
75485, 1.2217391304348, 0.61956521739131, 0.22727272727273
75486, 1.2434782608696, 0.64565217391304, 0.22727272727273
75487, 1.2434782608696, 0.61956521739131, 0.20454545454545
75488, 1.2217391304348, 0.61956521739131, 0.18181818181818
75489, 1.2434782608696, 0.64565217391304, 0.18181818181818
75490, 1.2434782608696, 0.61956521739131, 0.15909090909091
75491, 1.2217391304348, 0.61956521739131, 0.13636363636364
75492, 1.2434782608696, 0.64565217391304, 0.13636363636364
75493, 1.2434782608696, 0.61956521739131, 0.11363636363636
75494, 1.2217391304348, 0.61956521739131, 0.090909090909091
75495, 1.2434782608696, 0.64565217391304, 0.090909090909091
75496, 1.2434782608696, 0.61956521739131, 0.068181818181818
75497, 1.2217391304348, 0.61956521739131, 0.045454545454545
75498, 1.2434782608696, 0.64565217391304, 0.045454545454545
75499, 1.2434782608696, 0.61956521739131, 0.022727272727273
75500, 1.2869565217391, 0.61956521739131, 0.47727272727273
75501, 1.2652173913043, 0.6195652173913, 0.45454545454545
75502, 1.2869565217391, 0.64565217391304, 0.45454545454545
75503, 1.2869565217391, 0.6195652173913, 0.43181818181818
75504, 1.2652173913043, 0.6195652173913, 0.40909090909091
75505, 1.2869565217391, 0.64565217391304, 0.40909090909091
75506, 1.2869565217391, 0.61956521739131, 0.38636363636364
75507, 1.2652173913043, 0.61956521739131, 0.36363636363636
75508, 1.2869565217391, 0.64565217391304, 0.36363636363636
75509, 1.2869565217391, 0.61956521739131, 0.34090909090909
75510, 1.2652173913043, 0.61956521739131, 0.31818181818182
75511, 1.2869565217391, 0.64565217391304, 0.31818181818182
75512, 1.2869565217391, 0.61956521739131, 0.29545454545455
75513, 1.2652173913043, 0.61956521739131, 0.27272727272727
75514, 1.2869565217391, 0.64565217391304, 0.27272727272727
75515, 1.2869565217391, 0.61956521739131, 0.25
75516, 1.2652173913043, 0.61956521739131, 0.22727272727273
75517, 1.2869565217391, 0.64565217391304, 0.22727272727273
75518, 1.2869565217391, 0.61956521739131, 0.20454545454545
75519, 1.2652173913043, 0.61956521739131, 0.18181818181818
75520, 1.2869565217391, 0.64565217391304, 0.18181818181818
75521, 1.2869565217391, 0.61956521739131, 0.15909090909091
75522, 1.2652173913043, 0.61956521739131, 0.13636363636364
75523, 1.2869565217391, 0.64565217391304, 0.13636363636364
75524, 1.2869565217391, 0.61956521739131, 0.11363636363636
75525, 1.2652173913043, 0.61956521739131, 0.090909090909091
75526, 1.2869565217391, 0.64565217391304, 0.090909090909091
75527, 1.2869565217391, 0.61956521739131, 0.068181818181818
75528, 1.2652173913043, 0.61956521739131, 0.045454545454545
75529, 1.2869565217391, 0.64565217391304, 0.045454545454545
75530, 1.2869565217391, 0.61956521739131, 0.022727272727273
75531, 1.3304347826087, 0.61956521739131, 0.47727272727273
75532, 1.3086956521739, 0.61956521739131, 0.45454545454545
75533, 1.3304347826087, 0.64565217391304, 0.45454545454545
75534, 1.3304347826087, 0.61956521739131, 0.43181818181818
75535, 1.3086956521739, 0.6195652173913, 0.40909090909091
75536, 1.3304347826087, 0.64565217391304, 0.40909090909091
75537, 1.3304347826087, 0.61956521739131, 0.38636363636364
75538, 1.3086956521739, 0.61956521739131, 0.36363636363636
75539, 1.3304347826087, 0.64565217391304, 0.36363636363636
75540, 1.3304347826087, 0.61956521739131, 0.34090909090909
75541, 1.3086956521739, 0.61956521739131, 0.31818181818182
75542, 1.3304347826087, 0.64565217391304, 0.31818181818182
75543, 1.3304347826087, 0.61956521739131, 0.29545454545455
75544, 1.3086956521739, 0.61956521739131, 0.27272727272727
75545, 1.3304347826087, 0.64565217391304, 0.27272727272727
75546, 1.3304347826087, 0.61956521739131, 0.25
75547, 1.3086956521739, 0.61956521739131, 0.22727272727273
75548, 1.3304347826087, 0.64565217391304, 0.22727272727273
75549, 1.3304347826087, 0.61956521739131, 0.20454545454545
75550, 1.3086956521739, 0.61956521739131, 0.18181818181818
75551, 1.3304347826087, 0.64565217391304, 0.18181818181818
75552, 1.3304347826087, 0.61956521739131, 0.15909090909091
75553, 1.3086956521739, 0.61956521739131, 0.13636363636364
75554, 1.3304347826087, 0.64565217391304, 0.13636363636364
75555, 1.3304347826087, 0.61956521739131, 0.11363636363636
75556, 1.3086956521739, 0.61956521739131, 0.090909090909091
75557, 1.3304347826087, 0.64565217391304, 0.090909090909091
75558, 1.3304347826087, 0.61956521739131, 0.068181818181818
75559, 1.3086956521739, 0.61956521739131, 0.045454545454545
75560, 1.3304347826087, 0.64565217391304, 0.045454545454545
75561, 1.3304347826087, 0.61956521739131, 0.022727272727273
75562, 1.3739130434783, 0.61956521739131, 0.47727272727273
75563, 1.3521739130435, 0.61956521739131, 0.45454545454545
75564, 1.3739130434783, 0.64565217391304, 0.45454545454545
75565, 1.3739130434783, 0.61956521739131, 0.43181818181818
75566, 1.3521739130435, 0.61956521739131, 0.40909090909091
75567, 1.3739130434783, 0.64565217391304, 0.40909090909091
75568, 1.3739130434783, 0.61956521739131, 0.38636363636364
75569, 1.3521739130435, 0.61956521739131, 0.36363636363636
75570, 1.3739130434783, 0.64565217391304, 0.36363636363636
75571, 1.3739130434783, 0.61956521739131, 0.34090909090909
75572, 1.3521739130435, 0.61956521739131, 0.31818181818182
75573, 1.3739130434783, 0.64565217391304, 0.31818181818182
75574, 1.3739130434783, 0.61956521739131, 0.29545454545455
75575, 1.3521739130435, 0.61956521739131, 0.27272727272727
75576, 1.3739130434783, 0.64565217391304, 0.27272727272727
75577, 1.3739130434783, 0.61956521739131, 0.25
75578, 1.3521739130435, 0.61956521739131, 0.22727272727273
75579, 1.3739130434783, 0.64565217391304, 0.22727272727273
75580, 1.3739130434783, 0.61956521739131, 0.20454545454545
75581, 1.3521739130435, 0.61956521739131, 0.18181818181818
75582, 1.3739130434783, 0.64565217391304, 0.18181818181818
75583, 1.3739130434783, 0.61956521739131, 0.15909090909091
75584, 1.3521739130435, 0.61956521739131, 0.13636363636364
75585, 1.3739130434783, 0.64565217391304, 0.13636363636364
75586, 1.3739130434783, 0.61956521739131, 0.11363636363636
75587, 1.3521739130435, 0.61956521739131, 0.090909090909091
75588, 1.3739130434783, 0.64565217391304, 0.090909090909091
75589, 1.3739130434783, 0.61956521739131, 0.068181818181818
75590, 1.3521739130435, 0.61956521739131, 0.045454545454545
75591, 1.3739130434783, 0.64565217391304, 0.045454545454545
75592, 1.3739130434783, 0.61956521739131, 0.022727272727273
75593, 1.4173913043478, 0.61956521739131, 0.47727272727273
75594, 1.395652173913, 0.61956521739131, 0.45454545454545
75595, 1.4173913043478, 0.64565217391304, 0.45454545454545
75596, 1.4173913043478, 0.61956521739131, 0.43181818181818
75597, 1.395652173913, 0.61956521739131, 0.40909090909091
75598, 1.4173913043478, 0.64565217391304, 0.40909090909091
75599, 1.4173913043478, 0.61956521739131, 0.38636363636364
75600, 1.395652173913, 0.61956521739131, 0.36363636363636
75601, 1.4173913043478, 0.64565217391304, 0.36363636363636
75602, 1.4173913043478, 0.61956521739131, 0.34090909090909
75603, 1.395652173913, 0.61956521739131, 0.31818181818182
75604, 1.4173913043478, 0.64565217391304, 0.31818181818182
75605, 1.4173913043478, 0.61956521739131, 0.29545454545455
75606, 1.395652173913, 0.61956521739131, 0.27272727272727
75607, 1.4173913043478, 0.64565217391304, 0.27272727272727
75608, 1.4173913043478, 0.61956521739131, 0.25
75609, 1.395652173913, 0.61956521739131, 0.22727272727273
75610, 1.4173913043478, 0.64565217391304, 0.22727272727273
75611, 1.4173913043478, 0.61956521739131, 0.20454545454545
75612, 1.395652173913, 0.61956521739131, 0.18181818181818
75613, 1.4173913043478, 0.64565217391304, 0.18181818181818
75614, 1.4173913043478, 0.61956521739131, 0.15909090909091
75615, 1.395652173913, 0.61956521739131, 0.13636363636364
75616, 1.4173913043478, 0.64565217391304, 0.13636363636364
75617, 1.4173913043478, 0.61956521739131, 0.11363636363636
75618, 1.395652173913, 0.61956521739131, 0.090909090909091
75619, 1.4173913043478, 0.64565217391304, 0.090909090909091
75620, 1.4173913043478, 0.61956521739131, 0.068181818181818
75621, 1.395652173913, 0.61956521739131, 0.045454545454545
75622, 1.4173913043478, 0.64565217391304, 0.045454545454545
75623, 1.4173913043478, 0.61956521739131, 0.022727272727273
75624, 1.4608695652174, 0.61956521739131, 0.47727272727273
75625, 1.4391304347826, 0.61956521739131, 0.45454545454545
75626, 1.4608695652174, 0.64565217391304, 0.45454545454545
75627, 1.4608695652174, 0.6195652173913, 0.43181818181818
75628, 1.4391304347826, 0.6195652173913, 0.40909090909091
75629, 1.4608695652174, 0.64565217391304, 0.40909090909091
75630, 1.4608695652174, 0.6195652173913, 0.38636363636364
75631, 1.4391304347826, 0.61956521739131, 0.36363636363636
75632, 1.4608695652174, 0.64565217391304, 0.36363636363636
75633, 1.4608695652174, 0.6195652173913, 0.34090909090909
75634, 1.4391304347826, 0.6195652173913, 0.31818181818182
75635, 1.4608695652174, 0.64565217391304, 0.31818181818182
75636, 1.4608695652174, 0.6195652173913, 0.29545454545455
75637, 1.4391304347826, 0.61956521739131, 0.27272727272727
75638, 1.4608695652174, 0.64565217391304, 0.27272727272727
75639, 1.4608695652174, 0.6195652173913, 0.25
75640, 1.4391304347826, 0.61956521739131, 0.22727272727273
75641, 1.4608695652174, 0.64565217391304, 0.22727272727273
75642, 1.4608695652174, 0.6195652173913, 0.20454545454545
75643, 1.4391304347826, 0.6195652173913, 0.18181818181818
75644, 1.4608695652174, 0.64565217391304, 0.18181818181818
75645, 1.4608695652174, 0.6195652173913, 0.15909090909091
75646, 1.4391304347826, 0.61956521739131, 0.13636363636364
75647, 1.4608695652174, 0.64565217391304, 0.13636363636364
75648, 1.4608695652174, 0.6195652173913, 0.11363636363636
75649, 1.4391304347826, 0.6195652173913, 0.090909090909091
75650, 1.4608695652174, 0.64565217391304, 0.090909090909091
75651, 1.4608695652174, 0.6195652173913, 0.068181818181818
75652, 1.4391304347826, 0.61956521739131, 0.045454545454545
75653, 1.4608695652174, 0.64565217391304, 0.045454545454545
75654, 1.4608695652174, 0.61956521739131, 0.022727272727273
75655, 1.504347826087, 0.6195652173913, 0.47727272727273
75656, 1.4826086956522, 0.6195652173913, 0.45454545454545
75657, 1.504347826087, 0.64565217391304, 0.45454545454545
75658, 1.504347826087, 0.6195652173913, 0.43181818181818
75659, 1.4826086956522, 0.6195652173913, 0.40909090909091
75660, 1.504347826087, 0.64565217391304, 0.40909090909091
75661, 1.504347826087, 0.6195652173913, 0.38636363636364
75662, 1.4826086956522, 0.6195652173913, 0.36363636363636
75663, 1.504347826087, 0.64565217391304, 0.36363636363636
75664, 1.504347826087, 0.61956521739131, 0.34090909090909
75665, 1.4826086956522, 0.6195652173913, 0.31818181818182
75666, 1.504347826087, 0.64565217391304, 0.31818181818182
75667, 1.504347826087, 0.6195652173913, 0.29545454545455
75668, 1.4826086956522, 0.6195652173913, 0.27272727272727
75669, 1.504347826087, 0.64565217391304, 0.27272727272727
75670, 1.504347826087, 0.6195652173913, 0.25
75671, 1.4826086956522, 0.6195652173913, 0.22727272727273
75672, 1.504347826087, 0.64565217391304, 0.22727272727273
75673, 1.504347826087, 0.6195652173913, 0.20454545454545
75674, 1.4826086956522, 0.6195652173913, 0.18181818181818
75675, 1.504347826087, 0.64565217391304, 0.18181818181818
75676, 1.504347826087, 0.6195652173913, 0.15909090909091
75677, 1.4826086956522, 0.6195652173913, 0.13636363636364
75678, 1.504347826087, 0.64565217391304, 0.13636363636364
75679, 1.504347826087, 0.6195652173913, 0.11363636363636
75680, 1.4826086956522, 0.6195652173913, 0.090909090909091
75681, 1.504347826087, 0.64565217391304, 0.090909090909091
75682, 1.504347826087, 0.6195652173913, 0.068181818181818
75683, 1.4826086956522, 0.6195652173913, 0.045454545454545
75684, 1.504347826087, 0.64565217391304, 0.045454545454545
75685, 1.504347826087, 0.6195652173913, 0.022727272727273
75686, 1.5478260869565, 0.61956521739131, 0.47727272727273
75687, 1.5260869565217, 0.6195652173913, 0.45454545454545
75688, 1.5478260869565, 0.64565217391304, 0.45454545454545
75689, 1.5478260869565, 0.6195652173913, 0.43181818181818
75690, 1.5260869565217, 0.6195652173913, 0.40909090909091
75691, 1.5478260869565, 0.64565217391304, 0.40909090909091
75692, 1.5478260869565, 0.6195652173913, 0.38636363636364
75693, 1.5260869565217, 0.61956521739131, 0.36363636363636
75694, 1.5478260869565, 0.64565217391304, 0.36363636363636
75695, 1.5478260869565, 0.61956521739131, 0.34090909090909
75696, 1.5260869565217, 0.6195652173913, 0.31818181818182
75697, 1.5478260869565, 0.64565217391304, 0.31818181818182
75698, 1.5478260869565, 0.6195652173913, 0.29545454545455
75699, 1.5260869565217, 0.6195652173913, 0.27272727272727
75700, 1.5478260869565, 0.64565217391304, 0.27272727272727
75701, 1.5478260869565, 0.61956521739131, 0.25
75702, 1.5260869565217, 0.6195652173913, 0.22727272727273
75703, 1.5478260869565, 0.64565217391304, 0.22727272727273
75704, 1.5478260869565, 0.6195652173913, 0.20454545454545
75705, 1.5260869565217, 0.6195652173913, 0.18181818181818
75706, 1.5478260869565, 0.64565217391304, 0.18181818181818
75707, 1.5478260869565, 0.61956521739131, 0.15909090909091
75708, 1.5260869565217, 0.61956521739131, 0.13636363636364
75709, 1.5478260869565, 0.64565217391304, 0.13636363636364
75710, 1.5478260869565, 0.61956521739131, 0.11363636363636
75711, 1.5260869565217, 0.6195652173913, 0.090909090909091
75712, 1.5478260869565, 0.64565217391304, 0.090909090909091
75713, 1.5478260869565, 0.61956521739131, 0.068181818181818
75714, 1.5260869565217, 0.6195652173913, 0.045454545454545
75715, 1.5478260869565, 0.64565217391304, 0.045454545454545
75716, 1.5478260869565, 0.61956521739131, 0.022727272727273
75717, 1.5913043478261, 0.6195652173913, 0.47727272727273
75718, 1.5695652173913, 0.6195652173913, 0.45454545454545
75719, 1.5913043478261, 0.64565217391304, 0.45454545454545
75720, 1.5913043478261, 0.6195652173913, 0.43181818181818
75721, 1.5695652173913, 0.6195652173913, 0.40909090909091
75722, 1.5913043478261, 0.64565217391304, 0.40909090909091
75723, 1.5913043478261, 0.6195652173913, 0.38636363636364
75724, 1.5695652173913, 0.61956521739131, 0.36363636363636
75725, 1.5913043478261, 0.64565217391304, 0.36363636363636
75726, 1.5913043478261, 0.6195652173913, 0.34090909090909
75727, 1.5695652173913, 0.6195652173913, 0.31818181818182
75728, 1.5913043478261, 0.64565217391304, 0.31818181818182
75729, 1.5913043478261, 0.6195652173913, 0.29545454545455
75730, 1.5695652173913, 0.6195652173913, 0.27272727272727
75731, 1.5913043478261, 0.64565217391304, 0.27272727272727
75732, 1.5913043478261, 0.6195652173913, 0.25
75733, 1.5695652173913, 0.61956521739131, 0.22727272727273
75734, 1.5913043478261, 0.64565217391304, 0.22727272727273
75735, 1.5913043478261, 0.6195652173913, 0.20454545454545
75736, 1.5695652173913, 0.6195652173913, 0.18181818181818
75737, 1.5913043478261, 0.64565217391304, 0.18181818181818
75738, 1.5913043478261, 0.6195652173913, 0.15909090909091
75739, 1.5695652173913, 0.61956521739131, 0.13636363636364
75740, 1.5913043478261, 0.64565217391304, 0.13636363636364
75741, 1.5913043478261, 0.6195652173913, 0.11363636363636
75742, 1.5695652173913, 0.61956521739131, 0.090909090909091
75743, 1.5913043478261, 0.64565217391304, 0.090909090909091
75744, 1.5913043478261, 0.6195652173913, 0.068181818181818
75745, 1.5695652173913, 0.6195652173913, 0.045454545454545
75746, 1.5913043478261, 0.64565217391304, 0.045454545454545
75747, 1.5913043478261, 0.6195652173913, 0.022727272727273
75748, 1.6347826086957, 0.61956521739131, 0.47727272727273
75749, 1.6130434782609, 0.6195652173913, 0.45454545454545
75750, 1.6347826086957, 0.64565217391304, 0.45454545454545
75751, 1.6347826086957, 0.61956521739131, 0.43181818181818
75752, 1.6130434782609, 0.6195652173913, 0.40909090909091
75753, 1.6347826086957, 0.64565217391304, 0.40909090909091
75754, 1.6347826086957, 0.61956521739131, 0.38636363636364
75755, 1.6130434782609, 0.6195652173913, 0.36363636363636
75756, 1.6347826086957, 0.64565217391304, 0.36363636363636
75757, 1.6347826086957, 0.61956521739131, 0.34090909090909
75758, 1.6130434782609, 0.6195652173913, 0.31818181818182
75759, 1.6347826086957, 0.64565217391304, 0.31818181818182
75760, 1.6347826086957, 0.61956521739131, 0.29545454545455
75761, 1.6130434782609, 0.6195652173913, 0.27272727272727
75762, 1.6347826086957, 0.64565217391304, 0.27272727272727
75763, 1.6347826086957, 0.61956521739131, 0.25
75764, 1.6130434782609, 0.61956521739131, 0.22727272727273
75765, 1.6347826086957, 0.64565217391304, 0.22727272727273
75766, 1.6347826086957, 0.61956521739131, 0.20454545454545
75767, 1.6130434782609, 0.6195652173913, 0.18181818181818
75768, 1.6347826086957, 0.64565217391304, 0.18181818181818
75769, 1.6347826086957, 0.61956521739131, 0.15909090909091
75770, 1.6130434782609, 0.61956521739131, 0.13636363636364
75771, 1.6347826086957, 0.64565217391304, 0.13636363636364
75772, 1.6347826086957, 0.61956521739131, 0.11363636363636
75773, 1.6130434782609, 0.6195652173913, 0.090909090909091
75774, 1.6347826086957, 0.64565217391304, 0.090909090909091
75775, 1.6347826086957, 0.61956521739131, 0.068181818181818
75776, 1.6130434782609, 0.6195652173913, 0.045454545454545
75777, 1.6347826086957, 0.64565217391304, 0.045454545454545
75778, 1.6347826086957, 0.61956521739131, 0.022727272727273
75779, 1.6782608695652, 0.61956521739131, 0.47727272727273
75780, 1.6565217391304, 0.6195652173913, 0.45454545454545
75781, 1.6782608695652, 0.64565217391304, 0.45454545454545
75782, 1.6782608695652, 0.6195652173913, 0.43181818181818
75783, 1.6565217391304, 0.6195652173913, 0.40909090909091
75784, 1.6782608695652, 0.64565217391304, 0.40909090909091
75785, 1.6782608695652, 0.6195652173913, 0.38636363636364
75786, 1.6565217391304, 0.61956521739131, 0.36363636363636
75787, 1.6782608695652, 0.64565217391304, 0.36363636363636
75788, 1.6782608695652, 0.61956521739131, 0.34090909090909
75789, 1.6565217391304, 0.61956521739131, 0.31818181818182
75790, 1.6782608695652, 0.64565217391304, 0.31818181818182
75791, 1.6782608695652, 0.61956521739131, 0.29545454545455
75792, 1.6565217391304, 0.61956521739131, 0.27272727272727
75793, 1.6782608695652, 0.64565217391304, 0.27272727272727
75794, 1.6782608695652, 0.61956521739131, 0.25
75795, 1.6565217391304, 0.61956521739131, 0.22727272727273
75796, 1.6782608695652, 0.64565217391304, 0.22727272727273
75797, 1.6782608695652, 0.61956521739131, 0.20454545454545
75798, 1.6565217391304, 0.61956521739131, 0.18181818181818
75799, 1.6782608695652, 0.64565217391304, 0.18181818181818
75800, 1.6782608695652, 0.61956521739131, 0.15909090909091
75801, 1.6565217391304, 0.61956521739131, 0.13636363636364
75802, 1.6782608695652, 0.64565217391304, 0.13636363636364
75803, 1.6782608695652, 0.61956521739131, 0.11363636363636
75804, 1.6565217391304, 0.61956521739131, 0.090909090909091
75805, 1.6782608695652, 0.64565217391304, 0.090909090909091
75806, 1.6782608695652, 0.61956521739131, 0.068181818181818
75807, 1.6565217391304, 0.61956521739131, 0.045454545454545
75808, 1.6782608695652, 0.64565217391304, 0.045454545454545
75809, 1.6782608695652, 0.61956521739131, 0.022727272727273
75810, 1.7217391304348, 0.61956521739131, 0.47727272727273
75811, 1.7, 0.6195652173913, 0.45454545454545
75812, 1.7217391304348, 0.64565217391304, 0.45454545454545
75813, 1.7217391304348, 0.6195652173913, 0.43181818181818
75814, 1.7, 0.6195652173913, 0.40909090909091
75815, 1.7217391304348, 0.64565217391304, 0.40909090909091
75816, 1.7217391304348, 0.61956521739131, 0.38636363636364
75817, 1.7, 0.61956521739131, 0.36363636363636
75818, 1.7217391304348, 0.64565217391304, 0.36363636363636
75819, 1.7217391304348, 0.61956521739131, 0.34090909090909
75820, 1.7, 0.61956521739131, 0.31818181818182
75821, 1.7217391304348, 0.64565217391304, 0.31818181818182
75822, 1.7217391304348, 0.61956521739131, 0.29545454545455
75823, 1.7, 0.61956521739131, 0.27272727272727
75824, 1.7217391304348, 0.64565217391304, 0.27272727272727
75825, 1.7217391304348, 0.61956521739131, 0.25
75826, 1.7, 0.61956521739131, 0.22727272727273
75827, 1.7217391304348, 0.64565217391304, 0.22727272727273
75828, 1.7217391304348, 0.61956521739131, 0.20454545454545
75829, 1.7, 0.61956521739131, 0.18181818181818
75830, 1.7217391304348, 0.64565217391304, 0.18181818181818
75831, 1.7217391304348, 0.61956521739131, 0.15909090909091
75832, 1.7, 0.61956521739131, 0.13636363636364
75833, 1.7217391304348, 0.64565217391304, 0.13636363636364
75834, 1.7217391304348, 0.61956521739131, 0.11363636363636
75835, 1.7, 0.61956521739131, 0.090909090909091
75836, 1.7217391304348, 0.64565217391304, 0.090909090909091
75837, 1.7217391304348, 0.61956521739131, 0.068181818181818
75838, 1.7, 0.61956521739131, 0.045454545454545
75839, 1.7217391304348, 0.64565217391304, 0.045454545454545
75840, 1.7217391304348, 0.61956521739131, 0.022727272727273
75841, 1.7652173913043, 0.61956521739131, 0.47727272727273
75842, 1.7434782608696, 0.6195652173913, 0.45454545454545
75843, 1.7652173913043, 0.64565217391304, 0.45454545454545
75844, 1.7652173913043, 0.6195652173913, 0.43181818181818
75845, 1.7434782608696, 0.6195652173913, 0.40909090909091
75846, 1.7652173913043, 0.64565217391304, 0.40909090909091
75847, 1.7652173913043, 0.6195652173913, 0.38636363636364
75848, 1.7434782608696, 0.61956521739131, 0.36363636363636
75849, 1.7652173913043, 0.64565217391304, 0.36363636363636
75850, 1.7652173913043, 0.61956521739131, 0.34090909090909
75851, 1.7434782608696, 0.61956521739131, 0.31818181818182
75852, 1.7652173913043, 0.64565217391304, 0.31818181818182
75853, 1.7652173913043, 0.61956521739131, 0.29545454545455
75854, 1.7434782608696, 0.61956521739131, 0.27272727272727
75855, 1.7652173913043, 0.64565217391304, 0.27272727272727
75856, 1.7652173913043, 0.61956521739131, 0.25
75857, 1.7434782608696, 0.61956521739131, 0.22727272727273
75858, 1.7652173913043, 0.64565217391304, 0.22727272727273
75859, 1.7652173913043, 0.61956521739131, 0.20454545454545
75860, 1.7434782608696, 0.61956521739131, 0.18181818181818
75861, 1.7652173913043, 0.64565217391304, 0.18181818181818
75862, 1.7652173913043, 0.61956521739131, 0.15909090909091
75863, 1.7434782608696, 0.61956521739131, 0.13636363636364
75864, 1.7652173913043, 0.64565217391304, 0.13636363636364
75865, 1.7652173913043, 0.61956521739131, 0.11363636363636
75866, 1.7434782608696, 0.61956521739131, 0.090909090909091
75867, 1.7652173913043, 0.64565217391304, 0.090909090909091
75868, 1.7652173913043, 0.61956521739131, 0.068181818181818
75869, 1.7434782608696, 0.61956521739131, 0.045454545454545
75870, 1.7652173913043, 0.64565217391304, 0.045454545454545
75871, 1.7652173913043, 0.61956521739131, 0.022727272727273
75872, 1.8086956521739, 0.6195652173913, 0.47727272727273
75873, 1.7869565217391, 0.6195652173913, 0.45454545454545
75874, 1.8086956521739, 0.64565217391304, 0.45454545454545
75875, 1.8086956521739, 0.6195652173913, 0.43181818181818
75876, 1.7869565217391, 0.6195652173913, 0.40909090909091
75877, 1.8086956521739, 0.64565217391304, 0.40909090909091
75878, 1.8086956521739, 0.61956521739131, 0.38636363636364
75879, 1.7869565217391, 0.61956521739131, 0.36363636363636
75880, 1.8086956521739, 0.64565217391304, 0.36363636363636
75881, 1.8086956521739, 0.6195652173913, 0.34090909090909
75882, 1.7869565217391, 0.6195652173913, 0.31818181818182
75883, 1.8086956521739, 0.64565217391304, 0.31818181818182
75884, 1.8086956521739, 0.6195652173913, 0.29545454545455
75885, 1.7869565217391, 0.61956521739131, 0.27272727272727
75886, 1.8086956521739, 0.64565217391304, 0.27272727272727
75887, 1.8086956521739, 0.61956521739131, 0.25
75888, 1.7869565217391, 0.61956521739131, 0.22727272727273
75889, 1.8086956521739, 0.64565217391304, 0.22727272727273
75890, 1.8086956521739, 0.61956521739131, 0.20454545454545
75891, 1.7869565217391, 0.6195652173913, 0.18181818181818
75892, 1.8086956521739, 0.64565217391304, 0.18181818181818
75893, 1.8086956521739, 0.6195652173913, 0.15909090909091
75894, 1.7869565217391, 0.61956521739131, 0.13636363636364
75895, 1.8086956521739, 0.64565217391304, 0.13636363636364
75896, 1.8086956521739, 0.61956521739131, 0.11363636363636
75897, 1.7869565217391, 0.61956521739131, 0.090909090909091
75898, 1.8086956521739, 0.64565217391304, 0.090909090909091
75899, 1.8086956521739, 0.61956521739131, 0.068181818181818
75900, 1.7869565217391, 0.61956521739131, 0.045454545454545
75901, 1.8086956521739, 0.64565217391304, 0.045454545454545
75902, 1.8086956521739, 0.61956521739131, 0.022727272727273
75903, 1.8521739130435, 0.61956521739131, 0.47727272727273
75904, 1.8304347826087, 0.6195652173913, 0.45454545454545
75905, 1.8521739130435, 0.64565217391304, 0.45454545454545
75906, 1.8521739130435, 0.6195652173913, 0.43181818181818
75907, 1.8304347826087, 0.6195652173913, 0.40909090909091
75908, 1.8521739130435, 0.64565217391304, 0.40909090909091
75909, 1.8521739130435, 0.6195652173913, 0.38636363636364
75910, 1.8304347826087, 0.6195652173913, 0.36363636363636
75911, 1.8521739130435, 0.64565217391304, 0.36363636363636
75912, 1.8521739130435, 0.6195652173913, 0.34090909090909
75913, 1.8304347826087, 0.6195652173913, 0.31818181818182
75914, 1.8521739130435, 0.64565217391304, 0.31818181818182
75915, 1.8521739130435, 0.61956521739131, 0.29545454545455
75916, 1.8304347826087, 0.61956521739131, 0.27272727272727
75917, 1.8521739130435, 0.64565217391304, 0.27272727272727
75918, 1.8521739130435, 0.61956521739131, 0.25
75919, 1.8304347826087, 0.61956521739131, 0.22727272727273
75920, 1.8521739130435, 0.64565217391304, 0.22727272727273
75921, 1.8521739130435, 0.61956521739131, 0.20454545454545
75922, 1.8304347826087, 0.6195652173913, 0.18181818181818
75923, 1.8521739130435, 0.64565217391304, 0.18181818181818
75924, 1.8521739130435, 0.61956521739131, 0.15909090909091
75925, 1.8304347826087, 0.61956521739131, 0.13636363636364
75926, 1.8521739130435, 0.64565217391304, 0.13636363636364
75927, 1.8521739130435, 0.61956521739131, 0.11363636363636
75928, 1.8304347826087, 0.61956521739131, 0.090909090909091
75929, 1.8521739130435, 0.64565217391304, 0.090909090909091
75930, 1.8521739130435, 0.61956521739131, 0.068181818181818
75931, 1.8304347826087, 0.61956521739131, 0.045454545454545
75932, 1.8521739130435, 0.64565217391304, 0.045454545454545
75933, 1.8521739130435, 0.61956521739131, 0.022727272727273
75934, 1.895652173913, 0.61956521739131, 0.47727272727273
75935, 1.8739130434783, 0.6195652173913, 0.45454545454545
75936, 1.895652173913, 0.64565217391304, 0.45454545454545
75937, 1.895652173913, 0.6195652173913, 0.43181818181818
75938, 1.8739130434783, 0.6195652173913, 0.40909090909091
75939, 1.895652173913, 0.64565217391304, 0.40909090909091
75940, 1.895652173913, 0.6195652173913, 0.38636363636364
75941, 1.8739130434783, 0.61956521739131, 0.36363636363636
75942, 1.895652173913, 0.64565217391304, 0.36363636363636
75943, 1.895652173913, 0.61956521739131, 0.34090909090909
75944, 1.8739130434783, 0.61956521739131, 0.31818181818182
75945, 1.895652173913, 0.64565217391304, 0.31818181818182
75946, 1.895652173913, 0.61956521739131, 0.29545454545455
75947, 1.8739130434783, 0.61956521739131, 0.27272727272727
75948, 1.895652173913, 0.64565217391304, 0.27272727272727
75949, 1.895652173913, 0.61956521739131, 0.25
75950, 1.8739130434783, 0.61956521739131, 0.22727272727273
75951, 1.895652173913, 0.64565217391304, 0.22727272727273
75952, 1.895652173913, 0.61956521739131, 0.20454545454545
75953, 1.8739130434783, 0.61956521739131, 0.18181818181818
75954, 1.895652173913, 0.64565217391304, 0.18181818181818
75955, 1.895652173913, 0.61956521739131, 0.15909090909091
75956, 1.8739130434783, 0.61956521739131, 0.13636363636364
75957, 1.895652173913, 0.64565217391304, 0.13636363636364
75958, 1.895652173913, 0.61956521739131, 0.11363636363636
75959, 1.8739130434783, 0.61956521739131, 0.090909090909091
75960, 1.895652173913, 0.64565217391304, 0.090909090909091
75961, 1.895652173913, 0.61956521739131, 0.068181818181818
75962, 1.8739130434783, 0.61956521739131, 0.045454545454545
75963, 1.895652173913, 0.64565217391304, 0.045454545454545
75964, 1.895652173913, 0.61956521739131, 0.022727272727273
75965, 1.9391304347826, 0.61956521739131, 0.47727272727273
75966, 1.9173913043478, 0.61956521739131, 0.45454545454545
75967, 1.9391304347826, 0.64565217391304, 0.45454545454545
75968, 1.9391304347826, 0.61956521739131, 0.43181818181818
75969, 1.9173913043478, 0.61956521739131, 0.40909090909091
75970, 1.9391304347826, 0.64565217391304, 0.40909090909091
75971, 1.9391304347826, 0.61956521739131, 0.38636363636364
75972, 1.9173913043478, 0.61956521739131, 0.36363636363636
75973, 1.9391304347826, 0.64565217391304, 0.36363636363636
75974, 1.9391304347826, 0.61956521739131, 0.34090909090909
75975, 1.9173913043478, 0.61956521739131, 0.31818181818182
75976, 1.9391304347826, 0.64565217391304, 0.31818181818182
75977, 1.9391304347826, 0.61956521739131, 0.29545454545455
75978, 1.9173913043478, 0.61956521739131, 0.27272727272727
75979, 1.9391304347826, 0.64565217391304, 0.27272727272727
75980, 1.9391304347826, 0.61956521739131, 0.25
75981, 1.9173913043478, 0.61956521739131, 0.22727272727273
75982, 1.9391304347826, 0.64565217391304, 0.22727272727273
75983, 1.9391304347826, 0.61956521739131, 0.20454545454545
75984, 1.9173913043478, 0.61956521739131, 0.18181818181818
75985, 1.9391304347826, 0.64565217391304, 0.18181818181818
75986, 1.9391304347826, 0.61956521739131, 0.15909090909091
75987, 1.9173913043478, 0.61956521739131, 0.13636363636364
75988, 1.9391304347826, 0.64565217391304, 0.13636363636364
75989, 1.9391304347826, 0.61956521739131, 0.11363636363636
75990, 1.9173913043478, 0.6195652173913, 0.090909090909091
75991, 1.9391304347826, 0.64565217391304, 0.090909090909091
75992, 1.9391304347826, 0.61956521739131, 0.068181818181818
75993, 1.9173913043478, 0.61956521739131, 0.045454545454545
75994, 1.9391304347826, 0.64565217391304, 0.045454545454545
75995, 1.9391304347826, 0.61956521739131, 0.022727272727273
75996, 1.9826086956522, 0.61956521739131, 0.47727272727273
75997, 1.9608695652174, 0.61956521739131, 0.45454545454545
75998, 1.9826086956522, 0.64565217391304, 0.45454545454545
75999, 1.9826086956522, 0.6195652173913, 0.43181818181818
76000, 1.9608695652174, 0.61956521739131, 0.40909090909091
76001, 1.9826086956522, 0.64565217391304, 0.40909090909091
76002, 1.9826086956522, 0.6195652173913, 0.38636363636364
76003, 1.9608695652174, 0.61956521739131, 0.36363636363636
76004, 1.9826086956522, 0.64565217391304, 0.36363636363636
76005, 1.9826086956522, 0.6195652173913, 0.34090909090909
76006, 1.9608695652174, 0.61956521739131, 0.31818181818182
76007, 1.9826086956522, 0.64565217391304, 0.31818181818182
76008, 1.9826086956522, 0.61956521739131, 0.29545454545455
76009, 1.9608695652174, 0.61956521739131, 0.27272727272727
76010, 1.9826086956522, 0.64565217391304, 0.27272727272727
76011, 1.9826086956522, 0.61956521739131, 0.25
76012, 1.9608695652174, 0.61956521739131, 0.22727272727273
76013, 1.9826086956522, 0.64565217391304, 0.22727272727273
76014, 1.9826086956522, 0.61956521739131, 0.20454545454545
76015, 1.9608695652174, 0.61956521739131, 0.18181818181818
76016, 1.9826086956522, 0.64565217391304, 0.18181818181818
76017, 1.9826086956522, 0.61956521739131, 0.15909090909091
76018, 1.9608695652174, 0.61956521739131, 0.13636363636364
76019, 1.9826086956522, 0.64565217391304, 0.13636363636364
76020, 1.9826086956522, 0.61956521739131, 0.11363636363636
76021, 1.9608695652174, 0.6195652173913, 0.090909090909091
76022, 1.9826086956522, 0.64565217391304, 0.090909090909091
76023, 1.9826086956522, 0.61956521739131, 0.068181818181818
76024, 1.9608695652174, 0.61956521739131, 0.045454545454545
76025, 1.9826086956522, 0.64565217391304, 0.045454545454545
76026, 1.9826086956522, 0.61956521739131, 0.022727272727273
76027, 2.0260869565217, 0.61956521739131, 0.47727272727273
76028, 2.004347826087, 0.6195652173913, 0.45454545454545
76029, 2.0260869565217, 0.64565217391304, 0.45454545454545
76030, 2.0260869565217, 0.6195652173913, 0.43181818181818
76031, 2.004347826087, 0.6195652173913, 0.40909090909091
76032, 2.0260869565217, 0.64565217391304, 0.40909090909091
76033, 2.0260869565217, 0.6195652173913, 0.38636363636364
76034, 2.004347826087, 0.61956521739131, 0.36363636363636
76035, 2.0260869565217, 0.64565217391304, 0.36363636363636
76036, 2.0260869565217, 0.61956521739131, 0.34090909090909
76037, 2.004347826087, 0.6195652173913, 0.31818181818182
76038, 2.0260869565217, 0.64565217391304, 0.31818181818182
76039, 2.0260869565217, 0.61956521739131, 0.29545454545455
76040, 2.004347826087, 0.61956521739131, 0.27272727272727
76041, 2.0260869565217, 0.64565217391304, 0.27272727272727
76042, 2.0260869565217, 0.61956521739131, 0.25
76043, 2.004347826087, 0.61956521739131, 0.22727272727273
76044, 2.0260869565217, 0.64565217391304, 0.22727272727273
76045, 2.0260869565217, 0.61956521739131, 0.20454545454545
76046, 2.004347826087, 0.6195652173913, 0.18181818181818
76047, 2.0260869565217, 0.64565217391304, 0.18181818181818
76048, 2.0260869565217, 0.61956521739131, 0.15909090909091
76049, 2.004347826087, 0.61956521739131, 0.13636363636364
76050, 2.0260869565217, 0.64565217391304, 0.13636363636364
76051, 2.0260869565217, 0.61956521739131, 0.11363636363636
76052, 2.004347826087, 0.61956521739131, 0.090909090909091
76053, 2.0260869565217, 0.64565217391304, 0.090909090909091
76054, 2.0260869565217, 0.61956521739131, 0.068181818181818
76055, 2.004347826087, 0.61956521739131, 0.045454545454545
76056, 2.0260869565217, 0.64565217391304, 0.045454545454545
76057, 2.0260869565217, 0.61956521739131, 0.022727272727273
76058, 2.0695652173913, 0.61956521739131, 0.47727272727273
76059, 2.0478260869565, 0.6195652173913, 0.45454545454545
76060, 2.0695652173913, 0.64565217391304, 0.45454545454545
76061, 2.0695652173913, 0.6195652173913, 0.43181818181818
76062, 2.0478260869565, 0.6195652173913, 0.40909090909091
76063, 2.0695652173913, 0.64565217391304, 0.40909090909091
76064, 2.0695652173913, 0.6195652173913, 0.38636363636364
76065, 2.0478260869565, 0.61956521739131, 0.36363636363636
76066, 2.0695652173913, 0.64565217391304, 0.36363636363636
76067, 2.0695652173913, 0.6195652173913, 0.34090909090909
76068, 2.0478260869565, 0.6195652173913, 0.31818181818182
76069, 2.0695652173913, 0.64565217391304, 0.31818181818182
76070, 2.0695652173913, 0.6195652173913, 0.29545454545455
76071, 2.0478260869565, 0.61956521739131, 0.27272727272727
76072, 2.0695652173913, 0.64565217391304, 0.27272727272727
76073, 2.0695652173913, 0.61956521739131, 0.25
76074, 2.0478260869565, 0.61956521739131, 0.22727272727273
76075, 2.0695652173913, 0.64565217391304, 0.22727272727273
76076, 2.0695652173913, 0.6195652173913, 0.20454545454545
76077, 2.0478260869565, 0.6195652173913, 0.18181818181818
76078, 2.0695652173913, 0.64565217391304, 0.18181818181818
76079, 2.0695652173913, 0.61956521739131, 0.15909090909091
76080, 2.0478260869565, 0.61956521739131, 0.13636363636364
76081, 2.0695652173913, 0.64565217391304, 0.13636363636364
76082, 2.0695652173913, 0.61956521739131, 0.11363636363636
76083, 2.0478260869565, 0.61956521739131, 0.090909090909091
76084, 2.0695652173913, 0.64565217391304, 0.090909090909091
76085, 2.0695652173913, 0.6195652173913, 0.068181818181818
76086, 2.0478260869565, 0.6195652173913, 0.045454545454545
76087, 2.0695652173913, 0.64565217391304, 0.045454545454545
76088, 2.0695652173913, 0.61956521739131, 0.022727272727273
76089, 2.1130434782609, 0.61956521739131, 0.47727272727273
76090, 2.0913043478261, 0.6195652173913, 0.45454545454545
76091, 2.1130434782609, 0.64565217391304, 0.45454545454545
76092, 2.1130434782609, 0.6195652173913, 0.43181818181818
76093, 2.0913043478261, 0.6195652173913, 0.40909090909091
76094, 2.1130434782609, 0.64565217391304, 0.40909090909091
76095, 2.1130434782609, 0.61956521739131, 0.38636363636364
76096, 2.0913043478261, 0.61956521739131, 0.36363636363636
76097, 2.1130434782609, 0.64565217391304, 0.36363636363636
76098, 2.1130434782609, 0.61956521739131, 0.34090909090909
76099, 2.0913043478261, 0.6195652173913, 0.31818181818182
76100, 2.1130434782609, 0.64565217391304, 0.31818181818182
76101, 2.1130434782609, 0.61956521739131, 0.29545454545455
76102, 2.0913043478261, 0.61956521739131, 0.27272727272727
76103, 2.1130434782609, 0.64565217391304, 0.27272727272727
76104, 2.1130434782609, 0.61956521739131, 0.25
76105, 2.0913043478261, 0.61956521739131, 0.22727272727273
76106, 2.1130434782609, 0.64565217391304, 0.22727272727273
76107, 2.1130434782609, 0.61956521739131, 0.20454545454545
76108, 2.0913043478261, 0.6195652173913, 0.18181818181818
76109, 2.1130434782609, 0.64565217391304, 0.18181818181818
76110, 2.1130434782609, 0.61956521739131, 0.15909090909091
76111, 2.0913043478261, 0.61956521739131, 0.13636363636364
76112, 2.1130434782609, 0.64565217391304, 0.13636363636364
76113, 2.1130434782609, 0.61956521739131, 0.11363636363636
76114, 2.0913043478261, 0.6195652173913, 0.090909090909091
76115, 2.1130434782609, 0.64565217391304, 0.090909090909091
76116, 2.1130434782609, 0.6195652173913, 0.068181818181818
76117, 2.0913043478261, 0.6195652173913, 0.045454545454545
76118, 2.1130434782609, 0.64565217391304, 0.045454545454545
76119, 2.1130434782609, 0.61956521739131, 0.022727272727273
76120, 2.1565217391304, 0.61956521739131, 0.47727272727273
76121, 2.1347826086957, 0.6195652173913, 0.45454545454545
76122, 2.1565217391304, 0.64565217391304, 0.45454545454545
76123, 2.1565217391304, 0.6195652173913, 0.43181818181818
76124, 2.1347826086957, 0.6195652173913, 0.40909090909091
76125, 2.1565217391304, 0.64565217391304, 0.40909090909091
76126, 2.1565217391304, 0.61956521739131, 0.38636363636364
76127, 2.1347826086957, 0.61956521739131, 0.36363636363636
76128, 2.1565217391304, 0.64565217391304, 0.36363636363636
76129, 2.1565217391304, 0.61956521739131, 0.34090909090909
76130, 2.1347826086957, 0.61956521739131, 0.31818181818182
76131, 2.1565217391304, 0.64565217391304, 0.31818181818182
76132, 2.1565217391304, 0.61956521739131, 0.29545454545455
76133, 2.1347826086957, 0.61956521739131, 0.27272727272727
76134, 2.1565217391304, 0.64565217391304, 0.27272727272727
76135, 2.1565217391304, 0.61956521739131, 0.25
76136, 2.1347826086957, 0.61956521739131, 0.22727272727273
76137, 2.1565217391304, 0.64565217391304, 0.22727272727273
76138, 2.1565217391304, 0.61956521739131, 0.20454545454545
76139, 2.1347826086957, 0.61956521739131, 0.18181818181818
76140, 2.1565217391304, 0.64565217391304, 0.18181818181818
76141, 2.1565217391304, 0.61956521739131, 0.15909090909091
76142, 2.1347826086957, 0.61956521739131, 0.13636363636364
76143, 2.1565217391304, 0.64565217391304, 0.13636363636364
76144, 2.1565217391304, 0.61956521739131, 0.11363636363636
76145, 2.1347826086957, 0.6195652173913, 0.090909090909091
76146, 2.1565217391304, 0.64565217391304, 0.090909090909091
76147, 2.1565217391304, 0.61956521739131, 0.068181818181818
76148, 2.1347826086957, 0.61956521739131, 0.045454545454545
76149, 2.1565217391304, 0.64565217391304, 0.045454545454545
76150, 2.1565217391304, 0.61956521739131, 0.022727272727273
76151, 2.1782608695652, 0.6195652173913, 0.45454545454545
76152, 2.1782608695652, 0.6195652173913, 0.40909090909091
76153, 2.1782608695652, 0.61956521739131, 0.36363636363636
76154, 2.1782608695652, 0.61956521739131, 0.31818181818182
76155, 2.1782608695652, 0.61956521739131, 0.27272727272727
76156, 2.1782608695652, 0.61956521739131, 0.22727272727273
76157, 2.1782608695652, 0.61956521739131, 0.18181818181818
76158, 2.1782608695652, 0.61956521739131, 0.13636363636364
76159, 2.1782608695652, 0.6195652173913, 0.090909090909091
76160, 2.1782608695652, 0.61956521739131, 0.045454545454545
76161, 1.2434782608696, 0.56739130434783, 0.47727272727273
76162, 1.2217391304348, 0.56739130434783, 0.45454545454545
76163, 1.2434782608696, 0.59347826086957, 0.45454545454545
76164, 1.2434782608696, 0.56739130434783, 0.43181818181818
76165, 1.2217391304348, 0.56739130434783, 0.40909090909091
76166, 1.2434782608696, 0.59347826086957, 0.40909090909091
76167, 1.2434782608696, 0.56739130434783, 0.38636363636364
76168, 1.2217391304348, 0.56739130434783, 0.36363636363636
76169, 1.2434782608696, 0.59347826086957, 0.36363636363636
76170, 1.2434782608696, 0.56739130434783, 0.34090909090909
76171, 1.2217391304348, 0.56739130434783, 0.31818181818182
76172, 1.2434782608696, 0.59347826086957, 0.31818181818182
76173, 1.2434782608696, 0.56739130434783, 0.29545454545455
76174, 1.2217391304348, 0.56739130434783, 0.27272727272727
76175, 1.2434782608696, 0.59347826086957, 0.27272727272727
76176, 1.2434782608696, 0.56739130434783, 0.25
76177, 1.2217391304348, 0.56739130434783, 0.22727272727273
76178, 1.2434782608696, 0.59347826086957, 0.22727272727273
76179, 1.2434782608696, 0.56739130434783, 0.20454545454545
76180, 1.2217391304348, 0.56739130434783, 0.18181818181818
76181, 1.2434782608696, 0.59347826086957, 0.18181818181818
76182, 1.2434782608696, 0.56739130434783, 0.15909090909091
76183, 1.2217391304348, 0.56739130434783, 0.13636363636364
76184, 1.2434782608696, 0.59347826086957, 0.13636363636364
76185, 1.2434782608696, 0.56739130434783, 0.11363636363636
76186, 1.2217391304348, 0.56739130434783, 0.090909090909091
76187, 1.2434782608696, 0.59347826086957, 0.090909090909091
76188, 1.2434782608696, 0.56739130434783, 0.068181818181818
76189, 1.2217391304348, 0.56739130434783, 0.045454545454545
76190, 1.2434782608696, 0.59347826086957, 0.045454545454545
76191, 1.2434782608696, 0.56739130434783, 0.022727272727273
76192, 1.2869565217391, 0.56739130434783, 0.47727272727273
76193, 1.2652173913043, 0.56739130434783, 0.45454545454545
76194, 1.2869565217391, 0.59347826086957, 0.45454545454545
76195, 1.2869565217391, 0.56739130434783, 0.43181818181818
76196, 1.2652173913043, 0.56739130434783, 0.40909090909091
76197, 1.2869565217391, 0.59347826086957, 0.40909090909091
76198, 1.2869565217391, 0.56739130434783, 0.38636363636364
76199, 1.2652173913043, 0.56739130434783, 0.36363636363636
76200, 1.2869565217391, 0.59347826086957, 0.36363636363636
76201, 1.2869565217391, 0.56739130434783, 0.34090909090909
76202, 1.2652173913043, 0.56739130434783, 0.31818181818182
76203, 1.2869565217391, 0.59347826086957, 0.31818181818182
76204, 1.2869565217391, 0.56739130434783, 0.29545454545455
76205, 1.2652173913043, 0.56739130434783, 0.27272727272727
