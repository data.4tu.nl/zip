46503, 0.80434782608696, 0.72391304347826, 0.18181818181818
46504, 0.78260869565217, 0.69782608695652, 0.18181818181818
46505, 0.78260869565217, 0.72391304347826, 0.20454545454545
46506, 0.80434782608696, 0.72391304347826, 0.22727272727273
46507, 0.78260869565217, 0.69782608695652, 0.22727272727273
46508, 0.78260869565217, 0.72391304347826, 0.25
46509, 0.80434782608696, 0.72391304347826, 0.27272727272727
46510, 0.78260869565217, 0.69782608695652, 0.27272727272727
46511, 0.78260869565217, 0.72391304347826, 0.29545454545455
46512, 0.80434782608696, 0.72391304347826, 0.31818181818182
46513, 0.78260869565217, 0.69782608695652, 0.31818181818182
46514, 0.78260869565217, 0.72391304347826, 0.34090909090909
46515, 0.80434782608696, 0.72391304347826, 0.36363636363636
46516, 0.78260869565217, 0.69782608695652, 0.36363636363636
46517, 0.78260869565217, 0.72391304347826, 0.38636363636364
46518, 0.80434782608696, 0.72391304347826, 0.40909090909091
46519, 0.78260869565217, 0.69782608695652, 0.40909090909091
46520, 0.78260869565217, 0.72391304347826, 0.43181818181818
46521, 0.80434782608696, 0.72391304347826, 0.45454545454545
46522, 0.78260869565217, 0.69782608695652, 0.45454545454545
46523, 0.78260869565217, 0.72391304347826, 0.47727272727273
46524, 0.73913043478261, 0.72391304347826, 0.022727272727273
46525, 0.76086956521739, 0.72391304347826, 0.045454545454545
46526, 0.73913043478261, 0.69782608695652, 0.045454545454545
46527, 0.73913043478261, 0.72391304347826, 0.068181818181818
46528, 0.76086956521739, 0.72391304347826, 0.090909090909091
46529, 0.73913043478261, 0.69782608695652, 0.090909090909091
46530, 0.73913043478261, 0.72391304347826, 0.11363636363636
46531, 0.76086956521739, 0.72391304347826, 0.13636363636364
46532, 0.73913043478261, 0.69782608695652, 0.13636363636364
46533, 0.73913043478261, 0.72391304347826, 0.15909090909091
46534, 0.76086956521739, 0.72391304347826, 0.18181818181818
46535, 0.73913043478261, 0.69782608695652, 0.18181818181818
46536, 0.73913043478261, 0.72391304347826, 0.20454545454545
46537, 0.76086956521739, 0.72391304347826, 0.22727272727273
46538, 0.73913043478261, 0.69782608695652, 0.22727272727273
46539, 0.73913043478261, 0.72391304347826, 0.25
46540, 0.76086956521739, 0.72391304347826, 0.27272727272727
46541, 0.73913043478261, 0.69782608695652, 0.27272727272727
46542, 0.73913043478261, 0.72391304347826, 0.29545454545455
46543, 0.76086956521739, 0.72391304347826, 0.31818181818182
46544, 0.73913043478261, 0.69782608695652, 0.31818181818182
46545, 0.73913043478261, 0.72391304347826, 0.34090909090909
46546, 0.76086956521739, 0.72391304347826, 0.36363636363636
46547, 0.73913043478261, 0.69782608695652, 0.36363636363636
46548, 0.73913043478261, 0.72391304347826, 0.38636363636364
46549, 0.76086956521739, 0.72391304347826, 0.40909090909091
46550, 0.73913043478261, 0.69782608695652, 0.40909090909091
46551, 0.73913043478261, 0.72391304347826, 0.43181818181818
46552, 0.76086956521739, 0.72391304347826, 0.45454545454545
46553, 0.73913043478261, 0.69782608695652, 0.45454545454545
46554, 0.73913043478261, 0.72391304347826, 0.47727272727273
46555, 0.69565217391304, 0.72391304347826, 0.022727272727273
46556, 0.71739130434783, 0.72391304347826, 0.045454545454545
46557, 0.69565217391304, 0.69782608695652, 0.045454545454545
46558, 0.69565217391304, 0.72391304347826, 0.068181818181818
46559, 0.71739130434783, 0.72391304347826, 0.090909090909091
46560, 0.69565217391304, 0.69782608695652, 0.090909090909091
46561, 0.69565217391304, 0.72391304347826, 0.11363636363636
46562, 0.71739130434783, 0.72391304347826, 0.13636363636364
46563, 0.69565217391304, 0.69782608695652, 0.13636363636364
46564, 0.69565217391304, 0.72391304347826, 0.15909090909091
46565, 0.71739130434783, 0.72391304347826, 0.18181818181818
46566, 0.69565217391304, 0.69782608695652, 0.18181818181818
46567, 0.69565217391304, 0.72391304347826, 0.20454545454545
46568, 0.71739130434783, 0.72391304347826, 0.22727272727273
46569, 0.69565217391304, 0.69782608695652, 0.22727272727273
46570, 0.69565217391304, 0.72391304347826, 0.25
46571, 0.71739130434783, 0.72391304347826, 0.27272727272727
46572, 0.69565217391304, 0.69782608695652, 0.27272727272727
46573, 0.69565217391304, 0.72391304347826, 0.29545454545455
46574, 0.71739130434783, 0.72391304347826, 0.31818181818182
46575, 0.69565217391304, 0.69782608695652, 0.31818181818182
46576, 0.69565217391304, 0.72391304347826, 0.34090909090909
46577, 0.71739130434783, 0.72391304347826, 0.36363636363636
46578, 0.69565217391304, 0.69782608695652, 0.36363636363636
46579, 0.69565217391304, 0.72391304347826, 0.38636363636364
46580, 0.71739130434783, 0.72391304347826, 0.40909090909091
46581, 0.69565217391304, 0.69782608695652, 0.40909090909091
46582, 0.69565217391304, 0.72391304347826, 0.43181818181818
46583, 0.71739130434783, 0.72391304347826, 0.45454545454545
46584, 0.69565217391304, 0.69782608695652, 0.45454545454545
46585, 0.69565217391304, 0.72391304347826, 0.47727272727273
46586, 0.65217391304348, 0.72391304347826, 0.022727272727273
46587, 0.67391304347826, 0.72391304347826, 0.045454545454545
46588, 0.65217391304348, 0.69782608695652, 0.045454545454545
46589, 0.65217391304348, 0.72391304347826, 0.068181818181818
46590, 0.67391304347826, 0.72391304347826, 0.090909090909091
46591, 0.65217391304348, 0.69782608695652, 0.090909090909091
46592, 0.65217391304348, 0.72391304347826, 0.11363636363636
46593, 0.67391304347826, 0.72391304347826, 0.13636363636364
46594, 0.65217391304348, 0.69782608695652, 0.13636363636364
46595, 0.65217391304348, 0.72391304347826, 0.15909090909091
46596, 0.67391304347826, 0.72391304347826, 0.18181818181818
46597, 0.65217391304348, 0.69782608695652, 0.18181818181818
46598, 0.65217391304348, 0.72391304347826, 0.20454545454545
46599, 0.67391304347826, 0.72391304347826, 0.22727272727273
46600, 0.65217391304348, 0.69782608695652, 0.22727272727273
46601, 0.65217391304348, 0.72391304347826, 0.25
46602, 0.67391304347826, 0.72391304347826, 0.27272727272727
46603, 0.65217391304348, 0.69782608695652, 0.27272727272727
46604, 0.65217391304348, 0.72391304347826, 0.29545454545455
46605, 0.67391304347826, 0.72391304347826, 0.31818181818182
46606, 0.65217391304348, 0.69782608695652, 0.31818181818182
46607, 0.65217391304348, 0.72391304347826, 0.34090909090909
46608, 0.67391304347826, 0.72391304347826, 0.36363636363636
46609, 0.65217391304348, 0.69782608695652, 0.36363636363636
46610, 0.65217391304348, 0.72391304347826, 0.38636363636364
46611, 0.67391304347826, 0.72391304347826, 0.40909090909091
46612, 0.65217391304348, 0.69782608695652, 0.40909090909091
46613, 0.65217391304348, 0.72391304347826, 0.43181818181818
46614, 0.67391304347826, 0.72391304347826, 0.45454545454545
46615, 0.65217391304348, 0.69782608695652, 0.45454545454545
46616, 0.65217391304348, 0.72391304347826, 0.47727272727273
46617, 0.60869565217391, 0.72391304347826, 0.022727272727273
46618, 0.6304347826087, 0.72391304347826, 0.045454545454545
46619, 0.60869565217391, 0.69782608695652, 0.045454545454545
46620, 0.60869565217391, 0.72391304347826, 0.068181818181818
46621, 0.6304347826087, 0.72391304347826, 0.090909090909091
46622, 0.60869565217391, 0.69782608695652, 0.090909090909091
46623, 0.60869565217391, 0.72391304347826, 0.11363636363636
46624, 0.6304347826087, 0.72391304347826, 0.13636363636364
46625, 0.60869565217391, 0.69782608695652, 0.13636363636364
46626, 0.60869565217391, 0.72391304347826, 0.15909090909091
46627, 0.6304347826087, 0.72391304347826, 0.18181818181818
46628, 0.60869565217391, 0.69782608695652, 0.18181818181818
46629, 0.60869565217391, 0.72391304347826, 0.20454545454545
46630, 0.6304347826087, 0.72391304347826, 0.22727272727273
46631, 0.60869565217391, 0.69782608695652, 0.22727272727273
46632, 0.60869565217391, 0.72391304347826, 0.25
46633, 0.6304347826087, 0.72391304347826, 0.27272727272727
46634, 0.60869565217391, 0.69782608695652, 0.27272727272727
46635, 0.60869565217391, 0.72391304347826, 0.29545454545455
46636, 0.6304347826087, 0.72391304347826, 0.31818181818182
46637, 0.60869565217391, 0.69782608695652, 0.31818181818182
46638, 0.60869565217391, 0.72391304347826, 0.34090909090909
46639, 0.6304347826087, 0.72391304347826, 0.36363636363636
46640, 0.60869565217391, 0.69782608695652, 0.36363636363636
46641, 0.60869565217391, 0.72391304347826, 0.38636363636364
46642, 0.6304347826087, 0.72391304347826, 0.40909090909091
46643, 0.60869565217391, 0.69782608695652, 0.40909090909091
46644, 0.60869565217391, 0.72391304347826, 0.43181818181818
46645, 0.6304347826087, 0.72391304347826, 0.45454545454545
46646, 0.60869565217391, 0.69782608695652, 0.45454545454545
46647, 0.60869565217391, 0.72391304347826, 0.47727272727273
46648, 0.56521739130435, 0.72391304347826, 0.022727272727273
46649, 0.58695652173913, 0.72391304347826, 0.045454545454545
46650, 0.56521739130435, 0.69782608695652, 0.045454545454545
46651, 0.56521739130435, 0.72391304347826, 0.068181818181818
46652, 0.58695652173913, 0.72391304347826, 0.090909090909091
46653, 0.56521739130435, 0.69782608695652, 0.090909090909091
46654, 0.56521739130435, 0.72391304347826, 0.11363636363636
46655, 0.58695652173913, 0.72391304347826, 0.13636363636364
46656, 0.56521739130435, 0.69782608695652, 0.13636363636364
46657, 0.56521739130435, 0.72391304347826, 0.15909090909091
46658, 0.58695652173913, 0.72391304347826, 0.18181818181818
46659, 0.56521739130435, 0.69782608695652, 0.18181818181818
46660, 0.56521739130435, 0.72391304347826, 0.20454545454545
46661, 0.58695652173913, 0.72391304347826, 0.22727272727273
46662, 0.56521739130435, 0.69782608695652, 0.22727272727273
46663, 0.56521739130435, 0.72391304347826, 0.25
46664, 0.58695652173913, 0.72391304347826, 0.27272727272727
46665, 0.56521739130435, 0.69782608695652, 0.27272727272727
46666, 0.56521739130435, 0.72391304347826, 0.29545454545455
46667, 0.58695652173913, 0.72391304347826, 0.31818181818182
46668, 0.56521739130435, 0.69782608695652, 0.31818181818182
46669, 0.56521739130435, 0.72391304347826, 0.34090909090909
46670, 0.58695652173913, 0.72391304347826, 0.36363636363636
46671, 0.56521739130435, 0.69782608695652, 0.36363636363636
46672, 0.56521739130435, 0.72391304347826, 0.38636363636364
46673, 0.58695652173913, 0.72391304347826, 0.40909090909091
46674, 0.56521739130435, 0.69782608695652, 0.40909090909091
46675, 0.56521739130435, 0.72391304347826, 0.43181818181818
46676, 0.58695652173913, 0.72391304347826, 0.45454545454545
46677, 0.56521739130435, 0.69782608695652, 0.45454545454545
46678, 0.56521739130435, 0.72391304347826, 0.47727272727273
46679, 0.52173913043478, 0.72391304347826, 0.022727272727273
46680, 0.54347826086956, 0.72391304347826, 0.045454545454545
46681, 0.52173913043478, 0.69782608695652, 0.045454545454545
46682, 0.52173913043478, 0.72391304347826, 0.068181818181818
46683, 0.54347826086956, 0.72391304347826, 0.090909090909091
46684, 0.52173913043478, 0.69782608695652, 0.090909090909091
46685, 0.52173913043478, 0.72391304347826, 0.11363636363636
46686, 0.54347826086957, 0.72391304347826, 0.13636363636364
46687, 0.52173913043478, 0.69782608695652, 0.13636363636364
46688, 0.52173913043478, 0.72391304347826, 0.15909090909091
46689, 0.54347826086956, 0.72391304347826, 0.18181818181818
46690, 0.52173913043478, 0.69782608695652, 0.18181818181818
46691, 0.52173913043478, 0.72391304347826, 0.20454545454545
46692, 0.54347826086956, 0.72391304347826, 0.22727272727273
46693, 0.52173913043478, 0.69782608695652, 0.22727272727273
46694, 0.52173913043478, 0.72391304347826, 0.25
46695, 0.54347826086956, 0.72391304347826, 0.27272727272727
46696, 0.52173913043478, 0.69782608695652, 0.27272727272727
46697, 0.52173913043478, 0.72391304347826, 0.29545454545455
46698, 0.54347826086956, 0.72391304347826, 0.31818181818182
46699, 0.52173913043478, 0.69782608695652, 0.31818181818182
46700, 0.52173913043478, 0.72391304347826, 0.34090909090909
46701, 0.54347826086957, 0.72391304347826, 0.36363636363636
46702, 0.52173913043478, 0.69782608695652, 0.36363636363636
46703, 0.52173913043478, 0.72391304347826, 0.38636363636364
46704, 0.54347826086956, 0.72391304347826, 0.40909090909091
46705, 0.52173913043478, 0.69782608695652, 0.40909090909091
46706, 0.52173913043478, 0.72391304347826, 0.43181818181818
46707, 0.54347826086956, 0.72391304347826, 0.45454545454545
46708, 0.52173913043478, 0.69782608695652, 0.45454545454545
46709, 0.52173913043478, 0.72391304347826, 0.47727272727273
46710, 0.47826086956522, 0.72391304347826, 0.022727272727273
46711, 0.5, 0.72391304347826, 0.045454545454545
46712, 0.47826086956522, 0.69782608695652, 0.045454545454545
46713, 0.47826086956522, 0.72391304347826, 0.068181818181818
46714, 0.5, 0.72391304347826, 0.090909090909091
46715, 0.47826086956522, 0.69782608695652, 0.090909090909091
46716, 0.47826086956522, 0.72391304347826, 0.11363636363636
46717, 0.5, 0.72391304347826, 0.13636363636364
46718, 0.47826086956522, 0.69782608695652, 0.13636363636364
46719, 0.47826086956522, 0.72391304347826, 0.15909090909091
46720, 0.5, 0.72391304347826, 0.18181818181818
46721, 0.47826086956522, 0.69782608695652, 0.18181818181818
46722, 0.47826086956522, 0.72391304347826, 0.20454545454545
46723, 0.5, 0.72391304347826, 0.22727272727273
46724, 0.47826086956522, 0.69782608695652, 0.22727272727273
46725, 0.47826086956522, 0.72391304347826, 0.25
46726, 0.5, 0.72391304347826, 0.27272727272727
46727, 0.47826086956522, 0.69782608695652, 0.27272727272727
46728, 0.47826086956522, 0.72391304347826, 0.29545454545455
46729, 0.5, 0.72391304347826, 0.31818181818182
46730, 0.47826086956522, 0.69782608695652, 0.31818181818182
46731, 0.47826086956522, 0.72391304347826, 0.34090909090909
46732, 0.5, 0.72391304347826, 0.36363636363636
46733, 0.47826086956522, 0.69782608695652, 0.36363636363636
46734, 0.47826086956522, 0.72391304347826, 0.38636363636364
46735, 0.5, 0.72391304347826, 0.40909090909091
46736, 0.47826086956522, 0.69782608695652, 0.40909090909091
46737, 0.47826086956522, 0.72391304347826, 0.43181818181818
46738, 0.5, 0.72391304347826, 0.45454545454545
46739, 0.47826086956522, 0.69782608695652, 0.45454545454545
46740, 0.47826086956522, 0.72391304347826, 0.47727272727273
46741, 0.43478260869565, 0.72391304347826, 0.022727272727273
46742, 0.45652173913043, 0.72391304347826, 0.045454545454545
46743, 0.43478260869565, 0.69782608695652, 0.045454545454545
46744, 0.43478260869565, 0.72391304347826, 0.068181818181818
46745, 0.45652173913043, 0.72391304347826, 0.090909090909091
46746, 0.43478260869565, 0.69782608695652, 0.090909090909091
46747, 0.43478260869565, 0.72391304347826, 0.11363636363636
46748, 0.45652173913043, 0.72391304347826, 0.13636363636364
46749, 0.43478260869565, 0.69782608695652, 0.13636363636364
46750, 0.43478260869565, 0.72391304347826, 0.15909090909091
46751, 0.45652173913043, 0.72391304347826, 0.18181818181818
46752, 0.43478260869565, 0.69782608695652, 0.18181818181818
46753, 0.43478260869565, 0.72391304347826, 0.20454545454545
46754, 0.45652173913043, 0.72391304347826, 0.22727272727273
46755, 0.43478260869565, 0.69782608695652, 0.22727272727273
46756, 0.43478260869565, 0.72391304347826, 0.25
46757, 0.45652173913043, 0.72391304347826, 0.27272727272727
46758, 0.43478260869565, 0.69782608695652, 0.27272727272727
46759, 0.43478260869565, 0.72391304347826, 0.29545454545455
46760, 0.45652173913043, 0.72391304347826, 0.31818181818182
46761, 0.43478260869565, 0.69782608695652, 0.31818181818182
46762, 0.43478260869565, 0.72391304347826, 0.34090909090909
46763, 0.45652173913043, 0.72391304347826, 0.36363636363636
46764, 0.43478260869565, 0.69782608695652, 0.36363636363636
46765, 0.43478260869565, 0.72391304347826, 0.38636363636364
46766, 0.45652173913043, 0.72391304347826, 0.40909090909091
46767, 0.43478260869565, 0.69782608695652, 0.40909090909091
46768, 0.43478260869565, 0.72391304347826, 0.43181818181818
46769, 0.45652173913043, 0.72391304347826, 0.45454545454545
46770, 0.43478260869565, 0.69782608695652, 0.45454545454545
46771, 0.43478260869565, 0.72391304347826, 0.47727272727273
46772, 0.39130434782609, 0.72391304347826, 0.022727272727273
46773, 0.41304347826087, 0.72391304347826, 0.045454545454545
46774, 0.39130434782609, 0.69782608695652, 0.045454545454545
46775, 0.39130434782609, 0.72391304347826, 0.068181818181818
46776, 0.41304347826087, 0.72391304347826, 0.090909090909091
46777, 0.39130434782609, 0.69782608695652, 0.090909090909091
46778, 0.39130434782609, 0.72391304347826, 0.11363636363636
46779, 0.41304347826087, 0.72391304347826, 0.13636363636364
46780, 0.39130434782609, 0.69782608695652, 0.13636363636364
46781, 0.39130434782609, 0.72391304347826, 0.15909090909091
46782, 0.41304347826087, 0.72391304347826, 0.18181818181818
46783, 0.39130434782609, 0.69782608695652, 0.18181818181818
46784, 0.39130434782609, 0.72391304347826, 0.20454545454545
46785, 0.41304347826087, 0.72391304347826, 0.22727272727273
46786, 0.39130434782609, 0.69782608695652, 0.22727272727273
46787, 0.39130434782609, 0.72391304347826, 0.25
46788, 0.41304347826087, 0.72391304347826, 0.27272727272727
46789, 0.39130434782609, 0.69782608695652, 0.27272727272727
46790, 0.39130434782609, 0.72391304347826, 0.29545454545455
46791, 0.41304347826087, 0.72391304347826, 0.31818181818182
46792, 0.39130434782609, 0.69782608695652, 0.31818181818182
46793, 0.39130434782609, 0.72391304347826, 0.34090909090909
46794, 0.41304347826087, 0.72391304347826, 0.36363636363636
46795, 0.39130434782609, 0.69782608695652, 0.36363636363636
46796, 0.39130434782609, 0.72391304347826, 0.38636363636364
46797, 0.41304347826087, 0.72391304347826, 0.40909090909091
46798, 0.39130434782609, 0.69782608695652, 0.40909090909091
46799, 0.39130434782609, 0.72391304347826, 0.43181818181818
46800, 0.41304347826087, 0.72391304347826, 0.45454545454545
46801, 0.39130434782609, 0.69782608695652, 0.45454545454545
46802, 0.39130434782609, 0.72391304347826, 0.47727272727273
46803, 0.34782608695652, 0.72391304347826, 0.022727272727273
46804, 0.3695652173913, 0.72391304347826, 0.045454545454545
46805, 0.34782608695652, 0.69782608695652, 0.045454545454545
46806, 0.34782608695652, 0.72391304347826, 0.068181818181818
46807, 0.3695652173913, 0.72391304347826, 0.090909090909091
46808, 0.34782608695652, 0.69782608695652, 0.090909090909091
46809, 0.34782608695652, 0.72391304347826, 0.11363636363636
46810, 0.3695652173913, 0.72391304347826, 0.13636363636364
46811, 0.34782608695652, 0.69782608695652, 0.13636363636364
46812, 0.34782608695652, 0.72391304347826, 0.15909090909091
46813, 0.3695652173913, 0.72391304347826, 0.18181818181818
46814, 0.34782608695652, 0.69782608695652, 0.18181818181818
46815, 0.34782608695652, 0.72391304347826, 0.20454545454545
46816, 0.3695652173913, 0.72391304347826, 0.22727272727273
46817, 0.34782608695652, 0.69782608695652, 0.22727272727273
46818, 0.34782608695652, 0.72391304347826, 0.25
46819, 0.3695652173913, 0.72391304347826, 0.27272727272727
46820, 0.34782608695652, 0.69782608695652, 0.27272727272727
46821, 0.34782608695652, 0.72391304347826, 0.29545454545455
46822, 0.3695652173913, 0.72391304347826, 0.31818181818182
46823, 0.34782608695652, 0.69782608695652, 0.31818181818182
46824, 0.34782608695652, 0.72391304347826, 0.34090909090909
46825, 0.3695652173913, 0.72391304347826, 0.36363636363636
46826, 0.34782608695652, 0.69782608695652, 0.36363636363636
46827, 0.34782608695652, 0.72391304347826, 0.38636363636364
46828, 0.3695652173913, 0.72391304347826, 0.40909090909091
46829, 0.34782608695652, 0.69782608695652, 0.40909090909091
46830, 0.34782608695652, 0.72391304347826, 0.43181818181818
46831, 0.3695652173913, 0.72391304347826, 0.45454545454545
46832, 0.34782608695652, 0.69782608695652, 0.45454545454545
46833, 0.34782608695652, 0.72391304347826, 0.47727272727273
46834, 0.30434782608696, 0.72391304347826, 0.022727272727273
46835, 0.32608695652174, 0.72391304347826, 0.045454545454545
46836, 0.30434782608696, 0.69782608695652, 0.045454545454545
46837, 0.30434782608696, 0.72391304347826, 0.068181818181818
46838, 0.32608695652174, 0.72391304347826, 0.090909090909091
46839, 0.30434782608696, 0.69782608695652, 0.090909090909091
46840, 0.30434782608696, 0.72391304347826, 0.11363636363636
46841, 0.32608695652174, 0.72391304347826, 0.13636363636364
46842, 0.30434782608696, 0.69782608695652, 0.13636363636364
46843, 0.30434782608696, 0.72391304347826, 0.15909090909091
46844, 0.32608695652174, 0.72391304347826, 0.18181818181818
46845, 0.30434782608696, 0.69782608695652, 0.18181818181818
46846, 0.30434782608696, 0.72391304347826, 0.20454545454545
46847, 0.32608695652174, 0.72391304347826, 0.22727272727273
46848, 0.30434782608696, 0.69782608695652, 0.22727272727273
46849, 0.30434782608696, 0.72391304347826, 0.25
46850, 0.32608695652174, 0.72391304347826, 0.27272727272727
46851, 0.30434782608696, 0.69782608695652, 0.27272727272727
46852, 0.30434782608696, 0.72391304347826, 0.29545454545455
46853, 0.32608695652174, 0.72391304347826, 0.31818181818182
46854, 0.30434782608696, 0.69782608695652, 0.31818181818182
46855, 0.30434782608696, 0.72391304347826, 0.34090909090909
46856, 0.32608695652174, 0.72391304347826, 0.36363636363636
46857, 0.30434782608696, 0.69782608695652, 0.36363636363636
46858, 0.30434782608696, 0.72391304347826, 0.38636363636364
46859, 0.32608695652174, 0.72391304347826, 0.40909090909091
46860, 0.30434782608696, 0.69782608695652, 0.40909090909091
46861, 0.30434782608696, 0.72391304347826, 0.43181818181818
46862, 0.32608695652174, 0.72391304347826, 0.45454545454545
46863, 0.30434782608696, 0.69782608695652, 0.45454545454545
46864, 0.30434782608696, 0.72391304347826, 0.47727272727273
46865, 0.26086956521739, 0.72391304347826, 0.022727272727273
46866, 0.28260869565217, 0.72391304347826, 0.045454545454545
46867, 0.26086956521739, 0.69782608695652, 0.045454545454545
46868, 0.26086956521739, 0.72391304347826, 0.068181818181818
46869, 0.28260869565217, 0.72391304347826, 0.090909090909091
46870, 0.26086956521739, 0.69782608695652, 0.090909090909091
46871, 0.26086956521739, 0.72391304347826, 0.11363636363636
46872, 0.28260869565217, 0.72391304347826, 0.13636363636364
46873, 0.26086956521739, 0.69782608695652, 0.13636363636364
46874, 0.26086956521739, 0.72391304347826, 0.15909090909091
46875, 0.28260869565217, 0.72391304347826, 0.18181818181818
46876, 0.26086956521739, 0.69782608695652, 0.18181818181818
46877, 0.26086956521739, 0.72391304347826, 0.20454545454545
46878, 0.28260869565217, 0.72391304347826, 0.22727272727273
46879, 0.26086956521739, 0.69782608695652, 0.22727272727273
46880, 0.26086956521739, 0.72391304347826, 0.25
46881, 0.28260869565217, 0.72391304347826, 0.27272727272727
46882, 0.26086956521739, 0.69782608695652, 0.27272727272727
46883, 0.26086956521739, 0.72391304347826, 0.29545454545455
46884, 0.28260869565217, 0.72391304347826, 0.31818181818182
46885, 0.26086956521739, 0.69782608695652, 0.31818181818182
46886, 0.26086956521739, 0.72391304347826, 0.34090909090909
46887, 0.28260869565217, 0.72391304347826, 0.36363636363636
46888, 0.26086956521739, 0.69782608695652, 0.36363636363636
46889, 0.26086956521739, 0.72391304347826, 0.38636363636364
46890, 0.28260869565217, 0.72391304347826, 0.40909090909091
46891, 0.26086956521739, 0.69782608695652, 0.40909090909091
46892, 0.26086956521739, 0.72391304347826, 0.43181818181818
46893, 0.28260869565217, 0.72391304347826, 0.45454545454545
46894, 0.26086956521739, 0.69782608695652, 0.45454545454545
46895, 0.26086956521739, 0.72391304347826, 0.47727272727273
46896, 0.21739130434783, 0.72391304347826, 0.022727272727273
46897, 0.23913043478261, 0.72391304347826, 0.045454545454545
46898, 0.21739130434783, 0.69782608695652, 0.045454545454545
46899, 0.21739130434783, 0.72391304347826, 0.068181818181818
46900, 0.23913043478261, 0.72391304347826, 0.090909090909091
46901, 0.21739130434783, 0.69782608695652, 0.090909090909091
46902, 0.21739130434783, 0.72391304347826, 0.11363636363636
46903, 0.23913043478261, 0.72391304347826, 0.13636363636364
46904, 0.21739130434783, 0.69782608695652, 0.13636363636364
46905, 0.21739130434783, 0.72391304347826, 0.15909090909091
46906, 0.23913043478261, 0.72391304347826, 0.18181818181818
46907, 0.21739130434783, 0.69782608695652, 0.18181818181818
46908, 0.21739130434783, 0.72391304347826, 0.20454545454545
46909, 0.23913043478261, 0.72391304347826, 0.22727272727273
46910, 0.21739130434783, 0.69782608695652, 0.22727272727273
46911, 0.21739130434783, 0.72391304347826, 0.25
46912, 0.23913043478261, 0.72391304347826, 0.27272727272727
46913, 0.21739130434783, 0.69782608695652, 0.27272727272727
46914, 0.21739130434783, 0.72391304347826, 0.29545454545455
46915, 0.23913043478261, 0.72391304347826, 0.31818181818182
46916, 0.21739130434783, 0.69782608695652, 0.31818181818182
46917, 0.21739130434783, 0.72391304347826, 0.34090909090909
46918, 0.23913043478261, 0.72391304347826, 0.36363636363636
46919, 0.21739130434783, 0.69782608695652, 0.36363636363636
46920, 0.21739130434783, 0.72391304347826, 0.38636363636364
46921, 0.23913043478261, 0.72391304347826, 0.40909090909091
46922, 0.21739130434783, 0.69782608695652, 0.40909090909091
46923, 0.21739130434783, 0.72391304347826, 0.43181818181818
46924, 0.23913043478261, 0.72391304347826, 0.45454545454545
46925, 0.21739130434783, 0.69782608695652, 0.45454545454545
46926, 0.21739130434783, 0.72391304347826, 0.47727272727273
46927, 0.17391304347826, 0.72391304347826, 0.022727272727273
46928, 0.19565217391304, 0.72391304347826, 0.045454545454545
46929, 0.17391304347826, 0.69782608695652, 0.045454545454545
46930, 0.17391304347826, 0.72391304347826, 0.068181818181818
46931, 0.19565217391304, 0.72391304347826, 0.090909090909091
46932, 0.17391304347826, 0.69782608695652, 0.090909090909091
46933, 0.17391304347826, 0.72391304347826, 0.11363636363636
46934, 0.19565217391304, 0.72391304347826, 0.13636363636364
46935, 0.17391304347826, 0.69782608695652, 0.13636363636364
46936, 0.17391304347826, 0.72391304347826, 0.15909090909091
46937, 0.19565217391304, 0.72391304347826, 0.18181818181818
46938, 0.17391304347826, 0.69782608695652, 0.18181818181818
46939, 0.17391304347826, 0.72391304347826, 0.20454545454545
46940, 0.19565217391304, 0.72391304347826, 0.22727272727273
46941, 0.17391304347826, 0.69782608695652, 0.22727272727273
46942, 0.17391304347826, 0.72391304347826, 0.25
46943, 0.19565217391304, 0.72391304347826, 0.27272727272727
46944, 0.17391304347826, 0.69782608695652, 0.27272727272727
46945, 0.17391304347826, 0.72391304347826, 0.29545454545455
46946, 0.19565217391304, 0.72391304347826, 0.31818181818182
46947, 0.17391304347826, 0.69782608695652, 0.31818181818182
46948, 0.17391304347826, 0.72391304347826, 0.34090909090909
46949, 0.19565217391304, 0.72391304347826, 0.36363636363636
46950, 0.17391304347826, 0.69782608695652, 0.36363636363636
46951, 0.17391304347826, 0.72391304347826, 0.38636363636364
46952, 0.19565217391304, 0.72391304347826, 0.40909090909091
46953, 0.17391304347826, 0.69782608695652, 0.40909090909091
46954, 0.17391304347826, 0.72391304347826, 0.43181818181818
46955, 0.19565217391304, 0.72391304347826, 0.45454545454545
46956, 0.17391304347826, 0.69782608695652, 0.45454545454545
46957, 0.17391304347826, 0.72391304347826, 0.47727272727273
46958, 0.1304347826087, 0.72391304347826, 0.022727272727273
46959, 0.15217391304348, 0.72391304347826, 0.045454545454545
46960, 0.1304347826087, 0.69782608695652, 0.045454545454545
46961, 0.1304347826087, 0.72391304347826, 0.068181818181818
46962, 0.15217391304348, 0.72391304347826, 0.090909090909091
46963, 0.1304347826087, 0.69782608695652, 0.090909090909091
46964, 0.1304347826087, 0.72391304347826, 0.11363636363636
46965, 0.15217391304348, 0.72391304347826, 0.13636363636364
46966, 0.1304347826087, 0.69782608695652, 0.13636363636364
46967, 0.1304347826087, 0.72391304347826, 0.15909090909091
46968, 0.15217391304348, 0.72391304347826, 0.18181818181818
46969, 0.1304347826087, 0.69782608695652, 0.18181818181818
46970, 0.1304347826087, 0.72391304347826, 0.20454545454545
46971, 0.15217391304348, 0.72391304347826, 0.22727272727273
46972, 0.1304347826087, 0.69782608695652, 0.22727272727273
46973, 0.1304347826087, 0.72391304347826, 0.25
46974, 0.15217391304348, 0.72391304347826, 0.27272727272727
46975, 0.1304347826087, 0.69782608695652, 0.27272727272727
46976, 0.1304347826087, 0.72391304347826, 0.29545454545455
46977, 0.15217391304348, 0.72391304347826, 0.31818181818182
46978, 0.1304347826087, 0.69782608695652, 0.31818181818182
46979, 0.1304347826087, 0.72391304347826, 0.34090909090909
46980, 0.15217391304348, 0.72391304347826, 0.36363636363636
46981, 0.1304347826087, 0.69782608695652, 0.36363636363636
46982, 0.1304347826087, 0.72391304347826, 0.38636363636364
46983, 0.15217391304348, 0.72391304347826, 0.40909090909091
46984, 0.1304347826087, 0.69782608695652, 0.40909090909091
46985, 0.1304347826087, 0.72391304347826, 0.43181818181818
46986, 0.15217391304348, 0.72391304347826, 0.45454545454545
46987, 0.1304347826087, 0.69782608695652, 0.45454545454545
46988, 0.1304347826087, 0.72391304347826, 0.47727272727273
46989, 0.08695652173913, 0.72391304347826, 0.022727272727273
46990, 0.10869565217391, 0.72391304347826, 0.045454545454545
46991, 0.08695652173913, 0.69782608695652, 0.045454545454545
46992, 0.08695652173913, 0.72391304347826, 0.068181818181818
46993, 0.10869565217391, 0.72391304347826, 0.090909090909091
46994, 0.08695652173913, 0.69782608695652, 0.090909090909091
46995, 0.08695652173913, 0.72391304347826, 0.11363636363636
46996, 0.10869565217391, 0.72391304347826, 0.13636363636364
46997, 0.08695652173913, 0.69782608695652, 0.13636363636364
46998, 0.08695652173913, 0.72391304347826, 0.15909090909091
46999, 0.10869565217391, 0.72391304347826, 0.18181818181818
47000, 0.08695652173913, 0.69782608695652, 0.18181818181818
47001, 0.08695652173913, 0.72391304347826, 0.20454545454545
47002, 0.10869565217391, 0.72391304347826, 0.22727272727273
47003, 0.08695652173913, 0.69782608695652, 0.22727272727273
47004, 0.08695652173913, 0.72391304347826, 0.25
47005, 0.10869565217391, 0.72391304347826, 0.27272727272727
47006, 0.08695652173913, 0.69782608695652, 0.27272727272727
47007, 0.08695652173913, 0.72391304347826, 0.29545454545455
47008, 0.10869565217391, 0.72391304347826, 0.31818181818182
47009, 0.08695652173913, 0.69782608695652, 0.31818181818182
47010, 0.08695652173913, 0.72391304347826, 0.34090909090909
47011, 0.10869565217391, 0.72391304347826, 0.36363636363636
47012, 0.08695652173913, 0.69782608695652, 0.36363636363636
47013, 0.08695652173913, 0.72391304347826, 0.38636363636364
47014, 0.10869565217391, 0.72391304347826, 0.40909090909091
47015, 0.08695652173913, 0.69782608695652, 0.40909090909091
47016, 0.08695652173913, 0.72391304347826, 0.43181818181818
47017, 0.10869565217391, 0.72391304347826, 0.45454545454545
47018, 0.08695652173913, 0.69782608695652, 0.45454545454545
47019, 0.08695652173913, 0.72391304347826, 0.47727272727273
47020, 0.043478260869565, 0.72391304347826, 0.022727272727273
47021, 0.065217391304348, 0.72391304347826, 0.045454545454545
47022, 0.043478260869565, 0.69782608695652, 0.045454545454545
47023, 0.043478260869565, 0.72391304347826, 0.068181818181818
47024, 0.065217391304348, 0.72391304347826, 0.090909090909091
47025, 0.043478260869565, 0.69782608695652, 0.090909090909091
47026, 0.043478260869565, 0.72391304347826, 0.11363636363636
47027, 0.065217391304348, 0.72391304347826, 0.13636363636364
47028, 0.043478260869565, 0.69782608695652, 0.13636363636364
47029, 0.043478260869565, 0.72391304347826, 0.15909090909091
47030, 0.065217391304348, 0.72391304347826, 0.18181818181818
47031, 0.043478260869565, 0.69782608695652, 0.18181818181818
47032, 0.043478260869565, 0.72391304347826, 0.20454545454545
47033, 0.065217391304348, 0.72391304347826, 0.22727272727273
47034, 0.043478260869565, 0.69782608695652, 0.22727272727273
47035, 0.043478260869565, 0.72391304347826, 0.25
47036, 0.065217391304348, 0.72391304347826, 0.27272727272727
47037, 0.043478260869565, 0.69782608695652, 0.27272727272727
47038, 0.043478260869565, 0.72391304347826, 0.29545454545455
47039, 0.065217391304348, 0.72391304347826, 0.31818181818182
47040, 0.043478260869565, 0.69782608695652, 0.31818181818182
47041, 0.043478260869565, 0.72391304347826, 0.34090909090909
47042, 0.065217391304348, 0.72391304347826, 0.36363636363636
47043, 0.043478260869565, 0.69782608695652, 0.36363636363636
47044, 0.043478260869565, 0.72391304347826, 0.38636363636364
47045, 0.065217391304348, 0.72391304347826, 0.40909090909091
47046, 0.043478260869565, 0.69782608695652, 0.40909090909091
47047, 0.043478260869565, 0.72391304347826, 0.43181818181818
47048, 0.065217391304348, 0.72391304347826, 0.45454545454545
47049, 0.043478260869565, 0.69782608695652, 0.45454545454545
47050, 0.043478260869565, 0.72391304347826, 0.47727272727273
47051, 0.021739130434783, 0.72391304347826, 0.045454545454545
47052, 0.021739130434783, 0.72391304347826, 0.090909090909091
47053, 0.021739130434783, 0.72391304347826, 0.13636363636364
47054, 0.021739130434783, 0.72391304347826, 0.18181818181818
47055, 0.021739130434783, 0.72391304347826, 0.22727272727273
47056, 0.021739130434783, 0.72391304347826, 0.27272727272727
47057, 0.021739130434783, 0.72391304347826, 0.31818181818182
47058, 0.021739130434783, 0.72391304347826, 0.36363636363636
47059, 0.021739130434783, 0.72391304347826, 0.40909090909091
47060, 0.021739130434783, 0.72391304347826, 0.45454545454545
47061, 0.95652173913043, 0.77608695652174, 0.022727272727273
47062, 0.97826086956522, 0.77608695652174, 0.045454545454545
47063, 0.95652173913043, 0.75, 0.045454545454545
47064, 0.95652173913043, 0.77608695652174, 0.068181818181818
47065, 0.97826086956522, 0.77608695652174, 0.090909090909091
47066, 0.95652173913043, 0.75, 0.090909090909091
47067, 0.95652173913044, 0.77608695652174, 0.11363636363636
47068, 0.97826086956522, 0.77608695652174, 0.13636363636364
47069, 0.95652173913044, 0.75, 0.13636363636364
47070, 0.95652173913044, 0.77608695652174, 0.15909090909091
47071, 0.97826086956522, 0.77608695652174, 0.18181818181818
47072, 0.95652173913044, 0.75, 0.18181818181818
47073, 0.95652173913044, 0.77608695652174, 0.20454545454545
47074, 0.97826086956522, 0.77608695652174, 0.22727272727273
47075, 0.95652173913044, 0.75, 0.22727272727273
47076, 0.95652173913044, 0.77608695652174, 0.25
47077, 0.97826086956522, 0.77608695652174, 0.27272727272727
47078, 0.95652173913044, 0.75, 0.27272727272727
47079, 0.95652173913044, 0.77608695652174, 0.29545454545455
47080, 0.97826086956522, 0.77608695652174, 0.31818181818182
47081, 0.95652173913044, 0.75, 0.31818181818182
47082, 0.95652173913043, 0.77608695652174, 0.34090909090909
47083, 0.97826086956522, 0.77608695652174, 0.36363636363636
47084, 0.95652173913043, 0.75, 0.36363636363636
47085, 0.95652173913043, 0.77608695652174, 0.38636363636364
47086, 0.97826086956522, 0.77608695652174, 0.40909090909091
47087, 0.95652173913043, 0.75, 0.40909090909091
47088, 0.95652173913043, 0.77608695652174, 0.43181818181818
47089, 0.97826086956522, 0.77608695652174, 0.45454545454545
47090, 0.95652173913044, 0.75, 0.45454545454545
47091, 0.95652173913043, 0.77608695652174, 0.47727272727273
47092, 0.91304347826087, 0.77608695652174, 0.022727272727273
47093, 0.93478260869565, 0.77608695652174, 0.045454545454545
47094, 0.91304347826087, 0.75, 0.045454545454545
47095, 0.91304347826087, 0.77608695652174, 0.068181818181818
47096, 0.93478260869565, 0.77608695652174, 0.090909090909091
47097, 0.91304347826087, 0.75, 0.090909090909091
47098, 0.91304347826087, 0.77608695652174, 0.11363636363636
47099, 0.93478260869565, 0.77608695652174, 0.13636363636364
47100, 0.91304347826087, 0.75, 0.13636363636364
47101, 0.91304347826087, 0.77608695652174, 0.15909090909091
47102, 0.93478260869565, 0.77608695652174, 0.18181818181818
47103, 0.91304347826087, 0.75, 0.18181818181818
47104, 0.91304347826087, 0.77608695652174, 0.20454545454545
47105, 0.93478260869565, 0.77608695652174, 0.22727272727273
47106, 0.91304347826087, 0.75, 0.22727272727273
47107, 0.91304347826087, 0.77608695652174, 0.25
47108, 0.93478260869565, 0.77608695652174, 0.27272727272727
47109, 0.91304347826087, 0.75, 0.27272727272727
47110, 0.91304347826087, 0.77608695652174, 0.29545454545455
47111, 0.93478260869565, 0.77608695652174, 0.31818181818182
47112, 0.91304347826087, 0.75, 0.31818181818182
47113, 0.91304347826087, 0.77608695652174, 0.34090909090909
47114, 0.93478260869565, 0.77608695652174, 0.36363636363636
47115, 0.91304347826087, 0.75, 0.36363636363636
47116, 0.91304347826087, 0.77608695652174, 0.38636363636364
47117, 0.93478260869565, 0.77608695652174, 0.40909090909091
47118, 0.91304347826087, 0.75, 0.40909090909091
47119, 0.91304347826087, 0.77608695652174, 0.43181818181818
47120, 0.93478260869565, 0.77608695652174, 0.45454545454545
47121, 0.91304347826087, 0.75, 0.45454545454545
47122, 0.91304347826087, 0.77608695652174, 0.47727272727273
47123, 0.8695652173913, 0.77608695652174, 0.022727272727273
47124, 0.89130434782609, 0.77608695652174, 0.045454545454545
47125, 0.8695652173913, 0.75, 0.045454545454545
47126, 0.8695652173913, 0.77608695652174, 0.068181818181818
47127, 0.89130434782609, 0.77608695652174, 0.090909090909091
47128, 0.8695652173913, 0.75, 0.090909090909091
47129, 0.8695652173913, 0.77608695652174, 0.11363636363636
47130, 0.89130434782609, 0.77608695652174, 0.13636363636364
47131, 0.8695652173913, 0.75, 0.13636363636364
47132, 0.8695652173913, 0.77608695652174, 0.15909090909091
47133, 0.89130434782609, 0.77608695652174, 0.18181818181818
47134, 0.8695652173913, 0.75, 0.18181818181818
47135, 0.8695652173913, 0.77608695652174, 0.20454545454545
47136, 0.89130434782609, 0.77608695652174, 0.22727272727273
47137, 0.8695652173913, 0.75, 0.22727272727273
47138, 0.8695652173913, 0.77608695652174, 0.25
47139, 0.89130434782609, 0.77608695652174, 0.27272727272727
47140, 0.8695652173913, 0.75, 0.27272727272727
47141, 0.8695652173913, 0.77608695652174, 0.29545454545455
47142, 0.89130434782609, 0.77608695652174, 0.31818181818182
47143, 0.8695652173913, 0.75, 0.31818181818182
47144, 0.8695652173913, 0.77608695652174, 0.34090909090909
47145, 0.89130434782609, 0.77608695652174, 0.36363636363636
47146, 0.8695652173913, 0.75, 0.36363636363636
47147, 0.8695652173913, 0.77608695652174, 0.38636363636364
47148, 0.89130434782609, 0.77608695652174, 0.40909090909091
47149, 0.8695652173913, 0.75, 0.40909090909091
47150, 0.8695652173913, 0.77608695652174, 0.43181818181818
47151, 0.89130434782609, 0.77608695652174, 0.45454545454545
47152, 0.8695652173913, 0.75, 0.45454545454545
47153, 0.8695652173913, 0.77608695652174, 0.47727272727273
47154, 0.82608695652174, 0.77608695652174, 0.022727272727273
47155, 0.84782608695652, 0.77608695652174, 0.045454545454545
47156, 0.82608695652174, 0.75, 0.045454545454545
47157, 0.82608695652174, 0.77608695652174, 0.068181818181818
47158, 0.84782608695652, 0.77608695652174, 0.090909090909091
47159, 0.82608695652174, 0.75, 0.090909090909091
47160, 0.82608695652174, 0.77608695652174, 0.11363636363636
47161, 0.84782608695652, 0.77608695652174, 0.13636363636364
47162, 0.82608695652174, 0.75, 0.13636363636364
47163, 0.82608695652174, 0.77608695652174, 0.15909090909091
47164, 0.84782608695652, 0.77608695652174, 0.18181818181818
47165, 0.82608695652174, 0.75, 0.18181818181818
47166, 0.82608695652174, 0.77608695652174, 0.20454545454545
47167, 0.84782608695652, 0.77608695652174, 0.22727272727273
47168, 0.82608695652174, 0.75, 0.22727272727273
47169, 0.82608695652174, 0.77608695652174, 0.25
47170, 0.84782608695652, 0.77608695652174, 0.27272727272727
47171, 0.82608695652174, 0.75, 0.27272727272727
47172, 0.82608695652174, 0.77608695652174, 0.29545454545455
47173, 0.84782608695652, 0.77608695652174, 0.31818181818182
47174, 0.82608695652174, 0.75, 0.31818181818182
47175, 0.82608695652174, 0.77608695652174, 0.34090909090909
47176, 0.84782608695652, 0.77608695652174, 0.36363636363636
47177, 0.82608695652174, 0.75, 0.36363636363636
47178, 0.82608695652174, 0.77608695652174, 0.38636363636364
47179, 0.84782608695652, 0.77608695652174, 0.40909090909091
47180, 0.82608695652174, 0.75, 0.40909090909091
47181, 0.82608695652174, 0.77608695652174, 0.43181818181818
47182, 0.84782608695652, 0.77608695652174, 0.45454545454545
47183, 0.82608695652174, 0.75, 0.45454545454545
47184, 0.82608695652174, 0.77608695652174, 0.47727272727273
47185, 0.78260869565217, 0.77608695652174, 0.022727272727273
47186, 0.80434782608696, 0.77608695652174, 0.045454545454545
47187, 0.78260869565217, 0.75, 0.045454545454545
47188, 0.78260869565217, 0.77608695652174, 0.068181818181818
47189, 0.80434782608696, 0.77608695652174, 0.090909090909091
47190, 0.78260869565217, 0.75, 0.090909090909091
47191, 0.78260869565217, 0.77608695652174, 0.11363636363636
47192, 0.80434782608696, 0.77608695652174, 0.13636363636364
47193, 0.78260869565217, 0.75, 0.13636363636364
47194, 0.78260869565217, 0.77608695652174, 0.15909090909091
47195, 0.80434782608696, 0.77608695652174, 0.18181818181818
47196, 0.78260869565217, 0.75, 0.18181818181818
47197, 0.78260869565217, 0.77608695652174, 0.20454545454545
47198, 0.80434782608696, 0.77608695652174, 0.22727272727273
47199, 0.78260869565217, 0.75, 0.22727272727273
47200, 0.78260869565217, 0.77608695652174, 0.25
47201, 0.80434782608696, 0.77608695652174, 0.27272727272727
47202, 0.78260869565217, 0.75, 0.27272727272727
47203, 0.78260869565217, 0.77608695652174, 0.29545454545455
47204, 0.80434782608696, 0.77608695652174, 0.31818181818182
47205, 0.78260869565217, 0.75, 0.31818181818182
47206, 0.78260869565217, 0.77608695652174, 0.34090909090909
47207, 0.80434782608696, 0.77608695652174, 0.36363636363636
47208, 0.78260869565217, 0.75, 0.36363636363636
47209, 0.78260869565217, 0.77608695652174, 0.38636363636364
47210, 0.80434782608696, 0.77608695652174, 0.40909090909091
47211, 0.78260869565217, 0.75, 0.40909090909091
47212, 0.78260869565217, 0.77608695652174, 0.43181818181818
47213, 0.80434782608696, 0.77608695652174, 0.45454545454545
47214, 0.78260869565217, 0.75, 0.45454545454545
47215, 0.78260869565217, 0.77608695652174, 0.47727272727273
47216, 0.73913043478261, 0.77608695652174, 0.022727272727273
47217, 0.76086956521739, 0.77608695652174, 0.045454545454545
47218, 0.73913043478261, 0.75, 0.045454545454545
47219, 0.73913043478261, 0.77608695652174, 0.068181818181818
47220, 0.76086956521739, 0.77608695652174, 0.090909090909091
47221, 0.73913043478261, 0.75, 0.090909090909091
47222, 0.73913043478261, 0.77608695652174, 0.11363636363636
47223, 0.76086956521739, 0.77608695652174, 0.13636363636364
47224, 0.73913043478261, 0.75, 0.13636363636364
47225, 0.73913043478261, 0.77608695652174, 0.15909090909091
47226, 0.76086956521739, 0.77608695652174, 0.18181818181818
47227, 0.73913043478261, 0.75, 0.18181818181818
47228, 0.73913043478261, 0.77608695652174, 0.20454545454545
47229, 0.76086956521739, 0.77608695652174, 0.22727272727273
47230, 0.73913043478261, 0.75, 0.22727272727273
47231, 0.73913043478261, 0.77608695652174, 0.25
47232, 0.76086956521739, 0.77608695652174, 0.27272727272727
47233, 0.73913043478261, 0.75, 0.27272727272727
47234, 0.73913043478261, 0.77608695652174, 0.29545454545455
47235, 0.76086956521739, 0.77608695652174, 0.31818181818182
47236, 0.73913043478261, 0.75, 0.31818181818182
47237, 0.73913043478261, 0.77608695652174, 0.34090909090909
47238, 0.76086956521739, 0.77608695652174, 0.36363636363636
47239, 0.73913043478261, 0.75, 0.36363636363636
47240, 0.73913043478261, 0.77608695652174, 0.38636363636364
47241, 0.76086956521739, 0.77608695652174, 0.40909090909091
47242, 0.73913043478261, 0.75, 0.40909090909091
47243, 0.73913043478261, 0.77608695652174, 0.43181818181818
47244, 0.76086956521739, 0.77608695652174, 0.45454545454545
47245, 0.73913043478261, 0.75, 0.45454545454545
47246, 0.73913043478261, 0.77608695652174, 0.47727272727273
47247, 0.69565217391304, 0.77608695652174, 0.022727272727273
47248, 0.71739130434783, 0.77608695652174, 0.045454545454545
47249, 0.69565217391304, 0.75, 0.045454545454545
47250, 0.69565217391304, 0.77608695652174, 0.068181818181818
47251, 0.71739130434783, 0.77608695652174, 0.090909090909091
47252, 0.69565217391304, 0.75, 0.090909090909091
47253, 0.69565217391304, 0.77608695652174, 0.11363636363636
47254, 0.71739130434783, 0.77608695652174, 0.13636363636364
47255, 0.69565217391304, 0.75, 0.13636363636364
47256, 0.69565217391304, 0.77608695652174, 0.15909090909091
47257, 0.71739130434783, 0.77608695652174, 0.18181818181818
47258, 0.69565217391304, 0.75, 0.18181818181818
47259, 0.69565217391304, 0.77608695652174, 0.20454545454545
47260, 0.71739130434783, 0.77608695652174, 0.22727272727273
47261, 0.69565217391304, 0.75, 0.22727272727273
47262, 0.69565217391304, 0.77608695652174, 0.25
47263, 0.71739130434783, 0.77608695652174, 0.27272727272727
47264, 0.69565217391304, 0.75, 0.27272727272727
47265, 0.69565217391304, 0.77608695652174, 0.29545454545455
47266, 0.71739130434783, 0.77608695652174, 0.31818181818182
47267, 0.69565217391304, 0.75, 0.31818181818182
47268, 0.69565217391304, 0.77608695652174, 0.34090909090909
47269, 0.71739130434783, 0.77608695652174, 0.36363636363636
47270, 0.69565217391304, 0.75, 0.36363636363636
47271, 0.69565217391304, 0.77608695652174, 0.38636363636364
47272, 0.71739130434783, 0.77608695652174, 0.40909090909091
47273, 0.69565217391304, 0.75, 0.40909090909091
47274, 0.69565217391304, 0.77608695652174, 0.43181818181818
47275, 0.71739130434783, 0.77608695652174, 0.45454545454545
47276, 0.69565217391304, 0.75, 0.45454545454545
47277, 0.69565217391304, 0.77608695652174, 0.47727272727273
47278, 0.65217391304348, 0.77608695652174, 0.022727272727273
47279, 0.67391304347826, 0.77608695652174, 0.045454545454545
47280, 0.65217391304348, 0.75, 0.045454545454545
47281, 0.65217391304348, 0.77608695652174, 0.068181818181818
47282, 0.67391304347826, 0.77608695652174, 0.090909090909091
47283, 0.65217391304348, 0.75, 0.090909090909091
47284, 0.65217391304348, 0.77608695652174, 0.11363636363636
47285, 0.67391304347826, 0.77608695652174, 0.13636363636364
47286, 0.65217391304348, 0.75, 0.13636363636364
47287, 0.65217391304348, 0.77608695652174, 0.15909090909091
47288, 0.67391304347826, 0.77608695652174, 0.18181818181818
47289, 0.65217391304348, 0.75, 0.18181818181818
47290, 0.65217391304348, 0.77608695652174, 0.20454545454545
47291, 0.67391304347826, 0.77608695652174, 0.22727272727273
47292, 0.65217391304348, 0.75, 0.22727272727273
47293, 0.65217391304348, 0.77608695652174, 0.25
47294, 0.67391304347826, 0.77608695652174, 0.27272727272727
47295, 0.65217391304348, 0.75, 0.27272727272727
47296, 0.65217391304348, 0.77608695652174, 0.29545454545455
47297, 0.67391304347826, 0.77608695652174, 0.31818181818182
47298, 0.65217391304348, 0.75, 0.31818181818182
47299, 0.65217391304348, 0.77608695652174, 0.34090909090909
47300, 0.67391304347826, 0.77608695652174, 0.36363636363636
47301, 0.65217391304348, 0.75, 0.36363636363636
47302, 0.65217391304348, 0.77608695652174, 0.38636363636364
47303, 0.67391304347826, 0.77608695652174, 0.40909090909091
47304, 0.65217391304348, 0.75, 0.40909090909091
47305, 0.65217391304348, 0.77608695652174, 0.43181818181818
47306, 0.67391304347826, 0.77608695652174, 0.45454545454545
47307, 0.65217391304348, 0.75, 0.45454545454545
47308, 0.65217391304348, 0.77608695652174, 0.47727272727273
47309, 0.60869565217391, 0.77608695652174, 0.022727272727273
47310, 0.6304347826087, 0.77608695652174, 0.045454545454545
47311, 0.60869565217391, 0.75, 0.045454545454545
47312, 0.60869565217391, 0.77608695652174, 0.068181818181818
47313, 0.6304347826087, 0.77608695652174, 0.090909090909091
47314, 0.60869565217391, 0.75, 0.090909090909091
47315, 0.60869565217391, 0.77608695652174, 0.11363636363636
47316, 0.6304347826087, 0.77608695652174, 0.13636363636364
47317, 0.60869565217391, 0.75, 0.13636363636364
47318, 0.60869565217391, 0.77608695652174, 0.15909090909091
47319, 0.6304347826087, 0.77608695652174, 0.18181818181818
47320, 0.60869565217391, 0.75, 0.18181818181818
47321, 0.60869565217391, 0.77608695652174, 0.20454545454545
47322, 0.6304347826087, 0.77608695652174, 0.22727272727273
47323, 0.60869565217391, 0.75, 0.22727272727273
47324, 0.60869565217391, 0.77608695652174, 0.25
47325, 0.6304347826087, 0.77608695652174, 0.27272727272727
47326, 0.60869565217391, 0.75, 0.27272727272727
47327, 0.60869565217391, 0.77608695652174, 0.29545454545455
47328, 0.6304347826087, 0.77608695652174, 0.31818181818182
47329, 0.60869565217391, 0.75, 0.31818181818182
47330, 0.60869565217391, 0.77608695652174, 0.34090909090909
47331, 0.6304347826087, 0.77608695652174, 0.36363636363636
47332, 0.60869565217391, 0.75, 0.36363636363636
47333, 0.60869565217391, 0.77608695652174, 0.38636363636364
47334, 0.6304347826087, 0.77608695652174, 0.40909090909091
47335, 0.60869565217391, 0.75, 0.40909090909091
47336, 0.60869565217391, 0.77608695652174, 0.43181818181818
47337, 0.6304347826087, 0.77608695652174, 0.45454545454545
47338, 0.60869565217391, 0.75, 0.45454545454545
47339, 0.60869565217391, 0.77608695652174, 0.47727272727273
47340, 0.56521739130435, 0.77608695652174, 0.022727272727273
47341, 0.58695652173913, 0.77608695652174, 0.045454545454545
47342, 0.56521739130435, 0.75, 0.045454545454545
47343, 0.56521739130435, 0.77608695652174, 0.068181818181818
47344, 0.58695652173913, 0.77608695652174, 0.090909090909091
47345, 0.56521739130435, 0.75, 0.090909090909091
47346, 0.56521739130435, 0.77608695652174, 0.11363636363636
47347, 0.58695652173913, 0.77608695652174, 0.13636363636364
47348, 0.56521739130435, 0.75, 0.13636363636364
47349, 0.56521739130435, 0.77608695652174, 0.15909090909091
47350, 0.58695652173913, 0.77608695652174, 0.18181818181818
47351, 0.56521739130435, 0.75, 0.18181818181818
47352, 0.56521739130435, 0.77608695652174, 0.20454545454545
47353, 0.58695652173913, 0.77608695652174, 0.22727272727273
47354, 0.56521739130435, 0.75, 0.22727272727273
47355, 0.56521739130435, 0.77608695652174, 0.25
47356, 0.58695652173913, 0.77608695652174, 0.27272727272727
47357, 0.56521739130435, 0.75, 0.27272727272727
47358, 0.56521739130435, 0.77608695652174, 0.29545454545455
47359, 0.58695652173913, 0.77608695652174, 0.31818181818182
47360, 0.56521739130435, 0.75, 0.31818181818182
47361, 0.56521739130435, 0.77608695652174, 0.34090909090909
47362, 0.58695652173913, 0.77608695652174, 0.36363636363636
47363, 0.56521739130435, 0.75, 0.36363636363636
47364, 0.56521739130435, 0.77608695652174, 0.38636363636364
47365, 0.58695652173913, 0.77608695652174, 0.40909090909091
47366, 0.56521739130435, 0.75, 0.40909090909091
47367, 0.56521739130435, 0.77608695652174, 0.43181818181818
47368, 0.58695652173913, 0.77608695652174, 0.45454545454545
47369, 0.56521739130435, 0.75, 0.45454545454545
47370, 0.56521739130435, 0.77608695652174, 0.47727272727273
47371, 0.52173913043478, 0.77608695652174, 0.022727272727273
47372, 0.54347826086956, 0.77608695652174, 0.045454545454545
47373, 0.52173913043478, 0.75, 0.045454545454545
47374, 0.52173913043478, 0.77608695652174, 0.068181818181818
47375, 0.54347826086956, 0.77608695652174, 0.090909090909091
47376, 0.52173913043478, 0.75, 0.090909090909091
47377, 0.52173913043478, 0.77608695652174, 0.11363636363636
47378, 0.54347826086957, 0.77608695652174, 0.13636363636364
47379, 0.52173913043478, 0.75, 0.13636363636364
47380, 0.52173913043478, 0.77608695652174, 0.15909090909091
47381, 0.54347826086956, 0.77608695652174, 0.18181818181818
47382, 0.52173913043478, 0.75, 0.18181818181818
47383, 0.52173913043478, 0.77608695652174, 0.20454545454545
47384, 0.54347826086956, 0.77608695652174, 0.22727272727273
47385, 0.52173913043478, 0.75, 0.22727272727273
47386, 0.52173913043478, 0.77608695652174, 0.25
47387, 0.54347826086956, 0.77608695652174, 0.27272727272727
47388, 0.52173913043478, 0.75, 0.27272727272727
47389, 0.52173913043478, 0.77608695652174, 0.29545454545455
47390, 0.54347826086956, 0.77608695652174, 0.31818181818182
47391, 0.52173913043478, 0.75, 0.31818181818182
47392, 0.52173913043478, 0.77608695652174, 0.34090909090909
47393, 0.54347826086957, 0.77608695652174, 0.36363636363636
47394, 0.52173913043478, 0.75, 0.36363636363636
47395, 0.52173913043478, 0.77608695652174, 0.38636363636364
47396, 0.54347826086956, 0.77608695652174, 0.40909090909091
47397, 0.52173913043478, 0.75, 0.40909090909091
47398, 0.52173913043478, 0.77608695652174, 0.43181818181818
47399, 0.54347826086956, 0.77608695652174, 0.45454545454545
47400, 0.52173913043478, 0.75, 0.45454545454545
47401, 0.52173913043478, 0.77608695652174, 0.47727272727273
47402, 0.47826086956522, 0.77608695652174, 0.022727272727273
47403, 0.5, 0.77608695652174, 0.045454545454545
47404, 0.47826086956522, 0.75, 0.045454545454545
47405, 0.47826086956522, 0.77608695652174, 0.068181818181818
47406, 0.5, 0.77608695652174, 0.090909090909091
47407, 0.47826086956522, 0.75, 0.090909090909091
47408, 0.47826086956522, 0.77608695652174, 0.11363636363636
47409, 0.5, 0.77608695652174, 0.13636363636364
47410, 0.47826086956522, 0.75, 0.13636363636364
47411, 0.47826086956522, 0.77608695652174, 0.15909090909091
47412, 0.5, 0.77608695652174, 0.18181818181818
47413, 0.47826086956522, 0.75, 0.18181818181818
47414, 0.47826086956522, 0.77608695652174, 0.20454545454545
47415, 0.5, 0.77608695652174, 0.22727272727273
47416, 0.47826086956522, 0.75, 0.22727272727273
47417, 0.47826086956522, 0.77608695652174, 0.25
47418, 0.5, 0.77608695652174, 0.27272727272727
47419, 0.47826086956522, 0.75, 0.27272727272727
47420, 0.47826086956522, 0.77608695652174, 0.29545454545455
47421, 0.5, 0.77608695652174, 0.31818181818182
47422, 0.47826086956522, 0.75, 0.31818181818182
47423, 0.47826086956522, 0.77608695652174, 0.34090909090909
47424, 0.5, 0.77608695652174, 0.36363636363636
47425, 0.47826086956522, 0.75, 0.36363636363636
47426, 0.47826086956522, 0.77608695652174, 0.38636363636364
47427, 0.5, 0.77608695652174, 0.40909090909091
47428, 0.47826086956522, 0.75, 0.40909090909091
47429, 0.47826086956522, 0.77608695652174, 0.43181818181818
47430, 0.5, 0.77608695652174, 0.45454545454545
47431, 0.47826086956522, 0.75, 0.45454545454545
47432, 0.47826086956522, 0.77608695652174, 0.47727272727273
47433, 0.43478260869565, 0.77608695652174, 0.022727272727273
47434, 0.45652173913043, 0.77608695652174, 0.045454545454545
47435, 0.43478260869565, 0.75, 0.045454545454545
47436, 0.43478260869565, 0.77608695652174, 0.068181818181818
47437, 0.45652173913043, 0.77608695652174, 0.090909090909091
47438, 0.43478260869565, 0.75, 0.090909090909091
47439, 0.43478260869565, 0.77608695652174, 0.11363636363636
47440, 0.45652173913043, 0.77608695652174, 0.13636363636364
47441, 0.43478260869565, 0.75, 0.13636363636364
47442, 0.43478260869565, 0.77608695652174, 0.15909090909091
47443, 0.45652173913043, 0.77608695652174, 0.18181818181818
47444, 0.43478260869565, 0.75, 0.18181818181818
47445, 0.43478260869565, 0.77608695652174, 0.20454545454545
47446, 0.45652173913043, 0.77608695652174, 0.22727272727273
47447, 0.43478260869565, 0.75, 0.22727272727273
47448, 0.43478260869565, 0.77608695652174, 0.25
47449, 0.45652173913043, 0.77608695652174, 0.27272727272727
47450, 0.43478260869565, 0.75, 0.27272727272727
47451, 0.43478260869565, 0.77608695652174, 0.29545454545455
47452, 0.45652173913043, 0.77608695652174, 0.31818181818182
47453, 0.43478260869565, 0.75, 0.31818181818182
47454, 0.43478260869565, 0.77608695652174, 0.34090909090909
47455, 0.45652173913043, 0.77608695652174, 0.36363636363636
47456, 0.43478260869565, 0.75, 0.36363636363636
47457, 0.43478260869565, 0.77608695652174, 0.38636363636364
47458, 0.45652173913043, 0.77608695652174, 0.40909090909091
47459, 0.43478260869565, 0.75, 0.40909090909091
47460, 0.43478260869565, 0.77608695652174, 0.43181818181818
47461, 0.45652173913043, 0.77608695652174, 0.45454545454545
47462, 0.43478260869565, 0.75, 0.45454545454545
47463, 0.43478260869565, 0.77608695652174, 0.47727272727273
47464, 0.39130434782609, 0.77608695652174, 0.022727272727273
47465, 0.41304347826087, 0.77608695652174, 0.045454545454545
47466, 0.39130434782609, 0.75, 0.045454545454545
47467, 0.39130434782609, 0.77608695652174, 0.068181818181818
47468, 0.41304347826087, 0.77608695652174, 0.090909090909091
47469, 0.39130434782609, 0.75, 0.090909090909091
47470, 0.39130434782609, 0.77608695652174, 0.11363636363636
47471, 0.41304347826087, 0.77608695652174, 0.13636363636364
47472, 0.39130434782609, 0.75, 0.13636363636364
47473, 0.39130434782609, 0.77608695652174, 0.15909090909091
47474, 0.41304347826087, 0.77608695652174, 0.18181818181818
47475, 0.39130434782609, 0.75, 0.18181818181818
47476, 0.39130434782609, 0.77608695652174, 0.20454545454545
47477, 0.41304347826087, 0.77608695652174, 0.22727272727273
47478, 0.39130434782609, 0.75, 0.22727272727273
47479, 0.39130434782609, 0.77608695652174, 0.25
47480, 0.41304347826087, 0.77608695652174, 0.27272727272727
47481, 0.39130434782609, 0.75, 0.27272727272727
47482, 0.39130434782609, 0.77608695652174, 0.29545454545455
47483, 0.41304347826087, 0.77608695652174, 0.31818181818182
47484, 0.39130434782609, 0.75, 0.31818181818182
47485, 0.39130434782609, 0.77608695652174, 0.34090909090909
47486, 0.41304347826087, 0.77608695652174, 0.36363636363636
47487, 0.39130434782609, 0.75, 0.36363636363636
47488, 0.39130434782609, 0.77608695652174, 0.38636363636364
47489, 0.41304347826087, 0.77608695652174, 0.40909090909091
47490, 0.39130434782609, 0.75, 0.40909090909091
47491, 0.39130434782609, 0.77608695652174, 0.43181818181818
47492, 0.41304347826087, 0.77608695652174, 0.45454545454545
47493, 0.39130434782609, 0.75, 0.45454545454545
47494, 0.39130434782609, 0.77608695652174, 0.47727272727273
47495, 0.34782608695652, 0.77608695652174, 0.022727272727273
47496, 0.3695652173913, 0.77608695652174, 0.045454545454545
47497, 0.34782608695652, 0.75, 0.045454545454545
47498, 0.34782608695652, 0.77608695652174, 0.068181818181818
47499, 0.3695652173913, 0.77608695652174, 0.090909090909091
47500, 0.34782608695652, 0.75, 0.090909090909091
47501, 0.34782608695652, 0.77608695652174, 0.11363636363636
47502, 0.3695652173913, 0.77608695652174, 0.13636363636364
47503, 0.34782608695652, 0.75, 0.13636363636364
47504, 0.34782608695652, 0.77608695652174, 0.15909090909091
47505, 0.3695652173913, 0.77608695652174, 0.18181818181818
47506, 0.34782608695652, 0.75, 0.18181818181818
47507, 0.34782608695652, 0.77608695652174, 0.20454545454545
47508, 0.3695652173913, 0.77608695652174, 0.22727272727273
47509, 0.34782608695652, 0.75, 0.22727272727273
47510, 0.34782608695652, 0.77608695652174, 0.25
47511, 0.3695652173913, 0.77608695652174, 0.27272727272727
47512, 0.34782608695652, 0.75, 0.27272727272727
47513, 0.34782608695652, 0.77608695652174, 0.29545454545455
47514, 0.3695652173913, 0.77608695652174, 0.31818181818182
47515, 0.34782608695652, 0.75, 0.31818181818182
47516, 0.34782608695652, 0.77608695652174, 0.34090909090909
47517, 0.3695652173913, 0.77608695652174, 0.36363636363636
47518, 0.34782608695652, 0.75, 0.36363636363636
47519, 0.34782608695652, 0.77608695652174, 0.38636363636364
47520, 0.3695652173913, 0.77608695652174, 0.40909090909091
47521, 0.34782608695652, 0.75, 0.40909090909091
47522, 0.34782608695652, 0.77608695652174, 0.43181818181818
47523, 0.3695652173913, 0.77608695652174, 0.45454545454545
47524, 0.34782608695652, 0.75, 0.45454545454545
47525, 0.34782608695652, 0.77608695652174, 0.47727272727273
47526, 0.30434782608696, 0.77608695652174, 0.022727272727273
47527, 0.32608695652174, 0.77608695652174, 0.045454545454545
47528, 0.30434782608696, 0.75, 0.045454545454545
47529, 0.30434782608696, 0.77608695652174, 0.068181818181818
47530, 0.32608695652174, 0.77608695652174, 0.090909090909091
47531, 0.30434782608696, 0.75, 0.090909090909091
47532, 0.30434782608696, 0.77608695652174, 0.11363636363636
47533, 0.32608695652174, 0.77608695652174, 0.13636363636364
47534, 0.30434782608696, 0.75, 0.13636363636364
47535, 0.30434782608696, 0.77608695652174, 0.15909090909091
47536, 0.32608695652174, 0.77608695652174, 0.18181818181818
47537, 0.30434782608696, 0.75, 0.18181818181818
47538, 0.30434782608696, 0.77608695652174, 0.20454545454545
47539, 0.32608695652174, 0.77608695652174, 0.22727272727273
47540, 0.30434782608696, 0.75, 0.22727272727273
47541, 0.30434782608696, 0.77608695652174, 0.25
47542, 0.32608695652174, 0.77608695652174, 0.27272727272727
47543, 0.30434782608696, 0.75, 0.27272727272727
47544, 0.30434782608696, 0.77608695652174, 0.29545454545455
47545, 0.32608695652174, 0.77608695652174, 0.31818181818182
47546, 0.30434782608696, 0.75, 0.31818181818182
47547, 0.30434782608696, 0.77608695652174, 0.34090909090909
47548, 0.32608695652174, 0.77608695652174, 0.36363636363636
47549, 0.30434782608696, 0.75, 0.36363636363636
47550, 0.30434782608696, 0.77608695652174, 0.38636363636364
47551, 0.32608695652174, 0.77608695652174, 0.40909090909091
47552, 0.30434782608696, 0.75, 0.40909090909091
47553, 0.30434782608696, 0.77608695652174, 0.43181818181818
47554, 0.32608695652174, 0.77608695652174, 0.45454545454545
47555, 0.30434782608696, 0.75, 0.45454545454545
47556, 0.30434782608696, 0.77608695652174, 0.47727272727273
47557, 0.26086956521739, 0.77608695652174, 0.022727272727273
47558, 0.28260869565217, 0.77608695652174, 0.045454545454545
47559, 0.26086956521739, 0.75, 0.045454545454545
47560, 0.26086956521739, 0.77608695652174, 0.068181818181818
47561, 0.28260869565217, 0.77608695652174, 0.090909090909091
47562, 0.26086956521739, 0.75, 0.090909090909091
47563, 0.26086956521739, 0.77608695652174, 0.11363636363636
47564, 0.28260869565217, 0.77608695652174, 0.13636363636364
47565, 0.26086956521739, 0.75, 0.13636363636364
47566, 0.26086956521739, 0.77608695652174, 0.15909090909091
47567, 0.28260869565217, 0.77608695652174, 0.18181818181818
47568, 0.26086956521739, 0.75, 0.18181818181818
47569, 0.26086956521739, 0.77608695652174, 0.20454545454545
47570, 0.28260869565217, 0.77608695652174, 0.22727272727273
47571, 0.26086956521739, 0.75, 0.22727272727273
47572, 0.26086956521739, 0.77608695652174, 0.25
47573, 0.28260869565217, 0.77608695652174, 0.27272727272727
47574, 0.26086956521739, 0.75, 0.27272727272727
47575, 0.26086956521739, 0.77608695652174, 0.29545454545455
47576, 0.28260869565217, 0.77608695652174, 0.31818181818182
47577, 0.26086956521739, 0.75, 0.31818181818182
47578, 0.26086956521739, 0.77608695652174, 0.34090909090909
47579, 0.28260869565217, 0.77608695652174, 0.36363636363636
47580, 0.26086956521739, 0.75, 0.36363636363636
47581, 0.26086956521739, 0.77608695652174, 0.38636363636364
47582, 0.28260869565217, 0.77608695652174, 0.40909090909091
47583, 0.26086956521739, 0.75, 0.40909090909091
47584, 0.26086956521739, 0.77608695652174, 0.43181818181818
47585, 0.28260869565217, 0.77608695652174, 0.45454545454545
47586, 0.26086956521739, 0.75, 0.45454545454545
47587, 0.26086956521739, 0.77608695652174, 0.47727272727273
47588, 0.21739130434783, 0.77608695652174, 0.022727272727273
47589, 0.23913043478261, 0.77608695652174, 0.045454545454545
47590, 0.21739130434783, 0.75, 0.045454545454545
47591, 0.21739130434783, 0.77608695652174, 0.068181818181818
47592, 0.23913043478261, 0.77608695652174, 0.090909090909091
47593, 0.21739130434783, 0.75, 0.090909090909091
47594, 0.21739130434783, 0.77608695652174, 0.11363636363636
47595, 0.23913043478261, 0.77608695652174, 0.13636363636364
47596, 0.21739130434783, 0.75, 0.13636363636364
47597, 0.21739130434783, 0.77608695652174, 0.15909090909091
47598, 0.23913043478261, 0.77608695652174, 0.18181818181818
47599, 0.21739130434783, 0.75, 0.18181818181818
47600, 0.21739130434783, 0.77608695652174, 0.20454545454545
47601, 0.23913043478261, 0.77608695652174, 0.22727272727273
47602, 0.21739130434783, 0.75, 0.22727272727273
47603, 0.21739130434783, 0.77608695652174, 0.25
47604, 0.23913043478261, 0.77608695652174, 0.27272727272727
47605, 0.21739130434783, 0.75, 0.27272727272727
47606, 0.21739130434783, 0.77608695652174, 0.29545454545455
47607, 0.23913043478261, 0.77608695652174, 0.31818181818182
47608, 0.21739130434783, 0.75, 0.31818181818182
47609, 0.21739130434783, 0.77608695652174, 0.34090909090909
47610, 0.23913043478261, 0.77608695652174, 0.36363636363636
47611, 0.21739130434783, 0.75, 0.36363636363636
47612, 0.21739130434783, 0.77608695652174, 0.38636363636364
47613, 0.23913043478261, 0.77608695652174, 0.40909090909091
47614, 0.21739130434783, 0.75, 0.40909090909091
47615, 0.21739130434783, 0.77608695652174, 0.43181818181818
47616, 0.23913043478261, 0.77608695652174, 0.45454545454545
47617, 0.21739130434783, 0.75, 0.45454545454545
47618, 0.21739130434783, 0.77608695652174, 0.47727272727273
47619, 0.17391304347826, 0.77608695652174, 0.022727272727273
47620, 0.19565217391304, 0.77608695652174, 0.045454545454545
47621, 0.17391304347826, 0.75, 0.045454545454545
47622, 0.17391304347826, 0.77608695652174, 0.068181818181818
47623, 0.19565217391304, 0.77608695652174, 0.090909090909091
47624, 0.17391304347826, 0.75, 0.090909090909091
47625, 0.17391304347826, 0.77608695652174, 0.11363636363636
47626, 0.19565217391304, 0.77608695652174, 0.13636363636364
47627, 0.17391304347826, 0.75, 0.13636363636364
47628, 0.17391304347826, 0.77608695652174, 0.15909090909091
47629, 0.19565217391304, 0.77608695652174, 0.18181818181818
47630, 0.17391304347826, 0.75, 0.18181818181818
47631, 0.17391304347826, 0.77608695652174, 0.20454545454545
47632, 0.19565217391304, 0.77608695652174, 0.22727272727273
47633, 0.17391304347826, 0.75, 0.22727272727273
47634, 0.17391304347826, 0.77608695652174, 0.25
47635, 0.19565217391304, 0.77608695652174, 0.27272727272727
47636, 0.17391304347826, 0.75, 0.27272727272727
47637, 0.17391304347826, 0.77608695652174, 0.29545454545455
47638, 0.19565217391304, 0.77608695652174, 0.31818181818182
47639, 0.17391304347826, 0.75, 0.31818181818182
47640, 0.17391304347826, 0.77608695652174, 0.34090909090909
47641, 0.19565217391304, 0.77608695652174, 0.36363636363636
47642, 0.17391304347826, 0.75, 0.36363636363636
47643, 0.17391304347826, 0.77608695652174, 0.38636363636364
47644, 0.19565217391304, 0.77608695652174, 0.40909090909091
47645, 0.17391304347826, 0.75, 0.40909090909091
47646, 0.17391304347826, 0.77608695652174, 0.43181818181818
47647, 0.19565217391304, 0.77608695652174, 0.45454545454545
47648, 0.17391304347826, 0.75, 0.45454545454545
47649, 0.17391304347826, 0.77608695652174, 0.47727272727273
47650, 0.1304347826087, 0.77608695652174, 0.022727272727273
47651, 0.15217391304348, 0.77608695652174, 0.045454545454545
47652, 0.1304347826087, 0.75, 0.045454545454545
47653, 0.1304347826087, 0.77608695652174, 0.068181818181818
47654, 0.15217391304348, 0.77608695652174, 0.090909090909091
47655, 0.1304347826087, 0.75, 0.090909090909091
47656, 0.1304347826087, 0.77608695652174, 0.11363636363636
47657, 0.15217391304348, 0.77608695652174, 0.13636363636364
47658, 0.1304347826087, 0.75, 0.13636363636364
47659, 0.1304347826087, 0.77608695652174, 0.15909090909091
47660, 0.15217391304348, 0.77608695652174, 0.18181818181818
47661, 0.1304347826087, 0.75, 0.18181818181818
47662, 0.1304347826087, 0.77608695652174, 0.20454545454545
47663, 0.15217391304348, 0.77608695652174, 0.22727272727273
47664, 0.1304347826087, 0.75, 0.22727272727273
47665, 0.1304347826087, 0.77608695652174, 0.25
47666, 0.15217391304348, 0.77608695652174, 0.27272727272727
47667, 0.1304347826087, 0.75, 0.27272727272727
47668, 0.1304347826087, 0.77608695652174, 0.29545454545455
47669, 0.15217391304348, 0.77608695652174, 0.31818181818182
47670, 0.1304347826087, 0.75, 0.31818181818182
47671, 0.1304347826087, 0.77608695652174, 0.34090909090909
47672, 0.15217391304348, 0.77608695652174, 0.36363636363636
47673, 0.1304347826087, 0.75, 0.36363636363636
47674, 0.1304347826087, 0.77608695652174, 0.38636363636364
47675, 0.15217391304348, 0.77608695652174, 0.40909090909091
47676, 0.1304347826087, 0.75, 0.40909090909091
47677, 0.1304347826087, 0.77608695652174, 0.43181818181818
47678, 0.15217391304348, 0.77608695652174, 0.45454545454545
47679, 0.1304347826087, 0.75, 0.45454545454545
47680, 0.1304347826087, 0.77608695652174, 0.47727272727273
47681, 0.08695652173913, 0.77608695652174, 0.022727272727273
47682, 0.10869565217391, 0.77608695652174, 0.045454545454545
47683, 0.08695652173913, 0.75, 0.045454545454545
47684, 0.08695652173913, 0.77608695652174, 0.068181818181818
47685, 0.10869565217391, 0.77608695652174, 0.090909090909091
47686, 0.08695652173913, 0.75, 0.090909090909091
47687, 0.08695652173913, 0.77608695652174, 0.11363636363636
47688, 0.10869565217391, 0.77608695652174, 0.13636363636364
47689, 0.08695652173913, 0.75, 0.13636363636364
47690, 0.08695652173913, 0.77608695652174, 0.15909090909091
47691, 0.10869565217391, 0.77608695652174, 0.18181818181818
47692, 0.08695652173913, 0.75, 0.18181818181818
47693, 0.08695652173913, 0.77608695652174, 0.20454545454545
47694, 0.10869565217391, 0.77608695652174, 0.22727272727273
47695, 0.08695652173913, 0.75, 0.22727272727273
47696, 0.08695652173913, 0.77608695652174, 0.25
47697, 0.10869565217391, 0.77608695652174, 0.27272727272727
47698, 0.08695652173913, 0.75, 0.27272727272727
47699, 0.08695652173913, 0.77608695652174, 0.29545454545455
47700, 0.10869565217391, 0.77608695652174, 0.31818181818182
47701, 0.08695652173913, 0.75, 0.31818181818182
47702, 0.08695652173913, 0.77608695652174, 0.34090909090909
47703, 0.10869565217391, 0.77608695652174, 0.36363636363636
47704, 0.08695652173913, 0.75, 0.36363636363636
47705, 0.08695652173913, 0.77608695652174, 0.38636363636364
47706, 0.10869565217391, 0.77608695652174, 0.40909090909091
47707, 0.08695652173913, 0.75, 0.40909090909091
47708, 0.08695652173913, 0.77608695652174, 0.43181818181818
47709, 0.10869565217391, 0.77608695652174, 0.45454545454545
47710, 0.08695652173913, 0.75, 0.45454545454545
47711, 0.08695652173913, 0.77608695652174, 0.47727272727273
47712, 0.043478260869565, 0.77608695652174, 0.022727272727273
47713, 0.065217391304348, 0.77608695652174, 0.045454545454545
47714, 0.043478260869565, 0.75, 0.045454545454545
47715, 0.043478260869565, 0.77608695652174, 0.068181818181818
47716, 0.065217391304348, 0.77608695652174, 0.090909090909091
47717, 0.043478260869565, 0.75, 0.090909090909091
47718, 0.043478260869565, 0.77608695652174, 0.11363636363636
47719, 0.065217391304348, 0.77608695652174, 0.13636363636364
47720, 0.043478260869565, 0.75, 0.13636363636364
47721, 0.043478260869565, 0.77608695652174, 0.15909090909091
47722, 0.065217391304348, 0.77608695652174, 0.18181818181818
47723, 0.043478260869565, 0.75, 0.18181818181818
47724, 0.043478260869565, 0.77608695652174, 0.20454545454545
47725, 0.065217391304348, 0.77608695652174, 0.22727272727273
47726, 0.043478260869565, 0.75, 0.22727272727273
47727, 0.043478260869565, 0.77608695652174, 0.25
47728, 0.065217391304348, 0.77608695652174, 0.27272727272727
47729, 0.043478260869565, 0.75, 0.27272727272727
47730, 0.043478260869565, 0.77608695652174, 0.29545454545455
47731, 0.065217391304348, 0.77608695652174, 0.31818181818182
47732, 0.043478260869565, 0.75, 0.31818181818182
47733, 0.043478260869565, 0.77608695652174, 0.34090909090909
47734, 0.065217391304348, 0.77608695652174, 0.36363636363636
47735, 0.043478260869565, 0.75, 0.36363636363636
47736, 0.043478260869565, 0.77608695652174, 0.38636363636364
47737, 0.065217391304348, 0.77608695652174, 0.40909090909091
47738, 0.043478260869565, 0.75, 0.40909090909091
47739, 0.043478260869565, 0.77608695652174, 0.43181818181818
47740, 0.065217391304348, 0.77608695652174, 0.45454545454545
47741, 0.043478260869565, 0.75, 0.45454545454545
47742, 0.043478260869565, 0.77608695652174, 0.47727272727273
47743, 0.021739130434783, 0.77608695652174, 0.045454545454545
47744, 0.021739130434783, 0.77608695652174, 0.090909090909091
47745, 0.021739130434783, 0.77608695652174, 0.13636363636364
47746, 0.021739130434783, 0.77608695652174, 0.18181818181818
47747, 0.021739130434783, 0.77608695652174, 0.22727272727273
47748, 0.021739130434783, 0.77608695652174, 0.27272727272727
47749, 0.021739130434783, 0.77608695652174, 0.31818181818182
47750, 0.021739130434783, 0.77608695652174, 0.36363636363636
47751, 0.021739130434783, 0.77608695652174, 0.40909090909091
47752, 0.021739130434783, 0.77608695652174, 0.45454545454545
47753, 0.95652173913043, 0.82826086956522, 0.022727272727273
47754, 0.97826086956522, 0.82826086956522, 0.045454545454545
47755, 0.95652173913043, 0.80217391304348, 0.045454545454545
47756, 0.95652173913043, 0.82826086956522, 0.068181818181818
47757, 0.97826086956522, 0.82826086956522, 0.090909090909091
47758, 0.95652173913043, 0.80217391304348, 0.090909090909091
47759, 0.95652173913044, 0.82826086956522, 0.11363636363636
47760, 0.97826086956522, 0.82826086956522, 0.13636363636364
47761, 0.95652173913044, 0.80217391304348, 0.13636363636364
47762, 0.95652173913044, 0.82826086956522, 0.15909090909091
47763, 0.97826086956522, 0.82826086956522, 0.18181818181818
47764, 0.95652173913044, 0.80217391304348, 0.18181818181818
47765, 0.95652173913044, 0.82826086956522, 0.20454545454545
47766, 0.97826086956522, 0.82826086956522, 0.22727272727273
47767, 0.95652173913044, 0.80217391304348, 0.22727272727273
47768, 0.95652173913044, 0.82826086956522, 0.25
47769, 0.97826086956522, 0.82826086956522, 0.27272727272727
47770, 0.95652173913044, 0.80217391304348, 0.27272727272727
47771, 0.95652173913044, 0.82826086956522, 0.29545454545455
47772, 0.97826086956522, 0.82826086956522, 0.31818181818182
47773, 0.95652173913044, 0.80217391304348, 0.31818181818182
47774, 0.95652173913043, 0.82826086956522, 0.34090909090909
47775, 0.97826086956522, 0.82826086956522, 0.36363636363636
47776, 0.95652173913043, 0.80217391304348, 0.36363636363636
47777, 0.95652173913043, 0.82826086956522, 0.38636363636364
47778, 0.97826086956522, 0.82826086956522, 0.40909090909091
47779, 0.95652173913043, 0.80217391304348, 0.40909090909091
47780, 0.95652173913043, 0.82826086956522, 0.43181818181818
47781, 0.97826086956522, 0.82826086956522, 0.45454545454545
47782, 0.95652173913044, 0.80217391304348, 0.45454545454545
47783, 0.95652173913043, 0.82826086956522, 0.47727272727273
47784, 0.91304347826087, 0.82826086956522, 0.022727272727273
47785, 0.93478260869565, 0.82826086956522, 0.045454545454545
47786, 0.91304347826087, 0.80217391304348, 0.045454545454545
47787, 0.91304347826087, 0.82826086956522, 0.068181818181818
47788, 0.93478260869565, 0.82826086956522, 0.090909090909091
47789, 0.91304347826087, 0.80217391304348, 0.090909090909091
47790, 0.91304347826087, 0.82826086956522, 0.11363636363636
47791, 0.93478260869565, 0.82826086956522, 0.13636363636364
47792, 0.91304347826087, 0.80217391304348, 0.13636363636364
47793, 0.91304347826087, 0.82826086956522, 0.15909090909091
47794, 0.93478260869565, 0.82826086956522, 0.18181818181818
47795, 0.91304347826087, 0.80217391304348, 0.18181818181818
47796, 0.91304347826087, 0.82826086956522, 0.20454545454545
47797, 0.93478260869565, 0.82826086956522, 0.22727272727273
47798, 0.91304347826087, 0.80217391304348, 0.22727272727273
47799, 0.91304347826087, 0.82826086956522, 0.25
47800, 0.93478260869565, 0.82826086956522, 0.27272727272727
47801, 0.91304347826087, 0.80217391304348, 0.27272727272727
47802, 0.91304347826087, 0.82826086956522, 0.29545454545455
47803, 0.93478260869565, 0.82826086956522, 0.31818181818182
47804, 0.91304347826087, 0.80217391304348, 0.31818181818182
47805, 0.91304347826087, 0.82826086956522, 0.34090909090909
47806, 0.93478260869565, 0.82826086956522, 0.36363636363636
47807, 0.91304347826087, 0.80217391304348, 0.36363636363636
47808, 0.91304347826087, 0.82826086956522, 0.38636363636364
47809, 0.93478260869565, 0.82826086956522, 0.40909090909091
47810, 0.91304347826087, 0.80217391304348, 0.40909090909091
47811, 0.91304347826087, 0.82826086956522, 0.43181818181818
47812, 0.93478260869565, 0.82826086956522, 0.45454545454545
47813, 0.91304347826087, 0.80217391304348, 0.45454545454545
47814, 0.91304347826087, 0.82826086956522, 0.47727272727273
47815, 0.8695652173913, 0.82826086956522, 0.022727272727273
47816, 0.89130434782609, 0.82826086956522, 0.045454545454545
47817, 0.8695652173913, 0.80217391304348, 0.045454545454545
47818, 0.8695652173913, 0.82826086956522, 0.068181818181818
47819, 0.89130434782609, 0.82826086956522, 0.090909090909091
47820, 0.8695652173913, 0.80217391304348, 0.090909090909091
47821, 0.8695652173913, 0.82826086956522, 0.11363636363636
47822, 0.89130434782609, 0.82826086956522, 0.13636363636364
47823, 0.8695652173913, 0.80217391304348, 0.13636363636364
47824, 0.8695652173913, 0.82826086956522, 0.15909090909091
47825, 0.89130434782609, 0.82826086956522, 0.18181818181818
47826, 0.8695652173913, 0.80217391304348, 0.18181818181818
47827, 0.8695652173913, 0.82826086956522, 0.20454545454545
47828, 0.89130434782609, 0.82826086956522, 0.22727272727273
47829, 0.8695652173913, 0.80217391304348, 0.22727272727273
47830, 0.8695652173913, 0.82826086956522, 0.25
47831, 0.89130434782609, 0.82826086956522, 0.27272727272727
47832, 0.8695652173913, 0.80217391304348, 0.27272727272727
47833, 0.8695652173913, 0.82826086956522, 0.29545454545455
47834, 0.89130434782609, 0.82826086956522, 0.31818181818182
47835, 0.8695652173913, 0.80217391304348, 0.31818181818182
47836, 0.8695652173913, 0.82826086956522, 0.34090909090909
47837, 0.89130434782609, 0.82826086956522, 0.36363636363636
47838, 0.8695652173913, 0.80217391304348, 0.36363636363636
47839, 0.8695652173913, 0.82826086956522, 0.38636363636364
47840, 0.89130434782609, 0.82826086956522, 0.40909090909091
47841, 0.8695652173913, 0.80217391304348, 0.40909090909091
47842, 0.8695652173913, 0.82826086956522, 0.43181818181818
47843, 0.89130434782609, 0.82826086956522, 0.45454545454545
47844, 0.8695652173913, 0.80217391304348, 0.45454545454545
47845, 0.8695652173913, 0.82826086956522, 0.47727272727273
47846, 0.82608695652174, 0.82826086956522, 0.022727272727273
47847, 0.84782608695652, 0.82826086956522, 0.045454545454545
47848, 0.82608695652174, 0.80217391304348, 0.045454545454545
47849, 0.82608695652174, 0.82826086956522, 0.068181818181818
47850, 0.84782608695652, 0.82826086956522, 0.090909090909091
47851, 0.82608695652174, 0.80217391304348, 0.090909090909091
47852, 0.82608695652174, 0.82826086956522, 0.11363636363636
47853, 0.84782608695652, 0.82826086956522, 0.13636363636364
47854, 0.82608695652174, 0.80217391304348, 0.13636363636364
47855, 0.82608695652174, 0.82826086956522, 0.15909090909091
47856, 0.84782608695652, 0.82826086956522, 0.18181818181818
47857, 0.82608695652174, 0.80217391304348, 0.18181818181818
47858, 0.82608695652174, 0.82826086956522, 0.20454545454545
47859, 0.84782608695652, 0.82826086956522, 0.22727272727273
47860, 0.82608695652174, 0.80217391304348, 0.22727272727273
47861, 0.82608695652174, 0.82826086956522, 0.25
47862, 0.84782608695652, 0.82826086956522, 0.27272727272727
47863, 0.82608695652174, 0.80217391304348, 0.27272727272727
47864, 0.82608695652174, 0.82826086956522, 0.29545454545455
47865, 0.84782608695652, 0.82826086956522, 0.31818181818182
47866, 0.82608695652174, 0.80217391304348, 0.31818181818182
47867, 0.82608695652174, 0.82826086956522, 0.34090909090909
47868, 0.84782608695652, 0.82826086956522, 0.36363636363636
47869, 0.82608695652174, 0.80217391304348, 0.36363636363636
47870, 0.82608695652174, 0.82826086956522, 0.38636363636364
47871, 0.84782608695652, 0.82826086956522, 0.40909090909091
47872, 0.82608695652174, 0.80217391304348, 0.40909090909091
47873, 0.82608695652174, 0.82826086956522, 0.43181818181818
47874, 0.84782608695652, 0.82826086956522, 0.45454545454545
47875, 0.82608695652174, 0.80217391304348, 0.45454545454545
47876, 0.82608695652174, 0.82826086956522, 0.47727272727273
47877, 0.78260869565217, 0.82826086956522, 0.022727272727273
47878, 0.80434782608696, 0.82826086956522, 0.045454545454545
47879, 0.78260869565217, 0.80217391304348, 0.045454545454545
47880, 0.78260869565217, 0.82826086956522, 0.068181818181818
47881, 0.80434782608696, 0.82826086956522, 0.090909090909091
47882, 0.78260869565217, 0.80217391304348, 0.090909090909091
47883, 0.78260869565217, 0.82826086956522, 0.11363636363636
47884, 0.80434782608696, 0.82826086956522, 0.13636363636364
47885, 0.78260869565217, 0.80217391304348, 0.13636363636364
47886, 0.78260869565217, 0.82826086956522, 0.15909090909091
47887, 0.80434782608696, 0.82826086956522, 0.18181818181818
47888, 0.78260869565217, 0.80217391304348, 0.18181818181818
47889, 0.78260869565217, 0.82826086956522, 0.20454545454545
47890, 0.80434782608696, 0.82826086956522, 0.22727272727273
47891, 0.78260869565217, 0.80217391304348, 0.22727272727273
47892, 0.78260869565217, 0.82826086956522, 0.25
47893, 0.80434782608696, 0.82826086956522, 0.27272727272727
47894, 0.78260869565217, 0.80217391304348, 0.27272727272727
47895, 0.78260869565217, 0.82826086956522, 0.29545454545455
47896, 0.80434782608696, 0.82826086956522, 0.31818181818182
47897, 0.78260869565217, 0.80217391304348, 0.31818181818182
47898, 0.78260869565217, 0.82826086956522, 0.34090909090909
47899, 0.80434782608696, 0.82826086956522, 0.36363636363636
47900, 0.78260869565217, 0.80217391304348, 0.36363636363636
47901, 0.78260869565217, 0.82826086956522, 0.38636363636364
47902, 0.80434782608696, 0.82826086956522, 0.40909090909091
47903, 0.78260869565217, 0.80217391304348, 0.40909090909091
47904, 0.78260869565217, 0.82826086956522, 0.43181818181818
47905, 0.80434782608696, 0.82826086956522, 0.45454545454545
47906, 0.78260869565217, 0.80217391304348, 0.45454545454545
47907, 0.78260869565217, 0.82826086956522, 0.47727272727273
47908, 0.73913043478261, 0.82826086956522, 0.022727272727273
47909, 0.76086956521739, 0.82826086956522, 0.045454545454545
47910, 0.73913043478261, 0.80217391304348, 0.045454545454545
47911, 0.73913043478261, 0.82826086956522, 0.068181818181818
47912, 0.76086956521739, 0.82826086956522, 0.090909090909091
47913, 0.73913043478261, 0.80217391304348, 0.090909090909091
47914, 0.73913043478261, 0.82826086956522, 0.11363636363636
47915, 0.76086956521739, 0.82826086956522, 0.13636363636364
47916, 0.73913043478261, 0.80217391304348, 0.13636363636364
47917, 0.73913043478261, 0.82826086956522, 0.15909090909091
47918, 0.76086956521739, 0.82826086956522, 0.18181818181818
47919, 0.73913043478261, 0.80217391304348, 0.18181818181818
47920, 0.73913043478261, 0.82826086956522, 0.20454545454545
47921, 0.76086956521739, 0.82826086956522, 0.22727272727273
47922, 0.73913043478261, 0.80217391304348, 0.22727272727273
47923, 0.73913043478261, 0.82826086956522, 0.25
47924, 0.76086956521739, 0.82826086956522, 0.27272727272727
47925, 0.73913043478261, 0.80217391304348, 0.27272727272727
47926, 0.73913043478261, 0.82826086956522, 0.29545454545455
47927, 0.76086956521739, 0.82826086956522, 0.31818181818182
47928, 0.73913043478261, 0.80217391304348, 0.31818181818182
47929, 0.73913043478261, 0.82826086956522, 0.34090909090909
47930, 0.76086956521739, 0.82826086956522, 0.36363636363636
47931, 0.73913043478261, 0.80217391304348, 0.36363636363636
47932, 0.73913043478261, 0.82826086956522, 0.38636363636364
47933, 0.76086956521739, 0.82826086956522, 0.40909090909091
47934, 0.73913043478261, 0.80217391304348, 0.40909090909091
47935, 0.73913043478261, 0.82826086956522, 0.43181818181818
47936, 0.76086956521739, 0.82826086956522, 0.45454545454545
47937, 0.73913043478261, 0.80217391304348, 0.45454545454545
47938, 0.73913043478261, 0.82826086956522, 0.47727272727273
47939, 0.69565217391304, 0.82826086956522, 0.022727272727273
47940, 0.71739130434783, 0.82826086956522, 0.045454545454545
47941, 0.69565217391304, 0.80217391304348, 0.045454545454545
47942, 0.69565217391304, 0.82826086956522, 0.068181818181818
47943, 0.71739130434783, 0.82826086956522, 0.090909090909091
47944, 0.69565217391304, 0.80217391304348, 0.090909090909091
47945, 0.69565217391304, 0.82826086956522, 0.11363636363636
47946, 0.71739130434783, 0.82826086956522, 0.13636363636364
47947, 0.69565217391304, 0.80217391304348, 0.13636363636364
47948, 0.69565217391304, 0.82826086956522, 0.15909090909091
47949, 0.71739130434783, 0.82826086956522, 0.18181818181818
47950, 0.69565217391304, 0.80217391304348, 0.18181818181818
47951, 0.69565217391304, 0.82826086956522, 0.20454545454545
47952, 0.71739130434783, 0.82826086956522, 0.22727272727273
47953, 0.69565217391304, 0.80217391304348, 0.22727272727273
47954, 0.69565217391304, 0.82826086956522, 0.25
47955, 0.71739130434783, 0.82826086956522, 0.27272727272727
47956, 0.69565217391304, 0.80217391304348, 0.27272727272727
47957, 0.69565217391304, 0.82826086956522, 0.29545454545455
47958, 0.71739130434783, 0.82826086956522, 0.31818181818182
47959, 0.69565217391304, 0.80217391304348, 0.31818181818182
47960, 0.69565217391304, 0.82826086956522, 0.34090909090909
47961, 0.71739130434783, 0.82826086956522, 0.36363636363636
47962, 0.69565217391304, 0.80217391304348, 0.36363636363636
47963, 0.69565217391304, 0.82826086956522, 0.38636363636364
47964, 0.71739130434783, 0.82826086956522, 0.40909090909091
47965, 0.69565217391304, 0.80217391304348, 0.40909090909091
47966, 0.69565217391304, 0.82826086956522, 0.43181818181818
47967, 0.71739130434783, 0.82826086956522, 0.45454545454545
47968, 0.69565217391304, 0.80217391304348, 0.45454545454545
47969, 0.69565217391304, 0.82826086956522, 0.47727272727273
47970, 0.65217391304348, 0.82826086956522, 0.022727272727273
47971, 0.67391304347826, 0.82826086956522, 0.045454545454545
47972, 0.65217391304348, 0.80217391304348, 0.045454545454545
47973, 0.65217391304348, 0.82826086956522, 0.068181818181818
47974, 0.67391304347826, 0.82826086956522, 0.090909090909091
47975, 0.65217391304348, 0.80217391304348, 0.090909090909091
47976, 0.65217391304348, 0.82826086956522, 0.11363636363636
47977, 0.67391304347826, 0.82826086956522, 0.13636363636364
47978, 0.65217391304348, 0.80217391304348, 0.13636363636364
47979, 0.65217391304348, 0.82826086956522, 0.15909090909091
47980, 0.67391304347826, 0.82826086956522, 0.18181818181818
47981, 0.65217391304348, 0.80217391304348, 0.18181818181818
47982, 0.65217391304348, 0.82826086956522, 0.20454545454545
47983, 0.67391304347826, 0.82826086956522, 0.22727272727273
47984, 0.65217391304348, 0.80217391304348, 0.22727272727273
47985, 0.65217391304348, 0.82826086956522, 0.25
47986, 0.67391304347826, 0.82826086956522, 0.27272727272727
47987, 0.65217391304348, 0.80217391304348, 0.27272727272727
47988, 0.65217391304348, 0.82826086956522, 0.29545454545455
47989, 0.67391304347826, 0.82826086956522, 0.31818181818182
47990, 0.65217391304348, 0.80217391304348, 0.31818181818182
47991, 0.65217391304348, 0.82826086956522, 0.34090909090909
47992, 0.67391304347826, 0.82826086956522, 0.36363636363636
47993, 0.65217391304348, 0.80217391304348, 0.36363636363636
47994, 0.65217391304348, 0.82826086956522, 0.38636363636364
47995, 0.67391304347826, 0.82826086956522, 0.40909090909091
47996, 0.65217391304348, 0.80217391304348, 0.40909090909091
47997, 0.65217391304348, 0.82826086956522, 0.43181818181818
47998, 0.67391304347826, 0.82826086956522, 0.45454545454545
47999, 0.65217391304348, 0.80217391304348, 0.45454545454545
48000, 0.65217391304348, 0.82826086956522, 0.47727272727273
48001, 0.60869565217391, 0.82826086956522, 0.022727272727273
48002, 0.6304347826087, 0.82826086956522, 0.045454545454545
48003, 0.60869565217391, 0.80217391304348, 0.045454545454545
48004, 0.60869565217391, 0.82826086956522, 0.068181818181818
48005, 0.6304347826087, 0.82826086956522, 0.090909090909091
48006, 0.60869565217391, 0.80217391304348, 0.090909090909091
48007, 0.60869565217391, 0.82826086956522, 0.11363636363636
48008, 0.6304347826087, 0.82826086956522, 0.13636363636364
48009, 0.60869565217391, 0.80217391304348, 0.13636363636364
48010, 0.60869565217391, 0.82826086956522, 0.15909090909091
48011, 0.6304347826087, 0.82826086956522, 0.18181818181818
48012, 0.60869565217391, 0.80217391304348, 0.18181818181818
48013, 0.60869565217391, 0.82826086956522, 0.20454545454545
48014, 0.6304347826087, 0.82826086956522, 0.22727272727273
48015, 0.60869565217391, 0.80217391304348, 0.22727272727273
48016, 0.60869565217391, 0.82826086956522, 0.25
48017, 0.6304347826087, 0.82826086956522, 0.27272727272727
48018, 0.60869565217391, 0.80217391304348, 0.27272727272727
48019, 0.60869565217391, 0.82826086956522, 0.29545454545455
48020, 0.6304347826087, 0.82826086956522, 0.31818181818182
48021, 0.60869565217391, 0.80217391304348, 0.31818181818182
48022, 0.60869565217391, 0.82826086956522, 0.34090909090909
48023, 0.6304347826087, 0.82826086956522, 0.36363636363636
48024, 0.60869565217391, 0.80217391304348, 0.36363636363636
48025, 0.60869565217391, 0.82826086956522, 0.38636363636364
48026, 0.6304347826087, 0.82826086956522, 0.40909090909091
48027, 0.60869565217391, 0.80217391304348, 0.40909090909091
48028, 0.60869565217391, 0.82826086956522, 0.43181818181818
48029, 0.6304347826087, 0.82826086956522, 0.45454545454545
48030, 0.60869565217391, 0.80217391304348, 0.45454545454545
48031, 0.60869565217391, 0.82826086956522, 0.47727272727273
48032, 0.56521739130435, 0.82826086956522, 0.022727272727273
48033, 0.58695652173913, 0.82826086956522, 0.045454545454545
48034, 0.56521739130435, 0.80217391304348, 0.045454545454545
48035, 0.56521739130435, 0.82826086956522, 0.068181818181818
48036, 0.58695652173913, 0.82826086956522, 0.090909090909091
48037, 0.56521739130435, 0.80217391304348, 0.090909090909091
48038, 0.56521739130435, 0.82826086956522, 0.11363636363636
48039, 0.58695652173913, 0.82826086956522, 0.13636363636364
48040, 0.56521739130435, 0.80217391304348, 0.13636363636364
48041, 0.56521739130435, 0.82826086956522, 0.15909090909091
48042, 0.58695652173913, 0.82826086956522, 0.18181818181818
48043, 0.56521739130435, 0.80217391304348, 0.18181818181818
48044, 0.56521739130435, 0.82826086956522, 0.20454545454545
48045, 0.58695652173913, 0.82826086956522, 0.22727272727273
48046, 0.56521739130435, 0.80217391304348, 0.22727272727273
48047, 0.56521739130435, 0.82826086956522, 0.25
48048, 0.58695652173913, 0.82826086956522, 0.27272727272727
48049, 0.56521739130435, 0.80217391304348, 0.27272727272727
48050, 0.56521739130435, 0.82826086956522, 0.29545454545455
48051, 0.58695652173913, 0.82826086956522, 0.31818181818182
48052, 0.56521739130435, 0.80217391304348, 0.31818181818182
48053, 0.56521739130435, 0.82826086956522, 0.34090909090909
48054, 0.58695652173913, 0.82826086956522, 0.36363636363636
48055, 0.56521739130435, 0.80217391304348, 0.36363636363636
48056, 0.56521739130435, 0.82826086956522, 0.38636363636364
48057, 0.58695652173913, 0.82826086956522, 0.40909090909091
48058, 0.56521739130435, 0.80217391304348, 0.40909090909091
48059, 0.56521739130435, 0.82826086956522, 0.43181818181818
48060, 0.58695652173913, 0.82826086956522, 0.45454545454545
48061, 0.56521739130435, 0.80217391304348, 0.45454545454545
48062, 0.56521739130435, 0.82826086956522, 0.47727272727273
48063, 0.52173913043478, 0.82826086956522, 0.022727272727273
48064, 0.54347826086956, 0.82826086956522, 0.045454545454545
48065, 0.52173913043478, 0.80217391304348, 0.045454545454545
48066, 0.52173913043478, 0.82826086956522, 0.068181818181818
48067, 0.54347826086956, 0.82826086956522, 0.090909090909091
48068, 0.52173913043478, 0.80217391304348, 0.090909090909091
48069, 0.52173913043478, 0.82826086956522, 0.11363636363636
48070, 0.54347826086957, 0.82826086956522, 0.13636363636364
48071, 0.52173913043478, 0.80217391304348, 0.13636363636364
48072, 0.52173913043478, 0.82826086956522, 0.15909090909091
48073, 0.54347826086956, 0.82826086956522, 0.18181818181818
48074, 0.52173913043478, 0.80217391304348, 0.18181818181818
48075, 0.52173913043478, 0.82826086956522, 0.20454545454545
48076, 0.54347826086956, 0.82826086956522, 0.22727272727273
48077, 0.52173913043478, 0.80217391304348, 0.22727272727273
48078, 0.52173913043478, 0.82826086956522, 0.25
48079, 0.54347826086956, 0.82826086956522, 0.27272727272727
48080, 0.52173913043478, 0.80217391304348, 0.27272727272727
48081, 0.52173913043478, 0.82826086956522, 0.29545454545455
48082, 0.54347826086956, 0.82826086956522, 0.31818181818182
48083, 0.52173913043478, 0.80217391304348, 0.31818181818182
48084, 0.52173913043478, 0.82826086956522, 0.34090909090909
48085, 0.54347826086957, 0.82826086956522, 0.36363636363636
48086, 0.52173913043478, 0.80217391304348, 0.36363636363636
48087, 0.52173913043478, 0.82826086956522, 0.38636363636364
48088, 0.54347826086956, 0.82826086956522, 0.40909090909091
48089, 0.52173913043478, 0.80217391304348, 0.40909090909091
48090, 0.52173913043478, 0.82826086956522, 0.43181818181818
48091, 0.54347826086956, 0.82826086956522, 0.45454545454545
48092, 0.52173913043478, 0.80217391304348, 0.45454545454545
48093, 0.52173913043478, 0.82826086956522, 0.47727272727273
48094, 0.47826086956522, 0.82826086956522, 0.022727272727273
48095, 0.5, 0.82826086956522, 0.045454545454545
48096, 0.47826086956522, 0.80217391304348, 0.045454545454545
48097, 0.47826086956522, 0.82826086956522, 0.068181818181818
48098, 0.5, 0.82826086956522, 0.090909090909091
48099, 0.47826086956522, 0.80217391304348, 0.090909090909091
48100, 0.47826086956522, 0.82826086956522, 0.11363636363636
48101, 0.5, 0.82826086956522, 0.13636363636364
48102, 0.47826086956522, 0.80217391304348, 0.13636363636364
48103, 0.47826086956522, 0.82826086956522, 0.15909090909091
48104, 0.5, 0.82826086956522, 0.18181818181818
48105, 0.47826086956522, 0.80217391304348, 0.18181818181818
48106, 0.47826086956522, 0.82826086956522, 0.20454545454545
48107, 0.5, 0.82826086956522, 0.22727272727273
48108, 0.47826086956522, 0.80217391304348, 0.22727272727273
48109, 0.47826086956522, 0.82826086956522, 0.25
48110, 0.5, 0.82826086956522, 0.27272727272727
48111, 0.47826086956522, 0.80217391304348, 0.27272727272727
48112, 0.47826086956522, 0.82826086956522, 0.29545454545455
48113, 0.5, 0.82826086956522, 0.31818181818182
48114, 0.47826086956522, 0.80217391304348, 0.31818181818182
48115, 0.47826086956522, 0.82826086956522, 0.34090909090909
48116, 0.5, 0.82826086956522, 0.36363636363636
48117, 0.47826086956522, 0.80217391304348, 0.36363636363636
48118, 0.47826086956522, 0.82826086956522, 0.38636363636364
48119, 0.5, 0.82826086956522, 0.40909090909091
48120, 0.47826086956522, 0.80217391304348, 0.40909090909091
48121, 0.47826086956522, 0.82826086956522, 0.43181818181818
48122, 0.5, 0.82826086956522, 0.45454545454545
48123, 0.47826086956522, 0.80217391304348, 0.45454545454545
48124, 0.47826086956522, 0.82826086956522, 0.47727272727273
48125, 0.43478260869565, 0.82826086956522, 0.022727272727273
48126, 0.45652173913043, 0.82826086956522, 0.045454545454545
48127, 0.43478260869565, 0.80217391304348, 0.045454545454545
48128, 0.43478260869565, 0.82826086956522, 0.068181818181818
48129, 0.45652173913043, 0.82826086956522, 0.090909090909091
48130, 0.43478260869565, 0.80217391304348, 0.090909090909091
48131, 0.43478260869565, 0.82826086956522, 0.11363636363636
48132, 0.45652173913043, 0.82826086956522, 0.13636363636364
48133, 0.43478260869565, 0.80217391304348, 0.13636363636364
48134, 0.43478260869565, 0.82826086956522, 0.15909090909091
48135, 0.45652173913043, 0.82826086956522, 0.18181818181818
48136, 0.43478260869565, 0.80217391304348, 0.18181818181818
48137, 0.43478260869565, 0.82826086956522, 0.20454545454545
48138, 0.45652173913043, 0.82826086956522, 0.22727272727273
48139, 0.43478260869565, 0.80217391304348, 0.22727272727273
48140, 0.43478260869565, 0.82826086956522, 0.25
48141, 0.45652173913043, 0.82826086956522, 0.27272727272727
48142, 0.43478260869565, 0.80217391304348, 0.27272727272727
48143, 0.43478260869565, 0.82826086956522, 0.29545454545455
48144, 0.45652173913043, 0.82826086956522, 0.31818181818182
48145, 0.43478260869565, 0.80217391304348, 0.31818181818182
48146, 0.43478260869565, 0.82826086956522, 0.34090909090909
48147, 0.45652173913043, 0.82826086956522, 0.36363636363636
48148, 0.43478260869565, 0.80217391304348, 0.36363636363636
48149, 0.43478260869565, 0.82826086956522, 0.38636363636364
48150, 0.45652173913043, 0.82826086956522, 0.40909090909091
48151, 0.43478260869565, 0.80217391304348, 0.40909090909091
48152, 0.43478260869565, 0.82826086956522, 0.43181818181818
48153, 0.45652173913043, 0.82826086956522, 0.45454545454545
48154, 0.43478260869565, 0.80217391304348, 0.45454545454545
48155, 0.43478260869565, 0.82826086956522, 0.47727272727273
48156, 0.39130434782609, 0.82826086956522, 0.022727272727273
48157, 0.41304347826087, 0.82826086956522, 0.045454545454545
48158, 0.39130434782609, 0.80217391304348, 0.045454545454545
48159, 0.39130434782609, 0.82826086956522, 0.068181818181818
48160, 0.41304347826087, 0.82826086956522, 0.090909090909091
48161, 0.39130434782609, 0.80217391304348, 0.090909090909091
48162, 0.39130434782609, 0.82826086956522, 0.11363636363636
48163, 0.41304347826087, 0.82826086956522, 0.13636363636364
48164, 0.39130434782609, 0.80217391304348, 0.13636363636364
48165, 0.39130434782609, 0.82826086956522, 0.15909090909091
48166, 0.41304347826087, 0.82826086956522, 0.18181818181818
48167, 0.39130434782609, 0.80217391304348, 0.18181818181818
48168, 0.39130434782609, 0.82826086956522, 0.20454545454545
48169, 0.41304347826087, 0.82826086956522, 0.22727272727273
48170, 0.39130434782609, 0.80217391304348, 0.22727272727273
48171, 0.39130434782609, 0.82826086956522, 0.25
48172, 0.41304347826087, 0.82826086956522, 0.27272727272727
48173, 0.39130434782609, 0.80217391304348, 0.27272727272727
48174, 0.39130434782609, 0.82826086956522, 0.29545454545455
48175, 0.41304347826087, 0.82826086956522, 0.31818181818182
48176, 0.39130434782609, 0.80217391304348, 0.31818181818182
48177, 0.39130434782609, 0.82826086956522, 0.34090909090909
48178, 0.41304347826087, 0.82826086956522, 0.36363636363636
48179, 0.39130434782609, 0.80217391304348, 0.36363636363636
48180, 0.39130434782609, 0.82826086956522, 0.38636363636364
48181, 0.41304347826087, 0.82826086956522, 0.40909090909091
48182, 0.39130434782609, 0.80217391304348, 0.40909090909091
48183, 0.39130434782609, 0.82826086956522, 0.43181818181818
48184, 0.41304347826087, 0.82826086956522, 0.45454545454545
48185, 0.39130434782609, 0.80217391304348, 0.45454545454545
48186, 0.39130434782609, 0.82826086956522, 0.47727272727273
48187, 0.34782608695652, 0.82826086956522, 0.022727272727273
48188, 0.3695652173913, 0.82826086956522, 0.045454545454545
48189, 0.34782608695652, 0.80217391304348, 0.045454545454545
48190, 0.34782608695652, 0.82826086956522, 0.068181818181818
48191, 0.3695652173913, 0.82826086956522, 0.090909090909091
48192, 0.34782608695652, 0.80217391304348, 0.090909090909091
48193, 0.34782608695652, 0.82826086956522, 0.11363636363636
48194, 0.3695652173913, 0.82826086956522, 0.13636363636364
48195, 0.34782608695652, 0.80217391304348, 0.13636363636364
48196, 0.34782608695652, 0.82826086956522, 0.15909090909091
48197, 0.3695652173913, 0.82826086956522, 0.18181818181818
48198, 0.34782608695652, 0.80217391304348, 0.18181818181818
48199, 0.34782608695652, 0.82826086956522, 0.20454545454545
48200, 0.3695652173913, 0.82826086956522, 0.22727272727273
48201, 0.34782608695652, 0.80217391304348, 0.22727272727273
48202, 0.34782608695652, 0.82826086956522, 0.25
48203, 0.3695652173913, 0.82826086956522, 0.27272727272727
48204, 0.34782608695652, 0.80217391304348, 0.27272727272727
48205, 0.34782608695652, 0.82826086956522, 0.29545454545455
48206, 0.3695652173913, 0.82826086956522, 0.31818181818182
48207, 0.34782608695652, 0.80217391304348, 0.31818181818182
48208, 0.34782608695652, 0.82826086956522, 0.34090909090909
48209, 0.3695652173913, 0.82826086956522, 0.36363636363636
48210, 0.34782608695652, 0.80217391304348, 0.36363636363636
48211, 0.34782608695652, 0.82826086956522, 0.38636363636364
48212, 0.3695652173913, 0.82826086956522, 0.40909090909091
48213, 0.34782608695652, 0.80217391304348, 0.40909090909091
48214, 0.34782608695652, 0.82826086956522, 0.43181818181818
48215, 0.3695652173913, 0.82826086956522, 0.45454545454545
48216, 0.34782608695652, 0.80217391304348, 0.45454545454545
48217, 0.34782608695652, 0.82826086956522, 0.47727272727273
48218, 0.30434782608696, 0.82826086956522, 0.022727272727273
48219, 0.32608695652174, 0.82826086956522, 0.045454545454545
48220, 0.30434782608696, 0.80217391304348, 0.045454545454545
48221, 0.30434782608696, 0.82826086956522, 0.068181818181818
48222, 0.32608695652174, 0.82826086956522, 0.090909090909091
48223, 0.30434782608696, 0.80217391304348, 0.090909090909091
48224, 0.30434782608696, 0.82826086956522, 0.11363636363636
48225, 0.32608695652174, 0.82826086956522, 0.13636363636364
