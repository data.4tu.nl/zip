32882, 0.10869565217391, 0.066666666666667, 0.31818181818182
32883, 0.1304347826087, 0.05, 0.31818181818182
32884, 0.1304347826087, 0.066666666666667, 0.29545454545455
32885, 0.15217391304348, 0.066666666666667, 0.31818181818182
32886, 0.17391304347826, 0.05, 0.31818181818182
32887, 0.17391304347826, 0.066666666666667, 0.29545454545455
32888, 0.19565217391304, 0.066666666666667, 0.31818181818182
32889, 0.21739130434783, 0.05, 0.31818181818182
32890, 0.21739130434783, 0.066666666666667, 0.29545454545455
32891, 0.23913043478261, 0.066666666666667, 0.31818181818182
32892, 0.26086956521739, 0.05, 0.31818181818182
32893, 0.26086956521739, 0.066666666666667, 0.29545454545455
32894, 0.28260869565217, 0.066666666666667, 0.31818181818182
32895, 0.30434782608696, 0.05, 0.31818181818182
32896, 0.30434782608696, 0.066666666666667, 0.29545454545455
32897, 0.32608695652174, 0.066666666666667, 0.31818181818182
32898, 0.34782608695652, 0.05, 0.31818181818182
32899, 0.34782608695652, 0.066666666666667, 0.29545454545455
32900, 0.3695652173913, 0.066666666666667, 0.31818181818182
32901, 0.39130434782609, 0.05, 0.31818181818182
32902, 0.39130434782609, 0.066666666666667, 0.29545454545455
32903, 0.41304347826087, 0.066666666666667, 0.31818181818182
32904, 0.43478260869565, 0.05, 0.31818181818182
32905, 0.43478260869565, 0.066666666666667, 0.29545454545455
32906, 0.45652173913043, 0.066666666666667, 0.31818181818182
32907, 0.47826086956522, 0.05, 0.31818181818182
32908, 0.47826086956522, 0.066666666666667, 0.29545454545455
32909, 0.5, 0.066666666666667, 0.31818181818182
32910, 0.52173913043478, 0.05, 0.31818181818182
32911, 0.52173913043478, 0.066666666666667, 0.29545454545455
32912, 0.54347826086957, 0.066666666666667, 0.31818181818182
32913, 0.56521739130435, 0.05, 0.31818181818182
32914, 0.56521739130435, 0.066666666666667, 0.29545454545455
32915, 0.58695652173913, 0.066666666666667, 0.31818181818182
32916, 0.60869565217391, 0.05, 0.31818181818182
32917, 0.60869565217391, 0.066666666666667, 0.29545454545455
32918, 0.6304347826087, 0.066666666666667, 0.31818181818182
32919, 0.65217391304348, 0.05, 0.31818181818182
32920, 0.65217391304348, 0.066666666666667, 0.29545454545455
32921, 0.67391304347826, 0.066666666666667, 0.31818181818182
32922, 0.69565217391304, 0.05, 0.31818181818182
32923, 0.69565217391304, 0.066666666666667, 0.29545454545455
32924, 0.71739130434783, 0.066666666666667, 0.31818181818182
32925, 0.73913043478261, 0.05, 0.31818181818182
32926, 0.73913043478261, 0.066666666666667, 0.29545454545455
32927, 0.76086956521739, 0.066666666666667, 0.31818181818182
32928, 0.78260869565217, 0.05, 0.31818181818182
32929, 0.78260869565217, 0.066666666666667, 0.29545454545455
32930, 0.80434782608696, 0.066666666666667, 0.31818181818182
32931, 0.82608695652174, 0.05, 0.31818181818182
32932, 0.82608695652174, 0.066666666666667, 0.29545454545455
32933, 0.84782608695652, 0.066666666666667, 0.31818181818182
32934, 0.8695652173913, 0.05, 0.31818181818182
32935, 0.8695652173913, 0.066666666666667, 0.29545454545455
32936, 0.89130434782609, 0.066666666666667, 0.31818181818182
32937, 0.91304347826087, 0.05, 0.31818181818182
32938, 0.91304347826087, 0.066666666666667, 0.29545454545455
32939, 0.93478260869565, 0.066666666666667, 0.31818181818182
32940, 0.95652173913044, 0.05, 0.31818181818182
32941, 0.95652173913044, 0.066666666666667, 0.29545454545455
32942, 0.97826086956522, 0.066666666666667, 0.31818181818182
32943, 0.043478260869565, 0.083333333333333, 0.31818181818182
32944, 0.08695652173913, 0.083333333333333, 0.31818181818182
32945, 0.1304347826087, 0.083333333333333, 0.31818181818182
32946, 0.17391304347826, 0.083333333333333, 0.31818181818182
32947, 0.21739130434783, 0.083333333333333, 0.31818181818182
32948, 0.26086956521739, 0.083333333333333, 0.31818181818182
32949, 0.30434782608696, 0.083333333333333, 0.31818181818182
32950, 0.34782608695652, 0.083333333333333, 0.31818181818182
32951, 0.39130434782609, 0.083333333333333, 0.31818181818182
32952, 0.43478260869565, 0.083333333333333, 0.31818181818182
32953, 0.47826086956522, 0.083333333333333, 0.31818181818182
32954, 0.52173913043478, 0.083333333333333, 0.31818181818182
32955, 0.56521739130435, 0.083333333333333, 0.31818181818182
32956, 0.60869565217391, 0.083333333333333, 0.31818181818182
32957, 0.65217391304348, 0.083333333333333, 0.31818181818182
32958, 0.69565217391304, 0.083333333333333, 0.31818181818182
32959, 0.73913043478261, 0.083333333333333, 0.31818181818182
32960, 0.78260869565217, 0.083333333333333, 0.31818181818182
32961, 0.82608695652174, 0.083333333333333, 0.31818181818182
32962, 0.8695652173913, 0.083333333333333, 0.31818181818182
32963, 0.91304347826087, 0.083333333333333, 0.31818181818182
32964, 0.95652173913043, 0.083333333333333, 0.31818181818182
32965, 0.021739130434783, 0.033333333333333, 0.36363636363636
32966, 0.043478260869565, 0.016666666666667, 0.36363636363636
32967, 0.043478260869565, 0.033333333333333, 0.34090909090909
32968, 0.065217391304348, 0.033333333333333, 0.36363636363636
32969, 0.08695652173913, 0.016666666666667, 0.36363636363636
32970, 0.08695652173913, 0.033333333333333, 0.34090909090909
32971, 0.10869565217391, 0.033333333333333, 0.36363636363636
32972, 0.1304347826087, 0.016666666666667, 0.36363636363636
32973, 0.1304347826087, 0.033333333333333, 0.34090909090909
32974, 0.15217391304348, 0.033333333333333, 0.36363636363636
32975, 0.17391304347826, 0.016666666666667, 0.36363636363636
32976, 0.17391304347826, 0.033333333333333, 0.34090909090909
32977, 0.19565217391304, 0.033333333333333, 0.36363636363636
32978, 0.21739130434783, 0.016666666666667, 0.36363636363636
32979, 0.21739130434783, 0.033333333333333, 0.34090909090909
32980, 0.23913043478261, 0.033333333333333, 0.36363636363636
32981, 0.26086956521739, 0.016666666666667, 0.36363636363636
32982, 0.26086956521739, 0.033333333333333, 0.34090909090909
32983, 0.28260869565217, 0.033333333333333, 0.36363636363636
32984, 0.30434782608696, 0.016666666666667, 0.36363636363636
32985, 0.30434782608696, 0.033333333333333, 0.34090909090909
32986, 0.32608695652174, 0.033333333333333, 0.36363636363636
32987, 0.34782608695652, 0.016666666666667, 0.36363636363636
32988, 0.34782608695652, 0.033333333333333, 0.34090909090909
32989, 0.3695652173913, 0.033333333333333, 0.36363636363636
32990, 0.39130434782609, 0.016666666666667, 0.36363636363636
32991, 0.39130434782609, 0.033333333333333, 0.34090909090909
32992, 0.41304347826087, 0.033333333333333, 0.36363636363636
32993, 0.43478260869565, 0.016666666666667, 0.36363636363636
32994, 0.43478260869565, 0.033333333333333, 0.34090909090909
32995, 0.45652173913043, 0.033333333333333, 0.36363636363636
32996, 0.47826086956522, 0.016666666666667, 0.36363636363636
32997, 0.47826086956522, 0.033333333333333, 0.34090909090909
32998, 0.5, 0.033333333333333, 0.36363636363636
32999, 0.52173913043478, 0.016666666666667, 0.36363636363636
33000, 0.52173913043478, 0.033333333333333, 0.34090909090909
33001, 0.54347826086957, 0.033333333333333, 0.36363636363636
33002, 0.56521739130435, 0.016666666666667, 0.36363636363636
33003, 0.56521739130435, 0.033333333333333, 0.34090909090909
33004, 0.58695652173913, 0.033333333333333, 0.36363636363636
33005, 0.60869565217391, 0.016666666666667, 0.36363636363636
33006, 0.60869565217391, 0.033333333333333, 0.34090909090909
33007, 0.6304347826087, 0.033333333333333, 0.36363636363636
33008, 0.65217391304348, 0.016666666666667, 0.36363636363636
33009, 0.65217391304348, 0.033333333333333, 0.34090909090909
33010, 0.67391304347826, 0.033333333333333, 0.36363636363636
33011, 0.69565217391304, 0.016666666666667, 0.36363636363636
33012, 0.69565217391304, 0.033333333333333, 0.34090909090909
33013, 0.71739130434783, 0.033333333333333, 0.36363636363636
33014, 0.73913043478261, 0.016666666666667, 0.36363636363636
33015, 0.73913043478261, 0.033333333333333, 0.34090909090909
33016, 0.76086956521739, 0.033333333333333, 0.36363636363636
33017, 0.78260869565217, 0.016666666666667, 0.36363636363636
33018, 0.78260869565217, 0.033333333333333, 0.34090909090909
33019, 0.80434782608696, 0.033333333333333, 0.36363636363636
33020, 0.82608695652174, 0.016666666666667, 0.36363636363636
33021, 0.82608695652174, 0.033333333333333, 0.34090909090909
33022, 0.84782608695652, 0.033333333333333, 0.36363636363636
33023, 0.8695652173913, 0.016666666666667, 0.36363636363636
33024, 0.8695652173913, 0.033333333333333, 0.34090909090909
33025, 0.89130434782609, 0.033333333333333, 0.36363636363636
33026, 0.91304347826087, 0.016666666666667, 0.36363636363636
33027, 0.91304347826087, 0.033333333333333, 0.34090909090909
33028, 0.93478260869565, 0.033333333333333, 0.36363636363636
33029, 0.95652173913043, 0.016666666666667, 0.36363636363636
33030, 0.95652173913044, 0.033333333333333, 0.34090909090909
33031, 0.97826086956522, 0.033333333333333, 0.36363636363636
33032, 0.021739130434783, 0.066666666666667, 0.36363636363636
33033, 0.043478260869565, 0.05, 0.36363636363636
33034, 0.043478260869565, 0.066666666666667, 0.34090909090909
33035, 0.065217391304348, 0.066666666666667, 0.36363636363636
33036, 0.08695652173913, 0.05, 0.36363636363636
33037, 0.08695652173913, 0.066666666666667, 0.34090909090909
33038, 0.10869565217391, 0.066666666666667, 0.36363636363636
33039, 0.1304347826087, 0.05, 0.36363636363636
33040, 0.1304347826087, 0.066666666666667, 0.34090909090909
33041, 0.15217391304348, 0.066666666666667, 0.36363636363636
33042, 0.17391304347826, 0.05, 0.36363636363636
33043, 0.17391304347826, 0.066666666666667, 0.34090909090909
33044, 0.19565217391304, 0.066666666666667, 0.36363636363636
33045, 0.21739130434783, 0.05, 0.36363636363636
33046, 0.21739130434783, 0.066666666666667, 0.34090909090909
33047, 0.23913043478261, 0.066666666666667, 0.36363636363636
33048, 0.26086956521739, 0.05, 0.36363636363636
33049, 0.26086956521739, 0.066666666666667, 0.34090909090909
33050, 0.28260869565217, 0.066666666666667, 0.36363636363636
33051, 0.30434782608696, 0.05, 0.36363636363636
33052, 0.30434782608696, 0.066666666666667, 0.34090909090909
33053, 0.32608695652174, 0.066666666666667, 0.36363636363636
33054, 0.34782608695652, 0.05, 0.36363636363636
33055, 0.34782608695652, 0.066666666666667, 0.34090909090909
33056, 0.3695652173913, 0.066666666666667, 0.36363636363636
33057, 0.39130434782609, 0.05, 0.36363636363636
33058, 0.39130434782609, 0.066666666666667, 0.34090909090909
33059, 0.41304347826087, 0.066666666666667, 0.36363636363636
33060, 0.43478260869565, 0.05, 0.36363636363636
33061, 0.43478260869565, 0.066666666666667, 0.34090909090909
33062, 0.45652173913043, 0.066666666666667, 0.36363636363636
33063, 0.47826086956522, 0.05, 0.36363636363636
33064, 0.47826086956522, 0.066666666666667, 0.34090909090909
33065, 0.5, 0.066666666666667, 0.36363636363636
33066, 0.52173913043478, 0.05, 0.36363636363636
33067, 0.52173913043478, 0.066666666666667, 0.34090909090909
33068, 0.54347826086957, 0.066666666666667, 0.36363636363636
33069, 0.56521739130435, 0.05, 0.36363636363636
33070, 0.56521739130435, 0.066666666666667, 0.34090909090909
33071, 0.58695652173913, 0.066666666666667, 0.36363636363636
33072, 0.60869565217391, 0.05, 0.36363636363636
33073, 0.60869565217391, 0.066666666666667, 0.34090909090909
33074, 0.6304347826087, 0.066666666666667, 0.36363636363636
33075, 0.65217391304348, 0.05, 0.36363636363636
33076, 0.65217391304348, 0.066666666666667, 0.34090909090909
33077, 0.67391304347826, 0.066666666666667, 0.36363636363636
33078, 0.69565217391304, 0.05, 0.36363636363636
33079, 0.69565217391304, 0.066666666666667, 0.34090909090909
33080, 0.71739130434783, 0.066666666666667, 0.36363636363636
33081, 0.73913043478261, 0.05, 0.36363636363636
33082, 0.73913043478261, 0.066666666666667, 0.34090909090909
33083, 0.76086956521739, 0.066666666666667, 0.36363636363636
33084, 0.78260869565217, 0.05, 0.36363636363636
33085, 0.78260869565217, 0.066666666666667, 0.34090909090909
33086, 0.80434782608696, 0.066666666666667, 0.36363636363636
33087, 0.82608695652174, 0.05, 0.36363636363636
33088, 0.82608695652174, 0.066666666666667, 0.34090909090909
33089, 0.84782608695652, 0.066666666666667, 0.36363636363636
33090, 0.8695652173913, 0.05, 0.36363636363636
33091, 0.8695652173913, 0.066666666666667, 0.34090909090909
33092, 0.89130434782609, 0.066666666666667, 0.36363636363636
33093, 0.91304347826087, 0.05, 0.36363636363636
33094, 0.91304347826087, 0.066666666666667, 0.34090909090909
33095, 0.93478260869565, 0.066666666666667, 0.36363636363636
33096, 0.95652173913044, 0.05, 0.36363636363636
33097, 0.95652173913044, 0.066666666666667, 0.34090909090909
33098, 0.97826086956522, 0.066666666666667, 0.36363636363636
33099, 0.043478260869565, 0.083333333333333, 0.36363636363636
33100, 0.08695652173913, 0.083333333333333, 0.36363636363636
33101, 0.1304347826087, 0.083333333333333, 0.36363636363636
33102, 0.17391304347826, 0.083333333333333, 0.36363636363636
33103, 0.21739130434783, 0.083333333333333, 0.36363636363636
33104, 0.26086956521739, 0.083333333333333, 0.36363636363636
33105, 0.30434782608696, 0.083333333333333, 0.36363636363636
33106, 0.34782608695652, 0.083333333333333, 0.36363636363636
33107, 0.39130434782609, 0.083333333333333, 0.36363636363636
33108, 0.43478260869565, 0.083333333333333, 0.36363636363636
33109, 0.47826086956522, 0.083333333333333, 0.36363636363636
33110, 0.52173913043478, 0.083333333333333, 0.36363636363636
33111, 0.56521739130435, 0.083333333333333, 0.36363636363636
33112, 0.60869565217391, 0.083333333333333, 0.36363636363636
33113, 0.65217391304348, 0.083333333333333, 0.36363636363636
33114, 0.69565217391304, 0.083333333333333, 0.36363636363636
33115, 0.73913043478261, 0.083333333333333, 0.36363636363636
33116, 0.78260869565217, 0.083333333333333, 0.36363636363636
33117, 0.82608695652174, 0.083333333333333, 0.36363636363636
33118, 0.8695652173913, 0.083333333333333, 0.36363636363636
33119, 0.91304347826087, 0.083333333333333, 0.36363636363636
33120, 0.95652173913043, 0.083333333333333, 0.36363636363636
33121, 0.021739130434783, 0.033333333333333, 0.40909090909091
33122, 0.043478260869565, 0.016666666666667, 0.40909090909091
33123, 0.043478260869565, 0.033333333333333, 0.38636363636364
33124, 0.065217391304348, 0.033333333333333, 0.40909090909091
33125, 0.08695652173913, 0.016666666666667, 0.40909090909091
33126, 0.08695652173913, 0.033333333333333, 0.38636363636364
33127, 0.10869565217391, 0.033333333333333, 0.40909090909091
33128, 0.1304347826087, 0.016666666666667, 0.40909090909091
33129, 0.1304347826087, 0.033333333333333, 0.38636363636364
33130, 0.15217391304348, 0.033333333333333, 0.40909090909091
33131, 0.17391304347826, 0.016666666666667, 0.40909090909091
33132, 0.17391304347826, 0.033333333333333, 0.38636363636364
33133, 0.19565217391304, 0.033333333333333, 0.40909090909091
33134, 0.21739130434783, 0.016666666666667, 0.40909090909091
33135, 0.21739130434783, 0.033333333333333, 0.38636363636364
33136, 0.23913043478261, 0.033333333333333, 0.40909090909091
33137, 0.26086956521739, 0.016666666666667, 0.40909090909091
33138, 0.26086956521739, 0.033333333333333, 0.38636363636364
33139, 0.28260869565217, 0.033333333333333, 0.40909090909091
33140, 0.30434782608696, 0.016666666666667, 0.40909090909091
33141, 0.30434782608696, 0.033333333333333, 0.38636363636364
33142, 0.32608695652174, 0.033333333333333, 0.40909090909091
33143, 0.34782608695652, 0.016666666666667, 0.40909090909091
33144, 0.34782608695652, 0.033333333333333, 0.38636363636364
33145, 0.3695652173913, 0.033333333333333, 0.40909090909091
33146, 0.39130434782609, 0.016666666666667, 0.40909090909091
33147, 0.39130434782609, 0.033333333333333, 0.38636363636364
33148, 0.41304347826087, 0.033333333333333, 0.40909090909091
33149, 0.43478260869565, 0.016666666666667, 0.40909090909091
33150, 0.43478260869565, 0.033333333333333, 0.38636363636364
33151, 0.45652173913043, 0.033333333333333, 0.40909090909091
33152, 0.47826086956522, 0.016666666666667, 0.40909090909091
33153, 0.47826086956522, 0.033333333333333, 0.38636363636364
33154, 0.5, 0.033333333333333, 0.40909090909091
33155, 0.52173913043478, 0.016666666666667, 0.40909090909091
33156, 0.52173913043478, 0.033333333333333, 0.38636363636364
33157, 0.54347826086957, 0.033333333333333, 0.40909090909091
33158, 0.56521739130435, 0.016666666666667, 0.40909090909091
33159, 0.56521739130435, 0.033333333333333, 0.38636363636364
33160, 0.58695652173913, 0.033333333333333, 0.40909090909091
33161, 0.60869565217391, 0.016666666666667, 0.40909090909091
33162, 0.60869565217391, 0.033333333333333, 0.38636363636364
33163, 0.6304347826087, 0.033333333333333, 0.40909090909091
33164, 0.65217391304348, 0.016666666666667, 0.40909090909091
33165, 0.65217391304348, 0.033333333333333, 0.38636363636364
33166, 0.67391304347826, 0.033333333333333, 0.40909090909091
33167, 0.69565217391304, 0.016666666666667, 0.40909090909091
33168, 0.69565217391304, 0.033333333333333, 0.38636363636364
33169, 0.71739130434783, 0.033333333333333, 0.40909090909091
33170, 0.73913043478261, 0.016666666666667, 0.40909090909091
33171, 0.73913043478261, 0.033333333333333, 0.38636363636364
33172, 0.76086956521739, 0.033333333333333, 0.40909090909091
33173, 0.78260869565217, 0.016666666666667, 0.40909090909091
33174, 0.78260869565217, 0.033333333333333, 0.38636363636364
33175, 0.80434782608696, 0.033333333333333, 0.40909090909091
33176, 0.82608695652174, 0.016666666666667, 0.40909090909091
33177, 0.82608695652174, 0.033333333333333, 0.38636363636364
33178, 0.84782608695652, 0.033333333333333, 0.40909090909091
33179, 0.8695652173913, 0.016666666666667, 0.40909090909091
33180, 0.8695652173913, 0.033333333333333, 0.38636363636364
33181, 0.89130434782609, 0.033333333333333, 0.40909090909091
33182, 0.91304347826087, 0.016666666666667, 0.40909090909091
33183, 0.91304347826087, 0.033333333333333, 0.38636363636364
33184, 0.93478260869565, 0.033333333333333, 0.40909090909091
33185, 0.95652173913043, 0.016666666666667, 0.40909090909091
33186, 0.95652173913044, 0.033333333333333, 0.38636363636364
33187, 0.97826086956522, 0.033333333333333, 0.40909090909091
33188, 0.021739130434783, 0.066666666666667, 0.40909090909091
33189, 0.043478260869565, 0.05, 0.40909090909091
33190, 0.043478260869565, 0.066666666666667, 0.38636363636364
33191, 0.065217391304348, 0.066666666666667, 0.40909090909091
33192, 0.08695652173913, 0.05, 0.40909090909091
33193, 0.08695652173913, 0.066666666666667, 0.38636363636364
33194, 0.10869565217391, 0.066666666666667, 0.40909090909091
33195, 0.1304347826087, 0.05, 0.40909090909091
33196, 0.1304347826087, 0.066666666666667, 0.38636363636364
33197, 0.15217391304348, 0.066666666666667, 0.40909090909091
33198, 0.17391304347826, 0.05, 0.40909090909091
33199, 0.17391304347826, 0.066666666666667, 0.38636363636364
33200, 0.19565217391304, 0.066666666666667, 0.40909090909091
33201, 0.21739130434783, 0.05, 0.40909090909091
33202, 0.21739130434783, 0.066666666666667, 0.38636363636364
33203, 0.23913043478261, 0.066666666666667, 0.40909090909091
33204, 0.26086956521739, 0.05, 0.40909090909091
33205, 0.26086956521739, 0.066666666666667, 0.38636363636364
33206, 0.28260869565217, 0.066666666666667, 0.40909090909091
33207, 0.30434782608696, 0.05, 0.40909090909091
33208, 0.30434782608696, 0.066666666666667, 0.38636363636364
33209, 0.32608695652174, 0.066666666666667, 0.40909090909091
33210, 0.34782608695652, 0.05, 0.40909090909091
33211, 0.34782608695652, 0.066666666666667, 0.38636363636364
33212, 0.3695652173913, 0.066666666666667, 0.40909090909091
33213, 0.39130434782609, 0.05, 0.40909090909091
33214, 0.39130434782609, 0.066666666666667, 0.38636363636364
33215, 0.41304347826087, 0.066666666666667, 0.40909090909091
33216, 0.43478260869565, 0.05, 0.40909090909091
33217, 0.43478260869565, 0.066666666666667, 0.38636363636364
33218, 0.45652173913043, 0.066666666666667, 0.40909090909091
33219, 0.47826086956522, 0.05, 0.40909090909091
33220, 0.47826086956522, 0.066666666666667, 0.38636363636364
33221, 0.5, 0.066666666666667, 0.40909090909091
33222, 0.52173913043478, 0.05, 0.40909090909091
33223, 0.52173913043478, 0.066666666666667, 0.38636363636364
33224, 0.54347826086957, 0.066666666666667, 0.40909090909091
33225, 0.56521739130435, 0.05, 0.40909090909091
33226, 0.56521739130435, 0.066666666666667, 0.38636363636364
33227, 0.58695652173913, 0.066666666666667, 0.40909090909091
33228, 0.60869565217391, 0.05, 0.40909090909091
33229, 0.60869565217391, 0.066666666666667, 0.38636363636364
33230, 0.6304347826087, 0.066666666666667, 0.40909090909091
33231, 0.65217391304348, 0.05, 0.40909090909091
33232, 0.65217391304348, 0.066666666666667, 0.38636363636364
33233, 0.67391304347826, 0.066666666666667, 0.40909090909091
33234, 0.69565217391304, 0.05, 0.40909090909091
33235, 0.69565217391304, 0.066666666666667, 0.38636363636364
33236, 0.71739130434783, 0.066666666666667, 0.40909090909091
33237, 0.73913043478261, 0.05, 0.40909090909091
33238, 0.73913043478261, 0.066666666666667, 0.38636363636364
33239, 0.76086956521739, 0.066666666666667, 0.40909090909091
33240, 0.78260869565217, 0.05, 0.40909090909091
33241, 0.78260869565217, 0.066666666666667, 0.38636363636364
33242, 0.80434782608696, 0.066666666666667, 0.40909090909091
33243, 0.82608695652174, 0.05, 0.40909090909091
33244, 0.82608695652174, 0.066666666666667, 0.38636363636364
33245, 0.84782608695652, 0.066666666666667, 0.40909090909091
33246, 0.8695652173913, 0.05, 0.40909090909091
33247, 0.8695652173913, 0.066666666666667, 0.38636363636364
33248, 0.89130434782609, 0.066666666666667, 0.40909090909091
33249, 0.91304347826087, 0.05, 0.40909090909091
33250, 0.91304347826087, 0.066666666666667, 0.38636363636364
33251, 0.93478260869565, 0.066666666666667, 0.40909090909091
33252, 0.95652173913044, 0.05, 0.40909090909091
33253, 0.95652173913044, 0.066666666666667, 0.38636363636364
33254, 0.97826086956522, 0.066666666666667, 0.40909090909091
33255, 0.043478260869565, 0.083333333333333, 0.40909090909091
33256, 0.08695652173913, 0.083333333333333, 0.40909090909091
33257, 0.1304347826087, 0.083333333333333, 0.40909090909091
33258, 0.17391304347826, 0.083333333333333, 0.40909090909091
33259, 0.21739130434783, 0.083333333333333, 0.40909090909091
33260, 0.26086956521739, 0.083333333333333, 0.40909090909091
33261, 0.30434782608696, 0.083333333333333, 0.40909090909091
33262, 0.34782608695652, 0.083333333333333, 0.40909090909091
33263, 0.39130434782609, 0.083333333333333, 0.40909090909091
33264, 0.43478260869565, 0.083333333333333, 0.40909090909091
33265, 0.47826086956522, 0.083333333333333, 0.40909090909091
33266, 0.52173913043478, 0.083333333333333, 0.40909090909091
33267, 0.56521739130435, 0.083333333333333, 0.40909090909091
33268, 0.60869565217391, 0.083333333333333, 0.40909090909091
33269, 0.65217391304348, 0.083333333333333, 0.40909090909091
33270, 0.69565217391304, 0.083333333333333, 0.40909090909091
33271, 0.73913043478261, 0.083333333333333, 0.40909090909091
33272, 0.78260869565217, 0.083333333333333, 0.40909090909091
33273, 0.82608695652174, 0.083333333333333, 0.40909090909091
33274, 0.8695652173913, 0.083333333333333, 0.40909090909091
33275, 0.91304347826087, 0.083333333333333, 0.40909090909091
33276, 0.95652173913043, 0.083333333333333, 0.40909090909091
33277, 0.021739130434783, 0.033333333333333, 0.45454545454545
33278, 0.043478260869565, 0.016666666666667, 0.45454545454545
33279, 0.043478260869565, 0.033333333333333, 0.43181818181818
33280, 0.065217391304348, 0.033333333333333, 0.45454545454545
33281, 0.08695652173913, 0.016666666666667, 0.45454545454545
33282, 0.08695652173913, 0.033333333333333, 0.43181818181818
33283, 0.10869565217391, 0.033333333333333, 0.45454545454545
33284, 0.1304347826087, 0.016666666666667, 0.45454545454545
33285, 0.1304347826087, 0.033333333333333, 0.43181818181818
33286, 0.15217391304348, 0.033333333333333, 0.45454545454545
33287, 0.17391304347826, 0.016666666666667, 0.45454545454545
33288, 0.17391304347826, 0.033333333333333, 0.43181818181818
33289, 0.19565217391304, 0.033333333333333, 0.45454545454545
33290, 0.21739130434783, 0.016666666666667, 0.45454545454545
33291, 0.21739130434783, 0.033333333333333, 0.43181818181818
33292, 0.23913043478261, 0.033333333333333, 0.45454545454545
33293, 0.26086956521739, 0.016666666666667, 0.45454545454545
33294, 0.26086956521739, 0.033333333333333, 0.43181818181818
33295, 0.28260869565217, 0.033333333333333, 0.45454545454545
33296, 0.30434782608696, 0.016666666666667, 0.45454545454545
33297, 0.30434782608696, 0.033333333333333, 0.43181818181818
33298, 0.32608695652174, 0.033333333333333, 0.45454545454545
33299, 0.34782608695652, 0.016666666666667, 0.45454545454545
33300, 0.34782608695652, 0.033333333333333, 0.43181818181818
33301, 0.3695652173913, 0.033333333333333, 0.45454545454545
33302, 0.39130434782609, 0.016666666666667, 0.45454545454545
33303, 0.39130434782609, 0.033333333333333, 0.43181818181818
33304, 0.41304347826087, 0.033333333333333, 0.45454545454545
33305, 0.43478260869565, 0.016666666666667, 0.45454545454545
33306, 0.43478260869565, 0.033333333333333, 0.43181818181818
33307, 0.45652173913043, 0.033333333333333, 0.45454545454545
33308, 0.47826086956522, 0.016666666666667, 0.45454545454545
33309, 0.47826086956522, 0.033333333333333, 0.43181818181818
33310, 0.5, 0.033333333333333, 0.45454545454545
33311, 0.52173913043478, 0.016666666666667, 0.45454545454545
33312, 0.52173913043478, 0.033333333333333, 0.43181818181818
33313, 0.54347826086957, 0.033333333333333, 0.45454545454545
33314, 0.56521739130435, 0.016666666666667, 0.45454545454545
33315, 0.56521739130435, 0.033333333333333, 0.43181818181818
33316, 0.58695652173913, 0.033333333333333, 0.45454545454545
33317, 0.60869565217391, 0.016666666666667, 0.45454545454545
33318, 0.60869565217391, 0.033333333333333, 0.43181818181818
33319, 0.6304347826087, 0.033333333333333, 0.45454545454545
33320, 0.65217391304348, 0.016666666666667, 0.45454545454545
33321, 0.65217391304348, 0.033333333333333, 0.43181818181818
33322, 0.67391304347826, 0.033333333333333, 0.45454545454545
33323, 0.69565217391304, 0.016666666666667, 0.45454545454545
33324, 0.69565217391304, 0.033333333333333, 0.43181818181818
33325, 0.71739130434783, 0.033333333333333, 0.45454545454545
33326, 0.73913043478261, 0.016666666666667, 0.45454545454545
33327, 0.73913043478261, 0.033333333333333, 0.43181818181818
33328, 0.76086956521739, 0.033333333333333, 0.45454545454545
33329, 0.78260869565217, 0.016666666666667, 0.45454545454545
33330, 0.78260869565217, 0.033333333333333, 0.43181818181818
33331, 0.80434782608696, 0.033333333333333, 0.45454545454545
33332, 0.82608695652174, 0.016666666666667, 0.45454545454545
33333, 0.82608695652174, 0.033333333333333, 0.43181818181818
33334, 0.84782608695652, 0.033333333333333, 0.45454545454545
33335, 0.8695652173913, 0.016666666666667, 0.45454545454545
33336, 0.8695652173913, 0.033333333333333, 0.43181818181818
33337, 0.89130434782609, 0.033333333333333, 0.45454545454545
33338, 0.91304347826087, 0.016666666666667, 0.45454545454545
33339, 0.91304347826087, 0.033333333333333, 0.43181818181818
33340, 0.93478260869565, 0.033333333333333, 0.45454545454545
33341, 0.95652173913043, 0.016666666666667, 0.45454545454545
33342, 0.95652173913044, 0.033333333333333, 0.43181818181818
33343, 0.97826086956522, 0.033333333333333, 0.45454545454545
33344, 0.021739130434783, 0.066666666666667, 0.45454545454545
33345, 0.043478260869565, 0.05, 0.45454545454545
33346, 0.043478260869565, 0.066666666666667, 0.43181818181818
33347, 0.065217391304348, 0.066666666666667, 0.45454545454545
33348, 0.08695652173913, 0.05, 0.45454545454545
33349, 0.08695652173913, 0.066666666666667, 0.43181818181818
33350, 0.10869565217391, 0.066666666666667, 0.45454545454545
33351, 0.1304347826087, 0.05, 0.45454545454545
33352, 0.1304347826087, 0.066666666666667, 0.43181818181818
33353, 0.15217391304348, 0.066666666666667, 0.45454545454545
33354, 0.17391304347826, 0.05, 0.45454545454545
33355, 0.17391304347826, 0.066666666666667, 0.43181818181818
33356, 0.19565217391304, 0.066666666666667, 0.45454545454545
33357, 0.21739130434783, 0.05, 0.45454545454545
33358, 0.21739130434783, 0.066666666666667, 0.43181818181818
33359, 0.23913043478261, 0.066666666666667, 0.45454545454545
33360, 0.26086956521739, 0.05, 0.45454545454545
33361, 0.26086956521739, 0.066666666666667, 0.43181818181818
33362, 0.28260869565217, 0.066666666666667, 0.45454545454545
33363, 0.30434782608696, 0.05, 0.45454545454545
33364, 0.30434782608696, 0.066666666666667, 0.43181818181818
33365, 0.32608695652174, 0.066666666666667, 0.45454545454545
33366, 0.34782608695652, 0.05, 0.45454545454545
33367, 0.34782608695652, 0.066666666666667, 0.43181818181818
33368, 0.3695652173913, 0.066666666666667, 0.45454545454545
33369, 0.39130434782609, 0.05, 0.45454545454545
33370, 0.39130434782609, 0.066666666666667, 0.43181818181818
33371, 0.41304347826087, 0.066666666666667, 0.45454545454545
33372, 0.43478260869565, 0.05, 0.45454545454545
33373, 0.43478260869565, 0.066666666666667, 0.43181818181818
33374, 0.45652173913043, 0.066666666666667, 0.45454545454545
33375, 0.47826086956522, 0.05, 0.45454545454545
33376, 0.47826086956522, 0.066666666666667, 0.43181818181818
33377, 0.5, 0.066666666666667, 0.45454545454545
33378, 0.52173913043478, 0.05, 0.45454545454545
33379, 0.52173913043478, 0.066666666666667, 0.43181818181818
33380, 0.54347826086957, 0.066666666666667, 0.45454545454545
33381, 0.56521739130435, 0.05, 0.45454545454545
33382, 0.56521739130435, 0.066666666666667, 0.43181818181818
33383, 0.58695652173913, 0.066666666666667, 0.45454545454545
33384, 0.60869565217391, 0.05, 0.45454545454545
33385, 0.60869565217391, 0.066666666666667, 0.43181818181818
33386, 0.6304347826087, 0.066666666666667, 0.45454545454545
33387, 0.65217391304348, 0.05, 0.45454545454545
33388, 0.65217391304348, 0.066666666666667, 0.43181818181818
33389, 0.67391304347826, 0.066666666666667, 0.45454545454545
33390, 0.69565217391304, 0.05, 0.45454545454545
33391, 0.69565217391304, 0.066666666666667, 0.43181818181818
33392, 0.71739130434783, 0.066666666666667, 0.45454545454545
33393, 0.73913043478261, 0.05, 0.45454545454545
33394, 0.73913043478261, 0.066666666666667, 0.43181818181818
33395, 0.76086956521739, 0.066666666666667, 0.45454545454545
33396, 0.78260869565217, 0.05, 0.45454545454545
33397, 0.78260869565217, 0.066666666666667, 0.43181818181818
33398, 0.80434782608696, 0.066666666666667, 0.45454545454545
33399, 0.82608695652174, 0.05, 0.45454545454545
33400, 0.82608695652174, 0.066666666666667, 0.43181818181818
33401, 0.84782608695652, 0.066666666666667, 0.45454545454545
33402, 0.8695652173913, 0.05, 0.45454545454545
33403, 0.8695652173913, 0.066666666666667, 0.43181818181818
33404, 0.89130434782609, 0.066666666666667, 0.45454545454545
33405, 0.91304347826087, 0.05, 0.45454545454545
33406, 0.91304347826087, 0.066666666666667, 0.43181818181818
33407, 0.93478260869565, 0.066666666666667, 0.45454545454545
33408, 0.95652173913044, 0.05, 0.45454545454545
33409, 0.95652173913044, 0.066666666666667, 0.43181818181818
33410, 0.97826086956522, 0.066666666666667, 0.45454545454545
33411, 0.043478260869565, 0.083333333333333, 0.45454545454545
33412, 0.08695652173913, 0.083333333333333, 0.45454545454545
33413, 0.1304347826087, 0.083333333333333, 0.45454545454545
33414, 0.17391304347826, 0.083333333333333, 0.45454545454545
33415, 0.21739130434783, 0.083333333333333, 0.45454545454545
33416, 0.26086956521739, 0.083333333333333, 0.45454545454545
33417, 0.30434782608696, 0.083333333333333, 0.45454545454545
33418, 0.34782608695652, 0.083333333333333, 0.45454545454545
33419, 0.39130434782609, 0.083333333333333, 0.45454545454545
33420, 0.43478260869565, 0.083333333333333, 0.45454545454545
33421, 0.47826086956522, 0.083333333333333, 0.45454545454545
33422, 0.52173913043478, 0.083333333333333, 0.45454545454545
33423, 0.56521739130435, 0.083333333333333, 0.45454545454545
33424, 0.60869565217391, 0.083333333333333, 0.45454545454545
33425, 0.65217391304348, 0.083333333333333, 0.45454545454545
33426, 0.69565217391304, 0.083333333333333, 0.45454545454545
33427, 0.73913043478261, 0.083333333333333, 0.45454545454545
33428, 0.78260869565217, 0.083333333333333, 0.45454545454545
33429, 0.82608695652174, 0.083333333333333, 0.45454545454545
33430, 0.8695652173913, 0.083333333333333, 0.45454545454545
33431, 0.91304347826087, 0.083333333333333, 0.45454545454545
33432, 0.95652173913043, 0.083333333333333, 0.45454545454545
33433, 0.043478260869565, 0.033333333333333, 0.47727272727273
33434, 0.08695652173913, 0.033333333333333, 0.47727272727273
33435, 0.1304347826087, 0.033333333333333, 0.47727272727273
33436, 0.17391304347826, 0.033333333333333, 0.47727272727273
33437, 0.21739130434783, 0.033333333333333, 0.47727272727273
33438, 0.26086956521739, 0.033333333333333, 0.47727272727273
33439, 0.30434782608696, 0.033333333333333, 0.47727272727273
33440, 0.34782608695652, 0.033333333333333, 0.47727272727273
33441, 0.39130434782609, 0.033333333333333, 0.47727272727273
33442, 0.43478260869565, 0.033333333333333, 0.47727272727273
33443, 0.47826086956522, 0.033333333333333, 0.47727272727273
33444, 0.52173913043478, 0.033333333333333, 0.47727272727273
33445, 0.56521739130435, 0.033333333333333, 0.47727272727273
33446, 0.60869565217391, 0.033333333333333, 0.47727272727273
33447, 0.65217391304348, 0.033333333333333, 0.47727272727273
33448, 0.69565217391304, 0.033333333333333, 0.47727272727273
33449, 0.73913043478261, 0.033333333333333, 0.47727272727273
33450, 0.78260869565217, 0.033333333333333, 0.47727272727273
33451, 0.82608695652174, 0.033333333333333, 0.47727272727273
33452, 0.8695652173913, 0.033333333333333, 0.47727272727273
33453, 0.91304347826087, 0.033333333333333, 0.47727272727273
33454, 0.95652173913043, 0.033333333333333, 0.47727272727273
33455, 0.043478260869565, 0.066666666666667, 0.47727272727273
33456, 0.08695652173913, 0.066666666666667, 0.47727272727273
33457, 0.1304347826087, 0.066666666666667, 0.47727272727273
33458, 0.17391304347826, 0.066666666666667, 0.47727272727273
33459, 0.21739130434783, 0.066666666666667, 0.47727272727273
33460, 0.26086956521739, 0.066666666666667, 0.47727272727273
33461, 0.30434782608696, 0.066666666666667, 0.47727272727273
33462, 0.34782608695652, 0.066666666666667, 0.47727272727273
33463, 0.39130434782609, 0.066666666666667, 0.47727272727273
33464, 0.43478260869565, 0.066666666666667, 0.47727272727273
33465, 0.47826086956522, 0.066666666666667, 0.47727272727273
33466, 0.52173913043478, 0.066666666666667, 0.47727272727273
33467, 0.56521739130435, 0.066666666666667, 0.47727272727273
33468, 0.60869565217391, 0.066666666666667, 0.47727272727273
33469, 0.65217391304348, 0.066666666666667, 0.47727272727273
33470, 0.69565217391304, 0.066666666666667, 0.47727272727273
33471, 0.73913043478261, 0.066666666666667, 0.47727272727273
33472, 0.78260869565217, 0.066666666666667, 0.47727272727273
33473, 0.82608695652174, 0.066666666666667, 0.47727272727273
33474, 0.8695652173913, 0.066666666666667, 0.47727272727273
33475, 0.91304347826087, 0.066666666666667, 0.47727272727273
33476, 0.95652173913043, 0.066666666666667, 0.47727272727273
33477, 0.95652173913043, 0.125, 0.045454545454545
33478, 0.95652173913043, 0.125, 0.090909090909091
33479, 0.95652173913044, 0.125, 0.13636363636364
33480, 0.95652173913044, 0.125, 0.18181818181818
33481, 0.95652173913044, 0.125, 0.22727272727273
33482, 0.95652173913044, 0.125, 0.27272727272727
33483, 0.95652173913043, 0.125, 0.31818181818182
33484, 0.95652173913043, 0.125, 0.36363636363636
33485, 0.95652173913043, 0.125, 0.40909090909091
33486, 0.95652173913044, 0.125, 0.45454545454545
33487, 0.91304347826087, 0.125, 0.045454545454545
33488, 0.91304347826087, 0.125, 0.090909090909091
33489, 0.91304347826087, 0.125, 0.13636363636364
33490, 0.91304347826087, 0.125, 0.18181818181818
33491, 0.91304347826087, 0.125, 0.22727272727273
33492, 0.91304347826087, 0.125, 0.27272727272727
33493, 0.91304347826087, 0.125, 0.31818181818182
33494, 0.91304347826087, 0.125, 0.36363636363636
33495, 0.91304347826087, 0.125, 0.40909090909091
33496, 0.91304347826087, 0.125, 0.45454545454545
33497, 0.8695652173913, 0.125, 0.045454545454545
33498, 0.8695652173913, 0.125, 0.090909090909091
33499, 0.8695652173913, 0.125, 0.13636363636364
33500, 0.8695652173913, 0.125, 0.18181818181818
33501, 0.8695652173913, 0.125, 0.22727272727273
33502, 0.8695652173913, 0.125, 0.27272727272727
33503, 0.8695652173913, 0.125, 0.31818181818182
33504, 0.8695652173913, 0.125, 0.36363636363636
33505, 0.8695652173913, 0.125, 0.40909090909091
33506, 0.8695652173913, 0.125, 0.45454545454545
33507, 0.82608695652174, 0.125, 0.045454545454545
33508, 0.82608695652174, 0.125, 0.090909090909091
33509, 0.82608695652174, 0.125, 0.13636363636364
33510, 0.82608695652174, 0.125, 0.18181818181818
33511, 0.82608695652174, 0.125, 0.22727272727273
33512, 0.82608695652174, 0.125, 0.27272727272727
33513, 0.82608695652174, 0.125, 0.31818181818182
33514, 0.82608695652174, 0.125, 0.36363636363636
33515, 0.82608695652174, 0.125, 0.40909090909091
33516, 0.82608695652174, 0.125, 0.45454545454545
33517, 0.78260869565217, 0.125, 0.045454545454545
33518, 0.78260869565217, 0.125, 0.090909090909091
33519, 0.78260869565217, 0.125, 0.13636363636364
33520, 0.78260869565217, 0.125, 0.18181818181818
33521, 0.78260869565217, 0.125, 0.22727272727273
33522, 0.78260869565217, 0.125, 0.27272727272727
33523, 0.78260869565217, 0.125, 0.31818181818182
33524, 0.78260869565217, 0.125, 0.36363636363636
33525, 0.78260869565217, 0.125, 0.40909090909091
33526, 0.78260869565217, 0.125, 0.45454545454545
33527, 0.73913043478261, 0.125, 0.045454545454545
33528, 0.73913043478261, 0.125, 0.090909090909091
33529, 0.73913043478261, 0.125, 0.13636363636364
33530, 0.73913043478261, 0.125, 0.18181818181818
33531, 0.73913043478261, 0.125, 0.22727272727273
33532, 0.73913043478261, 0.125, 0.27272727272727
33533, 0.73913043478261, 0.125, 0.31818181818182
33534, 0.73913043478261, 0.125, 0.36363636363636
33535, 0.73913043478261, 0.125, 0.40909090909091
33536, 0.73913043478261, 0.125, 0.45454545454545
33537, 0.69565217391304, 0.125, 0.045454545454545
33538, 0.69565217391304, 0.125, 0.090909090909091
33539, 0.69565217391304, 0.125, 0.13636363636364
33540, 0.69565217391304, 0.125, 0.18181818181818
33541, 0.69565217391304, 0.125, 0.22727272727273
33542, 0.69565217391304, 0.125, 0.27272727272727
33543, 0.69565217391304, 0.125, 0.31818181818182
33544, 0.69565217391304, 0.125, 0.36363636363636
33545, 0.69565217391304, 0.125, 0.40909090909091
33546, 0.69565217391304, 0.125, 0.45454545454545
33547, 0.65217391304348, 0.125, 0.045454545454545
33548, 0.65217391304348, 0.125, 0.090909090909091
33549, 0.65217391304348, 0.125, 0.13636363636364
33550, 0.65217391304348, 0.125, 0.18181818181818
33551, 0.65217391304348, 0.125, 0.22727272727273
33552, 0.65217391304348, 0.125, 0.27272727272727
33553, 0.65217391304348, 0.125, 0.31818181818182
33554, 0.65217391304348, 0.125, 0.36363636363636
33555, 0.65217391304348, 0.125, 0.40909090909091
33556, 0.65217391304348, 0.125, 0.45454545454545
33557, 0.60869565217391, 0.125, 0.045454545454545
33558, 0.60869565217391, 0.125, 0.090909090909091
33559, 0.60869565217391, 0.125, 0.13636363636364
33560, 0.60869565217391, 0.125, 0.18181818181818
33561, 0.60869565217391, 0.125, 0.22727272727273
33562, 0.60869565217391, 0.125, 0.27272727272727
33563, 0.60869565217391, 0.125, 0.31818181818182
33564, 0.60869565217391, 0.125, 0.36363636363636
33565, 0.60869565217391, 0.125, 0.40909090909091
33566, 0.60869565217391, 0.125, 0.45454545454545
33567, 0.56521739130435, 0.125, 0.045454545454545
33568, 0.56521739130435, 0.125, 0.090909090909091
33569, 0.56521739130435, 0.125, 0.13636363636364
33570, 0.56521739130435, 0.125, 0.18181818181818
33571, 0.56521739130435, 0.125, 0.22727272727273
33572, 0.56521739130435, 0.125, 0.27272727272727
33573, 0.56521739130435, 0.125, 0.31818181818182
33574, 0.56521739130435, 0.125, 0.36363636363636
33575, 0.56521739130435, 0.125, 0.40909090909091
33576, 0.56521739130435, 0.125, 0.45454545454545
33577, 0.52173913043478, 0.125, 0.045454545454545
33578, 0.52173913043478, 0.125, 0.090909090909091
33579, 0.52173913043478, 0.125, 0.13636363636364
33580, 0.52173913043478, 0.125, 0.18181818181818
33581, 0.52173913043478, 0.125, 0.22727272727273
33582, 0.52173913043478, 0.125, 0.27272727272727
33583, 0.52173913043478, 0.125, 0.31818181818182
33584, 0.52173913043478, 0.125, 0.36363636363636
33585, 0.52173913043478, 0.125, 0.40909090909091
33586, 0.52173913043478, 0.125, 0.45454545454545
33587, 0.47826086956522, 0.125, 0.045454545454545
33588, 0.47826086956522, 0.125, 0.090909090909091
33589, 0.47826086956522, 0.125, 0.13636363636364
33590, 0.47826086956522, 0.125, 0.18181818181818
33591, 0.47826086956522, 0.125, 0.22727272727273
33592, 0.47826086956522, 0.125, 0.27272727272727
33593, 0.47826086956522, 0.125, 0.31818181818182
33594, 0.47826086956522, 0.125, 0.36363636363636
33595, 0.47826086956522, 0.125, 0.40909090909091
33596, 0.47826086956522, 0.125, 0.45454545454545
33597, 0.43478260869565, 0.125, 0.045454545454545
33598, 0.43478260869565, 0.125, 0.090909090909091
33599, 0.43478260869565, 0.125, 0.13636363636364
33600, 0.43478260869565, 0.125, 0.18181818181818
33601, 0.43478260869565, 0.125, 0.22727272727273
33602, 0.43478260869565, 0.125, 0.27272727272727
33603, 0.43478260869565, 0.125, 0.31818181818182
33604, 0.43478260869565, 0.125, 0.36363636363636
33605, 0.43478260869565, 0.125, 0.40909090909091
33606, 0.43478260869565, 0.125, 0.45454545454545
33607, 0.39130434782609, 0.125, 0.045454545454545
33608, 0.39130434782609, 0.125, 0.090909090909091
33609, 0.39130434782609, 0.125, 0.13636363636364
33610, 0.39130434782609, 0.125, 0.18181818181818
33611, 0.39130434782609, 0.125, 0.22727272727273
33612, 0.39130434782609, 0.125, 0.27272727272727
33613, 0.39130434782609, 0.125, 0.31818181818182
33614, 0.39130434782609, 0.125, 0.36363636363636
33615, 0.39130434782609, 0.125, 0.40909090909091
33616, 0.39130434782609, 0.125, 0.45454545454545
33617, 0.34782608695652, 0.125, 0.045454545454545
33618, 0.34782608695652, 0.125, 0.090909090909091
33619, 0.34782608695652, 0.125, 0.13636363636364
33620, 0.34782608695652, 0.125, 0.18181818181818
33621, 0.34782608695652, 0.125, 0.22727272727273
33622, 0.34782608695652, 0.125, 0.27272727272727
33623, 0.34782608695652, 0.125, 0.31818181818182
33624, 0.34782608695652, 0.125, 0.36363636363636
33625, 0.34782608695652, 0.125, 0.40909090909091
33626, 0.34782608695652, 0.125, 0.45454545454545
33627, 0.30434782608696, 0.125, 0.045454545454545
33628, 0.30434782608696, 0.125, 0.090909090909091
33629, 0.30434782608696, 0.125, 0.13636363636364
33630, 0.30434782608696, 0.125, 0.18181818181818
33631, 0.30434782608696, 0.125, 0.22727272727273
33632, 0.30434782608696, 0.125, 0.27272727272727
33633, 0.30434782608696, 0.125, 0.31818181818182
33634, 0.30434782608696, 0.125, 0.36363636363636
33635, 0.30434782608696, 0.125, 0.40909090909091
33636, 0.30434782608696, 0.125, 0.45454545454545
33637, 0.26086956521739, 0.125, 0.045454545454545
33638, 0.26086956521739, 0.125, 0.090909090909091
33639, 0.26086956521739, 0.125, 0.13636363636364
33640, 0.26086956521739, 0.125, 0.18181818181818
33641, 0.26086956521739, 0.125, 0.22727272727273
33642, 0.26086956521739, 0.125, 0.27272727272727
33643, 0.26086956521739, 0.125, 0.31818181818182
33644, 0.26086956521739, 0.125, 0.36363636363636
33645, 0.26086956521739, 0.125, 0.40909090909091
33646, 0.26086956521739, 0.125, 0.45454545454545
33647, 0.21739130434783, 0.125, 0.045454545454545
33648, 0.21739130434783, 0.125, 0.090909090909091
33649, 0.21739130434783, 0.125, 0.13636363636364
33650, 0.21739130434783, 0.125, 0.18181818181818
33651, 0.21739130434783, 0.125, 0.22727272727273
33652, 0.21739130434783, 0.125, 0.27272727272727
33653, 0.21739130434783, 0.125, 0.31818181818182
33654, 0.21739130434783, 0.125, 0.36363636363636
33655, 0.21739130434783, 0.125, 0.40909090909091
33656, 0.21739130434783, 0.125, 0.45454545454545
33657, 0.17391304347826, 0.125, 0.045454545454545
33658, 0.17391304347826, 0.125, 0.090909090909091
33659, 0.17391304347826, 0.125, 0.13636363636364
33660, 0.17391304347826, 0.125, 0.18181818181818
33661, 0.17391304347826, 0.125, 0.22727272727273
33662, 0.17391304347826, 0.125, 0.27272727272727
33663, 0.17391304347826, 0.125, 0.31818181818182
33664, 0.17391304347826, 0.125, 0.36363636363636
33665, 0.17391304347826, 0.125, 0.40909090909091
33666, 0.17391304347826, 0.125, 0.45454545454545
33667, 0.1304347826087, 0.125, 0.045454545454545
33668, 0.1304347826087, 0.125, 0.090909090909091
33669, 0.1304347826087, 0.125, 0.13636363636364
33670, 0.1304347826087, 0.125, 0.18181818181818
33671, 0.1304347826087, 0.125, 0.22727272727273
33672, 0.1304347826087, 0.125, 0.27272727272727
33673, 0.1304347826087, 0.125, 0.31818181818182
33674, 0.1304347826087, 0.125, 0.36363636363636
33675, 0.1304347826087, 0.125, 0.40909090909091
33676, 0.1304347826087, 0.125, 0.45454545454545
33677, 0.08695652173913, 0.125, 0.045454545454545
33678, 0.08695652173913, 0.125, 0.090909090909091
33679, 0.08695652173913, 0.125, 0.13636363636364
33680, 0.08695652173913, 0.125, 0.18181818181818
33681, 0.08695652173913, 0.125, 0.22727272727273
33682, 0.08695652173913, 0.125, 0.27272727272727
33683, 0.08695652173913, 0.125, 0.31818181818182
33684, 0.08695652173913, 0.125, 0.36363636363636
33685, 0.08695652173913, 0.125, 0.40909090909091
33686, 0.08695652173913, 0.125, 0.45454545454545
33687, 0.043478260869565, 0.125, 0.045454545454545
33688, 0.043478260869565, 0.125, 0.090909090909091
33689, 0.043478260869565, 0.125, 0.13636363636364
33690, 0.043478260869565, 0.125, 0.18181818181818
33691, 0.043478260869565, 0.125, 0.22727272727273
33692, 0.043478260869565, 0.125, 0.27272727272727
33693, 0.043478260869565, 0.125, 0.31818181818182
33694, 0.043478260869565, 0.125, 0.36363636363636
33695, 0.043478260869565, 0.125, 0.40909090909091
33696, 0.043478260869565, 0.125, 0.45454545454545
33697, 0.95652173913043, 0.125, 0.022727272727273
33698, 0.97826086956522, 0.125, 0.045454545454545
33699, 0.95652173913043, 0.1125, 0.045454545454545
33700, 0.95652173913043, 0.125, 0.068181818181818
33701, 0.97826086956522, 0.125, 0.090909090909091
33702, 0.95652173913043, 0.1125, 0.090909090909091
33703, 0.95652173913043, 0.125, 0.11363636363636
33704, 0.97826086956522, 0.125, 0.13636363636364
33705, 0.95652173913044, 0.1125, 0.13636363636364
33706, 0.95652173913044, 0.125, 0.15909090909091
33707, 0.97826086956522, 0.125, 0.18181818181818
33708, 0.95652173913043, 0.1125, 0.18181818181818
33709, 0.95652173913044, 0.125, 0.20454545454545
33710, 0.97826086956522, 0.125, 0.22727272727273
33711, 0.95652173913043, 0.1125, 0.22727272727273
33712, 0.95652173913044, 0.125, 0.25
33713, 0.97826086956522, 0.125, 0.27272727272727
33714, 0.95652173913043, 0.1125, 0.27272727272727
33715, 0.95652173913044, 0.125, 0.29545454545455
33716, 0.97826086956522, 0.125, 0.31818181818182
33717, 0.95652173913043, 0.1125, 0.31818181818182
33718, 0.95652173913043, 0.125, 0.34090909090909
33719, 0.97826086956522, 0.125, 0.36363636363636
33720, 0.95652173913043, 0.1125, 0.36363636363636
33721, 0.95652173913043, 0.125, 0.38636363636364
33722, 0.97826086956522, 0.125, 0.40909090909091
33723, 0.95652173913043, 0.1125, 0.40909090909091
33724, 0.95652173913043, 0.125, 0.43181818181818
33725, 0.97826086956522, 0.125, 0.45454545454545
33726, 0.95652173913043, 0.1125, 0.45454545454545
33727, 0.95652173913043, 0.125, 0.47727272727273
33728, 0.91304347826087, 0.125, 0.022727272727273
33729, 0.93478260869565, 0.125, 0.045454545454545
33730, 0.91304347826087, 0.1125, 0.045454545454545
33731, 0.91304347826087, 0.125, 0.068181818181818
33732, 0.93478260869565, 0.125, 0.090909090909091
33733, 0.91304347826087, 0.1125, 0.090909090909091
33734, 0.91304347826087, 0.125, 0.11363636363636
33735, 0.93478260869565, 0.125, 0.13636363636364
33736, 0.91304347826087, 0.1125, 0.13636363636364
33737, 0.91304347826087, 0.125, 0.15909090909091
33738, 0.93478260869565, 0.125, 0.18181818181818
33739, 0.91304347826087, 0.1125, 0.18181818181818
33740, 0.91304347826087, 0.125, 0.20454545454545
33741, 0.93478260869565, 0.125, 0.22727272727273
33742, 0.91304347826087, 0.1125, 0.22727272727273
33743, 0.91304347826087, 0.125, 0.25
33744, 0.93478260869565, 0.125, 0.27272727272727
33745, 0.91304347826087, 0.1125, 0.27272727272727
33746, 0.91304347826087, 0.125, 0.29545454545455
33747, 0.93478260869565, 0.125, 0.31818181818182
33748, 0.91304347826087, 0.1125, 0.31818181818182
33749, 0.91304347826087, 0.125, 0.34090909090909
33750, 0.93478260869565, 0.125, 0.36363636363636
33751, 0.91304347826087, 0.1125, 0.36363636363636
33752, 0.91304347826087, 0.125, 0.38636363636364
33753, 0.93478260869565, 0.125, 0.40909090909091
33754, 0.91304347826087, 0.1125, 0.40909090909091
33755, 0.91304347826087, 0.125, 0.43181818181818
33756, 0.93478260869565, 0.125, 0.45454545454545
33757, 0.91304347826087, 0.1125, 0.45454545454545
33758, 0.91304347826087, 0.125, 0.47727272727273
33759, 0.8695652173913, 0.125, 0.022727272727273
33760, 0.89130434782609, 0.125, 0.045454545454545
33761, 0.8695652173913, 0.1125, 0.045454545454545
33762, 0.8695652173913, 0.125, 0.068181818181818
33763, 0.89130434782609, 0.125, 0.090909090909091
33764, 0.8695652173913, 0.1125, 0.090909090909091
33765, 0.8695652173913, 0.125, 0.11363636363636
33766, 0.89130434782609, 0.125, 0.13636363636364
33767, 0.8695652173913, 0.1125, 0.13636363636364
33768, 0.8695652173913, 0.125, 0.15909090909091
33769, 0.89130434782609, 0.125, 0.18181818181818
33770, 0.8695652173913, 0.1125, 0.18181818181818
33771, 0.8695652173913, 0.125, 0.20454545454545
33772, 0.89130434782609, 0.125, 0.22727272727273
33773, 0.8695652173913, 0.1125, 0.22727272727273
33774, 0.8695652173913, 0.125, 0.25
33775, 0.89130434782609, 0.125, 0.27272727272727
33776, 0.8695652173913, 0.1125, 0.27272727272727
33777, 0.8695652173913, 0.125, 0.29545454545455
33778, 0.89130434782609, 0.125, 0.31818181818182
33779, 0.8695652173913, 0.1125, 0.31818181818182
33780, 0.8695652173913, 0.125, 0.34090909090909
33781, 0.89130434782609, 0.125, 0.36363636363636
33782, 0.8695652173913, 0.1125, 0.36363636363636
33783, 0.8695652173913, 0.125, 0.38636363636364
33784, 0.89130434782609, 0.125, 0.40909090909091
33785, 0.8695652173913, 0.1125, 0.40909090909091
33786, 0.8695652173913, 0.125, 0.43181818181818
33787, 0.89130434782609, 0.125, 0.45454545454545
33788, 0.8695652173913, 0.1125, 0.45454545454545
33789, 0.8695652173913, 0.125, 0.47727272727273
33790, 0.82608695652174, 0.125, 0.022727272727273
33791, 0.84782608695652, 0.125, 0.045454545454545
33792, 0.82608695652174, 0.1125, 0.045454545454545
33793, 0.82608695652174, 0.125, 0.068181818181818
33794, 0.84782608695652, 0.125, 0.090909090909091
33795, 0.82608695652174, 0.1125, 0.090909090909091
33796, 0.82608695652174, 0.125, 0.11363636363636
33797, 0.84782608695652, 0.125, 0.13636363636364
33798, 0.82608695652174, 0.1125, 0.13636363636364
33799, 0.82608695652174, 0.125, 0.15909090909091
33800, 0.84782608695652, 0.125, 0.18181818181818
33801, 0.82608695652174, 0.1125, 0.18181818181818
33802, 0.82608695652174, 0.125, 0.20454545454545
33803, 0.84782608695652, 0.125, 0.22727272727273
33804, 0.82608695652174, 0.1125, 0.22727272727273
33805, 0.82608695652174, 0.125, 0.25
33806, 0.84782608695652, 0.125, 0.27272727272727
33807, 0.82608695652174, 0.1125, 0.27272727272727
33808, 0.82608695652174, 0.125, 0.29545454545455
33809, 0.84782608695652, 0.125, 0.31818181818182
33810, 0.82608695652174, 0.1125, 0.31818181818182
33811, 0.82608695652174, 0.125, 0.34090909090909
33812, 0.84782608695652, 0.125, 0.36363636363636
33813, 0.82608695652174, 0.1125, 0.36363636363636
33814, 0.82608695652174, 0.125, 0.38636363636364
33815, 0.84782608695652, 0.125, 0.40909090909091
33816, 0.82608695652174, 0.1125, 0.40909090909091
33817, 0.82608695652174, 0.125, 0.43181818181818
33818, 0.84782608695652, 0.125, 0.45454545454545
33819, 0.82608695652174, 0.1125, 0.45454545454545
33820, 0.82608695652174, 0.125, 0.47727272727273
33821, 0.78260869565217, 0.125, 0.022727272727273
33822, 0.80434782608696, 0.125, 0.045454545454545
33823, 0.78260869565217, 0.1125, 0.045454545454545
33824, 0.78260869565217, 0.125, 0.068181818181818
33825, 0.80434782608696, 0.125, 0.090909090909091
33826, 0.78260869565217, 0.1125, 0.090909090909091
33827, 0.78260869565217, 0.125, 0.11363636363636
33828, 0.80434782608696, 0.125, 0.13636363636364
33829, 0.78260869565217, 0.1125, 0.13636363636364
33830, 0.78260869565217, 0.125, 0.15909090909091
33831, 0.80434782608696, 0.125, 0.18181818181818
33832, 0.78260869565217, 0.1125, 0.18181818181818
33833, 0.78260869565217, 0.125, 0.20454545454545
33834, 0.80434782608696, 0.125, 0.22727272727273
33835, 0.78260869565217, 0.1125, 0.22727272727273
33836, 0.78260869565217, 0.125, 0.25
33837, 0.80434782608696, 0.125, 0.27272727272727
33838, 0.78260869565217, 0.1125, 0.27272727272727
33839, 0.78260869565217, 0.125, 0.29545454545455
33840, 0.80434782608696, 0.125, 0.31818181818182
33841, 0.78260869565217, 0.1125, 0.31818181818182
33842, 0.78260869565217, 0.125, 0.34090909090909
33843, 0.80434782608696, 0.125, 0.36363636363636
33844, 0.78260869565217, 0.1125, 0.36363636363636
33845, 0.78260869565217, 0.125, 0.38636363636364
33846, 0.80434782608696, 0.125, 0.40909090909091
33847, 0.78260869565217, 0.1125, 0.40909090909091
33848, 0.78260869565217, 0.125, 0.43181818181818
33849, 0.80434782608696, 0.125, 0.45454545454545
33850, 0.78260869565217, 0.1125, 0.45454545454545
33851, 0.78260869565217, 0.125, 0.47727272727273
33852, 0.73913043478261, 0.125, 0.022727272727273
33853, 0.76086956521739, 0.125, 0.045454545454545
33854, 0.73913043478261, 0.1125, 0.045454545454545
33855, 0.73913043478261, 0.125, 0.068181818181818
33856, 0.76086956521739, 0.125, 0.090909090909091
33857, 0.73913043478261, 0.1125, 0.090909090909091
33858, 0.73913043478261, 0.125, 0.11363636363636
33859, 0.76086956521739, 0.125, 0.13636363636364
33860, 0.73913043478261, 0.1125, 0.13636363636364
33861, 0.73913043478261, 0.125, 0.15909090909091
33862, 0.76086956521739, 0.125, 0.18181818181818
33863, 0.73913043478261, 0.1125, 0.18181818181818
33864, 0.73913043478261, 0.125, 0.20454545454545
33865, 0.76086956521739, 0.125, 0.22727272727273
33866, 0.73913043478261, 0.1125, 0.22727272727273
33867, 0.73913043478261, 0.125, 0.25
33868, 0.76086956521739, 0.125, 0.27272727272727
33869, 0.73913043478261, 0.1125, 0.27272727272727
33870, 0.73913043478261, 0.125, 0.29545454545455
33871, 0.76086956521739, 0.125, 0.31818181818182
33872, 0.73913043478261, 0.1125, 0.31818181818182
33873, 0.73913043478261, 0.125, 0.34090909090909
33874, 0.76086956521739, 0.125, 0.36363636363636
33875, 0.73913043478261, 0.1125, 0.36363636363636
33876, 0.73913043478261, 0.125, 0.38636363636364
33877, 0.76086956521739, 0.125, 0.40909090909091
33878, 0.73913043478261, 0.1125, 0.40909090909091
33879, 0.73913043478261, 0.125, 0.43181818181818
33880, 0.76086956521739, 0.125, 0.45454545454545
33881, 0.73913043478261, 0.1125, 0.45454545454545
33882, 0.73913043478261, 0.125, 0.47727272727273
33883, 0.69565217391304, 0.125, 0.022727272727273
33884, 0.71739130434783, 0.125, 0.045454545454545
33885, 0.69565217391304, 0.1125, 0.045454545454545
33886, 0.69565217391304, 0.125, 0.068181818181818
33887, 0.71739130434783, 0.125, 0.090909090909091
33888, 0.69565217391304, 0.1125, 0.090909090909091
33889, 0.69565217391304, 0.125, 0.11363636363636
33890, 0.71739130434783, 0.125, 0.13636363636364
33891, 0.69565217391304, 0.1125, 0.13636363636364
33892, 0.69565217391304, 0.125, 0.15909090909091
33893, 0.71739130434783, 0.125, 0.18181818181818
33894, 0.69565217391304, 0.1125, 0.18181818181818
33895, 0.69565217391304, 0.125, 0.20454545454545
33896, 0.71739130434783, 0.125, 0.22727272727273
33897, 0.69565217391304, 0.1125, 0.22727272727273
33898, 0.69565217391304, 0.125, 0.25
33899, 0.71739130434783, 0.125, 0.27272727272727
33900, 0.69565217391304, 0.1125, 0.27272727272727
33901, 0.69565217391304, 0.125, 0.29545454545455
33902, 0.71739130434783, 0.125, 0.31818181818182
33903, 0.69565217391304, 0.1125, 0.31818181818182
33904, 0.69565217391304, 0.125, 0.34090909090909
33905, 0.71739130434783, 0.125, 0.36363636363636
33906, 0.69565217391304, 0.1125, 0.36363636363636
33907, 0.69565217391304, 0.125, 0.38636363636364
33908, 0.71739130434783, 0.125, 0.40909090909091
33909, 0.69565217391304, 0.1125, 0.40909090909091
33910, 0.69565217391304, 0.125, 0.43181818181818
33911, 0.71739130434783, 0.125, 0.45454545454545
33912, 0.69565217391304, 0.1125, 0.45454545454545
33913, 0.69565217391304, 0.125, 0.47727272727273
33914, 0.65217391304348, 0.125, 0.022727272727273
33915, 0.67391304347826, 0.125, 0.045454545454545
33916, 0.65217391304348, 0.1125, 0.045454545454545
33917, 0.65217391304348, 0.125, 0.068181818181818
33918, 0.67391304347826, 0.125, 0.090909090909091
33919, 0.65217391304348, 0.1125, 0.090909090909091
33920, 0.65217391304348, 0.125, 0.11363636363636
33921, 0.67391304347826, 0.125, 0.13636363636364
33922, 0.65217391304348, 0.1125, 0.13636363636364
33923, 0.65217391304348, 0.125, 0.15909090909091
33924, 0.67391304347826, 0.125, 0.18181818181818
33925, 0.65217391304348, 0.1125, 0.18181818181818
33926, 0.65217391304348, 0.125, 0.20454545454545
33927, 0.67391304347826, 0.125, 0.22727272727273
33928, 0.65217391304348, 0.1125, 0.22727272727273
33929, 0.65217391304348, 0.125, 0.25
33930, 0.67391304347826, 0.125, 0.27272727272727
33931, 0.65217391304348, 0.1125, 0.27272727272727
33932, 0.65217391304348, 0.125, 0.29545454545455
33933, 0.67391304347826, 0.125, 0.31818181818182
33934, 0.65217391304348, 0.1125, 0.31818181818182
33935, 0.65217391304348, 0.125, 0.34090909090909
33936, 0.67391304347826, 0.125, 0.36363636363636
33937, 0.65217391304348, 0.1125, 0.36363636363636
33938, 0.65217391304348, 0.125, 0.38636363636364
33939, 0.67391304347826, 0.125, 0.40909090909091
33940, 0.65217391304348, 0.1125, 0.40909090909091
33941, 0.65217391304348, 0.125, 0.43181818181818
33942, 0.67391304347826, 0.125, 0.45454545454545
33943, 0.65217391304348, 0.1125, 0.45454545454545
33944, 0.65217391304348, 0.125, 0.47727272727273
33945, 0.60869565217391, 0.125, 0.022727272727273
33946, 0.6304347826087, 0.125, 0.045454545454545
33947, 0.60869565217391, 0.1125, 0.045454545454545
33948, 0.60869565217391, 0.125, 0.068181818181818
33949, 0.6304347826087, 0.125, 0.090909090909091
33950, 0.60869565217391, 0.1125, 0.090909090909091
33951, 0.60869565217391, 0.125, 0.11363636363636
33952, 0.6304347826087, 0.125, 0.13636363636364
33953, 0.60869565217391, 0.1125, 0.13636363636364
33954, 0.60869565217391, 0.125, 0.15909090909091
33955, 0.6304347826087, 0.125, 0.18181818181818
33956, 0.60869565217391, 0.1125, 0.18181818181818
33957, 0.60869565217391, 0.125, 0.20454545454545
33958, 0.6304347826087, 0.125, 0.22727272727273
33959, 0.60869565217391, 0.1125, 0.22727272727273
33960, 0.60869565217391, 0.125, 0.25
33961, 0.6304347826087, 0.125, 0.27272727272727
33962, 0.60869565217391, 0.1125, 0.27272727272727
33963, 0.60869565217391, 0.125, 0.29545454545455
33964, 0.6304347826087, 0.125, 0.31818181818182
33965, 0.60869565217391, 0.1125, 0.31818181818182
33966, 0.60869565217391, 0.125, 0.34090909090909
33967, 0.6304347826087, 0.125, 0.36363636363636
33968, 0.60869565217391, 0.1125, 0.36363636363636
33969, 0.60869565217391, 0.125, 0.38636363636364
33970, 0.6304347826087, 0.125, 0.40909090909091
33971, 0.60869565217391, 0.1125, 0.40909090909091
33972, 0.60869565217391, 0.125, 0.43181818181818
33973, 0.6304347826087, 0.125, 0.45454545454545
33974, 0.60869565217391, 0.1125, 0.45454545454545
33975, 0.60869565217391, 0.125, 0.47727272727273
33976, 0.56521739130435, 0.125, 0.022727272727273
33977, 0.58695652173913, 0.125, 0.045454545454545
33978, 0.56521739130435, 0.1125, 0.045454545454545
33979, 0.56521739130435, 0.125, 0.068181818181818
33980, 0.58695652173913, 0.125, 0.090909090909091
33981, 0.56521739130435, 0.1125, 0.090909090909091
33982, 0.56521739130435, 0.125, 0.11363636363636
33983, 0.58695652173913, 0.125, 0.13636363636364
33984, 0.56521739130435, 0.1125, 0.13636363636364
33985, 0.56521739130435, 0.125, 0.15909090909091
33986, 0.58695652173913, 0.125, 0.18181818181818
33987, 0.56521739130435, 0.1125, 0.18181818181818
33988, 0.56521739130435, 0.125, 0.20454545454545
33989, 0.58695652173913, 0.125, 0.22727272727273
33990, 0.56521739130435, 0.1125, 0.22727272727273
33991, 0.56521739130435, 0.125, 0.25
33992, 0.58695652173913, 0.125, 0.27272727272727
33993, 0.56521739130435, 0.1125, 0.27272727272727
33994, 0.56521739130435, 0.125, 0.29545454545455
33995, 0.58695652173913, 0.125, 0.31818181818182
33996, 0.56521739130435, 0.1125, 0.31818181818182
33997, 0.56521739130435, 0.125, 0.34090909090909
33998, 0.58695652173913, 0.125, 0.36363636363636
33999, 0.56521739130435, 0.1125, 0.36363636363636
34000, 0.56521739130435, 0.125, 0.38636363636364
34001, 0.58695652173913, 0.125, 0.40909090909091
34002, 0.56521739130435, 0.1125, 0.40909090909091
34003, 0.56521739130435, 0.125, 0.43181818181818
34004, 0.58695652173913, 0.125, 0.45454545454545
34005, 0.56521739130435, 0.1125, 0.45454545454545
34006, 0.56521739130435, 0.125, 0.47727272727273
34007, 0.52173913043478, 0.125, 0.022727272727273
34008, 0.54347826086956, 0.125, 0.045454545454545
34009, 0.52173913043478, 0.1125, 0.045454545454545
34010, 0.52173913043478, 0.125, 0.068181818181818
34011, 0.54347826086956, 0.125, 0.090909090909091
34012, 0.52173913043478, 0.1125, 0.090909090909091
34013, 0.52173913043478, 0.125, 0.11363636363636
34014, 0.54347826086957, 0.125, 0.13636363636364
34015, 0.52173913043478, 0.1125, 0.13636363636364
34016, 0.52173913043478, 0.125, 0.15909090909091
34017, 0.54347826086956, 0.125, 0.18181818181818
34018, 0.52173913043478, 0.1125, 0.18181818181818
34019, 0.52173913043478, 0.125, 0.20454545454545
34020, 0.54347826086956, 0.125, 0.22727272727273
34021, 0.52173913043478, 0.1125, 0.22727272727273
34022, 0.52173913043478, 0.125, 0.25
34023, 0.54347826086956, 0.125, 0.27272727272727
34024, 0.52173913043478, 0.1125, 0.27272727272727
34025, 0.52173913043478, 0.125, 0.29545454545455
34026, 0.54347826086956, 0.125, 0.31818181818182
34027, 0.52173913043478, 0.1125, 0.31818181818182
34028, 0.52173913043478, 0.125, 0.34090909090909
34029, 0.54347826086957, 0.125, 0.36363636363636
34030, 0.52173913043478, 0.1125, 0.36363636363636
34031, 0.52173913043478, 0.125, 0.38636363636364
34032, 0.54347826086956, 0.125, 0.40909090909091
34033, 0.52173913043478, 0.1125, 0.40909090909091
34034, 0.52173913043478, 0.125, 0.43181818181818
34035, 0.54347826086956, 0.125, 0.45454545454545
34036, 0.52173913043478, 0.1125, 0.45454545454545
34037, 0.52173913043478, 0.125, 0.47727272727273
34038, 0.47826086956522, 0.125, 0.022727272727273
34039, 0.5, 0.125, 0.045454545454545
34040, 0.47826086956522, 0.1125, 0.045454545454545
34041, 0.47826086956522, 0.125, 0.068181818181818
34042, 0.5, 0.125, 0.090909090909091
34043, 0.47826086956522, 0.1125, 0.090909090909091
34044, 0.47826086956522, 0.125, 0.11363636363636
34045, 0.5, 0.125, 0.13636363636364
34046, 0.47826086956522, 0.1125, 0.13636363636364
34047, 0.47826086956522, 0.125, 0.15909090909091
34048, 0.5, 0.125, 0.18181818181818
34049, 0.47826086956522, 0.1125, 0.18181818181818
34050, 0.47826086956522, 0.125, 0.20454545454545
34051, 0.5, 0.125, 0.22727272727273
34052, 0.47826086956522, 0.1125, 0.22727272727273
34053, 0.47826086956522, 0.125, 0.25
34054, 0.5, 0.125, 0.27272727272727
34055, 0.47826086956522, 0.1125, 0.27272727272727
34056, 0.47826086956522, 0.125, 0.29545454545455
34057, 0.5, 0.125, 0.31818181818182
34058, 0.47826086956522, 0.1125, 0.31818181818182
34059, 0.47826086956522, 0.125, 0.34090909090909
34060, 0.5, 0.125, 0.36363636363636
34061, 0.47826086956522, 0.1125, 0.36363636363636
34062, 0.47826086956522, 0.125, 0.38636363636364
34063, 0.5, 0.125, 0.40909090909091
34064, 0.47826086956522, 0.1125, 0.40909090909091
34065, 0.47826086956522, 0.125, 0.43181818181818
34066, 0.5, 0.125, 0.45454545454545
34067, 0.47826086956522, 0.1125, 0.45454545454545
34068, 0.47826086956522, 0.125, 0.47727272727273
34069, 0.43478260869565, 0.125, 0.022727272727273
34070, 0.45652173913043, 0.125, 0.045454545454545
34071, 0.43478260869565, 0.1125, 0.045454545454545
34072, 0.43478260869565, 0.125, 0.068181818181818
34073, 0.45652173913043, 0.125, 0.090909090909091
34074, 0.43478260869565, 0.1125, 0.090909090909091
34075, 0.43478260869565, 0.125, 0.11363636363636
34076, 0.45652173913043, 0.125, 0.13636363636364
34077, 0.43478260869565, 0.1125, 0.13636363636364
34078, 0.43478260869565, 0.125, 0.15909090909091
34079, 0.45652173913043, 0.125, 0.18181818181818
34080, 0.43478260869565, 0.1125, 0.18181818181818
34081, 0.43478260869565, 0.125, 0.20454545454545
34082, 0.45652173913043, 0.125, 0.22727272727273
34083, 0.43478260869565, 0.1125, 0.22727272727273
34084, 0.43478260869565, 0.125, 0.25
34085, 0.45652173913043, 0.125, 0.27272727272727
34086, 0.43478260869565, 0.1125, 0.27272727272727
34087, 0.43478260869565, 0.125, 0.29545454545455
34088, 0.45652173913043, 0.125, 0.31818181818182
34089, 0.43478260869565, 0.1125, 0.31818181818182
34090, 0.43478260869565, 0.125, 0.34090909090909
34091, 0.45652173913043, 0.125, 0.36363636363636
34092, 0.43478260869565, 0.1125, 0.36363636363636
34093, 0.43478260869565, 0.125, 0.38636363636364
34094, 0.45652173913043, 0.125, 0.40909090909091
34095, 0.43478260869565, 0.1125, 0.40909090909091
34096, 0.43478260869565, 0.125, 0.43181818181818
34097, 0.45652173913043, 0.125, 0.45454545454545
34098, 0.43478260869565, 0.1125, 0.45454545454545
34099, 0.43478260869565, 0.125, 0.47727272727273
34100, 0.39130434782609, 0.125, 0.022727272727273
34101, 0.41304347826087, 0.125, 0.045454545454545
34102, 0.39130434782609, 0.1125, 0.045454545454545
34103, 0.39130434782609, 0.125, 0.068181818181818
34104, 0.41304347826087, 0.125, 0.090909090909091
34105, 0.39130434782609, 0.1125, 0.090909090909091
34106, 0.39130434782609, 0.125, 0.11363636363636
34107, 0.41304347826087, 0.125, 0.13636363636364
34108, 0.39130434782609, 0.1125, 0.13636363636364
34109, 0.39130434782609, 0.125, 0.15909090909091
34110, 0.41304347826087, 0.125, 0.18181818181818
34111, 0.39130434782609, 0.1125, 0.18181818181818
34112, 0.39130434782609, 0.125, 0.20454545454545
34113, 0.41304347826087, 0.125, 0.22727272727273
34114, 0.39130434782609, 0.1125, 0.22727272727273
34115, 0.39130434782609, 0.125, 0.25
34116, 0.41304347826087, 0.125, 0.27272727272727
34117, 0.39130434782609, 0.1125, 0.27272727272727
34118, 0.39130434782609, 0.125, 0.29545454545455
34119, 0.41304347826087, 0.125, 0.31818181818182
34120, 0.39130434782609, 0.1125, 0.31818181818182
34121, 0.39130434782609, 0.125, 0.34090909090909
34122, 0.41304347826087, 0.125, 0.36363636363636
34123, 0.39130434782609, 0.1125, 0.36363636363636
34124, 0.39130434782609, 0.125, 0.38636363636364
34125, 0.41304347826087, 0.125, 0.40909090909091
34126, 0.39130434782609, 0.1125, 0.40909090909091
34127, 0.39130434782609, 0.125, 0.43181818181818
34128, 0.41304347826087, 0.125, 0.45454545454545
34129, 0.39130434782609, 0.1125, 0.45454545454545
34130, 0.39130434782609, 0.125, 0.47727272727273
34131, 0.34782608695652, 0.125, 0.022727272727273
34132, 0.3695652173913, 0.125, 0.045454545454545
34133, 0.34782608695652, 0.1125, 0.045454545454545
34134, 0.34782608695652, 0.125, 0.068181818181818
34135, 0.3695652173913, 0.125, 0.090909090909091
34136, 0.34782608695652, 0.1125, 0.090909090909091
34137, 0.34782608695652, 0.125, 0.11363636363636
34138, 0.3695652173913, 0.125, 0.13636363636364
34139, 0.34782608695652, 0.1125, 0.13636363636364
34140, 0.34782608695652, 0.125, 0.15909090909091
34141, 0.3695652173913, 0.125, 0.18181818181818
34142, 0.34782608695652, 0.1125, 0.18181818181818
34143, 0.34782608695652, 0.125, 0.20454545454545
34144, 0.3695652173913, 0.125, 0.22727272727273
34145, 0.34782608695652, 0.1125, 0.22727272727273
34146, 0.34782608695652, 0.125, 0.25
34147, 0.3695652173913, 0.125, 0.27272727272727
34148, 0.34782608695652, 0.1125, 0.27272727272727
34149, 0.34782608695652, 0.125, 0.29545454545455
34150, 0.3695652173913, 0.125, 0.31818181818182
34151, 0.34782608695652, 0.1125, 0.31818181818182
34152, 0.34782608695652, 0.125, 0.34090909090909
34153, 0.3695652173913, 0.125, 0.36363636363636
34154, 0.34782608695652, 0.1125, 0.36363636363636
34155, 0.34782608695652, 0.125, 0.38636363636364
34156, 0.3695652173913, 0.125, 0.40909090909091
34157, 0.34782608695652, 0.1125, 0.40909090909091
34158, 0.34782608695652, 0.125, 0.43181818181818
34159, 0.3695652173913, 0.125, 0.45454545454545
34160, 0.34782608695652, 0.1125, 0.45454545454545
34161, 0.34782608695652, 0.125, 0.47727272727273
34162, 0.30434782608696, 0.125, 0.022727272727273
34163, 0.32608695652174, 0.125, 0.045454545454545
34164, 0.30434782608696, 0.1125, 0.045454545454545
34165, 0.30434782608696, 0.125, 0.068181818181818
34166, 0.32608695652174, 0.125, 0.090909090909091
34167, 0.30434782608696, 0.1125, 0.090909090909091
34168, 0.30434782608696, 0.125, 0.11363636363636
34169, 0.32608695652174, 0.125, 0.13636363636364
34170, 0.30434782608696, 0.1125, 0.13636363636364
34171, 0.30434782608696, 0.125, 0.15909090909091
34172, 0.32608695652174, 0.125, 0.18181818181818
34173, 0.30434782608696, 0.1125, 0.18181818181818
34174, 0.30434782608696, 0.125, 0.20454545454545
34175, 0.32608695652174, 0.125, 0.22727272727273
34176, 0.30434782608696, 0.1125, 0.22727272727273
34177, 0.30434782608696, 0.125, 0.25
34178, 0.32608695652174, 0.125, 0.27272727272727
34179, 0.30434782608696, 0.1125, 0.27272727272727
34180, 0.30434782608696, 0.125, 0.29545454545455
34181, 0.32608695652174, 0.125, 0.31818181818182
34182, 0.30434782608696, 0.1125, 0.31818181818182
34183, 0.30434782608696, 0.125, 0.34090909090909
34184, 0.32608695652174, 0.125, 0.36363636363636
34185, 0.30434782608696, 0.1125, 0.36363636363636
34186, 0.30434782608696, 0.125, 0.38636363636364
34187, 0.32608695652174, 0.125, 0.40909090909091
34188, 0.30434782608696, 0.1125, 0.40909090909091
34189, 0.30434782608696, 0.125, 0.43181818181818
34190, 0.32608695652174, 0.125, 0.45454545454545
34191, 0.30434782608696, 0.1125, 0.45454545454545
34192, 0.30434782608696, 0.125, 0.47727272727273
34193, 0.26086956521739, 0.125, 0.022727272727273
34194, 0.28260869565217, 0.125, 0.045454545454545
34195, 0.26086956521739, 0.1125, 0.045454545454545
34196, 0.26086956521739, 0.125, 0.068181818181818
34197, 0.28260869565217, 0.125, 0.090909090909091
34198, 0.26086956521739, 0.1125, 0.090909090909091
34199, 0.26086956521739, 0.125, 0.11363636363636
34200, 0.28260869565217, 0.125, 0.13636363636364
34201, 0.26086956521739, 0.1125, 0.13636363636364
34202, 0.26086956521739, 0.125, 0.15909090909091
34203, 0.28260869565217, 0.125, 0.18181818181818
34204, 0.26086956521739, 0.1125, 0.18181818181818
34205, 0.26086956521739, 0.125, 0.20454545454545
34206, 0.28260869565217, 0.125, 0.22727272727273
34207, 0.26086956521739, 0.1125, 0.22727272727273
34208, 0.26086956521739, 0.125, 0.25
34209, 0.28260869565217, 0.125, 0.27272727272727
34210, 0.26086956521739, 0.1125, 0.27272727272727
34211, 0.26086956521739, 0.125, 0.29545454545455
34212, 0.28260869565217, 0.125, 0.31818181818182
34213, 0.26086956521739, 0.1125, 0.31818181818182
34214, 0.26086956521739, 0.125, 0.34090909090909
34215, 0.28260869565217, 0.125, 0.36363636363636
34216, 0.26086956521739, 0.1125, 0.36363636363636
34217, 0.26086956521739, 0.125, 0.38636363636364
34218, 0.28260869565217, 0.125, 0.40909090909091
34219, 0.26086956521739, 0.1125, 0.40909090909091
34220, 0.26086956521739, 0.125, 0.43181818181818
34221, 0.28260869565217, 0.125, 0.45454545454545
34222, 0.26086956521739, 0.1125, 0.45454545454545
34223, 0.26086956521739, 0.125, 0.47727272727273
34224, 0.21739130434783, 0.125, 0.022727272727273
34225, 0.23913043478261, 0.125, 0.045454545454545
34226, 0.21739130434783, 0.1125, 0.045454545454545
34227, 0.21739130434783, 0.125, 0.068181818181818
34228, 0.23913043478261, 0.125, 0.090909090909091
34229, 0.21739130434783, 0.1125, 0.090909090909091
34230, 0.21739130434783, 0.125, 0.11363636363636
34231, 0.23913043478261, 0.125, 0.13636363636364
34232, 0.21739130434783, 0.1125, 0.13636363636364
34233, 0.21739130434783, 0.125, 0.15909090909091
34234, 0.23913043478261, 0.125, 0.18181818181818
34235, 0.21739130434783, 0.1125, 0.18181818181818
34236, 0.21739130434783, 0.125, 0.20454545454545
34237, 0.23913043478261, 0.125, 0.22727272727273
34238, 0.21739130434783, 0.1125, 0.22727272727273
34239, 0.21739130434783, 0.125, 0.25
34240, 0.23913043478261, 0.125, 0.27272727272727
34241, 0.21739130434783, 0.1125, 0.27272727272727
34242, 0.21739130434783, 0.125, 0.29545454545455
34243, 0.23913043478261, 0.125, 0.31818181818182
34244, 0.21739130434783, 0.1125, 0.31818181818182
34245, 0.21739130434783, 0.125, 0.34090909090909
34246, 0.23913043478261, 0.125, 0.36363636363636
34247, 0.21739130434783, 0.1125, 0.36363636363636
34248, 0.21739130434783, 0.125, 0.38636363636364
34249, 0.23913043478261, 0.125, 0.40909090909091
34250, 0.21739130434783, 0.1125, 0.40909090909091
34251, 0.21739130434783, 0.125, 0.43181818181818
34252, 0.23913043478261, 0.125, 0.45454545454545
34253, 0.21739130434783, 0.1125, 0.45454545454545
34254, 0.21739130434783, 0.125, 0.47727272727273
34255, 0.17391304347826, 0.125, 0.022727272727273
34256, 0.19565217391304, 0.125, 0.045454545454545
34257, 0.17391304347826, 0.1125, 0.045454545454545
34258, 0.17391304347826, 0.125, 0.068181818181818
34259, 0.19565217391304, 0.125, 0.090909090909091
34260, 0.17391304347826, 0.1125, 0.090909090909091
34261, 0.17391304347826, 0.125, 0.11363636363636
34262, 0.19565217391304, 0.125, 0.13636363636364
34263, 0.17391304347826, 0.1125, 0.13636363636364
34264, 0.17391304347826, 0.125, 0.15909090909091
34265, 0.19565217391304, 0.125, 0.18181818181818
34266, 0.17391304347826, 0.1125, 0.18181818181818
34267, 0.17391304347826, 0.125, 0.20454545454545
34268, 0.19565217391304, 0.125, 0.22727272727273
34269, 0.17391304347826, 0.1125, 0.22727272727273
34270, 0.17391304347826, 0.125, 0.25
34271, 0.19565217391304, 0.125, 0.27272727272727
34272, 0.17391304347826, 0.1125, 0.27272727272727
34273, 0.17391304347826, 0.125, 0.29545454545455
34274, 0.19565217391304, 0.125, 0.31818181818182
34275, 0.17391304347826, 0.1125, 0.31818181818182
34276, 0.17391304347826, 0.125, 0.34090909090909
34277, 0.19565217391304, 0.125, 0.36363636363636
34278, 0.17391304347826, 0.1125, 0.36363636363636
34279, 0.17391304347826, 0.125, 0.38636363636364
34280, 0.19565217391304, 0.125, 0.40909090909091
34281, 0.17391304347826, 0.1125, 0.40909090909091
34282, 0.17391304347826, 0.125, 0.43181818181818
34283, 0.19565217391304, 0.125, 0.45454545454545
34284, 0.17391304347826, 0.1125, 0.45454545454545
34285, 0.17391304347826, 0.125, 0.47727272727273
34286, 0.1304347826087, 0.125, 0.022727272727273
34287, 0.15217391304348, 0.125, 0.045454545454545
34288, 0.1304347826087, 0.1125, 0.045454545454545
34289, 0.1304347826087, 0.125, 0.068181818181818
34290, 0.15217391304348, 0.125, 0.090909090909091
34291, 0.1304347826087, 0.1125, 0.090909090909091
34292, 0.1304347826087, 0.125, 0.11363636363636
34293, 0.15217391304348, 0.125, 0.13636363636364
34294, 0.1304347826087, 0.1125, 0.13636363636364
34295, 0.1304347826087, 0.125, 0.15909090909091
34296, 0.15217391304348, 0.125, 0.18181818181818
34297, 0.1304347826087, 0.1125, 0.18181818181818
34298, 0.1304347826087, 0.125, 0.20454545454545
34299, 0.15217391304348, 0.125, 0.22727272727273
34300, 0.1304347826087, 0.1125, 0.22727272727273
34301, 0.1304347826087, 0.125, 0.25
34302, 0.15217391304348, 0.125, 0.27272727272727
34303, 0.1304347826087, 0.1125, 0.27272727272727
34304, 0.1304347826087, 0.125, 0.29545454545455
34305, 0.15217391304348, 0.125, 0.31818181818182
34306, 0.1304347826087, 0.1125, 0.31818181818182
34307, 0.1304347826087, 0.125, 0.34090909090909
34308, 0.15217391304348, 0.125, 0.36363636363636
34309, 0.1304347826087, 0.1125, 0.36363636363636
34310, 0.1304347826087, 0.125, 0.38636363636364
34311, 0.15217391304348, 0.125, 0.40909090909091
34312, 0.1304347826087, 0.1125, 0.40909090909091
34313, 0.1304347826087, 0.125, 0.43181818181818
34314, 0.15217391304348, 0.125, 0.45454545454545
34315, 0.1304347826087, 0.1125, 0.45454545454545
34316, 0.1304347826087, 0.125, 0.47727272727273
34317, 0.08695652173913, 0.125, 0.022727272727273
34318, 0.10869565217391, 0.125, 0.045454545454545
34319, 0.08695652173913, 0.1125, 0.045454545454545
34320, 0.08695652173913, 0.125, 0.068181818181818
34321, 0.10869565217391, 0.125, 0.090909090909091
34322, 0.08695652173913, 0.1125, 0.090909090909091
34323, 0.08695652173913, 0.125, 0.11363636363636
34324, 0.10869565217391, 0.125, 0.13636363636364
34325, 0.08695652173913, 0.1125, 0.13636363636364
34326, 0.08695652173913, 0.125, 0.15909090909091
34327, 0.10869565217391, 0.125, 0.18181818181818
34328, 0.08695652173913, 0.1125, 0.18181818181818
34329, 0.08695652173913, 0.125, 0.20454545454545
34330, 0.10869565217391, 0.125, 0.22727272727273
34331, 0.08695652173913, 0.1125, 0.22727272727273
34332, 0.08695652173913, 0.125, 0.25
34333, 0.10869565217391, 0.125, 0.27272727272727
34334, 0.08695652173913, 0.1125, 0.27272727272727
34335, 0.08695652173913, 0.125, 0.29545454545455
34336, 0.10869565217391, 0.125, 0.31818181818182
34337, 0.08695652173913, 0.1125, 0.31818181818182
34338, 0.08695652173913, 0.125, 0.34090909090909
34339, 0.10869565217391, 0.125, 0.36363636363636
34340, 0.08695652173913, 0.1125, 0.36363636363636
34341, 0.08695652173913, 0.125, 0.38636363636364
34342, 0.10869565217391, 0.125, 0.40909090909091
34343, 0.08695652173913, 0.1125, 0.40909090909091
34344, 0.08695652173913, 0.125, 0.43181818181818
34345, 0.10869565217391, 0.125, 0.45454545454545
34346, 0.08695652173913, 0.1125, 0.45454545454545
34347, 0.08695652173913, 0.125, 0.47727272727273
34348, 0.043478260869565, 0.125, 0.022727272727273
34349, 0.065217391304348, 0.125, 0.045454545454545
34350, 0.043478260869565, 0.1125, 0.045454545454545
34351, 0.043478260869565, 0.125, 0.068181818181818
34352, 0.065217391304348, 0.125, 0.090909090909091
34353, 0.043478260869565, 0.1125, 0.090909090909091
34354, 0.043478260869565, 0.125, 0.11363636363636
34355, 0.065217391304348, 0.125, 0.13636363636364
34356, 0.043478260869565, 0.1125, 0.13636363636364
34357, 0.043478260869565, 0.125, 0.15909090909091
34358, 0.065217391304348, 0.125, 0.18181818181818
34359, 0.043478260869565, 0.1125, 0.18181818181818
34360, 0.043478260869565, 0.125, 0.20454545454545
34361, 0.065217391304348, 0.125, 0.22727272727273
34362, 0.043478260869565, 0.1125, 0.22727272727273
34363, 0.043478260869565, 0.125, 0.25
34364, 0.065217391304348, 0.125, 0.27272727272727
34365, 0.043478260869565, 0.1125, 0.27272727272727
34366, 0.043478260869565, 0.125, 0.29545454545455
34367, 0.065217391304348, 0.125, 0.31818181818182
34368, 0.043478260869565, 0.1125, 0.31818181818182
34369, 0.043478260869565, 0.125, 0.34090909090909
34370, 0.065217391304348, 0.125, 0.36363636363636
34371, 0.043478260869565, 0.1125, 0.36363636363636
34372, 0.043478260869565, 0.125, 0.38636363636364
34373, 0.065217391304348, 0.125, 0.40909090909091
34374, 0.043478260869565, 0.1125, 0.40909090909091
34375, 0.043478260869565, 0.125, 0.43181818181818
34376, 0.065217391304348, 0.125, 0.45454545454545
34377, 0.043478260869565, 0.1125, 0.45454545454545
34378, 0.043478260869565, 0.125, 0.47727272727273
34379, 0.021739130434783, 0.125, 0.045454545454545
34380, 0.021739130434783, 0.125, 0.090909090909091
34381, 0.021739130434783, 0.125, 0.13636363636364
34382, 0.021739130434783, 0.125, 0.18181818181818
34383, 0.021739130434783, 0.125, 0.22727272727273
34384, 0.021739130434783, 0.125, 0.27272727272727
34385, 0.021739130434783, 0.125, 0.31818181818182
34386, 0.021739130434783, 0.125, 0.36363636363636
34387, 0.021739130434783, 0.125, 0.40909090909091
34388, 0.021739130434783, 0.125, 0.45454545454545
34389, 0.95652173913043, 0.1375, 0.045454545454545
34390, 0.95652173913043, 0.1375, 0.090909090909091
34391, 0.95652173913044, 0.1375, 0.13636363636364
34392, 0.95652173913043, 0.1375, 0.18181818181818
34393, 0.95652173913043, 0.1375, 0.22727272727273
34394, 0.95652173913043, 0.1375, 0.27272727272727
34395, 0.95652173913043, 0.1375, 0.31818181818182
34396, 0.95652173913043, 0.1375, 0.36363636363636
34397, 0.95652173913043, 0.1375, 0.40909090909091
34398, 0.95652173913043, 0.1375, 0.45454545454545
34399, 0.91304347826087, 0.1375, 0.045454545454545
34400, 0.91304347826087, 0.1375, 0.090909090909091
34401, 0.91304347826087, 0.1375, 0.13636363636364
34402, 0.91304347826087, 0.1375, 0.18181818181818
34403, 0.91304347826087, 0.1375, 0.22727272727273
34404, 0.91304347826087, 0.1375, 0.27272727272727
34405, 0.91304347826087, 0.1375, 0.31818181818182
34406, 0.91304347826087, 0.1375, 0.36363636363636
34407, 0.91304347826087, 0.1375, 0.40909090909091
34408, 0.91304347826087, 0.1375, 0.45454545454545
34409, 0.8695652173913, 0.1375, 0.045454545454545
34410, 0.8695652173913, 0.1375, 0.090909090909091
34411, 0.8695652173913, 0.1375, 0.13636363636364
34412, 0.8695652173913, 0.1375, 0.18181818181818
34413, 0.8695652173913, 0.1375, 0.22727272727273
34414, 0.8695652173913, 0.1375, 0.27272727272727
34415, 0.8695652173913, 0.1375, 0.31818181818182
34416, 0.8695652173913, 0.1375, 0.36363636363636
34417, 0.8695652173913, 0.1375, 0.40909090909091
34418, 0.8695652173913, 0.1375, 0.45454545454545
34419, 0.82608695652174, 0.1375, 0.045454545454545
34420, 0.82608695652174, 0.1375, 0.090909090909091
34421, 0.82608695652174, 0.1375, 0.13636363636364
34422, 0.82608695652174, 0.1375, 0.18181818181818
34423, 0.82608695652174, 0.1375, 0.22727272727273
34424, 0.82608695652174, 0.1375, 0.27272727272727
34425, 0.82608695652174, 0.1375, 0.31818181818182
34426, 0.82608695652174, 0.1375, 0.36363636363636
34427, 0.82608695652174, 0.1375, 0.40909090909091
34428, 0.82608695652174, 0.1375, 0.45454545454545
34429, 0.78260869565217, 0.1375, 0.045454545454545
34430, 0.78260869565217, 0.1375, 0.090909090909091
34431, 0.78260869565217, 0.1375, 0.13636363636364
34432, 0.78260869565217, 0.1375, 0.18181818181818
34433, 0.78260869565217, 0.1375, 0.22727272727273
34434, 0.78260869565217, 0.1375, 0.27272727272727
34435, 0.78260869565217, 0.1375, 0.31818181818182
34436, 0.78260869565217, 0.1375, 0.36363636363636
34437, 0.78260869565217, 0.1375, 0.40909090909091
34438, 0.78260869565217, 0.1375, 0.45454545454545
34439, 0.73913043478261, 0.1375, 0.045454545454545
34440, 0.73913043478261, 0.1375, 0.090909090909091
34441, 0.73913043478261, 0.1375, 0.13636363636364
34442, 0.73913043478261, 0.1375, 0.18181818181818
34443, 0.73913043478261, 0.1375, 0.22727272727273
34444, 0.73913043478261, 0.1375, 0.27272727272727
34445, 0.73913043478261, 0.1375, 0.31818181818182
34446, 0.73913043478261, 0.1375, 0.36363636363636
34447, 0.73913043478261, 0.1375, 0.40909090909091
34448, 0.73913043478261, 0.1375, 0.45454545454545
34449, 0.69565217391304, 0.1375, 0.045454545454545
34450, 0.69565217391304, 0.1375, 0.090909090909091
34451, 0.69565217391304, 0.1375, 0.13636363636364
34452, 0.69565217391304, 0.1375, 0.18181818181818
34453, 0.69565217391304, 0.1375, 0.22727272727273
34454, 0.69565217391304, 0.1375, 0.27272727272727
34455, 0.69565217391304, 0.1375, 0.31818181818182
34456, 0.69565217391304, 0.1375, 0.36363636363636
34457, 0.69565217391304, 0.1375, 0.40909090909091
34458, 0.69565217391304, 0.1375, 0.45454545454545
34459, 0.65217391304348, 0.1375, 0.045454545454545
34460, 0.65217391304348, 0.1375, 0.090909090909091
34461, 0.65217391304348, 0.1375, 0.13636363636364
34462, 0.65217391304348, 0.1375, 0.18181818181818
34463, 0.65217391304348, 0.1375, 0.22727272727273
34464, 0.65217391304348, 0.1375, 0.27272727272727
34465, 0.65217391304348, 0.1375, 0.31818181818182
34466, 0.65217391304348, 0.1375, 0.36363636363636
34467, 0.65217391304348, 0.1375, 0.40909090909091
34468, 0.65217391304348, 0.1375, 0.45454545454545
34469, 0.60869565217391, 0.1375, 0.045454545454545
34470, 0.60869565217391, 0.1375, 0.090909090909091
34471, 0.60869565217391, 0.1375, 0.13636363636364
34472, 0.60869565217391, 0.1375, 0.18181818181818
34473, 0.60869565217391, 0.1375, 0.22727272727273
34474, 0.60869565217391, 0.1375, 0.27272727272727
34475, 0.60869565217391, 0.1375, 0.31818181818182
34476, 0.60869565217391, 0.1375, 0.36363636363636
34477, 0.60869565217391, 0.1375, 0.40909090909091
34478, 0.60869565217391, 0.1375, 0.45454545454545
34479, 0.56521739130435, 0.1375, 0.045454545454545
34480, 0.56521739130435, 0.1375, 0.090909090909091
34481, 0.56521739130435, 0.1375, 0.13636363636364
34482, 0.56521739130435, 0.1375, 0.18181818181818
34483, 0.56521739130435, 0.1375, 0.22727272727273
34484, 0.56521739130435, 0.1375, 0.27272727272727
34485, 0.56521739130435, 0.1375, 0.31818181818182
34486, 0.56521739130435, 0.1375, 0.36363636363636
34487, 0.56521739130435, 0.1375, 0.40909090909091
34488, 0.56521739130435, 0.1375, 0.45454545454545
34489, 0.52173913043478, 0.1375, 0.045454545454545
34490, 0.52173913043478, 0.1375, 0.090909090909091
34491, 0.52173913043478, 0.1375, 0.13636363636364
34492, 0.52173913043478, 0.1375, 0.18181818181818
34493, 0.52173913043478, 0.1375, 0.22727272727273
34494, 0.52173913043478, 0.1375, 0.27272727272727
34495, 0.52173913043478, 0.1375, 0.31818181818182
34496, 0.52173913043478, 0.1375, 0.36363636363636
34497, 0.52173913043478, 0.1375, 0.40909090909091
34498, 0.52173913043478, 0.1375, 0.45454545454545
34499, 0.47826086956522, 0.1375, 0.045454545454545
34500, 0.47826086956522, 0.1375, 0.090909090909091
34501, 0.47826086956522, 0.1375, 0.13636363636364
34502, 0.47826086956522, 0.1375, 0.18181818181818
34503, 0.47826086956522, 0.1375, 0.22727272727273
34504, 0.47826086956522, 0.1375, 0.27272727272727
34505, 0.47826086956522, 0.1375, 0.31818181818182
34506, 0.47826086956522, 0.1375, 0.36363636363636
34507, 0.47826086956522, 0.1375, 0.40909090909091
34508, 0.47826086956522, 0.1375, 0.45454545454545
34509, 0.43478260869565, 0.1375, 0.045454545454545
34510, 0.43478260869565, 0.1375, 0.090909090909091
34511, 0.43478260869565, 0.1375, 0.13636363636364
34512, 0.43478260869565, 0.1375, 0.18181818181818
34513, 0.43478260869565, 0.1375, 0.22727272727273
34514, 0.43478260869565, 0.1375, 0.27272727272727
34515, 0.43478260869565, 0.1375, 0.31818181818182
34516, 0.43478260869565, 0.1375, 0.36363636363636
34517, 0.43478260869565, 0.1375, 0.40909090909091
34518, 0.43478260869565, 0.1375, 0.45454545454545
34519, 0.39130434782609, 0.1375, 0.045454545454545
34520, 0.39130434782609, 0.1375, 0.090909090909091
34521, 0.39130434782609, 0.1375, 0.13636363636364
34522, 0.39130434782609, 0.1375, 0.18181818181818
34523, 0.39130434782609, 0.1375, 0.22727272727273
34524, 0.39130434782609, 0.1375, 0.27272727272727
34525, 0.39130434782609, 0.1375, 0.31818181818182
34526, 0.39130434782609, 0.1375, 0.36363636363636
34527, 0.39130434782609, 0.1375, 0.40909090909091
34528, 0.39130434782609, 0.1375, 0.45454545454545
34529, 0.34782608695652, 0.1375, 0.045454545454545
34530, 0.34782608695652, 0.1375, 0.090909090909091
34531, 0.34782608695652, 0.1375, 0.13636363636364
34532, 0.34782608695652, 0.1375, 0.18181818181818
34533, 0.34782608695652, 0.1375, 0.22727272727273
34534, 0.34782608695652, 0.1375, 0.27272727272727
34535, 0.34782608695652, 0.1375, 0.31818181818182
34536, 0.34782608695652, 0.1375, 0.36363636363636
34537, 0.34782608695652, 0.1375, 0.40909090909091
34538, 0.34782608695652, 0.1375, 0.45454545454545
34539, 0.30434782608696, 0.1375, 0.045454545454545
34540, 0.30434782608696, 0.1375, 0.090909090909091
34541, 0.30434782608696, 0.1375, 0.13636363636364
34542, 0.30434782608696, 0.1375, 0.18181818181818
34543, 0.30434782608696, 0.1375, 0.22727272727273
34544, 0.30434782608696, 0.1375, 0.27272727272727
34545, 0.30434782608696, 0.1375, 0.31818181818182
34546, 0.30434782608696, 0.1375, 0.36363636363636
34547, 0.30434782608696, 0.1375, 0.40909090909091
34548, 0.30434782608696, 0.1375, 0.45454545454545
34549, 0.26086956521739, 0.1375, 0.045454545454545
34550, 0.26086956521739, 0.1375, 0.090909090909091
34551, 0.26086956521739, 0.1375, 0.13636363636364
34552, 0.26086956521739, 0.1375, 0.18181818181818
34553, 0.26086956521739, 0.1375, 0.22727272727273
34554, 0.26086956521739, 0.1375, 0.27272727272727
34555, 0.26086956521739, 0.1375, 0.31818181818182
34556, 0.26086956521739, 0.1375, 0.36363636363636
34557, 0.26086956521739, 0.1375, 0.40909090909091
34558, 0.26086956521739, 0.1375, 0.45454545454545
34559, 0.21739130434783, 0.1375, 0.045454545454545
34560, 0.21739130434783, 0.1375, 0.090909090909091
34561, 0.21739130434783, 0.1375, 0.13636363636364
34562, 0.21739130434783, 0.1375, 0.18181818181818
34563, 0.21739130434783, 0.1375, 0.22727272727273
34564, 0.21739130434783, 0.1375, 0.27272727272727
34565, 0.21739130434783, 0.1375, 0.31818181818182
34566, 0.21739130434783, 0.1375, 0.36363636363636
34567, 0.21739130434783, 0.1375, 0.40909090909091
34568, 0.21739130434783, 0.1375, 0.45454545454545
34569, 0.17391304347826, 0.1375, 0.045454545454545
34570, 0.17391304347826, 0.1375, 0.090909090909091
34571, 0.17391304347826, 0.1375, 0.13636363636364
34572, 0.17391304347826, 0.1375, 0.18181818181818
34573, 0.17391304347826, 0.1375, 0.22727272727273
34574, 0.17391304347826, 0.1375, 0.27272727272727
34575, 0.17391304347826, 0.1375, 0.31818181818182
34576, 0.17391304347826, 0.1375, 0.36363636363636
34577, 0.17391304347826, 0.1375, 0.40909090909091
34578, 0.17391304347826, 0.1375, 0.45454545454545
34579, 0.1304347826087, 0.1375, 0.045454545454545
34580, 0.1304347826087, 0.1375, 0.090909090909091
34581, 0.1304347826087, 0.1375, 0.13636363636364
34582, 0.1304347826087, 0.1375, 0.18181818181818
34583, 0.1304347826087, 0.1375, 0.22727272727273
34584, 0.1304347826087, 0.1375, 0.27272727272727
34585, 0.1304347826087, 0.1375, 0.31818181818182
34586, 0.1304347826087, 0.1375, 0.36363636363636
34587, 0.1304347826087, 0.1375, 0.40909090909091
34588, 0.1304347826087, 0.1375, 0.45454545454545
34589, 0.08695652173913, 0.1375, 0.045454545454545
34590, 0.08695652173913, 0.1375, 0.090909090909091
34591, 0.08695652173913, 0.1375, 0.13636363636364
34592, 0.08695652173913, 0.1375, 0.18181818181818
34593, 0.08695652173913, 0.1375, 0.22727272727273
34594, 0.08695652173913, 0.1375, 0.27272727272727
34595, 0.08695652173913, 0.1375, 0.31818181818182
34596, 0.08695652173913, 0.1375, 0.36363636363636
34597, 0.08695652173913, 0.1375, 0.40909090909091
34598, 0.08695652173913, 0.1375, 0.45454545454545
34599, 0.043478260869565, 0.1375, 0.045454545454545
34600, 0.043478260869565, 0.1375, 0.090909090909091
34601, 0.043478260869565, 0.1375, 0.13636363636364
34602, 0.043478260869565, 0.1375, 0.18181818181818
34603, 0.043478260869565, 0.1375, 0.22727272727273
34604, 0.043478260869565, 0.1375, 0.27272727272727
34605, 0.043478260869565, 0.1375, 0.31818181818182
34606, 0.043478260869565, 0.1375, 0.36363636363636
34607, 0.043478260869565, 0.1375, 0.40909090909091
34608, 0.043478260869565, 0.1375, 0.45454545454545
34609, 0.95652173913043, 0.20217391304348, 0.045454545454545
34610, 0.95652173913043, 0.20217391304348, 0.090909090909091
34611, 0.95652173913043, 0.20217391304348, 0.13636363636364
34612, 0.95652173913044, 0.20217391304348, 0.18181818181818
34613, 0.95652173913044, 0.20217391304348, 0.22727272727273
34614, 0.95652173913044, 0.20217391304348, 0.27272727272727
34615, 0.95652173913044, 0.20217391304348, 0.31818181818182
34616, 0.95652173913043, 0.20217391304348, 0.36363636363636
34617, 0.95652173913043, 0.20217391304348, 0.40909090909091
34618, 0.95652173913044, 0.20217391304348, 0.45454545454545
34619, 0.91304347826087, 0.20217391304348, 0.045454545454545
34620, 0.91304347826087, 0.20217391304348, 0.090909090909091
34621, 0.91304347826087, 0.20217391304348, 0.13636363636364
34622, 0.91304347826087, 0.20217391304348, 0.18181818181818
34623, 0.91304347826087, 0.20217391304348, 0.22727272727273
34624, 0.91304347826087, 0.20217391304348, 0.27272727272727
34625, 0.91304347826087, 0.20217391304348, 0.31818181818182
34626, 0.91304347826087, 0.20217391304348, 0.36363636363636
34627, 0.91304347826087, 0.20217391304348, 0.40909090909091
34628, 0.91304347826087, 0.20217391304348, 0.45454545454545
34629, 0.8695652173913, 0.20217391304348, 0.045454545454545
34630, 0.8695652173913, 0.20217391304348, 0.090909090909091
34631, 0.8695652173913, 0.20217391304348, 0.13636363636364
34632, 0.8695652173913, 0.20217391304348, 0.18181818181818
34633, 0.8695652173913, 0.20217391304348, 0.22727272727273
34634, 0.8695652173913, 0.20217391304348, 0.27272727272727
34635, 0.8695652173913, 0.20217391304348, 0.31818181818182
34636, 0.8695652173913, 0.20217391304348, 0.36363636363636
34637, 0.8695652173913, 0.20217391304348, 0.40909090909091
34638, 0.8695652173913, 0.20217391304348, 0.45454545454545
34639, 0.82608695652174, 0.20217391304348, 0.045454545454545
34640, 0.82608695652174, 0.20217391304348, 0.090909090909091
34641, 0.82608695652174, 0.20217391304348, 0.13636363636364
34642, 0.82608695652174, 0.20217391304348, 0.18181818181818
34643, 0.82608695652174, 0.20217391304348, 0.22727272727273
34644, 0.82608695652174, 0.20217391304348, 0.27272727272727
34645, 0.82608695652174, 0.20217391304348, 0.31818181818182
34646, 0.82608695652174, 0.20217391304348, 0.36363636363636
34647, 0.82608695652174, 0.20217391304348, 0.40909090909091
34648, 0.82608695652174, 0.20217391304348, 0.45454545454545
34649, 0.78260869565217, 0.20217391304348, 0.045454545454545
34650, 0.78260869565217, 0.20217391304348, 0.090909090909091
34651, 0.78260869565217, 0.20217391304348, 0.13636363636364
34652, 0.78260869565217, 0.20217391304348, 0.18181818181818
34653, 0.78260869565217, 0.20217391304348, 0.22727272727273
34654, 0.78260869565217, 0.20217391304348, 0.27272727272727
34655, 0.78260869565217, 0.20217391304348, 0.31818181818182
34656, 0.78260869565217, 0.20217391304348, 0.36363636363636
34657, 0.78260869565217, 0.20217391304348, 0.40909090909091
34658, 0.78260869565217, 0.20217391304348, 0.45454545454545
34659, 0.73913043478261, 0.20217391304348, 0.045454545454545
34660, 0.73913043478261, 0.20217391304348, 0.090909090909091
34661, 0.73913043478261, 0.20217391304348, 0.13636363636364
34662, 0.73913043478261, 0.20217391304348, 0.18181818181818
34663, 0.73913043478261, 0.20217391304348, 0.22727272727273
34664, 0.73913043478261, 0.20217391304348, 0.27272727272727
34665, 0.73913043478261, 0.20217391304348, 0.31818181818182
34666, 0.73913043478261, 0.20217391304348, 0.36363636363636
34667, 0.73913043478261, 0.20217391304348, 0.40909090909091
34668, 0.73913043478261, 0.20217391304348, 0.45454545454545
34669, 0.69565217391304, 0.20217391304348, 0.045454545454545
34670, 0.69565217391304, 0.20217391304348, 0.090909090909091
34671, 0.69565217391304, 0.20217391304348, 0.13636363636364
34672, 0.69565217391304, 0.20217391304348, 0.18181818181818
34673, 0.69565217391304, 0.20217391304348, 0.22727272727273
34674, 0.69565217391304, 0.20217391304348, 0.27272727272727
34675, 0.69565217391304, 0.20217391304348, 0.31818181818182
34676, 0.69565217391304, 0.20217391304348, 0.36363636363636
34677, 0.69565217391304, 0.20217391304348, 0.40909090909091
34678, 0.69565217391304, 0.20217391304348, 0.45454545454545
34679, 0.65217391304348, 0.20217391304348, 0.045454545454545
34680, 0.65217391304348, 0.20217391304348, 0.090909090909091
34681, 0.65217391304348, 0.20217391304348, 0.13636363636364
34682, 0.65217391304348, 0.20217391304348, 0.18181818181818
34683, 0.65217391304348, 0.20217391304348, 0.22727272727273
34684, 0.65217391304348, 0.20217391304348, 0.27272727272727
34685, 0.65217391304348, 0.20217391304348, 0.31818181818182
34686, 0.65217391304348, 0.20217391304348, 0.36363636363636
34687, 0.65217391304348, 0.20217391304348, 0.40909090909091
34688, 0.65217391304348, 0.20217391304348, 0.45454545454545
34689, 0.60869565217391, 0.20217391304348, 0.045454545454545
34690, 0.60869565217391, 0.20217391304348, 0.090909090909091
34691, 0.60869565217391, 0.20217391304348, 0.13636363636364
34692, 0.60869565217391, 0.20217391304348, 0.18181818181818
34693, 0.60869565217391, 0.20217391304348, 0.22727272727273
34694, 0.60869565217391, 0.20217391304348, 0.27272727272727
34695, 0.60869565217391, 0.20217391304348, 0.31818181818182
34696, 0.60869565217391, 0.20217391304348, 0.36363636363636
34697, 0.60869565217391, 0.20217391304348, 0.40909090909091
34698, 0.60869565217391, 0.20217391304348, 0.45454545454545
34699, 0.56521739130435, 0.20217391304348, 0.045454545454545
34700, 0.56521739130435, 0.20217391304348, 0.090909090909091
34701, 0.56521739130435, 0.20217391304348, 0.13636363636364
34702, 0.56521739130435, 0.20217391304348, 0.18181818181818
34703, 0.56521739130435, 0.20217391304348, 0.22727272727273
34704, 0.56521739130435, 0.20217391304348, 0.27272727272727
34705, 0.56521739130435, 0.20217391304348, 0.31818181818182
34706, 0.56521739130435, 0.20217391304348, 0.36363636363636
34707, 0.56521739130435, 0.20217391304348, 0.40909090909091
34708, 0.56521739130435, 0.20217391304348, 0.45454545454545
34709, 0.52173913043478, 0.20217391304348, 0.045454545454545
34710, 0.52173913043478, 0.20217391304348, 0.090909090909091
34711, 0.52173913043478, 0.20217391304348, 0.13636363636364
34712, 0.52173913043478, 0.20217391304348, 0.18181818181818
34713, 0.52173913043478, 0.20217391304348, 0.22727272727273
34714, 0.52173913043478, 0.20217391304348, 0.27272727272727
34715, 0.52173913043478, 0.20217391304348, 0.31818181818182
34716, 0.52173913043478, 0.20217391304348, 0.36363636363636
34717, 0.52173913043478, 0.20217391304348, 0.40909090909091
34718, 0.52173913043478, 0.20217391304348, 0.45454545454545
34719, 0.47826086956522, 0.20217391304348, 0.045454545454545
34720, 0.47826086956522, 0.20217391304348, 0.090909090909091
34721, 0.47826086956522, 0.20217391304348, 0.13636363636364
34722, 0.47826086956522, 0.20217391304348, 0.18181818181818
34723, 0.47826086956522, 0.20217391304348, 0.22727272727273
34724, 0.47826086956522, 0.20217391304348, 0.27272727272727
34725, 0.47826086956522, 0.20217391304348, 0.31818181818182
34726, 0.47826086956522, 0.20217391304348, 0.36363636363636
34727, 0.47826086956522, 0.20217391304348, 0.40909090909091
34728, 0.47826086956522, 0.20217391304348, 0.45454545454545
34729, 0.43478260869565, 0.20217391304348, 0.045454545454545
34730, 0.43478260869565, 0.20217391304348, 0.090909090909091
34731, 0.43478260869565, 0.20217391304348, 0.13636363636364
34732, 0.43478260869565, 0.20217391304348, 0.18181818181818
34733, 0.43478260869565, 0.20217391304348, 0.22727272727273
34734, 0.43478260869565, 0.20217391304348, 0.27272727272727
34735, 0.43478260869565, 0.20217391304348, 0.31818181818182
34736, 0.43478260869565, 0.20217391304348, 0.36363636363636
34737, 0.43478260869565, 0.20217391304348, 0.40909090909091
34738, 0.43478260869565, 0.20217391304348, 0.45454545454545
34739, 0.39130434782609, 0.20217391304348, 0.045454545454545
34740, 0.39130434782609, 0.20217391304348, 0.090909090909091
34741, 0.39130434782609, 0.20217391304348, 0.13636363636364
34742, 0.39130434782609, 0.20217391304348, 0.18181818181818
34743, 0.39130434782609, 0.20217391304348, 0.22727272727273
34744, 0.39130434782609, 0.20217391304348, 0.27272727272727
34745, 0.39130434782609, 0.20217391304348, 0.31818181818182
34746, 0.39130434782609, 0.20217391304348, 0.36363636363636
34747, 0.39130434782609, 0.20217391304348, 0.40909090909091
34748, 0.39130434782609, 0.20217391304348, 0.45454545454545
34749, 0.34782608695652, 0.20217391304348, 0.045454545454545
34750, 0.34782608695652, 0.20217391304348, 0.090909090909091
34751, 0.34782608695652, 0.20217391304348, 0.13636363636364
34752, 0.34782608695652, 0.20217391304348, 0.18181818181818
34753, 0.34782608695652, 0.20217391304348, 0.22727272727273
34754, 0.34782608695652, 0.20217391304348, 0.27272727272727
34755, 0.34782608695652, 0.20217391304348, 0.31818181818182
34756, 0.34782608695652, 0.20217391304348, 0.36363636363636
34757, 0.34782608695652, 0.20217391304348, 0.40909090909091
34758, 0.34782608695652, 0.20217391304348, 0.45454545454545
34759, 0.30434782608696, 0.20217391304348, 0.045454545454545
34760, 0.30434782608696, 0.20217391304348, 0.090909090909091
34761, 0.30434782608696, 0.20217391304348, 0.13636363636364
