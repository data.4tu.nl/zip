5638, 0.78260869565217, 0.15, 0.45454545454545
5639, 0.82608695652174, 0.15, 0.045454545454545
5640, 0.82608695652174, 0.15, 0.090909090909091
5641, 0.82608695652174, 0.15, 0.13636363636364
5642, 0.82608695652174, 0.15, 0.18181818181818
5643, 0.82608695652174, 0.15, 0.22727272727273
5644, 0.82608695652174, 0.15, 0.27272727272727
5645, 0.82608695652174, 0.15, 0.31818181818182
5646, 0.82608695652174, 0.15, 0.36363636363636
5647, 0.82608695652174, 0.15, 0.40909090909091
5648, 0.82608695652174, 0.15, 0.45454545454545
5649, 0.8695652173913, 0.15, 0.045454545454545
5650, 0.8695652173913, 0.15, 0.090909090909091
5651, 0.8695652173913, 0.15, 0.13636363636364
5652, 0.8695652173913, 0.15, 0.18181818181818
5653, 0.8695652173913, 0.15, 0.22727272727273
5654, 0.8695652173913, 0.15, 0.27272727272727
5655, 0.8695652173913, 0.15, 0.31818181818182
5656, 0.8695652173913, 0.15, 0.36363636363636
5657, 0.8695652173913, 0.15, 0.40909090909091
5658, 0.8695652173913, 0.15, 0.45454545454545
5659, 0.91304347826087, 0.15, 0.045454545454545
5660, 0.91304347826087, 0.15, 0.090909090909091
5661, 0.91304347826087, 0.15, 0.13636363636364
5662, 0.91304347826087, 0.15, 0.18181818181818
5663, 0.91304347826087, 0.15, 0.22727272727273
5664, 0.91304347826087, 0.15, 0.27272727272727
5665, 0.91304347826087, 0.15, 0.31818181818182
5666, 0.91304347826087, 0.15, 0.36363636363636
5667, 0.91304347826087, 0.15, 0.40909090909091
5668, 0.91304347826087, 0.15, 0.45454545454545
5669, 0.95652173913043, 0.15, 0.045454545454545
5670, 0.95652173913043, 0.15, 0.090909090909091
5671, 0.95652173913044, 0.15, 0.13636363636364
5672, 0.95652173913043, 0.15, 0.18181818181818
5673, 0.95652173913043, 0.15, 0.22727272727273
5674, 0.95652173913043, 0.15, 0.27272727272727
5675, 0.95652173913043, 0.15, 0.31818181818182
5676, 0.95652173913043, 0.15, 0.36363636363636
5677, 0.95652173913043, 0.15, 0.40909090909091
5678, 0.95652173913043, 0.15, 0.45454545454545
5679, 0.021739130434783, 0.15, 0.045454545454545
5680, 0.043478260869565, 0.15, 0.022727272727273
5681, 0.021739130434783, 0.15, 0.090909090909091
5682, 0.043478260869565, 0.15, 0.068181818181818
5683, 0.021739130434783, 0.15, 0.13636363636364
5684, 0.043478260869565, 0.15, 0.11363636363636
5685, 0.021739130434783, 0.15, 0.18181818181818
5686, 0.043478260869565, 0.15, 0.15909090909091
5687, 0.021739130434783, 0.15, 0.22727272727273
5688, 0.043478260869565, 0.15, 0.20454545454545
5689, 0.021739130434783, 0.15, 0.27272727272727
5690, 0.043478260869565, 0.15, 0.25
5691, 0.021739130434783, 0.15, 0.31818181818182
5692, 0.043478260869565, 0.15, 0.29545454545455
5693, 0.021739130434783, 0.15, 0.36363636363636
5694, 0.043478260869565, 0.15, 0.34090909090909
5695, 0.021739130434783, 0.15, 0.40909090909091
5696, 0.043478260869565, 0.15, 0.38636363636364
5697, 0.021739130434783, 0.15, 0.45454545454545
5698, 0.043478260869565, 0.15, 0.43181818181818
5699, 0.043478260869565, 0.15, 0.47727272727273
5700, 0.065217391304348, 0.15, 0.045454545454545
5701, 0.08695652173913, 0.15, 0.022727272727273
5702, 0.065217391304348, 0.15, 0.090909090909091
5703, 0.08695652173913, 0.15, 0.068181818181818
5704, 0.065217391304348, 0.15, 0.13636363636364
5705, 0.08695652173913, 0.15, 0.11363636363636
5706, 0.065217391304348, 0.15, 0.18181818181818
5707, 0.08695652173913, 0.15, 0.15909090909091
5708, 0.065217391304348, 0.15, 0.22727272727273
5709, 0.08695652173913, 0.15, 0.20454545454545
5710, 0.065217391304348, 0.15, 0.27272727272727
5711, 0.08695652173913, 0.15, 0.25
5712, 0.065217391304348, 0.15, 0.31818181818182
5713, 0.08695652173913, 0.15, 0.29545454545455
5714, 0.065217391304348, 0.15, 0.36363636363636
5715, 0.08695652173913, 0.15, 0.34090909090909
5716, 0.065217391304348, 0.15, 0.40909090909091
5717, 0.08695652173913, 0.15, 0.38636363636364
5718, 0.065217391304348, 0.15, 0.45454545454545
5719, 0.08695652173913, 0.15, 0.43181818181818
5720, 0.08695652173913, 0.15, 0.47727272727273
5721, 0.10869565217391, 0.15, 0.045454545454545
5722, 0.1304347826087, 0.15, 0.022727272727273
5723, 0.10869565217391, 0.15, 0.090909090909091
5724, 0.1304347826087, 0.15, 0.068181818181818
5725, 0.10869565217391, 0.15, 0.13636363636364
5726, 0.1304347826087, 0.15, 0.11363636363636
5727, 0.10869565217391, 0.15, 0.18181818181818
5728, 0.1304347826087, 0.15, 0.15909090909091
5729, 0.10869565217391, 0.15, 0.22727272727273
5730, 0.1304347826087, 0.15, 0.20454545454545
5731, 0.10869565217391, 0.15, 0.27272727272727
5732, 0.1304347826087, 0.15, 0.25
5733, 0.10869565217391, 0.15, 0.31818181818182
5734, 0.1304347826087, 0.15, 0.29545454545455
5735, 0.10869565217391, 0.15, 0.36363636363636
5736, 0.1304347826087, 0.15, 0.34090909090909
5737, 0.10869565217391, 0.15, 0.40909090909091
5738, 0.1304347826087, 0.15, 0.38636363636364
5739, 0.10869565217391, 0.15, 0.45454545454545
5740, 0.1304347826087, 0.15, 0.43181818181818
5741, 0.1304347826087, 0.15, 0.47727272727273
5742, 0.15217391304348, 0.15, 0.045454545454545
5743, 0.17391304347826, 0.15, 0.022727272727273
5744, 0.15217391304348, 0.15, 0.090909090909091
5745, 0.17391304347826, 0.15, 0.068181818181818
5746, 0.15217391304348, 0.15, 0.13636363636364
5747, 0.17391304347826, 0.15, 0.11363636363636
5748, 0.15217391304348, 0.15, 0.18181818181818
5749, 0.17391304347826, 0.15, 0.15909090909091
5750, 0.15217391304348, 0.15, 0.22727272727273
5751, 0.17391304347826, 0.15, 0.20454545454545
5752, 0.15217391304348, 0.15, 0.27272727272727
5753, 0.17391304347826, 0.15, 0.25
5754, 0.15217391304348, 0.15, 0.31818181818182
5755, 0.17391304347826, 0.15, 0.29545454545455
5756, 0.15217391304348, 0.15, 0.36363636363636
5757, 0.17391304347826, 0.15, 0.34090909090909
5758, 0.15217391304348, 0.15, 0.40909090909091
5759, 0.17391304347826, 0.15, 0.38636363636364
5760, 0.15217391304348, 0.15, 0.45454545454545
5761, 0.17391304347826, 0.15, 0.43181818181818
5762, 0.17391304347826, 0.15, 0.47727272727273
5763, 0.19565217391304, 0.15, 0.045454545454545
5764, 0.21739130434783, 0.15, 0.022727272727273
5765, 0.19565217391304, 0.15, 0.090909090909091
5766, 0.21739130434783, 0.15, 0.068181818181818
5767, 0.19565217391304, 0.15, 0.13636363636364
5768, 0.21739130434783, 0.15, 0.11363636363636
5769, 0.19565217391304, 0.15, 0.18181818181818
5770, 0.21739130434783, 0.15, 0.15909090909091
5771, 0.19565217391304, 0.15, 0.22727272727273
5772, 0.21739130434783, 0.15, 0.20454545454545
5773, 0.19565217391304, 0.15, 0.27272727272727
5774, 0.21739130434783, 0.15, 0.25
5775, 0.19565217391304, 0.15, 0.31818181818182
5776, 0.21739130434783, 0.15, 0.29545454545455
5777, 0.19565217391304, 0.15, 0.36363636363636
5778, 0.21739130434783, 0.15, 0.34090909090909
5779, 0.19565217391304, 0.15, 0.40909090909091
5780, 0.21739130434783, 0.15, 0.38636363636364
5781, 0.19565217391304, 0.15, 0.45454545454545
5782, 0.21739130434783, 0.15, 0.43181818181818
5783, 0.21739130434783, 0.15, 0.47727272727273
5784, 0.23913043478261, 0.15, 0.045454545454545
5785, 0.26086956521739, 0.15, 0.022727272727273
5786, 0.23913043478261, 0.15, 0.090909090909091
5787, 0.26086956521739, 0.15, 0.068181818181818
5788, 0.23913043478261, 0.15, 0.13636363636364
5789, 0.26086956521739, 0.15, 0.11363636363636
5790, 0.23913043478261, 0.15, 0.18181818181818
5791, 0.26086956521739, 0.15, 0.15909090909091
5792, 0.23913043478261, 0.15, 0.22727272727273
5793, 0.26086956521739, 0.15, 0.20454545454545
5794, 0.23913043478261, 0.15, 0.27272727272727
5795, 0.26086956521739, 0.15, 0.25
5796, 0.23913043478261, 0.15, 0.31818181818182
5797, 0.26086956521739, 0.15, 0.29545454545455
5798, 0.23913043478261, 0.15, 0.36363636363636
5799, 0.26086956521739, 0.15, 0.34090909090909
5800, 0.23913043478261, 0.15, 0.40909090909091
5801, 0.26086956521739, 0.15, 0.38636363636364
5802, 0.23913043478261, 0.15, 0.45454545454545
5803, 0.26086956521739, 0.15, 0.43181818181818
5804, 0.26086956521739, 0.15, 0.47727272727273
5805, 0.28260869565217, 0.15, 0.045454545454545
5806, 0.30434782608696, 0.15, 0.022727272727273
5807, 0.28260869565217, 0.15, 0.090909090909091
5808, 0.30434782608696, 0.15, 0.068181818181818
5809, 0.28260869565217, 0.15, 0.13636363636364
5810, 0.30434782608696, 0.15, 0.11363636363636
5811, 0.28260869565217, 0.15, 0.18181818181818
5812, 0.30434782608696, 0.15, 0.15909090909091
5813, 0.28260869565217, 0.15, 0.22727272727273
5814, 0.30434782608696, 0.15, 0.20454545454545
5815, 0.28260869565217, 0.15, 0.27272727272727
5816, 0.30434782608696, 0.15, 0.25
5817, 0.28260869565217, 0.15, 0.31818181818182
5818, 0.30434782608696, 0.15, 0.29545454545455
5819, 0.28260869565217, 0.15, 0.36363636363636
5820, 0.30434782608696, 0.15, 0.34090909090909
5821, 0.28260869565217, 0.15, 0.40909090909091
5822, 0.30434782608696, 0.15, 0.38636363636364
5823, 0.28260869565217, 0.15, 0.45454545454545
5824, 0.30434782608696, 0.15, 0.43181818181818
5825, 0.30434782608696, 0.15, 0.47727272727273
5826, 0.32608695652174, 0.15, 0.045454545454545
5827, 0.34782608695652, 0.15, 0.022727272727273
5828, 0.32608695652174, 0.15, 0.090909090909091
5829, 0.34782608695652, 0.15, 0.068181818181818
5830, 0.32608695652174, 0.15, 0.13636363636364
5831, 0.34782608695652, 0.15, 0.11363636363636
5832, 0.32608695652174, 0.15, 0.18181818181818
5833, 0.34782608695652, 0.15, 0.15909090909091
5834, 0.32608695652174, 0.15, 0.22727272727273
5835, 0.34782608695652, 0.15, 0.20454545454545
5836, 0.32608695652174, 0.15, 0.27272727272727
5837, 0.34782608695652, 0.15, 0.25
5838, 0.32608695652174, 0.15, 0.31818181818182
5839, 0.34782608695652, 0.15, 0.29545454545455
5840, 0.32608695652174, 0.15, 0.36363636363636
5841, 0.34782608695652, 0.15, 0.34090909090909
5842, 0.32608695652174, 0.15, 0.40909090909091
5843, 0.34782608695652, 0.15, 0.38636363636364
5844, 0.32608695652174, 0.15, 0.45454545454545
5845, 0.34782608695652, 0.15, 0.43181818181818
5846, 0.34782608695652, 0.15, 0.47727272727273
5847, 0.3695652173913, 0.15, 0.045454545454545
5848, 0.39130434782609, 0.15, 0.022727272727273
5849, 0.3695652173913, 0.15, 0.090909090909091
5850, 0.39130434782609, 0.15, 0.068181818181818
5851, 0.3695652173913, 0.15, 0.13636363636364
5852, 0.39130434782609, 0.15, 0.11363636363636
5853, 0.3695652173913, 0.15, 0.18181818181818
5854, 0.39130434782609, 0.15, 0.15909090909091
5855, 0.3695652173913, 0.15, 0.22727272727273
5856, 0.39130434782609, 0.15, 0.20454545454545
5857, 0.3695652173913, 0.15, 0.27272727272727
5858, 0.39130434782609, 0.15, 0.25
5859, 0.3695652173913, 0.15, 0.31818181818182
5860, 0.39130434782609, 0.15, 0.29545454545455
5861, 0.3695652173913, 0.15, 0.36363636363636
5862, 0.39130434782609, 0.15, 0.34090909090909
5863, 0.3695652173913, 0.15, 0.40909090909091
5864, 0.39130434782609, 0.15, 0.38636363636364
5865, 0.3695652173913, 0.15, 0.45454545454545
5866, 0.39130434782609, 0.15, 0.43181818181818
5867, 0.39130434782609, 0.15, 0.47727272727273
5868, 0.41304347826087, 0.15, 0.045454545454545
5869, 0.43478260869565, 0.15, 0.022727272727273
5870, 0.41304347826087, 0.15, 0.090909090909091
5871, 0.43478260869565, 0.15, 0.068181818181818
5872, 0.41304347826087, 0.15, 0.13636363636364
5873, 0.43478260869565, 0.15, 0.11363636363636
5874, 0.41304347826087, 0.15, 0.18181818181818
5875, 0.43478260869565, 0.15, 0.15909090909091
5876, 0.41304347826087, 0.15, 0.22727272727273
5877, 0.43478260869565, 0.15, 0.20454545454545
5878, 0.41304347826087, 0.15, 0.27272727272727
5879, 0.43478260869565, 0.15, 0.25
5880, 0.41304347826087, 0.15, 0.31818181818182
5881, 0.43478260869565, 0.15, 0.29545454545455
5882, 0.41304347826087, 0.15, 0.36363636363636
5883, 0.43478260869565, 0.15, 0.34090909090909
5884, 0.41304347826087, 0.15, 0.40909090909091
5885, 0.43478260869565, 0.15, 0.38636363636364
5886, 0.41304347826087, 0.15, 0.45454545454545
5887, 0.43478260869565, 0.15, 0.43181818181818
5888, 0.43478260869565, 0.15, 0.47727272727273
5889, 0.45652173913043, 0.15, 0.045454545454545
5890, 0.47826086956522, 0.15, 0.022727272727273
5891, 0.45652173913043, 0.15, 0.090909090909091
5892, 0.47826086956522, 0.15, 0.068181818181818
5893, 0.45652173913043, 0.15, 0.13636363636364
5894, 0.47826086956522, 0.15, 0.11363636363636
5895, 0.45652173913043, 0.15, 0.18181818181818
5896, 0.47826086956522, 0.15, 0.15909090909091
5897, 0.45652173913043, 0.15, 0.22727272727273
5898, 0.47826086956522, 0.15, 0.20454545454545
5899, 0.45652173913043, 0.15, 0.27272727272727
5900, 0.47826086956522, 0.15, 0.25
5901, 0.45652173913043, 0.15, 0.31818181818182
5902, 0.47826086956522, 0.15, 0.29545454545455
5903, 0.45652173913043, 0.15, 0.36363636363636
5904, 0.47826086956522, 0.15, 0.34090909090909
5905, 0.45652173913043, 0.15, 0.40909090909091
5906, 0.47826086956522, 0.15, 0.38636363636364
5907, 0.45652173913043, 0.15, 0.45454545454545
5908, 0.47826086956522, 0.15, 0.43181818181818
5909, 0.47826086956522, 0.15, 0.47727272727273
5910, 0.5, 0.15, 0.045454545454545
5911, 0.52173913043478, 0.15, 0.022727272727273
5912, 0.5, 0.15, 0.090909090909091
5913, 0.52173913043478, 0.15, 0.068181818181818
5914, 0.5, 0.15, 0.13636363636364
5915, 0.52173913043478, 0.15, 0.11363636363636
5916, 0.5, 0.15, 0.18181818181818
5917, 0.52173913043478, 0.15, 0.15909090909091
5918, 0.5, 0.15, 0.22727272727273
5919, 0.52173913043478, 0.15, 0.20454545454545
5920, 0.5, 0.15, 0.27272727272727
5921, 0.52173913043478, 0.15, 0.25
5922, 0.5, 0.15, 0.31818181818182
5923, 0.52173913043478, 0.15, 0.29545454545455
5924, 0.5, 0.15, 0.36363636363636
5925, 0.52173913043478, 0.15, 0.34090909090909
5926, 0.5, 0.15, 0.40909090909091
5927, 0.52173913043478, 0.15, 0.38636363636364
5928, 0.5, 0.15, 0.45454545454545
5929, 0.52173913043478, 0.15, 0.43181818181818
5930, 0.52173913043478, 0.15, 0.47727272727273
5931, 0.54347826086957, 0.15, 0.045454545454545
5932, 0.56521739130435, 0.15, 0.022727272727273
5933, 0.54347826086957, 0.15, 0.090909090909091
5934, 0.56521739130435, 0.15, 0.068181818181818
5935, 0.54347826086957, 0.15, 0.13636363636364
5936, 0.56521739130435, 0.15, 0.11363636363636
5937, 0.54347826086957, 0.15, 0.18181818181818
5938, 0.56521739130435, 0.15, 0.15909090909091
5939, 0.54347826086957, 0.15, 0.22727272727273
5940, 0.56521739130435, 0.15, 0.20454545454545
5941, 0.54347826086957, 0.15, 0.27272727272727
5942, 0.56521739130435, 0.15, 0.25
5943, 0.54347826086957, 0.15, 0.31818181818182
5944, 0.56521739130435, 0.15, 0.29545454545455
5945, 0.54347826086957, 0.15, 0.36363636363636
5946, 0.56521739130435, 0.15, 0.34090909090909
5947, 0.54347826086957, 0.15, 0.40909090909091
5948, 0.56521739130435, 0.15, 0.38636363636364
5949, 0.54347826086957, 0.15, 0.45454545454545
5950, 0.56521739130435, 0.15, 0.43181818181818
5951, 0.56521739130435, 0.15, 0.47727272727273
5952, 0.58695652173913, 0.15, 0.045454545454545
5953, 0.60869565217391, 0.15, 0.022727272727273
5954, 0.58695652173913, 0.15, 0.090909090909091
5955, 0.60869565217391, 0.15, 0.068181818181818
5956, 0.58695652173913, 0.15, 0.13636363636364
5957, 0.60869565217391, 0.15, 0.11363636363636
5958, 0.58695652173913, 0.15, 0.18181818181818
5959, 0.60869565217391, 0.15, 0.15909090909091
5960, 0.58695652173913, 0.15, 0.22727272727273
5961, 0.60869565217391, 0.15, 0.20454545454545
5962, 0.58695652173913, 0.15, 0.27272727272727
5963, 0.60869565217391, 0.15, 0.25
5964, 0.58695652173913, 0.15, 0.31818181818182
5965, 0.60869565217391, 0.15, 0.29545454545455
5966, 0.58695652173913, 0.15, 0.36363636363636
5967, 0.60869565217391, 0.15, 0.34090909090909
5968, 0.58695652173913, 0.15, 0.40909090909091
5969, 0.60869565217391, 0.15, 0.38636363636364
5970, 0.58695652173913, 0.15, 0.45454545454545
5971, 0.60869565217391, 0.15, 0.43181818181818
5972, 0.60869565217391, 0.15, 0.47727272727273
5973, 0.6304347826087, 0.15, 0.045454545454545
5974, 0.65217391304348, 0.15, 0.022727272727273
5975, 0.6304347826087, 0.15, 0.090909090909091
5976, 0.65217391304348, 0.15, 0.068181818181818
5977, 0.6304347826087, 0.15, 0.13636363636364
5978, 0.65217391304348, 0.15, 0.11363636363636
5979, 0.6304347826087, 0.15, 0.18181818181818
5980, 0.65217391304348, 0.15, 0.15909090909091
5981, 0.6304347826087, 0.15, 0.22727272727273
5982, 0.65217391304348, 0.15, 0.20454545454545
5983, 0.6304347826087, 0.15, 0.27272727272727
5984, 0.65217391304348, 0.15, 0.25
5985, 0.6304347826087, 0.15, 0.31818181818182
5986, 0.65217391304348, 0.15, 0.29545454545455
5987, 0.6304347826087, 0.15, 0.36363636363636
5988, 0.65217391304348, 0.15, 0.34090909090909
5989, 0.6304347826087, 0.15, 0.40909090909091
5990, 0.65217391304348, 0.15, 0.38636363636364
5991, 0.6304347826087, 0.15, 0.45454545454545
5992, 0.65217391304348, 0.15, 0.43181818181818
5993, 0.65217391304348, 0.15, 0.47727272727273
5994, 0.67391304347826, 0.15, 0.045454545454545
5995, 0.69565217391304, 0.15, 0.022727272727273
5996, 0.67391304347826, 0.15, 0.090909090909091
5997, 0.69565217391304, 0.15, 0.068181818181818
5998, 0.67391304347826, 0.15, 0.13636363636364
5999, 0.69565217391304, 0.15, 0.11363636363636
6000, 0.67391304347826, 0.15, 0.18181818181818
6001, 0.69565217391304, 0.15, 0.15909090909091
6002, 0.67391304347826, 0.15, 0.22727272727273
6003, 0.69565217391304, 0.15, 0.20454545454545
6004, 0.67391304347826, 0.15, 0.27272727272727
6005, 0.69565217391304, 0.15, 0.25
6006, 0.67391304347826, 0.15, 0.31818181818182
6007, 0.69565217391304, 0.15, 0.29545454545455
6008, 0.67391304347826, 0.15, 0.36363636363636
6009, 0.69565217391304, 0.15, 0.34090909090909
6010, 0.67391304347826, 0.15, 0.40909090909091
6011, 0.69565217391304, 0.15, 0.38636363636364
6012, 0.67391304347826, 0.15, 0.45454545454545
6013, 0.69565217391304, 0.15, 0.43181818181818
6014, 0.69565217391304, 0.15, 0.47727272727273
6015, 0.71739130434783, 0.15, 0.045454545454545
6016, 0.73913043478261, 0.15, 0.022727272727273
6017, 0.71739130434783, 0.15, 0.090909090909091
6018, 0.73913043478261, 0.15, 0.068181818181818
6019, 0.71739130434783, 0.15, 0.13636363636364
6020, 0.73913043478261, 0.15, 0.11363636363636
6021, 0.71739130434783, 0.15, 0.18181818181818
6022, 0.73913043478261, 0.15, 0.15909090909091
6023, 0.71739130434783, 0.15, 0.22727272727273
6024, 0.73913043478261, 0.15, 0.20454545454545
6025, 0.71739130434783, 0.15, 0.27272727272727
6026, 0.73913043478261, 0.15, 0.25
6027, 0.71739130434783, 0.15, 0.31818181818182
6028, 0.73913043478261, 0.15, 0.29545454545455
6029, 0.71739130434783, 0.15, 0.36363636363636
6030, 0.73913043478261, 0.15, 0.34090909090909
6031, 0.71739130434783, 0.15, 0.40909090909091
6032, 0.73913043478261, 0.15, 0.38636363636364
6033, 0.71739130434783, 0.15, 0.45454545454545
6034, 0.73913043478261, 0.15, 0.43181818181818
6035, 0.73913043478261, 0.15, 0.47727272727273
6036, 0.76086956521739, 0.15, 0.045454545454545
6037, 0.78260869565217, 0.15, 0.022727272727273
6038, 0.76086956521739, 0.15, 0.090909090909091
6039, 0.78260869565217, 0.15, 0.068181818181818
6040, 0.76086956521739, 0.15, 0.13636363636364
6041, 0.78260869565217, 0.15, 0.11363636363636
6042, 0.76086956521739, 0.15, 0.18181818181818
6043, 0.78260869565217, 0.15, 0.15909090909091
6044, 0.76086956521739, 0.15, 0.22727272727273
6045, 0.78260869565217, 0.15, 0.20454545454545
6046, 0.76086956521739, 0.15, 0.27272727272727
6047, 0.78260869565217, 0.15, 0.25
6048, 0.76086956521739, 0.15, 0.31818181818182
6049, 0.78260869565217, 0.15, 0.29545454545455
6050, 0.76086956521739, 0.15, 0.36363636363636
6051, 0.78260869565217, 0.15, 0.34090909090909
6052, 0.76086956521739, 0.15, 0.40909090909091
6053, 0.78260869565217, 0.15, 0.38636363636364
6054, 0.76086956521739, 0.15, 0.45454545454545
6055, 0.78260869565217, 0.15, 0.43181818181818
6056, 0.78260869565217, 0.15, 0.47727272727273
6057, 0.80434782608696, 0.15, 0.045454545454545
6058, 0.82608695652174, 0.15, 0.022727272727273
6059, 0.80434782608696, 0.15, 0.090909090909091
6060, 0.82608695652174, 0.15, 0.068181818181818
6061, 0.80434782608696, 0.15, 0.13636363636364
6062, 0.82608695652174, 0.15, 0.11363636363636
6063, 0.80434782608696, 0.15, 0.18181818181818
6064, 0.82608695652174, 0.15, 0.15909090909091
6065, 0.80434782608696, 0.15, 0.22727272727273
6066, 0.82608695652174, 0.15, 0.20454545454545
6067, 0.80434782608696, 0.15, 0.27272727272727
6068, 0.82608695652174, 0.15, 0.25
6069, 0.80434782608696, 0.15, 0.31818181818182
6070, 0.82608695652174, 0.15, 0.29545454545455
6071, 0.80434782608696, 0.15, 0.36363636363636
6072, 0.82608695652174, 0.15, 0.34090909090909
6073, 0.80434782608696, 0.15, 0.40909090909091
6074, 0.82608695652174, 0.15, 0.38636363636364
6075, 0.80434782608696, 0.15, 0.45454545454545
6076, 0.82608695652174, 0.15, 0.43181818181818
6077, 0.82608695652174, 0.15, 0.47727272727273
6078, 0.84782608695652, 0.15, 0.045454545454545
6079, 0.8695652173913, 0.15, 0.022727272727273
6080, 0.84782608695652, 0.15, 0.090909090909091
6081, 0.8695652173913, 0.15, 0.068181818181818
6082, 0.84782608695652, 0.15, 0.13636363636364
6083, 0.8695652173913, 0.15, 0.11363636363636
6084, 0.84782608695652, 0.15, 0.18181818181818
6085, 0.8695652173913, 0.15, 0.15909090909091
6086, 0.84782608695652, 0.15, 0.22727272727273
6087, 0.8695652173913, 0.15, 0.20454545454545
6088, 0.84782608695652, 0.15, 0.27272727272727
6089, 0.8695652173913, 0.15, 0.25
6090, 0.84782608695652, 0.15, 0.31818181818182
6091, 0.8695652173913, 0.15, 0.29545454545455
6092, 0.84782608695652, 0.15, 0.36363636363636
6093, 0.8695652173913, 0.15, 0.34090909090909
6094, 0.84782608695652, 0.15, 0.40909090909091
6095, 0.8695652173913, 0.15, 0.38636363636364
6096, 0.84782608695652, 0.15, 0.45454545454545
6097, 0.8695652173913, 0.15, 0.43181818181818
6098, 0.8695652173913, 0.15, 0.47727272727273
6099, 0.89130434782609, 0.15, 0.045454545454545
6100, 0.91304347826087, 0.15, 0.022727272727273
6101, 0.89130434782609, 0.15, 0.090909090909091
6102, 0.91304347826087, 0.15, 0.068181818181818
6103, 0.89130434782609, 0.15, 0.13636363636364
6104, 0.91304347826087, 0.15, 0.11363636363636
6105, 0.89130434782609, 0.15, 0.18181818181818
6106, 0.91304347826087, 0.15, 0.15909090909091
6107, 0.89130434782609, 0.15, 0.22727272727273
6108, 0.91304347826087, 0.15, 0.20454545454545
6109, 0.89130434782609, 0.15, 0.27272727272727
6110, 0.91304347826087, 0.15, 0.25
6111, 0.89130434782609, 0.15, 0.31818181818182
6112, 0.91304347826087, 0.15, 0.29545454545455
6113, 0.89130434782609, 0.15, 0.36363636363636
6114, 0.91304347826087, 0.15, 0.34090909090909
6115, 0.89130434782609, 0.15, 0.40909090909091
6116, 0.91304347826087, 0.15, 0.38636363636364
6117, 0.89130434782609, 0.15, 0.45454545454545
6118, 0.91304347826087, 0.15, 0.43181818181818
6119, 0.91304347826087, 0.15, 0.47727272727273
6120, 0.93478260869565, 0.15, 0.045454545454545
6121, 0.95652173913043, 0.15, 0.022727272727273
6122, 0.93478260869565, 0.15, 0.090909090909091
6123, 0.95652173913043, 0.15, 0.068181818181818
6124, 0.93478260869565, 0.15, 0.13636363636364
6125, 0.95652173913044, 0.15, 0.11363636363636
6126, 0.93478260869565, 0.15, 0.18181818181818
6127, 0.95652173913043, 0.15, 0.15909090909091
6128, 0.93478260869565, 0.15, 0.22727272727273
6129, 0.95652173913043, 0.15, 0.20454545454545
6130, 0.93478260869565, 0.15, 0.27272727272727
6131, 0.95652173913043, 0.15, 0.25
6132, 0.93478260869565, 0.15, 0.31818181818182
6133, 0.95652173913043, 0.15, 0.29545454545455
6134, 0.93478260869565, 0.15, 0.36363636363636
6135, 0.95652173913043, 0.15, 0.34090909090909
6136, 0.93478260869565, 0.15, 0.40909090909091
6137, 0.95652173913043, 0.15, 0.38636363636364
6138, 0.93478260869565, 0.15, 0.45454545454545
6139, 0.95652173913043, 0.15, 0.43181818181818
6140, 0.95652173913043, 0.15, 0.47727272727273
6141, 0.97826086956522, 0.15, 0.045454545454545
6142, 0.97826086956522, 0.15, 0.090909090909091
6143, 0.97826086956522, 0.15, 0.13636363636364
6144, 0.97826086956522, 0.15, 0.18181818181818
6145, 0.97826086956522, 0.15, 0.22727272727273
6146, 0.97826086956522, 0.15, 0.27272727272727
6147, 0.97826086956522, 0.15, 0.31818181818182
6148, 0.97826086956522, 0.15, 0.36363636363636
6149, 0.97826086956522, 0.15, 0.40909090909091
6150, 0.97826086956522, 0.15, 0.45454545454545
6151, 0.95652173913043, 0.20217391304348, 0
6152, 0.91304347826087, 0.20217391304348, 0
6153, 0.8695652173913, 0.20217391304348, 0
6154, 0.82608695652174, 0.20217391304348, 0
6155, 0.78260869565217, 0.20217391304348, 0
6156, 0.73913043478261, 0.20217391304348, 0
6157, 0.69565217391304, 0.20217391304348, 0
6158, 0.65217391304348, 0.20217391304348, 0
6159, 0.60869565217391, 0.20217391304348, 0
6160, 0.56521739130435, 0.20217391304348, 0
6161, 0.52173913043478, 0.20217391304348, 0
6162, 0.47826086956522, 0.20217391304348, 0
6163, 0.43478260869565, 0.20217391304348, 0
6164, 0.39130434782609, 0.20217391304348, 0
6165, 0.34782608695652, 0.20217391304348, 0
6166, 0.30434782608696, 0.20217391304348, 0
6167, 0.26086956521739, 0.20217391304348, 0
6168, 0.21739130434783, 0.20217391304348, 0
6169, 0.17391304347826, 0.20217391304348, 0
6170, 0.1304347826087, 0.20217391304348, 0
6171, 0.08695652173913, 0.20217391304348, 0
6172, 0.043478260869565, 0.20217391304348, 0
6173, 0.95652173913043, 0.25434782608696, 0
6174, 0.91304347826087, 0.25434782608696, 0
6175, 0.8695652173913, 0.25434782608696, 0
6176, 0.82608695652174, 0.25434782608696, 0
6177, 0.78260869565217, 0.25434782608696, 0
6178, 0.73913043478261, 0.25434782608696, 0
6179, 0.69565217391304, 0.25434782608696, 0
6180, 0.65217391304348, 0.25434782608696, 0
6181, 0.60869565217391, 0.25434782608696, 0
6182, 0.56521739130435, 0.25434782608696, 0
6183, 0.52173913043478, 0.25434782608696, 0
6184, 0.47826086956522, 0.25434782608696, 0
6185, 0.43478260869565, 0.25434782608696, 0
6186, 0.39130434782609, 0.25434782608696, 0
6187, 0.34782608695652, 0.25434782608696, 0
6188, 0.30434782608696, 0.25434782608696, 0
6189, 0.26086956521739, 0.25434782608696, 0
6190, 0.21739130434783, 0.25434782608696, 0
6191, 0.17391304347826, 0.25434782608696, 0
6192, 0.1304347826087, 0.25434782608696, 0
6193, 0.08695652173913, 0.25434782608696, 0
6194, 0.043478260869565, 0.25434782608696, 0
6195, 0.95652173913043, 0.30652173913043, 0
6196, 0.91304347826087, 0.30652173913043, 0
6197, 0.8695652173913, 0.30652173913043, 0
6198, 0.82608695652174, 0.30652173913043, 0
6199, 0.78260869565217, 0.30652173913043, 0
6200, 0.73913043478261, 0.30652173913043, 0
6201, 0.69565217391304, 0.30652173913043, 0
6202, 0.65217391304348, 0.30652173913043, 0
6203, 0.60869565217391, 0.30652173913043, 0
6204, 0.56521739130435, 0.30652173913043, 0
6205, 0.52173913043478, 0.30652173913043, 0
6206, 0.47826086956522, 0.30652173913043, 0
6207, 0.43478260869565, 0.30652173913043, 0
6208, 0.39130434782609, 0.30652173913043, 0
6209, 0.34782608695652, 0.30652173913043, 0
6210, 0.30434782608696, 0.30652173913043, 0
6211, 0.26086956521739, 0.30652173913043, 0
6212, 0.21739130434783, 0.30652173913043, 0
6213, 0.17391304347826, 0.30652173913043, 0
6214, 0.1304347826087, 0.30652173913043, 0
6215, 0.08695652173913, 0.30652173913043, 0
6216, 0.043478260869565, 0.30652173913043, 0
6217, 0.95652173913043, 0.35869565217391, 0
6218, 0.91304347826087, 0.35869565217391, 0
6219, 0.8695652173913, 0.35869565217391, 0
6220, 0.82608695652174, 0.35869565217391, 0
6221, 0.78260869565217, 0.35869565217391, 0
6222, 0.73913043478261, 0.35869565217391, 0
6223, 0.69565217391304, 0.35869565217391, 0
6224, 0.65217391304348, 0.35869565217391, 0
6225, 0.60869565217391, 0.35869565217391, 0
6226, 0.56521739130435, 0.35869565217391, 0
6227, 0.52173913043478, 0.35869565217391, 0
6228, 0.47826086956522, 0.35869565217391, 0
6229, 0.43478260869565, 0.35869565217391, 0
6230, 0.39130434782609, 0.35869565217391, 0
6231, 0.34782608695652, 0.35869565217391, 0
6232, 0.30434782608696, 0.35869565217391, 0
6233, 0.26086956521739, 0.35869565217391, 0
6234, 0.21739130434783, 0.35869565217391, 0
6235, 0.17391304347826, 0.35869565217391, 0
6236, 0.1304347826087, 0.35869565217391, 0
6237, 0.08695652173913, 0.35869565217391, 0
6238, 0.043478260869565, 0.35869565217391, 0
6239, 0.95652173913043, 0.41086956521739, 0
6240, 0.91304347826087, 0.41086956521739, 0
6241, 0.8695652173913, 0.41086956521739, 0
6242, 0.82608695652174, 0.41086956521739, 0
6243, 0.78260869565217, 0.41086956521739, 0
6244, 0.73913043478261, 0.41086956521739, 0
6245, 0.69565217391304, 0.41086956521739, 0
6246, 0.65217391304348, 0.41086956521739, 0
6247, 0.60869565217391, 0.41086956521739, 0
6248, 0.56521739130435, 0.41086956521739, 0
6249, 0.52173913043478, 0.41086956521739, 0
6250, 0.47826086956522, 0.41086956521739, 0
6251, 0.43478260869565, 0.41086956521739, 0
6252, 0.39130434782609, 0.41086956521739, 0
6253, 0.34782608695652, 0.41086956521739, 0
6254, 0.30434782608696, 0.41086956521739, 0
6255, 0.26086956521739, 0.41086956521739, 0
6256, 0.21739130434783, 0.41086956521739, 0
6257, 0.17391304347826, 0.41086956521739, 0
6258, 0.1304347826087, 0.41086956521739, 0
6259, 0.08695652173913, 0.41086956521739, 0
6260, 0.043478260869565, 0.41086956521739, 0
6261, 0.95652173913043, 0.46304347826087, 0
6262, 0.91304347826087, 0.46304347826087, 0
6263, 0.8695652173913, 0.46304347826087, 0
6264, 0.82608695652174, 0.46304347826087, 0
6265, 0.78260869565217, 0.46304347826087, 0
6266, 0.73913043478261, 0.46304347826087, 0
6267, 0.69565217391304, 0.46304347826087, 0
6268, 0.65217391304348, 0.46304347826087, 0
6269, 0.60869565217391, 0.46304347826087, 0
6270, 0.56521739130435, 0.46304347826087, 0
6271, 0.52173913043478, 0.46304347826087, 0
6272, 0.47826086956522, 0.46304347826087, 0
6273, 0.43478260869565, 0.46304347826087, 0
6274, 0.39130434782609, 0.46304347826087, 0
6275, 0.34782608695652, 0.46304347826087, 0
6276, 0.30434782608696, 0.46304347826087, 0
6277, 0.26086956521739, 0.46304347826087, 0
6278, 0.21739130434783, 0.46304347826087, 0
6279, 0.17391304347826, 0.46304347826087, 0
6280, 0.1304347826087, 0.46304347826087, 0
6281, 0.08695652173913, 0.46304347826087, 0
6282, 0.043478260869565, 0.46304347826087, 0
6283, 0.95652173913043, 0.51521739130435, 0
6284, 0.91304347826087, 0.51521739130435, 0
6285, 0.8695652173913, 0.51521739130435, 0
6286, 0.82608695652174, 0.51521739130435, 0
6287, 0.78260869565217, 0.51521739130435, 0
6288, 0.73913043478261, 0.51521739130435, 0
6289, 0.69565217391304, 0.51521739130435, 0
6290, 0.65217391304348, 0.51521739130435, 0
6291, 0.60869565217391, 0.51521739130435, 0
6292, 0.56521739130435, 0.51521739130435, 0
6293, 0.52173913043478, 0.51521739130435, 0
6294, 0.47826086956522, 0.51521739130435, 0
6295, 0.43478260869565, 0.51521739130435, 0
6296, 0.39130434782609, 0.51521739130435, 0
6297, 0.34782608695652, 0.51521739130435, 0
6298, 0.30434782608696, 0.51521739130435, 0
6299, 0.26086956521739, 0.51521739130435, 0
6300, 0.21739130434783, 0.51521739130435, 0
6301, 0.17391304347826, 0.51521739130435, 0
6302, 0.1304347826087, 0.51521739130435, 0
6303, 0.08695652173913, 0.51521739130435, 0
6304, 0.043478260869565, 0.51521739130435, 0
6305, 0.95652173913043, 0.56739130434783, 0
6306, 0.91304347826087, 0.56739130434783, 0
6307, 0.8695652173913, 0.56739130434783, 0
6308, 0.82608695652174, 0.56739130434783, 0
6309, 0.78260869565217, 0.56739130434783, 0
6310, 0.73913043478261, 0.56739130434783, 0
6311, 0.69565217391304, 0.56739130434783, 0
6312, 0.65217391304348, 0.56739130434783, 0
6313, 0.60869565217391, 0.56739130434783, 0
6314, 0.56521739130435, 0.56739130434783, 0
6315, 0.52173913043478, 0.56739130434783, 0
6316, 0.47826086956522, 0.56739130434783, 0
6317, 0.43478260869565, 0.56739130434783, 0
6318, 0.39130434782609, 0.56739130434783, 0
6319, 0.34782608695652, 0.56739130434783, 0
6320, 0.30434782608696, 0.56739130434783, 0
6321, 0.26086956521739, 0.56739130434783, 0
6322, 0.21739130434783, 0.56739130434783, 0
6323, 0.17391304347826, 0.56739130434783, 0
6324, 0.1304347826087, 0.56739130434783, 0
6325, 0.08695652173913, 0.56739130434783, 0
6326, 0.043478260869565, 0.56739130434783, 0
6327, 0.95652173913043, 0.6195652173913, 0
6328, 0.91304347826087, 0.6195652173913, 0
6329, 0.8695652173913, 0.6195652173913, 0
6330, 0.82608695652174, 0.6195652173913, 0
6331, 0.78260869565217, 0.6195652173913, 0
6332, 0.73913043478261, 0.6195652173913, 0
6333, 0.69565217391304, 0.6195652173913, 0
6334, 0.65217391304348, 0.6195652173913, 0
6335, 0.60869565217391, 0.6195652173913, 0
6336, 0.56521739130435, 0.6195652173913, 0
6337, 0.52173913043478, 0.6195652173913, 0
6338, 0.47826086956522, 0.6195652173913, 0
6339, 0.43478260869565, 0.6195652173913, 0
6340, 0.39130434782609, 0.6195652173913, 0
6341, 0.34782608695652, 0.6195652173913, 0
6342, 0.30434782608696, 0.6195652173913, 0
6343, 0.26086956521739, 0.6195652173913, 0
6344, 0.21739130434783, 0.6195652173913, 0
6345, 0.17391304347826, 0.6195652173913, 0
6346, 0.1304347826087, 0.6195652173913, 0
6347, 0.08695652173913, 0.6195652173913, 0
6348, 0.043478260869565, 0.6195652173913, 0
6349, 0.95652173913043, 0.67173913043478, 0
6350, 0.91304347826087, 0.67173913043478, 0
6351, 0.8695652173913, 0.67173913043478, 0
6352, 0.82608695652174, 0.67173913043478, 0
6353, 0.78260869565217, 0.67173913043478, 0
6354, 0.73913043478261, 0.67173913043478, 0
6355, 0.69565217391304, 0.67173913043478, 0
6356, 0.65217391304348, 0.67173913043478, 0
6357, 0.60869565217391, 0.67173913043478, 0
6358, 0.56521739130435, 0.67173913043478, 0
6359, 0.52173913043478, 0.67173913043478, 0
6360, 0.47826086956522, 0.67173913043478, 0
6361, 0.43478260869565, 0.67173913043478, 0
6362, 0.39130434782609, 0.67173913043478, 0
6363, 0.34782608695652, 0.67173913043478, 0
6364, 0.30434782608696, 0.67173913043478, 0
6365, 0.26086956521739, 0.67173913043478, 0
6366, 0.21739130434783, 0.67173913043478, 0
6367, 0.17391304347826, 0.67173913043478, 0
6368, 0.1304347826087, 0.67173913043478, 0
6369, 0.08695652173913, 0.67173913043478, 0
6370, 0.043478260869565, 0.67173913043478, 0
6371, 0.95652173913043, 0.72391304347826, 0
6372, 0.91304347826087, 0.72391304347826, 0
6373, 0.8695652173913, 0.72391304347826, 0
6374, 0.82608695652174, 0.72391304347826, 0
6375, 0.78260869565217, 0.72391304347826, 0
6376, 0.73913043478261, 0.72391304347826, 0
6377, 0.69565217391304, 0.72391304347826, 0
6378, 0.65217391304348, 0.72391304347826, 0
6379, 0.60869565217391, 0.72391304347826, 0
6380, 0.56521739130435, 0.72391304347826, 0
6381, 0.52173913043478, 0.72391304347826, 0
6382, 0.47826086956522, 0.72391304347826, 0
6383, 0.43478260869565, 0.72391304347826, 0
6384, 0.39130434782609, 0.72391304347826, 0
6385, 0.34782608695652, 0.72391304347826, 0
6386, 0.30434782608696, 0.72391304347826, 0
6387, 0.26086956521739, 0.72391304347826, 0
6388, 0.21739130434783, 0.72391304347826, 0
6389, 0.17391304347826, 0.72391304347826, 0
6390, 0.1304347826087, 0.72391304347826, 0
6391, 0.08695652173913, 0.72391304347826, 0
6392, 0.043478260869565, 0.72391304347826, 0
6393, 0.95652173913043, 0.77608695652174, 0
6394, 0.91304347826087, 0.77608695652174, 0
6395, 0.8695652173913, 0.77608695652174, 0
6396, 0.82608695652174, 0.77608695652174, 0
6397, 0.78260869565217, 0.77608695652174, 0
6398, 0.73913043478261, 0.77608695652174, 0
6399, 0.69565217391304, 0.77608695652174, 0
6400, 0.65217391304348, 0.77608695652174, 0
6401, 0.60869565217391, 0.77608695652174, 0
6402, 0.56521739130435, 0.77608695652174, 0
6403, 0.52173913043478, 0.77608695652174, 0
6404, 0.47826086956522, 0.77608695652174, 0
6405, 0.43478260869565, 0.77608695652174, 0
6406, 0.39130434782609, 0.77608695652174, 0
6407, 0.34782608695652, 0.77608695652174, 0
6408, 0.30434782608696, 0.77608695652174, 0
6409, 0.26086956521739, 0.77608695652174, 0
6410, 0.21739130434783, 0.77608695652174, 0
6411, 0.17391304347826, 0.77608695652174, 0
6412, 0.1304347826087, 0.77608695652174, 0
6413, 0.08695652173913, 0.77608695652174, 0
6414, 0.043478260869565, 0.77608695652174, 0
6415, 0.95652173913043, 0.82826086956522, 0
6416, 0.91304347826087, 0.82826086956522, 0
6417, 0.8695652173913, 0.82826086956522, 0
6418, 0.82608695652174, 0.82826086956522, 0
6419, 0.78260869565217, 0.82826086956522, 0
6420, 0.73913043478261, 0.82826086956522, 0
6421, 0.69565217391304, 0.82826086956522, 0
6422, 0.65217391304348, 0.82826086956522, 0
6423, 0.60869565217391, 0.82826086956522, 0
6424, 0.56521739130435, 0.82826086956522, 0
6425, 0.52173913043478, 0.82826086956522, 0
6426, 0.47826086956522, 0.82826086956522, 0
6427, 0.43478260869565, 0.82826086956522, 0
6428, 0.39130434782609, 0.82826086956522, 0
6429, 0.34782608695652, 0.82826086956522, 0
6430, 0.30434782608696, 0.82826086956522, 0
6431, 0.26086956521739, 0.82826086956522, 0
6432, 0.21739130434783, 0.82826086956522, 0
6433, 0.17391304347826, 0.82826086956522, 0
6434, 0.1304347826087, 0.82826086956522, 0
6435, 0.08695652173913, 0.82826086956522, 0
6436, 0.043478260869565, 0.82826086956522, 0
6437, 0.95652173913043, 0.8804347826087, 0
6438, 0.91304347826087, 0.8804347826087, 0
6439, 0.8695652173913, 0.88043478260869, 0
6440, 0.82608695652174, 0.8804347826087, 0
6441, 0.78260869565217, 0.8804347826087, 0
6442, 0.73913043478261, 0.8804347826087, 0
6443, 0.69565217391304, 0.8804347826087, 0
6444, 0.65217391304348, 0.8804347826087, 0
6445, 0.60869565217391, 0.8804347826087, 0
6446, 0.56521739130435, 0.8804347826087, 0
6447, 0.52173913043478, 0.88043478260869, 0
6448, 0.47826086956522, 0.8804347826087, 0
6449, 0.43478260869565, 0.8804347826087, 0
6450, 0.39130434782609, 0.88043478260869, 0
6451, 0.34782608695652, 0.8804347826087, 0
6452, 0.30434782608696, 0.8804347826087, 0
6453, 0.26086956521739, 0.8804347826087, 0
6454, 0.21739130434783, 0.8804347826087, 0
6455, 0.17391304347826, 0.8804347826087, 0
6456, 0.1304347826087, 0.8804347826087, 0
6457, 0.08695652173913, 0.8804347826087, 0
6458, 0.043478260869565, 0.8804347826087, 0
6459, 0.95652173913043, 0.93260869565217, 0
6460, 0.91304347826087, 0.93260869565217, 0
6461, 0.8695652173913, 0.93260869565217, 0
6462, 0.82608695652174, 0.93260869565217, 0
6463, 0.78260869565217, 0.93260869565217, 0
6464, 0.73913043478261, 0.93260869565217, 0
6465, 0.69565217391304, 0.93260869565217, 0
6466, 0.65217391304348, 0.93260869565217, 0
6467, 0.60869565217391, 0.93260869565217, 0
6468, 0.56521739130435, 0.93260869565217, 0
6469, 0.52173913043478, 0.93260869565217, 0
6470, 0.47826086956522, 0.93260869565217, 0
6471, 0.43478260869565, 0.93260869565217, 0
6472, 0.39130434782609, 0.93260869565217, 0
6473, 0.34782608695652, 0.93260869565217, 0
6474, 0.30434782608696, 0.93260869565217, 0
6475, 0.26086956521739, 0.93260869565217, 0
6476, 0.21739130434783, 0.93260869565217, 0
6477, 0.17391304347826, 0.93260869565217, 0
6478, 0.1304347826087, 0.93260869565217, 0
6479, 0.08695652173913, 0.93260869565217, 0
6480, 0.043478260869565, 0.93260869565217, 0
6481, 0.95652173913043, 0.98478260869565, 0
6482, 0.91304347826087, 0.98478260869565, 0
6483, 0.8695652173913, 0.98478260869565, 0
6484, 0.82608695652174, 0.98478260869565, 0
6485, 0.78260869565217, 0.98478260869565, 0
6486, 0.73913043478261, 0.98478260869565, 0
6487, 0.69565217391304, 0.98478260869565, 0
6488, 0.65217391304348, 0.98478260869565, 0
6489, 0.60869565217391, 0.98478260869565, 0
6490, 0.56521739130435, 0.98478260869565, 0
6491, 0.52173913043478, 0.98478260869565, 0
6492, 0.47826086956522, 0.98478260869565, 0
6493, 0.43478260869565, 0.98478260869565, 0
6494, 0.39130434782609, 0.98478260869565, 0
6495, 0.34782608695652, 0.98478260869565, 0
6496, 0.30434782608696, 0.98478260869565, 0
6497, 0.26086956521739, 0.98478260869565, 0
6498, 0.21739130434783, 0.98478260869565, 0
6499, 0.17391304347826, 0.98478260869565, 0
6500, 0.1304347826087, 0.98478260869565, 0
6501, 0.08695652173913, 0.98478260869565, 0
6502, 0.043478260869565, 0.98478260869565, 0
6503, 0.95652173913043, 1.0369565217391, 0
6504, 0.91304347826087, 1.0369565217391, 0
6505, 0.8695652173913, 1.0369565217391, 0
6506, 0.82608695652174, 1.0369565217391, 0
6507, 0.78260869565217, 1.0369565217391, 0
6508, 0.73913043478261, 1.0369565217391, 0
6509, 0.69565217391304, 1.0369565217391, 0
6510, 0.65217391304348, 1.0369565217391, 0
6511, 0.60869565217391, 1.0369565217391, 0
6512, 0.56521739130435, 1.0369565217391, 0
6513, 0.52173913043478, 1.0369565217391, 0
6514, 0.47826086956522, 1.0369565217391, 0
6515, 0.43478260869565, 1.0369565217391, 0
6516, 0.39130434782609, 1.0369565217391, 0
6517, 0.34782608695652, 1.0369565217391, 0
6518, 0.30434782608696, 1.0369565217391, 0
6519, 0.26086956521739, 1.0369565217391, 0
6520, 0.21739130434783, 1.0369565217391, 0
6521, 0.17391304347826, 1.0369565217391, 0
6522, 0.1304347826087, 1.0369565217391, 0
6523, 0.08695652173913, 1.0369565217391, 0
6524, 0.043478260869565, 1.0369565217391, 0
6525, 0.95652173913043, 1.0891304347826, 0
6526, 0.91304347826087, 1.0891304347826, 0
6527, 0.8695652173913, 1.0891304347826, 0
6528, 0.82608695652174, 1.0891304347826, 0
6529, 0.78260869565217, 1.0891304347826, 0
6530, 0.73913043478261, 1.0891304347826, 0
6531, 0.69565217391304, 1.0891304347826, 0
6532, 0.65217391304348, 1.0891304347826, 0
6533, 0.60869565217391, 1.0891304347826, 0
6534, 0.56521739130435, 1.0891304347826, 0
6535, 0.52173913043478, 1.0891304347826, 0
6536, 0.47826086956522, 1.0891304347826, 0
6537, 0.43478260869565, 1.0891304347826, 0
6538, 0.39130434782609, 1.0891304347826, 0
6539, 0.34782608695652, 1.0891304347826, 0
6540, 0.30434782608696, 1.0891304347826, 0
6541, 0.26086956521739, 1.0891304347826, 0
6542, 0.21739130434783, 1.0891304347826, 0
6543, 0.17391304347826, 1.0891304347826, 0
6544, 0.1304347826087, 1.0891304347826, 0
6545, 0.08695652173913, 1.0891304347826, 0
6546, 0.043478260869565, 1.0891304347826, 0
6547, 0.95652173913043, 1.1413043478261, 0
6548, 0.91304347826087, 1.1413043478261, 0
6549, 0.8695652173913, 1.1413043478261, 0
6550, 0.82608695652174, 1.1413043478261, 0
6551, 0.78260869565217, 1.1413043478261, 0
6552, 0.73913043478261, 1.1413043478261, 0
6553, 0.69565217391304, 1.1413043478261, 0
6554, 0.65217391304348, 1.1413043478261, 0
6555, 0.60869565217391, 1.1413043478261, 0
6556, 0.56521739130435, 1.1413043478261, 0
6557, 0.52173913043478, 1.1413043478261, 0
6558, 0.47826086956522, 1.1413043478261, 0
6559, 0.43478260869565, 1.1413043478261, 0
6560, 0.39130434782609, 1.1413043478261, 0
6561, 0.34782608695652, 1.1413043478261, 0
6562, 0.30434782608696, 1.1413043478261, 0
6563, 0.26086956521739, 1.1413043478261, 0
6564, 0.21739130434783, 1.1413043478261, 0
6565, 0.17391304347826, 1.1413043478261, 0
6566, 0.1304347826087, 1.1413043478261, 0
6567, 0.08695652173913, 1.1413043478261, 0
6568, 0.043478260869565, 1.1413043478261, 0
6569, 0.95652173913043, 1.1934782608696, 0
6570, 0.91304347826087, 1.1934782608696, 0
6571, 0.8695652173913, 1.1934782608696, 0
6572, 0.82608695652174, 1.1934782608696, 0
6573, 0.78260869565217, 1.1934782608696, 0
6574, 0.73913043478261, 1.1934782608696, 0
6575, 0.69565217391304, 1.1934782608696, 0
6576, 0.65217391304348, 1.1934782608696, 0
6577, 0.60869565217391, 1.1934782608696, 0
6578, 0.56521739130435, 1.1934782608696, 0
6579, 0.52173913043478, 1.1934782608696, 0
6580, 0.47826086956522, 1.1934782608696, 0
6581, 0.43478260869565, 1.1934782608696, 0
6582, 0.39130434782609, 1.1934782608696, 0
6583, 0.34782608695652, 1.1934782608696, 0
6584, 0.30434782608696, 1.1934782608696, 0
6585, 0.26086956521739, 1.1934782608696, 0
6586, 0.21739130434783, 1.1934782608696, 0
6587, 0.17391304347826, 1.1934782608696, 0
6588, 0.1304347826087, 1.1934782608696, 0
6589, 0.08695652173913, 1.1934782608696, 0
6590, 0.043478260869565, 1.1934782608696, 0
6591, 0.95652173913043, 1.245652173913, 0
6592, 0.91304347826087, 1.245652173913, 0
6593, 0.8695652173913, 1.245652173913, 0
6594, 0.82608695652174, 1.245652173913, 0
6595, 0.78260869565217, 1.245652173913, 0
6596, 0.73913043478261, 1.245652173913, 0
6597, 0.69565217391304, 1.245652173913, 0
6598, 0.65217391304348, 1.245652173913, 0
6599, 0.60869565217391, 1.245652173913, 0
6600, 0.56521739130435, 1.245652173913, 0
6601, 0.52173913043478, 1.245652173913, 0
6602, 0.47826086956522, 1.245652173913, 0
6603, 0.43478260869565, 1.245652173913, 0
6604, 0.39130434782609, 1.245652173913, 0
6605, 0.34782608695652, 1.245652173913, 0
6606, 0.30434782608696, 1.245652173913, 0
6607, 0.26086956521739, 1.245652173913, 0
6608, 0.21739130434783, 1.245652173913, 0
6609, 0.17391304347826, 1.245652173913, 0
6610, 0.1304347826087, 1.245652173913, 0
6611, 0.08695652173913, 1.245652173913, 0
6612, 0.043478260869565, 1.245652173913, 0
6613, 0.95652173913043, 1.2978260869565, 0
6614, 0.91304347826087, 1.2978260869565, 0
6615, 0.8695652173913, 1.2978260869565, 0
6616, 0.82608695652174, 1.2978260869565, 0
6617, 0.78260869565217, 1.2978260869565, 0
6618, 0.73913043478261, 1.2978260869565, 0
6619, 0.69565217391304, 1.2978260869565, 0
6620, 0.65217391304348, 1.2978260869565, 0
6621, 0.60869565217391, 1.2978260869565, 0
6622, 0.56521739130435, 1.2978260869565, 0
6623, 0.52173913043478, 1.2978260869565, 0
6624, 0.47826086956522, 1.2978260869565, 0
6625, 0.43478260869565, 1.2978260869565, 0
6626, 0.39130434782609, 1.2978260869565, 0
6627, 0.34782608695652, 1.2978260869565, 0
6628, 0.30434782608696, 1.2978260869565, 0
6629, 0.26086956521739, 1.2978260869565, 0
6630, 0.21739130434783, 1.2978260869565, 0
6631, 0.17391304347826, 1.2978260869565, 0
6632, 0.1304347826087, 1.2978260869565, 0
6633, 0.08695652173913, 1.2978260869565, 0
6634, 0.043478260869565, 1.2978260869565, 0
6635, 0.95652173913043, 0.17608695652174, 0
6636, 0.97826086956522, 0.20217391304348, 0
6637, 0.91304347826087, 0.17608695652174, 0
6638, 0.93478260869565, 0.20217391304348, 0
6639, 0.8695652173913, 0.17608695652174, 0
6640, 0.89130434782609, 0.20217391304348, 0
6641, 0.82608695652174, 0.17608695652174, 0
6642, 0.84782608695652, 0.20217391304348, 0
6643, 0.78260869565217, 0.17608695652174, 0
6644, 0.80434782608696, 0.20217391304348, 0
6645, 0.73913043478261, 0.17608695652174, 0
6646, 0.76086956521739, 0.20217391304348, 0
6647, 0.69565217391304, 0.17608695652174, 0
6648, 0.71739130434783, 0.20217391304348, 0
6649, 0.65217391304348, 0.17608695652174, 0
6650, 0.67391304347826, 0.20217391304348, 0
6651, 0.60869565217391, 0.17608695652174, 0
6652, 0.6304347826087, 0.20217391304348, 0
6653, 0.56521739130435, 0.17608695652174, 0
6654, 0.58695652173913, 0.20217391304348, 0
6655, 0.52173913043478, 0.17608695652174, 0
6656, 0.54347826086957, 0.20217391304348, 0
6657, 0.47826086956522, 0.17608695652174, 0
6658, 0.5, 0.20217391304348, 0
6659, 0.43478260869565, 0.17608695652174, 0
6660, 0.45652173913043, 0.20217391304348, 0
6661, 0.39130434782609, 0.17608695652174, 0
6662, 0.41304347826087, 0.20217391304348, 0
6663, 0.34782608695652, 0.17608695652174, 0
6664, 0.3695652173913, 0.20217391304348, 0
6665, 0.30434782608696, 0.17608695652174, 0
6666, 0.32608695652174, 0.20217391304348, 0
6667, 0.26086956521739, 0.17608695652174, 0
6668, 0.28260869565217, 0.20217391304348, 0
6669, 0.21739130434783, 0.17608695652174, 0
6670, 0.23913043478261, 0.20217391304348, 0
6671, 0.17391304347826, 0.17608695652174, 0
6672, 0.19565217391304, 0.20217391304348, 0
6673, 0.1304347826087, 0.17608695652174, 0
6674, 0.15217391304348, 0.20217391304348, 0
6675, 0.08695652173913, 0.17608695652174, 0
6676, 0.10869565217391, 0.20217391304348, 0
6677, 0.043478260869565, 0.17608695652174, 0
6678, 0.065217391304348, 0.20217391304348, 0
6679, 0.021739130434783, 0.20217391304348, 0
6680, 0.95652173913043, 0.22826086956522, 0
6681, 0.97826086956522, 0.25434782608696, 0
6682, 0.91304347826087, 0.22826086956522, 0
6683, 0.93478260869565, 0.25434782608696, 0
6684, 0.8695652173913, 0.22826086956522, 0
6685, 0.89130434782609, 0.25434782608696, 0
6686, 0.82608695652174, 0.22826086956522, 0
6687, 0.84782608695652, 0.25434782608696, 0
6688, 0.78260869565217, 0.22826086956522, 0
6689, 0.80434782608696, 0.25434782608696, 0
6690, 0.73913043478261, 0.22826086956522, 0
6691, 0.76086956521739, 0.25434782608696, 0
6692, 0.69565217391304, 0.22826086956522, 0
6693, 0.71739130434783, 0.25434782608696, 0
6694, 0.65217391304348, 0.22826086956522, 0
6695, 0.67391304347826, 0.25434782608696, 0
6696, 0.60869565217391, 0.22826086956522, 0
6697, 0.6304347826087, 0.25434782608696, 0
6698, 0.56521739130435, 0.22826086956522, 0
6699, 0.58695652173913, 0.25434782608696, 0
6700, 0.52173913043478, 0.22826086956522, 0
6701, 0.54347826086957, 0.25434782608696, 0
6702, 0.47826086956522, 0.22826086956522, 0
6703, 0.5, 0.25434782608696, 0
6704, 0.43478260869565, 0.22826086956522, 0
6705, 0.45652173913043, 0.25434782608696, 0
6706, 0.39130434782609, 0.22826086956522, 0
6707, 0.41304347826087, 0.25434782608696, 0
6708, 0.34782608695652, 0.22826086956522, 0
6709, 0.3695652173913, 0.25434782608696, 0
6710, 0.30434782608696, 0.22826086956522, 0
6711, 0.32608695652174, 0.25434782608696, 0
6712, 0.26086956521739, 0.22826086956522, 0
6713, 0.28260869565217, 0.25434782608696, 0
6714, 0.21739130434783, 0.22826086956522, 0
6715, 0.23913043478261, 0.25434782608696, 0
6716, 0.17391304347826, 0.22826086956522, 0
6717, 0.19565217391304, 0.25434782608696, 0
6718, 0.1304347826087, 0.22826086956522, 0
6719, 0.15217391304348, 0.25434782608696, 0
6720, 0.08695652173913, 0.22826086956522, 0
6721, 0.10869565217391, 0.25434782608696, 0
6722, 0.043478260869565, 0.22826086956522, 0
6723, 0.065217391304348, 0.25434782608696, 0
6724, 0.021739130434783, 0.25434782608696, 0
6725, 0.95652173913043, 0.2804347826087, 0
6726, 0.97826086956522, 0.30652173913043, 0
6727, 0.91304347826087, 0.2804347826087, 0
6728, 0.93478260869565, 0.30652173913043, 0
6729, 0.8695652173913, 0.2804347826087, 0
6730, 0.89130434782609, 0.30652173913043, 0
6731, 0.82608695652174, 0.2804347826087, 0
6732, 0.84782608695652, 0.30652173913043, 0
6733, 0.78260869565217, 0.2804347826087, 0
6734, 0.80434782608696, 0.30652173913043, 0
6735, 0.73913043478261, 0.2804347826087, 0
6736, 0.76086956521739, 0.30652173913043, 0
6737, 0.69565217391304, 0.2804347826087, 0
6738, 0.71739130434783, 0.30652173913043, 0
6739, 0.65217391304348, 0.2804347826087, 0
6740, 0.67391304347826, 0.30652173913043, 0
6741, 0.60869565217391, 0.2804347826087, 0
6742, 0.6304347826087, 0.30652173913043, 0
6743, 0.56521739130435, 0.2804347826087, 0
6744, 0.58695652173913, 0.30652173913043, 0
6745, 0.52173913043478, 0.2804347826087, 0
6746, 0.54347826086957, 0.30652173913043, 0
6747, 0.47826086956522, 0.2804347826087, 0
6748, 0.5, 0.30652173913043, 0
6749, 0.43478260869565, 0.2804347826087, 0
6750, 0.45652173913043, 0.30652173913043, 0
6751, 0.39130434782609, 0.2804347826087, 0
6752, 0.41304347826087, 0.30652173913043, 0
6753, 0.34782608695652, 0.2804347826087, 0
6754, 0.3695652173913, 0.30652173913043, 0
6755, 0.30434782608696, 0.2804347826087, 0
6756, 0.32608695652174, 0.30652173913043, 0
6757, 0.26086956521739, 0.2804347826087, 0
6758, 0.28260869565217, 0.30652173913043, 0
6759, 0.21739130434783, 0.2804347826087, 0
6760, 0.23913043478261, 0.30652173913043, 0
6761, 0.17391304347826, 0.2804347826087, 0
6762, 0.19565217391304, 0.30652173913043, 0
6763, 0.1304347826087, 0.2804347826087, 0
6764, 0.15217391304348, 0.30652173913043, 0
6765, 0.08695652173913, 0.2804347826087, 0
6766, 0.10869565217391, 0.30652173913043, 0
6767, 0.043478260869565, 0.2804347826087, 0
6768, 0.065217391304348, 0.30652173913043, 0
6769, 0.021739130434783, 0.30652173913043, 0
6770, 0.95652173913043, 0.33260869565217, 0
6771, 0.97826086956522, 0.35869565217391, 0
6772, 0.91304347826087, 0.33260869565217, 0
6773, 0.93478260869565, 0.35869565217391, 0
6774, 0.8695652173913, 0.33260869565217, 0
6775, 0.89130434782609, 0.35869565217391, 0
6776, 0.82608695652174, 0.33260869565217, 0
6777, 0.84782608695652, 0.35869565217391, 0
6778, 0.78260869565217, 0.33260869565217, 0
6779, 0.80434782608696, 0.35869565217391, 0
6780, 0.73913043478261, 0.33260869565217, 0
6781, 0.76086956521739, 0.35869565217391, 0
6782, 0.69565217391304, 0.33260869565217, 0
6783, 0.71739130434783, 0.35869565217391, 0
6784, 0.65217391304348, 0.33260869565217, 0
6785, 0.67391304347826, 0.35869565217391, 0
6786, 0.60869565217391, 0.33260869565217, 0
6787, 0.6304347826087, 0.35869565217391, 0
6788, 0.56521739130435, 0.33260869565217, 0
6789, 0.58695652173913, 0.35869565217391, 0
6790, 0.52173913043478, 0.33260869565217, 0
6791, 0.54347826086957, 0.35869565217391, 0
6792, 0.47826086956522, 0.33260869565217, 0
6793, 0.5, 0.35869565217391, 0
6794, 0.43478260869565, 0.33260869565217, 0
6795, 0.45652173913043, 0.35869565217391, 0
6796, 0.39130434782609, 0.33260869565217, 0
6797, 0.41304347826087, 0.35869565217391, 0
6798, 0.34782608695652, 0.33260869565217, 0
6799, 0.3695652173913, 0.35869565217391, 0
6800, 0.30434782608696, 0.33260869565217, 0
6801, 0.32608695652174, 0.35869565217391, 0
6802, 0.26086956521739, 0.33260869565217, 0
6803, 0.28260869565217, 0.35869565217391, 0
6804, 0.21739130434783, 0.33260869565217, 0
6805, 0.23913043478261, 0.35869565217391, 0
6806, 0.17391304347826, 0.33260869565217, 0
6807, 0.19565217391304, 0.35869565217391, 0
6808, 0.1304347826087, 0.33260869565217, 0
6809, 0.15217391304348, 0.35869565217391, 0
6810, 0.08695652173913, 0.33260869565217, 0
6811, 0.10869565217391, 0.35869565217391, 0
6812, 0.043478260869565, 0.33260869565217, 0
6813, 0.065217391304348, 0.35869565217391, 0
6814, 0.021739130434783, 0.35869565217391, 0
6815, 0.95652173913043, 0.38478260869565, 0
6816, 0.97826086956522, 0.41086956521739, 0
6817, 0.91304347826087, 0.38478260869565, 0
6818, 0.93478260869565, 0.41086956521739, 0
6819, 0.8695652173913, 0.38478260869565, 0
6820, 0.89130434782609, 0.41086956521739, 0
6821, 0.82608695652174, 0.38478260869565, 0
6822, 0.84782608695652, 0.41086956521739, 0
6823, 0.78260869565217, 0.38478260869565, 0
6824, 0.80434782608696, 0.41086956521739, 0
6825, 0.73913043478261, 0.38478260869565, 0
6826, 0.76086956521739, 0.41086956521739, 0
6827, 0.69565217391304, 0.38478260869565, 0
6828, 0.71739130434783, 0.41086956521739, 0
6829, 0.65217391304348, 0.38478260869565, 0
6830, 0.67391304347826, 0.41086956521739, 0
6831, 0.60869565217391, 0.38478260869565, 0
6832, 0.6304347826087, 0.41086956521739, 0
6833, 0.56521739130435, 0.38478260869565, 0
6834, 0.58695652173913, 0.41086956521739, 0
6835, 0.52173913043478, 0.38478260869565, 0
6836, 0.54347826086957, 0.41086956521739, 0
6837, 0.47826086956522, 0.38478260869565, 0
6838, 0.5, 0.41086956521739, 0
6839, 0.43478260869565, 0.38478260869565, 0
6840, 0.45652173913043, 0.41086956521739, 0
6841, 0.39130434782609, 0.38478260869565, 0
6842, 0.41304347826087, 0.41086956521739, 0
6843, 0.34782608695652, 0.38478260869565, 0
6844, 0.3695652173913, 0.41086956521739, 0
6845, 0.30434782608696, 0.38478260869565, 0
6846, 0.32608695652174, 0.41086956521739, 0
6847, 0.26086956521739, 0.38478260869565, 0
6848, 0.28260869565217, 0.41086956521739, 0
6849, 0.21739130434783, 0.38478260869565, 0
6850, 0.23913043478261, 0.41086956521739, 0
6851, 0.17391304347826, 0.38478260869565, 0
6852, 0.19565217391304, 0.41086956521739, 0
6853, 0.1304347826087, 0.38478260869565, 0
6854, 0.15217391304348, 0.41086956521739, 0
6855, 0.08695652173913, 0.38478260869565, 0
6856, 0.10869565217391, 0.41086956521739, 0
6857, 0.043478260869565, 0.38478260869565, 0
6858, 0.065217391304348, 0.41086956521739, 0
6859, 0.021739130434783, 0.41086956521739, 0
6860, 0.95652173913043, 0.43695652173913, 0
6861, 0.97826086956522, 0.46304347826087, 0
6862, 0.91304347826087, 0.43695652173913, 0
6863, 0.93478260869565, 0.46304347826087, 0
6864, 0.8695652173913, 0.43695652173913, 0
6865, 0.89130434782609, 0.46304347826087, 0
6866, 0.82608695652174, 0.43695652173913, 0
6867, 0.84782608695652, 0.46304347826087, 0
6868, 0.78260869565217, 0.43695652173913, 0
6869, 0.80434782608696, 0.46304347826087, 0
6870, 0.73913043478261, 0.43695652173913, 0
6871, 0.76086956521739, 0.46304347826087, 0
6872, 0.69565217391304, 0.43695652173913, 0
6873, 0.71739130434783, 0.46304347826087, 0
6874, 0.65217391304348, 0.43695652173913, 0
6875, 0.67391304347826, 0.46304347826087, 0
6876, 0.60869565217391, 0.43695652173913, 0
6877, 0.6304347826087, 0.46304347826087, 0
6878, 0.56521739130435, 0.43695652173913, 0
6879, 0.58695652173913, 0.46304347826087, 0
6880, 0.52173913043478, 0.43695652173913, 0
6881, 0.54347826086957, 0.46304347826087, 0
6882, 0.47826086956522, 0.43695652173913, 0
6883, 0.5, 0.46304347826087, 0
6884, 0.43478260869565, 0.43695652173913, 0
6885, 0.45652173913043, 0.46304347826087, 0
6886, 0.39130434782609, 0.43695652173913, 0
6887, 0.41304347826087, 0.46304347826087, 0
6888, 0.34782608695652, 0.43695652173913, 0
6889, 0.3695652173913, 0.46304347826087, 0
6890, 0.30434782608696, 0.43695652173913, 0
6891, 0.32608695652174, 0.46304347826087, 0
6892, 0.26086956521739, 0.43695652173913, 0
6893, 0.28260869565217, 0.46304347826087, 0
6894, 0.21739130434783, 0.43695652173913, 0
6895, 0.23913043478261, 0.46304347826087, 0
6896, 0.17391304347826, 0.43695652173913, 0
6897, 0.19565217391304, 0.46304347826087, 0
6898, 0.1304347826087, 0.43695652173913, 0
6899, 0.15217391304348, 0.46304347826087, 0
6900, 0.08695652173913, 0.43695652173913, 0
6901, 0.10869565217391, 0.46304347826087, 0
6902, 0.043478260869565, 0.43695652173913, 0
6903, 0.065217391304348, 0.46304347826087, 0
6904, 0.021739130434783, 0.46304347826087, 0
6905, 0.95652173913043, 0.48913043478261, 0
6906, 0.97826086956522, 0.51521739130435, 0
6907, 0.91304347826087, 0.48913043478261, 0
6908, 0.93478260869565, 0.51521739130435, 0
6909, 0.8695652173913, 0.48913043478261, 0
6910, 0.89130434782609, 0.51521739130435, 0
6911, 0.82608695652174, 0.48913043478261, 0
6912, 0.84782608695652, 0.51521739130435, 0
6913, 0.78260869565217, 0.48913043478261, 0
6914, 0.80434782608696, 0.51521739130435, 0
6915, 0.73913043478261, 0.48913043478261, 0
6916, 0.76086956521739, 0.51521739130435, 0
6917, 0.69565217391304, 0.48913043478261, 0
6918, 0.71739130434783, 0.51521739130435, 0
6919, 0.65217391304348, 0.48913043478261, 0
6920, 0.67391304347826, 0.51521739130435, 0
6921, 0.60869565217391, 0.48913043478261, 0
6922, 0.6304347826087, 0.51521739130435, 0
6923, 0.56521739130435, 0.48913043478261, 0
6924, 0.58695652173913, 0.51521739130435, 0
6925, 0.52173913043478, 0.48913043478261, 0
6926, 0.54347826086957, 0.51521739130435, 0
6927, 0.47826086956522, 0.48913043478261, 0
6928, 0.5, 0.51521739130435, 0
6929, 0.43478260869565, 0.48913043478261, 0
6930, 0.45652173913043, 0.51521739130435, 0
6931, 0.39130434782609, 0.48913043478261, 0
6932, 0.41304347826087, 0.51521739130435, 0
6933, 0.34782608695652, 0.48913043478261, 0
6934, 0.3695652173913, 0.51521739130435, 0
6935, 0.30434782608696, 0.48913043478261, 0
6936, 0.32608695652174, 0.51521739130435, 0
6937, 0.26086956521739, 0.48913043478261, 0
6938, 0.28260869565217, 0.51521739130435, 0
6939, 0.21739130434783, 0.48913043478261, 0
6940, 0.23913043478261, 0.51521739130435, 0
6941, 0.17391304347826, 0.48913043478261, 0
6942, 0.19565217391304, 0.51521739130435, 0
6943, 0.1304347826087, 0.48913043478261, 0
6944, 0.15217391304348, 0.51521739130435, 0
6945, 0.08695652173913, 0.48913043478261, 0
6946, 0.10869565217391, 0.51521739130435, 0
6947, 0.043478260869565, 0.48913043478261, 0
6948, 0.065217391304348, 0.51521739130435, 0
6949, 0.021739130434783, 0.51521739130435, 0
6950, 0.95652173913043, 0.54130434782609, 0
6951, 0.97826086956522, 0.56739130434783, 0
6952, 0.91304347826087, 0.54130434782609, 0
6953, 0.93478260869565, 0.56739130434783, 0
6954, 0.8695652173913, 0.54130434782609, 0
6955, 0.89130434782609, 0.56739130434783, 0
6956, 0.82608695652174, 0.54130434782609, 0
6957, 0.84782608695652, 0.56739130434783, 0
6958, 0.78260869565217, 0.54130434782609, 0
6959, 0.80434782608696, 0.56739130434783, 0
6960, 0.73913043478261, 0.54130434782609, 0
6961, 0.76086956521739, 0.56739130434783, 0
6962, 0.69565217391304, 0.54130434782609, 0
6963, 0.71739130434783, 0.56739130434783, 0
6964, 0.65217391304348, 0.54130434782609, 0
6965, 0.67391304347826, 0.56739130434783, 0
6966, 0.60869565217391, 0.54130434782609, 0
6967, 0.6304347826087, 0.56739130434783, 0
6968, 0.56521739130435, 0.54130434782609, 0
6969, 0.58695652173913, 0.56739130434783, 0
6970, 0.52173913043478, 0.54130434782609, 0
6971, 0.54347826086957, 0.56739130434783, 0
6972, 0.47826086956522, 0.54130434782609, 0
6973, 0.5, 0.56739130434783, 0
6974, 0.43478260869565, 0.54130434782609, 0
6975, 0.45652173913043, 0.56739130434783, 0
6976, 0.39130434782609, 0.54130434782609, 0
6977, 0.41304347826087, 0.56739130434783, 0
6978, 0.34782608695652, 0.54130434782609, 0
6979, 0.3695652173913, 0.56739130434783, 0
6980, 0.30434782608696, 0.54130434782609, 0
6981, 0.32608695652174, 0.56739130434783, 0
6982, 0.26086956521739, 0.54130434782609, 0
6983, 0.28260869565217, 0.56739130434783, 0
6984, 0.21739130434783, 0.54130434782609, 0
6985, 0.23913043478261, 0.56739130434783, 0
6986, 0.17391304347826, 0.54130434782609, 0
6987, 0.19565217391304, 0.56739130434783, 0
6988, 0.1304347826087, 0.54130434782609, 0
6989, 0.15217391304348, 0.56739130434783, 0
6990, 0.08695652173913, 0.54130434782609, 0
6991, 0.10869565217391, 0.56739130434783, 0
6992, 0.043478260869565, 0.54130434782609, 0
6993, 0.065217391304348, 0.56739130434783, 0
6994, 0.021739130434783, 0.56739130434783, 0
6995, 0.95652173913043, 0.59347826086956, 0
6996, 0.97826086956522, 0.6195652173913, 0
6997, 0.91304347826087, 0.59347826086956, 0
6998, 0.93478260869565, 0.6195652173913, 0
6999, 0.8695652173913, 0.59347826086956, 0
7000, 0.89130434782609, 0.6195652173913, 0
7001, 0.82608695652174, 0.59347826086956, 0
7002, 0.84782608695652, 0.6195652173913, 0
7003, 0.78260869565217, 0.59347826086956, 0
7004, 0.80434782608696, 0.6195652173913, 0
7005, 0.73913043478261, 0.59347826086956, 0
7006, 0.76086956521739, 0.6195652173913, 0
7007, 0.69565217391304, 0.59347826086956, 0
7008, 0.71739130434783, 0.6195652173913, 0
7009, 0.65217391304348, 0.59347826086956, 0
7010, 0.67391304347826, 0.6195652173913, 0
7011, 0.60869565217391, 0.59347826086956, 0
7012, 0.6304347826087, 0.6195652173913, 0
7013, 0.56521739130435, 0.59347826086956, 0
7014, 0.58695652173913, 0.6195652173913, 0
7015, 0.52173913043478, 0.59347826086956, 0
7016, 0.54347826086957, 0.6195652173913, 0
7017, 0.47826086956522, 0.59347826086956, 0
7018, 0.5, 0.6195652173913, 0
7019, 0.43478260869565, 0.59347826086956, 0
7020, 0.45652173913043, 0.6195652173913, 0
7021, 0.39130434782609, 0.59347826086956, 0
7022, 0.41304347826087, 0.6195652173913, 0
7023, 0.34782608695652, 0.59347826086956, 0
7024, 0.3695652173913, 0.6195652173913, 0
7025, 0.30434782608696, 0.59347826086956, 0
7026, 0.32608695652174, 0.6195652173913, 0
7027, 0.26086956521739, 0.59347826086956, 0
7028, 0.28260869565217, 0.6195652173913, 0
7029, 0.21739130434783, 0.59347826086956, 0
7030, 0.23913043478261, 0.6195652173913, 0
7031, 0.17391304347826, 0.59347826086956, 0
7032, 0.19565217391304, 0.6195652173913, 0
7033, 0.1304347826087, 0.59347826086956, 0
7034, 0.15217391304348, 0.6195652173913, 0
7035, 0.08695652173913, 0.59347826086956, 0
7036, 0.10869565217391, 0.6195652173913, 0
7037, 0.043478260869565, 0.59347826086956, 0
7038, 0.065217391304348, 0.6195652173913, 0
7039, 0.021739130434783, 0.6195652173913, 0
7040, 0.95652173913043, 0.64565217391304, 0
7041, 0.97826086956522, 0.67173913043478, 0
7042, 0.91304347826087, 0.64565217391304, 0
7043, 0.93478260869565, 0.67173913043478, 0
7044, 0.8695652173913, 0.64565217391304, 0
7045, 0.89130434782609, 0.67173913043478, 0
7046, 0.82608695652174, 0.64565217391304, 0
7047, 0.84782608695652, 0.67173913043478, 0
7048, 0.78260869565217, 0.64565217391304, 0
7049, 0.80434782608696, 0.67173913043478, 0
7050, 0.73913043478261, 0.64565217391304, 0
7051, 0.76086956521739, 0.67173913043478, 0
7052, 0.69565217391304, 0.64565217391304, 0
7053, 0.71739130434783, 0.67173913043478, 0
7054, 0.65217391304348, 0.64565217391304, 0
7055, 0.67391304347826, 0.67173913043478, 0
7056, 0.60869565217391, 0.64565217391304, 0
7057, 0.6304347826087, 0.67173913043478, 0
7058, 0.56521739130435, 0.64565217391304, 0
7059, 0.58695652173913, 0.67173913043478, 0
7060, 0.52173913043478, 0.64565217391304, 0
7061, 0.54347826086957, 0.67173913043478, 0
7062, 0.47826086956522, 0.64565217391304, 0
7063, 0.5, 0.67173913043478, 0
7064, 0.43478260869565, 0.64565217391304, 0
7065, 0.45652173913043, 0.67173913043478, 0
7066, 0.39130434782609, 0.64565217391304, 0
7067, 0.41304347826087, 0.67173913043478, 0
7068, 0.34782608695652, 0.64565217391304, 0
7069, 0.3695652173913, 0.67173913043478, 0
7070, 0.30434782608696, 0.64565217391304, 0
7071, 0.32608695652174, 0.67173913043478, 0
7072, 0.26086956521739, 0.64565217391304, 0
7073, 0.28260869565217, 0.67173913043478, 0
7074, 0.21739130434783, 0.64565217391304, 0
7075, 0.23913043478261, 0.67173913043478, 0
7076, 0.17391304347826, 0.64565217391304, 0
7077, 0.19565217391304, 0.67173913043478, 0
7078, 0.1304347826087, 0.64565217391304, 0
7079, 0.15217391304348, 0.67173913043478, 0
7080, 0.08695652173913, 0.64565217391304, 0
7081, 0.10869565217391, 0.67173913043478, 0
7082, 0.043478260869565, 0.64565217391304, 0
7083, 0.065217391304348, 0.67173913043478, 0
7084, 0.021739130434783, 0.67173913043478, 0
7085, 0.95652173913043, 0.69782608695652, 0
7086, 0.97826086956522, 0.72391304347826, 0
7087, 0.91304347826087, 0.69782608695652, 0
7088, 0.93478260869565, 0.72391304347826, 0
7089, 0.8695652173913, 0.69782608695652, 0
7090, 0.89130434782609, 0.72391304347826, 0
7091, 0.82608695652174, 0.69782608695652, 0
7092, 0.84782608695652, 0.72391304347826, 0
7093, 0.78260869565217, 0.69782608695652, 0
7094, 0.80434782608696, 0.72391304347826, 0
7095, 0.73913043478261, 0.69782608695652, 0
7096, 0.76086956521739, 0.72391304347826, 0
7097, 0.69565217391304, 0.69782608695652, 0
7098, 0.71739130434783, 0.72391304347826, 0
7099, 0.65217391304348, 0.69782608695652, 0
7100, 0.67391304347826, 0.72391304347826, 0
7101, 0.60869565217391, 0.69782608695652, 0
7102, 0.6304347826087, 0.72391304347826, 0
7103, 0.56521739130435, 0.69782608695652, 0
7104, 0.58695652173913, 0.72391304347826, 0
7105, 0.52173913043478, 0.69782608695652, 0
7106, 0.54347826086957, 0.72391304347826, 0
7107, 0.47826086956522, 0.69782608695652, 0
7108, 0.5, 0.72391304347826, 0
7109, 0.43478260869565, 0.69782608695652, 0
7110, 0.45652173913043, 0.72391304347826, 0
7111, 0.39130434782609, 0.69782608695652, 0
7112, 0.41304347826087, 0.72391304347826, 0
7113, 0.34782608695652, 0.69782608695652, 0
7114, 0.3695652173913, 0.72391304347826, 0
7115, 0.30434782608696, 0.69782608695652, 0
7116, 0.32608695652174, 0.72391304347826, 0
7117, 0.26086956521739, 0.69782608695652, 0
7118, 0.28260869565217, 0.72391304347826, 0
7119, 0.21739130434783, 0.69782608695652, 0
7120, 0.23913043478261, 0.72391304347826, 0
7121, 0.17391304347826, 0.69782608695652, 0
7122, 0.19565217391304, 0.72391304347826, 0
7123, 0.1304347826087, 0.69782608695652, 0
7124, 0.15217391304348, 0.72391304347826, 0
7125, 0.08695652173913, 0.69782608695652, 0
7126, 0.10869565217391, 0.72391304347826, 0
7127, 0.043478260869565, 0.69782608695652, 0
7128, 0.065217391304348, 0.72391304347826, 0
7129, 0.021739130434783, 0.72391304347826, 0
7130, 0.95652173913043, 0.75, 0
7131, 0.97826086956522, 0.77608695652174, 0
7132, 0.91304347826087, 0.75, 0
7133, 0.93478260869565, 0.77608695652174, 0
7134, 0.8695652173913, 0.75, 0
7135, 0.89130434782609, 0.77608695652174, 0
7136, 0.82608695652174, 0.75, 0
7137, 0.84782608695652, 0.77608695652174, 0
7138, 0.78260869565217, 0.75, 0
7139, 0.80434782608696, 0.77608695652174, 0
7140, 0.73913043478261, 0.75, 0
7141, 0.76086956521739, 0.77608695652174, 0
7142, 0.69565217391304, 0.75, 0
7143, 0.71739130434783, 0.77608695652174, 0
7144, 0.65217391304348, 0.75, 0
7145, 0.67391304347826, 0.77608695652174, 0
7146, 0.60869565217391, 0.75, 0
7147, 0.6304347826087, 0.77608695652174, 0
7148, 0.56521739130435, 0.75, 0
7149, 0.58695652173913, 0.77608695652174, 0
7150, 0.52173913043478, 0.75, 0
7151, 0.54347826086957, 0.77608695652174, 0
7152, 0.47826086956522, 0.75, 0
7153, 0.5, 0.77608695652174, 0
7154, 0.43478260869565, 0.75, 0
7155, 0.45652173913043, 0.77608695652174, 0
7156, 0.39130434782609, 0.75, 0
7157, 0.41304347826087, 0.77608695652174, 0
7158, 0.34782608695652, 0.75, 0
7159, 0.3695652173913, 0.77608695652174, 0
7160, 0.30434782608696, 0.75, 0
7161, 0.32608695652174, 0.77608695652174, 0
7162, 0.26086956521739, 0.75, 0
7163, 0.28260869565217, 0.77608695652174, 0
7164, 0.21739130434783, 0.75, 0
7165, 0.23913043478261, 0.77608695652174, 0
7166, 0.17391304347826, 0.75, 0
7167, 0.19565217391304, 0.77608695652174, 0
7168, 0.1304347826087, 0.75, 0
7169, 0.15217391304348, 0.77608695652174, 0
7170, 0.08695652173913, 0.75, 0
7171, 0.10869565217391, 0.77608695652174, 0
7172, 0.043478260869565, 0.75, 0
7173, 0.065217391304348, 0.77608695652174, 0
7174, 0.021739130434783, 0.77608695652174, 0
7175, 0.95652173913043, 0.80217391304348, 0
7176, 0.97826086956522, 0.82826086956522, 0
7177, 0.91304347826087, 0.80217391304348, 0
7178, 0.93478260869565, 0.82826086956522, 0
7179, 0.8695652173913, 0.80217391304348, 0
7180, 0.89130434782609, 0.82826086956522, 0
7181, 0.82608695652174, 0.80217391304348, 0
7182, 0.84782608695652, 0.82826086956522, 0
7183, 0.78260869565217, 0.80217391304348, 0
7184, 0.80434782608696, 0.82826086956522, 0
7185, 0.73913043478261, 0.80217391304348, 0
7186, 0.76086956521739, 0.82826086956522, 0
7187, 0.69565217391304, 0.80217391304348, 0
7188, 0.71739130434783, 0.82826086956522, 0
7189, 0.65217391304348, 0.80217391304348, 0
7190, 0.67391304347826, 0.82826086956522, 0
7191, 0.60869565217391, 0.80217391304348, 0
7192, 0.6304347826087, 0.82826086956522, 0
7193, 0.56521739130435, 0.80217391304348, 0
7194, 0.58695652173913, 0.82826086956522, 0
7195, 0.52173913043478, 0.80217391304348, 0
7196, 0.54347826086957, 0.82826086956522, 0
7197, 0.47826086956522, 0.80217391304348, 0
7198, 0.5, 0.82826086956522, 0
7199, 0.43478260869565, 0.80217391304348, 0
7200, 0.45652173913043, 0.82826086956522, 0
7201, 0.39130434782609, 0.80217391304348, 0
7202, 0.41304347826087, 0.82826086956522, 0
7203, 0.34782608695652, 0.80217391304348, 0
7204, 0.3695652173913, 0.82826086956522, 0
7205, 0.30434782608696, 0.80217391304348, 0
7206, 0.32608695652174, 0.82826086956522, 0
7207, 0.26086956521739, 0.80217391304348, 0
7208, 0.28260869565217, 0.82826086956522, 0
7209, 0.21739130434783, 0.80217391304348, 0
7210, 0.23913043478261, 0.82826086956522, 0
7211, 0.17391304347826, 0.80217391304348, 0
7212, 0.19565217391304, 0.82826086956522, 0
7213, 0.1304347826087, 0.80217391304348, 0
7214, 0.15217391304348, 0.82826086956522, 0
7215, 0.08695652173913, 0.80217391304348, 0
7216, 0.10869565217391, 0.82826086956522, 0
7217, 0.043478260869565, 0.80217391304348, 0
7218, 0.065217391304348, 0.82826086956522, 0
7219, 0.021739130434783, 0.82826086956522, 0
7220, 0.95652173913043, 0.85434782608696, 0
7221, 0.97826086956522, 0.8804347826087, 0
7222, 0.91304347826087, 0.85434782608696, 0
7223, 0.93478260869565, 0.8804347826087, 0
7224, 0.8695652173913, 0.85434782608696, 0
7225, 0.89130434782609, 0.8804347826087, 0
7226, 0.82608695652174, 0.85434782608696, 0
7227, 0.84782608695652, 0.8804347826087, 0
7228, 0.78260869565217, 0.85434782608696, 0
7229, 0.80434782608696, 0.8804347826087, 0
7230, 0.73913043478261, 0.85434782608696, 0
7231, 0.76086956521739, 0.8804347826087, 0
7232, 0.69565217391304, 0.85434782608696, 0
7233, 0.71739130434783, 0.8804347826087, 0
7234, 0.65217391304348, 0.85434782608696, 0
7235, 0.67391304347826, 0.8804347826087, 0
7236, 0.60869565217391, 0.85434782608696, 0
7237, 0.6304347826087, 0.8804347826087, 0
7238, 0.56521739130435, 0.85434782608696, 0
7239, 0.58695652173913, 0.8804347826087, 0
7240, 0.52173913043478, 0.85434782608696, 0
7241, 0.54347826086957, 0.88043478260869, 0
7242, 0.47826086956522, 0.85434782608696, 0
7243, 0.5, 0.88043478260869, 0
7244, 0.43478260869565, 0.85434782608696, 0
7245, 0.45652173913043, 0.8804347826087, 0
7246, 0.39130434782609, 0.85434782608696, 0
7247, 0.41304347826087, 0.88043478260869, 0
7248, 0.34782608695652, 0.85434782608696, 0
7249, 0.3695652173913, 0.8804347826087, 0
7250, 0.30434782608696, 0.85434782608696, 0
7251, 0.32608695652174, 0.8804347826087, 0
7252, 0.26086956521739, 0.85434782608696, 0
7253, 0.28260869565217, 0.8804347826087, 0
7254, 0.21739130434783, 0.85434782608696, 0
7255, 0.23913043478261, 0.8804347826087, 0
7256, 0.17391304347826, 0.85434782608696, 0
7257, 0.19565217391304, 0.8804347826087, 0
7258, 0.1304347826087, 0.85434782608696, 0
7259, 0.15217391304348, 0.8804347826087, 0
7260, 0.08695652173913, 0.85434782608696, 0
7261, 0.10869565217391, 0.8804347826087, 0
7262, 0.043478260869565, 0.85434782608696, 0
7263, 0.065217391304348, 0.8804347826087, 0
7264, 0.021739130434783, 0.8804347826087, 0
7265, 0.95652173913043, 0.90652173913043, 0
7266, 0.97826086956522, 0.93260869565217, 0
7267, 0.91304347826087, 0.90652173913043, 0
7268, 0.93478260869565, 0.93260869565217, 0
7269, 0.8695652173913, 0.90652173913043, 0
7270, 0.89130434782609, 0.93260869565217, 0
7271, 0.82608695652174, 0.90652173913043, 0
7272, 0.84782608695652, 0.93260869565217, 0
7273, 0.78260869565217, 0.90652173913043, 0
7274, 0.80434782608696, 0.93260869565217, 0
7275, 0.73913043478261, 0.90652173913043, 0
7276, 0.76086956521739, 0.93260869565217, 0
7277, 0.69565217391304, 0.90652173913043, 0
7278, 0.71739130434783, 0.93260869565217, 0
7279, 0.65217391304348, 0.90652173913043, 0
7280, 0.67391304347826, 0.93260869565217, 0
7281, 0.60869565217391, 0.90652173913043, 0
7282, 0.6304347826087, 0.93260869565217, 0
7283, 0.56521739130435, 0.90652173913043, 0
7284, 0.58695652173913, 0.93260869565217, 0
7285, 0.52173913043478, 0.90652173913043, 0
7286, 0.54347826086957, 0.93260869565217, 0
7287, 0.47826086956522, 0.90652173913043, 0
7288, 0.5, 0.93260869565217, 0
7289, 0.43478260869565, 0.90652173913043, 0
7290, 0.45652173913043, 0.93260869565217, 0
7291, 0.39130434782609, 0.90652173913043, 0
7292, 0.41304347826087, 0.93260869565217, 0
7293, 0.34782608695652, 0.90652173913043, 0
7294, 0.3695652173913, 0.93260869565217, 0
7295, 0.30434782608696, 0.90652173913043, 0
7296, 0.32608695652174, 0.93260869565217, 0
7297, 0.26086956521739, 0.90652173913043, 0
7298, 0.28260869565217, 0.93260869565217, 0
7299, 0.21739130434783, 0.90652173913043, 0
7300, 0.23913043478261, 0.93260869565217, 0
7301, 0.17391304347826, 0.90652173913043, 0
7302, 0.19565217391304, 0.93260869565217, 0
7303, 0.1304347826087, 0.90652173913043, 0
7304, 0.15217391304348, 0.93260869565217, 0
7305, 0.08695652173913, 0.90652173913043, 0
7306, 0.10869565217391, 0.93260869565217, 0
7307, 0.043478260869565, 0.90652173913043, 0
7308, 0.065217391304348, 0.93260869565217, 0
7309, 0.021739130434783, 0.93260869565217, 0
7310, 0.95652173913043, 0.95869565217391, 0
7311, 0.97826086956522, 0.98478260869565, 0
7312, 0.91304347826087, 0.95869565217391, 0
7313, 0.93478260869565, 0.98478260869565, 0
7314, 0.8695652173913, 0.95869565217391, 0
7315, 0.89130434782609, 0.98478260869565, 0
7316, 0.82608695652174, 0.95869565217391, 0
7317, 0.84782608695652, 0.98478260869565, 0
7318, 0.78260869565217, 0.95869565217391, 0
7319, 0.80434782608696, 0.98478260869565, 0
7320, 0.73913043478261, 0.95869565217391, 0
7321, 0.76086956521739, 0.98478260869565, 0
7322, 0.69565217391304, 0.95869565217391, 0
7323, 0.71739130434783, 0.98478260869565, 0
7324, 0.65217391304348, 0.95869565217391, 0
7325, 0.67391304347826, 0.98478260869565, 0
7326, 0.60869565217391, 0.95869565217391, 0
7327, 0.6304347826087, 0.98478260869565, 0
7328, 0.56521739130435, 0.95869565217391, 0
7329, 0.58695652173913, 0.98478260869565, 0
7330, 0.52173913043478, 0.95869565217391, 0
7331, 0.54347826086957, 0.98478260869565, 0
7332, 0.47826086956522, 0.95869565217391, 0
7333, 0.5, 0.98478260869565, 0
7334, 0.43478260869565, 0.95869565217391, 0
7335, 0.45652173913043, 0.98478260869565, 0
7336, 0.39130434782609, 0.95869565217391, 0
7337, 0.41304347826087, 0.98478260869565, 0
7338, 0.34782608695652, 0.95869565217391, 0
7339, 0.3695652173913, 0.98478260869565, 0
7340, 0.30434782608696, 0.95869565217391, 0
7341, 0.32608695652174, 0.98478260869565, 0
7342, 0.26086956521739, 0.95869565217391, 0
7343, 0.28260869565217, 0.98478260869565, 0
7344, 0.21739130434783, 0.95869565217391, 0
7345, 0.23913043478261, 0.98478260869565, 0
7346, 0.17391304347826, 0.95869565217391, 0
7347, 0.19565217391304, 0.98478260869565, 0
7348, 0.1304347826087, 0.95869565217391, 0
7349, 0.15217391304348, 0.98478260869565, 0
7350, 0.08695652173913, 0.95869565217391, 0
7351, 0.10869565217391, 0.98478260869565, 0
7352, 0.043478260869565, 0.95869565217391, 0
7353, 0.065217391304348, 0.98478260869565, 0
7354, 0.021739130434783, 0.98478260869565, 0
7355, 0.95652173913043, 1.0108695652174, 0
7356, 0.97826086956522, 1.0369565217391, 0
7357, 0.91304347826087, 1.0108695652174, 0
7358, 0.93478260869565, 1.0369565217391, 0
7359, 0.8695652173913, 1.0108695652174, 0
7360, 0.89130434782609, 1.0369565217391, 0
7361, 0.82608695652174, 1.0108695652174, 0
7362, 0.84782608695652, 1.0369565217391, 0
7363, 0.78260869565217, 1.0108695652174, 0
7364, 0.80434782608696, 1.0369565217391, 0
7365, 0.73913043478261, 1.0108695652174, 0
7366, 0.76086956521739, 1.0369565217391, 0
7367, 0.69565217391304, 1.0108695652174, 0
7368, 0.71739130434783, 1.0369565217391, 0
7369, 0.65217391304348, 1.0108695652174, 0
7370, 0.67391304347826, 1.0369565217391, 0
7371, 0.60869565217391, 1.0108695652174, 0
7372, 0.6304347826087, 1.0369565217391, 0
7373, 0.56521739130435, 1.0108695652174, 0
7374, 0.58695652173913, 1.0369565217391, 0
7375, 0.52173913043478, 1.0108695652174, 0
7376, 0.54347826086957, 1.0369565217391, 0
7377, 0.47826086956522, 1.0108695652174, 0
7378, 0.5, 1.0369565217391, 0
7379, 0.43478260869565, 1.0108695652174, 0
7380, 0.45652173913043, 1.0369565217391, 0
7381, 0.39130434782609, 1.0108695652174, 0
7382, 0.41304347826087, 1.0369565217391, 0
7383, 0.34782608695652, 1.0108695652174, 0
7384, 0.3695652173913, 1.0369565217391, 0
7385, 0.30434782608696, 1.0108695652174, 0
7386, 0.32608695652174, 1.0369565217391, 0
7387, 0.26086956521739, 1.0108695652174, 0
7388, 0.28260869565217, 1.0369565217391, 0
7389, 0.21739130434783, 1.0108695652174, 0
7390, 0.23913043478261, 1.0369565217391, 0
7391, 0.17391304347826, 1.0108695652174, 0
7392, 0.19565217391304, 1.0369565217391, 0
7393, 0.1304347826087, 1.0108695652174, 0
7394, 0.15217391304348, 1.0369565217391, 0
7395, 0.08695652173913, 1.0108695652174, 0
7396, 0.10869565217391, 1.0369565217391, 0
7397, 0.043478260869565, 1.0108695652174, 0
7398, 0.065217391304348, 1.0369565217391, 0
7399, 0.021739130434783, 1.0369565217391, 0
7400, 0.95652173913043, 1.0630434782609, 0
7401, 0.97826086956522, 1.0891304347826, 0
7402, 0.91304347826087, 1.0630434782609, 0
7403, 0.93478260869565, 1.0891304347826, 0
7404, 0.8695652173913, 1.0630434782609, 0
7405, 0.89130434782609, 1.0891304347826, 0
7406, 0.82608695652174, 1.0630434782609, 0
7407, 0.84782608695652, 1.0891304347826, 0
7408, 0.78260869565217, 1.0630434782609, 0
7409, 0.80434782608696, 1.0891304347826, 0
7410, 0.73913043478261, 1.0630434782609, 0
7411, 0.76086956521739, 1.0891304347826, 0
7412, 0.69565217391304, 1.0630434782609, 0
7413, 0.71739130434783, 1.0891304347826, 0
7414, 0.65217391304348, 1.0630434782609, 0
7415, 0.67391304347826, 1.0891304347826, 0
7416, 0.60869565217391, 1.0630434782609, 0
7417, 0.6304347826087, 1.0891304347826, 0
7418, 0.56521739130435, 1.0630434782609, 0
7419, 0.58695652173913, 1.0891304347826, 0
7420, 0.52173913043478, 1.0630434782609, 0
7421, 0.54347826086957, 1.0891304347826, 0
7422, 0.47826086956522, 1.0630434782609, 0
7423, 0.5, 1.0891304347826, 0
7424, 0.43478260869565, 1.0630434782609, 0
7425, 0.45652173913043, 1.0891304347826, 0
7426, 0.39130434782609, 1.0630434782609, 0
7427, 0.41304347826087, 1.0891304347826, 0
7428, 0.34782608695652, 1.0630434782609, 0
7429, 0.3695652173913, 1.0891304347826, 0
7430, 0.30434782608696, 1.0630434782609, 0
7431, 0.32608695652174, 1.0891304347826, 0
7432, 0.26086956521739, 1.0630434782609, 0
7433, 0.28260869565217, 1.0891304347826, 0
7434, 0.21739130434783, 1.0630434782609, 0
7435, 0.23913043478261, 1.0891304347826, 0
7436, 0.17391304347826, 1.0630434782609, 0
7437, 0.19565217391304, 1.0891304347826, 0
7438, 0.1304347826087, 1.0630434782609, 0
7439, 0.15217391304348, 1.0891304347826, 0
7440, 0.08695652173913, 1.0630434782609, 0
7441, 0.10869565217391, 1.0891304347826, 0
7442, 0.043478260869565, 1.0630434782609, 0
7443, 0.065217391304348, 1.0891304347826, 0
7444, 0.021739130434783, 1.0891304347826, 0
7445, 0.95652173913043, 1.1152173913043, 0
7446, 0.97826086956522, 1.1413043478261, 0
7447, 0.91304347826087, 1.1152173913043, 0
7448, 0.93478260869565, 1.1413043478261, 0
7449, 0.8695652173913, 1.1152173913043, 0
7450, 0.89130434782609, 1.1413043478261, 0
7451, 0.82608695652174, 1.1152173913043, 0
7452, 0.84782608695652, 1.1413043478261, 0
7453, 0.78260869565217, 1.1152173913043, 0
7454, 0.80434782608696, 1.1413043478261, 0
7455, 0.73913043478261, 1.1152173913043, 0
7456, 0.76086956521739, 1.1413043478261, 0
7457, 0.69565217391304, 1.1152173913043, 0
7458, 0.71739130434783, 1.1413043478261, 0
7459, 0.65217391304348, 1.1152173913043, 0
7460, 0.67391304347826, 1.1413043478261, 0
7461, 0.60869565217391, 1.1152173913043, 0
7462, 0.6304347826087, 1.1413043478261, 0
7463, 0.56521739130435, 1.1152173913043, 0
7464, 0.58695652173913, 1.1413043478261, 0
7465, 0.52173913043478, 1.1152173913043, 0
7466, 0.54347826086957, 1.1413043478261, 0
7467, 0.47826086956522, 1.1152173913043, 0
7468, 0.5, 1.1413043478261, 0
7469, 0.43478260869565, 1.1152173913043, 0
7470, 0.45652173913043, 1.1413043478261, 0
7471, 0.39130434782609, 1.1152173913043, 0
7472, 0.41304347826087, 1.1413043478261, 0
7473, 0.34782608695652, 1.1152173913043, 0
7474, 0.3695652173913, 1.1413043478261, 0
7475, 0.30434782608696, 1.1152173913043, 0
7476, 0.32608695652174, 1.1413043478261, 0
7477, 0.26086956521739, 1.1152173913043, 0
7478, 0.28260869565217, 1.1413043478261, 0
7479, 0.21739130434783, 1.1152173913043, 0
7480, 0.23913043478261, 1.1413043478261, 0
7481, 0.17391304347826, 1.1152173913043, 0
7482, 0.19565217391304, 1.1413043478261, 0
7483, 0.1304347826087, 1.1152173913043, 0
7484, 0.15217391304348, 1.1413043478261, 0
7485, 0.08695652173913, 1.1152173913043, 0
7486, 0.10869565217391, 1.1413043478261, 0
7487, 0.043478260869565, 1.1152173913043, 0
7488, 0.065217391304348, 1.1413043478261, 0
7489, 0.021739130434783, 1.1413043478261, 0
7490, 0.95652173913043, 1.1673913043478, 0
7491, 0.97826086956522, 1.1934782608696, 0
7492, 0.91304347826087, 1.1673913043478, 0
7493, 0.93478260869565, 1.1934782608696, 0
7494, 0.8695652173913, 1.1673913043478, 0
7495, 0.89130434782609, 1.1934782608696, 0
7496, 0.82608695652174, 1.1673913043478, 0
7497, 0.84782608695652, 1.1934782608696, 0
7498, 0.78260869565217, 1.1673913043478, 0
7499, 0.80434782608696, 1.1934782608696, 0
7500, 0.73913043478261, 1.1673913043478, 0
7501, 0.76086956521739, 1.1934782608696, 0
7502, 0.69565217391304, 1.1673913043478, 0
7503, 0.71739130434783, 1.1934782608696, 0
7504, 0.65217391304348, 1.1673913043478, 0
7505, 0.67391304347826, 1.1934782608696, 0
7506, 0.60869565217391, 1.1673913043478, 0
7507, 0.6304347826087, 1.1934782608696, 0
7508, 0.56521739130435, 1.1673913043478, 0
7509, 0.58695652173913, 1.1934782608696, 0
7510, 0.52173913043478, 1.1673913043478, 0
7511, 0.54347826086957, 1.1934782608696, 0
7512, 0.47826086956522, 1.1673913043478, 0
7513, 0.5, 1.1934782608696, 0
7514, 0.43478260869565, 1.1673913043478, 0
7515, 0.45652173913043, 1.1934782608696, 0
7516, 0.39130434782609, 1.1673913043478, 0
7517, 0.41304347826087, 1.1934782608696, 0
7518, 0.34782608695652, 1.1673913043478, 0
7519, 0.3695652173913, 1.1934782608696, 0
7520, 0.30434782608696, 1.1673913043478, 0
7521, 0.32608695652174, 1.1934782608696, 0
7522, 0.26086956521739, 1.1673913043478, 0
7523, 0.28260869565217, 1.1934782608696, 0
7524, 0.21739130434783, 1.1673913043478, 0
7525, 0.23913043478261, 1.1934782608696, 0
7526, 0.17391304347826, 1.1673913043478, 0
7527, 0.19565217391304, 1.1934782608696, 0
7528, 0.1304347826087, 1.1673913043478, 0
7529, 0.15217391304348, 1.1934782608696, 0
7530, 0.08695652173913, 1.1673913043478, 0
7531, 0.10869565217391, 1.1934782608696, 0
7532, 0.043478260869565, 1.1673913043478, 0
7533, 0.065217391304348, 1.1934782608696, 0
7534, 0.021739130434783, 1.1934782608696, 0
7535, 0.95652173913043, 1.2195652173913, 0
7536, 0.97826086956522, 1.245652173913, 0
7537, 0.91304347826087, 1.2195652173913, 0
7538, 0.93478260869565, 1.245652173913, 0
7539, 0.8695652173913, 1.2195652173913, 0
7540, 0.89130434782609, 1.245652173913, 0
7541, 0.82608695652174, 1.2195652173913, 0
7542, 0.84782608695652, 1.245652173913, 0
7543, 0.78260869565217, 1.2195652173913, 0
7544, 0.80434782608696, 1.245652173913, 0
7545, 0.73913043478261, 1.2195652173913, 0
7546, 0.76086956521739, 1.245652173913, 0
7547, 0.69565217391304, 1.2195652173913, 0
7548, 0.71739130434783, 1.245652173913, 0
7549, 0.65217391304348, 1.2195652173913, 0
7550, 0.67391304347826, 1.245652173913, 0
7551, 0.60869565217391, 1.2195652173913, 0
7552, 0.6304347826087, 1.245652173913, 0
7553, 0.56521739130435, 1.2195652173913, 0
7554, 0.58695652173913, 1.245652173913, 0
7555, 0.52173913043478, 1.2195652173913, 0
7556, 0.54347826086957, 1.245652173913, 0
7557, 0.47826086956522, 1.2195652173913, 0
7558, 0.5, 1.245652173913, 0
7559, 0.43478260869565, 1.2195652173913, 0
7560, 0.45652173913043, 1.245652173913, 0
7561, 0.39130434782609, 1.2195652173913, 0
7562, 0.41304347826087, 1.245652173913, 0
7563, 0.34782608695652, 1.2195652173913, 0
7564, 0.3695652173913, 1.245652173913, 0
7565, 0.30434782608696, 1.2195652173913, 0
7566, 0.32608695652174, 1.245652173913, 0
7567, 0.26086956521739, 1.2195652173913, 0
7568, 0.28260869565217, 1.245652173913, 0
7569, 0.21739130434783, 1.2195652173913, 0
7570, 0.23913043478261, 1.245652173913, 0
7571, 0.17391304347826, 1.2195652173913, 0
7572, 0.19565217391304, 1.245652173913, 0
7573, 0.1304347826087, 1.2195652173913, 0
7574, 0.15217391304348, 1.245652173913, 0
7575, 0.08695652173913, 1.2195652173913, 0
7576, 0.10869565217391, 1.245652173913, 0
7577, 0.043478260869565, 1.2195652173913, 0
7578, 0.065217391304348, 1.245652173913, 0
7579, 0.021739130434783, 1.245652173913, 0
7580, 0.95652173913043, 1.2717391304348, 0
7581, 0.97826086956522, 1.2978260869565, 0
7582, 0.91304347826087, 1.2717391304348, 0
7583, 0.93478260869565, 1.2978260869565, 0
7584, 0.8695652173913, 1.2717391304348, 0
7585, 0.89130434782609, 1.2978260869565, 0
7586, 0.82608695652174, 1.2717391304348, 0
7587, 0.84782608695652, 1.2978260869565, 0
7588, 0.78260869565217, 1.2717391304348, 0
7589, 0.80434782608696, 1.2978260869565, 0
7590, 0.73913043478261, 1.2717391304348, 0
7591, 0.76086956521739, 1.2978260869565, 0
7592, 0.69565217391304, 1.2717391304348, 0
7593, 0.71739130434783, 1.2978260869565, 0
7594, 0.65217391304348, 1.2717391304348, 0
7595, 0.67391304347826, 1.2978260869565, 0
7596, 0.60869565217391, 1.2717391304348, 0
7597, 0.6304347826087, 1.2978260869565, 0
7598, 0.56521739130435, 1.2717391304348, 0
7599, 0.58695652173913, 1.2978260869565, 0
7600, 0.52173913043478, 1.2717391304348, 0
7601, 0.54347826086957, 1.2978260869565, 0
7602, 0.47826086956522, 1.2717391304348, 0
7603, 0.5, 1.2978260869565, 0
7604, 0.43478260869565, 1.2717391304348, 0
7605, 0.45652173913043, 1.2978260869565, 0
7606, 0.39130434782609, 1.2717391304348, 0
7607, 0.41304347826087, 1.2978260869565, 0
7608, 0.34782608695652, 1.2717391304348, 0
7609, 0.3695652173913, 1.2978260869565, 0
7610, 0.30434782608696, 1.2717391304348, 0
7611, 0.32608695652174, 1.2978260869565, 0
7612, 0.26086956521739, 1.2717391304348, 0
7613, 0.28260869565217, 1.2978260869565, 0
7614, 0.21739130434783, 1.2717391304348, 0
7615, 0.23913043478261, 1.2978260869565, 0
7616, 0.17391304347826, 1.2717391304348, 0
7617, 0.19565217391304, 1.2978260869565, 0
7618, 0.1304347826087, 1.2717391304348, 0
7619, 0.15217391304348, 1.2978260869565, 0
7620, 0.08695652173913, 1.2717391304348, 0
7621, 0.10869565217391, 1.2978260869565, 0
7622, 0.043478260869565, 1.2717391304348, 0
7623, 0.065217391304348, 1.2978260869565, 0
7624, 0.021739130434783, 1.2978260869565, 0
7625, 0.95652173913043, 1.3239130434783, 0
7626, 0.91304347826087, 1.3239130434783, 0
7627, 0.8695652173913, 1.3239130434783, 0
7628, 0.82608695652174, 1.3239130434783, 0
7629, 0.78260869565217, 1.3239130434783, 0
7630, 0.73913043478261, 1.3239130434783, 0
7631, 0.69565217391304, 1.3239130434783, 0
7632, 0.65217391304348, 1.3239130434783, 0
7633, 0.60869565217391, 1.3239130434783, 0
7634, 0.56521739130435, 1.3239130434783, 0
7635, 0.52173913043478, 1.3239130434783, 0
7636, 0.47826086956522, 1.3239130434783, 0
7637, 0.43478260869565, 1.3239130434783, 0
7638, 0.39130434782609, 1.3239130434783, 0
7639, 0.34782608695652, 1.3239130434783, 0
7640, 0.30434782608696, 1.3239130434783, 0
7641, 0.26086956521739, 1.3239130434783, 0
7642, 0.21739130434783, 1.3239130434783, 0
7643, 0.17391304347826, 1.3239130434783, 0
7644, 0.1304347826087, 1.3239130434783, 0
7645, 0.08695652173913, 1.3239130434783, 0
7646, 0.043478260869565, 1.3239130434783, 0
7647, 1, 0.20217391304348, 0.45454545454545
7648, 1, 0.20217391304348, 0.40909090909091
7649, 1, 0.20217391304348, 0.36363636363636
7650, 1, 0.20217391304348, 0.31818181818182
7651, 1, 0.20217391304348, 0.27272727272727
7652, 1, 0.20217391304348, 0.22727272727273
7653, 1, 0.20217391304348, 0.18181818181818
7654, 1, 0.20217391304348, 0.13636363636364
7655, 1, 0.20217391304348, 0.090909090909091
7656, 1, 0.20217391304348, 0.045454545454545
7657, 1, 0.25434782608696, 0.45454545454545
7658, 1, 0.25434782608696, 0.40909090909091
7659, 1, 0.25434782608696, 0.36363636363636
7660, 1, 0.25434782608696, 0.31818181818182
7661, 1, 0.25434782608696, 0.27272727272727
7662, 1, 0.25434782608696, 0.22727272727273
7663, 1, 0.25434782608696, 0.18181818181818
7664, 1, 0.25434782608696, 0.13636363636364
7665, 1, 0.25434782608696, 0.090909090909091
7666, 1, 0.25434782608696, 0.045454545454545
7667, 1, 0.30652173913043, 0.45454545454545
7668, 1, 0.30652173913043, 0.40909090909091
7669, 1, 0.30652173913043, 0.36363636363636
7670, 1, 0.30652173913043, 0.31818181818182
7671, 1, 0.30652173913043, 0.27272727272727
7672, 1, 0.30652173913043, 0.22727272727273
7673, 1, 0.30652173913043, 0.18181818181818
7674, 1, 0.30652173913043, 0.13636363636364
7675, 1, 0.30652173913043, 0.090909090909091
7676, 1, 0.30652173913043, 0.045454545454545
7677, 1, 0.35869565217391, 0.45454545454545
7678, 1, 0.35869565217391, 0.40909090909091
7679, 1, 0.35869565217391, 0.36363636363636
7680, 1, 0.35869565217391, 0.31818181818182
7681, 1, 0.35869565217391, 0.27272727272727
7682, 1, 0.35869565217391, 0.22727272727273
7683, 1, 0.35869565217391, 0.18181818181818
7684, 1, 0.35869565217391, 0.13636363636364
7685, 1, 0.35869565217391, 0.090909090909091
7686, 1, 0.35869565217391, 0.045454545454545
7687, 1, 0.41086956521739, 0.45454545454545
7688, 1, 0.41086956521739, 0.40909090909091
7689, 1, 0.41086956521739, 0.36363636363636
7690, 1, 0.41086956521739, 0.31818181818182
7691, 1, 0.41086956521739, 0.27272727272727
7692, 1, 0.41086956521739, 0.22727272727273
7693, 1, 0.41086956521739, 0.18181818181818
7694, 1, 0.41086956521739, 0.13636363636364
7695, 1, 0.41086956521739, 0.090909090909091
7696, 1, 0.41086956521739, 0.045454545454545
7697, 1, 0.46304347826087, 0.45454545454545
7698, 1, 0.46304347826087, 0.40909090909091
7699, 1, 0.46304347826087, 0.36363636363636
7700, 1, 0.46304347826087, 0.31818181818182
7701, 1, 0.46304347826087, 0.27272727272727
7702, 1, 0.46304347826087, 0.22727272727273
7703, 1, 0.46304347826087, 0.18181818181818
7704, 1, 0.46304347826087, 0.13636363636364
7705, 1, 0.46304347826087, 0.090909090909091
7706, 1, 0.46304347826087, 0.045454545454545
7707, 1, 0.51521739130435, 0.45454545454545
7708, 1, 0.51521739130435, 0.40909090909091
7709, 1, 0.51521739130435, 0.36363636363636
7710, 1, 0.51521739130435, 0.31818181818182
7711, 1, 0.51521739130435, 0.27272727272727
7712, 1, 0.51521739130435, 0.22727272727273
7713, 1, 0.51521739130435, 0.18181818181818
7714, 1, 0.51521739130435, 0.13636363636364
7715, 1, 0.51521739130435, 0.090909090909091
7716, 1, 0.51521739130435, 0.045454545454545
7717, 1, 0.56739130434783, 0.45454545454545
7718, 1, 0.56739130434783, 0.40909090909091
7719, 1, 0.56739130434783, 0.36363636363636
7720, 1, 0.56739130434783, 0.31818181818182
7721, 1, 0.56739130434783, 0.27272727272727
7722, 1, 0.56739130434783, 0.22727272727273
7723, 1, 0.56739130434783, 0.18181818181818
7724, 1, 0.56739130434783, 0.13636363636364
7725, 1, 0.56739130434783, 0.090909090909091
7726, 1, 0.56739130434783, 0.045454545454545
7727, 1, 0.6195652173913, 0.45454545454545
7728, 1, 0.6195652173913, 0.40909090909091
7729, 1, 0.6195652173913, 0.36363636363636
7730, 1, 0.6195652173913, 0.31818181818182
7731, 1, 0.6195652173913, 0.27272727272727
7732, 1, 0.6195652173913, 0.22727272727273
7733, 1, 0.6195652173913, 0.18181818181818
7734, 1, 0.6195652173913, 0.13636363636364
7735, 1, 0.6195652173913, 0.090909090909091
7736, 1, 0.6195652173913, 0.045454545454545
7737, 1, 0.67173913043478, 0.45454545454545
7738, 1, 0.67173913043478, 0.40909090909091
7739, 1, 0.67173913043478, 0.36363636363636
7740, 1, 0.67173913043478, 0.31818181818182
7741, 1, 0.67173913043478, 0.27272727272727
7742, 1, 0.67173913043478, 0.22727272727273
7743, 1, 0.67173913043478, 0.18181818181818
7744, 1, 0.67173913043478, 0.13636363636364
7745, 1, 0.67173913043478, 0.090909090909091
7746, 1, 0.67173913043478, 0.045454545454545
7747, 1, 0.72391304347826, 0.45454545454545
7748, 1, 0.72391304347826, 0.40909090909091
7749, 1, 0.72391304347826, 0.36363636363636
7750, 1, 0.72391304347826, 0.31818181818182
7751, 1, 0.72391304347826, 0.27272727272727
7752, 1, 0.72391304347826, 0.22727272727273
7753, 1, 0.72391304347826, 0.18181818181818
7754, 1, 0.72391304347826, 0.13636363636364
7755, 1, 0.72391304347826, 0.090909090909091
7756, 1, 0.72391304347826, 0.045454545454545
7757, 1, 0.77608695652174, 0.45454545454545
7758, 1, 0.77608695652174, 0.40909090909091
7759, 1, 0.77608695652174, 0.36363636363636
7760, 1, 0.77608695652174, 0.31818181818182
7761, 1, 0.77608695652174, 0.27272727272727
7762, 1, 0.77608695652174, 0.22727272727273
7763, 1, 0.77608695652174, 0.18181818181818
7764, 1, 0.77608695652174, 0.13636363636364
7765, 1, 0.77608695652174, 0.090909090909091
7766, 1, 0.77608695652174, 0.045454545454545
7767, 1, 0.82826086956522, 0.45454545454545
7768, 1, 0.82826086956522, 0.40909090909091
7769, 1, 0.82826086956522, 0.36363636363636
7770, 1, 0.82826086956522, 0.31818181818182
7771, 1, 0.82826086956522, 0.27272727272727
7772, 1, 0.82826086956522, 0.22727272727273
7773, 1, 0.82826086956522, 0.18181818181818
7774, 1, 0.82826086956522, 0.13636363636364
7775, 1, 0.82826086956522, 0.090909090909091
7776, 1, 0.82826086956522, 0.045454545454545
7777, 1, 0.8804347826087, 0.45454545454545
7778, 1, 0.8804347826087, 0.40909090909091
7779, 1, 0.8804347826087, 0.36363636363636
7780, 1, 0.8804347826087, 0.31818181818182
7781, 1, 0.8804347826087, 0.27272727272727
7782, 1, 0.8804347826087, 0.22727272727273
7783, 1, 0.8804347826087, 0.18181818181818
7784, 1, 0.8804347826087, 0.13636363636364
7785, 1, 0.8804347826087, 0.090909090909091
7786, 1, 0.8804347826087, 0.045454545454545
7787, 1, 0.93260869565217, 0.45454545454545
7788, 1, 0.93260869565217, 0.40909090909091
7789, 1, 0.93260869565217, 0.36363636363636
7790, 1, 0.93260869565217, 0.31818181818182
7791, 1, 0.93260869565217, 0.27272727272727
7792, 1, 0.93260869565217, 0.22727272727273
7793, 1, 0.93260869565217, 0.18181818181818
7794, 1, 0.93260869565217, 0.13636363636364
7795, 1, 0.93260869565217, 0.090909090909091
7796, 1, 0.93260869565217, 0.045454545454545
7797, 1, 0.98478260869565, 0.45454545454545
7798, 1, 0.98478260869565, 0.40909090909091
7799, 1, 0.98478260869565, 0.36363636363636
7800, 1, 0.98478260869565, 0.31818181818182
7801, 1, 0.98478260869565, 0.27272727272727
7802, 1, 0.98478260869565, 0.22727272727273
7803, 1, 0.98478260869565, 0.18181818181818
7804, 1, 0.98478260869565, 0.13636363636364
7805, 1, 0.98478260869565, 0.090909090909091
7806, 1, 0.98478260869565, 0.045454545454545
7807, 1, 1.0369565217391, 0.45454545454545
7808, 1, 1.0369565217391, 0.40909090909091
7809, 1, 1.0369565217391, 0.36363636363636
7810, 1, 1.0369565217391, 0.31818181818182
7811, 1, 1.0369565217391, 0.27272727272727
7812, 1, 1.0369565217391, 0.22727272727273
7813, 1, 1.0369565217391, 0.18181818181818
7814, 1, 1.0369565217391, 0.13636363636364
7815, 1, 1.0369565217391, 0.090909090909091
7816, 1, 1.0369565217391, 0.045454545454545
7817, 1, 1.0891304347826, 0.45454545454545
7818, 1, 1.0891304347826, 0.40909090909091
7819, 1, 1.0891304347826, 0.36363636363636
7820, 1, 1.0891304347826, 0.31818181818182
7821, 1, 1.0891304347826, 0.27272727272727
7822, 1, 1.0891304347826, 0.22727272727273
7823, 1, 1.0891304347826, 0.18181818181818
7824, 1, 1.0891304347826, 0.13636363636364
7825, 1, 1.0891304347826, 0.090909090909091
7826, 1, 1.0891304347826, 0.045454545454545
7827, 1, 1.1413043478261, 0.45454545454545
7828, 1, 1.1413043478261, 0.40909090909091
7829, 1, 1.1413043478261, 0.36363636363636
7830, 1, 1.1413043478261, 0.31818181818182
7831, 1, 1.1413043478261, 0.27272727272727
7832, 1, 1.1413043478261, 0.22727272727273
7833, 1, 1.1413043478261, 0.18181818181818
7834, 1, 1.1413043478261, 0.13636363636364
7835, 1, 1.1413043478261, 0.090909090909091
7836, 1, 1.1413043478261, 0.045454545454545
7837, 1, 1.1934782608696, 0.45454545454545
7838, 1, 1.1934782608696, 0.40909090909091
7839, 1, 1.1934782608696, 0.36363636363636
7840, 1, 1.1934782608696, 0.31818181818182
7841, 1, 1.1934782608696, 0.27272727272727
7842, 1, 1.1934782608696, 0.22727272727273
7843, 1, 1.1934782608696, 0.18181818181818
7844, 1, 1.1934782608696, 0.13636363636364
7845, 1, 1.1934782608696, 0.090909090909091
7846, 1, 1.1934782608696, 0.045454545454545
7847, 1, 1.245652173913, 0.45454545454545
7848, 1, 1.245652173913, 0.40909090909091
7849, 1, 1.245652173913, 0.36363636363636
7850, 1, 1.245652173913, 0.31818181818182
7851, 1, 1.245652173913, 0.27272727272727
7852, 1, 1.245652173913, 0.22727272727273
7853, 1, 1.245652173913, 0.18181818181818
7854, 1, 1.245652173913, 0.13636363636364
7855, 1, 1.245652173913, 0.090909090909091
7856, 1, 1.245652173913, 0.045454545454545
7857, 1, 1.2978260869565, 0.45454545454545
7858, 1, 1.2978260869565, 0.40909090909091
7859, 1, 1.2978260869565, 0.36363636363636
7860, 1, 1.2978260869565, 0.31818181818182
7861, 1, 1.2978260869565, 0.27272727272727
7862, 1, 1.2978260869565, 0.22727272727273
7863, 1, 1.2978260869565, 0.18181818181818
7864, 1, 1.2978260869565, 0.13636363636364
7865, 1, 1.2978260869565, 0.090909090909091
7866, 1, 1.2978260869565, 0.045454545454545
7867, 1, 0.17608695652174, 0.45454545454545
7868, 1, 0.20217391304348, 0.47727272727273
7869, 1, 0.17608695652174, 0.40909090909091
7870, 1, 0.20217391304348, 0.43181818181818
7871, 1, 0.17608695652174, 0.36363636363636
7872, 1, 0.20217391304348, 0.38636363636364
7873, 1, 0.17608695652174, 0.31818181818182
7874, 1, 0.20217391304348, 0.34090909090909
7875, 1, 0.17608695652174, 0.27272727272727
7876, 1, 0.20217391304348, 0.29545454545455
7877, 1, 0.17608695652174, 0.22727272727273
7878, 1, 0.20217391304348, 0.25
7879, 1, 0.17608695652174, 0.18181818181818
7880, 1, 0.20217391304348, 0.20454545454545
7881, 1, 0.17608695652174, 0.13636363636364
7882, 1, 0.20217391304348, 0.15909090909091
7883, 1, 0.17608695652174, 0.090909090909091
7884, 1, 0.20217391304348, 0.11363636363636
7885, 1, 0.17608695652174, 0.045454545454545
7886, 1, 0.20217391304348, 0.068181818181818
7887, 1, 0.20217391304348, 0.022727272727273
7888, 1, 0.22826086956522, 0.45454545454545
7889, 1, 0.25434782608696, 0.47727272727273
7890, 1, 0.22826086956522, 0.40909090909091
7891, 1, 0.25434782608696, 0.43181818181818
7892, 1, 0.22826086956522, 0.36363636363636
7893, 1, 0.25434782608696, 0.38636363636364
7894, 1, 0.22826086956522, 0.31818181818182
7895, 1, 0.25434782608696, 0.34090909090909
7896, 1, 0.22826086956522, 0.27272727272727
7897, 1, 0.25434782608696, 0.29545454545455
7898, 1, 0.22826086956522, 0.22727272727273
7899, 1, 0.25434782608696, 0.25
7900, 1, 0.22826086956522, 0.18181818181818
7901, 1, 0.25434782608696, 0.20454545454545
7902, 1, 0.22826086956522, 0.13636363636364
7903, 1, 0.25434782608696, 0.15909090909091
7904, 1, 0.22826086956522, 0.090909090909091
7905, 1, 0.25434782608696, 0.11363636363636
7906, 1, 0.22826086956522, 0.045454545454545
7907, 1, 0.25434782608696, 0.068181818181818
7908, 1, 0.25434782608696, 0.022727272727273
7909, 1, 0.2804347826087, 0.45454545454545
