65829, 1.2869565217391, 0.30652173913043, 0.18181818181818
65830, 1.2869565217391, 0.30652173913043, 0.13636363636364
65831, 1.2869565217391, 0.30652173913043, 0.090909090909091
65832, 1.2869565217391, 0.30652173913043, 0.045454545454545
65833, 1.3304347826087, 0.30652173913043, 0.45454545454545
65834, 1.3304347826087, 0.30652173913043, 0.40909090909091
65835, 1.3304347826087, 0.30652173913043, 0.36363636363636
65836, 1.3304347826087, 0.30652173913043, 0.31818181818182
65837, 1.3304347826087, 0.30652173913043, 0.27272727272727
65838, 1.3304347826087, 0.30652173913043, 0.22727272727273
65839, 1.3304347826087, 0.30652173913043, 0.18181818181818
65840, 1.3304347826087, 0.30652173913043, 0.13636363636364
65841, 1.3304347826087, 0.30652173913043, 0.090909090909091
65842, 1.3304347826087, 0.30652173913043, 0.045454545454545
65843, 1.3739130434783, 0.30652173913044, 0.45454545454545
65844, 1.3739130434783, 0.30652173913044, 0.40909090909091
65845, 1.3739130434783, 0.30652173913044, 0.36363636363636
65846, 1.3739130434783, 0.30652173913044, 0.31818181818182
65847, 1.3739130434783, 0.30652173913044, 0.27272727272727
65848, 1.3739130434783, 0.30652173913044, 0.22727272727273
65849, 1.3739130434783, 0.30652173913044, 0.18181818181818
65850, 1.3739130434783, 0.30652173913044, 0.13636363636364
65851, 1.3739130434783, 0.30652173913044, 0.090909090909091
65852, 1.3739130434783, 0.30652173913044, 0.045454545454545
65853, 1.4173913043478, 0.30652173913044, 0.45454545454545
65854, 1.4173913043478, 0.30652173913043, 0.40909090909091
65855, 1.4173913043478, 0.30652173913043, 0.36363636363636
65856, 1.4173913043478, 0.30652173913043, 0.31818181818182
65857, 1.4173913043478, 0.30652173913043, 0.27272727272727
65858, 1.4173913043478, 0.30652173913043, 0.22727272727273
65859, 1.4173913043478, 0.30652173913043, 0.18181818181818
65860, 1.4173913043478, 0.30652173913043, 0.13636363636364
65861, 1.4173913043478, 0.30652173913043, 0.090909090909091
65862, 1.4173913043478, 0.30652173913043, 0.045454545454545
65863, 1.4608695652174, 0.30652173913043, 0.45454545454545
65864, 1.4608695652174, 0.30652173913043, 0.40909090909091
65865, 1.4608695652174, 0.30652173913043, 0.36363636363636
65866, 1.4608695652174, 0.30652173913043, 0.31818181818182
65867, 1.4608695652174, 0.30652173913043, 0.27272727272727
65868, 1.4608695652174, 0.30652173913043, 0.22727272727273
65869, 1.4608695652174, 0.30652173913043, 0.18181818181818
65870, 1.4608695652174, 0.30652173913043, 0.13636363636364
65871, 1.4608695652174, 0.30652173913043, 0.090909090909091
65872, 1.4608695652174, 0.30652173913043, 0.045454545454545
65873, 1.504347826087, 0.30652173913044, 0.45454545454545
65874, 1.504347826087, 0.30652173913044, 0.40909090909091
65875, 1.504347826087, 0.30652173913044, 0.36363636363636
65876, 1.504347826087, 0.30652173913044, 0.31818181818182
65877, 1.504347826087, 0.30652173913044, 0.27272727272727
65878, 1.504347826087, 0.30652173913044, 0.22727272727273
65879, 1.504347826087, 0.30652173913044, 0.18181818181818
65880, 1.504347826087, 0.30652173913044, 0.13636363636364
65881, 1.504347826087, 0.30652173913044, 0.090909090909091
65882, 1.504347826087, 0.30652173913044, 0.045454545454545
65883, 1.5478260869565, 0.30652173913044, 0.45454545454545
65884, 1.5478260869565, 0.30652173913044, 0.40909090909091
65885, 1.5478260869565, 0.30652173913044, 0.36363636363636
65886, 1.5478260869565, 0.30652173913044, 0.31818181818182
65887, 1.5478260869565, 0.30652173913044, 0.27272727272727
65888, 1.5478260869565, 0.30652173913044, 0.22727272727273
65889, 1.5478260869565, 0.30652173913044, 0.18181818181818
65890, 1.5478260869565, 0.30652173913044, 0.13636363636364
65891, 1.5478260869565, 0.30652173913044, 0.090909090909091
65892, 1.5478260869565, 0.30652173913044, 0.045454545454545
65893, 1.5913043478261, 0.30652173913043, 0.45454545454545
65894, 1.5913043478261, 0.30652173913043, 0.40909090909091
65895, 1.5913043478261, 0.30652173913043, 0.36363636363636
65896, 1.5913043478261, 0.30652173913043, 0.31818181818182
65897, 1.5913043478261, 0.30652173913043, 0.27272727272727
65898, 1.5913043478261, 0.30652173913043, 0.22727272727273
65899, 1.5913043478261, 0.30652173913043, 0.18181818181818
65900, 1.5913043478261, 0.30652173913043, 0.13636363636364
65901, 1.5913043478261, 0.30652173913043, 0.090909090909091
65902, 1.5913043478261, 0.30652173913043, 0.045454545454545
65903, 1.6347826086957, 0.30652173913043, 0.45454545454545
65904, 1.6347826086957, 0.30652173913043, 0.40909090909091
65905, 1.6347826086957, 0.30652173913043, 0.36363636363636
65906, 1.6347826086957, 0.30652173913043, 0.31818181818182
65907, 1.6347826086957, 0.30652173913043, 0.27272727272727
65908, 1.6347826086957, 0.30652173913043, 0.22727272727273
65909, 1.6347826086957, 0.30652173913043, 0.18181818181818
65910, 1.6347826086957, 0.30652173913043, 0.13636363636364
65911, 1.6347826086957, 0.30652173913043, 0.090909090909091
65912, 1.6347826086957, 0.30652173913043, 0.045454545454545
65913, 1.6782608695652, 0.30652173913043, 0.45454545454545
65914, 1.6782608695652, 0.30652173913043, 0.40909090909091
65915, 1.6782608695652, 0.30652173913043, 0.36363636363636
65916, 1.6782608695652, 0.30652173913043, 0.31818181818182
65917, 1.6782608695652, 0.30652173913043, 0.27272727272727
65918, 1.6782608695652, 0.30652173913043, 0.22727272727273
65919, 1.6782608695652, 0.30652173913043, 0.18181818181818
65920, 1.6782608695652, 0.30652173913043, 0.13636363636364
65921, 1.6782608695652, 0.30652173913043, 0.090909090909091
65922, 1.6782608695652, 0.30652173913043, 0.045454545454545
65923, 1.7217391304348, 0.30652173913043, 0.45454545454545
65924, 1.7217391304348, 0.30652173913043, 0.40909090909091
65925, 1.7217391304348, 0.30652173913043, 0.36363636363636
65926, 1.7217391304348, 0.30652173913043, 0.31818181818182
65927, 1.7217391304348, 0.30652173913043, 0.27272727272727
65928, 1.7217391304348, 0.30652173913043, 0.22727272727273
65929, 1.7217391304348, 0.30652173913043, 0.18181818181818
65930, 1.7217391304348, 0.30652173913043, 0.13636363636364
65931, 1.7217391304348, 0.30652173913043, 0.090909090909091
65932, 1.7217391304348, 0.30652173913043, 0.045454545454545
65933, 1.7652173913043, 0.30652173913043, 0.45454545454545
65934, 1.7652173913043, 0.30652173913043, 0.40909090909091
65935, 1.7652173913043, 0.30652173913043, 0.36363636363636
65936, 1.7652173913043, 0.30652173913043, 0.31818181818182
65937, 1.7652173913043, 0.30652173913043, 0.27272727272727
65938, 1.7652173913043, 0.30652173913043, 0.22727272727273
65939, 1.7652173913043, 0.30652173913043, 0.18181818181818
65940, 1.7652173913043, 0.30652173913043, 0.13636363636364
65941, 1.7652173913043, 0.30652173913043, 0.090909090909091
65942, 1.7652173913043, 0.30652173913043, 0.045454545454545
65943, 1.8086956521739, 0.30652173913044, 0.45454545454545
65944, 1.8086956521739, 0.30652173913044, 0.40909090909091
65945, 1.8086956521739, 0.30652173913044, 0.36363636363636
65946, 1.8086956521739, 0.30652173913044, 0.31818181818182
65947, 1.8086956521739, 0.30652173913044, 0.27272727272727
65948, 1.8086956521739, 0.30652173913044, 0.22727272727273
65949, 1.8086956521739, 0.30652173913044, 0.18181818181818
65950, 1.8086956521739, 0.30652173913044, 0.13636363636364
65951, 1.8086956521739, 0.30652173913044, 0.090909090909091
65952, 1.8086956521739, 0.30652173913044, 0.045454545454545
65953, 1.8521739130435, 0.30652173913043, 0.45454545454545
65954, 1.8521739130435, 0.30652173913043, 0.40909090909091
65955, 1.8521739130435, 0.30652173913043, 0.36363636363636
65956, 1.8521739130435, 0.30652173913043, 0.31818181818182
65957, 1.8521739130435, 0.30652173913043, 0.27272727272727
65958, 1.8521739130435, 0.30652173913043, 0.22727272727273
65959, 1.8521739130435, 0.30652173913043, 0.18181818181818
65960, 1.8521739130435, 0.30652173913043, 0.13636363636364
65961, 1.8521739130435, 0.30652173913043, 0.090909090909091
65962, 1.8521739130435, 0.30652173913043, 0.045454545454545
65963, 1.895652173913, 0.30652173913044, 0.45454545454545
65964, 1.895652173913, 0.30652173913043, 0.40909090909091
65965, 1.895652173913, 0.30652173913043, 0.36363636363636
65966, 1.895652173913, 0.30652173913043, 0.31818181818182
65967, 1.895652173913, 0.30652173913043, 0.27272727272727
65968, 1.895652173913, 0.30652173913043, 0.22727272727273
65969, 1.895652173913, 0.30652173913043, 0.18181818181818
65970, 1.895652173913, 0.30652173913043, 0.13636363636364
65971, 1.895652173913, 0.30652173913043, 0.090909090909091
65972, 1.895652173913, 0.30652173913043, 0.045454545454545
65973, 1.9391304347826, 0.30652173913043, 0.45454545454545
65974, 1.9391304347826, 0.30652173913043, 0.40909090909091
65975, 1.9391304347826, 0.30652173913043, 0.36363636363636
65976, 1.9391304347826, 0.30652173913043, 0.31818181818182
65977, 1.9391304347826, 0.30652173913043, 0.27272727272727
65978, 1.9391304347826, 0.30652173913043, 0.22727272727273
65979, 1.9391304347826, 0.30652173913043, 0.18181818181818
65980, 1.9391304347826, 0.30652173913043, 0.13636363636364
65981, 1.9391304347826, 0.30652173913043, 0.090909090909091
65982, 1.9391304347826, 0.30652173913043, 0.045454545454545
65983, 1.9826086956522, 0.30652173913044, 0.45454545454545
65984, 1.9826086956522, 0.30652173913044, 0.40909090909091
65985, 1.9826086956522, 0.30652173913044, 0.36363636363636
65986, 1.9826086956522, 0.30652173913044, 0.31818181818182
65987, 1.9826086956522, 0.30652173913044, 0.27272727272727
65988, 1.9826086956522, 0.30652173913044, 0.22727272727273
65989, 1.9826086956522, 0.30652173913044, 0.18181818181818
65990, 1.9826086956522, 0.30652173913044, 0.13636363636364
65991, 1.9826086956522, 0.30652173913044, 0.090909090909091
65992, 1.9826086956522, 0.30652173913044, 0.045454545454545
65993, 2.0260869565217, 0.30652173913044, 0.45454545454545
65994, 2.0260869565217, 0.30652173913044, 0.40909090909091
65995, 2.0260869565217, 0.30652173913044, 0.36363636363636
65996, 2.0260869565217, 0.30652173913044, 0.31818181818182
65997, 2.0260869565217, 0.30652173913044, 0.27272727272727
65998, 2.0260869565217, 0.30652173913044, 0.22727272727273
65999, 2.0260869565217, 0.30652173913044, 0.18181818181818
66000, 2.0260869565217, 0.30652173913044, 0.13636363636364
66001, 2.0260869565217, 0.30652173913044, 0.090909090909091
66002, 2.0260869565217, 0.30652173913044, 0.045454545454545
66003, 2.0695652173913, 0.30652173913043, 0.45454545454545
66004, 2.0695652173913, 0.30652173913043, 0.40909090909091
66005, 2.0695652173913, 0.30652173913043, 0.36363636363636
66006, 2.0695652173913, 0.30652173913043, 0.31818181818182
66007, 2.0695652173913, 0.30652173913043, 0.27272727272727
66008, 2.0695652173913, 0.30652173913043, 0.22727272727273
66009, 2.0695652173913, 0.30652173913043, 0.18181818181818
66010, 2.0695652173913, 0.30652173913043, 0.13636363636364
66011, 2.0695652173913, 0.30652173913043, 0.090909090909091
66012, 2.0695652173913, 0.30652173913043, 0.045454545454545
66013, 2.1130434782609, 0.30652173913043, 0.45454545454545
66014, 2.1130434782609, 0.30652173913043, 0.40909090909091
66015, 2.1130434782609, 0.30652173913043, 0.36363636363636
66016, 2.1130434782609, 0.30652173913043, 0.31818181818182
66017, 2.1130434782609, 0.30652173913043, 0.27272727272727
66018, 2.1130434782609, 0.30652173913043, 0.22727272727273
66019, 2.1130434782609, 0.30652173913043, 0.18181818181818
66020, 2.1130434782609, 0.30652173913043, 0.13636363636364
66021, 2.1130434782609, 0.30652173913043, 0.090909090909091
66022, 2.1130434782609, 0.30652173913043, 0.045454545454545
66023, 2.1565217391304, 0.30652173913043, 0.45454545454545
66024, 2.1565217391304, 0.30652173913043, 0.40909090909091
66025, 2.1565217391304, 0.30652173913043, 0.36363636363636
66026, 2.1565217391304, 0.30652173913043, 0.31818181818182
66027, 2.1565217391304, 0.30652173913043, 0.27272727272727
66028, 2.1565217391304, 0.30652173913043, 0.22727272727273
66029, 2.1565217391304, 0.30652173913043, 0.18181818181818
66030, 2.1565217391304, 0.30652173913043, 0.13636363636364
66031, 2.1565217391304, 0.30652173913043, 0.090909090909091
66032, 2.1565217391304, 0.30652173913043, 0.045454545454545
66033, 1.2434782608696, 0.25434782608696, 0.45454545454545
66034, 1.2434782608696, 0.25434782608696, 0.40909090909091
66035, 1.2434782608696, 0.25434782608696, 0.36363636363636
66036, 1.2434782608696, 0.25434782608696, 0.31818181818182
66037, 1.2434782608696, 0.25434782608696, 0.27272727272727
66038, 1.2434782608696, 0.25434782608696, 0.22727272727273
66039, 1.2434782608696, 0.25434782608696, 0.18181818181818
66040, 1.2434782608696, 0.25434782608696, 0.13636363636364
66041, 1.2434782608696, 0.25434782608696, 0.090909090909091
66042, 1.2434782608696, 0.25434782608696, 0.045454545454545
66043, 1.2869565217391, 0.25434782608696, 0.45454545454545
66044, 1.2869565217391, 0.25434782608696, 0.40909090909091
66045, 1.2869565217391, 0.25434782608696, 0.36363636363636
66046, 1.2869565217391, 0.25434782608696, 0.31818181818182
66047, 1.2869565217391, 0.25434782608696, 0.27272727272727
66048, 1.2869565217391, 0.25434782608696, 0.22727272727273
66049, 1.2869565217391, 0.25434782608696, 0.18181818181818
66050, 1.2869565217391, 0.25434782608696, 0.13636363636364
66051, 1.2869565217391, 0.25434782608696, 0.090909090909091
66052, 1.2869565217391, 0.25434782608696, 0.045454545454545
66053, 1.3304347826087, 0.25434782608696, 0.45454545454545
66054, 1.3304347826087, 0.25434782608696, 0.40909090909091
66055, 1.3304347826087, 0.25434782608696, 0.36363636363636
66056, 1.3304347826087, 0.25434782608696, 0.31818181818182
66057, 1.3304347826087, 0.25434782608696, 0.27272727272727
66058, 1.3304347826087, 0.25434782608696, 0.22727272727273
66059, 1.3304347826087, 0.25434782608696, 0.18181818181818
66060, 1.3304347826087, 0.25434782608696, 0.13636363636364
66061, 1.3304347826087, 0.25434782608696, 0.090909090909091
66062, 1.3304347826087, 0.25434782608696, 0.045454545454545
66063, 1.3739130434783, 0.25434782608696, 0.45454545454545
66064, 1.3739130434783, 0.25434782608696, 0.40909090909091
66065, 1.3739130434783, 0.25434782608696, 0.36363636363636
66066, 1.3739130434783, 0.25434782608696, 0.31818181818182
66067, 1.3739130434783, 0.25434782608696, 0.27272727272727
66068, 1.3739130434783, 0.25434782608696, 0.22727272727273
66069, 1.3739130434783, 0.25434782608696, 0.18181818181818
66070, 1.3739130434783, 0.25434782608696, 0.13636363636364
66071, 1.3739130434783, 0.25434782608696, 0.090909090909091
66072, 1.3739130434783, 0.25434782608696, 0.045454545454545
66073, 1.4173913043478, 0.25434782608696, 0.45454545454545
66074, 1.4173913043478, 0.25434782608696, 0.40909090909091
66075, 1.4173913043478, 0.25434782608696, 0.36363636363636
66076, 1.4173913043478, 0.25434782608696, 0.31818181818182
66077, 1.4173913043478, 0.25434782608696, 0.27272727272727
66078, 1.4173913043478, 0.25434782608696, 0.22727272727273
66079, 1.4173913043478, 0.25434782608696, 0.18181818181818
66080, 1.4173913043478, 0.25434782608696, 0.13636363636364
66081, 1.4173913043478, 0.25434782608696, 0.090909090909091
66082, 1.4173913043478, 0.25434782608696, 0.045454545454545
66083, 1.4608695652174, 0.25434782608696, 0.45454545454545
66084, 1.4608695652174, 0.25434782608696, 0.40909090909091
66085, 1.4608695652174, 0.25434782608696, 0.36363636363636
66086, 1.4608695652174, 0.25434782608696, 0.31818181818182
66087, 1.4608695652174, 0.25434782608696, 0.27272727272727
66088, 1.4608695652174, 0.25434782608696, 0.22727272727273
66089, 1.4608695652174, 0.25434782608696, 0.18181818181818
66090, 1.4608695652174, 0.25434782608696, 0.13636363636364
66091, 1.4608695652174, 0.25434782608696, 0.090909090909091
66092, 1.4608695652174, 0.25434782608696, 0.045454545454545
66093, 1.504347826087, 0.25434782608696, 0.45454545454545
66094, 1.504347826087, 0.25434782608696, 0.40909090909091
66095, 1.504347826087, 0.25434782608696, 0.36363636363636
66096, 1.504347826087, 0.25434782608696, 0.31818181818182
66097, 1.504347826087, 0.25434782608696, 0.27272727272727
66098, 1.504347826087, 0.25434782608696, 0.22727272727273
66099, 1.504347826087, 0.25434782608696, 0.18181818181818
66100, 1.504347826087, 0.25434782608696, 0.13636363636364
66101, 1.504347826087, 0.25434782608696, 0.090909090909091
66102, 1.504347826087, 0.25434782608696, 0.045454545454545
66103, 1.5478260869565, 0.25434782608696, 0.45454545454545
66104, 1.5478260869565, 0.25434782608696, 0.40909090909091
66105, 1.5478260869565, 0.25434782608696, 0.36363636363636
66106, 1.5478260869565, 0.25434782608696, 0.31818181818182
66107, 1.5478260869565, 0.25434782608696, 0.27272727272727
66108, 1.5478260869565, 0.25434782608696, 0.22727272727273
66109, 1.5478260869565, 0.25434782608696, 0.18181818181818
66110, 1.5478260869565, 0.25434782608696, 0.13636363636364
66111, 1.5478260869565, 0.25434782608696, 0.090909090909091
66112, 1.5478260869565, 0.25434782608696, 0.045454545454545
66113, 1.5913043478261, 0.25434782608696, 0.45454545454545
66114, 1.5913043478261, 0.25434782608696, 0.40909090909091
66115, 1.5913043478261, 0.25434782608696, 0.36363636363636
66116, 1.5913043478261, 0.25434782608696, 0.31818181818182
66117, 1.5913043478261, 0.25434782608696, 0.27272727272727
66118, 1.5913043478261, 0.25434782608696, 0.22727272727273
66119, 1.5913043478261, 0.25434782608696, 0.18181818181818
66120, 1.5913043478261, 0.25434782608696, 0.13636363636364
66121, 1.5913043478261, 0.25434782608696, 0.090909090909091
66122, 1.5913043478261, 0.25434782608696, 0.045454545454545
66123, 1.6347826086957, 0.25434782608696, 0.45454545454545
66124, 1.6347826086957, 0.25434782608696, 0.40909090909091
66125, 1.6347826086957, 0.25434782608696, 0.36363636363636
66126, 1.6347826086957, 0.25434782608696, 0.31818181818182
66127, 1.6347826086957, 0.25434782608696, 0.27272727272727
66128, 1.6347826086957, 0.25434782608696, 0.22727272727273
66129, 1.6347826086957, 0.25434782608696, 0.18181818181818
66130, 1.6347826086957, 0.25434782608696, 0.13636363636364
66131, 1.6347826086957, 0.25434782608696, 0.090909090909091
66132, 1.6347826086957, 0.25434782608696, 0.045454545454545
66133, 1.6782608695652, 0.25434782608696, 0.45454545454545
66134, 1.6782608695652, 0.25434782608696, 0.40909090909091
66135, 1.6782608695652, 0.25434782608696, 0.36363636363636
66136, 1.6782608695652, 0.25434782608696, 0.31818181818182
66137, 1.6782608695652, 0.25434782608696, 0.27272727272727
66138, 1.6782608695652, 0.25434782608696, 0.22727272727273
66139, 1.6782608695652, 0.25434782608696, 0.18181818181818
66140, 1.6782608695652, 0.25434782608696, 0.13636363636364
66141, 1.6782608695652, 0.25434782608696, 0.090909090909091
66142, 1.6782608695652, 0.25434782608696, 0.045454545454545
66143, 1.7217391304348, 0.25434782608696, 0.45454545454545
66144, 1.7217391304348, 0.25434782608696, 0.40909090909091
66145, 1.7217391304348, 0.25434782608696, 0.36363636363636
66146, 1.7217391304348, 0.25434782608696, 0.31818181818182
66147, 1.7217391304348, 0.25434782608696, 0.27272727272727
66148, 1.7217391304348, 0.25434782608696, 0.22727272727273
66149, 1.7217391304348, 0.25434782608696, 0.18181818181818
66150, 1.7217391304348, 0.25434782608696, 0.13636363636364
66151, 1.7217391304348, 0.25434782608696, 0.090909090909091
66152, 1.7217391304348, 0.25434782608696, 0.045454545454545
66153, 1.7652173913043, 0.25434782608696, 0.45454545454545
66154, 1.7652173913043, 0.25434782608696, 0.40909090909091
66155, 1.7652173913043, 0.25434782608696, 0.36363636363636
66156, 1.7652173913043, 0.25434782608696, 0.31818181818182
66157, 1.7652173913043, 0.25434782608696, 0.27272727272727
66158, 1.7652173913043, 0.25434782608696, 0.22727272727273
66159, 1.7652173913043, 0.25434782608696, 0.18181818181818
66160, 1.7652173913043, 0.25434782608696, 0.13636363636364
66161, 1.7652173913043, 0.25434782608696, 0.090909090909091
66162, 1.7652173913043, 0.25434782608696, 0.045454545454545
66163, 1.8086956521739, 0.25434782608696, 0.45454545454545
66164, 1.8086956521739, 0.25434782608696, 0.40909090909091
66165, 1.8086956521739, 0.25434782608696, 0.36363636363636
66166, 1.8086956521739, 0.25434782608696, 0.31818181818182
66167, 1.8086956521739, 0.25434782608696, 0.27272727272727
66168, 1.8086956521739, 0.25434782608696, 0.22727272727273
66169, 1.8086956521739, 0.25434782608696, 0.18181818181818
66170, 1.8086956521739, 0.25434782608696, 0.13636363636364
66171, 1.8086956521739, 0.25434782608696, 0.090909090909091
66172, 1.8086956521739, 0.25434782608696, 0.045454545454545
66173, 1.8521739130435, 0.25434782608696, 0.45454545454545
66174, 1.8521739130435, 0.25434782608696, 0.40909090909091
66175, 1.8521739130435, 0.25434782608696, 0.36363636363636
66176, 1.8521739130435, 0.25434782608696, 0.31818181818182
66177, 1.8521739130435, 0.25434782608696, 0.27272727272727
66178, 1.8521739130435, 0.25434782608696, 0.22727272727273
66179, 1.8521739130435, 0.25434782608696, 0.18181818181818
66180, 1.8521739130435, 0.25434782608696, 0.13636363636364
66181, 1.8521739130435, 0.25434782608696, 0.090909090909091
66182, 1.8521739130435, 0.25434782608696, 0.045454545454545
66183, 1.895652173913, 0.25434782608696, 0.45454545454545
66184, 1.895652173913, 0.25434782608696, 0.40909090909091
66185, 1.895652173913, 0.25434782608696, 0.36363636363636
66186, 1.895652173913, 0.25434782608696, 0.31818181818182
66187, 1.895652173913, 0.25434782608696, 0.27272727272727
66188, 1.895652173913, 0.25434782608696, 0.22727272727273
66189, 1.895652173913, 0.25434782608696, 0.18181818181818
66190, 1.895652173913, 0.25434782608696, 0.13636363636364
66191, 1.895652173913, 0.25434782608696, 0.090909090909091
66192, 1.895652173913, 0.25434782608696, 0.045454545454545
66193, 1.9391304347826, 0.25434782608696, 0.45454545454545
66194, 1.9391304347826, 0.25434782608696, 0.40909090909091
66195, 1.9391304347826, 0.25434782608696, 0.36363636363636
66196, 1.9391304347826, 0.25434782608696, 0.31818181818182
66197, 1.9391304347826, 0.25434782608696, 0.27272727272727
66198, 1.9391304347826, 0.25434782608696, 0.22727272727273
66199, 1.9391304347826, 0.25434782608696, 0.18181818181818
66200, 1.9391304347826, 0.25434782608696, 0.13636363636364
66201, 1.9391304347826, 0.25434782608696, 0.090909090909091
66202, 1.9391304347826, 0.25434782608696, 0.045454545454545
66203, 1.9826086956522, 0.25434782608696, 0.45454545454545
66204, 1.9826086956522, 0.25434782608696, 0.40909090909091
66205, 1.9826086956522, 0.25434782608696, 0.36363636363636
66206, 1.9826086956522, 0.25434782608696, 0.31818181818182
66207, 1.9826086956522, 0.25434782608696, 0.27272727272727
66208, 1.9826086956522, 0.25434782608696, 0.22727272727273
66209, 1.9826086956522, 0.25434782608696, 0.18181818181818
66210, 1.9826086956522, 0.25434782608696, 0.13636363636364
66211, 1.9826086956522, 0.25434782608696, 0.090909090909091
66212, 1.9826086956522, 0.25434782608696, 0.045454545454545
66213, 2.0260869565217, 0.25434782608696, 0.45454545454545
66214, 2.0260869565217, 0.25434782608696, 0.40909090909091
66215, 2.0260869565217, 0.25434782608696, 0.36363636363636
66216, 2.0260869565217, 0.25434782608696, 0.31818181818182
66217, 2.0260869565217, 0.25434782608696, 0.27272727272727
66218, 2.0260869565217, 0.25434782608696, 0.22727272727273
66219, 2.0260869565217, 0.25434782608696, 0.18181818181818
66220, 2.0260869565217, 0.25434782608696, 0.13636363636364
66221, 2.0260869565217, 0.25434782608696, 0.090909090909091
66222, 2.0260869565217, 0.25434782608696, 0.045454545454545
66223, 2.0695652173913, 0.25434782608696, 0.45454545454545
66224, 2.0695652173913, 0.25434782608696, 0.40909090909091
66225, 2.0695652173913, 0.25434782608696, 0.36363636363636
66226, 2.0695652173913, 0.25434782608696, 0.31818181818182
66227, 2.0695652173913, 0.25434782608696, 0.27272727272727
66228, 2.0695652173913, 0.25434782608696, 0.22727272727273
66229, 2.0695652173913, 0.25434782608696, 0.18181818181818
66230, 2.0695652173913, 0.25434782608696, 0.13636363636364
66231, 2.0695652173913, 0.25434782608696, 0.090909090909091
66232, 2.0695652173913, 0.25434782608696, 0.045454545454545
66233, 2.1130434782609, 0.25434782608696, 0.45454545454545
66234, 2.1130434782609, 0.25434782608696, 0.40909090909091
66235, 2.1130434782609, 0.25434782608696, 0.36363636363636
66236, 2.1130434782609, 0.25434782608696, 0.31818181818182
66237, 2.1130434782609, 0.25434782608696, 0.27272727272727
66238, 2.1130434782609, 0.25434782608696, 0.22727272727273
66239, 2.1130434782609, 0.25434782608696, 0.18181818181818
66240, 2.1130434782609, 0.25434782608696, 0.13636363636364
66241, 2.1130434782609, 0.25434782608696, 0.090909090909091
66242, 2.1130434782609, 0.25434782608696, 0.045454545454545
66243, 2.1565217391304, 0.25434782608696, 0.45454545454545
66244, 2.1565217391304, 0.25434782608696, 0.40909090909091
66245, 2.1565217391304, 0.25434782608696, 0.36363636363636
66246, 2.1565217391304, 0.25434782608696, 0.31818181818182
66247, 2.1565217391304, 0.25434782608696, 0.27272727272727
66248, 2.1565217391304, 0.25434782608696, 0.22727272727273
66249, 2.1565217391304, 0.25434782608696, 0.18181818181818
66250, 2.1565217391304, 0.25434782608696, 0.13636363636364
66251, 2.1565217391304, 0.25434782608696, 0.090909090909091
66252, 2.1565217391304, 0.25434782608696, 0.045454545454545
66253, 1.2434782608696, 0.20217391304348, 0.45454545454545
66254, 1.2434782608696, 0.20217391304348, 0.40909090909091
66255, 1.2434782608696, 0.20217391304348, 0.36363636363636
66256, 1.2434782608696, 0.20217391304348, 0.31818181818182
66257, 1.2434782608696, 0.20217391304348, 0.27272727272727
66258, 1.2434782608696, 0.20217391304348, 0.22727272727273
66259, 1.2434782608696, 0.20217391304348, 0.18181818181818
66260, 1.2434782608696, 0.20217391304348, 0.13636363636364
66261, 1.2434782608696, 0.20217391304348, 0.090909090909091
66262, 1.2434782608696, 0.20217391304348, 0.045454545454545
66263, 1.2869565217391, 0.20217391304348, 0.45454545454545
66264, 1.2869565217391, 0.20217391304348, 0.40909090909091
66265, 1.2869565217391, 0.20217391304348, 0.36363636363636
66266, 1.2869565217391, 0.20217391304348, 0.31818181818182
66267, 1.2869565217391, 0.20217391304348, 0.27272727272727
66268, 1.2869565217391, 0.20217391304348, 0.22727272727273
66269, 1.2869565217391, 0.20217391304348, 0.18181818181818
66270, 1.2869565217391, 0.20217391304348, 0.13636363636364
66271, 1.2869565217391, 0.20217391304348, 0.090909090909091
66272, 1.2869565217391, 0.20217391304348, 0.045454545454545
66273, 1.3304347826087, 0.20217391304348, 0.45454545454545
66274, 1.3304347826087, 0.20217391304348, 0.40909090909091
66275, 1.3304347826087, 0.20217391304348, 0.36363636363636
66276, 1.3304347826087, 0.20217391304348, 0.31818181818182
66277, 1.3304347826087, 0.20217391304348, 0.27272727272727
66278, 1.3304347826087, 0.20217391304348, 0.22727272727273
66279, 1.3304347826087, 0.20217391304348, 0.18181818181818
66280, 1.3304347826087, 0.20217391304348, 0.13636363636364
66281, 1.3304347826087, 0.20217391304348, 0.090909090909091
66282, 1.3304347826087, 0.20217391304348, 0.045454545454545
66283, 1.3739130434783, 0.20217391304348, 0.45454545454545
66284, 1.3739130434783, 0.20217391304348, 0.40909090909091
66285, 1.3739130434783, 0.20217391304348, 0.36363636363636
66286, 1.3739130434783, 0.20217391304348, 0.31818181818182
66287, 1.3739130434783, 0.20217391304348, 0.27272727272727
66288, 1.3739130434783, 0.20217391304348, 0.22727272727273
66289, 1.3739130434783, 0.20217391304348, 0.18181818181818
66290, 1.3739130434783, 0.20217391304348, 0.13636363636364
66291, 1.3739130434783, 0.20217391304348, 0.090909090909091
66292, 1.3739130434783, 0.20217391304348, 0.045454545454545
66293, 1.4173913043478, 0.20217391304348, 0.45454545454545
66294, 1.4173913043478, 0.20217391304348, 0.40909090909091
66295, 1.4173913043478, 0.20217391304348, 0.36363636363636
66296, 1.4173913043478, 0.20217391304348, 0.31818181818182
66297, 1.4173913043478, 0.20217391304348, 0.27272727272727
66298, 1.4173913043478, 0.20217391304348, 0.22727272727273
66299, 1.4173913043478, 0.20217391304348, 0.18181818181818
66300, 1.4173913043478, 0.20217391304348, 0.13636363636364
66301, 1.4173913043478, 0.20217391304348, 0.090909090909091
66302, 1.4173913043478, 0.20217391304348, 0.045454545454545
66303, 1.4608695652174, 0.20217391304348, 0.45454545454545
66304, 1.4608695652174, 0.20217391304348, 0.40909090909091
66305, 1.4608695652174, 0.20217391304348, 0.36363636363636
66306, 1.4608695652174, 0.20217391304348, 0.31818181818182
66307, 1.4608695652174, 0.20217391304348, 0.27272727272727
66308, 1.4608695652174, 0.20217391304348, 0.22727272727273
66309, 1.4608695652174, 0.20217391304348, 0.18181818181818
66310, 1.4608695652174, 0.20217391304348, 0.13636363636364
66311, 1.4608695652174, 0.20217391304348, 0.090909090909091
66312, 1.4608695652174, 0.20217391304348, 0.045454545454545
66313, 1.504347826087, 0.20217391304348, 0.45454545454545
66314, 1.504347826087, 0.20217391304348, 0.40909090909091
66315, 1.504347826087, 0.20217391304348, 0.36363636363636
66316, 1.504347826087, 0.20217391304348, 0.31818181818182
66317, 1.504347826087, 0.20217391304348, 0.27272727272727
66318, 1.504347826087, 0.20217391304348, 0.22727272727273
66319, 1.504347826087, 0.20217391304348, 0.18181818181818
66320, 1.504347826087, 0.20217391304348, 0.13636363636364
66321, 1.504347826087, 0.20217391304348, 0.090909090909091
66322, 1.504347826087, 0.20217391304348, 0.045454545454545
66323, 1.5478260869565, 0.20217391304348, 0.45454545454545
66324, 1.5478260869565, 0.20217391304348, 0.40909090909091
66325, 1.5478260869565, 0.20217391304348, 0.36363636363636
66326, 1.5478260869565, 0.20217391304348, 0.31818181818182
66327, 1.5478260869565, 0.20217391304348, 0.27272727272727
66328, 1.5478260869565, 0.20217391304348, 0.22727272727273
66329, 1.5478260869565, 0.20217391304348, 0.18181818181818
66330, 1.5478260869565, 0.20217391304348, 0.13636363636364
66331, 1.5478260869565, 0.20217391304348, 0.090909090909091
66332, 1.5478260869565, 0.20217391304348, 0.045454545454545
66333, 1.5913043478261, 0.20217391304348, 0.45454545454545
66334, 1.5913043478261, 0.20217391304348, 0.40909090909091
66335, 1.5913043478261, 0.20217391304348, 0.36363636363636
66336, 1.5913043478261, 0.20217391304348, 0.31818181818182
66337, 1.5913043478261, 0.20217391304348, 0.27272727272727
66338, 1.5913043478261, 0.20217391304348, 0.22727272727273
66339, 1.5913043478261, 0.20217391304348, 0.18181818181818
66340, 1.5913043478261, 0.20217391304348, 0.13636363636364
66341, 1.5913043478261, 0.20217391304348, 0.090909090909091
66342, 1.5913043478261, 0.20217391304348, 0.045454545454545
66343, 1.6347826086957, 0.20217391304348, 0.45454545454545
66344, 1.6347826086957, 0.20217391304348, 0.40909090909091
66345, 1.6347826086957, 0.20217391304348, 0.36363636363636
66346, 1.6347826086957, 0.20217391304348, 0.31818181818182
66347, 1.6347826086957, 0.20217391304348, 0.27272727272727
66348, 1.6347826086957, 0.20217391304348, 0.22727272727273
66349, 1.6347826086957, 0.20217391304348, 0.18181818181818
66350, 1.6347826086957, 0.20217391304348, 0.13636363636364
66351, 1.6347826086957, 0.20217391304348, 0.090909090909091
66352, 1.6347826086957, 0.20217391304348, 0.045454545454545
66353, 1.6782608695652, 0.20217391304348, 0.45454545454545
66354, 1.6782608695652, 0.20217391304348, 0.40909090909091
66355, 1.6782608695652, 0.20217391304348, 0.36363636363636
66356, 1.6782608695652, 0.20217391304348, 0.31818181818182
66357, 1.6782608695652, 0.20217391304348, 0.27272727272727
66358, 1.6782608695652, 0.20217391304348, 0.22727272727273
66359, 1.6782608695652, 0.20217391304348, 0.18181818181818
66360, 1.6782608695652, 0.20217391304348, 0.13636363636364
66361, 1.6782608695652, 0.20217391304348, 0.090909090909091
66362, 1.6782608695652, 0.20217391304348, 0.045454545454545
66363, 1.7217391304348, 0.20217391304348, 0.45454545454545
66364, 1.7217391304348, 0.20217391304348, 0.40909090909091
66365, 1.7217391304348, 0.20217391304348, 0.36363636363636
66366, 1.7217391304348, 0.20217391304348, 0.31818181818182
66367, 1.7217391304348, 0.20217391304348, 0.27272727272727
66368, 1.7217391304348, 0.20217391304348, 0.22727272727273
66369, 1.7217391304348, 0.20217391304348, 0.18181818181818
66370, 1.7217391304348, 0.20217391304348, 0.13636363636364
66371, 1.7217391304348, 0.20217391304348, 0.090909090909091
66372, 1.7217391304348, 0.20217391304348, 0.045454545454545
66373, 1.7652173913043, 0.20217391304348, 0.45454545454545
66374, 1.7652173913043, 0.20217391304348, 0.40909090909091
66375, 1.7652173913043, 0.20217391304348, 0.36363636363636
66376, 1.7652173913043, 0.20217391304348, 0.31818181818182
66377, 1.7652173913043, 0.20217391304348, 0.27272727272727
66378, 1.7652173913043, 0.20217391304348, 0.22727272727273
66379, 1.7652173913043, 0.20217391304348, 0.18181818181818
66380, 1.7652173913043, 0.20217391304348, 0.13636363636364
66381, 1.7652173913043, 0.20217391304348, 0.090909090909091
66382, 1.7652173913043, 0.20217391304348, 0.045454545454545
66383, 1.8086956521739, 0.20217391304348, 0.45454545454545
66384, 1.8086956521739, 0.20217391304348, 0.40909090909091
66385, 1.8086956521739, 0.20217391304348, 0.36363636363636
66386, 1.8086956521739, 0.20217391304348, 0.31818181818182
66387, 1.8086956521739, 0.20217391304348, 0.27272727272727
66388, 1.8086956521739, 0.20217391304348, 0.22727272727273
66389, 1.8086956521739, 0.20217391304348, 0.18181818181818
66390, 1.8086956521739, 0.20217391304348, 0.13636363636364
66391, 1.8086956521739, 0.20217391304348, 0.090909090909091
66392, 1.8086956521739, 0.20217391304348, 0.045454545454545
66393, 1.8521739130435, 0.20217391304348, 0.45454545454545
66394, 1.8521739130435, 0.20217391304348, 0.40909090909091
66395, 1.8521739130435, 0.20217391304348, 0.36363636363636
66396, 1.8521739130435, 0.20217391304348, 0.31818181818182
66397, 1.8521739130435, 0.20217391304348, 0.27272727272727
66398, 1.8521739130435, 0.20217391304348, 0.22727272727273
66399, 1.8521739130435, 0.20217391304348, 0.18181818181818
66400, 1.8521739130435, 0.20217391304348, 0.13636363636364
66401, 1.8521739130435, 0.20217391304348, 0.090909090909091
66402, 1.8521739130435, 0.20217391304348, 0.045454545454545
66403, 1.895652173913, 0.20217391304348, 0.45454545454545
66404, 1.895652173913, 0.20217391304348, 0.40909090909091
66405, 1.895652173913, 0.20217391304348, 0.36363636363636
66406, 1.895652173913, 0.20217391304348, 0.31818181818182
66407, 1.895652173913, 0.20217391304348, 0.27272727272727
66408, 1.895652173913, 0.20217391304348, 0.22727272727273
66409, 1.895652173913, 0.20217391304348, 0.18181818181818
66410, 1.895652173913, 0.20217391304348, 0.13636363636364
66411, 1.895652173913, 0.20217391304348, 0.090909090909091
66412, 1.895652173913, 0.20217391304348, 0.045454545454545
66413, 1.9391304347826, 0.20217391304348, 0.45454545454545
66414, 1.9391304347826, 0.20217391304348, 0.40909090909091
66415, 1.9391304347826, 0.20217391304348, 0.36363636363636
66416, 1.9391304347826, 0.20217391304348, 0.31818181818182
66417, 1.9391304347826, 0.20217391304348, 0.27272727272727
66418, 1.9391304347826, 0.20217391304348, 0.22727272727273
66419, 1.9391304347826, 0.20217391304348, 0.18181818181818
66420, 1.9391304347826, 0.20217391304348, 0.13636363636364
66421, 1.9391304347826, 0.20217391304348, 0.090909090909091
66422, 1.9391304347826, 0.20217391304348, 0.045454545454545
66423, 1.9826086956522, 0.20217391304348, 0.45454545454545
66424, 1.9826086956522, 0.20217391304348, 0.40909090909091
66425, 1.9826086956522, 0.20217391304348, 0.36363636363636
66426, 1.9826086956522, 0.20217391304348, 0.31818181818182
66427, 1.9826086956522, 0.20217391304348, 0.27272727272727
66428, 1.9826086956522, 0.20217391304348, 0.22727272727273
66429, 1.9826086956522, 0.20217391304348, 0.18181818181818
66430, 1.9826086956522, 0.20217391304348, 0.13636363636364
66431, 1.9826086956522, 0.20217391304348, 0.090909090909091
66432, 1.9826086956522, 0.20217391304348, 0.045454545454545
66433, 2.0260869565217, 0.20217391304348, 0.45454545454545
66434, 2.0260869565217, 0.20217391304348, 0.40909090909091
66435, 2.0260869565217, 0.20217391304348, 0.36363636363636
66436, 2.0260869565217, 0.20217391304348, 0.31818181818182
66437, 2.0260869565217, 0.20217391304348, 0.27272727272727
66438, 2.0260869565217, 0.20217391304348, 0.22727272727273
66439, 2.0260869565217, 0.20217391304348, 0.18181818181818
66440, 2.0260869565217, 0.20217391304348, 0.13636363636364
66441, 2.0260869565217, 0.20217391304348, 0.090909090909091
66442, 2.0260869565217, 0.20217391304348, 0.045454545454545
66443, 2.0695652173913, 0.20217391304348, 0.45454545454545
66444, 2.0695652173913, 0.20217391304348, 0.40909090909091
66445, 2.0695652173913, 0.20217391304348, 0.36363636363636
66446, 2.0695652173913, 0.20217391304348, 0.31818181818182
66447, 2.0695652173913, 0.20217391304348, 0.27272727272727
66448, 2.0695652173913, 0.20217391304348, 0.22727272727273
66449, 2.0695652173913, 0.20217391304348, 0.18181818181818
66450, 2.0695652173913, 0.20217391304348, 0.13636363636364
66451, 2.0695652173913, 0.20217391304348, 0.090909090909091
66452, 2.0695652173913, 0.20217391304348, 0.045454545454545
66453, 2.1130434782609, 0.20217391304348, 0.45454545454545
66454, 2.1130434782609, 0.20217391304348, 0.40909090909091
66455, 2.1130434782609, 0.20217391304348, 0.36363636363636
66456, 2.1130434782609, 0.20217391304348, 0.31818181818182
66457, 2.1130434782609, 0.20217391304348, 0.27272727272727
66458, 2.1130434782609, 0.20217391304348, 0.22727272727273
66459, 2.1130434782609, 0.20217391304348, 0.18181818181818
66460, 2.1130434782609, 0.20217391304348, 0.13636363636364
66461, 2.1130434782609, 0.20217391304348, 0.090909090909091
66462, 2.1130434782609, 0.20217391304348, 0.045454545454545
66463, 2.1565217391304, 0.20217391304348, 0.45454545454545
66464, 2.1565217391304, 0.20217391304348, 0.40909090909091
66465, 2.1565217391304, 0.20217391304348, 0.36363636363636
66466, 2.1565217391304, 0.20217391304348, 0.31818181818182
66467, 2.1565217391304, 0.20217391304348, 0.27272727272727
66468, 2.1565217391304, 0.20217391304348, 0.22727272727273
66469, 2.1565217391304, 0.20217391304348, 0.18181818181818
66470, 2.1565217391304, 0.20217391304348, 0.13636363636364
66471, 2.1565217391304, 0.20217391304348, 0.090909090909091
66472, 2.1565217391304, 0.20217391304348, 0.045454545454545
66473, 1.2434782608696, 1.2978260869565, 0.47727272727273
66474, 1.2217391304348, 1.2978260869565, 0.45454545454545
66475, 1.2434782608696, 1.3239130434783, 0.45454545454545
66476, 1.2434782608696, 1.2978260869565, 0.43181818181818
66477, 1.2217391304348, 1.2978260869565, 0.40909090909091
66478, 1.2434782608696, 1.3239130434783, 0.40909090909091
66479, 1.2434782608696, 1.2978260869565, 0.38636363636364
66480, 1.2217391304348, 1.2978260869565, 0.36363636363636
66481, 1.2434782608696, 1.3239130434783, 0.36363636363636
66482, 1.2434782608696, 1.2978260869565, 0.34090909090909
66483, 1.2217391304348, 1.2978260869565, 0.31818181818182
66484, 1.2434782608696, 1.3239130434783, 0.31818181818182
66485, 1.2434782608696, 1.2978260869565, 0.29545454545455
66486, 1.2217391304348, 1.2978260869565, 0.27272727272727
66487, 1.2434782608696, 1.3239130434783, 0.27272727272727
66488, 1.2434782608696, 1.2978260869565, 0.25
66489, 1.2217391304348, 1.2978260869565, 0.22727272727273
66490, 1.2434782608696, 1.3239130434783, 0.22727272727273
66491, 1.2434782608696, 1.2978260869565, 0.20454545454545
66492, 1.2217391304348, 1.2978260869565, 0.18181818181818
66493, 1.2434782608696, 1.3239130434783, 0.18181818181818
66494, 1.2434782608696, 1.2978260869565, 0.15909090909091
66495, 1.2217391304348, 1.2978260869565, 0.13636363636364
66496, 1.2434782608696, 1.3239130434783, 0.13636363636364
66497, 1.2434782608696, 1.2978260869565, 0.11363636363636
66498, 1.2217391304348, 1.2978260869565, 0.090909090909091
66499, 1.2434782608696, 1.3239130434783, 0.090909090909091
66500, 1.2434782608696, 1.2978260869565, 0.068181818181818
66501, 1.2217391304348, 1.2978260869565, 0.045454545454545
66502, 1.2434782608696, 1.3239130434783, 0.045454545454545
66503, 1.2434782608696, 1.2978260869565, 0.022727272727273
66504, 1.2869565217391, 1.2978260869565, 0.47727272727273
66505, 1.2652173913043, 1.2978260869565, 0.45454545454545
66506, 1.2869565217391, 1.3239130434783, 0.45454545454545
66507, 1.2869565217391, 1.2978260869565, 0.43181818181818
66508, 1.2652173913043, 1.2978260869565, 0.40909090909091
66509, 1.2869565217391, 1.3239130434783, 0.40909090909091
66510, 1.2869565217391, 1.2978260869565, 0.38636363636364
66511, 1.2652173913043, 1.2978260869565, 0.36363636363636
66512, 1.2869565217391, 1.3239130434783, 0.36363636363636
66513, 1.2869565217391, 1.2978260869565, 0.34090909090909
66514, 1.2652173913043, 1.2978260869565, 0.31818181818182
66515, 1.2869565217391, 1.3239130434783, 0.31818181818182
66516, 1.2869565217391, 1.2978260869565, 0.29545454545455
66517, 1.2652173913043, 1.2978260869565, 0.27272727272727
66518, 1.2869565217391, 1.3239130434783, 0.27272727272727
66519, 1.2869565217391, 1.2978260869565, 0.25
66520, 1.2652173913043, 1.2978260869565, 0.22727272727273
66521, 1.2869565217391, 1.3239130434783, 0.22727272727273
66522, 1.2869565217391, 1.2978260869565, 0.20454545454545
66523, 1.2652173913043, 1.2978260869565, 0.18181818181818
66524, 1.2869565217391, 1.3239130434783, 0.18181818181818
66525, 1.2869565217391, 1.2978260869565, 0.15909090909091
66526, 1.2652173913043, 1.2978260869565, 0.13636363636364
66527, 1.2869565217391, 1.3239130434783, 0.13636363636364
66528, 1.2869565217391, 1.2978260869565, 0.11363636363636
66529, 1.2652173913043, 1.2978260869565, 0.090909090909091
66530, 1.2869565217391, 1.3239130434783, 0.090909090909091
66531, 1.2869565217391, 1.2978260869565, 0.068181818181818
66532, 1.2652173913043, 1.2978260869565, 0.045454545454545
66533, 1.2869565217391, 1.3239130434783, 0.045454545454545
66534, 1.2869565217391, 1.2978260869565, 0.022727272727273
66535, 1.3304347826087, 1.2978260869565, 0.47727272727273
66536, 1.3086956521739, 1.2978260869565, 0.45454545454545
66537, 1.3304347826087, 1.3239130434783, 0.45454545454545
66538, 1.3304347826087, 1.2978260869565, 0.43181818181818
66539, 1.3086956521739, 1.2978260869565, 0.40909090909091
66540, 1.3304347826087, 1.3239130434783, 0.40909090909091
66541, 1.3304347826087, 1.2978260869565, 0.38636363636364
66542, 1.3086956521739, 1.2978260869565, 0.36363636363636
66543, 1.3304347826087, 1.3239130434783, 0.36363636363636
66544, 1.3304347826087, 1.2978260869565, 0.34090909090909
66545, 1.3086956521739, 1.2978260869565, 0.31818181818182
66546, 1.3304347826087, 1.3239130434783, 0.31818181818182
66547, 1.3304347826087, 1.2978260869565, 0.29545454545455
66548, 1.3086956521739, 1.2978260869565, 0.27272727272727
66549, 1.3304347826087, 1.3239130434783, 0.27272727272727
66550, 1.3304347826087, 1.2978260869565, 0.25
66551, 1.3086956521739, 1.2978260869565, 0.22727272727273
66552, 1.3304347826087, 1.3239130434783, 0.22727272727273
66553, 1.3304347826087, 1.2978260869565, 0.20454545454545
66554, 1.3086956521739, 1.2978260869565, 0.18181818181818
66555, 1.3304347826087, 1.3239130434783, 0.18181818181818
66556, 1.3304347826087, 1.2978260869565, 0.15909090909091
66557, 1.3086956521739, 1.2978260869565, 0.13636363636364
66558, 1.3304347826087, 1.3239130434783, 0.13636363636364
66559, 1.3304347826087, 1.2978260869565, 0.11363636363636
66560, 1.3086956521739, 1.2978260869565, 0.090909090909091
66561, 1.3304347826087, 1.3239130434783, 0.090909090909091
66562, 1.3304347826087, 1.2978260869565, 0.068181818181818
66563, 1.3086956521739, 1.2978260869565, 0.045454545454545
66564, 1.3304347826087, 1.3239130434783, 0.045454545454545
66565, 1.3304347826087, 1.2978260869565, 0.022727272727273
66566, 1.3739130434783, 1.2978260869565, 0.47727272727273
66567, 1.3521739130435, 1.2978260869565, 0.45454545454545
66568, 1.3739130434783, 1.3239130434783, 0.45454545454545
66569, 1.3739130434783, 1.2978260869565, 0.43181818181818
66570, 1.3521739130435, 1.2978260869565, 0.40909090909091
66571, 1.3739130434783, 1.3239130434783, 0.40909090909091
66572, 1.3739130434783, 1.2978260869565, 0.38636363636364
66573, 1.3521739130435, 1.2978260869565, 0.36363636363636
66574, 1.3739130434783, 1.3239130434783, 0.36363636363636
66575, 1.3739130434783, 1.2978260869565, 0.34090909090909
66576, 1.3521739130435, 1.2978260869565, 0.31818181818182
66577, 1.3739130434783, 1.3239130434783, 0.31818181818182
66578, 1.3739130434783, 1.2978260869565, 0.29545454545455
66579, 1.3521739130435, 1.2978260869565, 0.27272727272727
66580, 1.3739130434783, 1.3239130434783, 0.27272727272727
66581, 1.3739130434783, 1.2978260869565, 0.25
66582, 1.3521739130435, 1.2978260869565, 0.22727272727273
66583, 1.3739130434783, 1.3239130434783, 0.22727272727273
66584, 1.3739130434783, 1.2978260869565, 0.20454545454545
66585, 1.3521739130435, 1.2978260869565, 0.18181818181818
66586, 1.3739130434783, 1.3239130434783, 0.18181818181818
66587, 1.3739130434783, 1.2978260869565, 0.15909090909091
66588, 1.3521739130435, 1.2978260869565, 0.13636363636364
66589, 1.3739130434783, 1.3239130434783, 0.13636363636364
66590, 1.3739130434783, 1.2978260869565, 0.11363636363636
66591, 1.3521739130435, 1.2978260869565, 0.090909090909091
66592, 1.3739130434783, 1.3239130434783, 0.090909090909091
66593, 1.3739130434783, 1.2978260869565, 0.068181818181818
66594, 1.3521739130435, 1.2978260869565, 0.045454545454545
66595, 1.3739130434783, 1.3239130434783, 0.045454545454545
66596, 1.3739130434783, 1.2978260869565, 0.022727272727273
66597, 1.4173913043478, 1.2978260869565, 0.47727272727273
66598, 1.395652173913, 1.2978260869565, 0.45454545454545
66599, 1.4173913043478, 1.3239130434783, 0.45454545454545
66600, 1.4173913043478, 1.2978260869565, 0.43181818181818
66601, 1.395652173913, 1.2978260869565, 0.40909090909091
66602, 1.4173913043478, 1.3239130434783, 0.40909090909091
66603, 1.4173913043478, 1.2978260869565, 0.38636363636364
66604, 1.395652173913, 1.2978260869565, 0.36363636363636
66605, 1.4173913043478, 1.3239130434783, 0.36363636363636
66606, 1.4173913043478, 1.2978260869565, 0.34090909090909
66607, 1.395652173913, 1.2978260869565, 0.31818181818182
66608, 1.4173913043478, 1.3239130434783, 0.31818181818182
66609, 1.4173913043478, 1.2978260869565, 0.29545454545455
66610, 1.395652173913, 1.2978260869565, 0.27272727272727
66611, 1.4173913043478, 1.3239130434783, 0.27272727272727
66612, 1.4173913043478, 1.2978260869565, 0.25
66613, 1.395652173913, 1.2978260869565, 0.22727272727273
66614, 1.4173913043478, 1.3239130434783, 0.22727272727273
66615, 1.4173913043478, 1.2978260869565, 0.20454545454545
66616, 1.395652173913, 1.2978260869565, 0.18181818181818
66617, 1.4173913043478, 1.3239130434783, 0.18181818181818
66618, 1.4173913043478, 1.2978260869565, 0.15909090909091
66619, 1.395652173913, 1.2978260869565, 0.13636363636364
66620, 1.4173913043478, 1.3239130434783, 0.13636363636364
66621, 1.4173913043478, 1.2978260869565, 0.11363636363636
66622, 1.395652173913, 1.2978260869565, 0.090909090909091
66623, 1.4173913043478, 1.3239130434783, 0.090909090909091
66624, 1.4173913043478, 1.2978260869565, 0.068181818181818
66625, 1.395652173913, 1.2978260869565, 0.045454545454545
66626, 1.4173913043478, 1.3239130434783, 0.045454545454545
66627, 1.4173913043478, 1.2978260869565, 0.022727272727273
66628, 1.4608695652174, 1.2978260869565, 0.47727272727273
66629, 1.4391304347826, 1.2978260869565, 0.45454545454545
66630, 1.4608695652174, 1.3239130434783, 0.45454545454545
66631, 1.4608695652174, 1.2978260869565, 0.43181818181818
66632, 1.4391304347826, 1.2978260869565, 0.40909090909091
66633, 1.4608695652174, 1.3239130434783, 0.40909090909091
66634, 1.4608695652174, 1.2978260869565, 0.38636363636364
66635, 1.4391304347826, 1.2978260869565, 0.36363636363636
66636, 1.4608695652174, 1.3239130434783, 0.36363636363636
66637, 1.4608695652174, 1.2978260869565, 0.34090909090909
66638, 1.4391304347826, 1.2978260869565, 0.31818181818182
66639, 1.4608695652174, 1.3239130434783, 0.31818181818182
66640, 1.4608695652174, 1.2978260869565, 0.29545454545455
66641, 1.4391304347826, 1.2978260869565, 0.27272727272727
66642, 1.4608695652174, 1.3239130434783, 0.27272727272727
66643, 1.4608695652174, 1.2978260869565, 0.25
66644, 1.4391304347826, 1.2978260869565, 0.22727272727273
66645, 1.4608695652174, 1.3239130434783, 0.22727272727273
66646, 1.4608695652174, 1.2978260869565, 0.20454545454545
66647, 1.4391304347826, 1.2978260869565, 0.18181818181818
66648, 1.4608695652174, 1.3239130434783, 0.18181818181818
66649, 1.4608695652174, 1.2978260869565, 0.15909090909091
66650, 1.4391304347826, 1.2978260869565, 0.13636363636364
66651, 1.4608695652174, 1.3239130434783, 0.13636363636364
66652, 1.4608695652174, 1.2978260869565, 0.11363636363636
66653, 1.4391304347826, 1.2978260869565, 0.090909090909091
66654, 1.4608695652174, 1.3239130434783, 0.090909090909091
66655, 1.4608695652174, 1.2978260869565, 0.068181818181818
66656, 1.4391304347826, 1.2978260869565, 0.045454545454545
66657, 1.4608695652174, 1.3239130434783, 0.045454545454545
66658, 1.4608695652174, 1.2978260869565, 0.022727272727273
66659, 1.504347826087, 1.2978260869565, 0.47727272727273
66660, 1.4826086956522, 1.2978260869565, 0.45454545454545
66661, 1.504347826087, 1.3239130434783, 0.45454545454545
66662, 1.504347826087, 1.2978260869565, 0.43181818181818
66663, 1.4826086956522, 1.2978260869565, 0.40909090909091
66664, 1.504347826087, 1.3239130434783, 0.40909090909091
66665, 1.504347826087, 1.2978260869565, 0.38636363636364
66666, 1.4826086956522, 1.2978260869565, 0.36363636363636
66667, 1.504347826087, 1.3239130434783, 0.36363636363636
66668, 1.504347826087, 1.2978260869565, 0.34090909090909
66669, 1.4826086956522, 1.2978260869565, 0.31818181818182
66670, 1.504347826087, 1.3239130434783, 0.31818181818182
66671, 1.504347826087, 1.2978260869565, 0.29545454545455
66672, 1.4826086956522, 1.2978260869565, 0.27272727272727
66673, 1.504347826087, 1.3239130434783, 0.27272727272727
66674, 1.504347826087, 1.2978260869565, 0.25
66675, 1.4826086956522, 1.2978260869565, 0.22727272727273
66676, 1.504347826087, 1.3239130434783, 0.22727272727273
66677, 1.504347826087, 1.2978260869565, 0.20454545454545
66678, 1.4826086956522, 1.2978260869565, 0.18181818181818
66679, 1.504347826087, 1.3239130434783, 0.18181818181818
66680, 1.504347826087, 1.2978260869565, 0.15909090909091
66681, 1.4826086956522, 1.2978260869565, 0.13636363636364
66682, 1.504347826087, 1.3239130434783, 0.13636363636364
66683, 1.504347826087, 1.2978260869565, 0.11363636363636
66684, 1.4826086956522, 1.2978260869565, 0.090909090909091
66685, 1.504347826087, 1.3239130434783, 0.090909090909091
66686, 1.504347826087, 1.2978260869565, 0.068181818181818
66687, 1.4826086956522, 1.2978260869565, 0.045454545454545
66688, 1.504347826087, 1.3239130434783, 0.045454545454545
66689, 1.504347826087, 1.2978260869565, 0.022727272727273
66690, 1.5478260869565, 1.2978260869565, 0.47727272727273
66691, 1.5260869565217, 1.2978260869565, 0.45454545454545
66692, 1.5478260869565, 1.3239130434783, 0.45454545454545
66693, 1.5478260869565, 1.2978260869565, 0.43181818181818
66694, 1.5260869565217, 1.2978260869565, 0.40909090909091
66695, 1.5478260869565, 1.3239130434783, 0.40909090909091
66696, 1.5478260869565, 1.2978260869565, 0.38636363636364
66697, 1.5260869565217, 1.2978260869565, 0.36363636363636
66698, 1.5478260869565, 1.3239130434783, 0.36363636363636
66699, 1.5478260869565, 1.2978260869565, 0.34090909090909
66700, 1.5260869565217, 1.2978260869565, 0.31818181818182
66701, 1.5478260869565, 1.3239130434783, 0.31818181818182
66702, 1.5478260869565, 1.2978260869565, 0.29545454545455
66703, 1.5260869565217, 1.2978260869565, 0.27272727272727
66704, 1.5478260869565, 1.3239130434783, 0.27272727272727
66705, 1.5478260869565, 1.2978260869565, 0.25
66706, 1.5260869565217, 1.2978260869565, 0.22727272727273
66707, 1.5478260869565, 1.3239130434783, 0.22727272727273
66708, 1.5478260869565, 1.2978260869565, 0.20454545454545
66709, 1.5260869565217, 1.2978260869565, 0.18181818181818
66710, 1.5478260869565, 1.3239130434783, 0.18181818181818
66711, 1.5478260869565, 1.2978260869565, 0.15909090909091
66712, 1.5260869565217, 1.2978260869565, 0.13636363636364
66713, 1.5478260869565, 1.3239130434783, 0.13636363636364
66714, 1.5478260869565, 1.2978260869565, 0.11363636363636
66715, 1.5260869565217, 1.2978260869565, 0.090909090909091
66716, 1.5478260869565, 1.3239130434783, 0.090909090909091
66717, 1.5478260869565, 1.2978260869565, 0.068181818181818
66718, 1.5260869565217, 1.2978260869565, 0.045454545454545
66719, 1.5478260869565, 1.3239130434783, 0.045454545454545
66720, 1.5478260869565, 1.2978260869565, 0.022727272727273
66721, 1.5913043478261, 1.2978260869565, 0.47727272727273
66722, 1.5695652173913, 1.2978260869565, 0.45454545454545
66723, 1.5913043478261, 1.3239130434783, 0.45454545454545
66724, 1.5913043478261, 1.2978260869565, 0.43181818181818
66725, 1.5695652173913, 1.2978260869565, 0.40909090909091
66726, 1.5913043478261, 1.3239130434783, 0.40909090909091
66727, 1.5913043478261, 1.2978260869565, 0.38636363636364
66728, 1.5695652173913, 1.2978260869565, 0.36363636363636
66729, 1.5913043478261, 1.3239130434783, 0.36363636363636
66730, 1.5913043478261, 1.2978260869565, 0.34090909090909
66731, 1.5695652173913, 1.2978260869565, 0.31818181818182
66732, 1.5913043478261, 1.3239130434783, 0.31818181818182
66733, 1.5913043478261, 1.2978260869565, 0.29545454545455
66734, 1.5695652173913, 1.2978260869565, 0.27272727272727
66735, 1.5913043478261, 1.3239130434783, 0.27272727272727
66736, 1.5913043478261, 1.2978260869565, 0.25
66737, 1.5695652173913, 1.2978260869565, 0.22727272727273
66738, 1.5913043478261, 1.3239130434783, 0.22727272727273
66739, 1.5913043478261, 1.2978260869565, 0.20454545454545
66740, 1.5695652173913, 1.2978260869565, 0.18181818181818
66741, 1.5913043478261, 1.3239130434783, 0.18181818181818
66742, 1.5913043478261, 1.2978260869565, 0.15909090909091
66743, 1.5695652173913, 1.2978260869565, 0.13636363636364
66744, 1.5913043478261, 1.3239130434783, 0.13636363636364
66745, 1.5913043478261, 1.2978260869565, 0.11363636363636
66746, 1.5695652173913, 1.2978260869565, 0.090909090909091
66747, 1.5913043478261, 1.3239130434783, 0.090909090909091
66748, 1.5913043478261, 1.2978260869565, 0.068181818181818
66749, 1.5695652173913, 1.2978260869565, 0.045454545454545
66750, 1.5913043478261, 1.3239130434783, 0.045454545454545
66751, 1.5913043478261, 1.2978260869565, 0.022727272727273
66752, 1.6347826086957, 1.2978260869565, 0.47727272727273
66753, 1.6130434782609, 1.2978260869565, 0.45454545454545
66754, 1.6347826086957, 1.3239130434783, 0.45454545454545
66755, 1.6347826086957, 1.2978260869565, 0.43181818181818
66756, 1.6130434782609, 1.2978260869565, 0.40909090909091
66757, 1.6347826086957, 1.3239130434783, 0.40909090909091
66758, 1.6347826086957, 1.2978260869565, 0.38636363636364
66759, 1.6130434782609, 1.2978260869565, 0.36363636363636
66760, 1.6347826086957, 1.3239130434783, 0.36363636363636
66761, 1.6347826086957, 1.2978260869565, 0.34090909090909
66762, 1.6130434782609, 1.2978260869565, 0.31818181818182
66763, 1.6347826086957, 1.3239130434783, 0.31818181818182
66764, 1.6347826086957, 1.2978260869565, 0.29545454545455
66765, 1.6130434782609, 1.2978260869565, 0.27272727272727
66766, 1.6347826086957, 1.3239130434783, 0.27272727272727
66767, 1.6347826086957, 1.2978260869565, 0.25
66768, 1.6130434782609, 1.2978260869565, 0.22727272727273
66769, 1.6347826086957, 1.3239130434783, 0.22727272727273
66770, 1.6347826086957, 1.2978260869565, 0.20454545454545
66771, 1.6130434782609, 1.2978260869565, 0.18181818181818
66772, 1.6347826086957, 1.3239130434783, 0.18181818181818
66773, 1.6347826086957, 1.2978260869565, 0.15909090909091
66774, 1.6130434782609, 1.2978260869565, 0.13636363636364
66775, 1.6347826086957, 1.3239130434783, 0.13636363636364
66776, 1.6347826086957, 1.2978260869565, 0.11363636363636
66777, 1.6130434782609, 1.2978260869565, 0.090909090909091
66778, 1.6347826086957, 1.3239130434783, 0.090909090909091
66779, 1.6347826086957, 1.2978260869565, 0.068181818181818
66780, 1.6130434782609, 1.2978260869565, 0.045454545454545
66781, 1.6347826086957, 1.3239130434783, 0.045454545454545
66782, 1.6347826086957, 1.2978260869565, 0.022727272727273
66783, 1.6782608695652, 1.2978260869565, 0.47727272727273
66784, 1.6565217391304, 1.2978260869565, 0.45454545454545
66785, 1.6782608695652, 1.3239130434783, 0.45454545454545
66786, 1.6782608695652, 1.2978260869565, 0.43181818181818
66787, 1.6565217391304, 1.2978260869565, 0.40909090909091
66788, 1.6782608695652, 1.3239130434783, 0.40909090909091
66789, 1.6782608695652, 1.2978260869565, 0.38636363636364
66790, 1.6565217391304, 1.2978260869565, 0.36363636363636
66791, 1.6782608695652, 1.3239130434783, 0.36363636363636
66792, 1.6782608695652, 1.2978260869565, 0.34090909090909
66793, 1.6565217391304, 1.2978260869565, 0.31818181818182
66794, 1.6782608695652, 1.3239130434783, 0.31818181818182
66795, 1.6782608695652, 1.2978260869565, 0.29545454545455
66796, 1.6565217391304, 1.2978260869565, 0.27272727272727
66797, 1.6782608695652, 1.3239130434783, 0.27272727272727
66798, 1.6782608695652, 1.2978260869565, 0.25
66799, 1.6565217391304, 1.2978260869565, 0.22727272727273
66800, 1.6782608695652, 1.3239130434783, 0.22727272727273
66801, 1.6782608695652, 1.2978260869565, 0.20454545454545
66802, 1.6565217391304, 1.2978260869565, 0.18181818181818
66803, 1.6782608695652, 1.3239130434783, 0.18181818181818
66804, 1.6782608695652, 1.2978260869565, 0.15909090909091
66805, 1.6565217391304, 1.2978260869565, 0.13636363636364
66806, 1.6782608695652, 1.3239130434783, 0.13636363636364
66807, 1.6782608695652, 1.2978260869565, 0.11363636363636
66808, 1.6565217391304, 1.2978260869565, 0.090909090909091
66809, 1.6782608695652, 1.3239130434783, 0.090909090909091
66810, 1.6782608695652, 1.2978260869565, 0.068181818181818
66811, 1.6565217391304, 1.2978260869565, 0.045454545454545
66812, 1.6782608695652, 1.3239130434783, 0.045454545454545
66813, 1.6782608695652, 1.2978260869565, 0.022727272727273
66814, 1.7217391304348, 1.2978260869565, 0.47727272727273
66815, 1.7, 1.2978260869565, 0.45454545454545
66816, 1.7217391304348, 1.3239130434783, 0.45454545454545
66817, 1.7217391304348, 1.2978260869565, 0.43181818181818
66818, 1.7, 1.2978260869565, 0.40909090909091
66819, 1.7217391304348, 1.3239130434783, 0.40909090909091
66820, 1.7217391304348, 1.2978260869565, 0.38636363636364
66821, 1.7, 1.2978260869565, 0.36363636363636
66822, 1.7217391304348, 1.3239130434783, 0.36363636363636
66823, 1.7217391304348, 1.2978260869565, 0.34090909090909
66824, 1.7, 1.2978260869565, 0.31818181818182
66825, 1.7217391304348, 1.3239130434783, 0.31818181818182
66826, 1.7217391304348, 1.2978260869565, 0.29545454545455
66827, 1.7, 1.2978260869565, 0.27272727272727
66828, 1.7217391304348, 1.3239130434783, 0.27272727272727
66829, 1.7217391304348, 1.2978260869565, 0.25
66830, 1.7, 1.2978260869565, 0.22727272727273
66831, 1.7217391304348, 1.3239130434783, 0.22727272727273
66832, 1.7217391304348, 1.2978260869565, 0.20454545454545
66833, 1.7, 1.2978260869565, 0.18181818181818
66834, 1.7217391304348, 1.3239130434783, 0.18181818181818
66835, 1.7217391304348, 1.2978260869565, 0.15909090909091
66836, 1.7, 1.2978260869565, 0.13636363636364
66837, 1.7217391304348, 1.3239130434783, 0.13636363636364
66838, 1.7217391304348, 1.2978260869565, 0.11363636363636
66839, 1.7, 1.2978260869565, 0.090909090909091
66840, 1.7217391304348, 1.3239130434783, 0.090909090909091
66841, 1.7217391304348, 1.2978260869565, 0.068181818181818
66842, 1.7, 1.2978260869565, 0.045454545454545
66843, 1.7217391304348, 1.3239130434783, 0.045454545454545
66844, 1.7217391304348, 1.2978260869565, 0.022727272727273
66845, 1.7652173913043, 1.2978260869565, 0.47727272727273
66846, 1.7434782608696, 1.2978260869565, 0.45454545454545
66847, 1.7652173913043, 1.3239130434783, 0.45454545454545
66848, 1.7652173913043, 1.2978260869565, 0.43181818181818
66849, 1.7434782608696, 1.2978260869565, 0.40909090909091
66850, 1.7652173913043, 1.3239130434783, 0.40909090909091
66851, 1.7652173913043, 1.2978260869565, 0.38636363636364
66852, 1.7434782608696, 1.2978260869565, 0.36363636363636
66853, 1.7652173913043, 1.3239130434783, 0.36363636363636
66854, 1.7652173913043, 1.2978260869565, 0.34090909090909
66855, 1.7434782608696, 1.2978260869565, 0.31818181818182
66856, 1.7652173913043, 1.3239130434783, 0.31818181818182
66857, 1.7652173913043, 1.2978260869565, 0.29545454545455
66858, 1.7434782608696, 1.2978260869565, 0.27272727272727
66859, 1.7652173913043, 1.3239130434783, 0.27272727272727
66860, 1.7652173913043, 1.2978260869565, 0.25
66861, 1.7434782608696, 1.2978260869565, 0.22727272727273
66862, 1.7652173913043, 1.3239130434783, 0.22727272727273
66863, 1.7652173913043, 1.2978260869565, 0.20454545454545
66864, 1.7434782608696, 1.2978260869565, 0.18181818181818
66865, 1.7652173913043, 1.3239130434783, 0.18181818181818
66866, 1.7652173913043, 1.2978260869565, 0.15909090909091
66867, 1.7434782608696, 1.2978260869565, 0.13636363636364
66868, 1.7652173913043, 1.3239130434783, 0.13636363636364
66869, 1.7652173913043, 1.2978260869565, 0.11363636363636
66870, 1.7434782608696, 1.2978260869565, 0.090909090909091
66871, 1.7652173913043, 1.3239130434783, 0.090909090909091
66872, 1.7652173913043, 1.2978260869565, 0.068181818181818
66873, 1.7434782608696, 1.2978260869565, 0.045454545454545
66874, 1.7652173913043, 1.3239130434783, 0.045454545454545
66875, 1.7652173913043, 1.2978260869565, 0.022727272727273
66876, 1.8086956521739, 1.2978260869565, 0.47727272727273
66877, 1.7869565217391, 1.2978260869565, 0.45454545454545
66878, 1.8086956521739, 1.3239130434783, 0.45454545454545
66879, 1.8086956521739, 1.2978260869565, 0.43181818181818
66880, 1.7869565217391, 1.2978260869565, 0.40909090909091
66881, 1.8086956521739, 1.3239130434783, 0.40909090909091
66882, 1.8086956521739, 1.2978260869565, 0.38636363636364
66883, 1.7869565217391, 1.2978260869565, 0.36363636363636
66884, 1.8086956521739, 1.3239130434783, 0.36363636363636
66885, 1.8086956521739, 1.2978260869565, 0.34090909090909
66886, 1.7869565217391, 1.2978260869565, 0.31818181818182
66887, 1.8086956521739, 1.3239130434783, 0.31818181818182
66888, 1.8086956521739, 1.2978260869565, 0.29545454545455
66889, 1.7869565217391, 1.2978260869565, 0.27272727272727
66890, 1.8086956521739, 1.3239130434783, 0.27272727272727
66891, 1.8086956521739, 1.2978260869565, 0.25
66892, 1.7869565217391, 1.2978260869565, 0.22727272727273
66893, 1.8086956521739, 1.3239130434783, 0.22727272727273
66894, 1.8086956521739, 1.2978260869565, 0.20454545454545
66895, 1.7869565217391, 1.2978260869565, 0.18181818181818
66896, 1.8086956521739, 1.3239130434783, 0.18181818181818
66897, 1.8086956521739, 1.2978260869565, 0.15909090909091
66898, 1.7869565217391, 1.2978260869565, 0.13636363636364
66899, 1.8086956521739, 1.3239130434783, 0.13636363636364
66900, 1.8086956521739, 1.2978260869565, 0.11363636363636
66901, 1.7869565217391, 1.2978260869565, 0.090909090909091
66902, 1.8086956521739, 1.3239130434783, 0.090909090909091
66903, 1.8086956521739, 1.2978260869565, 0.068181818181818
66904, 1.7869565217391, 1.2978260869565, 0.045454545454545
66905, 1.8086956521739, 1.3239130434783, 0.045454545454545
66906, 1.8086956521739, 1.2978260869565, 0.022727272727273
66907, 1.8521739130435, 1.2978260869565, 0.47727272727273
66908, 1.8304347826087, 1.2978260869565, 0.45454545454545
66909, 1.8521739130435, 1.3239130434783, 0.45454545454545
66910, 1.8521739130435, 1.2978260869565, 0.43181818181818
66911, 1.8304347826087, 1.2978260869565, 0.40909090909091
66912, 1.8521739130435, 1.3239130434783, 0.40909090909091
66913, 1.8521739130435, 1.2978260869565, 0.38636363636364
66914, 1.8304347826087, 1.2978260869565, 0.36363636363636
66915, 1.8521739130435, 1.3239130434783, 0.36363636363636
66916, 1.8521739130435, 1.2978260869565, 0.34090909090909
66917, 1.8304347826087, 1.2978260869565, 0.31818181818182
66918, 1.8521739130435, 1.3239130434783, 0.31818181818182
66919, 1.8521739130435, 1.2978260869565, 0.29545454545455
66920, 1.8304347826087, 1.2978260869565, 0.27272727272727
66921, 1.8521739130435, 1.3239130434783, 0.27272727272727
66922, 1.8521739130435, 1.2978260869565, 0.25
66923, 1.8304347826087, 1.2978260869565, 0.22727272727273
66924, 1.8521739130435, 1.3239130434783, 0.22727272727273
66925, 1.8521739130435, 1.2978260869565, 0.20454545454545
66926, 1.8304347826087, 1.2978260869565, 0.18181818181818
66927, 1.8521739130435, 1.3239130434783, 0.18181818181818
66928, 1.8521739130435, 1.2978260869565, 0.15909090909091
66929, 1.8304347826087, 1.2978260869565, 0.13636363636364
66930, 1.8521739130435, 1.3239130434783, 0.13636363636364
66931, 1.8521739130435, 1.2978260869565, 0.11363636363636
66932, 1.8304347826087, 1.2978260869565, 0.090909090909091
66933, 1.8521739130435, 1.3239130434783, 0.090909090909091
66934, 1.8521739130435, 1.2978260869565, 0.068181818181818
66935, 1.8304347826087, 1.2978260869565, 0.045454545454545
66936, 1.8521739130435, 1.3239130434783, 0.045454545454545
66937, 1.8521739130435, 1.2978260869565, 0.022727272727273
66938, 1.895652173913, 1.2978260869565, 0.47727272727273
66939, 1.8739130434783, 1.2978260869565, 0.45454545454545
66940, 1.895652173913, 1.3239130434783, 0.45454545454545
66941, 1.895652173913, 1.2978260869565, 0.43181818181818
66942, 1.8739130434783, 1.2978260869565, 0.40909090909091
66943, 1.895652173913, 1.3239130434783, 0.40909090909091
66944, 1.895652173913, 1.2978260869565, 0.38636363636364
66945, 1.8739130434783, 1.2978260869565, 0.36363636363636
66946, 1.895652173913, 1.3239130434783, 0.36363636363636
66947, 1.895652173913, 1.2978260869565, 0.34090909090909
66948, 1.8739130434783, 1.2978260869565, 0.31818181818182
66949, 1.895652173913, 1.3239130434783, 0.31818181818182
66950, 1.895652173913, 1.2978260869565, 0.29545454545455
66951, 1.8739130434783, 1.2978260869565, 0.27272727272727
66952, 1.895652173913, 1.3239130434783, 0.27272727272727
66953, 1.895652173913, 1.2978260869565, 0.25
66954, 1.8739130434783, 1.2978260869565, 0.22727272727273
66955, 1.895652173913, 1.3239130434783, 0.22727272727273
66956, 1.895652173913, 1.2978260869565, 0.20454545454545
66957, 1.8739130434783, 1.2978260869565, 0.18181818181818
66958, 1.895652173913, 1.3239130434783, 0.18181818181818
66959, 1.895652173913, 1.2978260869565, 0.15909090909091
66960, 1.8739130434783, 1.2978260869565, 0.13636363636364
66961, 1.895652173913, 1.3239130434783, 0.13636363636364
66962, 1.895652173913, 1.2978260869565, 0.11363636363636
66963, 1.8739130434783, 1.2978260869565, 0.090909090909091
66964, 1.895652173913, 1.3239130434783, 0.090909090909091
66965, 1.895652173913, 1.2978260869565, 0.068181818181818
66966, 1.8739130434783, 1.2978260869565, 0.045454545454545
66967, 1.895652173913, 1.3239130434783, 0.045454545454545
66968, 1.895652173913, 1.2978260869565, 0.022727272727273
66969, 1.9391304347826, 1.2978260869565, 0.47727272727273
66970, 1.9173913043478, 1.2978260869565, 0.45454545454545
66971, 1.9391304347826, 1.3239130434783, 0.45454545454545
66972, 1.9391304347826, 1.2978260869565, 0.43181818181818
66973, 1.9173913043478, 1.2978260869565, 0.40909090909091
66974, 1.9391304347826, 1.3239130434783, 0.40909090909091
66975, 1.9391304347826, 1.2978260869565, 0.38636363636364
66976, 1.9173913043478, 1.2978260869565, 0.36363636363636
66977, 1.9391304347826, 1.3239130434783, 0.36363636363636
66978, 1.9391304347826, 1.2978260869565, 0.34090909090909
66979, 1.9173913043478, 1.2978260869565, 0.31818181818182
66980, 1.9391304347826, 1.3239130434783, 0.31818181818182
66981, 1.9391304347826, 1.2978260869565, 0.29545454545455
66982, 1.9173913043478, 1.2978260869565, 0.27272727272727
66983, 1.9391304347826, 1.3239130434783, 0.27272727272727
66984, 1.9391304347826, 1.2978260869565, 0.25
66985, 1.9173913043478, 1.2978260869565, 0.22727272727273
66986, 1.9391304347826, 1.3239130434783, 0.22727272727273
66987, 1.9391304347826, 1.2978260869565, 0.20454545454545
66988, 1.9173913043478, 1.2978260869565, 0.18181818181818
66989, 1.9391304347826, 1.3239130434783, 0.18181818181818
66990, 1.9391304347826, 1.2978260869565, 0.15909090909091
66991, 1.9173913043478, 1.2978260869565, 0.13636363636364
66992, 1.9391304347826, 1.3239130434783, 0.13636363636364
66993, 1.9391304347826, 1.2978260869565, 0.11363636363636
66994, 1.9173913043478, 1.2978260869565, 0.090909090909091
66995, 1.9391304347826, 1.3239130434783, 0.090909090909091
66996, 1.9391304347826, 1.2978260869565, 0.068181818181818
66997, 1.9173913043478, 1.2978260869565, 0.045454545454545
66998, 1.9391304347826, 1.3239130434783, 0.045454545454545
66999, 1.9391304347826, 1.2978260869565, 0.022727272727273
67000, 1.9826086956522, 1.2978260869565, 0.47727272727273
67001, 1.9608695652174, 1.2978260869565, 0.45454545454545
67002, 1.9826086956522, 1.3239130434783, 0.45454545454545
67003, 1.9826086956522, 1.2978260869565, 0.43181818181818
67004, 1.9608695652174, 1.2978260869565, 0.40909090909091
67005, 1.9826086956522, 1.3239130434783, 0.40909090909091
67006, 1.9826086956522, 1.2978260869565, 0.38636363636364
67007, 1.9608695652174, 1.2978260869565, 0.36363636363636
67008, 1.9826086956522, 1.3239130434783, 0.36363636363636
67009, 1.9826086956522, 1.2978260869565, 0.34090909090909
67010, 1.9608695652174, 1.2978260869565, 0.31818181818182
67011, 1.9826086956522, 1.3239130434783, 0.31818181818182
67012, 1.9826086956522, 1.2978260869565, 0.29545454545455
67013, 1.9608695652174, 1.2978260869565, 0.27272727272727
67014, 1.9826086956522, 1.3239130434783, 0.27272727272727
67015, 1.9826086956522, 1.2978260869565, 0.25
67016, 1.9608695652174, 1.2978260869565, 0.22727272727273
67017, 1.9826086956522, 1.3239130434783, 0.22727272727273
67018, 1.9826086956522, 1.2978260869565, 0.20454545454545
67019, 1.9608695652174, 1.2978260869565, 0.18181818181818
67020, 1.9826086956522, 1.3239130434783, 0.18181818181818
67021, 1.9826086956522, 1.2978260869565, 0.15909090909091
67022, 1.9608695652174, 1.2978260869565, 0.13636363636364
67023, 1.9826086956522, 1.3239130434783, 0.13636363636364
67024, 1.9826086956522, 1.2978260869565, 0.11363636363636
67025, 1.9608695652174, 1.2978260869565, 0.090909090909091
67026, 1.9826086956522, 1.3239130434783, 0.090909090909091
67027, 1.9826086956522, 1.2978260869565, 0.068181818181818
67028, 1.9608695652174, 1.2978260869565, 0.045454545454545
67029, 1.9826086956522, 1.3239130434783, 0.045454545454545
67030, 1.9826086956522, 1.2978260869565, 0.022727272727273
67031, 2.0260869565217, 1.2978260869565, 0.47727272727273
67032, 2.004347826087, 1.2978260869565, 0.45454545454545
67033, 2.0260869565217, 1.3239130434783, 0.45454545454545
67034, 2.0260869565217, 1.2978260869565, 0.43181818181818
67035, 2.004347826087, 1.2978260869565, 0.40909090909091
67036, 2.0260869565217, 1.3239130434783, 0.40909090909091
67037, 2.0260869565217, 1.2978260869565, 0.38636363636364
67038, 2.004347826087, 1.2978260869565, 0.36363636363636
67039, 2.0260869565217, 1.3239130434783, 0.36363636363636
67040, 2.0260869565217, 1.2978260869565, 0.34090909090909
67041, 2.004347826087, 1.2978260869565, 0.31818181818182
67042, 2.0260869565217, 1.3239130434783, 0.31818181818182
67043, 2.0260869565217, 1.2978260869565, 0.29545454545455
67044, 2.004347826087, 1.2978260869565, 0.27272727272727
67045, 2.0260869565217, 1.3239130434783, 0.27272727272727
67046, 2.0260869565217, 1.2978260869565, 0.25
67047, 2.004347826087, 1.2978260869565, 0.22727272727273
67048, 2.0260869565217, 1.3239130434783, 0.22727272727273
67049, 2.0260869565217, 1.2978260869565, 0.20454545454545
67050, 2.004347826087, 1.2978260869565, 0.18181818181818
67051, 2.0260869565217, 1.3239130434783, 0.18181818181818
67052, 2.0260869565217, 1.2978260869565, 0.15909090909091
67053, 2.004347826087, 1.2978260869565, 0.13636363636364
67054, 2.0260869565217, 1.3239130434783, 0.13636363636364
67055, 2.0260869565217, 1.2978260869565, 0.11363636363636
67056, 2.004347826087, 1.2978260869565, 0.090909090909091
67057, 2.0260869565217, 1.3239130434783, 0.090909090909091
67058, 2.0260869565217, 1.2978260869565, 0.068181818181818
67059, 2.004347826087, 1.2978260869565, 0.045454545454545
67060, 2.0260869565217, 1.3239130434783, 0.045454545454545
67061, 2.0260869565217, 1.2978260869565, 0.022727272727273
67062, 2.0695652173913, 1.2978260869565, 0.47727272727273
67063, 2.0478260869565, 1.2978260869565, 0.45454545454545
67064, 2.0695652173913, 1.3239130434783, 0.45454545454545
67065, 2.0695652173913, 1.2978260869565, 0.43181818181818
67066, 2.0478260869565, 1.2978260869565, 0.40909090909091
67067, 2.0695652173913, 1.3239130434783, 0.40909090909091
67068, 2.0695652173913, 1.2978260869565, 0.38636363636364
67069, 2.0478260869565, 1.2978260869565, 0.36363636363636
67070, 2.0695652173913, 1.3239130434783, 0.36363636363636
67071, 2.0695652173913, 1.2978260869565, 0.34090909090909
67072, 2.0478260869565, 1.2978260869565, 0.31818181818182
67073, 2.0695652173913, 1.3239130434783, 0.31818181818182
67074, 2.0695652173913, 1.2978260869565, 0.29545454545455
67075, 2.0478260869565, 1.2978260869565, 0.27272727272727
67076, 2.0695652173913, 1.3239130434783, 0.27272727272727
67077, 2.0695652173913, 1.2978260869565, 0.25
67078, 2.0478260869565, 1.2978260869565, 0.22727272727273
67079, 2.0695652173913, 1.3239130434783, 0.22727272727273
67080, 2.0695652173913, 1.2978260869565, 0.20454545454545
67081, 2.0478260869565, 1.2978260869565, 0.18181818181818
67082, 2.0695652173913, 1.3239130434783, 0.18181818181818
67083, 2.0695652173913, 1.2978260869565, 0.15909090909091
67084, 2.0478260869565, 1.2978260869565, 0.13636363636364
67085, 2.0695652173913, 1.3239130434783, 0.13636363636364
67086, 2.0695652173913, 1.2978260869565, 0.11363636363636
67087, 2.0478260869565, 1.2978260869565, 0.090909090909091
67088, 2.0695652173913, 1.3239130434783, 0.090909090909091
67089, 2.0695652173913, 1.2978260869565, 0.068181818181818
67090, 2.0478260869565, 1.2978260869565, 0.045454545454545
67091, 2.0695652173913, 1.3239130434783, 0.045454545454545
67092, 2.0695652173913, 1.2978260869565, 0.022727272727273
67093, 2.1130434782609, 1.2978260869565, 0.47727272727273
67094, 2.0913043478261, 1.2978260869565, 0.45454545454545
67095, 2.1130434782609, 1.3239130434783, 0.45454545454545
67096, 2.1130434782609, 1.2978260869565, 0.43181818181818
67097, 2.0913043478261, 1.2978260869565, 0.40909090909091
67098, 2.1130434782609, 1.3239130434783, 0.40909090909091
67099, 2.1130434782609, 1.2978260869565, 0.38636363636364
67100, 2.0913043478261, 1.2978260869565, 0.36363636363636
67101, 2.1130434782609, 1.3239130434783, 0.36363636363636
67102, 2.1130434782609, 1.2978260869565, 0.34090909090909
67103, 2.0913043478261, 1.2978260869565, 0.31818181818182
67104, 2.1130434782609, 1.3239130434783, 0.31818181818182
67105, 2.1130434782609, 1.2978260869565, 0.29545454545455
67106, 2.0913043478261, 1.2978260869565, 0.27272727272727
67107, 2.1130434782609, 1.3239130434783, 0.27272727272727
67108, 2.1130434782609, 1.2978260869565, 0.25
67109, 2.0913043478261, 1.2978260869565, 0.22727272727273
67110, 2.1130434782609, 1.3239130434783, 0.22727272727273
67111, 2.1130434782609, 1.2978260869565, 0.20454545454545
67112, 2.0913043478261, 1.2978260869565, 0.18181818181818
67113, 2.1130434782609, 1.3239130434783, 0.18181818181818
67114, 2.1130434782609, 1.2978260869565, 0.15909090909091
67115, 2.0913043478261, 1.2978260869565, 0.13636363636364
67116, 2.1130434782609, 1.3239130434783, 0.13636363636364
67117, 2.1130434782609, 1.2978260869565, 0.11363636363636
67118, 2.0913043478261, 1.2978260869565, 0.090909090909091
67119, 2.1130434782609, 1.3239130434783, 0.090909090909091
67120, 2.1130434782609, 1.2978260869565, 0.068181818181818
67121, 2.0913043478261, 1.2978260869565, 0.045454545454545
67122, 2.1130434782609, 1.3239130434783, 0.045454545454545
67123, 2.1130434782609, 1.2978260869565, 0.022727272727273
67124, 2.1565217391304, 1.2978260869565, 0.47727272727273
67125, 2.1347826086957, 1.2978260869565, 0.45454545454545
67126, 2.1565217391304, 1.3239130434783, 0.45454545454545
67127, 2.1565217391304, 1.2978260869565, 0.43181818181818
67128, 2.1347826086957, 1.2978260869565, 0.40909090909091
67129, 2.1565217391304, 1.3239130434783, 0.40909090909091
67130, 2.1565217391304, 1.2978260869565, 0.38636363636364
67131, 2.1347826086957, 1.2978260869565, 0.36363636363636
67132, 2.1565217391304, 1.3239130434783, 0.36363636363636
67133, 2.1565217391304, 1.2978260869565, 0.34090909090909
67134, 2.1347826086957, 1.2978260869565, 0.31818181818182
67135, 2.1565217391304, 1.3239130434783, 0.31818181818182
67136, 2.1565217391304, 1.2978260869565, 0.29545454545455
67137, 2.1347826086957, 1.2978260869565, 0.27272727272727
67138, 2.1565217391304, 1.3239130434783, 0.27272727272727
67139, 2.1565217391304, 1.2978260869565, 0.25
67140, 2.1347826086957, 1.2978260869565, 0.22727272727273
67141, 2.1565217391304, 1.3239130434783, 0.22727272727273
67142, 2.1565217391304, 1.2978260869565, 0.20454545454545
67143, 2.1347826086957, 1.2978260869565, 0.18181818181818
67144, 2.1565217391304, 1.3239130434783, 0.18181818181818
67145, 2.1565217391304, 1.2978260869565, 0.15909090909091
67146, 2.1347826086957, 1.2978260869565, 0.13636363636364
67147, 2.1565217391304, 1.3239130434783, 0.13636363636364
67148, 2.1565217391304, 1.2978260869565, 0.11363636363636
67149, 2.1347826086957, 1.2978260869565, 0.090909090909091
67150, 2.1565217391304, 1.3239130434783, 0.090909090909091
67151, 2.1565217391304, 1.2978260869565, 0.068181818181818
67152, 2.1347826086957, 1.2978260869565, 0.045454545454545
67153, 2.1565217391304, 1.3239130434783, 0.045454545454545
67154, 2.1565217391304, 1.2978260869565, 0.022727272727273
67155, 2.1782608695652, 1.2978260869565, 0.45454545454545
67156, 2.1782608695652, 1.2978260869565, 0.40909090909091
67157, 2.1782608695652, 1.2978260869565, 0.36363636363636
67158, 2.1782608695652, 1.2978260869565, 0.31818181818182
67159, 2.1782608695652, 1.2978260869565, 0.27272727272727
67160, 2.1782608695652, 1.2978260869565, 0.22727272727273
67161, 2.1782608695652, 1.2978260869565, 0.18181818181818
67162, 2.1782608695652, 1.2978260869565, 0.13636363636364
67163, 2.1782608695652, 1.2978260869565, 0.090909090909091
67164, 2.1782608695652, 1.2978260869565, 0.045454545454545
67165, 1.2434782608696, 1.245652173913, 0.47727272727273
67166, 1.2217391304348, 1.245652173913, 0.45454545454545
67167, 1.2434782608696, 1.2717391304348, 0.45454545454545
67168, 1.2434782608696, 1.245652173913, 0.43181818181818
67169, 1.2217391304348, 1.245652173913, 0.40909090909091
67170, 1.2434782608696, 1.2717391304348, 0.40909090909091
67171, 1.2434782608696, 1.245652173913, 0.38636363636364
67172, 1.2217391304348, 1.245652173913, 0.36363636363636
67173, 1.2434782608696, 1.2717391304348, 0.36363636363636
67174, 1.2434782608696, 1.245652173913, 0.34090909090909
67175, 1.2217391304348, 1.245652173913, 0.31818181818182
67176, 1.2434782608696, 1.2717391304348, 0.31818181818182
67177, 1.2434782608696, 1.245652173913, 0.29545454545455
67178, 1.2217391304348, 1.245652173913, 0.27272727272727
67179, 1.2434782608696, 1.2717391304348, 0.27272727272727
67180, 1.2434782608696, 1.245652173913, 0.25
67181, 1.2217391304348, 1.245652173913, 0.22727272727273
67182, 1.2434782608696, 1.2717391304348, 0.22727272727273
67183, 1.2434782608696, 1.245652173913, 0.20454545454545
67184, 1.2217391304348, 1.245652173913, 0.18181818181818
67185, 1.2434782608696, 1.2717391304348, 0.18181818181818
67186, 1.2434782608696, 1.245652173913, 0.15909090909091
67187, 1.2217391304348, 1.245652173913, 0.13636363636364
67188, 1.2434782608696, 1.2717391304348, 0.13636363636364
67189, 1.2434782608696, 1.245652173913, 0.11363636363636
67190, 1.2217391304348, 1.245652173913, 0.090909090909091
67191, 1.2434782608696, 1.2717391304348, 0.090909090909091
67192, 1.2434782608696, 1.245652173913, 0.068181818181818
67193, 1.2217391304348, 1.245652173913, 0.045454545454545
67194, 1.2434782608696, 1.2717391304348, 0.045454545454545
67195, 1.2434782608696, 1.245652173913, 0.022727272727273
67196, 1.2869565217391, 1.245652173913, 0.47727272727273
67197, 1.2652173913043, 1.245652173913, 0.45454545454545
67198, 1.2869565217391, 1.2717391304348, 0.45454545454545
67199, 1.2869565217391, 1.245652173913, 0.43181818181818
67200, 1.2652173913043, 1.245652173913, 0.40909090909091
67201, 1.2869565217391, 1.2717391304348, 0.40909090909091
67202, 1.2869565217391, 1.245652173913, 0.38636363636364
67203, 1.2652173913043, 1.245652173913, 0.36363636363636
67204, 1.2869565217391, 1.2717391304348, 0.36363636363636
67205, 1.2869565217391, 1.245652173913, 0.34090909090909
67206, 1.2652173913043, 1.245652173913, 0.31818181818182
67207, 1.2869565217391, 1.2717391304348, 0.31818181818182
67208, 1.2869565217391, 1.245652173913, 0.29545454545455
67209, 1.2652173913043, 1.245652173913, 0.27272727272727
67210, 1.2869565217391, 1.2717391304348, 0.27272727272727
67211, 1.2869565217391, 1.245652173913, 0.25
67212, 1.2652173913043, 1.245652173913, 0.22727272727273
67213, 1.2869565217391, 1.2717391304348, 0.22727272727273
67214, 1.2869565217391, 1.245652173913, 0.20454545454545
67215, 1.2652173913043, 1.245652173913, 0.18181818181818
67216, 1.2869565217391, 1.2717391304348, 0.18181818181818
67217, 1.2869565217391, 1.245652173913, 0.15909090909091
67218, 1.2652173913043, 1.245652173913, 0.13636363636364
67219, 1.2869565217391, 1.2717391304348, 0.13636363636364
67220, 1.2869565217391, 1.245652173913, 0.11363636363636
67221, 1.2652173913043, 1.245652173913, 0.090909090909091
67222, 1.2869565217391, 1.2717391304348, 0.090909090909091
67223, 1.2869565217391, 1.245652173913, 0.068181818181818
67224, 1.2652173913043, 1.245652173913, 0.045454545454545
67225, 1.2869565217391, 1.2717391304348, 0.045454545454545
67226, 1.2869565217391, 1.245652173913, 0.022727272727273
67227, 1.3304347826087, 1.245652173913, 0.47727272727273
67228, 1.3086956521739, 1.245652173913, 0.45454545454545
67229, 1.3304347826087, 1.2717391304348, 0.45454545454545
67230, 1.3304347826087, 1.245652173913, 0.43181818181818
67231, 1.3086956521739, 1.245652173913, 0.40909090909091
67232, 1.3304347826087, 1.2717391304348, 0.40909090909091
67233, 1.3304347826087, 1.245652173913, 0.38636363636364
67234, 1.3086956521739, 1.245652173913, 0.36363636363636
67235, 1.3304347826087, 1.2717391304348, 0.36363636363636
67236, 1.3304347826087, 1.245652173913, 0.34090909090909
67237, 1.3086956521739, 1.245652173913, 0.31818181818182
67238, 1.3304347826087, 1.2717391304348, 0.31818181818182
67239, 1.3304347826087, 1.245652173913, 0.29545454545455
67240, 1.3086956521739, 1.245652173913, 0.27272727272727
67241, 1.3304347826087, 1.2717391304348, 0.27272727272727
67242, 1.3304347826087, 1.245652173913, 0.25
67243, 1.3086956521739, 1.245652173913, 0.22727272727273
67244, 1.3304347826087, 1.2717391304348, 0.22727272727273
67245, 1.3304347826087, 1.245652173913, 0.20454545454545
67246, 1.3086956521739, 1.245652173913, 0.18181818181818
67247, 1.3304347826087, 1.2717391304348, 0.18181818181818
67248, 1.3304347826087, 1.245652173913, 0.15909090909091
67249, 1.3086956521739, 1.245652173913, 0.13636363636364
67250, 1.3304347826087, 1.2717391304348, 0.13636363636364
67251, 1.3304347826087, 1.245652173913, 0.11363636363636
67252, 1.3086956521739, 1.245652173913, 0.090909090909091
67253, 1.3304347826087, 1.2717391304348, 0.090909090909091
67254, 1.3304347826087, 1.245652173913, 0.068181818181818
67255, 1.3086956521739, 1.245652173913, 0.045454545454545
67256, 1.3304347826087, 1.2717391304348, 0.045454545454545
67257, 1.3304347826087, 1.245652173913, 0.022727272727273
67258, 1.3739130434783, 1.245652173913, 0.47727272727273
67259, 1.3521739130435, 1.245652173913, 0.45454545454545
67260, 1.3739130434783, 1.2717391304348, 0.45454545454545
67261, 1.3739130434783, 1.245652173913, 0.43181818181818
67262, 1.3521739130435, 1.245652173913, 0.40909090909091
67263, 1.3739130434783, 1.2717391304348, 0.40909090909091
67264, 1.3739130434783, 1.245652173913, 0.38636363636364
67265, 1.3521739130435, 1.245652173913, 0.36363636363636
67266, 1.3739130434783, 1.2717391304348, 0.36363636363636
67267, 1.3739130434783, 1.245652173913, 0.34090909090909
67268, 1.3521739130435, 1.245652173913, 0.31818181818182
67269, 1.3739130434783, 1.2717391304348, 0.31818181818182
67270, 1.3739130434783, 1.245652173913, 0.29545454545455
67271, 1.3521739130435, 1.245652173913, 0.27272727272727
67272, 1.3739130434783, 1.2717391304348, 0.27272727272727
67273, 1.3739130434783, 1.245652173913, 0.25
67274, 1.3521739130435, 1.245652173913, 0.22727272727273
67275, 1.3739130434783, 1.2717391304348, 0.22727272727273
67276, 1.3739130434783, 1.245652173913, 0.20454545454545
67277, 1.3521739130435, 1.245652173913, 0.18181818181818
67278, 1.3739130434783, 1.2717391304348, 0.18181818181818
67279, 1.3739130434783, 1.245652173913, 0.15909090909091
67280, 1.3521739130435, 1.245652173913, 0.13636363636364
67281, 1.3739130434783, 1.2717391304348, 0.13636363636364
67282, 1.3739130434783, 1.245652173913, 0.11363636363636
67283, 1.3521739130435, 1.245652173913, 0.090909090909091
67284, 1.3739130434783, 1.2717391304348, 0.090909090909091
67285, 1.3739130434783, 1.245652173913, 0.068181818181818
67286, 1.3521739130435, 1.245652173913, 0.045454545454545
67287, 1.3739130434783, 1.2717391304348, 0.045454545454545
67288, 1.3739130434783, 1.245652173913, 0.022727272727273
67289, 1.4173913043478, 1.245652173913, 0.47727272727273
67290, 1.395652173913, 1.245652173913, 0.45454545454545
67291, 1.4173913043478, 1.2717391304348, 0.45454545454545
67292, 1.4173913043478, 1.245652173913, 0.43181818181818
67293, 1.395652173913, 1.245652173913, 0.40909090909091
67294, 1.4173913043478, 1.2717391304348, 0.40909090909091
67295, 1.4173913043478, 1.245652173913, 0.38636363636364
67296, 1.395652173913, 1.245652173913, 0.36363636363636
67297, 1.4173913043478, 1.2717391304348, 0.36363636363636
67298, 1.4173913043478, 1.245652173913, 0.34090909090909
67299, 1.395652173913, 1.245652173913, 0.31818181818182
67300, 1.4173913043478, 1.2717391304348, 0.31818181818182
67301, 1.4173913043478, 1.245652173913, 0.29545454545455
67302, 1.395652173913, 1.245652173913, 0.27272727272727
67303, 1.4173913043478, 1.2717391304348, 0.27272727272727
67304, 1.4173913043478, 1.245652173913, 0.25
67305, 1.395652173913, 1.245652173913, 0.22727272727273
67306, 1.4173913043478, 1.2717391304348, 0.22727272727273
67307, 1.4173913043478, 1.245652173913, 0.20454545454545
67308, 1.395652173913, 1.245652173913, 0.18181818181818
67309, 1.4173913043478, 1.2717391304348, 0.18181818181818
67310, 1.4173913043478, 1.245652173913, 0.15909090909091
67311, 1.395652173913, 1.245652173913, 0.13636363636364
67312, 1.4173913043478, 1.2717391304348, 0.13636363636364
67313, 1.4173913043478, 1.245652173913, 0.11363636363636
67314, 1.395652173913, 1.245652173913, 0.090909090909091
67315, 1.4173913043478, 1.2717391304348, 0.090909090909091
67316, 1.4173913043478, 1.245652173913, 0.068181818181818
67317, 1.395652173913, 1.245652173913, 0.045454545454545
67318, 1.4173913043478, 1.2717391304348, 0.045454545454545
67319, 1.4173913043478, 1.245652173913, 0.022727272727273
67320, 1.4608695652174, 1.245652173913, 0.47727272727273
67321, 1.4391304347826, 1.245652173913, 0.45454545454545
67322, 1.4608695652174, 1.2717391304348, 0.45454545454545
67323, 1.4608695652174, 1.245652173913, 0.43181818181818
67324, 1.4391304347826, 1.245652173913, 0.40909090909091
67325, 1.4608695652174, 1.2717391304348, 0.40909090909091
67326, 1.4608695652174, 1.245652173913, 0.38636363636364
67327, 1.4391304347826, 1.245652173913, 0.36363636363636
67328, 1.4608695652174, 1.2717391304348, 0.36363636363636
67329, 1.4608695652174, 1.245652173913, 0.34090909090909
67330, 1.4391304347826, 1.245652173913, 0.31818181818182
67331, 1.4608695652174, 1.2717391304348, 0.31818181818182
67332, 1.4608695652174, 1.245652173913, 0.29545454545455
67333, 1.4391304347826, 1.245652173913, 0.27272727272727
67334, 1.4608695652174, 1.2717391304348, 0.27272727272727
67335, 1.4608695652174, 1.245652173913, 0.25
67336, 1.4391304347826, 1.245652173913, 0.22727272727273
67337, 1.4608695652174, 1.2717391304348, 0.22727272727273
67338, 1.4608695652174, 1.245652173913, 0.20454545454545
67339, 1.4391304347826, 1.245652173913, 0.18181818181818
67340, 1.4608695652174, 1.2717391304348, 0.18181818181818
67341, 1.4608695652174, 1.245652173913, 0.15909090909091
67342, 1.4391304347826, 1.245652173913, 0.13636363636364
67343, 1.4608695652174, 1.2717391304348, 0.13636363636364
67344, 1.4608695652174, 1.245652173913, 0.11363636363636
67345, 1.4391304347826, 1.245652173913, 0.090909090909091
67346, 1.4608695652174, 1.2717391304348, 0.090909090909091
67347, 1.4608695652174, 1.245652173913, 0.068181818181818
67348, 1.4391304347826, 1.245652173913, 0.045454545454545
67349, 1.4608695652174, 1.2717391304348, 0.045454545454545
67350, 1.4608695652174, 1.245652173913, 0.022727272727273
67351, 1.504347826087, 1.245652173913, 0.47727272727273
67352, 1.4826086956522, 1.245652173913, 0.45454545454545
67353, 1.504347826087, 1.2717391304348, 0.45454545454545
67354, 1.504347826087, 1.245652173913, 0.43181818181818
67355, 1.4826086956522, 1.245652173913, 0.40909090909091
67356, 1.504347826087, 1.2717391304348, 0.40909090909091
67357, 1.504347826087, 1.245652173913, 0.38636363636364
67358, 1.4826086956522, 1.245652173913, 0.36363636363636
67359, 1.504347826087, 1.2717391304348, 0.36363636363636
67360, 1.504347826087, 1.245652173913, 0.34090909090909
67361, 1.4826086956522, 1.245652173913, 0.31818181818182
67362, 1.504347826087, 1.2717391304348, 0.31818181818182
67363, 1.504347826087, 1.245652173913, 0.29545454545455
67364, 1.4826086956522, 1.245652173913, 0.27272727272727
67365, 1.504347826087, 1.2717391304348, 0.27272727272727
67366, 1.504347826087, 1.245652173913, 0.25
67367, 1.4826086956522, 1.245652173913, 0.22727272727273
67368, 1.504347826087, 1.2717391304348, 0.22727272727273
67369, 1.504347826087, 1.245652173913, 0.20454545454545
67370, 1.4826086956522, 1.245652173913, 0.18181818181818
67371, 1.504347826087, 1.2717391304348, 0.18181818181818
67372, 1.504347826087, 1.245652173913, 0.15909090909091
67373, 1.4826086956522, 1.245652173913, 0.13636363636364
67374, 1.504347826087, 1.2717391304348, 0.13636363636364
67375, 1.504347826087, 1.245652173913, 0.11363636363636
67376, 1.4826086956522, 1.245652173913, 0.090909090909091
67377, 1.504347826087, 1.2717391304348, 0.090909090909091
67378, 1.504347826087, 1.245652173913, 0.068181818181818
67379, 1.4826086956522, 1.245652173913, 0.045454545454545
67380, 1.504347826087, 1.2717391304348, 0.045454545454545
67381, 1.504347826087, 1.245652173913, 0.022727272727273
67382, 1.5478260869565, 1.245652173913, 0.47727272727273
67383, 1.5260869565217, 1.245652173913, 0.45454545454545
67384, 1.5478260869565, 1.2717391304348, 0.45454545454545
67385, 1.5478260869565, 1.245652173913, 0.43181818181818
67386, 1.5260869565217, 1.245652173913, 0.40909090909091
67387, 1.5478260869565, 1.2717391304348, 0.40909090909091
67388, 1.5478260869565, 1.245652173913, 0.38636363636364
67389, 1.5260869565217, 1.245652173913, 0.36363636363636
67390, 1.5478260869565, 1.2717391304348, 0.36363636363636
67391, 1.5478260869565, 1.245652173913, 0.34090909090909
67392, 1.5260869565217, 1.245652173913, 0.31818181818182
67393, 1.5478260869565, 1.2717391304348, 0.31818181818182
67394, 1.5478260869565, 1.245652173913, 0.29545454545455
67395, 1.5260869565217, 1.245652173913, 0.27272727272727
67396, 1.5478260869565, 1.2717391304348, 0.27272727272727
67397, 1.5478260869565, 1.245652173913, 0.25
67398, 1.5260869565217, 1.245652173913, 0.22727272727273
67399, 1.5478260869565, 1.2717391304348, 0.22727272727273
67400, 1.5478260869565, 1.245652173913, 0.20454545454545
67401, 1.5260869565217, 1.245652173913, 0.18181818181818
67402, 1.5478260869565, 1.2717391304348, 0.18181818181818
67403, 1.5478260869565, 1.245652173913, 0.15909090909091
67404, 1.5260869565217, 1.245652173913, 0.13636363636364
67405, 1.5478260869565, 1.2717391304348, 0.13636363636364
67406, 1.5478260869565, 1.245652173913, 0.11363636363636
67407, 1.5260869565217, 1.245652173913, 0.090909090909091
67408, 1.5478260869565, 1.2717391304348, 0.090909090909091
67409, 1.5478260869565, 1.245652173913, 0.068181818181818
67410, 1.5260869565217, 1.245652173913, 0.045454545454545
67411, 1.5478260869565, 1.2717391304348, 0.045454545454545
67412, 1.5478260869565, 1.245652173913, 0.022727272727273
67413, 1.5913043478261, 1.245652173913, 0.47727272727273
67414, 1.5695652173913, 1.245652173913, 0.45454545454545
67415, 1.5913043478261, 1.2717391304348, 0.45454545454545
67416, 1.5913043478261, 1.245652173913, 0.43181818181818
67417, 1.5695652173913, 1.245652173913, 0.40909090909091
67418, 1.5913043478261, 1.2717391304348, 0.40909090909091
67419, 1.5913043478261, 1.245652173913, 0.38636363636364
67420, 1.5695652173913, 1.245652173913, 0.36363636363636
67421, 1.5913043478261, 1.2717391304348, 0.36363636363636
67422, 1.5913043478261, 1.245652173913, 0.34090909090909
67423, 1.5695652173913, 1.245652173913, 0.31818181818182
67424, 1.5913043478261, 1.2717391304348, 0.31818181818182
67425, 1.5913043478261, 1.245652173913, 0.29545454545455
67426, 1.5695652173913, 1.245652173913, 0.27272727272727
67427, 1.5913043478261, 1.2717391304348, 0.27272727272727
67428, 1.5913043478261, 1.245652173913, 0.25
67429, 1.5695652173913, 1.245652173913, 0.22727272727273
67430, 1.5913043478261, 1.2717391304348, 0.22727272727273
67431, 1.5913043478261, 1.245652173913, 0.20454545454545
67432, 1.5695652173913, 1.245652173913, 0.18181818181818
67433, 1.5913043478261, 1.2717391304348, 0.18181818181818
67434, 1.5913043478261, 1.245652173913, 0.15909090909091
67435, 1.5695652173913, 1.245652173913, 0.13636363636364
67436, 1.5913043478261, 1.2717391304348, 0.13636363636364
67437, 1.5913043478261, 1.245652173913, 0.11363636363636
67438, 1.5695652173913, 1.245652173913, 0.090909090909091
67439, 1.5913043478261, 1.2717391304348, 0.090909090909091
67440, 1.5913043478261, 1.245652173913, 0.068181818181818
67441, 1.5695652173913, 1.245652173913, 0.045454545454545
67442, 1.5913043478261, 1.2717391304348, 0.045454545454545
67443, 1.5913043478261, 1.245652173913, 0.022727272727273
67444, 1.6347826086957, 1.245652173913, 0.47727272727273
67445, 1.6130434782609, 1.245652173913, 0.45454545454545
67446, 1.6347826086957, 1.2717391304348, 0.45454545454545
67447, 1.6347826086957, 1.245652173913, 0.43181818181818
67448, 1.6130434782609, 1.245652173913, 0.40909090909091
67449, 1.6347826086957, 1.2717391304348, 0.40909090909091
67450, 1.6347826086957, 1.245652173913, 0.38636363636364
67451, 1.6130434782609, 1.245652173913, 0.36363636363636
67452, 1.6347826086957, 1.2717391304348, 0.36363636363636
67453, 1.6347826086957, 1.245652173913, 0.34090909090909
67454, 1.6130434782609, 1.245652173913, 0.31818181818182
67455, 1.6347826086957, 1.2717391304348, 0.31818181818182
67456, 1.6347826086957, 1.245652173913, 0.29545454545455
67457, 1.6130434782609, 1.245652173913, 0.27272727272727
67458, 1.6347826086957, 1.2717391304348, 0.27272727272727
67459, 1.6347826086957, 1.245652173913, 0.25
67460, 1.6130434782609, 1.245652173913, 0.22727272727273
67461, 1.6347826086957, 1.2717391304348, 0.22727272727273
67462, 1.6347826086957, 1.245652173913, 0.20454545454545
67463, 1.6130434782609, 1.245652173913, 0.18181818181818
67464, 1.6347826086957, 1.2717391304348, 0.18181818181818
67465, 1.6347826086957, 1.245652173913, 0.15909090909091
67466, 1.6130434782609, 1.245652173913, 0.13636363636364
67467, 1.6347826086957, 1.2717391304348, 0.13636363636364
67468, 1.6347826086957, 1.245652173913, 0.11363636363636
67469, 1.6130434782609, 1.245652173913, 0.090909090909091
67470, 1.6347826086957, 1.2717391304348, 0.090909090909091
67471, 1.6347826086957, 1.245652173913, 0.068181818181818
67472, 1.6130434782609, 1.245652173913, 0.045454545454545
67473, 1.6347826086957, 1.2717391304348, 0.045454545454545
67474, 1.6347826086957, 1.245652173913, 0.022727272727273
67475, 1.6782608695652, 1.245652173913, 0.47727272727273
67476, 1.6565217391304, 1.245652173913, 0.45454545454545
67477, 1.6782608695652, 1.2717391304348, 0.45454545454545
67478, 1.6782608695652, 1.245652173913, 0.43181818181818
67479, 1.6565217391304, 1.245652173913, 0.40909090909091
67480, 1.6782608695652, 1.2717391304348, 0.40909090909091
67481, 1.6782608695652, 1.245652173913, 0.38636363636364
67482, 1.6565217391304, 1.245652173913, 0.36363636363636
67483, 1.6782608695652, 1.2717391304348, 0.36363636363636
67484, 1.6782608695652, 1.245652173913, 0.34090909090909
67485, 1.6565217391304, 1.245652173913, 0.31818181818182
67486, 1.6782608695652, 1.2717391304348, 0.31818181818182
67487, 1.6782608695652, 1.245652173913, 0.29545454545455
67488, 1.6565217391304, 1.245652173913, 0.27272727272727
67489, 1.6782608695652, 1.2717391304348, 0.27272727272727
67490, 1.6782608695652, 1.245652173913, 0.25
67491, 1.6565217391304, 1.245652173913, 0.22727272727273
67492, 1.6782608695652, 1.2717391304348, 0.22727272727273
67493, 1.6782608695652, 1.245652173913, 0.20454545454545
67494, 1.6565217391304, 1.245652173913, 0.18181818181818
67495, 1.6782608695652, 1.2717391304348, 0.18181818181818
67496, 1.6782608695652, 1.245652173913, 0.15909090909091
67497, 1.6565217391304, 1.245652173913, 0.13636363636364
67498, 1.6782608695652, 1.2717391304348, 0.13636363636364
67499, 1.6782608695652, 1.245652173913, 0.11363636363636
67500, 1.6565217391304, 1.245652173913, 0.090909090909091
67501, 1.6782608695652, 1.2717391304348, 0.090909090909091
67502, 1.6782608695652, 1.245652173913, 0.068181818181818
67503, 1.6565217391304, 1.245652173913, 0.045454545454545
67504, 1.6782608695652, 1.2717391304348, 0.045454545454545
67505, 1.6782608695652, 1.245652173913, 0.022727272727273
67506, 1.7217391304348, 1.245652173913, 0.47727272727273
67507, 1.7, 1.245652173913, 0.45454545454545
67508, 1.7217391304348, 1.2717391304348, 0.45454545454545
67509, 1.7217391304348, 1.245652173913, 0.43181818181818
67510, 1.7, 1.245652173913, 0.40909090909091
67511, 1.7217391304348, 1.2717391304348, 0.40909090909091
67512, 1.7217391304348, 1.245652173913, 0.38636363636364
67513, 1.7, 1.245652173913, 0.36363636363636
67514, 1.7217391304348, 1.2717391304348, 0.36363636363636
67515, 1.7217391304348, 1.245652173913, 0.34090909090909
67516, 1.7, 1.245652173913, 0.31818181818182
67517, 1.7217391304348, 1.2717391304348, 0.31818181818182
67518, 1.7217391304348, 1.245652173913, 0.29545454545455
67519, 1.7, 1.245652173913, 0.27272727272727
67520, 1.7217391304348, 1.2717391304348, 0.27272727272727
67521, 1.7217391304348, 1.245652173913, 0.25
67522, 1.7, 1.245652173913, 0.22727272727273
67523, 1.7217391304348, 1.2717391304348, 0.22727272727273
67524, 1.7217391304348, 1.245652173913, 0.20454545454545
67525, 1.7, 1.245652173913, 0.18181818181818
67526, 1.7217391304348, 1.2717391304348, 0.18181818181818
67527, 1.7217391304348, 1.245652173913, 0.15909090909091
67528, 1.7, 1.245652173913, 0.13636363636364
67529, 1.7217391304348, 1.2717391304348, 0.13636363636364
67530, 1.7217391304348, 1.245652173913, 0.11363636363636
67531, 1.7, 1.245652173913, 0.090909090909091
67532, 1.7217391304348, 1.2717391304348, 0.090909090909091
67533, 1.7217391304348, 1.245652173913, 0.068181818181818
67534, 1.7, 1.245652173913, 0.045454545454545
67535, 1.7217391304348, 1.2717391304348, 0.045454545454545
67536, 1.7217391304348, 1.245652173913, 0.022727272727273
67537, 1.7652173913043, 1.245652173913, 0.47727272727273
67538, 1.7434782608696, 1.245652173913, 0.45454545454545
67539, 1.7652173913043, 1.2717391304348, 0.45454545454545
67540, 1.7652173913043, 1.245652173913, 0.43181818181818
67541, 1.7434782608696, 1.245652173913, 0.40909090909091
67542, 1.7652173913043, 1.2717391304348, 0.40909090909091
67543, 1.7652173913043, 1.245652173913, 0.38636363636364
67544, 1.7434782608696, 1.245652173913, 0.36363636363636
67545, 1.7652173913043, 1.2717391304348, 0.36363636363636
67546, 1.7652173913043, 1.245652173913, 0.34090909090909
67547, 1.7434782608696, 1.245652173913, 0.31818181818182
67548, 1.7652173913043, 1.2717391304348, 0.31818181818182
67549, 1.7652173913043, 1.245652173913, 0.29545454545455
67550, 1.7434782608696, 1.245652173913, 0.27272727272727
67551, 1.7652173913043, 1.2717391304348, 0.27272727272727
67552, 1.7652173913043, 1.245652173913, 0.25
67553, 1.7434782608696, 1.245652173913, 0.22727272727273
