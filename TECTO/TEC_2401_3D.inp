94448, 94446, 94415, 93723, 93754
32659, 92553, 92543, 92323, 92333, 92554, 92544, 92324, 92334, 94447, 94417, 93755, 94448, 94450, 94420, 93758, 
94451, 94449, 94418, 93726, 93757
32660, 92554, 92544, 92324, 92334, 26318, 26317, 26295, 26296, 94450, 94420, 93758, 94451, 26444, 26441, 26399, 
26443, 94452, 94421, 93729, 93760
32661, 25993, 25992, 25970, 25971, 92555, 92545, 92325, 92335, 26119, 26118, 26074, 26120, 94454, 94424, 93762, 
94455, 94453, 94422, 93730, 93761
32662, 92555, 92545, 92325, 92335, 92556, 92546, 92326, 92336, 94454, 94424, 93762, 94455, 94457, 94427, 93765, 
94458, 94456, 94425, 93733, 93764
32663, 92556, 92546, 92326, 92336, 92557, 92547, 92327, 92337, 94457, 94427, 93765, 94458, 94460, 94430, 93768, 
94461, 94459, 94428, 93736, 93767
32664, 92557, 92547, 92327, 92337, 92558, 92548, 92328, 92338, 94460, 94430, 93768, 94461, 94463, 94433, 93771, 
94464, 94462, 94431, 93739, 93770
32665, 92558, 92548, 92328, 92338, 92559, 92549, 92329, 92339, 94463, 94433, 93771, 94464, 94466, 94436, 93774, 
94467, 94465, 94434, 93742, 93773
32666, 92559, 92549, 92329, 92339, 92560, 92550, 92330, 92340, 94466, 94436, 93774, 94467, 94469, 94439, 93777, 
94470, 94468, 94437, 93745, 93776
32667, 92560, 92550, 92330, 92340, 92561, 92551, 92331, 92341, 94469, 94439, 93777, 94470, 94472, 94442, 93780, 
94473, 94471, 94440, 93748, 93779
32668, 92561, 92551, 92331, 92341, 92562, 92552, 92332, 92342, 94472, 94442, 93780, 94473, 94475, 94445, 93783, 
94476, 94474, 94443, 93751, 93782
32669, 92562, 92552, 92332, 92342, 92563, 92553, 92333, 92343, 94475, 94445, 93783, 94476, 94478, 94448, 93786, 
94479, 94477, 94446, 93754, 93785
32670, 92563, 92553, 92333, 92343, 92564, 92554, 92334, 92344, 94478, 94448, 93786, 94479, 94481, 94451, 93789, 
94482, 94480, 94449, 93757, 93788
32671, 92564, 92554, 92334, 92344, 26319, 26318, 26296, 26297, 94481, 94451, 93789, 94482, 26446, 26443, 26401, 
26445, 94483, 94452, 93760, 93791
32672, 25994, 25993, 25971, 25972, 92565, 92555, 92335, 92345, 26121, 26120, 26076, 26122, 94485, 94455, 93793, 
94486, 94484, 94453, 93761, 93792
32673, 92565, 92555, 92335, 92345, 92566, 92556, 92336, 92346, 94485, 94455, 93793, 94486, 94488, 94458, 93796, 
94489, 94487, 94456, 93764, 93795
32674, 92566, 92556, 92336, 92346, 92567, 92557, 92337, 92347, 94488, 94458, 93796, 94489, 94491, 94461, 93799, 
94492, 94490, 94459, 93767, 93798
32675, 92567, 92557, 92337, 92347, 92568, 92558, 92338, 92348, 94491, 94461, 93799, 94492, 94494, 94464, 93802, 
94495, 94493, 94462, 93770, 93801
32676, 92568, 92558, 92338, 92348, 92569, 92559, 92339, 92349, 94494, 94464, 93802, 94495, 94497, 94467, 93805, 
94498, 94496, 94465, 93773, 93804
32677, 92569, 92559, 92339, 92349, 92570, 92560, 92340, 92350, 94497, 94467, 93805, 94498, 94500, 94470, 93808, 
94501, 94499, 94468, 93776, 93807
32678, 92570, 92560, 92340, 92350, 92571, 92561, 92341, 92351, 94500, 94470, 93808, 94501, 94503, 94473, 93811, 
94504, 94502, 94471, 93779, 93810
32679, 92571, 92561, 92341, 92351, 92572, 92562, 92342, 92352, 94503, 94473, 93811, 94504, 94506, 94476, 93814, 
94507, 94505, 94474, 93782, 93813
32680, 92572, 92562, 92342, 92352, 92573, 92563, 92343, 92353, 94506, 94476, 93814, 94507, 94509, 94479, 93817, 
94510, 94508, 94477, 93785, 93816
32681, 92573, 92563, 92343, 92353, 92574, 92564, 92344, 92354, 94509, 94479, 93817, 94510, 94512, 94482, 93820, 
94513, 94511, 94480, 93788, 93819
32682, 92574, 92564, 92344, 92354, 26320, 26319, 26297, 26298, 94512, 94482, 93820, 94513, 26448, 26445, 26403, 
26447, 94514, 94483, 93791, 93822
32683, 25995, 25994, 25972, 25973, 92575, 92565, 92345, 92355, 26123, 26122, 26078, 26124, 94516, 94486, 93824, 
94517, 94515, 94484, 93792, 93823
32684, 92575, 92565, 92345, 92355, 92576, 92566, 92346, 92356, 94516, 94486, 93824, 94517, 94519, 94489, 93827, 
94520, 94518, 94487, 93795, 93826
32685, 92576, 92566, 92346, 92356, 92577, 92567, 92347, 92357, 94519, 94489, 93827, 94520, 94522, 94492, 93830, 
94523, 94521, 94490, 93798, 93829
32686, 92577, 92567, 92347, 92357, 92578, 92568, 92348, 92358, 94522, 94492, 93830, 94523, 94525, 94495, 93833, 
94526, 94524, 94493, 93801, 93832
32687, 92578, 92568, 92348, 92358, 92579, 92569, 92349, 92359, 94525, 94495, 93833, 94526, 94528, 94498, 93836, 
94529, 94527, 94496, 93804, 93835
32688, 92579, 92569, 92349, 92359, 92580, 92570, 92350, 92360, 94528, 94498, 93836, 94529, 94531, 94501, 93839, 
94532, 94530, 94499, 93807, 93838
32689, 92580, 92570, 92350, 92360, 92581, 92571, 92351, 92361, 94531, 94501, 93839, 94532, 94534, 94504, 93842, 
94535, 94533, 94502, 93810, 93841
32690, 92581, 92571, 92351, 92361, 92582, 92572, 92352, 92362, 94534, 94504, 93842, 94535, 94537, 94507, 93845, 
94538, 94536, 94505, 93813, 93844
32691, 92582, 92572, 92352, 92362, 92583, 92573, 92353, 92363, 94537, 94507, 93845, 94538, 94540, 94510, 93848, 
94541, 94539, 94508, 93816, 93847
32692, 92583, 92573, 92353, 92363, 92584, 92574, 92354, 92364, 94540, 94510, 93848, 94541, 94543, 94513, 93851, 
94544, 94542, 94511, 93819, 93850
32693, 92584, 92574, 92354, 92364, 26321, 26320, 26298, 26299, 94543, 94513, 93851, 94544, 26450, 26447, 26405, 
26449, 94545, 94514, 93822, 93853
32694, 25996, 25995, 25973, 25974, 92585, 92575, 92355, 92365, 26125, 26124, 26080, 26126, 94547, 94517, 93855, 
94548, 94546, 94515, 93823, 93854
32695, 92585, 92575, 92355, 92365, 92586, 92576, 92356, 92366, 94547, 94517, 93855, 94548, 94550, 94520, 93858, 
94551, 94549, 94518, 93826, 93857
32696, 92586, 92576, 92356, 92366, 92587, 92577, 92357, 92367, 94550, 94520, 93858, 94551, 94553, 94523, 93861, 
94554, 94552, 94521, 93829, 93860
32697, 92587, 92577, 92357, 92367, 92588, 92578, 92358, 92368, 94553, 94523, 93861, 94554, 94556, 94526, 93864, 
94557, 94555, 94524, 93832, 93863
32698, 92588, 92578, 92358, 92368, 92589, 92579, 92359, 92369, 94556, 94526, 93864, 94557, 94559, 94529, 93867, 
94560, 94558, 94527, 93835, 93866
32699, 92589, 92579, 92359, 92369, 92590, 92580, 92360, 92370, 94559, 94529, 93867, 94560, 94562, 94532, 93870, 
94563, 94561, 94530, 93838, 93869
32700, 92590, 92580, 92360, 92370, 92591, 92581, 92361, 92371, 94562, 94532, 93870, 94563, 94565, 94535, 93873, 
94566, 94564, 94533, 93841, 93872
32701, 92591, 92581, 92361, 92371, 92592, 92582, 92362, 92372, 94565, 94535, 93873, 94566, 94568, 94538, 93876, 
94569, 94567, 94536, 93844, 93875
32702, 92592, 92582, 92362, 92372, 92593, 92583, 92363, 92373, 94568, 94538, 93876, 94569, 94571, 94541, 93879, 
94572, 94570, 94539, 93847, 93878
32703, 92593, 92583, 92363, 92373, 92594, 92584, 92364, 92374, 94571, 94541, 93879, 94572, 94574, 94544, 93882, 
94575, 94573, 94542, 93850, 93881
32704, 92594, 92584, 92364, 92374, 26322, 26321, 26299, 26300, 94574, 94544, 93882, 94575, 26452, 26449, 26407, 
26451, 94576, 94545, 93853, 93884
32705, 25997, 25996, 25974, 25975, 92595, 92585, 92365, 92375, 26127, 26126, 26082, 26128, 94578, 94548, 93886, 
94579, 94577, 94546, 93854, 93885
32706, 92595, 92585, 92365, 92375, 92596, 92586, 92366, 92376, 94578, 94548, 93886, 94579, 94581, 94551, 93889, 
94582, 94580, 94549, 93857, 93888
32707, 92596, 92586, 92366, 92376, 92597, 92587, 92367, 92377, 94581, 94551, 93889, 94582, 94584, 94554, 93892, 
94585, 94583, 94552, 93860, 93891
32708, 92597, 92587, 92367, 92377, 92598, 92588, 92368, 92378, 94584, 94554, 93892, 94585, 94587, 94557, 93895, 
94588, 94586, 94555, 93863, 93894
32709, 92598, 92588, 92368, 92378, 92599, 92589, 92369, 92379, 94587, 94557, 93895, 94588, 94590, 94560, 93898, 
94591, 94589, 94558, 93866, 93897
32710, 92599, 92589, 92369, 92379, 92600, 92590, 92370, 92380, 94590, 94560, 93898, 94591, 94593, 94563, 93901, 
94594, 94592, 94561, 93869, 93900
32711, 92600, 92590, 92370, 92380, 92601, 92591, 92371, 92381, 94593, 94563, 93901, 94594, 94596, 94566, 93904, 
94597, 94595, 94564, 93872, 93903
32712, 92601, 92591, 92371, 92381, 92602, 92592, 92372, 92382, 94596, 94566, 93904, 94597, 94599, 94569, 93907, 
94600, 94598, 94567, 93875, 93906
32713, 92602, 92592, 92372, 92382, 92603, 92593, 92373, 92383, 94599, 94569, 93907, 94600, 94602, 94572, 93910, 
94603, 94601, 94570, 93878, 93909
32714, 92603, 92593, 92373, 92383, 92604, 92594, 92374, 92384, 94602, 94572, 93910, 94603, 94605, 94575, 93913, 
94606, 94604, 94573, 93881, 93912
32715, 92604, 92594, 92374, 92384, 26323, 26322, 26300, 26301, 94605, 94575, 93913, 94606, 26454, 26451, 26409, 
26453, 94607, 94576, 93884, 93915
32716, 25998, 25997, 25975, 25976, 92605, 92595, 92375, 92385, 26129, 26128, 26084, 26130, 94609, 94579, 93917, 
94610, 94608, 94577, 93885, 93916
32717, 92605, 92595, 92375, 92385, 92606, 92596, 92376, 92386, 94609, 94579, 93917, 94610, 94612, 94582, 93920, 
94613, 94611, 94580, 93888, 93919
32718, 92606, 92596, 92376, 92386, 92607, 92597, 92377, 92387, 94612, 94582, 93920, 94613, 94615, 94585, 93923, 
94616, 94614, 94583, 93891, 93922
32719, 92607, 92597, 92377, 92387, 92608, 92598, 92378, 92388, 94615, 94585, 93923, 94616, 94618, 94588, 93926, 
94619, 94617, 94586, 93894, 93925
32720, 92608, 92598, 92378, 92388, 92609, 92599, 92379, 92389, 94618, 94588, 93926, 94619, 94621, 94591, 93929, 
94622, 94620, 94589, 93897, 93928
32721, 92609, 92599, 92379, 92389, 92610, 92600, 92380, 92390, 94621, 94591, 93929, 94622, 94624, 94594, 93932, 
94625, 94623, 94592, 93900, 93931
32722, 92610, 92600, 92380, 92390, 92611, 92601, 92381, 92391, 94624, 94594, 93932, 94625, 94627, 94597, 93935, 
94628, 94626, 94595, 93903, 93934
32723, 92611, 92601, 92381, 92391, 92612, 92602, 92382, 92392, 94627, 94597, 93935, 94628, 94630, 94600, 93938, 
94631, 94629, 94598, 93906, 93937
32724, 92612, 92602, 92382, 92392, 92613, 92603, 92383, 92393, 94630, 94600, 93938, 94631, 94633, 94603, 93941, 
94634, 94632, 94601, 93909, 93940
32725, 92613, 92603, 92383, 92393, 92614, 92604, 92384, 92394, 94633, 94603, 93941, 94634, 94636, 94606, 93944, 
94637, 94635, 94604, 93912, 93943
32726, 92614, 92604, 92384, 92394, 26324, 26323, 26301, 26302, 94636, 94606, 93944, 94637, 26456, 26453, 26411, 
26455, 94638, 94607, 93915, 93946
32727, 25999, 25998, 25976, 25977, 92615, 92605, 92385, 92395, 26131, 26130, 26086, 26132, 94640, 94610, 93948, 
94641, 94639, 94608, 93916, 93947
32728, 92615, 92605, 92385, 92395, 92616, 92606, 92386, 92396, 94640, 94610, 93948, 94641, 94643, 94613, 93951, 
94644, 94642, 94611, 93919, 93950
32729, 92616, 92606, 92386, 92396, 92617, 92607, 92387, 92397, 94643, 94613, 93951, 94644, 94646, 94616, 93954, 
94647, 94645, 94614, 93922, 93953
32730, 92617, 92607, 92387, 92397, 92618, 92608, 92388, 92398, 94646, 94616, 93954, 94647, 94649, 94619, 93957, 
94650, 94648, 94617, 93925, 93956
32731, 92618, 92608, 92388, 92398, 92619, 92609, 92389, 92399, 94649, 94619, 93957, 94650, 94652, 94622, 93960, 
94653, 94651, 94620, 93928, 93959
32732, 92619, 92609, 92389, 92399, 92620, 92610, 92390, 92400, 94652, 94622, 93960, 94653, 94655, 94625, 93963, 
94656, 94654, 94623, 93931, 93962
32733, 92620, 92610, 92390, 92400, 92621, 92611, 92391, 92401, 94655, 94625, 93963, 94656, 94658, 94628, 93966, 
94659, 94657, 94626, 93934, 93965
32734, 92621, 92611, 92391, 92401, 92622, 92612, 92392, 92402, 94658, 94628, 93966, 94659, 94661, 94631, 93969, 
94662, 94660, 94629, 93937, 93968
32735, 92622, 92612, 92392, 92402, 92623, 92613, 92393, 92403, 94661, 94631, 93969, 94662, 94664, 94634, 93972, 
94665, 94663, 94632, 93940, 93971
32736, 92623, 92613, 92393, 92403, 92624, 92614, 92394, 92404, 94664, 94634, 93972, 94665, 94667, 94637, 93975, 
94668, 94666, 94635, 93943, 93974
32737, 92624, 92614, 92394, 92404, 26325, 26324, 26302, 26303, 94667, 94637, 93975, 94668, 26458, 26455, 26413, 
26457, 94669, 94638, 93946, 93977
32738, 26000, 25999, 25977, 25978, 92625, 92615, 92395, 92405, 26133, 26132, 26088, 26134, 94671, 94641, 93979, 
94672, 94670, 94639, 93947, 93978
32739, 92625, 92615, 92395, 92405, 92626, 92616, 92396, 92406, 94671, 94641, 93979, 94672, 94674, 94644, 93982, 
94675, 94673, 94642, 93950, 93981
32740, 92626, 92616, 92396, 92406, 92627, 92617, 92397, 92407, 94674, 94644, 93982, 94675, 94677, 94647, 93985, 
94678, 94676, 94645, 93953, 93984
32741, 92627, 92617, 92397, 92407, 92628, 92618, 92398, 92408, 94677, 94647, 93985, 94678, 94680, 94650, 93988, 
94681, 94679, 94648, 93956, 93987
32742, 92628, 92618, 92398, 92408, 92629, 92619, 92399, 92409, 94680, 94650, 93988, 94681, 94683, 94653, 93991, 
94684, 94682, 94651, 93959, 93990
32743, 92629, 92619, 92399, 92409, 92630, 92620, 92400, 92410, 94683, 94653, 93991, 94684, 94686, 94656, 93994, 
94687, 94685, 94654, 93962, 93993
32744, 92630, 92620, 92400, 92410, 92631, 92621, 92401, 92411, 94686, 94656, 93994, 94687, 94689, 94659, 93997, 
94690, 94688, 94657, 93965, 93996
32745, 92631, 92621, 92401, 92411, 92632, 92622, 92402, 92412, 94689, 94659, 93997, 94690, 94692, 94662, 94000, 
94693, 94691, 94660, 93968, 93999
32746, 92632, 92622, 92402, 92412, 92633, 92623, 92403, 92413, 94692, 94662, 94000, 94693, 94695, 94665, 94003, 
94696, 94694, 94663, 93971, 94002
32747, 92633, 92623, 92403, 92413, 92634, 92624, 92404, 92414, 94695, 94665, 94003, 94696, 94698, 94668, 94006, 
94699, 94697, 94666, 93974, 94005
32748, 92634, 92624, 92404, 92414, 26326, 26325, 26303, 26304, 94698, 94668, 94006, 94699, 26460, 26457, 26415, 
26459, 94700, 94669, 93977, 94008
32749, 2567, 26000, 25978, 2566, 26513, 92625, 92405, 26503, 26135, 26134, 26090, 2570, 94701, 94672, 94009, 
26574, 26576, 94670, 93978, 26555
32750, 26513, 92625, 92405, 26503, 26512, 92626, 92406, 26502, 94701, 94672, 94009, 26574, 94702, 94675, 94010, 
26572, 26575, 94673, 93981, 26554
32751, 26512, 92626, 92406, 26502, 26511, 92627, 92407, 26501, 94702, 94675, 94010, 26572, 94703, 94678, 94011, 
26570, 26573, 94676, 93984, 26552
32752, 26511, 92627, 92407, 26501, 26510, 92628, 92408, 26500, 94703, 94678, 94011, 26570, 94704, 94681, 94012, 
26568, 26571, 94679, 93987, 26550
32753, 26510, 92628, 92408, 26500, 26509, 92629, 92409, 26499, 94704, 94681, 94012, 26568, 94705, 94684, 94013, 
26566, 26569, 94682, 93990, 26548
32754, 26509, 92629, 92409, 26499, 26508, 92630, 92410, 26498, 94705, 94684, 94013, 26566, 94706, 94687, 94014, 
26564, 26567, 94685, 93993, 26546
32755, 26508, 92630, 92410, 26498, 26507, 92631, 92411, 26497, 94706, 94687, 94014, 26564, 94707, 94690, 94015, 
26562, 26565, 94688, 93996, 26544
32756, 26507, 92631, 92411, 26497, 26506, 92632, 92412, 26496, 94707, 94690, 94015, 26562, 94708, 94693, 94016, 
26560, 26563, 94691, 93999, 26542
32757, 26506, 92632, 92412, 26496, 26505, 92633, 92413, 26495, 94708, 94693, 94016, 26560, 94709, 94696, 94017, 
26558, 26561, 94694, 94002, 26540
32758, 26505, 92633, 92413, 26495, 26504, 92634, 92414, 26494, 94709, 94696, 94017, 26558, 94710, 94699, 94018, 
26556, 26559, 94697, 94005, 26538
32759, 26504, 92634, 92414, 26494, 2647, 26326, 26304, 2646, 94710, 94699, 94018, 26556, 26461, 26459, 26416, 
2650, 26557, 94700, 94008, 26536
32760, 2593, 63, 2560, 25979, 26797, 2624, 26187, 92415, 2616, 2564, 26091, 26136, 27269, 26260, 94020, 
94711, 27248, 2634, 26250, 94019
32761, 26797, 2624, 26187, 92415, 26798, 2625, 26186, 92416, 27269, 26260, 94020, 94711, 27270, 26259, 94023, 
94712, 27250, 2635, 26248, 94022
32762, 26798, 2625, 26186, 92416, 26799, 2626, 26185, 92417, 27270, 26259, 94023, 94712, 27271, 26258, 94026, 
94713, 27252, 2636, 26246, 94025
32763, 26799, 2626, 26185, 92417, 26800, 2627, 26184, 92418, 27271, 26258, 94026, 94713, 27272, 26257, 94029, 
94714, 27254, 2637, 26244, 94028
32764, 26800, 2627, 26184, 92418, 26801, 2628, 26183, 92419, 27272, 26257, 94029, 94714, 27273, 26256, 94032, 
94715, 27256, 2638, 26242, 94031
32765, 26801, 2628, 26183, 92419, 26802, 2629, 26182, 92420, 27273, 26256, 94032, 94715, 27274, 26255, 94035, 
94716, 27258, 2639, 26240, 94034
32766, 26802, 2629, 26182, 92420, 26803, 2630, 26181, 92421, 27274, 26255, 94035, 94716, 27275, 26254, 94038, 
94717, 27260, 2640, 26238, 94037
32767, 26803, 2630, 26181, 92421, 26804, 2631, 26180, 92422, 27275, 26254, 94038, 94717, 27276, 26253, 94041, 
94718, 27262, 2641, 26236, 94040
32768, 26804, 2631, 26180, 92422, 26805, 2632, 26179, 92423, 27276, 26253, 94041, 94718, 27277, 26252, 94044, 
94719, 27264, 2642, 26234, 94043
32769, 26805, 2632, 26179, 92423, 26806, 2633, 26178, 92424, 27277, 26252, 94044, 94719, 27278, 26251, 94047, 
94720, 27266, 2643, 26232, 94046
32770, 26806, 2633, 26178, 92424, 2673, 65, 2619, 26305, 27278, 26251, 94047, 94720, 2696, 2623, 26418, 
26462, 27268, 2644, 26230, 94049
32771, 2592, 2593, 25979, 25980, 26787, 26797, 92415, 92425, 2615, 26136, 26093, 26137, 27249, 94711, 94051, 
94721, 27227, 27248, 94019, 94050
32772, 26787, 26797, 92415, 92425, 26788, 26798, 92416, 92426, 27249, 94711, 94051, 94721, 27251, 94712, 94054, 
94722, 27229, 27250, 94022, 94053
32773, 26788, 26798, 92416, 92426, 26789, 26799, 92417, 92427, 27251, 94712, 94054, 94722, 27253, 94713, 94057, 
94723, 27231, 27252, 94025, 94056
32774, 26789, 26799, 92417, 92427, 26790, 26800, 92418, 92428, 27253, 94713, 94057, 94723, 27255, 94714, 94060, 
94724, 27233, 27254, 94028, 94059
32775, 26790, 26800, 92418, 92428, 26791, 26801, 92419, 92429, 27255, 94714, 94060, 94724, 27257, 94715, 94063, 
94725, 27235, 27256, 94031, 94062
32776, 26791, 26801, 92419, 92429, 26792, 26802, 92420, 92430, 27257, 94715, 94063, 94725, 27259, 94716, 94066, 
94726, 27237, 27258, 94034, 94065
32777, 26792, 26802, 92420, 92430, 26793, 26803, 92421, 92431, 27259, 94716, 94066, 94726, 27261, 94717, 94069, 
94727, 27239, 27260, 94037, 94068
32778, 26793, 26803, 92421, 92431, 26794, 26804, 92422, 92432, 27261, 94717, 94069, 94727, 27263, 94718, 94072, 
94728, 27241, 27262, 94040, 94071
32779, 26794, 26804, 92422, 92432, 26795, 26805, 92423, 92433, 27263, 94718, 94072, 94728, 27265, 94719, 94075, 
94729, 27243, 27264, 94043, 94074
32780, 26795, 26805, 92423, 92433, 26796, 26806, 92424, 92434, 27265, 94719, 94075, 94729, 27267, 94720, 94078, 
94730, 27245, 27266, 94046, 94077
32781, 26796, 26806, 92424, 92434, 2672, 2673, 26305, 26306, 27267, 94720, 94078, 94730, 2695, 26462, 26420, 
26463, 27247, 27268, 94049, 94080
32782, 2591, 2592, 25980, 25981, 26777, 26787, 92425, 92435, 2614, 26137, 26095, 26138, 27228, 94721, 94082, 
94731, 27206, 27227, 94050, 94081
32783, 26777, 26787, 92425, 92435, 26778, 26788, 92426, 92436, 27228, 94721, 94082, 94731, 27230, 94722, 94085, 
94732, 27208, 27229, 94053, 94084
32784, 26778, 26788, 92426, 92436, 26779, 26789, 92427, 92437, 27230, 94722, 94085, 94732, 27232, 94723, 94088, 
94733, 27210, 27231, 94056, 94087
32785, 26779, 26789, 92427, 92437, 26780, 26790, 92428, 92438, 27232, 94723, 94088, 94733, 27234, 94724, 94091, 
94734, 27212, 27233, 94059, 94090
32786, 26780, 26790, 92428, 92438, 26781, 26791, 92429, 92439, 27234, 94724, 94091, 94734, 27236, 94725, 94094, 
94735, 27214, 27235, 94062, 94093
32787, 26781, 26791, 92429, 92439, 26782, 26792, 92430, 92440, 27236, 94725, 94094, 94735, 27238, 94726, 94097, 
94736, 27216, 27237, 94065, 94096
32788, 26782, 26792, 92430, 92440, 26783, 26793, 92431, 92441, 27238, 94726, 94097, 94736, 27240, 94727, 94100, 
94737, 27218, 27239, 94068, 94099
32789, 26783, 26793, 92431, 92441, 26784, 26794, 92432, 92442, 27240, 94727, 94100, 94737, 27242, 94728, 94103, 
94738, 27220, 27241, 94071, 94102
32790, 26784, 26794, 92432, 92442, 26785, 26795, 92433, 92443, 27242, 94728, 94103, 94738, 27244, 94729, 94106, 
94739, 27222, 27243, 94074, 94105
32791, 26785, 26795, 92433, 92443, 26786, 26796, 92434, 92444, 27244, 94729, 94106, 94739, 27246, 94730, 94109, 
94740, 27224, 27245, 94077, 94108
32792, 26786, 26796, 92434, 92444, 2671, 2672, 26306, 26307, 27246, 94730, 94109, 94740, 2694, 26463, 26422, 
26464, 27226, 27247, 94080, 94111
32793, 2590, 2591, 25981, 25982, 26767, 26777, 92435, 92445, 2613, 26138, 26097, 26139, 27207, 94731, 94113, 
94741, 27185, 27206, 94081, 94112
32794, 26767, 26777, 92435, 92445, 26768, 26778, 92436, 92446, 27207, 94731, 94113, 94741, 27209, 94732, 94116, 
94742, 27187, 27208, 94084, 94115
32795, 26768, 26778, 92436, 92446, 26769, 26779, 92437, 92447, 27209, 94732, 94116, 94742, 27211, 94733, 94119, 
94743, 27189, 27210, 94087, 94118
32796, 26769, 26779, 92437, 92447, 26770, 26780, 92438, 92448, 27211, 94733, 94119, 94743, 27213, 94734, 94122, 
94744, 27191, 27212, 94090, 94121
32797, 26770, 26780, 92438, 92448, 26771, 26781, 92439, 92449, 27213, 94734, 94122, 94744, 27215, 94735, 94125, 
94745, 27193, 27214, 94093, 94124
32798, 26771, 26781, 92439, 92449, 26772, 26782, 92440, 92450, 27215, 94735, 94125, 94745, 27217, 94736, 94128, 
94746, 27195, 27216, 94096, 94127
32799, 26772, 26782, 92440, 92450, 26773, 26783, 92441, 92451, 27217, 94736, 94128, 94746, 27219, 94737, 94131, 
94747, 27197, 27218, 94099, 94130
32800, 26773, 26783, 92441, 92451, 26774, 26784, 92442, 92452, 27219, 94737, 94131, 94747, 27221, 94738, 94134, 
94748, 27199, 27220, 94102, 94133
32801, 26774, 26784, 92442, 92452, 26775, 26785, 92443, 92453, 27221, 94738, 94134, 94748, 27223, 94739, 94137, 
94749, 27201, 27222, 94105, 94136
32802, 26775, 26785, 92443, 92453, 26776, 26786, 92444, 92454, 27223, 94739, 94137, 94749, 27225, 94740, 94140, 
94750, 27203, 27224, 94108, 94139
32803, 26776, 26786, 92444, 92454, 2670, 2671, 26307, 26308, 27225, 94740, 94140, 94750, 2693, 26464, 26424, 
26465, 27205, 27226, 94111, 94142
32804, 2589, 2590, 25982, 25983, 26757, 26767, 92445, 92455, 2612, 26139, 26099, 26140, 27186, 94741, 94144, 
94751, 27164, 27185, 94112, 94143
32805, 26757, 26767, 92445, 92455, 26758, 26768, 92446, 92456, 27186, 94741, 94144, 94751, 27188, 94742, 94147, 
94752, 27166, 27187, 94115, 94146
32806, 26758, 26768, 92446, 92456, 26759, 26769, 92447, 92457, 27188, 94742, 94147, 94752, 27190, 94743, 94150, 
94753, 27168, 27189, 94118, 94149
32807, 26759, 26769, 92447, 92457, 26760, 26770, 92448, 92458, 27190, 94743, 94150, 94753, 27192, 94744, 94153, 
94754, 27170, 27191, 94121, 94152
32808, 26760, 26770, 92448, 92458, 26761, 26771, 92449, 92459, 27192, 94744, 94153, 94754, 27194, 94745, 94156, 
94755, 27172, 27193, 94124, 94155
32809, 26761, 26771, 92449, 92459, 26762, 26772, 92450, 92460, 27194, 94745, 94156, 94755, 27196, 94746, 94159, 
94756, 27174, 27195, 94127, 94158
32810, 26762, 26772, 92450, 92460, 26763, 26773, 92451, 92461, 27196, 94746, 94159, 94756, 27198, 94747, 94162, 
94757, 27176, 27197, 94130, 94161
32811, 26763, 26773, 92451, 92461, 26764, 26774, 92452, 92462, 27198, 94747, 94162, 94757, 27200, 94748, 94165, 
94758, 27178, 27199, 94133, 94164
32812, 26764, 26774, 92452, 92462, 26765, 26775, 92453, 92463, 27200, 94748, 94165, 94758, 27202, 94749, 94168, 
94759, 27180, 27201, 94136, 94167
32813, 26765, 26775, 92453, 92463, 26766, 26776, 92454, 92464, 27202, 94749, 94168, 94759, 27204, 94750, 94171, 
94760, 27182, 27203, 94139, 94170
32814, 26766, 26776, 92454, 92464, 2669, 2670, 26308, 26309, 27204, 94750, 94171, 94760, 2692, 26465, 26426, 
26466, 27184, 27205, 94142, 94173
32815, 2588, 2589, 25983, 25984, 26747, 26757, 92455, 92465, 2611, 26140, 26101, 26141, 27165, 94751, 94175, 
94761, 27143, 27164, 94143, 94174
32816, 26747, 26757, 92455, 92465, 26748, 26758, 92456, 92466, 27165, 94751, 94175, 94761, 27167, 94752, 94178, 
94762, 27145, 27166, 94146, 94177
32817, 26748, 26758, 92456, 92466, 26749, 26759, 92457, 92467, 27167, 94752, 94178, 94762, 27169, 94753, 94181, 
94763, 27147, 27168, 94149, 94180
32818, 26749, 26759, 92457, 92467, 26750, 26760, 92458, 92468, 27169, 94753, 94181, 94763, 27171, 94754, 94184, 
94764, 27149, 27170, 94152, 94183
32819, 26750, 26760, 92458, 92468, 26751, 26761, 92459, 92469, 27171, 94754, 94184, 94764, 27173, 94755, 94187, 
94765, 27151, 27172, 94155, 94186
32820, 26751, 26761, 92459, 92469, 26752, 26762, 92460, 92470, 27173, 94755, 94187, 94765, 27175, 94756, 94190, 
94766, 27153, 27174, 94158, 94189
32821, 26752, 26762, 92460, 92470, 26753, 26763, 92461, 92471, 27175, 94756, 94190, 94766, 27177, 94757, 94193, 
94767, 27155, 27176, 94161, 94192
32822, 26753, 26763, 92461, 92471, 26754, 26764, 92462, 92472, 27177, 94757, 94193, 94767, 27179, 94758, 94196, 
94768, 27157, 27178, 94164, 94195
32823, 26754, 26764, 92462, 92472, 26755, 26765, 92463, 92473, 27179, 94758, 94196, 94768, 27181, 94759, 94199, 
94769, 27159, 27180, 94167, 94198
32824, 26755, 26765, 92463, 92473, 26756, 26766, 92464, 92474, 27181, 94759, 94199, 94769, 27183, 94760, 94202, 
94770, 27161, 27182, 94170, 94201
32825, 26756, 26766, 92464, 92474, 2668, 2669, 26309, 26310, 27183, 94760, 94202, 94770, 2691, 26466, 26428, 
26467, 27163, 27184, 94173, 94204
32826, 2587, 2588, 25984, 25985, 26737, 26747, 92465, 92475, 2610, 26141, 26103, 26142, 27144, 94761, 94206, 
94771, 27122, 27143, 94174, 94205
32827, 26737, 26747, 92465, 92475, 26738, 26748, 92466, 92476, 27144, 94761, 94206, 94771, 27146, 94762, 94209, 
94772, 27124, 27145, 94177, 94208
32828, 26738, 26748, 92466, 92476, 26739, 26749, 92467, 92477, 27146, 94762, 94209, 94772, 27148, 94763, 94212, 
94773, 27126, 27147, 94180, 94211
32829, 26739, 26749, 92467, 92477, 26740, 26750, 92468, 92478, 27148, 94763, 94212, 94773, 27150, 94764, 94215, 
94774, 27128, 27149, 94183, 94214
32830, 26740, 26750, 92468, 92478, 26741, 26751, 92469, 92479, 27150, 94764, 94215, 94774, 27152, 94765, 94218, 
94775, 27130, 27151, 94186, 94217
32831, 26741, 26751, 92469, 92479, 26742, 26752, 92470, 92480, 27152, 94765, 94218, 94775, 27154, 94766, 94221, 
94776, 27132, 27153, 94189, 94220
32832, 26742, 26752, 92470, 92480, 26743, 26753, 92471, 92481, 27154, 94766, 94221, 94776, 27156, 94767, 94224, 
94777, 27134, 27155, 94192, 94223
32833, 26743, 26753, 92471, 92481, 26744, 26754, 92472, 92482, 27156, 94767, 94224, 94777, 27158, 94768, 94227, 
94778, 27136, 27157, 94195, 94226
32834, 26744, 26754, 92472, 92482, 26745, 26755, 92473, 92483, 27158, 94768, 94227, 94778, 27160, 94769, 94230, 
94779, 27138, 27159, 94198, 94229
32835, 26745, 26755, 92473, 92483, 26746, 26756, 92474, 92484, 27160, 94769, 94230, 94779, 27162, 94770, 94233, 
94780, 27140, 27161, 94201, 94232
32836, 26746, 26756, 92474, 92484, 2667, 2668, 26310, 26311, 27162, 94770, 94233, 94780, 2690, 26467, 26430, 
26468, 27142, 27163, 94204, 94235
32837, 2586, 2587, 25985, 25986, 26727, 26737, 92475, 92485, 2609, 26142, 26105, 26143, 27123, 94771, 94237, 
94781, 27101, 27122, 94205, 94236
32838, 26727, 26737, 92475, 92485, 26728, 26738, 92476, 92486, 27123, 94771, 94237, 94781, 27125, 94772, 94240, 
94782, 27103, 27124, 94208, 94239
32839, 26728, 26738, 92476, 92486, 26729, 26739, 92477, 92487, 27125, 94772, 94240, 94782, 27127, 94773, 94243, 
94783, 27105, 27126, 94211, 94242
32840, 26729, 26739, 92477, 92487, 26730, 26740, 92478, 92488, 27127, 94773, 94243, 94783, 27129, 94774, 94246, 
94784, 27107, 27128, 94214, 94245
32841, 26730, 26740, 92478, 92488, 26731, 26741, 92479, 92489, 27129, 94774, 94246, 94784, 27131, 94775, 94249, 
94785, 27109, 27130, 94217, 94248
32842, 26731, 26741, 92479, 92489, 26732, 26742, 92480, 92490, 27131, 94775, 94249, 94785, 27133, 94776, 94252, 
94786, 27111, 27132, 94220, 94251
32843, 26732, 26742, 92480, 92490, 26733, 26743, 92481, 92491, 27133, 94776, 94252, 94786, 27135, 94777, 94255, 
94787, 27113, 27134, 94223, 94254
32844, 26733, 26743, 92481, 92491, 26734, 26744, 92482, 92492, 27135, 94777, 94255, 94787, 27137, 94778, 94258, 
94788, 27115, 27136, 94226, 94257
32845, 26734, 26744, 92482, 92492, 26735, 26745, 92483, 92493, 27137, 94778, 94258, 94788, 27139, 94779, 94261, 
94789, 27117, 27138, 94229, 94260
32846, 26735, 26745, 92483, 92493, 26736, 26746, 92484, 92494, 27139, 94779, 94261, 94789, 27141, 94780, 94264, 
94790, 27119, 27140, 94232, 94263
32847, 26736, 26746, 92484, 92494, 2666, 2667, 26311, 26312, 27141, 94780, 94264, 94790, 2689, 26468, 26432, 
26469, 27121, 27142, 94235, 94266
32848, 2585, 2586, 25986, 25987, 26717, 26727, 92485, 92495, 2608, 26143, 26107, 26144, 27102, 94781, 94268, 
94791, 27080, 27101, 94236, 94267
32849, 26717, 26727, 92485, 92495, 26718, 26728, 92486, 92496, 27102, 94781, 94268, 94791, 27104, 94782, 94271, 
94792, 27082, 27103, 94239, 94270
32850, 26718, 26728, 92486, 92496, 26719, 26729, 92487, 92497, 27104, 94782, 94271, 94792, 27106, 94783, 94274, 
94793, 27084, 27105, 94242, 94273
32851, 26719, 26729, 92487, 92497, 26720, 26730, 92488, 92498, 27106, 94783, 94274, 94793, 27108, 94784, 94277, 
94794, 27086, 27107, 94245, 94276
32852, 26720, 26730, 92488, 92498, 26721, 26731, 92489, 92499, 27108, 94784, 94277, 94794, 27110, 94785, 94280, 
94795, 27088, 27109, 94248, 94279
32853, 26721, 26731, 92489, 92499, 26722, 26732, 92490, 92500, 27110, 94785, 94280, 94795, 27112, 94786, 94283, 
94796, 27090, 27111, 94251, 94282
32854, 26722, 26732, 92490, 92500, 26723, 26733, 92491, 92501, 27112, 94786, 94283, 94796, 27114, 94787, 94286, 
94797, 27092, 27113, 94254, 94285
32855, 26723, 26733, 92491, 92501, 26724, 26734, 92492, 92502, 27114, 94787, 94286, 94797, 27116, 94788, 94289, 
94798, 27094, 27115, 94257, 94288
32856, 26724, 26734, 92492, 92502, 26725, 26735, 92493, 92503, 27116, 94788, 94289, 94798, 27118, 94789, 94292, 
94799, 27096, 27117, 94260, 94291
32857, 26725, 26735, 92493, 92503, 26726, 26736, 92494, 92504, 27118, 94789, 94292, 94799, 27120, 94790, 94295, 
94800, 27098, 27119, 94263, 94294
32858, 26726, 26736, 92494, 92504, 2665, 2666, 26312, 26313, 27120, 94790, 94295, 94800, 2688, 26469, 26434, 
26470, 27100, 27121, 94266, 94297
32859, 2584, 2585, 25987, 25988, 26707, 26717, 92495, 92505, 2607, 26144, 26109, 26145, 27081, 94791, 94299, 
94801, 27059, 27080, 94267, 94298
32860, 26707, 26717, 92495, 92505, 26708, 26718, 92496, 92506, 27081, 94791, 94299, 94801, 27083, 94792, 94302, 
94802, 27061, 27082, 94270, 94301
32861, 26708, 26718, 92496, 92506, 26709, 26719, 92497, 92507, 27083, 94792, 94302, 94802, 27085, 94793, 94305, 
94803, 27063, 27084, 94273, 94304
32862, 26709, 26719, 92497, 92507, 26710, 26720, 92498, 92508, 27085, 94793, 94305, 94803, 27087, 94794, 94308, 
94804, 27065, 27086, 94276, 94307
32863, 26710, 26720, 92498, 92508, 26711, 26721, 92499, 92509, 27087, 94794, 94308, 94804, 27089, 94795, 94311, 
94805, 27067, 27088, 94279, 94310
32864, 26711, 26721, 92499, 92509, 26712, 26722, 92500, 92510, 27089, 94795, 94311, 94805, 27091, 94796, 94314, 
94806, 27069, 27090, 94282, 94313
32865, 26712, 26722, 92500, 92510, 26713, 26723, 92501, 92511, 27091, 94796, 94314, 94806, 27093, 94797, 94317, 
94807, 27071, 27092, 94285, 94316
32866, 26713, 26723, 92501, 92511, 26714, 26724, 92502, 92512, 27093, 94797, 94317, 94807, 27095, 94798, 94320, 
94808, 27073, 27094, 94288, 94319
32867, 26714, 26724, 92502, 92512, 26715, 26725, 92503, 92513, 27095, 94798, 94320, 94808, 27097, 94799, 94323, 
94809, 27075, 27096, 94291, 94322
32868, 26715, 26725, 92503, 92513, 26716, 26726, 92504, 92514, 27097, 94799, 94323, 94809, 27099, 94800, 94326, 
94810, 27077, 27098, 94294, 94325
32869, 26716, 26726, 92504, 92514, 2664, 2665, 26313, 26314, 27099, 94800, 94326, 94810, 2687, 26470, 26436, 
26471, 27079, 27100, 94297, 94328
32870, 2583, 2584, 25988, 25989, 26697, 26707, 92505, 92515, 2606, 26145, 26111, 26146, 27060, 94801, 94330, 
94811, 27038, 27059, 94298, 94329
32871, 26697, 26707, 92505, 92515, 26698, 26708, 92506, 92516, 27060, 94801, 94330, 94811, 27062, 94802, 94333, 
94812, 27040, 27061, 94301, 94332
32872, 26698, 26708, 92506, 92516, 26699, 26709, 92507, 92517, 27062, 94802, 94333, 94812, 27064, 94803, 94336, 
94813, 27042, 27063, 94304, 94335
32873, 26699, 26709, 92507, 92517, 26700, 26710, 92508, 92518, 27064, 94803, 94336, 94813, 27066, 94804, 94339, 
94814, 27044, 27065, 94307, 94338
32874, 26700, 26710, 92508, 92518, 26701, 26711, 92509, 92519, 27066, 94804, 94339, 94814, 27068, 94805, 94342, 
94815, 27046, 27067, 94310, 94341
32875, 26701, 26711, 92509, 92519, 26702, 26712, 92510, 92520, 27068, 94805, 94342, 94815, 27070, 94806, 94345, 
94816, 27048, 27069, 94313, 94344
32876, 26702, 26712, 92510, 92520, 26703, 26713, 92511, 92521, 27070, 94806, 94345, 94816, 27072, 94807, 94348, 
94817, 27050, 27071, 94316, 94347
32877, 26703, 26713, 92511, 92521, 26704, 26714, 92512, 92522, 27072, 94807, 94348, 94817, 27074, 94808, 94351, 
94818, 27052, 27073, 94319, 94350
32878, 26704, 26714, 92512, 92522, 26705, 26715, 92513, 92523, 27074, 94808, 94351, 94818, 27076, 94809, 94354, 
94819, 27054, 27075, 94322, 94353
32879, 26705, 26715, 92513, 92523, 26706, 26716, 92514, 92524, 27076, 94809, 94354, 94819, 27078, 94810, 94357, 
94820, 27056, 27077, 94325, 94356
32880, 26706, 26716, 92514, 92524, 2663, 2664, 26314, 26315, 27078, 94810, 94357, 94820, 2686, 26471, 26438, 
26472, 27058, 27079, 94328, 94359
32881, 2582, 2583, 25989, 25990, 26687, 26697, 92515, 92525, 2605, 26146, 26113, 26147, 27039, 94811, 94361, 
94821, 27017, 27038, 94329, 94360
32882, 26687, 26697, 92515, 92525, 26688, 26698, 92516, 92526, 27039, 94811, 94361, 94821, 27041, 94812, 94364, 
94822, 27019, 27040, 94332, 94363
32883, 26688, 26698, 92516, 92526, 26689, 26699, 92517, 92527, 27041, 94812, 94364, 94822, 27043, 94813, 94367, 
94823, 27021, 27042, 94335, 94366
32884, 26689, 26699, 92517, 92527, 26690, 26700, 92518, 92528, 27043, 94813, 94367, 94823, 27045, 94814, 94370, 
94824, 27023, 27044, 94338, 94369
32885, 26690, 26700, 92518, 92528, 26691, 26701, 92519, 92529, 27045, 94814, 94370, 94824, 27047, 94815, 94373, 
94825, 27025, 27046, 94341, 94372
32886, 26691, 26701, 92519, 92529, 26692, 26702, 92520, 92530, 27047, 94815, 94373, 94825, 27049, 94816, 94376, 
94826, 27027, 27048, 94344, 94375
32887, 26692, 26702, 92520, 92530, 26693, 26703, 92521, 92531, 27049, 94816, 94376, 94826, 27051, 94817, 94379, 
94827, 27029, 27050, 94347, 94378
32888, 26693, 26703, 92521, 92531, 26694, 26704, 92522, 92532, 27051, 94817, 94379, 94827, 27053, 94818, 94382, 
94828, 27031, 27052, 94350, 94381
32889, 26694, 26704, 92522, 92532, 26695, 26705, 92523, 92533, 27053, 94818, 94382, 94828, 27055, 94819, 94385, 
94829, 27033, 27054, 94353, 94384
32890, 26695, 26705, 92523, 92533, 26696, 26706, 92524, 92534, 27055, 94819, 94385, 94829, 27057, 94820, 94388, 
94830, 27035, 27056, 94356, 94387
32891, 26696, 26706, 92524, 92534, 2662, 2663, 26315, 26316, 27057, 94820, 94388, 94830, 2685, 26472, 26440, 
26473, 27037, 27058, 94359, 94390
32892, 2581, 2582, 25990, 25991, 26677, 26687, 92525, 92535, 2604, 26147, 26115, 26148, 27018, 94821, 94392, 
94831, 26996, 27017, 94360, 94391
32893, 26677, 26687, 92525, 92535, 26678, 26688, 92526, 92536, 27018, 94821, 94392, 94831, 27020, 94822, 94395, 
94832, 26998, 27019, 94363, 94394
32894, 26678, 26688, 92526, 92536, 26679, 26689, 92527, 92537, 27020, 94822, 94395, 94832, 27022, 94823, 94398, 
94833, 27000, 27021, 94366, 94397
32895, 26679, 26689, 92527, 92537, 26680, 26690, 92528, 92538, 27022, 94823, 94398, 94833, 27024, 94824, 94401, 
94834, 27002, 27023, 94369, 94400
32896, 26680, 26690, 92528, 92538, 26681, 26691, 92529, 92539, 27024, 94824, 94401, 94834, 27026, 94825, 94404, 
94835, 27004, 27025, 94372, 94403
32897, 26681, 26691, 92529, 92539, 26682, 26692, 92530, 92540, 27026, 94825, 94404, 94835, 27028, 94826, 94407, 
94836, 27006, 27027, 94375, 94406
32898, 26682, 26692, 92530, 92540, 26683, 26693, 92531, 92541, 27028, 94826, 94407, 94836, 27030, 94827, 94410, 
94837, 27008, 27029, 94378, 94409
32899, 26683, 26693, 92531, 92541, 26684, 26694, 92532, 92542, 27030, 94827, 94410, 94837, 27032, 94828, 94413, 
94838, 27010, 27031, 94381, 94412
32900, 26684, 26694, 92532, 92542, 26685, 26695, 92533, 92543, 27032, 94828, 94413, 94838, 27034, 94829, 94416, 
94839, 27012, 27033, 94384, 94415
32901, 26685, 26695, 92533, 92543, 26686, 26696, 92534, 92544, 27034, 94829, 94416, 94839, 27036, 94830, 94419, 
94840, 27014, 27035, 94387, 94418
32902, 26686, 26696, 92534, 92544, 2661, 2662, 26316, 26317, 27036, 94830, 94419, 94840, 2684, 26473, 26442, 
26474, 27016, 27037, 94390, 94421
32903, 2580, 2581, 25991, 25992, 26667, 26677, 92535, 92545, 2603, 26148, 26117, 26149, 26997, 94831, 94423, 
94841, 26975, 26996, 94391, 94422
32904, 26667, 26677, 92535, 92545, 26668, 26678, 92536, 92546, 26997, 94831, 94423, 94841, 26999, 94832, 94426, 
94842, 26977, 26998, 94394, 94425
32905, 26668, 26678, 92536, 92546, 26669, 26679, 92537, 92547, 26999, 94832, 94426, 94842, 27001, 94833, 94429, 
94843, 26979, 27000, 94397, 94428
32906, 26669, 26679, 92537, 92547, 26670, 26680, 92538, 92548, 27001, 94833, 94429, 94843, 27003, 94834, 94432, 
94844, 26981, 27002, 94400, 94431
32907, 26670, 26680, 92538, 92548, 26671, 26681, 92539, 92549, 27003, 94834, 94432, 94844, 27005, 94835, 94435, 
94845, 26983, 27004, 94403, 94434
32908, 26671, 26681, 92539, 92549, 26672, 26682, 92540, 92550, 27005, 94835, 94435, 94845, 27007, 94836, 94438, 
94846, 26985, 27006, 94406, 94437
32909, 26672, 26682, 92540, 92550, 26673, 26683, 92541, 92551, 27007, 94836, 94438, 94846, 27009, 94837, 94441, 
94847, 26987, 27008, 94409, 94440
32910, 26673, 26683, 92541, 92551, 26674, 26684, 92542, 92552, 27009, 94837, 94441, 94847, 27011, 94838, 94444, 
94848, 26989, 27010, 94412, 94443
32911, 26674, 26684, 92542, 92552, 26675, 26685, 92543, 92553, 27011, 94838, 94444, 94848, 27013, 94839, 94447, 
94849, 26991, 27012, 94415, 94446
32912, 26675, 26685, 92543, 92553, 26676, 26686, 92544, 92554, 27013, 94839, 94447, 94849, 27015, 94840, 94450, 
94850, 26993, 27014, 94418, 94449
32913, 26676, 26686, 92544, 92554, 2660, 2661, 26317, 26318, 27015, 94840, 94450, 94850, 2683, 26474, 26444, 
26475, 26995, 27016, 94421, 94452
32914, 2579, 2580, 25992, 25993, 26657, 26667, 92545, 92555, 2602, 26149, 26119, 26150, 26976, 94841, 94454, 
94851, 26954, 26975, 94422, 94453
32915, 26657, 26667, 92545, 92555, 26658, 26668, 92546, 92556, 26976, 94841, 94454, 94851, 26978, 94842, 94457, 
94852, 26956, 26977, 94425, 94456
32916, 26658, 26668, 92546, 92556, 26659, 26669, 92547, 92557, 26978, 94842, 94457, 94852, 26980, 94843, 94460, 
94853, 26958, 26979, 94428, 94459
32917, 26659, 26669, 92547, 92557, 26660, 26670, 92548, 92558, 26980, 94843, 94460, 94853, 26982, 94844, 94463, 
94854, 26960, 26981, 94431, 94462
32918, 26660, 26670, 92548, 92558, 26661, 26671, 92549, 92559, 26982, 94844, 94463, 94854, 26984, 94845, 94466, 
94855, 26962, 26983, 94434, 94465
32919, 26661, 26671, 92549, 92559, 26662, 26672, 92550, 92560, 26984, 94845, 94466, 94855, 26986, 94846, 94469, 
94856, 26964, 26985, 94437, 94468
32920, 26662, 26672, 92550, 92560, 26663, 26673, 92551, 92561, 26986, 94846, 94469, 94856, 26988, 94847, 94472, 
94857, 26966, 26987, 94440, 94471
32921, 26663, 26673, 92551, 92561, 26664, 26674, 92552, 92562, 26988, 94847, 94472, 94857, 26990, 94848, 94475, 
94858, 26968, 26989, 94443, 94474
32922, 26664, 26674, 92552, 92562, 26665, 26675, 92553, 92563, 26990, 94848, 94475, 94858, 26992, 94849, 94478, 
94859, 26970, 26991, 94446, 94477
32923, 26665, 26675, 92553, 92563, 26666, 26676, 92554, 92564, 26992, 94849, 94478, 94859, 26994, 94850, 94481, 
94860, 26972, 26993, 94449, 94480
32924, 26666, 26676, 92554, 92564, 2659, 2660, 26318, 26319, 26994, 94850, 94481, 94860, 2682, 26475, 26446, 
26476, 26974, 26995, 94452, 94483
32925, 2578, 2579, 25993, 25994, 26647, 26657, 92555, 92565, 2601, 26150, 26121, 26151, 26955, 94851, 94485, 
94861, 26933, 26954, 94453, 94484
32926, 26647, 26657, 92555, 92565, 26648, 26658, 92556, 92566, 26955, 94851, 94485, 94861, 26957, 94852, 94488, 
94862, 26935, 26956, 94456, 94487
32927, 26648, 26658, 92556, 92566, 26649, 26659, 92557, 92567, 26957, 94852, 94488, 94862, 26959, 94853, 94491, 
94863, 26937, 26958, 94459, 94490
32928, 26649, 26659, 92557, 92567, 26650, 26660, 92558, 92568, 26959, 94853, 94491, 94863, 26961, 94854, 94494, 
94864, 26939, 26960, 94462, 94493
32929, 26650, 26660, 92558, 92568, 26651, 26661, 92559, 92569, 26961, 94854, 94494, 94864, 26963, 94855, 94497, 
94865, 26941, 26962, 94465, 94496
32930, 26651, 26661, 92559, 92569, 26652, 26662, 92560, 92570, 26963, 94855, 94497, 94865, 26965, 94856, 94500, 
94866, 26943, 26964, 94468, 94499
32931, 26652, 26662, 92560, 92570, 26653, 26663, 92561, 92571, 26965, 94856, 94500, 94866, 26967, 94857, 94503, 
94867, 26945, 26966, 94471, 94502
32932, 26653, 26663, 92561, 92571, 26654, 26664, 92562, 92572, 26967, 94857, 94503, 94867, 26969, 94858, 94506, 
94868, 26947, 26968, 94474, 94505
32933, 26654, 26664, 92562, 92572, 26655, 26665, 92563, 92573, 26969, 94858, 94506, 94868, 26971, 94859, 94509, 
94869, 26949, 26970, 94477, 94508
32934, 26655, 26665, 92563, 92573, 26656, 26666, 92564, 92574, 26971, 94859, 94509, 94869, 26973, 94860, 94512, 
94870, 26951, 26972, 94480, 94511
32935, 26656, 26666, 92564, 92574, 2658, 2659, 26319, 26320, 26973, 94860, 94512, 94870, 2681, 26476, 26448, 
26477, 26953, 26974, 94483, 94514
32936, 2577, 2578, 25994, 25995, 26637, 26647, 92565, 92575, 2600, 26151, 26123, 26152, 26934, 94861, 94516, 
94871, 26912, 26933, 94484, 94515
32937, 26637, 26647, 92565, 92575, 26638, 26648, 92566, 92576, 26934, 94861, 94516, 94871, 26936, 94862, 94519, 
94872, 26914, 26935, 94487, 94518
32938, 26638, 26648, 92566, 92576, 26639, 26649, 92567, 92577, 26936, 94862, 94519, 94872, 26938, 94863, 94522, 
94873, 26916, 26937, 94490, 94521
32939, 26639, 26649, 92567, 92577, 26640, 26650, 92568, 92578, 26938, 94863, 94522, 94873, 26940, 94864, 94525, 
94874, 26918, 26939, 94493, 94524
32940, 26640, 26650, 92568, 92578, 26641, 26651, 92569, 92579, 26940, 94864, 94525, 94874, 26942, 94865, 94528, 
94875, 26920, 26941, 94496, 94527
32941, 26641, 26651, 92569, 92579, 26642, 26652, 92570, 92580, 26942, 94865, 94528, 94875, 26944, 94866, 94531, 
94876, 26922, 26943, 94499, 94530
32942, 26642, 26652, 92570, 92580, 26643, 26653, 92571, 92581, 26944, 94866, 94531, 94876, 26946, 94867, 94534, 
94877, 26924, 26945, 94502, 94533
32943, 26643, 26653, 92571, 92581, 26644, 26654, 92572, 92582, 26946, 94867, 94534, 94877, 26948, 94868, 94537, 
94878, 26926, 26947, 94505, 94536
32944, 26644, 26654, 92572, 92582, 26645, 26655, 92573, 92583, 26948, 94868, 94537, 94878, 26950, 94869, 94540, 
94879, 26928, 26949, 94508, 94539
32945, 26645, 26655, 92573, 92583, 26646, 26656, 92574, 92584, 26950, 94869, 94540, 94879, 26952, 94870, 94543, 
94880, 26930, 26951, 94511, 94542
32946, 26646, 26656, 92574, 92584, 2657, 2658, 26320, 26321, 26952, 94870, 94543, 94880, 2680, 26477, 26450, 
26478, 26932, 26953, 94514, 94545
32947, 2576, 2577, 25995, 25996, 26627, 26637, 92575, 92585, 2599, 26152, 26125, 26153, 26913, 94871, 94547, 
94881, 26891, 26912, 94515, 94546
32948, 26627, 26637, 92575, 92585, 26628, 26638, 92576, 92586, 26913, 94871, 94547, 94881, 26915, 94872, 94550, 
94882, 26893, 26914, 94518, 94549
32949, 26628, 26638, 92576, 92586, 26629, 26639, 92577, 92587, 26915, 94872, 94550, 94882, 26917, 94873, 94553, 
94883, 26895, 26916, 94521, 94552
32950, 26629, 26639, 92577, 92587, 26630, 26640, 92578, 92588, 26917, 94873, 94553, 94883, 26919, 94874, 94556, 
94884, 26897, 26918, 94524, 94555
32951, 26630, 26640, 92578, 92588, 26631, 26641, 92579, 92589, 26919, 94874, 94556, 94884, 26921, 94875, 94559, 
94885, 26899, 26920, 94527, 94558
32952, 26631, 26641, 92579, 92589, 26632, 26642, 92580, 92590, 26921, 94875, 94559, 94885, 26923, 94876, 94562, 
94886, 26901, 26922, 94530, 94561
32953, 26632, 26642, 92580, 92590, 26633, 26643, 92581, 92591, 26923, 94876, 94562, 94886, 26925, 94877, 94565, 
94887, 26903, 26924, 94533, 94564
32954, 26633, 26643, 92581, 92591, 26634, 26644, 92582, 92592, 26925, 94877, 94565, 94887, 26927, 94878, 94568, 
94888, 26905, 26926, 94536, 94567
32955, 26634, 26644, 92582, 92592, 26635, 26645, 92583, 92593, 26927, 94878, 94568, 94888, 26929, 94879, 94571, 
94889, 26907, 26928, 94539, 94570
32956, 26635, 26645, 92583, 92593, 26636, 26646, 92584, 92594, 26929, 94879, 94571, 94889, 26931, 94880, 94574, 
94890, 26909, 26930, 94542, 94573
32957, 26636, 26646, 92584, 92594, 2656, 2657, 26321, 26322, 26931, 94880, 94574, 94890, 2679, 26478, 26452, 
26479, 26911, 26932, 94545, 94576
32958, 2575, 2576, 25996, 25997, 26617, 26627, 92585, 92595, 2598, 26153, 26127, 26154, 26892, 94881, 94578, 
94891, 26870, 26891, 94546, 94577
32959, 26617, 26627, 92585, 92595, 26618, 26628, 92586, 92596, 26892, 94881, 94578, 94891, 26894, 94882, 94581, 
94892, 26872, 26893, 94549, 94580
32960, 26618, 26628, 92586, 92596, 26619, 26629, 92587, 92597, 26894, 94882, 94581, 94892, 26896, 94883, 94584, 
94893, 26874, 26895, 94552, 94583
32961, 26619, 26629, 92587, 92597, 26620, 26630, 92588, 92598, 26896, 94883, 94584, 94893, 26898, 94884, 94587, 
94894, 26876, 26897, 94555, 94586
32962, 26620, 26630, 92588, 92598, 26621, 26631, 92589, 92599, 26898, 94884, 94587, 94894, 26900, 94885, 94590, 
94895, 26878, 26899, 94558, 94589
32963, 26621, 26631, 92589, 92599, 26622, 26632, 92590, 92600, 26900, 94885, 94590, 94895, 26902, 94886, 94593, 
94896, 26880, 26901, 94561, 94592
32964, 26622, 26632, 92590, 92600, 26623, 26633, 92591, 92601, 26902, 94886, 94593, 94896, 26904, 94887, 94596, 
94897, 26882, 26903, 94564, 94595
32965, 26623, 26633, 92591, 92601, 26624, 26634, 92592, 92602, 26904, 94887, 94596, 94897, 26906, 94888, 94599, 
94898, 26884, 26905, 94567, 94598
32966, 26624, 26634, 92592, 92602, 26625, 26635, 92593, 92603, 26906, 94888, 94599, 94898, 26908, 94889, 94602, 
94899, 26886, 26907, 94570, 94601
32967, 26625, 26635, 92593, 92603, 26626, 26636, 92594, 92604, 26908, 94889, 94602, 94899, 26910, 94890, 94605, 
94900, 26888, 26909, 94573, 94604
32968, 26626, 26636, 92594, 92604, 2655, 2656, 26322, 26323, 26910, 94890, 94605, 94900, 2678, 26479, 26454, 
26480, 26890, 26911, 94576, 94607
32969, 2574, 2575, 25997, 25998, 26607, 26617, 92595, 92605, 2597, 26154, 26129, 26155, 26871, 94891, 94609, 
94901, 26849, 26870, 94577, 94608
32970, 26607, 26617, 92595, 92605, 26608, 26618, 92596, 92606, 26871, 94891, 94609, 94901, 26873, 94892, 94612, 
94902, 26851, 26872, 94580, 94611
32971, 26608, 26618, 92596, 92606, 26609, 26619, 92597, 92607, 26873, 94892, 94612, 94902, 26875, 94893, 94615, 
94903, 26853, 26874, 94583, 94614
32972, 26609, 26619, 92597, 92607, 26610, 26620, 92598, 92608, 26875, 94893, 94615, 94903, 26877, 94894, 94618, 
94904, 26855, 26876, 94586, 94617
32973, 26610, 26620, 92598, 92608, 26611, 26621, 92599, 92609, 26877, 94894, 94618, 94904, 26879, 94895, 94621, 
94905, 26857, 26878, 94589, 94620
32974, 26611, 26621, 92599, 92609, 26612, 26622, 92600, 92610, 26879, 94895, 94621, 94905, 26881, 94896, 94624, 
94906, 26859, 26880, 94592, 94623
32975, 26612, 26622, 92600, 92610, 26613, 26623, 92601, 92611, 26881, 94896, 94624, 94906, 26883, 94897, 94627, 
94907, 26861, 26882, 94595, 94626
32976, 26613, 26623, 92601, 92611, 26614, 26624, 92602, 92612, 26883, 94897, 94627, 94907, 26885, 94898, 94630, 
94908, 26863, 26884, 94598, 94629
32977, 26614, 26624, 92602, 92612, 26615, 26625, 92603, 92613, 26885, 94898, 94630, 94908, 26887, 94899, 94633, 
94909, 26865, 26886, 94601, 94632
32978, 26615, 26625, 92603, 92613, 26616, 26626, 92604, 92614, 26887, 94899, 94633, 94909, 26889, 94900, 94636, 
94910, 26867, 26888, 94604, 94635
32979, 26616, 26626, 92604, 92614, 2654, 2655, 26323, 26324, 26889, 94900, 94636, 94910, 2677, 26480, 26456, 
26481, 26869, 26890, 94607, 94638
32980, 2573, 2574, 25998, 25999, 26597, 26607, 92605, 92615, 2596, 26155, 26131, 26156, 26850, 94901, 94640, 
94911, 26828, 26849, 94608, 94639
32981, 26597, 26607, 92605, 92615, 26598, 26608, 92606, 92616, 26850, 94901, 94640, 94911, 26852, 94902, 94643, 
94912, 26830, 26851, 94611, 94642
32982, 26598, 26608, 92606, 92616, 26599, 26609, 92607, 92617, 26852, 94902, 94643, 94912, 26854, 94903, 94646, 
94913, 26832, 26853, 94614, 94645
32983, 26599, 26609, 92607, 92617, 26600, 26610, 92608, 92618, 26854, 94903, 94646, 94913, 26856, 94904, 94649, 
94914, 26834, 26855, 94617, 94648
32984, 26600, 26610, 92608, 92618, 26601, 26611, 92609, 92619, 26856, 94904, 94649, 94914, 26858, 94905, 94652, 
94915, 26836, 26857, 94620, 94651
32985, 26601, 26611, 92609, 92619, 26602, 26612, 92610, 92620, 26858, 94905, 94652, 94915, 26860, 94906, 94655, 
94916, 26838, 26859, 94623, 94654
32986, 26602, 26612, 92610, 92620, 26603, 26613, 92611, 92621, 26860, 94906, 94655, 94916, 26862, 94907, 94658, 
94917, 26840, 26861, 94626, 94657
32987, 26603, 26613, 92611, 92621, 26604, 26614, 92612, 92622, 26862, 94907, 94658, 94917, 26864, 94908, 94661, 
94918, 26842, 26863, 94629, 94660
32988, 26604, 26614, 92612, 92622, 26605, 26615, 92613, 92623, 26864, 94908, 94661, 94918, 26866, 94909, 94664, 
94919, 26844, 26865, 94632, 94663
32989, 26605, 26615, 92613, 92623, 26606, 26616, 92614, 92624, 26866, 94909, 94664, 94919, 26868, 94910, 94667, 
94920, 26846, 26867, 94635, 94666
32990, 26606, 26616, 92614, 92624, 2653, 2654, 26324, 26325, 26868, 94910, 94667, 94920, 2676, 26481, 26458, 
26482, 26848, 26869, 94638, 94669
32991, 2572, 2573, 25999, 26000, 26587, 26597, 92615, 92625, 2595, 26156, 26133, 26157, 26829, 94911, 94671, 
94921, 26807, 26828, 94639, 94670
32992, 26587, 26597, 92615, 92625, 26588, 26598, 92616, 92626, 26829, 94911, 94671, 94921, 26831, 94912, 94674, 
94922, 26809, 26830, 94642, 94673
32993, 26588, 26598, 92616, 92626, 26589, 26599, 92617, 92627, 26831, 94912, 94674, 94922, 26833, 94913, 94677, 
94923, 26811, 26832, 94645, 94676
32994, 26589, 26599, 92617, 92627, 26590, 26600, 92618, 92628, 26833, 94913, 94677, 94923, 26835, 94914, 94680, 
94924, 26813, 26834, 94648, 94679
32995, 26590, 26600, 92618, 92628, 26591, 26601, 92619, 92629, 26835, 94914, 94680, 94924, 26837, 94915, 94683, 
94925, 26815, 26836, 94651, 94682
32996, 26591, 26601, 92619, 92629, 26592, 26602, 92620, 92630, 26837, 94915, 94683, 94925, 26839, 94916, 94686, 
94926, 26817, 26838, 94654, 94685
32997, 26592, 26602, 92620, 92630, 26593, 26603, 92621, 92631, 26839, 94916, 94686, 94926, 26841, 94917, 94689, 
94927, 26819, 26840, 94657, 94688
32998, 26593, 26603, 92621, 92631, 26594, 26604, 92622, 92632, 26841, 94917, 94689, 94927, 26843, 94918, 94692, 
94928, 26821, 26842, 94660, 94691
32999, 26594, 26604, 92622, 92632, 26595, 26605, 92623, 92633, 26843, 94918, 94692, 94928, 26845, 94919, 94695, 
94929, 26823, 26844, 94663, 94694
33000, 26595, 26605, 92623, 92633, 26596, 26606, 92624, 92634, 26845, 94919, 94695, 94929, 26847, 94920, 94698, 
94930, 26825, 26846, 94666, 94697
33001, 26596, 26606, 92624, 92634, 2652, 2653, 26325, 26326, 26847, 94920, 94698, 94930, 2675, 26482, 26460, 
26483, 26827, 26848, 94669, 94700
33002, 64, 2572, 26000, 2567, 2697, 26587, 92625, 26513, 2594, 26157, 26135, 2571, 26808, 94921, 94701, 
26586, 2707, 26807, 94670, 26576
33003, 2697, 26587, 92625, 26513, 2698, 26588, 92626, 26512, 26808, 94921, 94701, 26586, 26810, 94922, 94702, 
26585, 2708, 26809, 94673, 26575
33004, 2698, 26588, 92626, 26512, 2699, 26589, 92627, 26511, 26810, 94922, 94702, 26585, 26812, 94923, 94703, 
26584, 2709, 26811, 94676, 26573
33005, 2699, 26589, 92627, 26511, 2700, 26590, 92628, 26510, 26812, 94923, 94703, 26584, 26814, 94924, 94704, 
26583, 2710, 26813, 94679, 26571
33006, 2700, 26590, 92628, 26510, 2701, 26591, 92629, 26509, 26814, 94924, 94704, 26583, 26816, 94925, 94705, 
26582, 2711, 26815, 94682, 26569
33007, 2701, 26591, 92629, 26509, 2702, 26592, 92630, 26508, 26816, 94925, 94705, 26582, 26818, 94926, 94706, 
26581, 2712, 26817, 94685, 26567
33008, 2702, 26592, 92630, 26508, 2703, 26593, 92631, 26507, 26818, 94926, 94706, 26581, 26820, 94927, 94707, 
26580, 2713, 26819, 94688, 26565
33009, 2703, 26593, 92631, 26507, 2704, 26594, 92632, 26506, 26820, 94927, 94707, 26580, 26822, 94928, 94708, 
26579, 2714, 26821, 94691, 26563
33010, 2704, 26594, 92632, 26506, 2705, 26595, 92633, 26505, 26822, 94928, 94708, 26579, 26824, 94929, 94709, 
26578, 2715, 26823, 94694, 26561
33011, 2705, 26595, 92633, 26505, 2706, 26596, 92634, 26504, 26824, 94929, 94709, 26578, 26826, 94930, 94710, 
26577, 2716, 26825, 94697, 26559
33012, 2706, 26596, 92634, 26504, 66, 2652, 26326, 2647, 26826, 94930, 94710, 26577, 2674, 26483, 26461, 
2651, 2717, 26827, 94700, 26557
*ELEMENT, type=C3D20, ELSET=Volume24
33013, 1, 2645, 27279, 2148, 98, 26484, 94931, 22779, 2648, 27286, 27285, 2150, 26514, 94992, 94993, 
22800, 109, 26515, 94991, 22799
33014, 98, 26484, 94931, 22779, 97, 26485, 94932, 22780, 26514, 94992, 94993, 22800, 26516, 94995, 94996, 
22802, 108, 26517, 94994, 22801
33015, 97, 26485, 94932, 22780, 96, 26486, 94933, 22781, 26516, 94995, 94996, 22802, 26518, 94998, 94999, 
22804, 107, 26519, 94997, 22803
33016, 96, 26486, 94933, 22781, 95, 26487, 94934, 22782, 26518, 94998, 94999, 22804, 26520, 95001, 95002, 
22806, 106, 26521, 95000, 22805
33017, 95, 26487, 94934, 22782, 94, 26488, 94935, 22783, 26520, 95001, 95002, 22806, 26522, 95004, 95005, 
22808, 105, 26523, 95003, 22807
33018, 94, 26488, 94935, 22783, 93, 26489, 94936, 22784, 26522, 95004, 95005, 22808, 26524, 95007, 95008, 
22810, 104, 26525, 95006, 22809
33019, 93, 26489, 94936, 22784, 92, 26490, 94937, 22785, 26524, 95007, 95008, 22810, 26526, 95010, 95011, 
22812, 103, 26527, 95009, 22811
33020, 92, 26490, 94937, 22785, 91, 26491, 94938, 22786, 26526, 95010, 95011, 22812, 26528, 95013, 95014, 
22814, 102, 26529, 95012, 22813
33021, 91, 26491, 94938, 22786, 90, 26492, 94939, 22787, 26528, 95013, 95014, 22814, 26530, 95016, 95017, 
22816, 101, 26531, 95015, 22815
33022, 90, 26492, 94939, 22787, 89, 26493, 94940, 22788, 26530, 95016, 95017, 22816, 26532, 95019, 95020, 
22818, 100, 26533, 95018, 22817
33023, 89, 26493, 94940, 22788, 2, 2565, 27302, 2153, 26532, 95019, 95020, 22818, 2568, 27308, 27309, 
2155, 99, 26534, 95021, 22819
33024, 2148, 27279, 27280, 2149, 22779, 94931, 94941, 22789, 27285, 27288, 27287, 2151, 94993, 95023, 95024, 
22821, 22799, 94991, 95022, 22820
33025, 22779, 94931, 94941, 22789, 22780, 94932, 94942, 22790, 94993, 95023, 95024, 22821, 94996, 95026, 95027, 
22823, 22801, 94994, 95025, 22822
33026, 22780, 94932, 94942, 22790, 22781, 94933, 94943, 22791, 94996, 95026, 95027, 22823, 94999, 95029, 95030, 
22825, 22803, 94997, 95028, 22824
33027, 22781, 94933, 94943, 22791, 22782, 94934, 94944, 22792, 94999, 95029, 95030, 22825, 95002, 95032, 95033, 
22827, 22805, 95000, 95031, 22826
33028, 22782, 94934, 94944, 22792, 22783, 94935, 94945, 22793, 95002, 95032, 95033, 22827, 95005, 95035, 95036, 
22829, 22807, 95003, 95034, 22828
33029, 22783, 94935, 94945, 22793, 22784, 94936, 94946, 22794, 95005, 95035, 95036, 22829, 95008, 95038, 95039, 
22831, 22809, 95006, 95037, 22830
33030, 22784, 94936, 94946, 22794, 22785, 94937, 94947, 22795, 95008, 95038, 95039, 22831, 95011, 95041, 95042, 
22833, 22811, 95009, 95040, 22832
33031, 22785, 94937, 94947, 22795, 22786, 94938, 94948, 22796, 95011, 95041, 95042, 22833, 95014, 95044, 95045, 
22835, 22813, 95012, 95043, 22834
33032, 22786, 94938, 94948, 22796, 22787, 94939, 94949, 22797, 95014, 95044, 95045, 22835, 95017, 95047, 95048, 
22837, 22815, 95015, 95046, 22836
33033, 22787, 94939, 94949, 22797, 22788, 94940, 94950, 22798, 95017, 95047, 95048, 22837, 95020, 95050, 95051, 
22839, 22817, 95018, 95049, 22838
33034, 22788, 94940, 94950, 22798, 2153, 27302, 27303, 2154, 95020, 95050, 95051, 22839, 27309, 27310, 27311, 
2156, 22819, 95021, 95052, 22840
33035, 2149, 27280, 2718, 51, 22789, 94941, 27325, 2167, 27287, 27289, 2721, 2152, 95024, 95053, 27355, 
22841, 22820, 95022, 27356, 2178
33036, 22789, 94941, 27325, 2167, 22790, 94942, 27326, 2166, 95024, 95053, 27355, 22841, 95027, 95054, 27357, 
22842, 22822, 95025, 27358, 2177
33037, 22790, 94942, 27326, 2166, 22791, 94943, 27327, 2165, 95027, 95054, 27357, 22842, 95030, 95055, 27359, 
22843, 22824, 95028, 27360, 2176
33038, 22791, 94943, 27327, 2165, 22792, 94944, 27328, 2164, 95030, 95055, 27359, 22843, 95033, 95056, 27361, 
22844, 22826, 95031, 27362, 2175
33039, 22792, 94944, 27328, 2164, 22793, 94945, 27329, 2163, 95033, 95056, 27361, 22844, 95036, 95057, 27363, 
22845, 22828, 95034, 27364, 2174
33040, 22793, 94945, 27329, 2163, 22794, 94946, 27330, 2162, 95036, 95057, 27363, 22845, 95039, 95058, 27365, 
22846, 22830, 95037, 27366, 2173
33041, 22794, 94946, 27330, 2162, 22795, 94947, 27331, 2161, 95039, 95058, 27365, 22846, 95042, 95059, 27367, 
22847, 22832, 95040, 27368, 2172
33042, 22795, 94947, 27331, 2161, 22796, 94948, 27332, 2160, 95042, 95059, 27367, 22847, 95045, 95060, 27369, 
22848, 22834, 95043, 27370, 2171
33043, 22796, 94948, 27332, 2160, 22797, 94949, 27333, 2159, 95045, 95060, 27369, 22848, 95048, 95061, 27371, 
22849, 22836, 95046, 27372, 2170
33044, 22797, 94949, 27333, 2159, 22798, 94950, 27334, 2158, 95048, 95061, 27371, 22849, 95051, 95062, 27373, 
22850, 22838, 95049, 27374, 2169
33045, 22798, 94950, 27334, 2158, 2154, 27303, 2730, 52, 95051, 95062, 27373, 22850, 27311, 27312, 2733, 
2157, 22840, 95052, 27375, 2168
33046, 2645, 2646, 27281, 27279, 26484, 26494, 94951, 94931, 2649, 27291, 27290, 27286, 26535, 95064, 95065, 
94992, 26515, 26536, 95063, 94991
33047, 26484, 26494, 94951, 94931, 26485, 26495, 94952, 94932, 26535, 95064, 95065, 94992, 26537, 95067, 95068, 
94995, 26517, 26538, 95066, 94994
33048, 26485, 26495, 94952, 94932, 26486, 26496, 94953, 94933, 26537, 95067, 95068, 94995, 26539, 95070, 95071, 
94998, 26519, 26540, 95069, 94997
33049, 26486, 26496, 94953, 94933, 26487, 26497, 94954, 94934, 26539, 95070, 95071, 94998, 26541, 95073, 95074, 
95001, 26521, 26542, 95072, 95000
33050, 26487, 26497, 94954, 94934, 26488, 26498, 94955, 94935, 26541, 95073, 95074, 95001, 26543, 95076, 95077, 
95004, 26523, 26544, 95075, 95003
33051, 26488, 26498, 94955, 94935, 26489, 26499, 94956, 94936, 26543, 95076, 95077, 95004, 26545, 95079, 95080, 
95007, 26525, 26546, 95078, 95006
33052, 26489, 26499, 94956, 94936, 26490, 26500, 94957, 94937, 26545, 95079, 95080, 95007, 26547, 95082, 95083, 
95010, 26527, 26548, 95081, 95009
33053, 26490, 26500, 94957, 94937, 26491, 26501, 94958, 94938, 26547, 95082, 95083, 95010, 26549, 95085, 95086, 
95013, 26529, 26550, 95084, 95012
33054, 26491, 26501, 94958, 94938, 26492, 26502, 94959, 94939, 26549, 95085, 95086, 95013, 26551, 95088, 95089, 
95016, 26531, 26552, 95087, 95015
33055, 26492, 26502, 94959, 94939, 26493, 26503, 94960, 94940, 26551, 95088, 95089, 95016, 26553, 95091, 95092, 
95019, 26533, 26554, 95090, 95018
33056, 26493, 26503, 94960, 94940, 2565, 2566, 27304, 27302, 26553, 95091, 95092, 95019, 2569, 27313, 27314, 
27308, 26534, 26555, 95093, 95021
33057, 27279, 27281, 27282, 27280, 94931, 94951, 94961, 94941, 27290, 27293, 27292, 27288, 95065, 95095, 95096, 
95023, 94991, 95063, 95094, 95022
33058, 94931, 94951, 94961, 94941, 94932, 94952, 94962, 94942, 95065, 95095, 95096, 95023, 95068, 95098, 95099, 
95026, 94994, 95066, 95097, 95025
33059, 94932, 94952, 94962, 94942, 94933, 94953, 94963, 94943, 95068, 95098, 95099, 95026, 95071, 95101, 95102, 
95029, 94997, 95069, 95100, 95028
33060, 94933, 94953, 94963, 94943, 94934, 94954, 94964, 94944, 95071, 95101, 95102, 95029, 95074, 95104, 95105, 
95032, 95000, 95072, 95103, 95031
33061, 94934, 94954, 94964, 94944, 94935, 94955, 94965, 94945, 95074, 95104, 95105, 95032, 95077, 95107, 95108, 
95035, 95003, 95075, 95106, 95034
33062, 94935, 94955, 94965, 94945, 94936, 94956, 94966, 94946, 95077, 95107, 95108, 95035, 95080, 95110, 95111, 
95038, 95006, 95078, 95109, 95037
33063, 94936, 94956, 94966, 94946, 94937, 94957, 94967, 94947, 95080, 95110, 95111, 95038, 95083, 95113, 95114, 
95041, 95009, 95081, 95112, 95040
33064, 94937, 94957, 94967, 94947, 94938, 94958, 94968, 94948, 95083, 95113, 95114, 95041, 95086, 95116, 95117, 
95044, 95012, 95084, 95115, 95043
33065, 94938, 94958, 94968, 94948, 94939, 94959, 94969, 94949, 95086, 95116, 95117, 95044, 95089, 95119, 95120, 
95047, 95015, 95087, 95118, 95046
33066, 94939, 94959, 94969, 94949, 94940, 94960, 94970, 94950, 95089, 95119, 95120, 95047, 95092, 95122, 95123, 
95050, 95018, 95090, 95121, 95049
33067, 94940, 94960, 94970, 94950, 27302, 27304, 27305, 27303, 95092, 95122, 95123, 95050, 27314, 27315, 27316, 
27310, 95021, 95093, 95124, 95052
33068, 27280, 27282, 2719, 2718, 94941, 94961, 27335, 27325, 27292, 27294, 2722, 27289, 95096, 95125, 27376, 
95053, 95022, 95094, 27377, 27356
33069, 94941, 94961, 27335, 27325, 94942, 94962, 27336, 27326, 95096, 95125, 27376, 95053, 95099, 95126, 27378, 
95054, 95025, 95097, 27379, 27358
33070, 94942, 94962, 27336, 27326, 94943, 94963, 27337, 27327, 95099, 95126, 27378, 95054, 95102, 95127, 27380, 
95055, 95028, 95100, 27381, 27360
33071, 94943, 94963, 27337, 27327, 94944, 94964, 27338, 27328, 95102, 95127, 27380, 95055, 95105, 95128, 27382, 
95056, 95031, 95103, 27383, 27362
33072, 94944, 94964, 27338, 27328, 94945, 94965, 27339, 27329, 95105, 95128, 27382, 95056, 95108, 95129, 27384, 
95057, 95034, 95106, 27385, 27364
33073, 94945, 94965, 27339, 27329, 94946, 94966, 27340, 27330, 95108, 95129, 27384, 95057, 95111, 95130, 27386, 
95058, 95037, 95109, 27387, 27366
33074, 94946, 94966, 27340, 27330, 94947, 94967, 27341, 27331, 95111, 95130, 27386, 95058, 95114, 95131, 27388, 
95059, 95040, 95112, 27389, 27368
33075, 94947, 94967, 27341, 27331, 94948, 94968, 27342, 27332, 95114, 95131, 27388, 95059, 95117, 95132, 27390, 
95060, 95043, 95115, 27391, 27370
33076, 94948, 94968, 27342, 27332, 94949, 94969, 27343, 27333, 95117, 95132, 27390, 95060, 95120, 95133, 27392, 
95061, 95046, 95118, 27393, 27372
33077, 94949, 94969, 27343, 27333, 94950, 94970, 27344, 27334, 95120, 95133, 27392, 95061, 95123, 95134, 27394, 
95062, 95049, 95121, 27395, 27374
33078, 94950, 94970, 27344, 27334, 27303, 27305, 2731, 2730, 95123, 95134, 27394, 95062, 27316, 27317, 2734, 
27312, 95052, 95124, 27396, 27375
33079, 2646, 2647, 27283, 27281, 26494, 26504, 94971, 94951, 2650, 27296, 27295, 27291, 26556, 95136, 95137, 
95064, 26536, 26557, 95135, 95063
33080, 26494, 26504, 94971, 94951, 26495, 26505, 94972, 94952, 26556, 95136, 95137, 95064, 26558, 95139, 95140, 
95067, 26538, 26559, 95138, 95066
33081, 26495, 26505, 94972, 94952, 26496, 26506, 94973, 94953, 26558, 95139, 95140, 95067, 26560, 95142, 95143, 
95070, 26540, 26561, 95141, 95069
33082, 26496, 26506, 94973, 94953, 26497, 26507, 94974, 94954, 26560, 95142, 95143, 95070, 26562, 95145, 95146, 
95073, 26542, 26563, 95144, 95072
33083, 26497, 26507, 94974, 94954, 26498, 26508, 94975, 94955, 26562, 95145, 95146, 95073, 26564, 95148, 95149, 
95076, 26544, 26565, 95147, 95075
33084, 26498, 26508, 94975, 94955, 26499, 26509, 94976, 94956, 26564, 95148, 95149, 95076, 26566, 95151, 95152, 
95079, 26546, 26567, 95150, 95078
33085, 26499, 26509, 94976, 94956, 26500, 26510, 94977, 94957, 26566, 95151, 95152, 95079, 26568, 95154, 95155, 
95082, 26548, 26569, 95153, 95081
33086, 26500, 26510, 94977, 94957, 26501, 26511, 94978, 94958, 26568, 95154, 95155, 95082, 26570, 95157, 95158, 
95085, 26550, 26571, 95156, 95084
33087, 26501, 26511, 94978, 94958, 26502, 26512, 94979, 94959, 26570, 95157, 95158, 95085, 26572, 95160, 95161, 
95088, 26552, 26573, 95159, 95087
33088, 26502, 26512, 94979, 94959, 26503, 26513, 94980, 94960, 26572, 95160, 95161, 95088, 26574, 95163, 95164, 
95091, 26554, 26575, 95162, 95090
33089, 26503, 26513, 94980, 94960, 2566, 2567, 27306, 27304, 26574, 95163, 95164, 95091, 2570, 27318, 27319, 
27313, 26555, 26576, 95165, 95093
33090, 27281, 27283, 27284, 27282, 94951, 94971, 94981, 94961, 27295, 27298, 27297, 27293, 95137, 95167, 95168, 
95095, 95063, 95135, 95166, 95094
33091, 94951, 94971, 94981, 94961, 94952, 94972, 94982, 94962, 95137, 95167, 95168, 95095, 95140, 95170, 95171, 
95098, 95066, 95138, 95169, 95097
33092, 94952, 94972, 94982, 94962, 94953, 94973, 94983, 94963, 95140, 95170, 95171, 95098, 95143, 95173, 95174, 
95101, 95069, 95141, 95172, 95100
33093, 94953, 94973, 94983, 94963, 94954, 94974, 94984, 94964, 95143, 95173, 95174, 95101, 95146, 95176, 95177, 
95104, 95072, 95144, 95175, 95103
33094, 94954, 94974, 94984, 94964, 94955, 94975, 94985, 94965, 95146, 95176, 95177, 95104, 95149, 95179, 95180, 
95107, 95075, 95147, 95178, 95106
33095, 94955, 94975, 94985, 94965, 94956, 94976, 94986, 94966, 95149, 95179, 95180, 95107, 95152, 95182, 95183, 
95110, 95078, 95150, 95181, 95109
33096, 94956, 94976, 94986, 94966, 94957, 94977, 94987, 94967, 95152, 95182, 95183, 95110, 95155, 95185, 95186, 
95113, 95081, 95153, 95184, 95112
33097, 94957, 94977, 94987, 94967, 94958, 94978, 94988, 94968, 95155, 95185, 95186, 95113, 95158, 95188, 95189, 
95116, 95084, 95156, 95187, 95115
33098, 94958, 94978, 94988, 94968, 94959, 94979, 94989, 94969, 95158, 95188, 95189, 95116, 95161, 95191, 95192, 
95119, 95087, 95159, 95190, 95118
33099, 94959, 94979, 94989, 94969, 94960, 94980, 94990, 94970, 95161, 95191, 95192, 95119, 95164, 95194, 95195, 
95122, 95090, 95162, 95193, 95121
33100, 94960, 94980, 94990, 94970, 27304, 27306, 27307, 27305, 95164, 95194, 95195, 95122, 27319, 27320, 27321, 
27315, 95093, 95165, 95196, 95124
33101, 27282, 27284, 2720, 2719, 94961, 94981, 27345, 27335, 27297, 27299, 2723, 27294, 95168, 95197, 27397, 
95125, 95094, 95166, 27398, 27377
33102, 94961, 94981, 27345, 27335, 94962, 94982, 27346, 27336, 95168, 95197, 27397, 95125, 95171, 95198, 27399, 
95126, 95097, 95169, 27400, 27379
33103, 94962, 94982, 27346, 27336, 94963, 94983, 27347, 27337, 95171, 95198, 27399, 95126, 95174, 95199, 27401, 
95127, 95100, 95172, 27402, 27381
33104, 94963, 94983, 27347, 27337, 94964, 94984, 27348, 27338, 95174, 95199, 27401, 95127, 95177, 95200, 27403, 
95128, 95103, 95175, 27404, 27383
33105, 94964, 94984, 27348, 27338, 94965, 94985, 27349, 27339, 95177, 95200, 27403, 95128, 95180, 95201, 27405, 
95129, 95106, 95178, 27406, 27385
33106, 94965, 94985, 27349, 27339, 94966, 94986, 27350, 27340, 95180, 95201, 27405, 95129, 95183, 95202, 27407, 
95130, 95109, 95181, 27408, 27387
33107, 94966, 94986, 27350, 27340, 94967, 94987, 27351, 27341, 95183, 95202, 27407, 95130, 95186, 95203, 27409, 
95131, 95112, 95184, 27410, 27389
33108, 94967, 94987, 27351, 27341, 94968, 94988, 27352, 27342, 95186, 95203, 27409, 95131, 95189, 95204, 27411, 
95132, 95115, 95187, 27412, 27391
33109, 94968, 94988, 27352, 27342, 94969, 94989, 27353, 27343, 95189, 95204, 27411, 95132, 95192, 95205, 27413, 
95133, 95118, 95190, 27414, 27393
33110, 94969, 94989, 27353, 27343, 94970, 94990, 27354, 27344, 95192, 95205, 27413, 95133, 95195, 95206, 27415, 
95134, 95121, 95193, 27416, 27395
33111, 94970, 94990, 27354, 27344, 27305, 27307, 2732, 2731, 95195, 95206, 27415, 95134, 27321, 27322, 2735, 
27317, 95124, 95196, 27417, 27396
33112, 2647, 66, 2725, 27283, 26504, 2706, 27428, 94971, 2651, 2727, 27300, 27296, 26577, 27449, 95207, 
95136, 26557, 2717, 27448, 95135
33113, 26504, 2706, 27428, 94971, 26505, 2705, 27429, 94972, 26577, 27449, 95207, 95136, 26578, 27451, 95208, 
95139, 26559, 2716, 27450, 95138
33114, 26505, 2705, 27429, 94972, 26506, 2704, 27430, 94973, 26578, 27451, 95208, 95139, 26579, 27453, 95209, 
95142, 26561, 2715, 27452, 95141
33115, 26506, 2704, 27430, 94973, 26507, 2703, 27431, 94974, 26579, 27453, 95209, 95142, 26580, 27455, 95210, 
95145, 26563, 2714, 27454, 95144
33116, 26507, 2703, 27431, 94974, 26508, 2702, 27432, 94975, 26580, 27455, 95210, 95145, 26581, 27457, 95211, 
95148, 26565, 2713, 27456, 95147
33117, 26508, 2702, 27432, 94975, 26509, 2701, 27433, 94976, 26581, 27457, 95211, 95148, 26582, 27459, 95212, 
95151, 26567, 2712, 27458, 95150
33118, 26509, 2701, 27433, 94976, 26510, 2700, 27434, 94977, 26582, 27459, 95212, 95151, 26583, 27461, 95213, 
95154, 26569, 2711, 27460, 95153
33119, 26510, 2700, 27434, 94977, 26511, 2699, 27435, 94978, 26583, 27461, 95213, 95154, 26584, 27463, 95214, 
95157, 26571, 2710, 27462, 95156
33120, 26511, 2699, 27435, 94978, 26512, 2698, 27436, 94979, 26584, 27463, 95214, 95157, 26585, 27465, 95215, 
95160, 26573, 2709, 27464, 95159
33121, 26512, 2698, 27436, 94979, 26513, 2697, 27437, 94980, 26585, 27465, 95215, 95160, 26586, 27467, 95216, 
95163, 26575, 2708, 27466, 95162
33122, 26513, 2697, 27437, 94980, 2567, 64, 2737, 27306, 26586, 27467, 95216, 95163, 2571, 2739, 27323, 
27318, 26576, 2707, 27468, 95165
33123, 27283, 2725, 2726, 27284, 94971, 27428, 27438, 94981, 27300, 2728, 27301, 27298, 95207, 27470, 95217, 
95167, 95135, 27448, 27469, 95166
33124, 94971, 27428, 27438, 94981, 94972, 27429, 27439, 94982, 95207, 27470, 95217, 95167, 95208, 27472, 95218, 
95170, 95138, 27450, 27471, 95169
33125, 94972, 27429, 27439, 94982, 94973, 27430, 27440, 94983, 95208, 27472, 95218, 95170, 95209, 27474, 95219, 
95173, 95141, 27452, 27473, 95172
33126, 94973, 27430, 27440, 94983, 94974, 27431, 27441, 94984, 95209, 27474, 95219, 95173, 95210, 27476, 95220, 
95176, 95144, 27454, 27475, 95175
33127, 94974, 27431, 27441, 94984, 94975, 27432, 27442, 94985, 95210, 27476, 95220, 95176, 95211, 27478, 95221, 
95179, 95147, 27456, 27477, 95178
33128, 94975, 27432, 27442, 94985, 94976, 27433, 27443, 94986, 95211, 27478, 95221, 95179, 95212, 27480, 95222, 
95182, 95150, 27458, 27479, 95181
33129, 94976, 27433, 27443, 94986, 94977, 27434, 27444, 94987, 95212, 27480, 95222, 95182, 95213, 27482, 95223, 
95185, 95153, 27460, 27481, 95184
33130, 94977, 27434, 27444, 94987, 94978, 27435, 27445, 94988, 95213, 27482, 95223, 95185, 95214, 27484, 95224, 
95188, 95156, 27462, 27483, 95187
33131, 94978, 27435, 27445, 94988, 94979, 27436, 27446, 94989, 95214, 27484, 95224, 95188, 95215, 27486, 95225, 
95191, 95159, 27464, 27485, 95190
33132, 94979, 27436, 27446, 94989, 94980, 27437, 27447, 94990, 95215, 27486, 95225, 95191, 95216, 27488, 95226, 
95194, 95162, 27466, 27487, 95193
33133, 94980, 27437, 27447, 94990, 27306, 2737, 2738, 27307, 95216, 27488, 95226, 95194, 27323, 2740, 27324, 
27320, 95165, 27468, 27489, 95196
33134, 27284, 2726, 67, 2720, 94981, 27438, 2751, 27345, 27301, 2729, 2724, 27299, 95217, 27490, 27418, 
95197, 95166, 27469, 2762, 27398
33135, 94981, 27438, 2751, 27345, 94982, 27439, 2750, 27346, 95217, 27490, 27418, 95197, 95218, 27491, 27419, 
95198, 95169, 27471, 2761, 27400
33136, 94982, 27439, 2750, 27346, 94983, 27440, 2749, 27347, 95218, 27491, 27419, 95198, 95219, 27492, 27420, 
95199, 95172, 27473, 2760, 27402
33137, 94983, 27440, 2749, 27347, 94984, 27441, 2748, 27348, 95219, 27492, 27420, 95199, 95220, 27493, 27421, 
95200, 95175, 27475, 2759, 27404
33138, 94984, 27441, 2748, 27348, 94985, 27442, 2747, 27349, 95220, 27493, 27421, 95200, 95221, 27494, 27422, 
95201, 95178, 27477, 2758, 27406
33139, 94985, 27442, 2747, 27349, 94986, 27443, 2746, 27350, 95221, 27494, 27422, 95201, 95222, 27495, 27423, 
95202, 95181, 27479, 2757, 27408
33140, 94986, 27443, 2746, 27350, 94987, 27444, 2745, 27351, 95222, 27495, 27423, 95202, 95223, 27496, 27424, 
95203, 95184, 27481, 2756, 27410
33141, 94987, 27444, 2745, 27351, 94988, 27445, 2744, 27352, 95223, 27496, 27424, 95203, 95224, 27497, 27425, 
95204, 95187, 27483, 2755, 27412
33142, 94988, 27445, 2744, 27352, 94989, 27446, 2743, 27353, 95224, 27497, 27425, 95204, 95225, 27498, 27426, 
95205, 95190, 27485, 2754, 27414
33143, 94989, 27446, 2743, 27353, 94990, 27447, 2742, 27354, 95225, 27498, 27426, 95205, 95226, 27499, 27427, 
95206, 95193, 27487, 2753, 27416
33144, 94990, 27447, 2742, 27354, 27307, 2738, 68, 2732, 95226, 27499, 27427, 95206, 27324, 2741, 2736, 
27322, 95196, 27489, 2752, 27417
*ELEMENT, type=C3D20, ELSET=Volume25
33145, 29838, 3198, 85, 3082, 95227, 30284, 3186, 29146, 29904, 3201, 3104, 29905, 95888, 30314, 29366, 
95889, 95887, 30315, 3197, 29367
33146, 95227, 30284, 3186, 29146, 95228, 30285, 3185, 29147, 95888, 30314, 29366, 95889, 95891, 30316, 29368, 
95892, 95890, 30317, 3196, 29369
33147, 95228, 30285, 3185, 29147, 95229, 30286, 3184, 29148, 95891, 30316, 29368, 95892, 95894, 30318, 29370, 
95895, 95893, 30319, 3195, 29371
33148, 95229, 30286, 3184, 29148, 95230, 30287, 3183, 29149, 95894, 30318, 29370, 95895, 95897, 30320, 29372, 
95898, 95896, 30321, 3194, 29373
33149, 95230, 30287, 3183, 29149, 95231, 30288, 3182, 29150, 95897, 30320, 29372, 95898, 95900, 30322, 29374, 
95901, 95899, 30323, 3193, 29375
33150, 95231, 30288, 3182, 29150, 95232, 30289, 3181, 29151, 95900, 30322, 29374, 95901, 95903, 30324, 29376, 
95904, 95902, 30325, 3192, 29377
33151, 95232, 30289, 3181, 29151, 95233, 30290, 3180, 29152, 95903, 30324, 29376, 95904, 95906, 30326, 29378, 
95907, 95905, 30327, 3191, 29379
33152, 95233, 30290, 3180, 29152, 95234, 30291, 3179, 29153, 95906, 30326, 29378, 95907, 95909, 30328, 29380, 
95910, 95908, 30329, 3190, 29381
33153, 95234, 30291, 3179, 29153, 95235, 30292, 3178, 29154, 95909, 30328, 29380, 95910, 95912, 30330, 29382, 
95913, 95911, 30331, 3189, 29383
33154, 95235, 30292, 3178, 29154, 95236, 30293, 3177, 29155, 95912, 30330, 29382, 95913, 95915, 30332, 29384, 
95916, 95914, 30333, 3188, 29385
33155, 95236, 30293, 3177, 29155, 30061, 3250, 86, 3132, 95915, 30332, 29384, 95916, 30128, 3253, 3154, 
30127, 95917, 30334, 3187, 29386
33156, 29839, 29838, 3082, 3083, 95237, 95227, 29146, 29156, 29906, 29905, 3105, 29907, 95919, 95889, 29387, 
95920, 95918, 95887, 29367, 29388
33157, 95237, 95227, 29146, 29156, 95238, 95228, 29147, 29157, 95919, 95889, 29387, 95920, 95922, 95892, 29389, 
95923, 95921, 95890, 29369, 29390
33158, 95238, 95228, 29147, 29157, 95239, 95229, 29148, 29158, 95922, 95892, 29389, 95923, 95925, 95895, 29391, 
95926, 95924, 95893, 29371, 29392
33159, 95239, 95229, 29148, 29158, 95240, 95230, 29149, 29159, 95925, 95895, 29391, 95926, 95928, 95898, 29393, 
95929, 95927, 95896, 29373, 29394
33160, 95240, 95230, 29149, 29159, 95241, 95231, 29150, 29160, 95928, 95898, 29393, 95929, 95931, 95901, 29395, 
95932, 95930, 95899, 29375, 29396
33161, 95241, 95231, 29150, 29160, 95242, 95232, 29151, 29161, 95931, 95901, 29395, 95932, 95934, 95904, 29397, 
95935, 95933, 95902, 29377, 29398
33162, 95242, 95232, 29151, 29161, 95243, 95233, 29152, 29162, 95934, 95904, 29397, 95935, 95937, 95907, 29399, 
95938, 95936, 95905, 29379, 29400
33163, 95243, 95233, 29152, 29162, 95244, 95234, 29153, 29163, 95937, 95907, 29399, 95938, 95940, 95910, 29401, 
95941, 95939, 95908, 29381, 29402
33164, 95244, 95234, 29153, 29163, 95245, 95235, 29154, 29164, 95940, 95910, 29401, 95941, 95943, 95913, 29403, 
95944, 95942, 95911, 29383, 29404
33165, 95245, 95235, 29154, 29164, 95246, 95236, 29155, 29165, 95943, 95913, 29403, 95944, 95946, 95916, 29405, 
95947, 95945, 95914, 29385, 29406
33166, 95246, 95236, 29155, 29165, 30062, 30061, 3132, 3133, 95946, 95916, 29405, 95947, 30130, 30127, 3155, 
30129, 95948, 95917, 29386, 29407
33167, 29840, 29839, 3083, 3084, 95247, 95237, 29156, 29166, 29908, 29907, 3106, 29909, 95950, 95920, 29408, 
95951, 95949, 95918, 29388, 29409
33168, 95247, 95237, 29156, 29166, 95248, 95238, 29157, 29167, 95950, 95920, 29408, 95951, 95953, 95923, 29410, 
95954, 95952, 95921, 29390, 29411
33169, 95248, 95238, 29157, 29167, 95249, 95239, 29158, 29168, 95953, 95923, 29410, 95954, 95956, 95926, 29412, 
95957, 95955, 95924, 29392, 29413
33170, 95249, 95239, 29158, 29168, 95250, 95240, 29159, 29169, 95956, 95926, 29412, 95957, 95959, 95929, 29414, 
95960, 95958, 95927, 29394, 29415
33171, 95250, 95240, 29159, 29169, 95251, 95241, 29160, 29170, 95959, 95929, 29414, 95960, 95962, 95932, 29416, 
95963, 95961, 95930, 29396, 29417
33172, 95251, 95241, 29160, 29170, 95252, 95242, 29161, 29171, 95962, 95932, 29416, 95963, 95965, 95935, 29418, 
95966, 95964, 95933, 29398, 29419
33173, 95252, 95242, 29161, 29171, 95253, 95243, 29162, 29172, 95965, 95935, 29418, 95966, 95968, 95938, 29420, 
95969, 95967, 95936, 29400, 29421
33174, 95253, 95243, 29162, 29172, 95254, 95244, 29163, 29173, 95968, 95938, 29420, 95969, 95971, 95941, 29422, 
95972, 95970, 95939, 29402, 29423
33175, 95254, 95244, 29163, 29173, 95255, 95245, 29164, 29174, 95971, 95941, 29422, 95972, 95974, 95944, 29424, 
95975, 95973, 95942, 29404, 29425
33176, 95255, 95245, 29164, 29174, 95256, 95246, 29165, 29175, 95974, 95944, 29424, 95975, 95977, 95947, 29426, 
95978, 95976, 95945, 29406, 29427
33177, 95256, 95246, 29165, 29175, 30063, 30062, 3133, 3134, 95977, 95947, 29426, 95978, 30132, 30129, 3156, 
30131, 95979, 95948, 29407, 29428
33178, 29841, 29840, 3084, 3085, 95257, 95247, 29166, 29176, 29910, 29909, 3107, 29911, 95981, 95951, 29429, 
95982, 95980, 95949, 29409, 29430
33179, 95257, 95247, 29166, 29176, 95258, 95248, 29167, 29177, 95981, 95951, 29429, 95982, 95984, 95954, 29431, 
95985, 95983, 95952, 29411, 29432
33180, 95258, 95248, 29167, 29177, 95259, 95249, 29168, 29178, 95984, 95954, 29431, 95985, 95987, 95957, 29433, 
95988, 95986, 95955, 29413, 29434
33181, 95259, 95249, 29168, 29178, 95260, 95250, 29169, 29179, 95987, 95957, 29433, 95988, 95990, 95960, 29435, 
95991, 95989, 95958, 29415, 29436
33182, 95260, 95250, 29169, 29179, 95261, 95251, 29170, 29180, 95990, 95960, 29435, 95991, 95993, 95963, 29437, 
95994, 95992, 95961, 29417, 29438
33183, 95261, 95251, 29170, 29180, 95262, 95252, 29171, 29181, 95993, 95963, 29437, 95994, 95996, 95966, 29439, 
95997, 95995, 95964, 29419, 29440
33184, 95262, 95252, 29171, 29181, 95263, 95253, 29172, 29182, 95996, 95966, 29439, 95997, 95999, 95969, 29441, 
96000, 95998, 95967, 29421, 29442
33185, 95263, 95253, 29172, 29182, 95264, 95254, 29173, 29183, 95999, 95969, 29441, 96000, 96002, 95972, 29443, 
96003, 96001, 95970, 29423, 29444
33186, 95264, 95254, 29173, 29183, 95265, 95255, 29174, 29184, 96002, 95972, 29443, 96003, 96005, 95975, 29445, 
96006, 96004, 95973, 29425, 29446
33187, 95265, 95255, 29174, 29184, 95266, 95256, 29175, 29185, 96005, 95975, 29445, 96006, 96008, 95978, 29447, 
96009, 96007, 95976, 29427, 29448
33188, 95266, 95256, 29175, 29185, 30064, 30063, 3134, 3135, 96008, 95978, 29447, 96009, 30134, 30131, 3157, 
30133, 96010, 95979, 29428, 29449
33189, 29842, 29841, 3085, 3086, 95267, 95257, 29176, 29186, 29912, 29911, 3108, 29913, 96012, 95982, 29450, 
96013, 96011, 95980, 29430, 29451
33190, 95267, 95257, 29176, 29186, 95268, 95258, 29177, 29187, 96012, 95982, 29450, 96013, 96015, 95985, 29452, 
96016, 96014, 95983, 29432, 29453
33191, 95268, 95258, 29177, 29187, 95269, 95259, 29178, 29188, 96015, 95985, 29452, 96016, 96018, 95988, 29454, 
96019, 96017, 95986, 29434, 29455
33192, 95269, 95259, 29178, 29188, 95270, 95260, 29179, 29189, 96018, 95988, 29454, 96019, 96021, 95991, 29456, 
96022, 96020, 95989, 29436, 29457
33193, 95270, 95260, 29179, 29189, 95271, 95261, 29180, 29190, 96021, 95991, 29456, 96022, 96024, 95994, 29458, 
96025, 96023, 95992, 29438, 29459
33194, 95271, 95261, 29180, 29190, 95272, 95262, 29181, 29191, 96024, 95994, 29458, 96025, 96027, 95997, 29460, 
96028, 96026, 95995, 29440, 29461
33195, 95272, 95262, 29181, 29191, 95273, 95263, 29182, 29192, 96027, 95997, 29460, 96028, 96030, 96000, 29462, 
96031, 96029, 95998, 29442, 29463
33196, 95273, 95263, 29182, 29192, 95274, 95264, 29183, 29193, 96030, 96000, 29462, 96031, 96033, 96003, 29464, 
96034, 96032, 96001, 29444, 29465
33197, 95274, 95264, 29183, 29193, 95275, 95265, 29184, 29194, 96033, 96003, 29464, 96034, 96036, 96006, 29466, 
96037, 96035, 96004, 29446, 29467
33198, 95275, 95265, 29184, 29194, 95276, 95266, 29185, 29195, 96036, 96006, 29466, 96037, 96039, 96009, 29468, 
96040, 96038, 96007, 29448, 29469
33199, 95276, 95266, 29185, 29195, 30065, 30064, 3135, 3136, 96039, 96009, 29468, 96040, 30136, 30133, 3158, 
30135, 96041, 96010, 29449, 29470
33200, 29843, 29842, 3086, 3087, 95277, 95267, 29186, 29196, 29914, 29913, 3109, 29915, 96043, 96013, 29471, 
96044, 96042, 96011, 29451, 29472
33201, 95277, 95267, 29186, 29196, 95278, 95268, 29187, 29197, 96043, 96013, 29471, 96044, 96046, 96016, 29473, 
96047, 96045, 96014, 29453, 29474
33202, 95278, 95268, 29187, 29197, 95279, 95269, 29188, 29198, 96046, 96016, 29473, 96047, 96049, 96019, 29475, 
96050, 96048, 96017, 29455, 29476
33203, 95279, 95269, 29188, 29198, 95280, 95270, 29189, 29199, 96049, 96019, 29475, 96050, 96052, 96022, 29477, 
96053, 96051, 96020, 29457, 29478
33204, 95280, 95270, 29189, 29199, 95281, 95271, 29190, 29200, 96052, 96022, 29477, 96053, 96055, 96025, 29479, 
96056, 96054, 96023, 29459, 29480
33205, 95281, 95271, 29190, 29200, 95282, 95272, 29191, 29201, 96055, 96025, 29479, 96056, 96058, 96028, 29481, 
96059, 96057, 96026, 29461, 29482
33206, 95282, 95272, 29191, 29201, 95283, 95273, 29192, 29202, 96058, 96028, 29481, 96059, 96061, 96031, 29483, 
96062, 96060, 96029, 29463, 29484
33207, 95283, 95273, 29192, 29202, 95284, 95274, 29193, 29203, 96061, 96031, 29483, 96062, 96064, 96034, 29485, 
96065, 96063, 96032, 29465, 29486
33208, 95284, 95274, 29193, 29203, 95285, 95275, 29194, 29204, 96064, 96034, 29485, 96065, 96067, 96037, 29487, 
96068, 96066, 96035, 29467, 29488
33209, 95285, 95275, 29194, 29204, 95286, 95276, 29195, 29205, 96067, 96037, 29487, 96068, 96070, 96040, 29489, 
96071, 96069, 96038, 29469, 29490
33210, 95286, 95276, 29195, 29205, 30066, 30065, 3136, 3137, 96070, 96040, 29489, 96071, 30138, 30135, 3159, 
30137, 96072, 96041, 29470, 29491
33211, 29844, 29843, 3087, 3088, 95287, 95277, 29196, 29206, 29916, 29915, 3110, 29917, 96074, 96044, 29492, 
96075, 96073, 96042, 29472, 29493
33212, 95287, 95277, 29196, 29206, 95288, 95278, 29197, 29207, 96074, 96044, 29492, 96075, 96077, 96047, 29494, 
96078, 96076, 96045, 29474, 29495
33213, 95288, 95278, 29197, 29207, 95289, 95279, 29198, 29208, 96077, 96047, 29494, 96078, 96080, 96050, 29496, 
96081, 96079, 96048, 29476, 29497
33214, 95289, 95279, 29198, 29208, 95290, 95280, 29199, 29209, 96080, 96050, 29496, 96081, 96083, 96053, 29498, 
96084, 96082, 96051, 29478, 29499
33215, 95290, 95280, 29199, 29209, 95291, 95281, 29200, 29210, 96083, 96053, 29498, 96084, 96086, 96056, 29500, 
96087, 96085, 96054, 29480, 29501
33216, 95291, 95281, 29200, 29210, 95292, 95282, 29201, 29211, 96086, 96056, 29500, 96087, 96089, 96059, 29502, 
96090, 96088, 96057, 29482, 29503
33217, 95292, 95282, 29201, 29211, 95293, 95283, 29202, 29212, 96089, 96059, 29502, 96090, 96092, 96062, 29504, 
96093, 96091, 96060, 29484, 29505
33218, 95293, 95283, 29202, 29212, 95294, 95284, 29203, 29213, 96092, 96062, 29504, 96093, 96095, 96065, 29506, 
96096, 96094, 96063, 29486, 29507
33219, 95294, 95284, 29203, 29213, 95295, 95285, 29204, 29214, 96095, 96065, 29506, 96096, 96098, 96068, 29508, 
96099, 96097, 96066, 29488, 29509
33220, 95295, 95285, 29204, 29214, 95296, 95286, 29205, 29215, 96098, 96068, 29508, 96099, 96101, 96071, 29510, 
96102, 96100, 96069, 29490, 29511
33221, 95296, 95286, 29205, 29215, 30067, 30066, 3137, 3138, 96101, 96071, 29510, 96102, 30140, 30137, 3160, 
30139, 96103, 96072, 29491, 29512
33222, 29845, 29844, 3088, 3089, 95297, 95287, 29206, 29216, 29918, 29917, 3111, 29919, 96105, 96075, 29513, 
96106, 96104, 96073, 29493, 29514
33223, 95297, 95287, 29206, 29216, 95298, 95288, 29207, 29217, 96105, 96075, 29513, 96106, 96108, 96078, 29515, 
96109, 96107, 96076, 29495, 29516
33224, 95298, 95288, 29207, 29217, 95299, 95289, 29208, 29218, 96108, 96078, 29515, 96109, 96111, 96081, 29517, 
96112, 96110, 96079, 29497, 29518
33225, 95299, 95289, 29208, 29218, 95300, 95290, 29209, 29219, 96111, 96081, 29517, 96112, 96114, 96084, 29519, 
96115, 96113, 96082, 29499, 29520
33226, 95300, 95290, 29209, 29219, 95301, 95291, 29210, 29220, 96114, 96084, 29519, 96115, 96117, 96087, 29521, 
96118, 96116, 96085, 29501, 29522
33227, 95301, 95291, 29210, 29220, 95302, 95292, 29211, 29221, 96117, 96087, 29521, 96118, 96120, 96090, 29523, 
96121, 96119, 96088, 29503, 29524
33228, 95302, 95292, 29211, 29221, 95303, 95293, 29212, 29222, 96120, 96090, 29523, 96121, 96123, 96093, 29525, 
96124, 96122, 96091, 29505, 29526
33229, 95303, 95293, 29212, 29222, 95304, 95294, 29213, 29223, 96123, 96093, 29525, 96124, 96126, 96096, 29527, 
96127, 96125, 96094, 29507, 29528
33230, 95304, 95294, 29213, 29223, 95305, 95295, 29214, 29224, 96126, 96096, 29527, 96127, 96129, 96099, 29529, 
96130, 96128, 96097, 29509, 29530
33231, 95305, 95295, 29214, 29224, 95306, 95296, 29215, 29225, 96129, 96099, 29529, 96130, 96132, 96102, 29531, 
96133, 96131, 96100, 29511, 29532
33232, 95306, 95296, 29215, 29225, 30068, 30067, 3138, 3139, 96132, 96102, 29531, 96133, 30142, 30139, 3161, 
30141, 96134, 96103, 29512, 29533
33233, 29846, 29845, 3089, 3090, 95307, 95297, 29216, 29226, 29920, 29919, 3112, 29921, 96136, 96106, 29534, 
96137, 96135, 96104, 29514, 29535
33234, 95307, 95297, 29216, 29226, 95308, 95298, 29217, 29227, 96136, 96106, 29534, 96137, 96139, 96109, 29536, 
96140, 96138, 96107, 29516, 29537
33235, 95308, 95298, 29217, 29227, 95309, 95299, 29218, 29228, 96139, 96109, 29536, 96140, 96142, 96112, 29538, 
96143, 96141, 96110, 29518, 29539
33236, 95309, 95299, 29218, 29228, 95310, 95300, 29219, 29229, 96142, 96112, 29538, 96143, 96145, 96115, 29540, 
96146, 96144, 96113, 29520, 29541
33237, 95310, 95300, 29219, 29229, 95311, 95301, 29220, 29230, 96145, 96115, 29540, 96146, 96148, 96118, 29542, 
96149, 96147, 96116, 29522, 29543
33238, 95311, 95301, 29220, 29230, 95312, 95302, 29221, 29231, 96148, 96118, 29542, 96149, 96151, 96121, 29544, 
96152, 96150, 96119, 29524, 29545
33239, 95312, 95302, 29221, 29231, 95313, 95303, 29222, 29232, 96151, 96121, 29544, 96152, 96154, 96124, 29546, 
96155, 96153, 96122, 29526, 29547
33240, 95313, 95303, 29222, 29232, 95314, 95304, 29223, 29233, 96154, 96124, 29546, 96155, 96157, 96127, 29548, 
96158, 96156, 96125, 29528, 29549
33241, 95314, 95304, 29223, 29233, 95315, 95305, 29224, 29234, 96157, 96127, 29548, 96158, 96160, 96130, 29550, 
96161, 96159, 96128, 29530, 29551
33242, 95315, 95305, 29224, 29234, 95316, 95306, 29225, 29235, 96160, 96130, 29550, 96161, 96163, 96133, 29552, 
96164, 96162, 96131, 29532, 29553
33243, 95316, 95306, 29225, 29235, 30069, 30068, 3139, 3140, 96163, 96133, 29552, 96164, 30144, 30141, 3162, 
30143, 96165, 96134, 29533, 29554
33244, 29847, 29846, 3090, 3091, 95317, 95307, 29226, 29236, 29922, 29921, 3113, 29923, 96167, 96137, 29555, 
96168, 96166, 96135, 29535, 29556
33245, 95317, 95307, 29226, 29236, 95318, 95308, 29227, 29237, 96167, 96137, 29555, 96168, 96170, 96140, 29557, 
96171, 96169, 96138, 29537, 29558
33246, 95318, 95308, 29227, 29237, 95319, 95309, 29228, 29238, 96170, 96140, 29557, 96171, 96173, 96143, 29559, 
96174, 96172, 96141, 29539, 29560
33247, 95319, 95309, 29228, 29238, 95320, 95310, 29229, 29239, 96173, 96143, 29559, 96174, 96176, 96146, 29561, 
96177, 96175, 96144, 29541, 29562
33248, 95320, 95310, 29229, 29239, 95321, 95311, 29230, 29240, 96176, 96146, 29561, 96177, 96179, 96149, 29563, 
96180, 96178, 96147, 29543, 29564
33249, 95321, 95311, 29230, 29240, 95322, 95312, 29231, 29241, 96179, 96149, 29563, 96180, 96182, 96152, 29565, 
96183, 96181, 96150, 29545, 29566
33250, 95322, 95312, 29231, 29241, 95323, 95313, 29232, 29242, 96182, 96152, 29565, 96183, 96185, 96155, 29567, 
96186, 96184, 96153, 29547, 29568
33251, 95323, 95313, 29232, 29242, 95324, 95314, 29233, 29243, 96185, 96155, 29567, 96186, 96188, 96158, 29569, 
96189, 96187, 96156, 29549, 29570
33252, 95324, 95314, 29233, 29243, 95325, 95315, 29234, 29244, 96188, 96158, 29569, 96189, 96191, 96161, 29571, 
96192, 96190, 96159, 29551, 29572
33253, 95325, 95315, 29234, 29244, 95326, 95316, 29235, 29245, 96191, 96161, 29571, 96192, 96194, 96164, 29573, 
96195, 96193, 96162, 29553, 29574
33254, 95326, 95316, 29235, 29245, 30070, 30069, 3140, 3141, 96194, 96164, 29573, 96195, 30146, 30143, 3163, 
30145, 96196, 96165, 29554, 29575
33255, 29848, 29847, 3091, 3092, 95327, 95317, 29236, 29246, 29924, 29923, 3114, 29925, 96198, 96168, 29576, 
96199, 96197, 96166, 29556, 29577
33256, 95327, 95317, 29236, 29246, 95328, 95318, 29237, 29247, 96198, 96168, 29576, 96199, 96201, 96171, 29578, 
96202, 96200, 96169, 29558, 29579
33257, 95328, 95318, 29237, 29247, 95329, 95319, 29238, 29248, 96201, 96171, 29578, 96202, 96204, 96174, 29580, 
96205, 96203, 96172, 29560, 29581
33258, 95329, 95319, 29238, 29248, 95330, 95320, 29239, 29249, 96204, 96174, 29580, 96205, 96207, 96177, 29582, 
96208, 96206, 96175, 29562, 29583
33259, 95330, 95320, 29239, 29249, 95331, 95321, 29240, 29250, 96207, 96177, 29582, 96208, 96210, 96180, 29584, 
96211, 96209, 96178, 29564, 29585
33260, 95331, 95321, 29240, 29250, 95332, 95322, 29241, 29251, 96210, 96180, 29584, 96211, 96213, 96183, 29586, 
96214, 96212, 96181, 29566, 29587
33261, 95332, 95322, 29241, 29251, 95333, 95323, 29242, 29252, 96213, 96183, 29586, 96214, 96216, 96186, 29588, 
96217, 96215, 96184, 29568, 29589
33262, 95333, 95323, 29242, 29252, 95334, 95324, 29243, 29253, 96216, 96186, 29588, 96217, 96219, 96189, 29590, 
96220, 96218, 96187, 29570, 29591
33263, 95334, 95324, 29243, 29253, 95335, 95325, 29244, 29254, 96219, 96189, 29590, 96220, 96222, 96192, 29592, 
96223, 96221, 96190, 29572, 29593
33264, 95335, 95325, 29244, 29254, 95336, 95326, 29245, 29255, 96222, 96192, 29592, 96223, 96225, 96195, 29594, 
96226, 96224, 96193, 29574, 29595
33265, 95336, 95326, 29245, 29255, 30071, 30070, 3141, 3142, 96225, 96195, 29594, 96226, 30148, 30145, 3164, 
30147, 96227, 96196, 29575, 29596
33266, 29849, 29848, 3092, 3093, 95337, 95327, 29246, 29256, 29926, 29925, 3115, 29927, 96229, 96199, 29597, 
96230, 96228, 96197, 29577, 29598
33267, 95337, 95327, 29246, 29256, 95338, 95328, 29247, 29257, 96229, 96199, 29597, 96230, 96232, 96202, 29599, 
96233, 96231, 96200, 29579, 29600
33268, 95338, 95328, 29247, 29257, 95339, 95329, 29248, 29258, 96232, 96202, 29599, 96233, 96235, 96205, 29601, 
96236, 96234, 96203, 29581, 29602
33269, 95339, 95329, 29248, 29258, 95340, 95330, 29249, 29259, 96235, 96205, 29601, 96236, 96238, 96208, 29603, 
96239, 96237, 96206, 29583, 29604
33270, 95340, 95330, 29249, 29259, 95341, 95331, 29250, 29260, 96238, 96208, 29603, 96239, 96241, 96211, 29605, 
96242, 96240, 96209, 29585, 29606
33271, 95341, 95331, 29250, 29260, 95342, 95332, 29251, 29261, 96241, 96211, 29605, 96242, 96244, 96214, 29607, 
96245, 96243, 96212, 29587, 29608
33272, 95342, 95332, 29251, 29261, 95343, 95333, 29252, 29262, 96244, 96214, 29607, 96245, 96247, 96217, 29609, 
96248, 96246, 96215, 29589, 29610
33273, 95343, 95333, 29252, 29262, 95344, 95334, 29253, 29263, 96247, 96217, 29609, 96248, 96250, 96220, 29611, 
96251, 96249, 96218, 29591, 29612
33274, 95344, 95334, 29253, 29263, 95345, 95335, 29254, 29264, 96250, 96220, 29611, 96251, 96253, 96223, 29613, 
96254, 96252, 96221, 29593, 29614
33275, 95345, 95335, 29254, 29264, 95346, 95336, 29255, 29265, 96253, 96223, 29613, 96254, 96256, 96226, 29615, 
96257, 96255, 96224, 29595, 29616
33276, 95346, 95336, 29255, 29265, 30072, 30071, 3142, 3143, 96256, 96226, 29615, 96257, 30150, 30147, 3165, 
30149, 96258, 96227, 29596, 29617
33277, 29850, 29849, 3093, 3094, 95347, 95337, 29256, 29266, 29928, 29927, 3116, 29929, 96260, 96230, 29618, 
96261, 96259, 96228, 29598, 29619
33278, 95347, 95337, 29256, 29266, 95348, 95338, 29257, 29267, 96260, 96230, 29618, 96261, 96263, 96233, 29620, 
96264, 96262, 96231, 29600, 29621
33279, 95348, 95338, 29257, 29267, 95349, 95339, 29258, 29268, 96263, 96233, 29620, 96264, 96266, 96236, 29622, 
96267, 96265, 96234, 29602, 29623
33280, 95349, 95339, 29258, 29268, 95350, 95340, 29259, 29269, 96266, 96236, 29622, 96267, 96269, 96239, 29624, 
96270, 96268, 96237, 29604, 29625
33281, 95350, 95340, 29259, 29269, 95351, 95341, 29260, 29270, 96269, 96239, 29624, 96270, 96272, 96242, 29626, 
96273, 96271, 96240, 29606, 29627
33282, 95351, 95341, 29260, 29270, 95352, 95342, 29261, 29271, 96272, 96242, 29626, 96273, 96275, 96245, 29628, 
96276, 96274, 96243, 29608, 29629
33283, 95352, 95342, 29261, 29271, 95353, 95343, 29262, 29272, 96275, 96245, 29628, 96276, 96278, 96248, 29630, 
96279, 96277, 96246, 29610, 29631
33284, 95353, 95343, 29262, 29272, 95354, 95344, 29263, 29273, 96278, 96248, 29630, 96279, 96281, 96251, 29632, 
96282, 96280, 96249, 29612, 29633
33285, 95354, 95344, 29263, 29273, 95355, 95345, 29264, 29274, 96281, 96251, 29632, 96282, 96284, 96254, 29634, 
96285, 96283, 96252, 29614, 29635
33286, 95355, 95345, 29264, 29274, 95356, 95346, 29265, 29275, 96284, 96254, 29634, 96285, 96287, 96257, 29636, 
96288, 96286, 96255, 29616, 29637
33287, 95356, 95346, 29265, 29275, 30073, 30072, 3143, 3144, 96287, 96257, 29636, 96288, 30152, 30149, 3166, 
30151, 96289, 96258, 29617, 29638
33288, 29851, 29850, 3094, 3095, 95357, 95347, 29266, 29276, 29930, 29929, 3117, 29931, 96291, 96261, 29639, 
96292, 96290, 96259, 29619, 29640
33289, 95357, 95347, 29266, 29276, 95358, 95348, 29267, 29277, 96291, 96261, 29639, 96292, 96294, 96264, 29641, 
96295, 96293, 96262, 29621, 29642
33290, 95358, 95348, 29267, 29277, 95359, 95349, 29268, 29278, 96294, 96264, 29641, 96295, 96297, 96267, 29643, 
96298, 96296, 96265, 29623, 29644
33291, 95359, 95349, 29268, 29278, 95360, 95350, 29269, 29279, 96297, 96267, 29643, 96298, 96300, 96270, 29645, 
96301, 96299, 96268, 29625, 29646
33292, 95360, 95350, 29269, 29279, 95361, 95351, 29270, 29280, 96300, 96270, 29645, 96301, 96303, 96273, 29647, 
96304, 96302, 96271, 29627, 29648
33293, 95361, 95351, 29270, 29280, 95362, 95352, 29271, 29281, 96303, 96273, 29647, 96304, 96306, 96276, 29649, 
96307, 96305, 96274, 29629, 29650
33294, 95362, 95352, 29271, 29281, 95363, 95353, 29272, 29282, 96306, 96276, 29649, 96307, 96309, 96279, 29651, 
96310, 96308, 96277, 29631, 29652
33295, 95363, 95353, 29272, 29282, 95364, 95354, 29273, 29283, 96309, 96279, 29651, 96310, 96312, 96282, 29653, 
96313, 96311, 96280, 29633, 29654
33296, 95364, 95354, 29273, 29283, 95365, 95355, 29274, 29284, 96312, 96282, 29653, 96313, 96315, 96285, 29655, 
96316, 96314, 96283, 29635, 29656
33297, 95365, 95355, 29274, 29284, 95366, 95356, 29275, 29285, 96315, 96285, 29655, 96316, 96318, 96288, 29657, 
96319, 96317, 96286, 29637, 29658
33298, 95366, 95356, 29275, 29285, 30074, 30073, 3144, 3145, 96318, 96288, 29657, 96319, 30154, 30151, 3167, 
30153, 96320, 96289, 29638, 29659
33299, 29852, 29851, 3095, 3096, 95367, 95357, 29276, 29286, 29932, 29931, 3118, 29933, 96322, 96292, 29660, 
96323, 96321, 96290, 29640, 29661
33300, 95367, 95357, 29276, 29286, 95368, 95358, 29277, 29287, 96322, 96292, 29660, 96323, 96325, 96295, 29662, 
96326, 96324, 96293, 29642, 29663
33301, 95368, 95358, 29277, 29287, 95369, 95359, 29278, 29288, 96325, 96295, 29662, 96326, 96328, 96298, 29664, 
96329, 96327, 96296, 29644, 29665
33302, 95369, 95359, 29278, 29288, 95370, 95360, 29279, 29289, 96328, 96298, 29664, 96329, 96331, 96301, 29666, 
96332, 96330, 96299, 29646, 29667
33303, 95370, 95360, 29279, 29289, 95371, 95361, 29280, 29290, 96331, 96301, 29666, 96332, 96334, 96304, 29668, 
96335, 96333, 96302, 29648, 29669
33304, 95371, 95361, 29280, 29290, 95372, 95362, 29281, 29291, 96334, 96304, 29668, 96335, 96337, 96307, 29670, 
96338, 96336, 96305, 29650, 29671
33305, 95372, 95362, 29281, 29291, 95373, 95363, 29282, 29292, 96337, 96307, 29670, 96338, 96340, 96310, 29672, 
96341, 96339, 96308, 29652, 29673
33306, 95373, 95363, 29282, 29292, 95374, 95364, 29283, 29293, 96340, 96310, 29672, 96341, 96343, 96313, 29674, 
96344, 96342, 96311, 29654, 29675
33307, 95374, 95364, 29283, 29293, 95375, 95365, 29284, 29294, 96343, 96313, 29674, 96344, 96346, 96316, 29676, 
96347, 96345, 96314, 29656, 29677
33308, 95375, 95365, 29284, 29294, 95376, 95366, 29285, 29295, 96346, 96316, 29676, 96347, 96349, 96319, 29678, 
96350, 96348, 96317, 29658, 29679
33309, 95376, 95366, 29285, 29295, 30075, 30074, 3145, 3146, 96349, 96319, 29678, 96350, 30156, 30153, 3168, 
30155, 96351, 96320, 29659, 29680
33310, 29853, 29852, 3096, 3097, 95377, 95367, 29286, 29296, 29934, 29933, 3119, 29935, 96353, 96323, 29681, 
96354, 96352, 96321, 29661, 29682
33311, 95377, 95367, 29286, 29296, 95378, 95368, 29287, 29297, 96353, 96323, 29681, 96354, 96356, 96326, 29683, 
96357, 96355, 96324, 29663, 29684
33312, 95378, 95368, 29287, 29297, 95379, 95369, 29288, 29298, 96356, 96326, 29683, 96357, 96359, 96329, 29685, 
96360, 96358, 96327, 29665, 29686
33313, 95379, 95369, 29288, 29298, 95380, 95370, 29289, 29299, 96359, 96329, 29685, 96360, 96362, 96332, 29687, 
96363, 96361, 96330, 29667, 29688
33314, 95380, 95370, 29289, 29299, 95381, 95371, 29290, 29300, 96362, 96332, 29687, 96363, 96365, 96335, 29689, 
96366, 96364, 96333, 29669, 29690
33315, 95381, 95371, 29290, 29300, 95382, 95372, 29291, 29301, 96365, 96335, 29689, 96366, 96368, 96338, 29691, 
96369, 96367, 96336, 29671, 29692
33316, 95382, 95372, 29291, 29301, 95383, 95373, 29292, 29302, 96368, 96338, 29691, 96369, 96371, 96341, 29693, 
96372, 96370, 96339, 29673, 29694
33317, 95383, 95373, 29292, 29302, 95384, 95374, 29293, 29303, 96371, 96341, 29693, 96372, 96374, 96344, 29695, 
96375, 96373, 96342, 29675, 29696
33318, 95384, 95374, 29293, 29303, 95385, 95375, 29294, 29304, 96374, 96344, 29695, 96375, 96377, 96347, 29697, 
96378, 96376, 96345, 29677, 29698
33319, 95385, 95375, 29294, 29304, 95386, 95376, 29295, 29305, 96377, 96347, 29697, 96378, 96380, 96350, 29699, 
96381, 96379, 96348, 29679, 29700
33320, 95386, 95376, 29295, 29305, 30076, 30075, 3146, 3147, 96380, 96350, 29699, 96381, 30158, 30155, 3169, 
30157, 96382, 96351, 29680, 29701
33321, 29854, 29853, 3097, 3098, 95387, 95377, 29296, 29306, 29936, 29935, 3120, 29937, 96384, 96354, 29702, 
96385, 96383, 96352, 29682, 29703
33322, 95387, 95377, 29296, 29306, 95388, 95378, 29297, 29307, 96384, 96354, 29702, 96385, 96387, 96357, 29704, 
96388, 96386, 96355, 29684, 29705
33323, 95388, 95378, 29297, 29307, 95389, 95379, 29298, 29308, 96387, 96357, 29704, 96388, 96390, 96360, 29706, 
96391, 96389, 96358, 29686, 29707
33324, 95389, 95379, 29298, 29308, 95390, 95380, 29299, 29309, 96390, 96360, 29706, 96391, 96393, 96363, 29708, 
96394, 96392, 96361, 29688, 29709
33325, 95390, 95380, 29299, 29309, 95391, 95381, 29300, 29310, 96393, 96363, 29708, 96394, 96396, 96366, 29710, 
96397, 96395, 96364, 29690, 29711
33326, 95391, 95381, 29300, 29310, 95392, 95382, 29301, 29311, 96396, 96366, 29710, 96397, 96399, 96369, 29712, 
96400, 96398, 96367, 29692, 29713
33327, 95392, 95382, 29301, 29311, 95393, 95383, 29302, 29312, 96399, 96369, 29712, 96400, 96402, 96372, 29714, 
96403, 96401, 96370, 29694, 29715
33328, 95393, 95383, 29302, 29312, 95394, 95384, 29303, 29313, 96402, 96372, 29714, 96403, 96405, 96375, 29716, 
96406, 96404, 96373, 29696, 29717
33329, 95394, 95384, 29303, 29313, 95395, 95385, 29304, 29314, 96405, 96375, 29716, 96406, 96408, 96378, 29718, 
96409, 96407, 96376, 29698, 29719
33330, 95395, 95385, 29304, 29314, 95396, 95386, 29305, 29315, 96408, 96378, 29718, 96409, 96411, 96381, 29720, 
96412, 96410, 96379, 29700, 29721
33331, 95396, 95386, 29305, 29315, 30077, 30076, 3147, 3148, 96411, 96381, 29720, 96412, 30160, 30157, 3170, 
30159, 96413, 96382, 29701, 29722
33332, 29855, 29854, 3098, 3099, 95397, 95387, 29306, 29316, 29938, 29937, 3121, 29939, 96415, 96385, 29723, 
96416, 96414, 96383, 29703, 29724
33333, 95397, 95387, 29306, 29316, 95398, 95388, 29307, 29317, 96415, 96385, 29723, 96416, 96418, 96388, 29725, 
96419, 96417, 96386, 29705, 29726
33334, 95398, 95388, 29307, 29317, 95399, 95389, 29308, 29318, 96418, 96388, 29725, 96419, 96421, 96391, 29727, 
96422, 96420, 96389, 29707, 29728
33335, 95399, 95389, 29308, 29318, 95400, 95390, 29309, 29319, 96421, 96391, 29727, 96422, 96424, 96394, 29729, 
96425, 96423, 96392, 29709, 29730
33336, 95400, 95390, 29309, 29319, 95401, 95391, 29310, 29320, 96424, 96394, 29729, 96425, 96427, 96397, 29731, 
96428, 96426, 96395, 29711, 29732
33337, 95401, 95391, 29310, 29320, 95402, 95392, 29311, 29321, 96427, 96397, 29731, 96428, 96430, 96400, 29733, 
96431, 96429, 96398, 29713, 29734
33338, 95402, 95392, 29311, 29321, 95403, 95393, 29312, 29322, 96430, 96400, 29733, 96431, 96433, 96403, 29735, 
96434, 96432, 96401, 29715, 29736
33339, 95403, 95393, 29312, 29322, 95404, 95394, 29313, 29323, 96433, 96403, 29735, 96434, 96436, 96406, 29737, 
96437, 96435, 96404, 29717, 29738
33340, 95404, 95394, 29313, 29323, 95405, 95395, 29314, 29324, 96436, 96406, 29737, 96437, 96439, 96409, 29739, 
96440, 96438, 96407, 29719, 29740
33341, 95405, 95395, 29314, 29324, 95406, 95396, 29315, 29325, 96439, 96409, 29739, 96440, 96442, 96412, 29741, 
96443, 96441, 96410, 29721, 29742
33342, 95406, 95396, 29315, 29325, 30078, 30077, 3148, 3149, 96442, 96412, 29741, 96443, 30162, 30159, 3171, 
