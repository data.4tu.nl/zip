19199, 1.5260869565217, 0.41086956521739, 0
19200, 1.5913043478261, 0.43695652173913, 0
19201, 1.5695652173913, 0.41086956521739, 0
19202, 1.6347826086957, 0.43695652173913, 0
19203, 1.6130434782609, 0.41086956521739, 0
19204, 1.6782608695652, 0.43695652173913, 0
19205, 1.6565217391304, 0.41086956521739, 0
19206, 1.7217391304348, 0.43695652173913, 0
19207, 1.7, 0.41086956521739, 0
19208, 1.7652173913043, 0.43695652173913, 0
19209, 1.7434782608696, 0.41086956521739, 0
19210, 1.8086956521739, 0.43695652173913, 0
19211, 1.7869565217391, 0.41086956521739, 0
19212, 1.8521739130435, 0.43695652173913, 0
19213, 1.8304347826087, 0.41086956521739, 0
19214, 1.895652173913, 0.43695652173913, 0
19215, 1.8739130434783, 0.41086956521739, 0
19216, 1.9391304347826, 0.43695652173913, 0
19217, 1.9173913043478, 0.41086956521739, 0
19218, 1.9826086956522, 0.43695652173913, 0
19219, 1.9608695652174, 0.41086956521739, 0
19220, 2.0260869565217, 0.43695652173913, 0
19221, 2.004347826087, 0.41086956521739, 0
19222, 2.0695652173913, 0.43695652173913, 0
19223, 2.0478260869565, 0.41086956521739, 0
19224, 2.1130434782609, 0.43695652173913, 0
19225, 2.0913043478261, 0.41086956521739, 0
19226, 2.1565217391304, 0.43695652173913, 0
19227, 2.1347826086957, 0.41086956521739, 0
19228, 2.1782608695652, 0.41086956521739, 0
19229, 1.2434782608696, 0.38478260869565, 0
19230, 1.2217391304348, 0.35869565217391, 0
19231, 1.2869565217391, 0.38478260869565, 0
19232, 1.2652173913043, 0.35869565217391, 0
19233, 1.3304347826087, 0.38478260869565, 0
19234, 1.3086956521739, 0.35869565217391, 0
19235, 1.3739130434783, 0.38478260869565, 0
19236, 1.3521739130435, 0.35869565217391, 0
19237, 1.4173913043478, 0.38478260869565, 0
19238, 1.395652173913, 0.35869565217391, 0
19239, 1.4608695652174, 0.38478260869565, 0
19240, 1.4391304347826, 0.35869565217391, 0
19241, 1.504347826087, 0.38478260869565, 0
19242, 1.4826086956522, 0.35869565217391, 0
19243, 1.5478260869565, 0.38478260869565, 0
19244, 1.5260869565217, 0.35869565217391, 0
19245, 1.5913043478261, 0.38478260869565, 0
19246, 1.5695652173913, 0.35869565217391, 0
19247, 1.6347826086957, 0.38478260869565, 0
19248, 1.6130434782609, 0.35869565217391, 0
19249, 1.6782608695652, 0.38478260869565, 0
19250, 1.6565217391304, 0.35869565217391, 0
19251, 1.7217391304348, 0.38478260869565, 0
19252, 1.7, 0.35869565217391, 0
19253, 1.7652173913043, 0.38478260869565, 0
19254, 1.7434782608696, 0.35869565217391, 0
19255, 1.8086956521739, 0.38478260869565, 0
19256, 1.7869565217391, 0.35869565217391, 0
19257, 1.8521739130435, 0.38478260869565, 0
19258, 1.8304347826087, 0.35869565217391, 0
19259, 1.895652173913, 0.38478260869565, 0
19260, 1.8739130434783, 0.35869565217391, 0
19261, 1.9391304347826, 0.38478260869565, 0
19262, 1.9173913043478, 0.35869565217391, 0
19263, 1.9826086956522, 0.38478260869565, 0
19264, 1.9608695652174, 0.35869565217391, 0
19265, 2.0260869565217, 0.38478260869565, 0
19266, 2.004347826087, 0.35869565217391, 0
19267, 2.0695652173913, 0.38478260869565, 0
19268, 2.0478260869565, 0.35869565217391, 0
19269, 2.1130434782609, 0.38478260869565, 0
19270, 2.0913043478261, 0.35869565217391, 0
19271, 2.1565217391304, 0.38478260869565, 0
19272, 2.1347826086957, 0.35869565217391, 0
19273, 2.1782608695652, 0.35869565217391, 0
19274, 1.2434782608696, 0.33260869565217, 0
19275, 1.2217391304348, 0.30652173913044, 0
19276, 1.2869565217391, 0.33260869565217, 0
19277, 1.2652173913043, 0.30652173913044, 0
19278, 1.3304347826087, 0.33260869565217, 0
19279, 1.3086956521739, 0.30652173913043, 0
19280, 1.3739130434783, 0.33260869565217, 0
19281, 1.3521739130435, 0.30652173913044, 0
19282, 1.4173913043478, 0.33260869565217, 0
19283, 1.395652173913, 0.30652173913044, 0
19284, 1.4608695652174, 0.33260869565217, 0
19285, 1.4391304347826, 0.30652173913044, 0
19286, 1.504347826087, 0.33260869565217, 0
19287, 1.4826086956522, 0.30652173913044, 0
19288, 1.5478260869565, 0.33260869565217, 0
19289, 1.5260869565217, 0.30652173913044, 0
19290, 1.5913043478261, 0.33260869565217, 0
19291, 1.5695652173913, 0.30652173913044, 0
19292, 1.6347826086957, 0.33260869565217, 0
19293, 1.6130434782609, 0.30652173913044, 0
19294, 1.6782608695652, 0.33260869565217, 0
19295, 1.6565217391304, 0.30652173913043, 0
19296, 1.7217391304348, 0.33260869565217, 0
19297, 1.7, 0.30652173913043, 0
19298, 1.7652173913043, 0.33260869565217, 0
19299, 1.7434782608696, 0.30652173913043, 0
19300, 1.8086956521739, 0.33260869565217, 0
19301, 1.7869565217391, 0.30652173913044, 0
19302, 1.8521739130435, 0.33260869565217, 0
19303, 1.8304347826087, 0.30652173913044, 0
19304, 1.895652173913, 0.33260869565217, 0
19305, 1.8739130434783, 0.30652173913043, 0
19306, 1.9391304347826, 0.33260869565217, 0
19307, 1.9173913043478, 0.30652173913044, 0
19308, 1.9826086956522, 0.33260869565217, 0
19309, 1.9608695652174, 0.30652173913044, 0
19310, 2.0260869565217, 0.33260869565217, 0
19311, 2.004347826087, 0.30652173913044, 0
19312, 2.0695652173913, 0.33260869565217, 0
19313, 2.0478260869565, 0.30652173913044, 0
19314, 2.1130434782609, 0.33260869565217, 0
19315, 2.0913043478261, 0.30652173913043, 0
19316, 2.1565217391304, 0.33260869565217, 0
19317, 2.1347826086957, 0.30652173913043, 0
19318, 2.1782608695652, 0.30652173913044, 0
19319, 1.2434782608696, 0.2804347826087, 0
19320, 1.2217391304348, 0.25434782608696, 0
19321, 1.2869565217391, 0.2804347826087, 0
19322, 1.2652173913043, 0.25434782608696, 0
19323, 1.3304347826087, 0.2804347826087, 0
19324, 1.3086956521739, 0.25434782608696, 0
19325, 1.3739130434783, 0.2804347826087, 0
19326, 1.3521739130435, 0.25434782608696, 0
19327, 1.4173913043478, 0.2804347826087, 0
19328, 1.395652173913, 0.25434782608696, 0
19329, 1.4608695652174, 0.2804347826087, 0
19330, 1.4391304347826, 0.25434782608696, 0
19331, 1.504347826087, 0.2804347826087, 0
19332, 1.4826086956522, 0.25434782608696, 0
19333, 1.5478260869565, 0.2804347826087, 0
19334, 1.5260869565217, 0.25434782608696, 0
19335, 1.5913043478261, 0.2804347826087, 0
19336, 1.5695652173913, 0.25434782608696, 0
19337, 1.6347826086957, 0.2804347826087, 0
19338, 1.6130434782609, 0.25434782608696, 0
19339, 1.6782608695652, 0.2804347826087, 0
19340, 1.6565217391304, 0.25434782608696, 0
19341, 1.7217391304348, 0.2804347826087, 0
19342, 1.7, 0.25434782608696, 0
19343, 1.7652173913043, 0.2804347826087, 0
19344, 1.7434782608696, 0.25434782608696, 0
19345, 1.8086956521739, 0.2804347826087, 0
19346, 1.7869565217391, 0.25434782608696, 0
19347, 1.8521739130435, 0.2804347826087, 0
19348, 1.8304347826087, 0.25434782608696, 0
19349, 1.895652173913, 0.2804347826087, 0
19350, 1.8739130434783, 0.25434782608696, 0
19351, 1.9391304347826, 0.2804347826087, 0
19352, 1.9173913043478, 0.25434782608696, 0
19353, 1.9826086956522, 0.2804347826087, 0
19354, 1.9608695652174, 0.25434782608696, 0
19355, 2.0260869565217, 0.2804347826087, 0
19356, 2.004347826087, 0.25434782608696, 0
19357, 2.0695652173913, 0.2804347826087, 0
19358, 2.0478260869565, 0.25434782608696, 0
19359, 2.1130434782609, 0.2804347826087, 0
19360, 2.0913043478261, 0.25434782608696, 0
19361, 2.1565217391304, 0.2804347826087, 0
19362, 2.1347826086957, 0.25434782608696, 0
19363, 2.1782608695652, 0.25434782608696, 0
19364, 1.2434782608696, 0.22826086956522, 0
19365, 1.2217391304348, 0.20217391304348, 0
19366, 1.2869565217391, 0.22826086956522, 0
19367, 1.2652173913043, 0.20217391304348, 0
19368, 1.3304347826087, 0.22826086956522, 0
19369, 1.3086956521739, 0.20217391304348, 0
19370, 1.3739130434783, 0.22826086956522, 0
19371, 1.3521739130435, 0.20217391304348, 0
19372, 1.4173913043478, 0.22826086956522, 0
19373, 1.395652173913, 0.20217391304348, 0
19374, 1.4608695652174, 0.22826086956522, 0
19375, 1.4391304347826, 0.20217391304348, 0
19376, 1.504347826087, 0.22826086956522, 0
19377, 1.4826086956522, 0.20217391304348, 0
19378, 1.5478260869565, 0.22826086956522, 0
19379, 1.5260869565217, 0.20217391304348, 0
19380, 1.5913043478261, 0.22826086956522, 0
19381, 1.5695652173913, 0.20217391304348, 0
19382, 1.6347826086957, 0.22826086956522, 0
19383, 1.6130434782609, 0.20217391304348, 0
19384, 1.6782608695652, 0.22826086956522, 0
19385, 1.6565217391304, 0.20217391304348, 0
19386, 1.7217391304348, 0.22826086956522, 0
19387, 1.7, 0.20217391304348, 0
19388, 1.7652173913043, 0.22826086956522, 0
19389, 1.7434782608696, 0.20217391304348, 0
19390, 1.8086956521739, 0.22826086956522, 0
19391, 1.7869565217391, 0.20217391304348, 0
19392, 1.8521739130435, 0.22826086956522, 0
19393, 1.8304347826087, 0.20217391304348, 0
19394, 1.895652173913, 0.22826086956522, 0
19395, 1.8739130434783, 0.20217391304348, 0
19396, 1.9391304347826, 0.22826086956522, 0
19397, 1.9173913043478, 0.20217391304348, 0
19398, 1.9826086956522, 0.22826086956522, 0
19399, 1.9608695652174, 0.20217391304348, 0
19400, 2.0260869565217, 0.22826086956522, 0
19401, 2.004347826087, 0.20217391304348, 0
19402, 2.0695652173913, 0.22826086956522, 0
19403, 2.0478260869565, 0.20217391304348, 0
19404, 2.1130434782609, 0.22826086956522, 0
19405, 2.0913043478261, 0.20217391304348, 0
19406, 2.1565217391304, 0.22826086956522, 0
19407, 2.1347826086957, 0.20217391304348, 0
19408, 2.1782608695652, 0.20217391304348, 0
19409, 1.2434782608696, 0.17608695652174, 0
19410, 1.2869565217391, 0.17608695652174, 0
19411, 1.3304347826087, 0.17608695652174, 0
19412, 1.3739130434783, 0.17608695652174, 0
19413, 1.4173913043478, 0.17608695652174, 0
19414, 1.4608695652174, 0.17608695652174, 0
19415, 1.504347826087, 0.17608695652174, 0
19416, 1.5478260869565, 0.17608695652174, 0
19417, 1.5913043478261, 0.17608695652174, 0
19418, 1.6347826086957, 0.17608695652174, 0
19419, 1.6782608695652, 0.17608695652174, 0
19420, 1.7217391304348, 0.17608695652174, 0
19421, 1.7652173913043, 0.17608695652174, 0
19422, 1.8086956521739, 0.17608695652174, 0
19423, 1.8521739130435, 0.17608695652174, 0
19424, 1.895652173913, 0.17608695652174, 0
19425, 1.9391304347826, 0.17608695652174, 0
19426, 1.9826086956522, 0.17608695652174, 0
19427, 2.0260869565217, 0.17608695652174, 0
19428, 2.0695652173913, 0.17608695652174, 0
19429, 2.1130434782609, 0.17608695652174, 0
19430, 2.1565217391304, 0.17608695652174, 0
19431, 1.2, 1.2978260869565, 0.45454545454545
19432, 1.2, 1.2978260869565, 0.40909090909091
19433, 1.2, 1.2978260869565, 0.36363636363636
19434, 1.2, 1.2978260869565, 0.31818181818182
19435, 1.2, 1.2978260869565, 0.27272727272727
19436, 1.2, 1.2978260869565, 0.22727272727273
19437, 1.2, 1.2978260869565, 0.18181818181818
19438, 1.2, 1.2978260869565, 0.13636363636364
19439, 1.2, 1.2978260869565, 0.090909090909091
19440, 1.2, 1.2978260869565, 0.045454545454545
19441, 1.2, 1.245652173913, 0.45454545454545
19442, 1.2, 1.245652173913, 0.40909090909091
19443, 1.2, 1.245652173913, 0.36363636363636
19444, 1.2, 1.245652173913, 0.31818181818182
19445, 1.2, 1.245652173913, 0.27272727272727
19446, 1.2, 1.245652173913, 0.22727272727273
19447, 1.2, 1.245652173913, 0.18181818181818
19448, 1.2, 1.245652173913, 0.13636363636364
19449, 1.2, 1.245652173913, 0.090909090909091
19450, 1.2, 1.245652173913, 0.045454545454545
19451, 1.2, 1.1934782608696, 0.45454545454545
19452, 1.2, 1.1934782608696, 0.40909090909091
19453, 1.2, 1.1934782608696, 0.36363636363636
19454, 1.2, 1.1934782608696, 0.31818181818182
19455, 1.2, 1.1934782608696, 0.27272727272727
19456, 1.2, 1.1934782608696, 0.22727272727273
19457, 1.2, 1.1934782608696, 0.18181818181818
19458, 1.2, 1.1934782608696, 0.13636363636364
19459, 1.2, 1.1934782608696, 0.090909090909091
19460, 1.2, 1.1934782608696, 0.045454545454545
19461, 1.2, 1.1413043478261, 0.45454545454545
19462, 1.2, 1.1413043478261, 0.40909090909091
19463, 1.2, 1.1413043478261, 0.36363636363636
19464, 1.2, 1.1413043478261, 0.31818181818182
19465, 1.2, 1.1413043478261, 0.27272727272727
19466, 1.2, 1.1413043478261, 0.22727272727273
19467, 1.2, 1.1413043478261, 0.18181818181818
19468, 1.2, 1.1413043478261, 0.13636363636364
19469, 1.2, 1.1413043478261, 0.090909090909091
19470, 1.2, 1.1413043478261, 0.045454545454545
19471, 1.2, 1.0891304347826, 0.45454545454545
19472, 1.2, 1.0891304347826, 0.40909090909091
19473, 1.2, 1.0891304347826, 0.36363636363636
19474, 1.2, 1.0891304347826, 0.31818181818182
19475, 1.2, 1.0891304347826, 0.27272727272727
19476, 1.2, 1.0891304347826, 0.22727272727273
19477, 1.2, 1.0891304347826, 0.18181818181818
19478, 1.2, 1.0891304347826, 0.13636363636364
19479, 1.2, 1.0891304347826, 0.090909090909091
19480, 1.2, 1.0891304347826, 0.045454545454545
19481, 1.2, 1.0369565217391, 0.45454545454545
19482, 1.2, 1.0369565217391, 0.40909090909091
19483, 1.2, 1.0369565217391, 0.36363636363636
19484, 1.2, 1.0369565217391, 0.31818181818182
19485, 1.2, 1.0369565217391, 0.27272727272727
19486, 1.2, 1.0369565217391, 0.22727272727273
19487, 1.2, 1.0369565217391, 0.18181818181818
19488, 1.2, 1.0369565217391, 0.13636363636364
19489, 1.2, 1.0369565217391, 0.090909090909091
19490, 1.2, 1.0369565217391, 0.045454545454545
19491, 1.2, 0.98478260869565, 0.45454545454545
19492, 1.2, 0.98478260869565, 0.40909090909091
19493, 1.2, 0.98478260869565, 0.36363636363636
19494, 1.2, 0.98478260869565, 0.31818181818182
19495, 1.2, 0.98478260869565, 0.27272727272727
19496, 1.2, 0.98478260869565, 0.22727272727273
19497, 1.2, 0.98478260869565, 0.18181818181818
19498, 1.2, 0.98478260869565, 0.13636363636364
19499, 1.2, 0.98478260869565, 0.090909090909091
19500, 1.2, 0.98478260869565, 0.045454545454545
19501, 1.2, 0.93260869565217, 0.45454545454545
19502, 1.2, 0.93260869565217, 0.40909090909091
19503, 1.2, 0.93260869565217, 0.36363636363636
19504, 1.2, 0.93260869565217, 0.31818181818182
19505, 1.2, 0.93260869565217, 0.27272727272727
19506, 1.2, 0.93260869565217, 0.22727272727273
19507, 1.2, 0.93260869565217, 0.18181818181818
19508, 1.2, 0.93260869565217, 0.13636363636364
19509, 1.2, 0.93260869565217, 0.090909090909091
19510, 1.2, 0.93260869565217, 0.045454545454545
19511, 1.2, 0.8804347826087, 0.45454545454545
19512, 1.2, 0.8804347826087, 0.40909090909091
19513, 1.2, 0.8804347826087, 0.36363636363636
19514, 1.2, 0.8804347826087, 0.31818181818182
19515, 1.2, 0.8804347826087, 0.27272727272727
19516, 1.2, 0.8804347826087, 0.22727272727273
19517, 1.2, 0.8804347826087, 0.18181818181818
19518, 1.2, 0.8804347826087, 0.13636363636364
19519, 1.2, 0.8804347826087, 0.090909090909091
19520, 1.2, 0.8804347826087, 0.045454545454545
19521, 1.2, 0.82826086956522, 0.45454545454545
19522, 1.2, 0.82826086956522, 0.40909090909091
19523, 1.2, 0.82826086956522, 0.36363636363636
19524, 1.2, 0.82826086956522, 0.31818181818182
19525, 1.2, 0.82826086956522, 0.27272727272727
19526, 1.2, 0.82826086956522, 0.22727272727273
19527, 1.2, 0.82826086956522, 0.18181818181818
19528, 1.2, 0.82826086956522, 0.13636363636364
19529, 1.2, 0.82826086956522, 0.090909090909091
19530, 1.2, 0.82826086956522, 0.045454545454545
19531, 1.2, 0.77608695652174, 0.45454545454545
19532, 1.2, 0.77608695652174, 0.40909090909091
19533, 1.2, 0.77608695652174, 0.36363636363636
19534, 1.2, 0.77608695652174, 0.31818181818182
19535, 1.2, 0.77608695652174, 0.27272727272727
19536, 1.2, 0.77608695652174, 0.22727272727273
19537, 1.2, 0.77608695652174, 0.18181818181818
19538, 1.2, 0.77608695652174, 0.13636363636364
19539, 1.2, 0.77608695652174, 0.090909090909091
19540, 1.2, 0.77608695652174, 0.045454545454545
19541, 1.2, 0.72391304347826, 0.45454545454545
19542, 1.2, 0.72391304347826, 0.40909090909091
19543, 1.2, 0.72391304347826, 0.36363636363636
19544, 1.2, 0.72391304347826, 0.31818181818182
19545, 1.2, 0.72391304347826, 0.27272727272727
19546, 1.2, 0.72391304347826, 0.22727272727273
19547, 1.2, 0.72391304347826, 0.18181818181818
19548, 1.2, 0.72391304347826, 0.13636363636364
19549, 1.2, 0.72391304347826, 0.090909090909091
19550, 1.2, 0.72391304347826, 0.045454545454545
19551, 1.2, 0.67173913043478, 0.45454545454545
19552, 1.2, 0.67173913043478, 0.40909090909091
19553, 1.2, 0.67173913043478, 0.36363636363636
19554, 1.2, 0.67173913043478, 0.31818181818182
19555, 1.2, 0.67173913043478, 0.27272727272727
19556, 1.2, 0.67173913043478, 0.22727272727273
19557, 1.2, 0.67173913043478, 0.18181818181818
19558, 1.2, 0.67173913043478, 0.13636363636364
19559, 1.2, 0.67173913043478, 0.090909090909091
19560, 1.2, 0.67173913043478, 0.045454545454545
19561, 1.2, 0.6195652173913, 0.45454545454545
19562, 1.2, 0.6195652173913, 0.40909090909091
19563, 1.2, 0.61956521739131, 0.36363636363636
19564, 1.2, 0.61956521739131, 0.31818181818182
19565, 1.2, 0.61956521739131, 0.27272727272727
19566, 1.2, 0.61956521739131, 0.22727272727273
19567, 1.2, 0.61956521739131, 0.18181818181818
19568, 1.2, 0.61956521739131, 0.13636363636364
19569, 1.2, 0.61956521739131, 0.090909090909091
19570, 1.2, 0.61956521739131, 0.045454545454545
19571, 1.2, 0.56739130434783, 0.45454545454545
19572, 1.2, 0.56739130434783, 0.40909090909091
19573, 1.2, 0.56739130434783, 0.36363636363636
19574, 1.2, 0.56739130434783, 0.31818181818182
19575, 1.2, 0.56739130434783, 0.27272727272727
19576, 1.2, 0.56739130434783, 0.22727272727273
19577, 1.2, 0.56739130434783, 0.18181818181818
19578, 1.2, 0.56739130434783, 0.13636363636364
19579, 1.2, 0.56739130434783, 0.090909090909091
19580, 1.2, 0.56739130434783, 0.045454545454545
19581, 1.2, 0.51521739130435, 0.45454545454545
19582, 1.2, 0.51521739130435, 0.40909090909091
19583, 1.2, 0.51521739130435, 0.36363636363636
19584, 1.2, 0.51521739130435, 0.31818181818182
19585, 1.2, 0.51521739130435, 0.27272727272727
19586, 1.2, 0.51521739130435, 0.22727272727273
19587, 1.2, 0.51521739130435, 0.18181818181818
19588, 1.2, 0.51521739130435, 0.13636363636364
19589, 1.2, 0.51521739130435, 0.090909090909091
19590, 1.2, 0.51521739130435, 0.045454545454545
19591, 1.2, 0.46304347826087, 0.45454545454545
19592, 1.2, 0.46304347826087, 0.40909090909091
19593, 1.2, 0.46304347826087, 0.36363636363636
19594, 1.2, 0.46304347826087, 0.31818181818182
19595, 1.2, 0.46304347826087, 0.27272727272727
19596, 1.2, 0.46304347826087, 0.22727272727273
19597, 1.2, 0.46304347826087, 0.18181818181818
19598, 1.2, 0.46304347826087, 0.13636363636364
19599, 1.2, 0.46304347826087, 0.090909090909091
19600, 1.2, 0.46304347826087, 0.045454545454545
19601, 1.2, 0.41086956521739, 0.45454545454545
19602, 1.2, 0.41086956521739, 0.40909090909091
19603, 1.2, 0.41086956521739, 0.36363636363636
19604, 1.2, 0.41086956521739, 0.31818181818182
19605, 1.2, 0.41086956521739, 0.27272727272727
19606, 1.2, 0.41086956521739, 0.22727272727273
19607, 1.2, 0.41086956521739, 0.18181818181818
19608, 1.2, 0.41086956521739, 0.13636363636364
19609, 1.2, 0.41086956521739, 0.090909090909091
19610, 1.2, 0.41086956521739, 0.045454545454545
19611, 1.2, 0.35869565217391, 0.45454545454545
19612, 1.2, 0.35869565217391, 0.40909090909091
19613, 1.2, 0.35869565217391, 0.36363636363636
19614, 1.2, 0.35869565217391, 0.31818181818182
19615, 1.2, 0.35869565217391, 0.27272727272727
19616, 1.2, 0.35869565217391, 0.22727272727273
19617, 1.2, 0.35869565217391, 0.18181818181818
19618, 1.2, 0.35869565217391, 0.13636363636364
19619, 1.2, 0.35869565217391, 0.090909090909091
19620, 1.2, 0.35869565217391, 0.045454545454545
19621, 1.2, 0.30652173913043, 0.45454545454545
19622, 1.2, 0.30652173913043, 0.40909090909091
19623, 1.2, 0.30652173913043, 0.36363636363636
19624, 1.2, 0.30652173913043, 0.31818181818182
19625, 1.2, 0.30652173913043, 0.27272727272727
19626, 1.2, 0.30652173913043, 0.22727272727273
19627, 1.2, 0.30652173913043, 0.18181818181818
19628, 1.2, 0.30652173913043, 0.13636363636364
19629, 1.2, 0.30652173913043, 0.090909090909091
19630, 1.2, 0.30652173913043, 0.045454545454545
19631, 1.2, 0.25434782608696, 0.45454545454545
19632, 1.2, 0.25434782608696, 0.40909090909091
19633, 1.2, 0.25434782608696, 0.36363636363636
19634, 1.2, 0.25434782608696, 0.31818181818182
19635, 1.2, 0.25434782608696, 0.27272727272727
19636, 1.2, 0.25434782608696, 0.22727272727273
19637, 1.2, 0.25434782608696, 0.18181818181818
19638, 1.2, 0.25434782608696, 0.13636363636364
19639, 1.2, 0.25434782608696, 0.090909090909091
19640, 1.2, 0.25434782608696, 0.045454545454545
19641, 1.2, 0.20217391304348, 0.45454545454545
19642, 1.2, 0.20217391304348, 0.40909090909091
19643, 1.2, 0.20217391304348, 0.36363636363636
19644, 1.2, 0.20217391304348, 0.31818181818182
19645, 1.2, 0.20217391304348, 0.27272727272727
19646, 1.2, 0.20217391304348, 0.22727272727273
19647, 1.2, 0.20217391304348, 0.18181818181818
19648, 1.2, 0.20217391304348, 0.13636363636364
19649, 1.2, 0.20217391304348, 0.090909090909091
19650, 1.2, 0.20217391304348, 0.045454545454545
19651, 1.2, 1.3239130434783, 0.45454545454545
19652, 1.2, 1.2978260869565, 0.47727272727273
19653, 1.2, 1.3239130434783, 0.40909090909091
19654, 1.2, 1.2978260869565, 0.43181818181818
19655, 1.2, 1.3239130434783, 0.36363636363636
19656, 1.2, 1.2978260869565, 0.38636363636364
19657, 1.2, 1.3239130434783, 0.31818181818182
19658, 1.2, 1.2978260869565, 0.34090909090909
19659, 1.2, 1.3239130434783, 0.27272727272727
19660, 1.2, 1.2978260869565, 0.29545454545455
19661, 1.2, 1.3239130434783, 0.22727272727273
19662, 1.2, 1.2978260869565, 0.25
19663, 1.2, 1.3239130434783, 0.18181818181818
19664, 1.2, 1.2978260869565, 0.20454545454545
19665, 1.2, 1.3239130434783, 0.13636363636364
19666, 1.2, 1.2978260869565, 0.15909090909091
19667, 1.2, 1.3239130434783, 0.090909090909091
19668, 1.2, 1.2978260869565, 0.11363636363636
19669, 1.2, 1.3239130434783, 0.045454545454545
19670, 1.2, 1.2978260869565, 0.068181818181818
19671, 1.2, 1.2978260869565, 0.022727272727273
19672, 1.2, 1.2717391304348, 0.45454545454545
19673, 1.2, 1.245652173913, 0.47727272727273
19674, 1.2, 1.2717391304348, 0.40909090909091
19675, 1.2, 1.245652173913, 0.43181818181818
19676, 1.2, 1.2717391304348, 0.36363636363636
19677, 1.2, 1.245652173913, 0.38636363636364
19678, 1.2, 1.2717391304348, 0.31818181818182
19679, 1.2, 1.245652173913, 0.34090909090909
19680, 1.2, 1.2717391304348, 0.27272727272727
19681, 1.2, 1.245652173913, 0.29545454545455
19682, 1.2, 1.2717391304348, 0.22727272727273
19683, 1.2, 1.245652173913, 0.25
19684, 1.2, 1.2717391304348, 0.18181818181818
19685, 1.2, 1.245652173913, 0.20454545454545
19686, 1.2, 1.2717391304348, 0.13636363636364
19687, 1.2, 1.245652173913, 0.15909090909091
19688, 1.2, 1.2717391304348, 0.090909090909091
19689, 1.2, 1.245652173913, 0.11363636363636
19690, 1.2, 1.2717391304348, 0.045454545454545
19691, 1.2, 1.245652173913, 0.068181818181818
19692, 1.2, 1.245652173913, 0.022727272727273
19693, 1.2, 1.2195652173913, 0.45454545454545
19694, 1.2, 1.1934782608696, 0.47727272727273
19695, 1.2, 1.2195652173913, 0.40909090909091
19696, 1.2, 1.1934782608696, 0.43181818181818
19697, 1.2, 1.2195652173913, 0.36363636363636
19698, 1.2, 1.1934782608696, 0.38636363636364
19699, 1.2, 1.2195652173913, 0.31818181818182
19700, 1.2, 1.1934782608696, 0.34090909090909
19701, 1.2, 1.2195652173913, 0.27272727272727
19702, 1.2, 1.1934782608696, 0.29545454545455
19703, 1.2, 1.2195652173913, 0.22727272727273
19704, 1.2, 1.1934782608696, 0.25
19705, 1.2, 1.2195652173913, 0.18181818181818
19706, 1.2, 1.1934782608696, 0.20454545454545
19707, 1.2, 1.2195652173913, 0.13636363636364
19708, 1.2, 1.1934782608696, 0.15909090909091
19709, 1.2, 1.2195652173913, 0.090909090909091
19710, 1.2, 1.1934782608696, 0.11363636363636
19711, 1.2, 1.2195652173913, 0.045454545454545
19712, 1.2, 1.1934782608696, 0.068181818181818
19713, 1.2, 1.1934782608696, 0.022727272727273
19714, 1.2, 1.1673913043478, 0.45454545454545
19715, 1.2, 1.1413043478261, 0.47727272727273
19716, 1.2, 1.1673913043478, 0.40909090909091
19717, 1.2, 1.1413043478261, 0.43181818181818
19718, 1.2, 1.1673913043478, 0.36363636363636
19719, 1.2, 1.1413043478261, 0.38636363636364
19720, 1.2, 1.1673913043478, 0.31818181818182
19721, 1.2, 1.1413043478261, 0.34090909090909
19722, 1.2, 1.1673913043478, 0.27272727272727
19723, 1.2, 1.1413043478261, 0.29545454545455
19724, 1.2, 1.1673913043478, 0.22727272727273
19725, 1.2, 1.1413043478261, 0.25
19726, 1.2, 1.1673913043478, 0.18181818181818
19727, 1.2, 1.1413043478261, 0.20454545454545
19728, 1.2, 1.1673913043478, 0.13636363636364
19729, 1.2, 1.1413043478261, 0.15909090909091
19730, 1.2, 1.1673913043478, 0.090909090909091
19731, 1.2, 1.1413043478261, 0.11363636363636
19732, 1.2, 1.1673913043478, 0.045454545454545
19733, 1.2, 1.1413043478261, 0.068181818181818
19734, 1.2, 1.1413043478261, 0.022727272727273
19735, 1.2, 1.1152173913043, 0.45454545454545
19736, 1.2, 1.0891304347826, 0.47727272727273
19737, 1.2, 1.1152173913043, 0.40909090909091
19738, 1.2, 1.0891304347826, 0.43181818181818
19739, 1.2, 1.1152173913043, 0.36363636363636
19740, 1.2, 1.0891304347826, 0.38636363636364
19741, 1.2, 1.1152173913043, 0.31818181818182
19742, 1.2, 1.0891304347826, 0.34090909090909
19743, 1.2, 1.1152173913043, 0.27272727272727
19744, 1.2, 1.0891304347826, 0.29545454545455
19745, 1.2, 1.1152173913043, 0.22727272727273
19746, 1.2, 1.0891304347826, 0.25
19747, 1.2, 1.1152173913043, 0.18181818181818
19748, 1.2, 1.0891304347826, 0.20454545454545
19749, 1.2, 1.1152173913043, 0.13636363636364
19750, 1.2, 1.0891304347826, 0.15909090909091
19751, 1.2, 1.1152173913043, 0.090909090909091
19752, 1.2, 1.0891304347826, 0.11363636363636
19753, 1.2, 1.1152173913043, 0.045454545454545
19754, 1.2, 1.0891304347826, 0.068181818181818
19755, 1.2, 1.0891304347826, 0.022727272727273
19756, 1.2, 1.0630434782609, 0.45454545454545
19757, 1.2, 1.0369565217391, 0.47727272727273
19758, 1.2, 1.0630434782609, 0.40909090909091
19759, 1.2, 1.0369565217391, 0.43181818181818
19760, 1.2, 1.0630434782609, 0.36363636363636
19761, 1.2, 1.0369565217391, 0.38636363636364
19762, 1.2, 1.0630434782609, 0.31818181818182
19763, 1.2, 1.0369565217391, 0.34090909090909
19764, 1.2, 1.0630434782609, 0.27272727272727
19765, 1.2, 1.0369565217391, 0.29545454545455
19766, 1.2, 1.0630434782609, 0.22727272727273
19767, 1.2, 1.0369565217391, 0.25
19768, 1.2, 1.0630434782609, 0.18181818181818
19769, 1.2, 1.0369565217391, 0.20454545454545
19770, 1.2, 1.0630434782609, 0.13636363636364
19771, 1.2, 1.0369565217391, 0.15909090909091
19772, 1.2, 1.0630434782609, 0.090909090909091
19773, 1.2, 1.0369565217391, 0.11363636363636
19774, 1.2, 1.0630434782609, 0.045454545454545
19775, 1.2, 1.0369565217391, 0.068181818181818
19776, 1.2, 1.0369565217391, 0.022727272727273
19777, 1.2, 1.0108695652174, 0.45454545454545
19778, 1.2, 0.98478260869565, 0.47727272727273
19779, 1.2, 1.0108695652174, 0.40909090909091
19780, 1.2, 0.98478260869565, 0.43181818181818
19781, 1.2, 1.0108695652174, 0.36363636363636
19782, 1.2, 0.98478260869565, 0.38636363636364
19783, 1.2, 1.0108695652174, 0.31818181818182
19784, 1.2, 0.98478260869565, 0.34090909090909
19785, 1.2, 1.0108695652174, 0.27272727272727
19786, 1.2, 0.98478260869565, 0.29545454545455
19787, 1.2, 1.0108695652174, 0.22727272727273
19788, 1.2, 0.98478260869565, 0.25
19789, 1.2, 1.0108695652174, 0.18181818181818
19790, 1.2, 0.98478260869565, 0.20454545454545
19791, 1.2, 1.0108695652174, 0.13636363636364
19792, 1.2, 0.98478260869565, 0.15909090909091
19793, 1.2, 1.0108695652174, 0.090909090909091
19794, 1.2, 0.98478260869565, 0.11363636363636
19795, 1.2, 1.0108695652174, 0.045454545454545
19796, 1.2, 0.98478260869565, 0.068181818181818
19797, 1.2, 0.98478260869565, 0.022727272727273
19798, 1.2, 0.95869565217391, 0.45454545454545
19799, 1.2, 0.93260869565217, 0.47727272727273
19800, 1.2, 0.95869565217391, 0.40909090909091
19801, 1.2, 0.93260869565217, 0.43181818181818
19802, 1.2, 0.95869565217391, 0.36363636363636
19803, 1.2, 0.93260869565217, 0.38636363636364
19804, 1.2, 0.95869565217391, 0.31818181818182
19805, 1.2, 0.93260869565217, 0.34090909090909
19806, 1.2, 0.95869565217391, 0.27272727272727
19807, 1.2, 0.93260869565217, 0.29545454545455
19808, 1.2, 0.95869565217391, 0.22727272727273
19809, 1.2, 0.93260869565217, 0.25
19810, 1.2, 0.95869565217391, 0.18181818181818
19811, 1.2, 0.93260869565217, 0.20454545454545
19812, 1.2, 0.95869565217391, 0.13636363636364
19813, 1.2, 0.93260869565217, 0.15909090909091
19814, 1.2, 0.95869565217391, 0.090909090909091
19815, 1.2, 0.93260869565217, 0.11363636363636
19816, 1.2, 0.95869565217391, 0.045454545454545
19817, 1.2, 0.93260869565217, 0.068181818181818
19818, 1.2, 0.93260869565217, 0.022727272727273
19819, 1.2, 0.90652173913044, 0.45454545454545
19820, 1.2, 0.8804347826087, 0.47727272727273
19821, 1.2, 0.90652173913044, 0.40909090909091
19822, 1.2, 0.8804347826087, 0.43181818181818
19823, 1.2, 0.90652173913044, 0.36363636363636
19824, 1.2, 0.8804347826087, 0.38636363636364
19825, 1.2, 0.90652173913044, 0.31818181818182
19826, 1.2, 0.8804347826087, 0.34090909090909
19827, 1.2, 0.90652173913044, 0.27272727272727
19828, 1.2, 0.8804347826087, 0.29545454545455
19829, 1.2, 0.90652173913044, 0.22727272727273
19830, 1.2, 0.8804347826087, 0.25
19831, 1.2, 0.90652173913044, 0.18181818181818
19832, 1.2, 0.8804347826087, 0.20454545454545
19833, 1.2, 0.90652173913044, 0.13636363636364
19834, 1.2, 0.8804347826087, 0.15909090909091
19835, 1.2, 0.90652173913044, 0.090909090909091
19836, 1.2, 0.8804347826087, 0.11363636363636
19837, 1.2, 0.90652173913044, 0.045454545454545
19838, 1.2, 0.8804347826087, 0.068181818181818
19839, 1.2, 0.8804347826087, 0.022727272727273
19840, 1.2, 0.85434782608696, 0.45454545454545
19841, 1.2, 0.82826086956522, 0.47727272727273
19842, 1.2, 0.85434782608696, 0.40909090909091
19843, 1.2, 0.82826086956522, 0.43181818181818
19844, 1.2, 0.85434782608696, 0.36363636363636
19845, 1.2, 0.82826086956522, 0.38636363636364
19846, 1.2, 0.85434782608696, 0.31818181818182
19847, 1.2, 0.82826086956522, 0.34090909090909
19848, 1.2, 0.85434782608696, 0.27272727272727
19849, 1.2, 0.82826086956522, 0.29545454545455
19850, 1.2, 0.85434782608696, 0.22727272727273
19851, 1.2, 0.82826086956522, 0.25
19852, 1.2, 0.85434782608696, 0.18181818181818
19853, 1.2, 0.82826086956522, 0.20454545454545
19854, 1.2, 0.85434782608696, 0.13636363636364
19855, 1.2, 0.82826086956522, 0.15909090909091
19856, 1.2, 0.85434782608696, 0.090909090909091
19857, 1.2, 0.82826086956522, 0.11363636363636
19858, 1.2, 0.85434782608696, 0.045454545454545
19859, 1.2, 0.82826086956522, 0.068181818181818
19860, 1.2, 0.82826086956522, 0.022727272727273
19861, 1.2, 0.80217391304348, 0.45454545454545
19862, 1.2, 0.77608695652174, 0.47727272727273
19863, 1.2, 0.80217391304348, 0.40909090909091
19864, 1.2, 0.77608695652174, 0.43181818181818
19865, 1.2, 0.80217391304348, 0.36363636363636
19866, 1.2, 0.77608695652174, 0.38636363636364
19867, 1.2, 0.80217391304348, 0.31818181818182
19868, 1.2, 0.77608695652174, 0.34090909090909
19869, 1.2, 0.80217391304348, 0.27272727272727
19870, 1.2, 0.77608695652174, 0.29545454545455
19871, 1.2, 0.80217391304348, 0.22727272727273
19872, 1.2, 0.77608695652174, 0.25
19873, 1.2, 0.80217391304348, 0.18181818181818
19874, 1.2, 0.77608695652174, 0.20454545454545
19875, 1.2, 0.80217391304348, 0.13636363636364
19876, 1.2, 0.77608695652174, 0.15909090909091
19877, 1.2, 0.80217391304348, 0.090909090909091
19878, 1.2, 0.77608695652174, 0.11363636363636
19879, 1.2, 0.80217391304348, 0.045454545454545
19880, 1.2, 0.77608695652174, 0.068181818181818
19881, 1.2, 0.77608695652174, 0.022727272727273
19882, 1.2, 0.75, 0.45454545454545
19883, 1.2, 0.72391304347826, 0.47727272727273
19884, 1.2, 0.75, 0.40909090909091
19885, 1.2, 0.72391304347826, 0.43181818181818
19886, 1.2, 0.75, 0.36363636363636
19887, 1.2, 0.72391304347826, 0.38636363636364
19888, 1.2, 0.75, 0.31818181818182
19889, 1.2, 0.72391304347826, 0.34090909090909
19890, 1.2, 0.75, 0.27272727272727
19891, 1.2, 0.72391304347826, 0.29545454545455
19892, 1.2, 0.75, 0.22727272727273
19893, 1.2, 0.72391304347826, 0.25
19894, 1.2, 0.75, 0.18181818181818
19895, 1.2, 0.72391304347826, 0.20454545454545
19896, 1.2, 0.75, 0.13636363636364
19897, 1.2, 0.72391304347826, 0.15909090909091
19898, 1.2, 0.75, 0.090909090909091
19899, 1.2, 0.72391304347826, 0.11363636363636
19900, 1.2, 0.75, 0.045454545454545
19901, 1.2, 0.72391304347826, 0.068181818181818
19902, 1.2, 0.72391304347826, 0.022727272727273
19903, 1.2, 0.69782608695652, 0.45454545454545
19904, 1.2, 0.67173913043478, 0.47727272727273
19905, 1.2, 0.69782608695652, 0.40909090909091
19906, 1.2, 0.67173913043478, 0.43181818181818
19907, 1.2, 0.69782608695652, 0.36363636363636
19908, 1.2, 0.67173913043478, 0.38636363636364
19909, 1.2, 0.69782608695652, 0.31818181818182
19910, 1.2, 0.67173913043478, 0.34090909090909
19911, 1.2, 0.69782608695652, 0.27272727272727
19912, 1.2, 0.67173913043478, 0.29545454545455
19913, 1.2, 0.69782608695652, 0.22727272727273
19914, 1.2, 0.67173913043478, 0.25
19915, 1.2, 0.69782608695652, 0.18181818181818
19916, 1.2, 0.67173913043478, 0.20454545454545
19917, 1.2, 0.69782608695652, 0.13636363636364
19918, 1.2, 0.67173913043478, 0.15909090909091
19919, 1.2, 0.69782608695652, 0.090909090909091
19920, 1.2, 0.67173913043478, 0.11363636363636
19921, 1.2, 0.69782608695652, 0.045454545454545
19922, 1.2, 0.67173913043478, 0.068181818181818
19923, 1.2, 0.67173913043478, 0.022727272727273
19924, 1.2, 0.64565217391304, 0.45454545454545
19925, 1.2, 0.61956521739131, 0.47727272727273
19926, 1.2, 0.64565217391304, 0.40909090909091
19927, 1.2, 0.6195652173913, 0.43181818181818
19928, 1.2, 0.64565217391304, 0.36363636363636
19929, 1.2, 0.61956521739131, 0.38636363636364
19930, 1.2, 0.64565217391304, 0.31818181818182
19931, 1.2, 0.61956521739131, 0.34090909090909
19932, 1.2, 0.64565217391304, 0.27272727272727
19933, 1.2, 0.61956521739131, 0.29545454545455
19934, 1.2, 0.64565217391304, 0.22727272727273
19935, 1.2, 0.61956521739131, 0.25
19936, 1.2, 0.64565217391304, 0.18181818181818
19937, 1.2, 0.61956521739131, 0.20454545454545
19938, 1.2, 0.64565217391304, 0.13636363636364
19939, 1.2, 0.61956521739131, 0.15909090909091
19940, 1.2, 0.64565217391304, 0.090909090909091
19941, 1.2, 0.61956521739131, 0.11363636363636
19942, 1.2, 0.64565217391304, 0.045454545454545
19943, 1.2, 0.61956521739131, 0.068181818181818
19944, 1.2, 0.61956521739131, 0.022727272727273
19945, 1.2, 0.59347826086957, 0.45454545454545
19946, 1.2, 0.56739130434783, 0.47727272727273
19947, 1.2, 0.59347826086957, 0.40909090909091
19948, 1.2, 0.56739130434783, 0.43181818181818
19949, 1.2, 0.59347826086957, 0.36363636363636
19950, 1.2, 0.56739130434783, 0.38636363636364
19951, 1.2, 0.59347826086957, 0.31818181818182
19952, 1.2, 0.56739130434783, 0.34090909090909
19953, 1.2, 0.59347826086957, 0.27272727272727
19954, 1.2, 0.56739130434783, 0.29545454545455
19955, 1.2, 0.59347826086957, 0.22727272727273
19956, 1.2, 0.56739130434783, 0.25
19957, 1.2, 0.59347826086957, 0.18181818181818
19958, 1.2, 0.56739130434783, 0.20454545454545
19959, 1.2, 0.59347826086957, 0.13636363636364
19960, 1.2, 0.56739130434783, 0.15909090909091
19961, 1.2, 0.59347826086957, 0.090909090909091
19962, 1.2, 0.56739130434783, 0.11363636363636
19963, 1.2, 0.59347826086957, 0.045454545454545
19964, 1.2, 0.56739130434783, 0.068181818181818
19965, 1.2, 0.56739130434783, 0.022727272727273
19966, 1.2, 0.54130434782609, 0.45454545454545
19967, 1.2, 0.51521739130435, 0.47727272727273
19968, 1.2, 0.54130434782609, 0.40909090909091
19969, 1.2, 0.51521739130435, 0.43181818181818
19970, 1.2, 0.54130434782609, 0.36363636363636
19971, 1.2, 0.51521739130435, 0.38636363636364
19972, 1.2, 0.54130434782609, 0.31818181818182
19973, 1.2, 0.51521739130435, 0.34090909090909
19974, 1.2, 0.54130434782609, 0.27272727272727
19975, 1.2, 0.51521739130435, 0.29545454545455
19976, 1.2, 0.54130434782609, 0.22727272727273
19977, 1.2, 0.51521739130435, 0.25
19978, 1.2, 0.54130434782609, 0.18181818181818
19979, 1.2, 0.51521739130435, 0.20454545454545
19980, 1.2, 0.54130434782609, 0.13636363636364
19981, 1.2, 0.51521739130435, 0.15909090909091
19982, 1.2, 0.54130434782609, 0.090909090909091
19983, 1.2, 0.51521739130435, 0.11363636363636
19984, 1.2, 0.54130434782609, 0.045454545454545
19985, 1.2, 0.51521739130435, 0.068181818181818
19986, 1.2, 0.51521739130435, 0.022727272727273
19987, 1.2, 0.48913043478261, 0.45454545454545
19988, 1.2, 0.46304347826087, 0.47727272727273
19989, 1.2, 0.48913043478261, 0.40909090909091
19990, 1.2, 0.46304347826087, 0.43181818181818
19991, 1.2, 0.48913043478261, 0.36363636363636
19992, 1.2, 0.46304347826087, 0.38636363636364
19993, 1.2, 0.48913043478261, 0.31818181818182
19994, 1.2, 0.46304347826087, 0.34090909090909
19995, 1.2, 0.48913043478261, 0.27272727272727
19996, 1.2, 0.46304347826087, 0.29545454545455
19997, 1.2, 0.48913043478261, 0.22727272727273
19998, 1.2, 0.46304347826087, 0.25
19999, 1.2, 0.48913043478261, 0.18181818181818
20000, 1.2, 0.46304347826087, 0.20454545454545
20001, 1.2, 0.48913043478261, 0.13636363636364
20002, 1.2, 0.46304347826087, 0.15909090909091
20003, 1.2, 0.48913043478261, 0.090909090909091
20004, 1.2, 0.46304347826087, 0.11363636363636
20005, 1.2, 0.48913043478261, 0.045454545454545
20006, 1.2, 0.46304347826087, 0.068181818181818
20007, 1.2, 0.46304347826087, 0.022727272727273
20008, 1.2, 0.43695652173913, 0.45454545454545
20009, 1.2, 0.41086956521739, 0.47727272727273
20010, 1.2, 0.43695652173913, 0.40909090909091
20011, 1.2, 0.41086956521739, 0.43181818181818
20012, 1.2, 0.43695652173913, 0.36363636363636
20013, 1.2, 0.41086956521739, 0.38636363636364
20014, 1.2, 0.43695652173913, 0.31818181818182
20015, 1.2, 0.41086956521739, 0.34090909090909
20016, 1.2, 0.43695652173913, 0.27272727272727
20017, 1.2, 0.41086956521739, 0.29545454545455
20018, 1.2, 0.43695652173913, 0.22727272727273
20019, 1.2, 0.41086956521739, 0.25
20020, 1.2, 0.43695652173913, 0.18181818181818
20021, 1.2, 0.41086956521739, 0.20454545454545
20022, 1.2, 0.43695652173913, 0.13636363636364
20023, 1.2, 0.41086956521739, 0.15909090909091
20024, 1.2, 0.43695652173913, 0.090909090909091
20025, 1.2, 0.41086956521739, 0.11363636363636
20026, 1.2, 0.43695652173913, 0.045454545454545
20027, 1.2, 0.41086956521739, 0.068181818181818
20028, 1.2, 0.41086956521739, 0.022727272727273
20029, 1.2, 0.38478260869565, 0.45454545454545
20030, 1.2, 0.35869565217391, 0.47727272727273
20031, 1.2, 0.38478260869565, 0.40909090909091
20032, 1.2, 0.35869565217391, 0.43181818181818
20033, 1.2, 0.38478260869565, 0.36363636363636
20034, 1.2, 0.35869565217391, 0.38636363636364
20035, 1.2, 0.38478260869565, 0.31818181818182
20036, 1.2, 0.35869565217391, 0.34090909090909
20037, 1.2, 0.38478260869565, 0.27272727272727
20038, 1.2, 0.35869565217391, 0.29545454545455
20039, 1.2, 0.38478260869565, 0.22727272727273
20040, 1.2, 0.35869565217391, 0.25
20041, 1.2, 0.38478260869565, 0.18181818181818
20042, 1.2, 0.35869565217391, 0.20454545454545
20043, 1.2, 0.38478260869565, 0.13636363636364
20044, 1.2, 0.35869565217391, 0.15909090909091
20045, 1.2, 0.38478260869565, 0.090909090909091
20046, 1.2, 0.35869565217391, 0.11363636363636
20047, 1.2, 0.38478260869565, 0.045454545454545
20048, 1.2, 0.35869565217391, 0.068181818181818
20049, 1.2, 0.35869565217391, 0.022727272727273
20050, 1.2, 0.33260869565217, 0.45454545454545
20051, 1.2, 0.30652173913044, 0.47727272727273
20052, 1.2, 0.33260869565217, 0.40909090909091
20053, 1.2, 0.30652173913043, 0.43181818181818
20054, 1.2, 0.33260869565217, 0.36363636363636
20055, 1.2, 0.30652173913043, 0.38636363636364
20056, 1.2, 0.33260869565217, 0.31818181818182
20057, 1.2, 0.30652173913043, 0.34090909090909
20058, 1.2, 0.33260869565217, 0.27272727272727
20059, 1.2, 0.30652173913043, 0.29545454545455
20060, 1.2, 0.33260869565217, 0.22727272727273
20061, 1.2, 0.30652173913043, 0.25
20062, 1.2, 0.33260869565217, 0.18181818181818
20063, 1.2, 0.30652173913043, 0.20454545454545
20064, 1.2, 0.33260869565217, 0.13636363636364
20065, 1.2, 0.30652173913043, 0.15909090909091
20066, 1.2, 0.33260869565217, 0.090909090909091
20067, 1.2, 0.30652173913043, 0.11363636363636
20068, 1.2, 0.33260869565217, 0.045454545454545
20069, 1.2, 0.30652173913043, 0.068181818181818
20070, 1.2, 0.30652173913044, 0.022727272727273
20071, 1.2, 0.2804347826087, 0.45454545454545
20072, 1.2, 0.25434782608696, 0.47727272727273
20073, 1.2, 0.2804347826087, 0.40909090909091
20074, 1.2, 0.25434782608696, 0.43181818181818
20075, 1.2, 0.2804347826087, 0.36363636363636
20076, 1.2, 0.25434782608696, 0.38636363636364
20077, 1.2, 0.2804347826087, 0.31818181818182
20078, 1.2, 0.25434782608696, 0.34090909090909
20079, 1.2, 0.2804347826087, 0.27272727272727
20080, 1.2, 0.25434782608696, 0.29545454545455
20081, 1.2, 0.2804347826087, 0.22727272727273
20082, 1.2, 0.25434782608696, 0.25
20083, 1.2, 0.2804347826087, 0.18181818181818
20084, 1.2, 0.25434782608696, 0.20454545454545
20085, 1.2, 0.2804347826087, 0.13636363636364
20086, 1.2, 0.25434782608696, 0.15909090909091
20087, 1.2, 0.2804347826087, 0.090909090909091
20088, 1.2, 0.25434782608696, 0.11363636363636
20089, 1.2, 0.2804347826087, 0.045454545454545
20090, 1.2, 0.25434782608696, 0.068181818181818
20091, 1.2, 0.25434782608696, 0.022727272727273
20092, 1.2, 0.22826086956522, 0.45454545454545
20093, 1.2, 0.20217391304348, 0.47727272727273
20094, 1.2, 0.22826086956522, 0.40909090909091
20095, 1.2, 0.20217391304348, 0.43181818181818
20096, 1.2, 0.22826086956522, 0.36363636363636
20097, 1.2, 0.20217391304348, 0.38636363636364
20098, 1.2, 0.22826086956522, 0.31818181818182
20099, 1.2, 0.20217391304348, 0.34090909090909
20100, 1.2, 0.22826086956522, 0.27272727272727
20101, 1.2, 0.20217391304348, 0.29545454545455
20102, 1.2, 0.22826086956522, 0.22727272727273
20103, 1.2, 0.20217391304348, 0.25
20104, 1.2, 0.22826086956522, 0.18181818181818
20105, 1.2, 0.20217391304348, 0.20454545454545
20106, 1.2, 0.22826086956522, 0.13636363636364
20107, 1.2, 0.20217391304348, 0.15909090909091
20108, 1.2, 0.22826086956522, 0.090909090909091
20109, 1.2, 0.20217391304348, 0.11363636363636
20110, 1.2, 0.22826086956522, 0.045454545454545
20111, 1.2, 0.20217391304348, 0.068181818181818
20112, 1.2, 0.20217391304348, 0.022727272727273
20113, 1.2, 0.17608695652174, 0.45454545454545
20114, 1.2, 0.17608695652174, 0.40909090909091
20115, 1.2, 0.17608695652174, 0.36363636363636
20116, 1.2, 0.17608695652174, 0.31818181818182
20117, 1.2, 0.17608695652174, 0.27272727272727
20118, 1.2, 0.17608695652174, 0.22727272727273
20119, 1.2, 0.17608695652174, 0.18181818181818
20120, 1.2, 0.17608695652174, 0.13636363636364
20121, 1.2, 0.17608695652174, 0.090909090909091
20122, 1.2, 0.17608695652174, 0.045454545454545
20123, 2.2, 1.2978260869565, 0.45454545454545
20124, 2.2, 1.2978260869565, 0.40909090909091
20125, 2.2, 1.2978260869565, 0.36363636363636
20126, 2.2, 1.2978260869565, 0.31818181818182
20127, 2.2, 1.2978260869565, 0.27272727272727
20128, 2.2, 1.2978260869565, 0.22727272727273
20129, 2.2, 1.2978260869565, 0.18181818181818
20130, 2.2, 1.2978260869565, 0.13636363636364
20131, 2.2, 1.2978260869565, 0.090909090909091
20132, 2.2, 1.2978260869565, 0.045454545454545
20133, 2.2, 1.245652173913, 0.45454545454545
20134, 2.2, 1.245652173913, 0.40909090909091
20135, 2.2, 1.245652173913, 0.36363636363636
20136, 2.2, 1.245652173913, 0.31818181818182
20137, 2.2, 1.245652173913, 0.27272727272727
20138, 2.2, 1.245652173913, 0.22727272727273
20139, 2.2, 1.245652173913, 0.18181818181818
20140, 2.2, 1.245652173913, 0.13636363636364
20141, 2.2, 1.245652173913, 0.090909090909091
20142, 2.2, 1.245652173913, 0.045454545454545
20143, 2.2, 1.1934782608696, 0.45454545454545
20144, 2.2, 1.1934782608696, 0.40909090909091
20145, 2.2, 1.1934782608696, 0.36363636363636
20146, 2.2, 1.1934782608696, 0.31818181818182
20147, 2.2, 1.1934782608696, 0.27272727272727
20148, 2.2, 1.1934782608696, 0.22727272727273
20149, 2.2, 1.1934782608696, 0.18181818181818
20150, 2.2, 1.1934782608696, 0.13636363636364
20151, 2.2, 1.1934782608696, 0.090909090909091
20152, 2.2, 1.1934782608696, 0.045454545454545
20153, 2.2, 1.1413043478261, 0.45454545454545
20154, 2.2, 1.1413043478261, 0.40909090909091
20155, 2.2, 1.1413043478261, 0.36363636363636
20156, 2.2, 1.1413043478261, 0.31818181818182
20157, 2.2, 1.1413043478261, 0.27272727272727
20158, 2.2, 1.1413043478261, 0.22727272727273
20159, 2.2, 1.1413043478261, 0.18181818181818
20160, 2.2, 1.1413043478261, 0.13636363636364
20161, 2.2, 1.1413043478261, 0.090909090909091
20162, 2.2, 1.1413043478261, 0.045454545454545
20163, 2.2, 1.0891304347826, 0.45454545454545
20164, 2.2, 1.0891304347826, 0.40909090909091
20165, 2.2, 1.0891304347826, 0.36363636363636
20166, 2.2, 1.0891304347826, 0.31818181818182
20167, 2.2, 1.0891304347826, 0.27272727272727
20168, 2.2, 1.0891304347826, 0.22727272727273
20169, 2.2, 1.0891304347826, 0.18181818181818
20170, 2.2, 1.0891304347826, 0.13636363636364
20171, 2.2, 1.0891304347826, 0.090909090909091
20172, 2.2, 1.0891304347826, 0.045454545454545
20173, 2.2, 1.0369565217391, 0.45454545454545
20174, 2.2, 1.0369565217391, 0.40909090909091
20175, 2.2, 1.0369565217391, 0.36363636363636
20176, 2.2, 1.0369565217391, 0.31818181818182
20177, 2.2, 1.0369565217391, 0.27272727272727
20178, 2.2, 1.0369565217391, 0.22727272727273
20179, 2.2, 1.0369565217391, 0.18181818181818
20180, 2.2, 1.0369565217391, 0.13636363636364
20181, 2.2, 1.0369565217391, 0.090909090909091
20182, 2.2, 1.0369565217391, 0.045454545454545
20183, 2.2, 0.98478260869565, 0.45454545454545
20184, 2.2, 0.98478260869565, 0.40909090909091
20185, 2.2, 0.98478260869565, 0.36363636363636
20186, 2.2, 0.98478260869565, 0.31818181818182
20187, 2.2, 0.98478260869565, 0.27272727272727
20188, 2.2, 0.98478260869565, 0.22727272727273
20189, 2.2, 0.98478260869565, 0.18181818181818
20190, 2.2, 0.98478260869565, 0.13636363636364
20191, 2.2, 0.98478260869565, 0.090909090909091
20192, 2.2, 0.98478260869565, 0.045454545454545
20193, 2.2, 0.93260869565217, 0.45454545454545
20194, 2.2, 0.93260869565217, 0.40909090909091
20195, 2.2, 0.93260869565217, 0.36363636363636
20196, 2.2, 0.93260869565217, 0.31818181818182
20197, 2.2, 0.93260869565217, 0.27272727272727
20198, 2.2, 0.93260869565217, 0.22727272727273
20199, 2.2, 0.93260869565217, 0.18181818181818
20200, 2.2, 0.93260869565217, 0.13636363636364
20201, 2.2, 0.93260869565217, 0.090909090909091
20202, 2.2, 0.93260869565217, 0.045454545454545
20203, 2.2, 0.8804347826087, 0.45454545454545
20204, 2.2, 0.8804347826087, 0.40909090909091
20205, 2.2, 0.8804347826087, 0.36363636363636
20206, 2.2, 0.8804347826087, 0.31818181818182
20207, 2.2, 0.8804347826087, 0.27272727272727
20208, 2.2, 0.8804347826087, 0.22727272727273
20209, 2.2, 0.8804347826087, 0.18181818181818
20210, 2.2, 0.8804347826087, 0.13636363636364
20211, 2.2, 0.8804347826087, 0.090909090909091
20212, 2.2, 0.8804347826087, 0.045454545454545
20213, 2.2, 0.82826086956522, 0.45454545454545
20214, 2.2, 0.82826086956522, 0.40909090909091
20215, 2.2, 0.82826086956522, 0.36363636363636
20216, 2.2, 0.82826086956522, 0.31818181818182
20217, 2.2, 0.82826086956522, 0.27272727272727
20218, 2.2, 0.82826086956522, 0.22727272727273
20219, 2.2, 0.82826086956522, 0.18181818181818
20220, 2.2, 0.82826086956522, 0.13636363636364
20221, 2.2, 0.82826086956522, 0.090909090909091
20222, 2.2, 0.82826086956522, 0.045454545454545
20223, 2.2, 0.77608695652174, 0.45454545454545
20224, 2.2, 0.77608695652174, 0.40909090909091
20225, 2.2, 0.77608695652174, 0.36363636363636
20226, 2.2, 0.77608695652174, 0.31818181818182
20227, 2.2, 0.77608695652174, 0.27272727272727
20228, 2.2, 0.77608695652174, 0.22727272727273
20229, 2.2, 0.77608695652174, 0.18181818181818
20230, 2.2, 0.77608695652174, 0.13636363636364
20231, 2.2, 0.77608695652174, 0.090909090909091
20232, 2.2, 0.77608695652174, 0.045454545454545
20233, 2.2, 0.72391304347826, 0.45454545454545
20234, 2.2, 0.72391304347826, 0.40909090909091
20235, 2.2, 0.72391304347826, 0.36363636363636
20236, 2.2, 0.72391304347826, 0.31818181818182
20237, 2.2, 0.72391304347826, 0.27272727272727
20238, 2.2, 0.72391304347826, 0.22727272727273
20239, 2.2, 0.72391304347826, 0.18181818181818
20240, 2.2, 0.72391304347826, 0.13636363636364
20241, 2.2, 0.72391304347826, 0.090909090909091
20242, 2.2, 0.72391304347826, 0.045454545454545
20243, 2.2, 0.67173913043478, 0.45454545454545
20244, 2.2, 0.67173913043478, 0.40909090909091
20245, 2.2, 0.67173913043478, 0.36363636363636
20246, 2.2, 0.67173913043478, 0.31818181818182
20247, 2.2, 0.67173913043478, 0.27272727272727
20248, 2.2, 0.67173913043478, 0.22727272727273
20249, 2.2, 0.67173913043478, 0.18181818181818
20250, 2.2, 0.67173913043478, 0.13636363636364
20251, 2.2, 0.67173913043478, 0.090909090909091
20252, 2.2, 0.67173913043478, 0.045454545454545
20253, 2.2, 0.6195652173913, 0.45454545454545
20254, 2.2, 0.6195652173913, 0.40909090909091
20255, 2.2, 0.61956521739131, 0.36363636363636
20256, 2.2, 0.61956521739131, 0.31818181818182
20257, 2.2, 0.61956521739131, 0.27272727272727
20258, 2.2, 0.61956521739131, 0.22727272727273
20259, 2.2, 0.61956521739131, 0.18181818181818
20260, 2.2, 0.61956521739131, 0.13636363636364
20261, 2.2, 0.61956521739131, 0.090909090909091
20262, 2.2, 0.61956521739131, 0.045454545454545
20263, 2.2, 0.56739130434783, 0.45454545454545
20264, 2.2, 0.56739130434783, 0.40909090909091
20265, 2.2, 0.56739130434783, 0.36363636363636
20266, 2.2, 0.56739130434783, 0.31818181818182
20267, 2.2, 0.56739130434783, 0.27272727272727
20268, 2.2, 0.56739130434783, 0.22727272727273
20269, 2.2, 0.56739130434783, 0.18181818181818
20270, 2.2, 0.56739130434783, 0.13636363636364
20271, 2.2, 0.56739130434783, 0.090909090909091
20272, 2.2, 0.56739130434783, 0.045454545454545
20273, 2.2, 0.51521739130435, 0.45454545454545
20274, 2.2, 0.51521739130435, 0.40909090909091
20275, 2.2, 0.51521739130435, 0.36363636363636
20276, 2.2, 0.51521739130435, 0.31818181818182
20277, 2.2, 0.51521739130435, 0.27272727272727
20278, 2.2, 0.51521739130435, 0.22727272727273
20279, 2.2, 0.51521739130435, 0.18181818181818
20280, 2.2, 0.51521739130435, 0.13636363636364
20281, 2.2, 0.51521739130435, 0.090909090909091
20282, 2.2, 0.51521739130435, 0.045454545454545
20283, 2.2, 0.46304347826087, 0.45454545454545
20284, 2.2, 0.46304347826087, 0.40909090909091
20285, 2.2, 0.46304347826087, 0.36363636363636
20286, 2.2, 0.46304347826087, 0.31818181818182
20287, 2.2, 0.46304347826087, 0.27272727272727
20288, 2.2, 0.46304347826087, 0.22727272727273
20289, 2.2, 0.46304347826087, 0.18181818181818
20290, 2.2, 0.46304347826087, 0.13636363636364
20291, 2.2, 0.46304347826087, 0.090909090909091
20292, 2.2, 0.46304347826087, 0.045454545454545
20293, 2.2, 0.41086956521739, 0.45454545454545
20294, 2.2, 0.41086956521739, 0.40909090909091
20295, 2.2, 0.41086956521739, 0.36363636363636
20296, 2.2, 0.41086956521739, 0.31818181818182
20297, 2.2, 0.41086956521739, 0.27272727272727
20298, 2.2, 0.41086956521739, 0.22727272727273
20299, 2.2, 0.41086956521739, 0.18181818181818
20300, 2.2, 0.41086956521739, 0.13636363636364
20301, 2.2, 0.41086956521739, 0.090909090909091
20302, 2.2, 0.41086956521739, 0.045454545454545
20303, 2.2, 0.35869565217391, 0.45454545454545
20304, 2.2, 0.35869565217391, 0.40909090909091
20305, 2.2, 0.35869565217391, 0.36363636363636
20306, 2.2, 0.35869565217391, 0.31818181818182
20307, 2.2, 0.35869565217391, 0.27272727272727
20308, 2.2, 0.35869565217391, 0.22727272727273
20309, 2.2, 0.35869565217391, 0.18181818181818
20310, 2.2, 0.35869565217391, 0.13636363636364
20311, 2.2, 0.35869565217391, 0.090909090909091
20312, 2.2, 0.35869565217391, 0.045454545454545
20313, 2.2, 0.30652173913043, 0.45454545454545
20314, 2.2, 0.30652173913043, 0.40909090909091
20315, 2.2, 0.30652173913043, 0.36363636363636
20316, 2.2, 0.30652173913043, 0.31818181818182
20317, 2.2, 0.30652173913043, 0.27272727272727
20318, 2.2, 0.30652173913043, 0.22727272727273
20319, 2.2, 0.30652173913043, 0.18181818181818
20320, 2.2, 0.30652173913043, 0.13636363636364
20321, 2.2, 0.30652173913043, 0.090909090909091
20322, 2.2, 0.30652173913043, 0.045454545454545
20323, 2.2, 0.25434782608696, 0.45454545454545
20324, 2.2, 0.25434782608696, 0.40909090909091
20325, 2.2, 0.25434782608696, 0.36363636363636
20326, 2.2, 0.25434782608696, 0.31818181818182
20327, 2.2, 0.25434782608696, 0.27272727272727
20328, 2.2, 0.25434782608696, 0.22727272727273
20329, 2.2, 0.25434782608696, 0.18181818181818
20330, 2.2, 0.25434782608696, 0.13636363636364
20331, 2.2, 0.25434782608696, 0.090909090909091
20332, 2.2, 0.25434782608696, 0.045454545454545
20333, 2.2, 0.20217391304348, 0.45454545454545
20334, 2.2, 0.20217391304348, 0.40909090909091
20335, 2.2, 0.20217391304348, 0.36363636363636
20336, 2.2, 0.20217391304348, 0.31818181818182
20337, 2.2, 0.20217391304348, 0.27272727272727
20338, 2.2, 0.20217391304348, 0.22727272727273
20339, 2.2, 0.20217391304348, 0.18181818181818
20340, 2.2, 0.20217391304348, 0.13636363636364
20341, 2.2, 0.20217391304348, 0.090909090909091
20342, 2.2, 0.20217391304348, 0.045454545454545
20343, 2.2, 1.2978260869565, 0.47727272727273
20344, 2.2, 1.3239130434783, 0.45454545454545
20345, 2.2, 1.2978260869565, 0.43181818181818
20346, 2.2, 1.3239130434783, 0.40909090909091
20347, 2.2, 1.2978260869565, 0.38636363636364
20348, 2.2, 1.3239130434783, 0.36363636363636
20349, 2.2, 1.2978260869565, 0.34090909090909
20350, 2.2, 1.3239130434783, 0.31818181818182
20351, 2.2, 1.2978260869565, 0.29545454545455
20352, 2.2, 1.3239130434783, 0.27272727272727
20353, 2.2, 1.2978260869565, 0.25
20354, 2.2, 1.3239130434783, 0.22727272727273
20355, 2.2, 1.2978260869565, 0.20454545454545
20356, 2.2, 1.3239130434783, 0.18181818181818
20357, 2.2, 1.2978260869565, 0.15909090909091
20358, 2.2, 1.3239130434783, 0.13636363636364
20359, 2.2, 1.2978260869565, 0.11363636363636
20360, 2.2, 1.3239130434783, 0.090909090909091
20361, 2.2, 1.2978260869565, 0.068181818181818
20362, 2.2, 1.3239130434783, 0.045454545454545
20363, 2.2, 1.2978260869565, 0.022727272727273
20364, 2.2, 1.245652173913, 0.47727272727273
20365, 2.2, 1.2717391304348, 0.45454545454545
20366, 2.2, 1.245652173913, 0.43181818181818
20367, 2.2, 1.2717391304348, 0.40909090909091
20368, 2.2, 1.245652173913, 0.38636363636364
20369, 2.2, 1.2717391304348, 0.36363636363636
20370, 2.2, 1.245652173913, 0.34090909090909
20371, 2.2, 1.2717391304348, 0.31818181818182
20372, 2.2, 1.245652173913, 0.29545454545455
20373, 2.2, 1.2717391304348, 0.27272727272727
20374, 2.2, 1.245652173913, 0.25
20375, 2.2, 1.2717391304348, 0.22727272727273
20376, 2.2, 1.245652173913, 0.20454545454545
20377, 2.2, 1.2717391304348, 0.18181818181818
20378, 2.2, 1.245652173913, 0.15909090909091
20379, 2.2, 1.2717391304348, 0.13636363636364
20380, 2.2, 1.245652173913, 0.11363636363636
20381, 2.2, 1.2717391304348, 0.090909090909091
20382, 2.2, 1.245652173913, 0.068181818181818
20383, 2.2, 1.2717391304348, 0.045454545454545
20384, 2.2, 1.245652173913, 0.022727272727273
20385, 2.2, 1.1934782608696, 0.47727272727273
20386, 2.2, 1.2195652173913, 0.45454545454545
20387, 2.2, 1.1934782608696, 0.43181818181818
20388, 2.2, 1.2195652173913, 0.40909090909091
20389, 2.2, 1.1934782608696, 0.38636363636364
20390, 2.2, 1.2195652173913, 0.36363636363636
20391, 2.2, 1.1934782608696, 0.34090909090909
20392, 2.2, 1.2195652173913, 0.31818181818182
20393, 2.2, 1.1934782608696, 0.29545454545455
20394, 2.2, 1.2195652173913, 0.27272727272727
20395, 2.2, 1.1934782608696, 0.25
20396, 2.2, 1.2195652173913, 0.22727272727273
20397, 2.2, 1.1934782608696, 0.20454545454545
20398, 2.2, 1.2195652173913, 0.18181818181818
20399, 2.2, 1.1934782608696, 0.15909090909091
20400, 2.2, 1.2195652173913, 0.13636363636364
20401, 2.2, 1.1934782608696, 0.11363636363636
20402, 2.2, 1.2195652173913, 0.090909090909091
20403, 2.2, 1.1934782608696, 0.068181818181818
20404, 2.2, 1.2195652173913, 0.045454545454545
20405, 2.2, 1.1934782608696, 0.022727272727273
20406, 2.2, 1.1413043478261, 0.47727272727273
20407, 2.2, 1.1673913043478, 0.45454545454545
20408, 2.2, 1.1413043478261, 0.43181818181818
20409, 2.2, 1.1673913043478, 0.40909090909091
20410, 2.2, 1.1413043478261, 0.38636363636364
20411, 2.2, 1.1673913043478, 0.36363636363636
20412, 2.2, 1.1413043478261, 0.34090909090909
20413, 2.2, 1.1673913043478, 0.31818181818182
20414, 2.2, 1.1413043478261, 0.29545454545455
20415, 2.2, 1.1673913043478, 0.27272727272727
20416, 2.2, 1.1413043478261, 0.25
20417, 2.2, 1.1673913043478, 0.22727272727273
20418, 2.2, 1.1413043478261, 0.20454545454545
20419, 2.2, 1.1673913043478, 0.18181818181818
20420, 2.2, 1.1413043478261, 0.15909090909091
20421, 2.2, 1.1673913043478, 0.13636363636364
20422, 2.2, 1.1413043478261, 0.11363636363636
20423, 2.2, 1.1673913043478, 0.090909090909091
20424, 2.2, 1.1413043478261, 0.068181818181818
20425, 2.2, 1.1673913043478, 0.045454545454545
20426, 2.2, 1.1413043478261, 0.022727272727273
20427, 2.2, 1.0891304347826, 0.47727272727273
20428, 2.2, 1.1152173913043, 0.45454545454545
20429, 2.2, 1.0891304347826, 0.43181818181818
20430, 2.2, 1.1152173913043, 0.40909090909091
20431, 2.2, 1.0891304347826, 0.38636363636364
20432, 2.2, 1.1152173913043, 0.36363636363636
20433, 2.2, 1.0891304347826, 0.34090909090909
20434, 2.2, 1.1152173913043, 0.31818181818182
20435, 2.2, 1.0891304347826, 0.29545454545455
20436, 2.2, 1.1152173913043, 0.27272727272727
20437, 2.2, 1.0891304347826, 0.25
20438, 2.2, 1.1152173913043, 0.22727272727273
20439, 2.2, 1.0891304347826, 0.20454545454545
20440, 2.2, 1.1152173913043, 0.18181818181818
20441, 2.2, 1.0891304347826, 0.15909090909091
20442, 2.2, 1.1152173913043, 0.13636363636364
20443, 2.2, 1.0891304347826, 0.11363636363636
20444, 2.2, 1.1152173913043, 0.090909090909091
20445, 2.2, 1.0891304347826, 0.068181818181818
20446, 2.2, 1.1152173913043, 0.045454545454545
20447, 2.2, 1.0891304347826, 0.022727272727273
20448, 2.2, 1.0369565217391, 0.47727272727273
20449, 2.2, 1.0630434782609, 0.45454545454545
20450, 2.2, 1.0369565217391, 0.43181818181818
20451, 2.2, 1.0630434782609, 0.40909090909091
20452, 2.2, 1.0369565217391, 0.38636363636364
20453, 2.2, 1.0630434782609, 0.36363636363636
20454, 2.2, 1.0369565217391, 0.34090909090909
20455, 2.2, 1.0630434782609, 0.31818181818182
20456, 2.2, 1.0369565217391, 0.29545454545455
20457, 2.2, 1.0630434782609, 0.27272727272727
20458, 2.2, 1.0369565217391, 0.25
20459, 2.2, 1.0630434782609, 0.22727272727273
20460, 2.2, 1.0369565217391, 0.20454545454545
20461, 2.2, 1.0630434782609, 0.18181818181818
20462, 2.2, 1.0369565217391, 0.15909090909091
20463, 2.2, 1.0630434782609, 0.13636363636364
20464, 2.2, 1.0369565217391, 0.11363636363636
20465, 2.2, 1.0630434782609, 0.090909090909091
20466, 2.2, 1.0369565217391, 0.068181818181818
20467, 2.2, 1.0630434782609, 0.045454545454545
20468, 2.2, 1.0369565217391, 0.022727272727273
20469, 2.2, 0.98478260869565, 0.47727272727273
20470, 2.2, 1.0108695652174, 0.45454545454545
20471, 2.2, 0.98478260869565, 0.43181818181818
20472, 2.2, 1.0108695652174, 0.40909090909091
20473, 2.2, 0.98478260869565, 0.38636363636364
20474, 2.2, 1.0108695652174, 0.36363636363636
20475, 2.2, 0.98478260869565, 0.34090909090909
20476, 2.2, 1.0108695652174, 0.31818181818182
20477, 2.2, 0.98478260869565, 0.29545454545455
20478, 2.2, 1.0108695652174, 0.27272727272727
20479, 2.2, 0.98478260869565, 0.25
20480, 2.2, 1.0108695652174, 0.22727272727273
20481, 2.2, 0.98478260869565, 0.20454545454545
20482, 2.2, 1.0108695652174, 0.18181818181818
20483, 2.2, 0.98478260869565, 0.15909090909091
20484, 2.2, 1.0108695652174, 0.13636363636364
20485, 2.2, 0.98478260869565, 0.11363636363636
20486, 2.2, 1.0108695652174, 0.090909090909091
20487, 2.2, 0.98478260869565, 0.068181818181818
20488, 2.2, 1.0108695652174, 0.045454545454545
20489, 2.2, 0.98478260869565, 0.022727272727273
20490, 2.2, 0.93260869565217, 0.47727272727273
20491, 2.2, 0.95869565217391, 0.45454545454545
20492, 2.2, 0.93260869565217, 0.43181818181818
20493, 2.2, 0.95869565217391, 0.40909090909091
20494, 2.2, 0.93260869565217, 0.38636363636364
20495, 2.2, 0.95869565217391, 0.36363636363636
20496, 2.2, 0.93260869565217, 0.34090909090909
20497, 2.2, 0.95869565217391, 0.31818181818182
20498, 2.2, 0.93260869565217, 0.29545454545455
20499, 2.2, 0.95869565217391, 0.27272727272727
20500, 2.2, 0.93260869565217, 0.25
20501, 2.2, 0.95869565217391, 0.22727272727273
20502, 2.2, 0.93260869565217, 0.20454545454545
20503, 2.2, 0.95869565217391, 0.18181818181818
20504, 2.2, 0.93260869565217, 0.15909090909091
20505, 2.2, 0.95869565217391, 0.13636363636364
20506, 2.2, 0.93260869565217, 0.11363636363636
20507, 2.2, 0.95869565217391, 0.090909090909091
20508, 2.2, 0.93260869565217, 0.068181818181818
20509, 2.2, 0.95869565217391, 0.045454545454545
20510, 2.2, 0.93260869565217, 0.022727272727273
20511, 2.2, 0.8804347826087, 0.47727272727273
20512, 2.2, 0.90652173913044, 0.45454545454545
20513, 2.2, 0.8804347826087, 0.43181818181818
20514, 2.2, 0.90652173913044, 0.40909090909091
20515, 2.2, 0.8804347826087, 0.38636363636364
20516, 2.2, 0.90652173913044, 0.36363636363636
20517, 2.2, 0.8804347826087, 0.34090909090909
20518, 2.2, 0.90652173913044, 0.31818181818182
20519, 2.2, 0.8804347826087, 0.29545454545455
20520, 2.2, 0.90652173913044, 0.27272727272727
20521, 2.2, 0.8804347826087, 0.25
20522, 2.2, 0.90652173913044, 0.22727272727273
20523, 2.2, 0.8804347826087, 0.20454545454545
20524, 2.2, 0.90652173913044, 0.18181818181818
20525, 2.2, 0.8804347826087, 0.15909090909091
20526, 2.2, 0.90652173913044, 0.13636363636364
20527, 2.2, 0.8804347826087, 0.11363636363636
20528, 2.2, 0.90652173913044, 0.090909090909091
20529, 2.2, 0.8804347826087, 0.068181818181818
20530, 2.2, 0.90652173913044, 0.045454545454545
20531, 2.2, 0.8804347826087, 0.022727272727273
20532, 2.2, 0.82826086956522, 0.47727272727273
20533, 2.2, 0.85434782608696, 0.45454545454545
20534, 2.2, 0.82826086956522, 0.43181818181818
20535, 2.2, 0.85434782608696, 0.40909090909091
20536, 2.2, 0.82826086956522, 0.38636363636364
20537, 2.2, 0.85434782608696, 0.36363636363636
20538, 2.2, 0.82826086956522, 0.34090909090909
20539, 2.2, 0.85434782608696, 0.31818181818182
20540, 2.2, 0.82826086956522, 0.29545454545455
20541, 2.2, 0.85434782608696, 0.27272727272727
20542, 2.2, 0.82826086956522, 0.25
20543, 2.2, 0.85434782608696, 0.22727272727273
20544, 2.2, 0.82826086956522, 0.20454545454545
20545, 2.2, 0.85434782608696, 0.18181818181818
20546, 2.2, 0.82826086956522, 0.15909090909091
20547, 2.2, 0.85434782608696, 0.13636363636364
20548, 2.2, 0.82826086956522, 0.11363636363636
20549, 2.2, 0.85434782608696, 0.090909090909091
20550, 2.2, 0.82826086956522, 0.068181818181818
20551, 2.2, 0.85434782608696, 0.045454545454545
20552, 2.2, 0.82826086956522, 0.022727272727273
20553, 2.2, 0.77608695652174, 0.47727272727273
20554, 2.2, 0.80217391304348, 0.45454545454545
20555, 2.2, 0.77608695652174, 0.43181818181818
20556, 2.2, 0.80217391304348, 0.40909090909091
20557, 2.2, 0.77608695652174, 0.38636363636364
20558, 2.2, 0.80217391304348, 0.36363636363636
20559, 2.2, 0.77608695652174, 0.34090909090909
20560, 2.2, 0.80217391304348, 0.31818181818182
20561, 2.2, 0.77608695652174, 0.29545454545455
20562, 2.2, 0.80217391304348, 0.27272727272727
20563, 2.2, 0.77608695652174, 0.25
20564, 2.2, 0.80217391304348, 0.22727272727273
20565, 2.2, 0.77608695652174, 0.20454545454545
20566, 2.2, 0.80217391304348, 0.18181818181818
20567, 2.2, 0.77608695652174, 0.15909090909091
20568, 2.2, 0.80217391304348, 0.13636363636364
20569, 2.2, 0.77608695652174, 0.11363636363636
20570, 2.2, 0.80217391304348, 0.090909090909091
20571, 2.2, 0.77608695652174, 0.068181818181818
20572, 2.2, 0.80217391304348, 0.045454545454545
20573, 2.2, 0.77608695652174, 0.022727272727273
20574, 2.2, 0.72391304347826, 0.47727272727273
20575, 2.2, 0.75, 0.45454545454545
20576, 2.2, 0.72391304347826, 0.43181818181818
20577, 2.2, 0.75, 0.40909090909091
20578, 2.2, 0.72391304347826, 0.38636363636364
20579, 2.2, 0.75, 0.36363636363636
20580, 2.2, 0.72391304347826, 0.34090909090909
20581, 2.2, 0.75, 0.31818181818182
20582, 2.2, 0.72391304347826, 0.29545454545455
20583, 2.2, 0.75, 0.27272727272727
20584, 2.2, 0.72391304347826, 0.25
20585, 2.2, 0.75, 0.22727272727273
20586, 2.2, 0.72391304347826, 0.20454545454545
20587, 2.2, 0.75, 0.18181818181818
20588, 2.2, 0.72391304347826, 0.15909090909091
20589, 2.2, 0.75, 0.13636363636364
20590, 2.2, 0.72391304347826, 0.11363636363636
20591, 2.2, 0.75, 0.090909090909091
20592, 2.2, 0.72391304347826, 0.068181818181818
20593, 2.2, 0.75, 0.045454545454545
20594, 2.2, 0.72391304347826, 0.022727272727273
20595, 2.2, 0.67173913043478, 0.47727272727273
20596, 2.2, 0.69782608695652, 0.45454545454545
20597, 2.2, 0.67173913043478, 0.43181818181818
20598, 2.2, 0.69782608695652, 0.40909090909091
20599, 2.2, 0.67173913043478, 0.38636363636364
20600, 2.2, 0.69782608695652, 0.36363636363636
20601, 2.2, 0.67173913043478, 0.34090909090909
20602, 2.2, 0.69782608695652, 0.31818181818182
20603, 2.2, 0.67173913043478, 0.29545454545455
20604, 2.2, 0.69782608695652, 0.27272727272727
20605, 2.2, 0.67173913043478, 0.25
20606, 2.2, 0.69782608695652, 0.22727272727273
20607, 2.2, 0.67173913043478, 0.20454545454545
20608, 2.2, 0.69782608695652, 0.18181818181818
20609, 2.2, 0.67173913043478, 0.15909090909091
20610, 2.2, 0.69782608695652, 0.13636363636364
20611, 2.2, 0.67173913043478, 0.11363636363636
20612, 2.2, 0.69782608695652, 0.090909090909091
20613, 2.2, 0.67173913043478, 0.068181818181818
20614, 2.2, 0.69782608695652, 0.045454545454545
20615, 2.2, 0.67173913043478, 0.022727272727273
20616, 2.2, 0.61956521739131, 0.47727272727273
20617, 2.2, 0.64565217391304, 0.45454545454545
20618, 2.2, 0.6195652173913, 0.43181818181818
20619, 2.2, 0.64565217391304, 0.40909090909091
20620, 2.2, 0.61956521739131, 0.38636363636364
20621, 2.2, 0.64565217391304, 0.36363636363636
20622, 2.2, 0.61956521739131, 0.34090909090909
20623, 2.2, 0.64565217391304, 0.31818181818182
20624, 2.2, 0.61956521739131, 0.29545454545455
20625, 2.2, 0.64565217391304, 0.27272727272727
20626, 2.2, 0.61956521739131, 0.25
20627, 2.2, 0.64565217391304, 0.22727272727273
20628, 2.2, 0.61956521739131, 0.20454545454545
20629, 2.2, 0.64565217391304, 0.18181818181818
20630, 2.2, 0.61956521739131, 0.15909090909091
20631, 2.2, 0.64565217391304, 0.13636363636364
20632, 2.2, 0.61956521739131, 0.11363636363636
20633, 2.2, 0.64565217391304, 0.090909090909091
20634, 2.2, 0.61956521739131, 0.068181818181818
20635, 2.2, 0.64565217391304, 0.045454545454545
20636, 2.2, 0.61956521739131, 0.022727272727273
20637, 2.2, 0.56739130434783, 0.47727272727273
20638, 2.2, 0.59347826086957, 0.45454545454545
20639, 2.2, 0.56739130434783, 0.43181818181818
20640, 2.2, 0.59347826086957, 0.40909090909091
20641, 2.2, 0.56739130434783, 0.38636363636364
20642, 2.2, 0.59347826086957, 0.36363636363636
20643, 2.2, 0.56739130434783, 0.34090909090909
20644, 2.2, 0.59347826086957, 0.31818181818182
20645, 2.2, 0.56739130434783, 0.29545454545455
20646, 2.2, 0.59347826086957, 0.27272727272727
20647, 2.2, 0.56739130434783, 0.25
20648, 2.2, 0.59347826086957, 0.22727272727273
20649, 2.2, 0.56739130434783, 0.20454545454545
20650, 2.2, 0.59347826086957, 0.18181818181818
20651, 2.2, 0.56739130434783, 0.15909090909091
20652, 2.2, 0.59347826086957, 0.13636363636364
20653, 2.2, 0.56739130434783, 0.11363636363636
20654, 2.2, 0.59347826086957, 0.090909090909091
20655, 2.2, 0.56739130434783, 0.068181818181818
20656, 2.2, 0.59347826086957, 0.045454545454545
20657, 2.2, 0.56739130434783, 0.022727272727273
20658, 2.2, 0.51521739130435, 0.47727272727273
20659, 2.2, 0.54130434782609, 0.45454545454545
20660, 2.2, 0.51521739130435, 0.43181818181818
20661, 2.2, 0.54130434782609, 0.40909090909091
20662, 2.2, 0.51521739130435, 0.38636363636364
20663, 2.2, 0.54130434782609, 0.36363636363636
20664, 2.2, 0.51521739130435, 0.34090909090909
20665, 2.2, 0.54130434782609, 0.31818181818182
20666, 2.2, 0.51521739130435, 0.29545454545455
20667, 2.2, 0.54130434782609, 0.27272727272727
20668, 2.2, 0.51521739130435, 0.25
20669, 2.2, 0.54130434782609, 0.22727272727273
20670, 2.2, 0.51521739130435, 0.20454545454545
20671, 2.2, 0.54130434782609, 0.18181818181818
20672, 2.2, 0.51521739130435, 0.15909090909091
20673, 2.2, 0.54130434782609, 0.13636363636364
20674, 2.2, 0.51521739130435, 0.11363636363636
20675, 2.2, 0.54130434782609, 0.090909090909091
20676, 2.2, 0.51521739130435, 0.068181818181818
20677, 2.2, 0.54130434782609, 0.045454545454545
20678, 2.2, 0.51521739130435, 0.022727272727273
20679, 2.2, 0.46304347826087, 0.47727272727273
20680, 2.2, 0.48913043478261, 0.45454545454545
20681, 2.2, 0.46304347826087, 0.43181818181818
20682, 2.2, 0.48913043478261, 0.40909090909091
20683, 2.2, 0.46304347826087, 0.38636363636364
20684, 2.2, 0.48913043478261, 0.36363636363636
20685, 2.2, 0.46304347826087, 0.34090909090909
20686, 2.2, 0.48913043478261, 0.31818181818182
20687, 2.2, 0.46304347826087, 0.29545454545455
20688, 2.2, 0.48913043478261, 0.27272727272727
20689, 2.2, 0.46304347826087, 0.25
20690, 2.2, 0.48913043478261, 0.22727272727273
20691, 2.2, 0.46304347826087, 0.20454545454545
20692, 2.2, 0.48913043478261, 0.18181818181818
20693, 2.2, 0.46304347826087, 0.15909090909091
20694, 2.2, 0.48913043478261, 0.13636363636364
20695, 2.2, 0.46304347826087, 0.11363636363636
20696, 2.2, 0.48913043478261, 0.090909090909091
20697, 2.2, 0.46304347826087, 0.068181818181818
20698, 2.2, 0.48913043478261, 0.045454545454545
20699, 2.2, 0.46304347826087, 0.022727272727273
20700, 2.2, 0.41086956521739, 0.47727272727273
20701, 2.2, 0.43695652173913, 0.45454545454545
20702, 2.2, 0.41086956521739, 0.43181818181818
20703, 2.2, 0.43695652173913, 0.40909090909091
20704, 2.2, 0.41086956521739, 0.38636363636364
20705, 2.2, 0.43695652173913, 0.36363636363636
20706, 2.2, 0.41086956521739, 0.34090909090909
20707, 2.2, 0.43695652173913, 0.31818181818182
20708, 2.2, 0.41086956521739, 0.29545454545455
20709, 2.2, 0.43695652173913, 0.27272727272727
20710, 2.2, 0.41086956521739, 0.25
20711, 2.2, 0.43695652173913, 0.22727272727273
20712, 2.2, 0.41086956521739, 0.20454545454545
20713, 2.2, 0.43695652173913, 0.18181818181818
20714, 2.2, 0.41086956521739, 0.15909090909091
20715, 2.2, 0.43695652173913, 0.13636363636364
20716, 2.2, 0.41086956521739, 0.11363636363636
20717, 2.2, 0.43695652173913, 0.090909090909091
20718, 2.2, 0.41086956521739, 0.068181818181818
20719, 2.2, 0.43695652173913, 0.045454545454545
20720, 2.2, 0.41086956521739, 0.022727272727273
20721, 2.2, 0.35869565217391, 0.47727272727273
20722, 2.2, 0.38478260869565, 0.45454545454545
20723, 2.2, 0.35869565217391, 0.43181818181818
20724, 2.2, 0.38478260869565, 0.40909090909091
20725, 2.2, 0.35869565217391, 0.38636363636364
20726, 2.2, 0.38478260869565, 0.36363636363636
20727, 2.2, 0.35869565217391, 0.34090909090909
20728, 2.2, 0.38478260869565, 0.31818181818182
20729, 2.2, 0.35869565217391, 0.29545454545455
20730, 2.2, 0.38478260869565, 0.27272727272727
20731, 2.2, 0.35869565217391, 0.25
20732, 2.2, 0.38478260869565, 0.22727272727273
20733, 2.2, 0.35869565217391, 0.20454545454545
20734, 2.2, 0.38478260869565, 0.18181818181818
20735, 2.2, 0.35869565217391, 0.15909090909091
20736, 2.2, 0.38478260869565, 0.13636363636364
20737, 2.2, 0.35869565217391, 0.11363636363636
20738, 2.2, 0.38478260869565, 0.090909090909091
20739, 2.2, 0.35869565217391, 0.068181818181818
20740, 2.2, 0.38478260869565, 0.045454545454545
20741, 2.2, 0.35869565217391, 0.022727272727273
20742, 2.2, 0.30652173913044, 0.47727272727273
20743, 2.2, 0.33260869565217, 0.45454545454545
20744, 2.2, 0.30652173913043, 0.43181818181818
20745, 2.2, 0.33260869565217, 0.40909090909091
20746, 2.2, 0.30652173913043, 0.38636363636364
20747, 2.2, 0.33260869565217, 0.36363636363636
20748, 2.2, 0.30652173913043, 0.34090909090909
20749, 2.2, 0.33260869565217, 0.31818181818182
20750, 2.2, 0.30652173913043, 0.29545454545455
20751, 2.2, 0.33260869565217, 0.27272727272727
20752, 2.2, 0.30652173913043, 0.25
20753, 2.2, 0.33260869565217, 0.22727272727273
20754, 2.2, 0.30652173913043, 0.20454545454545
20755, 2.2, 0.33260869565217, 0.18181818181818
20756, 2.2, 0.30652173913043, 0.15909090909091
20757, 2.2, 0.33260869565217, 0.13636363636364
20758, 2.2, 0.30652173913043, 0.11363636363636
20759, 2.2, 0.33260869565217, 0.090909090909091
20760, 2.2, 0.30652173913043, 0.068181818181818
20761, 2.2, 0.33260869565217, 0.045454545454545
20762, 2.2, 0.30652173913044, 0.022727272727273
20763, 2.2, 0.25434782608696, 0.47727272727273
20764, 2.2, 0.2804347826087, 0.45454545454545
20765, 2.2, 0.25434782608696, 0.43181818181818
20766, 2.2, 0.2804347826087, 0.40909090909091
20767, 2.2, 0.25434782608696, 0.38636363636364
20768, 2.2, 0.2804347826087, 0.36363636363636
20769, 2.2, 0.25434782608696, 0.34090909090909
20770, 2.2, 0.2804347826087, 0.31818181818182
20771, 2.2, 0.25434782608696, 0.29545454545455
20772, 2.2, 0.2804347826087, 0.27272727272727
20773, 2.2, 0.25434782608696, 0.25
20774, 2.2, 0.2804347826087, 0.22727272727273
20775, 2.2, 0.25434782608696, 0.20454545454545
20776, 2.2, 0.2804347826087, 0.18181818181818
20777, 2.2, 0.25434782608696, 0.15909090909091
20778, 2.2, 0.2804347826087, 0.13636363636364
20779, 2.2, 0.25434782608696, 0.11363636363636
20780, 2.2, 0.2804347826087, 0.090909090909091
20781, 2.2, 0.25434782608696, 0.068181818181818
20782, 2.2, 0.2804347826087, 0.045454545454545
20783, 2.2, 0.25434782608696, 0.022727272727273
20784, 2.2, 0.20217391304348, 0.47727272727273
20785, 2.2, 0.22826086956522, 0.45454545454545
20786, 2.2, 0.20217391304348, 0.43181818181818
20787, 2.2, 0.22826086956522, 0.40909090909091
20788, 2.2, 0.20217391304348, 0.38636363636364
20789, 2.2, 0.22826086956522, 0.36363636363636
20790, 2.2, 0.20217391304348, 0.34090909090909
20791, 2.2, 0.22826086956522, 0.31818181818182
20792, 2.2, 0.20217391304348, 0.29545454545455
20793, 2.2, 0.22826086956522, 0.27272727272727
20794, 2.2, 0.20217391304348, 0.25
20795, 2.2, 0.22826086956522, 0.22727272727273
20796, 2.2, 0.20217391304348, 0.20454545454545
20797, 2.2, 0.22826086956522, 0.18181818181818
20798, 2.2, 0.20217391304348, 0.15909090909091
20799, 2.2, 0.22826086956522, 0.13636363636364
20800, 2.2, 0.20217391304348, 0.11363636363636
20801, 2.2, 0.22826086956522, 0.090909090909091
20802, 2.2, 0.20217391304348, 0.068181818181818
20803, 2.2, 0.22826086956522, 0.045454545454545
20804, 2.2, 0.20217391304348, 0.022727272727273
20805, 2.2, 0.17608695652174, 0.45454545454545
20806, 2.2, 0.17608695652174, 0.40909090909091
20807, 2.2, 0.17608695652174, 0.36363636363636
20808, 2.2, 0.17608695652174, 0.31818181818182
20809, 2.2, 0.17608695652174, 0.27272727272727
20810, 2.2, 0.17608695652174, 0.22727272727273
20811, 2.2, 0.17608695652174, 0.18181818181818
20812, 2.2, 0.17608695652174, 0.13636363636364
20813, 2.2, 0.17608695652174, 0.090909090909091
20814, 2.2, 0.17608695652174, 0.045454545454545
20815, 1.2434782608696, 0.15, 0.45454545454545
20816, 1.2434782608696, 0.15, 0.40909090909091
20817, 1.2434782608696, 0.15, 0.36363636363636
20818, 1.2434782608696, 0.15, 0.31818181818182
20819, 1.2434782608696, 0.15, 0.27272727272727
20820, 1.2434782608696, 0.15, 0.22727272727273
20821, 1.2434782608696, 0.15, 0.18181818181818
20822, 1.2434782608696, 0.15, 0.13636363636364
20823, 1.2434782608696, 0.15, 0.090909090909091
20824, 1.2434782608696, 0.15, 0.045454545454545
20825, 1.2869565217391, 0.15, 0.45454545454545
20826, 1.2869565217391, 0.15, 0.40909090909091
20827, 1.2869565217391, 0.15, 0.36363636363636
20828, 1.2869565217391, 0.15, 0.31818181818182
20829, 1.2869565217391, 0.15, 0.27272727272727
20830, 1.2869565217391, 0.15, 0.22727272727273
20831, 1.2869565217391, 0.15, 0.18181818181818
20832, 1.2869565217391, 0.15, 0.13636363636364
20833, 1.2869565217391, 0.15, 0.090909090909091
20834, 1.2869565217391, 0.15, 0.045454545454545
20835, 1.3304347826087, 0.15, 0.45454545454545
20836, 1.3304347826087, 0.15, 0.40909090909091
20837, 1.3304347826087, 0.15, 0.36363636363636
20838, 1.3304347826087, 0.15, 0.31818181818182
20839, 1.3304347826087, 0.15, 0.27272727272727
20840, 1.3304347826087, 0.15, 0.22727272727273
20841, 1.3304347826087, 0.15, 0.18181818181818
20842, 1.3304347826087, 0.15, 0.13636363636364
20843, 1.3304347826087, 0.15, 0.090909090909091
20844, 1.3304347826087, 0.15, 0.045454545454545
20845, 1.3739130434783, 0.15, 0.45454545454545
20846, 1.3739130434783, 0.15, 0.40909090909091
20847, 1.3739130434783, 0.15, 0.36363636363636
20848, 1.3739130434783, 0.15, 0.31818181818182
20849, 1.3739130434783, 0.15, 0.27272727272727
20850, 1.3739130434783, 0.15, 0.22727272727273
20851, 1.3739130434783, 0.15, 0.18181818181818
20852, 1.3739130434783, 0.15, 0.13636363636364
20853, 1.3739130434783, 0.15, 0.090909090909091
20854, 1.3739130434783, 0.15, 0.045454545454545
20855, 1.4173913043478, 0.15, 0.45454545454545
20856, 1.4173913043478, 0.15, 0.40909090909091
20857, 1.4173913043478, 0.15, 0.36363636363636
20858, 1.4173913043478, 0.15, 0.31818181818182
20859, 1.4173913043478, 0.15, 0.27272727272727
20860, 1.4173913043478, 0.15, 0.22727272727273
20861, 1.4173913043478, 0.15, 0.18181818181818
20862, 1.4173913043478, 0.15, 0.13636363636364
20863, 1.4173913043478, 0.15, 0.090909090909091
20864, 1.4173913043478, 0.15, 0.045454545454545
20865, 1.4608695652174, 0.15, 0.45454545454545
20866, 1.4608695652174, 0.15, 0.40909090909091
20867, 1.4608695652174, 0.15, 0.36363636363636
20868, 1.4608695652174, 0.15, 0.31818181818182
20869, 1.4608695652174, 0.15, 0.27272727272727
20870, 1.4608695652174, 0.15, 0.22727272727273
20871, 1.4608695652174, 0.15, 0.18181818181818
20872, 1.4608695652174, 0.15, 0.13636363636364
20873, 1.4608695652174, 0.15, 0.090909090909091
20874, 1.4608695652174, 0.15, 0.045454545454545
20875, 1.504347826087, 0.15, 0.45454545454545
20876, 1.504347826087, 0.15, 0.40909090909091
20877, 1.504347826087, 0.15, 0.36363636363636
20878, 1.504347826087, 0.15, 0.31818181818182
20879, 1.504347826087, 0.15, 0.27272727272727
20880, 1.504347826087, 0.15, 0.22727272727273
20881, 1.504347826087, 0.15, 0.18181818181818
20882, 1.504347826087, 0.15, 0.13636363636364
20883, 1.504347826087, 0.15, 0.090909090909091
20884, 1.504347826087, 0.15, 0.045454545454545
20885, 1.5478260869565, 0.15, 0.45454545454545
20886, 1.5478260869565, 0.15, 0.40909090909091
20887, 1.5478260869565, 0.15, 0.36363636363636
20888, 1.5478260869565, 0.15, 0.31818181818182
20889, 1.5478260869565, 0.15, 0.27272727272727
20890, 1.5478260869565, 0.15, 0.22727272727273
20891, 1.5478260869565, 0.15, 0.18181818181818
20892, 1.5478260869565, 0.15, 0.13636363636364
20893, 1.5478260869565, 0.15, 0.090909090909091
20894, 1.5478260869565, 0.15, 0.045454545454545
20895, 1.5913043478261, 0.15, 0.45454545454545
20896, 1.5913043478261, 0.15, 0.40909090909091
20897, 1.5913043478261, 0.15, 0.36363636363636
20898, 1.5913043478261, 0.15, 0.31818181818182
20899, 1.5913043478261, 0.15, 0.27272727272727
20900, 1.5913043478261, 0.15, 0.22727272727273
20901, 1.5913043478261, 0.15, 0.18181818181818
20902, 1.5913043478261, 0.15, 0.13636363636364
20903, 1.5913043478261, 0.15, 0.090909090909091
20904, 1.5913043478261, 0.15, 0.045454545454545
20905, 1.6347826086957, 0.15, 0.45454545454545
20906, 1.6347826086957, 0.15, 0.40909090909091
20907, 1.6347826086957, 0.15, 0.36363636363636
20908, 1.6347826086957, 0.15, 0.31818181818182
20909, 1.6347826086957, 0.15, 0.27272727272727
20910, 1.6347826086957, 0.15, 0.22727272727273
20911, 1.6347826086957, 0.15, 0.18181818181818
20912, 1.6347826086957, 0.15, 0.13636363636364
20913, 1.6347826086957, 0.15, 0.090909090909091
20914, 1.6347826086957, 0.15, 0.045454545454545
20915, 1.6782608695652, 0.15, 0.45454545454545
20916, 1.6782608695652, 0.15, 0.40909090909091
20917, 1.6782608695652, 0.15, 0.36363636363636
20918, 1.6782608695652, 0.15, 0.31818181818182
20919, 1.6782608695652, 0.15, 0.27272727272727
20920, 1.6782608695652, 0.15, 0.22727272727273
20921, 1.6782608695652, 0.15, 0.18181818181818
20922, 1.6782608695652, 0.15, 0.13636363636364
20923, 1.6782608695652, 0.15, 0.090909090909091
20924, 1.6782608695652, 0.15, 0.045454545454545
20925, 1.7217391304348, 0.15, 0.45454545454545
20926, 1.7217391304348, 0.15, 0.40909090909091
20927, 1.7217391304348, 0.15, 0.36363636363636
20928, 1.7217391304348, 0.15, 0.31818181818182
20929, 1.7217391304348, 0.15, 0.27272727272727
20930, 1.7217391304348, 0.15, 0.22727272727273
20931, 1.7217391304348, 0.15, 0.18181818181818
20932, 1.7217391304348, 0.15, 0.13636363636364
20933, 1.7217391304348, 0.15, 0.090909090909091
20934, 1.7217391304348, 0.15, 0.045454545454545
20935, 1.7652173913043, 0.15, 0.45454545454545
20936, 1.7652173913043, 0.15, 0.40909090909091
20937, 1.7652173913043, 0.15, 0.36363636363636
20938, 1.7652173913043, 0.15, 0.31818181818182
20939, 1.7652173913043, 0.15, 0.27272727272727
20940, 1.7652173913043, 0.15, 0.22727272727273
20941, 1.7652173913043, 0.15, 0.18181818181818
20942, 1.7652173913043, 0.15, 0.13636363636364
20943, 1.7652173913043, 0.15, 0.090909090909091
20944, 1.7652173913043, 0.15, 0.045454545454545
20945, 1.8086956521739, 0.15, 0.45454545454545
20946, 1.8086956521739, 0.15, 0.40909090909091
20947, 1.8086956521739, 0.15, 0.36363636363636
20948, 1.8086956521739, 0.15, 0.31818181818182
20949, 1.8086956521739, 0.15, 0.27272727272727
20950, 1.8086956521739, 0.15, 0.22727272727273
20951, 1.8086956521739, 0.15, 0.18181818181818
20952, 1.8086956521739, 0.15, 0.13636363636364
20953, 1.8086956521739, 0.15, 0.090909090909091
20954, 1.8086956521739, 0.15, 0.045454545454545
20955, 1.8521739130435, 0.15, 0.45454545454545
20956, 1.8521739130435, 0.15, 0.40909090909091
20957, 1.8521739130435, 0.15, 0.36363636363636
20958, 1.8521739130435, 0.15, 0.31818181818182
20959, 1.8521739130435, 0.15, 0.27272727272727
20960, 1.8521739130435, 0.15, 0.22727272727273
20961, 1.8521739130435, 0.15, 0.18181818181818
20962, 1.8521739130435, 0.15, 0.13636363636364
20963, 1.8521739130435, 0.15, 0.090909090909091
20964, 1.8521739130435, 0.15, 0.045454545454545
20965, 1.895652173913, 0.15, 0.45454545454545
20966, 1.895652173913, 0.15, 0.40909090909091
20967, 1.895652173913, 0.15, 0.36363636363636
20968, 1.895652173913, 0.15, 0.31818181818182
20969, 1.895652173913, 0.15, 0.27272727272727
20970, 1.895652173913, 0.15, 0.22727272727273
20971, 1.895652173913, 0.15, 0.18181818181818
20972, 1.895652173913, 0.15, 0.13636363636364
20973, 1.895652173913, 0.15, 0.090909090909091
20974, 1.895652173913, 0.15, 0.045454545454545
20975, 1.9391304347826, 0.15, 0.45454545454545
20976, 1.9391304347826, 0.15, 0.40909090909091
20977, 1.9391304347826, 0.15, 0.36363636363636
20978, 1.9391304347826, 0.15, 0.31818181818182
20979, 1.9391304347826, 0.15, 0.27272727272727
20980, 1.9391304347826, 0.15, 0.22727272727273
20981, 1.9391304347826, 0.15, 0.18181818181818
20982, 1.9391304347826, 0.15, 0.13636363636364
20983, 1.9391304347826, 0.15, 0.090909090909091
20984, 1.9391304347826, 0.15, 0.045454545454545
20985, 1.9826086956522, 0.15, 0.45454545454545
20986, 1.9826086956522, 0.15, 0.40909090909091
20987, 1.9826086956522, 0.15, 0.36363636363636
20988, 1.9826086956522, 0.15, 0.31818181818182
20989, 1.9826086956522, 0.15, 0.27272727272727
20990, 1.9826086956522, 0.15, 0.22727272727273
20991, 1.9826086956522, 0.15, 0.18181818181818
20992, 1.9826086956522, 0.15, 0.13636363636364
20993, 1.9826086956522, 0.15, 0.090909090909091
20994, 1.9826086956522, 0.15, 0.045454545454545
20995, 2.0260869565217, 0.15, 0.45454545454545
20996, 2.0260869565217, 0.15, 0.40909090909091
20997, 2.0260869565217, 0.15, 0.36363636363636
20998, 2.0260869565217, 0.15, 0.31818181818182
20999, 2.0260869565217, 0.15, 0.27272727272727
21000, 2.0260869565217, 0.15, 0.22727272727273
21001, 2.0260869565217, 0.15, 0.18181818181818
21002, 2.0260869565217, 0.15, 0.13636363636364
21003, 2.0260869565217, 0.15, 0.090909090909091
21004, 2.0260869565217, 0.15, 0.045454545454545
21005, 2.0695652173913, 0.15, 0.45454545454545
21006, 2.0695652173913, 0.15, 0.40909090909091
21007, 2.0695652173913, 0.15, 0.36363636363636
21008, 2.0695652173913, 0.15, 0.31818181818182
21009, 2.0695652173913, 0.15, 0.27272727272727
21010, 2.0695652173913, 0.15, 0.22727272727273
21011, 2.0695652173913, 0.15, 0.18181818181818
21012, 2.0695652173913, 0.15, 0.13636363636364
21013, 2.0695652173913, 0.15, 0.090909090909091
21014, 2.0695652173913, 0.15, 0.045454545454545
21015, 2.1130434782609, 0.15, 0.45454545454545
21016, 2.1130434782609, 0.15, 0.40909090909091
21017, 2.1130434782609, 0.15, 0.36363636363636
21018, 2.1130434782609, 0.15, 0.31818181818182
21019, 2.1130434782609, 0.15, 0.27272727272727
21020, 2.1130434782609, 0.15, 0.22727272727273
21021, 2.1130434782609, 0.15, 0.18181818181818
21022, 2.1130434782609, 0.15, 0.13636363636364
21023, 2.1130434782609, 0.15, 0.090909090909091
21024, 2.1130434782609, 0.15, 0.045454545454545
21025, 2.1565217391304, 0.15, 0.45454545454545
21026, 2.1565217391304, 0.15, 0.40909090909091
21027, 2.1565217391304, 0.15, 0.36363636363636
21028, 2.1565217391304, 0.15, 0.31818181818182
21029, 2.1565217391304, 0.15, 0.27272727272727
21030, 2.1565217391304, 0.15, 0.22727272727273
21031, 2.1565217391304, 0.15, 0.18181818181818
21032, 2.1565217391304, 0.15, 0.13636363636364
21033, 2.1565217391304, 0.15, 0.090909090909091
21034, 2.1565217391304, 0.15, 0.045454545454545
21035, 1.2217391304348, 0.15, 0.45454545454545
21036, 1.2434782608696, 0.15, 0.47727272727273
21037, 1.2217391304348, 0.15, 0.40909090909091
21038, 1.2434782608696, 0.15, 0.43181818181818
21039, 1.2217391304348, 0.15, 0.36363636363636
21040, 1.2434782608696, 0.15, 0.38636363636364
21041, 1.2217391304348, 0.15, 0.31818181818182
21042, 1.2434782608696, 0.15, 0.34090909090909
21043, 1.2217391304348, 0.15, 0.27272727272727
21044, 1.2434782608696, 0.15, 0.29545454545455
21045, 1.2217391304348, 0.15, 0.22727272727273
21046, 1.2434782608696, 0.15, 0.25
21047, 1.2217391304348, 0.15, 0.18181818181818
21048, 1.2434782608696, 0.15, 0.20454545454545
21049, 1.2217391304348, 0.15, 0.13636363636364
21050, 1.2434782608696, 0.15, 0.15909090909091
21051, 1.2217391304348, 0.15, 0.090909090909091
21052, 1.2434782608696, 0.15, 0.11363636363636
21053, 1.2217391304348, 0.15, 0.045454545454545
21054, 1.2434782608696, 0.15, 0.068181818181818
21055, 1.2434782608696, 0.15, 0.022727272727273
21056, 1.2652173913043, 0.15, 0.45454545454545
21057, 1.2869565217391, 0.15, 0.47727272727273
21058, 1.2652173913043, 0.15, 0.40909090909091
21059, 1.2869565217391, 0.15, 0.43181818181818
21060, 1.2652173913043, 0.15, 0.36363636363636
21061, 1.2869565217391, 0.15, 0.38636363636364
21062, 1.2652173913043, 0.15, 0.31818181818182
21063, 1.2869565217391, 0.15, 0.34090909090909
21064, 1.2652173913043, 0.15, 0.27272727272727
21065, 1.2869565217391, 0.15, 0.29545454545455
21066, 1.2652173913043, 0.15, 0.22727272727273
21067, 1.2869565217391, 0.15, 0.25
21068, 1.2652173913043, 0.15, 0.18181818181818
21069, 1.2869565217391, 0.15, 0.20454545454545
21070, 1.2652173913043, 0.15, 0.13636363636364
21071, 1.2869565217391, 0.15, 0.15909090909091
21072, 1.2652173913043, 0.15, 0.090909090909091
21073, 1.2869565217391, 0.15, 0.11363636363636
21074, 1.2652173913043, 0.15, 0.045454545454545
21075, 1.2869565217391, 0.15, 0.068181818181818
21076, 1.2869565217391, 0.15, 0.022727272727273
21077, 1.3086956521739, 0.15, 0.45454545454545
21078, 1.3304347826087, 0.15, 0.47727272727273
21079, 1.3086956521739, 0.15, 0.40909090909091
21080, 1.3304347826087, 0.15, 0.43181818181818
21081, 1.3086956521739, 0.15, 0.36363636363636
21082, 1.3304347826087, 0.15, 0.38636363636364
21083, 1.3086956521739, 0.15, 0.31818181818182
21084, 1.3304347826087, 0.15, 0.34090909090909
21085, 1.3086956521739, 0.15, 0.27272727272727
21086, 1.3304347826087, 0.15, 0.29545454545455
21087, 1.3086956521739, 0.15, 0.22727272727273
21088, 1.3304347826087, 0.15, 0.25
21089, 1.3086956521739, 0.15, 0.18181818181818
21090, 1.3304347826087, 0.15, 0.20454545454545
21091, 1.3086956521739, 0.15, 0.13636363636364
21092, 1.3304347826087, 0.15, 0.15909090909091
21093, 1.3086956521739, 0.15, 0.090909090909091
21094, 1.3304347826087, 0.15, 0.11363636363636
21095, 1.3086956521739, 0.15, 0.045454545454545
21096, 1.3304347826087, 0.15, 0.068181818181818
21097, 1.3304347826087, 0.15, 0.022727272727273
21098, 1.3521739130435, 0.15, 0.45454545454545
21099, 1.3739130434783, 0.15, 0.47727272727273
21100, 1.3521739130435, 0.15, 0.40909090909091
21101, 1.3739130434783, 0.15, 0.43181818181818
21102, 1.3521739130435, 0.15, 0.36363636363636
21103, 1.3739130434783, 0.15, 0.38636363636364
21104, 1.3521739130435, 0.15, 0.31818181818182
21105, 1.3739130434783, 0.15, 0.34090909090909
21106, 1.3521739130435, 0.15, 0.27272727272727
21107, 1.3739130434783, 0.15, 0.29545454545455
21108, 1.3521739130435, 0.15, 0.22727272727273
21109, 1.3739130434783, 0.15, 0.25
21110, 1.3521739130435, 0.15, 0.18181818181818
21111, 1.3739130434783, 0.15, 0.20454545454545
21112, 1.3521739130435, 0.15, 0.13636363636364
21113, 1.3739130434783, 0.15, 0.15909090909091
21114, 1.3521739130435, 0.15, 0.090909090909091
21115, 1.3739130434783, 0.15, 0.11363636363636
21116, 1.3521739130435, 0.15, 0.045454545454545
21117, 1.3739130434783, 0.15, 0.068181818181818
21118, 1.3739130434783, 0.15, 0.022727272727273
21119, 1.395652173913, 0.15, 0.45454545454545
21120, 1.4173913043478, 0.15, 0.47727272727273
21121, 1.395652173913, 0.15, 0.40909090909091
21122, 1.4173913043478, 0.15, 0.43181818181818
21123, 1.395652173913, 0.15, 0.36363636363636
21124, 1.4173913043478, 0.15, 0.38636363636364
21125, 1.395652173913, 0.15, 0.31818181818182
21126, 1.4173913043478, 0.15, 0.34090909090909
21127, 1.395652173913, 0.15, 0.27272727272727
21128, 1.4173913043478, 0.15, 0.29545454545455
21129, 1.395652173913, 0.15, 0.22727272727273
21130, 1.4173913043478, 0.15, 0.25
21131, 1.395652173913, 0.15, 0.18181818181818
21132, 1.4173913043478, 0.15, 0.20454545454545
21133, 1.395652173913, 0.15, 0.13636363636364
21134, 1.4173913043478, 0.15, 0.15909090909091
21135, 1.395652173913, 0.15, 0.090909090909091
21136, 1.4173913043478, 0.15, 0.11363636363636
21137, 1.395652173913, 0.15, 0.045454545454545
21138, 1.4173913043478, 0.15, 0.068181818181818
21139, 1.4173913043478, 0.15, 0.022727272727273
21140, 1.4391304347826, 0.15, 0.45454545454545
21141, 1.4608695652174, 0.15, 0.47727272727273
21142, 1.4391304347826, 0.15, 0.40909090909091
21143, 1.4608695652174, 0.15, 0.43181818181818
21144, 1.4391304347826, 0.15, 0.36363636363636
21145, 1.4608695652174, 0.15, 0.38636363636364
21146, 1.4391304347826, 0.15, 0.31818181818182
21147, 1.4608695652174, 0.15, 0.34090909090909
21148, 1.4391304347826, 0.15, 0.27272727272727
21149, 1.4608695652174, 0.15, 0.29545454545455
21150, 1.4391304347826, 0.15, 0.22727272727273
21151, 1.4608695652174, 0.15, 0.25
21152, 1.4391304347826, 0.15, 0.18181818181818
21153, 1.4608695652174, 0.15, 0.20454545454545
21154, 1.4391304347826, 0.15, 0.13636363636364
21155, 1.4608695652174, 0.15, 0.15909090909091
21156, 1.4391304347826, 0.15, 0.090909090909091
21157, 1.4608695652174, 0.15, 0.11363636363636
21158, 1.4391304347826, 0.15, 0.045454545454545
21159, 1.4608695652174, 0.15, 0.068181818181818
21160, 1.4608695652174, 0.15, 0.022727272727273
21161, 1.4826086956522, 0.15, 0.45454545454545
21162, 1.504347826087, 0.15, 0.47727272727273
21163, 1.4826086956522, 0.15, 0.40909090909091
21164, 1.504347826087, 0.15, 0.43181818181818
21165, 1.4826086956522, 0.15, 0.36363636363636
21166, 1.504347826087, 0.15, 0.38636363636364
21167, 1.4826086956522, 0.15, 0.31818181818182
21168, 1.504347826087, 0.15, 0.34090909090909
21169, 1.4826086956522, 0.15, 0.27272727272727
21170, 1.504347826087, 0.15, 0.29545454545455
21171, 1.4826086956522, 0.15, 0.22727272727273
21172, 1.504347826087, 0.15, 0.25
21173, 1.4826086956522, 0.15, 0.18181818181818
21174, 1.504347826087, 0.15, 0.20454545454545
21175, 1.4826086956522, 0.15, 0.13636363636364
21176, 1.504347826087, 0.15, 0.15909090909091
21177, 1.4826086956522, 0.15, 0.090909090909091
21178, 1.504347826087, 0.15, 0.11363636363636
21179, 1.4826086956522, 0.15, 0.045454545454545
21180, 1.504347826087, 0.15, 0.068181818181818
21181, 1.504347826087, 0.15, 0.022727272727273
21182, 1.5260869565217, 0.15, 0.45454545454545
21183, 1.5478260869565, 0.15, 0.47727272727273
21184, 1.5260869565217, 0.15, 0.40909090909091
21185, 1.5478260869565, 0.15, 0.43181818181818
21186, 1.5260869565217, 0.15, 0.36363636363636
21187, 1.5478260869565, 0.15, 0.38636363636364
21188, 1.5260869565217, 0.15, 0.31818181818182
21189, 1.5478260869565, 0.15, 0.34090909090909
21190, 1.5260869565217, 0.15, 0.27272727272727
21191, 1.5478260869565, 0.15, 0.29545454545455
21192, 1.5260869565217, 0.15, 0.22727272727273
21193, 1.5478260869565, 0.15, 0.25
21194, 1.5260869565217, 0.15, 0.18181818181818
21195, 1.5478260869565, 0.15, 0.20454545454545
21196, 1.5260869565217, 0.15, 0.13636363636364
21197, 1.5478260869565, 0.15, 0.15909090909091
21198, 1.5260869565217, 0.15, 0.090909090909091
21199, 1.5478260869565, 0.15, 0.11363636363636
21200, 1.5260869565217, 0.15, 0.045454545454545
21201, 1.5478260869565, 0.15, 0.068181818181818
21202, 1.5478260869565, 0.15, 0.022727272727273
21203, 1.5695652173913, 0.15, 0.45454545454545
21204, 1.5913043478261, 0.15, 0.47727272727273
21205, 1.5695652173913, 0.15, 0.40909090909091
21206, 1.5913043478261, 0.15, 0.43181818181818
21207, 1.5695652173913, 0.15, 0.36363636363636
21208, 1.5913043478261, 0.15, 0.38636363636364
21209, 1.5695652173913, 0.15, 0.31818181818182
21210, 1.5913043478261, 0.15, 0.34090909090909
21211, 1.5695652173913, 0.15, 0.27272727272727
21212, 1.5913043478261, 0.15, 0.29545454545455
21213, 1.5695652173913, 0.15, 0.22727272727273
21214, 1.5913043478261, 0.15, 0.25
21215, 1.5695652173913, 0.15, 0.18181818181818
21216, 1.5913043478261, 0.15, 0.20454545454545
21217, 1.5695652173913, 0.15, 0.13636363636364
21218, 1.5913043478261, 0.15, 0.15909090909091
21219, 1.5695652173913, 0.15, 0.090909090909091
21220, 1.5913043478261, 0.15, 0.11363636363636
21221, 1.5695652173913, 0.15, 0.045454545454545
21222, 1.5913043478261, 0.15, 0.068181818181818
21223, 1.5913043478261, 0.15, 0.022727272727273
21224, 1.6130434782609, 0.15, 0.45454545454545
21225, 1.6347826086957, 0.15, 0.47727272727273
21226, 1.6130434782609, 0.15, 0.40909090909091
21227, 1.6347826086957, 0.15, 0.43181818181818
21228, 1.6130434782609, 0.15, 0.36363636363636
21229, 1.6347826086957, 0.15, 0.38636363636364
21230, 1.6130434782609, 0.15, 0.31818181818182
21231, 1.6347826086957, 0.15, 0.34090909090909
21232, 1.6130434782609, 0.15, 0.27272727272727
21233, 1.6347826086957, 0.15, 0.29545454545455
21234, 1.6130434782609, 0.15, 0.22727272727273
21235, 1.6347826086957, 0.15, 0.25
21236, 1.6130434782609, 0.15, 0.18181818181818
21237, 1.6347826086957, 0.15, 0.20454545454545
21238, 1.6130434782609, 0.15, 0.13636363636364
21239, 1.6347826086957, 0.15, 0.15909090909091
21240, 1.6130434782609, 0.15, 0.090909090909091
21241, 1.6347826086957, 0.15, 0.11363636363636
21242, 1.6130434782609, 0.15, 0.045454545454545
21243, 1.6347826086957, 0.15, 0.068181818181818
21244, 1.6347826086957, 0.15, 0.022727272727273
21245, 1.6565217391304, 0.15, 0.45454545454545
21246, 1.6782608695652, 0.15, 0.47727272727273
21247, 1.6565217391304, 0.15, 0.40909090909091
21248, 1.6782608695652, 0.15, 0.43181818181818
21249, 1.6565217391304, 0.15, 0.36363636363636
21250, 1.6782608695652, 0.15, 0.38636363636364
21251, 1.6565217391304, 0.15, 0.31818181818182
21252, 1.6782608695652, 0.15, 0.34090909090909
21253, 1.6565217391304, 0.15, 0.27272727272727
21254, 1.6782608695652, 0.15, 0.29545454545455
21255, 1.6565217391304, 0.15, 0.22727272727273
21256, 1.6782608695652, 0.15, 0.25
21257, 1.6565217391304, 0.15, 0.18181818181818
21258, 1.6782608695652, 0.15, 0.20454545454545
21259, 1.6565217391304, 0.15, 0.13636363636364
21260, 1.6782608695652, 0.15, 0.15909090909091
21261, 1.6565217391304, 0.15, 0.090909090909091
21262, 1.6782608695652, 0.15, 0.11363636363636
21263, 1.6565217391304, 0.15, 0.045454545454545
21264, 1.6782608695652, 0.15, 0.068181818181818
21265, 1.6782608695652, 0.15, 0.022727272727273
21266, 1.7, 0.15, 0.45454545454545
21267, 1.7217391304348, 0.15, 0.47727272727273
21268, 1.7, 0.15, 0.40909090909091
21269, 1.7217391304348, 0.15, 0.43181818181818
21270, 1.7, 0.15, 0.36363636363636
21271, 1.7217391304348, 0.15, 0.38636363636364
21272, 1.7, 0.15, 0.31818181818182
21273, 1.7217391304348, 0.15, 0.34090909090909
21274, 1.7, 0.15, 0.27272727272727
21275, 1.7217391304348, 0.15, 0.29545454545455
21276, 1.7, 0.15, 0.22727272727273
21277, 1.7217391304348, 0.15, 0.25
21278, 1.7, 0.15, 0.18181818181818
21279, 1.7217391304348, 0.15, 0.20454545454545
21280, 1.7, 0.15, 0.13636363636364
21281, 1.7217391304348, 0.15, 0.15909090909091
21282, 1.7, 0.15, 0.090909090909091
21283, 1.7217391304348, 0.15, 0.11363636363636
21284, 1.7, 0.15, 0.045454545454545
21285, 1.7217391304348, 0.15, 0.068181818181818
21286, 1.7217391304348, 0.15, 0.022727272727273
21287, 1.7434782608696, 0.15, 0.45454545454545
21288, 1.7652173913043, 0.15, 0.47727272727273
21289, 1.7434782608696, 0.15, 0.40909090909091
21290, 1.7652173913043, 0.15, 0.43181818181818
21291, 1.7434782608696, 0.15, 0.36363636363636
21292, 1.7652173913043, 0.15, 0.38636363636364
21293, 1.7434782608696, 0.15, 0.31818181818182
21294, 1.7652173913043, 0.15, 0.34090909090909
21295, 1.7434782608696, 0.15, 0.27272727272727
21296, 1.7652173913043, 0.15, 0.29545454545455
21297, 1.7434782608696, 0.15, 0.22727272727273
21298, 1.7652173913043, 0.15, 0.25
21299, 1.7434782608696, 0.15, 0.18181818181818
21300, 1.7652173913043, 0.15, 0.20454545454545
21301, 1.7434782608696, 0.15, 0.13636363636364
21302, 1.7652173913043, 0.15, 0.15909090909091
21303, 1.7434782608696, 0.15, 0.090909090909091
21304, 1.7652173913043, 0.15, 0.11363636363636
21305, 1.7434782608696, 0.15, 0.045454545454545
21306, 1.7652173913043, 0.15, 0.068181818181818
21307, 1.7652173913043, 0.15, 0.022727272727273
21308, 1.7869565217391, 0.15, 0.45454545454545
21309, 1.8086956521739, 0.15, 0.47727272727273
21310, 1.7869565217391, 0.15, 0.40909090909091
21311, 1.8086956521739, 0.15, 0.43181818181818
21312, 1.7869565217391, 0.15, 0.36363636363636
21313, 1.8086956521739, 0.15, 0.38636363636364
21314, 1.7869565217391, 0.15, 0.31818181818182
21315, 1.8086956521739, 0.15, 0.34090909090909
21316, 1.7869565217391, 0.15, 0.27272727272727
21317, 1.8086956521739, 0.15, 0.29545454545455
21318, 1.7869565217391, 0.15, 0.22727272727273
21319, 1.8086956521739, 0.15, 0.25
21320, 1.7869565217391, 0.15, 0.18181818181818
21321, 1.8086956521739, 0.15, 0.20454545454545
21322, 1.7869565217391, 0.15, 0.13636363636364
21323, 1.8086956521739, 0.15, 0.15909090909091
21324, 1.7869565217391, 0.15, 0.090909090909091
21325, 1.8086956521739, 0.15, 0.11363636363636
21326, 1.7869565217391, 0.15, 0.045454545454545
21327, 1.8086956521739, 0.15, 0.068181818181818
21328, 1.8086956521739, 0.15, 0.022727272727273
21329, 1.8304347826087, 0.15, 0.45454545454545
21330, 1.8521739130435, 0.15, 0.47727272727273
21331, 1.8304347826087, 0.15, 0.40909090909091
21332, 1.8521739130435, 0.15, 0.43181818181818
21333, 1.8304347826087, 0.15, 0.36363636363636
21334, 1.8521739130435, 0.15, 0.38636363636364
21335, 1.8304347826087, 0.15, 0.31818181818182
21336, 1.8521739130435, 0.15, 0.34090909090909
21337, 1.8304347826087, 0.15, 0.27272727272727
21338, 1.8521739130435, 0.15, 0.29545454545455
21339, 1.8304347826087, 0.15, 0.22727272727273
21340, 1.8521739130435, 0.15, 0.25
21341, 1.8304347826087, 0.15, 0.18181818181818
21342, 1.8521739130435, 0.15, 0.20454545454545
21343, 1.8304347826087, 0.15, 0.13636363636364
21344, 1.8521739130435, 0.15, 0.15909090909091
21345, 1.8304347826087, 0.15, 0.090909090909091
21346, 1.8521739130435, 0.15, 0.11363636363636
21347, 1.8304347826087, 0.15, 0.045454545454545
21348, 1.8521739130435, 0.15, 0.068181818181818
21349, 1.8521739130435, 0.15, 0.022727272727273
21350, 1.8739130434783, 0.15, 0.45454545454545
21351, 1.895652173913, 0.15, 0.47727272727273
21352, 1.8739130434783, 0.15, 0.40909090909091
21353, 1.895652173913, 0.15, 0.43181818181818
21354, 1.8739130434783, 0.15, 0.36363636363636
21355, 1.895652173913, 0.15, 0.38636363636364
21356, 1.8739130434783, 0.15, 0.31818181818182
21357, 1.895652173913, 0.15, 0.34090909090909
21358, 1.8739130434783, 0.15, 0.27272727272727
21359, 1.895652173913, 0.15, 0.29545454545455
21360, 1.8739130434783, 0.15, 0.22727272727273
21361, 1.895652173913, 0.15, 0.25
21362, 1.8739130434783, 0.15, 0.18181818181818
21363, 1.895652173913, 0.15, 0.20454545454545
21364, 1.8739130434783, 0.15, 0.13636363636364
21365, 1.895652173913, 0.15, 0.15909090909091
21366, 1.8739130434783, 0.15, 0.090909090909091
21367, 1.895652173913, 0.15, 0.11363636363636
21368, 1.8739130434783, 0.15, 0.045454545454545
21369, 1.895652173913, 0.15, 0.068181818181818
