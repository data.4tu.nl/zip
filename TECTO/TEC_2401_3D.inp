79621, 1.2434782608696, 0.30652173913044, 0.47727272727273
79622, 1.2217391304348, 0.30652173913044, 0.45454545454545
79623, 1.2434782608696, 0.33260869565217, 0.45454545454545
79624, 1.2434782608696, 0.30652173913044, 0.43181818181818
79625, 1.2217391304348, 0.30652173913044, 0.40909090909091
79626, 1.2434782608696, 0.33260869565217, 0.40909090909091
79627, 1.2434782608696, 0.30652173913044, 0.38636363636364
79628, 1.2217391304348, 0.30652173913044, 0.36363636363636
79629, 1.2434782608696, 0.33260869565217, 0.36363636363636
79630, 1.2434782608696, 0.30652173913044, 0.34090909090909
79631, 1.2217391304348, 0.30652173913044, 0.31818181818182
79632, 1.2434782608696, 0.33260869565217, 0.31818181818182
79633, 1.2434782608696, 0.30652173913044, 0.29545454545455
79634, 1.2217391304348, 0.30652173913044, 0.27272727272727
79635, 1.2434782608696, 0.33260869565217, 0.27272727272727
79636, 1.2434782608696, 0.30652173913044, 0.25
79637, 1.2217391304348, 0.30652173913044, 0.22727272727273
79638, 1.2434782608696, 0.33260869565217, 0.22727272727273
79639, 1.2434782608696, 0.30652173913044, 0.20454545454545
79640, 1.2217391304348, 0.30652173913044, 0.18181818181818
79641, 1.2434782608696, 0.33260869565217, 0.18181818181818
79642, 1.2434782608696, 0.30652173913044, 0.15909090909091
79643, 1.2217391304348, 0.30652173913044, 0.13636363636364
79644, 1.2434782608696, 0.33260869565217, 0.13636363636364
79645, 1.2434782608696, 0.30652173913044, 0.11363636363636
79646, 1.2217391304348, 0.30652173913044, 0.090909090909091
79647, 1.2434782608696, 0.33260869565217, 0.090909090909091
79648, 1.2434782608696, 0.30652173913044, 0.068181818181818
79649, 1.2217391304348, 0.30652173913044, 0.045454545454545
79650, 1.2434782608696, 0.33260869565217, 0.045454545454545
79651, 1.2434782608696, 0.30652173913044, 0.022727272727273
79652, 1.2869565217391, 0.30652173913043, 0.47727272727273
79653, 1.2652173913043, 0.30652173913044, 0.45454545454545
79654, 1.2869565217391, 0.33260869565217, 0.45454545454545
79655, 1.2869565217391, 0.30652173913043, 0.43181818181818
79656, 1.2652173913043, 0.30652173913043, 0.40909090909091
79657, 1.2869565217391, 0.33260869565217, 0.40909090909091
79658, 1.2869565217391, 0.30652173913043, 0.38636363636364
79659, 1.2652173913043, 0.30652173913044, 0.36363636363636
79660, 1.2869565217391, 0.33260869565217, 0.36363636363636
79661, 1.2869565217391, 0.30652173913043, 0.34090909090909
79662, 1.2652173913043, 0.30652173913043, 0.31818181818182
79663, 1.2869565217391, 0.33260869565217, 0.31818181818182
79664, 1.2869565217391, 0.30652173913043, 0.29545454545455
79665, 1.2652173913043, 0.30652173913043, 0.27272727272727
79666, 1.2869565217391, 0.33260869565217, 0.27272727272727
79667, 1.2869565217391, 0.30652173913043, 0.25
79668, 1.2652173913043, 0.30652173913043, 0.22727272727273
79669, 1.2869565217391, 0.33260869565217, 0.22727272727273
79670, 1.2869565217391, 0.30652173913043, 0.20454545454545
79671, 1.2652173913043, 0.30652173913043, 0.18181818181818
79672, 1.2869565217391, 0.33260869565217, 0.18181818181818
79673, 1.2869565217391, 0.30652173913043, 0.15909090909091
79674, 1.2652173913043, 0.30652173913043, 0.13636363636364
79675, 1.2869565217391, 0.33260869565217, 0.13636363636364
79676, 1.2869565217391, 0.30652173913043, 0.11363636363636
79677, 1.2652173913043, 0.30652173913043, 0.090909090909091
79678, 1.2869565217391, 0.33260869565217, 0.090909090909091
79679, 1.2869565217391, 0.30652173913043, 0.068181818181818
79680, 1.2652173913043, 0.30652173913043, 0.045454545454545
79681, 1.2869565217391, 0.33260869565217, 0.045454545454545
79682, 1.2869565217391, 0.30652173913043, 0.022727272727273
79683, 1.3304347826087, 0.30652173913043, 0.47727272727273
79684, 1.3086956521739, 0.30652173913043, 0.45454545454545
79685, 1.3304347826087, 0.33260869565217, 0.45454545454545
79686, 1.3304347826087, 0.30652173913043, 0.43181818181818
79687, 1.3086956521739, 0.30652173913043, 0.40909090909091
79688, 1.3304347826087, 0.33260869565217, 0.40909090909091
79689, 1.3304347826087, 0.30652173913043, 0.38636363636364
79690, 1.3086956521739, 0.30652173913043, 0.36363636363636
79691, 1.3304347826087, 0.33260869565217, 0.36363636363636
79692, 1.3304347826087, 0.30652173913043, 0.34090909090909
79693, 1.3086956521739, 0.30652173913043, 0.31818181818182
79694, 1.3304347826087, 0.33260869565217, 0.31818181818182
79695, 1.3304347826087, 0.30652173913043, 0.29545454545455
79696, 1.3086956521739, 0.30652173913043, 0.27272727272727
79697, 1.3304347826087, 0.33260869565217, 0.27272727272727
79698, 1.3304347826087, 0.30652173913043, 0.25
79699, 1.3086956521739, 0.30652173913043, 0.22727272727273
79700, 1.3304347826087, 0.33260869565217, 0.22727272727273
79701, 1.3304347826087, 0.30652173913043, 0.20454545454545
79702, 1.3086956521739, 0.30652173913043, 0.18181818181818
79703, 1.3304347826087, 0.33260869565217, 0.18181818181818
79704, 1.3304347826087, 0.30652173913043, 0.15909090909091
79705, 1.3086956521739, 0.30652173913043, 0.13636363636364
79706, 1.3304347826087, 0.33260869565217, 0.13636363636364
79707, 1.3304347826087, 0.30652173913043, 0.11363636363636
79708, 1.3086956521739, 0.30652173913043, 0.090909090909091
79709, 1.3304347826087, 0.33260869565217, 0.090909090909091
79710, 1.3304347826087, 0.30652173913043, 0.068181818181818
79711, 1.3086956521739, 0.30652173913043, 0.045454545454545
79712, 1.3304347826087, 0.33260869565217, 0.045454545454545
79713, 1.3304347826087, 0.30652173913043, 0.022727272727273
79714, 1.3739130434783, 0.30652173913044, 0.47727272727273
79715, 1.3521739130435, 0.30652173913044, 0.45454545454545
79716, 1.3739130434783, 0.33260869565217, 0.45454545454545
79717, 1.3739130434783, 0.30652173913044, 0.43181818181818
79718, 1.3521739130435, 0.30652173913043, 0.40909090909091
79719, 1.3739130434783, 0.33260869565217, 0.40909090909091
79720, 1.3739130434783, 0.30652173913044, 0.38636363636364
79721, 1.3521739130435, 0.30652173913043, 0.36363636363636
79722, 1.3739130434783, 0.33260869565217, 0.36363636363636
79723, 1.3739130434783, 0.30652173913044, 0.34090909090909
79724, 1.3521739130435, 0.30652173913043, 0.31818181818182
79725, 1.3739130434783, 0.33260869565217, 0.31818181818182
79726, 1.3739130434783, 0.30652173913044, 0.29545454545455
79727, 1.3521739130435, 0.30652173913043, 0.27272727272727
79728, 1.3739130434783, 0.33260869565217, 0.27272727272727
79729, 1.3739130434783, 0.30652173913044, 0.25
79730, 1.3521739130435, 0.30652173913043, 0.22727272727273
79731, 1.3739130434783, 0.33260869565217, 0.22727272727273
79732, 1.3739130434783, 0.30652173913044, 0.20454545454545
79733, 1.3521739130435, 0.30652173913043, 0.18181818181818
79734, 1.3739130434783, 0.33260869565217, 0.18181818181818
79735, 1.3739130434783, 0.30652173913044, 0.15909090909091
79736, 1.3521739130435, 0.30652173913043, 0.13636363636364
79737, 1.3739130434783, 0.33260869565217, 0.13636363636364
79738, 1.3739130434783, 0.30652173913044, 0.11363636363636
79739, 1.3521739130435, 0.30652173913043, 0.090909090909091
79740, 1.3739130434783, 0.33260869565217, 0.090909090909091
79741, 1.3739130434783, 0.30652173913044, 0.068181818181818
79742, 1.3521739130435, 0.30652173913043, 0.045454545454545
79743, 1.3739130434783, 0.33260869565217, 0.045454545454545
79744, 1.3739130434783, 0.30652173913044, 0.022727272727273
79745, 1.4173913043478, 0.30652173913044, 0.47727272727273
79746, 1.395652173913, 0.30652173913044, 0.45454545454545
79747, 1.4173913043478, 0.33260869565217, 0.45454545454545
79748, 1.4173913043478, 0.30652173913043, 0.43181818181818
79749, 1.395652173913, 0.30652173913043, 0.40909090909091
79750, 1.4173913043478, 0.33260869565217, 0.40909090909091
79751, 1.4173913043478, 0.30652173913043, 0.38636363636364
79752, 1.395652173913, 0.30652173913044, 0.36363636363636
79753, 1.4173913043478, 0.33260869565217, 0.36363636363636
79754, 1.4173913043478, 0.30652173913043, 0.34090909090909
79755, 1.395652173913, 0.30652173913044, 0.31818181818182
79756, 1.4173913043478, 0.33260869565217, 0.31818181818182
79757, 1.4173913043478, 0.30652173913043, 0.29545454545455
79758, 1.395652173913, 0.30652173913044, 0.27272727272727
79759, 1.4173913043478, 0.33260869565217, 0.27272727272727
79760, 1.4173913043478, 0.30652173913043, 0.25
79761, 1.395652173913, 0.30652173913044, 0.22727272727273
79762, 1.4173913043478, 0.33260869565217, 0.22727272727273
79763, 1.4173913043478, 0.30652173913043, 0.20454545454545
79764, 1.395652173913, 0.30652173913044, 0.18181818181818
79765, 1.4173913043478, 0.33260869565217, 0.18181818181818
79766, 1.4173913043478, 0.30652173913043, 0.15909090909091
79767, 1.395652173913, 0.30652173913044, 0.13636363636364
79768, 1.4173913043478, 0.33260869565217, 0.13636363636364
79769, 1.4173913043478, 0.30652173913043, 0.11363636363636
79770, 1.395652173913, 0.30652173913044, 0.090909090909091
79771, 1.4173913043478, 0.33260869565217, 0.090909090909091
79772, 1.4173913043478, 0.30652173913043, 0.068181818181818
79773, 1.395652173913, 0.30652173913043, 0.045454545454545
79774, 1.4173913043478, 0.33260869565217, 0.045454545454545
79775, 1.4173913043478, 0.30652173913044, 0.022727272727273
79776, 1.4608695652174, 0.30652173913043, 0.47727272727273
79777, 1.4391304347826, 0.30652173913043, 0.45454545454545
79778, 1.4608695652174, 0.33260869565217, 0.45454545454545
79779, 1.4608695652174, 0.30652173913043, 0.43181818181818
79780, 1.4391304347826, 0.30652173913043, 0.40909090909091
79781, 1.4608695652174, 0.33260869565217, 0.40909090909091
79782, 1.4608695652174, 0.30652173913043, 0.38636363636364
79783, 1.4391304347826, 0.30652173913043, 0.36363636363636
79784, 1.4608695652174, 0.33260869565217, 0.36363636363636
79785, 1.4608695652174, 0.30652173913043, 0.34090909090909
79786, 1.4391304347826, 0.30652173913043, 0.31818181818182
79787, 1.4608695652174, 0.33260869565217, 0.31818181818182
79788, 1.4608695652174, 0.30652173913043, 0.29545454545455
79789, 1.4391304347826, 0.30652173913043, 0.27272727272727
79790, 1.4608695652174, 0.33260869565217, 0.27272727272727
79791, 1.4608695652174, 0.30652173913043, 0.25
79792, 1.4391304347826, 0.30652173913043, 0.22727272727273
79793, 1.4608695652174, 0.33260869565217, 0.22727272727273
79794, 1.4608695652174, 0.30652173913043, 0.20454545454545
79795, 1.4391304347826, 0.30652173913043, 0.18181818181818
79796, 1.4608695652174, 0.33260869565217, 0.18181818181818
79797, 1.4608695652174, 0.30652173913043, 0.15909090909091
79798, 1.4391304347826, 0.30652173913043, 0.13636363636364
79799, 1.4608695652174, 0.33260869565217, 0.13636363636364
79800, 1.4608695652174, 0.30652173913043, 0.11363636363636
79801, 1.4391304347826, 0.30652173913043, 0.090909090909091
79802, 1.4608695652174, 0.33260869565217, 0.090909090909091
79803, 1.4608695652174, 0.30652173913043, 0.068181818181818
79804, 1.4391304347826, 0.30652173913043, 0.045454545454545
79805, 1.4608695652174, 0.33260869565217, 0.045454545454545
79806, 1.4608695652174, 0.30652173913043, 0.022727272727273
79807, 1.504347826087, 0.30652173913044, 0.47727272727273
79808, 1.4826086956522, 0.30652173913044, 0.45454545454545
79809, 1.504347826087, 0.33260869565217, 0.45454545454545
79810, 1.504347826087, 0.30652173913044, 0.43181818181818
79811, 1.4826086956522, 0.30652173913043, 0.40909090909091
79812, 1.504347826087, 0.33260869565217, 0.40909090909091
79813, 1.504347826087, 0.30652173913044, 0.38636363636364
79814, 1.4826086956522, 0.30652173913044, 0.36363636363636
79815, 1.504347826087, 0.33260869565217, 0.36363636363636
79816, 1.504347826087, 0.30652173913044, 0.34090909090909
79817, 1.4826086956522, 0.30652173913043, 0.31818181818182
79818, 1.504347826087, 0.33260869565217, 0.31818181818182
79819, 1.504347826087, 0.30652173913044, 0.29545454545455
79820, 1.4826086956522, 0.30652173913043, 0.27272727272727
79821, 1.504347826087, 0.33260869565217, 0.27272727272727
79822, 1.504347826087, 0.30652173913044, 0.25
79823, 1.4826086956522, 0.30652173913043, 0.22727272727273
79824, 1.504347826087, 0.33260869565217, 0.22727272727273
79825, 1.504347826087, 0.30652173913044, 0.20454545454545
79826, 1.4826086956522, 0.30652173913043, 0.18181818181818
79827, 1.504347826087, 0.33260869565217, 0.18181818181818
79828, 1.504347826087, 0.30652173913044, 0.15909090909091
79829, 1.4826086956522, 0.30652173913043, 0.13636363636364
79830, 1.504347826087, 0.33260869565217, 0.13636363636364
79831, 1.504347826087, 0.30652173913044, 0.11363636363636
79832, 1.4826086956522, 0.30652173913043, 0.090909090909091
79833, 1.504347826087, 0.33260869565217, 0.090909090909091
79834, 1.504347826087, 0.30652173913044, 0.068181818181818
79835, 1.4826086956522, 0.30652173913043, 0.045454545454545
79836, 1.504347826087, 0.33260869565217, 0.045454545454545
79837, 1.504347826087, 0.30652173913044, 0.022727272727273
79838, 1.5478260869565, 0.30652173913044, 0.47727272727273
79839, 1.5260869565217, 0.30652173913044, 0.45454545454545
79840, 1.5478260869565, 0.33260869565217, 0.45454545454545
79841, 1.5478260869565, 0.30652173913044, 0.43181818181818
79842, 1.5260869565217, 0.30652173913044, 0.40909090909091
79843, 1.5478260869565, 0.33260869565217, 0.40909090909091
79844, 1.5478260869565, 0.30652173913044, 0.38636363636364
79845, 1.5260869565217, 0.30652173913044, 0.36363636363636
79846, 1.5478260869565, 0.33260869565217, 0.36363636363636
79847, 1.5478260869565, 0.30652173913044, 0.34090909090909
79848, 1.5260869565217, 0.30652173913044, 0.31818181818182
79849, 1.5478260869565, 0.33260869565217, 0.31818181818182
79850, 1.5478260869565, 0.30652173913044, 0.29545454545455
79851, 1.5260869565217, 0.30652173913044, 0.27272727272727
79852, 1.5478260869565, 0.33260869565217, 0.27272727272727
79853, 1.5478260869565, 0.30652173913044, 0.25
79854, 1.5260869565217, 0.30652173913044, 0.22727272727273
79855, 1.5478260869565, 0.33260869565217, 0.22727272727273
79856, 1.5478260869565, 0.30652173913044, 0.20454545454545
79857, 1.5260869565217, 0.30652173913044, 0.18181818181818
79858, 1.5478260869565, 0.33260869565217, 0.18181818181818
79859, 1.5478260869565, 0.30652173913044, 0.15909090909091
79860, 1.5260869565217, 0.30652173913044, 0.13636363636364
79861, 1.5478260869565, 0.33260869565217, 0.13636363636364
79862, 1.5478260869565, 0.30652173913044, 0.11363636363636
79863, 1.5260869565217, 0.30652173913044, 0.090909090909091
79864, 1.5478260869565, 0.33260869565217, 0.090909090909091
79865, 1.5478260869565, 0.30652173913044, 0.068181818181818
79866, 1.5260869565217, 0.30652173913044, 0.045454545454545
79867, 1.5478260869565, 0.33260869565217, 0.045454545454545
79868, 1.5478260869565, 0.30652173913044, 0.022727272727273
79869, 1.5913043478261, 0.30652173913044, 0.47727272727273
79870, 1.5695652173913, 0.30652173913044, 0.45454545454545
79871, 1.5913043478261, 0.33260869565217, 0.45454545454545
79872, 1.5913043478261, 0.30652173913043, 0.43181818181818
79873, 1.5695652173913, 0.30652173913043, 0.40909090909091
79874, 1.5913043478261, 0.33260869565217, 0.40909090909091
79875, 1.5913043478261, 0.30652173913043, 0.38636363636364
79876, 1.5695652173913, 0.30652173913044, 0.36363636363636
79877, 1.5913043478261, 0.33260869565217, 0.36363636363636
79878, 1.5913043478261, 0.30652173913043, 0.34090909090909
79879, 1.5695652173913, 0.30652173913044, 0.31818181818182
79880, 1.5913043478261, 0.33260869565217, 0.31818181818182
79881, 1.5913043478261, 0.30652173913043, 0.29545454545455
79882, 1.5695652173913, 0.30652173913043, 0.27272727272727
79883, 1.5913043478261, 0.33260869565217, 0.27272727272727
79884, 1.5913043478261, 0.30652173913043, 0.25
79885, 1.5695652173913, 0.30652173913044, 0.22727272727273
79886, 1.5913043478261, 0.33260869565217, 0.22727272727273
79887, 1.5913043478261, 0.30652173913043, 0.20454545454545
79888, 1.5695652173913, 0.30652173913043, 0.18181818181818
79889, 1.5913043478261, 0.33260869565217, 0.18181818181818
79890, 1.5913043478261, 0.30652173913043, 0.15909090909091
79891, 1.5695652173913, 0.30652173913043, 0.13636363636364
79892, 1.5913043478261, 0.33260869565217, 0.13636363636364
79893, 1.5913043478261, 0.30652173913043, 0.11363636363636
79894, 1.5695652173913, 0.30652173913043, 0.090909090909091
79895, 1.5913043478261, 0.33260869565217, 0.090909090909091
79896, 1.5913043478261, 0.30652173913043, 0.068181818181818
79897, 1.5695652173913, 0.30652173913043, 0.045454545454545
79898, 1.5913043478261, 0.33260869565217, 0.045454545454545
79899, 1.5913043478261, 0.30652173913043, 0.022727272727273
79900, 1.6347826086957, 0.30652173913043, 0.47727272727273
79901, 1.6130434782609, 0.30652173913043, 0.45454545454545
79902, 1.6347826086957, 0.33260869565217, 0.45454545454545
79903, 1.6347826086957, 0.30652173913043, 0.43181818181818
79904, 1.6130434782609, 0.30652173913043, 0.40909090909091
79905, 1.6347826086957, 0.33260869565217, 0.40909090909091
79906, 1.6347826086957, 0.30652173913043, 0.38636363636364
79907, 1.6130434782609, 0.30652173913043, 0.36363636363636
79908, 1.6347826086957, 0.33260869565217, 0.36363636363636
79909, 1.6347826086957, 0.30652173913043, 0.34090909090909
79910, 1.6130434782609, 0.30652173913043, 0.31818181818182
79911, 1.6347826086957, 0.33260869565217, 0.31818181818182
79912, 1.6347826086957, 0.30652173913043, 0.29545454545455
79913, 1.6130434782609, 0.30652173913043, 0.27272727272727
79914, 1.6347826086957, 0.33260869565217, 0.27272727272727
79915, 1.6347826086957, 0.30652173913043, 0.25
79916, 1.6130434782609, 0.30652173913043, 0.22727272727273
79917, 1.6347826086957, 0.33260869565217, 0.22727272727273
79918, 1.6347826086957, 0.30652173913043, 0.20454545454545
79919, 1.6130434782609, 0.30652173913043, 0.18181818181818
79920, 1.6347826086957, 0.33260869565217, 0.18181818181818
79921, 1.6347826086957, 0.30652173913043, 0.15909090909091
79922, 1.6130434782609, 0.30652173913043, 0.13636363636364
79923, 1.6347826086957, 0.33260869565217, 0.13636363636364
79924, 1.6347826086957, 0.30652173913043, 0.11363636363636
79925, 1.6130434782609, 0.30652173913043, 0.090909090909091
79926, 1.6347826086957, 0.33260869565217, 0.090909090909091
79927, 1.6347826086957, 0.30652173913043, 0.068181818181818
79928, 1.6130434782609, 0.30652173913043, 0.045454545454545
79929, 1.6347826086957, 0.33260869565217, 0.045454545454545
79930, 1.6347826086957, 0.30652173913043, 0.022727272727273
79931, 1.6782608695652, 0.30652173913043, 0.47727272727273
79932, 1.6565217391304, 0.30652173913043, 0.45454545454545
79933, 1.6782608695652, 0.33260869565217, 0.45454545454545
79934, 1.6782608695652, 0.30652173913043, 0.43181818181818
79935, 1.6565217391304, 0.30652173913043, 0.40909090909091
79936, 1.6782608695652, 0.33260869565217, 0.40909090909091
79937, 1.6782608695652, 0.30652173913043, 0.38636363636364
79938, 1.6565217391304, 0.30652173913043, 0.36363636363636
79939, 1.6782608695652, 0.33260869565217, 0.36363636363636
79940, 1.6782608695652, 0.30652173913043, 0.34090909090909
79941, 1.6565217391304, 0.30652173913043, 0.31818181818182
79942, 1.6782608695652, 0.33260869565217, 0.31818181818182
79943, 1.6782608695652, 0.30652173913043, 0.29545454545455
79944, 1.6565217391304, 0.30652173913043, 0.27272727272727
79945, 1.6782608695652, 0.33260869565217, 0.27272727272727
79946, 1.6782608695652, 0.30652173913043, 0.25
79947, 1.6565217391304, 0.30652173913043, 0.22727272727273
79948, 1.6782608695652, 0.33260869565217, 0.22727272727273
79949, 1.6782608695652, 0.30652173913043, 0.20454545454545
79950, 1.6565217391304, 0.30652173913043, 0.18181818181818
79951, 1.6782608695652, 0.33260869565217, 0.18181818181818
79952, 1.6782608695652, 0.30652173913043, 0.15909090909091
79953, 1.6565217391304, 0.30652173913043, 0.13636363636364
79954, 1.6782608695652, 0.33260869565217, 0.13636363636364
79955, 1.6782608695652, 0.30652173913043, 0.11363636363636
79956, 1.6565217391304, 0.30652173913043, 0.090909090909091
79957, 1.6782608695652, 0.33260869565217, 0.090909090909091
79958, 1.6782608695652, 0.30652173913043, 0.068181818181818
79959, 1.6565217391304, 0.30652173913043, 0.045454545454545
79960, 1.6782608695652, 0.33260869565217, 0.045454545454545
79961, 1.6782608695652, 0.30652173913043, 0.022727272727273
79962, 1.7217391304348, 0.30652173913043, 0.47727272727273
79963, 1.7, 0.30652173913043, 0.45454545454545
79964, 1.7217391304348, 0.33260869565217, 0.45454545454545
79965, 1.7217391304348, 0.30652173913043, 0.43181818181818
79966, 1.7, 0.30652173913043, 0.40909090909091
79967, 1.7217391304348, 0.33260869565217, 0.40909090909091
79968, 1.7217391304348, 0.30652173913043, 0.38636363636364
79969, 1.7, 0.30652173913043, 0.36363636363636
79970, 1.7217391304348, 0.33260869565217, 0.36363636363636
79971, 1.7217391304348, 0.30652173913043, 0.34090909090909
79972, 1.7, 0.30652173913043, 0.31818181818182
79973, 1.7217391304348, 0.33260869565217, 0.31818181818182
79974, 1.7217391304348, 0.30652173913043, 0.29545454545455
79975, 1.7, 0.30652173913043, 0.27272727272727
79976, 1.7217391304348, 0.33260869565217, 0.27272727272727
79977, 1.7217391304348, 0.30652173913043, 0.25
79978, 1.7, 0.30652173913043, 0.22727272727273
79979, 1.7217391304348, 0.33260869565217, 0.22727272727273
79980, 1.7217391304348, 0.30652173913043, 0.20454545454545
79981, 1.7, 0.30652173913043, 0.18181818181818
79982, 1.7217391304348, 0.33260869565217, 0.18181818181818
79983, 1.7217391304348, 0.30652173913043, 0.15909090909091
79984, 1.7, 0.30652173913043, 0.13636363636364
79985, 1.7217391304348, 0.33260869565217, 0.13636363636364
79986, 1.7217391304348, 0.30652173913043, 0.11363636363636
79987, 1.7, 0.30652173913043, 0.090909090909091
79988, 1.7217391304348, 0.33260869565217, 0.090909090909091
79989, 1.7217391304348, 0.30652173913043, 0.068181818181818
79990, 1.7, 0.30652173913043, 0.045454545454545
79991, 1.7217391304348, 0.33260869565217, 0.045454545454545
79992, 1.7217391304348, 0.30652173913043, 0.022727272727273
79993, 1.7652173913043, 0.30652173913043, 0.47727272727273
79994, 1.7434782608696, 0.30652173913043, 0.45454545454545
79995, 1.7652173913043, 0.33260869565217, 0.45454545454545
79996, 1.7652173913043, 0.30652173913043, 0.43181818181818
79997, 1.7434782608696, 0.30652173913043, 0.40909090909091
79998, 1.7652173913043, 0.33260869565217, 0.40909090909091
79999, 1.7652173913043, 0.30652173913043, 0.38636363636364
80000, 1.7434782608696, 0.30652173913043, 0.36363636363636
80001, 1.7652173913043, 0.33260869565217, 0.36363636363636
80002, 1.7652173913043, 0.30652173913043, 0.34090909090909
80003, 1.7434782608696, 0.30652173913043, 0.31818181818182
80004, 1.7652173913043, 0.33260869565217, 0.31818181818182
80005, 1.7652173913043, 0.30652173913043, 0.29545454545455
80006, 1.7434782608696, 0.30652173913043, 0.27272727272727
80007, 1.7652173913043, 0.33260869565217, 0.27272727272727
80008, 1.7652173913043, 0.30652173913043, 0.25
80009, 1.7434782608696, 0.30652173913043, 0.22727272727273
80010, 1.7652173913043, 0.33260869565217, 0.22727272727273
80011, 1.7652173913043, 0.30652173913043, 0.20454545454545
80012, 1.7434782608696, 0.30652173913043, 0.18181818181818
80013, 1.7652173913043, 0.33260869565217, 0.18181818181818
80014, 1.7652173913043, 0.30652173913043, 0.15909090909091
80015, 1.7434782608696, 0.30652173913043, 0.13636363636364
80016, 1.7652173913043, 0.33260869565217, 0.13636363636364
80017, 1.7652173913043, 0.30652173913043, 0.11363636363636
80018, 1.7434782608696, 0.30652173913043, 0.090909090909091
80019, 1.7652173913043, 0.33260869565217, 0.090909090909091
80020, 1.7652173913043, 0.30652173913043, 0.068181818181818
80021, 1.7434782608696, 0.30652173913043, 0.045454545454545
80022, 1.7652173913043, 0.33260869565217, 0.045454545454545
80023, 1.7652173913043, 0.30652173913043, 0.022727272727273
80024, 1.8086956521739, 0.30652173913044, 0.47727272727273
80025, 1.7869565217391, 0.30652173913044, 0.45454545454545
80026, 1.8086956521739, 0.33260869565217, 0.45454545454545
80027, 1.8086956521739, 0.30652173913044, 0.43181818181818
80028, 1.7869565217391, 0.30652173913043, 0.40909090909091
80029, 1.8086956521739, 0.33260869565217, 0.40909090909091
80030, 1.8086956521739, 0.30652173913044, 0.38636363636364
80031, 1.7869565217391, 0.30652173913043, 0.36363636363636
80032, 1.8086956521739, 0.33260869565217, 0.36363636363636
80033, 1.8086956521739, 0.30652173913044, 0.34090909090909
80034, 1.7869565217391, 0.30652173913043, 0.31818181818182
80035, 1.8086956521739, 0.33260869565217, 0.31818181818182
80036, 1.8086956521739, 0.30652173913044, 0.29545454545455
80037, 1.7869565217391, 0.30652173913043, 0.27272727272727
80038, 1.8086956521739, 0.33260869565217, 0.27272727272727
80039, 1.8086956521739, 0.30652173913044, 0.25
80040, 1.7869565217391, 0.30652173913043, 0.22727272727273
80041, 1.8086956521739, 0.33260869565217, 0.22727272727273
80042, 1.8086956521739, 0.30652173913044, 0.20454545454545
80043, 1.7869565217391, 0.30652173913043, 0.18181818181818
80044, 1.8086956521739, 0.33260869565217, 0.18181818181818
80045, 1.8086956521739, 0.30652173913044, 0.15909090909091
80046, 1.7869565217391, 0.30652173913043, 0.13636363636364
80047, 1.8086956521739, 0.33260869565217, 0.13636363636364
80048, 1.8086956521739, 0.30652173913044, 0.11363636363636
80049, 1.7869565217391, 0.30652173913043, 0.090909090909091
80050, 1.8086956521739, 0.33260869565217, 0.090909090909091
80051, 1.8086956521739, 0.30652173913044, 0.068181818181818
80052, 1.7869565217391, 0.30652173913043, 0.045454545454545
80053, 1.8086956521739, 0.33260869565217, 0.045454545454545
80054, 1.8086956521739, 0.30652173913044, 0.022727272727273
80055, 1.8521739130435, 0.30652173913043, 0.47727272727273
80056, 1.8304347826087, 0.30652173913043, 0.45454545454545
80057, 1.8521739130435, 0.33260869565217, 0.45454545454545
80058, 1.8521739130435, 0.30652173913043, 0.43181818181818
80059, 1.8304347826087, 0.30652173913043, 0.40909090909091
80060, 1.8521739130435, 0.33260869565217, 0.40909090909091
80061, 1.8521739130435, 0.30652173913043, 0.38636363636364
80062, 1.8304347826087, 0.30652173913043, 0.36363636363636
80063, 1.8521739130435, 0.33260869565217, 0.36363636363636
80064, 1.8521739130435, 0.30652173913043, 0.34090909090909
80065, 1.8304347826087, 0.30652173913043, 0.31818181818182
80066, 1.8521739130435, 0.33260869565217, 0.31818181818182
80067, 1.8521739130435, 0.30652173913043, 0.29545454545455
80068, 1.8304347826087, 0.30652173913043, 0.27272727272727
80069, 1.8521739130435, 0.33260869565217, 0.27272727272727
80070, 1.8521739130435, 0.30652173913043, 0.25
80071, 1.8304347826087, 0.30652173913043, 0.22727272727273
80072, 1.8521739130435, 0.33260869565217, 0.22727272727273
80073, 1.8521739130435, 0.30652173913043, 0.20454545454545
80074, 1.8304347826087, 0.30652173913043, 0.18181818181818
80075, 1.8521739130435, 0.33260869565217, 0.18181818181818
80076, 1.8521739130435, 0.30652173913043, 0.15909090909091
80077, 1.8304347826087, 0.30652173913043, 0.13636363636364
80078, 1.8521739130435, 0.33260869565217, 0.13636363636364
80079, 1.8521739130435, 0.30652173913043, 0.11363636363636
80080, 1.8304347826087, 0.30652173913043, 0.090909090909091
80081, 1.8521739130435, 0.33260869565217, 0.090909090909091
80082, 1.8521739130435, 0.30652173913043, 0.068181818181818
80083, 1.8304347826087, 0.30652173913043, 0.045454545454545
80084, 1.8521739130435, 0.33260869565217, 0.045454545454545
80085, 1.8521739130435, 0.30652173913043, 0.022727272727273
80086, 1.895652173913, 0.30652173913044, 0.47727272727273
80087, 1.8739130434783, 0.30652173913043, 0.45454545454545
80088, 1.895652173913, 0.33260869565217, 0.45454545454545
80089, 1.895652173913, 0.30652173913043, 0.43181818181818
80090, 1.8739130434783, 0.30652173913043, 0.40909090909091
80091, 1.895652173913, 0.33260869565217, 0.40909090909091
80092, 1.895652173913, 0.30652173913043, 0.38636363636364
80093, 1.8739130434783, 0.30652173913043, 0.36363636363636
80094, 1.895652173913, 0.33260869565217, 0.36363636363636
80095, 1.895652173913, 0.30652173913043, 0.34090909090909
80096, 1.8739130434783, 0.30652173913043, 0.31818181818182
80097, 1.895652173913, 0.33260869565217, 0.31818181818182
80098, 1.895652173913, 0.30652173913043, 0.29545454545455
80099, 1.8739130434783, 0.30652173913043, 0.27272727272727
80100, 1.895652173913, 0.33260869565217, 0.27272727272727
80101, 1.895652173913, 0.30652173913043, 0.25
80102, 1.8739130434783, 0.30652173913043, 0.22727272727273
80103, 1.895652173913, 0.33260869565217, 0.22727272727273
80104, 1.895652173913, 0.30652173913043, 0.20454545454545
80105, 1.8739130434783, 0.30652173913043, 0.18181818181818
80106, 1.895652173913, 0.33260869565217, 0.18181818181818
80107, 1.895652173913, 0.30652173913043, 0.15909090909091
80108, 1.8739130434783, 0.30652173913043, 0.13636363636364
80109, 1.895652173913, 0.33260869565217, 0.13636363636364
80110, 1.895652173913, 0.30652173913043, 0.11363636363636
80111, 1.8739130434783, 0.30652173913043, 0.090909090909091
80112, 1.895652173913, 0.33260869565217, 0.090909090909091
80113, 1.895652173913, 0.30652173913043, 0.068181818181818
80114, 1.8739130434783, 0.30652173913043, 0.045454545454545
80115, 1.895652173913, 0.33260869565217, 0.045454545454545
80116, 1.895652173913, 0.30652173913044, 0.022727272727273
80117, 1.9391304347826, 0.30652173913043, 0.47727272727273
80118, 1.9173913043478, 0.30652173913043, 0.45454545454545
80119, 1.9391304347826, 0.33260869565217, 0.45454545454545
80120, 1.9391304347826, 0.30652173913043, 0.43181818181818
80121, 1.9173913043478, 0.30652173913043, 0.40909090909091
80122, 1.9391304347826, 0.33260869565217, 0.40909090909091
80123, 1.9391304347826, 0.30652173913043, 0.38636363636364
80124, 1.9173913043478, 0.30652173913043, 0.36363636363636
80125, 1.9391304347826, 0.33260869565217, 0.36363636363636
80126, 1.9391304347826, 0.30652173913043, 0.34090909090909
80127, 1.9173913043478, 0.30652173913043, 0.31818181818182
80128, 1.9391304347826, 0.33260869565217, 0.31818181818182
80129, 1.9391304347826, 0.30652173913043, 0.29545454545455
80130, 1.9173913043478, 0.30652173913043, 0.27272727272727
80131, 1.9391304347826, 0.33260869565217, 0.27272727272727
80132, 1.9391304347826, 0.30652173913043, 0.25
80133, 1.9173913043478, 0.30652173913043, 0.22727272727273
80134, 1.9391304347826, 0.33260869565217, 0.22727272727273
80135, 1.9391304347826, 0.30652173913043, 0.20454545454545
80136, 1.9173913043478, 0.30652173913043, 0.18181818181818
80137, 1.9391304347826, 0.33260869565217, 0.18181818181818
80138, 1.9391304347826, 0.30652173913043, 0.15909090909091
80139, 1.9173913043478, 0.30652173913043, 0.13636363636364
80140, 1.9391304347826, 0.33260869565217, 0.13636363636364
80141, 1.9391304347826, 0.30652173913043, 0.11363636363636
80142, 1.9173913043478, 0.30652173913043, 0.090909090909091
80143, 1.9391304347826, 0.33260869565217, 0.090909090909091
80144, 1.9391304347826, 0.30652173913043, 0.068181818181818
80145, 1.9173913043478, 0.30652173913043, 0.045454545454545
80146, 1.9391304347826, 0.33260869565217, 0.045454545454545
80147, 1.9391304347826, 0.30652173913043, 0.022727272727273
80148, 1.9826086956522, 0.30652173913044, 0.47727272727273
80149, 1.9608695652174, 0.30652173913044, 0.45454545454545
80150, 1.9826086956522, 0.33260869565217, 0.45454545454545
80151, 1.9826086956522, 0.30652173913044, 0.43181818181818
80152, 1.9608695652174, 0.30652173913043, 0.40909090909091
80153, 1.9826086956522, 0.33260869565217, 0.40909090909091
80154, 1.9826086956522, 0.30652173913044, 0.38636363636364
80155, 1.9608695652174, 0.30652173913044, 0.36363636363636
80156, 1.9826086956522, 0.33260869565217, 0.36363636363636
80157, 1.9826086956522, 0.30652173913044, 0.34090909090909
80158, 1.9608695652174, 0.30652173913043, 0.31818181818182
80159, 1.9826086956522, 0.33260869565217, 0.31818181818182
80160, 1.9826086956522, 0.30652173913044, 0.29545454545455
80161, 1.9608695652174, 0.30652173913043, 0.27272727272727
80162, 1.9826086956522, 0.33260869565217, 0.27272727272727
80163, 1.9826086956522, 0.30652173913044, 0.25
80164, 1.9608695652174, 0.30652173913043, 0.22727272727273
80165, 1.9826086956522, 0.33260869565217, 0.22727272727273
80166, 1.9826086956522, 0.30652173913044, 0.20454545454545
80167, 1.9608695652174, 0.30652173913043, 0.18181818181818
80168, 1.9826086956522, 0.33260869565217, 0.18181818181818
80169, 1.9826086956522, 0.30652173913044, 0.15909090909091
80170, 1.9608695652174, 0.30652173913043, 0.13636363636364
80171, 1.9826086956522, 0.33260869565217, 0.13636363636364
80172, 1.9826086956522, 0.30652173913044, 0.11363636363636
80173, 1.9608695652174, 0.30652173913043, 0.090909090909091
80174, 1.9826086956522, 0.33260869565217, 0.090909090909091
80175, 1.9826086956522, 0.30652173913044, 0.068181818181818
80176, 1.9608695652174, 0.30652173913043, 0.045454545454545
80177, 1.9826086956522, 0.33260869565217, 0.045454545454545
80178, 1.9826086956522, 0.30652173913044, 0.022727272727273
80179, 2.0260869565217, 0.30652173913044, 0.47727272727273
80180, 2.004347826087, 0.30652173913044, 0.45454545454545
80181, 2.0260869565217, 0.33260869565217, 0.45454545454545
80182, 2.0260869565217, 0.30652173913044, 0.43181818181818
80183, 2.004347826087, 0.30652173913044, 0.40909090909091
80184, 2.0260869565217, 0.33260869565217, 0.40909090909091
80185, 2.0260869565217, 0.30652173913044, 0.38636363636364
80186, 2.004347826087, 0.30652173913044, 0.36363636363636
80187, 2.0260869565217, 0.33260869565217, 0.36363636363636
80188, 2.0260869565217, 0.30652173913044, 0.34090909090909
80189, 2.004347826087, 0.30652173913044, 0.31818181818182
80190, 2.0260869565217, 0.33260869565217, 0.31818181818182
80191, 2.0260869565217, 0.30652173913044, 0.29545454545455
80192, 2.004347826087, 0.30652173913044, 0.27272727272727
80193, 2.0260869565217, 0.33260869565217, 0.27272727272727
80194, 2.0260869565217, 0.30652173913044, 0.25
80195, 2.004347826087, 0.30652173913044, 0.22727272727273
80196, 2.0260869565217, 0.33260869565217, 0.22727272727273
80197, 2.0260869565217, 0.30652173913044, 0.20454545454545
80198, 2.004347826087, 0.30652173913044, 0.18181818181818
80199, 2.0260869565217, 0.33260869565217, 0.18181818181818
80200, 2.0260869565217, 0.30652173913044, 0.15909090909091
80201, 2.004347826087, 0.30652173913044, 0.13636363636364
80202, 2.0260869565217, 0.33260869565217, 0.13636363636364
80203, 2.0260869565217, 0.30652173913044, 0.11363636363636
80204, 2.004347826087, 0.30652173913044, 0.090909090909091
80205, 2.0260869565217, 0.33260869565217, 0.090909090909091
80206, 2.0260869565217, 0.30652173913044, 0.068181818181818
80207, 2.004347826087, 0.30652173913044, 0.045454545454545
80208, 2.0260869565217, 0.33260869565217, 0.045454545454545
80209, 2.0260869565217, 0.30652173913044, 0.022727272727273
80210, 2.0695652173913, 0.30652173913043, 0.47727272727273
80211, 2.0478260869565, 0.30652173913044, 0.45454545454545
80212, 2.0695652173913, 0.33260869565217, 0.45454545454545
80213, 2.0695652173913, 0.30652173913043, 0.43181818181818
80214, 2.0478260869565, 0.30652173913043, 0.40909090909091
80215, 2.0695652173913, 0.33260869565217, 0.40909090909091
80216, 2.0695652173913, 0.30652173913043, 0.38636363636364
80217, 2.0478260869565, 0.30652173913043, 0.36363636363636
80218, 2.0695652173913, 0.33260869565217, 0.36363636363636
80219, 2.0695652173913, 0.30652173913043, 0.34090909090909
80220, 2.0478260869565, 0.30652173913043, 0.31818181818182
80221, 2.0695652173913, 0.33260869565217, 0.31818181818182
80222, 2.0695652173913, 0.30652173913043, 0.29545454545455
80223, 2.0478260869565, 0.30652173913043, 0.27272727272727
80224, 2.0695652173913, 0.33260869565217, 0.27272727272727
80225, 2.0695652173913, 0.30652173913043, 0.25
80226, 2.0478260869565, 0.30652173913043, 0.22727272727273
80227, 2.0695652173913, 0.33260869565217, 0.22727272727273
80228, 2.0695652173913, 0.30652173913043, 0.20454545454545
80229, 2.0478260869565, 0.30652173913043, 0.18181818181818
80230, 2.0695652173913, 0.33260869565217, 0.18181818181818
80231, 2.0695652173913, 0.30652173913043, 0.15909090909091
80232, 2.0478260869565, 0.30652173913043, 0.13636363636364
80233, 2.0695652173913, 0.33260869565217, 0.13636363636364
80234, 2.0695652173913, 0.30652173913043, 0.11363636363636
80235, 2.0478260869565, 0.30652173913043, 0.090909090909091
80236, 2.0695652173913, 0.33260869565217, 0.090909090909091
80237, 2.0695652173913, 0.30652173913043, 0.068181818181818
80238, 2.0478260869565, 0.30652173913043, 0.045454545454545
80239, 2.0695652173913, 0.33260869565217, 0.045454545454545
80240, 2.0695652173913, 0.30652173913043, 0.022727272727273
80241, 2.1130434782609, 0.30652173913043, 0.47727272727273
80242, 2.0913043478261, 0.30652173913043, 0.45454545454545
80243, 2.1130434782609, 0.33260869565217, 0.45454545454545
80244, 2.1130434782609, 0.30652173913043, 0.43181818181818
80245, 2.0913043478261, 0.30652173913043, 0.40909090909091
80246, 2.1130434782609, 0.33260869565217, 0.40909090909091
80247, 2.1130434782609, 0.30652173913043, 0.38636363636364
80248, 2.0913043478261, 0.30652173913043, 0.36363636363636
80249, 2.1130434782609, 0.33260869565217, 0.36363636363636
80250, 2.1130434782609, 0.30652173913043, 0.34090909090909
80251, 2.0913043478261, 0.30652173913043, 0.31818181818182
80252, 2.1130434782609, 0.33260869565217, 0.31818181818182
80253, 2.1130434782609, 0.30652173913043, 0.29545454545455
80254, 2.0913043478261, 0.30652173913043, 0.27272727272727
80255, 2.1130434782609, 0.33260869565217, 0.27272727272727
80256, 2.1130434782609, 0.30652173913043, 0.25
80257, 2.0913043478261, 0.30652173913043, 0.22727272727273
80258, 2.1130434782609, 0.33260869565217, 0.22727272727273
80259, 2.1130434782609, 0.30652173913043, 0.20454545454545
80260, 2.0913043478261, 0.30652173913043, 0.18181818181818
80261, 2.1130434782609, 0.33260869565217, 0.18181818181818
80262, 2.1130434782609, 0.30652173913043, 0.15909090909091
80263, 2.0913043478261, 0.30652173913043, 0.13636363636364
80264, 2.1130434782609, 0.33260869565217, 0.13636363636364
80265, 2.1130434782609, 0.30652173913043, 0.11363636363636
80266, 2.0913043478261, 0.30652173913043, 0.090909090909091
80267, 2.1130434782609, 0.33260869565217, 0.090909090909091
80268, 2.1130434782609, 0.30652173913043, 0.068181818181818
80269, 2.0913043478261, 0.30652173913043, 0.045454545454545
80270, 2.1130434782609, 0.33260869565217, 0.045454545454545
80271, 2.1130434782609, 0.30652173913043, 0.022727272727273
80272, 2.1565217391304, 0.30652173913043, 0.47727272727273
80273, 2.1347826086957, 0.30652173913043, 0.45454545454545
80274, 2.1565217391304, 0.33260869565217, 0.45454545454545
80275, 2.1565217391304, 0.30652173913043, 0.43181818181818
80276, 2.1347826086957, 0.30652173913043, 0.40909090909091
80277, 2.1565217391304, 0.33260869565217, 0.40909090909091
80278, 2.1565217391304, 0.30652173913043, 0.38636363636364
80279, 2.1347826086957, 0.30652173913043, 0.36363636363636
80280, 2.1565217391304, 0.33260869565217, 0.36363636363636
80281, 2.1565217391304, 0.30652173913043, 0.34090909090909
80282, 2.1347826086957, 0.30652173913043, 0.31818181818182
80283, 2.1565217391304, 0.33260869565217, 0.31818181818182
80284, 2.1565217391304, 0.30652173913043, 0.29545454545455
80285, 2.1347826086957, 0.30652173913043, 0.27272727272727
80286, 2.1565217391304, 0.33260869565217, 0.27272727272727
80287, 2.1565217391304, 0.30652173913043, 0.25
80288, 2.1347826086957, 0.30652173913043, 0.22727272727273
80289, 2.1565217391304, 0.33260869565217, 0.22727272727273
80290, 2.1565217391304, 0.30652173913043, 0.20454545454545
80291, 2.1347826086957, 0.30652173913043, 0.18181818181818
80292, 2.1565217391304, 0.33260869565217, 0.18181818181818
80293, 2.1565217391304, 0.30652173913043, 0.15909090909091
80294, 2.1347826086957, 0.30652173913043, 0.13636363636364
80295, 2.1565217391304, 0.33260869565217, 0.13636363636364
80296, 2.1565217391304, 0.30652173913043, 0.11363636363636
80297, 2.1347826086957, 0.30652173913043, 0.090909090909091
80298, 2.1565217391304, 0.33260869565217, 0.090909090909091
80299, 2.1565217391304, 0.30652173913043, 0.068181818181818
80300, 2.1347826086957, 0.30652173913043, 0.045454545454545
80301, 2.1565217391304, 0.33260869565217, 0.045454545454545
80302, 2.1565217391304, 0.30652173913043, 0.022727272727273
80303, 2.1782608695652, 0.30652173913043, 0.45454545454545
80304, 2.1782608695652, 0.30652173913043, 0.40909090909091
80305, 2.1782608695652, 0.30652173913043, 0.36363636363636
80306, 2.1782608695652, 0.30652173913043, 0.31818181818182
80307, 2.1782608695652, 0.30652173913043, 0.27272727272727
80308, 2.1782608695652, 0.30652173913043, 0.22727272727273
80309, 2.1782608695652, 0.30652173913043, 0.18181818181818
80310, 2.1782608695652, 0.30652173913043, 0.13636363636364
80311, 2.1782608695652, 0.30652173913043, 0.090909090909091
80312, 2.1782608695652, 0.30652173913043, 0.045454545454545
80313, 1.2434782608696, 0.25434782608696, 0.47727272727273
80314, 1.2217391304348, 0.25434782608696, 0.45454545454545
80315, 1.2434782608696, 0.2804347826087, 0.45454545454545
80316, 1.2434782608696, 0.25434782608696, 0.43181818181818
80317, 1.2217391304348, 0.25434782608696, 0.40909090909091
80318, 1.2434782608696, 0.2804347826087, 0.40909090909091
80319, 1.2434782608696, 0.25434782608696, 0.38636363636364
80320, 1.2217391304348, 0.25434782608696, 0.36363636363636
80321, 1.2434782608696, 0.2804347826087, 0.36363636363636
80322, 1.2434782608696, 0.25434782608696, 0.34090909090909
80323, 1.2217391304348, 0.25434782608696, 0.31818181818182
80324, 1.2434782608696, 0.2804347826087, 0.31818181818182
80325, 1.2434782608696, 0.25434782608696, 0.29545454545455
80326, 1.2217391304348, 0.25434782608696, 0.27272727272727
80327, 1.2434782608696, 0.2804347826087, 0.27272727272727
80328, 1.2434782608696, 0.25434782608696, 0.25
80329, 1.2217391304348, 0.25434782608696, 0.22727272727273
80330, 1.2434782608696, 0.2804347826087, 0.22727272727273
80331, 1.2434782608696, 0.25434782608696, 0.20454545454545
80332, 1.2217391304348, 0.25434782608696, 0.18181818181818
80333, 1.2434782608696, 0.2804347826087, 0.18181818181818
80334, 1.2434782608696, 0.25434782608696, 0.15909090909091
80335, 1.2217391304348, 0.25434782608696, 0.13636363636364
80336, 1.2434782608696, 0.2804347826087, 0.13636363636364
80337, 1.2434782608696, 0.25434782608696, 0.11363636363636
80338, 1.2217391304348, 0.25434782608696, 0.090909090909091
80339, 1.2434782608696, 0.2804347826087, 0.090909090909091
80340, 1.2434782608696, 0.25434782608696, 0.068181818181818
80341, 1.2217391304348, 0.25434782608696, 0.045454545454545
80342, 1.2434782608696, 0.2804347826087, 0.045454545454545
80343, 1.2434782608696, 0.25434782608696, 0.022727272727273
80344, 1.2869565217391, 0.25434782608696, 0.47727272727273
80345, 1.2652173913043, 0.25434782608696, 0.45454545454545
80346, 1.2869565217391, 0.2804347826087, 0.45454545454545
80347, 1.2869565217391, 0.25434782608696, 0.43181818181818
80348, 1.2652173913043, 0.25434782608696, 0.40909090909091
80349, 1.2869565217391, 0.2804347826087, 0.40909090909091
80350, 1.2869565217391, 0.25434782608696, 0.38636363636364
80351, 1.2652173913043, 0.25434782608696, 0.36363636363636
80352, 1.2869565217391, 0.2804347826087, 0.36363636363636
80353, 1.2869565217391, 0.25434782608696, 0.34090909090909
80354, 1.2652173913043, 0.25434782608696, 0.31818181818182
80355, 1.2869565217391, 0.2804347826087, 0.31818181818182
80356, 1.2869565217391, 0.25434782608696, 0.29545454545455
80357, 1.2652173913043, 0.25434782608696, 0.27272727272727
80358, 1.2869565217391, 0.2804347826087, 0.27272727272727
80359, 1.2869565217391, 0.25434782608696, 0.25
80360, 1.2652173913043, 0.25434782608696, 0.22727272727273
80361, 1.2869565217391, 0.2804347826087, 0.22727272727273
80362, 1.2869565217391, 0.25434782608696, 0.20454545454545
80363, 1.2652173913043, 0.25434782608696, 0.18181818181818
80364, 1.2869565217391, 0.2804347826087, 0.18181818181818
80365, 1.2869565217391, 0.25434782608696, 0.15909090909091
80366, 1.2652173913043, 0.25434782608696, 0.13636363636364
80367, 1.2869565217391, 0.2804347826087, 0.13636363636364
80368, 1.2869565217391, 0.25434782608696, 0.11363636363636
80369, 1.2652173913043, 0.25434782608696, 0.090909090909091
80370, 1.2869565217391, 0.2804347826087, 0.090909090909091
80371, 1.2869565217391, 0.25434782608696, 0.068181818181818
80372, 1.2652173913043, 0.25434782608696, 0.045454545454545
80373, 1.2869565217391, 0.2804347826087, 0.045454545454545
80374, 1.2869565217391, 0.25434782608696, 0.022727272727273
80375, 1.3304347826087, 0.25434782608696, 0.47727272727273
80376, 1.3086956521739, 0.25434782608696, 0.45454545454545
80377, 1.3304347826087, 0.2804347826087, 0.45454545454545
80378, 1.3304347826087, 0.25434782608696, 0.43181818181818
80379, 1.3086956521739, 0.25434782608696, 0.40909090909091
80380, 1.3304347826087, 0.2804347826087, 0.40909090909091
80381, 1.3304347826087, 0.25434782608696, 0.38636363636364
80382, 1.3086956521739, 0.25434782608696, 0.36363636363636
80383, 1.3304347826087, 0.2804347826087, 0.36363636363636
80384, 1.3304347826087, 0.25434782608696, 0.34090909090909
80385, 1.3086956521739, 0.25434782608696, 0.31818181818182
80386, 1.3304347826087, 0.2804347826087, 0.31818181818182
80387, 1.3304347826087, 0.25434782608696, 0.29545454545455
80388, 1.3086956521739, 0.25434782608696, 0.27272727272727
80389, 1.3304347826087, 0.2804347826087, 0.27272727272727
80390, 1.3304347826087, 0.25434782608696, 0.25
80391, 1.3086956521739, 0.25434782608696, 0.22727272727273
80392, 1.3304347826087, 0.2804347826087, 0.22727272727273
80393, 1.3304347826087, 0.25434782608696, 0.20454545454545
80394, 1.3086956521739, 0.25434782608696, 0.18181818181818
80395, 1.3304347826087, 0.2804347826087, 0.18181818181818
80396, 1.3304347826087, 0.25434782608696, 0.15909090909091
80397, 1.3086956521739, 0.25434782608696, 0.13636363636364
80398, 1.3304347826087, 0.2804347826087, 0.13636363636364
80399, 1.3304347826087, 0.25434782608696, 0.11363636363636
80400, 1.3086956521739, 0.25434782608696, 0.090909090909091
80401, 1.3304347826087, 0.2804347826087, 0.090909090909091
80402, 1.3304347826087, 0.25434782608696, 0.068181818181818
80403, 1.3086956521739, 0.25434782608696, 0.045454545454545
80404, 1.3304347826087, 0.2804347826087, 0.045454545454545
80405, 1.3304347826087, 0.25434782608696, 0.022727272727273
80406, 1.3739130434783, 0.25434782608696, 0.47727272727273
80407, 1.3521739130435, 0.25434782608696, 0.45454545454545
80408, 1.3739130434783, 0.2804347826087, 0.45454545454545
80409, 1.3739130434783, 0.25434782608696, 0.43181818181818
80410, 1.3521739130435, 0.25434782608696, 0.40909090909091
80411, 1.3739130434783, 0.2804347826087, 0.40909090909091
80412, 1.3739130434783, 0.25434782608696, 0.38636363636364
80413, 1.3521739130435, 0.25434782608696, 0.36363636363636
80414, 1.3739130434783, 0.2804347826087, 0.36363636363636
80415, 1.3739130434783, 0.25434782608696, 0.34090909090909
80416, 1.3521739130435, 0.25434782608696, 0.31818181818182
80417, 1.3739130434783, 0.2804347826087, 0.31818181818182
80418, 1.3739130434783, 0.25434782608696, 0.29545454545455
80419, 1.3521739130435, 0.25434782608696, 0.27272727272727
80420, 1.3739130434783, 0.2804347826087, 0.27272727272727
80421, 1.3739130434783, 0.25434782608696, 0.25
80422, 1.3521739130435, 0.25434782608696, 0.22727272727273
80423, 1.3739130434783, 0.2804347826087, 0.22727272727273
80424, 1.3739130434783, 0.25434782608696, 0.20454545454545
80425, 1.3521739130435, 0.25434782608696, 0.18181818181818
80426, 1.3739130434783, 0.2804347826087, 0.18181818181818
80427, 1.3739130434783, 0.25434782608696, 0.15909090909091
80428, 1.3521739130435, 0.25434782608696, 0.13636363636364
80429, 1.3739130434783, 0.2804347826087, 0.13636363636364
80430, 1.3739130434783, 0.25434782608696, 0.11363636363636
80431, 1.3521739130435, 0.25434782608696, 0.090909090909091
80432, 1.3739130434783, 0.2804347826087, 0.090909090909091
80433, 1.3739130434783, 0.25434782608696, 0.068181818181818
80434, 1.3521739130435, 0.25434782608696, 0.045454545454545
80435, 1.3739130434783, 0.2804347826087, 0.045454545454545
80436, 1.3739130434783, 0.25434782608696, 0.022727272727273
80437, 1.4173913043478, 0.25434782608696, 0.47727272727273
80438, 1.395652173913, 0.25434782608696, 0.45454545454545
80439, 1.4173913043478, 0.2804347826087, 0.45454545454545
80440, 1.4173913043478, 0.25434782608696, 0.43181818181818
80441, 1.395652173913, 0.25434782608696, 0.40909090909091
80442, 1.4173913043478, 0.2804347826087, 0.40909090909091
80443, 1.4173913043478, 0.25434782608696, 0.38636363636364
80444, 1.395652173913, 0.25434782608696, 0.36363636363636
80445, 1.4173913043478, 0.2804347826087, 0.36363636363636
80446, 1.4173913043478, 0.25434782608696, 0.34090909090909
80447, 1.395652173913, 0.25434782608696, 0.31818181818182
80448, 1.4173913043478, 0.2804347826087, 0.31818181818182
80449, 1.4173913043478, 0.25434782608696, 0.29545454545455
80450, 1.395652173913, 0.25434782608696, 0.27272727272727
80451, 1.4173913043478, 0.2804347826087, 0.27272727272727
80452, 1.4173913043478, 0.25434782608696, 0.25
80453, 1.395652173913, 0.25434782608696, 0.22727272727273
80454, 1.4173913043478, 0.2804347826087, 0.22727272727273
80455, 1.4173913043478, 0.25434782608696, 0.20454545454545
80456, 1.395652173913, 0.25434782608696, 0.18181818181818
80457, 1.4173913043478, 0.2804347826087, 0.18181818181818
80458, 1.4173913043478, 0.25434782608696, 0.15909090909091
80459, 1.395652173913, 0.25434782608696, 0.13636363636364
80460, 1.4173913043478, 0.2804347826087, 0.13636363636364
80461, 1.4173913043478, 0.25434782608696, 0.11363636363636
80462, 1.395652173913, 0.25434782608696, 0.090909090909091
80463, 1.4173913043478, 0.2804347826087, 0.090909090909091
80464, 1.4173913043478, 0.25434782608696, 0.068181818181818
80465, 1.395652173913, 0.25434782608696, 0.045454545454545
80466, 1.4173913043478, 0.2804347826087, 0.045454545454545
80467, 1.4173913043478, 0.25434782608696, 0.022727272727273
80468, 1.4608695652174, 0.25434782608696, 0.47727272727273
80469, 1.4391304347826, 0.25434782608696, 0.45454545454545
80470, 1.4608695652174, 0.2804347826087, 0.45454545454545
80471, 1.4608695652174, 0.25434782608696, 0.43181818181818
80472, 1.4391304347826, 0.25434782608696, 0.40909090909091
80473, 1.4608695652174, 0.2804347826087, 0.40909090909091
80474, 1.4608695652174, 0.25434782608696, 0.38636363636364
80475, 1.4391304347826, 0.25434782608696, 0.36363636363636
80476, 1.4608695652174, 0.2804347826087, 0.36363636363636
80477, 1.4608695652174, 0.25434782608696, 0.34090909090909
80478, 1.4391304347826, 0.25434782608696, 0.31818181818182
80479, 1.4608695652174, 0.2804347826087, 0.31818181818182
80480, 1.4608695652174, 0.25434782608696, 0.29545454545455
80481, 1.4391304347826, 0.25434782608696, 0.27272727272727
80482, 1.4608695652174, 0.2804347826087, 0.27272727272727
80483, 1.4608695652174, 0.25434782608696, 0.25
80484, 1.4391304347826, 0.25434782608696, 0.22727272727273
80485, 1.4608695652174, 0.2804347826087, 0.22727272727273
80486, 1.4608695652174, 0.25434782608696, 0.20454545454545
80487, 1.4391304347826, 0.25434782608696, 0.18181818181818
80488, 1.4608695652174, 0.2804347826087, 0.18181818181818
80489, 1.4608695652174, 0.25434782608696, 0.15909090909091
80490, 1.4391304347826, 0.25434782608696, 0.13636363636364
80491, 1.4608695652174, 0.2804347826087, 0.13636363636364
80492, 1.4608695652174, 0.25434782608696, 0.11363636363636
80493, 1.4391304347826, 0.25434782608696, 0.090909090909091
80494, 1.4608695652174, 0.2804347826087, 0.090909090909091
80495, 1.4608695652174, 0.25434782608696, 0.068181818181818
80496, 1.4391304347826, 0.25434782608696, 0.045454545454545
80497, 1.4608695652174, 0.2804347826087, 0.045454545454545
80498, 1.4608695652174, 0.25434782608696, 0.022727272727273
80499, 1.504347826087, 0.25434782608696, 0.47727272727273
80500, 1.4826086956522, 0.25434782608696, 0.45454545454545
80501, 1.504347826087, 0.2804347826087, 0.45454545454545
80502, 1.504347826087, 0.25434782608696, 0.43181818181818
80503, 1.4826086956522, 0.25434782608696, 0.40909090909091
80504, 1.504347826087, 0.2804347826087, 0.40909090909091
80505, 1.504347826087, 0.25434782608696, 0.38636363636364
80506, 1.4826086956522, 0.25434782608696, 0.36363636363636
80507, 1.504347826087, 0.2804347826087, 0.36363636363636
80508, 1.504347826087, 0.25434782608696, 0.34090909090909
80509, 1.4826086956522, 0.25434782608696, 0.31818181818182
80510, 1.504347826087, 0.2804347826087, 0.31818181818182
80511, 1.504347826087, 0.25434782608696, 0.29545454545455
80512, 1.4826086956522, 0.25434782608696, 0.27272727272727
80513, 1.504347826087, 0.2804347826087, 0.27272727272727
80514, 1.504347826087, 0.25434782608696, 0.25
80515, 1.4826086956522, 0.25434782608696, 0.22727272727273
80516, 1.504347826087, 0.2804347826087, 0.22727272727273
80517, 1.504347826087, 0.25434782608696, 0.20454545454545
80518, 1.4826086956522, 0.25434782608696, 0.18181818181818
80519, 1.504347826087, 0.2804347826087, 0.18181818181818
80520, 1.504347826087, 0.25434782608696, 0.15909090909091
80521, 1.4826086956522, 0.25434782608696, 0.13636363636364
80522, 1.504347826087, 0.2804347826087, 0.13636363636364
80523, 1.504347826087, 0.25434782608696, 0.11363636363636
80524, 1.4826086956522, 0.25434782608696, 0.090909090909091
80525, 1.504347826087, 0.2804347826087, 0.090909090909091
80526, 1.504347826087, 0.25434782608696, 0.068181818181818
80527, 1.4826086956522, 0.25434782608696, 0.045454545454545
80528, 1.504347826087, 0.2804347826087, 0.045454545454545
80529, 1.504347826087, 0.25434782608696, 0.022727272727273
80530, 1.5478260869565, 0.25434782608696, 0.47727272727273
80531, 1.5260869565217, 0.25434782608696, 0.45454545454545
80532, 1.5478260869565, 0.2804347826087, 0.45454545454545
80533, 1.5478260869565, 0.25434782608696, 0.43181818181818
80534, 1.5260869565217, 0.25434782608696, 0.40909090909091
80535, 1.5478260869565, 0.2804347826087, 0.40909090909091
80536, 1.5478260869565, 0.25434782608696, 0.38636363636364
80537, 1.5260869565217, 0.25434782608696, 0.36363636363636
80538, 1.5478260869565, 0.2804347826087, 0.36363636363636
80539, 1.5478260869565, 0.25434782608696, 0.34090909090909
80540, 1.5260869565217, 0.25434782608696, 0.31818181818182
80541, 1.5478260869565, 0.2804347826087, 0.31818181818182
80542, 1.5478260869565, 0.25434782608696, 0.29545454545455
80543, 1.5260869565217, 0.25434782608696, 0.27272727272727
80544, 1.5478260869565, 0.2804347826087, 0.27272727272727
80545, 1.5478260869565, 0.25434782608696, 0.25
80546, 1.5260869565217, 0.25434782608696, 0.22727272727273
80547, 1.5478260869565, 0.2804347826087, 0.22727272727273
80548, 1.5478260869565, 0.25434782608696, 0.20454545454545
80549, 1.5260869565217, 0.25434782608696, 0.18181818181818
80550, 1.5478260869565, 0.2804347826087, 0.18181818181818
80551, 1.5478260869565, 0.25434782608696, 0.15909090909091
80552, 1.5260869565217, 0.25434782608696, 0.13636363636364
80553, 1.5478260869565, 0.2804347826087, 0.13636363636364
80554, 1.5478260869565, 0.25434782608696, 0.11363636363636
80555, 1.5260869565217, 0.25434782608696, 0.090909090909091
80556, 1.5478260869565, 0.2804347826087, 0.090909090909091
80557, 1.5478260869565, 0.25434782608696, 0.068181818181818
80558, 1.5260869565217, 0.25434782608696, 0.045454545454545
80559, 1.5478260869565, 0.2804347826087, 0.045454545454545
80560, 1.5478260869565, 0.25434782608696, 0.022727272727273
80561, 1.5913043478261, 0.25434782608696, 0.47727272727273
80562, 1.5695652173913, 0.25434782608696, 0.45454545454545
80563, 1.5913043478261, 0.2804347826087, 0.45454545454545
80564, 1.5913043478261, 0.25434782608696, 0.43181818181818
80565, 1.5695652173913, 0.25434782608696, 0.40909090909091
80566, 1.5913043478261, 0.2804347826087, 0.40909090909091
80567, 1.5913043478261, 0.25434782608696, 0.38636363636364
80568, 1.5695652173913, 0.25434782608696, 0.36363636363636
80569, 1.5913043478261, 0.2804347826087, 0.36363636363636
80570, 1.5913043478261, 0.25434782608696, 0.34090909090909
80571, 1.5695652173913, 0.25434782608696, 0.31818181818182
80572, 1.5913043478261, 0.2804347826087, 0.31818181818182
80573, 1.5913043478261, 0.25434782608696, 0.29545454545455
80574, 1.5695652173913, 0.25434782608696, 0.27272727272727
80575, 1.5913043478261, 0.2804347826087, 0.27272727272727
80576, 1.5913043478261, 0.25434782608696, 0.25
80577, 1.5695652173913, 0.25434782608696, 0.22727272727273
80578, 1.5913043478261, 0.2804347826087, 0.22727272727273
80579, 1.5913043478261, 0.25434782608696, 0.20454545454545
80580, 1.5695652173913, 0.25434782608696, 0.18181818181818
80581, 1.5913043478261, 0.2804347826087, 0.18181818181818
80582, 1.5913043478261, 0.25434782608696, 0.15909090909091
80583, 1.5695652173913, 0.25434782608696, 0.13636363636364
80584, 1.5913043478261, 0.2804347826087, 0.13636363636364
80585, 1.5913043478261, 0.25434782608696, 0.11363636363636
80586, 1.5695652173913, 0.25434782608696, 0.090909090909091
80587, 1.5913043478261, 0.2804347826087, 0.090909090909091
80588, 1.5913043478261, 0.25434782608696, 0.068181818181818
80589, 1.5695652173913, 0.25434782608696, 0.045454545454545
80590, 1.5913043478261, 0.2804347826087, 0.045454545454545
80591, 1.5913043478261, 0.25434782608696, 0.022727272727273
80592, 1.6347826086957, 0.25434782608696, 0.47727272727273
80593, 1.6130434782609, 0.25434782608696, 0.45454545454545
80594, 1.6347826086957, 0.2804347826087, 0.45454545454545
80595, 1.6347826086957, 0.25434782608696, 0.43181818181818
80596, 1.6130434782609, 0.25434782608696, 0.40909090909091
80597, 1.6347826086957, 0.2804347826087, 0.40909090909091
80598, 1.6347826086957, 0.25434782608696, 0.38636363636364
80599, 1.6130434782609, 0.25434782608696, 0.36363636363636
80600, 1.6347826086957, 0.2804347826087, 0.36363636363636
80601, 1.6347826086957, 0.25434782608696, 0.34090909090909
80602, 1.6130434782609, 0.25434782608696, 0.31818181818182
80603, 1.6347826086957, 0.2804347826087, 0.31818181818182
80604, 1.6347826086957, 0.25434782608696, 0.29545454545455
80605, 1.6130434782609, 0.25434782608696, 0.27272727272727
80606, 1.6347826086957, 0.2804347826087, 0.27272727272727
80607, 1.6347826086957, 0.25434782608696, 0.25
80608, 1.6130434782609, 0.25434782608696, 0.22727272727273
80609, 1.6347826086957, 0.2804347826087, 0.22727272727273
80610, 1.6347826086957, 0.25434782608696, 0.20454545454545
80611, 1.6130434782609, 0.25434782608696, 0.18181818181818
80612, 1.6347826086957, 0.2804347826087, 0.18181818181818
80613, 1.6347826086957, 0.25434782608696, 0.15909090909091
80614, 1.6130434782609, 0.25434782608696, 0.13636363636364
80615, 1.6347826086957, 0.2804347826087, 0.13636363636364
80616, 1.6347826086957, 0.25434782608696, 0.11363636363636
80617, 1.6130434782609, 0.25434782608696, 0.090909090909091
80618, 1.6347826086957, 0.2804347826087, 0.090909090909091
80619, 1.6347826086957, 0.25434782608696, 0.068181818181818
80620, 1.6130434782609, 0.25434782608696, 0.045454545454545
80621, 1.6347826086957, 0.2804347826087, 0.045454545454545
80622, 1.6347826086957, 0.25434782608696, 0.022727272727273
80623, 1.6782608695652, 0.25434782608696, 0.47727272727273
80624, 1.6565217391304, 0.25434782608696, 0.45454545454545
80625, 1.6782608695652, 0.2804347826087, 0.45454545454545
80626, 1.6782608695652, 0.25434782608696, 0.43181818181818
80627, 1.6565217391304, 0.25434782608696, 0.40909090909091
80628, 1.6782608695652, 0.2804347826087, 0.40909090909091
80629, 1.6782608695652, 0.25434782608696, 0.38636363636364
80630, 1.6565217391304, 0.25434782608696, 0.36363636363636
80631, 1.6782608695652, 0.2804347826087, 0.36363636363636
80632, 1.6782608695652, 0.25434782608696, 0.34090909090909
80633, 1.6565217391304, 0.25434782608696, 0.31818181818182
80634, 1.6782608695652, 0.2804347826087, 0.31818181818182
80635, 1.6782608695652, 0.25434782608696, 0.29545454545455
80636, 1.6565217391304, 0.25434782608696, 0.27272727272727
80637, 1.6782608695652, 0.2804347826087, 0.27272727272727
80638, 1.6782608695652, 0.25434782608696, 0.25
80639, 1.6565217391304, 0.25434782608696, 0.22727272727273
80640, 1.6782608695652, 0.2804347826087, 0.22727272727273
80641, 1.6782608695652, 0.25434782608696, 0.20454545454545
80642, 1.6565217391304, 0.25434782608696, 0.18181818181818
80643, 1.6782608695652, 0.2804347826087, 0.18181818181818
80644, 1.6782608695652, 0.25434782608696, 0.15909090909091
80645, 1.6565217391304, 0.25434782608696, 0.13636363636364
80646, 1.6782608695652, 0.2804347826087, 0.13636363636364
80647, 1.6782608695652, 0.25434782608696, 0.11363636363636
80648, 1.6565217391304, 0.25434782608696, 0.090909090909091
80649, 1.6782608695652, 0.2804347826087, 0.090909090909091
80650, 1.6782608695652, 0.25434782608696, 0.068181818181818
80651, 1.6565217391304, 0.25434782608696, 0.045454545454545
80652, 1.6782608695652, 0.2804347826087, 0.045454545454545
80653, 1.6782608695652, 0.25434782608696, 0.022727272727273
80654, 1.7217391304348, 0.25434782608696, 0.47727272727273
80655, 1.7, 0.25434782608696, 0.45454545454545
80656, 1.7217391304348, 0.2804347826087, 0.45454545454545
80657, 1.7217391304348, 0.25434782608696, 0.43181818181818
80658, 1.7, 0.25434782608696, 0.40909090909091
80659, 1.7217391304348, 0.2804347826087, 0.40909090909091
80660, 1.7217391304348, 0.25434782608696, 0.38636363636364
80661, 1.7, 0.25434782608696, 0.36363636363636
80662, 1.7217391304348, 0.2804347826087, 0.36363636363636
80663, 1.7217391304348, 0.25434782608696, 0.34090909090909
80664, 1.7, 0.25434782608696, 0.31818181818182
80665, 1.7217391304348, 0.2804347826087, 0.31818181818182
80666, 1.7217391304348, 0.25434782608696, 0.29545454545455
80667, 1.7, 0.25434782608696, 0.27272727272727
80668, 1.7217391304348, 0.2804347826087, 0.27272727272727
80669, 1.7217391304348, 0.25434782608696, 0.25
80670, 1.7, 0.25434782608696, 0.22727272727273
80671, 1.7217391304348, 0.2804347826087, 0.22727272727273
80672, 1.7217391304348, 0.25434782608696, 0.20454545454545
80673, 1.7, 0.25434782608696, 0.18181818181818
80674, 1.7217391304348, 0.2804347826087, 0.18181818181818
80675, 1.7217391304348, 0.25434782608696, 0.15909090909091
80676, 1.7, 0.25434782608696, 0.13636363636364
80677, 1.7217391304348, 0.2804347826087, 0.13636363636364
80678, 1.7217391304348, 0.25434782608696, 0.11363636363636
80679, 1.7, 0.25434782608696, 0.090909090909091
80680, 1.7217391304348, 0.2804347826087, 0.090909090909091
80681, 1.7217391304348, 0.25434782608696, 0.068181818181818
80682, 1.7, 0.25434782608696, 0.045454545454545
80683, 1.7217391304348, 0.2804347826087, 0.045454545454545
80684, 1.7217391304348, 0.25434782608696, 0.022727272727273
80685, 1.7652173913043, 0.25434782608696, 0.47727272727273
80686, 1.7434782608696, 0.25434782608696, 0.45454545454545
80687, 1.7652173913043, 0.2804347826087, 0.45454545454545
80688, 1.7652173913043, 0.25434782608696, 0.43181818181818
80689, 1.7434782608696, 0.25434782608696, 0.40909090909091
80690, 1.7652173913043, 0.2804347826087, 0.40909090909091
80691, 1.7652173913043, 0.25434782608696, 0.38636363636364
80692, 1.7434782608696, 0.25434782608696, 0.36363636363636
80693, 1.7652173913043, 0.2804347826087, 0.36363636363636
80694, 1.7652173913043, 0.25434782608696, 0.34090909090909
80695, 1.7434782608696, 0.25434782608696, 0.31818181818182
80696, 1.7652173913043, 0.2804347826087, 0.31818181818182
80697, 1.7652173913043, 0.25434782608696, 0.29545454545455
80698, 1.7434782608696, 0.25434782608696, 0.27272727272727
80699, 1.7652173913043, 0.2804347826087, 0.27272727272727
80700, 1.7652173913043, 0.25434782608696, 0.25
80701, 1.7434782608696, 0.25434782608696, 0.22727272727273
80702, 1.7652173913043, 0.2804347826087, 0.22727272727273
80703, 1.7652173913043, 0.25434782608696, 0.20454545454545
80704, 1.7434782608696, 0.25434782608696, 0.18181818181818
80705, 1.7652173913043, 0.2804347826087, 0.18181818181818
80706, 1.7652173913043, 0.25434782608696, 0.15909090909091
80707, 1.7434782608696, 0.25434782608696, 0.13636363636364
80708, 1.7652173913043, 0.2804347826087, 0.13636363636364
80709, 1.7652173913043, 0.25434782608696, 0.11363636363636
80710, 1.7434782608696, 0.25434782608696, 0.090909090909091
80711, 1.7652173913043, 0.2804347826087, 0.090909090909091
80712, 1.7652173913043, 0.25434782608696, 0.068181818181818
80713, 1.7434782608696, 0.25434782608696, 0.045454545454545
80714, 1.7652173913043, 0.2804347826087, 0.045454545454545
80715, 1.7652173913043, 0.25434782608696, 0.022727272727273
80716, 1.8086956521739, 0.25434782608696, 0.47727272727273
80717, 1.7869565217391, 0.25434782608696, 0.45454545454545
80718, 1.8086956521739, 0.2804347826087, 0.45454545454545
80719, 1.8086956521739, 0.25434782608696, 0.43181818181818
80720, 1.7869565217391, 0.25434782608696, 0.40909090909091
80721, 1.8086956521739, 0.2804347826087, 0.40909090909091
80722, 1.8086956521739, 0.25434782608696, 0.38636363636364
80723, 1.7869565217391, 0.25434782608696, 0.36363636363636
80724, 1.8086956521739, 0.2804347826087, 0.36363636363636
80725, 1.8086956521739, 0.25434782608696, 0.34090909090909
80726, 1.7869565217391, 0.25434782608696, 0.31818181818182
80727, 1.8086956521739, 0.2804347826087, 0.31818181818182
80728, 1.8086956521739, 0.25434782608696, 0.29545454545455
80729, 1.7869565217391, 0.25434782608696, 0.27272727272727
80730, 1.8086956521739, 0.2804347826087, 0.27272727272727
80731, 1.8086956521739, 0.25434782608696, 0.25
80732, 1.7869565217391, 0.25434782608696, 0.22727272727273
80733, 1.8086956521739, 0.2804347826087, 0.22727272727273
80734, 1.8086956521739, 0.25434782608696, 0.20454545454545
80735, 1.7869565217391, 0.25434782608696, 0.18181818181818
80736, 1.8086956521739, 0.2804347826087, 0.18181818181818
80737, 1.8086956521739, 0.25434782608696, 0.15909090909091
80738, 1.7869565217391, 0.25434782608696, 0.13636363636364
80739, 1.8086956521739, 0.2804347826087, 0.13636363636364
80740, 1.8086956521739, 0.25434782608696, 0.11363636363636
80741, 1.7869565217391, 0.25434782608696, 0.090909090909091
80742, 1.8086956521739, 0.2804347826087, 0.090909090909091
80743, 1.8086956521739, 0.25434782608696, 0.068181818181818
80744, 1.7869565217391, 0.25434782608696, 0.045454545454545
80745, 1.8086956521739, 0.2804347826087, 0.045454545454545
80746, 1.8086956521739, 0.25434782608696, 0.022727272727273
80747, 1.8521739130435, 0.25434782608696, 0.47727272727273
80748, 1.8304347826087, 0.25434782608696, 0.45454545454545
80749, 1.8521739130435, 0.2804347826087, 0.45454545454545
80750, 1.8521739130435, 0.25434782608696, 0.43181818181818
80751, 1.8304347826087, 0.25434782608696, 0.40909090909091
80752, 1.8521739130435, 0.2804347826087, 0.40909090909091
80753, 1.8521739130435, 0.25434782608696, 0.38636363636364
80754, 1.8304347826087, 0.25434782608696, 0.36363636363636
80755, 1.8521739130435, 0.2804347826087, 0.36363636363636
80756, 1.8521739130435, 0.25434782608696, 0.34090909090909
80757, 1.8304347826087, 0.25434782608696, 0.31818181818182
80758, 1.8521739130435, 0.2804347826087, 0.31818181818182
80759, 1.8521739130435, 0.25434782608696, 0.29545454545455
80760, 1.8304347826087, 0.25434782608696, 0.27272727272727
80761, 1.8521739130435, 0.2804347826087, 0.27272727272727
80762, 1.8521739130435, 0.25434782608696, 0.25
80763, 1.8304347826087, 0.25434782608696, 0.22727272727273
80764, 1.8521739130435, 0.2804347826087, 0.22727272727273
80765, 1.8521739130435, 0.25434782608696, 0.20454545454545
80766, 1.8304347826087, 0.25434782608696, 0.18181818181818
80767, 1.8521739130435, 0.2804347826087, 0.18181818181818
80768, 1.8521739130435, 0.25434782608696, 0.15909090909091
80769, 1.8304347826087, 0.25434782608696, 0.13636363636364
80770, 1.8521739130435, 0.2804347826087, 0.13636363636364
80771, 1.8521739130435, 0.25434782608696, 0.11363636363636
80772, 1.8304347826087, 0.25434782608696, 0.090909090909091
80773, 1.8521739130435, 0.2804347826087, 0.090909090909091
80774, 1.8521739130435, 0.25434782608696, 0.068181818181818
80775, 1.8304347826087, 0.25434782608696, 0.045454545454545
80776, 1.8521739130435, 0.2804347826087, 0.045454545454545
80777, 1.8521739130435, 0.25434782608696, 0.022727272727273
80778, 1.895652173913, 0.25434782608696, 0.47727272727273
80779, 1.8739130434783, 0.25434782608696, 0.45454545454545
80780, 1.895652173913, 0.2804347826087, 0.45454545454545
80781, 1.895652173913, 0.25434782608696, 0.43181818181818
80782, 1.8739130434783, 0.25434782608696, 0.40909090909091
80783, 1.895652173913, 0.2804347826087, 0.40909090909091
80784, 1.895652173913, 0.25434782608696, 0.38636363636364
80785, 1.8739130434783, 0.25434782608696, 0.36363636363636
80786, 1.895652173913, 0.2804347826087, 0.36363636363636
80787, 1.895652173913, 0.25434782608696, 0.34090909090909
80788, 1.8739130434783, 0.25434782608696, 0.31818181818182
80789, 1.895652173913, 0.2804347826087, 0.31818181818182
80790, 1.895652173913, 0.25434782608696, 0.29545454545455
80791, 1.8739130434783, 0.25434782608696, 0.27272727272727
80792, 1.895652173913, 0.2804347826087, 0.27272727272727
80793, 1.895652173913, 0.25434782608696, 0.25
80794, 1.8739130434783, 0.25434782608696, 0.22727272727273
80795, 1.895652173913, 0.2804347826087, 0.22727272727273
80796, 1.895652173913, 0.25434782608696, 0.20454545454545
80797, 1.8739130434783, 0.25434782608696, 0.18181818181818
80798, 1.895652173913, 0.2804347826087, 0.18181818181818
80799, 1.895652173913, 0.25434782608696, 0.15909090909091
80800, 1.8739130434783, 0.25434782608696, 0.13636363636364
80801, 1.895652173913, 0.2804347826087, 0.13636363636364
80802, 1.895652173913, 0.25434782608696, 0.11363636363636
80803, 1.8739130434783, 0.25434782608696, 0.090909090909091
80804, 1.895652173913, 0.2804347826087, 0.090909090909091
80805, 1.895652173913, 0.25434782608696, 0.068181818181818
80806, 1.8739130434783, 0.25434782608696, 0.045454545454545
80807, 1.895652173913, 0.2804347826087, 0.045454545454545
80808, 1.895652173913, 0.25434782608696, 0.022727272727273
80809, 1.9391304347826, 0.25434782608696, 0.47727272727273
80810, 1.9173913043478, 0.25434782608696, 0.45454545454545
80811, 1.9391304347826, 0.2804347826087, 0.45454545454545
80812, 1.9391304347826, 0.25434782608696, 0.43181818181818
80813, 1.9173913043478, 0.25434782608696, 0.40909090909091
80814, 1.9391304347826, 0.2804347826087, 0.40909090909091
80815, 1.9391304347826, 0.25434782608696, 0.38636363636364
80816, 1.9173913043478, 0.25434782608696, 0.36363636363636
80817, 1.9391304347826, 0.2804347826087, 0.36363636363636
80818, 1.9391304347826, 0.25434782608696, 0.34090909090909
80819, 1.9173913043478, 0.25434782608696, 0.31818181818182
80820, 1.9391304347826, 0.2804347826087, 0.31818181818182
80821, 1.9391304347826, 0.25434782608696, 0.29545454545455
80822, 1.9173913043478, 0.25434782608696, 0.27272727272727
80823, 1.9391304347826, 0.2804347826087, 0.27272727272727
80824, 1.9391304347826, 0.25434782608696, 0.25
80825, 1.9173913043478, 0.25434782608696, 0.22727272727273
80826, 1.9391304347826, 0.2804347826087, 0.22727272727273
80827, 1.9391304347826, 0.25434782608696, 0.20454545454545
80828, 1.9173913043478, 0.25434782608696, 0.18181818181818
80829, 1.9391304347826, 0.2804347826087, 0.18181818181818
80830, 1.9391304347826, 0.25434782608696, 0.15909090909091
80831, 1.9173913043478, 0.25434782608696, 0.13636363636364
80832, 1.9391304347826, 0.2804347826087, 0.13636363636364
80833, 1.9391304347826, 0.25434782608696, 0.11363636363636
80834, 1.9173913043478, 0.25434782608696, 0.090909090909091
80835, 1.9391304347826, 0.2804347826087, 0.090909090909091
80836, 1.9391304347826, 0.25434782608696, 0.068181818181818
80837, 1.9173913043478, 0.25434782608696, 0.045454545454545
80838, 1.9391304347826, 0.2804347826087, 0.045454545454545
80839, 1.9391304347826, 0.25434782608696, 0.022727272727273
80840, 1.9826086956522, 0.25434782608696, 0.47727272727273
80841, 1.9608695652174, 0.25434782608696, 0.45454545454545
80842, 1.9826086956522, 0.2804347826087, 0.45454545454545
80843, 1.9826086956522, 0.25434782608696, 0.43181818181818
80844, 1.9608695652174, 0.25434782608696, 0.40909090909091
80845, 1.9826086956522, 0.2804347826087, 0.40909090909091
80846, 1.9826086956522, 0.25434782608696, 0.38636363636364
80847, 1.9608695652174, 0.25434782608696, 0.36363636363636
80848, 1.9826086956522, 0.2804347826087, 0.36363636363636
80849, 1.9826086956522, 0.25434782608696, 0.34090909090909
80850, 1.9608695652174, 0.25434782608696, 0.31818181818182
80851, 1.9826086956522, 0.2804347826087, 0.31818181818182
80852, 1.9826086956522, 0.25434782608696, 0.29545454545455
80853, 1.9608695652174, 0.25434782608696, 0.27272727272727
80854, 1.9826086956522, 0.2804347826087, 0.27272727272727
80855, 1.9826086956522, 0.25434782608696, 0.25
80856, 1.9608695652174, 0.25434782608696, 0.22727272727273
80857, 1.9826086956522, 0.2804347826087, 0.22727272727273
80858, 1.9826086956522, 0.25434782608696, 0.20454545454545
80859, 1.9608695652174, 0.25434782608696, 0.18181818181818
80860, 1.9826086956522, 0.2804347826087, 0.18181818181818
80861, 1.9826086956522, 0.25434782608696, 0.15909090909091
80862, 1.9608695652174, 0.25434782608696, 0.13636363636364
80863, 1.9826086956522, 0.2804347826087, 0.13636363636364
80864, 1.9826086956522, 0.25434782608696, 0.11363636363636
80865, 1.9608695652174, 0.25434782608696, 0.090909090909091
80866, 1.9826086956522, 0.2804347826087, 0.090909090909091
80867, 1.9826086956522, 0.25434782608696, 0.068181818181818
80868, 1.9608695652174, 0.25434782608696, 0.045454545454545
80869, 1.9826086956522, 0.2804347826087, 0.045454545454545
80870, 1.9826086956522, 0.25434782608696, 0.022727272727273
80871, 2.0260869565217, 0.25434782608696, 0.47727272727273
80872, 2.004347826087, 0.25434782608696, 0.45454545454545
80873, 2.0260869565217, 0.2804347826087, 0.45454545454545
80874, 2.0260869565217, 0.25434782608696, 0.43181818181818
80875, 2.004347826087, 0.25434782608696, 0.40909090909091
80876, 2.0260869565217, 0.2804347826087, 0.40909090909091
80877, 2.0260869565217, 0.25434782608696, 0.38636363636364
80878, 2.004347826087, 0.25434782608696, 0.36363636363636
80879, 2.0260869565217, 0.2804347826087, 0.36363636363636
80880, 2.0260869565217, 0.25434782608696, 0.34090909090909
80881, 2.004347826087, 0.25434782608696, 0.31818181818182
80882, 2.0260869565217, 0.2804347826087, 0.31818181818182
80883, 2.0260869565217, 0.25434782608696, 0.29545454545455
80884, 2.004347826087, 0.25434782608696, 0.27272727272727
80885, 2.0260869565217, 0.2804347826087, 0.27272727272727
80886, 2.0260869565217, 0.25434782608696, 0.25
80887, 2.004347826087, 0.25434782608696, 0.22727272727273
80888, 2.0260869565217, 0.2804347826087, 0.22727272727273
80889, 2.0260869565217, 0.25434782608696, 0.20454545454545
80890, 2.004347826087, 0.25434782608696, 0.18181818181818
80891, 2.0260869565217, 0.2804347826087, 0.18181818181818
80892, 2.0260869565217, 0.25434782608696, 0.15909090909091
80893, 2.004347826087, 0.25434782608696, 0.13636363636364
80894, 2.0260869565217, 0.2804347826087, 0.13636363636364
80895, 2.0260869565217, 0.25434782608696, 0.11363636363636
80896, 2.004347826087, 0.25434782608696, 0.090909090909091
80897, 2.0260869565217, 0.2804347826087, 0.090909090909091
80898, 2.0260869565217, 0.25434782608696, 0.068181818181818
80899, 2.004347826087, 0.25434782608696, 0.045454545454545
80900, 2.0260869565217, 0.2804347826087, 0.045454545454545
80901, 2.0260869565217, 0.25434782608696, 0.022727272727273
80902, 2.0695652173913, 0.25434782608696, 0.47727272727273
80903, 2.0478260869565, 0.25434782608696, 0.45454545454545
80904, 2.0695652173913, 0.2804347826087, 0.45454545454545
80905, 2.0695652173913, 0.25434782608696, 0.43181818181818
80906, 2.0478260869565, 0.25434782608696, 0.40909090909091
80907, 2.0695652173913, 0.2804347826087, 0.40909090909091
80908, 2.0695652173913, 0.25434782608696, 0.38636363636364
80909, 2.0478260869565, 0.25434782608696, 0.36363636363636
80910, 2.0695652173913, 0.2804347826087, 0.36363636363636
80911, 2.0695652173913, 0.25434782608696, 0.34090909090909
80912, 2.0478260869565, 0.25434782608696, 0.31818181818182
80913, 2.0695652173913, 0.2804347826087, 0.31818181818182
80914, 2.0695652173913, 0.25434782608696, 0.29545454545455
80915, 2.0478260869565, 0.25434782608696, 0.27272727272727
80916, 2.0695652173913, 0.2804347826087, 0.27272727272727
80917, 2.0695652173913, 0.25434782608696, 0.25
80918, 2.0478260869565, 0.25434782608696, 0.22727272727273
80919, 2.0695652173913, 0.2804347826087, 0.22727272727273
80920, 2.0695652173913, 0.25434782608696, 0.20454545454545
80921, 2.0478260869565, 0.25434782608696, 0.18181818181818
80922, 2.0695652173913, 0.2804347826087, 0.18181818181818
80923, 2.0695652173913, 0.25434782608696, 0.15909090909091
80924, 2.0478260869565, 0.25434782608696, 0.13636363636364
80925, 2.0695652173913, 0.2804347826087, 0.13636363636364
80926, 2.0695652173913, 0.25434782608696, 0.11363636363636
80927, 2.0478260869565, 0.25434782608696, 0.090909090909091
80928, 2.0695652173913, 0.2804347826087, 0.090909090909091
80929, 2.0695652173913, 0.25434782608696, 0.068181818181818
80930, 2.0478260869565, 0.25434782608696, 0.045454545454545
80931, 2.0695652173913, 0.2804347826087, 0.045454545454545
80932, 2.0695652173913, 0.25434782608696, 0.022727272727273
80933, 2.1130434782609, 0.25434782608696, 0.47727272727273
80934, 2.0913043478261, 0.25434782608696, 0.45454545454545
80935, 2.1130434782609, 0.2804347826087, 0.45454545454545
80936, 2.1130434782609, 0.25434782608696, 0.43181818181818
80937, 2.0913043478261, 0.25434782608696, 0.40909090909091
80938, 2.1130434782609, 0.2804347826087, 0.40909090909091
80939, 2.1130434782609, 0.25434782608696, 0.38636363636364
80940, 2.0913043478261, 0.25434782608696, 0.36363636363636
80941, 2.1130434782609, 0.2804347826087, 0.36363636363636
80942, 2.1130434782609, 0.25434782608696, 0.34090909090909
80943, 2.0913043478261, 0.25434782608696, 0.31818181818182
80944, 2.1130434782609, 0.2804347826087, 0.31818181818182
80945, 2.1130434782609, 0.25434782608696, 0.29545454545455
80946, 2.0913043478261, 0.25434782608696, 0.27272727272727
80947, 2.1130434782609, 0.2804347826087, 0.27272727272727
80948, 2.1130434782609, 0.25434782608696, 0.25
80949, 2.0913043478261, 0.25434782608696, 0.22727272727273
80950, 2.1130434782609, 0.2804347826087, 0.22727272727273
80951, 2.1130434782609, 0.25434782608696, 0.20454545454545
80952, 2.0913043478261, 0.25434782608696, 0.18181818181818
80953, 2.1130434782609, 0.2804347826087, 0.18181818181818
80954, 2.1130434782609, 0.25434782608696, 0.15909090909091
80955, 2.0913043478261, 0.25434782608696, 0.13636363636364
80956, 2.1130434782609, 0.2804347826087, 0.13636363636364
80957, 2.1130434782609, 0.25434782608696, 0.11363636363636
80958, 2.0913043478261, 0.25434782608696, 0.090909090909091
80959, 2.1130434782609, 0.2804347826087, 0.090909090909091
80960, 2.1130434782609, 0.25434782608696, 0.068181818181818
80961, 2.0913043478261, 0.25434782608696, 0.045454545454545
80962, 2.1130434782609, 0.2804347826087, 0.045454545454545
80963, 2.1130434782609, 0.25434782608696, 0.022727272727273
80964, 2.1565217391304, 0.25434782608696, 0.47727272727273
80965, 2.1347826086957, 0.25434782608696, 0.45454545454545
80966, 2.1565217391304, 0.2804347826087, 0.45454545454545
80967, 2.1565217391304, 0.25434782608696, 0.43181818181818
80968, 2.1347826086957, 0.25434782608696, 0.40909090909091
80969, 2.1565217391304, 0.2804347826087, 0.40909090909091
80970, 2.1565217391304, 0.25434782608696, 0.38636363636364
80971, 2.1347826086957, 0.25434782608696, 0.36363636363636
80972, 2.1565217391304, 0.2804347826087, 0.36363636363636
80973, 2.1565217391304, 0.25434782608696, 0.34090909090909
80974, 2.1347826086957, 0.25434782608696, 0.31818181818182
80975, 2.1565217391304, 0.2804347826087, 0.31818181818182
80976, 2.1565217391304, 0.25434782608696, 0.29545454545455
80977, 2.1347826086957, 0.25434782608696, 0.27272727272727
80978, 2.1565217391304, 0.2804347826087, 0.27272727272727
80979, 2.1565217391304, 0.25434782608696, 0.25
80980, 2.1347826086957, 0.25434782608696, 0.22727272727273
80981, 2.1565217391304, 0.2804347826087, 0.22727272727273
80982, 2.1565217391304, 0.25434782608696, 0.20454545454545
80983, 2.1347826086957, 0.25434782608696, 0.18181818181818
80984, 2.1565217391304, 0.2804347826087, 0.18181818181818
80985, 2.1565217391304, 0.25434782608696, 0.15909090909091
80986, 2.1347826086957, 0.25434782608696, 0.13636363636364
80987, 2.1565217391304, 0.2804347826087, 0.13636363636364
80988, 2.1565217391304, 0.25434782608696, 0.11363636363636
80989, 2.1347826086957, 0.25434782608696, 0.090909090909091
80990, 2.1565217391304, 0.2804347826087, 0.090909090909091
80991, 2.1565217391304, 0.25434782608696, 0.068181818181818
80992, 2.1347826086957, 0.25434782608696, 0.045454545454545
80993, 2.1565217391304, 0.2804347826087, 0.045454545454545
80994, 2.1565217391304, 0.25434782608696, 0.022727272727273
80995, 2.1782608695652, 0.25434782608696, 0.45454545454545
80996, 2.1782608695652, 0.25434782608696, 0.40909090909091
80997, 2.1782608695652, 0.25434782608696, 0.36363636363636
80998, 2.1782608695652, 0.25434782608696, 0.31818181818182
80999, 2.1782608695652, 0.25434782608696, 0.27272727272727
81000, 2.1782608695652, 0.25434782608696, 0.22727272727273
81001, 2.1782608695652, 0.25434782608696, 0.18181818181818
81002, 2.1782608695652, 0.25434782608696, 0.13636363636364
81003, 2.1782608695652, 0.25434782608696, 0.090909090909091
81004, 2.1782608695652, 0.25434782608696, 0.045454545454545
81005, 1.2434782608696, 0.20217391304348, 0.47727272727273
81006, 1.2217391304348, 0.20217391304348, 0.45454545454545
81007, 1.2434782608696, 0.22826086956522, 0.45454545454545
81008, 1.2434782608696, 0.20217391304348, 0.43181818181818
81009, 1.2217391304348, 0.20217391304348, 0.40909090909091
81010, 1.2434782608696, 0.22826086956522, 0.40909090909091
81011, 1.2434782608696, 0.20217391304348, 0.38636363636364
81012, 1.2217391304348, 0.20217391304348, 0.36363636363636
81013, 1.2434782608696, 0.22826086956522, 0.36363636363636
81014, 1.2434782608696, 0.20217391304348, 0.34090909090909
81015, 1.2217391304348, 0.20217391304348, 0.31818181818182
81016, 1.2434782608696, 0.22826086956522, 0.31818181818182
81017, 1.2434782608696, 0.20217391304348, 0.29545454545455
81018, 1.2217391304348, 0.20217391304348, 0.27272727272727
81019, 1.2434782608696, 0.22826086956522, 0.27272727272727
81020, 1.2434782608696, 0.20217391304348, 0.25
81021, 1.2217391304348, 0.20217391304348, 0.22727272727273
81022, 1.2434782608696, 0.22826086956522, 0.22727272727273
81023, 1.2434782608696, 0.20217391304348, 0.20454545454545
81024, 1.2217391304348, 0.20217391304348, 0.18181818181818
81025, 1.2434782608696, 0.22826086956522, 0.18181818181818
81026, 1.2434782608696, 0.20217391304348, 0.15909090909091
81027, 1.2217391304348, 0.20217391304348, 0.13636363636364
81028, 1.2434782608696, 0.22826086956522, 0.13636363636364
81029, 1.2434782608696, 0.20217391304348, 0.11363636363636
81030, 1.2217391304348, 0.20217391304348, 0.090909090909091
81031, 1.2434782608696, 0.22826086956522, 0.090909090909091
81032, 1.2434782608696, 0.20217391304348, 0.068181818181818
81033, 1.2217391304348, 0.20217391304348, 0.045454545454545
81034, 1.2434782608696, 0.22826086956522, 0.045454545454545
81035, 1.2434782608696, 0.20217391304348, 0.022727272727273
81036, 1.2869565217391, 0.20217391304348, 0.47727272727273
81037, 1.2652173913043, 0.20217391304348, 0.45454545454545
81038, 1.2869565217391, 0.22826086956522, 0.45454545454545
81039, 1.2869565217391, 0.20217391304348, 0.43181818181818
81040, 1.2652173913043, 0.20217391304348, 0.40909090909091
81041, 1.2869565217391, 0.22826086956522, 0.40909090909091
81042, 1.2869565217391, 0.20217391304348, 0.38636363636364
81043, 1.2652173913043, 0.20217391304348, 0.36363636363636
81044, 1.2869565217391, 0.22826086956522, 0.36363636363636
81045, 1.2869565217391, 0.20217391304348, 0.34090909090909
81046, 1.2652173913043, 0.20217391304348, 0.31818181818182
81047, 1.2869565217391, 0.22826086956522, 0.31818181818182
81048, 1.2869565217391, 0.20217391304348, 0.29545454545455
81049, 1.2652173913043, 0.20217391304348, 0.27272727272727
81050, 1.2869565217391, 0.22826086956522, 0.27272727272727
81051, 1.2869565217391, 0.20217391304348, 0.25
81052, 1.2652173913043, 0.20217391304348, 0.22727272727273
81053, 1.2869565217391, 0.22826086956522, 0.22727272727273
81054, 1.2869565217391, 0.20217391304348, 0.20454545454545
81055, 1.2652173913043, 0.20217391304348, 0.18181818181818
81056, 1.2869565217391, 0.22826086956522, 0.18181818181818
81057, 1.2869565217391, 0.20217391304348, 0.15909090909091
81058, 1.2652173913043, 0.20217391304348, 0.13636363636364
81059, 1.2869565217391, 0.22826086956522, 0.13636363636364
81060, 1.2869565217391, 0.20217391304348, 0.11363636363636
81061, 1.2652173913043, 0.20217391304348, 0.090909090909091
81062, 1.2869565217391, 0.22826086956522, 0.090909090909091
81063, 1.2869565217391, 0.20217391304348, 0.068181818181818
81064, 1.2652173913043, 0.20217391304348, 0.045454545454545
81065, 1.2869565217391, 0.22826086956522, 0.045454545454545
81066, 1.2869565217391, 0.20217391304348, 0.022727272727273
81067, 1.3304347826087, 0.20217391304348, 0.47727272727273
81068, 1.3086956521739, 0.20217391304348, 0.45454545454545
81069, 1.3304347826087, 0.22826086956522, 0.45454545454545
81070, 1.3304347826087, 0.20217391304348, 0.43181818181818
81071, 1.3086956521739, 0.20217391304348, 0.40909090909091
81072, 1.3304347826087, 0.22826086956522, 0.40909090909091
81073, 1.3304347826087, 0.20217391304348, 0.38636363636364
81074, 1.3086956521739, 0.20217391304348, 0.36363636363636
81075, 1.3304347826087, 0.22826086956522, 0.36363636363636
81076, 1.3304347826087, 0.20217391304348, 0.34090909090909
81077, 1.3086956521739, 0.20217391304348, 0.31818181818182
81078, 1.3304347826087, 0.22826086956522, 0.31818181818182
81079, 1.3304347826087, 0.20217391304348, 0.29545454545455
81080, 1.3086956521739, 0.20217391304348, 0.27272727272727
81081, 1.3304347826087, 0.22826086956522, 0.27272727272727
81082, 1.3304347826087, 0.20217391304348, 0.25
81083, 1.3086956521739, 0.20217391304348, 0.22727272727273
81084, 1.3304347826087, 0.22826086956522, 0.22727272727273
81085, 1.3304347826087, 0.20217391304348, 0.20454545454545
81086, 1.3086956521739, 0.20217391304348, 0.18181818181818
81087, 1.3304347826087, 0.22826086956522, 0.18181818181818
81088, 1.3304347826087, 0.20217391304348, 0.15909090909091
81089, 1.3086956521739, 0.20217391304348, 0.13636363636364
81090, 1.3304347826087, 0.22826086956522, 0.13636363636364
81091, 1.3304347826087, 0.20217391304348, 0.11363636363636
81092, 1.3086956521739, 0.20217391304348, 0.090909090909091
81093, 1.3304347826087, 0.22826086956522, 0.090909090909091
81094, 1.3304347826087, 0.20217391304348, 0.068181818181818
81095, 1.3086956521739, 0.20217391304348, 0.045454545454545
81096, 1.3304347826087, 0.22826086956522, 0.045454545454545
81097, 1.3304347826087, 0.20217391304348, 0.022727272727273
81098, 1.3739130434783, 0.20217391304348, 0.47727272727273
81099, 1.3521739130435, 0.20217391304348, 0.45454545454545
81100, 1.3739130434783, 0.22826086956522, 0.45454545454545
81101, 1.3739130434783, 0.20217391304348, 0.43181818181818
81102, 1.3521739130435, 0.20217391304348, 0.40909090909091
81103, 1.3739130434783, 0.22826086956522, 0.40909090909091
81104, 1.3739130434783, 0.20217391304348, 0.38636363636364
81105, 1.3521739130435, 0.20217391304348, 0.36363636363636
81106, 1.3739130434783, 0.22826086956522, 0.36363636363636
81107, 1.3739130434783, 0.20217391304348, 0.34090909090909
81108, 1.3521739130435, 0.20217391304348, 0.31818181818182
81109, 1.3739130434783, 0.22826086956522, 0.31818181818182
81110, 1.3739130434783, 0.20217391304348, 0.29545454545455
81111, 1.3521739130435, 0.20217391304348, 0.27272727272727
81112, 1.3739130434783, 0.22826086956522, 0.27272727272727
81113, 1.3739130434783, 0.20217391304348, 0.25
81114, 1.3521739130435, 0.20217391304348, 0.22727272727273
81115, 1.3739130434783, 0.22826086956522, 0.22727272727273
81116, 1.3739130434783, 0.20217391304348, 0.20454545454545
81117, 1.3521739130435, 0.20217391304348, 0.18181818181818
81118, 1.3739130434783, 0.22826086956522, 0.18181818181818
81119, 1.3739130434783, 0.20217391304348, 0.15909090909091
81120, 1.3521739130435, 0.20217391304348, 0.13636363636364
81121, 1.3739130434783, 0.22826086956522, 0.13636363636364
81122, 1.3739130434783, 0.20217391304348, 0.11363636363636
81123, 1.3521739130435, 0.20217391304348, 0.090909090909091
81124, 1.3739130434783, 0.22826086956522, 0.090909090909091
81125, 1.3739130434783, 0.20217391304348, 0.068181818181818
81126, 1.3521739130435, 0.20217391304348, 0.045454545454545
81127, 1.3739130434783, 0.22826086956522, 0.045454545454545
81128, 1.3739130434783, 0.20217391304348, 0.022727272727273
81129, 1.4173913043478, 0.20217391304348, 0.47727272727273
81130, 1.395652173913, 0.20217391304348, 0.45454545454545
81131, 1.4173913043478, 0.22826086956522, 0.45454545454545
81132, 1.4173913043478, 0.20217391304348, 0.43181818181818
81133, 1.395652173913, 0.20217391304348, 0.40909090909091
81134, 1.4173913043478, 0.22826086956522, 0.40909090909091
81135, 1.4173913043478, 0.20217391304348, 0.38636363636364
81136, 1.395652173913, 0.20217391304348, 0.36363636363636
81137, 1.4173913043478, 0.22826086956522, 0.36363636363636
81138, 1.4173913043478, 0.20217391304348, 0.34090909090909
81139, 1.395652173913, 0.20217391304348, 0.31818181818182
81140, 1.4173913043478, 0.22826086956522, 0.31818181818182
81141, 1.4173913043478, 0.20217391304348, 0.29545454545455
81142, 1.395652173913, 0.20217391304348, 0.27272727272727
81143, 1.4173913043478, 0.22826086956522, 0.27272727272727
81144, 1.4173913043478, 0.20217391304348, 0.25
81145, 1.395652173913, 0.20217391304348, 0.22727272727273
81146, 1.4173913043478, 0.22826086956522, 0.22727272727273
81147, 1.4173913043478, 0.20217391304348, 0.20454545454545
81148, 1.395652173913, 0.20217391304348, 0.18181818181818
81149, 1.4173913043478, 0.22826086956522, 0.18181818181818
81150, 1.4173913043478, 0.20217391304348, 0.15909090909091
81151, 1.395652173913, 0.20217391304348, 0.13636363636364
81152, 1.4173913043478, 0.22826086956522, 0.13636363636364
81153, 1.4173913043478, 0.20217391304348, 0.11363636363636
81154, 1.395652173913, 0.20217391304348, 0.090909090909091
81155, 1.4173913043478, 0.22826086956522, 0.090909090909091
81156, 1.4173913043478, 0.20217391304348, 0.068181818181818
81157, 1.395652173913, 0.20217391304348, 0.045454545454545
81158, 1.4173913043478, 0.22826086956522, 0.045454545454545
81159, 1.4173913043478, 0.20217391304348, 0.022727272727273
81160, 1.4608695652174, 0.20217391304348, 0.47727272727273
81161, 1.4391304347826, 0.20217391304348, 0.45454545454545
81162, 1.4608695652174, 0.22826086956522, 0.45454545454545
81163, 1.4608695652174, 0.20217391304348, 0.43181818181818
81164, 1.4391304347826, 0.20217391304348, 0.40909090909091
81165, 1.4608695652174, 0.22826086956522, 0.40909090909091
81166, 1.4608695652174, 0.20217391304348, 0.38636363636364
81167, 1.4391304347826, 0.20217391304348, 0.36363636363636
81168, 1.4608695652174, 0.22826086956522, 0.36363636363636
81169, 1.4608695652174, 0.20217391304348, 0.34090909090909
81170, 1.4391304347826, 0.20217391304348, 0.31818181818182
81171, 1.4608695652174, 0.22826086956522, 0.31818181818182
81172, 1.4608695652174, 0.20217391304348, 0.29545454545455
81173, 1.4391304347826, 0.20217391304348, 0.27272727272727
81174, 1.4608695652174, 0.22826086956522, 0.27272727272727
81175, 1.4608695652174, 0.20217391304348, 0.25
81176, 1.4391304347826, 0.20217391304348, 0.22727272727273
81177, 1.4608695652174, 0.22826086956522, 0.22727272727273
81178, 1.4608695652174, 0.20217391304348, 0.20454545454545
81179, 1.4391304347826, 0.20217391304348, 0.18181818181818
81180, 1.4608695652174, 0.22826086956522, 0.18181818181818
81181, 1.4608695652174, 0.20217391304348, 0.15909090909091
81182, 1.4391304347826, 0.20217391304348, 0.13636363636364
81183, 1.4608695652174, 0.22826086956522, 0.13636363636364
81184, 1.4608695652174, 0.20217391304348, 0.11363636363636
81185, 1.4391304347826, 0.20217391304348, 0.090909090909091
81186, 1.4608695652174, 0.22826086956522, 0.090909090909091
81187, 1.4608695652174, 0.20217391304348, 0.068181818181818
81188, 1.4391304347826, 0.20217391304348, 0.045454545454545
81189, 1.4608695652174, 0.22826086956522, 0.045454545454545
81190, 1.4608695652174, 0.20217391304348, 0.022727272727273
81191, 1.504347826087, 0.20217391304348, 0.47727272727273
81192, 1.4826086956522, 0.20217391304348, 0.45454545454545
81193, 1.504347826087, 0.22826086956522, 0.45454545454545
81194, 1.504347826087, 0.20217391304348, 0.43181818181818
81195, 1.4826086956522, 0.20217391304348, 0.40909090909091
81196, 1.504347826087, 0.22826086956522, 0.40909090909091
81197, 1.504347826087, 0.20217391304348, 0.38636363636364
81198, 1.4826086956522, 0.20217391304348, 0.36363636363636
81199, 1.504347826087, 0.22826086956522, 0.36363636363636
81200, 1.504347826087, 0.20217391304348, 0.34090909090909
81201, 1.4826086956522, 0.20217391304348, 0.31818181818182
81202, 1.504347826087, 0.22826086956522, 0.31818181818182
81203, 1.504347826087, 0.20217391304348, 0.29545454545455
81204, 1.4826086956522, 0.20217391304348, 0.27272727272727
81205, 1.504347826087, 0.22826086956522, 0.27272727272727
81206, 1.504347826087, 0.20217391304348, 0.25
81207, 1.4826086956522, 0.20217391304348, 0.22727272727273
81208, 1.504347826087, 0.22826086956522, 0.22727272727273
81209, 1.504347826087, 0.20217391304348, 0.20454545454545
81210, 1.4826086956522, 0.20217391304348, 0.18181818181818
81211, 1.504347826087, 0.22826086956522, 0.18181818181818
81212, 1.504347826087, 0.20217391304348, 0.15909090909091
81213, 1.4826086956522, 0.20217391304348, 0.13636363636364
81214, 1.504347826087, 0.22826086956522, 0.13636363636364
81215, 1.504347826087, 0.20217391304348, 0.11363636363636
81216, 1.4826086956522, 0.20217391304348, 0.090909090909091
81217, 1.504347826087, 0.22826086956522, 0.090909090909091
81218, 1.504347826087, 0.20217391304348, 0.068181818181818
81219, 1.4826086956522, 0.20217391304348, 0.045454545454545
81220, 1.504347826087, 0.22826086956522, 0.045454545454545
81221, 1.504347826087, 0.20217391304348, 0.022727272727273
81222, 1.5478260869565, 0.20217391304348, 0.47727272727273
81223, 1.5260869565217, 0.20217391304348, 0.45454545454545
81224, 1.5478260869565, 0.22826086956522, 0.45454545454545
81225, 1.5478260869565, 0.20217391304348, 0.43181818181818
81226, 1.5260869565217, 0.20217391304348, 0.40909090909091
81227, 1.5478260869565, 0.22826086956522, 0.40909090909091
81228, 1.5478260869565, 0.20217391304348, 0.38636363636364
81229, 1.5260869565217, 0.20217391304348, 0.36363636363636
81230, 1.5478260869565, 0.22826086956522, 0.36363636363636
81231, 1.5478260869565, 0.20217391304348, 0.34090909090909
81232, 1.5260869565217, 0.20217391304348, 0.31818181818182
81233, 1.5478260869565, 0.22826086956522, 0.31818181818182
81234, 1.5478260869565, 0.20217391304348, 0.29545454545455
81235, 1.5260869565217, 0.20217391304348, 0.27272727272727
81236, 1.5478260869565, 0.22826086956522, 0.27272727272727
81237, 1.5478260869565, 0.20217391304348, 0.25
81238, 1.5260869565217, 0.20217391304348, 0.22727272727273
81239, 1.5478260869565, 0.22826086956522, 0.22727272727273
81240, 1.5478260869565, 0.20217391304348, 0.20454545454545
81241, 1.5260869565217, 0.20217391304348, 0.18181818181818
81242, 1.5478260869565, 0.22826086956522, 0.18181818181818
81243, 1.5478260869565, 0.20217391304348, 0.15909090909091
81244, 1.5260869565217, 0.20217391304348, 0.13636363636364
81245, 1.5478260869565, 0.22826086956522, 0.13636363636364
81246, 1.5478260869565, 0.20217391304348, 0.11363636363636
81247, 1.5260869565217, 0.20217391304348, 0.090909090909091
81248, 1.5478260869565, 0.22826086956522, 0.090909090909091
81249, 1.5478260869565, 0.20217391304348, 0.068181818181818
81250, 1.5260869565217, 0.20217391304348, 0.045454545454545
81251, 1.5478260869565, 0.22826086956522, 0.045454545454545
81252, 1.5478260869565, 0.20217391304348, 0.022727272727273
81253, 1.5913043478261, 0.20217391304348, 0.47727272727273
81254, 1.5695652173913, 0.20217391304348, 0.45454545454545
81255, 1.5913043478261, 0.22826086956522, 0.45454545454545
81256, 1.5913043478261, 0.20217391304348, 0.43181818181818
81257, 1.5695652173913, 0.20217391304348, 0.40909090909091
81258, 1.5913043478261, 0.22826086956522, 0.40909090909091
81259, 1.5913043478261, 0.20217391304348, 0.38636363636364
81260, 1.5695652173913, 0.20217391304348, 0.36363636363636
81261, 1.5913043478261, 0.22826086956522, 0.36363636363636
81262, 1.5913043478261, 0.20217391304348, 0.34090909090909
81263, 1.5695652173913, 0.20217391304348, 0.31818181818182
81264, 1.5913043478261, 0.22826086956522, 0.31818181818182
81265, 1.5913043478261, 0.20217391304348, 0.29545454545455
81266, 1.5695652173913, 0.20217391304348, 0.27272727272727
81267, 1.5913043478261, 0.22826086956522, 0.27272727272727
81268, 1.5913043478261, 0.20217391304348, 0.25
81269, 1.5695652173913, 0.20217391304348, 0.22727272727273
81270, 1.5913043478261, 0.22826086956522, 0.22727272727273
81271, 1.5913043478261, 0.20217391304348, 0.20454545454545
81272, 1.5695652173913, 0.20217391304348, 0.18181818181818
81273, 1.5913043478261, 0.22826086956522, 0.18181818181818
81274, 1.5913043478261, 0.20217391304348, 0.15909090909091
81275, 1.5695652173913, 0.20217391304348, 0.13636363636364
81276, 1.5913043478261, 0.22826086956522, 0.13636363636364
81277, 1.5913043478261, 0.20217391304348, 0.11363636363636
81278, 1.5695652173913, 0.20217391304348, 0.090909090909091
81279, 1.5913043478261, 0.22826086956522, 0.090909090909091
81280, 1.5913043478261, 0.20217391304348, 0.068181818181818
81281, 1.5695652173913, 0.20217391304348, 0.045454545454545
81282, 1.5913043478261, 0.22826086956522, 0.045454545454545
81283, 1.5913043478261, 0.20217391304348, 0.022727272727273
81284, 1.6347826086957, 0.20217391304348, 0.47727272727273
81285, 1.6130434782609, 0.20217391304348, 0.45454545454545
81286, 1.6347826086957, 0.22826086956522, 0.45454545454545
81287, 1.6347826086957, 0.20217391304348, 0.43181818181818
81288, 1.6130434782609, 0.20217391304348, 0.40909090909091
81289, 1.6347826086957, 0.22826086956522, 0.40909090909091
81290, 1.6347826086957, 0.20217391304348, 0.38636363636364
81291, 1.6130434782609, 0.20217391304348, 0.36363636363636
81292, 1.6347826086957, 0.22826086956522, 0.36363636363636
81293, 1.6347826086957, 0.20217391304348, 0.34090909090909
81294, 1.6130434782609, 0.20217391304348, 0.31818181818182
81295, 1.6347826086957, 0.22826086956522, 0.31818181818182
81296, 1.6347826086957, 0.20217391304348, 0.29545454545455
81297, 1.6130434782609, 0.20217391304348, 0.27272727272727
81298, 1.6347826086957, 0.22826086956522, 0.27272727272727
81299, 1.6347826086957, 0.20217391304348, 0.25
81300, 1.6130434782609, 0.20217391304348, 0.22727272727273
81301, 1.6347826086957, 0.22826086956522, 0.22727272727273
81302, 1.6347826086957, 0.20217391304348, 0.20454545454545
81303, 1.6130434782609, 0.20217391304348, 0.18181818181818
81304, 1.6347826086957, 0.22826086956522, 0.18181818181818
81305, 1.6347826086957, 0.20217391304348, 0.15909090909091
81306, 1.6130434782609, 0.20217391304348, 0.13636363636364
81307, 1.6347826086957, 0.22826086956522, 0.13636363636364
81308, 1.6347826086957, 0.20217391304348, 0.11363636363636
81309, 1.6130434782609, 0.20217391304348, 0.090909090909091
81310, 1.6347826086957, 0.22826086956522, 0.090909090909091
81311, 1.6347826086957, 0.20217391304348, 0.068181818181818
81312, 1.6130434782609, 0.20217391304348, 0.045454545454545
81313, 1.6347826086957, 0.22826086956522, 0.045454545454545
81314, 1.6347826086957, 0.20217391304348, 0.022727272727273
81315, 1.6782608695652, 0.20217391304348, 0.47727272727273
81316, 1.6565217391304, 0.20217391304348, 0.45454545454545
81317, 1.6782608695652, 0.22826086956522, 0.45454545454545
81318, 1.6782608695652, 0.20217391304348, 0.43181818181818
81319, 1.6565217391304, 0.20217391304348, 0.40909090909091
81320, 1.6782608695652, 0.22826086956522, 0.40909090909091
81321, 1.6782608695652, 0.20217391304348, 0.38636363636364
81322, 1.6565217391304, 0.20217391304348, 0.36363636363636
81323, 1.6782608695652, 0.22826086956522, 0.36363636363636
81324, 1.6782608695652, 0.20217391304348, 0.34090909090909
81325, 1.6565217391304, 0.20217391304348, 0.31818181818182
81326, 1.6782608695652, 0.22826086956522, 0.31818181818182
81327, 1.6782608695652, 0.20217391304348, 0.29545454545455
81328, 1.6565217391304, 0.20217391304348, 0.27272727272727
81329, 1.6782608695652, 0.22826086956522, 0.27272727272727
81330, 1.6782608695652, 0.20217391304348, 0.25
