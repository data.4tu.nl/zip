44819, 0.26086956521739, 0.56739130434783, 0.47727272727273
44820, 0.21739130434783, 0.56739130434783, 0.022727272727273
44821, 0.23913043478261, 0.56739130434783, 0.045454545454545
44822, 0.21739130434783, 0.54130434782609, 0.045454545454545
44823, 0.21739130434783, 0.56739130434783, 0.068181818181818
44824, 0.23913043478261, 0.56739130434783, 0.090909090909091
44825, 0.21739130434783, 0.54130434782609, 0.090909090909091
44826, 0.21739130434783, 0.56739130434783, 0.11363636363636
44827, 0.23913043478261, 0.56739130434783, 0.13636363636364
44828, 0.21739130434783, 0.54130434782609, 0.13636363636364
44829, 0.21739130434783, 0.56739130434783, 0.15909090909091
44830, 0.23913043478261, 0.56739130434783, 0.18181818181818
44831, 0.21739130434783, 0.54130434782609, 0.18181818181818
44832, 0.21739130434783, 0.56739130434783, 0.20454545454545
44833, 0.23913043478261, 0.56739130434783, 0.22727272727273
44834, 0.21739130434783, 0.54130434782609, 0.22727272727273
44835, 0.21739130434783, 0.56739130434783, 0.25
44836, 0.23913043478261, 0.56739130434783, 0.27272727272727
44837, 0.21739130434783, 0.54130434782609, 0.27272727272727
44838, 0.21739130434783, 0.56739130434783, 0.29545454545455
44839, 0.23913043478261, 0.56739130434783, 0.31818181818182
44840, 0.21739130434783, 0.54130434782609, 0.31818181818182
44841, 0.21739130434783, 0.56739130434783, 0.34090909090909
44842, 0.23913043478261, 0.56739130434783, 0.36363636363636
44843, 0.21739130434783, 0.54130434782609, 0.36363636363636
44844, 0.21739130434783, 0.56739130434783, 0.38636363636364
44845, 0.23913043478261, 0.56739130434783, 0.40909090909091
44846, 0.21739130434783, 0.54130434782609, 0.40909090909091
44847, 0.21739130434783, 0.56739130434783, 0.43181818181818
44848, 0.23913043478261, 0.56739130434783, 0.45454545454545
44849, 0.21739130434783, 0.54130434782609, 0.45454545454545
44850, 0.21739130434783, 0.56739130434783, 0.47727272727273
44851, 0.17391304347826, 0.56739130434783, 0.022727272727273
44852, 0.19565217391304, 0.56739130434783, 0.045454545454545
44853, 0.17391304347826, 0.54130434782609, 0.045454545454545
44854, 0.17391304347826, 0.56739130434783, 0.068181818181818
44855, 0.19565217391304, 0.56739130434783, 0.090909090909091
44856, 0.17391304347826, 0.54130434782609, 0.090909090909091
44857, 0.17391304347826, 0.56739130434783, 0.11363636363636
44858, 0.19565217391304, 0.56739130434783, 0.13636363636364
44859, 0.17391304347826, 0.54130434782609, 0.13636363636364
44860, 0.17391304347826, 0.56739130434783, 0.15909090909091
44861, 0.19565217391304, 0.56739130434783, 0.18181818181818
44862, 0.17391304347826, 0.54130434782609, 0.18181818181818
44863, 0.17391304347826, 0.56739130434783, 0.20454545454545
44864, 0.19565217391304, 0.56739130434783, 0.22727272727273
44865, 0.17391304347826, 0.54130434782609, 0.22727272727273
44866, 0.17391304347826, 0.56739130434783, 0.25
44867, 0.19565217391304, 0.56739130434783, 0.27272727272727
44868, 0.17391304347826, 0.54130434782609, 0.27272727272727
44869, 0.17391304347826, 0.56739130434783, 0.29545454545455
44870, 0.19565217391304, 0.56739130434783, 0.31818181818182
44871, 0.17391304347826, 0.54130434782609, 0.31818181818182
44872, 0.17391304347826, 0.56739130434783, 0.34090909090909
44873, 0.19565217391304, 0.56739130434783, 0.36363636363636
44874, 0.17391304347826, 0.54130434782609, 0.36363636363636
44875, 0.17391304347826, 0.56739130434783, 0.38636363636364
44876, 0.19565217391304, 0.56739130434783, 0.40909090909091
44877, 0.17391304347826, 0.54130434782609, 0.40909090909091
44878, 0.17391304347826, 0.56739130434783, 0.43181818181818
44879, 0.19565217391304, 0.56739130434783, 0.45454545454545
44880, 0.17391304347826, 0.54130434782609, 0.45454545454545
44881, 0.17391304347826, 0.56739130434783, 0.47727272727273
44882, 0.1304347826087, 0.56739130434783, 0.022727272727273
44883, 0.15217391304348, 0.56739130434783, 0.045454545454545
44884, 0.1304347826087, 0.54130434782609, 0.045454545454545
44885, 0.1304347826087, 0.56739130434783, 0.068181818181818
44886, 0.15217391304348, 0.56739130434783, 0.090909090909091
44887, 0.1304347826087, 0.54130434782609, 0.090909090909091
44888, 0.1304347826087, 0.56739130434783, 0.11363636363636
44889, 0.15217391304348, 0.56739130434783, 0.13636363636364
44890, 0.1304347826087, 0.54130434782609, 0.13636363636364
44891, 0.1304347826087, 0.56739130434783, 0.15909090909091
44892, 0.15217391304348, 0.56739130434783, 0.18181818181818
44893, 0.1304347826087, 0.54130434782609, 0.18181818181818
44894, 0.1304347826087, 0.56739130434783, 0.20454545454545
44895, 0.15217391304348, 0.56739130434783, 0.22727272727273
44896, 0.1304347826087, 0.54130434782609, 0.22727272727273
44897, 0.1304347826087, 0.56739130434783, 0.25
44898, 0.15217391304348, 0.56739130434783, 0.27272727272727
44899, 0.1304347826087, 0.54130434782609, 0.27272727272727
44900, 0.1304347826087, 0.56739130434783, 0.29545454545455
44901, 0.15217391304348, 0.56739130434783, 0.31818181818182
44902, 0.1304347826087, 0.54130434782609, 0.31818181818182
44903, 0.1304347826087, 0.56739130434783, 0.34090909090909
44904, 0.15217391304348, 0.56739130434783, 0.36363636363636
44905, 0.1304347826087, 0.54130434782609, 0.36363636363636
44906, 0.1304347826087, 0.56739130434783, 0.38636363636364
44907, 0.15217391304348, 0.56739130434783, 0.40909090909091
44908, 0.1304347826087, 0.54130434782609, 0.40909090909091
44909, 0.1304347826087, 0.56739130434783, 0.43181818181818
44910, 0.15217391304348, 0.56739130434783, 0.45454545454545
44911, 0.1304347826087, 0.54130434782609, 0.45454545454545
44912, 0.1304347826087, 0.56739130434783, 0.47727272727273
44913, 0.08695652173913, 0.56739130434783, 0.022727272727273
44914, 0.10869565217391, 0.56739130434783, 0.045454545454545
44915, 0.08695652173913, 0.54130434782609, 0.045454545454545
44916, 0.08695652173913, 0.56739130434783, 0.068181818181818
44917, 0.10869565217391, 0.56739130434783, 0.090909090909091
44918, 0.08695652173913, 0.54130434782609, 0.090909090909091
44919, 0.08695652173913, 0.56739130434783, 0.11363636363636
44920, 0.10869565217391, 0.56739130434783, 0.13636363636364
44921, 0.08695652173913, 0.54130434782609, 0.13636363636364
44922, 0.08695652173913, 0.56739130434783, 0.15909090909091
44923, 0.10869565217391, 0.56739130434783, 0.18181818181818
44924, 0.08695652173913, 0.54130434782609, 0.18181818181818
44925, 0.08695652173913, 0.56739130434783, 0.20454545454545
44926, 0.10869565217391, 0.56739130434783, 0.22727272727273
44927, 0.08695652173913, 0.54130434782609, 0.22727272727273
44928, 0.08695652173913, 0.56739130434783, 0.25
44929, 0.10869565217391, 0.56739130434783, 0.27272727272727
44930, 0.08695652173913, 0.54130434782609, 0.27272727272727
44931, 0.08695652173913, 0.56739130434783, 0.29545454545455
44932, 0.10869565217391, 0.56739130434783, 0.31818181818182
44933, 0.08695652173913, 0.54130434782609, 0.31818181818182
44934, 0.08695652173913, 0.56739130434783, 0.34090909090909
44935, 0.10869565217391, 0.56739130434783, 0.36363636363636
44936, 0.08695652173913, 0.54130434782609, 0.36363636363636
44937, 0.08695652173913, 0.56739130434783, 0.38636363636364
44938, 0.10869565217391, 0.56739130434783, 0.40909090909091
44939, 0.08695652173913, 0.54130434782609, 0.40909090909091
44940, 0.08695652173913, 0.56739130434783, 0.43181818181818
44941, 0.10869565217391, 0.56739130434783, 0.45454545454545
44942, 0.08695652173913, 0.54130434782609, 0.45454545454545
44943, 0.08695652173913, 0.56739130434783, 0.47727272727273
44944, 0.043478260869565, 0.56739130434783, 0.022727272727273
44945, 0.065217391304348, 0.56739130434783, 0.045454545454545
44946, 0.043478260869565, 0.54130434782609, 0.045454545454545
44947, 0.043478260869565, 0.56739130434783, 0.068181818181818
44948, 0.065217391304348, 0.56739130434783, 0.090909090909091
44949, 0.043478260869565, 0.54130434782609, 0.090909090909091
44950, 0.043478260869565, 0.56739130434783, 0.11363636363636
44951, 0.065217391304348, 0.56739130434783, 0.13636363636364
44952, 0.043478260869565, 0.54130434782609, 0.13636363636364
44953, 0.043478260869565, 0.56739130434783, 0.15909090909091
44954, 0.065217391304348, 0.56739130434783, 0.18181818181818
44955, 0.043478260869565, 0.54130434782609, 0.18181818181818
44956, 0.043478260869565, 0.56739130434783, 0.20454545454545
44957, 0.065217391304348, 0.56739130434783, 0.22727272727273
44958, 0.043478260869565, 0.54130434782609, 0.22727272727273
44959, 0.043478260869565, 0.56739130434783, 0.25
44960, 0.065217391304348, 0.56739130434783, 0.27272727272727
44961, 0.043478260869565, 0.54130434782609, 0.27272727272727
44962, 0.043478260869565, 0.56739130434783, 0.29545454545455
44963, 0.065217391304348, 0.56739130434783, 0.31818181818182
44964, 0.043478260869565, 0.54130434782609, 0.31818181818182
44965, 0.043478260869565, 0.56739130434783, 0.34090909090909
44966, 0.065217391304348, 0.56739130434783, 0.36363636363636
44967, 0.043478260869565, 0.54130434782609, 0.36363636363636
44968, 0.043478260869565, 0.56739130434783, 0.38636363636364
44969, 0.065217391304348, 0.56739130434783, 0.40909090909091
44970, 0.043478260869565, 0.54130434782609, 0.40909090909091
44971, 0.043478260869565, 0.56739130434783, 0.43181818181818
44972, 0.065217391304348, 0.56739130434783, 0.45454545454545
44973, 0.043478260869565, 0.54130434782609, 0.45454545454545
44974, 0.043478260869565, 0.56739130434783, 0.47727272727273
44975, 0.021739130434783, 0.56739130434783, 0.045454545454545
44976, 0.021739130434783, 0.56739130434783, 0.090909090909091
44977, 0.021739130434783, 0.56739130434783, 0.13636363636364
44978, 0.021739130434783, 0.56739130434783, 0.18181818181818
44979, 0.021739130434783, 0.56739130434783, 0.22727272727273
44980, 0.021739130434783, 0.56739130434783, 0.27272727272727
44981, 0.021739130434783, 0.56739130434783, 0.31818181818182
44982, 0.021739130434783, 0.56739130434783, 0.36363636363636
44983, 0.021739130434783, 0.56739130434783, 0.40909090909091
44984, 0.021739130434783, 0.56739130434783, 0.45454545454545
44985, 0.95652173913043, 0.6195652173913, 0.022727272727273
44986, 0.97826086956522, 0.6195652173913, 0.045454545454545
44987, 0.95652173913043, 0.59347826086956, 0.045454545454545
44988, 0.95652173913043, 0.6195652173913, 0.068181818181818
44989, 0.97826086956522, 0.6195652173913, 0.090909090909091
44990, 0.95652173913043, 0.59347826086956, 0.090909090909091
44991, 0.95652173913043, 0.6195652173913, 0.11363636363636
44992, 0.97826086956522, 0.6195652173913, 0.13636363636364
44993, 0.95652173913043, 0.59347826086956, 0.13636363636364
44994, 0.95652173913043, 0.6195652173913, 0.15909090909091
44995, 0.97826086956522, 0.6195652173913, 0.18181818181818
44996, 0.95652173913043, 0.59347826086956, 0.18181818181818
44997, 0.95652173913044, 0.6195652173913, 0.20454545454545
44998, 0.97826086956522, 0.6195652173913, 0.22727272727273
44999, 0.95652173913043, 0.59347826086956, 0.22727272727273
45000, 0.95652173913044, 0.6195652173913, 0.25
45001, 0.97826086956522, 0.6195652173913, 0.27272727272727
45002, 0.95652173913044, 0.59347826086956, 0.27272727272727
45003, 0.95652173913044, 0.6195652173913, 0.29545454545455
45004, 0.97826086956522, 0.6195652173913, 0.31818181818182
45005, 0.95652173913044, 0.59347826086956, 0.31818181818182
45006, 0.95652173913043, 0.6195652173913, 0.34090909090909
45007, 0.97826086956522, 0.6195652173913, 0.36363636363636
45008, 0.95652173913043, 0.59347826086956, 0.36363636363636
45009, 0.95652173913043, 0.6195652173913, 0.38636363636364
45010, 0.97826086956522, 0.6195652173913, 0.40909090909091
45011, 0.95652173913043, 0.59347826086956, 0.40909090909091
45012, 0.95652173913043, 0.6195652173913, 0.43181818181818
45013, 0.97826086956522, 0.6195652173913, 0.45454545454545
45014, 0.95652173913044, 0.59347826086956, 0.45454545454545
45015, 0.95652173913043, 0.6195652173913, 0.47727272727273
45016, 0.91304347826087, 0.6195652173913, 0.022727272727273
45017, 0.93478260869565, 0.6195652173913, 0.045454545454545
45018, 0.91304347826087, 0.59347826086956, 0.045454545454545
45019, 0.91304347826087, 0.6195652173913, 0.068181818181818
45020, 0.93478260869565, 0.6195652173913, 0.090909090909091
45021, 0.91304347826087, 0.59347826086956, 0.090909090909091
45022, 0.91304347826087, 0.6195652173913, 0.11363636363636
45023, 0.93478260869565, 0.6195652173913, 0.13636363636364
45024, 0.91304347826087, 0.59347826086956, 0.13636363636364
45025, 0.91304347826087, 0.6195652173913, 0.15909090909091
45026, 0.93478260869565, 0.6195652173913, 0.18181818181818
45027, 0.91304347826087, 0.59347826086957, 0.18181818181818
45028, 0.91304347826087, 0.6195652173913, 0.20454545454545
45029, 0.93478260869565, 0.6195652173913, 0.22727272727273
45030, 0.91304347826087, 0.59347826086956, 0.22727272727273
45031, 0.91304347826087, 0.6195652173913, 0.25
45032, 0.93478260869565, 0.6195652173913, 0.27272727272727
45033, 0.91304347826087, 0.59347826086956, 0.27272727272727
45034, 0.91304347826087, 0.6195652173913, 0.29545454545455
45035, 0.93478260869565, 0.6195652173913, 0.31818181818182
45036, 0.91304347826087, 0.59347826086957, 0.31818181818182
45037, 0.91304347826087, 0.6195652173913, 0.34090909090909
45038, 0.93478260869565, 0.6195652173913, 0.36363636363636
45039, 0.91304347826087, 0.59347826086956, 0.36363636363636
45040, 0.91304347826087, 0.6195652173913, 0.38636363636364
45041, 0.93478260869565, 0.6195652173913, 0.40909090909091
45042, 0.91304347826087, 0.59347826086956, 0.40909090909091
45043, 0.91304347826087, 0.6195652173913, 0.43181818181818
45044, 0.93478260869565, 0.6195652173913, 0.45454545454545
45045, 0.91304347826087, 0.59347826086957, 0.45454545454545
45046, 0.91304347826087, 0.6195652173913, 0.47727272727273
45047, 0.8695652173913, 0.6195652173913, 0.022727272727273
45048, 0.89130434782609, 0.6195652173913, 0.045454545454545
45049, 0.8695652173913, 0.59347826086956, 0.045454545454545
45050, 0.8695652173913, 0.6195652173913, 0.068181818181818
45051, 0.89130434782609, 0.6195652173913, 0.090909090909091
45052, 0.8695652173913, 0.59347826086956, 0.090909090909091
45053, 0.8695652173913, 0.6195652173913, 0.11363636363636
45054, 0.89130434782609, 0.6195652173913, 0.13636363636364
45055, 0.8695652173913, 0.59347826086956, 0.13636363636364
45056, 0.8695652173913, 0.6195652173913, 0.15909090909091
45057, 0.89130434782609, 0.6195652173913, 0.18181818181818
45058, 0.8695652173913, 0.59347826086956, 0.18181818181818
45059, 0.8695652173913, 0.6195652173913, 0.20454545454545
45060, 0.89130434782609, 0.6195652173913, 0.22727272727273
45061, 0.8695652173913, 0.59347826086956, 0.22727272727273
45062, 0.8695652173913, 0.6195652173913, 0.25
45063, 0.89130434782609, 0.6195652173913, 0.27272727272727
45064, 0.8695652173913, 0.59347826086956, 0.27272727272727
45065, 0.8695652173913, 0.6195652173913, 0.29545454545455
45066, 0.89130434782609, 0.6195652173913, 0.31818181818182
45067, 0.8695652173913, 0.59347826086956, 0.31818181818182
45068, 0.8695652173913, 0.6195652173913, 0.34090909090909
45069, 0.89130434782609, 0.6195652173913, 0.36363636363636
45070, 0.8695652173913, 0.59347826086956, 0.36363636363636
45071, 0.8695652173913, 0.6195652173913, 0.38636363636364
45072, 0.89130434782609, 0.6195652173913, 0.40909090909091
45073, 0.8695652173913, 0.59347826086956, 0.40909090909091
45074, 0.8695652173913, 0.6195652173913, 0.43181818181818
45075, 0.89130434782609, 0.6195652173913, 0.45454545454545
45076, 0.8695652173913, 0.59347826086957, 0.45454545454545
45077, 0.8695652173913, 0.6195652173913, 0.47727272727273
45078, 0.82608695652174, 0.6195652173913, 0.022727272727273
45079, 0.84782608695652, 0.6195652173913, 0.045454545454545
45080, 0.82608695652174, 0.59347826086956, 0.045454545454545
45081, 0.82608695652174, 0.6195652173913, 0.068181818181818
45082, 0.84782608695652, 0.6195652173913, 0.090909090909091
45083, 0.82608695652174, 0.59347826086956, 0.090909090909091
45084, 0.82608695652174, 0.6195652173913, 0.11363636363636
45085, 0.84782608695652, 0.6195652173913, 0.13636363636364
45086, 0.82608695652174, 0.59347826086956, 0.13636363636364
45087, 0.82608695652174, 0.6195652173913, 0.15909090909091
45088, 0.84782608695652, 0.6195652173913, 0.18181818181818
45089, 0.82608695652174, 0.59347826086956, 0.18181818181818
45090, 0.82608695652174, 0.6195652173913, 0.20454545454545
45091, 0.84782608695652, 0.6195652173913, 0.22727272727273
45092, 0.82608695652174, 0.59347826086956, 0.22727272727273
45093, 0.82608695652174, 0.6195652173913, 0.25
45094, 0.84782608695652, 0.6195652173913, 0.27272727272727
45095, 0.82608695652174, 0.59347826086957, 0.27272727272727
45096, 0.82608695652174, 0.6195652173913, 0.29545454545455
45097, 0.84782608695652, 0.6195652173913, 0.31818181818182
45098, 0.82608695652174, 0.59347826086957, 0.31818181818182
45099, 0.82608695652174, 0.6195652173913, 0.34090909090909
45100, 0.84782608695652, 0.6195652173913, 0.36363636363636
45101, 0.82608695652174, 0.59347826086956, 0.36363636363636
45102, 0.82608695652174, 0.6195652173913, 0.38636363636364
45103, 0.84782608695652, 0.6195652173913, 0.40909090909091
45104, 0.82608695652174, 0.59347826086957, 0.40909090909091
45105, 0.82608695652174, 0.6195652173913, 0.43181818181818
45106, 0.84782608695652, 0.6195652173913, 0.45454545454545
45107, 0.82608695652174, 0.59347826086957, 0.45454545454545
45108, 0.82608695652174, 0.6195652173913, 0.47727272727273
45109, 0.78260869565217, 0.6195652173913, 0.022727272727273
45110, 0.80434782608696, 0.6195652173913, 0.045454545454545
45111, 0.78260869565217, 0.59347826086956, 0.045454545454545
45112, 0.78260869565217, 0.6195652173913, 0.068181818181818
45113, 0.80434782608696, 0.6195652173913, 0.090909090909091
45114, 0.78260869565217, 0.59347826086956, 0.090909090909091
45115, 0.78260869565217, 0.6195652173913, 0.11363636363636
45116, 0.80434782608696, 0.6195652173913, 0.13636363636364
45117, 0.78260869565217, 0.59347826086956, 0.13636363636364
45118, 0.78260869565217, 0.6195652173913, 0.15909090909091
45119, 0.80434782608696, 0.6195652173913, 0.18181818181818
45120, 0.78260869565217, 0.59347826086957, 0.18181818181818
45121, 0.78260869565217, 0.6195652173913, 0.20454545454545
45122, 0.80434782608696, 0.6195652173913, 0.22727272727273
45123, 0.78260869565217, 0.59347826086956, 0.22727272727273
45124, 0.78260869565217, 0.6195652173913, 0.25
45125, 0.80434782608696, 0.6195652173913, 0.27272727272727
45126, 0.78260869565217, 0.59347826086956, 0.27272727272727
45127, 0.78260869565217, 0.6195652173913, 0.29545454545455
45128, 0.80434782608696, 0.6195652173913, 0.31818181818182
45129, 0.78260869565217, 0.59347826086957, 0.31818181818182
45130, 0.78260869565217, 0.6195652173913, 0.34090909090909
45131, 0.80434782608696, 0.6195652173913, 0.36363636363636
45132, 0.78260869565217, 0.59347826086956, 0.36363636363636
45133, 0.78260869565217, 0.6195652173913, 0.38636363636364
45134, 0.80434782608696, 0.6195652173913, 0.40909090909091
45135, 0.78260869565217, 0.59347826086956, 0.40909090909091
45136, 0.78260869565217, 0.6195652173913, 0.43181818181818
45137, 0.80434782608696, 0.6195652173913, 0.45454545454545
45138, 0.78260869565217, 0.59347826086957, 0.45454545454545
45139, 0.78260869565217, 0.6195652173913, 0.47727272727273
45140, 0.73913043478261, 0.6195652173913, 0.022727272727273
45141, 0.76086956521739, 0.6195652173913, 0.045454545454545
45142, 0.73913043478261, 0.59347826086956, 0.045454545454545
45143, 0.73913043478261, 0.6195652173913, 0.068181818181818
45144, 0.76086956521739, 0.6195652173913, 0.090909090909091
45145, 0.73913043478261, 0.59347826086957, 0.090909090909091
45146, 0.73913043478261, 0.6195652173913, 0.11363636363636
45147, 0.76086956521739, 0.6195652173913, 0.13636363636364
45148, 0.73913043478261, 0.59347826086956, 0.13636363636364
45149, 0.73913043478261, 0.6195652173913, 0.15909090909091
45150, 0.76086956521739, 0.6195652173913, 0.18181818181818
45151, 0.73913043478261, 0.59347826086957, 0.18181818181818
45152, 0.73913043478261, 0.6195652173913, 0.20454545454545
45153, 0.76086956521739, 0.6195652173913, 0.22727272727273
45154, 0.73913043478261, 0.59347826086957, 0.22727272727273
45155, 0.73913043478261, 0.6195652173913, 0.25
45156, 0.76086956521739, 0.6195652173913, 0.27272727272727
45157, 0.73913043478261, 0.59347826086957, 0.27272727272727
45158, 0.73913043478261, 0.6195652173913, 0.29545454545455
45159, 0.76086956521739, 0.6195652173913, 0.31818181818182
45160, 0.73913043478261, 0.59347826086956, 0.31818181818182
45161, 0.73913043478261, 0.6195652173913, 0.34090909090909
45162, 0.76086956521739, 0.6195652173913, 0.36363636363636
45163, 0.73913043478261, 0.59347826086956, 0.36363636363636
45164, 0.73913043478261, 0.6195652173913, 0.38636363636364
45165, 0.76086956521739, 0.6195652173913, 0.40909090909091
45166, 0.73913043478261, 0.59347826086956, 0.40909090909091
45167, 0.73913043478261, 0.6195652173913, 0.43181818181818
45168, 0.76086956521739, 0.6195652173913, 0.45454545454545
45169, 0.73913043478261, 0.59347826086957, 0.45454545454545
45170, 0.73913043478261, 0.6195652173913, 0.47727272727273
45171, 0.69565217391304, 0.6195652173913, 0.022727272727273
45172, 0.71739130434783, 0.6195652173913, 0.045454545454545
45173, 0.69565217391304, 0.59347826086956, 0.045454545454545
45174, 0.69565217391304, 0.6195652173913, 0.068181818181818
45175, 0.71739130434783, 0.6195652173913, 0.090909090909091
45176, 0.69565217391304, 0.59347826086956, 0.090909090909091
45177, 0.69565217391304, 0.6195652173913, 0.11363636363636
45178, 0.71739130434783, 0.6195652173913, 0.13636363636364
45179, 0.69565217391304, 0.59347826086956, 0.13636363636364
45180, 0.69565217391304, 0.6195652173913, 0.15909090909091
45181, 0.71739130434783, 0.6195652173913, 0.18181818181818
45182, 0.69565217391304, 0.59347826086957, 0.18181818181818
45183, 0.69565217391304, 0.6195652173913, 0.20454545454545
45184, 0.71739130434783, 0.6195652173913, 0.22727272727273
45185, 0.69565217391304, 0.59347826086956, 0.22727272727273
45186, 0.69565217391304, 0.6195652173913, 0.25
45187, 0.71739130434783, 0.6195652173913, 0.27272727272727
45188, 0.69565217391304, 0.59347826086956, 0.27272727272727
45189, 0.69565217391304, 0.6195652173913, 0.29545454545455
45190, 0.71739130434783, 0.6195652173913, 0.31818181818182
45191, 0.69565217391304, 0.59347826086956, 0.31818181818182
45192, 0.69565217391304, 0.6195652173913, 0.34090909090909
45193, 0.71739130434783, 0.6195652173913, 0.36363636363636
45194, 0.69565217391304, 0.59347826086956, 0.36363636363636
45195, 0.69565217391304, 0.6195652173913, 0.38636363636364
45196, 0.71739130434783, 0.6195652173913, 0.40909090909091
45197, 0.69565217391304, 0.59347826086956, 0.40909090909091
45198, 0.69565217391304, 0.6195652173913, 0.43181818181818
45199, 0.71739130434783, 0.6195652173913, 0.45454545454545
45200, 0.69565217391304, 0.59347826086956, 0.45454545454545
45201, 0.69565217391304, 0.6195652173913, 0.47727272727273
45202, 0.65217391304348, 0.6195652173913, 0.022727272727273
45203, 0.67391304347826, 0.6195652173913, 0.045454545454545
45204, 0.65217391304348, 0.59347826086956, 0.045454545454545
45205, 0.65217391304348, 0.6195652173913, 0.068181818181818
45206, 0.67391304347826, 0.6195652173913, 0.090909090909091
45207, 0.65217391304348, 0.59347826086956, 0.090909090909091
45208, 0.65217391304348, 0.6195652173913, 0.11363636363636
45209, 0.67391304347826, 0.6195652173913, 0.13636363636364
45210, 0.65217391304348, 0.59347826086956, 0.13636363636364
45211, 0.65217391304348, 0.6195652173913, 0.15909090909091
45212, 0.67391304347826, 0.6195652173913, 0.18181818181818
45213, 0.65217391304348, 0.59347826086957, 0.18181818181818
45214, 0.65217391304348, 0.6195652173913, 0.20454545454545
45215, 0.67391304347826, 0.6195652173913, 0.22727272727273
45216, 0.65217391304348, 0.59347826086956, 0.22727272727273
45217, 0.65217391304348, 0.6195652173913, 0.25
45218, 0.67391304347826, 0.6195652173913, 0.27272727272727
45219, 0.65217391304348, 0.59347826086956, 0.27272727272727
45220, 0.65217391304348, 0.6195652173913, 0.29545454545455
45221, 0.67391304347826, 0.6195652173913, 0.31818181818182
45222, 0.65217391304348, 0.59347826086956, 0.31818181818182
45223, 0.65217391304348, 0.6195652173913, 0.34090909090909
45224, 0.67391304347826, 0.6195652173913, 0.36363636363636
45225, 0.65217391304348, 0.59347826086956, 0.36363636363636
45226, 0.65217391304348, 0.6195652173913, 0.38636363636364
45227, 0.67391304347826, 0.6195652173913, 0.40909090909091
45228, 0.65217391304348, 0.59347826086956, 0.40909090909091
45229, 0.65217391304348, 0.6195652173913, 0.43181818181818
45230, 0.67391304347826, 0.6195652173913, 0.45454545454545
45231, 0.65217391304348, 0.59347826086956, 0.45454545454545
45232, 0.65217391304348, 0.6195652173913, 0.47727272727273
45233, 0.60869565217391, 0.6195652173913, 0.022727272727273
45234, 0.6304347826087, 0.6195652173913, 0.045454545454545
45235, 0.60869565217391, 0.59347826086956, 0.045454545454545
45236, 0.60869565217391, 0.6195652173913, 0.068181818181818
45237, 0.6304347826087, 0.6195652173913, 0.090909090909091
45238, 0.60869565217391, 0.59347826086956, 0.090909090909091
45239, 0.60869565217391, 0.6195652173913, 0.11363636363636
45240, 0.6304347826087, 0.6195652173913, 0.13636363636364
45241, 0.60869565217391, 0.59347826086956, 0.13636363636364
45242, 0.60869565217391, 0.6195652173913, 0.15909090909091
45243, 0.6304347826087, 0.6195652173913, 0.18181818181818
45244, 0.60869565217391, 0.59347826086956, 0.18181818181818
45245, 0.60869565217391, 0.6195652173913, 0.20454545454545
45246, 0.6304347826087, 0.6195652173913, 0.22727272727273
45247, 0.60869565217391, 0.59347826086956, 0.22727272727273
45248, 0.60869565217391, 0.6195652173913, 0.25
45249, 0.6304347826087, 0.6195652173913, 0.27272727272727
45250, 0.60869565217391, 0.59347826086956, 0.27272727272727
45251, 0.60869565217391, 0.6195652173913, 0.29545454545455
45252, 0.6304347826087, 0.6195652173913, 0.31818181818182
45253, 0.60869565217391, 0.59347826086956, 0.31818181818182
45254, 0.60869565217391, 0.6195652173913, 0.34090909090909
45255, 0.6304347826087, 0.6195652173913, 0.36363636363636
45256, 0.60869565217391, 0.59347826086956, 0.36363636363636
45257, 0.60869565217391, 0.6195652173913, 0.38636363636364
45258, 0.6304347826087, 0.6195652173913, 0.40909090909091
45259, 0.60869565217391, 0.59347826086956, 0.40909090909091
45260, 0.60869565217391, 0.6195652173913, 0.43181818181818
45261, 0.6304347826087, 0.6195652173913, 0.45454545454545
45262, 0.60869565217391, 0.59347826086956, 0.45454545454545
45263, 0.60869565217391, 0.6195652173913, 0.47727272727273
45264, 0.56521739130435, 0.6195652173913, 0.022727272727273
45265, 0.58695652173913, 0.6195652173913, 0.045454545454545
45266, 0.56521739130435, 0.59347826086956, 0.045454545454545
45267, 0.56521739130435, 0.6195652173913, 0.068181818181818
45268, 0.58695652173913, 0.6195652173913, 0.090909090909091
45269, 0.56521739130435, 0.59347826086956, 0.090909090909091
45270, 0.56521739130435, 0.6195652173913, 0.11363636363636
45271, 0.58695652173913, 0.6195652173913, 0.13636363636364
45272, 0.56521739130435, 0.59347826086956, 0.13636363636364
45273, 0.56521739130435, 0.6195652173913, 0.15909090909091
45274, 0.58695652173913, 0.6195652173913, 0.18181818181818
45275, 0.56521739130435, 0.59347826086956, 0.18181818181818
45276, 0.56521739130435, 0.6195652173913, 0.20454545454545
45277, 0.58695652173913, 0.6195652173913, 0.22727272727273
45278, 0.56521739130435, 0.59347826086956, 0.22727272727273
45279, 0.56521739130435, 0.6195652173913, 0.25
45280, 0.58695652173913, 0.6195652173913, 0.27272727272727
45281, 0.56521739130435, 0.59347826086956, 0.27272727272727
45282, 0.56521739130435, 0.6195652173913, 0.29545454545455
45283, 0.58695652173913, 0.6195652173913, 0.31818181818182
45284, 0.56521739130435, 0.59347826086956, 0.31818181818182
45285, 0.56521739130435, 0.6195652173913, 0.34090909090909
45286, 0.58695652173913, 0.6195652173913, 0.36363636363636
45287, 0.56521739130435, 0.59347826086956, 0.36363636363636
45288, 0.56521739130435, 0.6195652173913, 0.38636363636364
45289, 0.58695652173913, 0.6195652173913, 0.40909090909091
45290, 0.56521739130435, 0.59347826086957, 0.40909090909091
45291, 0.56521739130435, 0.6195652173913, 0.43181818181818
45292, 0.58695652173913, 0.6195652173913, 0.45454545454545
45293, 0.56521739130435, 0.59347826086956, 0.45454545454545
45294, 0.56521739130435, 0.6195652173913, 0.47727272727273
45295, 0.52173913043478, 0.6195652173913, 0.022727272727273
45296, 0.54347826086956, 0.6195652173913, 0.045454545454545
45297, 0.52173913043478, 0.59347826086956, 0.045454545454545
45298, 0.52173913043478, 0.6195652173913, 0.068181818181818
45299, 0.54347826086956, 0.6195652173913, 0.090909090909091
45300, 0.52173913043478, 0.59347826086956, 0.090909090909091
45301, 0.52173913043478, 0.6195652173913, 0.11363636363636
45302, 0.54347826086956, 0.6195652173913, 0.13636363636364
45303, 0.52173913043478, 0.59347826086956, 0.13636363636364
45304, 0.52173913043478, 0.6195652173913, 0.15909090909091
45305, 0.54347826086956, 0.6195652173913, 0.18181818181818
45306, 0.52173913043478, 0.59347826086956, 0.18181818181818
45307, 0.52173913043478, 0.6195652173913, 0.20454545454545
45308, 0.54347826086956, 0.6195652173913, 0.22727272727273
45309, 0.52173913043478, 0.59347826086956, 0.22727272727273
45310, 0.52173913043478, 0.6195652173913, 0.25
45311, 0.54347826086956, 0.6195652173913, 0.27272727272727
45312, 0.52173913043478, 0.59347826086956, 0.27272727272727
45313, 0.52173913043478, 0.6195652173913, 0.29545454545455
45314, 0.54347826086956, 0.6195652173913, 0.31818181818182
45315, 0.52173913043478, 0.59347826086956, 0.31818181818182
45316, 0.52173913043478, 0.6195652173913, 0.34090909090909
45317, 0.54347826086956, 0.6195652173913, 0.36363636363636
45318, 0.52173913043478, 0.59347826086956, 0.36363636363636
45319, 0.52173913043478, 0.6195652173913, 0.38636363636364
45320, 0.54347826086956, 0.6195652173913, 0.40909090909091
45321, 0.52173913043478, 0.59347826086956, 0.40909090909091
45322, 0.52173913043478, 0.6195652173913, 0.43181818181818
45323, 0.54347826086957, 0.6195652173913, 0.45454545454545
45324, 0.52173913043478, 0.59347826086956, 0.45454545454545
45325, 0.52173913043478, 0.6195652173913, 0.47727272727273
45326, 0.47826086956522, 0.6195652173913, 0.022727272727273
45327, 0.5, 0.6195652173913, 0.045454545454545
45328, 0.47826086956522, 0.59347826086956, 0.045454545454545
45329, 0.47826086956522, 0.6195652173913, 0.068181818181818
45330, 0.5, 0.6195652173913, 0.090909090909091
45331, 0.47826086956522, 0.59347826086957, 0.090909090909091
45332, 0.47826086956522, 0.6195652173913, 0.11363636363636
45333, 0.5, 0.6195652173913, 0.13636363636364
45334, 0.47826086956522, 0.59347826086956, 0.13636363636364
45335, 0.47826086956522, 0.6195652173913, 0.15909090909091
45336, 0.5, 0.6195652173913, 0.18181818181818
45337, 0.47826086956522, 0.59347826086957, 0.18181818181818
45338, 0.47826086956522, 0.6195652173913, 0.20454545454545
45339, 0.5, 0.6195652173913, 0.22727272727273
45340, 0.47826086956522, 0.59347826086956, 0.22727272727273
45341, 0.47826086956522, 0.6195652173913, 0.25
45342, 0.5, 0.6195652173913, 0.27272727272727
45343, 0.47826086956522, 0.59347826086956, 0.27272727272727
45344, 0.47826086956522, 0.6195652173913, 0.29545454545455
45345, 0.5, 0.6195652173913, 0.31818181818182
45346, 0.47826086956522, 0.59347826086957, 0.31818181818182
45347, 0.47826086956522, 0.6195652173913, 0.34090909090909
45348, 0.5, 0.6195652173913, 0.36363636363636
45349, 0.47826086956522, 0.59347826086956, 0.36363636363636
45350, 0.47826086956522, 0.6195652173913, 0.38636363636364
45351, 0.5, 0.6195652173913, 0.40909090909091
45352, 0.47826086956522, 0.59347826086956, 0.40909090909091
45353, 0.47826086956522, 0.6195652173913, 0.43181818181818
45354, 0.5, 0.6195652173913, 0.45454545454545
45355, 0.47826086956522, 0.59347826086957, 0.45454545454545
45356, 0.47826086956522, 0.6195652173913, 0.47727272727273
45357, 0.43478260869565, 0.6195652173913, 0.022727272727273
45358, 0.45652173913043, 0.6195652173913, 0.045454545454545
45359, 0.43478260869565, 0.59347826086956, 0.045454545454545
45360, 0.43478260869565, 0.6195652173913, 0.068181818181818
45361, 0.45652173913043, 0.6195652173913, 0.090909090909091
45362, 0.43478260869565, 0.59347826086956, 0.090909090909091
45363, 0.43478260869565, 0.6195652173913, 0.11363636363636
45364, 0.45652173913043, 0.6195652173913, 0.13636363636364
45365, 0.43478260869565, 0.59347826086956, 0.13636363636364
45366, 0.43478260869565, 0.6195652173913, 0.15909090909091
45367, 0.45652173913043, 0.6195652173913, 0.18181818181818
45368, 0.43478260869565, 0.59347826086956, 0.18181818181818
45369, 0.43478260869565, 0.6195652173913, 0.20454545454545
45370, 0.45652173913043, 0.6195652173913, 0.22727272727273
45371, 0.43478260869565, 0.59347826086956, 0.22727272727273
45372, 0.43478260869565, 0.6195652173913, 0.25
45373, 0.45652173913043, 0.6195652173913, 0.27272727272727
45374, 0.43478260869565, 0.59347826086956, 0.27272727272727
45375, 0.43478260869565, 0.6195652173913, 0.29545454545455
45376, 0.45652173913043, 0.6195652173913, 0.31818181818182
45377, 0.43478260869565, 0.59347826086956, 0.31818181818182
45378, 0.43478260869565, 0.6195652173913, 0.34090909090909
45379, 0.45652173913043, 0.6195652173913, 0.36363636363636
45380, 0.43478260869565, 0.59347826086956, 0.36363636363636
45381, 0.43478260869565, 0.6195652173913, 0.38636363636364
45382, 0.45652173913043, 0.6195652173913, 0.40909090909091
45383, 0.43478260869565, 0.59347826086956, 0.40909090909091
45384, 0.43478260869565, 0.6195652173913, 0.43181818181818
45385, 0.45652173913043, 0.6195652173913, 0.45454545454545
45386, 0.43478260869565, 0.59347826086957, 0.45454545454545
45387, 0.43478260869565, 0.6195652173913, 0.47727272727273
45388, 0.39130434782609, 0.6195652173913, 0.022727272727273
45389, 0.41304347826087, 0.6195652173913, 0.045454545454545
45390, 0.39130434782609, 0.59347826086956, 0.045454545454545
45391, 0.39130434782609, 0.6195652173913, 0.068181818181818
45392, 0.41304347826087, 0.6195652173913, 0.090909090909091
45393, 0.39130434782609, 0.59347826086956, 0.090909090909091
45394, 0.39130434782609, 0.6195652173913, 0.11363636363636
45395, 0.41304347826087, 0.6195652173913, 0.13636363636364
45396, 0.39130434782609, 0.59347826086956, 0.13636363636364
45397, 0.39130434782609, 0.6195652173913, 0.15909090909091
45398, 0.41304347826087, 0.6195652173913, 0.18181818181818
45399, 0.39130434782609, 0.59347826086956, 0.18181818181818
45400, 0.39130434782609, 0.6195652173913, 0.20454545454545
45401, 0.41304347826087, 0.6195652173913, 0.22727272727273
45402, 0.39130434782609, 0.59347826086956, 0.22727272727273
45403, 0.39130434782609, 0.6195652173913, 0.25
45404, 0.41304347826087, 0.6195652173913, 0.27272727272727
45405, 0.39130434782609, 0.59347826086956, 0.27272727272727
45406, 0.39130434782609, 0.6195652173913, 0.29545454545455
45407, 0.41304347826087, 0.6195652173913, 0.31818181818182
45408, 0.39130434782609, 0.59347826086956, 0.31818181818182
45409, 0.39130434782609, 0.6195652173913, 0.34090909090909
45410, 0.41304347826087, 0.6195652173913, 0.36363636363636
45411, 0.39130434782609, 0.59347826086956, 0.36363636363636
45412, 0.39130434782609, 0.6195652173913, 0.38636363636364
45413, 0.41304347826087, 0.6195652173913, 0.40909090909091
45414, 0.39130434782609, 0.59347826086956, 0.40909090909091
45415, 0.39130434782609, 0.6195652173913, 0.43181818181818
45416, 0.41304347826087, 0.6195652173913, 0.45454545454545
45417, 0.39130434782609, 0.59347826086956, 0.45454545454545
45418, 0.39130434782609, 0.6195652173913, 0.47727272727273
45419, 0.34782608695652, 0.6195652173913, 0.022727272727273
45420, 0.3695652173913, 0.6195652173913, 0.045454545454545
45421, 0.34782608695652, 0.59347826086956, 0.045454545454545
45422, 0.34782608695652, 0.6195652173913, 0.068181818181818
45423, 0.3695652173913, 0.6195652173913, 0.090909090909091
45424, 0.34782608695652, 0.59347826086956, 0.090909090909091
45425, 0.34782608695652, 0.6195652173913, 0.11363636363636
45426, 0.3695652173913, 0.6195652173913, 0.13636363636364
45427, 0.34782608695652, 0.59347826086956, 0.13636363636364
45428, 0.34782608695652, 0.6195652173913, 0.15909090909091
45429, 0.3695652173913, 0.6195652173913, 0.18181818181818
45430, 0.34782608695652, 0.59347826086957, 0.18181818181818
45431, 0.34782608695652, 0.6195652173913, 0.20454545454545
45432, 0.3695652173913, 0.6195652173913, 0.22727272727273
45433, 0.34782608695652, 0.59347826086956, 0.22727272727273
45434, 0.34782608695652, 0.6195652173913, 0.25
45435, 0.3695652173913, 0.6195652173913, 0.27272727272727
45436, 0.34782608695652, 0.59347826086956, 0.27272727272727
45437, 0.34782608695652, 0.6195652173913, 0.29545454545455
45438, 0.3695652173913, 0.6195652173913, 0.31818181818182
45439, 0.34782608695652, 0.59347826086956, 0.31818181818182
45440, 0.34782608695652, 0.6195652173913, 0.34090909090909
45441, 0.3695652173913, 0.6195652173913, 0.36363636363636
45442, 0.34782608695652, 0.59347826086956, 0.36363636363636
45443, 0.34782608695652, 0.6195652173913, 0.38636363636364
45444, 0.3695652173913, 0.6195652173913, 0.40909090909091
45445, 0.34782608695652, 0.59347826086956, 0.40909090909091
45446, 0.34782608695652, 0.6195652173913, 0.43181818181818
45447, 0.3695652173913, 0.6195652173913, 0.45454545454545
45448, 0.34782608695652, 0.59347826086956, 0.45454545454545
45449, 0.34782608695652, 0.6195652173913, 0.47727272727273
45450, 0.30434782608696, 0.6195652173913, 0.022727272727273
45451, 0.32608695652174, 0.6195652173913, 0.045454545454545
45452, 0.30434782608696, 0.59347826086956, 0.045454545454545
45453, 0.30434782608696, 0.6195652173913, 0.068181818181818
45454, 0.32608695652174, 0.6195652173913, 0.090909090909091
45455, 0.30434782608696, 0.59347826086956, 0.090909090909091
45456, 0.30434782608696, 0.6195652173913, 0.11363636363636
45457, 0.32608695652174, 0.6195652173913, 0.13636363636364
45458, 0.30434782608696, 0.59347826086956, 0.13636363636364
45459, 0.30434782608696, 0.6195652173913, 0.15909090909091
45460, 0.32608695652174, 0.6195652173913, 0.18181818181818
45461, 0.30434782608696, 0.59347826086956, 0.18181818181818
45462, 0.30434782608696, 0.6195652173913, 0.20454545454545
45463, 0.32608695652174, 0.6195652173913, 0.22727272727273
45464, 0.30434782608696, 0.59347826086956, 0.22727272727273
45465, 0.30434782608696, 0.6195652173913, 0.25
45466, 0.32608695652174, 0.6195652173913, 0.27272727272727
45467, 0.30434782608696, 0.59347826086956, 0.27272727272727
45468, 0.30434782608696, 0.6195652173913, 0.29545454545455
45469, 0.32608695652174, 0.6195652173913, 0.31818181818182
45470, 0.30434782608696, 0.59347826086956, 0.31818181818182
45471, 0.30434782608696, 0.6195652173913, 0.34090909090909
45472, 0.32608695652174, 0.6195652173913, 0.36363636363636
45473, 0.30434782608696, 0.59347826086956, 0.36363636363636
45474, 0.30434782608696, 0.6195652173913, 0.38636363636364
45475, 0.32608695652174, 0.6195652173913, 0.40909090909091
45476, 0.30434782608696, 0.59347826086957, 0.40909090909091
45477, 0.30434782608696, 0.6195652173913, 0.43181818181818
45478, 0.32608695652174, 0.6195652173913, 0.45454545454545
45479, 0.30434782608696, 0.59347826086957, 0.45454545454545
45480, 0.30434782608696, 0.6195652173913, 0.47727272727273
45481, 0.26086956521739, 0.6195652173913, 0.022727272727273
45482, 0.28260869565217, 0.6195652173913, 0.045454545454545
45483, 0.26086956521739, 0.59347826086956, 0.045454545454545
45484, 0.26086956521739, 0.6195652173913, 0.068181818181818
45485, 0.28260869565217, 0.6195652173913, 0.090909090909091
45486, 0.26086956521739, 0.59347826086956, 0.090909090909091
45487, 0.26086956521739, 0.6195652173913, 0.11363636363636
45488, 0.28260869565217, 0.6195652173913, 0.13636363636364
45489, 0.26086956521739, 0.59347826086956, 0.13636363636364
45490, 0.26086956521739, 0.6195652173913, 0.15909090909091
45491, 0.28260869565217, 0.6195652173913, 0.18181818181818
45492, 0.26086956521739, 0.59347826086957, 0.18181818181818
45493, 0.26086956521739, 0.6195652173913, 0.20454545454545
45494, 0.28260869565217, 0.6195652173913, 0.22727272727273
45495, 0.26086956521739, 0.59347826086956, 0.22727272727273
45496, 0.26086956521739, 0.6195652173913, 0.25
45497, 0.28260869565217, 0.6195652173913, 0.27272727272727
45498, 0.26086956521739, 0.59347826086956, 0.27272727272727
45499, 0.26086956521739, 0.6195652173913, 0.29545454545455
45500, 0.28260869565217, 0.6195652173913, 0.31818181818182
45501, 0.26086956521739, 0.59347826086956, 0.31818181818182
45502, 0.26086956521739, 0.6195652173913, 0.34090909090909
45503, 0.28260869565217, 0.6195652173913, 0.36363636363636
45504, 0.26086956521739, 0.59347826086956, 0.36363636363636
45505, 0.26086956521739, 0.6195652173913, 0.38636363636364
45506, 0.28260869565217, 0.6195652173913, 0.40909090909091
45507, 0.26086956521739, 0.59347826086956, 0.40909090909091
45508, 0.26086956521739, 0.6195652173913, 0.43181818181818
45509, 0.28260869565217, 0.6195652173913, 0.45454545454545
45510, 0.26086956521739, 0.59347826086956, 0.45454545454545
45511, 0.26086956521739, 0.6195652173913, 0.47727272727273
45512, 0.21739130434783, 0.6195652173913, 0.022727272727273
45513, 0.23913043478261, 0.6195652173913, 0.045454545454545
45514, 0.21739130434783, 0.59347826086956, 0.045454545454545
45515, 0.21739130434783, 0.6195652173913, 0.068181818181818
45516, 0.23913043478261, 0.6195652173913, 0.090909090909091
45517, 0.21739130434783, 0.59347826086956, 0.090909090909091
45518, 0.21739130434783, 0.6195652173913, 0.11363636363636
45519, 0.23913043478261, 0.6195652173913, 0.13636363636364
45520, 0.21739130434783, 0.59347826086956, 0.13636363636364
45521, 0.21739130434783, 0.6195652173913, 0.15909090909091
45522, 0.23913043478261, 0.6195652173913, 0.18181818181818
45523, 0.21739130434783, 0.59347826086956, 0.18181818181818
45524, 0.21739130434783, 0.6195652173913, 0.20454545454545
45525, 0.23913043478261, 0.6195652173913, 0.22727272727273
45526, 0.21739130434783, 0.59347826086956, 0.22727272727273
45527, 0.21739130434783, 0.6195652173913, 0.25
45528, 0.23913043478261, 0.6195652173913, 0.27272727272727
45529, 0.21739130434783, 0.59347826086956, 0.27272727272727
45530, 0.21739130434783, 0.6195652173913, 0.29545454545455
45531, 0.23913043478261, 0.6195652173913, 0.31818181818182
45532, 0.21739130434783, 0.59347826086956, 0.31818181818182
45533, 0.21739130434783, 0.6195652173913, 0.34090909090909
45534, 0.23913043478261, 0.6195652173913, 0.36363636363636
45535, 0.21739130434783, 0.59347826086956, 0.36363636363636
45536, 0.21739130434783, 0.6195652173913, 0.38636363636364
45537, 0.23913043478261, 0.6195652173913, 0.40909090909091
45538, 0.21739130434783, 0.59347826086956, 0.40909090909091
45539, 0.21739130434783, 0.6195652173913, 0.43181818181818
45540, 0.23913043478261, 0.6195652173913, 0.45454545454545
45541, 0.21739130434783, 0.59347826086956, 0.45454545454545
45542, 0.21739130434783, 0.6195652173913, 0.47727272727273
45543, 0.17391304347826, 0.6195652173913, 0.022727272727273
45544, 0.19565217391304, 0.6195652173913, 0.045454545454545
45545, 0.17391304347826, 0.59347826086956, 0.045454545454545
45546, 0.17391304347826, 0.6195652173913, 0.068181818181818
45547, 0.19565217391304, 0.6195652173913, 0.090909090909091
45548, 0.17391304347826, 0.59347826086956, 0.090909090909091
45549, 0.17391304347826, 0.6195652173913, 0.11363636363636
45550, 0.19565217391304, 0.6195652173913, 0.13636363636364
45551, 0.17391304347826, 0.59347826086956, 0.13636363636364
45552, 0.17391304347826, 0.6195652173913, 0.15909090909091
45553, 0.19565217391304, 0.6195652173913, 0.18181818181818
45554, 0.17391304347826, 0.59347826086956, 0.18181818181818
45555, 0.17391304347826, 0.6195652173913, 0.20454545454545
45556, 0.19565217391304, 0.6195652173913, 0.22727272727273
45557, 0.17391304347826, 0.59347826086956, 0.22727272727273
45558, 0.17391304347826, 0.6195652173913, 0.25
45559, 0.19565217391304, 0.6195652173913, 0.27272727272727
45560, 0.17391304347826, 0.59347826086956, 0.27272727272727
45561, 0.17391304347826, 0.6195652173913, 0.29545454545455
45562, 0.19565217391304, 0.6195652173913, 0.31818181818182
45563, 0.17391304347826, 0.59347826086956, 0.31818181818182
45564, 0.17391304347826, 0.6195652173913, 0.34090909090909
45565, 0.19565217391304, 0.6195652173913, 0.36363636363636
45566, 0.17391304347826, 0.59347826086956, 0.36363636363636
45567, 0.17391304347826, 0.6195652173913, 0.38636363636364
45568, 0.19565217391304, 0.6195652173913, 0.40909090909091
45569, 0.17391304347826, 0.59347826086956, 0.40909090909091
45570, 0.17391304347826, 0.6195652173913, 0.43181818181818
45571, 0.19565217391304, 0.6195652173913, 0.45454545454545
45572, 0.17391304347826, 0.59347826086956, 0.45454545454545
45573, 0.17391304347826, 0.6195652173913, 0.47727272727273
45574, 0.1304347826087, 0.6195652173913, 0.022727272727273
45575, 0.15217391304348, 0.6195652173913, 0.045454545454545
45576, 0.1304347826087, 0.59347826086956, 0.045454545454545
45577, 0.1304347826087, 0.6195652173913, 0.068181818181818
45578, 0.15217391304348, 0.6195652173913, 0.090909090909091
45579, 0.1304347826087, 0.59347826086956, 0.090909090909091
45580, 0.1304347826087, 0.6195652173913, 0.11363636363636
45581, 0.15217391304348, 0.6195652173913, 0.13636363636364
45582, 0.1304347826087, 0.59347826086956, 0.13636363636364
45583, 0.1304347826087, 0.6195652173913, 0.15909090909091
45584, 0.15217391304348, 0.6195652173913, 0.18181818181818
45585, 0.1304347826087, 0.59347826086956, 0.18181818181818
45586, 0.1304347826087, 0.6195652173913, 0.20454545454545
45587, 0.15217391304348, 0.6195652173913, 0.22727272727273
45588, 0.1304347826087, 0.59347826086956, 0.22727272727273
45589, 0.1304347826087, 0.6195652173913, 0.25
45590, 0.15217391304348, 0.6195652173913, 0.27272727272727
45591, 0.1304347826087, 0.59347826086956, 0.27272727272727
45592, 0.1304347826087, 0.6195652173913, 0.29545454545455
45593, 0.15217391304348, 0.6195652173913, 0.31818181818182
45594, 0.1304347826087, 0.59347826086956, 0.31818181818182
45595, 0.1304347826087, 0.6195652173913, 0.34090909090909
45596, 0.15217391304348, 0.6195652173913, 0.36363636363636
45597, 0.1304347826087, 0.59347826086956, 0.36363636363636
45598, 0.1304347826087, 0.6195652173913, 0.38636363636364
45599, 0.15217391304348, 0.6195652173913, 0.40909090909091
45600, 0.1304347826087, 0.59347826086957, 0.40909090909091
45601, 0.1304347826087, 0.6195652173913, 0.43181818181818
45602, 0.15217391304348, 0.6195652173913, 0.45454545454545
45603, 0.1304347826087, 0.59347826086956, 0.45454545454545
45604, 0.1304347826087, 0.6195652173913, 0.47727272727273
45605, 0.08695652173913, 0.6195652173913, 0.022727272727273
45606, 0.10869565217391, 0.6195652173913, 0.045454545454545
45607, 0.08695652173913, 0.59347826086956, 0.045454545454545
45608, 0.08695652173913, 0.6195652173913, 0.068181818181818
45609, 0.10869565217391, 0.6195652173913, 0.090909090909091
45610, 0.08695652173913, 0.59347826086956, 0.090909090909091
45611, 0.08695652173913, 0.6195652173913, 0.11363636363636
45612, 0.10869565217391, 0.6195652173913, 0.13636363636364
45613, 0.08695652173913, 0.59347826086956, 0.13636363636364
45614, 0.08695652173913, 0.6195652173913, 0.15909090909091
45615, 0.10869565217391, 0.6195652173913, 0.18181818181818
45616, 0.08695652173913, 0.59347826086956, 0.18181818181818
45617, 0.08695652173913, 0.6195652173913, 0.20454545454545
45618, 0.10869565217391, 0.6195652173913, 0.22727272727273
45619, 0.08695652173913, 0.59347826086956, 0.22727272727273
45620, 0.08695652173913, 0.6195652173913, 0.25
45621, 0.10869565217391, 0.6195652173913, 0.27272727272727
45622, 0.08695652173913, 0.59347826086956, 0.27272727272727
45623, 0.08695652173913, 0.6195652173913, 0.29545454545455
45624, 0.10869565217391, 0.6195652173913, 0.31818181818182
45625, 0.08695652173913, 0.59347826086956, 0.31818181818182
45626, 0.08695652173913, 0.6195652173913, 0.34090909090909
45627, 0.10869565217391, 0.6195652173913, 0.36363636363636
45628, 0.08695652173913, 0.59347826086956, 0.36363636363636
45629, 0.08695652173913, 0.6195652173913, 0.38636363636364
45630, 0.10869565217391, 0.6195652173913, 0.40909090909091
45631, 0.08695652173913, 0.59347826086956, 0.40909090909091
45632, 0.08695652173913, 0.6195652173913, 0.43181818181818
45633, 0.10869565217391, 0.6195652173913, 0.45454545454545
45634, 0.08695652173913, 0.59347826086957, 0.45454545454545
45635, 0.08695652173913, 0.6195652173913, 0.47727272727273
45636, 0.043478260869565, 0.6195652173913, 0.022727272727273
45637, 0.065217391304348, 0.6195652173913, 0.045454545454545
45638, 0.043478260869565, 0.59347826086956, 0.045454545454545
45639, 0.043478260869565, 0.6195652173913, 0.068181818181818
45640, 0.065217391304348, 0.6195652173913, 0.090909090909091
45641, 0.043478260869565, 0.59347826086956, 0.090909090909091
45642, 0.043478260869565, 0.6195652173913, 0.11363636363636
45643, 0.065217391304348, 0.6195652173913, 0.13636363636364
45644, 0.043478260869565, 0.59347826086956, 0.13636363636364
45645, 0.043478260869565, 0.6195652173913, 0.15909090909091
45646, 0.065217391304348, 0.6195652173913, 0.18181818181818
45647, 0.043478260869565, 0.59347826086956, 0.18181818181818
45648, 0.043478260869565, 0.6195652173913, 0.20454545454545
45649, 0.065217391304348, 0.6195652173913, 0.22727272727273
45650, 0.043478260869565, 0.59347826086956, 0.22727272727273
45651, 0.043478260869565, 0.6195652173913, 0.25
45652, 0.065217391304348, 0.6195652173913, 0.27272727272727
45653, 0.043478260869565, 0.59347826086956, 0.27272727272727
45654, 0.043478260869565, 0.6195652173913, 0.29545454545455
45655, 0.065217391304348, 0.6195652173913, 0.31818181818182
45656, 0.043478260869565, 0.59347826086956, 0.31818181818182
45657, 0.043478260869565, 0.6195652173913, 0.34090909090909
45658, 0.065217391304348, 0.6195652173913, 0.36363636363636
45659, 0.043478260869565, 0.59347826086956, 0.36363636363636
45660, 0.043478260869565, 0.6195652173913, 0.38636363636364
45661, 0.065217391304348, 0.6195652173913, 0.40909090909091
45662, 0.043478260869565, 0.59347826086956, 0.40909090909091
45663, 0.043478260869565, 0.6195652173913, 0.43181818181818
45664, 0.065217391304348, 0.6195652173913, 0.45454545454545
45665, 0.043478260869565, 0.59347826086956, 0.45454545454545
45666, 0.043478260869565, 0.6195652173913, 0.47727272727273
45667, 0.021739130434783, 0.6195652173913, 0.045454545454545
45668, 0.021739130434783, 0.6195652173913, 0.090909090909091
45669, 0.021739130434783, 0.6195652173913, 0.13636363636364
45670, 0.021739130434783, 0.6195652173913, 0.18181818181818
45671, 0.021739130434783, 0.6195652173913, 0.22727272727273
45672, 0.021739130434783, 0.6195652173913, 0.27272727272727
45673, 0.021739130434783, 0.6195652173913, 0.31818181818182
45674, 0.021739130434783, 0.6195652173913, 0.36363636363636
45675, 0.021739130434783, 0.6195652173913, 0.40909090909091
45676, 0.021739130434783, 0.6195652173913, 0.45454545454545
45677, 0.95652173913043, 0.67173913043478, 0.022727272727273
45678, 0.97826086956522, 0.67173913043478, 0.045454545454545
45679, 0.95652173913043, 0.64565217391304, 0.045454545454545
45680, 0.95652173913043, 0.67173913043478, 0.068181818181818
45681, 0.97826086956522, 0.67173913043478, 0.090909090909091
45682, 0.95652173913043, 0.64565217391304, 0.090909090909091
45683, 0.95652173913043, 0.67173913043478, 0.11363636363636
45684, 0.97826086956522, 0.67173913043478, 0.13636363636364
45685, 0.95652173913043, 0.64565217391304, 0.13636363636364
45686, 0.95652173913043, 0.67173913043478, 0.15909090909091
45687, 0.97826086956522, 0.67173913043478, 0.18181818181818
45688, 0.95652173913043, 0.64565217391304, 0.18181818181818
45689, 0.95652173913043, 0.67173913043478, 0.20454545454545
45690, 0.97826086956522, 0.67173913043478, 0.22727272727273
45691, 0.95652173913044, 0.64565217391304, 0.22727272727273
45692, 0.95652173913044, 0.67173913043478, 0.25
45693, 0.97826086956522, 0.67173913043478, 0.27272727272727
45694, 0.95652173913044, 0.64565217391304, 0.27272727272727
45695, 0.95652173913044, 0.67173913043478, 0.29545454545455
45696, 0.97826086956522, 0.67173913043478, 0.31818181818182
45697, 0.95652173913044, 0.64565217391304, 0.31818181818182
45698, 0.95652173913043, 0.67173913043478, 0.34090909090909
45699, 0.97826086956522, 0.67173913043478, 0.36363636363636
45700, 0.95652173913043, 0.64565217391304, 0.36363636363636
45701, 0.95652173913043, 0.67173913043478, 0.38636363636364
45702, 0.97826086956522, 0.67173913043478, 0.40909090909091
45703, 0.95652173913043, 0.64565217391304, 0.40909090909091
45704, 0.95652173913043, 0.67173913043478, 0.43181818181818
45705, 0.97826086956522, 0.67173913043478, 0.45454545454545
45706, 0.95652173913044, 0.64565217391304, 0.45454545454545
45707, 0.95652173913043, 0.67173913043478, 0.47727272727273
45708, 0.91304347826087, 0.67173913043478, 0.022727272727273
45709, 0.93478260869565, 0.67173913043478, 0.045454545454545
45710, 0.91304347826087, 0.64565217391304, 0.045454545454545
45711, 0.91304347826087, 0.67173913043478, 0.068181818181818
45712, 0.93478260869565, 0.67173913043478, 0.090909090909091
45713, 0.91304347826087, 0.64565217391304, 0.090909090909091
45714, 0.91304347826087, 0.67173913043478, 0.11363636363636
45715, 0.93478260869565, 0.67173913043478, 0.13636363636364
45716, 0.91304347826087, 0.64565217391304, 0.13636363636364
45717, 0.91304347826087, 0.67173913043478, 0.15909090909091
45718, 0.93478260869565, 0.67173913043478, 0.18181818181818
45719, 0.91304347826087, 0.64565217391304, 0.18181818181818
45720, 0.91304347826087, 0.67173913043478, 0.20454545454545
45721, 0.93478260869565, 0.67173913043478, 0.22727272727273
45722, 0.91304347826087, 0.64565217391304, 0.22727272727273
45723, 0.91304347826087, 0.67173913043478, 0.25
45724, 0.93478260869565, 0.67173913043478, 0.27272727272727
45725, 0.91304347826087, 0.64565217391304, 0.27272727272727
45726, 0.91304347826087, 0.67173913043478, 0.29545454545455
45727, 0.93478260869565, 0.67173913043478, 0.31818181818182
45728, 0.91304347826087, 0.64565217391304, 0.31818181818182
45729, 0.91304347826087, 0.67173913043478, 0.34090909090909
45730, 0.93478260869565, 0.67173913043478, 0.36363636363636
45731, 0.91304347826087, 0.64565217391304, 0.36363636363636
45732, 0.91304347826087, 0.67173913043478, 0.38636363636364
45733, 0.93478260869565, 0.67173913043478, 0.40909090909091
45734, 0.91304347826087, 0.64565217391304, 0.40909090909091
45735, 0.91304347826087, 0.67173913043478, 0.43181818181818
45736, 0.93478260869565, 0.67173913043478, 0.45454545454545
45737, 0.91304347826087, 0.64565217391304, 0.45454545454545
45738, 0.91304347826087, 0.67173913043478, 0.47727272727273
45739, 0.8695652173913, 0.67173913043478, 0.022727272727273
45740, 0.89130434782609, 0.67173913043478, 0.045454545454545
45741, 0.8695652173913, 0.64565217391304, 0.045454545454545
45742, 0.8695652173913, 0.67173913043478, 0.068181818181818
45743, 0.89130434782609, 0.67173913043478, 0.090909090909091
45744, 0.8695652173913, 0.64565217391304, 0.090909090909091
45745, 0.8695652173913, 0.67173913043478, 0.11363636363636
45746, 0.89130434782609, 0.67173913043478, 0.13636363636364
45747, 0.8695652173913, 0.64565217391304, 0.13636363636364
45748, 0.8695652173913, 0.67173913043478, 0.15909090909091
45749, 0.89130434782609, 0.67173913043478, 0.18181818181818
45750, 0.8695652173913, 0.64565217391304, 0.18181818181818
45751, 0.8695652173913, 0.67173913043478, 0.20454545454545
45752, 0.89130434782609, 0.67173913043478, 0.22727272727273
45753, 0.8695652173913, 0.64565217391304, 0.22727272727273
45754, 0.8695652173913, 0.67173913043478, 0.25
45755, 0.89130434782609, 0.67173913043478, 0.27272727272727
45756, 0.8695652173913, 0.64565217391304, 0.27272727272727
45757, 0.8695652173913, 0.67173913043478, 0.29545454545455
45758, 0.89130434782609, 0.67173913043478, 0.31818181818182
45759, 0.8695652173913, 0.64565217391304, 0.31818181818182
45760, 0.8695652173913, 0.67173913043478, 0.34090909090909
45761, 0.89130434782609, 0.67173913043478, 0.36363636363636
45762, 0.8695652173913, 0.64565217391304, 0.36363636363636
45763, 0.8695652173913, 0.67173913043478, 0.38636363636364
45764, 0.89130434782609, 0.67173913043478, 0.40909090909091
45765, 0.8695652173913, 0.64565217391304, 0.40909090909091
45766, 0.8695652173913, 0.67173913043478, 0.43181818181818
45767, 0.89130434782609, 0.67173913043478, 0.45454545454545
45768, 0.8695652173913, 0.64565217391304, 0.45454545454545
45769, 0.8695652173913, 0.67173913043478, 0.47727272727273
45770, 0.82608695652174, 0.67173913043478, 0.022727272727273
45771, 0.84782608695652, 0.67173913043478, 0.045454545454545
45772, 0.82608695652174, 0.64565217391304, 0.045454545454545
45773, 0.82608695652174, 0.67173913043478, 0.068181818181818
45774, 0.84782608695652, 0.67173913043478, 0.090909090909091
45775, 0.82608695652174, 0.64565217391304, 0.090909090909091
45776, 0.82608695652174, 0.67173913043478, 0.11363636363636
45777, 0.84782608695652, 0.67173913043478, 0.13636363636364
45778, 0.82608695652174, 0.64565217391304, 0.13636363636364
45779, 0.82608695652174, 0.67173913043478, 0.15909090909091
45780, 0.84782608695652, 0.67173913043478, 0.18181818181818
45781, 0.82608695652174, 0.64565217391304, 0.18181818181818
45782, 0.82608695652174, 0.67173913043478, 0.20454545454545
45783, 0.84782608695652, 0.67173913043478, 0.22727272727273
45784, 0.82608695652174, 0.64565217391304, 0.22727272727273
45785, 0.82608695652174, 0.67173913043478, 0.25
45786, 0.84782608695652, 0.67173913043478, 0.27272727272727
45787, 0.82608695652174, 0.64565217391304, 0.27272727272727
45788, 0.82608695652174, 0.67173913043478, 0.29545454545455
45789, 0.84782608695652, 0.67173913043478, 0.31818181818182
45790, 0.82608695652174, 0.64565217391304, 0.31818181818182
45791, 0.82608695652174, 0.67173913043478, 0.34090909090909
45792, 0.84782608695652, 0.67173913043478, 0.36363636363636
45793, 0.82608695652174, 0.64565217391304, 0.36363636363636
45794, 0.82608695652174, 0.67173913043478, 0.38636363636364
45795, 0.84782608695652, 0.67173913043478, 0.40909090909091
45796, 0.82608695652174, 0.64565217391304, 0.40909090909091
45797, 0.82608695652174, 0.67173913043478, 0.43181818181818
45798, 0.84782608695652, 0.67173913043478, 0.45454545454545
45799, 0.82608695652174, 0.64565217391304, 0.45454545454545
45800, 0.82608695652174, 0.67173913043478, 0.47727272727273
45801, 0.78260869565217, 0.67173913043478, 0.022727272727273
45802, 0.80434782608696, 0.67173913043478, 0.045454545454545
45803, 0.78260869565217, 0.64565217391304, 0.045454545454545
45804, 0.78260869565217, 0.67173913043478, 0.068181818181818
45805, 0.80434782608696, 0.67173913043478, 0.090909090909091
45806, 0.78260869565217, 0.64565217391304, 0.090909090909091
45807, 0.78260869565217, 0.67173913043478, 0.11363636363636
45808, 0.80434782608696, 0.67173913043478, 0.13636363636364
45809, 0.78260869565217, 0.64565217391304, 0.13636363636364
45810, 0.78260869565217, 0.67173913043478, 0.15909090909091
45811, 0.80434782608696, 0.67173913043478, 0.18181818181818
45812, 0.78260869565217, 0.64565217391304, 0.18181818181818
45813, 0.78260869565217, 0.67173913043478, 0.20454545454545
45814, 0.80434782608696, 0.67173913043478, 0.22727272727273
45815, 0.78260869565217, 0.64565217391304, 0.22727272727273
45816, 0.78260869565217, 0.67173913043478, 0.25
45817, 0.80434782608696, 0.67173913043478, 0.27272727272727
45818, 0.78260869565217, 0.64565217391304, 0.27272727272727
45819, 0.78260869565217, 0.67173913043478, 0.29545454545455
45820, 0.80434782608696, 0.67173913043478, 0.31818181818182
45821, 0.78260869565217, 0.64565217391304, 0.31818181818182
45822, 0.78260869565217, 0.67173913043478, 0.34090909090909
45823, 0.80434782608696, 0.67173913043478, 0.36363636363636
45824, 0.78260869565217, 0.64565217391304, 0.36363636363636
45825, 0.78260869565217, 0.67173913043478, 0.38636363636364
45826, 0.80434782608696, 0.67173913043478, 0.40909090909091
45827, 0.78260869565217, 0.64565217391304, 0.40909090909091
45828, 0.78260869565217, 0.67173913043478, 0.43181818181818
45829, 0.80434782608696, 0.67173913043478, 0.45454545454545
45830, 0.78260869565217, 0.64565217391304, 0.45454545454545
45831, 0.78260869565217, 0.67173913043478, 0.47727272727273
45832, 0.73913043478261, 0.67173913043478, 0.022727272727273
45833, 0.76086956521739, 0.67173913043478, 0.045454545454545
45834, 0.73913043478261, 0.64565217391304, 0.045454545454545
45835, 0.73913043478261, 0.67173913043478, 0.068181818181818
45836, 0.76086956521739, 0.67173913043478, 0.090909090909091
45837, 0.73913043478261, 0.64565217391304, 0.090909090909091
45838, 0.73913043478261, 0.67173913043478, 0.11363636363636
45839, 0.76086956521739, 0.67173913043478, 0.13636363636364
45840, 0.73913043478261, 0.64565217391304, 0.13636363636364
45841, 0.73913043478261, 0.67173913043478, 0.15909090909091
45842, 0.76086956521739, 0.67173913043478, 0.18181818181818
45843, 0.73913043478261, 0.64565217391304, 0.18181818181818
45844, 0.73913043478261, 0.67173913043478, 0.20454545454545
45845, 0.76086956521739, 0.67173913043478, 0.22727272727273
45846, 0.73913043478261, 0.64565217391304, 0.22727272727273
45847, 0.73913043478261, 0.67173913043478, 0.25
45848, 0.76086956521739, 0.67173913043478, 0.27272727272727
45849, 0.73913043478261, 0.64565217391304, 0.27272727272727
45850, 0.73913043478261, 0.67173913043478, 0.29545454545455
45851, 0.76086956521739, 0.67173913043478, 0.31818181818182
45852, 0.73913043478261, 0.64565217391304, 0.31818181818182
45853, 0.73913043478261, 0.67173913043478, 0.34090909090909
45854, 0.76086956521739, 0.67173913043478, 0.36363636363636
45855, 0.73913043478261, 0.64565217391304, 0.36363636363636
45856, 0.73913043478261, 0.67173913043478, 0.38636363636364
45857, 0.76086956521739, 0.67173913043478, 0.40909090909091
45858, 0.73913043478261, 0.64565217391304, 0.40909090909091
45859, 0.73913043478261, 0.67173913043478, 0.43181818181818
45860, 0.76086956521739, 0.67173913043478, 0.45454545454545
45861, 0.73913043478261, 0.64565217391304, 0.45454545454545
45862, 0.73913043478261, 0.67173913043478, 0.47727272727273
45863, 0.69565217391304, 0.67173913043478, 0.022727272727273
45864, 0.71739130434783, 0.67173913043478, 0.045454545454545
45865, 0.69565217391304, 0.64565217391304, 0.045454545454545
45866, 0.69565217391304, 0.67173913043478, 0.068181818181818
45867, 0.71739130434783, 0.67173913043478, 0.090909090909091
45868, 0.69565217391304, 0.64565217391304, 0.090909090909091
45869, 0.69565217391304, 0.67173913043478, 0.11363636363636
45870, 0.71739130434783, 0.67173913043478, 0.13636363636364
45871, 0.69565217391304, 0.64565217391304, 0.13636363636364
45872, 0.69565217391304, 0.67173913043478, 0.15909090909091
45873, 0.71739130434783, 0.67173913043478, 0.18181818181818
45874, 0.69565217391304, 0.64565217391304, 0.18181818181818
45875, 0.69565217391304, 0.67173913043478, 0.20454545454545
45876, 0.71739130434783, 0.67173913043478, 0.22727272727273
45877, 0.69565217391304, 0.64565217391304, 0.22727272727273
45878, 0.69565217391304, 0.67173913043478, 0.25
45879, 0.71739130434783, 0.67173913043478, 0.27272727272727
45880, 0.69565217391304, 0.64565217391304, 0.27272727272727
45881, 0.69565217391304, 0.67173913043478, 0.29545454545455
45882, 0.71739130434783, 0.67173913043478, 0.31818181818182
45883, 0.69565217391304, 0.64565217391304, 0.31818181818182
45884, 0.69565217391304, 0.67173913043478, 0.34090909090909
45885, 0.71739130434783, 0.67173913043478, 0.36363636363636
45886, 0.69565217391304, 0.64565217391304, 0.36363636363636
45887, 0.69565217391304, 0.67173913043478, 0.38636363636364
45888, 0.71739130434783, 0.67173913043478, 0.40909090909091
45889, 0.69565217391304, 0.64565217391304, 0.40909090909091
45890, 0.69565217391304, 0.67173913043478, 0.43181818181818
45891, 0.71739130434783, 0.67173913043478, 0.45454545454545
45892, 0.69565217391304, 0.64565217391304, 0.45454545454545
45893, 0.69565217391304, 0.67173913043478, 0.47727272727273
45894, 0.65217391304348, 0.67173913043478, 0.022727272727273
45895, 0.67391304347826, 0.67173913043478, 0.045454545454545
45896, 0.65217391304348, 0.64565217391304, 0.045454545454545
45897, 0.65217391304348, 0.67173913043478, 0.068181818181818
45898, 0.67391304347826, 0.67173913043478, 0.090909090909091
45899, 0.65217391304348, 0.64565217391304, 0.090909090909091
45900, 0.65217391304348, 0.67173913043478, 0.11363636363636
45901, 0.67391304347826, 0.67173913043478, 0.13636363636364
45902, 0.65217391304348, 0.64565217391304, 0.13636363636364
45903, 0.65217391304348, 0.67173913043478, 0.15909090909091
45904, 0.67391304347826, 0.67173913043478, 0.18181818181818
45905, 0.65217391304348, 0.64565217391304, 0.18181818181818
45906, 0.65217391304348, 0.67173913043478, 0.20454545454545
45907, 0.67391304347826, 0.67173913043478, 0.22727272727273
45908, 0.65217391304348, 0.64565217391304, 0.22727272727273
45909, 0.65217391304348, 0.67173913043478, 0.25
45910, 0.67391304347826, 0.67173913043478, 0.27272727272727
45911, 0.65217391304348, 0.64565217391304, 0.27272727272727
45912, 0.65217391304348, 0.67173913043478, 0.29545454545455
45913, 0.67391304347826, 0.67173913043478, 0.31818181818182
45914, 0.65217391304348, 0.64565217391304, 0.31818181818182
45915, 0.65217391304348, 0.67173913043478, 0.34090909090909
45916, 0.67391304347826, 0.67173913043478, 0.36363636363636
45917, 0.65217391304348, 0.64565217391304, 0.36363636363636
45918, 0.65217391304348, 0.67173913043478, 0.38636363636364
45919, 0.67391304347826, 0.67173913043478, 0.40909090909091
45920, 0.65217391304348, 0.64565217391304, 0.40909090909091
45921, 0.65217391304348, 0.67173913043478, 0.43181818181818
45922, 0.67391304347826, 0.67173913043478, 0.45454545454545
45923, 0.65217391304348, 0.64565217391304, 0.45454545454545
45924, 0.65217391304348, 0.67173913043478, 0.47727272727273
45925, 0.60869565217391, 0.67173913043478, 0.022727272727273
45926, 0.6304347826087, 0.67173913043478, 0.045454545454545
45927, 0.60869565217391, 0.64565217391304, 0.045454545454545
45928, 0.60869565217391, 0.67173913043478, 0.068181818181818
45929, 0.6304347826087, 0.67173913043478, 0.090909090909091
45930, 0.60869565217391, 0.64565217391304, 0.090909090909091
45931, 0.60869565217391, 0.67173913043478, 0.11363636363636
45932, 0.6304347826087, 0.67173913043478, 0.13636363636364
45933, 0.60869565217391, 0.64565217391304, 0.13636363636364
45934, 0.60869565217391, 0.67173913043478, 0.15909090909091
45935, 0.6304347826087, 0.67173913043478, 0.18181818181818
45936, 0.60869565217391, 0.64565217391304, 0.18181818181818
45937, 0.60869565217391, 0.67173913043478, 0.20454545454545
45938, 0.6304347826087, 0.67173913043478, 0.22727272727273
45939, 0.60869565217391, 0.64565217391304, 0.22727272727273
45940, 0.60869565217391, 0.67173913043478, 0.25
45941, 0.6304347826087, 0.67173913043478, 0.27272727272727
45942, 0.60869565217391, 0.64565217391304, 0.27272727272727
45943, 0.60869565217391, 0.67173913043478, 0.29545454545455
45944, 0.6304347826087, 0.67173913043478, 0.31818181818182
45945, 0.60869565217391, 0.64565217391304, 0.31818181818182
45946, 0.60869565217391, 0.67173913043478, 0.34090909090909
45947, 0.6304347826087, 0.67173913043478, 0.36363636363636
45948, 0.60869565217391, 0.64565217391304, 0.36363636363636
45949, 0.60869565217391, 0.67173913043478, 0.38636363636364
45950, 0.6304347826087, 0.67173913043478, 0.40909090909091
45951, 0.60869565217391, 0.64565217391304, 0.40909090909091
45952, 0.60869565217391, 0.67173913043478, 0.43181818181818
45953, 0.6304347826087, 0.67173913043478, 0.45454545454545
45954, 0.60869565217391, 0.64565217391304, 0.45454545454545
45955, 0.60869565217391, 0.67173913043478, 0.47727272727273
45956, 0.56521739130435, 0.67173913043478, 0.022727272727273
45957, 0.58695652173913, 0.67173913043478, 0.045454545454545
45958, 0.56521739130435, 0.64565217391304, 0.045454545454545
45959, 0.56521739130435, 0.67173913043478, 0.068181818181818
45960, 0.58695652173913, 0.67173913043478, 0.090909090909091
45961, 0.56521739130435, 0.64565217391304, 0.090909090909091
45962, 0.56521739130435, 0.67173913043478, 0.11363636363636
45963, 0.58695652173913, 0.67173913043478, 0.13636363636364
45964, 0.56521739130435, 0.64565217391304, 0.13636363636364
45965, 0.56521739130435, 0.67173913043478, 0.15909090909091
45966, 0.58695652173913, 0.67173913043478, 0.18181818181818
45967, 0.56521739130435, 0.64565217391304, 0.18181818181818
45968, 0.56521739130435, 0.67173913043478, 0.20454545454545
45969, 0.58695652173913, 0.67173913043478, 0.22727272727273
45970, 0.56521739130435, 0.64565217391304, 0.22727272727273
45971, 0.56521739130435, 0.67173913043478, 0.25
45972, 0.58695652173913, 0.67173913043478, 0.27272727272727
45973, 0.56521739130435, 0.64565217391304, 0.27272727272727
45974, 0.56521739130435, 0.67173913043478, 0.29545454545455
45975, 0.58695652173913, 0.67173913043478, 0.31818181818182
45976, 0.56521739130435, 0.64565217391304, 0.31818181818182
45977, 0.56521739130435, 0.67173913043478, 0.34090909090909
45978, 0.58695652173913, 0.67173913043478, 0.36363636363636
45979, 0.56521739130435, 0.64565217391304, 0.36363636363636
45980, 0.56521739130435, 0.67173913043478, 0.38636363636364
45981, 0.58695652173913, 0.67173913043478, 0.40909090909091
45982, 0.56521739130435, 0.64565217391304, 0.40909090909091
45983, 0.56521739130435, 0.67173913043478, 0.43181818181818
45984, 0.58695652173913, 0.67173913043478, 0.45454545454545
45985, 0.56521739130435, 0.64565217391304, 0.45454545454545
45986, 0.56521739130435, 0.67173913043478, 0.47727272727273
45987, 0.52173913043478, 0.67173913043478, 0.022727272727273
45988, 0.54347826086956, 0.67173913043478, 0.045454545454545
45989, 0.52173913043478, 0.64565217391304, 0.045454545454545
45990, 0.52173913043478, 0.67173913043478, 0.068181818181818
45991, 0.54347826086956, 0.67173913043478, 0.090909090909091
45992, 0.52173913043478, 0.64565217391304, 0.090909090909091
45993, 0.52173913043478, 0.67173913043478, 0.11363636363636
45994, 0.54347826086957, 0.67173913043478, 0.13636363636364
45995, 0.52173913043478, 0.64565217391304, 0.13636363636364
45996, 0.52173913043478, 0.67173913043478, 0.15909090909091
45997, 0.54347826086956, 0.67173913043478, 0.18181818181818
45998, 0.52173913043478, 0.64565217391304, 0.18181818181818
45999, 0.52173913043478, 0.67173913043478, 0.20454545454545
46000, 0.54347826086956, 0.67173913043478, 0.22727272727273
46001, 0.52173913043478, 0.64565217391304, 0.22727272727273
46002, 0.52173913043478, 0.67173913043478, 0.25
46003, 0.54347826086956, 0.67173913043478, 0.27272727272727
46004, 0.52173913043478, 0.64565217391304, 0.27272727272727
46005, 0.52173913043478, 0.67173913043478, 0.29545454545455
46006, 0.54347826086956, 0.67173913043478, 0.31818181818182
46007, 0.52173913043478, 0.64565217391304, 0.31818181818182
46008, 0.52173913043478, 0.67173913043478, 0.34090909090909
46009, 0.54347826086956, 0.67173913043478, 0.36363636363636
46010, 0.52173913043478, 0.64565217391304, 0.36363636363636
46011, 0.52173913043478, 0.67173913043478, 0.38636363636364
46012, 0.54347826086956, 0.67173913043478, 0.40909090909091
46013, 0.52173913043478, 0.64565217391304, 0.40909090909091
46014, 0.52173913043478, 0.67173913043478, 0.43181818181818
46015, 0.54347826086957, 0.67173913043478, 0.45454545454545
46016, 0.52173913043478, 0.64565217391304, 0.45454545454545
46017, 0.52173913043478, 0.67173913043478, 0.47727272727273
46018, 0.47826086956522, 0.67173913043478, 0.022727272727273
46019, 0.5, 0.67173913043478, 0.045454545454545
46020, 0.47826086956522, 0.64565217391304, 0.045454545454545
46021, 0.47826086956522, 0.67173913043478, 0.068181818181818
46022, 0.5, 0.67173913043478, 0.090909090909091
46023, 0.47826086956522, 0.64565217391304, 0.090909090909091
46024, 0.47826086956522, 0.67173913043478, 0.11363636363636
46025, 0.5, 0.67173913043478, 0.13636363636364
46026, 0.47826086956522, 0.64565217391304, 0.13636363636364
46027, 0.47826086956522, 0.67173913043478, 0.15909090909091
46028, 0.5, 0.67173913043478, 0.18181818181818
46029, 0.47826086956522, 0.64565217391304, 0.18181818181818
46030, 0.47826086956522, 0.67173913043478, 0.20454545454545
46031, 0.5, 0.67173913043478, 0.22727272727273
46032, 0.47826086956522, 0.64565217391304, 0.22727272727273
46033, 0.47826086956522, 0.67173913043478, 0.25
46034, 0.5, 0.67173913043478, 0.27272727272727
46035, 0.47826086956522, 0.64565217391304, 0.27272727272727
46036, 0.47826086956522, 0.67173913043478, 0.29545454545455
46037, 0.5, 0.67173913043478, 0.31818181818182
46038, 0.47826086956522, 0.64565217391304, 0.31818181818182
46039, 0.47826086956522, 0.67173913043478, 0.34090909090909
46040, 0.5, 0.67173913043478, 0.36363636363636
46041, 0.47826086956522, 0.64565217391304, 0.36363636363636
46042, 0.47826086956522, 0.67173913043478, 0.38636363636364
46043, 0.5, 0.67173913043478, 0.40909090909091
46044, 0.47826086956522, 0.64565217391304, 0.40909090909091
46045, 0.47826086956522, 0.67173913043478, 0.43181818181818
46046, 0.5, 0.67173913043478, 0.45454545454545
46047, 0.47826086956522, 0.64565217391304, 0.45454545454545
46048, 0.47826086956522, 0.67173913043478, 0.47727272727273
46049, 0.43478260869565, 0.67173913043478, 0.022727272727273
46050, 0.45652173913043, 0.67173913043478, 0.045454545454545
46051, 0.43478260869565, 0.64565217391304, 0.045454545454545
46052, 0.43478260869565, 0.67173913043478, 0.068181818181818
46053, 0.45652173913043, 0.67173913043478, 0.090909090909091
46054, 0.43478260869565, 0.64565217391304, 0.090909090909091
46055, 0.43478260869565, 0.67173913043478, 0.11363636363636
46056, 0.45652173913043, 0.67173913043478, 0.13636363636364
46057, 0.43478260869565, 0.64565217391304, 0.13636363636364
46058, 0.43478260869565, 0.67173913043478, 0.15909090909091
46059, 0.45652173913043, 0.67173913043478, 0.18181818181818
46060, 0.43478260869565, 0.64565217391304, 0.18181818181818
46061, 0.43478260869565, 0.67173913043478, 0.20454545454545
46062, 0.45652173913043, 0.67173913043478, 0.22727272727273
46063, 0.43478260869565, 0.64565217391304, 0.22727272727273
46064, 0.43478260869565, 0.67173913043478, 0.25
46065, 0.45652173913043, 0.67173913043478, 0.27272727272727
46066, 0.43478260869565, 0.64565217391304, 0.27272727272727
46067, 0.43478260869565, 0.67173913043478, 0.29545454545455
46068, 0.45652173913043, 0.67173913043478, 0.31818181818182
46069, 0.43478260869565, 0.64565217391304, 0.31818181818182
46070, 0.43478260869565, 0.67173913043478, 0.34090909090909
46071, 0.45652173913043, 0.67173913043478, 0.36363636363636
46072, 0.43478260869565, 0.64565217391304, 0.36363636363636
46073, 0.43478260869565, 0.67173913043478, 0.38636363636364
46074, 0.45652173913043, 0.67173913043478, 0.40909090909091
46075, 0.43478260869565, 0.64565217391304, 0.40909090909091
46076, 0.43478260869565, 0.67173913043478, 0.43181818181818
46077, 0.45652173913043, 0.67173913043478, 0.45454545454545
46078, 0.43478260869565, 0.64565217391304, 0.45454545454545
46079, 0.43478260869565, 0.67173913043478, 0.47727272727273
46080, 0.39130434782609, 0.67173913043478, 0.022727272727273
46081, 0.41304347826087, 0.67173913043478, 0.045454545454545
46082, 0.39130434782609, 0.64565217391304, 0.045454545454545
46083, 0.39130434782609, 0.67173913043478, 0.068181818181818
46084, 0.41304347826087, 0.67173913043478, 0.090909090909091
46085, 0.39130434782609, 0.64565217391304, 0.090909090909091
46086, 0.39130434782609, 0.67173913043478, 0.11363636363636
46087, 0.41304347826087, 0.67173913043478, 0.13636363636364
46088, 0.39130434782609, 0.64565217391304, 0.13636363636364
46089, 0.39130434782609, 0.67173913043478, 0.15909090909091
46090, 0.41304347826087, 0.67173913043478, 0.18181818181818
46091, 0.39130434782609, 0.64565217391304, 0.18181818181818
46092, 0.39130434782609, 0.67173913043478, 0.20454545454545
46093, 0.41304347826087, 0.67173913043478, 0.22727272727273
46094, 0.39130434782609, 0.64565217391304, 0.22727272727273
46095, 0.39130434782609, 0.67173913043478, 0.25
46096, 0.41304347826087, 0.67173913043478, 0.27272727272727
46097, 0.39130434782609, 0.64565217391304, 0.27272727272727
46098, 0.39130434782609, 0.67173913043478, 0.29545454545455
46099, 0.41304347826087, 0.67173913043478, 0.31818181818182
46100, 0.39130434782609, 0.64565217391304, 0.31818181818182
46101, 0.39130434782609, 0.67173913043478, 0.34090909090909
46102, 0.41304347826087, 0.67173913043478, 0.36363636363636
46103, 0.39130434782609, 0.64565217391304, 0.36363636363636
46104, 0.39130434782609, 0.67173913043478, 0.38636363636364
46105, 0.41304347826087, 0.67173913043478, 0.40909090909091
46106, 0.39130434782609, 0.64565217391304, 0.40909090909091
46107, 0.39130434782609, 0.67173913043478, 0.43181818181818
46108, 0.41304347826087, 0.67173913043478, 0.45454545454545
46109, 0.39130434782609, 0.64565217391304, 0.45454545454545
46110, 0.39130434782609, 0.67173913043478, 0.47727272727273
46111, 0.34782608695652, 0.67173913043478, 0.022727272727273
46112, 0.3695652173913, 0.67173913043478, 0.045454545454545
46113, 0.34782608695652, 0.64565217391304, 0.045454545454545
46114, 0.34782608695652, 0.67173913043478, 0.068181818181818
46115, 0.3695652173913, 0.67173913043478, 0.090909090909091
46116, 0.34782608695652, 0.64565217391304, 0.090909090909091
46117, 0.34782608695652, 0.67173913043478, 0.11363636363636
46118, 0.3695652173913, 0.67173913043478, 0.13636363636364
46119, 0.34782608695652, 0.64565217391304, 0.13636363636364
46120, 0.34782608695652, 0.67173913043478, 0.15909090909091
46121, 0.3695652173913, 0.67173913043478, 0.18181818181818
46122, 0.34782608695652, 0.64565217391304, 0.18181818181818
46123, 0.34782608695652, 0.67173913043478, 0.20454545454545
46124, 0.3695652173913, 0.67173913043478, 0.22727272727273
46125, 0.34782608695652, 0.64565217391304, 0.22727272727273
46126, 0.34782608695652, 0.67173913043478, 0.25
46127, 0.3695652173913, 0.67173913043478, 0.27272727272727
46128, 0.34782608695652, 0.64565217391304, 0.27272727272727
46129, 0.34782608695652, 0.67173913043478, 0.29545454545455
46130, 0.3695652173913, 0.67173913043478, 0.31818181818182
46131, 0.34782608695652, 0.64565217391304, 0.31818181818182
46132, 0.34782608695652, 0.67173913043478, 0.34090909090909
46133, 0.3695652173913, 0.67173913043478, 0.36363636363636
46134, 0.34782608695652, 0.64565217391304, 0.36363636363636
46135, 0.34782608695652, 0.67173913043478, 0.38636363636364
46136, 0.3695652173913, 0.67173913043478, 0.40909090909091
46137, 0.34782608695652, 0.64565217391304, 0.40909090909091
46138, 0.34782608695652, 0.67173913043478, 0.43181818181818
46139, 0.3695652173913, 0.67173913043478, 0.45454545454545
46140, 0.34782608695652, 0.64565217391304, 0.45454545454545
46141, 0.34782608695652, 0.67173913043478, 0.47727272727273
46142, 0.30434782608696, 0.67173913043478, 0.022727272727273
46143, 0.32608695652174, 0.67173913043478, 0.045454545454545
46144, 0.30434782608696, 0.64565217391304, 0.045454545454545
46145, 0.30434782608696, 0.67173913043478, 0.068181818181818
46146, 0.32608695652174, 0.67173913043478, 0.090909090909091
46147, 0.30434782608696, 0.64565217391304, 0.090909090909091
46148, 0.30434782608696, 0.67173913043478, 0.11363636363636
46149, 0.32608695652174, 0.67173913043478, 0.13636363636364
46150, 0.30434782608696, 0.64565217391304, 0.13636363636364
46151, 0.30434782608696, 0.67173913043478, 0.15909090909091
46152, 0.32608695652174, 0.67173913043478, 0.18181818181818
46153, 0.30434782608696, 0.64565217391304, 0.18181818181818
46154, 0.30434782608696, 0.67173913043478, 0.20454545454545
46155, 0.32608695652174, 0.67173913043478, 0.22727272727273
46156, 0.30434782608696, 0.64565217391304, 0.22727272727273
46157, 0.30434782608696, 0.67173913043478, 0.25
46158, 0.32608695652174, 0.67173913043478, 0.27272727272727
46159, 0.30434782608696, 0.64565217391304, 0.27272727272727
46160, 0.30434782608696, 0.67173913043478, 0.29545454545455
46161, 0.32608695652174, 0.67173913043478, 0.31818181818182
46162, 0.30434782608696, 0.64565217391304, 0.31818181818182
46163, 0.30434782608696, 0.67173913043478, 0.34090909090909
46164, 0.32608695652174, 0.67173913043478, 0.36363636363636
46165, 0.30434782608696, 0.64565217391304, 0.36363636363636
46166, 0.30434782608696, 0.67173913043478, 0.38636363636364
46167, 0.32608695652174, 0.67173913043478, 0.40909090909091
46168, 0.30434782608696, 0.64565217391304, 0.40909090909091
46169, 0.30434782608696, 0.67173913043478, 0.43181818181818
46170, 0.32608695652174, 0.67173913043478, 0.45454545454545
46171, 0.30434782608696, 0.64565217391304, 0.45454545454545
46172, 0.30434782608696, 0.67173913043478, 0.47727272727273
46173, 0.26086956521739, 0.67173913043478, 0.022727272727273
46174, 0.28260869565217, 0.67173913043478, 0.045454545454545
46175, 0.26086956521739, 0.64565217391304, 0.045454545454545
46176, 0.26086956521739, 0.67173913043478, 0.068181818181818
46177, 0.28260869565217, 0.67173913043478, 0.090909090909091
46178, 0.26086956521739, 0.64565217391304, 0.090909090909091
46179, 0.26086956521739, 0.67173913043478, 0.11363636363636
46180, 0.28260869565217, 0.67173913043478, 0.13636363636364
46181, 0.26086956521739, 0.64565217391304, 0.13636363636364
46182, 0.26086956521739, 0.67173913043478, 0.15909090909091
46183, 0.28260869565217, 0.67173913043478, 0.18181818181818
46184, 0.26086956521739, 0.64565217391304, 0.18181818181818
46185, 0.26086956521739, 0.67173913043478, 0.20454545454545
46186, 0.28260869565217, 0.67173913043478, 0.22727272727273
46187, 0.26086956521739, 0.64565217391304, 0.22727272727273
46188, 0.26086956521739, 0.67173913043478, 0.25
46189, 0.28260869565217, 0.67173913043478, 0.27272727272727
46190, 0.26086956521739, 0.64565217391304, 0.27272727272727
46191, 0.26086956521739, 0.67173913043478, 0.29545454545455
46192, 0.28260869565217, 0.67173913043478, 0.31818181818182
46193, 0.26086956521739, 0.64565217391304, 0.31818181818182
46194, 0.26086956521739, 0.67173913043478, 0.34090909090909
46195, 0.28260869565217, 0.67173913043478, 0.36363636363636
46196, 0.26086956521739, 0.64565217391304, 0.36363636363636
46197, 0.26086956521739, 0.67173913043478, 0.38636363636364
46198, 0.28260869565217, 0.67173913043478, 0.40909090909091
46199, 0.26086956521739, 0.64565217391304, 0.40909090909091
46200, 0.26086956521739, 0.67173913043478, 0.43181818181818
46201, 0.28260869565217, 0.67173913043478, 0.45454545454545
46202, 0.26086956521739, 0.64565217391304, 0.45454545454545
46203, 0.26086956521739, 0.67173913043478, 0.47727272727273
46204, 0.21739130434783, 0.67173913043478, 0.022727272727273
46205, 0.23913043478261, 0.67173913043478, 0.045454545454545
46206, 0.21739130434783, 0.64565217391304, 0.045454545454545
46207, 0.21739130434783, 0.67173913043478, 0.068181818181818
46208, 0.23913043478261, 0.67173913043478, 0.090909090909091
46209, 0.21739130434783, 0.64565217391304, 0.090909090909091
46210, 0.21739130434783, 0.67173913043478, 0.11363636363636
46211, 0.23913043478261, 0.67173913043478, 0.13636363636364
46212, 0.21739130434783, 0.64565217391304, 0.13636363636364
46213, 0.21739130434783, 0.67173913043478, 0.15909090909091
46214, 0.23913043478261, 0.67173913043478, 0.18181818181818
46215, 0.21739130434783, 0.64565217391304, 0.18181818181818
46216, 0.21739130434783, 0.67173913043478, 0.20454545454545
46217, 0.23913043478261, 0.67173913043478, 0.22727272727273
46218, 0.21739130434783, 0.64565217391304, 0.22727272727273
46219, 0.21739130434783, 0.67173913043478, 0.25
46220, 0.23913043478261, 0.67173913043478, 0.27272727272727
46221, 0.21739130434783, 0.64565217391304, 0.27272727272727
46222, 0.21739130434783, 0.67173913043478, 0.29545454545455
46223, 0.23913043478261, 0.67173913043478, 0.31818181818182
46224, 0.21739130434783, 0.64565217391304, 0.31818181818182
46225, 0.21739130434783, 0.67173913043478, 0.34090909090909
46226, 0.23913043478261, 0.67173913043478, 0.36363636363636
46227, 0.21739130434783, 0.64565217391304, 0.36363636363636
46228, 0.21739130434783, 0.67173913043478, 0.38636363636364
46229, 0.23913043478261, 0.67173913043478, 0.40909090909091
46230, 0.21739130434783, 0.64565217391304, 0.40909090909091
46231, 0.21739130434783, 0.67173913043478, 0.43181818181818
46232, 0.23913043478261, 0.67173913043478, 0.45454545454545
46233, 0.21739130434783, 0.64565217391304, 0.45454545454545
46234, 0.21739130434783, 0.67173913043478, 0.47727272727273
46235, 0.17391304347826, 0.67173913043478, 0.022727272727273
46236, 0.19565217391304, 0.67173913043478, 0.045454545454545
46237, 0.17391304347826, 0.64565217391304, 0.045454545454545
46238, 0.17391304347826, 0.67173913043478, 0.068181818181818
46239, 0.19565217391304, 0.67173913043478, 0.090909090909091
46240, 0.17391304347826, 0.64565217391304, 0.090909090909091
46241, 0.17391304347826, 0.67173913043478, 0.11363636363636
46242, 0.19565217391304, 0.67173913043478, 0.13636363636364
46243, 0.17391304347826, 0.64565217391304, 0.13636363636364
46244, 0.17391304347826, 0.67173913043478, 0.15909090909091
46245, 0.19565217391304, 0.67173913043478, 0.18181818181818
46246, 0.17391304347826, 0.64565217391304, 0.18181818181818
46247, 0.17391304347826, 0.67173913043478, 0.20454545454545
46248, 0.19565217391304, 0.67173913043478, 0.22727272727273
46249, 0.17391304347826, 0.64565217391304, 0.22727272727273
46250, 0.17391304347826, 0.67173913043478, 0.25
46251, 0.19565217391304, 0.67173913043478, 0.27272727272727
46252, 0.17391304347826, 0.64565217391304, 0.27272727272727
46253, 0.17391304347826, 0.67173913043478, 0.29545454545455
46254, 0.19565217391304, 0.67173913043478, 0.31818181818182
46255, 0.17391304347826, 0.64565217391304, 0.31818181818182
46256, 0.17391304347826, 0.67173913043478, 0.34090909090909
46257, 0.19565217391304, 0.67173913043478, 0.36363636363636
46258, 0.17391304347826, 0.64565217391304, 0.36363636363636
46259, 0.17391304347826, 0.67173913043478, 0.38636363636364
46260, 0.19565217391304, 0.67173913043478, 0.40909090909091
46261, 0.17391304347826, 0.64565217391304, 0.40909090909091
46262, 0.17391304347826, 0.67173913043478, 0.43181818181818
46263, 0.19565217391304, 0.67173913043478, 0.45454545454545
46264, 0.17391304347826, 0.64565217391304, 0.45454545454545
46265, 0.17391304347826, 0.67173913043478, 0.47727272727273
46266, 0.1304347826087, 0.67173913043478, 0.022727272727273
46267, 0.15217391304348, 0.67173913043478, 0.045454545454545
46268, 0.1304347826087, 0.64565217391304, 0.045454545454545
46269, 0.1304347826087, 0.67173913043478, 0.068181818181818
46270, 0.15217391304348, 0.67173913043478, 0.090909090909091
46271, 0.1304347826087, 0.64565217391304, 0.090909090909091
46272, 0.1304347826087, 0.67173913043478, 0.11363636363636
46273, 0.15217391304348, 0.67173913043478, 0.13636363636364
46274, 0.1304347826087, 0.64565217391304, 0.13636363636364
46275, 0.1304347826087, 0.67173913043478, 0.15909090909091
46276, 0.15217391304348, 0.67173913043478, 0.18181818181818
46277, 0.1304347826087, 0.64565217391304, 0.18181818181818
46278, 0.1304347826087, 0.67173913043478, 0.20454545454545
46279, 0.15217391304348, 0.67173913043478, 0.22727272727273
46280, 0.1304347826087, 0.64565217391304, 0.22727272727273
46281, 0.1304347826087, 0.67173913043478, 0.25
46282, 0.15217391304348, 0.67173913043478, 0.27272727272727
46283, 0.1304347826087, 0.64565217391304, 0.27272727272727
46284, 0.1304347826087, 0.67173913043478, 0.29545454545455
46285, 0.15217391304348, 0.67173913043478, 0.31818181818182
46286, 0.1304347826087, 0.64565217391304, 0.31818181818182
46287, 0.1304347826087, 0.67173913043478, 0.34090909090909
46288, 0.15217391304348, 0.67173913043478, 0.36363636363636
46289, 0.1304347826087, 0.64565217391304, 0.36363636363636
46290, 0.1304347826087, 0.67173913043478, 0.38636363636364
46291, 0.15217391304348, 0.67173913043478, 0.40909090909091
46292, 0.1304347826087, 0.64565217391304, 0.40909090909091
46293, 0.1304347826087, 0.67173913043478, 0.43181818181818
46294, 0.15217391304348, 0.67173913043478, 0.45454545454545
46295, 0.1304347826087, 0.64565217391304, 0.45454545454545
46296, 0.1304347826087, 0.67173913043478, 0.47727272727273
46297, 0.08695652173913, 0.67173913043478, 0.022727272727273
46298, 0.10869565217391, 0.67173913043478, 0.045454545454545
46299, 0.08695652173913, 0.64565217391304, 0.045454545454545
46300, 0.08695652173913, 0.67173913043478, 0.068181818181818
46301, 0.10869565217391, 0.67173913043478, 0.090909090909091
46302, 0.08695652173913, 0.64565217391304, 0.090909090909091
46303, 0.08695652173913, 0.67173913043478, 0.11363636363636
46304, 0.10869565217391, 0.67173913043478, 0.13636363636364
46305, 0.08695652173913, 0.64565217391304, 0.13636363636364
46306, 0.08695652173913, 0.67173913043478, 0.15909090909091
46307, 0.10869565217391, 0.67173913043478, 0.18181818181818
46308, 0.08695652173913, 0.64565217391304, 0.18181818181818
46309, 0.08695652173913, 0.67173913043478, 0.20454545454545
46310, 0.10869565217391, 0.67173913043478, 0.22727272727273
46311, 0.08695652173913, 0.64565217391304, 0.22727272727273
46312, 0.08695652173913, 0.67173913043478, 0.25
46313, 0.10869565217391, 0.67173913043478, 0.27272727272727
46314, 0.08695652173913, 0.64565217391304, 0.27272727272727
46315, 0.08695652173913, 0.67173913043478, 0.29545454545455
46316, 0.10869565217391, 0.67173913043478, 0.31818181818182
46317, 0.08695652173913, 0.64565217391304, 0.31818181818182
46318, 0.08695652173913, 0.67173913043478, 0.34090909090909
46319, 0.10869565217391, 0.67173913043478, 0.36363636363636
46320, 0.08695652173913, 0.64565217391304, 0.36363636363636
46321, 0.08695652173913, 0.67173913043478, 0.38636363636364
46322, 0.10869565217391, 0.67173913043478, 0.40909090909091
46323, 0.08695652173913, 0.64565217391304, 0.40909090909091
46324, 0.08695652173913, 0.67173913043478, 0.43181818181818
46325, 0.10869565217391, 0.67173913043478, 0.45454545454545
46326, 0.08695652173913, 0.64565217391304, 0.45454545454545
46327, 0.08695652173913, 0.67173913043478, 0.47727272727273
46328, 0.043478260869565, 0.67173913043478, 0.022727272727273
46329, 0.065217391304348, 0.67173913043478, 0.045454545454545
46330, 0.043478260869565, 0.64565217391304, 0.045454545454545
46331, 0.043478260869565, 0.67173913043478, 0.068181818181818
46332, 0.065217391304348, 0.67173913043478, 0.090909090909091
46333, 0.043478260869565, 0.64565217391304, 0.090909090909091
46334, 0.043478260869565, 0.67173913043478, 0.11363636363636
46335, 0.065217391304348, 0.67173913043478, 0.13636363636364
46336, 0.043478260869565, 0.64565217391304, 0.13636363636364
46337, 0.043478260869565, 0.67173913043478, 0.15909090909091
46338, 0.065217391304348, 0.67173913043478, 0.18181818181818
46339, 0.043478260869565, 0.64565217391304, 0.18181818181818
46340, 0.043478260869565, 0.67173913043478, 0.20454545454545
46341, 0.065217391304348, 0.67173913043478, 0.22727272727273
46342, 0.043478260869565, 0.64565217391304, 0.22727272727273
46343, 0.043478260869565, 0.67173913043478, 0.25
46344, 0.065217391304348, 0.67173913043478, 0.27272727272727
46345, 0.043478260869565, 0.64565217391304, 0.27272727272727
46346, 0.043478260869565, 0.67173913043478, 0.29545454545455
46347, 0.065217391304348, 0.67173913043478, 0.31818181818182
46348, 0.043478260869565, 0.64565217391304, 0.31818181818182
46349, 0.043478260869565, 0.67173913043478, 0.34090909090909
46350, 0.065217391304348, 0.67173913043478, 0.36363636363636
46351, 0.043478260869565, 0.64565217391304, 0.36363636363636
46352, 0.043478260869565, 0.67173913043478, 0.38636363636364
46353, 0.065217391304348, 0.67173913043478, 0.40909090909091
46354, 0.043478260869565, 0.64565217391304, 0.40909090909091
46355, 0.043478260869565, 0.67173913043478, 0.43181818181818
46356, 0.065217391304348, 0.67173913043478, 0.45454545454545
46357, 0.043478260869565, 0.64565217391304, 0.45454545454545
46358, 0.043478260869565, 0.67173913043478, 0.47727272727273
46359, 0.021739130434783, 0.67173913043478, 0.045454545454545
46360, 0.021739130434783, 0.67173913043478, 0.090909090909091
46361, 0.021739130434783, 0.67173913043478, 0.13636363636364
46362, 0.021739130434783, 0.67173913043478, 0.18181818181818
46363, 0.021739130434783, 0.67173913043478, 0.22727272727273
46364, 0.021739130434783, 0.67173913043478, 0.27272727272727
46365, 0.021739130434783, 0.67173913043478, 0.31818181818182
46366, 0.021739130434783, 0.67173913043478, 0.36363636363636
46367, 0.021739130434783, 0.67173913043478, 0.40909090909091
46368, 0.021739130434783, 0.67173913043478, 0.45454545454545
46369, 0.95652173913043, 0.72391304347826, 0.022727272727273
46370, 0.97826086956522, 0.72391304347826, 0.045454545454545
46371, 0.95652173913043, 0.69782608695652, 0.045454545454545
46372, 0.95652173913043, 0.72391304347826, 0.068181818181818
46373, 0.97826086956522, 0.72391304347826, 0.090909090909091
46374, 0.95652173913043, 0.69782608695652, 0.090909090909091
46375, 0.95652173913043, 0.72391304347826, 0.11363636363636
46376, 0.97826086956522, 0.72391304347826, 0.13636363636364
46377, 0.95652173913044, 0.69782608695652, 0.13636363636364
46378, 0.95652173913044, 0.72391304347826, 0.15909090909091
46379, 0.97826086956522, 0.72391304347826, 0.18181818181818
46380, 0.95652173913043, 0.69782608695652, 0.18181818181818
46381, 0.95652173913044, 0.72391304347826, 0.20454545454545
46382, 0.97826086956522, 0.72391304347826, 0.22727272727273
46383, 0.95652173913044, 0.69782608695652, 0.22727272727273
46384, 0.95652173913044, 0.72391304347826, 0.25
46385, 0.97826086956522, 0.72391304347826, 0.27272727272727
46386, 0.95652173913044, 0.69782608695652, 0.27272727272727
46387, 0.95652173913044, 0.72391304347826, 0.29545454545455
46388, 0.97826086956522, 0.72391304347826, 0.31818181818182
46389, 0.95652173913044, 0.69782608695652, 0.31818181818182
46390, 0.95652173913043, 0.72391304347826, 0.34090909090909
46391, 0.97826086956522, 0.72391304347826, 0.36363636363636
46392, 0.95652173913043, 0.69782608695652, 0.36363636363636
46393, 0.95652173913043, 0.72391304347826, 0.38636363636364
46394, 0.97826086956522, 0.72391304347826, 0.40909090909091
46395, 0.95652173913043, 0.69782608695652, 0.40909090909091
46396, 0.95652173913043, 0.72391304347826, 0.43181818181818
46397, 0.97826086956522, 0.72391304347826, 0.45454545454545
46398, 0.95652173913044, 0.69782608695652, 0.45454545454545
46399, 0.95652173913043, 0.72391304347826, 0.47727272727273
46400, 0.91304347826087, 0.72391304347826, 0.022727272727273
46401, 0.93478260869565, 0.72391304347826, 0.045454545454545
46402, 0.91304347826087, 0.69782608695652, 0.045454545454545
46403, 0.91304347826087, 0.72391304347826, 0.068181818181818
46404, 0.93478260869565, 0.72391304347826, 0.090909090909091
46405, 0.91304347826087, 0.69782608695652, 0.090909090909091
46406, 0.91304347826087, 0.72391304347826, 0.11363636363636
46407, 0.93478260869565, 0.72391304347826, 0.13636363636364
46408, 0.91304347826087, 0.69782608695652, 0.13636363636364
46409, 0.91304347826087, 0.72391304347826, 0.15909090909091
46410, 0.93478260869565, 0.72391304347826, 0.18181818181818
46411, 0.91304347826087, 0.69782608695652, 0.18181818181818
46412, 0.91304347826087, 0.72391304347826, 0.20454545454545
46413, 0.93478260869565, 0.72391304347826, 0.22727272727273
46414, 0.91304347826087, 0.69782608695652, 0.22727272727273
46415, 0.91304347826087, 0.72391304347826, 0.25
46416, 0.93478260869565, 0.72391304347826, 0.27272727272727
46417, 0.91304347826087, 0.69782608695652, 0.27272727272727
46418, 0.91304347826087, 0.72391304347826, 0.29545454545455
46419, 0.93478260869565, 0.72391304347826, 0.31818181818182
46420, 0.91304347826087, 0.69782608695652, 0.31818181818182
46421, 0.91304347826087, 0.72391304347826, 0.34090909090909
46422, 0.93478260869565, 0.72391304347826, 0.36363636363636
46423, 0.91304347826087, 0.69782608695652, 0.36363636363636
46424, 0.91304347826087, 0.72391304347826, 0.38636363636364
46425, 0.93478260869565, 0.72391304347826, 0.40909090909091
46426, 0.91304347826087, 0.69782608695652, 0.40909090909091
46427, 0.91304347826087, 0.72391304347826, 0.43181818181818
46428, 0.93478260869565, 0.72391304347826, 0.45454545454545
46429, 0.91304347826087, 0.69782608695652, 0.45454545454545
46430, 0.91304347826087, 0.72391304347826, 0.47727272727273
46431, 0.8695652173913, 0.72391304347826, 0.022727272727273
46432, 0.89130434782609, 0.72391304347826, 0.045454545454545
46433, 0.8695652173913, 0.69782608695652, 0.045454545454545
46434, 0.8695652173913, 0.72391304347826, 0.068181818181818
46435, 0.89130434782609, 0.72391304347826, 0.090909090909091
46436, 0.8695652173913, 0.69782608695652, 0.090909090909091
46437, 0.8695652173913, 0.72391304347826, 0.11363636363636
46438, 0.89130434782609, 0.72391304347826, 0.13636363636364
46439, 0.8695652173913, 0.69782608695652, 0.13636363636364
46440, 0.8695652173913, 0.72391304347826, 0.15909090909091
46441, 0.89130434782609, 0.72391304347826, 0.18181818181818
46442, 0.8695652173913, 0.69782608695652, 0.18181818181818
46443, 0.8695652173913, 0.72391304347826, 0.20454545454545
46444, 0.89130434782609, 0.72391304347826, 0.22727272727273
46445, 0.8695652173913, 0.69782608695652, 0.22727272727273
46446, 0.8695652173913, 0.72391304347826, 0.25
46447, 0.89130434782609, 0.72391304347826, 0.27272727272727
46448, 0.8695652173913, 0.69782608695652, 0.27272727272727
46449, 0.8695652173913, 0.72391304347826, 0.29545454545455
46450, 0.89130434782609, 0.72391304347826, 0.31818181818182
46451, 0.8695652173913, 0.69782608695652, 0.31818181818182
46452, 0.8695652173913, 0.72391304347826, 0.34090909090909
46453, 0.89130434782609, 0.72391304347826, 0.36363636363636
46454, 0.8695652173913, 0.69782608695652, 0.36363636363636
46455, 0.8695652173913, 0.72391304347826, 0.38636363636364
46456, 0.89130434782609, 0.72391304347826, 0.40909090909091
46457, 0.8695652173913, 0.69782608695652, 0.40909090909091
46458, 0.8695652173913, 0.72391304347826, 0.43181818181818
46459, 0.89130434782609, 0.72391304347826, 0.45454545454545
46460, 0.8695652173913, 0.69782608695652, 0.45454545454545
46461, 0.8695652173913, 0.72391304347826, 0.47727272727273
46462, 0.82608695652174, 0.72391304347826, 0.022727272727273
46463, 0.84782608695652, 0.72391304347826, 0.045454545454545
46464, 0.82608695652174, 0.69782608695652, 0.045454545454545
46465, 0.82608695652174, 0.72391304347826, 0.068181818181818
46466, 0.84782608695652, 0.72391304347826, 0.090909090909091
46467, 0.82608695652174, 0.69782608695652, 0.090909090909091
46468, 0.82608695652174, 0.72391304347826, 0.11363636363636
46469, 0.84782608695652, 0.72391304347826, 0.13636363636364
46470, 0.82608695652174, 0.69782608695652, 0.13636363636364
46471, 0.82608695652174, 0.72391304347826, 0.15909090909091
46472, 0.84782608695652, 0.72391304347826, 0.18181818181818
46473, 0.82608695652174, 0.69782608695652, 0.18181818181818
46474, 0.82608695652174, 0.72391304347826, 0.20454545454545
46475, 0.84782608695652, 0.72391304347826, 0.22727272727273
46476, 0.82608695652174, 0.69782608695652, 0.22727272727273
46477, 0.82608695652174, 0.72391304347826, 0.25
46478, 0.84782608695652, 0.72391304347826, 0.27272727272727
46479, 0.82608695652174, 0.69782608695652, 0.27272727272727
46480, 0.82608695652174, 0.72391304347826, 0.29545454545455
46481, 0.84782608695652, 0.72391304347826, 0.31818181818182
46482, 0.82608695652174, 0.69782608695652, 0.31818181818182
46483, 0.82608695652174, 0.72391304347826, 0.34090909090909
46484, 0.84782608695652, 0.72391304347826, 0.36363636363636
46485, 0.82608695652174, 0.69782608695652, 0.36363636363636
46486, 0.82608695652174, 0.72391304347826, 0.38636363636364
46487, 0.84782608695652, 0.72391304347826, 0.40909090909091
46488, 0.82608695652174, 0.69782608695652, 0.40909090909091
46489, 0.82608695652174, 0.72391304347826, 0.43181818181818
46490, 0.84782608695652, 0.72391304347826, 0.45454545454545
46491, 0.82608695652174, 0.69782608695652, 0.45454545454545
46492, 0.82608695652174, 0.72391304347826, 0.47727272727273
46493, 0.78260869565217, 0.72391304347826, 0.022727272727273
46494, 0.80434782608696, 0.72391304347826, 0.045454545454545
46495, 0.78260869565217, 0.69782608695652, 0.045454545454545
46496, 0.78260869565217, 0.72391304347826, 0.068181818181818
46497, 0.80434782608696, 0.72391304347826, 0.090909090909091
46498, 0.78260869565217, 0.69782608695652, 0.090909090909091
46499, 0.78260869565217, 0.72391304347826, 0.11363636363636
46500, 0.80434782608696, 0.72391304347826, 0.13636363636364
46501, 0.78260869565217, 0.69782608695652, 0.13636363636364
46502, 0.78260869565217, 0.72391304347826, 0.15909090909091
