21370, 1.895652173913, 0.15, 0.022727272727273
21371, 1.9173913043478, 0.15, 0.45454545454545
21372, 1.9391304347826, 0.15, 0.47727272727273
21373, 1.9173913043478, 0.15, 0.40909090909091
21374, 1.9391304347826, 0.15, 0.43181818181818
21375, 1.9173913043478, 0.15, 0.36363636363636
21376, 1.9391304347826, 0.15, 0.38636363636364
21377, 1.9173913043478, 0.15, 0.31818181818182
21378, 1.9391304347826, 0.15, 0.34090909090909
21379, 1.9173913043478, 0.15, 0.27272727272727
21380, 1.9391304347826, 0.15, 0.29545454545455
21381, 1.9173913043478, 0.15, 0.22727272727273
21382, 1.9391304347826, 0.15, 0.25
21383, 1.9173913043478, 0.15, 0.18181818181818
21384, 1.9391304347826, 0.15, 0.20454545454545
21385, 1.9173913043478, 0.15, 0.13636363636364
21386, 1.9391304347826, 0.15, 0.15909090909091
21387, 1.9173913043478, 0.15, 0.090909090909091
21388, 1.9391304347826, 0.15, 0.11363636363636
21389, 1.9173913043478, 0.15, 0.045454545454545
21390, 1.9391304347826, 0.15, 0.068181818181818
21391, 1.9391304347826, 0.15, 0.022727272727273
21392, 1.9608695652174, 0.15, 0.45454545454545
21393, 1.9826086956522, 0.15, 0.47727272727273
21394, 1.9608695652174, 0.15, 0.40909090909091
21395, 1.9826086956522, 0.15, 0.43181818181818
21396, 1.9608695652174, 0.15, 0.36363636363636
21397, 1.9826086956522, 0.15, 0.38636363636364
21398, 1.9608695652174, 0.15, 0.31818181818182
21399, 1.9826086956522, 0.15, 0.34090909090909
21400, 1.9608695652174, 0.15, 0.27272727272727
21401, 1.9826086956522, 0.15, 0.29545454545455
21402, 1.9608695652174, 0.15, 0.22727272727273
21403, 1.9826086956522, 0.15, 0.25
21404, 1.9608695652174, 0.15, 0.18181818181818
21405, 1.9826086956522, 0.15, 0.20454545454545
21406, 1.9608695652174, 0.15, 0.13636363636364
21407, 1.9826086956522, 0.15, 0.15909090909091
21408, 1.9608695652174, 0.15, 0.090909090909091
21409, 1.9826086956522, 0.15, 0.11363636363636
21410, 1.9608695652174, 0.15, 0.045454545454545
21411, 1.9826086956522, 0.15, 0.068181818181818
21412, 1.9826086956522, 0.15, 0.022727272727273
21413, 2.004347826087, 0.15, 0.45454545454545
21414, 2.0260869565217, 0.15, 0.47727272727273
21415, 2.004347826087, 0.15, 0.40909090909091
21416, 2.0260869565217, 0.15, 0.43181818181818
21417, 2.004347826087, 0.15, 0.36363636363636
21418, 2.0260869565217, 0.15, 0.38636363636364
21419, 2.004347826087, 0.15, 0.31818181818182
21420, 2.0260869565217, 0.15, 0.34090909090909
21421, 2.004347826087, 0.15, 0.27272727272727
21422, 2.0260869565217, 0.15, 0.29545454545455
21423, 2.004347826087, 0.15, 0.22727272727273
21424, 2.0260869565217, 0.15, 0.25
21425, 2.004347826087, 0.15, 0.18181818181818
21426, 2.0260869565217, 0.15, 0.20454545454545
21427, 2.004347826087, 0.15, 0.13636363636364
21428, 2.0260869565217, 0.15, 0.15909090909091
21429, 2.004347826087, 0.15, 0.090909090909091
21430, 2.0260869565217, 0.15, 0.11363636363636
21431, 2.004347826087, 0.15, 0.045454545454545
21432, 2.0260869565217, 0.15, 0.068181818181818
21433, 2.0260869565217, 0.15, 0.022727272727273
21434, 2.0478260869565, 0.15, 0.45454545454545
21435, 2.0695652173913, 0.15, 0.47727272727273
21436, 2.0478260869565, 0.15, 0.40909090909091
21437, 2.0695652173913, 0.15, 0.43181818181818
21438, 2.0478260869565, 0.15, 0.36363636363636
21439, 2.0695652173913, 0.15, 0.38636363636364
21440, 2.0478260869565, 0.15, 0.31818181818182
21441, 2.0695652173913, 0.15, 0.34090909090909
21442, 2.0478260869565, 0.15, 0.27272727272727
21443, 2.0695652173913, 0.15, 0.29545454545455
21444, 2.0478260869565, 0.15, 0.22727272727273
21445, 2.0695652173913, 0.15, 0.25
21446, 2.0478260869565, 0.15, 0.18181818181818
21447, 2.0695652173913, 0.15, 0.20454545454545
21448, 2.0478260869565, 0.15, 0.13636363636364
21449, 2.0695652173913, 0.15, 0.15909090909091
21450, 2.0478260869565, 0.15, 0.090909090909091
21451, 2.0695652173913, 0.15, 0.11363636363636
21452, 2.0478260869565, 0.15, 0.045454545454545
21453, 2.0695652173913, 0.15, 0.068181818181818
21454, 2.0695652173913, 0.15, 0.022727272727273
21455, 2.0913043478261, 0.15, 0.45454545454545
21456, 2.1130434782609, 0.15, 0.47727272727273
21457, 2.0913043478261, 0.15, 0.40909090909091
21458, 2.1130434782609, 0.15, 0.43181818181818
21459, 2.0913043478261, 0.15, 0.36363636363636
21460, 2.1130434782609, 0.15, 0.38636363636364
21461, 2.0913043478261, 0.15, 0.31818181818182
21462, 2.1130434782609, 0.15, 0.34090909090909
21463, 2.0913043478261, 0.15, 0.27272727272727
21464, 2.1130434782609, 0.15, 0.29545454545455
21465, 2.0913043478261, 0.15, 0.22727272727273
21466, 2.1130434782609, 0.15, 0.25
21467, 2.0913043478261, 0.15, 0.18181818181818
21468, 2.1130434782609, 0.15, 0.20454545454545
21469, 2.0913043478261, 0.15, 0.13636363636364
21470, 2.1130434782609, 0.15, 0.15909090909091
21471, 2.0913043478261, 0.15, 0.090909090909091
21472, 2.1130434782609, 0.15, 0.11363636363636
21473, 2.0913043478261, 0.15, 0.045454545454545
21474, 2.1130434782609, 0.15, 0.068181818181818
21475, 2.1130434782609, 0.15, 0.022727272727273
21476, 2.1347826086957, 0.15, 0.45454545454545
21477, 2.1565217391304, 0.15, 0.47727272727273
21478, 2.1347826086957, 0.15, 0.40909090909091
21479, 2.1565217391304, 0.15, 0.43181818181818
21480, 2.1347826086957, 0.15, 0.36363636363636
21481, 2.1565217391304, 0.15, 0.38636363636364
21482, 2.1347826086957, 0.15, 0.31818181818182
21483, 2.1565217391304, 0.15, 0.34090909090909
21484, 2.1347826086957, 0.15, 0.27272727272727
21485, 2.1565217391304, 0.15, 0.29545454545455
21486, 2.1347826086957, 0.15, 0.22727272727273
21487, 2.1565217391304, 0.15, 0.25
21488, 2.1347826086957, 0.15, 0.18181818181818
21489, 2.1565217391304, 0.15, 0.20454545454545
21490, 2.1347826086957, 0.15, 0.13636363636364
21491, 2.1565217391304, 0.15, 0.15909090909091
21492, 2.1347826086957, 0.15, 0.090909090909091
21493, 2.1565217391304, 0.15, 0.11363636363636
21494, 2.1347826086957, 0.15, 0.045454545454545
21495, 2.1565217391304, 0.15, 0.068181818181818
21496, 2.1565217391304, 0.15, 0.022727272727273
21497, 2.1782608695652, 0.15, 0.45454545454545
21498, 2.1782608695652, 0.15, 0.40909090909091
21499, 2.1782608695652, 0.15, 0.36363636363636
21500, 2.1782608695652, 0.15, 0.31818181818182
21501, 2.1782608695652, 0.15, 0.27272727272727
21502, 2.1782608695652, 0.15, 0.22727272727273
21503, 2.1782608695652, 0.15, 0.18181818181818
21504, 2.1782608695652, 0.15, 0.13636363636364
21505, 2.1782608695652, 0.15, 0.090909090909091
21506, 2.1782608695652, 0.15, 0.045454545454545
21507, 1.2434782608696, 0.125, 0.5
21508, 1.2869565217391, 0.125, 0.5
21509, 1.3304347826087, 0.125, 0.5
21510, 1.3739130434783, 0.125, 0.5
21511, 1.4173913043478, 0.125, 0.5
21512, 1.4608695652174, 0.125, 0.5
21513, 1.504347826087, 0.125, 0.5
21514, 1.5478260869565, 0.125, 0.5
21515, 1.5913043478261, 0.125, 0.5
21516, 1.6347826086957, 0.125, 0.5
21517, 1.6782608695652, 0.125, 0.5
21518, 1.7217391304348, 0.125, 0.5
21519, 1.7652173913043, 0.125, 0.5
21520, 1.8086956521739, 0.125, 0.5
21521, 1.8521739130435, 0.125, 0.5
21522, 1.895652173913, 0.125, 0.5
21523, 1.9391304347826, 0.125, 0.5
21524, 1.9826086956522, 0.125, 0.5
21525, 2.0260869565217, 0.125, 0.5
21526, 2.0695652173913, 0.125, 0.5
21527, 2.1130434782609, 0.125, 0.5
21528, 2.1565217391304, 0.125, 0.5
21529, 1.2217391304348, 0.125, 0.5
21530, 1.2434782608696, 0.1375, 0.5
21531, 1.2652173913043, 0.125, 0.5
21532, 1.2869565217391, 0.1375, 0.5
21533, 1.3086956521739, 0.125, 0.5
21534, 1.3304347826087, 0.1375, 0.5
21535, 1.3521739130435, 0.125, 0.5
21536, 1.3739130434783, 0.1375, 0.5
21537, 1.395652173913, 0.125, 0.5
21538, 1.4173913043478, 0.1375, 0.5
21539, 1.4391304347826, 0.125, 0.5
21540, 1.4608695652174, 0.1375, 0.5
21541, 1.4826086956522, 0.125, 0.5
21542, 1.504347826087, 0.1375, 0.5
21543, 1.5260869565217, 0.125, 0.5
21544, 1.5478260869565, 0.1375, 0.5
21545, 1.5695652173913, 0.125, 0.5
21546, 1.5913043478261, 0.1375, 0.5
21547, 1.6130434782609, 0.125, 0.5
21548, 1.6347826086957, 0.1375, 0.5
21549, 1.6565217391304, 0.125, 0.5
21550, 1.6782608695652, 0.1375, 0.5
21551, 1.7, 0.125, 0.5
21552, 1.7217391304348, 0.1375, 0.5
21553, 1.7434782608696, 0.125, 0.5
21554, 1.7652173913043, 0.1375, 0.5
21555, 1.7869565217391, 0.125, 0.5
21556, 1.8086956521739, 0.1375, 0.5
21557, 1.8304347826087, 0.125, 0.5
21558, 1.8521739130435, 0.1375, 0.5
21559, 1.8739130434783, 0.125, 0.5
21560, 1.895652173913, 0.1375, 0.5
21561, 1.9173913043478, 0.125, 0.5
21562, 1.9391304347826, 0.1375, 0.5
21563, 1.9608695652174, 0.125, 0.5
21564, 1.9826086956522, 0.1375, 0.5
21565, 2.004347826087, 0.125, 0.5
21566, 2.0260869565217, 0.1375, 0.5
21567, 2.0478260869565, 0.125, 0.5
21568, 2.0695652173913, 0.1375, 0.5
21569, 2.0913043478261, 0.125, 0.5
21570, 2.1130434782609, 0.1375, 0.5
21571, 2.1347826086957, 0.125, 0.5
21572, 2.1565217391304, 0.1375, 0.5
21573, 2.1782608695652, 0.125, 0.5
21574, 1.2434782608696, 0.1125, 0.5
21575, 1.2869565217391, 0.1125, 0.5
21576, 1.3304347826087, 0.1125, 0.5
21577, 1.3739130434783, 0.1125, 0.5
21578, 1.4173913043478, 0.1125, 0.5
21579, 1.4608695652174, 0.1125, 0.5
21580, 1.504347826087, 0.1125, 0.5
21581, 1.5478260869565, 0.1125, 0.5
21582, 1.5913043478261, 0.1125, 0.5
21583, 1.6347826086957, 0.1125, 0.5
21584, 1.6782608695652, 0.1125, 0.5
21585, 1.7217391304348, 0.1125, 0.5
21586, 1.7652173913043, 0.1125, 0.5
21587, 1.8086956521739, 0.1125, 0.5
21588, 1.8521739130435, 0.1125, 0.5
21589, 1.895652173913, 0.1125, 0.5
21590, 1.9391304347826, 0.1125, 0.5
21591, 1.9826086956522, 0.1125, 0.5
21592, 2.0260869565217, 0.1125, 0.5
21593, 2.0695652173913, 0.1125, 0.5
21594, 2.1130434782609, 0.1125, 0.5
21595, 2.1565217391304, 0.1125, 0.5
21596, 1.2434782608696, 0.125, 0
21597, 1.2869565217391, 0.125, 0
21598, 1.3304347826087, 0.125, 0
21599, 1.3739130434783, 0.125, 0
21600, 1.4173913043478, 0.125, 0
21601, 1.4608695652174, 0.125, 0
21602, 1.504347826087, 0.125, 0
21603, 1.5478260869565, 0.125, 0
21604, 1.5913043478261, 0.125, 0
21605, 1.6347826086957, 0.125, 0
21606, 1.6782608695652, 0.125, 0
21607, 1.7217391304348, 0.125, 0
21608, 1.7652173913043, 0.125, 0
21609, 1.8086956521739, 0.125, 0
21610, 1.8521739130435, 0.125, 0
21611, 1.895652173913, 0.125, 0
21612, 1.9391304347826, 0.125, 0
21613, 1.9826086956522, 0.125, 0
21614, 2.0260869565217, 0.125, 0
21615, 2.0695652173913, 0.125, 0
21616, 2.1130434782609, 0.125, 0
21617, 2.1565217391304, 0.125, 0
21618, 1.2434782608696, 0.1375, 0
21619, 1.2217391304348, 0.125, 0
21620, 1.2869565217391, 0.1375, 0
21621, 1.2652173913043, 0.125, 0
21622, 1.3304347826087, 0.1375, 0
21623, 1.3086956521739, 0.125, 0
21624, 1.3739130434783, 0.1375, 0
21625, 1.3521739130435, 0.125, 0
21626, 1.4173913043478, 0.1375, 0
21627, 1.395652173913, 0.125, 0
21628, 1.4608695652174, 0.1375, 0
21629, 1.4391304347826, 0.125, 0
21630, 1.504347826087, 0.1375, 0
21631, 1.4826086956522, 0.125, 0
21632, 1.5478260869565, 0.1375, 0
21633, 1.5260869565217, 0.125, 0
21634, 1.5913043478261, 0.1375, 0
21635, 1.5695652173913, 0.125, 0
21636, 1.6347826086957, 0.1375, 0
21637, 1.6130434782609, 0.125, 0
21638, 1.6782608695652, 0.1375, 0
21639, 1.6565217391304, 0.125, 0
21640, 1.7217391304348, 0.1375, 0
21641, 1.7, 0.125, 0
21642, 1.7652173913043, 0.1375, 0
21643, 1.7434782608696, 0.125, 0
21644, 1.8086956521739, 0.1375, 0
21645, 1.7869565217391, 0.125, 0
21646, 1.8521739130435, 0.1375, 0
21647, 1.8304347826087, 0.125, 0
21648, 1.895652173913, 0.1375, 0
21649, 1.8739130434783, 0.125, 0
21650, 1.9391304347826, 0.1375, 0
21651, 1.9173913043478, 0.125, 0
21652, 1.9826086956522, 0.1375, 0
21653, 1.9608695652174, 0.125, 0
21654, 2.0260869565217, 0.1375, 0
21655, 2.004347826087, 0.125, 0
21656, 2.0695652173913, 0.1375, 0
21657, 2.0478260869565, 0.125, 0
21658, 2.1130434782609, 0.1375, 0
21659, 2.0913043478261, 0.125, 0
21660, 2.1565217391304, 0.1375, 0
21661, 2.1347826086957, 0.125, 0
21662, 2.1782608695652, 0.125, 0
21663, 1.2434782608696, 0.1125, 0
21664, 1.2869565217391, 0.1125, 0
21665, 1.3304347826087, 0.1125, 0
21666, 1.3739130434783, 0.1125, 0
21667, 1.4173913043478, 0.1125, 0
21668, 1.4608695652174, 0.1125, 0
21669, 1.504347826087, 0.1125, 0
21670, 1.5478260869565, 0.1125, 0
21671, 1.5913043478261, 0.1125, 0
21672, 1.6347826086957, 0.1125, 0
21673, 1.6782608695652, 0.1125, 0
21674, 1.7217391304348, 0.1125, 0
21675, 1.7652173913043, 0.1125, 0
21676, 1.8086956521739, 0.1125, 0
21677, 1.8521739130435, 0.1125, 0
21678, 1.895652173913, 0.1125, 0
21679, 1.9391304347826, 0.1125, 0
21680, 1.9826086956522, 0.1125, 0
21681, 2.0260869565217, 0.1125, 0
21682, 2.0695652173913, 0.1125, 0
21683, 2.1130434782609, 0.1125, 0
21684, 2.1565217391304, 0.1125, 0
21685, 1.2, 0.125, 0.45454545454545
21686, 1.2, 0.125, 0.40909090909091
21687, 1.2, 0.125, 0.36363636363636
21688, 1.2, 0.125, 0.31818181818182
21689, 1.2, 0.125, 0.27272727272727
21690, 1.2, 0.125, 0.22727272727273
21691, 1.2, 0.125, 0.18181818181818
21692, 1.2, 0.125, 0.13636363636364
21693, 1.2, 0.125, 0.090909090909091
21694, 1.2, 0.125, 0.045454545454545
21695, 1.2, 0.1375, 0.45454545454545
21696, 1.2, 0.125, 0.47727272727273
21697, 1.2, 0.1375, 0.40909090909091
21698, 1.2, 0.125, 0.43181818181818
21699, 1.2, 0.1375, 0.36363636363636
21700, 1.2, 0.125, 0.38636363636364
21701, 1.2, 0.1375, 0.31818181818182
21702, 1.2, 0.125, 0.34090909090909
21703, 1.2, 0.1375, 0.27272727272727
21704, 1.2, 0.125, 0.29545454545455
21705, 1.2, 0.1375, 0.22727272727273
21706, 1.2, 0.125, 0.25
21707, 1.2, 0.1375, 0.18181818181818
21708, 1.2, 0.125, 0.20454545454545
21709, 1.2, 0.1375, 0.13636363636364
21710, 1.2, 0.125, 0.15909090909091
21711, 1.2, 0.1375, 0.090909090909091
21712, 1.2, 0.125, 0.11363636363636
21713, 1.2, 0.1375, 0.045454545454545
21714, 1.2, 0.125, 0.068181818181818
21715, 1.2, 0.125, 0.022727272727273
21716, 1.2, 0.1125, 0.45454545454545
21717, 1.2, 0.1125, 0.40909090909091
21718, 1.2, 0.1125, 0.36363636363636
21719, 1.2, 0.1125, 0.31818181818182
21720, 1.2, 0.1125, 0.27272727272727
21721, 1.2, 0.1125, 0.22727272727273
21722, 1.2, 0.1125, 0.18181818181818
21723, 1.2, 0.1125, 0.13636363636364
21724, 1.2, 0.1125, 0.090909090909091
21725, 1.2, 0.1125, 0.045454545454545
21726, 2.2, 0.125, 0.45454545454545
21727, 2.2, 0.125, 0.40909090909091
21728, 2.2, 0.125, 0.36363636363636
21729, 2.2, 0.125, 0.31818181818182
21730, 2.2, 0.125, 0.27272727272727
21731, 2.2, 0.125, 0.22727272727273
21732, 2.2, 0.125, 0.18181818181818
21733, 2.2, 0.125, 0.13636363636364
21734, 2.2, 0.125, 0.090909090909091
21735, 2.2, 0.125, 0.045454545454545
21736, 2.2, 0.125, 0.47727272727273
21737, 2.2, 0.1375, 0.45454545454545
21738, 2.2, 0.125, 0.43181818181818
21739, 2.2, 0.1375, 0.40909090909091
21740, 2.2, 0.125, 0.38636363636364
21741, 2.2, 0.1375, 0.36363636363636
21742, 2.2, 0.125, 0.34090909090909
21743, 2.2, 0.1375, 0.31818181818182
21744, 2.2, 0.125, 0.29545454545455
21745, 2.2, 0.1375, 0.27272727272727
21746, 2.2, 0.125, 0.25
21747, 2.2, 0.1375, 0.22727272727273
21748, 2.2, 0.125, 0.20454545454545
21749, 2.2, 0.1375, 0.18181818181818
21750, 2.2, 0.125, 0.15909090909091
21751, 2.2, 0.1375, 0.13636363636364
21752, 2.2, 0.125, 0.11363636363636
21753, 2.2, 0.1375, 0.090909090909091
21754, 2.2, 0.125, 0.068181818181818
21755, 2.2, 0.1375, 0.045454545454545
21756, 2.2, 0.125, 0.022727272727273
21757, 2.2, 0.1125, 0.45454545454545
21758, 2.2, 0.1125, 0.40909090909091
21759, 2.2, 0.1125, 0.36363636363636
21760, 2.2, 0.1125, 0.31818181818182
21761, 2.2, 0.1125, 0.27272727272727
21762, 2.2, 0.1125, 0.22727272727273
21763, 2.2, 0.1125, 0.18181818181818
21764, 2.2, 0.1125, 0.13636363636364
21765, 2.2, 0.1125, 0.090909090909091
21766, 2.2, 0.1125, 0.045454545454545
21767, 1.2434782608696, 0.1, 0.45454545454545
21768, 1.2434782608696, 0.1, 0.40909090909091
21769, 1.2434782608696, 0.1, 0.36363636363636
21770, 1.2434782608696, 0.1, 0.31818181818182
21771, 1.2434782608696, 0.1, 0.27272727272727
21772, 1.2434782608696, 0.1, 0.22727272727273
21773, 1.2434782608696, 0.1, 0.18181818181818
21774, 1.2434782608696, 0.1, 0.13636363636364
21775, 1.2434782608696, 0.1, 0.090909090909091
21776, 1.2434782608696, 0.1, 0.045454545454545
21777, 1.2869565217391, 0.1, 0.45454545454545
21778, 1.2869565217391, 0.1, 0.40909090909091
21779, 1.2869565217391, 0.1, 0.36363636363636
21780, 1.2869565217391, 0.1, 0.31818181818182
21781, 1.2869565217391, 0.1, 0.27272727272727
21782, 1.2869565217391, 0.1, 0.22727272727273
21783, 1.2869565217391, 0.1, 0.18181818181818
21784, 1.2869565217391, 0.1, 0.13636363636364
21785, 1.2869565217391, 0.1, 0.090909090909091
21786, 1.2869565217391, 0.1, 0.045454545454545
21787, 1.3304347826087, 0.1, 0.45454545454545
21788, 1.3304347826087, 0.1, 0.40909090909091
21789, 1.3304347826087, 0.1, 0.36363636363636
21790, 1.3304347826087, 0.1, 0.31818181818182
21791, 1.3304347826087, 0.1, 0.27272727272727
21792, 1.3304347826087, 0.1, 0.22727272727273
21793, 1.3304347826087, 0.1, 0.18181818181818
21794, 1.3304347826087, 0.1, 0.13636363636364
21795, 1.3304347826087, 0.1, 0.090909090909091
21796, 1.3304347826087, 0.1, 0.045454545454545
21797, 1.3739130434783, 0.1, 0.45454545454545
21798, 1.3739130434783, 0.1, 0.40909090909091
21799, 1.3739130434783, 0.1, 0.36363636363636
21800, 1.3739130434783, 0.1, 0.31818181818182
21801, 1.3739130434783, 0.1, 0.27272727272727
21802, 1.3739130434783, 0.1, 0.22727272727273
21803, 1.3739130434783, 0.1, 0.18181818181818
21804, 1.3739130434783, 0.1, 0.13636363636364
21805, 1.3739130434783, 0.1, 0.090909090909091
21806, 1.3739130434783, 0.1, 0.045454545454545
21807, 1.4173913043478, 0.1, 0.45454545454545
21808, 1.4173913043478, 0.1, 0.40909090909091
21809, 1.4173913043478, 0.1, 0.36363636363636
21810, 1.4173913043478, 0.1, 0.31818181818182
21811, 1.4173913043478, 0.1, 0.27272727272727
21812, 1.4173913043478, 0.1, 0.22727272727273
21813, 1.4173913043478, 0.1, 0.18181818181818
21814, 1.4173913043478, 0.1, 0.13636363636364
21815, 1.4173913043478, 0.1, 0.090909090909091
21816, 1.4173913043478, 0.1, 0.045454545454545
21817, 1.4608695652174, 0.1, 0.45454545454545
21818, 1.4608695652174, 0.1, 0.40909090909091
21819, 1.4608695652174, 0.1, 0.36363636363636
21820, 1.4608695652174, 0.1, 0.31818181818182
21821, 1.4608695652174, 0.1, 0.27272727272727
21822, 1.4608695652174, 0.1, 0.22727272727273
21823, 1.4608695652174, 0.1, 0.18181818181818
21824, 1.4608695652174, 0.1, 0.13636363636364
21825, 1.4608695652174, 0.1, 0.090909090909091
21826, 1.4608695652174, 0.1, 0.045454545454545
21827, 1.504347826087, 0.1, 0.45454545454545
21828, 1.504347826087, 0.1, 0.40909090909091
21829, 1.504347826087, 0.1, 0.36363636363636
21830, 1.504347826087, 0.1, 0.31818181818182
21831, 1.504347826087, 0.1, 0.27272727272727
21832, 1.504347826087, 0.1, 0.22727272727273
21833, 1.504347826087, 0.1, 0.18181818181818
21834, 1.504347826087, 0.1, 0.13636363636364
21835, 1.504347826087, 0.1, 0.090909090909091
21836, 1.504347826087, 0.1, 0.045454545454545
21837, 1.5478260869565, 0.1, 0.45454545454545
21838, 1.5478260869565, 0.1, 0.40909090909091
21839, 1.5478260869565, 0.1, 0.36363636363636
21840, 1.5478260869565, 0.1, 0.31818181818182
21841, 1.5478260869565, 0.1, 0.27272727272727
21842, 1.5478260869565, 0.1, 0.22727272727273
21843, 1.5478260869565, 0.1, 0.18181818181818
21844, 1.5478260869565, 0.1, 0.13636363636364
21845, 1.5478260869565, 0.1, 0.090909090909091
21846, 1.5478260869565, 0.1, 0.045454545454545
21847, 1.5913043478261, 0.1, 0.45454545454545
21848, 1.5913043478261, 0.1, 0.40909090909091
21849, 1.5913043478261, 0.1, 0.36363636363636
21850, 1.5913043478261, 0.1, 0.31818181818182
21851, 1.5913043478261, 0.1, 0.27272727272727
21852, 1.5913043478261, 0.1, 0.22727272727273
21853, 1.5913043478261, 0.1, 0.18181818181818
21854, 1.5913043478261, 0.1, 0.13636363636364
21855, 1.5913043478261, 0.1, 0.090909090909091
21856, 1.5913043478261, 0.1, 0.045454545454545
21857, 1.6347826086957, 0.1, 0.45454545454545
21858, 1.6347826086957, 0.1, 0.40909090909091
21859, 1.6347826086957, 0.1, 0.36363636363636
21860, 1.6347826086957, 0.1, 0.31818181818182
21861, 1.6347826086957, 0.1, 0.27272727272727
21862, 1.6347826086957, 0.1, 0.22727272727273
21863, 1.6347826086957, 0.1, 0.18181818181818
21864, 1.6347826086957, 0.1, 0.13636363636364
21865, 1.6347826086957, 0.1, 0.090909090909091
21866, 1.6347826086957, 0.1, 0.045454545454545
21867, 1.6782608695652, 0.1, 0.45454545454545
21868, 1.6782608695652, 0.1, 0.40909090909091
21869, 1.6782608695652, 0.1, 0.36363636363636
21870, 1.6782608695652, 0.1, 0.31818181818182
21871, 1.6782608695652, 0.1, 0.27272727272727
21872, 1.6782608695652, 0.1, 0.22727272727273
21873, 1.6782608695652, 0.1, 0.18181818181818
21874, 1.6782608695652, 0.1, 0.13636363636364
21875, 1.6782608695652, 0.1, 0.090909090909091
21876, 1.6782608695652, 0.1, 0.045454545454545
21877, 1.7217391304348, 0.1, 0.45454545454545
21878, 1.7217391304348, 0.1, 0.40909090909091
21879, 1.7217391304348, 0.1, 0.36363636363636
21880, 1.7217391304348, 0.1, 0.31818181818182
21881, 1.7217391304348, 0.1, 0.27272727272727
21882, 1.7217391304348, 0.1, 0.22727272727273
21883, 1.7217391304348, 0.1, 0.18181818181818
21884, 1.7217391304348, 0.1, 0.13636363636364
21885, 1.7217391304348, 0.1, 0.090909090909091
21886, 1.7217391304348, 0.1, 0.045454545454545
21887, 1.7652173913043, 0.1, 0.45454545454545
21888, 1.7652173913043, 0.1, 0.40909090909091
21889, 1.7652173913043, 0.1, 0.36363636363636
21890, 1.7652173913043, 0.1, 0.31818181818182
21891, 1.7652173913043, 0.1, 0.27272727272727
21892, 1.7652173913043, 0.1, 0.22727272727273
21893, 1.7652173913043, 0.1, 0.18181818181818
21894, 1.7652173913043, 0.1, 0.13636363636364
21895, 1.7652173913043, 0.1, 0.090909090909091
21896, 1.7652173913043, 0.1, 0.045454545454545
21897, 1.8086956521739, 0.1, 0.45454545454545
21898, 1.8086956521739, 0.1, 0.40909090909091
21899, 1.8086956521739, 0.1, 0.36363636363636
21900, 1.8086956521739, 0.1, 0.31818181818182
21901, 1.8086956521739, 0.1, 0.27272727272727
21902, 1.8086956521739, 0.1, 0.22727272727273
21903, 1.8086956521739, 0.1, 0.18181818181818
21904, 1.8086956521739, 0.1, 0.13636363636364
21905, 1.8086956521739, 0.1, 0.090909090909091
21906, 1.8086956521739, 0.1, 0.045454545454545
21907, 1.8521739130435, 0.1, 0.45454545454545
21908, 1.8521739130435, 0.1, 0.40909090909091
21909, 1.8521739130435, 0.1, 0.36363636363636
21910, 1.8521739130435, 0.1, 0.31818181818182
21911, 1.8521739130435, 0.1, 0.27272727272727
21912, 1.8521739130435, 0.1, 0.22727272727273
21913, 1.8521739130435, 0.1, 0.18181818181818
21914, 1.8521739130435, 0.1, 0.13636363636364
21915, 1.8521739130435, 0.1, 0.090909090909091
21916, 1.8521739130435, 0.1, 0.045454545454545
21917, 1.895652173913, 0.1, 0.45454545454545
21918, 1.895652173913, 0.1, 0.40909090909091
21919, 1.895652173913, 0.1, 0.36363636363636
21920, 1.895652173913, 0.1, 0.31818181818182
21921, 1.895652173913, 0.1, 0.27272727272727
21922, 1.895652173913, 0.1, 0.22727272727273
21923, 1.895652173913, 0.1, 0.18181818181818
21924, 1.895652173913, 0.1, 0.13636363636364
21925, 1.895652173913, 0.1, 0.090909090909091
21926, 1.895652173913, 0.1, 0.045454545454545
21927, 1.9391304347826, 0.1, 0.45454545454545
21928, 1.9391304347826, 0.1, 0.40909090909091
21929, 1.9391304347826, 0.1, 0.36363636363636
21930, 1.9391304347826, 0.1, 0.31818181818182
21931, 1.9391304347826, 0.1, 0.27272727272727
21932, 1.9391304347826, 0.1, 0.22727272727273
21933, 1.9391304347826, 0.1, 0.18181818181818
21934, 1.9391304347826, 0.1, 0.13636363636364
21935, 1.9391304347826, 0.1, 0.090909090909091
21936, 1.9391304347826, 0.1, 0.045454545454545
21937, 1.9826086956522, 0.1, 0.45454545454545
21938, 1.9826086956522, 0.1, 0.40909090909091
21939, 1.9826086956522, 0.1, 0.36363636363636
21940, 1.9826086956522, 0.1, 0.31818181818182
21941, 1.9826086956522, 0.1, 0.27272727272727
21942, 1.9826086956522, 0.1, 0.22727272727273
21943, 1.9826086956522, 0.1, 0.18181818181818
21944, 1.9826086956522, 0.1, 0.13636363636364
21945, 1.9826086956522, 0.1, 0.090909090909091
21946, 1.9826086956522, 0.1, 0.045454545454545
21947, 2.0260869565217, 0.1, 0.45454545454545
21948, 2.0260869565217, 0.1, 0.40909090909091
21949, 2.0260869565217, 0.1, 0.36363636363636
21950, 2.0260869565217, 0.1, 0.31818181818182
21951, 2.0260869565217, 0.1, 0.27272727272727
21952, 2.0260869565217, 0.1, 0.22727272727273
21953, 2.0260869565217, 0.1, 0.18181818181818
21954, 2.0260869565217, 0.1, 0.13636363636364
21955, 2.0260869565217, 0.1, 0.090909090909091
21956, 2.0260869565217, 0.1, 0.045454545454545
21957, 2.0695652173913, 0.1, 0.45454545454545
21958, 2.0695652173913, 0.1, 0.40909090909091
21959, 2.0695652173913, 0.1, 0.36363636363636
21960, 2.0695652173913, 0.1, 0.31818181818182
21961, 2.0695652173913, 0.1, 0.27272727272727
21962, 2.0695652173913, 0.1, 0.22727272727273
21963, 2.0695652173913, 0.1, 0.18181818181818
21964, 2.0695652173913, 0.1, 0.13636363636364
21965, 2.0695652173913, 0.1, 0.090909090909091
21966, 2.0695652173913, 0.1, 0.045454545454545
21967, 2.1130434782609, 0.1, 0.45454545454545
21968, 2.1130434782609, 0.1, 0.40909090909091
21969, 2.1130434782609, 0.1, 0.36363636363636
21970, 2.1130434782609, 0.1, 0.31818181818182
21971, 2.1130434782609, 0.1, 0.27272727272727
21972, 2.1130434782609, 0.1, 0.22727272727273
21973, 2.1130434782609, 0.1, 0.18181818181818
21974, 2.1130434782609, 0.1, 0.13636363636364
21975, 2.1130434782609, 0.1, 0.090909090909091
21976, 2.1130434782609, 0.1, 0.045454545454545
21977, 2.1565217391304, 0.1, 0.45454545454545
21978, 2.1565217391304, 0.1, 0.40909090909091
21979, 2.1565217391304, 0.1, 0.36363636363636
21980, 2.1565217391304, 0.1, 0.31818181818182
21981, 2.1565217391304, 0.1, 0.27272727272727
21982, 2.1565217391304, 0.1, 0.22727272727273
21983, 2.1565217391304, 0.1, 0.18181818181818
21984, 2.1565217391304, 0.1, 0.13636363636364
21985, 2.1565217391304, 0.1, 0.090909090909091
21986, 2.1565217391304, 0.1, 0.045454545454545
21987, 1.2217391304348, 0.1, 0.45454545454545
21988, 1.2434782608696, 0.1, 0.47727272727273
21989, 1.2217391304348, 0.1, 0.40909090909091
21990, 1.2434782608696, 0.1, 0.43181818181818
21991, 1.2217391304348, 0.1, 0.36363636363636
21992, 1.2434782608696, 0.1, 0.38636363636364
21993, 1.2217391304348, 0.1, 0.31818181818182
21994, 1.2434782608696, 0.1, 0.34090909090909
21995, 1.2217391304348, 0.1, 0.27272727272727
21996, 1.2434782608696, 0.1, 0.29545454545455
21997, 1.2217391304348, 0.1, 0.22727272727273
21998, 1.2434782608696, 0.1, 0.25
21999, 1.2217391304348, 0.1, 0.18181818181818
22000, 1.2434782608696, 0.1, 0.20454545454545
22001, 1.2217391304348, 0.1, 0.13636363636364
22002, 1.2434782608696, 0.1, 0.15909090909091
22003, 1.2217391304348, 0.1, 0.090909090909091
22004, 1.2434782608696, 0.1, 0.11363636363636
22005, 1.2217391304348, 0.1, 0.045454545454545
22006, 1.2434782608696, 0.1, 0.068181818181818
22007, 1.2434782608696, 0.1, 0.022727272727273
22008, 1.2652173913043, 0.1, 0.45454545454545
22009, 1.2869565217391, 0.1, 0.47727272727273
22010, 1.2652173913043, 0.1, 0.40909090909091
22011, 1.2869565217391, 0.1, 0.43181818181818
22012, 1.2652173913043, 0.1, 0.36363636363636
22013, 1.2869565217391, 0.1, 0.38636363636364
22014, 1.2652173913043, 0.1, 0.31818181818182
22015, 1.2869565217391, 0.1, 0.34090909090909
22016, 1.2652173913043, 0.1, 0.27272727272727
22017, 1.2869565217391, 0.1, 0.29545454545455
22018, 1.2652173913043, 0.1, 0.22727272727273
22019, 1.2869565217391, 0.1, 0.25
22020, 1.2652173913043, 0.1, 0.18181818181818
22021, 1.2869565217391, 0.1, 0.20454545454545
22022, 1.2652173913043, 0.1, 0.13636363636364
22023, 1.2869565217391, 0.1, 0.15909090909091
22024, 1.2652173913043, 0.1, 0.090909090909091
22025, 1.2869565217391, 0.1, 0.11363636363636
22026, 1.2652173913043, 0.1, 0.045454545454545
22027, 1.2869565217391, 0.1, 0.068181818181818
22028, 1.2869565217391, 0.1, 0.022727272727273
22029, 1.3086956521739, 0.1, 0.45454545454545
22030, 1.3304347826087, 0.1, 0.47727272727273
22031, 1.3086956521739, 0.1, 0.40909090909091
22032, 1.3304347826087, 0.1, 0.43181818181818
22033, 1.3086956521739, 0.1, 0.36363636363636
22034, 1.3304347826087, 0.1, 0.38636363636364
22035, 1.3086956521739, 0.1, 0.31818181818182
22036, 1.3304347826087, 0.1, 0.34090909090909
22037, 1.3086956521739, 0.1, 0.27272727272727
22038, 1.3304347826087, 0.1, 0.29545454545455
22039, 1.3086956521739, 0.1, 0.22727272727273
22040, 1.3304347826087, 0.1, 0.25
22041, 1.3086956521739, 0.1, 0.18181818181818
22042, 1.3304347826087, 0.1, 0.20454545454545
22043, 1.3086956521739, 0.1, 0.13636363636364
22044, 1.3304347826087, 0.1, 0.15909090909091
22045, 1.3086956521739, 0.1, 0.090909090909091
22046, 1.3304347826087, 0.1, 0.11363636363636
22047, 1.3086956521739, 0.1, 0.045454545454545
22048, 1.3304347826087, 0.1, 0.068181818181818
22049, 1.3304347826087, 0.1, 0.022727272727273
22050, 1.3521739130435, 0.1, 0.45454545454545
22051, 1.3739130434783, 0.1, 0.47727272727273
22052, 1.3521739130435, 0.1, 0.40909090909091
22053, 1.3739130434783, 0.1, 0.43181818181818
22054, 1.3521739130435, 0.1, 0.36363636363636
22055, 1.3739130434783, 0.1, 0.38636363636364
22056, 1.3521739130435, 0.1, 0.31818181818182
22057, 1.3739130434783, 0.1, 0.34090909090909
22058, 1.3521739130435, 0.1, 0.27272727272727
22059, 1.3739130434783, 0.1, 0.29545454545455
22060, 1.3521739130435, 0.1, 0.22727272727273
22061, 1.3739130434783, 0.1, 0.25
22062, 1.3521739130435, 0.1, 0.18181818181818
22063, 1.3739130434783, 0.1, 0.20454545454545
22064, 1.3521739130435, 0.1, 0.13636363636364
22065, 1.3739130434783, 0.1, 0.15909090909091
22066, 1.3521739130435, 0.1, 0.090909090909091
22067, 1.3739130434783, 0.1, 0.11363636363636
22068, 1.3521739130435, 0.1, 0.045454545454545
22069, 1.3739130434783, 0.1, 0.068181818181818
22070, 1.3739130434783, 0.1, 0.022727272727273
22071, 1.395652173913, 0.1, 0.45454545454545
22072, 1.4173913043478, 0.1, 0.47727272727273
22073, 1.395652173913, 0.1, 0.40909090909091
22074, 1.4173913043478, 0.1, 0.43181818181818
22075, 1.395652173913, 0.1, 0.36363636363636
22076, 1.4173913043478, 0.1, 0.38636363636364
22077, 1.395652173913, 0.1, 0.31818181818182
22078, 1.4173913043478, 0.1, 0.34090909090909
22079, 1.395652173913, 0.1, 0.27272727272727
22080, 1.4173913043478, 0.1, 0.29545454545455
22081, 1.395652173913, 0.1, 0.22727272727273
22082, 1.4173913043478, 0.1, 0.25
22083, 1.395652173913, 0.1, 0.18181818181818
22084, 1.4173913043478, 0.1, 0.20454545454545
22085, 1.395652173913, 0.1, 0.13636363636364
22086, 1.4173913043478, 0.1, 0.15909090909091
22087, 1.395652173913, 0.1, 0.090909090909091
22088, 1.4173913043478, 0.1, 0.11363636363636
22089, 1.395652173913, 0.1, 0.045454545454545
22090, 1.4173913043478, 0.1, 0.068181818181818
22091, 1.4173913043478, 0.1, 0.022727272727273
22092, 1.4391304347826, 0.1, 0.45454545454545
22093, 1.4608695652174, 0.1, 0.47727272727273
22094, 1.4391304347826, 0.1, 0.40909090909091
22095, 1.4608695652174, 0.1, 0.43181818181818
22096, 1.4391304347826, 0.1, 0.36363636363636
22097, 1.4608695652174, 0.1, 0.38636363636364
22098, 1.4391304347826, 0.1, 0.31818181818182
22099, 1.4608695652174, 0.1, 0.34090909090909
22100, 1.4391304347826, 0.1, 0.27272727272727
22101, 1.4608695652174, 0.1, 0.29545454545455
22102, 1.4391304347826, 0.1, 0.22727272727273
22103, 1.4608695652174, 0.1, 0.25
22104, 1.4391304347826, 0.1, 0.18181818181818
22105, 1.4608695652174, 0.1, 0.20454545454545
22106, 1.4391304347826, 0.1, 0.13636363636364
22107, 1.4608695652174, 0.1, 0.15909090909091
22108, 1.4391304347826, 0.1, 0.090909090909091
22109, 1.4608695652174, 0.1, 0.11363636363636
22110, 1.4391304347826, 0.1, 0.045454545454545
22111, 1.4608695652174, 0.1, 0.068181818181818
22112, 1.4608695652174, 0.1, 0.022727272727273
22113, 1.4826086956522, 0.1, 0.45454545454545
22114, 1.504347826087, 0.1, 0.47727272727273
22115, 1.4826086956522, 0.1, 0.40909090909091
22116, 1.504347826087, 0.1, 0.43181818181818
22117, 1.4826086956522, 0.1, 0.36363636363636
22118, 1.504347826087, 0.1, 0.38636363636364
22119, 1.4826086956522, 0.1, 0.31818181818182
22120, 1.504347826087, 0.1, 0.34090909090909
22121, 1.4826086956522, 0.1, 0.27272727272727
22122, 1.504347826087, 0.1, 0.29545454545455
22123, 1.4826086956522, 0.1, 0.22727272727273
22124, 1.504347826087, 0.1, 0.25
22125, 1.4826086956522, 0.1, 0.18181818181818
22126, 1.504347826087, 0.1, 0.20454545454545
22127, 1.4826086956522, 0.1, 0.13636363636364
22128, 1.504347826087, 0.1, 0.15909090909091
22129, 1.4826086956522, 0.1, 0.090909090909091
22130, 1.504347826087, 0.1, 0.11363636363636
22131, 1.4826086956522, 0.1, 0.045454545454545
22132, 1.504347826087, 0.1, 0.068181818181818
22133, 1.504347826087, 0.1, 0.022727272727273
22134, 1.5260869565217, 0.1, 0.45454545454545
22135, 1.5478260869565, 0.1, 0.47727272727273
22136, 1.5260869565217, 0.1, 0.40909090909091
22137, 1.5478260869565, 0.1, 0.43181818181818
22138, 1.5260869565217, 0.1, 0.36363636363636
22139, 1.5478260869565, 0.1, 0.38636363636364
22140, 1.5260869565217, 0.1, 0.31818181818182
22141, 1.5478260869565, 0.1, 0.34090909090909
22142, 1.5260869565217, 0.1, 0.27272727272727
22143, 1.5478260869565, 0.1, 0.29545454545455
22144, 1.5260869565217, 0.1, 0.22727272727273
22145, 1.5478260869565, 0.1, 0.25
22146, 1.5260869565217, 0.1, 0.18181818181818
22147, 1.5478260869565, 0.1, 0.20454545454545
22148, 1.5260869565217, 0.1, 0.13636363636364
22149, 1.5478260869565, 0.1, 0.15909090909091
22150, 1.5260869565217, 0.1, 0.090909090909091
22151, 1.5478260869565, 0.1, 0.11363636363636
22152, 1.5260869565217, 0.1, 0.045454545454545
22153, 1.5478260869565, 0.1, 0.068181818181818
22154, 1.5478260869565, 0.1, 0.022727272727273
22155, 1.5695652173913, 0.1, 0.45454545454545
22156, 1.5913043478261, 0.1, 0.47727272727273
22157, 1.5695652173913, 0.1, 0.40909090909091
22158, 1.5913043478261, 0.1, 0.43181818181818
22159, 1.5695652173913, 0.1, 0.36363636363636
22160, 1.5913043478261, 0.1, 0.38636363636364
22161, 1.5695652173913, 0.1, 0.31818181818182
22162, 1.5913043478261, 0.1, 0.34090909090909
22163, 1.5695652173913, 0.1, 0.27272727272727
22164, 1.5913043478261, 0.1, 0.29545454545455
22165, 1.5695652173913, 0.1, 0.22727272727273
22166, 1.5913043478261, 0.1, 0.25
22167, 1.5695652173913, 0.1, 0.18181818181818
22168, 1.5913043478261, 0.1, 0.20454545454545
22169, 1.5695652173913, 0.1, 0.13636363636364
22170, 1.5913043478261, 0.1, 0.15909090909091
22171, 1.5695652173913, 0.1, 0.090909090909091
22172, 1.5913043478261, 0.1, 0.11363636363636
22173, 1.5695652173913, 0.1, 0.045454545454545
22174, 1.5913043478261, 0.1, 0.068181818181818
22175, 1.5913043478261, 0.1, 0.022727272727273
22176, 1.6130434782609, 0.1, 0.45454545454545
22177, 1.6347826086957, 0.1, 0.47727272727273
22178, 1.6130434782609, 0.1, 0.40909090909091
22179, 1.6347826086957, 0.1, 0.43181818181818
22180, 1.6130434782609, 0.1, 0.36363636363636
22181, 1.6347826086957, 0.1, 0.38636363636364
22182, 1.6130434782609, 0.1, 0.31818181818182
22183, 1.6347826086957, 0.1, 0.34090909090909
22184, 1.6130434782609, 0.1, 0.27272727272727
22185, 1.6347826086957, 0.1, 0.29545454545455
22186, 1.6130434782609, 0.1, 0.22727272727273
22187, 1.6347826086957, 0.1, 0.25
22188, 1.6130434782609, 0.1, 0.18181818181818
22189, 1.6347826086957, 0.1, 0.20454545454545
22190, 1.6130434782609, 0.1, 0.13636363636364
22191, 1.6347826086957, 0.1, 0.15909090909091
22192, 1.6130434782609, 0.1, 0.090909090909091
22193, 1.6347826086957, 0.1, 0.11363636363636
22194, 1.6130434782609, 0.1, 0.045454545454545
22195, 1.6347826086957, 0.1, 0.068181818181818
22196, 1.6347826086957, 0.1, 0.022727272727273
22197, 1.6565217391304, 0.1, 0.45454545454545
22198, 1.6782608695652, 0.1, 0.47727272727273
22199, 1.6565217391304, 0.1, 0.40909090909091
22200, 1.6782608695652, 0.1, 0.43181818181818
22201, 1.6565217391304, 0.1, 0.36363636363636
22202, 1.6782608695652, 0.1, 0.38636363636364
22203, 1.6565217391304, 0.1, 0.31818181818182
22204, 1.6782608695652, 0.1, 0.34090909090909
22205, 1.6565217391304, 0.1, 0.27272727272727
22206, 1.6782608695652, 0.1, 0.29545454545455
22207, 1.6565217391304, 0.1, 0.22727272727273
22208, 1.6782608695652, 0.1, 0.25
22209, 1.6565217391304, 0.1, 0.18181818181818
22210, 1.6782608695652, 0.1, 0.20454545454545
22211, 1.6565217391304, 0.1, 0.13636363636364
22212, 1.6782608695652, 0.1, 0.15909090909091
22213, 1.6565217391304, 0.1, 0.090909090909091
22214, 1.6782608695652, 0.1, 0.11363636363636
22215, 1.6565217391304, 0.1, 0.045454545454545
22216, 1.6782608695652, 0.1, 0.068181818181818
22217, 1.6782608695652, 0.1, 0.022727272727273
22218, 1.7, 0.1, 0.45454545454545
22219, 1.7217391304348, 0.1, 0.47727272727273
22220, 1.7, 0.1, 0.40909090909091
22221, 1.7217391304348, 0.1, 0.43181818181818
22222, 1.7, 0.1, 0.36363636363636
22223, 1.7217391304348, 0.1, 0.38636363636364
22224, 1.7, 0.1, 0.31818181818182
22225, 1.7217391304348, 0.1, 0.34090909090909
22226, 1.7, 0.1, 0.27272727272727
22227, 1.7217391304348, 0.1, 0.29545454545455
22228, 1.7, 0.1, 0.22727272727273
22229, 1.7217391304348, 0.1, 0.25
22230, 1.7, 0.1, 0.18181818181818
22231, 1.7217391304348, 0.1, 0.20454545454545
22232, 1.7, 0.1, 0.13636363636364
22233, 1.7217391304348, 0.1, 0.15909090909091
22234, 1.7, 0.1, 0.090909090909091
22235, 1.7217391304348, 0.1, 0.11363636363636
22236, 1.7, 0.1, 0.045454545454545
22237, 1.7217391304348, 0.1, 0.068181818181818
22238, 1.7217391304348, 0.1, 0.022727272727273
22239, 1.7434782608696, 0.1, 0.45454545454545
22240, 1.7652173913043, 0.1, 0.47727272727273
22241, 1.7434782608696, 0.1, 0.40909090909091
22242, 1.7652173913043, 0.1, 0.43181818181818
22243, 1.7434782608696, 0.1, 0.36363636363636
22244, 1.7652173913043, 0.1, 0.38636363636364
22245, 1.7434782608696, 0.1, 0.31818181818182
22246, 1.7652173913043, 0.1, 0.34090909090909
22247, 1.7434782608696, 0.1, 0.27272727272727
22248, 1.7652173913043, 0.1, 0.29545454545455
22249, 1.7434782608696, 0.1, 0.22727272727273
22250, 1.7652173913043, 0.1, 0.25
22251, 1.7434782608696, 0.1, 0.18181818181818
22252, 1.7652173913043, 0.1, 0.20454545454545
22253, 1.7434782608696, 0.1, 0.13636363636364
22254, 1.7652173913043, 0.1, 0.15909090909091
22255, 1.7434782608696, 0.1, 0.090909090909091
22256, 1.7652173913043, 0.1, 0.11363636363636
22257, 1.7434782608696, 0.1, 0.045454545454545
22258, 1.7652173913043, 0.1, 0.068181818181818
22259, 1.7652173913043, 0.1, 0.022727272727273
22260, 1.7869565217391, 0.1, 0.45454545454545
22261, 1.8086956521739, 0.1, 0.47727272727273
22262, 1.7869565217391, 0.1, 0.40909090909091
22263, 1.8086956521739, 0.1, 0.43181818181818
22264, 1.7869565217391, 0.1, 0.36363636363636
22265, 1.8086956521739, 0.1, 0.38636363636364
22266, 1.7869565217391, 0.1, 0.31818181818182
22267, 1.8086956521739, 0.1, 0.34090909090909
22268, 1.7869565217391, 0.1, 0.27272727272727
22269, 1.8086956521739, 0.1, 0.29545454545455
22270, 1.7869565217391, 0.1, 0.22727272727273
22271, 1.8086956521739, 0.1, 0.25
22272, 1.7869565217391, 0.1, 0.18181818181818
22273, 1.8086956521739, 0.1, 0.20454545454545
22274, 1.7869565217391, 0.1, 0.13636363636364
22275, 1.8086956521739, 0.1, 0.15909090909091
22276, 1.7869565217391, 0.1, 0.090909090909091
22277, 1.8086956521739, 0.1, 0.11363636363636
22278, 1.7869565217391, 0.1, 0.045454545454545
22279, 1.8086956521739, 0.1, 0.068181818181818
22280, 1.8086956521739, 0.1, 0.022727272727273
22281, 1.8304347826087, 0.1, 0.45454545454545
22282, 1.8521739130435, 0.1, 0.47727272727273
22283, 1.8304347826087, 0.1, 0.40909090909091
22284, 1.8521739130435, 0.1, 0.43181818181818
22285, 1.8304347826087, 0.1, 0.36363636363636
22286, 1.8521739130435, 0.1, 0.38636363636364
22287, 1.8304347826087, 0.1, 0.31818181818182
22288, 1.8521739130435, 0.1, 0.34090909090909
22289, 1.8304347826087, 0.1, 0.27272727272727
22290, 1.8521739130435, 0.1, 0.29545454545455
22291, 1.8304347826087, 0.1, 0.22727272727273
22292, 1.8521739130435, 0.1, 0.25
22293, 1.8304347826087, 0.1, 0.18181818181818
22294, 1.8521739130435, 0.1, 0.20454545454545
22295, 1.8304347826087, 0.1, 0.13636363636364
22296, 1.8521739130435, 0.1, 0.15909090909091
22297, 1.8304347826087, 0.1, 0.090909090909091
22298, 1.8521739130435, 0.1, 0.11363636363636
22299, 1.8304347826087, 0.1, 0.045454545454545
22300, 1.8521739130435, 0.1, 0.068181818181818
22301, 1.8521739130435, 0.1, 0.022727272727273
22302, 1.8739130434783, 0.1, 0.45454545454545
22303, 1.895652173913, 0.1, 0.47727272727273
22304, 1.8739130434783, 0.1, 0.40909090909091
22305, 1.895652173913, 0.1, 0.43181818181818
22306, 1.8739130434783, 0.1, 0.36363636363636
22307, 1.895652173913, 0.1, 0.38636363636364
22308, 1.8739130434783, 0.1, 0.31818181818182
22309, 1.895652173913, 0.1, 0.34090909090909
22310, 1.8739130434783, 0.1, 0.27272727272727
22311, 1.895652173913, 0.1, 0.29545454545455
22312, 1.8739130434783, 0.1, 0.22727272727273
22313, 1.895652173913, 0.1, 0.25
22314, 1.8739130434783, 0.1, 0.18181818181818
22315, 1.895652173913, 0.1, 0.20454545454545
22316, 1.8739130434783, 0.1, 0.13636363636364
22317, 1.895652173913, 0.1, 0.15909090909091
22318, 1.8739130434783, 0.1, 0.090909090909091
22319, 1.895652173913, 0.1, 0.11363636363636
22320, 1.8739130434783, 0.1, 0.045454545454545
22321, 1.895652173913, 0.1, 0.068181818181818
22322, 1.895652173913, 0.1, 0.022727272727273
22323, 1.9173913043478, 0.1, 0.45454545454545
22324, 1.9391304347826, 0.1, 0.47727272727273
22325, 1.9173913043478, 0.1, 0.40909090909091
22326, 1.9391304347826, 0.1, 0.43181818181818
22327, 1.9173913043478, 0.1, 0.36363636363636
22328, 1.9391304347826, 0.1, 0.38636363636364
22329, 1.9173913043478, 0.1, 0.31818181818182
22330, 1.9391304347826, 0.1, 0.34090909090909
22331, 1.9173913043478, 0.1, 0.27272727272727
22332, 1.9391304347826, 0.1, 0.29545454545455
22333, 1.9173913043478, 0.1, 0.22727272727273
22334, 1.9391304347826, 0.1, 0.25
22335, 1.9173913043478, 0.1, 0.18181818181818
22336, 1.9391304347826, 0.1, 0.20454545454545
22337, 1.9173913043478, 0.1, 0.13636363636364
22338, 1.9391304347826, 0.1, 0.15909090909091
22339, 1.9173913043478, 0.1, 0.090909090909091
22340, 1.9391304347826, 0.1, 0.11363636363636
22341, 1.9173913043478, 0.1, 0.045454545454545
22342, 1.9391304347826, 0.1, 0.068181818181818
22343, 1.9391304347826, 0.1, 0.022727272727273
22344, 1.9608695652174, 0.1, 0.45454545454545
22345, 1.9826086956522, 0.1, 0.47727272727273
22346, 1.9608695652174, 0.1, 0.40909090909091
22347, 1.9826086956522, 0.1, 0.43181818181818
22348, 1.9608695652174, 0.1, 0.36363636363636
22349, 1.9826086956522, 0.1, 0.38636363636364
22350, 1.9608695652174, 0.1, 0.31818181818182
22351, 1.9826086956522, 0.1, 0.34090909090909
22352, 1.9608695652174, 0.1, 0.27272727272727
22353, 1.9826086956522, 0.1, 0.29545454545455
22354, 1.9608695652174, 0.1, 0.22727272727273
22355, 1.9826086956522, 0.1, 0.25
22356, 1.9608695652174, 0.1, 0.18181818181818
22357, 1.9826086956522, 0.1, 0.20454545454545
22358, 1.9608695652174, 0.1, 0.13636363636364
22359, 1.9826086956522, 0.1, 0.15909090909091
22360, 1.9608695652174, 0.1, 0.090909090909091
22361, 1.9826086956522, 0.1, 0.11363636363636
22362, 1.9608695652174, 0.1, 0.045454545454545
22363, 1.9826086956522, 0.1, 0.068181818181818
22364, 1.9826086956522, 0.1, 0.022727272727273
22365, 2.004347826087, 0.1, 0.45454545454545
22366, 2.0260869565217, 0.1, 0.47727272727273
22367, 2.004347826087, 0.1, 0.40909090909091
22368, 2.0260869565217, 0.1, 0.43181818181818
22369, 2.004347826087, 0.1, 0.36363636363636
22370, 2.0260869565217, 0.1, 0.38636363636364
22371, 2.004347826087, 0.1, 0.31818181818182
22372, 2.0260869565217, 0.1, 0.34090909090909
22373, 2.004347826087, 0.1, 0.27272727272727
22374, 2.0260869565217, 0.1, 0.29545454545455
22375, 2.004347826087, 0.1, 0.22727272727273
22376, 2.0260869565217, 0.1, 0.25
22377, 2.004347826087, 0.1, 0.18181818181818
22378, 2.0260869565217, 0.1, 0.20454545454545
22379, 2.004347826087, 0.1, 0.13636363636364
22380, 2.0260869565217, 0.1, 0.15909090909091
22381, 2.004347826087, 0.1, 0.090909090909091
22382, 2.0260869565217, 0.1, 0.11363636363636
22383, 2.004347826087, 0.1, 0.045454545454545
22384, 2.0260869565217, 0.1, 0.068181818181818
22385, 2.0260869565217, 0.1, 0.022727272727273
22386, 2.0478260869565, 0.1, 0.45454545454545
22387, 2.0695652173913, 0.1, 0.47727272727273
22388, 2.0478260869565, 0.1, 0.40909090909091
22389, 2.0695652173913, 0.1, 0.43181818181818
22390, 2.0478260869565, 0.1, 0.36363636363636
22391, 2.0695652173913, 0.1, 0.38636363636364
22392, 2.0478260869565, 0.1, 0.31818181818182
22393, 2.0695652173913, 0.1, 0.34090909090909
22394, 2.0478260869565, 0.1, 0.27272727272727
22395, 2.0695652173913, 0.1, 0.29545454545455
22396, 2.0478260869565, 0.1, 0.22727272727273
22397, 2.0695652173913, 0.1, 0.25
22398, 2.0478260869565, 0.1, 0.18181818181818
22399, 2.0695652173913, 0.1, 0.20454545454545
22400, 2.0478260869565, 0.1, 0.13636363636364
22401, 2.0695652173913, 0.1, 0.15909090909091
22402, 2.0478260869565, 0.1, 0.090909090909091
22403, 2.0695652173913, 0.1, 0.11363636363636
22404, 2.0478260869565, 0.1, 0.045454545454545
22405, 2.0695652173913, 0.1, 0.068181818181818
22406, 2.0695652173913, 0.1, 0.022727272727273
22407, 2.0913043478261, 0.1, 0.45454545454545
22408, 2.1130434782609, 0.1, 0.47727272727273
22409, 2.0913043478261, 0.1, 0.40909090909091
22410, 2.1130434782609, 0.1, 0.43181818181818
22411, 2.0913043478261, 0.1, 0.36363636363636
22412, 2.1130434782609, 0.1, 0.38636363636364
22413, 2.0913043478261, 0.1, 0.31818181818182
22414, 2.1130434782609, 0.1, 0.34090909090909
22415, 2.0913043478261, 0.1, 0.27272727272727
22416, 2.1130434782609, 0.1, 0.29545454545455
22417, 2.0913043478261, 0.1, 0.22727272727273
22418, 2.1130434782609, 0.1, 0.25
22419, 2.0913043478261, 0.1, 0.18181818181818
22420, 2.1130434782609, 0.1, 0.20454545454545
22421, 2.0913043478261, 0.1, 0.13636363636364
22422, 2.1130434782609, 0.1, 0.15909090909091
22423, 2.0913043478261, 0.1, 0.090909090909091
22424, 2.1130434782609, 0.1, 0.11363636363636
22425, 2.0913043478261, 0.1, 0.045454545454545
22426, 2.1130434782609, 0.1, 0.068181818181818
22427, 2.1130434782609, 0.1, 0.022727272727273
22428, 2.1347826086957, 0.1, 0.45454545454545
22429, 2.1565217391304, 0.1, 0.47727272727273
22430, 2.1347826086957, 0.1, 0.40909090909091
22431, 2.1565217391304, 0.1, 0.43181818181818
22432, 2.1347826086957, 0.1, 0.36363636363636
22433, 2.1565217391304, 0.1, 0.38636363636364
22434, 2.1347826086957, 0.1, 0.31818181818182
22435, 2.1565217391304, 0.1, 0.34090909090909
22436, 2.1347826086957, 0.1, 0.27272727272727
22437, 2.1565217391304, 0.1, 0.29545454545455
22438, 2.1347826086957, 0.1, 0.22727272727273
22439, 2.1565217391304, 0.1, 0.25
22440, 2.1347826086957, 0.1, 0.18181818181818
22441, 2.1565217391304, 0.1, 0.20454545454545
22442, 2.1347826086957, 0.1, 0.13636363636364
22443, 2.1565217391304, 0.1, 0.15909090909091
22444, 2.1347826086957, 0.1, 0.090909090909091
22445, 2.1565217391304, 0.1, 0.11363636363636
22446, 2.1347826086957, 0.1, 0.045454545454545
22447, 2.1565217391304, 0.1, 0.068181818181818
22448, 2.1565217391304, 0.1, 0.022727272727273
22449, 2.1782608695652, 0.1, 0.45454545454545
22450, 2.1782608695652, 0.1, 0.40909090909091
22451, 2.1782608695652, 0.1, 0.36363636363636
22452, 2.1782608695652, 0.1, 0.31818181818182
22453, 2.1782608695652, 0.1, 0.27272727272727
22454, 2.1782608695652, 0.1, 0.22727272727273
22455, 2.1782608695652, 0.1, 0.18181818181818
22456, 2.1782608695652, 0.1, 0.13636363636364
22457, 2.1782608695652, 0.1, 0.090909090909091
22458, 2.1782608695652, 0.1, 0.045454545454545
22459, 2.2, 0.066666666666667, 0.45454545454545
22460, 2.2, 0.066666666666667, 0.40909090909091
22461, 2.2, 0.066666666666667, 0.36363636363636
22462, 2.2, 0.066666666666667, 0.31818181818182
22463, 2.2, 0.066666666666667, 0.27272727272727
22464, 2.2, 0.066666666666667, 0.22727272727273
22465, 2.2, 0.066666666666667, 0.18181818181818
22466, 2.2, 0.066666666666667, 0.13636363636364
22467, 2.2, 0.066666666666667, 0.090909090909091
22468, 2.2, 0.066666666666667, 0.045454545454545
22469, 2.2, 0.033333333333333, 0.45454545454545
22470, 2.2, 0.033333333333333, 0.40909090909091
22471, 2.2, 0.033333333333333, 0.36363636363636
22472, 2.2, 0.033333333333333, 0.31818181818182
22473, 2.2, 0.033333333333333, 0.27272727272727
22474, 2.2, 0.033333333333333, 0.22727272727273
22475, 2.2, 0.033333333333333, 0.18181818181818
22476, 2.2, 0.033333333333333, 0.13636363636364
22477, 2.2, 0.033333333333333, 0.090909090909091
22478, 2.2, 0.033333333333333, 0.045454545454545
22479, 2.2, 0.066666666666667, 0.47727272727273
22480, 2.2, 0.083333333333333, 0.45454545454545
22481, 2.2, 0.066666666666667, 0.43181818181818
22482, 2.2, 0.083333333333333, 0.40909090909091
22483, 2.2, 0.066666666666667, 0.38636363636364
22484, 2.2, 0.083333333333333, 0.36363636363636
22485, 2.2, 0.066666666666667, 0.34090909090909
22486, 2.2, 0.083333333333333, 0.31818181818182
22487, 2.2, 0.066666666666667, 0.29545454545455
22488, 2.2, 0.083333333333333, 0.27272727272727
22489, 2.2, 0.066666666666667, 0.25
22490, 2.2, 0.083333333333333, 0.22727272727273
22491, 2.2, 0.066666666666667, 0.20454545454545
22492, 2.2, 0.083333333333333, 0.18181818181818
22493, 2.2, 0.066666666666667, 0.15909090909091
22494, 2.2, 0.083333333333333, 0.13636363636364
22495, 2.2, 0.066666666666667, 0.11363636363636
22496, 2.2, 0.083333333333333, 0.090909090909091
22497, 2.2, 0.066666666666667, 0.068181818181818
22498, 2.2, 0.083333333333333, 0.045454545454545
22499, 2.2, 0.066666666666667, 0.022727272727273
22500, 2.2, 0.033333333333333, 0.47727272727273
22501, 2.2, 0.05, 0.45454545454545
22502, 2.2, 0.033333333333333, 0.43181818181818
22503, 2.2, 0.05, 0.40909090909091
22504, 2.2, 0.033333333333333, 0.38636363636364
22505, 2.2, 0.05, 0.36363636363636
22506, 2.2, 0.033333333333333, 0.34090909090909
22507, 2.2, 0.05, 0.31818181818182
22508, 2.2, 0.033333333333333, 0.29545454545455
22509, 2.2, 0.05, 0.27272727272727
22510, 2.2, 0.033333333333333, 0.25
22511, 2.2, 0.05, 0.22727272727273
22512, 2.2, 0.033333333333333, 0.20454545454545
22513, 2.2, 0.05, 0.18181818181818
22514, 2.2, 0.033333333333333, 0.15909090909091
22515, 2.2, 0.05, 0.13636363636364
22516, 2.2, 0.033333333333333, 0.11363636363636
22517, 2.2, 0.05, 0.090909090909091
22518, 2.2, 0.033333333333333, 0.068181818181818
22519, 2.2, 0.05, 0.045454545454545
22520, 2.2, 0.033333333333333, 0.022727272727273
22521, 2.2, 0.016666666666667, 0.45454545454545
22522, 2.2, 0.016666666666667, 0.40909090909091
22523, 2.2, 0.016666666666667, 0.36363636363636
22524, 2.2, 0.016666666666667, 0.31818181818182
22525, 2.2, 0.016666666666667, 0.27272727272727
22526, 2.2, 0.016666666666667, 0.22727272727273
22527, 2.2, 0.016666666666667, 0.18181818181818
22528, 2.2, 0.016666666666667, 0.13636363636364
22529, 2.2, 0.016666666666667, 0.090909090909091
22530, 2.2, 0.016666666666667, 0.045454545454545
22531, 2.2333333333333, 0.066666666666667, 0.5
22532, 2.2333333333333, 0.033333333333333, 0.5
22533, 2.2666666666667, 0.066666666666667, 0.5
22534, 2.2666666666667, 0.033333333333333, 0.5
22535, 2.2166666666667, 0.066666666666667, 0.5
22536, 2.2333333333333, 0.083333333333333, 0.5
22537, 2.2166666666667, 0.033333333333333, 0.5
22538, 2.2333333333333, 0.05, 0.5
22539, 2.2333333333333, 0.016666666666667, 0.5
22540, 2.25, 0.066666666666667, 0.5
22541, 2.2666666666667, 0.083333333333333, 0.5
22542, 2.25, 0.033333333333333, 0.5
22543, 2.2666666666667, 0.05, 0.5
22544, 2.2666666666667, 0.016666666666667, 0.5
22545, 2.2833333333333, 0.066666666666667, 0.5
22546, 2.2833333333333, 0.033333333333333, 0.5
22547, 2.2333333333333, 0.066666666666667, 0
22548, 2.2333333333333, 0.033333333333333, 0
22549, 2.2666666666667, 0.066666666666667, 0
22550, 2.2666666666667, 0.033333333333333, 0
22551, 2.2333333333333, 0.083333333333333, 0
22552, 2.2166666666667, 0.066666666666667, 0
22553, 2.2333333333333, 0.05, 0
22554, 2.2166666666667, 0.033333333333333, 0
22555, 2.2333333333333, 0.016666666666667, 0
22556, 2.2666666666667, 0.083333333333333, 0
22557, 2.25, 0.066666666666667, 0
22558, 2.2666666666667, 0.05, 0
22559, 2.25, 0.033333333333333, 0
22560, 2.2666666666667, 0.016666666666667, 0
22561, 2.2833333333333, 0.066666666666667, 0
22562, 2.2833333333333, 0.033333333333333, 0
22563, 2.2333333333333, 0.1, 0.45454545454545
22564, 2.2333333333333, 0.1, 0.40909090909091
22565, 2.2333333333333, 0.1, 0.36363636363636
22566, 2.2333333333333, 0.1, 0.31818181818182
22567, 2.2333333333333, 0.1, 0.27272727272727
22568, 2.2333333333333, 0.1, 0.22727272727273
22569, 2.2333333333333, 0.1, 0.18181818181818
22570, 2.2333333333333, 0.1, 0.13636363636364
22571, 2.2333333333333, 0.1, 0.090909090909091
22572, 2.2333333333333, 0.1, 0.045454545454545
22573, 2.2666666666667, 0.1, 0.45454545454545
22574, 2.2666666666667, 0.1, 0.40909090909091
22575, 2.2666666666667, 0.1, 0.36363636363636
22576, 2.2666666666667, 0.1, 0.31818181818182
22577, 2.2666666666667, 0.1, 0.27272727272727
22578, 2.2666666666667, 0.1, 0.22727272727273
22579, 2.2666666666667, 0.1, 0.18181818181818
22580, 2.2666666666667, 0.1, 0.13636363636364
22581, 2.2666666666667, 0.1, 0.090909090909091
22582, 2.2666666666667, 0.1, 0.045454545454545
22583, 2.2333333333333, 0.1, 0.47727272727273
22584, 2.2166666666667, 0.1, 0.45454545454545
22585, 2.2333333333333, 0.1, 0.43181818181818
22586, 2.2166666666667, 0.1, 0.40909090909091
22587, 2.2333333333333, 0.1, 0.38636363636364
22588, 2.2166666666667, 0.1, 0.36363636363636
22589, 2.2333333333333, 0.1, 0.34090909090909
22590, 2.2166666666667, 0.1, 0.31818181818182
22591, 2.2333333333333, 0.1, 0.29545454545455
22592, 2.2166666666667, 0.1, 0.27272727272727
22593, 2.2333333333333, 0.1, 0.25
22594, 2.2166666666667, 0.1, 0.22727272727273
22595, 2.2333333333333, 0.1, 0.20454545454545
22596, 2.2166666666667, 0.1, 0.18181818181818
22597, 2.2333333333333, 0.1, 0.15909090909091
22598, 2.2166666666667, 0.1, 0.13636363636364
22599, 2.2333333333333, 0.1, 0.11363636363636
22600, 2.2166666666667, 0.1, 0.090909090909091
22601, 2.2333333333333, 0.1, 0.068181818181818
22602, 2.2166666666667, 0.1, 0.045454545454545
22603, 2.2333333333333, 0.1, 0.022727272727273
22604, 2.2666666666667, 0.1, 0.47727272727273
22605, 2.25, 0.1, 0.45454545454545
22606, 2.2666666666667, 0.1, 0.43181818181818
22607, 2.25, 0.1, 0.40909090909091
22608, 2.2666666666667, 0.1, 0.38636363636364
22609, 2.25, 0.1, 0.36363636363636
22610, 2.2666666666667, 0.1, 0.34090909090909
22611, 2.25, 0.1, 0.31818181818182
22612, 2.2666666666667, 0.1, 0.29545454545455
22613, 2.25, 0.1, 0.27272727272727
22614, 2.2666666666667, 0.1, 0.25
22615, 2.25, 0.1, 0.22727272727273
22616, 2.2666666666667, 0.1, 0.20454545454545
22617, 2.25, 0.1, 0.18181818181818
22618, 2.2666666666667, 0.1, 0.15909090909091
22619, 2.25, 0.1, 0.13636363636364
22620, 2.2666666666667, 0.1, 0.11363636363636
22621, 2.25, 0.1, 0.090909090909091
22622, 2.2666666666667, 0.1, 0.068181818181818
22623, 2.25, 0.1, 0.045454545454545
22624, 2.2666666666667, 0.1, 0.022727272727273
22625, 2.2833333333333, 0.1, 0.45454545454545
22626, 2.2833333333333, 0.1, 0.40909090909091
22627, 2.2833333333333, 0.1, 0.36363636363636
22628, 2.2833333333333, 0.1, 0.31818181818182
22629, 2.2833333333333, 0.1, 0.27272727272727
22630, 2.2833333333333, 0.1, 0.22727272727273
22631, 2.2833333333333, 0.1, 0.18181818181818
22632, 2.2833333333333, 0.1, 0.13636363636364
22633, 2.2833333333333, 0.1, 0.090909090909091
22634, 2.2833333333333, 0.1, 0.045454545454545
22635, 2.2333333333333, -1.2490009027033e-16, 0.45454545454545
22636, 2.2333333333333, -1.2490009027033e-16, 0.40909090909091
22637, 2.2333333333333, -1.2490009027033e-16, 0.36363636363636
22638, 2.2333333333333, -1.2490009027033e-16, 0.31818181818182
22639, 2.2333333333333, -1.2490009027033e-16, 0.27272727272727
22640, 2.2333333333333, -1.2490009027033e-16, 0.22727272727273
22641, 2.2333333333333, -1.2490009027033e-16, 0.18181818181818
22642, 2.2333333333333, -1.2490009027033e-16, 0.13636363636364
22643, 2.2333333333333, -1.2490009027033e-16, 0.090909090909091
22644, 2.2333333333333, -1.2490009027033e-16, 0.045454545454545
22645, 2.2666666666667, -1.2490009027033e-16, 0.45454545454545
22646, 2.2666666666667, -1.2490009027033e-16, 0.40909090909091
22647, 2.2666666666667, -1.2490009027033e-16, 0.36363636363636
22648, 2.2666666666667, -1.2490009027033e-16, 0.31818181818182
22649, 2.2666666666667, -1.2490009027033e-16, 0.27272727272727
22650, 2.2666666666667, -1.2490009027033e-16, 0.22727272727273
22651, 2.2666666666667, -1.2490009027033e-16, 0.18181818181818
22652, 2.2666666666667, -1.2490009027033e-16, 0.13636363636364
22653, 2.2666666666667, -1.2490009027033e-16, 0.090909090909091
22654, 2.2666666666667, -1.2490009027033e-16, 0.045454545454545
22655, 2.2166666666667, -1.2490009027033e-16, 0.45454545454545
22656, 2.2333333333333, -1.2490009027033e-16, 0.47727272727273
22657, 2.2166666666667, -1.2490009027033e-16, 0.40909090909091
22658, 2.2333333333333, -1.2490009027033e-16, 0.43181818181818
22659, 2.2166666666667, -1.2490009027033e-16, 0.36363636363636
22660, 2.2333333333333, -1.2490009027033e-16, 0.38636363636364
22661, 2.2166666666667, -1.2490009027033e-16, 0.31818181818182
22662, 2.2333333333333, -1.2490009027033e-16, 0.34090909090909
22663, 2.2166666666667, -1.2490009027033e-16, 0.27272727272727
22664, 2.2333333333333, -1.2490009027033e-16, 0.29545454545455
22665, 2.2166666666667, -1.2490009027033e-16, 0.22727272727273
22666, 2.2333333333333, -1.2490009027033e-16, 0.25
22667, 2.2166666666667, -1.2490009027033e-16, 0.18181818181818
22668, 2.2333333333333, -1.2490009027033e-16, 0.20454545454545
22669, 2.2166666666667, -1.2490009027033e-16, 0.13636363636364
22670, 2.2333333333333, -1.2490009027033e-16, 0.15909090909091
22671, 2.2166666666667, -1.2490009027033e-16, 0.090909090909091
22672, 2.2333333333333, -1.2490009027033e-16, 0.11363636363636
22673, 2.2166666666667, -1.2490009027033e-16, 0.045454545454545
22674, 2.2333333333333, -1.2490009027033e-16, 0.068181818181818
22675, 2.2333333333333, -1.2490009027033e-16, 0.022727272727273
22676, 2.25, -1.2490009027033e-16, 0.45454545454545
22677, 2.2666666666667, -1.2490009027033e-16, 0.47727272727273
22678, 2.25, -1.2490009027033e-16, 0.40909090909091
22679, 2.2666666666667, -1.2490009027033e-16, 0.43181818181818
22680, 2.25, -1.2490009027033e-16, 0.36363636363636
22681, 2.2666666666667, -1.2490009027033e-16, 0.38636363636364
22682, 2.25, -1.2490009027033e-16, 0.31818181818182
22683, 2.2666666666667, -1.2490009027033e-16, 0.34090909090909
22684, 2.25, -1.2490009027033e-16, 0.27272727272727
22685, 2.2666666666667, -1.2490009027033e-16, 0.29545454545455
22686, 2.25, -1.2490009027033e-16, 0.22727272727273
22687, 2.2666666666667, -1.2490009027033e-16, 0.25
22688, 2.25, -1.2490009027033e-16, 0.18181818181818
22689, 2.2666666666667, -1.2490009027033e-16, 0.20454545454545
22690, 2.25, -1.2490009027033e-16, 0.13636363636364
22691, 2.2666666666667, -1.2490009027033e-16, 0.15909090909091
22692, 2.25, -1.2490009027033e-16, 0.090909090909091
22693, 2.2666666666667, -1.2490009027033e-16, 0.11363636363636
22694, 2.25, -1.2490009027033e-16, 0.045454545454545
22695, 2.2666666666667, -1.2490009027033e-16, 0.068181818181818
22696, 2.2666666666667, -1.2490009027033e-16, 0.022727272727273
22697, 2.2833333333333, -1.2490009027033e-16, 0.45454545454545
22698, 2.2833333333333, -1.2490009027033e-16, 0.40909090909091
22699, 2.2833333333333, -1.2490009027033e-16, 0.36363636363636
22700, 2.2833333333333, -1.2490009027033e-16, 0.31818181818182
22701, 2.2833333333333, -1.2490009027033e-16, 0.27272727272727
22702, 2.2833333333333, -1.2490009027033e-16, 0.22727272727273
22703, 2.2833333333333, -1.2490009027033e-16, 0.18181818181818
22704, 2.2833333333333, -1.2490009027033e-16, 0.13636363636364
22705, 2.2833333333333, -1.2490009027033e-16, 0.090909090909091
22706, 2.2833333333333, -1.2490009027033e-16, 0.045454545454545
22707, 2.3, 0.066666666666667, 0.45454545454545
22708, 2.3, 0.066666666666667, 0.40909090909091
22709, 2.3, 0.066666666666667, 0.36363636363636
22710, 2.3, 0.066666666666667, 0.31818181818182
22711, 2.3, 0.066666666666667, 0.27272727272727
22712, 2.3, 0.066666666666667, 0.22727272727273
22713, 2.3, 0.066666666666667, 0.18181818181818
22714, 2.3, 0.066666666666667, 0.13636363636364
22715, 2.3, 0.066666666666667, 0.090909090909091
22716, 2.3, 0.066666666666667, 0.045454545454545
22717, 2.3, 0.033333333333333, 0.45454545454545
22718, 2.3, 0.033333333333333, 0.40909090909091
22719, 2.3, 0.033333333333333, 0.36363636363636
22720, 2.3, 0.033333333333333, 0.31818181818182
22721, 2.3, 0.033333333333333, 0.27272727272727
22722, 2.3, 0.033333333333333, 0.22727272727273
22723, 2.3, 0.033333333333333, 0.18181818181818
22724, 2.3, 0.033333333333333, 0.13636363636364
22725, 2.3, 0.033333333333333, 0.090909090909091
22726, 2.3, 0.033333333333333, 0.045454545454545
22727, 2.3, 0.066666666666667, 0.47727272727273
22728, 2.3, 0.083333333333333, 0.45454545454545
22729, 2.3, 0.066666666666667, 0.43181818181818
22730, 2.3, 0.083333333333333, 0.40909090909091
22731, 2.3, 0.066666666666667, 0.38636363636364
22732, 2.3, 0.083333333333333, 0.36363636363636
22733, 2.3, 0.066666666666667, 0.34090909090909
22734, 2.3, 0.083333333333333, 0.31818181818182
22735, 2.3, 0.066666666666667, 0.29545454545455
22736, 2.3, 0.083333333333333, 0.27272727272727
22737, 2.3, 0.066666666666667, 0.25
22738, 2.3, 0.083333333333333, 0.22727272727273
22739, 2.3, 0.066666666666667, 0.20454545454545
22740, 2.3, 0.083333333333333, 0.18181818181818
22741, 2.3, 0.066666666666667, 0.15909090909091
22742, 2.3, 0.083333333333333, 0.13636363636364
22743, 2.3, 0.066666666666667, 0.11363636363636
22744, 2.3, 0.083333333333333, 0.090909090909091
22745, 2.3, 0.066666666666667, 0.068181818181818
22746, 2.3, 0.083333333333333, 0.045454545454545
22747, 2.3, 0.066666666666667, 0.022727272727273
22748, 2.3, 0.033333333333333, 0.47727272727273
22749, 2.3, 0.05, 0.45454545454545
22750, 2.3, 0.033333333333333, 0.43181818181818
22751, 2.3, 0.05, 0.40909090909091
22752, 2.3, 0.033333333333333, 0.38636363636364
22753, 2.3, 0.05, 0.36363636363636
22754, 2.3, 0.033333333333333, 0.34090909090909
22755, 2.3, 0.05, 0.31818181818182
22756, 2.3, 0.033333333333333, 0.29545454545455
22757, 2.3, 0.05, 0.27272727272727
22758, 2.3, 0.033333333333333, 0.25
22759, 2.3, 0.05, 0.22727272727273
22760, 2.3, 0.033333333333333, 0.20454545454545
22761, 2.3, 0.05, 0.18181818181818
22762, 2.3, 0.033333333333333, 0.15909090909091
22763, 2.3, 0.05, 0.13636363636364
22764, 2.3, 0.033333333333333, 0.11363636363636
22765, 2.3, 0.05, 0.090909090909091
22766, 2.3, 0.033333333333333, 0.068181818181818
22767, 2.3, 0.05, 0.045454545454545
22768, 2.3, 0.033333333333333, 0.022727272727273
22769, 2.3, 0.016666666666667, 0.45454545454545
22770, 2.3, 0.016666666666667, 0.40909090909091
22771, 2.3, 0.016666666666667, 0.36363636363636
22772, 2.3, 0.016666666666667, 0.31818181818182
22773, 2.3, 0.016666666666667, 0.27272727272727
22774, 2.3, 0.016666666666667, 0.22727272727273
22775, 2.3, 0.016666666666667, 0.18181818181818
22776, 2.3, 0.016666666666667, 0.13636363636364
22777, 2.3, 0.016666666666667, 0.090909090909091
22778, 2.3, 0.016666666666667, 0.045454545454545
22779, -0.033333333333333, 0, 0.45454545454545
22780, -0.033333333333333, 0, 0.40909090909091
22781, -0.033333333333333, 0, 0.36363636363636
22782, -0.033333333333333, 0, 0.31818181818182
22783, -0.033333333333333, 0, 0.27272727272727
22784, -0.033333333333333, 0, 0.22727272727273
22785, -0.033333333333333, 0, 0.18181818181818
22786, -0.033333333333333, 0, 0.13636363636364
22787, -0.033333333333333, 0, 0.090909090909091
22788, -0.033333333333333, 0, 0.045454545454545
22789, -0.066666666666667, 0, 0.45454545454545
22790, -0.066666666666667, 0, 0.40909090909091
22791, -0.066666666666667, 0, 0.36363636363636
22792, -0.066666666666667, 0, 0.31818181818182
22793, -0.066666666666667, 0, 0.27272727272727
22794, -0.066666666666667, 0, 0.22727272727273
22795, -0.066666666666667, 0, 0.18181818181818
22796, -0.066666666666667, 0, 0.13636363636364
22797, -0.066666666666667, 0, 0.090909090909091
22798, -0.066666666666667, 0, 0.045454545454545
22799, -0.033333333333333, 0, 0.47727272727273
22800, -0.016666666666667, 0, 0.45454545454545
22801, -0.033333333333333, 0, 0.43181818181818
22802, -0.016666666666667, 0, 0.40909090909091
22803, -0.033333333333333, 0, 0.38636363636364
22804, -0.016666666666667, 0, 0.36363636363636
22805, -0.033333333333333, 0, 0.34090909090909
22806, -0.016666666666667, 0, 0.31818181818182
22807, -0.033333333333333, 0, 0.29545454545455
22808, -0.016666666666667, 0, 0.27272727272727
22809, -0.033333333333333, 0, 0.25
22810, -0.016666666666667, 0, 0.22727272727273
22811, -0.033333333333333, 0, 0.20454545454545
22812, -0.016666666666667, 0, 0.18181818181818
22813, -0.033333333333333, 0, 0.15909090909091
22814, -0.016666666666667, 0, 0.13636363636364
22815, -0.033333333333333, 0, 0.11363636363636
22816, -0.016666666666667, 0, 0.090909090909091
22817, -0.033333333333333, 0, 0.068181818181818
22818, -0.016666666666667, 0, 0.045454545454545
22819, -0.033333333333333, 0, 0.022727272727273
22820, -0.066666666666667, 0, 0.47727272727273
22821, -0.05, 0, 0.45454545454545
22822, -0.066666666666667, 0, 0.43181818181818
22823, -0.05, 0, 0.40909090909091
22824, -0.066666666666667, 0, 0.38636363636364
22825, -0.05, 0, 0.36363636363636
22826, -0.066666666666667, 0, 0.34090909090909
22827, -0.05, 0, 0.31818181818182
22828, -0.066666666666667, 0, 0.29545454545455
22829, -0.05, 0, 0.27272727272727
22830, -0.066666666666667, 0, 0.25
22831, -0.05, 0, 0.22727272727273
22832, -0.066666666666667, 0, 0.20454545454545
22833, -0.05, 0, 0.18181818181818
22834, -0.066666666666667, 0, 0.15909090909091
22835, -0.05, 0, 0.13636363636364
22836, -0.066666666666667, 0, 0.11363636363636
22837, -0.05, 0, 0.090909090909091
22838, -0.066666666666667, 0, 0.068181818181818
22839, -0.05, 0, 0.045454545454545
22840, -0.066666666666667, 0, 0.022727272727273
22841, -0.083333333333333, 0, 0.45454545454545
22842, -0.083333333333333, 0, 0.40909090909091
22843, -0.083333333333333, 0, 0.36363636363636
22844, -0.083333333333333, 0, 0.31818181818182
22845, -0.083333333333333, 0, 0.27272727272727
22846, -0.083333333333333, 0, 0.22727272727273
22847, -0.083333333333333, 0, 0.18181818181818
22848, -0.083333333333333, 0, 0.13636363636364
22849, -0.083333333333333, 0, 0.090909090909091
22850, -0.083333333333333, 0, 0.045454545454545
22851, -0.033333333333333, 0.066666666666667, 0.5
22852, -0.033333333333333, 0.033333333333333, 0.5
22853, -0.066666666666667, 0.066666666666667, 0.5
22854, -0.066666666666667, 0.033333333333333, 0.5
22855, -0.033333333333333, 0.083333333333333, 0.5
22856, -0.016666666666667, 0.066666666666667, 0.5
22857, -0.033333333333333, 0.05, 0.5
22858, -0.016666666666667, 0.033333333333333, 0.5
22859, -0.033333333333333, 0.016666666666667, 0.5
22860, -0.066666666666667, 0.083333333333333, 0.5
22861, -0.05, 0.066666666666667, 0.5
22862, -0.066666666666667, 0.05, 0.5
22863, -0.05, 0.033333333333333, 0.5
22864, -0.066666666666667, 0.016666666666667, 0.5
22865, -0.083333333333333, 0.066666666666667, 0.5
22866, -0.083333333333333, 0.033333333333333, 0.5
22867, -0.033333333333333, 0.1, 0.45454545454545
22868, -0.033333333333333, 0.1, 0.40909090909091
22869, -0.033333333333333, 0.1, 0.36363636363636
22870, -0.033333333333333, 0.1, 0.31818181818182
22871, -0.033333333333333, 0.1, 0.27272727272727
22872, -0.033333333333333, 0.1, 0.22727272727273
22873, -0.033333333333333, 0.1, 0.18181818181818
22874, -0.033333333333333, 0.1, 0.13636363636364
22875, -0.033333333333333, 0.1, 0.090909090909091
22876, -0.033333333333333, 0.1, 0.045454545454545
22877, -0.066666666666667, 0.1, 0.45454545454545
22878, -0.066666666666667, 0.1, 0.40909090909091
22879, -0.066666666666667, 0.1, 0.36363636363636
22880, -0.066666666666667, 0.1, 0.31818181818182
22881, -0.066666666666667, 0.1, 0.27272727272727
22882, -0.066666666666667, 0.1, 0.22727272727273
22883, -0.066666666666667, 0.1, 0.18181818181818
22884, -0.066666666666667, 0.1, 0.13636363636364
22885, -0.066666666666667, 0.1, 0.090909090909091
22886, -0.066666666666667, 0.1, 0.045454545454545
22887, -0.016666666666667, 0.1, 0.45454545454545
22888, -0.033333333333333, 0.1, 0.47727272727273
22889, -0.016666666666667, 0.1, 0.40909090909091
22890, -0.033333333333333, 0.1, 0.43181818181818
22891, -0.016666666666667, 0.1, 0.36363636363636
22892, -0.033333333333333, 0.1, 0.38636363636364
22893, -0.016666666666667, 0.1, 0.31818181818182
22894, -0.033333333333333, 0.1, 0.34090909090909
22895, -0.016666666666667, 0.1, 0.27272727272727
22896, -0.033333333333333, 0.1, 0.29545454545455
22897, -0.016666666666667, 0.1, 0.22727272727273
22898, -0.033333333333333, 0.1, 0.25
22899, -0.016666666666667, 0.1, 0.18181818181818
22900, -0.033333333333333, 0.1, 0.20454545454545
22901, -0.016666666666667, 0.1, 0.13636363636364
22902, -0.033333333333333, 0.1, 0.15909090909091
22903, -0.016666666666667, 0.1, 0.090909090909091
22904, -0.033333333333333, 0.1, 0.11363636363636
22905, -0.016666666666667, 0.1, 0.045454545454545
22906, -0.033333333333333, 0.1, 0.068181818181818
22907, -0.033333333333333, 0.1, 0.022727272727273
22908, -0.05, 0.1, 0.45454545454545
22909, -0.066666666666667, 0.1, 0.47727272727273
22910, -0.05, 0.1, 0.40909090909091
22911, -0.066666666666667, 0.1, 0.43181818181818
22912, -0.05, 0.1, 0.36363636363636
22913, -0.066666666666667, 0.1, 0.38636363636364
22914, -0.05, 0.1, 0.31818181818182
22915, -0.066666666666667, 0.1, 0.34090909090909
22916, -0.05, 0.1, 0.27272727272727
22917, -0.066666666666667, 0.1, 0.29545454545455
22918, -0.05, 0.1, 0.22727272727273
22919, -0.066666666666667, 0.1, 0.25
22920, -0.05, 0.1, 0.18181818181818
22921, -0.066666666666667, 0.1, 0.20454545454545
22922, -0.05, 0.1, 0.13636363636364
22923, -0.066666666666667, 0.1, 0.15909090909091
22924, -0.05, 0.1, 0.090909090909091
22925, -0.066666666666667, 0.1, 0.11363636363636
22926, -0.05, 0.1, 0.045454545454545
22927, -0.066666666666667, 0.1, 0.068181818181818
22928, -0.066666666666667, 0.1, 0.022727272727273
22929, -0.083333333333333, 0.1, 0.45454545454545
22930, -0.083333333333333, 0.1, 0.40909090909091
22931, -0.083333333333333, 0.1, 0.36363636363636
22932, -0.083333333333333, 0.1, 0.31818181818182
22933, -0.083333333333333, 0.1, 0.27272727272727
22934, -0.083333333333333, 0.1, 0.22727272727273
22935, -0.083333333333333, 0.1, 0.18181818181818
22936, -0.083333333333333, 0.1, 0.13636363636364
22937, -0.083333333333333, 0.1, 0.090909090909091
22938, -0.083333333333333, 0.1, 0.045454545454545
22939, -0.033333333333333, 0.066666666666667, 0
22940, -0.033333333333333, 0.033333333333333, 0
22941, -0.066666666666667, 0.066666666666667, 0
22942, -0.066666666666667, 0.033333333333333, 0
22943, -0.016666666666667, 0.066666666666667, 0
22944, -0.033333333333333, 0.083333333333333, 0
22945, -0.016666666666667, 0.033333333333333, 0
22946, -0.033333333333333, 0.05, 0
22947, -0.033333333333333, 0.016666666666667, 0
22948, -0.05, 0.066666666666667, 0
22949, -0.066666666666667, 0.083333333333333, 0
22950, -0.05, 0.033333333333333, 0
22951, -0.066666666666667, 0.05, 0
22952, -0.066666666666667, 0.016666666666667, 0
22953, -0.083333333333333, 0.066666666666667, 0
22954, -0.083333333333333, 0.033333333333333, 0
22955, -0.1, 0.033333333333333, 0.045454545454545
22956, -0.1, 0.066666666666667, 0.045454545454545
22957, -0.1, 0.033333333333333, 0.090909090909091
22958, -0.1, 0.066666666666667, 0.090909090909091
22959, -0.1, 0.033333333333333, 0.13636363636364
22960, -0.1, 0.066666666666667, 0.13636363636364
22961, -0.1, 0.033333333333333, 0.18181818181818
22962, -0.1, 0.066666666666667, 0.18181818181818
22963, -0.1, 0.033333333333333, 0.22727272727273
22964, -0.1, 0.066666666666667, 0.22727272727273
22965, -0.1, 0.033333333333333, 0.27272727272727
22966, -0.1, 0.066666666666667, 0.27272727272727
22967, -0.1, 0.033333333333333, 0.31818181818182
22968, -0.1, 0.066666666666667, 0.31818181818182
22969, -0.1, 0.033333333333333, 0.36363636363636
22970, -0.1, 0.066666666666667, 0.36363636363636
22971, -0.1, 0.033333333333333, 0.40909090909091
22972, -0.1, 0.066666666666667, 0.40909090909091
22973, -0.1, 0.033333333333333, 0.45454545454545
22974, -0.1, 0.066666666666667, 0.45454545454545
22975, -0.1, 0.016666666666667, 0.045454545454545
22976, -0.1, 0.033333333333333, 0.022727272727273
22977, -0.1, 0.05, 0.045454545454545
22978, -0.1, 0.066666666666667, 0.022727272727273
22979, -0.1, 0.083333333333333, 0.045454545454545
22980, -0.1, 0.016666666666667, 0.090909090909091
22981, -0.1, 0.033333333333333, 0.068181818181818
22982, -0.1, 0.05, 0.090909090909091
22983, -0.1, 0.066666666666667, 0.068181818181818
22984, -0.1, 0.083333333333333, 0.090909090909091
22985, -0.1, 0.016666666666667, 0.13636363636364
22986, -0.1, 0.033333333333333, 0.11363636363636
22987, -0.1, 0.05, 0.13636363636364
22988, -0.1, 0.066666666666667, 0.11363636363636
22989, -0.1, 0.083333333333333, 0.13636363636364
22990, -0.1, 0.016666666666667, 0.18181818181818
22991, -0.1, 0.033333333333333, 0.15909090909091
22992, -0.1, 0.05, 0.18181818181818
22993, -0.1, 0.066666666666667, 0.15909090909091
22994, -0.1, 0.083333333333333, 0.18181818181818
22995, -0.1, 0.016666666666667, 0.22727272727273
22996, -0.1, 0.033333333333333, 0.20454545454545
22997, -0.1, 0.05, 0.22727272727273
22998, -0.1, 0.066666666666667, 0.20454545454545
22999, -0.1, 0.083333333333333, 0.22727272727273
23000, -0.1, 0.016666666666667, 0.27272727272727
23001, -0.1, 0.033333333333333, 0.25
23002, -0.1, 0.05, 0.27272727272727
23003, -0.1, 0.066666666666667, 0.25
23004, -0.1, 0.083333333333333, 0.27272727272727
23005, -0.1, 0.016666666666667, 0.31818181818182
23006, -0.1, 0.033333333333333, 0.29545454545455
23007, -0.1, 0.05, 0.31818181818182
23008, -0.1, 0.066666666666667, 0.29545454545455
23009, -0.1, 0.083333333333333, 0.31818181818182
23010, -0.1, 0.016666666666667, 0.36363636363636
23011, -0.1, 0.033333333333333, 0.34090909090909
23012, -0.1, 0.05, 0.36363636363636
23013, -0.1, 0.066666666666667, 0.34090909090909
23014, -0.1, 0.083333333333333, 0.36363636363636
23015, -0.1, 0.016666666666667, 0.40909090909091
23016, -0.1, 0.033333333333333, 0.38636363636364
23017, -0.1, 0.05, 0.40909090909091
23018, -0.1, 0.066666666666667, 0.38636363636364
23019, -0.1, 0.083333333333333, 0.40909090909091
23020, -0.1, 0.016666666666667, 0.45454545454545
23021, -0.1, 0.033333333333333, 0.43181818181818
23022, -0.1, 0.05, 0.45454545454545
23023, -0.1, 0.066666666666667, 0.43181818181818
23024, -0.1, 0.083333333333333, 0.45454545454545
23025, -0.1, 0.033333333333333, 0.47727272727273
23026, -0.1, 0.066666666666667, 0.47727272727273
23027, 0.95652173913043, 1.55, 0
23028, 0.91304347826087, 1.55, 0
23029, 0.8695652173913, 1.55, 0
23030, 0.82608695652174, 1.55, 0
23031, 0.78260869565217, 1.55, 0
23032, 0.73913043478261, 1.55, 0
23033, 0.69565217391304, 1.55, 0
23034, 0.65217391304348, 1.55, 0
23035, 0.60869565217391, 1.55, 0
23036, 0.56521739130435, 1.55, 0
23037, 0.52173913043478, 1.55, 0
23038, 0.47826086956522, 1.55, 0
23039, 0.43478260869565, 1.55, 0
23040, 0.39130434782609, 1.55, 0
23041, 0.34782608695652, 1.55, 0
23042, 0.30434782608696, 1.55, 0
23043, 0.26086956521739, 1.55, 0
23044, 0.21739130434783, 1.55, 0
23045, 0.17391304347826, 1.55, 0
23046, 0.1304347826087, 1.55, 0
23047, 0.08695652173913, 1.55, 0
23048, 0.043478260869565, 1.55, 0
23049, 0.95652173913043, 1.6, 0
23050, 0.91304347826087, 1.6, 0
23051, 0.8695652173913, 1.6, 0
23052, 0.82608695652174, 1.6, 0
23053, 0.78260869565217, 1.6, 0
23054, 0.73913043478261, 1.6, 0
23055, 0.69565217391304, 1.6, 0
23056, 0.65217391304348, 1.6, 0
23057, 0.60869565217391, 1.6, 0
23058, 0.56521739130435, 1.6, 0
23059, 0.52173913043478, 1.6, 0
23060, 0.47826086956522, 1.6, 0
23061, 0.43478260869565, 1.6, 0
23062, 0.39130434782609, 1.6, 0
23063, 0.34782608695652, 1.6, 0
23064, 0.30434782608696, 1.6, 0
23065, 0.26086956521739, 1.6, 0
23066, 0.21739130434783, 1.6, 0
23067, 0.17391304347826, 1.6, 0
23068, 0.1304347826087, 1.6, 0
23069, 0.08695652173913, 1.6, 0
23070, 0.043478260869565, 1.6, 0
23071, 0.95652173913043, 1.65, 0
23072, 0.91304347826087, 1.65, 0
23073, 0.8695652173913, 1.65, 0
23074, 0.82608695652174, 1.65, 0
23075, 0.78260869565217, 1.65, 0
23076, 0.73913043478261, 1.65, 0
23077, 0.69565217391304, 1.65, 0
23078, 0.65217391304348, 1.65, 0
23079, 0.60869565217391, 1.65, 0
23080, 0.56521739130435, 1.65, 0
23081, 0.52173913043478, 1.65, 0
23082, 0.47826086956522, 1.65, 0
23083, 0.43478260869565, 1.65, 0
23084, 0.39130434782609, 1.65, 0
23085, 0.34782608695652, 1.65, 0
23086, 0.30434782608696, 1.65, 0
23087, 0.26086956521739, 1.65, 0
23088, 0.21739130434783, 1.65, 0
23089, 0.17391304347826, 1.65, 0
23090, 0.1304347826087, 1.65, 0
23091, 0.08695652173913, 1.65, 0
23092, 0.043478260869565, 1.65, 0
23093, 0.95652173913043, 1.525, 0
23094, 0.97826086956522, 1.55, 0
23095, 0.91304347826087, 1.525, 0
23096, 0.93478260869565, 1.55, 0
23097, 0.8695652173913, 1.525, 0
23098, 0.89130434782609, 1.55, 0
23099, 0.82608695652174, 1.525, 0
23100, 0.84782608695652, 1.55, 0
23101, 0.78260869565217, 1.525, 0
23102, 0.80434782608696, 1.55, 0
23103, 0.73913043478261, 1.525, 0
23104, 0.76086956521739, 1.55, 0
23105, 0.69565217391304, 1.525, 0
23106, 0.71739130434783, 1.55, 0
23107, 0.65217391304348, 1.525, 0
23108, 0.67391304347826, 1.55, 0
23109, 0.60869565217391, 1.525, 0
23110, 0.6304347826087, 1.55, 0
23111, 0.56521739130435, 1.525, 0
23112, 0.58695652173913, 1.55, 0
23113, 0.52173913043478, 1.525, 0
23114, 0.54347826086957, 1.55, 0
23115, 0.47826086956522, 1.525, 0
23116, 0.5, 1.55, 0
23117, 0.43478260869565, 1.525, 0
23118, 0.45652173913043, 1.55, 0
23119, 0.39130434782609, 1.525, 0
23120, 0.41304347826087, 1.55, 0
23121, 0.34782608695652, 1.525, 0
23122, 0.3695652173913, 1.55, 0
23123, 0.30434782608696, 1.525, 0
23124, 0.32608695652174, 1.55, 0
23125, 0.26086956521739, 1.525, 0
23126, 0.28260869565217, 1.55, 0
23127, 0.21739130434783, 1.525, 0
23128, 0.23913043478261, 1.55, 0
23129, 0.17391304347826, 1.525, 0
23130, 0.19565217391304, 1.55, 0
23131, 0.1304347826087, 1.525, 0
23132, 0.15217391304348, 1.55, 0
23133, 0.08695652173913, 1.525, 0
23134, 0.10869565217391, 1.55, 0
23135, 0.043478260869565, 1.525, 0
23136, 0.065217391304348, 1.55, 0
23137, 0.021739130434783, 1.55, 0
23138, 0.95652173913043, 1.575, 0
23139, 0.97826086956522, 1.6, 0
23140, 0.91304347826087, 1.575, 0
23141, 0.93478260869565, 1.6, 0
23142, 0.8695652173913, 1.575, 0
23143, 0.89130434782609, 1.6, 0
23144, 0.82608695652174, 1.575, 0
23145, 0.84782608695652, 1.6, 0
23146, 0.78260869565217, 1.575, 0
23147, 0.80434782608696, 1.6, 0
23148, 0.73913043478261, 1.575, 0
23149, 0.76086956521739, 1.6, 0
23150, 0.69565217391304, 1.575, 0
23151, 0.71739130434783, 1.6, 0
23152, 0.65217391304348, 1.575, 0
23153, 0.67391304347826, 1.6, 0
23154, 0.60869565217391, 1.575, 0
23155, 0.6304347826087, 1.6, 0
23156, 0.56521739130435, 1.575, 0
23157, 0.58695652173913, 1.6, 0
23158, 0.52173913043478, 1.575, 0
23159, 0.54347826086957, 1.6, 0
23160, 0.47826086956522, 1.575, 0
23161, 0.5, 1.6, 0
23162, 0.43478260869565, 1.575, 0
23163, 0.45652173913043, 1.6, 0
23164, 0.39130434782609, 1.575, 0
23165, 0.41304347826087, 1.6, 0
23166, 0.34782608695652, 1.575, 0
23167, 0.3695652173913, 1.6, 0
23168, 0.30434782608696, 1.575, 0
23169, 0.32608695652174, 1.6, 0
23170, 0.26086956521739, 1.575, 0
23171, 0.28260869565217, 1.6, 0
23172, 0.21739130434783, 1.575, 0
23173, 0.23913043478261, 1.6, 0
23174, 0.17391304347826, 1.575, 0
23175, 0.19565217391304, 1.6, 0
23176, 0.1304347826087, 1.575, 0
23177, 0.15217391304348, 1.6, 0
23178, 0.08695652173913, 1.575, 0
23179, 0.10869565217391, 1.6, 0
23180, 0.043478260869565, 1.575, 0
23181, 0.065217391304348, 1.6, 0
23182, 0.021739130434783, 1.6, 0
23183, 0.95652173913043, 1.625, 0
23184, 0.97826086956522, 1.65, 0
23185, 0.91304347826087, 1.625, 0
23186, 0.93478260869565, 1.65, 0
23187, 0.8695652173913, 1.625, 0
23188, 0.89130434782609, 1.65, 0
23189, 0.82608695652174, 1.625, 0
23190, 0.84782608695652, 1.65, 0
23191, 0.78260869565217, 1.625, 0
23192, 0.80434782608696, 1.65, 0
23193, 0.73913043478261, 1.625, 0
23194, 0.76086956521739, 1.65, 0
23195, 0.69565217391304, 1.625, 0
23196, 0.71739130434783, 1.65, 0
23197, 0.65217391304348, 1.625, 0
23198, 0.67391304347826, 1.65, 0
23199, 0.60869565217391, 1.625, 0
23200, 0.6304347826087, 1.65, 0
23201, 0.56521739130435, 1.625, 0
23202, 0.58695652173913, 1.65, 0
23203, 0.52173913043478, 1.625, 0
23204, 0.54347826086957, 1.65, 0
23205, 0.47826086956522, 1.625, 0
23206, 0.5, 1.65, 0
23207, 0.43478260869565, 1.625, 0
23208, 0.45652173913043, 1.65, 0
23209, 0.39130434782609, 1.625, 0
23210, 0.41304347826087, 1.65, 0
23211, 0.34782608695652, 1.625, 0
23212, 0.3695652173913, 1.65, 0
23213, 0.30434782608696, 1.625, 0
23214, 0.32608695652174, 1.65, 0
23215, 0.26086956521739, 1.625, 0
23216, 0.28260869565217, 1.65, 0
23217, 0.21739130434783, 1.625, 0
23218, 0.23913043478261, 1.65, 0
23219, 0.17391304347826, 1.625, 0
23220, 0.19565217391304, 1.65, 0
23221, 0.1304347826087, 1.625, 0
23222, 0.15217391304348, 1.65, 0
23223, 0.08695652173913, 1.625, 0
23224, 0.10869565217391, 1.65, 0
23225, 0.043478260869565, 1.625, 0
23226, 0.065217391304348, 1.65, 0
23227, 0.021739130434783, 1.65, 0
23228, 0.95652173913043, 1.675, 0
23229, 0.91304347826087, 1.675, 0
23230, 0.8695652173913, 1.675, 0
23231, 0.82608695652174, 1.675, 0
23232, 0.78260869565217, 1.675, 0
23233, 0.73913043478261, 1.675, 0
23234, 0.69565217391304, 1.675, 0
23235, 0.65217391304348, 1.675, 0
23236, 0.60869565217391, 1.675, 0
23237, 0.56521739130435, 1.675, 0
23238, 0.52173913043478, 1.675, 0
23239, 0.47826086956522, 1.675, 0
23240, 0.43478260869565, 1.675, 0
23241, 0.39130434782609, 1.675, 0
23242, 0.34782608695652, 1.675, 0
23243, 0.30434782608696, 1.675, 0
23244, 0.26086956521739, 1.675, 0
23245, 0.21739130434783, 1.675, 0
23246, 0.17391304347826, 1.675, 0
23247, 0.1304347826087, 1.675, 0
23248, 0.08695652173913, 1.675, 0
23249, 0.043478260869565, 1.675, 0
23250, 1, 1.55, 0.45454545454545
23251, 1, 1.55, 0.40909090909091
23252, 1, 1.55, 0.36363636363636
23253, 1, 1.55, 0.31818181818182
23254, 1, 1.55, 0.27272727272727
23255, 1, 1.55, 0.22727272727273
23256, 1, 1.55, 0.18181818181818
23257, 1, 1.55, 0.13636363636364
23258, 1, 1.55, 0.090909090909091
23259, 1, 1.55, 0.045454545454545
23260, 1, 1.6, 0.45454545454545
23261, 1, 1.6, 0.40909090909091
23262, 1, 1.6, 0.36363636363636
23263, 1, 1.6, 0.31818181818182
23264, 1, 1.6, 0.27272727272727
23265, 1, 1.6, 0.22727272727273
23266, 1, 1.6, 0.18181818181818
23267, 1, 1.6, 0.13636363636364
23268, 1, 1.6, 0.090909090909091
23269, 1, 1.6, 0.045454545454545
23270, 1, 1.65, 0.45454545454545
23271, 1, 1.65, 0.40909090909091
23272, 1, 1.65, 0.36363636363636
23273, 1, 1.65, 0.31818181818182
23274, 1, 1.65, 0.27272727272727
23275, 1, 1.65, 0.22727272727273
23276, 1, 1.65, 0.18181818181818
23277, 1, 1.65, 0.13636363636364
23278, 1, 1.65, 0.090909090909091
23279, 1, 1.65, 0.045454545454545
23280, 1, 1.525, 0.45454545454545
23281, 1, 1.55, 0.47727272727273
23282, 1, 1.525, 0.40909090909091
23283, 1, 1.55, 0.43181818181818
23284, 1, 1.525, 0.36363636363636
23285, 1, 1.55, 0.38636363636364
23286, 1, 1.525, 0.31818181818182
23287, 1, 1.55, 0.34090909090909
23288, 1, 1.525, 0.27272727272727
23289, 1, 1.55, 0.29545454545455
23290, 1, 1.525, 0.22727272727273
23291, 1, 1.55, 0.25
23292, 1, 1.525, 0.18181818181818
23293, 1, 1.55, 0.20454545454545
23294, 1, 1.525, 0.13636363636364
23295, 1, 1.55, 0.15909090909091
23296, 1, 1.525, 0.090909090909091
23297, 1, 1.55, 0.11363636363636
23298, 1, 1.525, 0.045454545454545
23299, 1, 1.55, 0.068181818181818
23300, 1, 1.55, 0.022727272727273
23301, 1, 1.575, 0.45454545454545
23302, 1, 1.6, 0.47727272727273
23303, 1, 1.575, 0.40909090909091
23304, 1, 1.6, 0.43181818181818
23305, 1, 1.575, 0.36363636363636
23306, 1, 1.6, 0.38636363636364
23307, 1, 1.575, 0.31818181818182
23308, 1, 1.6, 0.34090909090909
23309, 1, 1.575, 0.27272727272727
23310, 1, 1.6, 0.29545454545455
23311, 1, 1.575, 0.22727272727273
23312, 1, 1.6, 0.25
23313, 1, 1.575, 0.18181818181818
23314, 1, 1.6, 0.20454545454545
23315, 1, 1.575, 0.13636363636364
23316, 1, 1.6, 0.15909090909091
23317, 1, 1.575, 0.090909090909091
23318, 1, 1.6, 0.11363636363636
23319, 1, 1.575, 0.045454545454545
23320, 1, 1.6, 0.068181818181818
23321, 1, 1.6, 0.022727272727273
23322, 1, 1.625, 0.45454545454545
23323, 1, 1.65, 0.47727272727273
23324, 1, 1.625, 0.40909090909091
23325, 1, 1.65, 0.43181818181818
23326, 1, 1.625, 0.36363636363636
23327, 1, 1.65, 0.38636363636364
23328, 1, 1.625, 0.31818181818182
23329, 1, 1.65, 0.34090909090909
23330, 1, 1.625, 0.27272727272727
23331, 1, 1.65, 0.29545454545455
23332, 1, 1.625, 0.22727272727273
23333, 1, 1.65, 0.25
23334, 1, 1.625, 0.18181818181818
23335, 1, 1.65, 0.20454545454545
23336, 1, 1.625, 0.13636363636364
23337, 1, 1.65, 0.15909090909091
23338, 1, 1.625, 0.090909090909091
23339, 1, 1.65, 0.11363636363636
23340, 1, 1.625, 0.045454545454545
23341, 1, 1.65, 0.068181818181818
23342, 1, 1.65, 0.022727272727273
23343, 1, 1.675, 0.45454545454545
23344, 1, 1.675, 0.40909090909091
23345, 1, 1.675, 0.36363636363636
23346, 1, 1.675, 0.31818181818182
23347, 1, 1.675, 0.27272727272727
23348, 1, 1.675, 0.22727272727273
23349, 1, 1.675, 0.18181818181818
23350, 1, 1.675, 0.13636363636364
23351, 1, 1.675, 0.090909090909091
23352, 1, 1.675, 0.045454545454545
23353, 0.95652173913043, 1.55, 0.5
23354, 0.91304347826087, 1.55, 0.5
23355, 0.8695652173913, 1.55, 0.5
23356, 0.82608695652174, 1.55, 0.5
23357, 0.78260869565217, 1.55, 0.5
23358, 0.73913043478261, 1.55, 0.5
23359, 0.69565217391304, 1.55, 0.5
23360, 0.65217391304348, 1.55, 0.5
23361, 0.60869565217391, 1.55, 0.5
23362, 0.56521739130435, 1.55, 0.5
23363, 0.52173913043478, 1.55, 0.5
23364, 0.47826086956522, 1.55, 0.5
23365, 0.43478260869565, 1.55, 0.5
23366, 0.39130434782609, 1.55, 0.5
23367, 0.34782608695652, 1.55, 0.5
23368, 0.30434782608696, 1.55, 0.5
23369, 0.26086956521739, 1.55, 0.5
23370, 0.21739130434783, 1.55, 0.5
23371, 0.17391304347826, 1.55, 0.5
23372, 0.1304347826087, 1.55, 0.5
23373, 0.08695652173913, 1.55, 0.5
23374, 0.043478260869565, 1.55, 0.5
23375, 0.95652173913043, 1.6, 0.5
23376, 0.91304347826087, 1.6, 0.5
23377, 0.8695652173913, 1.6, 0.5
23378, 0.82608695652174, 1.6, 0.5
23379, 0.78260869565217, 1.6, 0.5
23380, 0.73913043478261, 1.6, 0.5
23381, 0.69565217391304, 1.6, 0.5
23382, 0.65217391304348, 1.6, 0.5
23383, 0.60869565217391, 1.6, 0.5
23384, 0.56521739130435, 1.6, 0.5
23385, 0.52173913043478, 1.6, 0.5
23386, 0.47826086956522, 1.6, 0.5
23387, 0.43478260869565, 1.6, 0.5
23388, 0.39130434782609, 1.6, 0.5
23389, 0.34782608695652, 1.6, 0.5
23390, 0.30434782608696, 1.6, 0.5
23391, 0.26086956521739, 1.6, 0.5
23392, 0.21739130434783, 1.6, 0.5
23393, 0.17391304347826, 1.6, 0.5
23394, 0.1304347826087, 1.6, 0.5
23395, 0.08695652173913, 1.6, 0.5
23396, 0.043478260869565, 1.6, 0.5
23397, 0.95652173913043, 1.65, 0.5
23398, 0.91304347826087, 1.65, 0.5
23399, 0.8695652173913, 1.65, 0.5
23400, 0.82608695652174, 1.65, 0.5
23401, 0.78260869565217, 1.65, 0.5
23402, 0.73913043478261, 1.65, 0.5
23403, 0.69565217391304, 1.65, 0.5
23404, 0.65217391304348, 1.65, 0.5
23405, 0.60869565217391, 1.65, 0.5
23406, 0.56521739130435, 1.65, 0.5
23407, 0.52173913043478, 1.65, 0.5
23408, 0.47826086956522, 1.65, 0.5
23409, 0.43478260869565, 1.65, 0.5
23410, 0.39130434782609, 1.65, 0.5
23411, 0.34782608695652, 1.65, 0.5
23412, 0.30434782608696, 1.65, 0.5
23413, 0.26086956521739, 1.65, 0.5
23414, 0.21739130434783, 1.65, 0.5
23415, 0.17391304347826, 1.65, 0.5
23416, 0.1304347826087, 1.65, 0.5
23417, 0.08695652173913, 1.65, 0.5
23418, 0.043478260869565, 1.65, 0.5
23419, 0.97826086956522, 1.55, 0.5
23420, 0.95652173913043, 1.525, 0.5
23421, 0.93478260869565, 1.55, 0.5
23422, 0.91304347826087, 1.525, 0.5
23423, 0.89130434782609, 1.55, 0.5
23424, 0.8695652173913, 1.525, 0.5
23425, 0.84782608695652, 1.55, 0.5
23426, 0.82608695652174, 1.525, 0.5
23427, 0.80434782608696, 1.55, 0.5
23428, 0.78260869565217, 1.525, 0.5
23429, 0.76086956521739, 1.55, 0.5
23430, 0.73913043478261, 1.525, 0.5
23431, 0.71739130434783, 1.55, 0.5
23432, 0.69565217391304, 1.525, 0.5
23433, 0.67391304347826, 1.55, 0.5
23434, 0.65217391304348, 1.525, 0.5
23435, 0.6304347826087, 1.55, 0.5
23436, 0.60869565217391, 1.525, 0.5
23437, 0.58695652173913, 1.55, 0.5
23438, 0.56521739130435, 1.525, 0.5
23439, 0.54347826086957, 1.55, 0.5
23440, 0.52173913043478, 1.525, 0.5
23441, 0.5, 1.55, 0.5
23442, 0.47826086956522, 1.525, 0.5
23443, 0.45652173913043, 1.55, 0.5
23444, 0.43478260869565, 1.525, 0.5
23445, 0.41304347826087, 1.55, 0.5
23446, 0.39130434782609, 1.525, 0.5
23447, 0.3695652173913, 1.55, 0.5
23448, 0.34782608695652, 1.525, 0.5
23449, 0.32608695652174, 1.55, 0.5
23450, 0.30434782608696, 1.525, 0.5
23451, 0.28260869565217, 1.55, 0.5
23452, 0.26086956521739, 1.525, 0.5
23453, 0.23913043478261, 1.55, 0.5
23454, 0.21739130434783, 1.525, 0.5
23455, 0.19565217391304, 1.55, 0.5
23456, 0.17391304347826, 1.525, 0.5
23457, 0.15217391304348, 1.55, 0.5
23458, 0.1304347826087, 1.525, 0.5
23459, 0.10869565217391, 1.55, 0.5
23460, 0.08695652173913, 1.525, 0.5
23461, 0.065217391304348, 1.55, 0.5
23462, 0.043478260869565, 1.525, 0.5
23463, 0.021739130434783, 1.55, 0.5
23464, 0.97826086956522, 1.6, 0.5
23465, 0.95652173913043, 1.575, 0.5
23466, 0.93478260869565, 1.6, 0.5
23467, 0.91304347826087, 1.575, 0.5
23468, 0.89130434782609, 1.6, 0.5
23469, 0.8695652173913, 1.575, 0.5
23470, 0.84782608695652, 1.6, 0.5
23471, 0.82608695652174, 1.575, 0.5
23472, 0.80434782608696, 1.6, 0.5
23473, 0.78260869565217, 1.575, 0.5
23474, 0.76086956521739, 1.6, 0.5
23475, 0.73913043478261, 1.575, 0.5
23476, 0.71739130434783, 1.6, 0.5
23477, 0.69565217391304, 1.575, 0.5
23478, 0.67391304347826, 1.6, 0.5
23479, 0.65217391304348, 1.575, 0.5
23480, 0.6304347826087, 1.6, 0.5
23481, 0.60869565217391, 1.575, 0.5
23482, 0.58695652173913, 1.6, 0.5
23483, 0.56521739130435, 1.575, 0.5
23484, 0.54347826086957, 1.6, 0.5
23485, 0.52173913043478, 1.575, 0.5
23486, 0.5, 1.6, 0.5
23487, 0.47826086956522, 1.575, 0.5
23488, 0.45652173913043, 1.6, 0.5
23489, 0.43478260869565, 1.575, 0.5
23490, 0.41304347826087, 1.6, 0.5
23491, 0.39130434782609, 1.575, 0.5
23492, 0.3695652173913, 1.6, 0.5
23493, 0.34782608695652, 1.575, 0.5
23494, 0.32608695652174, 1.6, 0.5
23495, 0.30434782608696, 1.575, 0.5
23496, 0.28260869565217, 1.6, 0.5
23497, 0.26086956521739, 1.575, 0.5
23498, 0.23913043478261, 1.6, 0.5
23499, 0.21739130434783, 1.575, 0.5
23500, 0.19565217391304, 1.6, 0.5
23501, 0.17391304347826, 1.575, 0.5
23502, 0.15217391304348, 1.6, 0.5
23503, 0.1304347826087, 1.575, 0.5
23504, 0.10869565217391, 1.6, 0.5
23505, 0.08695652173913, 1.575, 0.5
23506, 0.065217391304348, 1.6, 0.5
23507, 0.043478260869565, 1.575, 0.5
23508, 0.021739130434783, 1.6, 0.5
23509, 0.97826086956522, 1.65, 0.5
23510, 0.95652173913043, 1.625, 0.5
23511, 0.93478260869565, 1.65, 0.5
23512, 0.91304347826087, 1.625, 0.5
23513, 0.89130434782609, 1.65, 0.5
23514, 0.8695652173913, 1.625, 0.5
23515, 0.84782608695652, 1.65, 0.5
23516, 0.82608695652174, 1.625, 0.5
23517, 0.80434782608696, 1.65, 0.5
23518, 0.78260869565217, 1.625, 0.5
23519, 0.76086956521739, 1.65, 0.5
23520, 0.73913043478261, 1.625, 0.5
23521, 0.71739130434783, 1.65, 0.5
23522, 0.69565217391304, 1.625, 0.5
23523, 0.67391304347826, 1.65, 0.5
23524, 0.65217391304348, 1.625, 0.5
23525, 0.6304347826087, 1.65, 0.5
23526, 0.60869565217391, 1.625, 0.5
23527, 0.58695652173913, 1.65, 0.5
23528, 0.56521739130435, 1.625, 0.5
23529, 0.54347826086957, 1.65, 0.5
23530, 0.52173913043478, 1.625, 0.5
23531, 0.5, 1.65, 0.5
23532, 0.47826086956522, 1.625, 0.5
23533, 0.45652173913043, 1.65, 0.5
23534, 0.43478260869565, 1.625, 0.5
23535, 0.41304347826087, 1.65, 0.5
23536, 0.39130434782609, 1.625, 0.5
23537, 0.3695652173913, 1.65, 0.5
23538, 0.34782608695652, 1.625, 0.5
23539, 0.32608695652174, 1.65, 0.5
23540, 0.30434782608696, 1.625, 0.5
23541, 0.28260869565217, 1.65, 0.5
23542, 0.26086956521739, 1.625, 0.5
23543, 0.23913043478261, 1.65, 0.5
23544, 0.21739130434783, 1.625, 0.5
23545, 0.19565217391304, 1.65, 0.5
23546, 0.17391304347826, 1.625, 0.5
23547, 0.15217391304348, 1.65, 0.5
23548, 0.1304347826087, 1.625, 0.5
23549, 0.10869565217391, 1.65, 0.5
23550, 0.08695652173913, 1.625, 0.5
23551, 0.065217391304348, 1.65, 0.5
23552, 0.043478260869565, 1.625, 0.5
23553, 0.021739130434783, 1.65, 0.5
23554, 0.95652173913043, 1.675, 0.5
23555, 0.91304347826087, 1.675, 0.5
23556, 0.8695652173913, 1.675, 0.5
23557, 0.82608695652174, 1.675, 0.5
23558, 0.78260869565217, 1.675, 0.5
23559, 0.73913043478261, 1.675, 0.5
23560, 0.69565217391304, 1.675, 0.5
23561, 0.65217391304348, 1.675, 0.5
23562, 0.60869565217391, 1.675, 0.5
23563, 0.56521739130435, 1.675, 0.5
23564, 0.52173913043478, 1.675, 0.5
23565, 0.47826086956522, 1.675, 0.5
23566, 0.43478260869565, 1.675, 0.5
23567, 0.39130434782609, 1.675, 0.5
23568, 0.34782608695652, 1.675, 0.5
23569, 0.30434782608696, 1.675, 0.5
23570, 0.26086956521739, 1.675, 0.5
23571, 0.21739130434783, 1.675, 0.5
23572, 0.17391304347826, 1.675, 0.5
23573, 0.1304347826087, 1.675, 0.5
23574, 0.08695652173913, 1.675, 0.5
23575, 0.043478260869565, 1.675, 0.5
23576, 0, 1.55, 0.45454545454545
23577, 0, 1.55, 0.40909090909091
23578, 0, 1.55, 0.36363636363636
23579, 0, 1.55, 0.31818181818182
23580, 0, 1.55, 0.27272727272727
23581, 0, 1.55, 0.22727272727273
23582, 0, 1.55, 0.18181818181818
23583, 0, 1.55, 0.13636363636364
23584, 0, 1.55, 0.090909090909091
23585, 0, 1.55, 0.045454545454545
23586, 0, 1.6, 0.45454545454545
23587, 0, 1.6, 0.40909090909091
23588, 0, 1.6, 0.36363636363636
23589, 0, 1.6, 0.31818181818182
23590, 0, 1.6, 0.27272727272727
23591, 0, 1.6, 0.22727272727273
23592, 0, 1.6, 0.18181818181818
23593, 0, 1.6, 0.13636363636364
23594, 0, 1.6, 0.090909090909091
23595, 0, 1.6, 0.045454545454545
23596, 0, 1.65, 0.45454545454545
23597, 0, 1.65, 0.40909090909091
23598, 0, 1.65, 0.36363636363636
23599, 0, 1.65, 0.31818181818182
23600, 0, 1.65, 0.27272727272727
23601, 0, 1.65, 0.22727272727273
23602, 0, 1.65, 0.18181818181818
23603, 0, 1.65, 0.13636363636364
23604, 0, 1.65, 0.090909090909091
23605, 0, 1.65, 0.045454545454545
23606, 0, 1.55, 0.47727272727273
23607, 0, 1.525, 0.45454545454545
23608, 0, 1.55, 0.43181818181818
23609, 0, 1.525, 0.40909090909091
23610, 0, 1.55, 0.38636363636364
23611, 0, 1.525, 0.36363636363636
23612, 0, 1.55, 0.34090909090909
23613, 0, 1.525, 0.31818181818182
23614, 0, 1.55, 0.29545454545455
23615, 0, 1.525, 0.27272727272727
23616, 0, 1.55, 0.25
23617, 0, 1.525, 0.22727272727273
23618, 0, 1.55, 0.20454545454545
23619, 0, 1.525, 0.18181818181818
23620, 0, 1.55, 0.15909090909091
23621, 0, 1.525, 0.13636363636364
23622, 0, 1.55, 0.11363636363636
23623, 0, 1.525, 0.090909090909091
23624, 0, 1.55, 0.068181818181818
23625, 0, 1.525, 0.045454545454545
23626, 0, 1.55, 0.022727272727273
23627, 0, 1.6, 0.47727272727273
23628, 0, 1.575, 0.45454545454545
23629, 0, 1.6, 0.43181818181818
23630, 0, 1.575, 0.40909090909091
23631, 0, 1.6, 0.38636363636364
23632, 0, 1.575, 0.36363636363636
23633, 0, 1.6, 0.34090909090909
23634, 0, 1.575, 0.31818181818182
23635, 0, 1.6, 0.29545454545455
23636, 0, 1.575, 0.27272727272727
23637, 0, 1.6, 0.25
23638, 0, 1.575, 0.22727272727273
23639, 0, 1.6, 0.20454545454545
23640, 0, 1.575, 0.18181818181818
23641, 0, 1.6, 0.15909090909091
23642, 0, 1.575, 0.13636363636364
23643, 0, 1.6, 0.11363636363636
23644, 0, 1.575, 0.090909090909091
23645, 0, 1.6, 0.068181818181818
23646, 0, 1.575, 0.045454545454545
23647, 0, 1.6, 0.022727272727273
23648, 0, 1.65, 0.47727272727273
23649, 0, 1.625, 0.45454545454545
23650, 0, 1.65, 0.43181818181818
23651, 0, 1.625, 0.40909090909091
23652, 0, 1.65, 0.38636363636364
23653, 0, 1.625, 0.36363636363636
23654, 0, 1.65, 0.34090909090909
23655, 0, 1.625, 0.31818181818182
23656, 0, 1.65, 0.29545454545455
23657, 0, 1.625, 0.27272727272727
23658, 0, 1.65, 0.25
23659, 0, 1.625, 0.22727272727273
23660, 0, 1.65, 0.20454545454545
23661, 0, 1.625, 0.18181818181818
23662, 0, 1.65, 0.15909090909091
23663, 0, 1.625, 0.13636363636364
23664, 0, 1.65, 0.11363636363636
23665, 0, 1.625, 0.090909090909091
23666, 0, 1.65, 0.068181818181818
23667, 0, 1.625, 0.045454545454545
23668, 0, 1.65, 0.022727272727273
23669, 0, 1.675, 0.45454545454545
23670, 0, 1.675, 0.40909090909091
23671, 0, 1.675, 0.36363636363636
23672, 0, 1.675, 0.31818181818182
23673, 0, 1.675, 0.27272727272727
23674, 0, 1.675, 0.22727272727273
23675, 0, 1.675, 0.18181818181818
23676, 0, 1.675, 0.13636363636364
23677, 0, 1.675, 0.090909090909091
23678, 0, 1.675, 0.045454545454545
23679, 0.043478260869565, 1.7, 0.045454545454545
23680, 0.043478260869565, 1.7, 0.090909090909091
23681, 0.043478260869565, 1.7, 0.13636363636364
23682, 0.043478260869565, 1.7, 0.18181818181818
23683, 0.043478260869565, 1.7, 0.22727272727273
23684, 0.043478260869565, 1.7, 0.27272727272727
23685, 0.043478260869565, 1.7, 0.31818181818182
23686, 0.043478260869565, 1.7, 0.36363636363636
23687, 0.043478260869565, 1.7, 0.40909090909091
23688, 0.043478260869565, 1.7, 0.45454545454545
23689, 0.08695652173913, 1.7, 0.045454545454545
23690, 0.08695652173913, 1.7, 0.090909090909091
23691, 0.08695652173913, 1.7, 0.13636363636364
23692, 0.08695652173913, 1.7, 0.18181818181818
23693, 0.08695652173913, 1.7, 0.22727272727273
23694, 0.08695652173913, 1.7, 0.27272727272727
23695, 0.08695652173913, 1.7, 0.31818181818182
23696, 0.08695652173913, 1.7, 0.36363636363636
23697, 0.08695652173913, 1.7, 0.40909090909091
23698, 0.08695652173913, 1.7, 0.45454545454545
23699, 0.1304347826087, 1.7, 0.045454545454545
23700, 0.1304347826087, 1.7, 0.090909090909091
23701, 0.1304347826087, 1.7, 0.13636363636364
23702, 0.1304347826087, 1.7, 0.18181818181818
23703, 0.1304347826087, 1.7, 0.22727272727273
23704, 0.1304347826087, 1.7, 0.27272727272727
23705, 0.1304347826087, 1.7, 0.31818181818182
23706, 0.1304347826087, 1.7, 0.36363636363636
23707, 0.1304347826087, 1.7, 0.40909090909091
23708, 0.1304347826087, 1.7, 0.45454545454545
23709, 0.17391304347826, 1.7, 0.045454545454545
23710, 0.17391304347826, 1.7, 0.090909090909091
23711, 0.17391304347826, 1.7, 0.13636363636364
23712, 0.17391304347826, 1.7, 0.18181818181818
23713, 0.17391304347826, 1.7, 0.22727272727273
23714, 0.17391304347826, 1.7, 0.27272727272727
23715, 0.17391304347826, 1.7, 0.31818181818182
23716, 0.17391304347826, 1.7, 0.36363636363636
23717, 0.17391304347826, 1.7, 0.40909090909091
23718, 0.17391304347826, 1.7, 0.45454545454545
23719, 0.21739130434783, 1.7, 0.045454545454545
23720, 0.21739130434783, 1.7, 0.090909090909091
23721, 0.21739130434783, 1.7, 0.13636363636364
23722, 0.21739130434783, 1.7, 0.18181818181818
23723, 0.21739130434783, 1.7, 0.22727272727273
23724, 0.21739130434783, 1.7, 0.27272727272727
23725, 0.21739130434783, 1.7, 0.31818181818182
23726, 0.21739130434783, 1.7, 0.36363636363636
23727, 0.21739130434783, 1.7, 0.40909090909091
23728, 0.21739130434783, 1.7, 0.45454545454545
23729, 0.26086956521739, 1.7, 0.045454545454545
23730, 0.26086956521739, 1.7, 0.090909090909091
23731, 0.26086956521739, 1.7, 0.13636363636364
23732, 0.26086956521739, 1.7, 0.18181818181818
23733, 0.26086956521739, 1.7, 0.22727272727273
23734, 0.26086956521739, 1.7, 0.27272727272727
23735, 0.26086956521739, 1.7, 0.31818181818182
23736, 0.26086956521739, 1.7, 0.36363636363636
23737, 0.26086956521739, 1.7, 0.40909090909091
23738, 0.26086956521739, 1.7, 0.45454545454545
23739, 0.30434782608696, 1.7, 0.045454545454545
23740, 0.30434782608696, 1.7, 0.090909090909091
23741, 0.30434782608696, 1.7, 0.13636363636364
23742, 0.30434782608696, 1.7, 0.18181818181818
23743, 0.30434782608696, 1.7, 0.22727272727273
23744, 0.30434782608696, 1.7, 0.27272727272727
23745, 0.30434782608696, 1.7, 0.31818181818182
23746, 0.30434782608696, 1.7, 0.36363636363636
23747, 0.30434782608696, 1.7, 0.40909090909091
23748, 0.30434782608696, 1.7, 0.45454545454545
23749, 0.34782608695652, 1.7, 0.045454545454545
23750, 0.34782608695652, 1.7, 0.090909090909091
23751, 0.34782608695652, 1.7, 0.13636363636364
23752, 0.34782608695652, 1.7, 0.18181818181818
23753, 0.34782608695652, 1.7, 0.22727272727273
23754, 0.34782608695652, 1.7, 0.27272727272727
23755, 0.34782608695652, 1.7, 0.31818181818182
23756, 0.34782608695652, 1.7, 0.36363636363636
23757, 0.34782608695652, 1.7, 0.40909090909091
23758, 0.34782608695652, 1.7, 0.45454545454545
23759, 0.39130434782609, 1.7, 0.045454545454545
23760, 0.39130434782609, 1.7, 0.090909090909091
23761, 0.39130434782609, 1.7, 0.13636363636364
