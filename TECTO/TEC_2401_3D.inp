23105, 62185, 62175, 61955, 61965, 62186, 62176, 61956, 61966, 68205, 68175, 67513, 68206, 68208, 68178, 67516, 
68209, 68207, 68176, 67484, 67515
23106, 62186, 62176, 61956, 61966, 62187, 62177, 61957, 61967, 68208, 68178, 67516, 68209, 68211, 68181, 67519, 
68212, 68210, 68179, 67487, 67518
23107, 62187, 62177, 61957, 61967, 62188, 62178, 61958, 61968, 68211, 68181, 67519, 68212, 68214, 68184, 67522, 
68215, 68213, 68182, 67490, 67521
23108, 62188, 62178, 61958, 61968, 62189, 62179, 61959, 61969, 68214, 68184, 67522, 68215, 68217, 68187, 67525, 
68218, 68216, 68185, 67493, 67524
23109, 62189, 62179, 61959, 61969, 62190, 62180, 61960, 61970, 68217, 68187, 67525, 68218, 68220, 68190, 67528, 
68221, 68219, 68188, 67496, 67527
23110, 62190, 62180, 61960, 61970, 62191, 62181, 61961, 61971, 68220, 68190, 67528, 68221, 68223, 68193, 67531, 
68224, 68222, 68191, 67499, 67530
23111, 62191, 62181, 61961, 61971, 62192, 62182, 61962, 61972, 68223, 68193, 67531, 68224, 68226, 68196, 67534, 
68227, 68225, 68194, 67502, 67533
23112, 62192, 62182, 61962, 61972, 17990, 17989, 17967, 17968, 68226, 68196, 67534, 68227, 18532, 18529, 18487, 
18531, 68228, 68197, 67505, 67536
23113, 16495, 16494, 16472, 16473, 62193, 62183, 61963, 61973, 17037, 17036, 16992, 17038, 68230, 68200, 67538, 
68231, 68229, 68198, 67506, 67537
23114, 62193, 62183, 61963, 61973, 62194, 62184, 61964, 61974, 68230, 68200, 67538, 68231, 68233, 68203, 67541, 
68234, 68232, 68201, 67509, 67540
23115, 62194, 62184, 61964, 61974, 62195, 62185, 61965, 61975, 68233, 68203, 67541, 68234, 68236, 68206, 67544, 
68237, 68235, 68204, 67512, 67543
23116, 62195, 62185, 61965, 61975, 62196, 62186, 61966, 61976, 68236, 68206, 67544, 68237, 68239, 68209, 67547, 
68240, 68238, 68207, 67515, 67546
23117, 62196, 62186, 61966, 61976, 62197, 62187, 61967, 61977, 68239, 68209, 67547, 68240, 68242, 68212, 67550, 
68243, 68241, 68210, 67518, 67549
23118, 62197, 62187, 61967, 61977, 62198, 62188, 61968, 61978, 68242, 68212, 67550, 68243, 68245, 68215, 67553, 
68246, 68244, 68213, 67521, 67552
23119, 62198, 62188, 61968, 61978, 62199, 62189, 61969, 61979, 68245, 68215, 67553, 68246, 68248, 68218, 67556, 
68249, 68247, 68216, 67524, 67555
23120, 62199, 62189, 61969, 61979, 62200, 62190, 61970, 61980, 68248, 68218, 67556, 68249, 68251, 68221, 67559, 
68252, 68250, 68219, 67527, 67558
23121, 62200, 62190, 61970, 61980, 62201, 62191, 61971, 61981, 68251, 68221, 67559, 68252, 68254, 68224, 67562, 
68255, 68253, 68222, 67530, 67561
23122, 62201, 62191, 61971, 61981, 62202, 62192, 61972, 61982, 68254, 68224, 67562, 68255, 68257, 68227, 67565, 
68258, 68256, 68225, 67533, 67564
23123, 62202, 62192, 61972, 61982, 17991, 17990, 17968, 17969, 68257, 68227, 67565, 68258, 18534, 18531, 18489, 
18533, 68259, 68228, 67536, 67567
23124, 16496, 16495, 16473, 16474, 62203, 62193, 61973, 61983, 17039, 17038, 16994, 17040, 68261, 68231, 67569, 
68262, 68260, 68229, 67537, 67568
23125, 62203, 62193, 61973, 61983, 62204, 62194, 61974, 61984, 68261, 68231, 67569, 68262, 68264, 68234, 67572, 
68265, 68263, 68232, 67540, 67571
23126, 62204, 62194, 61974, 61984, 62205, 62195, 61975, 61985, 68264, 68234, 67572, 68265, 68267, 68237, 67575, 
68268, 68266, 68235, 67543, 67574
23127, 62205, 62195, 61975, 61985, 62206, 62196, 61976, 61986, 68267, 68237, 67575, 68268, 68270, 68240, 67578, 
68271, 68269, 68238, 67546, 67577
23128, 62206, 62196, 61976, 61986, 62207, 62197, 61977, 61987, 68270, 68240, 67578, 68271, 68273, 68243, 67581, 
68274, 68272, 68241, 67549, 67580
23129, 62207, 62197, 61977, 61987, 62208, 62198, 61978, 61988, 68273, 68243, 67581, 68274, 68276, 68246, 67584, 
68277, 68275, 68244, 67552, 67583
23130, 62208, 62198, 61978, 61988, 62209, 62199, 61979, 61989, 68276, 68246, 67584, 68277, 68279, 68249, 67587, 
68280, 68278, 68247, 67555, 67586
23131, 62209, 62199, 61979, 61989, 62210, 62200, 61980, 61990, 68279, 68249, 67587, 68280, 68282, 68252, 67590, 
68283, 68281, 68250, 67558, 67589
23132, 62210, 62200, 61980, 61990, 62211, 62201, 61981, 61991, 68282, 68252, 67590, 68283, 68285, 68255, 67593, 
68286, 68284, 68253, 67561, 67592
23133, 62211, 62201, 61981, 61991, 62212, 62202, 61982, 61992, 68285, 68255, 67593, 68286, 68288, 68258, 67596, 
68289, 68287, 68256, 67564, 67595
23134, 62212, 62202, 61982, 61992, 17992, 17991, 17969, 17970, 68288, 68258, 67596, 68289, 18536, 18533, 18491, 
18535, 68290, 68259, 67567, 67598
23135, 16497, 16496, 16474, 16475, 62213, 62203, 61983, 61993, 17041, 17040, 16996, 17042, 68292, 68262, 67600, 
68293, 68291, 68260, 67568, 67599
23136, 62213, 62203, 61983, 61993, 62214, 62204, 61984, 61994, 68292, 68262, 67600, 68293, 68295, 68265, 67603, 
68296, 68294, 68263, 67571, 67602
23137, 62214, 62204, 61984, 61994, 62215, 62205, 61985, 61995, 68295, 68265, 67603, 68296, 68298, 68268, 67606, 
68299, 68297, 68266, 67574, 67605
23138, 62215, 62205, 61985, 61995, 62216, 62206, 61986, 61996, 68298, 68268, 67606, 68299, 68301, 68271, 67609, 
68302, 68300, 68269, 67577, 67608
23139, 62216, 62206, 61986, 61996, 62217, 62207, 61987, 61997, 68301, 68271, 67609, 68302, 68304, 68274, 67612, 
68305, 68303, 68272, 67580, 67611
23140, 62217, 62207, 61987, 61997, 62218, 62208, 61988, 61998, 68304, 68274, 67612, 68305, 68307, 68277, 67615, 
68308, 68306, 68275, 67583, 67614
23141, 62218, 62208, 61988, 61998, 62219, 62209, 61989, 61999, 68307, 68277, 67615, 68308, 68310, 68280, 67618, 
68311, 68309, 68278, 67586, 67617
23142, 62219, 62209, 61989, 61999, 62220, 62210, 61990, 62000, 68310, 68280, 67618, 68311, 68313, 68283, 67621, 
68314, 68312, 68281, 67589, 67620
23143, 62220, 62210, 61990, 62000, 62221, 62211, 61991, 62001, 68313, 68283, 67621, 68314, 68316, 68286, 67624, 
68317, 68315, 68284, 67592, 67623
23144, 62221, 62211, 61991, 62001, 62222, 62212, 61992, 62002, 68316, 68286, 67624, 68317, 68319, 68289, 67627, 
68320, 68318, 68287, 67595, 67626
23145, 62222, 62212, 61992, 62002, 17993, 17992, 17970, 17971, 68319, 68289, 67627, 68320, 18538, 18535, 18493, 
18537, 68321, 68290, 67598, 67629
23146, 16498, 16497, 16475, 16476, 62223, 62213, 61993, 62003, 17043, 17042, 16998, 17044, 68323, 68293, 67631, 
68324, 68322, 68291, 67599, 67630
23147, 62223, 62213, 61993, 62003, 62224, 62214, 61994, 62004, 68323, 68293, 67631, 68324, 68326, 68296, 67634, 
68327, 68325, 68294, 67602, 67633
23148, 62224, 62214, 61994, 62004, 62225, 62215, 61995, 62005, 68326, 68296, 67634, 68327, 68329, 68299, 67637, 
68330, 68328, 68297, 67605, 67636
23149, 62225, 62215, 61995, 62005, 62226, 62216, 61996, 62006, 68329, 68299, 67637, 68330, 68332, 68302, 67640, 
68333, 68331, 68300, 67608, 67639
23150, 62226, 62216, 61996, 62006, 62227, 62217, 61997, 62007, 68332, 68302, 67640, 68333, 68335, 68305, 67643, 
68336, 68334, 68303, 67611, 67642
23151, 62227, 62217, 61997, 62007, 62228, 62218, 61998, 62008, 68335, 68305, 67643, 68336, 68338, 68308, 67646, 
68339, 68337, 68306, 67614, 67645
23152, 62228, 62218, 61998, 62008, 62229, 62219, 61999, 62009, 68338, 68308, 67646, 68339, 68341, 68311, 67649, 
68342, 68340, 68309, 67617, 67648
23153, 62229, 62219, 61999, 62009, 62230, 62220, 62000, 62010, 68341, 68311, 67649, 68342, 68344, 68314, 67652, 
68345, 68343, 68312, 67620, 67651
23154, 62230, 62220, 62000, 62010, 62231, 62221, 62001, 62011, 68344, 68314, 67652, 68345, 68347, 68317, 67655, 
68348, 68346, 68315, 67623, 67654
23155, 62231, 62221, 62001, 62011, 62232, 62222, 62002, 62012, 68347, 68317, 67655, 68348, 68350, 68320, 67658, 
68351, 68349, 68318, 67626, 67657
23156, 62232, 62222, 62002, 62012, 17994, 17993, 17971, 17972, 68350, 68320, 67658, 68351, 18540, 18537, 18495, 
18539, 68352, 68321, 67629, 67660
23157, 16499, 16498, 16476, 16477, 62233, 62223, 62003, 62013, 17045, 17044, 17000, 17046, 68354, 68324, 67662, 
68355, 68353, 68322, 67630, 67661
23158, 62233, 62223, 62003, 62013, 62234, 62224, 62004, 62014, 68354, 68324, 67662, 68355, 68357, 68327, 67665, 
68358, 68356, 68325, 67633, 67664
23159, 62234, 62224, 62004, 62014, 62235, 62225, 62005, 62015, 68357, 68327, 67665, 68358, 68360, 68330, 67668, 
68361, 68359, 68328, 67636, 67667
23160, 62235, 62225, 62005, 62015, 62236, 62226, 62006, 62016, 68360, 68330, 67668, 68361, 68363, 68333, 67671, 
68364, 68362, 68331, 67639, 67670
23161, 62236, 62226, 62006, 62016, 62237, 62227, 62007, 62017, 68363, 68333, 67671, 68364, 68366, 68336, 67674, 
68367, 68365, 68334, 67642, 67673
23162, 62237, 62227, 62007, 62017, 62238, 62228, 62008, 62018, 68366, 68336, 67674, 68367, 68369, 68339, 67677, 
68370, 68368, 68337, 67645, 67676
23163, 62238, 62228, 62008, 62018, 62239, 62229, 62009, 62019, 68369, 68339, 67677, 68370, 68372, 68342, 67680, 
68373, 68371, 68340, 67648, 67679
23164, 62239, 62229, 62009, 62019, 62240, 62230, 62010, 62020, 68372, 68342, 67680, 68373, 68375, 68345, 67683, 
68376, 68374, 68343, 67651, 67682
23165, 62240, 62230, 62010, 62020, 62241, 62231, 62011, 62021, 68375, 68345, 67683, 68376, 68378, 68348, 67686, 
68379, 68377, 68346, 67654, 67685
23166, 62241, 62231, 62011, 62021, 62242, 62232, 62012, 62022, 68378, 68348, 67686, 68379, 68381, 68351, 67689, 
68382, 68380, 68349, 67657, 67688
23167, 62242, 62232, 62012, 62022, 17995, 17994, 17972, 17973, 68381, 68351, 67689, 68382, 18542, 18539, 18497, 
18541, 68383, 68352, 67660, 67691
23168, 16500, 16499, 16477, 16478, 62243, 62233, 62013, 62023, 17047, 17046, 17002, 17048, 68385, 68355, 67693, 
68386, 68384, 68353, 67661, 67692
23169, 62243, 62233, 62013, 62023, 62244, 62234, 62014, 62024, 68385, 68355, 67693, 68386, 68388, 68358, 67696, 
68389, 68387, 68356, 67664, 67695
23170, 62244, 62234, 62014, 62024, 62245, 62235, 62015, 62025, 68388, 68358, 67696, 68389, 68391, 68361, 67699, 
68392, 68390, 68359, 67667, 67698
23171, 62245, 62235, 62015, 62025, 62246, 62236, 62016, 62026, 68391, 68361, 67699, 68392, 68394, 68364, 67702, 
68395, 68393, 68362, 67670, 67701
23172, 62246, 62236, 62016, 62026, 62247, 62237, 62017, 62027, 68394, 68364, 67702, 68395, 68397, 68367, 67705, 
68398, 68396, 68365, 67673, 67704
23173, 62247, 62237, 62017, 62027, 62248, 62238, 62018, 62028, 68397, 68367, 67705, 68398, 68400, 68370, 67708, 
68401, 68399, 68368, 67676, 67707
23174, 62248, 62238, 62018, 62028, 62249, 62239, 62019, 62029, 68400, 68370, 67708, 68401, 68403, 68373, 67711, 
68404, 68402, 68371, 67679, 67710
23175, 62249, 62239, 62019, 62029, 62250, 62240, 62020, 62030, 68403, 68373, 67711, 68404, 68406, 68376, 67714, 
68407, 68405, 68374, 67682, 67713
23176, 62250, 62240, 62020, 62030, 62251, 62241, 62021, 62031, 68406, 68376, 67714, 68407, 68409, 68379, 67717, 
68410, 68408, 68377, 67685, 67716
23177, 62251, 62241, 62021, 62031, 62252, 62242, 62022, 62032, 68409, 68379, 67717, 68410, 68412, 68382, 67720, 
68413, 68411, 68380, 67688, 67719
23178, 62252, 62242, 62022, 62032, 17996, 17995, 17973, 17974, 68412, 68382, 67720, 68413, 18544, 18541, 18499, 
18543, 68414, 68383, 67691, 67722
23179, 16501, 16500, 16478, 16479, 62253, 62243, 62023, 62033, 17049, 17048, 17004, 17050, 68416, 68386, 67724, 
68417, 68415, 68384, 67692, 67723
23180, 62253, 62243, 62023, 62033, 62254, 62244, 62024, 62034, 68416, 68386, 67724, 68417, 68419, 68389, 67727, 
68420, 68418, 68387, 67695, 67726
23181, 62254, 62244, 62024, 62034, 62255, 62245, 62025, 62035, 68419, 68389, 67727, 68420, 68422, 68392, 67730, 
68423, 68421, 68390, 67698, 67729
23182, 62255, 62245, 62025, 62035, 62256, 62246, 62026, 62036, 68422, 68392, 67730, 68423, 68425, 68395, 67733, 
68426, 68424, 68393, 67701, 67732
23183, 62256, 62246, 62026, 62036, 62257, 62247, 62027, 62037, 68425, 68395, 67733, 68426, 68428, 68398, 67736, 
68429, 68427, 68396, 67704, 67735
23184, 62257, 62247, 62027, 62037, 62258, 62248, 62028, 62038, 68428, 68398, 67736, 68429, 68431, 68401, 67739, 
68432, 68430, 68399, 67707, 67738
23185, 62258, 62248, 62028, 62038, 62259, 62249, 62029, 62039, 68431, 68401, 67739, 68432, 68434, 68404, 67742, 
68435, 68433, 68402, 67710, 67741
23186, 62259, 62249, 62029, 62039, 62260, 62250, 62030, 62040, 68434, 68404, 67742, 68435, 68437, 68407, 67745, 
68438, 68436, 68405, 67713, 67744
23187, 62260, 62250, 62030, 62040, 62261, 62251, 62031, 62041, 68437, 68407, 67745, 68438, 68440, 68410, 67748, 
68441, 68439, 68408, 67716, 67747
23188, 62261, 62251, 62031, 62041, 62262, 62252, 62032, 62042, 68440, 68410, 67748, 68441, 68443, 68413, 67751, 
68444, 68442, 68411, 67719, 67750
23189, 62262, 62252, 62032, 62042, 17997, 17996, 17974, 17975, 68443, 68413, 67751, 68444, 18546, 18543, 18501, 
18545, 68445, 68414, 67722, 67753
23190, 16502, 16501, 16479, 16480, 62263, 62253, 62033, 62043, 17051, 17050, 17006, 17052, 68447, 68417, 67755, 
68448, 68446, 68415, 67723, 67754
23191, 62263, 62253, 62033, 62043, 62264, 62254, 62034, 62044, 68447, 68417, 67755, 68448, 68450, 68420, 67758, 
68451, 68449, 68418, 67726, 67757
23192, 62264, 62254, 62034, 62044, 62265, 62255, 62035, 62045, 68450, 68420, 67758, 68451, 68453, 68423, 67761, 
68454, 68452, 68421, 67729, 67760
23193, 62265, 62255, 62035, 62045, 62266, 62256, 62036, 62046, 68453, 68423, 67761, 68454, 68456, 68426, 67764, 
68457, 68455, 68424, 67732, 67763
23194, 62266, 62256, 62036, 62046, 62267, 62257, 62037, 62047, 68456, 68426, 67764, 68457, 68459, 68429, 67767, 
68460, 68458, 68427, 67735, 67766
23195, 62267, 62257, 62037, 62047, 62268, 62258, 62038, 62048, 68459, 68429, 67767, 68460, 68462, 68432, 67770, 
68463, 68461, 68430, 67738, 67769
23196, 62268, 62258, 62038, 62048, 62269, 62259, 62039, 62049, 68462, 68432, 67770, 68463, 68465, 68435, 67773, 
68466, 68464, 68433, 67741, 67772
23197, 62269, 62259, 62039, 62049, 62270, 62260, 62040, 62050, 68465, 68435, 67773, 68466, 68468, 68438, 67776, 
68469, 68467, 68436, 67744, 67775
23198, 62270, 62260, 62040, 62050, 62271, 62261, 62041, 62051, 68468, 68438, 67776, 68469, 68471, 68441, 67779, 
68472, 68470, 68439, 67747, 67778
23199, 62271, 62261, 62041, 62051, 62272, 62262, 62042, 62052, 68471, 68441, 67779, 68472, 68474, 68444, 67782, 
68475, 68473, 68442, 67750, 67781
23200, 62272, 62262, 62042, 62052, 17998, 17997, 17975, 17976, 68474, 68444, 67782, 68475, 18548, 18545, 18503, 
18547, 68476, 68445, 67753, 67784
23201, 16503, 16502, 16480, 16481, 62273, 62263, 62043, 62053, 17053, 17052, 17008, 17054, 68478, 68448, 67786, 
68479, 68477, 68446, 67754, 67785
23202, 62273, 62263, 62043, 62053, 62274, 62264, 62044, 62054, 68478, 68448, 67786, 68479, 68481, 68451, 67789, 
68482, 68480, 68449, 67757, 67788
23203, 62274, 62264, 62044, 62054, 62275, 62265, 62045, 62055, 68481, 68451, 67789, 68482, 68484, 68454, 67792, 
68485, 68483, 68452, 67760, 67791
23204, 62275, 62265, 62045, 62055, 62276, 62266, 62046, 62056, 68484, 68454, 67792, 68485, 68487, 68457, 67795, 
68488, 68486, 68455, 67763, 67794
23205, 62276, 62266, 62046, 62056, 62277, 62267, 62047, 62057, 68487, 68457, 67795, 68488, 68490, 68460, 67798, 
68491, 68489, 68458, 67766, 67797
23206, 62277, 62267, 62047, 62057, 62278, 62268, 62048, 62058, 68490, 68460, 67798, 68491, 68493, 68463, 67801, 
68494, 68492, 68461, 67769, 67800
23207, 62278, 62268, 62048, 62058, 62279, 62269, 62049, 62059, 68493, 68463, 67801, 68494, 68496, 68466, 67804, 
68497, 68495, 68464, 67772, 67803
23208, 62279, 62269, 62049, 62059, 62280, 62270, 62050, 62060, 68496, 68466, 67804, 68497, 68499, 68469, 67807, 
68500, 68498, 68467, 67775, 67806
23209, 62280, 62270, 62050, 62060, 62281, 62271, 62051, 62061, 68499, 68469, 67807, 68500, 68502, 68472, 67810, 
68503, 68501, 68470, 67778, 67809
23210, 62281, 62271, 62051, 62061, 62282, 62272, 62052, 62062, 68502, 68472, 67810, 68503, 68505, 68475, 67813, 
68506, 68504, 68473, 67781, 67812
23211, 62282, 62272, 62052, 62062, 17999, 17998, 17976, 17977, 68505, 68475, 67813, 68506, 18550, 18547, 18505, 
18549, 68507, 68476, 67784, 67815
23212, 16504, 16503, 16481, 16482, 62283, 62273, 62053, 62063, 17055, 17054, 17010, 17056, 68509, 68479, 67817, 
68510, 68508, 68477, 67785, 67816
23213, 62283, 62273, 62053, 62063, 62284, 62274, 62054, 62064, 68509, 68479, 67817, 68510, 68512, 68482, 67820, 
68513, 68511, 68480, 67788, 67819
23214, 62284, 62274, 62054, 62064, 62285, 62275, 62055, 62065, 68512, 68482, 67820, 68513, 68515, 68485, 67823, 
68516, 68514, 68483, 67791, 67822
23215, 62285, 62275, 62055, 62065, 62286, 62276, 62056, 62066, 68515, 68485, 67823, 68516, 68518, 68488, 67826, 
68519, 68517, 68486, 67794, 67825
23216, 62286, 62276, 62056, 62066, 62287, 62277, 62057, 62067, 68518, 68488, 67826, 68519, 68521, 68491, 67829, 
68522, 68520, 68489, 67797, 67828
23217, 62287, 62277, 62057, 62067, 62288, 62278, 62058, 62068, 68521, 68491, 67829, 68522, 68524, 68494, 67832, 
68525, 68523, 68492, 67800, 67831
23218, 62288, 62278, 62058, 62068, 62289, 62279, 62059, 62069, 68524, 68494, 67832, 68525, 68527, 68497, 67835, 
68528, 68526, 68495, 67803, 67834
23219, 62289, 62279, 62059, 62069, 62290, 62280, 62060, 62070, 68527, 68497, 67835, 68528, 68530, 68500, 67838, 
68531, 68529, 68498, 67806, 67837
23220, 62290, 62280, 62060, 62070, 62291, 62281, 62061, 62071, 68530, 68500, 67838, 68531, 68533, 68503, 67841, 
68534, 68532, 68501, 67809, 67840
23221, 62291, 62281, 62061, 62071, 62292, 62282, 62062, 62072, 68533, 68503, 67841, 68534, 68536, 68506, 67844, 
68537, 68535, 68504, 67812, 67843
23222, 62292, 62282, 62062, 62072, 18000, 17999, 17977, 17978, 68536, 68506, 67844, 68537, 18552, 18549, 18507, 
18551, 68538, 68507, 67815, 67846
23223, 1636, 16504, 16482, 1635, 20143, 62283, 62063, 20133, 17057, 17056, 17012, 1658, 68539, 68510, 67847, 
20386, 20385, 68508, 67816, 20364
23224, 20143, 62283, 62063, 20133, 20144, 62284, 62064, 20134, 68539, 68510, 67847, 20386, 68540, 68513, 67848, 
20388, 20387, 68511, 67819, 20366
23225, 20144, 62284, 62064, 20134, 20145, 62285, 62065, 20135, 68540, 68513, 67848, 20388, 68541, 68516, 67849, 
20390, 20389, 68514, 67822, 20368
23226, 20145, 62285, 62065, 20135, 20146, 62286, 62066, 20136, 68541, 68516, 67849, 20390, 68542, 68519, 67850, 
20392, 20391, 68517, 67825, 20370
23227, 20146, 62286, 62066, 20136, 20147, 62287, 62067, 20137, 68542, 68519, 67850, 20392, 68543, 68522, 67851, 
20394, 20393, 68520, 67828, 20372
23228, 20147, 62287, 62067, 20137, 20148, 62288, 62068, 20138, 68543, 68522, 67851, 20394, 68544, 68525, 67852, 
20396, 20395, 68523, 67831, 20374
23229, 20148, 62288, 62068, 20138, 20149, 62289, 62069, 20139, 68544, 68525, 67852, 20396, 68545, 68528, 67853, 
20398, 20397, 68526, 67834, 20376
23230, 20149, 62289, 62069, 20139, 20150, 62290, 62070, 20140, 68545, 68528, 67853, 20398, 68546, 68531, 67854, 
20400, 20399, 68529, 67837, 20378
23231, 20150, 62290, 62070, 20140, 20151, 62291, 62071, 20141, 68546, 68531, 67854, 20400, 68547, 68534, 67855, 
20402, 20401, 68532, 67840, 20380
23232, 20151, 62291, 62071, 20141, 20152, 62292, 62072, 20142, 68547, 68534, 67855, 20402, 68548, 68537, 67856, 
20404, 20403, 68535, 67843, 20382
23233, 20152, 62292, 62072, 20142, 1771, 18000, 17978, 1770, 68548, 68537, 67856, 20404, 18553, 18551, 18508, 
1793, 20405, 68538, 67846, 20384
23234, 16505, 1592, 1591, 16483, 62293, 19461, 19451, 62073, 17058, 1614, 17013, 17059, 68550, 19714, 67858, 
68551, 68549, 19715, 19694, 67857
23235, 62293, 19461, 19451, 62073, 62294, 19462, 19452, 62074, 68550, 19714, 67858, 68551, 68553, 19716, 67861, 
68554, 68552, 19717, 19696, 67860
23236, 62294, 19462, 19452, 62074, 62295, 19463, 19453, 62075, 68553, 19716, 67861, 68554, 68556, 19718, 67864, 
68557, 68555, 19719, 19698, 67863
23237, 62295, 19463, 19453, 62075, 62296, 19464, 19454, 62076, 68556, 19718, 67864, 68557, 68559, 19720, 67867, 
68560, 68558, 19721, 19700, 67866
23238, 62296, 19464, 19454, 62076, 62297, 19465, 19455, 62077, 68559, 19720, 67867, 68560, 68562, 19722, 67870, 
68563, 68561, 19723, 19702, 67869
23239, 62297, 19465, 19455, 62077, 62298, 19466, 19456, 62078, 68562, 19722, 67870, 68563, 68565, 19724, 67873, 
68566, 68564, 19725, 19704, 67872
23240, 62298, 19466, 19456, 62078, 62299, 19467, 19457, 62079, 68565, 19724, 67873, 68566, 68568, 19726, 67876, 
68569, 68567, 19727, 19706, 67875
23241, 62299, 19467, 19457, 62079, 62300, 19468, 19458, 62080, 68568, 19726, 67876, 68569, 68571, 19728, 67879, 
68572, 68570, 19729, 19708, 67878
23242, 62300, 19468, 19458, 62080, 62301, 19469, 19459, 62081, 68571, 19728, 67879, 68572, 68574, 19730, 67882, 
68575, 68573, 19731, 19710, 67881
23243, 62301, 19469, 19459, 62081, 62302, 19470, 19460, 62082, 68574, 19730, 67882, 68575, 68577, 19732, 67885, 
68578, 68576, 19733, 19712, 67884
23244, 62302, 19470, 19460, 62082, 18001, 1727, 1726, 17979, 68577, 19732, 67885, 68578, 18555, 1749, 18510, 
18554, 68579, 19734, 19713, 67887
23245, 16506, 16505, 16483, 16484, 62303, 62293, 62073, 62083, 17060, 17059, 17015, 17061, 68581, 68551, 67889, 
68582, 68580, 68549, 67857, 67888
23246, 62303, 62293, 62073, 62083, 62304, 62294, 62074, 62084, 68581, 68551, 67889, 68582, 68584, 68554, 67892, 
68585, 68583, 68552, 67860, 67891
23247, 62304, 62294, 62074, 62084, 62305, 62295, 62075, 62085, 68584, 68554, 67892, 68585, 68587, 68557, 67895, 
68588, 68586, 68555, 67863, 67894
23248, 62305, 62295, 62075, 62085, 62306, 62296, 62076, 62086, 68587, 68557, 67895, 68588, 68590, 68560, 67898, 
68591, 68589, 68558, 67866, 67897
23249, 62306, 62296, 62076, 62086, 62307, 62297, 62077, 62087, 68590, 68560, 67898, 68591, 68593, 68563, 67901, 
68594, 68592, 68561, 67869, 67900
23250, 62307, 62297, 62077, 62087, 62308, 62298, 62078, 62088, 68593, 68563, 67901, 68594, 68596, 68566, 67904, 
68597, 68595, 68564, 67872, 67903
23251, 62308, 62298, 62078, 62088, 62309, 62299, 62079, 62089, 68596, 68566, 67904, 68597, 68599, 68569, 67907, 
68600, 68598, 68567, 67875, 67906
23252, 62309, 62299, 62079, 62089, 62310, 62300, 62080, 62090, 68599, 68569, 67907, 68600, 68602, 68572, 67910, 
68603, 68601, 68570, 67878, 67909
23253, 62310, 62300, 62080, 62090, 62311, 62301, 62081, 62091, 68602, 68572, 67910, 68603, 68605, 68575, 67913, 
68606, 68604, 68573, 67881, 67912
23254, 62311, 62301, 62081, 62091, 62312, 62302, 62082, 62092, 68605, 68575, 67913, 68606, 68608, 68578, 67916, 
68609, 68607, 68576, 67884, 67915
23255, 62312, 62302, 62082, 62092, 18002, 18001, 17979, 17980, 68608, 68578, 67916, 68609, 18557, 18554, 18512, 
18556, 68610, 68579, 67887, 67918
23256, 16507, 16506, 16484, 16485, 62313, 62303, 62083, 62093, 17062, 17061, 17017, 17063, 68612, 68582, 67920, 
68613, 68611, 68580, 67888, 67919
23257, 62313, 62303, 62083, 62093, 62314, 62304, 62084, 62094, 68612, 68582, 67920, 68613, 68615, 68585, 67923, 
68616, 68614, 68583, 67891, 67922
23258, 62314, 62304, 62084, 62094, 62315, 62305, 62085, 62095, 68615, 68585, 67923, 68616, 68618, 68588, 67926, 
68619, 68617, 68586, 67894, 67925
23259, 62315, 62305, 62085, 62095, 62316, 62306, 62086, 62096, 68618, 68588, 67926, 68619, 68621, 68591, 67929, 
68622, 68620, 68589, 67897, 67928
23260, 62316, 62306, 62086, 62096, 62317, 62307, 62087, 62097, 68621, 68591, 67929, 68622, 68624, 68594, 67932, 
68625, 68623, 68592, 67900, 67931
23261, 62317, 62307, 62087, 62097, 62318, 62308, 62088, 62098, 68624, 68594, 67932, 68625, 68627, 68597, 67935, 
68628, 68626, 68595, 67903, 67934
23262, 62318, 62308, 62088, 62098, 62319, 62309, 62089, 62099, 68627, 68597, 67935, 68628, 68630, 68600, 67938, 
68631, 68629, 68598, 67906, 67937
23263, 62319, 62309, 62089, 62099, 62320, 62310, 62090, 62100, 68630, 68600, 67938, 68631, 68633, 68603, 67941, 
68634, 68632, 68601, 67909, 67940
23264, 62320, 62310, 62090, 62100, 62321, 62311, 62091, 62101, 68633, 68603, 67941, 68634, 68636, 68606, 67944, 
68637, 68635, 68604, 67912, 67943
23265, 62321, 62311, 62091, 62101, 62322, 62312, 62092, 62102, 68636, 68606, 67944, 68637, 68639, 68609, 67947, 
68640, 68638, 68607, 67915, 67946
23266, 62322, 62312, 62092, 62102, 18003, 18002, 17980, 17981, 68639, 68609, 67947, 68640, 18559, 18556, 18514, 
18558, 68641, 68610, 67918, 67949
23267, 16508, 16507, 16485, 16486, 62323, 62313, 62093, 62103, 17064, 17063, 17019, 17065, 68643, 68613, 67951, 
68644, 68642, 68611, 67919, 67950
23268, 62323, 62313, 62093, 62103, 62324, 62314, 62094, 62104, 68643, 68613, 67951, 68644, 68646, 68616, 67954, 
68647, 68645, 68614, 67922, 67953
23269, 62324, 62314, 62094, 62104, 62325, 62315, 62095, 62105, 68646, 68616, 67954, 68647, 68649, 68619, 67957, 
68650, 68648, 68617, 67925, 67956
23270, 62325, 62315, 62095, 62105, 62326, 62316, 62096, 62106, 68649, 68619, 67957, 68650, 68652, 68622, 67960, 
68653, 68651, 68620, 67928, 67959
23271, 62326, 62316, 62096, 62106, 62327, 62317, 62097, 62107, 68652, 68622, 67960, 68653, 68655, 68625, 67963, 
68656, 68654, 68623, 67931, 67962
23272, 62327, 62317, 62097, 62107, 62328, 62318, 62098, 62108, 68655, 68625, 67963, 68656, 68658, 68628, 67966, 
68659, 68657, 68626, 67934, 67965
23273, 62328, 62318, 62098, 62108, 62329, 62319, 62099, 62109, 68658, 68628, 67966, 68659, 68661, 68631, 67969, 
68662, 68660, 68629, 67937, 67968
23274, 62329, 62319, 62099, 62109, 62330, 62320, 62100, 62110, 68661, 68631, 67969, 68662, 68664, 68634, 67972, 
68665, 68663, 68632, 67940, 67971
23275, 62330, 62320, 62100, 62110, 62331, 62321, 62101, 62111, 68664, 68634, 67972, 68665, 68667, 68637, 67975, 
68668, 68666, 68635, 67943, 67974
23276, 62331, 62321, 62101, 62111, 62332, 62322, 62102, 62112, 68667, 68637, 67975, 68668, 68670, 68640, 67978, 
68671, 68669, 68638, 67946, 67977
23277, 62332, 62322, 62102, 62112, 18004, 18003, 17981, 17982, 68670, 68640, 67978, 68671, 18561, 18558, 18516, 
18560, 68672, 68641, 67949, 67980
23278, 16509, 16508, 16486, 16487, 62333, 62323, 62103, 62113, 17066, 17065, 17021, 17067, 68674, 68644, 67982, 
68675, 68673, 68642, 67950, 67981
23279, 62333, 62323, 62103, 62113, 62334, 62324, 62104, 62114, 68674, 68644, 67982, 68675, 68677, 68647, 67985, 
68678, 68676, 68645, 67953, 67984
23280, 62334, 62324, 62104, 62114, 62335, 62325, 62105, 62115, 68677, 68647, 67985, 68678, 68680, 68650, 67988, 
68681, 68679, 68648, 67956, 67987
23281, 62335, 62325, 62105, 62115, 62336, 62326, 62106, 62116, 68680, 68650, 67988, 68681, 68683, 68653, 67991, 
68684, 68682, 68651, 67959, 67990
23282, 62336, 62326, 62106, 62116, 62337, 62327, 62107, 62117, 68683, 68653, 67991, 68684, 68686, 68656, 67994, 
68687, 68685, 68654, 67962, 67993
23283, 62337, 62327, 62107, 62117, 62338, 62328, 62108, 62118, 68686, 68656, 67994, 68687, 68689, 68659, 67997, 
68690, 68688, 68657, 67965, 67996
23284, 62338, 62328, 62108, 62118, 62339, 62329, 62109, 62119, 68689, 68659, 67997, 68690, 68692, 68662, 68000, 
68693, 68691, 68660, 67968, 67999
23285, 62339, 62329, 62109, 62119, 62340, 62330, 62110, 62120, 68692, 68662, 68000, 68693, 68695, 68665, 68003, 
68696, 68694, 68663, 67971, 68002
23286, 62340, 62330, 62110, 62120, 62341, 62331, 62111, 62121, 68695, 68665, 68003, 68696, 68698, 68668, 68006, 
68699, 68697, 68666, 67974, 68005
23287, 62341, 62331, 62111, 62121, 62342, 62332, 62112, 62122, 68698, 68668, 68006, 68699, 68701, 68671, 68009, 
68702, 68700, 68669, 67977, 68008
23288, 62342, 62332, 62112, 62122, 18005, 18004, 17982, 17983, 68701, 68671, 68009, 68702, 18563, 18560, 18518, 
18562, 68703, 68672, 67980, 68011
23289, 16510, 16509, 16487, 16488, 62343, 62333, 62113, 62123, 17068, 17067, 17023, 17069, 68705, 68675, 68013, 
68706, 68704, 68673, 67981, 68012
23290, 62343, 62333, 62113, 62123, 62344, 62334, 62114, 62124, 68705, 68675, 68013, 68706, 68708, 68678, 68016, 
68709, 68707, 68676, 67984, 68015
23291, 62344, 62334, 62114, 62124, 62345, 62335, 62115, 62125, 68708, 68678, 68016, 68709, 68711, 68681, 68019, 
68712, 68710, 68679, 67987, 68018
23292, 62345, 62335, 62115, 62125, 62346, 62336, 62116, 62126, 68711, 68681, 68019, 68712, 68714, 68684, 68022, 
68715, 68713, 68682, 67990, 68021
23293, 62346, 62336, 62116, 62126, 62347, 62337, 62117, 62127, 68714, 68684, 68022, 68715, 68717, 68687, 68025, 
68718, 68716, 68685, 67993, 68024
23294, 62347, 62337, 62117, 62127, 62348, 62338, 62118, 62128, 68717, 68687, 68025, 68718, 68720, 68690, 68028, 
68721, 68719, 68688, 67996, 68027
23295, 62348, 62338, 62118, 62128, 62349, 62339, 62119, 62129, 68720, 68690, 68028, 68721, 68723, 68693, 68031, 
68724, 68722, 68691, 67999, 68030
23296, 62349, 62339, 62119, 62129, 62350, 62340, 62120, 62130, 68723, 68693, 68031, 68724, 68726, 68696, 68034, 
68727, 68725, 68694, 68002, 68033
23297, 62350, 62340, 62120, 62130, 62351, 62341, 62121, 62131, 68726, 68696, 68034, 68727, 68729, 68699, 68037, 
68730, 68728, 68697, 68005, 68036
23298, 62351, 62341, 62121, 62131, 62352, 62342, 62122, 62132, 68729, 68699, 68037, 68730, 68732, 68702, 68040, 
68733, 68731, 68700, 68008, 68039
23299, 62352, 62342, 62122, 62132, 18006, 18005, 17983, 17984, 68732, 68702, 68040, 68733, 18565, 18562, 18520, 
18564, 68734, 68703, 68011, 68042
23300, 16511, 16510, 16488, 16489, 62353, 62343, 62123, 62133, 17070, 17069, 17025, 17071, 68736, 68706, 68044, 
68737, 68735, 68704, 68012, 68043
23301, 62353, 62343, 62123, 62133, 62354, 62344, 62124, 62134, 68736, 68706, 68044, 68737, 68739, 68709, 68047, 
68740, 68738, 68707, 68015, 68046
23302, 62354, 62344, 62124, 62134, 62355, 62345, 62125, 62135, 68739, 68709, 68047, 68740, 68742, 68712, 68050, 
68743, 68741, 68710, 68018, 68049
23303, 62355, 62345, 62125, 62135, 62356, 62346, 62126, 62136, 68742, 68712, 68050, 68743, 68745, 68715, 68053, 
68746, 68744, 68713, 68021, 68052
23304, 62356, 62346, 62126, 62136, 62357, 62347, 62127, 62137, 68745, 68715, 68053, 68746, 68748, 68718, 68056, 
68749, 68747, 68716, 68024, 68055
23305, 62357, 62347, 62127, 62137, 62358, 62348, 62128, 62138, 68748, 68718, 68056, 68749, 68751, 68721, 68059, 
68752, 68750, 68719, 68027, 68058
23306, 62358, 62348, 62128, 62138, 62359, 62349, 62129, 62139, 68751, 68721, 68059, 68752, 68754, 68724, 68062, 
68755, 68753, 68722, 68030, 68061
23307, 62359, 62349, 62129, 62139, 62360, 62350, 62130, 62140, 68754, 68724, 68062, 68755, 68757, 68727, 68065, 
68758, 68756, 68725, 68033, 68064
23308, 62360, 62350, 62130, 62140, 62361, 62351, 62131, 62141, 68757, 68727, 68065, 68758, 68760, 68730, 68068, 
68761, 68759, 68728, 68036, 68067
23309, 62361, 62351, 62131, 62141, 62362, 62352, 62132, 62142, 68760, 68730, 68068, 68761, 68763, 68733, 68071, 
68764, 68762, 68731, 68039, 68070
23310, 62362, 62352, 62132, 62142, 18007, 18006, 17984, 17985, 68763, 68733, 68071, 68764, 18567, 18564, 18522, 
18566, 68765, 68734, 68042, 68073
23311, 16512, 16511, 16489, 16490, 62363, 62353, 62133, 62143, 17072, 17071, 17027, 17073, 68767, 68737, 68075, 
68768, 68766, 68735, 68043, 68074
23312, 62363, 62353, 62133, 62143, 62364, 62354, 62134, 62144, 68767, 68737, 68075, 68768, 68770, 68740, 68078, 
68771, 68769, 68738, 68046, 68077
23313, 62364, 62354, 62134, 62144, 62365, 62355, 62135, 62145, 68770, 68740, 68078, 68771, 68773, 68743, 68081, 
68774, 68772, 68741, 68049, 68080
23314, 62365, 62355, 62135, 62145, 62366, 62356, 62136, 62146, 68773, 68743, 68081, 68774, 68776, 68746, 68084, 
68777, 68775, 68744, 68052, 68083
23315, 62366, 62356, 62136, 62146, 62367, 62357, 62137, 62147, 68776, 68746, 68084, 68777, 68779, 68749, 68087, 
68780, 68778, 68747, 68055, 68086
23316, 62367, 62357, 62137, 62147, 62368, 62358, 62138, 62148, 68779, 68749, 68087, 68780, 68782, 68752, 68090, 
68783, 68781, 68750, 68058, 68089
23317, 62368, 62358, 62138, 62148, 62369, 62359, 62139, 62149, 68782, 68752, 68090, 68783, 68785, 68755, 68093, 
68786, 68784, 68753, 68061, 68092
23318, 62369, 62359, 62139, 62149, 62370, 62360, 62140, 62150, 68785, 68755, 68093, 68786, 68788, 68758, 68096, 
68789, 68787, 68756, 68064, 68095
23319, 62370, 62360, 62140, 62150, 62371, 62361, 62141, 62151, 68788, 68758, 68096, 68789, 68791, 68761, 68099, 
68792, 68790, 68759, 68067, 68098
23320, 62371, 62361, 62141, 62151, 62372, 62362, 62142, 62152, 68791, 68761, 68099, 68792, 68794, 68764, 68102, 
68795, 68793, 68762, 68070, 68101
23321, 62372, 62362, 62142, 62152, 18008, 18007, 17985, 17986, 68794, 68764, 68102, 68795, 18569, 18566, 18524, 
18568, 68796, 68765, 68073, 68104
23322, 16513, 16512, 16490, 16491, 62373, 62363, 62143, 62153, 17074, 17073, 17029, 17075, 68798, 68768, 68106, 
68799, 68797, 68766, 68074, 68105
23323, 62373, 62363, 62143, 62153, 62374, 62364, 62144, 62154, 68798, 68768, 68106, 68799, 68801, 68771, 68109, 
68802, 68800, 68769, 68077, 68108
23324, 62374, 62364, 62144, 62154, 62375, 62365, 62145, 62155, 68801, 68771, 68109, 68802, 68804, 68774, 68112, 
68805, 68803, 68772, 68080, 68111
23325, 62375, 62365, 62145, 62155, 62376, 62366, 62146, 62156, 68804, 68774, 68112, 68805, 68807, 68777, 68115, 
68808, 68806, 68775, 68083, 68114
23326, 62376, 62366, 62146, 62156, 62377, 62367, 62147, 62157, 68807, 68777, 68115, 68808, 68810, 68780, 68118, 
68811, 68809, 68778, 68086, 68117
23327, 62377, 62367, 62147, 62157, 62378, 62368, 62148, 62158, 68810, 68780, 68118, 68811, 68813, 68783, 68121, 
68814, 68812, 68781, 68089, 68120
23328, 62378, 62368, 62148, 62158, 62379, 62369, 62149, 62159, 68813, 68783, 68121, 68814, 68816, 68786, 68124, 
68817, 68815, 68784, 68092, 68123
23329, 62379, 62369, 62149, 62159, 62380, 62370, 62150, 62160, 68816, 68786, 68124, 68817, 68819, 68789, 68127, 
68820, 68818, 68787, 68095, 68126
23330, 62380, 62370, 62150, 62160, 62381, 62371, 62151, 62161, 68819, 68789, 68127, 68820, 68822, 68792, 68130, 
68823, 68821, 68790, 68098, 68129
23331, 62381, 62371, 62151, 62161, 62382, 62372, 62152, 62162, 68822, 68792, 68130, 68823, 68825, 68795, 68133, 
68826, 68824, 68793, 68101, 68132
23332, 62382, 62372, 62152, 62162, 18009, 18008, 17986, 17987, 68825, 68795, 68133, 68826, 18571, 18568, 18526, 
18570, 68827, 68796, 68104, 68135
23333, 16514, 16513, 16491, 16492, 62383, 62373, 62153, 62163, 17076, 17075, 17031, 17077, 68829, 68799, 68137, 
68830, 68828, 68797, 68105, 68136
23334, 62383, 62373, 62153, 62163, 62384, 62374, 62154, 62164, 68829, 68799, 68137, 68830, 68832, 68802, 68140, 
68833, 68831, 68800, 68108, 68139
23335, 62384, 62374, 62154, 62164, 62385, 62375, 62155, 62165, 68832, 68802, 68140, 68833, 68835, 68805, 68143, 
68836, 68834, 68803, 68111, 68142
23336, 62385, 62375, 62155, 62165, 62386, 62376, 62156, 62166, 68835, 68805, 68143, 68836, 68838, 68808, 68146, 
68839, 68837, 68806, 68114, 68145
23337, 62386, 62376, 62156, 62166, 62387, 62377, 62157, 62167, 68838, 68808, 68146, 68839, 68841, 68811, 68149, 
68842, 68840, 68809, 68117, 68148
23338, 62387, 62377, 62157, 62167, 62388, 62378, 62158, 62168, 68841, 68811, 68149, 68842, 68844, 68814, 68152, 
68845, 68843, 68812, 68120, 68151
23339, 62388, 62378, 62158, 62168, 62389, 62379, 62159, 62169, 68844, 68814, 68152, 68845, 68847, 68817, 68155, 
68848, 68846, 68815, 68123, 68154
23340, 62389, 62379, 62159, 62169, 62390, 62380, 62160, 62170, 68847, 68817, 68155, 68848, 68850, 68820, 68158, 
68851, 68849, 68818, 68126, 68157
23341, 62390, 62380, 62160, 62170, 62391, 62381, 62161, 62171, 68850, 68820, 68158, 68851, 68853, 68823, 68161, 
68854, 68852, 68821, 68129, 68160
23342, 62391, 62381, 62161, 62171, 62392, 62382, 62162, 62172, 68853, 68823, 68161, 68854, 68856, 68826, 68164, 
68857, 68855, 68824, 68132, 68163
23343, 62392, 62382, 62162, 62172, 18010, 18009, 17987, 17988, 68856, 68826, 68164, 68857, 18573, 18570, 18528, 
18572, 68858, 68827, 68135, 68166
23344, 16515, 16514, 16492, 16493, 62393, 62383, 62163, 62173, 17078, 17077, 17033, 17079, 68860, 68830, 68168, 
68861, 68859, 68828, 68136, 68167
23345, 62393, 62383, 62163, 62173, 62394, 62384, 62164, 62174, 68860, 68830, 68168, 68861, 68863, 68833, 68171, 
68864, 68862, 68831, 68139, 68170
23346, 62394, 62384, 62164, 62174, 62395, 62385, 62165, 62175, 68863, 68833, 68171, 68864, 68866, 68836, 68174, 
68867, 68865, 68834, 68142, 68173
23347, 62395, 62385, 62165, 62175, 62396, 62386, 62166, 62176, 68866, 68836, 68174, 68867, 68869, 68839, 68177, 
68870, 68868, 68837, 68145, 68176
23348, 62396, 62386, 62166, 62176, 62397, 62387, 62167, 62177, 68869, 68839, 68177, 68870, 68872, 68842, 68180, 
68873, 68871, 68840, 68148, 68179
23349, 62397, 62387, 62167, 62177, 62398, 62388, 62168, 62178, 68872, 68842, 68180, 68873, 68875, 68845, 68183, 
68876, 68874, 68843, 68151, 68182
23350, 62398, 62388, 62168, 62178, 62399, 62389, 62169, 62179, 68875, 68845, 68183, 68876, 68878, 68848, 68186, 
68879, 68877, 68846, 68154, 68185
23351, 62399, 62389, 62169, 62179, 62400, 62390, 62170, 62180, 68878, 68848, 68186, 68879, 68881, 68851, 68189, 
68882, 68880, 68849, 68157, 68188
23352, 62400, 62390, 62170, 62180, 62401, 62391, 62171, 62181, 68881, 68851, 68189, 68882, 68884, 68854, 68192, 
68885, 68883, 68852, 68160, 68191
23353, 62401, 62391, 62171, 62181, 62402, 62392, 62172, 62182, 68884, 68854, 68192, 68885, 68887, 68857, 68195, 
68888, 68886, 68855, 68163, 68194
23354, 62402, 62392, 62172, 62182, 18011, 18010, 17988, 17989, 68887, 68857, 68195, 68888, 18575, 18572, 18530, 
18574, 68889, 68858, 68166, 68197
23355, 16516, 16515, 16493, 16494, 62403, 62393, 62173, 62183, 17080, 17079, 17035, 17081, 68891, 68861, 68199, 
68892, 68890, 68859, 68167, 68198
23356, 62403, 62393, 62173, 62183, 62404, 62394, 62174, 62184, 68891, 68861, 68199, 68892, 68894, 68864, 68202, 
68895, 68893, 68862, 68170, 68201
23357, 62404, 62394, 62174, 62184, 62405, 62395, 62175, 62185, 68894, 68864, 68202, 68895, 68897, 68867, 68205, 
68898, 68896, 68865, 68173, 68204
23358, 62405, 62395, 62175, 62185, 62406, 62396, 62176, 62186, 68897, 68867, 68205, 68898, 68900, 68870, 68208, 
68901, 68899, 68868, 68176, 68207
23359, 62406, 62396, 62176, 62186, 62407, 62397, 62177, 62187, 68900, 68870, 68208, 68901, 68903, 68873, 68211, 
68904, 68902, 68871, 68179, 68210
23360, 62407, 62397, 62177, 62187, 62408, 62398, 62178, 62188, 68903, 68873, 68211, 68904, 68906, 68876, 68214, 
68907, 68905, 68874, 68182, 68213
23361, 62408, 62398, 62178, 62188, 62409, 62399, 62179, 62189, 68906, 68876, 68214, 68907, 68909, 68879, 68217, 
68910, 68908, 68877, 68185, 68216
23362, 62409, 62399, 62179, 62189, 62410, 62400, 62180, 62190, 68909, 68879, 68217, 68910, 68912, 68882, 68220, 
68913, 68911, 68880, 68188, 68219
23363, 62410, 62400, 62180, 62190, 62411, 62401, 62181, 62191, 68912, 68882, 68220, 68913, 68915, 68885, 68223, 
68916, 68914, 68883, 68191, 68222
23364, 62411, 62401, 62181, 62191, 62412, 62402, 62182, 62192, 68915, 68885, 68223, 68916, 68918, 68888, 68226, 
68919, 68917, 68886, 68194, 68225
23365, 62412, 62402, 62182, 62192, 18012, 18011, 17989, 17990, 68918, 68888, 68226, 68919, 18577, 18574, 18532, 
18576, 68920, 68889, 68197, 68228
23366, 16517, 16516, 16494, 16495, 62413, 62403, 62183, 62193, 17082, 17081, 17037, 17083, 68922, 68892, 68230, 
68923, 68921, 68890, 68198, 68229
23367, 62413, 62403, 62183, 62193, 62414, 62404, 62184, 62194, 68922, 68892, 68230, 68923, 68925, 68895, 68233, 
68926, 68924, 68893, 68201, 68232
23368, 62414, 62404, 62184, 62194, 62415, 62405, 62185, 62195, 68925, 68895, 68233, 68926, 68928, 68898, 68236, 
68929, 68927, 68896, 68204, 68235
23369, 62415, 62405, 62185, 62195, 62416, 62406, 62186, 62196, 68928, 68898, 68236, 68929, 68931, 68901, 68239, 
68932, 68930, 68899, 68207, 68238
23370, 62416, 62406, 62186, 62196, 62417, 62407, 62187, 62197, 68931, 68901, 68239, 68932, 68934, 68904, 68242, 
68935, 68933, 68902, 68210, 68241
23371, 62417, 62407, 62187, 62197, 62418, 62408, 62188, 62198, 68934, 68904, 68242, 68935, 68937, 68907, 68245, 
68938, 68936, 68905, 68213, 68244
23372, 62418, 62408, 62188, 62198, 62419, 62409, 62189, 62199, 68937, 68907, 68245, 68938, 68940, 68910, 68248, 
68941, 68939, 68908, 68216, 68247
23373, 62419, 62409, 62189, 62199, 62420, 62410, 62190, 62200, 68940, 68910, 68248, 68941, 68943, 68913, 68251, 
68944, 68942, 68911, 68219, 68250
23374, 62420, 62410, 62190, 62200, 62421, 62411, 62191, 62201, 68943, 68913, 68251, 68944, 68946, 68916, 68254, 
68947, 68945, 68914, 68222, 68253
23375, 62421, 62411, 62191, 62201, 62422, 62412, 62192, 62202, 68946, 68916, 68254, 68947, 68949, 68919, 68257, 
68950, 68948, 68917, 68225, 68256
23376, 62422, 62412, 62192, 62202, 18013, 18012, 17990, 17991, 68949, 68919, 68257, 68950, 18579, 18576, 18534, 
18578, 68951, 68920, 68228, 68259
23377, 16518, 16517, 16495, 16496, 62423, 62413, 62193, 62203, 17084, 17083, 17039, 17085, 68953, 68923, 68261, 
68954, 68952, 68921, 68229, 68260
23378, 62423, 62413, 62193, 62203, 62424, 62414, 62194, 62204, 68953, 68923, 68261, 68954, 68956, 68926, 68264, 
68957, 68955, 68924, 68232, 68263
23379, 62424, 62414, 62194, 62204, 62425, 62415, 62195, 62205, 68956, 68926, 68264, 68957, 68959, 68929, 68267, 
68960, 68958, 68927, 68235, 68266
23380, 62425, 62415, 62195, 62205, 62426, 62416, 62196, 62206, 68959, 68929, 68267, 68960, 68962, 68932, 68270, 
68963, 68961, 68930, 68238, 68269
23381, 62426, 62416, 62196, 62206, 62427, 62417, 62197, 62207, 68962, 68932, 68270, 68963, 68965, 68935, 68273, 
68966, 68964, 68933, 68241, 68272
23382, 62427, 62417, 62197, 62207, 62428, 62418, 62198, 62208, 68965, 68935, 68273, 68966, 68968, 68938, 68276, 
68969, 68967, 68936, 68244, 68275
23383, 62428, 62418, 62198, 62208, 62429, 62419, 62199, 62209, 68968, 68938, 68276, 68969, 68971, 68941, 68279, 
68972, 68970, 68939, 68247, 68278
23384, 62429, 62419, 62199, 62209, 62430, 62420, 62200, 62210, 68971, 68941, 68279, 68972, 68974, 68944, 68282, 
68975, 68973, 68942, 68250, 68281
23385, 62430, 62420, 62200, 62210, 62431, 62421, 62201, 62211, 68974, 68944, 68282, 68975, 68977, 68947, 68285, 
68978, 68976, 68945, 68253, 68284
23386, 62431, 62421, 62201, 62211, 62432, 62422, 62202, 62212, 68977, 68947, 68285, 68978, 68980, 68950, 68288, 
68981, 68979, 68948, 68256, 68287
23387, 62432, 62422, 62202, 62212, 18014, 18013, 17991, 17992, 68980, 68950, 68288, 68981, 18581, 18578, 18536, 
18580, 68982, 68951, 68259, 68290
23388, 16519, 16518, 16496, 16497, 62433, 62423, 62203, 62213, 17086, 17085, 17041, 17087, 68984, 68954, 68292, 
68985, 68983, 68952, 68260, 68291
23389, 62433, 62423, 62203, 62213, 62434, 62424, 62204, 62214, 68984, 68954, 68292, 68985, 68987, 68957, 68295, 
68988, 68986, 68955, 68263, 68294
23390, 62434, 62424, 62204, 62214, 62435, 62425, 62205, 62215, 68987, 68957, 68295, 68988, 68990, 68960, 68298, 
68991, 68989, 68958, 68266, 68297
23391, 62435, 62425, 62205, 62215, 62436, 62426, 62206, 62216, 68990, 68960, 68298, 68991, 68993, 68963, 68301, 
68994, 68992, 68961, 68269, 68300
23392, 62436, 62426, 62206, 62216, 62437, 62427, 62207, 62217, 68993, 68963, 68301, 68994, 68996, 68966, 68304, 
68997, 68995, 68964, 68272, 68303
23393, 62437, 62427, 62207, 62217, 62438, 62428, 62208, 62218, 68996, 68966, 68304, 68997, 68999, 68969, 68307, 
69000, 68998, 68967, 68275, 68306
23394, 62438, 62428, 62208, 62218, 62439, 62429, 62209, 62219, 68999, 68969, 68307, 69000, 69002, 68972, 68310, 
69003, 69001, 68970, 68278, 68309
23395, 62439, 62429, 62209, 62219, 62440, 62430, 62210, 62220, 69002, 68972, 68310, 69003, 69005, 68975, 68313, 
69006, 69004, 68973, 68281, 68312
23396, 62440, 62430, 62210, 62220, 62441, 62431, 62211, 62221, 69005, 68975, 68313, 69006, 69008, 68978, 68316, 
69009, 69007, 68976, 68284, 68315
23397, 62441, 62431, 62211, 62221, 62442, 62432, 62212, 62222, 69008, 68978, 68316, 69009, 69011, 68981, 68319, 
69012, 69010, 68979, 68287, 68318
23398, 62442, 62432, 62212, 62222, 18015, 18014, 17992, 17993, 69011, 68981, 68319, 69012, 18583, 18580, 18538, 
18582, 69013, 68982, 68290, 68321
23399, 16520, 16519, 16497, 16498, 62443, 62433, 62213, 62223, 17088, 17087, 17043, 17089, 69015, 68985, 68323, 
69016, 69014, 68983, 68291, 68322
23400, 62443, 62433, 62213, 62223, 62444, 62434, 62214, 62224, 69015, 68985, 68323, 69016, 69018, 68988, 68326, 
69019, 69017, 68986, 68294, 68325
23401, 62444, 62434, 62214, 62224, 62445, 62435, 62215, 62225, 69018, 68988, 68326, 69019, 69021, 68991, 68329, 
69022, 69020, 68989, 68297, 68328
23402, 62445, 62435, 62215, 62225, 62446, 62436, 62216, 62226, 69021, 68991, 68329, 69022, 69024, 68994, 68332, 
69025, 69023, 68992, 68300, 68331
23403, 62446, 62436, 62216, 62226, 62447, 62437, 62217, 62227, 69024, 68994, 68332, 69025, 69027, 68997, 68335, 
69028, 69026, 68995, 68303, 68334
23404, 62447, 62437, 62217, 62227, 62448, 62438, 62218, 62228, 69027, 68997, 68335, 69028, 69030, 69000, 68338, 
69031, 69029, 68998, 68306, 68337
23405, 62448, 62438, 62218, 62228, 62449, 62439, 62219, 62229, 69030, 69000, 68338, 69031, 69033, 69003, 68341, 
69034, 69032, 69001, 68309, 68340
23406, 62449, 62439, 62219, 62229, 62450, 62440, 62220, 62230, 69033, 69003, 68341, 69034, 69036, 69006, 68344, 
69037, 69035, 69004, 68312, 68343
23407, 62450, 62440, 62220, 62230, 62451, 62441, 62221, 62231, 69036, 69006, 68344, 69037, 69039, 69009, 68347, 
69040, 69038, 69007, 68315, 68346
23408, 62451, 62441, 62221, 62231, 62452, 62442, 62222, 62232, 69039, 69009, 68347, 69040, 69042, 69012, 68350, 
69043, 69041, 69010, 68318, 68349
23409, 62452, 62442, 62222, 62232, 18016, 18015, 17993, 17994, 69042, 69012, 68350, 69043, 18585, 18582, 18540, 
18584, 69044, 69013, 68321, 68352
23410, 16521, 16520, 16498, 16499, 62453, 62443, 62223, 62233, 17090, 17089, 17045, 17091, 69046, 69016, 68354, 
69047, 69045, 69014, 68322, 68353
23411, 62453, 62443, 62223, 62233, 62454, 62444, 62224, 62234, 69046, 69016, 68354, 69047, 69049, 69019, 68357, 
69050, 69048, 69017, 68325, 68356
23412, 62454, 62444, 62224, 62234, 62455, 62445, 62225, 62235, 69049, 69019, 68357, 69050, 69052, 69022, 68360, 
69053, 69051, 69020, 68328, 68359
23413, 62455, 62445, 62225, 62235, 62456, 62446, 62226, 62236, 69052, 69022, 68360, 69053, 69055, 69025, 68363, 
69056, 69054, 69023, 68331, 68362
23414, 62456, 62446, 62226, 62236, 62457, 62447, 62227, 62237, 69055, 69025, 68363, 69056, 69058, 69028, 68366, 
69059, 69057, 69026, 68334, 68365
23415, 62457, 62447, 62227, 62237, 62458, 62448, 62228, 62238, 69058, 69028, 68366, 69059, 69061, 69031, 68369, 
69062, 69060, 69029, 68337, 68368
23416, 62458, 62448, 62228, 62238, 62459, 62449, 62229, 62239, 69061, 69031, 68369, 69062, 69064, 69034, 68372, 
69065, 69063, 69032, 68340, 68371
23417, 62459, 62449, 62229, 62239, 62460, 62450, 62230, 62240, 69064, 69034, 68372, 69065, 69067, 69037, 68375, 
69068, 69066, 69035, 68343, 68374
23418, 62460, 62450, 62230, 62240, 62461, 62451, 62231, 62241, 69067, 69037, 68375, 69068, 69070, 69040, 68378, 
69071, 69069, 69038, 68346, 68377
23419, 62461, 62451, 62231, 62241, 62462, 62452, 62232, 62242, 69070, 69040, 68378, 69071, 69073, 69043, 68381, 
69074, 69072, 69041, 68349, 68380
23420, 62462, 62452, 62232, 62242, 18017, 18016, 17994, 17995, 69073, 69043, 68381, 69074, 18587, 18584, 18542, 
18586, 69075, 69044, 68352, 68383
23421, 16522, 16521, 16499, 16500, 62463, 62453, 62233, 62243, 17092, 17091, 17047, 17093, 69077, 69047, 68385, 
69078, 69076, 69045, 68353, 68384
23422, 62463, 62453, 62233, 62243, 62464, 62454, 62234, 62244, 69077, 69047, 68385, 69078, 69080, 69050, 68388, 
69081, 69079, 69048, 68356, 68387
23423, 62464, 62454, 62234, 62244, 62465, 62455, 62235, 62245, 69080, 69050, 68388, 69081, 69083, 69053, 68391, 
69084, 69082, 69051, 68359, 68390
23424, 62465, 62455, 62235, 62245, 62466, 62456, 62236, 62246, 69083, 69053, 68391, 69084, 69086, 69056, 68394, 
69087, 69085, 69054, 68362, 68393
23425, 62466, 62456, 62236, 62246, 62467, 62457, 62237, 62247, 69086, 69056, 68394, 69087, 69089, 69059, 68397, 
69090, 69088, 69057, 68365, 68396
23426, 62467, 62457, 62237, 62247, 62468, 62458, 62238, 62248, 69089, 69059, 68397, 69090, 69092, 69062, 68400, 
69093, 69091, 69060, 68368, 68399
23427, 62468, 62458, 62238, 62248, 62469, 62459, 62239, 62249, 69092, 69062, 68400, 69093, 69095, 69065, 68403, 
69096, 69094, 69063, 68371, 68402
23428, 62469, 62459, 62239, 62249, 62470, 62460, 62240, 62250, 69095, 69065, 68403, 69096, 69098, 69068, 68406, 
69099, 69097, 69066, 68374, 68405
23429, 62470, 62460, 62240, 62250, 62471, 62461, 62241, 62251, 69098, 69068, 68406, 69099, 69101, 69071, 68409, 
69102, 69100, 69069, 68377, 68408
23430, 62471, 62461, 62241, 62251, 62472, 62462, 62242, 62252, 69101, 69071, 68409, 69102, 69104, 69074, 68412, 
69105, 69103, 69072, 68380, 68411
23431, 62472, 62462, 62242, 62252, 18018, 18017, 17995, 17996, 69104, 69074, 68412, 69105, 18589, 18586, 18544, 
18588, 69106, 69075, 68383, 68414
23432, 16523, 16522, 16500, 16501, 62473, 62463, 62243, 62253, 17094, 17093, 17049, 17095, 69108, 69078, 68416, 
69109, 69107, 69076, 68384, 68415
23433, 62473, 62463, 62243, 62253, 62474, 62464, 62244, 62254, 69108, 69078, 68416, 69109, 69111, 69081, 68419, 
69112, 69110, 69079, 68387, 68418
23434, 62474, 62464, 62244, 62254, 62475, 62465, 62245, 62255, 69111, 69081, 68419, 69112, 69114, 69084, 68422, 
69115, 69113, 69082, 68390, 68421
23435, 62475, 62465, 62245, 62255, 62476, 62466, 62246, 62256, 69114, 69084, 68422, 69115, 69117, 69087, 68425, 
69118, 69116, 69085, 68393, 68424
23436, 62476, 62466, 62246, 62256, 62477, 62467, 62247, 62257, 69117, 69087, 68425, 69118, 69120, 69090, 68428, 
69121, 69119, 69088, 68396, 68427
23437, 62477, 62467, 62247, 62257, 62478, 62468, 62248, 62258, 69120, 69090, 68428, 69121, 69123, 69093, 68431, 
69124, 69122, 69091, 68399, 68430
23438, 62478, 62468, 62248, 62258, 62479, 62469, 62249, 62259, 69123, 69093, 68431, 69124, 69126, 69096, 68434, 
69127, 69125, 69094, 68402, 68433
23439, 62479, 62469, 62249, 62259, 62480, 62470, 62250, 62260, 69126, 69096, 68434, 69127, 69129, 69099, 68437, 
69130, 69128, 69097, 68405, 68436
23440, 62480, 62470, 62250, 62260, 62481, 62471, 62251, 62261, 69129, 69099, 68437, 69130, 69132, 69102, 68440, 
69133, 69131, 69100, 68408, 68439
23441, 62481, 62471, 62251, 62261, 62482, 62472, 62252, 62262, 69132, 69102, 68440, 69133, 69135, 69105, 68443, 
69136, 69134, 69103, 68411, 68442
23442, 62482, 62472, 62252, 62262, 18019, 18018, 17996, 17997, 69135, 69105, 68443, 69136, 18591, 18588, 18546, 
18590, 69137, 69106, 68414, 68445
23443, 16524, 16523, 16501, 16502, 62483, 62473, 62253, 62263, 17096, 17095, 17051, 17097, 69139, 69109, 68447, 
69140, 69138, 69107, 68415, 68446
23444, 62483, 62473, 62253, 62263, 62484, 62474, 62254, 62264, 69139, 69109, 68447, 69140, 69142, 69112, 68450, 
69143, 69141, 69110, 68418, 68449
23445, 62484, 62474, 62254, 62264, 62485, 62475, 62255, 62265, 69142, 69112, 68450, 69143, 69145, 69115, 68453, 
69146, 69144, 69113, 68421, 68452
23446, 62485, 62475, 62255, 62265, 62486, 62476, 62256, 62266, 69145, 69115, 68453, 69146, 69148, 69118, 68456, 
69149, 69147, 69116, 68424, 68455
23447, 62486, 62476, 62256, 62266, 62487, 62477, 62257, 62267, 69148, 69118, 68456, 69149, 69151, 69121, 68459, 
69152, 69150, 69119, 68427, 68458
23448, 62487, 62477, 62257, 62267, 62488, 62478, 62258, 62268, 69151, 69121, 68459, 69152, 69154, 69124, 68462, 
69155, 69153, 69122, 68430, 68461
23449, 62488, 62478, 62258, 62268, 62489, 62479, 62259, 62269, 69154, 69124, 68462, 69155, 69157, 69127, 68465, 
69158, 69156, 69125, 68433, 68464
23450, 62489, 62479, 62259, 62269, 62490, 62480, 62260, 62270, 69157, 69127, 68465, 69158, 69160, 69130, 68468, 
69161, 69159, 69128, 68436, 68467
23451, 62490, 62480, 62260, 62270, 62491, 62481, 62261, 62271, 69160, 69130, 68468, 69161, 69163, 69133, 68471, 
69164, 69162, 69131, 68439, 68470
23452, 62491, 62481, 62261, 62271, 62492, 62482, 62262, 62272, 69163, 69133, 68471, 69164, 69166, 69136, 68474, 
69167, 69165, 69134, 68442, 68473
23453, 62492, 62482, 62262, 62272, 18020, 18019, 17997, 17998, 69166, 69136, 68474, 69167, 18593, 18590, 18548, 
18592, 69168, 69137, 68445, 68476
23454, 16525, 16524, 16502, 16503, 62493, 62483, 62263, 62273, 17098, 17097, 17053, 17099, 69170, 69140, 68478, 
69171, 69169, 69138, 68446, 68477
23455, 62493, 62483, 62263, 62273, 62494, 62484, 62264, 62274, 69170, 69140, 68478, 69171, 69173, 69143, 68481, 
69174, 69172, 69141, 68449, 68480
23456, 62494, 62484, 62264, 62274, 62495, 62485, 62265, 62275, 69173, 69143, 68481, 69174, 69176, 69146, 68484, 
69177, 69175, 69144, 68452, 68483
23457, 62495, 62485, 62265, 62275, 62496, 62486, 62266, 62276, 69176, 69146, 68484, 69177, 69179, 69149, 68487, 
69180, 69178, 69147, 68455, 68486
23458, 62496, 62486, 62266, 62276, 62497, 62487, 62267, 62277, 69179, 69149, 68487, 69180, 69182, 69152, 68490, 
69183, 69181, 69150, 68458, 68489
23459, 62497, 62487, 62267, 62277, 62498, 62488, 62268, 62278, 69182, 69152, 68490, 69183, 69185, 69155, 68493, 
69186, 69184, 69153, 68461, 68492
23460, 62498, 62488, 62268, 62278, 62499, 62489, 62269, 62279, 69185, 69155, 68493, 69186, 69188, 69158, 68496, 
69189, 69187, 69156, 68464, 68495
23461, 62499, 62489, 62269, 62279, 62500, 62490, 62270, 62280, 69188, 69158, 68496, 69189, 69191, 69161, 68499, 
69192, 69190, 69159, 68467, 68498
23462, 62500, 62490, 62270, 62280, 62501, 62491, 62271, 62281, 69191, 69161, 68499, 69192, 69194, 69164, 68502, 
69195, 69193, 69162, 68470, 68501
23463, 62501, 62491, 62271, 62281, 62502, 62492, 62272, 62282, 69194, 69164, 68502, 69195, 69197, 69167, 68505, 
69198, 69196, 69165, 68473, 68504
23464, 62502, 62492, 62272, 62282, 18021, 18020, 17998, 17999, 69197, 69167, 68505, 69198, 18595, 18592, 18550, 
18594, 69199, 69168, 68476, 68507
23465, 16526, 16525, 16503, 16504, 62503, 62493, 62273, 62283, 17100, 17099, 17055, 17101, 69201, 69171, 68509, 
69202, 69200, 69169, 68477, 68508
23466, 62503, 62493, 62273, 62283, 62504, 62494, 62274, 62284, 69201, 69171, 68509, 69202, 69204, 69174, 68512, 
69205, 69203, 69172, 68480, 68511
23467, 62504, 62494, 62274, 62284, 62505, 62495, 62275, 62285, 69204, 69174, 68512, 69205, 69207, 69177, 68515, 
69208, 69206, 69175, 68483, 68514
23468, 62505, 62495, 62275, 62285, 62506, 62496, 62276, 62286, 69207, 69177, 68515, 69208, 69210, 69180, 68518, 
69211, 69209, 69178, 68486, 68517
23469, 62506, 62496, 62276, 62286, 62507, 62497, 62277, 62287, 69210, 69180, 68518, 69211, 69213, 69183, 68521, 
69214, 69212, 69181, 68489, 68520
23470, 62507, 62497, 62277, 62287, 62508, 62498, 62278, 62288, 69213, 69183, 68521, 69214, 69216, 69186, 68524, 
69217, 69215, 69184, 68492, 68523
23471, 62508, 62498, 62278, 62288, 62509, 62499, 62279, 62289, 69216, 69186, 68524, 69217, 69219, 69189, 68527, 
69220, 69218, 69187, 68495, 68526
23472, 62509, 62499, 62279, 62289, 62510, 62500, 62280, 62290, 69219, 69189, 68527, 69220, 69222, 69192, 68530, 
69223, 69221, 69190, 68498, 68529
23473, 62510, 62500, 62280, 62290, 62511, 62501, 62281, 62291, 69222, 69192, 68530, 69223, 69225, 69195, 68533, 
69226, 69224, 69193, 68501, 68532
23474, 62511, 62501, 62281, 62291, 62512, 62502, 62282, 62292, 69225, 69195, 68533, 69226, 69228, 69198, 68536, 
69229, 69227, 69196, 68504, 68535
23475, 62512, 62502, 62282, 62292, 18022, 18021, 17999, 18000, 69228, 69198, 68536, 69229, 18597, 18594, 18552, 
18596, 69230, 69199, 68507, 68538
23476, 1637, 16526, 16504, 1636, 20153, 62503, 62283, 20143, 17102, 17101, 17057, 1659, 69231, 69202, 68539, 
20407, 20406, 69200, 68508, 20385
23477, 20153, 62503, 62283, 20143, 20154, 62504, 62284, 20144, 69231, 69202, 68539, 20407, 69232, 69205, 68540, 
20409, 20408, 69203, 68511, 20387
23478, 20154, 62504, 62284, 20144, 20155, 62505, 62285, 20145, 69232, 69205, 68540, 20409, 69233, 69208, 68541, 
20411, 20410, 69206, 68514, 20389
23479, 20155, 62505, 62285, 20145, 20156, 62506, 62286, 20146, 69233, 69208, 68541, 20411, 69234, 69211, 68542, 
20413, 20412, 69209, 68517, 20391
23480, 20156, 62506, 62286, 20146, 20157, 62507, 62287, 20147, 69234, 69211, 68542, 20413, 69235, 69214, 68543, 
20415, 20414, 69212, 68520, 20393
23481, 20157, 62507, 62287, 20147, 20158, 62508, 62288, 20148, 69235, 69214, 68543, 20415, 69236, 69217, 68544, 
20417, 20416, 69215, 68523, 20395
23482, 20158, 62508, 62288, 20148, 20159, 62509, 62289, 20149, 69236, 69217, 68544, 20417, 69237, 69220, 68545, 
20419, 20418, 69218, 68526, 20397
23483, 20159, 62509, 62289, 20149, 20160, 62510, 62290, 20150, 69237, 69220, 68545, 20419, 69238, 69223, 68546, 
20421, 20420, 69221, 68529, 20399
23484, 20160, 62510, 62290, 20150, 20161, 62511, 62291, 20151, 69238, 69223, 68546, 20421, 69239, 69226, 68547, 
20423, 20422, 69224, 68532, 20401
23485, 20161, 62511, 62291, 20151, 20162, 62512, 62292, 20152, 69239, 69226, 68547, 20423, 69240, 69229, 68548, 
20425, 20424, 69227, 68535, 20403
23486, 20162, 62512, 62292, 20152, 1772, 18022, 18000, 1771, 69240, 69229, 68548, 20425, 18598, 18596, 18553, 
1794, 20426, 69230, 68538, 20405
23487, 16527, 1593, 1592, 16505, 62513, 19471, 19461, 62293, 17103, 1615, 17058, 17104, 69242, 19735, 68550, 
69243, 69241, 19736, 19715, 68549
23488, 62513, 19471, 19461, 62293, 62514, 19472, 19462, 62294, 69242, 19735, 68550, 69243, 69245, 19737, 68553, 
69246, 69244, 19738, 19717, 68552
23489, 62514, 19472, 19462, 62294, 62515, 19473, 19463, 62295, 69245, 19737, 68553, 69246, 69248, 19739, 68556, 
69249, 69247, 19740, 19719, 68555
23490, 62515, 19473, 19463, 62295, 62516, 19474, 19464, 62296, 69248, 19739, 68556, 69249, 69251, 19741, 68559, 
69252, 69250, 19742, 19721, 68558
23491, 62516, 19474, 19464, 62296, 62517, 19475, 19465, 62297, 69251, 19741, 68559, 69252, 69254, 19743, 68562, 
69255, 69253, 19744, 19723, 68561
23492, 62517, 19475, 19465, 62297, 62518, 19476, 19466, 62298, 69254, 19743, 68562, 69255, 69257, 19745, 68565, 
69258, 69256, 19746, 19725, 68564
23493, 62518, 19476, 19466, 62298, 62519, 19477, 19467, 62299, 69257, 19745, 68565, 69258, 69260, 19747, 68568, 
69261, 69259, 19748, 19727, 68567
23494, 62519, 19477, 19467, 62299, 62520, 19478, 19468, 62300, 69260, 19747, 68568, 69261, 69263, 19749, 68571, 
69264, 69262, 19750, 19729, 68570
23495, 62520, 19478, 19468, 62300, 62521, 19479, 19469, 62301, 69263, 19749, 68571, 69264, 69266, 19751, 68574, 
69267, 69265, 19752, 19731, 68573
23496, 62521, 19479, 19469, 62301, 62522, 19480, 19470, 62302, 69266, 19751, 68574, 69267, 69269, 19753, 68577, 
69270, 69268, 19754, 19733, 68576
23497, 62522, 19480, 19470, 62302, 18023, 1728, 1727, 18001, 69269, 19753, 68577, 69270, 18600, 1750, 18555, 
18599, 69271, 19755, 19734, 68579
23498, 16528, 16527, 16505, 16506, 62523, 62513, 62293, 62303, 17105, 17104, 17060, 17106, 69273, 69243, 68581, 
69274, 69272, 69241, 68549, 68580
23499, 62523, 62513, 62293, 62303, 62524, 62514, 62294, 62304, 69273, 69243, 68581, 69274, 69276, 69246, 68584, 
69277, 69275, 69244, 68552, 68583
23500, 62524, 62514, 62294, 62304, 62525, 62515, 62295, 62305, 69276, 69246, 68584, 69277, 69279, 69249, 68587, 
69280, 69278, 69247, 68555, 68586
23501, 62525, 62515, 62295, 62305, 62526, 62516, 62296, 62306, 69279, 69249, 68587, 69280, 69282, 69252, 68590, 
69283, 69281, 69250, 68558, 68589
23502, 62526, 62516, 62296, 62306, 62527, 62517, 62297, 62307, 69282, 69252, 68590, 69283, 69285, 69255, 68593, 
69286, 69284, 69253, 68561, 68592
23503, 62527, 62517, 62297, 62307, 62528, 62518, 62298, 62308, 69285, 69255, 68593, 69286, 69288, 69258, 68596, 
69289, 69287, 69256, 68564, 68595
23504, 62528, 62518, 62298, 62308, 62529, 62519, 62299, 62309, 69288, 69258, 68596, 69289, 69291, 69261, 68599, 
69292, 69290, 69259, 68567, 68598
23505, 62529, 62519, 62299, 62309, 62530, 62520, 62300, 62310, 69291, 69261, 68599, 69292, 69294, 69264, 68602, 
69295, 69293, 69262, 68570, 68601
23506, 62530, 62520, 62300, 62310, 62531, 62521, 62301, 62311, 69294, 69264, 68602, 69295, 69297, 69267, 68605, 
69298, 69296, 69265, 68573, 68604
23507, 62531, 62521, 62301, 62311, 62532, 62522, 62302, 62312, 69297, 69267, 68605, 69298, 69300, 69270, 68608, 
69301, 69299, 69268, 68576, 68607
23508, 62532, 62522, 62302, 62312, 18024, 18023, 18001, 18002, 69300, 69270, 68608, 69301, 18602, 18599, 18557, 
18601, 69302, 69271, 68579, 68610
23509, 16529, 16528, 16506, 16507, 62533, 62523, 62303, 62313, 17107, 17106, 17062, 17108, 69304, 69274, 68612, 
69305, 69303, 69272, 68580, 68611
23510, 62533, 62523, 62303, 62313, 62534, 62524, 62304, 62314, 69304, 69274, 68612, 69305, 69307, 69277, 68615, 
69308, 69306, 69275, 68583, 68614
23511, 62534, 62524, 62304, 62314, 62535, 62525, 62305, 62315, 69307, 69277, 68615, 69308, 69310, 69280, 68618, 
69311, 69309, 69278, 68586, 68617
23512, 62535, 62525, 62305, 62315, 62536, 62526, 62306, 62316, 69310, 69280, 68618, 69311, 69313, 69283, 68621, 
69314, 69312, 69281, 68589, 68620
23513, 62536, 62526, 62306, 62316, 62537, 62527, 62307, 62317, 69313, 69283, 68621, 69314, 69316, 69286, 68624, 
69317, 69315, 69284, 68592, 68623
23514, 62537, 62527, 62307, 62317, 62538, 62528, 62308, 62318, 69316, 69286, 68624, 69317, 69319, 69289, 68627, 
69320, 69318, 69287, 68595, 68626
23515, 62538, 62528, 62308, 62318, 62539, 62529, 62309, 62319, 69319, 69289, 68627, 69320, 69322, 69292, 68630, 
69323, 69321, 69290, 68598, 68629
23516, 62539, 62529, 62309, 62319, 62540, 62530, 62310, 62320, 69322, 69292, 68630, 69323, 69325, 69295, 68633, 
69326, 69324, 69293, 68601, 68632
23517, 62540, 62530, 62310, 62320, 62541, 62531, 62311, 62321, 69325, 69295, 68633, 69326, 69328, 69298, 68636, 
69329, 69327, 69296, 68604, 68635
23518, 62541, 62531, 62311, 62321, 62542, 62532, 62312, 62322, 69328, 69298, 68636, 69329, 69331, 69301, 68639, 
69332, 69330, 69299, 68607, 68638
23519, 62542, 62532, 62312, 62322, 18025, 18024, 18002, 18003, 69331, 69301, 68639, 69332, 18604, 18601, 18559, 
18603, 69333, 69302, 68610, 68641
23520, 16530, 16529, 16507, 16508, 62543, 62533, 62313, 62323, 17109, 17108, 17064, 17110, 69335, 69305, 68643, 
69336, 69334, 69303, 68611, 68642
23521, 62543, 62533, 62313, 62323, 62544, 62534, 62314, 62324, 69335, 69305, 68643, 69336, 69338, 69308, 68646, 
69339, 69337, 69306, 68614, 68645
23522, 62544, 62534, 62314, 62324, 62545, 62535, 62315, 62325, 69338, 69308, 68646, 69339, 69341, 69311, 68649, 
69342, 69340, 69309, 68617, 68648
23523, 62545, 62535, 62315, 62325, 62546, 62536, 62316, 62326, 69341, 69311, 68649, 69342, 69344, 69314, 68652, 
69345, 69343, 69312, 68620, 68651
23524, 62546, 62536, 62316, 62326, 62547, 62537, 62317, 62327, 69344, 69314, 68652, 69345, 69347, 69317, 68655, 
69348, 69346, 69315, 68623, 68654
23525, 62547, 62537, 62317, 62327, 62548, 62538, 62318, 62328, 69347, 69317, 68655, 69348, 69350, 69320, 68658, 
69351, 69349, 69318, 68626, 68657
23526, 62548, 62538, 62318, 62328, 62549, 62539, 62319, 62329, 69350, 69320, 68658, 69351, 69353, 69323, 68661, 
69354, 69352, 69321, 68629, 68660
23527, 62549, 62539, 62319, 62329, 62550, 62540, 62320, 62330, 69353, 69323, 68661, 69354, 69356, 69326, 68664, 
69357, 69355, 69324, 68632, 68663
23528, 62550, 62540, 62320, 62330, 62551, 62541, 62321, 62331, 69356, 69326, 68664, 69357, 69359, 69329, 68667, 
69360, 69358, 69327, 68635, 68666
23529, 62551, 62541, 62321, 62331, 62552, 62542, 62322, 62332, 69359, 69329, 68667, 69360, 69362, 69332, 68670, 
69363, 69361, 69330, 68638, 68669
23530, 62552, 62542, 62322, 62332, 18026, 18025, 18003, 18004, 69362, 69332, 68670, 69363, 18606, 18603, 18561, 
18605, 69364, 69333, 68641, 68672
23531, 16531, 16530, 16508, 16509, 62553, 62543, 62323, 62333, 17111, 17110, 17066, 17112, 69366, 69336, 68674, 
69367, 69365, 69334, 68642, 68673
23532, 62553, 62543, 62323, 62333, 62554, 62544, 62324, 62334, 69366, 69336, 68674, 69367, 69369, 69339, 68677, 
69370, 69368, 69337, 68645, 68676
23533, 62554, 62544, 62324, 62334, 62555, 62545, 62325, 62335, 69369, 69339, 68677, 69370, 69372, 69342, 68680, 
69373, 69371, 69340, 68648, 68679
23534, 62555, 62545, 62325, 62335, 62556, 62546, 62326, 62336, 69372, 69342, 68680, 69373, 69375, 69345, 68683, 
69376, 69374, 69343, 68651, 68682
23535, 62556, 62546, 62326, 62336, 62557, 62547, 62327, 62337, 69375, 69345, 68683, 69376, 69378, 69348, 68686, 
69379, 69377, 69346, 68654, 68685
23536, 62557, 62547, 62327, 62337, 62558, 62548, 62328, 62338, 69378, 69348, 68686, 69379, 69381, 69351, 68689, 
69382, 69380, 69349, 68657, 68688
23537, 62558, 62548, 62328, 62338, 62559, 62549, 62329, 62339, 69381, 69351, 68689, 69382, 69384, 69354, 68692, 
69385, 69383, 69352, 68660, 68691
23538, 62559, 62549, 62329, 62339, 62560, 62550, 62330, 62340, 69384, 69354, 68692, 69385, 69387, 69357, 68695, 
69388, 69386, 69355, 68663, 68694
23539, 62560, 62550, 62330, 62340, 62561, 62551, 62331, 62341, 69387, 69357, 68695, 69388, 69390, 69360, 68698, 
69391, 69389, 69358, 68666, 68697
23540, 62561, 62551, 62331, 62341, 62562, 62552, 62332, 62342, 69390, 69360, 68698, 69391, 69393, 69363, 68701, 
69394, 69392, 69361, 68669, 68700
23541, 62562, 62552, 62332, 62342, 18027, 18026, 18004, 18005, 69393, 69363, 68701, 69394, 18608, 18605, 18563, 
18607, 69395, 69364, 68672, 68703
23542, 16532, 16531, 16509, 16510, 62563, 62553, 62333, 62343, 17113, 17112, 17068, 17114, 69397, 69367, 68705, 
69398, 69396, 69365, 68673, 68704
23543, 62563, 62553, 62333, 62343, 62564, 62554, 62334, 62344, 69397, 69367, 68705, 69398, 69400, 69370, 68708, 
69401, 69399, 69368, 68676, 68707
23544, 62564, 62554, 62334, 62344, 62565, 62555, 62335, 62345, 69400, 69370, 68708, 69401, 69403, 69373, 68711, 
69404, 69402, 69371, 68679, 68710
23545, 62565, 62555, 62335, 62345, 62566, 62556, 62336, 62346, 69403, 69373, 68711, 69404, 69406, 69376, 68714, 
69407, 69405, 69374, 68682, 68713
23546, 62566, 62556, 62336, 62346, 62567, 62557, 62337, 62347, 69406, 69376, 68714, 69407, 69409, 69379, 68717, 
69410, 69408, 69377, 68685, 68716
23547, 62567, 62557, 62337, 62347, 62568, 62558, 62338, 62348, 69409, 69379, 68717, 69410, 69412, 69382, 68720, 
69413, 69411, 69380, 68688, 68719
23548, 62568, 62558, 62338, 62348, 62569, 62559, 62339, 62349, 69412, 69382, 68720, 69413, 69415, 69385, 68723, 
69416, 69414, 69383, 68691, 68722
23549, 62569, 62559, 62339, 62349, 62570, 62560, 62340, 62350, 69415, 69385, 68723, 69416, 69418, 69388, 68726, 
69419, 69417, 69386, 68694, 68725
23550, 62570, 62560, 62340, 62350, 62571, 62561, 62341, 62351, 69418, 69388, 68726, 69419, 69421, 69391, 68729, 
69422, 69420, 69389, 68697, 68728
23551, 62571, 62561, 62341, 62351, 62572, 62562, 62342, 62352, 69421, 69391, 68729, 69422, 69424, 69394, 68732, 
69425, 69423, 69392, 68700, 68731
23552, 62572, 62562, 62342, 62352, 18028, 18027, 18005, 18006, 69424, 69394, 68732, 69425, 18610, 18607, 18565, 
18609, 69426, 69395, 68703, 68734
23553, 16533, 16532, 16510, 16511, 62573, 62563, 62343, 62353, 17115, 17114, 17070, 17116, 69428, 69398, 68736, 
69429, 69427, 69396, 68704, 68735
23554, 62573, 62563, 62343, 62353, 62574, 62564, 62344, 62354, 69428, 69398, 68736, 69429, 69431, 69401, 68739, 
69432, 69430, 69399, 68707, 68738
23555, 62574, 62564, 62344, 62354, 62575, 62565, 62345, 62355, 69431, 69401, 68739, 69432, 69434, 69404, 68742, 
69435, 69433, 69402, 68710, 68741
23556, 62575, 62565, 62345, 62355, 62576, 62566, 62346, 62356, 69434, 69404, 68742, 69435, 69437, 69407, 68745, 
69438, 69436, 69405, 68713, 68744
23557, 62576, 62566, 62346, 62356, 62577, 62567, 62347, 62357, 69437, 69407, 68745, 69438, 69440, 69410, 68748, 
69441, 69439, 69408, 68716, 68747
23558, 62577, 62567, 62347, 62357, 62578, 62568, 62348, 62358, 69440, 69410, 68748, 69441, 69443, 69413, 68751, 
69444, 69442, 69411, 68719, 68750
23559, 62578, 62568, 62348, 62358, 62579, 62569, 62349, 62359, 69443, 69413, 68751, 69444, 69446, 69416, 68754, 
69447, 69445, 69414, 68722, 68753
23560, 62579, 62569, 62349, 62359, 62580, 62570, 62350, 62360, 69446, 69416, 68754, 69447, 69449, 69419, 68757, 
69450, 69448, 69417, 68725, 68756
23561, 62580, 62570, 62350, 62360, 62581, 62571, 62351, 62361, 69449, 69419, 68757, 69450, 69452, 69422, 68760, 
69453, 69451, 69420, 68728, 68759
23562, 62581, 62571, 62351, 62361, 62582, 62572, 62352, 62362, 69452, 69422, 68760, 69453, 69455, 69425, 68763, 
69456, 69454, 69423, 68731, 68762
23563, 62582, 62572, 62352, 62362, 18029, 18028, 18006, 18007, 69455, 69425, 68763, 69456, 18612, 18609, 18567, 
18611, 69457, 69426, 68734, 68765
23564, 16534, 16533, 16511, 16512, 62583, 62573, 62353, 62363, 17117, 17116, 17072, 17118, 69459, 69429, 68767, 
69460, 69458, 69427, 68735, 68766
23565, 62583, 62573, 62353, 62363, 62584, 62574, 62354, 62364, 69459, 69429, 68767, 69460, 69462, 69432, 68770, 
69463, 69461, 69430, 68738, 68769
23566, 62584, 62574, 62354, 62364, 62585, 62575, 62355, 62365, 69462, 69432, 68770, 69463, 69465, 69435, 68773, 
69466, 69464, 69433, 68741, 68772
23567, 62585, 62575, 62355, 62365, 62586, 62576, 62356, 62366, 69465, 69435, 68773, 69466, 69468, 69438, 68776, 
69469, 69467, 69436, 68744, 68775
23568, 62586, 62576, 62356, 62366, 62587, 62577, 62357, 62367, 69468, 69438, 68776, 69469, 69471, 69441, 68779, 
69472, 69470, 69439, 68747, 68778
23569, 62587, 62577, 62357, 62367, 62588, 62578, 62358, 62368, 69471, 69441, 68779, 69472, 69474, 69444, 68782, 
69475, 69473, 69442, 68750, 68781
23570, 62588, 62578, 62358, 62368, 62589, 62579, 62359, 62369, 69474, 69444, 68782, 69475, 69477, 69447, 68785, 
69478, 69476, 69445, 68753, 68784
23571, 62589, 62579, 62359, 62369, 62590, 62580, 62360, 62370, 69477, 69447, 68785, 69478, 69480, 69450, 68788, 
69481, 69479, 69448, 68756, 68787
23572, 62590, 62580, 62360, 62370, 62591, 62581, 62361, 62371, 69480, 69450, 68788, 69481, 69483, 69453, 68791, 
69484, 69482, 69451, 68759, 68790
23573, 62591, 62581, 62361, 62371, 62592, 62582, 62362, 62372, 69483, 69453, 68791, 69484, 69486, 69456, 68794, 
69487, 69485, 69454, 68762, 68793
23574, 62592, 62582, 62362, 62372, 18030, 18029, 18007, 18008, 69486, 69456, 68794, 69487, 18614, 18611, 18569, 
18613, 69488, 69457, 68765, 68796
23575, 16535, 16534, 16512, 16513, 62593, 62583, 62363, 62373, 17119, 17118, 17074, 17120, 69490, 69460, 68798, 
69491, 69489, 69458, 68766, 68797
23576, 62593, 62583, 62363, 62373, 62594, 62584, 62364, 62374, 69490, 69460, 68798, 69491, 69493, 69463, 68801, 
69494, 69492, 69461, 68769, 68800
23577, 62594, 62584, 62364, 62374, 62595, 62585, 62365, 62375, 69493, 69463, 68801, 69494, 69496, 69466, 68804, 
69497, 69495, 69464, 68772, 68803
23578, 62595, 62585, 62365, 62375, 62596, 62586, 62366, 62376, 69496, 69466, 68804, 69497, 69499, 69469, 68807, 
69500, 69498, 69467, 68775, 68806
23579, 62596, 62586, 62366, 62376, 62597, 62587, 62367, 62377, 69499, 69469, 68807, 69500, 69502, 69472, 68810, 
69503, 69501, 69470, 68778, 68809
23580, 62597, 62587, 62367, 62377, 62598, 62588, 62368, 62378, 69502, 69472, 68810, 69503, 69505, 69475, 68813, 
69506, 69504, 69473, 68781, 68812
23581, 62598, 62588, 62368, 62378, 62599, 62589, 62369, 62379, 69505, 69475, 68813, 69506, 69508, 69478, 68816, 
69509, 69507, 69476, 68784, 68815
23582, 62599, 62589, 62369, 62379, 62600, 62590, 62370, 62380, 69508, 69478, 68816, 69509, 69511, 69481, 68819, 
69512, 69510, 69479, 68787, 68818
23583, 62600, 62590, 62370, 62380, 62601, 62591, 62371, 62381, 69511, 69481, 68819, 69512, 69514, 69484, 68822, 
69515, 69513, 69482, 68790, 68821
23584, 62601, 62591, 62371, 62381, 62602, 62592, 62372, 62382, 69514, 69484, 68822, 69515, 69517, 69487, 68825, 
69518, 69516, 69485, 68793, 68824
23585, 62602, 62592, 62372, 62382, 18031, 18030, 18008, 18009, 69517, 69487, 68825, 69518, 18616, 18613, 18571, 
18615, 69519, 69488, 68796, 68827
23586, 16536, 16535, 16513, 16514, 62603, 62593, 62373, 62383, 17121, 17120, 17076, 17122, 69521, 69491, 68829, 
69522, 69520, 69489, 68797, 68828
23587, 62603, 62593, 62373, 62383, 62604, 62594, 62374, 62384, 69521, 69491, 68829, 69522, 69524, 69494, 68832, 
69525, 69523, 69492, 68800, 68831
23588, 62604, 62594, 62374, 62384, 62605, 62595, 62375, 62385, 69524, 69494, 68832, 69525, 69527, 69497, 68835, 
69528, 69526, 69495, 68803, 68834
23589, 62605, 62595, 62375, 62385, 62606, 62596, 62376, 62386, 69527, 69497, 68835, 69528, 69530, 69500, 68838, 
69531, 69529, 69498, 68806, 68837
23590, 62606, 62596, 62376, 62386, 62607, 62597, 62377, 62387, 69530, 69500, 68838, 69531, 69533, 69503, 68841, 
69534, 69532, 69501, 68809, 68840
23591, 62607, 62597, 62377, 62387, 62608, 62598, 62378, 62388, 69533, 69503, 68841, 69534, 69536, 69506, 68844, 
69537, 69535, 69504, 68812, 68843
23592, 62608, 62598, 62378, 62388, 62609, 62599, 62379, 62389, 69536, 69506, 68844, 69537, 69539, 69509, 68847, 
69540, 69538, 69507, 68815, 68846
23593, 62609, 62599, 62379, 62389, 62610, 62600, 62380, 62390, 69539, 69509, 68847, 69540, 69542, 69512, 68850, 
69543, 69541, 69510, 68818, 68849
23594, 62610, 62600, 62380, 62390, 62611, 62601, 62381, 62391, 69542, 69512, 68850, 69543, 69545, 69515, 68853, 
69546, 69544, 69513, 68821, 68852
23595, 62611, 62601, 62381, 62391, 62612, 62602, 62382, 62392, 69545, 69515, 68853, 69546, 69548, 69518, 68856, 
69549, 69547, 69516, 68824, 68855
23596, 62612, 62602, 62382, 62392, 18032, 18031, 18009, 18010, 69548, 69518, 68856, 69549, 18618, 18615, 18573, 
18617, 69550, 69519, 68827, 68858
23597, 16537, 16536, 16514, 16515, 62613, 62603, 62383, 62393, 17123, 17122, 17078, 17124, 69552, 69522, 68860, 
69553, 69551, 69520, 68828, 68859
23598, 62613, 62603, 62383, 62393, 62614, 62604, 62384, 62394, 69552, 69522, 68860, 69553, 69555, 69525, 68863, 
69556, 69554, 69523, 68831, 68862
23599, 62614, 62604, 62384, 62394, 62615, 62605, 62385, 62395, 69555, 69525, 68863, 69556, 69558, 69528, 68866, 
69559, 69557, 69526, 68834, 68865
23600, 62615, 62605, 62385, 62395, 62616, 62606, 62386, 62396, 69558, 69528, 68866, 69559, 69561, 69531, 68869, 
69562, 69560, 69529, 68837, 68868
23601, 62616, 62606, 62386, 62396, 62617, 62607, 62387, 62397, 69561, 69531, 68869, 69562, 69564, 69534, 68872, 
69565, 69563, 69532, 68840, 68871
23602, 62617, 62607, 62387, 62397, 62618, 62608, 62388, 62398, 69564, 69534, 68872, 69565, 69567, 69537, 68875, 
69568, 69566, 69535, 68843, 68874
23603, 62618, 62608, 62388, 62398, 62619, 62609, 62389, 62399, 69567, 69537, 68875, 69568, 69570, 69540, 68878, 
69571, 69569, 69538, 68846, 68877
23604, 62619, 62609, 62389, 62399, 62620, 62610, 62390, 62400, 69570, 69540, 68878, 69571, 69573, 69543, 68881, 
69574, 69572, 69541, 68849, 68880
23605, 62620, 62610, 62390, 62400, 62621, 62611, 62391, 62401, 69573, 69543, 68881, 69574, 69576, 69546, 68884, 
69577, 69575, 69544, 68852, 68883
23606, 62621, 62611, 62391, 62401, 62622, 62612, 62392, 62402, 69576, 69546, 68884, 69577, 69579, 69549, 68887, 
69580, 69578, 69547, 68855, 68886
23607, 62622, 62612, 62392, 62402, 18033, 18032, 18010, 18011, 69579, 69549, 68887, 69580, 18620, 18617, 18575, 
18619, 69581, 69550, 68858, 68889
23608, 16538, 16537, 16515, 16516, 62623, 62613, 62393, 62403, 17125, 17124, 17080, 17126, 69583, 69553, 68891, 
69584, 69582, 69551, 68859, 68890
23609, 62623, 62613, 62393, 62403, 62624, 62614, 62394, 62404, 69583, 69553, 68891, 69584, 69586, 69556, 68894, 
69587, 69585, 69554, 68862, 68893
23610, 62624, 62614, 62394, 62404, 62625, 62615, 62395, 62405, 69586, 69556, 68894, 69587, 69589, 69559, 68897, 
69590, 69588, 69557, 68865, 68896
23611, 62625, 62615, 62395, 62405, 62626, 62616, 62396, 62406, 69589, 69559, 68897, 69590, 69592, 69562, 68900, 
69593, 69591, 69560, 68868, 68899
23612, 62626, 62616, 62396, 62406, 62627, 62617, 62397, 62407, 69592, 69562, 68900, 69593, 69595, 69565, 68903, 
69596, 69594, 69563, 68871, 68902
23613, 62627, 62617, 62397, 62407, 62628, 62618, 62398, 62408, 69595, 69565, 68903, 69596, 69598, 69568, 68906, 
69599, 69597, 69566, 68874, 68905
23614, 62628, 62618, 62398, 62408, 62629, 62619, 62399, 62409, 69598, 69568, 68906, 69599, 69601, 69571, 68909, 
69602, 69600, 69569, 68877, 68908
23615, 62629, 62619, 62399, 62409, 62630, 62620, 62400, 62410, 69601, 69571, 68909, 69602, 69604, 69574, 68912, 
69605, 69603, 69572, 68880, 68911
23616, 62630, 62620, 62400, 62410, 62631, 62621, 62401, 62411, 69604, 69574, 68912, 69605, 69607, 69577, 68915, 
69608, 69606, 69575, 68883, 68914
23617, 62631, 62621, 62401, 62411, 62632, 62622, 62402, 62412, 69607, 69577, 68915, 69608, 69610, 69580, 68918, 
69611, 69609, 69578, 68886, 68917
23618, 62632, 62622, 62402, 62412, 18034, 18033, 18011, 18012, 69610, 69580, 68918, 69611, 18622, 18619, 18577, 
18621, 69612, 69581, 68889, 68920
23619, 16539, 16538, 16516, 16517, 62633, 62623, 62403, 62413, 17127, 17126, 17082, 17128, 69614, 69584, 68922, 
69615, 69613, 69582, 68890, 68921
23620, 62633, 62623, 62403, 62413, 62634, 62624, 62404, 62414, 69614, 69584, 68922, 69615, 69617, 69587, 68925, 
69618, 69616, 69585, 68893, 68924
23621, 62634, 62624, 62404, 62414, 62635, 62625, 62405, 62415, 69617, 69587, 68925, 69618, 69620, 69590, 68928, 
69621, 69619, 69588, 68896, 68927
23622, 62635, 62625, 62405, 62415, 62636, 62626, 62406, 62416, 69620, 69590, 68928, 69621, 69623, 69593, 68931, 
69624, 69622, 69591, 68899, 68930
23623, 62636, 62626, 62406, 62416, 62637, 62627, 62407, 62417, 69623, 69593, 68931, 69624, 69626, 69596, 68934, 
69627, 69625, 69594, 68902, 68933
23624, 62637, 62627, 62407, 62417, 62638, 62628, 62408, 62418, 69626, 69596, 68934, 69627, 69629, 69599, 68937, 
69630, 69628, 69597, 68905, 68936
23625, 62638, 62628, 62408, 62418, 62639, 62629, 62409, 62419, 69629, 69599, 68937, 69630, 69632, 69602, 68940, 
69633, 69631, 69600, 68908, 68939
23626, 62639, 62629, 62409, 62419, 62640, 62630, 62410, 62420, 69632, 69602, 68940, 69633, 69635, 69605, 68943, 
69636, 69634, 69603, 68911, 68942
23627, 62640, 62630, 62410, 62420, 62641, 62631, 62411, 62421, 69635, 69605, 68943, 69636, 69638, 69608, 68946, 
69639, 69637, 69606, 68914, 68945
23628, 62641, 62631, 62411, 62421, 62642, 62632, 62412, 62422, 69638, 69608, 68946, 69639, 69641, 69611, 68949, 
69642, 69640, 69609, 68917, 68948
23629, 62642, 62632, 62412, 62422, 18035, 18034, 18012, 18013, 69641, 69611, 68949, 69642, 18624, 18621, 18579, 
18623, 69643, 69612, 68920, 68951
23630, 16540, 16539, 16517, 16518, 62643, 62633, 62413, 62423, 17129, 17128, 17084, 17130, 69645, 69615, 68953, 
69646, 69644, 69613, 68921, 68952
23631, 62643, 62633, 62413, 62423, 62644, 62634, 62414, 62424, 69645, 69615, 68953, 69646, 69648, 69618, 68956, 
69649, 69647, 69616, 68924, 68955
23632, 62644, 62634, 62414, 62424, 62645, 62635, 62415, 62425, 69648, 69618, 68956, 69649, 69651, 69621, 68959, 
69652, 69650, 69619, 68927, 68958
23633, 62645, 62635, 62415, 62425, 62646, 62636, 62416, 62426, 69651, 69621, 68959, 69652, 69654, 69624, 68962, 
69655, 69653, 69622, 68930, 68961
23634, 62646, 62636, 62416, 62426, 62647, 62637, 62417, 62427, 69654, 69624, 68962, 69655, 69657, 69627, 68965, 
69658, 69656, 69625, 68933, 68964
23635, 62647, 62637, 62417, 62427, 62648, 62638, 62418, 62428, 69657, 69627, 68965, 69658, 69660, 69630, 68968, 
69661, 69659, 69628, 68936, 68967
23636, 62648, 62638, 62418, 62428, 62649, 62639, 62419, 62429, 69660, 69630, 68968, 69661, 69663, 69633, 68971, 
69664, 69662, 69631, 68939, 68970
23637, 62649, 62639, 62419, 62429, 62650, 62640, 62420, 62430, 69663, 69633, 68971, 69664, 69666, 69636, 68974, 
69667, 69665, 69634, 68942, 68973
23638, 62650, 62640, 62420, 62430, 62651, 62641, 62421, 62431, 69666, 69636, 68974, 69667, 69669, 69639, 68977, 
69670, 69668, 69637, 68945, 68976
23639, 62651, 62641, 62421, 62431, 62652, 62642, 62422, 62432, 69669, 69639, 68977, 69670, 69672, 69642, 68980, 
69673, 69671, 69640, 68948, 68979
23640, 62652, 62642, 62422, 62432, 18036, 18035, 18013, 18014, 69672, 69642, 68980, 69673, 18626, 18623, 18581, 
18625, 69674, 69643, 68951, 68982
23641, 16541, 16540, 16518, 16519, 62653, 62643, 62423, 62433, 17131, 17130, 17086, 17132, 69676, 69646, 68984, 
69677, 69675, 69644, 68952, 68983
23642, 62653, 62643, 62423, 62433, 62654, 62644, 62424, 62434, 69676, 69646, 68984, 69677, 69679, 69649, 68987, 
69680, 69678, 69647, 68955, 68986
23643, 62654, 62644, 62424, 62434, 62655, 62645, 62425, 62435, 69679, 69649, 68987, 69680, 69682, 69652, 68990, 
69683, 69681, 69650, 68958, 68989
23644, 62655, 62645, 62425, 62435, 62656, 62646, 62426, 62436, 69682, 69652, 68990, 69683, 69685, 69655, 68993, 
69686, 69684, 69653, 68961, 68992
23645, 62656, 62646, 62426, 62436, 62657, 62647, 62427, 62437, 69685, 69655, 68993, 69686, 69688, 69658, 68996, 
69689, 69687, 69656, 68964, 68995
23646, 62657, 62647, 62427, 62437, 62658, 62648, 62428, 62438, 69688, 69658, 68996, 69689, 69691, 69661, 68999, 
69692, 69690, 69659, 68967, 68998
23647, 62658, 62648, 62428, 62438, 62659, 62649, 62429, 62439, 69691, 69661, 68999, 69692, 69694, 69664, 69002, 
69695, 69693, 69662, 68970, 69001
23648, 62659, 62649, 62429, 62439, 62660, 62650, 62430, 62440, 69694, 69664, 69002, 69695, 69697, 69667, 69005, 
69698, 69696, 69665, 68973, 69004
23649, 62660, 62650, 62430, 62440, 62661, 62651, 62431, 62441, 69697, 69667, 69005, 69698, 69700, 69670, 69008, 
69701, 69699, 69668, 68976, 69007
23650, 62661, 62651, 62431, 62441, 62662, 62652, 62432, 62442, 69700, 69670, 69008, 69701, 69703, 69673, 69011, 
69704, 69702, 69671, 68979, 69010
23651, 62662, 62652, 62432, 62442, 18037, 18036, 18014, 18015, 69703, 69673, 69011, 69704, 18628, 18625, 18583, 
18627, 69705, 69674, 68982, 69013
23652, 16542, 16541, 16519, 16520, 62663, 62653, 62433, 62443, 17133, 17132, 17088, 17134, 69707, 69677, 69015, 
69708, 69706, 69675, 68983, 69014
23653, 62663, 62653, 62433, 62443, 62664, 62654, 62434, 62444, 69707, 69677, 69015, 69708, 69710, 69680, 69018, 
69711, 69709, 69678, 68986, 69017
23654, 62664, 62654, 62434, 62444, 62665, 62655, 62435, 62445, 69710, 69680, 69018, 69711, 69713, 69683, 69021, 
69714, 69712, 69681, 68989, 69020
23655, 62665, 62655, 62435, 62445, 62666, 62656, 62436, 62446, 69713, 69683, 69021, 69714, 69716, 69686, 69024, 
69717, 69715, 69684, 68992, 69023
23656, 62666, 62656, 62436, 62446, 62667, 62657, 62437, 62447, 69716, 69686, 69024, 69717, 69719, 69689, 69027, 
69720, 69718, 69687, 68995, 69026
23657, 62667, 62657, 62437, 62447, 62668, 62658, 62438, 62448, 69719, 69689, 69027, 69720, 69722, 69692, 69030, 
69723, 69721, 69690, 68998, 69029
23658, 62668, 62658, 62438, 62448, 62669, 62659, 62439, 62449, 69722, 69692, 69030, 69723, 69725, 69695, 69033, 
69726, 69724, 69693, 69001, 69032
23659, 62669, 62659, 62439, 62449, 62670, 62660, 62440, 62450, 69725, 69695, 69033, 69726, 69728, 69698, 69036, 
69729, 69727, 69696, 69004, 69035
23660, 62670, 62660, 62440, 62450, 62671, 62661, 62441, 62451, 69728, 69698, 69036, 69729, 69731, 69701, 69039, 
69732, 69730, 69699, 69007, 69038
23661, 62671, 62661, 62441, 62451, 62672, 62662, 62442, 62452, 69731, 69701, 69039, 69732, 69734, 69704, 69042, 
69735, 69733, 69702, 69010, 69041
23662, 62672, 62662, 62442, 62452, 18038, 18037, 18015, 18016, 69734, 69704, 69042, 69735, 18630, 18627, 18585, 
18629, 69736, 69705, 69013, 69044
23663, 16543, 16542, 16520, 16521, 62673, 62663, 62443, 62453, 17135, 17134, 17090, 17136, 69738, 69708, 69046, 
69739, 69737, 69706, 69014, 69045
23664, 62673, 62663, 62443, 62453, 62674, 62664, 62444, 62454, 69738, 69708, 69046, 69739, 69741, 69711, 69049, 
69742, 69740, 69709, 69017, 69048
23665, 62674, 62664, 62444, 62454, 62675, 62665, 62445, 62455, 69741, 69711, 69049, 69742, 69744, 69714, 69052, 
69745, 69743, 69712, 69020, 69051
23666, 62675, 62665, 62445, 62455, 62676, 62666, 62446, 62456, 69744, 69714, 69052, 69745, 69747, 69717, 69055, 
69748, 69746, 69715, 69023, 69054
23667, 62676, 62666, 62446, 62456, 62677, 62667, 62447, 62457, 69747, 69717, 69055, 69748, 69750, 69720, 69058, 
69751, 69749, 69718, 69026, 69057
23668, 62677, 62667, 62447, 62457, 62678, 62668, 62448, 62458, 69750, 69720, 69058, 69751, 69753, 69723, 69061, 
69754, 69752, 69721, 69029, 69060
23669, 62678, 62668, 62448, 62458, 62679, 62669, 62449, 62459, 69753, 69723, 69061, 69754, 69756, 69726, 69064, 
69757, 69755, 69724, 69032, 69063
23670, 62679, 62669, 62449, 62459, 62680, 62670, 62450, 62460, 69756, 69726, 69064, 69757, 69759, 69729, 69067, 
69760, 69758, 69727, 69035, 69066
23671, 62680, 62670, 62450, 62460, 62681, 62671, 62451, 62461, 69759, 69729, 69067, 69760, 69762, 69732, 69070, 
69763, 69761, 69730, 69038, 69069
23672, 62681, 62671, 62451, 62461, 62682, 62672, 62452, 62462, 69762, 69732, 69070, 69763, 69765, 69735, 69073, 
69766, 69764, 69733, 69041, 69072
23673, 62682, 62672, 62452, 62462, 18039, 18038, 18016, 18017, 69765, 69735, 69073, 69766, 18632, 18629, 18587, 
18631, 69767, 69736, 69044, 69075
23674, 16544, 16543, 16521, 16522, 62683, 62673, 62453, 62463, 17137, 17136, 17092, 17138, 69769, 69739, 69077, 
69770, 69768, 69737, 69045, 69076
23675, 62683, 62673, 62453, 62463, 62684, 62674, 62454, 62464, 69769, 69739, 69077, 69770, 69772, 69742, 69080, 
69773, 69771, 69740, 69048, 69079
23676, 62684, 62674, 62454, 62464, 62685, 62675, 62455, 62465, 69772, 69742, 69080, 69773, 69775, 69745, 69083, 
69776, 69774, 69743, 69051, 69082
23677, 62685, 62675, 62455, 62465, 62686, 62676, 62456, 62466, 69775, 69745, 69083, 69776, 69778, 69748, 69086, 
69779, 69777, 69746, 69054, 69085
23678, 62686, 62676, 62456, 62466, 62687, 62677, 62457, 62467, 69778, 69748, 69086, 69779, 69781, 69751, 69089, 
69782, 69780, 69749, 69057, 69088
23679, 62687, 62677, 62457, 62467, 62688, 62678, 62458, 62468, 69781, 69751, 69089, 69782, 69784, 69754, 69092, 
69785, 69783, 69752, 69060, 69091
23680, 62688, 62678, 62458, 62468, 62689, 62679, 62459, 62469, 69784, 69754, 69092, 69785, 69787, 69757, 69095, 
69788, 69786, 69755, 69063, 69094
23681, 62689, 62679, 62459, 62469, 62690, 62680, 62460, 62470, 69787, 69757, 69095, 69788, 69790, 69760, 69098, 
69791, 69789, 69758, 69066, 69097
23682, 62690, 62680, 62460, 62470, 62691, 62681, 62461, 62471, 69790, 69760, 69098, 69791, 69793, 69763, 69101, 
69794, 69792, 69761, 69069, 69100
23683, 62691, 62681, 62461, 62471, 62692, 62682, 62462, 62472, 69793, 69763, 69101, 69794, 69796, 69766, 69104, 
69797, 69795, 69764, 69072, 69103
23684, 62692, 62682, 62462, 62472, 18040, 18039, 18017, 18018, 69796, 69766, 69104, 69797, 18634, 18631, 18589, 
18633, 69798, 69767, 69075, 69106
23685, 16545, 16544, 16522, 16523, 62693, 62683, 62463, 62473, 17139, 17138, 17094, 17140, 69800, 69770, 69108, 
69801, 69799, 69768, 69076, 69107
23686, 62693, 62683, 62463, 62473, 62694, 62684, 62464, 62474, 69800, 69770, 69108, 69801, 69803, 69773, 69111, 
69804, 69802, 69771, 69079, 69110
23687, 62694, 62684, 62464, 62474, 62695, 62685, 62465, 62475, 69803, 69773, 69111, 69804, 69806, 69776, 69114, 
69807, 69805, 69774, 69082, 69113
23688, 62695, 62685, 62465, 62475, 62696, 62686, 62466, 62476, 69806, 69776, 69114, 69807, 69809, 69779, 69117, 
69810, 69808, 69777, 69085, 69116
23689, 62696, 62686, 62466, 62476, 62697, 62687, 62467, 62477, 69809, 69779, 69117, 69810, 69812, 69782, 69120, 
69813, 69811, 69780, 69088, 69119
23690, 62697, 62687, 62467, 62477, 62698, 62688, 62468, 62478, 69812, 69782, 69120, 69813, 69815, 69785, 69123, 
69816, 69814, 69783, 69091, 69122
23691, 62698, 62688, 62468, 62478, 62699, 62689, 62469, 62479, 69815, 69785, 69123, 69816, 69818, 69788, 69126, 
69819, 69817, 69786, 69094, 69125
23692, 62699, 62689, 62469, 62479, 62700, 62690, 62470, 62480, 69818, 69788, 69126, 69819, 69821, 69791, 69129, 
69822, 69820, 69789, 69097, 69128
23693, 62700, 62690, 62470, 62480, 62701, 62691, 62471, 62481, 69821, 69791, 69129, 69822, 69824, 69794, 69132, 
69825, 69823, 69792, 69100, 69131
23694, 62701, 62691, 62471, 62481, 62702, 62692, 62472, 62482, 69824, 69794, 69132, 69825, 69827, 69797, 69135, 
69828, 69826, 69795, 69103, 69134
23695, 62702, 62692, 62472, 62482, 18041, 18040, 18018, 18019, 69827, 69797, 69135, 69828, 18636, 18633, 18591, 
18635, 69829, 69798, 69106, 69137
23696, 16546, 16545, 16523, 16524, 62703, 62693, 62473, 62483, 17141, 17140, 17096, 17142, 69831, 69801, 69139, 
69832, 69830, 69799, 69107, 69138
23697, 62703, 62693, 62473, 62483, 62704, 62694, 62474, 62484, 69831, 69801, 69139, 69832, 69834, 69804, 69142, 
69835, 69833, 69802, 69110, 69141
23698, 62704, 62694, 62474, 62484, 62705, 62695, 62475, 62485, 69834, 69804, 69142, 69835, 69837, 69807, 69145, 
69838, 69836, 69805, 69113, 69144
23699, 62705, 62695, 62475, 62485, 62706, 62696, 62476, 62486, 69837, 69807, 69145, 69838, 69840, 69810, 69148, 
69841, 69839, 69808, 69116, 69147
23700, 62706, 62696, 62476, 62486, 62707, 62697, 62477, 62487, 69840, 69810, 69148, 69841, 69843, 69813, 69151, 
69844, 69842, 69811, 69119, 69150
23701, 62707, 62697, 62477, 62487, 62708, 62698, 62478, 62488, 69843, 69813, 69151, 69844, 69846, 69816, 69154, 
69847, 69845, 69814, 69122, 69153
23702, 62708, 62698, 62478, 62488, 62709, 62699, 62479, 62489, 69846, 69816, 69154, 69847, 69849, 69819, 69157, 
69850, 69848, 69817, 69125, 69156
23703, 62709, 62699, 62479, 62489, 62710, 62700, 62480, 62490, 69849, 69819, 69157, 69850, 69852, 69822, 69160, 
69853, 69851, 69820, 69128, 69159
23704, 62710, 62700, 62480, 62490, 62711, 62701, 62481, 62491, 69852, 69822, 69160, 69853, 69855, 69825, 69163, 
69856, 69854, 69823, 69131, 69162
23705, 62711, 62701, 62481, 62491, 62712, 62702, 62482, 62492, 69855, 69825, 69163, 69856, 69858, 69828, 69166, 
69859, 69857, 69826, 69134, 69165
23706, 62712, 62702, 62482, 62492, 18042, 18041, 18019, 18020, 69858, 69828, 69166, 69859, 18638, 18635, 18593, 
18637, 69860, 69829, 69137, 69168
23707, 16547, 16546, 16524, 16525, 62713, 62703, 62483, 62493, 17143, 17142, 17098, 17144, 69862, 69832, 69170, 
69863, 69861, 69830, 69138, 69169
23708, 62713, 62703, 62483, 62493, 62714, 62704, 62484, 62494, 69862, 69832, 69170, 69863, 69865, 69835, 69173, 
69866, 69864, 69833, 69141, 69172
23709, 62714, 62704, 62484, 62494, 62715, 62705, 62485, 62495, 69865, 69835, 69173, 69866, 69868, 69838, 69176, 
69869, 69867, 69836, 69144, 69175
23710, 62715, 62705, 62485, 62495, 62716, 62706, 62486, 62496, 69868, 69838, 69176, 69869, 69871, 69841, 69179, 
69872, 69870, 69839, 69147, 69178
23711, 62716, 62706, 62486, 62496, 62717, 62707, 62487, 62497, 69871, 69841, 69179, 69872, 69874, 69844, 69182, 
69875, 69873, 69842, 69150, 69181
23712, 62717, 62707, 62487, 62497, 62718, 62708, 62488, 62498, 69874, 69844, 69182, 69875, 69877, 69847, 69185, 
69878, 69876, 69845, 69153, 69184
23713, 62718, 62708, 62488, 62498, 62719, 62709, 62489, 62499, 69877, 69847, 69185, 69878, 69880, 69850, 69188, 
69881, 69879, 69848, 69156, 69187
23714, 62719, 62709, 62489, 62499, 62720, 62710, 62490, 62500, 69880, 69850, 69188, 69881, 69883, 69853, 69191, 
69884, 69882, 69851, 69159, 69190
23715, 62720, 62710, 62490, 62500, 62721, 62711, 62491, 62501, 69883, 69853, 69191, 69884, 69886, 69856, 69194, 
69887, 69885, 69854, 69162, 69193
23716, 62721, 62711, 62491, 62501, 62722, 62712, 62492, 62502, 69886, 69856, 69194, 69887, 69889, 69859, 69197, 
69890, 69888, 69857, 69165, 69196
23717, 62722, 62712, 62492, 62502, 18043, 18042, 18020, 18021, 69889, 69859, 69197, 69890, 18640, 18637, 18595, 
18639, 69891, 69860, 69168, 69199
23718, 16548, 16547, 16525, 16526, 62723, 62713, 62493, 62503, 17145, 17144, 17100, 17146, 69893, 69863, 69201, 
69894, 69892, 69861, 69169, 69200
23719, 62723, 62713, 62493, 62503, 62724, 62714, 62494, 62504, 69893, 69863, 69201, 69894, 69896, 69866, 69204, 
69897, 69895, 69864, 69172, 69203
23720, 62724, 62714, 62494, 62504, 62725, 62715, 62495, 62505, 69896, 69866, 69204, 69897, 69899, 69869, 69207, 
69900, 69898, 69867, 69175, 69206
23721, 62725, 62715, 62495, 62505, 62726, 62716, 62496, 62506, 69899, 69869, 69207, 69900, 69902, 69872, 69210, 
69903, 69901, 69870, 69178, 69209
23722, 62726, 62716, 62496, 62506, 62727, 62717, 62497, 62507, 69902, 69872, 69210, 69903, 69905, 69875, 69213, 
69906, 69904, 69873, 69181, 69212
23723, 62727, 62717, 62497, 62507, 62728, 62718, 62498, 62508, 69905, 69875, 69213, 69906, 69908, 69878, 69216, 
69909, 69907, 69876, 69184, 69215
23724, 62728, 62718, 62498, 62508, 62729, 62719, 62499, 62509, 69908, 69878, 69216, 69909, 69911, 69881, 69219, 
69912, 69910, 69879, 69187, 69218
23725, 62729, 62719, 62499, 62509, 62730, 62720, 62500, 62510, 69911, 69881, 69219, 69912, 69914, 69884, 69222, 
69915, 69913, 69882, 69190, 69221
23726, 62730, 62720, 62500, 62510, 62731, 62721, 62501, 62511, 69914, 69884, 69222, 69915, 69917, 69887, 69225, 
69918, 69916, 69885, 69193, 69224
23727, 62731, 62721, 62501, 62511, 62732, 62722, 62502, 62512, 69917, 69887, 69225, 69918, 69920, 69890, 69228, 
69921, 69919, 69888, 69196, 69227
23728, 62732, 62722, 62502, 62512, 18044, 18043, 18021, 18022, 69920, 69890, 69228, 69921, 18642, 18639, 18597, 
18641, 69922, 69891, 69199, 69230
23729, 1638, 16548, 16526, 1637, 20163, 62723, 62503, 20153, 17147, 17146, 17102, 1660, 69923, 69894, 69231, 
20428, 20427, 69892, 69200, 20406
23730, 20163, 62723, 62503, 20153, 20164, 62724, 62504, 20154, 69923, 69894, 69231, 20428, 69924, 69897, 69232, 
20430, 20429, 69895, 69203, 20408
23731, 20164, 62724, 62504, 20154, 20165, 62725, 62505, 20155, 69924, 69897, 69232, 20430, 69925, 69900, 69233, 
20432, 20431, 69898, 69206, 20410
23732, 20165, 62725, 62505, 20155, 20166, 62726, 62506, 20156, 69925, 69900, 69233, 20432, 69926, 69903, 69234, 
20434, 20433, 69901, 69209, 20412
23733, 20166, 62726, 62506, 20156, 20167, 62727, 62507, 20157, 69926, 69903, 69234, 20434, 69927, 69906, 69235, 
20436, 20435, 69904, 69212, 20414
23734, 20167, 62727, 62507, 20157, 20168, 62728, 62508, 20158, 69927, 69906, 69235, 20436, 69928, 69909, 69236, 
20438, 20437, 69907, 69215, 20416
23735, 20168, 62728, 62508, 20158, 20169, 62729, 62509, 20159, 69928, 69909, 69236, 20438, 69929, 69912, 69237, 
20440, 20439, 69910, 69218, 20418
23736, 20169, 62729, 62509, 20159, 20170, 62730, 62510, 20160, 69929, 69912, 69237, 20440, 69930, 69915, 69238, 
20442, 20441, 69913, 69221, 20420
23737, 20170, 62730, 62510, 20160, 20171, 62731, 62511, 20161, 69930, 69915, 69238, 20442, 69931, 69918, 69239, 
20444, 20443, 69916, 69224, 20422
23738, 20171, 62731, 62511, 20161, 20172, 62732, 62512, 20162, 69931, 69918, 69239, 20444, 69932, 69921, 69240, 
20446, 20445, 69919, 69227, 20424
23739, 20172, 62732, 62512, 20162, 1773, 18044, 18022, 1772, 69932, 69921, 69240, 20446, 18643, 18641, 18598, 
1795, 20447, 69922, 69230, 20426
23740, 16549, 1594, 1593, 16527, 62733, 19481, 19471, 62513, 17148, 1616, 17103, 17149, 69934, 19756, 69242, 
69935, 69933, 19757, 19736, 69241
23741, 62733, 19481, 19471, 62513, 62734, 19482, 19472, 62514, 69934, 19756, 69242, 69935, 69937, 19758, 69245, 
69938, 69936, 19759, 19738, 69244
23742, 62734, 19482, 19472, 62514, 62735, 19483, 19473, 62515, 69937, 19758, 69245, 69938, 69940, 19760, 69248, 
69941, 69939, 19761, 19740, 69247
23743, 62735, 19483, 19473, 62515, 62736, 19484, 19474, 62516, 69940, 19760, 69248, 69941, 69943, 19762, 69251, 
69944, 69942, 19763, 19742, 69250
23744, 62736, 19484, 19474, 62516, 62737, 19485, 19475, 62517, 69943, 19762, 69251, 69944, 69946, 19764, 69254, 
69947, 69945, 19765, 19744, 69253
23745, 62737, 19485, 19475, 62517, 62738, 19486, 19476, 62518, 69946, 19764, 69254, 69947, 69949, 19766, 69257, 
69950, 69948, 19767, 19746, 69256
23746, 62738, 19486, 19476, 62518, 62739, 19487, 19477, 62519, 69949, 19766, 69257, 69950, 69952, 19768, 69260, 
69953, 69951, 19769, 19748, 69259
23747, 62739, 19487, 19477, 62519, 62740, 19488, 19478, 62520, 69952, 19768, 69260, 69953, 69955, 19770, 69263, 
69956, 69954, 19771, 19750, 69262
23748, 62740, 19488, 19478, 62520, 62741, 19489, 19479, 62521, 69955, 19770, 69263, 69956, 69958, 19772, 69266, 
69959, 69957, 19773, 19752, 69265
23749, 62741, 19489, 19479, 62521, 62742, 19490, 19480, 62522, 69958, 19772, 69266, 69959, 69961, 19774, 69269, 
69962, 69960, 19775, 19754, 69268
23750, 62742, 19490, 19480, 62522, 18045, 1729, 1728, 18023, 69961, 19774, 69269, 69962, 18645, 1751, 18600, 
18644, 69963, 19776, 19755, 69271
23751, 16550, 16549, 16527, 16528, 62743, 62733, 62513, 62523, 17150, 17149, 17105, 17151, 69965, 69935, 69273, 
69966, 69964, 69933, 69241, 69272
23752, 62743, 62733, 62513, 62523, 62744, 62734, 62514, 62524, 69965, 69935, 69273, 69966, 69968, 69938, 69276, 
69969, 69967, 69936, 69244, 69275
23753, 62744, 62734, 62514, 62524, 62745, 62735, 62515, 62525, 69968, 69938, 69276, 69969, 69971, 69941, 69279, 
69972, 69970, 69939, 69247, 69278
23754, 62745, 62735, 62515, 62525, 62746, 62736, 62516, 62526, 69971, 69941, 69279, 69972, 69974, 69944, 69282, 
69975, 69973, 69942, 69250, 69281
23755, 62746, 62736, 62516, 62526, 62747, 62737, 62517, 62527, 69974, 69944, 69282, 69975, 69977, 69947, 69285, 
69978, 69976, 69945, 69253, 69284
23756, 62747, 62737, 62517, 62527, 62748, 62738, 62518, 62528, 69977, 69947, 69285, 69978, 69980, 69950, 69288, 
69981, 69979, 69948, 69256, 69287
23757, 62748, 62738, 62518, 62528, 62749, 62739, 62519, 62529, 69980, 69950, 69288, 69981, 69983, 69953, 69291, 
69984, 69982, 69951, 69259, 69290
23758, 62749, 62739, 62519, 62529, 62750, 62740, 62520, 62530, 69983, 69953, 69291, 69984, 69986, 69956, 69294, 
69987, 69985, 69954, 69262, 69293
23759, 62750, 62740, 62520, 62530, 62751, 62741, 62521, 62531, 69986, 69956, 69294, 69987, 69989, 69959, 69297, 
69990, 69988, 69957, 69265, 69296
23760, 62751, 62741, 62521, 62531, 62752, 62742, 62522, 62532, 69989, 69959, 69297, 69990, 69992, 69962, 69300, 
69993, 69991, 69960, 69268, 69299
23761, 62752, 62742, 62522, 62532, 18046, 18045, 18023, 18024, 69992, 69962, 69300, 69993, 18647, 18644, 18602, 
18646, 69994, 69963, 69271, 69302
23762, 16551, 16550, 16528, 16529, 62753, 62743, 62523, 62533, 17152, 17151, 17107, 17153, 69996, 69966, 69304, 
69997, 69995, 69964, 69272, 69303
23763, 62753, 62743, 62523, 62533, 62754, 62744, 62524, 62534, 69996, 69966, 69304, 69997, 69999, 69969, 69307, 
70000, 69998, 69967, 69275, 69306
23764, 62754, 62744, 62524, 62534, 62755, 62745, 62525, 62535, 69999, 69969, 69307, 70000, 70002, 69972, 69310, 
70003, 70001, 69970, 69278, 69309
23765, 62755, 62745, 62525, 62535, 62756, 62746, 62526, 62536, 70002, 69972, 69310, 70003, 70005, 69975, 69313, 
70006, 70004, 69973, 69281, 69312
23766, 62756, 62746, 62526, 62536, 62757, 62747, 62527, 62537, 70005, 69975, 69313, 70006, 70008, 69978, 69316, 
70009, 70007, 69976, 69284, 69315
23767, 62757, 62747, 62527, 62537, 62758, 62748, 62528, 62538, 70008, 69978, 69316, 70009, 70011, 69981, 69319, 
70012, 70010, 69979, 69287, 69318
23768, 62758, 62748, 62528, 62538, 62759, 62749, 62529, 62539, 70011, 69981, 69319, 70012, 70014, 69984, 69322, 
70015, 70013, 69982, 69290, 69321
23769, 62759, 62749, 62529, 62539, 62760, 62750, 62530, 62540, 70014, 69984, 69322, 70015, 70017, 69987, 69325, 
70018, 70016, 69985, 69293, 69324
23770, 62760, 62750, 62530, 62540, 62761, 62751, 62531, 62541, 70017, 69987, 69325, 70018, 70020, 69990, 69328, 
70021, 70019, 69988, 69296, 69327
23771, 62761, 62751, 62531, 62541, 62762, 62752, 62532, 62542, 70020, 69990, 69328, 70021, 70023, 69993, 69331, 
70024, 70022, 69991, 69299, 69330
23772, 62762, 62752, 62532, 62542, 18047, 18046, 18024, 18025, 70023, 69993, 69331, 70024, 18649, 18646, 18604, 
18648, 70025, 69994, 69302, 69333
23773, 16552, 16551, 16529, 16530, 62763, 62753, 62533, 62543, 17154, 17153, 17109, 17155, 70027, 69997, 69335, 
70028, 70026, 69995, 69303, 69334
23774, 62763, 62753, 62533, 62543, 62764, 62754, 62534, 62544, 70027, 69997, 69335, 70028, 70030, 70000, 69338, 
70031, 70029, 69998, 69306, 69337
23775, 62764, 62754, 62534, 62544, 62765, 62755, 62535, 62545, 70030, 70000, 69338, 70031, 70033, 70003, 69341, 
70034, 70032, 70001, 69309, 69340
23776, 62765, 62755, 62535, 62545, 62766, 62756, 62536, 62546, 70033, 70003, 69341, 70034, 70036, 70006, 69344, 
70037, 70035, 70004, 69312, 69343
23777, 62766, 62756, 62536, 62546, 62767, 62757, 62537, 62547, 70036, 70006, 69344, 70037, 70039, 70009, 69347, 
70040, 70038, 70007, 69315, 69346
23778, 62767, 62757, 62537, 62547, 62768, 62758, 62538, 62548, 70039, 70009, 69347, 70040, 70042, 70012, 69350, 
70043, 70041, 70010, 69318, 69349
23779, 62768, 62758, 62538, 62548, 62769, 62759, 62539, 62549, 70042, 70012, 69350, 70043, 70045, 70015, 69353, 
70046, 70044, 70013, 69321, 69352
23780, 62769, 62759, 62539, 62549, 62770, 62760, 62540, 62550, 70045, 70015, 69353, 70046, 70048, 70018, 69356, 
70049, 70047, 70016, 69324, 69355
23781, 62770, 62760, 62540, 62550, 62771, 62761, 62541, 62551, 70048, 70018, 69356, 70049, 70051, 70021, 69359, 
70052, 70050, 70019, 69327, 69358
23782, 62771, 62761, 62541, 62551, 62772, 62762, 62542, 62552, 70051, 70021, 69359, 70052, 70054, 70024, 69362, 
70055, 70053, 70022, 69330, 69361
23783, 62772, 62762, 62542, 62552, 18048, 18047, 18025, 18026, 70054, 70024, 69362, 70055, 18651, 18648, 18606, 
18650, 70056, 70025, 69333, 69364
23784, 16553, 16552, 16530, 16531, 62773, 62763, 62543, 62553, 17156, 17155, 17111, 17157, 70058, 70028, 69366, 
70059, 70057, 70026, 69334, 69365
