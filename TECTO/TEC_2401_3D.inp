27865, 16908, 16907, 16885, 16886, 66323, 66313, 66093, 66103, 17882, 17881, 17837, 17883, 81223, 81193, 80531, 
81224, 81222, 81191, 80499, 80530
27866, 66323, 66313, 66093, 66103, 66324, 66314, 66094, 66104, 81223, 81193, 80531, 81224, 81226, 81196, 80534, 
81227, 81225, 81194, 80502, 80533
27867, 66324, 66314, 66094, 66104, 66325, 66315, 66095, 66105, 81226, 81196, 80534, 81227, 81229, 81199, 80537, 
81230, 81228, 81197, 80505, 80536
27868, 66325, 66315, 66095, 66105, 66326, 66316, 66096, 66106, 81229, 81199, 80537, 81230, 81232, 81202, 80540, 
81233, 81231, 81200, 80508, 80539
27869, 66326, 66316, 66096, 66106, 66327, 66317, 66097, 66107, 81232, 81202, 80540, 81233, 81235, 81205, 80543, 
81236, 81234, 81203, 80511, 80542
27870, 66327, 66317, 66097, 66107, 66328, 66318, 66098, 66108, 81235, 81205, 80543, 81236, 81238, 81208, 80546, 
81239, 81237, 81206, 80514, 80545
27871, 66328, 66318, 66098, 66108, 66329, 66319, 66099, 66109, 81238, 81208, 80546, 81239, 81241, 81211, 80549, 
81242, 81240, 81209, 80517, 80548
27872, 66329, 66319, 66099, 66109, 66330, 66320, 66100, 66110, 81241, 81211, 80549, 81242, 81244, 81214, 80552, 
81245, 81243, 81212, 80520, 80551
27873, 66330, 66320, 66100, 66110, 66331, 66321, 66101, 66111, 81244, 81214, 80552, 81245, 81247, 81217, 80555, 
81248, 81246, 81215, 80523, 80554
27874, 66331, 66321, 66101, 66111, 66332, 66322, 66102, 66112, 81247, 81217, 80555, 81248, 81250, 81220, 80558, 
81251, 81249, 81218, 80526, 80557
27875, 66332, 66322, 66102, 66112, 18404, 18403, 18381, 18382, 81250, 81220, 80558, 81251, 19379, 19376, 19334, 
19378, 81252, 81221, 80529, 80560
27876, 16909, 16908, 16886, 16887, 66333, 66323, 66103, 66113, 17884, 17883, 17839, 17885, 81254, 81224, 80562, 
81255, 81253, 81222, 80530, 80561
27877, 66333, 66323, 66103, 66113, 66334, 66324, 66104, 66114, 81254, 81224, 80562, 81255, 81257, 81227, 80565, 
81258, 81256, 81225, 80533, 80564
27878, 66334, 66324, 66104, 66114, 66335, 66325, 66105, 66115, 81257, 81227, 80565, 81258, 81260, 81230, 80568, 
81261, 81259, 81228, 80536, 80567
27879, 66335, 66325, 66105, 66115, 66336, 66326, 66106, 66116, 81260, 81230, 80568, 81261, 81263, 81233, 80571, 
81264, 81262, 81231, 80539, 80570
27880, 66336, 66326, 66106, 66116, 66337, 66327, 66107, 66117, 81263, 81233, 80571, 81264, 81266, 81236, 80574, 
81267, 81265, 81234, 80542, 80573
27881, 66337, 66327, 66107, 66117, 66338, 66328, 66108, 66118, 81266, 81236, 80574, 81267, 81269, 81239, 80577, 
81270, 81268, 81237, 80545, 80576
27882, 66338, 66328, 66108, 66118, 66339, 66329, 66109, 66119, 81269, 81239, 80577, 81270, 81272, 81242, 80580, 
81273, 81271, 81240, 80548, 80579
27883, 66339, 66329, 66109, 66119, 66340, 66330, 66110, 66120, 81272, 81242, 80580, 81273, 81275, 81245, 80583, 
81276, 81274, 81243, 80551, 80582
27884, 66340, 66330, 66110, 66120, 66341, 66331, 66111, 66121, 81275, 81245, 80583, 81276, 81278, 81248, 80586, 
81279, 81277, 81246, 80554, 80585
27885, 66341, 66331, 66111, 66121, 66342, 66332, 66112, 66122, 81278, 81248, 80586, 81279, 81281, 81251, 80589, 
81282, 81280, 81249, 80557, 80588
27886, 66342, 66332, 66112, 66122, 18405, 18404, 18382, 18383, 81281, 81251, 80589, 81282, 19381, 19378, 19336, 
19380, 81283, 81252, 80560, 80591
27887, 16910, 16909, 16887, 16888, 66343, 66333, 66113, 66123, 17886, 17885, 17841, 17887, 81285, 81255, 80593, 
81286, 81284, 81253, 80561, 80592
27888, 66343, 66333, 66113, 66123, 66344, 66334, 66114, 66124, 81285, 81255, 80593, 81286, 81288, 81258, 80596, 
81289, 81287, 81256, 80564, 80595
27889, 66344, 66334, 66114, 66124, 66345, 66335, 66115, 66125, 81288, 81258, 80596, 81289, 81291, 81261, 80599, 
81292, 81290, 81259, 80567, 80598
27890, 66345, 66335, 66115, 66125, 66346, 66336, 66116, 66126, 81291, 81261, 80599, 81292, 81294, 81264, 80602, 
81295, 81293, 81262, 80570, 80601
27891, 66346, 66336, 66116, 66126, 66347, 66337, 66117, 66127, 81294, 81264, 80602, 81295, 81297, 81267, 80605, 
81298, 81296, 81265, 80573, 80604
27892, 66347, 66337, 66117, 66127, 66348, 66338, 66118, 66128, 81297, 81267, 80605, 81298, 81300, 81270, 80608, 
81301, 81299, 81268, 80576, 80607
27893, 66348, 66338, 66118, 66128, 66349, 66339, 66119, 66129, 81300, 81270, 80608, 81301, 81303, 81273, 80611, 
81304, 81302, 81271, 80579, 80610
27894, 66349, 66339, 66119, 66129, 66350, 66340, 66120, 66130, 81303, 81273, 80611, 81304, 81306, 81276, 80614, 
81307, 81305, 81274, 80582, 80613
27895, 66350, 66340, 66120, 66130, 66351, 66341, 66121, 66131, 81306, 81276, 80614, 81307, 81309, 81279, 80617, 
81310, 81308, 81277, 80585, 80616
27896, 66351, 66341, 66121, 66131, 66352, 66342, 66122, 66132, 81309, 81279, 80617, 81310, 81312, 81282, 80620, 
81313, 81311, 81280, 80588, 80619
27897, 66352, 66342, 66122, 66132, 18406, 18405, 18383, 18384, 81312, 81282, 80620, 81313, 19383, 19380, 19338, 
19382, 81314, 81283, 80591, 80622
27898, 16911, 16910, 16888, 16889, 66353, 66343, 66123, 66133, 17888, 17887, 17843, 17889, 81316, 81286, 80624, 
81317, 81315, 81284, 80592, 80623
27899, 66353, 66343, 66123, 66133, 66354, 66344, 66124, 66134, 81316, 81286, 80624, 81317, 81319, 81289, 80627, 
81320, 81318, 81287, 80595, 80626
27900, 66354, 66344, 66124, 66134, 66355, 66345, 66125, 66135, 81319, 81289, 80627, 81320, 81322, 81292, 80630, 
81323, 81321, 81290, 80598, 80629
27901, 66355, 66345, 66125, 66135, 66356, 66346, 66126, 66136, 81322, 81292, 80630, 81323, 81325, 81295, 80633, 
81326, 81324, 81293, 80601, 80632
27902, 66356, 66346, 66126, 66136, 66357, 66347, 66127, 66137, 81325, 81295, 80633, 81326, 81328, 81298, 80636, 
81329, 81327, 81296, 80604, 80635
27903, 66357, 66347, 66127, 66137, 66358, 66348, 66128, 66138, 81328, 81298, 80636, 81329, 81331, 81301, 80639, 
81332, 81330, 81299, 80607, 80638
27904, 66358, 66348, 66128, 66138, 66359, 66349, 66129, 66139, 81331, 81301, 80639, 81332, 81334, 81304, 80642, 
81335, 81333, 81302, 80610, 80641
27905, 66359, 66349, 66129, 66139, 66360, 66350, 66130, 66140, 81334, 81304, 80642, 81335, 81337, 81307, 80645, 
81338, 81336, 81305, 80613, 80644
27906, 66360, 66350, 66130, 66140, 66361, 66351, 66131, 66141, 81337, 81307, 80645, 81338, 81340, 81310, 80648, 
81341, 81339, 81308, 80616, 80647
27907, 66361, 66351, 66131, 66141, 66362, 66352, 66132, 66142, 81340, 81310, 80648, 81341, 81343, 81313, 80651, 
81344, 81342, 81311, 80619, 80650
27908, 66362, 66352, 66132, 66142, 18407, 18406, 18384, 18385, 81343, 81313, 80651, 81344, 19385, 19382, 19340, 
19384, 81345, 81314, 80622, 80653
27909, 16912, 16911, 16889, 16890, 66363, 66353, 66133, 66143, 17890, 17889, 17845, 17891, 81347, 81317, 80655, 
81348, 81346, 81315, 80623, 80654
27910, 66363, 66353, 66133, 66143, 66364, 66354, 66134, 66144, 81347, 81317, 80655, 81348, 81350, 81320, 80658, 
81351, 81349, 81318, 80626, 80657
27911, 66364, 66354, 66134, 66144, 66365, 66355, 66135, 66145, 81350, 81320, 80658, 81351, 81353, 81323, 80661, 
81354, 81352, 81321, 80629, 80660
27912, 66365, 66355, 66135, 66145, 66366, 66356, 66136, 66146, 81353, 81323, 80661, 81354, 81356, 81326, 80664, 
81357, 81355, 81324, 80632, 80663
27913, 66366, 66356, 66136, 66146, 66367, 66357, 66137, 66147, 81356, 81326, 80664, 81357, 81359, 81329, 80667, 
81360, 81358, 81327, 80635, 80666
27914, 66367, 66357, 66137, 66147, 66368, 66358, 66138, 66148, 81359, 81329, 80667, 81360, 81362, 81332, 80670, 
81363, 81361, 81330, 80638, 80669
27915, 66368, 66358, 66138, 66148, 66369, 66359, 66139, 66149, 81362, 81332, 80670, 81363, 81365, 81335, 80673, 
81366, 81364, 81333, 80641, 80672
27916, 66369, 66359, 66139, 66149, 66370, 66360, 66140, 66150, 81365, 81335, 80673, 81366, 81368, 81338, 80676, 
81369, 81367, 81336, 80644, 80675
27917, 66370, 66360, 66140, 66150, 66371, 66361, 66141, 66151, 81368, 81338, 80676, 81369, 81371, 81341, 80679, 
81372, 81370, 81339, 80647, 80678
27918, 66371, 66361, 66141, 66151, 66372, 66362, 66142, 66152, 81371, 81341, 80679, 81372, 81374, 81344, 80682, 
81375, 81373, 81342, 80650, 80681
27919, 66372, 66362, 66142, 66152, 18408, 18407, 18385, 18386, 81374, 81344, 80682, 81375, 19387, 19384, 19342, 
19386, 81376, 81345, 80653, 80684
27920, 16913, 16912, 16890, 16891, 66373, 66363, 66143, 66153, 17892, 17891, 17847, 17893, 81378, 81348, 80686, 
81379, 81377, 81346, 80654, 80685
27921, 66373, 66363, 66143, 66153, 66374, 66364, 66144, 66154, 81378, 81348, 80686, 81379, 81381, 81351, 80689, 
81382, 81380, 81349, 80657, 80688
27922, 66374, 66364, 66144, 66154, 66375, 66365, 66145, 66155, 81381, 81351, 80689, 81382, 81384, 81354, 80692, 
81385, 81383, 81352, 80660, 80691
27923, 66375, 66365, 66145, 66155, 66376, 66366, 66146, 66156, 81384, 81354, 80692, 81385, 81387, 81357, 80695, 
81388, 81386, 81355, 80663, 80694
27924, 66376, 66366, 66146, 66156, 66377, 66367, 66147, 66157, 81387, 81357, 80695, 81388, 81390, 81360, 80698, 
81391, 81389, 81358, 80666, 80697
27925, 66377, 66367, 66147, 66157, 66378, 66368, 66148, 66158, 81390, 81360, 80698, 81391, 81393, 81363, 80701, 
81394, 81392, 81361, 80669, 80700
27926, 66378, 66368, 66148, 66158, 66379, 66369, 66149, 66159, 81393, 81363, 80701, 81394, 81396, 81366, 80704, 
81397, 81395, 81364, 80672, 80703
27927, 66379, 66369, 66149, 66159, 66380, 66370, 66150, 66160, 81396, 81366, 80704, 81397, 81399, 81369, 80707, 
81400, 81398, 81367, 80675, 80706
27928, 66380, 66370, 66150, 66160, 66381, 66371, 66151, 66161, 81399, 81369, 80707, 81400, 81402, 81372, 80710, 
81403, 81401, 81370, 80678, 80709
27929, 66381, 66371, 66151, 66161, 66382, 66372, 66152, 66162, 81402, 81372, 80710, 81403, 81405, 81375, 80713, 
81406, 81404, 81373, 80681, 80712
27930, 66382, 66372, 66152, 66162, 18409, 18408, 18386, 18387, 81405, 81375, 80713, 81406, 19389, 19386, 19344, 
19388, 81407, 81376, 80684, 80715
27931, 16914, 16913, 16891, 16892, 66383, 66373, 66153, 66163, 17894, 17893, 17849, 17895, 81409, 81379, 80717, 
81410, 81408, 81377, 80685, 80716
27932, 66383, 66373, 66153, 66163, 66384, 66374, 66154, 66164, 81409, 81379, 80717, 81410, 81412, 81382, 80720, 
81413, 81411, 81380, 80688, 80719
27933, 66384, 66374, 66154, 66164, 66385, 66375, 66155, 66165, 81412, 81382, 80720, 81413, 81415, 81385, 80723, 
81416, 81414, 81383, 80691, 80722
27934, 66385, 66375, 66155, 66165, 66386, 66376, 66156, 66166, 81415, 81385, 80723, 81416, 81418, 81388, 80726, 
81419, 81417, 81386, 80694, 80725
27935, 66386, 66376, 66156, 66166, 66387, 66377, 66157, 66167, 81418, 81388, 80726, 81419, 81421, 81391, 80729, 
81422, 81420, 81389, 80697, 80728
27936, 66387, 66377, 66157, 66167, 66388, 66378, 66158, 66168, 81421, 81391, 80729, 81422, 81424, 81394, 80732, 
81425, 81423, 81392, 80700, 80731
27937, 66388, 66378, 66158, 66168, 66389, 66379, 66159, 66169, 81424, 81394, 80732, 81425, 81427, 81397, 80735, 
81428, 81426, 81395, 80703, 80734
27938, 66389, 66379, 66159, 66169, 66390, 66380, 66160, 66170, 81427, 81397, 80735, 81428, 81430, 81400, 80738, 
81431, 81429, 81398, 80706, 80737
27939, 66390, 66380, 66160, 66170, 66391, 66381, 66161, 66171, 81430, 81400, 80738, 81431, 81433, 81403, 80741, 
81434, 81432, 81401, 80709, 80740
27940, 66391, 66381, 66161, 66171, 66392, 66382, 66162, 66172, 81433, 81403, 80741, 81434, 81436, 81406, 80744, 
81437, 81435, 81404, 80712, 80743
27941, 66392, 66382, 66162, 66172, 18410, 18409, 18387, 18388, 81436, 81406, 80744, 81437, 19391, 19388, 19346, 
19390, 81438, 81407, 80715, 80746
27942, 16915, 16914, 16892, 16893, 66393, 66383, 66163, 66173, 17896, 17895, 17851, 17897, 81440, 81410, 80748, 
81441, 81439, 81408, 80716, 80747
27943, 66393, 66383, 66163, 66173, 66394, 66384, 66164, 66174, 81440, 81410, 80748, 81441, 81443, 81413, 80751, 
81444, 81442, 81411, 80719, 80750
27944, 66394, 66384, 66164, 66174, 66395, 66385, 66165, 66175, 81443, 81413, 80751, 81444, 81446, 81416, 80754, 
81447, 81445, 81414, 80722, 80753
27945, 66395, 66385, 66165, 66175, 66396, 66386, 66166, 66176, 81446, 81416, 80754, 81447, 81449, 81419, 80757, 
81450, 81448, 81417, 80725, 80756
27946, 66396, 66386, 66166, 66176, 66397, 66387, 66167, 66177, 81449, 81419, 80757, 81450, 81452, 81422, 80760, 
81453, 81451, 81420, 80728, 80759
27947, 66397, 66387, 66167, 66177, 66398, 66388, 66168, 66178, 81452, 81422, 80760, 81453, 81455, 81425, 80763, 
81456, 81454, 81423, 80731, 80762
27948, 66398, 66388, 66168, 66178, 66399, 66389, 66169, 66179, 81455, 81425, 80763, 81456, 81458, 81428, 80766, 
81459, 81457, 81426, 80734, 80765
27949, 66399, 66389, 66169, 66179, 66400, 66390, 66170, 66180, 81458, 81428, 80766, 81459, 81461, 81431, 80769, 
81462, 81460, 81429, 80737, 80768
27950, 66400, 66390, 66170, 66180, 66401, 66391, 66171, 66181, 81461, 81431, 80769, 81462, 81464, 81434, 80772, 
81465, 81463, 81432, 80740, 80771
27951, 66401, 66391, 66171, 66181, 66402, 66392, 66172, 66182, 81464, 81434, 80772, 81465, 81467, 81437, 80775, 
81468, 81466, 81435, 80743, 80774
27952, 66402, 66392, 66172, 66182, 18411, 18410, 18388, 18389, 81467, 81437, 80775, 81468, 19393, 19390, 19348, 
19392, 81469, 81438, 80746, 80777
27953, 16916, 16915, 16893, 16894, 66403, 66393, 66173, 66183, 17898, 17897, 17853, 17899, 81471, 81441, 80779, 
81472, 81470, 81439, 80747, 80778
27954, 66403, 66393, 66173, 66183, 66404, 66394, 66174, 66184, 81471, 81441, 80779, 81472, 81474, 81444, 80782, 
81475, 81473, 81442, 80750, 80781
27955, 66404, 66394, 66174, 66184, 66405, 66395, 66175, 66185, 81474, 81444, 80782, 81475, 81477, 81447, 80785, 
81478, 81476, 81445, 80753, 80784
27956, 66405, 66395, 66175, 66185, 66406, 66396, 66176, 66186, 81477, 81447, 80785, 81478, 81480, 81450, 80788, 
81481, 81479, 81448, 80756, 80787
27957, 66406, 66396, 66176, 66186, 66407, 66397, 66177, 66187, 81480, 81450, 80788, 81481, 81483, 81453, 80791, 
81484, 81482, 81451, 80759, 80790
27958, 66407, 66397, 66177, 66187, 66408, 66398, 66178, 66188, 81483, 81453, 80791, 81484, 81486, 81456, 80794, 
81487, 81485, 81454, 80762, 80793
27959, 66408, 66398, 66178, 66188, 66409, 66399, 66179, 66189, 81486, 81456, 80794, 81487, 81489, 81459, 80797, 
81490, 81488, 81457, 80765, 80796
27960, 66409, 66399, 66179, 66189, 66410, 66400, 66180, 66190, 81489, 81459, 80797, 81490, 81492, 81462, 80800, 
81493, 81491, 81460, 80768, 80799
27961, 66410, 66400, 66180, 66190, 66411, 66401, 66181, 66191, 81492, 81462, 80800, 81493, 81495, 81465, 80803, 
81496, 81494, 81463, 80771, 80802
27962, 66411, 66401, 66181, 66191, 66412, 66402, 66182, 66192, 81495, 81465, 80803, 81496, 81498, 81468, 80806, 
81499, 81497, 81466, 80774, 80805
27963, 66412, 66402, 66182, 66192, 18412, 18411, 18389, 18390, 81498, 81468, 80806, 81499, 19395, 19392, 19350, 
19394, 81500, 81469, 80777, 80808
27964, 16917, 16916, 16894, 16895, 66413, 66403, 66183, 66193, 17900, 17899, 17855, 17901, 81502, 81472, 80810, 
81503, 81501, 81470, 80778, 80809
27965, 66413, 66403, 66183, 66193, 66414, 66404, 66184, 66194, 81502, 81472, 80810, 81503, 81505, 81475, 80813, 
81506, 81504, 81473, 80781, 80812
27966, 66414, 66404, 66184, 66194, 66415, 66405, 66185, 66195, 81505, 81475, 80813, 81506, 81508, 81478, 80816, 
81509, 81507, 81476, 80784, 80815
27967, 66415, 66405, 66185, 66195, 66416, 66406, 66186, 66196, 81508, 81478, 80816, 81509, 81511, 81481, 80819, 
81512, 81510, 81479, 80787, 80818
27968, 66416, 66406, 66186, 66196, 66417, 66407, 66187, 66197, 81511, 81481, 80819, 81512, 81514, 81484, 80822, 
81515, 81513, 81482, 80790, 80821
27969, 66417, 66407, 66187, 66197, 66418, 66408, 66188, 66198, 81514, 81484, 80822, 81515, 81517, 81487, 80825, 
81518, 81516, 81485, 80793, 80824
27970, 66418, 66408, 66188, 66198, 66419, 66409, 66189, 66199, 81517, 81487, 80825, 81518, 81520, 81490, 80828, 
81521, 81519, 81488, 80796, 80827
27971, 66419, 66409, 66189, 66199, 66420, 66410, 66190, 66200, 81520, 81490, 80828, 81521, 81523, 81493, 80831, 
81524, 81522, 81491, 80799, 80830
27972, 66420, 66410, 66190, 66200, 66421, 66411, 66191, 66201, 81523, 81493, 80831, 81524, 81526, 81496, 80834, 
81527, 81525, 81494, 80802, 80833
27973, 66421, 66411, 66191, 66201, 66422, 66412, 66192, 66202, 81526, 81496, 80834, 81527, 81529, 81499, 80837, 
81530, 81528, 81497, 80805, 80836
27974, 66422, 66412, 66192, 66202, 18413, 18412, 18390, 18391, 81529, 81499, 80837, 81530, 19397, 19394, 19352, 
19396, 81531, 81500, 80808, 80839
27975, 16918, 16917, 16895, 16896, 66423, 66413, 66193, 66203, 17902, 17901, 17857, 17903, 81533, 81503, 80841, 
81534, 81532, 81501, 80809, 80840
27976, 66423, 66413, 66193, 66203, 66424, 66414, 66194, 66204, 81533, 81503, 80841, 81534, 81536, 81506, 80844, 
81537, 81535, 81504, 80812, 80843
27977, 66424, 66414, 66194, 66204, 66425, 66415, 66195, 66205, 81536, 81506, 80844, 81537, 81539, 81509, 80847, 
81540, 81538, 81507, 80815, 80846
27978, 66425, 66415, 66195, 66205, 66426, 66416, 66196, 66206, 81539, 81509, 80847, 81540, 81542, 81512, 80850, 
81543, 81541, 81510, 80818, 80849
27979, 66426, 66416, 66196, 66206, 66427, 66417, 66197, 66207, 81542, 81512, 80850, 81543, 81545, 81515, 80853, 
81546, 81544, 81513, 80821, 80852
27980, 66427, 66417, 66197, 66207, 66428, 66418, 66198, 66208, 81545, 81515, 80853, 81546, 81548, 81518, 80856, 
81549, 81547, 81516, 80824, 80855
27981, 66428, 66418, 66198, 66208, 66429, 66419, 66199, 66209, 81548, 81518, 80856, 81549, 81551, 81521, 80859, 
81552, 81550, 81519, 80827, 80858
27982, 66429, 66419, 66199, 66209, 66430, 66420, 66200, 66210, 81551, 81521, 80859, 81552, 81554, 81524, 80862, 
81555, 81553, 81522, 80830, 80861
27983, 66430, 66420, 66200, 66210, 66431, 66421, 66201, 66211, 81554, 81524, 80862, 81555, 81557, 81527, 80865, 
81558, 81556, 81525, 80833, 80864
27984, 66431, 66421, 66201, 66211, 66432, 66422, 66202, 66212, 81557, 81527, 80865, 81558, 81560, 81530, 80868, 
81561, 81559, 81528, 80836, 80867
27985, 66432, 66422, 66202, 66212, 18414, 18413, 18391, 18392, 81560, 81530, 80868, 81561, 19399, 19396, 19354, 
19398, 81562, 81531, 80839, 80870
27986, 16919, 16918, 16896, 16897, 66433, 66423, 66203, 66213, 17904, 17903, 17859, 17905, 81564, 81534, 80872, 
81565, 81563, 81532, 80840, 80871
27987, 66433, 66423, 66203, 66213, 66434, 66424, 66204, 66214, 81564, 81534, 80872, 81565, 81567, 81537, 80875, 
81568, 81566, 81535, 80843, 80874
27988, 66434, 66424, 66204, 66214, 66435, 66425, 66205, 66215, 81567, 81537, 80875, 81568, 81570, 81540, 80878, 
81571, 81569, 81538, 80846, 80877
27989, 66435, 66425, 66205, 66215, 66436, 66426, 66206, 66216, 81570, 81540, 80878, 81571, 81573, 81543, 80881, 
81574, 81572, 81541, 80849, 80880
27990, 66436, 66426, 66206, 66216, 66437, 66427, 66207, 66217, 81573, 81543, 80881, 81574, 81576, 81546, 80884, 
81577, 81575, 81544, 80852, 80883
27991, 66437, 66427, 66207, 66217, 66438, 66428, 66208, 66218, 81576, 81546, 80884, 81577, 81579, 81549, 80887, 
81580, 81578, 81547, 80855, 80886
27992, 66438, 66428, 66208, 66218, 66439, 66429, 66209, 66219, 81579, 81549, 80887, 81580, 81582, 81552, 80890, 
81583, 81581, 81550, 80858, 80889
27993, 66439, 66429, 66209, 66219, 66440, 66430, 66210, 66220, 81582, 81552, 80890, 81583, 81585, 81555, 80893, 
81586, 81584, 81553, 80861, 80892
27994, 66440, 66430, 66210, 66220, 66441, 66431, 66211, 66221, 81585, 81555, 80893, 81586, 81588, 81558, 80896, 
81589, 81587, 81556, 80864, 80895
27995, 66441, 66431, 66211, 66221, 66442, 66432, 66212, 66222, 81588, 81558, 80896, 81589, 81591, 81561, 80899, 
81592, 81590, 81559, 80867, 80898
27996, 66442, 66432, 66212, 66222, 18415, 18414, 18392, 18393, 81591, 81561, 80899, 81592, 19401, 19398, 19356, 
19400, 81593, 81562, 80870, 80901
27997, 16920, 16919, 16897, 16898, 66443, 66433, 66213, 66223, 17906, 17905, 17861, 17907, 81595, 81565, 80903, 
81596, 81594, 81563, 80871, 80902
27998, 66443, 66433, 66213, 66223, 66444, 66434, 66214, 66224, 81595, 81565, 80903, 81596, 81598, 81568, 80906, 
81599, 81597, 81566, 80874, 80905
27999, 66444, 66434, 66214, 66224, 66445, 66435, 66215, 66225, 81598, 81568, 80906, 81599, 81601, 81571, 80909, 
81602, 81600, 81569, 80877, 80908
28000, 66445, 66435, 66215, 66225, 66446, 66436, 66216, 66226, 81601, 81571, 80909, 81602, 81604, 81574, 80912, 
81605, 81603, 81572, 80880, 80911
28001, 66446, 66436, 66216, 66226, 66447, 66437, 66217, 66227, 81604, 81574, 80912, 81605, 81607, 81577, 80915, 
81608, 81606, 81575, 80883, 80914
28002, 66447, 66437, 66217, 66227, 66448, 66438, 66218, 66228, 81607, 81577, 80915, 81608, 81610, 81580, 80918, 
81611, 81609, 81578, 80886, 80917
28003, 66448, 66438, 66218, 66228, 66449, 66439, 66219, 66229, 81610, 81580, 80918, 81611, 81613, 81583, 80921, 
81614, 81612, 81581, 80889, 80920
28004, 66449, 66439, 66219, 66229, 66450, 66440, 66220, 66230, 81613, 81583, 80921, 81614, 81616, 81586, 80924, 
81617, 81615, 81584, 80892, 80923
28005, 66450, 66440, 66220, 66230, 66451, 66441, 66221, 66231, 81616, 81586, 80924, 81617, 81619, 81589, 80927, 
81620, 81618, 81587, 80895, 80926
28006, 66451, 66441, 66221, 66231, 66452, 66442, 66222, 66232, 81619, 81589, 80927, 81620, 81622, 81592, 80930, 
81623, 81621, 81590, 80898, 80929
28007, 66452, 66442, 66222, 66232, 18416, 18415, 18393, 18394, 81622, 81592, 80930, 81623, 19403, 19400, 19358, 
19402, 81624, 81593, 80901, 80932
28008, 16921, 16920, 16898, 16899, 66453, 66443, 66223, 66233, 17908, 17907, 17863, 17909, 81626, 81596, 80934, 
81627, 81625, 81594, 80902, 80933
28009, 66453, 66443, 66223, 66233, 66454, 66444, 66224, 66234, 81626, 81596, 80934, 81627, 81629, 81599, 80937, 
81630, 81628, 81597, 80905, 80936
28010, 66454, 66444, 66224, 66234, 66455, 66445, 66225, 66235, 81629, 81599, 80937, 81630, 81632, 81602, 80940, 
81633, 81631, 81600, 80908, 80939
28011, 66455, 66445, 66225, 66235, 66456, 66446, 66226, 66236, 81632, 81602, 80940, 81633, 81635, 81605, 80943, 
81636, 81634, 81603, 80911, 80942
28012, 66456, 66446, 66226, 66236, 66457, 66447, 66227, 66237, 81635, 81605, 80943, 81636, 81638, 81608, 80946, 
81639, 81637, 81606, 80914, 80945
28013, 66457, 66447, 66227, 66237, 66458, 66448, 66228, 66238, 81638, 81608, 80946, 81639, 81641, 81611, 80949, 
81642, 81640, 81609, 80917, 80948
28014, 66458, 66448, 66228, 66238, 66459, 66449, 66229, 66239, 81641, 81611, 80949, 81642, 81644, 81614, 80952, 
81645, 81643, 81612, 80920, 80951
28015, 66459, 66449, 66229, 66239, 66460, 66450, 66230, 66240, 81644, 81614, 80952, 81645, 81647, 81617, 80955, 
81648, 81646, 81615, 80923, 80954
28016, 66460, 66450, 66230, 66240, 66461, 66451, 66231, 66241, 81647, 81617, 80955, 81648, 81650, 81620, 80958, 
81651, 81649, 81618, 80926, 80957
28017, 66461, 66451, 66231, 66241, 66462, 66452, 66232, 66242, 81650, 81620, 80958, 81651, 81653, 81623, 80961, 
81654, 81652, 81621, 80929, 80960
28018, 66462, 66452, 66232, 66242, 18417, 18416, 18394, 18395, 81653, 81623, 80961, 81654, 19405, 19402, 19360, 
19404, 81655, 81624, 80932, 80963
28019, 16922, 16921, 16899, 16900, 66463, 66453, 66233, 66243, 17910, 17909, 17865, 17911, 81657, 81627, 80965, 
81658, 81656, 81625, 80933, 80964
28020, 66463, 66453, 66233, 66243, 66464, 66454, 66234, 66244, 81657, 81627, 80965, 81658, 81660, 81630, 80968, 
81661, 81659, 81628, 80936, 80967
28021, 66464, 66454, 66234, 66244, 66465, 66455, 66235, 66245, 81660, 81630, 80968, 81661, 81663, 81633, 80971, 
81664, 81662, 81631, 80939, 80970
28022, 66465, 66455, 66235, 66245, 66466, 66456, 66236, 66246, 81663, 81633, 80971, 81664, 81666, 81636, 80974, 
81667, 81665, 81634, 80942, 80973
28023, 66466, 66456, 66236, 66246, 66467, 66457, 66237, 66247, 81666, 81636, 80974, 81667, 81669, 81639, 80977, 
81670, 81668, 81637, 80945, 80976
28024, 66467, 66457, 66237, 66247, 66468, 66458, 66238, 66248, 81669, 81639, 80977, 81670, 81672, 81642, 80980, 
81673, 81671, 81640, 80948, 80979
28025, 66468, 66458, 66238, 66248, 66469, 66459, 66239, 66249, 81672, 81642, 80980, 81673, 81675, 81645, 80983, 
81676, 81674, 81643, 80951, 80982
28026, 66469, 66459, 66239, 66249, 66470, 66460, 66240, 66250, 81675, 81645, 80983, 81676, 81678, 81648, 80986, 
81679, 81677, 81646, 80954, 80985
28027, 66470, 66460, 66240, 66250, 66471, 66461, 66241, 66251, 81678, 81648, 80986, 81679, 81681, 81651, 80989, 
81682, 81680, 81649, 80957, 80988
28028, 66471, 66461, 66241, 66251, 66472, 66462, 66242, 66252, 81681, 81651, 80989, 81682, 81684, 81654, 80992, 
81685, 81683, 81652, 80960, 80991
28029, 66472, 66462, 66242, 66252, 18418, 18417, 18395, 18396, 81684, 81654, 80992, 81685, 19407, 19404, 19362, 
19406, 81686, 81655, 80963, 80994
28030, 1655, 16922, 16900, 1654, 20333, 66463, 66243, 20323, 17912, 17911, 17867, 1677, 81687, 81658, 80995, 
20785, 20784, 81656, 80964, 20763
28031, 20333, 66463, 66243, 20323, 20334, 66464, 66244, 20324, 81687, 81658, 80995, 20785, 81688, 81661, 80996, 
20787, 20786, 81659, 80967, 20765
28032, 20334, 66464, 66244, 20324, 20335, 66465, 66245, 20325, 81688, 81661, 80996, 20787, 81689, 81664, 80997, 
20789, 20788, 81662, 80970, 20767
28033, 20335, 66465, 66245, 20325, 20336, 66466, 66246, 20326, 81689, 81664, 80997, 20789, 81690, 81667, 80998, 
20791, 20790, 81665, 80973, 20769
28034, 20336, 66466, 66246, 20326, 20337, 66467, 66247, 20327, 81690, 81667, 80998, 20791, 81691, 81670, 80999, 
20793, 20792, 81668, 80976, 20771
28035, 20337, 66467, 66247, 20327, 20338, 66468, 66248, 20328, 81691, 81670, 80999, 20793, 81692, 81673, 81000, 
20795, 20794, 81671, 80979, 20773
28036, 20338, 66468, 66248, 20328, 20339, 66469, 66249, 20329, 81692, 81673, 81000, 20795, 81693, 81676, 81001, 
20797, 20796, 81674, 80982, 20775
28037, 20339, 66469, 66249, 20329, 20340, 66470, 66250, 20330, 81693, 81676, 81001, 20797, 81694, 81679, 81002, 
20799, 20798, 81677, 80985, 20777
28038, 20340, 66470, 66250, 20330, 20341, 66471, 66251, 20331, 81694, 81679, 81002, 20799, 81695, 81682, 81003, 
20801, 20800, 81680, 80988, 20779
28039, 20341, 66471, 66251, 20331, 20342, 66472, 66252, 20332, 81695, 81682, 81003, 20801, 81696, 81685, 81004, 
20803, 20802, 81683, 80991, 20781
28040, 20342, 66472, 66252, 20332, 1790, 18418, 18396, 1789, 81696, 81685, 81004, 20803, 19408, 19406, 19363, 
1812, 20804, 81686, 80994, 20783
28041, 1679, 37, 1610, 16901, 20815, 1868, 19641, 66253, 1701, 1633, 17868, 17913, 21035, 20113, 81006, 
81697, 21036, 1879, 20093, 81005
28042, 20815, 1868, 19641, 66253, 20816, 1867, 19642, 66254, 21035, 20113, 81006, 81697, 21037, 20114, 81009, 
81698, 21038, 1878, 20095, 81008
28043, 20816, 1867, 19642, 66254, 20817, 1866, 19643, 66255, 21037, 20114, 81009, 81698, 21039, 20115, 81012, 
81699, 21040, 1877, 20097, 81011
28044, 20817, 1866, 19643, 66255, 20818, 1865, 19644, 66256, 21039, 20115, 81012, 81699, 21041, 20116, 81015, 
81700, 21042, 1876, 20099, 81014
28045, 20818, 1865, 19644, 66256, 20819, 1864, 19645, 66257, 21041, 20116, 81015, 81700, 21043, 20117, 81018, 
81701, 21044, 1875, 20101, 81017
28046, 20819, 1864, 19645, 66257, 20820, 1863, 19646, 66258, 21043, 20117, 81018, 81701, 21045, 20118, 81021, 
81702, 21046, 1874, 20103, 81020
28047, 20820, 1863, 19646, 66258, 20821, 1862, 19647, 66259, 21045, 20118, 81021, 81702, 21047, 20119, 81024, 
81703, 21048, 1873, 20105, 81023
28048, 20821, 1862, 19647, 66259, 20822, 1861, 19648, 66260, 21047, 20119, 81024, 81703, 21049, 20120, 81027, 
81704, 21050, 1872, 20107, 81026
28049, 20822, 1861, 19648, 66260, 20823, 1860, 19649, 66261, 21049, 20120, 81027, 81704, 21051, 20121, 81030, 
81705, 21052, 1871, 20109, 81029
28050, 20823, 1860, 19649, 66261, 20824, 1859, 19650, 66262, 21051, 20121, 81030, 81705, 21053, 20122, 81033, 
81706, 21054, 1870, 20111, 81032
28051, 20824, 1859, 19650, 66262, 1814, 39, 1745, 18397, 21053, 20122, 81033, 81706, 1836, 1768, 19365, 
19409, 21055, 1869, 20112, 81035
28052, 1680, 1679, 16901, 16902, 20825, 20815, 66253, 66263, 1702, 17913, 17870, 17914, 21056, 81697, 81037, 
81707, 21057, 21036, 81005, 81036
28053, 20825, 20815, 66253, 66263, 20826, 20816, 66254, 66264, 21056, 81697, 81037, 81707, 21058, 81698, 81040, 
81708, 21059, 21038, 81008, 81039
28054, 20826, 20816, 66254, 66264, 20827, 20817, 66255, 66265, 21058, 81698, 81040, 81708, 21060, 81699, 81043, 
81709, 21061, 21040, 81011, 81042
28055, 20827, 20817, 66255, 66265, 20828, 20818, 66256, 66266, 21060, 81699, 81043, 81709, 21062, 81700, 81046, 
81710, 21063, 21042, 81014, 81045
28056, 20828, 20818, 66256, 66266, 20829, 20819, 66257, 66267, 21062, 81700, 81046, 81710, 21064, 81701, 81049, 
81711, 21065, 21044, 81017, 81048
28057, 20829, 20819, 66257, 66267, 20830, 20820, 66258, 66268, 21064, 81701, 81049, 81711, 21066, 81702, 81052, 
81712, 21067, 21046, 81020, 81051
28058, 20830, 20820, 66258, 66268, 20831, 20821, 66259, 66269, 21066, 81702, 81052, 81712, 21068, 81703, 81055, 
81713, 21069, 21048, 81023, 81054
28059, 20831, 20821, 66259, 66269, 20832, 20822, 66260, 66270, 21068, 81703, 81055, 81713, 21070, 81704, 81058, 
81714, 21071, 21050, 81026, 81057
28060, 20832, 20822, 66260, 66270, 20833, 20823, 66261, 66271, 21070, 81704, 81058, 81714, 21072, 81705, 81061, 
81715, 21073, 21052, 81029, 81060
28061, 20833, 20823, 66261, 66271, 20834, 20824, 66262, 66272, 21072, 81705, 81061, 81715, 21074, 81706, 81064, 
81716, 21075, 21054, 81032, 81063
28062, 20834, 20824, 66262, 66272, 1815, 1814, 18397, 18398, 21074, 81706, 81064, 81716, 1837, 19409, 19367, 
19410, 21076, 21055, 81035, 81066
28063, 1681, 1680, 16902, 16903, 20835, 20825, 66263, 66273, 1703, 17914, 17872, 17915, 21077, 81707, 81068, 
81717, 21078, 21057, 81036, 81067
28064, 20835, 20825, 66263, 66273, 20836, 20826, 66264, 66274, 21077, 81707, 81068, 81717, 21079, 81708, 81071, 
81718, 21080, 21059, 81039, 81070
28065, 20836, 20826, 66264, 66274, 20837, 20827, 66265, 66275, 21079, 81708, 81071, 81718, 21081, 81709, 81074, 
81719, 21082, 21061, 81042, 81073
28066, 20837, 20827, 66265, 66275, 20838, 20828, 66266, 66276, 21081, 81709, 81074, 81719, 21083, 81710, 81077, 
81720, 21084, 21063, 81045, 81076
28067, 20838, 20828, 66266, 66276, 20839, 20829, 66267, 66277, 21083, 81710, 81077, 81720, 21085, 81711, 81080, 
81721, 21086, 21065, 81048, 81079
28068, 20839, 20829, 66267, 66277, 20840, 20830, 66268, 66278, 21085, 81711, 81080, 81721, 21087, 81712, 81083, 
81722, 21088, 21067, 81051, 81082
28069, 20840, 20830, 66268, 66278, 20841, 20831, 66269, 66279, 21087, 81712, 81083, 81722, 21089, 81713, 81086, 
81723, 21090, 21069, 81054, 81085
28070, 20841, 20831, 66269, 66279, 20842, 20832, 66270, 66280, 21089, 81713, 81086, 81723, 21091, 81714, 81089, 
81724, 21092, 21071, 81057, 81088
28071, 20842, 20832, 66270, 66280, 20843, 20833, 66271, 66281, 21091, 81714, 81089, 81724, 21093, 81715, 81092, 
81725, 21094, 21073, 81060, 81091
28072, 20843, 20833, 66271, 66281, 20844, 20834, 66272, 66282, 21093, 81715, 81092, 81725, 21095, 81716, 81095, 
81726, 21096, 21075, 81063, 81094
28073, 20844, 20834, 66272, 66282, 1816, 1815, 18398, 18399, 21095, 81716, 81095, 81726, 1838, 19410, 19369, 
19411, 21097, 21076, 81066, 81097
28074, 1682, 1681, 16903, 16904, 20845, 20835, 66273, 66283, 1704, 17915, 17874, 17916, 21098, 81717, 81099, 
81727, 21099, 21078, 81067, 81098
28075, 20845, 20835, 66273, 66283, 20846, 20836, 66274, 66284, 21098, 81717, 81099, 81727, 21100, 81718, 81102, 
81728, 21101, 21080, 81070, 81101
28076, 20846, 20836, 66274, 66284, 20847, 20837, 66275, 66285, 21100, 81718, 81102, 81728, 21102, 81719, 81105, 
81729, 21103, 21082, 81073, 81104
28077, 20847, 20837, 66275, 66285, 20848, 20838, 66276, 66286, 21102, 81719, 81105, 81729, 21104, 81720, 81108, 
81730, 21105, 21084, 81076, 81107
28078, 20848, 20838, 66276, 66286, 20849, 20839, 66277, 66287, 21104, 81720, 81108, 81730, 21106, 81721, 81111, 
81731, 21107, 21086, 81079, 81110
28079, 20849, 20839, 66277, 66287, 20850, 20840, 66278, 66288, 21106, 81721, 81111, 81731, 21108, 81722, 81114, 
81732, 21109, 21088, 81082, 81113
28080, 20850, 20840, 66278, 66288, 20851, 20841, 66279, 66289, 21108, 81722, 81114, 81732, 21110, 81723, 81117, 
81733, 21111, 21090, 81085, 81116
28081, 20851, 20841, 66279, 66289, 20852, 20842, 66280, 66290, 21110, 81723, 81117, 81733, 21112, 81724, 81120, 
81734, 21113, 21092, 81088, 81119
28082, 20852, 20842, 66280, 66290, 20853, 20843, 66281, 66291, 21112, 81724, 81120, 81734, 21114, 81725, 81123, 
81735, 21115, 21094, 81091, 81122
28083, 20853, 20843, 66281, 66291, 20854, 20844, 66282, 66292, 21114, 81725, 81123, 81735, 21116, 81726, 81126, 
81736, 21117, 21096, 81094, 81125
28084, 20854, 20844, 66282, 66292, 1817, 1816, 18399, 18400, 21116, 81726, 81126, 81736, 1839, 19411, 19371, 
19412, 21118, 21097, 81097, 81128
28085, 1683, 1682, 16904, 16905, 20855, 20845, 66283, 66293, 1705, 17916, 17876, 17917, 21119, 81727, 81130, 
81737, 21120, 21099, 81098, 81129
28086, 20855, 20845, 66283, 66293, 20856, 20846, 66284, 66294, 21119, 81727, 81130, 81737, 21121, 81728, 81133, 
81738, 21122, 21101, 81101, 81132
28087, 20856, 20846, 66284, 66294, 20857, 20847, 66285, 66295, 21121, 81728, 81133, 81738, 21123, 81729, 81136, 
81739, 21124, 21103, 81104, 81135
28088, 20857, 20847, 66285, 66295, 20858, 20848, 66286, 66296, 21123, 81729, 81136, 81739, 21125, 81730, 81139, 
81740, 21126, 21105, 81107, 81138
28089, 20858, 20848, 66286, 66296, 20859, 20849, 66287, 66297, 21125, 81730, 81139, 81740, 21127, 81731, 81142, 
81741, 21128, 21107, 81110, 81141
28090, 20859, 20849, 66287, 66297, 20860, 20850, 66288, 66298, 21127, 81731, 81142, 81741, 21129, 81732, 81145, 
81742, 21130, 21109, 81113, 81144
28091, 20860, 20850, 66288, 66298, 20861, 20851, 66289, 66299, 21129, 81732, 81145, 81742, 21131, 81733, 81148, 
81743, 21132, 21111, 81116, 81147
28092, 20861, 20851, 66289, 66299, 20862, 20852, 66290, 66300, 21131, 81733, 81148, 81743, 21133, 81734, 81151, 
81744, 21134, 21113, 81119, 81150
28093, 20862, 20852, 66290, 66300, 20863, 20853, 66291, 66301, 21133, 81734, 81151, 81744, 21135, 81735, 81154, 
81745, 21136, 21115, 81122, 81153
28094, 20863, 20853, 66291, 66301, 20864, 20854, 66292, 66302, 21135, 81735, 81154, 81745, 21137, 81736, 81157, 
81746, 21138, 21117, 81125, 81156
28095, 20864, 20854, 66292, 66302, 1818, 1817, 18400, 18401, 21137, 81736, 81157, 81746, 1840, 19412, 19373, 
19413, 21139, 21118, 81128, 81159
28096, 1684, 1683, 16905, 16906, 20865, 20855, 66293, 66303, 1706, 17917, 17878, 17918, 21140, 81737, 81161, 
81747, 21141, 21120, 81129, 81160
28097, 20865, 20855, 66293, 66303, 20866, 20856, 66294, 66304, 21140, 81737, 81161, 81747, 21142, 81738, 81164, 
81748, 21143, 21122, 81132, 81163
28098, 20866, 20856, 66294, 66304, 20867, 20857, 66295, 66305, 21142, 81738, 81164, 81748, 21144, 81739, 81167, 
81749, 21145, 21124, 81135, 81166
28099, 20867, 20857, 66295, 66305, 20868, 20858, 66296, 66306, 21144, 81739, 81167, 81749, 21146, 81740, 81170, 
81750, 21147, 21126, 81138, 81169
28100, 20868, 20858, 66296, 66306, 20869, 20859, 66297, 66307, 21146, 81740, 81170, 81750, 21148, 81741, 81173, 
81751, 21149, 21128, 81141, 81172
28101, 20869, 20859, 66297, 66307, 20870, 20860, 66298, 66308, 21148, 81741, 81173, 81751, 21150, 81742, 81176, 
81752, 21151, 21130, 81144, 81175
28102, 20870, 20860, 66298, 66308, 20871, 20861, 66299, 66309, 21150, 81742, 81176, 81752, 21152, 81743, 81179, 
81753, 21153, 21132, 81147, 81178
28103, 20871, 20861, 66299, 66309, 20872, 20862, 66300, 66310, 21152, 81743, 81179, 81753, 21154, 81744, 81182, 
81754, 21155, 21134, 81150, 81181
28104, 20872, 20862, 66300, 66310, 20873, 20863, 66301, 66311, 21154, 81744, 81182, 81754, 21156, 81745, 81185, 
81755, 21157, 21136, 81153, 81184
28105, 20873, 20863, 66301, 66311, 20874, 20864, 66302, 66312, 21156, 81745, 81185, 81755, 21158, 81746, 81188, 
81756, 21159, 21138, 81156, 81187
28106, 20874, 20864, 66302, 66312, 1819, 1818, 18401, 18402, 21158, 81746, 81188, 81756, 1841, 19413, 19375, 
19414, 21160, 21139, 81159, 81190
28107, 1685, 1684, 16906, 16907, 20875, 20865, 66303, 66313, 1707, 17918, 17880, 17919, 21161, 81747, 81192, 
81757, 21162, 21141, 81160, 81191
28108, 20875, 20865, 66303, 66313, 20876, 20866, 66304, 66314, 21161, 81747, 81192, 81757, 21163, 81748, 81195, 
81758, 21164, 21143, 81163, 81194
28109, 20876, 20866, 66304, 66314, 20877, 20867, 66305, 66315, 21163, 81748, 81195, 81758, 21165, 81749, 81198, 
81759, 21166, 21145, 81166, 81197
28110, 20877, 20867, 66305, 66315, 20878, 20868, 66306, 66316, 21165, 81749, 81198, 81759, 21167, 81750, 81201, 
81760, 21168, 21147, 81169, 81200
28111, 20878, 20868, 66306, 66316, 20879, 20869, 66307, 66317, 21167, 81750, 81201, 81760, 21169, 81751, 81204, 
81761, 21170, 21149, 81172, 81203
28112, 20879, 20869, 66307, 66317, 20880, 20870, 66308, 66318, 21169, 81751, 81204, 81761, 21171, 81752, 81207, 
81762, 21172, 21151, 81175, 81206
28113, 20880, 20870, 66308, 66318, 20881, 20871, 66309, 66319, 21171, 81752, 81207, 81762, 21173, 81753, 81210, 
81763, 21174, 21153, 81178, 81209
28114, 20881, 20871, 66309, 66319, 20882, 20872, 66310, 66320, 21173, 81753, 81210, 81763, 21175, 81754, 81213, 
81764, 21176, 21155, 81181, 81212
28115, 20882, 20872, 66310, 66320, 20883, 20873, 66311, 66321, 21175, 81754, 81213, 81764, 21177, 81755, 81216, 
81765, 21178, 21157, 81184, 81215
28116, 20883, 20873, 66311, 66321, 20884, 20874, 66312, 66322, 21177, 81755, 81216, 81765, 21179, 81756, 81219, 
81766, 21180, 21159, 81187, 81218
28117, 20884, 20874, 66312, 66322, 1820, 1819, 18402, 18403, 21179, 81756, 81219, 81766, 1842, 19414, 19377, 
19415, 21181, 21160, 81190, 81221
28118, 1686, 1685, 16907, 16908, 20885, 20875, 66313, 66323, 1708, 17919, 17882, 17920, 21182, 81757, 81223, 
81767, 21183, 21162, 81191, 81222
28119, 20885, 20875, 66313, 66323, 20886, 20876, 66314, 66324, 21182, 81757, 81223, 81767, 21184, 81758, 81226, 
81768, 21185, 21164, 81194, 81225
28120, 20886, 20876, 66314, 66324, 20887, 20877, 66315, 66325, 21184, 81758, 81226, 81768, 21186, 81759, 81229, 
81769, 21187, 21166, 81197, 81228
28121, 20887, 20877, 66315, 66325, 20888, 20878, 66316, 66326, 21186, 81759, 81229, 81769, 21188, 81760, 81232, 
81770, 21189, 21168, 81200, 81231
28122, 20888, 20878, 66316, 66326, 20889, 20879, 66317, 66327, 21188, 81760, 81232, 81770, 21190, 81761, 81235, 
81771, 21191, 21170, 81203, 81234
28123, 20889, 20879, 66317, 66327, 20890, 20880, 66318, 66328, 21190, 81761, 81235, 81771, 21192, 81762, 81238, 
81772, 21193, 21172, 81206, 81237
28124, 20890, 20880, 66318, 66328, 20891, 20881, 66319, 66329, 21192, 81762, 81238, 81772, 21194, 81763, 81241, 
81773, 21195, 21174, 81209, 81240
28125, 20891, 20881, 66319, 66329, 20892, 20882, 66320, 66330, 21194, 81763, 81241, 81773, 21196, 81764, 81244, 
81774, 21197, 21176, 81212, 81243
28126, 20892, 20882, 66320, 66330, 20893, 20883, 66321, 66331, 21196, 81764, 81244, 81774, 21198, 81765, 81247, 
81775, 21199, 21178, 81215, 81246
28127, 20893, 20883, 66321, 66331, 20894, 20884, 66322, 66332, 21198, 81765, 81247, 81775, 21200, 81766, 81250, 
81776, 21201, 21180, 81218, 81249
28128, 20894, 20884, 66322, 66332, 1821, 1820, 18403, 18404, 21200, 81766, 81250, 81776, 1843, 19415, 19379, 
19416, 21202, 21181, 81221, 81252
28129, 1687, 1686, 16908, 16909, 20895, 20885, 66323, 66333, 1709, 17920, 17884, 17921, 21203, 81767, 81254, 
81777, 21204, 21183, 81222, 81253
28130, 20895, 20885, 66323, 66333, 20896, 20886, 66324, 66334, 21203, 81767, 81254, 81777, 21205, 81768, 81257, 
81778, 21206, 21185, 81225, 81256
28131, 20896, 20886, 66324, 66334, 20897, 20887, 66325, 66335, 21205, 81768, 81257, 81778, 21207, 81769, 81260, 
81779, 21208, 21187, 81228, 81259
28132, 20897, 20887, 66325, 66335, 20898, 20888, 66326, 66336, 21207, 81769, 81260, 81779, 21209, 81770, 81263, 
81780, 21210, 21189, 81231, 81262
28133, 20898, 20888, 66326, 66336, 20899, 20889, 66327, 66337, 21209, 81770, 81263, 81780, 21211, 81771, 81266, 
81781, 21212, 21191, 81234, 81265
28134, 20899, 20889, 66327, 66337, 20900, 20890, 66328, 66338, 21211, 81771, 81266, 81781, 21213, 81772, 81269, 
81782, 21214, 21193, 81237, 81268
28135, 20900, 20890, 66328, 66338, 20901, 20891, 66329, 66339, 21213, 81772, 81269, 81782, 21215, 81773, 81272, 
81783, 21216, 21195, 81240, 81271
28136, 20901, 20891, 66329, 66339, 20902, 20892, 66330, 66340, 21215, 81773, 81272, 81783, 21217, 81774, 81275, 
81784, 21218, 21197, 81243, 81274
28137, 20902, 20892, 66330, 66340, 20903, 20893, 66331, 66341, 21217, 81774, 81275, 81784, 21219, 81775, 81278, 
81785, 21220, 21199, 81246, 81277
28138, 20903, 20893, 66331, 66341, 20904, 20894, 66332, 66342, 21219, 81775, 81278, 81785, 21221, 81776, 81281, 
81786, 21222, 21201, 81249, 81280
28139, 20904, 20894, 66332, 66342, 1822, 1821, 18404, 18405, 21221, 81776, 81281, 81786, 1844, 19416, 19381, 
19417, 21223, 21202, 81252, 81283
28140, 1688, 1687, 16909, 16910, 20905, 20895, 66333, 66343, 1710, 17921, 17886, 17922, 21224, 81777, 81285, 
81787, 21225, 21204, 81253, 81284
28141, 20905, 20895, 66333, 66343, 20906, 20896, 66334, 66344, 21224, 81777, 81285, 81787, 21226, 81778, 81288, 
81788, 21227, 21206, 81256, 81287
28142, 20906, 20896, 66334, 66344, 20907, 20897, 66335, 66345, 21226, 81778, 81288, 81788, 21228, 81779, 81291, 
81789, 21229, 21208, 81259, 81290
28143, 20907, 20897, 66335, 66345, 20908, 20898, 66336, 66346, 21228, 81779, 81291, 81789, 21230, 81780, 81294, 
81790, 21231, 21210, 81262, 81293
28144, 20908, 20898, 66336, 66346, 20909, 20899, 66337, 66347, 21230, 81780, 81294, 81790, 21232, 81781, 81297, 
81791, 21233, 21212, 81265, 81296
28145, 20909, 20899, 66337, 66347, 20910, 20900, 66338, 66348, 21232, 81781, 81297, 81791, 21234, 81782, 81300, 
81792, 21235, 21214, 81268, 81299
28146, 20910, 20900, 66338, 66348, 20911, 20901, 66339, 66349, 21234, 81782, 81300, 81792, 21236, 81783, 81303, 
81793, 21237, 21216, 81271, 81302
28147, 20911, 20901, 66339, 66349, 20912, 20902, 66340, 66350, 21236, 81783, 81303, 81793, 21238, 81784, 81306, 
81794, 21239, 21218, 81274, 81305
28148, 20912, 20902, 66340, 66350, 20913, 20903, 66341, 66351, 21238, 81784, 81306, 81794, 21240, 81785, 81309, 
81795, 21241, 21220, 81277, 81308
28149, 20913, 20903, 66341, 66351, 20914, 20904, 66342, 66352, 21240, 81785, 81309, 81795, 21242, 81786, 81312, 
81796, 21243, 21222, 81280, 81311
28150, 20914, 20904, 66342, 66352, 1823, 1822, 18405, 18406, 21242, 81786, 81312, 81796, 1845, 19417, 19383, 
19418, 21244, 21223, 81283, 81314
28151, 1689, 1688, 16910, 16911, 20915, 20905, 66343, 66353, 1711, 17922, 17888, 17923, 21245, 81787, 81316, 
81797, 21246, 21225, 81284, 81315
28152, 20915, 20905, 66343, 66353, 20916, 20906, 66344, 66354, 21245, 81787, 81316, 81797, 21247, 81788, 81319, 
81798, 21248, 21227, 81287, 81318
28153, 20916, 20906, 66344, 66354, 20917, 20907, 66345, 66355, 21247, 81788, 81319, 81798, 21249, 81789, 81322, 
81799, 21250, 21229, 81290, 81321
28154, 20917, 20907, 66345, 66355, 20918, 20908, 66346, 66356, 21249, 81789, 81322, 81799, 21251, 81790, 81325, 
81800, 21252, 21231, 81293, 81324
28155, 20918, 20908, 66346, 66356, 20919, 20909, 66347, 66357, 21251, 81790, 81325, 81800, 21253, 81791, 81328, 
81801, 21254, 21233, 81296, 81327
28156, 20919, 20909, 66347, 66357, 20920, 20910, 66348, 66358, 21253, 81791, 81328, 81801, 21255, 81792, 81331, 
81802, 21256, 21235, 81299, 81330
28157, 20920, 20910, 66348, 66358, 20921, 20911, 66349, 66359, 21255, 81792, 81331, 81802, 21257, 81793, 81334, 
81803, 21258, 21237, 81302, 81333
28158, 20921, 20911, 66349, 66359, 20922, 20912, 66350, 66360, 21257, 81793, 81334, 81803, 21259, 81794, 81337, 
81804, 21260, 21239, 81305, 81336
28159, 20922, 20912, 66350, 66360, 20923, 20913, 66351, 66361, 21259, 81794, 81337, 81804, 21261, 81795, 81340, 
81805, 21262, 21241, 81308, 81339
28160, 20923, 20913, 66351, 66361, 20924, 20914, 66352, 66362, 21261, 81795, 81340, 81805, 21263, 81796, 81343, 
81806, 21264, 21243, 81311, 81342
28161, 20924, 20914, 66352, 66362, 1824, 1823, 18406, 18407, 21263, 81796, 81343, 81806, 1846, 19418, 19385, 
19419, 21265, 21244, 81314, 81345
28162, 1690, 1689, 16911, 16912, 20925, 20915, 66353, 66363, 1712, 17923, 17890, 17924, 21266, 81797, 81347, 
81807, 21267, 21246, 81315, 81346
28163, 20925, 20915, 66353, 66363, 20926, 20916, 66354, 66364, 21266, 81797, 81347, 81807, 21268, 81798, 81350, 
81808, 21269, 21248, 81318, 81349
28164, 20926, 20916, 66354, 66364, 20927, 20917, 66355, 66365, 21268, 81798, 81350, 81808, 21270, 81799, 81353, 
81809, 21271, 21250, 81321, 81352
28165, 20927, 20917, 66355, 66365, 20928, 20918, 66356, 66366, 21270, 81799, 81353, 81809, 21272, 81800, 81356, 
81810, 21273, 21252, 81324, 81355
28166, 20928, 20918, 66356, 66366, 20929, 20919, 66357, 66367, 21272, 81800, 81356, 81810, 21274, 81801, 81359, 
81811, 21275, 21254, 81327, 81358
28167, 20929, 20919, 66357, 66367, 20930, 20920, 66358, 66368, 21274, 81801, 81359, 81811, 21276, 81802, 81362, 
81812, 21277, 21256, 81330, 81361
28168, 20930, 20920, 66358, 66368, 20931, 20921, 66359, 66369, 21276, 81802, 81362, 81812, 21278, 81803, 81365, 
81813, 21279, 21258, 81333, 81364
28169, 20931, 20921, 66359, 66369, 20932, 20922, 66360, 66370, 21278, 81803, 81365, 81813, 21280, 81804, 81368, 
81814, 21281, 21260, 81336, 81367
28170, 20932, 20922, 66360, 66370, 20933, 20923, 66361, 66371, 21280, 81804, 81368, 81814, 21282, 81805, 81371, 
81815, 21283, 21262, 81339, 81370
28171, 20933, 20923, 66361, 66371, 20934, 20924, 66362, 66372, 21282, 81805, 81371, 81815, 21284, 81806, 81374, 
81816, 21285, 21264, 81342, 81373
28172, 20934, 20924, 66362, 66372, 1825, 1824, 18407, 18408, 21284, 81806, 81374, 81816, 1847, 19419, 19387, 
19420, 21286, 21265, 81345, 81376
28173, 1691, 1690, 16912, 16913, 20935, 20925, 66363, 66373, 1713, 17924, 17892, 17925, 21287, 81807, 81378, 
81817, 21288, 21267, 81346, 81377
28174, 20935, 20925, 66363, 66373, 20936, 20926, 66364, 66374, 21287, 81807, 81378, 81817, 21289, 81808, 81381, 
81818, 21290, 21269, 81349, 81380
28175, 20936, 20926, 66364, 66374, 20937, 20927, 66365, 66375, 21289, 81808, 81381, 81818, 21291, 81809, 81384, 
81819, 21292, 21271, 81352, 81383
28176, 20937, 20927, 66365, 66375, 20938, 20928, 66366, 66376, 21291, 81809, 81384, 81819, 21293, 81810, 81387, 
81820, 21294, 21273, 81355, 81386
28177, 20938, 20928, 66366, 66376, 20939, 20929, 66367, 66377, 21293, 81810, 81387, 81820, 21295, 81811, 81390, 
81821, 21296, 21275, 81358, 81389
28178, 20939, 20929, 66367, 66377, 20940, 20930, 66368, 66378, 21295, 81811, 81390, 81821, 21297, 81812, 81393, 
81822, 21298, 21277, 81361, 81392
28179, 20940, 20930, 66368, 66378, 20941, 20931, 66369, 66379, 21297, 81812, 81393, 81822, 21299, 81813, 81396, 
81823, 21300, 21279, 81364, 81395
28180, 20941, 20931, 66369, 66379, 20942, 20932, 66370, 66380, 21299, 81813, 81396, 81823, 21301, 81814, 81399, 
81824, 21302, 21281, 81367, 81398
28181, 20942, 20932, 66370, 66380, 20943, 20933, 66371, 66381, 21301, 81814, 81399, 81824, 21303, 81815, 81402, 
81825, 21304, 21283, 81370, 81401
28182, 20943, 20933, 66371, 66381, 20944, 20934, 66372, 66382, 21303, 81815, 81402, 81825, 21305, 81816, 81405, 
81826, 21306, 21285, 81373, 81404
28183, 20944, 20934, 66372, 66382, 1826, 1825, 18408, 18409, 21305, 81816, 81405, 81826, 1848, 19420, 19389, 
19421, 21307, 21286, 81376, 81407
28184, 1692, 1691, 16913, 16914, 20945, 20935, 66373, 66383, 1714, 17925, 17894, 17926, 21308, 81817, 81409, 
81827, 21309, 21288, 81377, 81408
28185, 20945, 20935, 66373, 66383, 20946, 20936, 66374, 66384, 21308, 81817, 81409, 81827, 21310, 81818, 81412, 
81828, 21311, 21290, 81380, 81411
28186, 20946, 20936, 66374, 66384, 20947, 20937, 66375, 66385, 21310, 81818, 81412, 81828, 21312, 81819, 81415, 
81829, 21313, 21292, 81383, 81414
28187, 20947, 20937, 66375, 66385, 20948, 20938, 66376, 66386, 21312, 81819, 81415, 81829, 21314, 81820, 81418, 
81830, 21315, 21294, 81386, 81417
28188, 20948, 20938, 66376, 66386, 20949, 20939, 66377, 66387, 21314, 81820, 81418, 81830, 21316, 81821, 81421, 
81831, 21317, 21296, 81389, 81420
28189, 20949, 20939, 66377, 66387, 20950, 20940, 66378, 66388, 21316, 81821, 81421, 81831, 21318, 81822, 81424, 
81832, 21319, 21298, 81392, 81423
28190, 20950, 20940, 66378, 66388, 20951, 20941, 66379, 66389, 21318, 81822, 81424, 81832, 21320, 81823, 81427, 
81833, 21321, 21300, 81395, 81426
28191, 20951, 20941, 66379, 66389, 20952, 20942, 66380, 66390, 21320, 81823, 81427, 81833, 21322, 81824, 81430, 
81834, 21323, 21302, 81398, 81429
28192, 20952, 20942, 66380, 66390, 20953, 20943, 66381, 66391, 21322, 81824, 81430, 81834, 21324, 81825, 81433, 
81835, 21325, 21304, 81401, 81432
28193, 20953, 20943, 66381, 66391, 20954, 20944, 66382, 66392, 21324, 81825, 81433, 81835, 21326, 81826, 81436, 
81836, 21327, 21306, 81404, 81435
28194, 20954, 20944, 66382, 66392, 1827, 1826, 18409, 18410, 21326, 81826, 81436, 81836, 1849, 19421, 19391, 
19422, 21328, 21307, 81407, 81438
28195, 1693, 1692, 16914, 16915, 20955, 20945, 66383, 66393, 1715, 17926, 17896, 17927, 21329, 81827, 81440, 
81837, 21330, 21309, 81408, 81439
28196, 20955, 20945, 66383, 66393, 20956, 20946, 66384, 66394, 21329, 81827, 81440, 81837, 21331, 81828, 81443, 
81838, 21332, 21311, 81411, 81442
28197, 20956, 20946, 66384, 66394, 20957, 20947, 66385, 66395, 21331, 81828, 81443, 81838, 21333, 81829, 81446, 
81839, 21334, 21313, 81414, 81445
28198, 20957, 20947, 66385, 66395, 20958, 20948, 66386, 66396, 21333, 81829, 81446, 81839, 21335, 81830, 81449, 
81840, 21336, 21315, 81417, 81448
28199, 20958, 20948, 66386, 66396, 20959, 20949, 66387, 66397, 21335, 81830, 81449, 81840, 21337, 81831, 81452, 
81841, 21338, 21317, 81420, 81451
28200, 20959, 20949, 66387, 66397, 20960, 20950, 66388, 66398, 21337, 81831, 81452, 81841, 21339, 81832, 81455, 
81842, 21340, 21319, 81423, 81454
28201, 20960, 20950, 66388, 66398, 20961, 20951, 66389, 66399, 21339, 81832, 81455, 81842, 21341, 81833, 81458, 
81843, 21342, 21321, 81426, 81457
28202, 20961, 20951, 66389, 66399, 20962, 20952, 66390, 66400, 21341, 81833, 81458, 81843, 21343, 81834, 81461, 
81844, 21344, 21323, 81429, 81460
28203, 20962, 20952, 66390, 66400, 20963, 20953, 66391, 66401, 21343, 81834, 81461, 81844, 21345, 81835, 81464, 
81845, 21346, 21325, 81432, 81463
28204, 20963, 20953, 66391, 66401, 20964, 20954, 66392, 66402, 21345, 81835, 81464, 81845, 21347, 81836, 81467, 
81846, 21348, 21327, 81435, 81466
28205, 20964, 20954, 66392, 66402, 1828, 1827, 18410, 18411, 21347, 81836, 81467, 81846, 1850, 19422, 19393, 
19423, 21349, 21328, 81438, 81469
28206, 1694, 1693, 16915, 16916, 20965, 20955, 66393, 66403, 1716, 17927, 17898, 17928, 21350, 81837, 81471, 
81847, 21351, 21330, 81439, 81470
28207, 20965, 20955, 66393, 66403, 20966, 20956, 66394, 66404, 21350, 81837, 81471, 81847, 21352, 81838, 81474, 
81848, 21353, 21332, 81442, 81473
28208, 20966, 20956, 66394, 66404, 20967, 20957, 66395, 66405, 21352, 81838, 81474, 81848, 21354, 81839, 81477, 
81849, 21355, 21334, 81445, 81476
28209, 20967, 20957, 66395, 66405, 20968, 20958, 66396, 66406, 21354, 81839, 81477, 81849, 21356, 81840, 81480, 
81850, 21357, 21336, 81448, 81479
28210, 20968, 20958, 66396, 66406, 20969, 20959, 66397, 66407, 21356, 81840, 81480, 81850, 21358, 81841, 81483, 
81851, 21359, 21338, 81451, 81482
28211, 20969, 20959, 66397, 66407, 20970, 20960, 66398, 66408, 21358, 81841, 81483, 81851, 21360, 81842, 81486, 
81852, 21361, 21340, 81454, 81485
28212, 20970, 20960, 66398, 66408, 20971, 20961, 66399, 66409, 21360, 81842, 81486, 81852, 21362, 81843, 81489, 
81853, 21363, 21342, 81457, 81488
28213, 20971, 20961, 66399, 66409, 20972, 20962, 66400, 66410, 21362, 81843, 81489, 81853, 21364, 81844, 81492, 
81854, 21365, 21344, 81460, 81491
28214, 20972, 20962, 66400, 66410, 20973, 20963, 66401, 66411, 21364, 81844, 81492, 81854, 21366, 81845, 81495, 
81855, 21367, 21346, 81463, 81494
28215, 20973, 20963, 66401, 66411, 20974, 20964, 66402, 66412, 21366, 81845, 81495, 81855, 21368, 81846, 81498, 
81856, 21369, 21348, 81466, 81497
28216, 20974, 20964, 66402, 66412, 1829, 1828, 18411, 18412, 21368, 81846, 81498, 81856, 1851, 19423, 19395, 
19424, 21370, 21349, 81469, 81500
28217, 1695, 1694, 16916, 16917, 20975, 20965, 66403, 66413, 1717, 17928, 17900, 17929, 21371, 81847, 81502, 
81857, 21372, 21351, 81470, 81501
28218, 20975, 20965, 66403, 66413, 20976, 20966, 66404, 66414, 21371, 81847, 81502, 81857, 21373, 81848, 81505, 
81858, 21374, 21353, 81473, 81504
28219, 20976, 20966, 66404, 66414, 20977, 20967, 66405, 66415, 21373, 81848, 81505, 81858, 21375, 81849, 81508, 
81859, 21376, 21355, 81476, 81507
28220, 20977, 20967, 66405, 66415, 20978, 20968, 66406, 66416, 21375, 81849, 81508, 81859, 21377, 81850, 81511, 
81860, 21378, 21357, 81479, 81510
28221, 20978, 20968, 66406, 66416, 20979, 20969, 66407, 66417, 21377, 81850, 81511, 81860, 21379, 81851, 81514, 
81861, 21380, 21359, 81482, 81513
28222, 20979, 20969, 66407, 66417, 20980, 20970, 66408, 66418, 21379, 81851, 81514, 81861, 21381, 81852, 81517, 
81862, 21382, 21361, 81485, 81516
28223, 20980, 20970, 66408, 66418, 20981, 20971, 66409, 66419, 21381, 81852, 81517, 81862, 21383, 81853, 81520, 
81863, 21384, 21363, 81488, 81519
28224, 20981, 20971, 66409, 66419, 20982, 20972, 66410, 66420, 21383, 81853, 81520, 81863, 21385, 81854, 81523, 
81864, 21386, 21365, 81491, 81522
28225, 20982, 20972, 66410, 66420, 20983, 20973, 66411, 66421, 21385, 81854, 81523, 81864, 21387, 81855, 81526, 
81865, 21388, 21367, 81494, 81525
28226, 20983, 20973, 66411, 66421, 20984, 20974, 66412, 66422, 21387, 81855, 81526, 81865, 21389, 81856, 81529, 
81866, 21390, 21369, 81497, 81528
28227, 20984, 20974, 66412, 66422, 1830, 1829, 18412, 18413, 21389, 81856, 81529, 81866, 1852, 19424, 19397, 
19425, 21391, 21370, 81500, 81531
28228, 1696, 1695, 16917, 16918, 20985, 20975, 66413, 66423, 1718, 17929, 17902, 17930, 21392, 81857, 81533, 
81867, 21393, 21372, 81501, 81532
28229, 20985, 20975, 66413, 66423, 20986, 20976, 66414, 66424, 21392, 81857, 81533, 81867, 21394, 81858, 81536, 
81868, 21395, 21374, 81504, 81535
28230, 20986, 20976, 66414, 66424, 20987, 20977, 66415, 66425, 21394, 81858, 81536, 81868, 21396, 81859, 81539, 
81869, 21397, 21376, 81507, 81538
28231, 20987, 20977, 66415, 66425, 20988, 20978, 66416, 66426, 21396, 81859, 81539, 81869, 21398, 81860, 81542, 
81870, 21399, 21378, 81510, 81541
28232, 20988, 20978, 66416, 66426, 20989, 20979, 66417, 66427, 21398, 81860, 81542, 81870, 21400, 81861, 81545, 
81871, 21401, 21380, 81513, 81544
28233, 20989, 20979, 66417, 66427, 20990, 20980, 66418, 66428, 21400, 81861, 81545, 81871, 21402, 81862, 81548, 
81872, 21403, 21382, 81516, 81547
28234, 20990, 20980, 66418, 66428, 20991, 20981, 66419, 66429, 21402, 81862, 81548, 81872, 21404, 81863, 81551, 
81873, 21405, 21384, 81519, 81550
28235, 20991, 20981, 66419, 66429, 20992, 20982, 66420, 66430, 21404, 81863, 81551, 81873, 21406, 81864, 81554, 
81874, 21407, 21386, 81522, 81553
28236, 20992, 20982, 66420, 66430, 20993, 20983, 66421, 66431, 21406, 81864, 81554, 81874, 21408, 81865, 81557, 
81875, 21409, 21388, 81525, 81556
28237, 20993, 20983, 66421, 66431, 20994, 20984, 66422, 66432, 21408, 81865, 81557, 81875, 21410, 81866, 81560, 
81876, 21411, 21390, 81528, 81559
28238, 20994, 20984, 66422, 66432, 1831, 1830, 18413, 18414, 21410, 81866, 81560, 81876, 1853, 19425, 19399, 
19426, 21412, 21391, 81531, 81562
28239, 1697, 1696, 16918, 16919, 20995, 20985, 66423, 66433, 1719, 17930, 17904, 17931, 21413, 81867, 81564, 
81877, 21414, 21393, 81532, 81563
28240, 20995, 20985, 66423, 66433, 20996, 20986, 66424, 66434, 21413, 81867, 81564, 81877, 21415, 81868, 81567, 
81878, 21416, 21395, 81535, 81566
28241, 20996, 20986, 66424, 66434, 20997, 20987, 66425, 66435, 21415, 81868, 81567, 81878, 21417, 81869, 81570, 
81879, 21418, 21397, 81538, 81569
28242, 20997, 20987, 66425, 66435, 20998, 20988, 66426, 66436, 21417, 81869, 81570, 81879, 21419, 81870, 81573, 
81880, 21420, 21399, 81541, 81572
28243, 20998, 20988, 66426, 66436, 20999, 20989, 66427, 66437, 21419, 81870, 81573, 81880, 21421, 81871, 81576, 
81881, 21422, 21401, 81544, 81575
28244, 20999, 20989, 66427, 66437, 21000, 20990, 66428, 66438, 21421, 81871, 81576, 81881, 21423, 81872, 81579, 
81882, 21424, 21403, 81547, 81578
28245, 21000, 20990, 66428, 66438, 21001, 20991, 66429, 66439, 21423, 81872, 81579, 81882, 21425, 81873, 81582, 
81883, 21426, 21405, 81550, 81581
28246, 21001, 20991, 66429, 66439, 21002, 20992, 66430, 66440, 21425, 81873, 81582, 81883, 21427, 81874, 81585, 
81884, 21428, 21407, 81553, 81584
28247, 21002, 20992, 66430, 66440, 21003, 20993, 66431, 66441, 21427, 81874, 81585, 81884, 21429, 81875, 81588, 
81885, 21430, 21409, 81556, 81587
28248, 21003, 20993, 66431, 66441, 21004, 20994, 66432, 66442, 21429, 81875, 81588, 81885, 21431, 81876, 81591, 
81886, 21432, 21411, 81559, 81590
28249, 21004, 20994, 66432, 66442, 1832, 1831, 18414, 18415, 21431, 81876, 81591, 81886, 1854, 19426, 19401, 
19427, 21433, 21412, 81562, 81593
28250, 1698, 1697, 16919, 16920, 21005, 20995, 66433, 66443, 1720, 17931, 17906, 17932, 21434, 81877, 81595, 
81887, 21435, 21414, 81563, 81594
28251, 21005, 20995, 66433, 66443, 21006, 20996, 66434, 66444, 21434, 81877, 81595, 81887, 21436, 81878, 81598, 
81888, 21437, 21416, 81566, 81597
28252, 21006, 20996, 66434, 66444, 21007, 20997, 66435, 66445, 21436, 81878, 81598, 81888, 21438, 81879, 81601, 
81889, 21439, 21418, 81569, 81600
28253, 21007, 20997, 66435, 66445, 21008, 20998, 66436, 66446, 21438, 81879, 81601, 81889, 21440, 81880, 81604, 
81890, 21441, 21420, 81572, 81603
28254, 21008, 20998, 66436, 66446, 21009, 20999, 66437, 66447, 21440, 81880, 81604, 81890, 21442, 81881, 81607, 
81891, 21443, 21422, 81575, 81606
28255, 21009, 20999, 66437, 66447, 21010, 21000, 66438, 66448, 21442, 81881, 81607, 81891, 21444, 81882, 81610, 
81892, 21445, 21424, 81578, 81609
28256, 21010, 21000, 66438, 66448, 21011, 21001, 66439, 66449, 21444, 81882, 81610, 81892, 21446, 81883, 81613, 
81893, 21447, 21426, 81581, 81612
28257, 21011, 21001, 66439, 66449, 21012, 21002, 66440, 66450, 21446, 81883, 81613, 81893, 21448, 81884, 81616, 
81894, 21449, 21428, 81584, 81615
28258, 21012, 21002, 66440, 66450, 21013, 21003, 66441, 66451, 21448, 81884, 81616, 81894, 21450, 81885, 81619, 
81895, 21451, 21430, 81587, 81618
28259, 21013, 21003, 66441, 66451, 21014, 21004, 66442, 66452, 21450, 81885, 81619, 81895, 21452, 81886, 81622, 
81896, 21453, 21432, 81590, 81621
28260, 21014, 21004, 66442, 66452, 1833, 1832, 18415, 18416, 21452, 81886, 81622, 81896, 1855, 19427, 19403, 
19428, 21454, 21433, 81593, 81624
28261, 1699, 1698, 16920, 16921, 21015, 21005, 66443, 66453, 1721, 17932, 17908, 17933, 21455, 81887, 81626, 
81897, 21456, 21435, 81594, 81625
28262, 21015, 21005, 66443, 66453, 21016, 21006, 66444, 66454, 21455, 81887, 81626, 81897, 21457, 81888, 81629, 
81898, 21458, 21437, 81597, 81628
28263, 21016, 21006, 66444, 66454, 21017, 21007, 66445, 66455, 21457, 81888, 81629, 81898, 21459, 81889, 81632, 
81899, 21460, 21439, 81600, 81631
28264, 21017, 21007, 66445, 66455, 21018, 21008, 66446, 66456, 21459, 81889, 81632, 81899, 21461, 81890, 81635, 
81900, 21462, 21441, 81603, 81634
28265, 21018, 21008, 66446, 66456, 21019, 21009, 66447, 66457, 21461, 81890, 81635, 81900, 21463, 81891, 81638, 
81901, 21464, 21443, 81606, 81637
28266, 21019, 21009, 66447, 66457, 21020, 21010, 66448, 66458, 21463, 81891, 81638, 81901, 21465, 81892, 81641, 
81902, 21466, 21445, 81609, 81640
28267, 21020, 21010, 66448, 66458, 21021, 21011, 66449, 66459, 21465, 81892, 81641, 81902, 21467, 81893, 81644, 
81903, 21468, 21447, 81612, 81643
28268, 21021, 21011, 66449, 66459, 21022, 21012, 66450, 66460, 21467, 81893, 81644, 81903, 21469, 81894, 81647, 
81904, 21470, 21449, 81615, 81646
28269, 21022, 21012, 66450, 66460, 21023, 21013, 66451, 66461, 21469, 81894, 81647, 81904, 21471, 81895, 81650, 
81905, 21472, 21451, 81618, 81649
28270, 21023, 21013, 66451, 66461, 21024, 21014, 66452, 66462, 21471, 81895, 81650, 81905, 21473, 81896, 81653, 
81906, 21474, 21453, 81621, 81652
28271, 21024, 21014, 66452, 66462, 1834, 1833, 18416, 18417, 21473, 81896, 81653, 81906, 1856, 19428, 19405, 
19429, 21475, 21454, 81624, 81655
28272, 1700, 1699, 16921, 16922, 21025, 21015, 66453, 66463, 1722, 17933, 17910, 17934, 21476, 81897, 81657, 
81907, 21477, 21456, 81625, 81656
28273, 21025, 21015, 66453, 66463, 21026, 21016, 66454, 66464, 21476, 81897, 81657, 81907, 21478, 81898, 81660, 
81908, 21479, 21458, 81628, 81659
28274, 21026, 21016, 66454, 66464, 21027, 21017, 66455, 66465, 21478, 81898, 81660, 81908, 21480, 81899, 81663, 
81909, 21481, 21460, 81631, 81662
28275, 21027, 21017, 66455, 66465, 21028, 21018, 66456, 66466, 21480, 81899, 81663, 81909, 21482, 81900, 81666, 
81910, 21483, 21462, 81634, 81665
28276, 21028, 21018, 66456, 66466, 21029, 21019, 66457, 66467, 21482, 81900, 81666, 81910, 21484, 81901, 81669, 
81911, 21485, 21464, 81637, 81668
28277, 21029, 21019, 66457, 66467, 21030, 21020, 66458, 66468, 21484, 81901, 81669, 81911, 21486, 81902, 81672, 
81912, 21487, 21466, 81640, 81671
28278, 21030, 21020, 66458, 66468, 21031, 21021, 66459, 66469, 21486, 81902, 81672, 81912, 21488, 81903, 81675, 
81913, 21489, 21468, 81643, 81674
28279, 21031, 21021, 66459, 66469, 21032, 21022, 66460, 66470, 21488, 81903, 81675, 81913, 21490, 81904, 81678, 
81914, 21491, 21470, 81646, 81677
28280, 21032, 21022, 66460, 66470, 21033, 21023, 66461, 66471, 21490, 81904, 81678, 81914, 21492, 81905, 81681, 
81915, 21493, 21472, 81649, 81680
28281, 21033, 21023, 66461, 66471, 21034, 21024, 66462, 66472, 21492, 81905, 81681, 81915, 21494, 81906, 81684, 
81916, 21495, 21474, 81652, 81683
28282, 21034, 21024, 66462, 66472, 1835, 1834, 18417, 18418, 21494, 81906, 81684, 81916, 1857, 19429, 19407, 
19430, 21496, 21475, 81655, 81686
28283, 38, 1700, 16922, 1655, 1889, 21025, 66463, 20333, 1723, 17934, 17912, 1678, 21497, 81907, 81687, 
20805, 1900, 21477, 81656, 20784
28284, 1889, 21025, 66463, 20333, 1888, 21026, 66464, 20334, 21497, 81907, 81687, 20805, 21498, 81908, 81688, 
20806, 1899, 21479, 81659, 20786
28285, 1888, 21026, 66464, 20334, 1887, 21027, 66465, 20335, 21498, 81908, 81688, 20806, 21499, 81909, 81689, 
20807, 1898, 21481, 81662, 20788
28286, 1887, 21027, 66465, 20335, 1886, 21028, 66466, 20336, 21499, 81909, 81689, 20807, 21500, 81910, 81690, 
20808, 1897, 21483, 81665, 20790
28287, 1886, 21028, 66466, 20336, 1885, 21029, 66467, 20337, 21500, 81910, 81690, 20808, 21501, 81911, 81691, 
20809, 1896, 21485, 81668, 20792
28288, 1885, 21029, 66467, 20337, 1884, 21030, 66468, 20338, 21501, 81911, 81691, 20809, 21502, 81912, 81692, 
20810, 1895, 21487, 81671, 20794
28289, 1884, 21030, 66468, 20338, 1883, 21031, 66469, 20339, 21502, 81912, 81692, 20810, 21503, 81913, 81693, 
20811, 1894, 21489, 81674, 20796
28290, 1883, 21031, 66469, 20339, 1882, 21032, 66470, 20340, 21503, 81913, 81693, 20811, 21504, 81914, 81694, 
20812, 1893, 21491, 81677, 20798
28291, 1882, 21032, 66470, 20340, 1881, 21033, 66471, 20341, 21504, 81914, 81694, 20812, 21505, 81915, 81695, 
20813, 1892, 21493, 81680, 20800
28292, 1881, 21033, 66471, 20341, 1880, 21034, 66472, 20342, 21505, 81915, 81695, 20813, 21506, 81916, 81696, 
20814, 1891, 21495, 81683, 20802
28293, 1880, 21034, 66472, 20342, 40, 1835, 18418, 1790, 21506, 81916, 81696, 20814, 1858, 19430, 19408, 
1813, 1890, 21496, 81686, 20804
*ELEMENT, type=C3D20, ELSET=Volume10
28294, 21507, 1901, 37, 1679, 81917, 21685, 1868, 20815, 21529, 1902, 1701, 21530, 82138, 21695, 21035, 
82139, 82137, 21696, 1879, 21036
28295, 81917, 21685, 1868, 20815, 81918, 21686, 1867, 20816, 82138, 21695, 21035, 82139, 82141, 21697, 21037, 
82142, 82140, 21698, 1878, 21038
28296, 81918, 21686, 1867, 20816, 81919, 21687, 1866, 20817, 82141, 21697, 21037, 82142, 82144, 21699, 21039, 
82145, 82143, 21700, 1877, 21040
28297, 81919, 21687, 1866, 20817, 81920, 21688, 1865, 20818, 82144, 21699, 21039, 82145, 82147, 21701, 21041, 
82148, 82146, 21702, 1876, 21042
28298, 81920, 21688, 1865, 20818, 81921, 21689, 1864, 20819, 82147, 21701, 21041, 82148, 82150, 21703, 21043, 
82151, 82149, 21704, 1875, 21044
28299, 81921, 21689, 1864, 20819, 81922, 21690, 1863, 20820, 82150, 21703, 21043, 82151, 82153, 21705, 21045, 
82154, 82152, 21706, 1874, 21046
28300, 81922, 21690, 1863, 20820, 81923, 21691, 1862, 20821, 82153, 21705, 21045, 82154, 82156, 21707, 21047, 
82157, 82155, 21708, 1873, 21048
28301, 81923, 21691, 1862, 20821, 81924, 21692, 1861, 20822, 82156, 21707, 21047, 82157, 82159, 21709, 21049, 
82160, 82158, 21710, 1872, 21050
28302, 81924, 21692, 1861, 20822, 81925, 21693, 1860, 20823, 82159, 21709, 21049, 82160, 82162, 21711, 21051, 
82163, 82161, 21712, 1871, 21052
28303, 81925, 21693, 1860, 20823, 81926, 21694, 1859, 20824, 82162, 21711, 21051, 82163, 82165, 21713, 21053, 
82166, 82164, 21714, 1870, 21054
28304, 81926, 21694, 1859, 20824, 21596, 1952, 39, 1814, 82165, 21713, 21053, 82166, 21619, 1953, 1836, 
21618, 82167, 21715, 1869, 21055
28305, 21508, 21507, 1679, 1680, 81927, 81917, 20815, 20825, 21531, 21530, 1702, 21532, 82169, 82139, 21056, 
82170, 82168, 82137, 21036, 21057
28306, 81927, 81917, 20815, 20825, 81928, 81918, 20816, 20826, 82169, 82139, 21056, 82170, 82172, 82142, 21058, 
82173, 82171, 82140, 21038, 21059
28307, 81928, 81918, 20816, 20826, 81929, 81919, 20817, 20827, 82172, 82142, 21058, 82173, 82175, 82145, 21060, 
82176, 82174, 82143, 21040, 21061
28308, 81929, 81919, 20817, 20827, 81930, 81920, 20818, 20828, 82175, 82145, 21060, 82176, 82178, 82148, 21062, 
82179, 82177, 82146, 21042, 21063
28309, 81930, 81920, 20818, 20828, 81931, 81921, 20819, 20829, 82178, 82148, 21062, 82179, 82181, 82151, 21064, 
82182, 82180, 82149, 21044, 21065
28310, 81931, 81921, 20819, 20829, 81932, 81922, 20820, 20830, 82181, 82151, 21064, 82182, 82184, 82154, 21066, 
82185, 82183, 82152, 21046, 21067
28311, 81932, 81922, 20820, 20830, 81933, 81923, 20821, 20831, 82184, 82154, 21066, 82185, 82187, 82157, 21068, 
82188, 82186, 82155, 21048, 21069
28312, 81933, 81923, 20821, 20831, 81934, 81924, 20822, 20832, 82187, 82157, 21068, 82188, 82190, 82160, 21070, 
82191, 82189, 82158, 21050, 21071
28313, 81934, 81924, 20822, 20832, 81935, 81925, 20823, 20833, 82190, 82160, 21070, 82191, 82193, 82163, 21072, 
82194, 82192, 82161, 21052, 21073
28314, 81935, 81925, 20823, 20833, 81936, 81926, 20824, 20834, 82193, 82163, 21072, 82194, 82196, 82166, 21074, 
82197, 82195, 82164, 21054, 21075
28315, 81936, 81926, 20824, 20834, 21597, 21596, 1814, 1815, 82196, 82166, 21074, 82197, 21621, 21618, 1837, 
21620, 82198, 82167, 21055, 21076
28316, 21509, 21508, 1680, 1681, 81937, 81927, 20825, 20835, 21533, 21532, 1703, 21534, 82200, 82170, 21077, 
82201, 82199, 82168, 21057, 21078
28317, 81937, 81927, 20825, 20835, 81938, 81928, 20826, 20836, 82200, 82170, 21077, 82201, 82203, 82173, 21079, 
82204, 82202, 82171, 21059, 21080
28318, 81938, 81928, 20826, 20836, 81939, 81929, 20827, 20837, 82203, 82173, 21079, 82204, 82206, 82176, 21081, 
82207, 82205, 82174, 21061, 21082
28319, 81939, 81929, 20827, 20837, 81940, 81930, 20828, 20838, 82206, 82176, 21081, 82207, 82209, 82179, 21083, 
82210, 82208, 82177, 21063, 21084
28320, 81940, 81930, 20828, 20838, 81941, 81931, 20829, 20839, 82209, 82179, 21083, 82210, 82212, 82182, 21085, 
82213, 82211, 82180, 21065, 21086
28321, 81941, 81931, 20829, 20839, 81942, 81932, 20830, 20840, 82212, 82182, 21085, 82213, 82215, 82185, 21087, 
82216, 82214, 82183, 21067, 21088
28322, 81942, 81932, 20830, 20840, 81943, 81933, 20831, 20841, 82215, 82185, 21087, 82216, 82218, 82188, 21089, 
82219, 82217, 82186, 21069, 21090
28323, 81943, 81933, 20831, 20841, 81944, 81934, 20832, 20842, 82218, 82188, 21089, 82219, 82221, 82191, 21091, 
82222, 82220, 82189, 21071, 21092
28324, 81944, 81934, 20832, 20842, 81945, 81935, 20833, 20843, 82221, 82191, 21091, 82222, 82224, 82194, 21093, 
82225, 82223, 82192, 21073, 21094
28325, 81945, 81935, 20833, 20843, 81946, 81936, 20834, 20844, 82224, 82194, 21093, 82225, 82227, 82197, 21095, 
82228, 82226, 82195, 21075, 21096
28326, 81946, 81936, 20834, 20844, 21598, 21597, 1815, 1816, 82227, 82197, 21095, 82228, 21623, 21620, 1838, 
21622, 82229, 82198, 21076, 21097
28327, 21510, 21509, 1681, 1682, 81947, 81937, 20835, 20845, 21535, 21534, 1704, 21536, 82231, 82201, 21098, 
82232, 82230, 82199, 21078, 21099
28328, 81947, 81937, 20835, 20845, 81948, 81938, 20836, 20846, 82231, 82201, 21098, 82232, 82234, 82204, 21100, 
82235, 82233, 82202, 21080, 21101
28329, 81948, 81938, 20836, 20846, 81949, 81939, 20837, 20847, 82234, 82204, 21100, 82235, 82237, 82207, 21102, 
82238, 82236, 82205, 21082, 21103
28330, 81949, 81939, 20837, 20847, 81950, 81940, 20838, 20848, 82237, 82207, 21102, 82238, 82240, 82210, 21104, 
82241, 82239, 82208, 21084, 21105
28331, 81950, 81940, 20838, 20848, 81951, 81941, 20839, 20849, 82240, 82210, 21104, 82241, 82243, 82213, 21106, 
82244, 82242, 82211, 21086, 21107
28332, 81951, 81941, 20839, 20849, 81952, 81942, 20840, 20850, 82243, 82213, 21106, 82244, 82246, 82216, 21108, 
82247, 82245, 82214, 21088, 21109
28333, 81952, 81942, 20840, 20850, 81953, 81943, 20841, 20851, 82246, 82216, 21108, 82247, 82249, 82219, 21110, 
82250, 82248, 82217, 21090, 21111
28334, 81953, 81943, 20841, 20851, 81954, 81944, 20842, 20852, 82249, 82219, 21110, 82250, 82252, 82222, 21112, 
82253, 82251, 82220, 21092, 21113
28335, 81954, 81944, 20842, 20852, 81955, 81945, 20843, 20853, 82252, 82222, 21112, 82253, 82255, 82225, 21114, 
82256, 82254, 82223, 21094, 21115
28336, 81955, 81945, 20843, 20853, 81956, 81946, 20844, 20854, 82255, 82225, 21114, 82256, 82258, 82228, 21116, 
82259, 82257, 82226, 21096, 21117
28337, 81956, 81946, 20844, 20854, 21599, 21598, 1816, 1817, 82258, 82228, 21116, 82259, 21625, 21622, 1839, 
21624, 82260, 82229, 21097, 21118
28338, 21511, 21510, 1682, 1683, 81957, 81947, 20845, 20855, 21537, 21536, 1705, 21538, 82262, 82232, 21119, 
82263, 82261, 82230, 21099, 21120
28339, 81957, 81947, 20845, 20855, 81958, 81948, 20846, 20856, 82262, 82232, 21119, 82263, 82265, 82235, 21121, 
82266, 82264, 82233, 21101, 21122
28340, 81958, 81948, 20846, 20856, 81959, 81949, 20847, 20857, 82265, 82235, 21121, 82266, 82268, 82238, 21123, 
82269, 82267, 82236, 21103, 21124
28341, 81959, 81949, 20847, 20857, 81960, 81950, 20848, 20858, 82268, 82238, 21123, 82269, 82271, 82241, 21125, 
82272, 82270, 82239, 21105, 21126
28342, 81960, 81950, 20848, 20858, 81961, 81951, 20849, 20859, 82271, 82241, 21125, 82272, 82274, 82244, 21127, 
82275, 82273, 82242, 21107, 21128
28343, 81961, 81951, 20849, 20859, 81962, 81952, 20850, 20860, 82274, 82244, 21127, 82275, 82277, 82247, 21129, 
82278, 82276, 82245, 21109, 21130
28344, 81962, 81952, 20850, 20860, 81963, 81953, 20851, 20861, 82277, 82247, 21129, 82278, 82280, 82250, 21131, 
82281, 82279, 82248, 21111, 21132
28345, 81963, 81953, 20851, 20861, 81964, 81954, 20852, 20862, 82280, 82250, 21131, 82281, 82283, 82253, 21133, 
82284, 82282, 82251, 21113, 21134
28346, 81964, 81954, 20852, 20862, 81965, 81955, 20853, 20863, 82283, 82253, 21133, 82284, 82286, 82256, 21135, 
82287, 82285, 82254, 21115, 21136
28347, 81965, 81955, 20853, 20863, 81966, 81956, 20854, 20864, 82286, 82256, 21135, 82287, 82289, 82259, 21137, 
82290, 82288, 82257, 21117, 21138
28348, 81966, 81956, 20854, 20864, 21600, 21599, 1817, 1818, 82289, 82259, 21137, 82290, 21627, 21624, 1840, 
21626, 82291, 82260, 21118, 21139
28349, 21512, 21511, 1683, 1684, 81967, 81957, 20855, 20865, 21539, 21538, 1706, 21540, 82293, 82263, 21140, 
82294, 82292, 82261, 21120, 21141
28350, 81967, 81957, 20855, 20865, 81968, 81958, 20856, 20866, 82293, 82263, 21140, 82294, 82296, 82266, 21142, 
82297, 82295, 82264, 21122, 21143
28351, 81968, 81958, 20856, 20866, 81969, 81959, 20857, 20867, 82296, 82266, 21142, 82297, 82299, 82269, 21144, 
82300, 82298, 82267, 21124, 21145
28352, 81969, 81959, 20857, 20867, 81970, 81960, 20858, 20868, 82299, 82269, 21144, 82300, 82302, 82272, 21146, 
82303, 82301, 82270, 21126, 21147
28353, 81970, 81960, 20858, 20868, 81971, 81961, 20859, 20869, 82302, 82272, 21146, 82303, 82305, 82275, 21148, 
82306, 82304, 82273, 21128, 21149
28354, 81971, 81961, 20859, 20869, 81972, 81962, 20860, 20870, 82305, 82275, 21148, 82306, 82308, 82278, 21150, 
82309, 82307, 82276, 21130, 21151
28355, 81972, 81962, 20860, 20870, 81973, 81963, 20861, 20871, 82308, 82278, 21150, 82309, 82311, 82281, 21152, 
82312, 82310, 82279, 21132, 21153
28356, 81973, 81963, 20861, 20871, 81974, 81964, 20862, 20872, 82311, 82281, 21152, 82312, 82314, 82284, 21154, 
82315, 82313, 82282, 21134, 21155
28357, 81974, 81964, 20862, 20872, 81975, 81965, 20863, 20873, 82314, 82284, 21154, 82315, 82317, 82287, 21156, 
82318, 82316, 82285, 21136, 21157
28358, 81975, 81965, 20863, 20873, 81976, 81966, 20864, 20874, 82317, 82287, 21156, 82318, 82320, 82290, 21158, 
82321, 82319, 82288, 21138, 21159
28359, 81976, 81966, 20864, 20874, 21601, 21600, 1818, 1819, 82320, 82290, 21158, 82321, 21629, 21626, 1841, 
21628, 82322, 82291, 21139, 21160
28360, 21513, 21512, 1684, 1685, 81977, 81967, 20865, 20875, 21541, 21540, 1707, 21542, 82324, 82294, 21161, 
82325, 82323, 82292, 21141, 21162
28361, 81977, 81967, 20865, 20875, 81978, 81968, 20866, 20876, 82324, 82294, 21161, 82325, 82327, 82297, 21163, 
82328, 82326, 82295, 21143, 21164
28362, 81978, 81968, 20866, 20876, 81979, 81969, 20867, 20877, 82327, 82297, 21163, 82328, 82330, 82300, 21165, 
82331, 82329, 82298, 21145, 21166
28363, 81979, 81969, 20867, 20877, 81980, 81970, 20868, 20878, 82330, 82300, 21165, 82331, 82333, 82303, 21167, 
82334, 82332, 82301, 21147, 21168
28364, 81980, 81970, 20868, 20878, 81981, 81971, 20869, 20879, 82333, 82303, 21167, 82334, 82336, 82306, 21169, 
82337, 82335, 82304, 21149, 21170
28365, 81981, 81971, 20869, 20879, 81982, 81972, 20870, 20880, 82336, 82306, 21169, 82337, 82339, 82309, 21171, 
82340, 82338, 82307, 21151, 21172
28366, 81982, 81972, 20870, 20880, 81983, 81973, 20871, 20881, 82339, 82309, 21171, 82340, 82342, 82312, 21173, 
82343, 82341, 82310, 21153, 21174
28367, 81983, 81973, 20871, 20881, 81984, 81974, 20872, 20882, 82342, 82312, 21173, 82343, 82345, 82315, 21175, 
82346, 82344, 82313, 21155, 21176
28368, 81984, 81974, 20872, 20882, 81985, 81975, 20873, 20883, 82345, 82315, 21175, 82346, 82348, 82318, 21177, 
82349, 82347, 82316, 21157, 21178
28369, 81985, 81975, 20873, 20883, 81986, 81976, 20874, 20884, 82348, 82318, 21177, 82349, 82351, 82321, 21179, 
82352, 82350, 82319, 21159, 21180
28370, 81986, 81976, 20874, 20884, 21602, 21601, 1819, 1820, 82351, 82321, 21179, 82352, 21631, 21628, 1842, 
21630, 82353, 82322, 21160, 21181
28371, 21514, 21513, 1685, 1686, 81987, 81977, 20875, 20885, 21543, 21542, 1708, 21544, 82355, 82325, 21182, 
82356, 82354, 82323, 21162, 21183
28372, 81987, 81977, 20875, 20885, 81988, 81978, 20876, 20886, 82355, 82325, 21182, 82356, 82358, 82328, 21184, 
82359, 82357, 82326, 21164, 21185
28373, 81988, 81978, 20876, 20886, 81989, 81979, 20877, 20887, 82358, 82328, 21184, 82359, 82361, 82331, 21186, 
82362, 82360, 82329, 21166, 21187
28374, 81989, 81979, 20877, 20887, 81990, 81980, 20878, 20888, 82361, 82331, 21186, 82362, 82364, 82334, 21188, 
82365, 82363, 82332, 21168, 21189
28375, 81990, 81980, 20878, 20888, 81991, 81981, 20879, 20889, 82364, 82334, 21188, 82365, 82367, 82337, 21190, 
82368, 82366, 82335, 21170, 21191
28376, 81991, 81981, 20879, 20889, 81992, 81982, 20880, 20890, 82367, 82337, 21190, 82368, 82370, 82340, 21192, 
82371, 82369, 82338, 21172, 21193
28377, 81992, 81982, 20880, 20890, 81993, 81983, 20881, 20891, 82370, 82340, 21192, 82371, 82373, 82343, 21194, 
82374, 82372, 82341, 21174, 21195
28378, 81993, 81983, 20881, 20891, 81994, 81984, 20882, 20892, 82373, 82343, 21194, 82374, 82376, 82346, 21196, 
82377, 82375, 82344, 21176, 21197
28379, 81994, 81984, 20882, 20892, 81995, 81985, 20883, 20893, 82376, 82346, 21196, 82377, 82379, 82349, 21198, 
82380, 82378, 82347, 21178, 21199
28380, 81995, 81985, 20883, 20893, 81996, 81986, 20884, 20894, 82379, 82349, 21198, 82380, 82382, 82352, 21200, 
82383, 82381, 82350, 21180, 21201
28381, 81996, 81986, 20884, 20894, 21603, 21602, 1820, 1821, 82382, 82352, 21200, 82383, 21633, 21630, 1843, 
21632, 82384, 82353, 21181, 21202
28382, 21515, 21514, 1686, 1687, 81997, 81987, 20885, 20895, 21545, 21544, 1709, 21546, 82386, 82356, 21203, 
82387, 82385, 82354, 21183, 21204
28383, 81997, 81987, 20885, 20895, 81998, 81988, 20886, 20896, 82386, 82356, 21203, 82387, 82389, 82359, 21205, 
82390, 82388, 82357, 21185, 21206
28384, 81998, 81988, 20886, 20896, 81999, 81989, 20887, 20897, 82389, 82359, 21205, 82390, 82392, 82362, 21207, 
82393, 82391, 82360, 21187, 21208
28385, 81999, 81989, 20887, 20897, 82000, 81990, 20888, 20898, 82392, 82362, 21207, 82393, 82395, 82365, 21209, 
82396, 82394, 82363, 21189, 21210
28386, 82000, 81990, 20888, 20898, 82001, 81991, 20889, 20899, 82395, 82365, 21209, 82396, 82398, 82368, 21211, 
82399, 82397, 82366, 21191, 21212
28387, 82001, 81991, 20889, 20899, 82002, 81992, 20890, 20900, 82398, 82368, 21211, 82399, 82401, 82371, 21213, 
82402, 82400, 82369, 21193, 21214
28388, 82002, 81992, 20890, 20900, 82003, 81993, 20891, 20901, 82401, 82371, 21213, 82402, 82404, 82374, 21215, 
82405, 82403, 82372, 21195, 21216
28389, 82003, 81993, 20891, 20901, 82004, 81994, 20892, 20902, 82404, 82374, 21215, 82405, 82407, 82377, 21217, 
82408, 82406, 82375, 21197, 21218
28390, 82004, 81994, 20892, 20902, 82005, 81995, 20893, 20903, 82407, 82377, 21217, 82408, 82410, 82380, 21219, 
82411, 82409, 82378, 21199, 21220
28391, 82005, 81995, 20893, 20903, 82006, 81996, 20894, 20904, 82410, 82380, 21219, 82411, 82413, 82383, 21221, 
82414, 82412, 82381, 21201, 21222
28392, 82006, 81996, 20894, 20904, 21604, 21603, 1821, 1822, 82413, 82383, 21221, 82414, 21635, 21632, 1844, 
21634, 82415, 82384, 21202, 21223
28393, 21516, 21515, 1687, 1688, 82007, 81997, 20895, 20905, 21547, 21546, 1710, 21548, 82417, 82387, 21224, 
82418, 82416, 82385, 21204, 21225
28394, 82007, 81997, 20895, 20905, 82008, 81998, 20896, 20906, 82417, 82387, 21224, 82418, 82420, 82390, 21226, 
82421, 82419, 82388, 21206, 21227
28395, 82008, 81998, 20896, 20906, 82009, 81999, 20897, 20907, 82420, 82390, 21226, 82421, 82423, 82393, 21228, 
82424, 82422, 82391, 21208, 21229
28396, 82009, 81999, 20897, 20907, 82010, 82000, 20898, 20908, 82423, 82393, 21228, 82424, 82426, 82396, 21230, 
82427, 82425, 82394, 21210, 21231
28397, 82010, 82000, 20898, 20908, 82011, 82001, 20899, 20909, 82426, 82396, 21230, 82427, 82429, 82399, 21232, 
82430, 82428, 82397, 21212, 21233
28398, 82011, 82001, 20899, 20909, 82012, 82002, 20900, 20910, 82429, 82399, 21232, 82430, 82432, 82402, 21234, 
82433, 82431, 82400, 21214, 21235
28399, 82012, 82002, 20900, 20910, 82013, 82003, 20901, 20911, 82432, 82402, 21234, 82433, 82435, 82405, 21236, 
82436, 82434, 82403, 21216, 21237
28400, 82013, 82003, 20901, 20911, 82014, 82004, 20902, 20912, 82435, 82405, 21236, 82436, 82438, 82408, 21238, 
82439, 82437, 82406, 21218, 21239
28401, 82014, 82004, 20902, 20912, 82015, 82005, 20903, 20913, 82438, 82408, 21238, 82439, 82441, 82411, 21240, 
82442, 82440, 82409, 21220, 21241
28402, 82015, 82005, 20903, 20913, 82016, 82006, 20904, 20914, 82441, 82411, 21240, 82442, 82444, 82414, 21242, 
82445, 82443, 82412, 21222, 21243
28403, 82016, 82006, 20904, 20914, 21605, 21604, 1822, 1823, 82444, 82414, 21242, 82445, 21637, 21634, 1845, 
21636, 82446, 82415, 21223, 21244
28404, 21517, 21516, 1688, 1689, 82017, 82007, 20905, 20915, 21549, 21548, 1711, 21550, 82448, 82418, 21245, 
82449, 82447, 82416, 21225, 21246
28405, 82017, 82007, 20905, 20915, 82018, 82008, 20906, 20916, 82448, 82418, 21245, 82449, 82451, 82421, 21247, 
82452, 82450, 82419, 21227, 21248
28406, 82018, 82008, 20906, 20916, 82019, 82009, 20907, 20917, 82451, 82421, 21247, 82452, 82454, 82424, 21249, 
82455, 82453, 82422, 21229, 21250
28407, 82019, 82009, 20907, 20917, 82020, 82010, 20908, 20918, 82454, 82424, 21249, 82455, 82457, 82427, 21251, 
82458, 82456, 82425, 21231, 21252
28408, 82020, 82010, 20908, 20918, 82021, 82011, 20909, 20919, 82457, 82427, 21251, 82458, 82460, 82430, 21253, 
82461, 82459, 82428, 21233, 21254
28409, 82021, 82011, 20909, 20919, 82022, 82012, 20910, 20920, 82460, 82430, 21253, 82461, 82463, 82433, 21255, 
82464, 82462, 82431, 21235, 21256
28410, 82022, 82012, 20910, 20920, 82023, 82013, 20911, 20921, 82463, 82433, 21255, 82464, 82466, 82436, 21257, 
82467, 82465, 82434, 21237, 21258
28411, 82023, 82013, 20911, 20921, 82024, 82014, 20912, 20922, 82466, 82436, 21257, 82467, 82469, 82439, 21259, 
82470, 82468, 82437, 21239, 21260
28412, 82024, 82014, 20912, 20922, 82025, 82015, 20913, 20923, 82469, 82439, 21259, 82470, 82472, 82442, 21261, 
82473, 82471, 82440, 21241, 21262
28413, 82025, 82015, 20913, 20923, 82026, 82016, 20914, 20924, 82472, 82442, 21261, 82473, 82475, 82445, 21263, 
82476, 82474, 82443, 21243, 21264
28414, 82026, 82016, 20914, 20924, 21606, 21605, 1823, 1824, 82475, 82445, 21263, 82476, 21639, 21636, 1846, 
21638, 82477, 82446, 21244, 21265
28415, 21518, 21517, 1689, 1690, 82027, 82017, 20915, 20925, 21551, 21550, 1712, 21552, 82479, 82449, 21266, 
82480, 82478, 82447, 21246, 21267
28416, 82027, 82017, 20915, 20925, 82028, 82018, 20916, 20926, 82479, 82449, 21266, 82480, 82482, 82452, 21268, 
82483, 82481, 82450, 21248, 21269
28417, 82028, 82018, 20916, 20926, 82029, 82019, 20917, 20927, 82482, 82452, 21268, 82483, 82485, 82455, 21270, 
82486, 82484, 82453, 21250, 21271
28418, 82029, 82019, 20917, 20927, 82030, 82020, 20918, 20928, 82485, 82455, 21270, 82486, 82488, 82458, 21272, 
82489, 82487, 82456, 21252, 21273
28419, 82030, 82020, 20918, 20928, 82031, 82021, 20919, 20929, 82488, 82458, 21272, 82489, 82491, 82461, 21274, 
82492, 82490, 82459, 21254, 21275
28420, 82031, 82021, 20919, 20929, 82032, 82022, 20920, 20930, 82491, 82461, 21274, 82492, 82494, 82464, 21276, 
82495, 82493, 82462, 21256, 21277
28421, 82032, 82022, 20920, 20930, 82033, 82023, 20921, 20931, 82494, 82464, 21276, 82495, 82497, 82467, 21278, 
82498, 82496, 82465, 21258, 21279
28422, 82033, 82023, 20921, 20931, 82034, 82024, 20922, 20932, 82497, 82467, 21278, 82498, 82500, 82470, 21280, 
82501, 82499, 82468, 21260, 21281
28423, 82034, 82024, 20922, 20932, 82035, 82025, 20923, 20933, 82500, 82470, 21280, 82501, 82503, 82473, 21282, 
82504, 82502, 82471, 21262, 21283
28424, 82035, 82025, 20923, 20933, 82036, 82026, 20924, 20934, 82503, 82473, 21282, 82504, 82506, 82476, 21284, 
82507, 82505, 82474, 21264, 21285
28425, 82036, 82026, 20924, 20934, 21607, 21606, 1824, 1825, 82506, 82476, 21284, 82507, 21641, 21638, 1847, 
21640, 82508, 82477, 21265, 21286
28426, 21519, 21518, 1690, 1691, 82037, 82027, 20925, 20935, 21553, 21552, 1713, 21554, 82510, 82480, 21287, 
82511, 82509, 82478, 21267, 21288
28427, 82037, 82027, 20925, 20935, 82038, 82028, 20926, 20936, 82510, 82480, 21287, 82511, 82513, 82483, 21289, 
82514, 82512, 82481, 21269, 21290
28428, 82038, 82028, 20926, 20936, 82039, 82029, 20927, 20937, 82513, 82483, 21289, 82514, 82516, 82486, 21291, 
82517, 82515, 82484, 21271, 21292
28429, 82039, 82029, 20927, 20937, 82040, 82030, 20928, 20938, 82516, 82486, 21291, 82517, 82519, 82489, 21293, 
82520, 82518, 82487, 21273, 21294
28430, 82040, 82030, 20928, 20938, 82041, 82031, 20929, 20939, 82519, 82489, 21293, 82520, 82522, 82492, 21295, 
82523, 82521, 82490, 21275, 21296
28431, 82041, 82031, 20929, 20939, 82042, 82032, 20930, 20940, 82522, 82492, 21295, 82523, 82525, 82495, 21297, 
82526, 82524, 82493, 21277, 21298
28432, 82042, 82032, 20930, 20940, 82043, 82033, 20931, 20941, 82525, 82495, 21297, 82526, 82528, 82498, 21299, 
82529, 82527, 82496, 21279, 21300
28433, 82043, 82033, 20931, 20941, 82044, 82034, 20932, 20942, 82528, 82498, 21299, 82529, 82531, 82501, 21301, 
82532, 82530, 82499, 21281, 21302
28434, 82044, 82034, 20932, 20942, 82045, 82035, 20933, 20943, 82531, 82501, 21301, 82532, 82534, 82504, 21303, 
82535, 82533, 82502, 21283, 21304
28435, 82045, 82035, 20933, 20943, 82046, 82036, 20934, 20944, 82534, 82504, 21303, 82535, 82537, 82507, 21305, 
82538, 82536, 82505, 21285, 21306
28436, 82046, 82036, 20934, 20944, 21608, 21607, 1825, 1826, 82537, 82507, 21305, 82538, 21643, 21640, 1848, 
21642, 82539, 82508, 21286, 21307
28437, 21520, 21519, 1691, 1692, 82047, 82037, 20935, 20945, 21555, 21554, 1714, 21556, 82541, 82511, 21308, 
82542, 82540, 82509, 21288, 21309
28438, 82047, 82037, 20935, 20945, 82048, 82038, 20936, 20946, 82541, 82511, 21308, 82542, 82544, 82514, 21310, 
82545, 82543, 82512, 21290, 21311
28439, 82048, 82038, 20936, 20946, 82049, 82039, 20937, 20947, 82544, 82514, 21310, 82545, 82547, 82517, 21312, 
82548, 82546, 82515, 21292, 21313
28440, 82049, 82039, 20937, 20947, 82050, 82040, 20938, 20948, 82547, 82517, 21312, 82548, 82550, 82520, 21314, 
82551, 82549, 82518, 21294, 21315
28441, 82050, 82040, 20938, 20948, 82051, 82041, 20939, 20949, 82550, 82520, 21314, 82551, 82553, 82523, 21316, 
82554, 82552, 82521, 21296, 21317
28442, 82051, 82041, 20939, 20949, 82052, 82042, 20940, 20950, 82553, 82523, 21316, 82554, 82556, 82526, 21318, 
82557, 82555, 82524, 21298, 21319
28443, 82052, 82042, 20940, 20950, 82053, 82043, 20941, 20951, 82556, 82526, 21318, 82557, 82559, 82529, 21320, 
82560, 82558, 82527, 21300, 21321
28444, 82053, 82043, 20941, 20951, 82054, 82044, 20942, 20952, 82559, 82529, 21320, 82560, 82562, 82532, 21322, 
82563, 82561, 82530, 21302, 21323
28445, 82054, 82044, 20942, 20952, 82055, 82045, 20943, 20953, 82562, 82532, 21322, 82563, 82565, 82535, 21324, 
82566, 82564, 82533, 21304, 21325
28446, 82055, 82045, 20943, 20953, 82056, 82046, 20944, 20954, 82565, 82535, 21324, 82566, 82568, 82538, 21326, 
82569, 82567, 82536, 21306, 21327
28447, 82056, 82046, 20944, 20954, 21609, 21608, 1826, 1827, 82568, 82538, 21326, 82569, 21645, 21642, 1849, 
21644, 82570, 82539, 21307, 21328
28448, 21521, 21520, 1692, 1693, 82057, 82047, 20945, 20955, 21557, 21556, 1715, 21558, 82572, 82542, 21329, 
82573, 82571, 82540, 21309, 21330
28449, 82057, 82047, 20945, 20955, 82058, 82048, 20946, 20956, 82572, 82542, 21329, 82573, 82575, 82545, 21331, 
82576, 82574, 82543, 21311, 21332
28450, 82058, 82048, 20946, 20956, 82059, 82049, 20947, 20957, 82575, 82545, 21331, 82576, 82578, 82548, 21333, 
82579, 82577, 82546, 21313, 21334
28451, 82059, 82049, 20947, 20957, 82060, 82050, 20948, 20958, 82578, 82548, 21333, 82579, 82581, 82551, 21335, 
82582, 82580, 82549, 21315, 21336
28452, 82060, 82050, 20948, 20958, 82061, 82051, 20949, 20959, 82581, 82551, 21335, 82582, 82584, 82554, 21337, 
82585, 82583, 82552, 21317, 21338
28453, 82061, 82051, 20949, 20959, 82062, 82052, 20950, 20960, 82584, 82554, 21337, 82585, 82587, 82557, 21339, 
82588, 82586, 82555, 21319, 21340
28454, 82062, 82052, 20950, 20960, 82063, 82053, 20951, 20961, 82587, 82557, 21339, 82588, 82590, 82560, 21341, 
82591, 82589, 82558, 21321, 21342
28455, 82063, 82053, 20951, 20961, 82064, 82054, 20952, 20962, 82590, 82560, 21341, 82591, 82593, 82563, 21343, 
82594, 82592, 82561, 21323, 21344
28456, 82064, 82054, 20952, 20962, 82065, 82055, 20953, 20963, 82593, 82563, 21343, 82594, 82596, 82566, 21345, 
82597, 82595, 82564, 21325, 21346
28457, 82065, 82055, 20953, 20963, 82066, 82056, 20954, 20964, 82596, 82566, 21345, 82597, 82599, 82569, 21347, 
82600, 82598, 82567, 21327, 21348
28458, 82066, 82056, 20954, 20964, 21610, 21609, 1827, 1828, 82599, 82569, 21347, 82600, 21647, 21644, 1850, 
21646, 82601, 82570, 21328, 21349
28459, 21522, 21521, 1693, 1694, 82067, 82057, 20955, 20965, 21559, 21558, 1716, 21560, 82603, 82573, 21350, 
82604, 82602, 82571, 21330, 21351
28460, 82067, 82057, 20955, 20965, 82068, 82058, 20956, 20966, 82603, 82573, 21350, 82604, 82606, 82576, 21352, 
82607, 82605, 82574, 21332, 21353
28461, 82068, 82058, 20956, 20966, 82069, 82059, 20957, 20967, 82606, 82576, 21352, 82607, 82609, 82579, 21354, 
82610, 82608, 82577, 21334, 21355
28462, 82069, 82059, 20957, 20967, 82070, 82060, 20958, 20968, 82609, 82579, 21354, 82610, 82612, 82582, 21356, 
82613, 82611, 82580, 21336, 21357
28463, 82070, 82060, 20958, 20968, 82071, 82061, 20959, 20969, 82612, 82582, 21356, 82613, 82615, 82585, 21358, 
82616, 82614, 82583, 21338, 21359
28464, 82071, 82061, 20959, 20969, 82072, 82062, 20960, 20970, 82615, 82585, 21358, 82616, 82618, 82588, 21360, 
82619, 82617, 82586, 21340, 21361
28465, 82072, 82062, 20960, 20970, 82073, 82063, 20961, 20971, 82618, 82588, 21360, 82619, 82621, 82591, 21362, 
82622, 82620, 82589, 21342, 21363
28466, 82073, 82063, 20961, 20971, 82074, 82064, 20962, 20972, 82621, 82591, 21362, 82622, 82624, 82594, 21364, 
82625, 82623, 82592, 21344, 21365
28467, 82074, 82064, 20962, 20972, 82075, 82065, 20963, 20973, 82624, 82594, 21364, 82625, 82627, 82597, 21366, 
82628, 82626, 82595, 21346, 21367
28468, 82075, 82065, 20963, 20973, 82076, 82066, 20964, 20974, 82627, 82597, 21366, 82628, 82630, 82600, 21368, 
82631, 82629, 82598, 21348, 21369
28469, 82076, 82066, 20964, 20974, 21611, 21610, 1828, 1829, 82630, 82600, 21368, 82631, 21649, 21646, 1851, 
21648, 82632, 82601, 21349, 21370
28470, 21523, 21522, 1694, 1695, 82077, 82067, 20965, 20975, 21561, 21560, 1717, 21562, 82634, 82604, 21371, 
82635, 82633, 82602, 21351, 21372
28471, 82077, 82067, 20965, 20975, 82078, 82068, 20966, 20976, 82634, 82604, 21371, 82635, 82637, 82607, 21373, 
82638, 82636, 82605, 21353, 21374
28472, 82078, 82068, 20966, 20976, 82079, 82069, 20967, 20977, 82637, 82607, 21373, 82638, 82640, 82610, 21375, 
82641, 82639, 82608, 21355, 21376
28473, 82079, 82069, 20967, 20977, 82080, 82070, 20968, 20978, 82640, 82610, 21375, 82641, 82643, 82613, 21377, 
82644, 82642, 82611, 21357, 21378
28474, 82080, 82070, 20968, 20978, 82081, 82071, 20969, 20979, 82643, 82613, 21377, 82644, 82646, 82616, 21379, 
82647, 82645, 82614, 21359, 21380
28475, 82081, 82071, 20969, 20979, 82082, 82072, 20970, 20980, 82646, 82616, 21379, 82647, 82649, 82619, 21381, 
82650, 82648, 82617, 21361, 21382
28476, 82082, 82072, 20970, 20980, 82083, 82073, 20971, 20981, 82649, 82619, 21381, 82650, 82652, 82622, 21383, 
82653, 82651, 82620, 21363, 21384
28477, 82083, 82073, 20971, 20981, 82084, 82074, 20972, 20982, 82652, 82622, 21383, 82653, 82655, 82625, 21385, 
82656, 82654, 82623, 21365, 21386
28478, 82084, 82074, 20972, 20982, 82085, 82075, 20973, 20983, 82655, 82625, 21385, 82656, 82658, 82628, 21387, 
82659, 82657, 82626, 21367, 21388
28479, 82085, 82075, 20973, 20983, 82086, 82076, 20974, 20984, 82658, 82628, 21387, 82659, 82661, 82631, 21389, 
82662, 82660, 82629, 21369, 21390
28480, 82086, 82076, 20974, 20984, 21612, 21611, 1829, 1830, 82661, 82631, 21389, 82662, 21651, 21648, 1852, 
21650, 82663, 82632, 21370, 21391
28481, 21524, 21523, 1695, 1696, 82087, 82077, 20975, 20985, 21563, 21562, 1718, 21564, 82665, 82635, 21392, 
82666, 82664, 82633, 21372, 21393
28482, 82087, 82077, 20975, 20985, 82088, 82078, 20976, 20986, 82665, 82635, 21392, 82666, 82668, 82638, 21394, 
82669, 82667, 82636, 21374, 21395
28483, 82088, 82078, 20976, 20986, 82089, 82079, 20977, 20987, 82668, 82638, 21394, 82669, 82671, 82641, 21396, 
82672, 82670, 82639, 21376, 21397
28484, 82089, 82079, 20977, 20987, 82090, 82080, 20978, 20988, 82671, 82641, 21396, 82672, 82674, 82644, 21398, 
82675, 82673, 82642, 21378, 21399
28485, 82090, 82080, 20978, 20988, 82091, 82081, 20979, 20989, 82674, 82644, 21398, 82675, 82677, 82647, 21400, 
82678, 82676, 82645, 21380, 21401
28486, 82091, 82081, 20979, 20989, 82092, 82082, 20980, 20990, 82677, 82647, 21400, 82678, 82680, 82650, 21402, 
82681, 82679, 82648, 21382, 21403
28487, 82092, 82082, 20980, 20990, 82093, 82083, 20981, 20991, 82680, 82650, 21402, 82681, 82683, 82653, 21404, 
82684, 82682, 82651, 21384, 21405
28488, 82093, 82083, 20981, 20991, 82094, 82084, 20982, 20992, 82683, 82653, 21404, 82684, 82686, 82656, 21406, 
82687, 82685, 82654, 21386, 21407
28489, 82094, 82084, 20982, 20992, 82095, 82085, 20983, 20993, 82686, 82656, 21406, 82687, 82689, 82659, 21408, 
82690, 82688, 82657, 21388, 21409
28490, 82095, 82085, 20983, 20993, 82096, 82086, 20984, 20994, 82689, 82659, 21408, 82690, 82692, 82662, 21410, 
82693, 82691, 82660, 21390, 21411
28491, 82096, 82086, 20984, 20994, 21613, 21612, 1830, 1831, 82692, 82662, 21410, 82693, 21653, 21650, 1853, 
21652, 82694, 82663, 21391, 21412
28492, 21525, 21524, 1696, 1697, 82097, 82087, 20985, 20995, 21565, 21564, 1719, 21566, 82696, 82666, 21413, 
82697, 82695, 82664, 21393, 21414
28493, 82097, 82087, 20985, 20995, 82098, 82088, 20986, 20996, 82696, 82666, 21413, 82697, 82699, 82669, 21415, 
82700, 82698, 82667, 21395, 21416
28494, 82098, 82088, 20986, 20996, 82099, 82089, 20987, 20997, 82699, 82669, 21415, 82700, 82702, 82672, 21417, 
82703, 82701, 82670, 21397, 21418
28495, 82099, 82089, 20987, 20997, 82100, 82090, 20988, 20998, 82702, 82672, 21417, 82703, 82705, 82675, 21419, 
82706, 82704, 82673, 21399, 21420
28496, 82100, 82090, 20988, 20998, 82101, 82091, 20989, 20999, 82705, 82675, 21419, 82706, 82708, 82678, 21421, 
82709, 82707, 82676, 21401, 21422
28497, 82101, 82091, 20989, 20999, 82102, 82092, 20990, 21000, 82708, 82678, 21421, 82709, 82711, 82681, 21423, 
82712, 82710, 82679, 21403, 21424
28498, 82102, 82092, 20990, 21000, 82103, 82093, 20991, 21001, 82711, 82681, 21423, 82712, 82714, 82684, 21425, 
82715, 82713, 82682, 21405, 21426
28499, 82103, 82093, 20991, 21001, 82104, 82094, 20992, 21002, 82714, 82684, 21425, 82715, 82717, 82687, 21427, 
82718, 82716, 82685, 21407, 21428
28500, 82104, 82094, 20992, 21002, 82105, 82095, 20993, 21003, 82717, 82687, 21427, 82718, 82720, 82690, 21429, 
82721, 82719, 82688, 21409, 21430
28501, 82105, 82095, 20993, 21003, 82106, 82096, 20994, 21004, 82720, 82690, 21429, 82721, 82723, 82693, 21431, 
82724, 82722, 82691, 21411, 21432
28502, 82106, 82096, 20994, 21004, 21614, 21613, 1831, 1832, 82723, 82693, 21431, 82724, 21655, 21652, 1854, 
21654, 82725, 82694, 21412, 21433
28503, 21526, 21525, 1697, 1698, 82107, 82097, 20995, 21005, 21567, 21566, 1720, 21568, 82727, 82697, 21434, 
82728, 82726, 82695, 21414, 21435
28504, 82107, 82097, 20995, 21005, 82108, 82098, 20996, 21006, 82727, 82697, 21434, 82728, 82730, 82700, 21436, 
82731, 82729, 82698, 21416, 21437
28505, 82108, 82098, 20996, 21006, 82109, 82099, 20997, 21007, 82730, 82700, 21436, 82731, 82733, 82703, 21438, 
82734, 82732, 82701, 21418, 21439
28506, 82109, 82099, 20997, 21007, 82110, 82100, 20998, 21008, 82733, 82703, 21438, 82734, 82736, 82706, 21440, 
82737, 82735, 82704, 21420, 21441
28507, 82110, 82100, 20998, 21008, 82111, 82101, 20999, 21009, 82736, 82706, 21440, 82737, 82739, 82709, 21442, 
82740, 82738, 82707, 21422, 21443
28508, 82111, 82101, 20999, 21009, 82112, 82102, 21000, 21010, 82739, 82709, 21442, 82740, 82742, 82712, 21444, 
82743, 82741, 82710, 21424, 21445
28509, 82112, 82102, 21000, 21010, 82113, 82103, 21001, 21011, 82742, 82712, 21444, 82743, 82745, 82715, 21446, 
82746, 82744, 82713, 21426, 21447
28510, 82113, 82103, 21001, 21011, 82114, 82104, 21002, 21012, 82745, 82715, 21446, 82746, 82748, 82718, 21448, 
82749, 82747, 82716, 21428, 21449
28511, 82114, 82104, 21002, 21012, 82115, 82105, 21003, 21013, 82748, 82718, 21448, 82749, 82751, 82721, 21450, 
82752, 82750, 82719, 21430, 21451
28512, 82115, 82105, 21003, 21013, 82116, 82106, 21004, 21014, 82751, 82721, 21450, 82752, 82754, 82724, 21452, 
82755, 82753, 82722, 21432, 21453
28513, 82116, 82106, 21004, 21014, 21615, 21614, 1832, 1833, 82754, 82724, 21452, 82755, 21657, 21654, 1855, 
21656, 82756, 82725, 21433, 21454
28514, 21527, 21526, 1698, 1699, 82117, 82107, 21005, 21015, 21569, 21568, 1721, 21570, 82758, 82728, 21455, 
82759, 82757, 82726, 21435, 21456
28515, 82117, 82107, 21005, 21015, 82118, 82108, 21006, 21016, 82758, 82728, 21455, 82759, 82761, 82731, 21457, 
82762, 82760, 82729, 21437, 21458
28516, 82118, 82108, 21006, 21016, 82119, 82109, 21007, 21017, 82761, 82731, 21457, 82762, 82764, 82734, 21459, 
82765, 82763, 82732, 21439, 21460
28517, 82119, 82109, 21007, 21017, 82120, 82110, 21008, 21018, 82764, 82734, 21459, 82765, 82767, 82737, 21461, 
82768, 82766, 82735, 21441, 21462
28518, 82120, 82110, 21008, 21018, 82121, 82111, 21009, 21019, 82767, 82737, 21461, 82768, 82770, 82740, 21463, 
82771, 82769, 82738, 21443, 21464
28519, 82121, 82111, 21009, 21019, 82122, 82112, 21010, 21020, 82770, 82740, 21463, 82771, 82773, 82743, 21465, 
82774, 82772, 82741, 21445, 21466
28520, 82122, 82112, 21010, 21020, 82123, 82113, 21011, 21021, 82773, 82743, 21465, 82774, 82776, 82746, 21467, 
82777, 82775, 82744, 21447, 21468
28521, 82123, 82113, 21011, 21021, 82124, 82114, 21012, 21022, 82776, 82746, 21467, 82777, 82779, 82749, 21469, 
82780, 82778, 82747, 21449, 21470
28522, 82124, 82114, 21012, 21022, 82125, 82115, 21013, 21023, 82779, 82749, 21469, 82780, 82782, 82752, 21471, 
82783, 82781, 82750, 21451, 21472
28523, 82125, 82115, 21013, 21023, 82126, 82116, 21014, 21024, 82782, 82752, 21471, 82783, 82785, 82755, 21473, 
82786, 82784, 82753, 21453, 21474
28524, 82126, 82116, 21014, 21024, 21616, 21615, 1833, 1834, 82785, 82755, 21473, 82786, 21659, 21656, 1856, 
21658, 82787, 82756, 21454, 21475
28525, 21528, 21527, 1699, 1700, 82127, 82117, 21015, 21025, 21571, 21570, 1722, 21572, 82789, 82759, 21476, 
82790, 82788, 82757, 21456, 21477
28526, 82127, 82117, 21015, 21025, 82128, 82118, 21016, 21026, 82789, 82759, 21476, 82790, 82792, 82762, 21478, 
82793, 82791, 82760, 21458, 21479
28527, 82128, 82118, 21016, 21026, 82129, 82119, 21017, 21027, 82792, 82762, 21478, 82793, 82795, 82765, 21480, 
82796, 82794, 82763, 21460, 21481
28528, 82129, 82119, 21017, 21027, 82130, 82120, 21018, 21028, 82795, 82765, 21480, 82796, 82798, 82768, 21482, 
82799, 82797, 82766, 21462, 21483
28529, 82130, 82120, 21018, 21028, 82131, 82121, 21019, 21029, 82798, 82768, 21482, 82799, 82801, 82771, 21484, 
82802, 82800, 82769, 21464, 21485
28530, 82131, 82121, 21019, 21029, 82132, 82122, 21020, 21030, 82801, 82771, 21484, 82802, 82804, 82774, 21486, 
82805, 82803, 82772, 21466, 21487
28531, 82132, 82122, 21020, 21030, 82133, 82123, 21021, 21031, 82804, 82774, 21486, 82805, 82807, 82777, 21488, 
82808, 82806, 82775, 21468, 21489
28532, 82133, 82123, 21021, 21031, 82134, 82124, 21022, 21032, 82807, 82777, 21488, 82808, 82810, 82780, 21490, 
82811, 82809, 82778, 21470, 21491
28533, 82134, 82124, 21022, 21032, 82135, 82125, 21023, 21033, 82810, 82780, 21490, 82811, 82813, 82783, 21492, 
82814, 82812, 82781, 21472, 21493
28534, 82135, 82125, 21023, 21033, 82136, 82126, 21024, 21034, 82813, 82783, 21492, 82814, 82816, 82786, 21494, 
82817, 82815, 82784, 21474, 21495
28535, 82136, 82126, 21024, 21034, 21617, 21616, 1834, 1835, 82816, 82786, 21494, 82817, 21661, 21658, 1857, 
21660, 82818, 82787, 21475, 21496
28536, 1904, 21528, 1700, 38, 21726, 82127, 21025, 1889, 21573, 21572, 1723, 1905, 82819, 82790, 21497, 
21737, 21736, 82788, 21477, 1900
28537, 21726, 82127, 21025, 1889, 21727, 82128, 21026, 1888, 82819, 82790, 21497, 21737, 82820, 82793, 21498, 
21739, 21738, 82791, 21479, 1899
28538, 21727, 82128, 21026, 1888, 21728, 82129, 21027, 1887, 82820, 82793, 21498, 21739, 82821, 82796, 21499, 
21741, 21740, 82794, 21481, 1898
28539, 21728, 82129, 21027, 1887, 21729, 82130, 21028, 1886, 82821, 82796, 21499, 21741, 82822, 82799, 21500, 
21743, 21742, 82797, 21483, 1897
28540, 21729, 82130, 21028, 1886, 21730, 82131, 21029, 1885, 82822, 82799, 21500, 21743, 82823, 82802, 21501, 
21745, 21744, 82800, 21485, 1896
28541, 21730, 82131, 21029, 1885, 21731, 82132, 21030, 1884, 82823, 82802, 21501, 21745, 82824, 82805, 21502, 
21747, 21746, 82803, 21487, 1895
28542, 21731, 82132, 21030, 1884, 21732, 82133, 21031, 1883, 82824, 82805, 21502, 21747, 82825, 82808, 21503, 
21749, 21748, 82806, 21489, 1894
28543, 21732, 82133, 21031, 1883, 21733, 82134, 21032, 1882, 82825, 82808, 21503, 21749, 82826, 82811, 21504, 
21751, 21750, 82809, 21491, 1893
28544, 21733, 82134, 21032, 1882, 21734, 82135, 21033, 1881, 82826, 82811, 21504, 21751, 82827, 82814, 21505, 
21753, 21752, 82812, 21493, 1892
28545, 21734, 82135, 21033, 1881, 21735, 82136, 21034, 1880, 82827, 82814, 21505, 21753, 82828, 82817, 21506, 
21755, 21754, 82815, 21495, 1891
28546, 21735, 82136, 21034, 1880, 1955, 21617, 1835, 40, 82828, 82817, 21506, 21755, 21662, 21660, 1858, 
1956, 21756, 82818, 21496, 1890
28547, 1907, 41, 1901, 21507, 21767, 2012, 21685, 81917, 1929, 1903, 21529, 21574, 21987, 21716, 82138, 
82829, 21988, 2023, 21696, 82137
