34024, 30496, 30486, 95766, 95776, 3267, 3266, 30114, 30115, 30835, 98062, 97609, 98072, 3289, 30271, 30238, 
30272, 30837, 30816, 97580, 97611
34025, 3216, 3215, 29892, 29893, 30497, 30487, 95767, 95777, 3238, 30049, 30016, 30050, 30838, 98063, 97613, 
98073, 30839, 30818, 97581, 97612
34026, 30497, 30487, 95767, 95777, 30498, 30488, 95768, 95778, 30838, 98063, 97613, 98073, 30840, 98064, 97616, 
98074, 30841, 30820, 97584, 97615
34027, 30498, 30488, 95768, 95778, 30499, 30489, 95769, 95779, 30840, 98064, 97616, 98074, 30842, 98065, 97619, 
98075, 30843, 30822, 97587, 97618
34028, 30499, 30489, 95769, 95779, 30500, 30490, 95770, 95780, 30842, 98065, 97619, 98075, 30844, 98066, 97622, 
98076, 30845, 30824, 97590, 97621
34029, 30500, 30490, 95770, 95780, 30501, 30491, 95771, 95781, 30844, 98066, 97622, 98076, 30846, 98067, 97625, 
98077, 30847, 30826, 97593, 97624
34030, 30501, 30491, 95771, 95781, 30502, 30492, 95772, 95782, 30846, 98067, 97625, 98077, 30848, 98068, 97628, 
98078, 30849, 30828, 97596, 97627
34031, 30502, 30492, 95772, 95782, 30503, 30493, 95773, 95783, 30848, 98068, 97628, 98078, 30850, 98069, 97631, 
98079, 30851, 30830, 97599, 97630
34032, 30503, 30493, 95773, 95783, 30504, 30494, 95774, 95784, 30850, 98069, 97631, 98079, 30852, 98070, 97634, 
98080, 30853, 30832, 97602, 97633
34033, 30504, 30494, 95774, 95784, 30505, 30495, 95775, 95785, 30852, 98070, 97634, 98080, 30854, 98071, 97637, 
98081, 30855, 30834, 97605, 97636
34034, 30505, 30495, 95775, 95785, 30506, 30496, 95776, 95786, 30854, 98071, 97637, 98081, 30856, 98072, 97640, 
98082, 30857, 30836, 97608, 97639
34035, 30506, 30496, 95776, 95786, 3268, 3267, 30115, 30116, 30856, 98072, 97640, 98082, 3290, 30272, 30240, 
30273, 30858, 30837, 97611, 97642
34036, 3217, 3216, 29893, 29894, 30507, 30497, 95777, 95787, 3239, 30050, 30018, 30051, 30859, 98073, 97644, 
98083, 30860, 30839, 97612, 97643
34037, 30507, 30497, 95777, 95787, 30508, 30498, 95778, 95788, 30859, 98073, 97644, 98083, 30861, 98074, 97647, 
98084, 30862, 30841, 97615, 97646
34038, 30508, 30498, 95778, 95788, 30509, 30499, 95779, 95789, 30861, 98074, 97647, 98084, 30863, 98075, 97650, 
98085, 30864, 30843, 97618, 97649
34039, 30509, 30499, 95779, 95789, 30510, 30500, 95780, 95790, 30863, 98075, 97650, 98085, 30865, 98076, 97653, 
98086, 30866, 30845, 97621, 97652
34040, 30510, 30500, 95780, 95790, 30511, 30501, 95781, 95791, 30865, 98076, 97653, 98086, 30867, 98077, 97656, 
98087, 30868, 30847, 97624, 97655
34041, 30511, 30501, 95781, 95791, 30512, 30502, 95782, 95792, 30867, 98077, 97656, 98087, 30869, 98078, 97659, 
98088, 30870, 30849, 97627, 97658
34042, 30512, 30502, 95782, 95792, 30513, 30503, 95783, 95793, 30869, 98078, 97659, 98088, 30871, 98079, 97662, 
98089, 30872, 30851, 97630, 97661
34043, 30513, 30503, 95783, 95793, 30514, 30504, 95784, 95794, 30871, 98079, 97662, 98089, 30873, 98080, 97665, 
98090, 30874, 30853, 97633, 97664
34044, 30514, 30504, 95784, 95794, 30515, 30505, 95785, 95795, 30873, 98080, 97665, 98090, 30875, 98081, 97668, 
98091, 30876, 30855, 97636, 97667
34045, 30515, 30505, 95785, 95795, 30516, 30506, 95786, 95796, 30875, 98081, 97668, 98091, 30877, 98082, 97671, 
98092, 30878, 30857, 97639, 97670
34046, 30516, 30506, 95786, 95796, 3269, 3268, 30116, 30117, 30877, 98082, 97671, 98092, 3291, 30273, 30242, 
30274, 30879, 30858, 97642, 97673
34047, 3218, 3217, 29894, 29895, 30517, 30507, 95787, 95797, 3240, 30051, 30020, 30052, 30880, 98083, 97675, 
98093, 30881, 30860, 97643, 97674
34048, 30517, 30507, 95787, 95797, 30518, 30508, 95788, 95798, 30880, 98083, 97675, 98093, 30882, 98084, 97678, 
98094, 30883, 30862, 97646, 97677
34049, 30518, 30508, 95788, 95798, 30519, 30509, 95789, 95799, 30882, 98084, 97678, 98094, 30884, 98085, 97681, 
98095, 30885, 30864, 97649, 97680
34050, 30519, 30509, 95789, 95799, 30520, 30510, 95790, 95800, 30884, 98085, 97681, 98095, 30886, 98086, 97684, 
98096, 30887, 30866, 97652, 97683
34051, 30520, 30510, 95790, 95800, 30521, 30511, 95791, 95801, 30886, 98086, 97684, 98096, 30888, 98087, 97687, 
98097, 30889, 30868, 97655, 97686
34052, 30521, 30511, 95791, 95801, 30522, 30512, 95792, 95802, 30888, 98087, 97687, 98097, 30890, 98088, 97690, 
98098, 30891, 30870, 97658, 97689
34053, 30522, 30512, 95792, 95802, 30523, 30513, 95793, 95803, 30890, 98088, 97690, 98098, 30892, 98089, 97693, 
98099, 30893, 30872, 97661, 97692
34054, 30523, 30513, 95793, 95803, 30524, 30514, 95794, 95804, 30892, 98089, 97693, 98099, 30894, 98090, 97696, 
98100, 30895, 30874, 97664, 97695
34055, 30524, 30514, 95794, 95804, 30525, 30515, 95795, 95805, 30894, 98090, 97696, 98100, 30896, 98091, 97699, 
98101, 30897, 30876, 97667, 97698
34056, 30525, 30515, 95795, 95805, 30526, 30516, 95796, 95806, 30896, 98091, 97699, 98101, 30898, 98092, 97702, 
98102, 30899, 30878, 97670, 97701
34057, 30526, 30516, 95796, 95806, 3270, 3269, 30117, 30118, 30898, 98092, 97702, 98102, 3292, 30274, 30244, 
30275, 30900, 30879, 97673, 97704
34058, 3219, 3218, 29895, 29896, 30527, 30517, 95797, 95807, 3241, 30052, 30022, 30053, 30901, 98093, 97706, 
98103, 30902, 30881, 97674, 97705
34059, 30527, 30517, 95797, 95807, 30528, 30518, 95798, 95808, 30901, 98093, 97706, 98103, 30903, 98094, 97709, 
98104, 30904, 30883, 97677, 97708
34060, 30528, 30518, 95798, 95808, 30529, 30519, 95799, 95809, 30903, 98094, 97709, 98104, 30905, 98095, 97712, 
98105, 30906, 30885, 97680, 97711
34061, 30529, 30519, 95799, 95809, 30530, 30520, 95800, 95810, 30905, 98095, 97712, 98105, 30907, 98096, 97715, 
98106, 30908, 30887, 97683, 97714
34062, 30530, 30520, 95800, 95810, 30531, 30521, 95801, 95811, 30907, 98096, 97715, 98106, 30909, 98097, 97718, 
98107, 30910, 30889, 97686, 97717
34063, 30531, 30521, 95801, 95811, 30532, 30522, 95802, 95812, 30909, 98097, 97718, 98107, 30911, 98098, 97721, 
98108, 30912, 30891, 97689, 97720
34064, 30532, 30522, 95802, 95812, 30533, 30523, 95803, 95813, 30911, 98098, 97721, 98108, 30913, 98099, 97724, 
98109, 30914, 30893, 97692, 97723
34065, 30533, 30523, 95803, 95813, 30534, 30524, 95804, 95814, 30913, 98099, 97724, 98109, 30915, 98100, 97727, 
98110, 30916, 30895, 97695, 97726
34066, 30534, 30524, 95804, 95814, 30535, 30525, 95805, 95815, 30915, 98100, 97727, 98110, 30917, 98101, 97730, 
98111, 30918, 30897, 97698, 97729
34067, 30535, 30525, 95805, 95815, 30536, 30526, 95806, 95816, 30917, 98101, 97730, 98111, 30919, 98102, 97733, 
98112, 30920, 30899, 97701, 97732
34068, 30536, 30526, 95806, 95816, 3271, 3270, 30118, 30119, 30919, 98102, 97733, 98112, 3293, 30275, 30246, 
30276, 30921, 30900, 97704, 97735
34069, 3220, 3219, 29896, 29897, 30537, 30527, 95807, 95817, 3242, 30053, 30024, 30054, 30922, 98103, 97737, 
98113, 30923, 30902, 97705, 97736
34070, 30537, 30527, 95807, 95817, 30538, 30528, 95808, 95818, 30922, 98103, 97737, 98113, 30924, 98104, 97740, 
98114, 30925, 30904, 97708, 97739
34071, 30538, 30528, 95808, 95818, 30539, 30529, 95809, 95819, 30924, 98104, 97740, 98114, 30926, 98105, 97743, 
98115, 30927, 30906, 97711, 97742
34072, 30539, 30529, 95809, 95819, 30540, 30530, 95810, 95820, 30926, 98105, 97743, 98115, 30928, 98106, 97746, 
98116, 30929, 30908, 97714, 97745
34073, 30540, 30530, 95810, 95820, 30541, 30531, 95811, 95821, 30928, 98106, 97746, 98116, 30930, 98107, 97749, 
98117, 30931, 30910, 97717, 97748
34074, 30541, 30531, 95811, 95821, 30542, 30532, 95812, 95822, 30930, 98107, 97749, 98117, 30932, 98108, 97752, 
98118, 30933, 30912, 97720, 97751
34075, 30542, 30532, 95812, 95822, 30543, 30533, 95813, 95823, 30932, 98108, 97752, 98118, 30934, 98109, 97755, 
98119, 30935, 30914, 97723, 97754
34076, 30543, 30533, 95813, 95823, 30544, 30534, 95814, 95824, 30934, 98109, 97755, 98119, 30936, 98110, 97758, 
98120, 30937, 30916, 97726, 97757
34077, 30544, 30534, 95814, 95824, 30545, 30535, 95815, 95825, 30936, 98110, 97758, 98120, 30938, 98111, 97761, 
98121, 30939, 30918, 97729, 97760
34078, 30545, 30535, 95815, 95825, 30546, 30536, 95816, 95826, 30938, 98111, 97761, 98121, 30940, 98112, 97764, 
98122, 30941, 30920, 97732, 97763
34079, 30546, 30536, 95816, 95826, 3272, 3271, 30119, 30120, 30940, 98112, 97764, 98122, 3294, 30276, 30248, 
30277, 30942, 30921, 97735, 97766
34080, 3221, 3220, 29897, 29898, 30547, 30537, 95817, 95827, 3243, 30054, 30026, 30055, 30943, 98113, 97768, 
98123, 30944, 30923, 97736, 97767
34081, 30547, 30537, 95817, 95827, 30548, 30538, 95818, 95828, 30943, 98113, 97768, 98123, 30945, 98114, 97771, 
98124, 30946, 30925, 97739, 97770
34082, 30548, 30538, 95818, 95828, 30549, 30539, 95819, 95829, 30945, 98114, 97771, 98124, 30947, 98115, 97774, 
98125, 30948, 30927, 97742, 97773
34083, 30549, 30539, 95819, 95829, 30550, 30540, 95820, 95830, 30947, 98115, 97774, 98125, 30949, 98116, 97777, 
98126, 30950, 30929, 97745, 97776
34084, 30550, 30540, 95820, 95830, 30551, 30541, 95821, 95831, 30949, 98116, 97777, 98126, 30951, 98117, 97780, 
98127, 30952, 30931, 97748, 97779
34085, 30551, 30541, 95821, 95831, 30552, 30542, 95822, 95832, 30951, 98117, 97780, 98127, 30953, 98118, 97783, 
98128, 30954, 30933, 97751, 97782
34086, 30552, 30542, 95822, 95832, 30553, 30543, 95823, 95833, 30953, 98118, 97783, 98128, 30955, 98119, 97786, 
98129, 30956, 30935, 97754, 97785
34087, 30553, 30543, 95823, 95833, 30554, 30544, 95824, 95834, 30955, 98119, 97786, 98129, 30957, 98120, 97789, 
98130, 30958, 30937, 97757, 97788
34088, 30554, 30544, 95824, 95834, 30555, 30545, 95825, 95835, 30957, 98120, 97789, 98130, 30959, 98121, 97792, 
98131, 30960, 30939, 97760, 97791
34089, 30555, 30545, 95825, 95835, 30556, 30546, 95826, 95836, 30959, 98121, 97792, 98131, 30961, 98122, 97795, 
98132, 30962, 30941, 97763, 97794
34090, 30556, 30546, 95826, 95836, 3273, 3272, 30120, 30121, 30961, 98122, 97795, 98132, 3295, 30277, 30250, 
30278, 30963, 30942, 97766, 97797
34091, 3222, 3221, 29898, 29899, 30557, 30547, 95827, 95837, 3244, 30055, 30028, 30056, 30964, 98123, 97799, 
98133, 30965, 30944, 97767, 97798
34092, 30557, 30547, 95827, 95837, 30558, 30548, 95828, 95838, 30964, 98123, 97799, 98133, 30966, 98124, 97802, 
98134, 30967, 30946, 97770, 97801
34093, 30558, 30548, 95828, 95838, 30559, 30549, 95829, 95839, 30966, 98124, 97802, 98134, 30968, 98125, 97805, 
98135, 30969, 30948, 97773, 97804
34094, 30559, 30549, 95829, 95839, 30560, 30550, 95830, 95840, 30968, 98125, 97805, 98135, 30970, 98126, 97808, 
98136, 30971, 30950, 97776, 97807
34095, 30560, 30550, 95830, 95840, 30561, 30551, 95831, 95841, 30970, 98126, 97808, 98136, 30972, 98127, 97811, 
98137, 30973, 30952, 97779, 97810
34096, 30561, 30551, 95831, 95841, 30562, 30552, 95832, 95842, 30972, 98127, 97811, 98137, 30974, 98128, 97814, 
98138, 30975, 30954, 97782, 97813
34097, 30562, 30552, 95832, 95842, 30563, 30553, 95833, 95843, 30974, 98128, 97814, 98138, 30976, 98129, 97817, 
98139, 30977, 30956, 97785, 97816
34098, 30563, 30553, 95833, 95843, 30564, 30554, 95834, 95844, 30976, 98129, 97817, 98139, 30978, 98130, 97820, 
98140, 30979, 30958, 97788, 97819
34099, 30564, 30554, 95834, 95844, 30565, 30555, 95835, 95845, 30978, 98130, 97820, 98140, 30980, 98131, 97823, 
98141, 30981, 30960, 97791, 97822
34100, 30565, 30555, 95835, 95845, 30566, 30556, 95836, 95846, 30980, 98131, 97823, 98141, 30982, 98132, 97826, 
98142, 30983, 30962, 97794, 97825
34101, 30566, 30556, 95836, 95846, 3274, 3273, 30121, 30122, 30982, 98132, 97826, 98142, 3296, 30278, 30252, 
30279, 30984, 30963, 97797, 97828
34102, 3223, 3222, 29899, 29900, 30567, 30557, 95837, 95847, 3245, 30056, 30030, 30057, 30985, 98133, 97830, 
98143, 30986, 30965, 97798, 97829
34103, 30567, 30557, 95837, 95847, 30568, 30558, 95838, 95848, 30985, 98133, 97830, 98143, 30987, 98134, 97833, 
98144, 30988, 30967, 97801, 97832
34104, 30568, 30558, 95838, 95848, 30569, 30559, 95839, 95849, 30987, 98134, 97833, 98144, 30989, 98135, 97836, 
98145, 30990, 30969, 97804, 97835
34105, 30569, 30559, 95839, 95849, 30570, 30560, 95840, 95850, 30989, 98135, 97836, 98145, 30991, 98136, 97839, 
98146, 30992, 30971, 97807, 97838
34106, 30570, 30560, 95840, 95850, 30571, 30561, 95841, 95851, 30991, 98136, 97839, 98146, 30993, 98137, 97842, 
98147, 30994, 30973, 97810, 97841
34107, 30571, 30561, 95841, 95851, 30572, 30562, 95842, 95852, 30993, 98137, 97842, 98147, 30995, 98138, 97845, 
98148, 30996, 30975, 97813, 97844
34108, 30572, 30562, 95842, 95852, 30573, 30563, 95843, 95853, 30995, 98138, 97845, 98148, 30997, 98139, 97848, 
98149, 30998, 30977, 97816, 97847
34109, 30573, 30563, 95843, 95853, 30574, 30564, 95844, 95854, 30997, 98139, 97848, 98149, 30999, 98140, 97851, 
98150, 31000, 30979, 97819, 97850
34110, 30574, 30564, 95844, 95854, 30575, 30565, 95845, 95855, 30999, 98140, 97851, 98150, 31001, 98141, 97854, 
98151, 31002, 30981, 97822, 97853
34111, 30575, 30565, 95845, 95855, 30576, 30566, 95846, 95856, 31001, 98141, 97854, 98151, 31003, 98142, 97857, 
98152, 31004, 30983, 97825, 97856
34112, 30576, 30566, 95846, 95856, 3275, 3274, 30122, 30123, 31003, 98142, 97857, 98152, 3297, 30279, 30254, 
30280, 31005, 30984, 97828, 97859
34113, 3224, 3223, 29900, 29901, 30577, 30567, 95847, 95857, 3246, 30057, 30032, 30058, 31006, 98143, 97861, 
98153, 31007, 30986, 97829, 97860
34114, 30577, 30567, 95847, 95857, 30578, 30568, 95848, 95858, 31006, 98143, 97861, 98153, 31008, 98144, 97864, 
98154, 31009, 30988, 97832, 97863
34115, 30578, 30568, 95848, 95858, 30579, 30569, 95849, 95859, 31008, 98144, 97864, 98154, 31010, 98145, 97867, 
98155, 31011, 30990, 97835, 97866
34116, 30579, 30569, 95849, 95859, 30580, 30570, 95850, 95860, 31010, 98145, 97867, 98155, 31012, 98146, 97870, 
98156, 31013, 30992, 97838, 97869
34117, 30580, 30570, 95850, 95860, 30581, 30571, 95851, 95861, 31012, 98146, 97870, 98156, 31014, 98147, 97873, 
98157, 31015, 30994, 97841, 97872
34118, 30581, 30571, 95851, 95861, 30582, 30572, 95852, 95862, 31014, 98147, 97873, 98157, 31016, 98148, 97876, 
98158, 31017, 30996, 97844, 97875
34119, 30582, 30572, 95852, 95862, 30583, 30573, 95853, 95863, 31016, 98148, 97876, 98158, 31018, 98149, 97879, 
98159, 31019, 30998, 97847, 97878
34120, 30583, 30573, 95853, 95863, 30584, 30574, 95854, 95864, 31018, 98149, 97879, 98159, 31020, 98150, 97882, 
98160, 31021, 31000, 97850, 97881
34121, 30584, 30574, 95854, 95864, 30585, 30575, 95855, 95865, 31020, 98150, 97882, 98160, 31022, 98151, 97885, 
98161, 31023, 31002, 97853, 97884
34122, 30585, 30575, 95855, 95865, 30586, 30576, 95856, 95866, 31022, 98151, 97885, 98161, 31024, 98152, 97888, 
98162, 31025, 31004, 97856, 97887
34123, 30586, 30576, 95856, 95866, 3276, 3275, 30123, 30124, 31024, 98152, 97888, 98162, 3298, 30280, 30256, 
30281, 31026, 31005, 97859, 97890
34124, 3225, 3224, 29901, 29902, 30587, 30577, 95857, 95867, 3247, 30058, 30034, 30059, 31027, 98153, 97892, 
98163, 31028, 31007, 97860, 97891
34125, 30587, 30577, 95857, 95867, 30588, 30578, 95858, 95868, 31027, 98153, 97892, 98163, 31029, 98154, 97895, 
98164, 31030, 31009, 97863, 97894
34126, 30588, 30578, 95858, 95868, 30589, 30579, 95859, 95869, 31029, 98154, 97895, 98164, 31031, 98155, 97898, 
98165, 31032, 31011, 97866, 97897
34127, 30589, 30579, 95859, 95869, 30590, 30580, 95860, 95870, 31031, 98155, 97898, 98165, 31033, 98156, 97901, 
98166, 31034, 31013, 97869, 97900
34128, 30590, 30580, 95860, 95870, 30591, 30581, 95861, 95871, 31033, 98156, 97901, 98166, 31035, 98157, 97904, 
98167, 31036, 31015, 97872, 97903
34129, 30591, 30581, 95861, 95871, 30592, 30582, 95862, 95872, 31035, 98157, 97904, 98167, 31037, 98158, 97907, 
98168, 31038, 31017, 97875, 97906
34130, 30592, 30582, 95862, 95872, 30593, 30583, 95863, 95873, 31037, 98158, 97907, 98168, 31039, 98159, 97910, 
98169, 31040, 31019, 97878, 97909
34131, 30593, 30583, 95863, 95873, 30594, 30584, 95864, 95874, 31039, 98159, 97910, 98169, 31041, 98160, 97913, 
98170, 31042, 31021, 97881, 97912
34132, 30594, 30584, 95864, 95874, 30595, 30585, 95865, 95875, 31041, 98160, 97913, 98170, 31043, 98161, 97916, 
98171, 31044, 31023, 97884, 97915
34133, 30595, 30585, 95865, 95875, 30596, 30586, 95866, 95876, 31043, 98161, 97916, 98171, 31045, 98162, 97919, 
98172, 31046, 31025, 97887, 97918
34134, 30596, 30586, 95866, 95876, 3277, 3276, 30124, 30125, 31045, 98162, 97919, 98172, 3299, 30281, 30258, 
30282, 31047, 31026, 97890, 97921
34135, 3226, 3225, 29902, 29903, 30597, 30587, 95867, 95877, 3248, 30059, 30036, 30060, 31048, 98163, 97923, 
98173, 31049, 31028, 97891, 97922
34136, 30597, 30587, 95867, 95877, 30598, 30588, 95868, 95878, 31048, 98163, 97923, 98173, 31050, 98164, 97926, 
98174, 31051, 31030, 97894, 97925
34137, 30598, 30588, 95868, 95878, 30599, 30589, 95869, 95879, 31050, 98164, 97926, 98174, 31052, 98165, 97929, 
98175, 31053, 31032, 97897, 97928
34138, 30599, 30589, 95869, 95879, 30600, 30590, 95870, 95880, 31052, 98165, 97929, 98175, 31054, 98166, 97932, 
98176, 31055, 31034, 97900, 97931
34139, 30600, 30590, 95870, 95880, 30601, 30591, 95871, 95881, 31054, 98166, 97932, 98176, 31056, 98167, 97935, 
98177, 31057, 31036, 97903, 97934
34140, 30601, 30591, 95871, 95881, 30602, 30592, 95872, 95882, 31056, 98167, 97935, 98177, 31058, 98168, 97938, 
98178, 31059, 31038, 97906, 97937
34141, 30602, 30592, 95872, 95882, 30603, 30593, 95873, 95883, 31058, 98168, 97938, 98178, 31060, 98169, 97941, 
98179, 31061, 31040, 97909, 97940
34142, 30603, 30593, 95873, 95883, 30604, 30594, 95874, 95884, 31060, 98169, 97941, 98179, 31062, 98170, 97944, 
98180, 31063, 31042, 97912, 97943
34143, 30604, 30594, 95874, 95884, 30605, 30595, 95875, 95885, 31062, 98170, 97944, 98180, 31064, 98171, 97947, 
98181, 31065, 31044, 97915, 97946
34144, 30605, 30595, 95875, 95885, 30606, 30596, 95876, 95886, 31064, 98171, 97947, 98181, 31066, 98172, 97950, 
98182, 31067, 31046, 97918, 97949
34145, 30606, 30596, 95876, 95886, 3278, 3277, 30125, 30126, 31066, 98172, 97950, 98182, 3300, 30282, 30260, 
30283, 31068, 31047, 97921, 97952
34146, 69, 3226, 29903, 2765, 2786, 30597, 95877, 27520, 3249, 30060, 30038, 2769, 31069, 98173, 97953, 
27593, 2797, 31049, 97922, 27572
34147, 2786, 30597, 95877, 27520, 2785, 30598, 95878, 27521, 31069, 98173, 97953, 27593, 31070, 98174, 97954, 
27594, 2796, 31051, 97925, 27574
34148, 2785, 30598, 95878, 27521, 2784, 30599, 95879, 27522, 31070, 98174, 97954, 27594, 31071, 98175, 97955, 
27595, 2795, 31053, 97928, 27576
34149, 2784, 30599, 95879, 27522, 2783, 30600, 95880, 27523, 31071, 98175, 97955, 27595, 31072, 98176, 97956, 
27596, 2794, 31055, 97931, 27578
34150, 2783, 30600, 95880, 27523, 2782, 30601, 95881, 27524, 31072, 98176, 97956, 27596, 31073, 98177, 97957, 
27597, 2793, 31057, 97934, 27580
34151, 2782, 30601, 95881, 27524, 2781, 30602, 95882, 27525, 31073, 98177, 97957, 27597, 31074, 98178, 97958, 
27598, 2792, 31059, 97937, 27582
34152, 2781, 30602, 95882, 27525, 2780, 30603, 95883, 27526, 31074, 98178, 97958, 27598, 31075, 98179, 97959, 
27599, 2791, 31061, 97940, 27584
34153, 2780, 30603, 95883, 27526, 2779, 30604, 95884, 27527, 31075, 98179, 97959, 27599, 31076, 98180, 97960, 
27600, 2790, 31063, 97943, 27586
34154, 2779, 30604, 95884, 27527, 2778, 30605, 95885, 27528, 31076, 98180, 97960, 27600, 31077, 98181, 97961, 
27601, 2789, 31065, 97946, 27588
34155, 2778, 30605, 95885, 27528, 2777, 30606, 95886, 27529, 31077, 98181, 97961, 27601, 31078, 98182, 97962, 
27602, 2788, 31067, 97949, 27590
34156, 2777, 30606, 95886, 27529, 70, 3278, 30126, 2772, 31078, 98182, 97962, 27602, 3301, 30283, 30261, 
2776, 2787, 31068, 97952, 27592
*ELEMENT, type=C3D20, ELSET=Volume26
34157, 27603, 2763, 45, 2081, 98183, 27500, 2064, 22635, 27609, 2766, 2083, 27610, 98244, 27531, 22655, 
98245, 98243, 27530, 2075, 22656
34158, 98183, 27500, 2064, 22635, 98184, 27501, 2063, 22636, 98244, 27531, 22655, 98245, 98247, 27533, 22657, 
98248, 98246, 27532, 2074, 22658
34159, 98184, 27501, 2063, 22636, 98185, 27502, 2062, 22637, 98247, 27533, 22657, 98248, 98250, 27535, 22659, 
98251, 98249, 27534, 2073, 22660
34160, 98185, 27502, 2062, 22637, 98186, 27503, 2061, 22638, 98250, 27535, 22659, 98251, 98253, 27537, 22661, 
98254, 98252, 27536, 2072, 22662
34161, 98186, 27503, 2061, 22638, 98187, 27504, 2060, 22639, 98253, 27537, 22661, 98254, 98256, 27539, 22663, 
98257, 98255, 27538, 2071, 22664
34162, 98187, 27504, 2060, 22639, 98188, 27505, 2059, 22640, 98256, 27539, 22663, 98257, 98259, 27541, 22665, 
98260, 98258, 27540, 2070, 22666
34163, 98188, 27505, 2059, 22640, 98189, 27506, 2058, 22641, 98259, 27541, 22665, 98260, 98262, 27543, 22667, 
98263, 98261, 27542, 2069, 22668
34164, 98189, 27506, 2058, 22641, 98190, 27507, 2057, 22642, 98262, 27543, 22667, 98263, 98265, 27545, 22669, 
98266, 98264, 27544, 2068, 22670
34165, 98190, 27507, 2057, 22642, 98191, 27508, 2056, 22643, 98265, 27545, 22669, 98266, 98268, 27547, 22671, 
98269, 98267, 27546, 2067, 22672
34166, 98191, 27508, 2056, 22643, 98192, 27509, 2055, 22644, 98268, 27547, 22671, 98269, 98271, 27549, 22673, 
98272, 98270, 27548, 2066, 22674
34167, 98192, 27509, 2055, 22644, 27626, 2770, 46, 2096, 98271, 27549, 22673, 98272, 27633, 2773, 2098, 
27632, 98273, 27550, 2065, 22675
34168, 27604, 27603, 2081, 2082, 98193, 98183, 22635, 22645, 27611, 27610, 2084, 27612, 98275, 98245, 22676, 
98276, 98274, 98243, 22656, 22677
34169, 98193, 98183, 22635, 22645, 98194, 98184, 22636, 22646, 98275, 98245, 22676, 98276, 98278, 98248, 22678, 
98279, 98277, 98246, 22658, 22679
34170, 98194, 98184, 22636, 22646, 98195, 98185, 22637, 22647, 98278, 98248, 22678, 98279, 98281, 98251, 22680, 
98282, 98280, 98249, 22660, 22681
34171, 98195, 98185, 22637, 22647, 98196, 98186, 22638, 22648, 98281, 98251, 22680, 98282, 98284, 98254, 22682, 
98285, 98283, 98252, 22662, 22683
34172, 98196, 98186, 22638, 22648, 98197, 98187, 22639, 22649, 98284, 98254, 22682, 98285, 98287, 98257, 22684, 
98288, 98286, 98255, 22664, 22685
34173, 98197, 98187, 22639, 22649, 98198, 98188, 22640, 22650, 98287, 98257, 22684, 98288, 98290, 98260, 22686, 
98291, 98289, 98258, 22666, 22687
34174, 98198, 98188, 22640, 22650, 98199, 98189, 22641, 22651, 98290, 98260, 22686, 98291, 98293, 98263, 22688, 
98294, 98292, 98261, 22668, 22689
34175, 98199, 98189, 22641, 22651, 98200, 98190, 22642, 22652, 98293, 98263, 22688, 98294, 98296, 98266, 22690, 
98297, 98295, 98264, 22670, 22691
34176, 98200, 98190, 22642, 22652, 98201, 98191, 22643, 22653, 98296, 98266, 22690, 98297, 98299, 98269, 22692, 
98300, 98298, 98267, 22672, 22693
34177, 98201, 98191, 22643, 22653, 98202, 98192, 22644, 22654, 98299, 98269, 22692, 98300, 98302, 98272, 22694, 
98303, 98301, 98270, 22674, 22695
34178, 98202, 98192, 22644, 22654, 27627, 27626, 2096, 2097, 98302, 98272, 22694, 98303, 27635, 27632, 2099, 
27634, 98304, 98273, 22675, 22696
34179, 2798, 27604, 2082, 48, 27649, 98193, 22645, 2136, 27613, 27612, 2085, 2801, 98305, 98276, 22697, 
27680, 27679, 98274, 22677, 2147
34180, 27649, 98193, 22645, 2136, 27650, 98194, 22646, 2135, 98305, 98276, 22697, 27680, 98306, 98279, 22698, 
27682, 27681, 98277, 22679, 2146
34181, 27650, 98194, 22646, 2135, 27651, 98195, 22647, 2134, 98306, 98279, 22698, 27682, 98307, 98282, 22699, 
27684, 27683, 98280, 22681, 2145
34182, 27651, 98195, 22647, 2134, 27652, 98196, 22648, 2133, 98307, 98282, 22699, 27684, 98308, 98285, 22700, 
27686, 27685, 98283, 22683, 2144
34183, 27652, 98196, 22648, 2133, 27653, 98197, 22649, 2132, 98308, 98285, 22700, 27686, 98309, 98288, 22701, 
27688, 27687, 98286, 22685, 2143
34184, 27653, 98197, 22649, 2132, 27654, 98198, 22650, 2131, 98309, 98288, 22701, 27688, 98310, 98291, 22702, 
27690, 27689, 98289, 22687, 2142
34185, 27654, 98198, 22650, 2131, 27655, 98199, 22651, 2130, 98310, 98291, 22702, 27690, 98311, 98294, 22703, 
27692, 27691, 98292, 22689, 2141
34186, 27655, 98199, 22651, 2130, 27656, 98200, 22652, 2129, 98311, 98294, 22703, 27692, 98312, 98297, 22704, 
27694, 27693, 98295, 22691, 2140
34187, 27656, 98200, 22652, 2129, 27657, 98201, 22653, 2128, 98312, 98297, 22704, 27694, 98313, 98300, 22705, 
27696, 27695, 98298, 22693, 2139
34188, 27657, 98201, 22653, 2128, 27658, 98202, 22654, 2127, 98313, 98300, 22705, 27696, 98314, 98303, 22706, 
27698, 27697, 98301, 22695, 2138
34189, 27658, 98202, 22654, 2127, 2810, 27627, 2097, 50, 98314, 98303, 22706, 27698, 27636, 27634, 2100, 
2813, 27699, 98304, 22696, 2137
34190, 27605, 2764, 2763, 27603, 98203, 27510, 27500, 98183, 27614, 2767, 27609, 27615, 98316, 27552, 98244, 
98317, 98315, 27551, 27530, 98243
34191, 98203, 27510, 27500, 98183, 98204, 27511, 27501, 98184, 98316, 27552, 98244, 98317, 98319, 27554, 98247, 
98320, 98318, 27553, 27532, 98246
34192, 98204, 27511, 27501, 98184, 98205, 27512, 27502, 98185, 98319, 27554, 98247, 98320, 98322, 27556, 98250, 
98323, 98321, 27555, 27534, 98249
34193, 98205, 27512, 27502, 98185, 98206, 27513, 27503, 98186, 98322, 27556, 98250, 98323, 98325, 27558, 98253, 
98326, 98324, 27557, 27536, 98252
34194, 98206, 27513, 27503, 98186, 98207, 27514, 27504, 98187, 98325, 27558, 98253, 98326, 98328, 27560, 98256, 
98329, 98327, 27559, 27538, 98255
34195, 98207, 27514, 27504, 98187, 98208, 27515, 27505, 98188, 98328, 27560, 98256, 98329, 98331, 27562, 98259, 
98332, 98330, 27561, 27540, 98258
34196, 98208, 27515, 27505, 98188, 98209, 27516, 27506, 98189, 98331, 27562, 98259, 98332, 98334, 27564, 98262, 
98335, 98333, 27563, 27542, 98261
34197, 98209, 27516, 27506, 98189, 98210, 27517, 27507, 98190, 98334, 27564, 98262, 98335, 98337, 27566, 98265, 
98338, 98336, 27565, 27544, 98264
34198, 98210, 27517, 27507, 98190, 98211, 27518, 27508, 98191, 98337, 27566, 98265, 98338, 98340, 27568, 98268, 
98341, 98339, 27567, 27546, 98267
34199, 98211, 27518, 27508, 98191, 98212, 27519, 27509, 98192, 98340, 27568, 98268, 98341, 98343, 27570, 98271, 
98344, 98342, 27569, 27548, 98270
34200, 98212, 27519, 27509, 98192, 27628, 2771, 2770, 27626, 98343, 27570, 98271, 98344, 27638, 2774, 27633, 
27637, 98345, 27571, 27550, 98273
34201, 27606, 27605, 27603, 27604, 98213, 98203, 98183, 98193, 27616, 27615, 27611, 27617, 98347, 98317, 98275, 
98348, 98346, 98315, 98243, 98274
34202, 98213, 98203, 98183, 98193, 98214, 98204, 98184, 98194, 98347, 98317, 98275, 98348, 98350, 98320, 98278, 
98351, 98349, 98318, 98246, 98277
34203, 98214, 98204, 98184, 98194, 98215, 98205, 98185, 98195, 98350, 98320, 98278, 98351, 98353, 98323, 98281, 
98354, 98352, 98321, 98249, 98280
34204, 98215, 98205, 98185, 98195, 98216, 98206, 98186, 98196, 98353, 98323, 98281, 98354, 98356, 98326, 98284, 
98357, 98355, 98324, 98252, 98283
34205, 98216, 98206, 98186, 98196, 98217, 98207, 98187, 98197, 98356, 98326, 98284, 98357, 98359, 98329, 98287, 
98360, 98358, 98327, 98255, 98286
34206, 98217, 98207, 98187, 98197, 98218, 98208, 98188, 98198, 98359, 98329, 98287, 98360, 98362, 98332, 98290, 
98363, 98361, 98330, 98258, 98289
34207, 98218, 98208, 98188, 98198, 98219, 98209, 98189, 98199, 98362, 98332, 98290, 98363, 98365, 98335, 98293, 
98366, 98364, 98333, 98261, 98292
34208, 98219, 98209, 98189, 98199, 98220, 98210, 98190, 98200, 98365, 98335, 98293, 98366, 98368, 98338, 98296, 
98369, 98367, 98336, 98264, 98295
34209, 98220, 98210, 98190, 98200, 98221, 98211, 98191, 98201, 98368, 98338, 98296, 98369, 98371, 98341, 98299, 
98372, 98370, 98339, 98267, 98298
34210, 98221, 98211, 98191, 98201, 98222, 98212, 98192, 98202, 98371, 98341, 98299, 98372, 98374, 98344, 98302, 
98375, 98373, 98342, 98270, 98301
34211, 98222, 98212, 98192, 98202, 27629, 27628, 27626, 27627, 98374, 98344, 98302, 98375, 27640, 27637, 27635, 
27639, 98376, 98345, 98273, 98304
34212, 2799, 27606, 27604, 2798, 27659, 98213, 98193, 27649, 27618, 27617, 27613, 2802, 98377, 98348, 98305, 
27701, 27700, 98346, 98274, 27679
34213, 27659, 98213, 98193, 27649, 27660, 98214, 98194, 27650, 98377, 98348, 98305, 27701, 98378, 98351, 98306, 
27703, 27702, 98349, 98277, 27681
34214, 27660, 98214, 98194, 27650, 27661, 98215, 98195, 27651, 98378, 98351, 98306, 27703, 98379, 98354, 98307, 
27705, 27704, 98352, 98280, 27683
34215, 27661, 98215, 98195, 27651, 27662, 98216, 98196, 27652, 98379, 98354, 98307, 27705, 98380, 98357, 98308, 
27707, 27706, 98355, 98283, 27685
34216, 27662, 98216, 98196, 27652, 27663, 98217, 98197, 27653, 98380, 98357, 98308, 27707, 98381, 98360, 98309, 
27709, 27708, 98358, 98286, 27687
34217, 27663, 98217, 98197, 27653, 27664, 98218, 98198, 27654, 98381, 98360, 98309, 27709, 98382, 98363, 98310, 
27711, 27710, 98361, 98289, 27689
34218, 27664, 98218, 98198, 27654, 27665, 98219, 98199, 27655, 98382, 98363, 98310, 27711, 98383, 98366, 98311, 
27713, 27712, 98364, 98292, 27691
34219, 27665, 98219, 98199, 27655, 27666, 98220, 98200, 27656, 98383, 98366, 98311, 27713, 98384, 98369, 98312, 
27715, 27714, 98367, 98295, 27693
34220, 27666, 98220, 98200, 27656, 27667, 98221, 98201, 27657, 98384, 98369, 98312, 27715, 98385, 98372, 98313, 
27717, 27716, 98370, 98298, 27695
34221, 27667, 98221, 98201, 27657, 27668, 98222, 98202, 27658, 98385, 98372, 98313, 27717, 98386, 98375, 98314, 
27719, 27718, 98373, 98301, 27697
34222, 27668, 98222, 98202, 27658, 2811, 27629, 27627, 2810, 98386, 98375, 98314, 27719, 27641, 27639, 27636, 
2814, 27720, 98376, 98304, 27699
34223, 27607, 2765, 2764, 27605, 98223, 27520, 27510, 98203, 27619, 2768, 27614, 27620, 98388, 27573, 98316, 
98389, 98387, 27572, 27551, 98315
34224, 98223, 27520, 27510, 98203, 98224, 27521, 27511, 98204, 98388, 27573, 98316, 98389, 98391, 27575, 98319, 
98392, 98390, 27574, 27553, 98318
34225, 98224, 27521, 27511, 98204, 98225, 27522, 27512, 98205, 98391, 27575, 98319, 98392, 98394, 27577, 98322, 
98395, 98393, 27576, 27555, 98321
34226, 98225, 27522, 27512, 98205, 98226, 27523, 27513, 98206, 98394, 27577, 98322, 98395, 98397, 27579, 98325, 
98398, 98396, 27578, 27557, 98324
34227, 98226, 27523, 27513, 98206, 98227, 27524, 27514, 98207, 98397, 27579, 98325, 98398, 98400, 27581, 98328, 
98401, 98399, 27580, 27559, 98327
34228, 98227, 27524, 27514, 98207, 98228, 27525, 27515, 98208, 98400, 27581, 98328, 98401, 98403, 27583, 98331, 
98404, 98402, 27582, 27561, 98330
34229, 98228, 27525, 27515, 98208, 98229, 27526, 27516, 98209, 98403, 27583, 98331, 98404, 98406, 27585, 98334, 
98407, 98405, 27584, 27563, 98333
34230, 98229, 27526, 27516, 98209, 98230, 27527, 27517, 98210, 98406, 27585, 98334, 98407, 98409, 27587, 98337, 
98410, 98408, 27586, 27565, 98336
34231, 98230, 27527, 27517, 98210, 98231, 27528, 27518, 98211, 98409, 27587, 98337, 98410, 98412, 27589, 98340, 
98413, 98411, 27588, 27567, 98339
34232, 98231, 27528, 27518, 98211, 98232, 27529, 27519, 98212, 98412, 27589, 98340, 98413, 98415, 27591, 98343, 
98416, 98414, 27590, 27569, 98342
34233, 98232, 27529, 27519, 98212, 27630, 2772, 2771, 27628, 98415, 27591, 98343, 98416, 27643, 2775, 27638, 
27642, 98417, 27592, 27571, 98345
34234, 27608, 27607, 27605, 27606, 98233, 98223, 98203, 98213, 27621, 27620, 27616, 27622, 98419, 98389, 98347, 
98420, 98418, 98387, 98315, 98346
34235, 98233, 98223, 98203, 98213, 98234, 98224, 98204, 98214, 98419, 98389, 98347, 98420, 98422, 98392, 98350, 
98423, 98421, 98390, 98318, 98349
34236, 98234, 98224, 98204, 98214, 98235, 98225, 98205, 98215, 98422, 98392, 98350, 98423, 98425, 98395, 98353, 
98426, 98424, 98393, 98321, 98352
34237, 98235, 98225, 98205, 98215, 98236, 98226, 98206, 98216, 98425, 98395, 98353, 98426, 98428, 98398, 98356, 
98429, 98427, 98396, 98324, 98355
34238, 98236, 98226, 98206, 98216, 98237, 98227, 98207, 98217, 98428, 98398, 98356, 98429, 98431, 98401, 98359, 
98432, 98430, 98399, 98327, 98358
34239, 98237, 98227, 98207, 98217, 98238, 98228, 98208, 98218, 98431, 98401, 98359, 98432, 98434, 98404, 98362, 
98435, 98433, 98402, 98330, 98361
34240, 98238, 98228, 98208, 98218, 98239, 98229, 98209, 98219, 98434, 98404, 98362, 98435, 98437, 98407, 98365, 
98438, 98436, 98405, 98333, 98364
34241, 98239, 98229, 98209, 98219, 98240, 98230, 98210, 98220, 98437, 98407, 98365, 98438, 98440, 98410, 98368, 
98441, 98439, 98408, 98336, 98367
34242, 98240, 98230, 98210, 98220, 98241, 98231, 98211, 98221, 98440, 98410, 98368, 98441, 98443, 98413, 98371, 
98444, 98442, 98411, 98339, 98370
34243, 98241, 98231, 98211, 98221, 98242, 98232, 98212, 98222, 98443, 98413, 98371, 98444, 98446, 98416, 98374, 
98447, 98445, 98414, 98342, 98373
34244, 98242, 98232, 98212, 98222, 27631, 27630, 27628, 27629, 98446, 98416, 98374, 98447, 27645, 27642, 27640, 
27644, 98448, 98417, 98345, 98376
34245, 2800, 27608, 27606, 2799, 27669, 98233, 98213, 27659, 27623, 27622, 27618, 2803, 98449, 98420, 98377, 
27722, 27721, 98418, 98346, 27700
34246, 27669, 98233, 98213, 27659, 27670, 98234, 98214, 27660, 98449, 98420, 98377, 27722, 98450, 98423, 98378, 
27724, 27723, 98421, 98349, 27702
34247, 27670, 98234, 98214, 27660, 27671, 98235, 98215, 27661, 98450, 98423, 98378, 27724, 98451, 98426, 98379, 
27726, 27725, 98424, 98352, 27704
34248, 27671, 98235, 98215, 27661, 27672, 98236, 98216, 27662, 98451, 98426, 98379, 27726, 98452, 98429, 98380, 
27728, 27727, 98427, 98355, 27706
34249, 27672, 98236, 98216, 27662, 27673, 98237, 98217, 27663, 98452, 98429, 98380, 27728, 98453, 98432, 98381, 
27730, 27729, 98430, 98358, 27708
34250, 27673, 98237, 98217, 27663, 27674, 98238, 98218, 27664, 98453, 98432, 98381, 27730, 98454, 98435, 98382, 
27732, 27731, 98433, 98361, 27710
34251, 27674, 98238, 98218, 27664, 27675, 98239, 98219, 27665, 98454, 98435, 98382, 27732, 98455, 98438, 98383, 
27734, 27733, 98436, 98364, 27712
34252, 27675, 98239, 98219, 27665, 27676, 98240, 98220, 27666, 98455, 98438, 98383, 27734, 98456, 98441, 98384, 
27736, 27735, 98439, 98367, 27714
34253, 27676, 98240, 98220, 27666, 27677, 98241, 98221, 27667, 98456, 98441, 98384, 27736, 98457, 98444, 98385, 
27738, 27737, 98442, 98370, 27716
34254, 27677, 98241, 98221, 27667, 27678, 98242, 98222, 27668, 98457, 98444, 98385, 27738, 98458, 98447, 98386, 
27740, 27739, 98445, 98373, 27718
34255, 27678, 98242, 98222, 27668, 2812, 27631, 27629, 2811, 98458, 98447, 98386, 27740, 27646, 27644, 27641, 
2815, 27741, 98448, 98376, 27720
34256, 2805, 69, 2765, 27607, 27752, 2786, 27520, 98223, 2807, 2769, 27619, 27624, 27772, 27593, 98388, 
98459, 27773, 2797, 27572, 98387
34257, 27752, 2786, 27520, 98223, 27753, 2785, 27521, 98224, 27772, 27593, 98388, 98459, 27774, 27594, 98391, 
98460, 27775, 2796, 27574, 98390
34258, 27753, 2785, 27521, 98224, 27754, 2784, 27522, 98225, 27774, 27594, 98391, 98460, 27776, 27595, 98394, 
98461, 27777, 2795, 27576, 98393
34259, 27754, 2784, 27522, 98225, 27755, 2783, 27523, 98226, 27776, 27595, 98394, 98461, 27778, 27596, 98397, 
98462, 27779, 2794, 27578, 98396
34260, 27755, 2783, 27523, 98226, 27756, 2782, 27524, 98227, 27778, 27596, 98397, 98462, 27780, 27597, 98400, 
98463, 27781, 2793, 27580, 98399
34261, 27756, 2782, 27524, 98227, 27757, 2781, 27525, 98228, 27780, 27597, 98400, 98463, 27782, 27598, 98403, 
98464, 27783, 2792, 27582, 98402
34262, 27757, 2781, 27525, 98228, 27758, 2780, 27526, 98229, 27782, 27598, 98403, 98464, 27784, 27599, 98406, 
98465, 27785, 2791, 27584, 98405
34263, 27758, 2780, 27526, 98229, 27759, 2779, 27527, 98230, 27784, 27599, 98406, 98465, 27786, 27600, 98409, 
98466, 27787, 2790, 27586, 98408
34264, 27759, 2779, 27527, 98230, 27760, 2778, 27528, 98231, 27786, 27600, 98409, 98466, 27788, 27601, 98412, 
98467, 27789, 2789, 27588, 98411
34265, 27760, 2778, 27528, 98231, 27761, 2777, 27529, 98232, 27788, 27601, 98412, 98467, 27790, 27602, 98415, 
98468, 27791, 2788, 27590, 98414
34266, 27761, 2777, 27529, 98232, 2817, 70, 2772, 27630, 27790, 27602, 98415, 98468, 2819, 2776, 27643, 
27647, 27792, 2787, 27592, 98417
34267, 2806, 2805, 27607, 27608, 27762, 27752, 98223, 98233, 2808, 27624, 27621, 27625, 27793, 98459, 98419, 
98469, 27794, 27773, 98387, 98418
34268, 27762, 27752, 98223, 98233, 27763, 27753, 98224, 98234, 27793, 98459, 98419, 98469, 27795, 98460, 98422, 
98470, 27796, 27775, 98390, 98421
34269, 27763, 27753, 98224, 98234, 27764, 27754, 98225, 98235, 27795, 98460, 98422, 98470, 27797, 98461, 98425, 
98471, 27798, 27777, 98393, 98424
34270, 27764, 27754, 98225, 98235, 27765, 27755, 98226, 98236, 27797, 98461, 98425, 98471, 27799, 98462, 98428, 
98472, 27800, 27779, 98396, 98427
34271, 27765, 27755, 98226, 98236, 27766, 27756, 98227, 98237, 27799, 98462, 98428, 98472, 27801, 98463, 98431, 
98473, 27802, 27781, 98399, 98430
34272, 27766, 27756, 98227, 98237, 27767, 27757, 98228, 98238, 27801, 98463, 98431, 98473, 27803, 98464, 98434, 
98474, 27804, 27783, 98402, 98433
34273, 27767, 27757, 98228, 98238, 27768, 27758, 98229, 98239, 27803, 98464, 98434, 98474, 27805, 98465, 98437, 
98475, 27806, 27785, 98405, 98436
34274, 27768, 27758, 98229, 98239, 27769, 27759, 98230, 98240, 27805, 98465, 98437, 98475, 27807, 98466, 98440, 
98476, 27808, 27787, 98408, 98439
34275, 27769, 27759, 98230, 98240, 27770, 27760, 98231, 98241, 27807, 98466, 98440, 98476, 27809, 98467, 98443, 
98477, 27810, 27789, 98411, 98442
34276, 27770, 27760, 98231, 98241, 27771, 27761, 98232, 98242, 27809, 98467, 98443, 98477, 27811, 98468, 98446, 
98478, 27812, 27791, 98414, 98445
34277, 27771, 27761, 98232, 98242, 2818, 2817, 27630, 27631, 27811, 98468, 98446, 98478, 2820, 27647, 27645, 
27648, 27813, 27792, 98417, 98448
34278, 71, 2806, 27608, 2800, 2831, 27762, 98233, 27669, 2809, 27625, 27623, 2804, 27814, 98469, 98449, 
27742, 2842, 27794, 98418, 27721
34279, 2831, 27762, 98233, 27669, 2830, 27763, 98234, 27670, 27814, 98469, 98449, 27742, 27815, 98470, 98450, 
27743, 2841, 27796, 98421, 27723
34280, 2830, 27763, 98234, 27670, 2829, 27764, 98235, 27671, 27815, 98470, 98450, 27743, 27816, 98471, 98451, 
27744, 2840, 27798, 98424, 27725
34281, 2829, 27764, 98235, 27671, 2828, 27765, 98236, 27672, 27816, 98471, 98451, 27744, 27817, 98472, 98452, 
27745, 2839, 27800, 98427, 27727
34282, 2828, 27765, 98236, 27672, 2827, 27766, 98237, 27673, 27817, 98472, 98452, 27745, 27818, 98473, 98453, 
27746, 2838, 27802, 98430, 27729
34283, 2827, 27766, 98237, 27673, 2826, 27767, 98238, 27674, 27818, 98473, 98453, 27746, 27819, 98474, 98454, 
27747, 2837, 27804, 98433, 27731
34284, 2826, 27767, 98238, 27674, 2825, 27768, 98239, 27675, 27819, 98474, 98454, 27747, 27820, 98475, 98455, 
27748, 2836, 27806, 98436, 27733
34285, 2825, 27768, 98239, 27675, 2824, 27769, 98240, 27676, 27820, 98475, 98455, 27748, 27821, 98476, 98456, 
27749, 2835, 27808, 98439, 27735
34286, 2824, 27769, 98240, 27676, 2823, 27770, 98241, 27677, 27821, 98476, 98456, 27749, 27822, 98477, 98457, 
27750, 2834, 27810, 98442, 27737
34287, 2823, 27770, 98241, 27677, 2822, 27771, 98242, 27678, 27822, 98477, 98457, 27750, 27823, 98478, 98458, 
27751, 2833, 27812, 98445, 27739
34288, 2822, 27771, 98242, 27678, 72, 2818, 27631, 2812, 27823, 98478, 98458, 27751, 2821, 27648, 27646, 
2816, 2832, 27813, 98448, 27741
*ELEMENT, type=C3D20, ELSET=Volume27
34289, 5, 3323, 31079, 2617, 150, 31165, 98479, 26158, 3327, 31092, 31091, 2620, 31206, 98600, 98601, 
26189, 161, 31205, 98599, 26188
34290, 150, 31165, 98479, 26158, 149, 31166, 98480, 26159, 31206, 98600, 98601, 26189, 31208, 98603, 98604, 
26191, 160, 31207, 98602, 26190
34291, 149, 31166, 98480, 26159, 148, 31167, 98481, 26160, 31208, 98603, 98604, 26191, 31210, 98606, 98607, 
26193, 159, 31209, 98605, 26192
34292, 148, 31167, 98481, 26160, 147, 31168, 98482, 26161, 31210, 98606, 98607, 26193, 31212, 98609, 98610, 
26195, 158, 31211, 98608, 26194
34293, 147, 31168, 98482, 26161, 146, 31169, 98483, 26162, 31212, 98609, 98610, 26195, 31214, 98612, 98613, 
26197, 157, 31213, 98611, 26196
34294, 146, 31169, 98483, 26162, 145, 31170, 98484, 26163, 31214, 98612, 98613, 26197, 31216, 98615, 98616, 
26199, 156, 31215, 98614, 26198
34295, 145, 31170, 98484, 26163, 144, 31171, 98485, 26164, 31216, 98615, 98616, 26199, 31218, 98618, 98619, 
26201, 155, 31217, 98617, 26200
34296, 144, 31171, 98485, 26164, 143, 31172, 98486, 26165, 31218, 98618, 98619, 26201, 31220, 98621, 98622, 
26203, 154, 31219, 98620, 26202
34297, 143, 31172, 98486, 26165, 142, 31173, 98487, 26166, 31220, 98621, 98622, 26203, 31222, 98624, 98625, 
26205, 153, 31221, 98623, 26204
34298, 142, 31173, 98487, 26166, 141, 31174, 98488, 26167, 31222, 98624, 98625, 26205, 31224, 98627, 98628, 
26207, 152, 31223, 98626, 26206
34299, 141, 31174, 98488, 26167, 6, 3341, 31122, 2558, 31224, 98627, 98628, 26207, 3345, 31134, 31135, 
2561, 151, 31225, 98629, 26208
34300, 2617, 31079, 31080, 2618, 26158, 98479, 98489, 26168, 31091, 31094, 31093, 2621, 98601, 98631, 98632, 
26210, 26188, 98599, 98630, 26209
34301, 26158, 98479, 98489, 26168, 26159, 98480, 98490, 26169, 98601, 98631, 98632, 26210, 98604, 98634, 98635, 
26212, 26190, 98602, 98633, 26211
34302, 26159, 98480, 98490, 26169, 26160, 98481, 98491, 26170, 98604, 98634, 98635, 26212, 98607, 98637, 98638, 
26214, 26192, 98605, 98636, 26213
34303, 26160, 98481, 98491, 26170, 26161, 98482, 98492, 26171, 98607, 98637, 98638, 26214, 98610, 98640, 98641, 
26216, 26194, 98608, 98639, 26215
34304, 26161, 98482, 98492, 26171, 26162, 98483, 98493, 26172, 98610, 98640, 98641, 26216, 98613, 98643, 98644, 
26218, 26196, 98611, 98642, 26217
34305, 26162, 98483, 98493, 26172, 26163, 98484, 98494, 26173, 98613, 98643, 98644, 26218, 98616, 98646, 98647, 
26220, 26198, 98614, 98645, 26219
34306, 26163, 98484, 98494, 26173, 26164, 98485, 98495, 26174, 98616, 98646, 98647, 26220, 98619, 98649, 98650, 
26222, 26200, 98617, 98648, 26221
34307, 26164, 98485, 98495, 26174, 26165, 98486, 98496, 26175, 98619, 98649, 98650, 26222, 98622, 98652, 98653, 
26224, 26202, 98620, 98651, 26223
34308, 26165, 98486, 98496, 26175, 26166, 98487, 98497, 26176, 98622, 98652, 98653, 26224, 98625, 98655, 98656, 
26226, 26204, 98623, 98654, 26225
34309, 26166, 98487, 98497, 26176, 26167, 98488, 98498, 26177, 98625, 98655, 98656, 26226, 98628, 98658, 98659, 
26228, 26206, 98626, 98657, 26227
34310, 26167, 98488, 98498, 26177, 2558, 31122, 31123, 2559, 98628, 98658, 98659, 26228, 31135, 31136, 31137, 
2562, 26208, 98629, 98660, 26229
34311, 2618, 31080, 31081, 2619, 26168, 98489, 98499, 26178, 31093, 31096, 31095, 2622, 98632, 98662, 98663, 
26231, 26209, 98630, 98661, 26230
34312, 26168, 98489, 98499, 26178, 26169, 98490, 98500, 26179, 98632, 98662, 98663, 26231, 98635, 98665, 98666, 
26233, 26211, 98633, 98664, 26232
34313, 26169, 98490, 98500, 26179, 26170, 98491, 98501, 26180, 98635, 98665, 98666, 26233, 98638, 98668, 98669, 
26235, 26213, 98636, 98667, 26234
34314, 26170, 98491, 98501, 26180, 26171, 98492, 98502, 26181, 98638, 98668, 98669, 26235, 98641, 98671, 98672, 
26237, 26215, 98639, 98670, 26236
34315, 26171, 98492, 98502, 26181, 26172, 98493, 98503, 26182, 98641, 98671, 98672, 26237, 98644, 98674, 98675, 
26239, 26217, 98642, 98673, 26238
34316, 26172, 98493, 98503, 26182, 26173, 98494, 98504, 26183, 98644, 98674, 98675, 26239, 98647, 98677, 98678, 
26241, 26219, 98645, 98676, 26240
34317, 26173, 98494, 98504, 26183, 26174, 98495, 98505, 26184, 98647, 98677, 98678, 26241, 98650, 98680, 98681, 
26243, 26221, 98648, 98679, 26242
34318, 26174, 98495, 98505, 26184, 26175, 98496, 98506, 26185, 98650, 98680, 98681, 26243, 98653, 98683, 98684, 
26245, 26223, 98651, 98682, 26244
34319, 26175, 98496, 98506, 26185, 26176, 98497, 98507, 26186, 98653, 98683, 98684, 26245, 98656, 98686, 98687, 
26247, 26225, 98654, 98685, 26246
34320, 26176, 98497, 98507, 26186, 26177, 98498, 98508, 26187, 98656, 98686, 98687, 26247, 98659, 98689, 98690, 
26249, 26227, 98657, 98688, 26248
34321, 26177, 98498, 98508, 26187, 2559, 31123, 31124, 2560, 98659, 98689, 98690, 26249, 31137, 31138, 31139, 
2563, 26229, 98660, 98691, 26250
34322, 2619, 31081, 3332, 65, 26178, 98499, 31299, 2633, 31095, 31097, 3336, 2623, 98663, 98692, 31339, 
26251, 26230, 98661, 31340, 2644
34323, 26178, 98499, 31299, 2633, 26179, 98500, 31300, 2632, 98663, 98692, 31339, 26251, 98666, 98693, 31341, 
26252, 26232, 98664, 31342, 2643
34324, 26179, 98500, 31300, 2632, 26180, 98501, 31301, 2631, 98666, 98693, 31341, 26252, 98669, 98694, 31343, 
26253, 26234, 98667, 31344, 2642
34325, 26180, 98501, 31301, 2631, 26181, 98502, 31302, 2630, 98669, 98694, 31343, 26253, 98672, 98695, 31345, 
26254, 26236, 98670, 31346, 2641
34326, 26181, 98502, 31302, 2630, 26182, 98503, 31303, 2629, 98672, 98695, 31345, 26254, 98675, 98696, 31347, 
26255, 26238, 98673, 31348, 2640
34327, 26182, 98503, 31303, 2629, 26183, 98504, 31304, 2628, 98675, 98696, 31347, 26255, 98678, 98697, 31349, 
26256, 26240, 98676, 31350, 2639
34328, 26183, 98504, 31304, 2628, 26184, 98505, 31305, 2627, 98678, 98697, 31349, 26256, 98681, 98698, 31351, 
26257, 26242, 98679, 31352, 2638
34329, 26184, 98505, 31305, 2627, 26185, 98506, 31306, 2626, 98681, 98698, 31351, 26257, 98684, 98699, 31353, 
26258, 26244, 98682, 31354, 2637
34330, 26185, 98506, 31306, 2626, 26186, 98507, 31307, 2625, 98684, 98699, 31353, 26258, 98687, 98700, 31355, 
26259, 26246, 98685, 31356, 2636
34331, 26186, 98507, 31307, 2625, 26187, 98508, 31308, 2624, 98687, 98700, 31355, 26259, 98690, 98701, 31357, 
26260, 26248, 98688, 31358, 2635
34332, 26187, 98508, 31308, 2624, 2560, 31124, 3350, 63, 98690, 98701, 31357, 26260, 31139, 31140, 3354, 
2564, 26250, 98691, 31359, 2634
34333, 3323, 3324, 31082, 31079, 31165, 31175, 98509, 98479, 3328, 31099, 31098, 31092, 31227, 98703, 98704, 
98600, 31205, 31226, 98702, 98599
34334, 31165, 31175, 98509, 98479, 31166, 31176, 98510, 98480, 31227, 98703, 98704, 98600, 31229, 98706, 98707, 
98603, 31207, 31228, 98705, 98602
34335, 31166, 31176, 98510, 98480, 31167, 31177, 98511, 98481, 31229, 98706, 98707, 98603, 31231, 98709, 98710, 
98606, 31209, 31230, 98708, 98605
34336, 31167, 31177, 98511, 98481, 31168, 31178, 98512, 98482, 31231, 98709, 98710, 98606, 31233, 98712, 98713, 
98609, 31211, 31232, 98711, 98608
34337, 31168, 31178, 98512, 98482, 31169, 31179, 98513, 98483, 31233, 98712, 98713, 98609, 31235, 98715, 98716, 
98612, 31213, 31234, 98714, 98611
34338, 31169, 31179, 98513, 98483, 31170, 31180, 98514, 98484, 31235, 98715, 98716, 98612, 31237, 98718, 98719, 
98615, 31215, 31236, 98717, 98614
34339, 31170, 31180, 98514, 98484, 31171, 31181, 98515, 98485, 31237, 98718, 98719, 98615, 31239, 98721, 98722, 
98618, 31217, 31238, 98720, 98617
34340, 31171, 31181, 98515, 98485, 31172, 31182, 98516, 98486, 31239, 98721, 98722, 98618, 31241, 98724, 98725, 
98621, 31219, 31240, 98723, 98620
34341, 31172, 31182, 98516, 98486, 31173, 31183, 98517, 98487, 31241, 98724, 98725, 98621, 31243, 98727, 98728, 
98624, 31221, 31242, 98726, 98623
34342, 31173, 31183, 98517, 98487, 31174, 31184, 98518, 98488, 31243, 98727, 98728, 98624, 31245, 98730, 98731, 
98627, 31223, 31244, 98729, 98626
34343, 31174, 31184, 98518, 98488, 3341, 3342, 31125, 31122, 31245, 98730, 98731, 98627, 3346, 31141, 31142, 
31134, 31225, 31246, 98732, 98629
34344, 31079, 31082, 31083, 31080, 98479, 98509, 98519, 98489, 31098, 31101, 31100, 31094, 98704, 98734, 98735, 
98631, 98599, 98702, 98733, 98630
34345, 98479, 98509, 98519, 98489, 98480, 98510, 98520, 98490, 98704, 98734, 98735, 98631, 98707, 98737, 98738, 
98634, 98602, 98705, 98736, 98633
34346, 98480, 98510, 98520, 98490, 98481, 98511, 98521, 98491, 98707, 98737, 98738, 98634, 98710, 98740, 98741, 
98637, 98605, 98708, 98739, 98636
34347, 98481, 98511, 98521, 98491, 98482, 98512, 98522, 98492, 98710, 98740, 98741, 98637, 98713, 98743, 98744, 
98640, 98608, 98711, 98742, 98639
34348, 98482, 98512, 98522, 98492, 98483, 98513, 98523, 98493, 98713, 98743, 98744, 98640, 98716, 98746, 98747, 
98643, 98611, 98714, 98745, 98642
34349, 98483, 98513, 98523, 98493, 98484, 98514, 98524, 98494, 98716, 98746, 98747, 98643, 98719, 98749, 98750, 
98646, 98614, 98717, 98748, 98645
34350, 98484, 98514, 98524, 98494, 98485, 98515, 98525, 98495, 98719, 98749, 98750, 98646, 98722, 98752, 98753, 
98649, 98617, 98720, 98751, 98648
34351, 98485, 98515, 98525, 98495, 98486, 98516, 98526, 98496, 98722, 98752, 98753, 98649, 98725, 98755, 98756, 
98652, 98620, 98723, 98754, 98651
34352, 98486, 98516, 98526, 98496, 98487, 98517, 98527, 98497, 98725, 98755, 98756, 98652, 98728, 98758, 98759, 
98655, 98623, 98726, 98757, 98654
34353, 98487, 98517, 98527, 98497, 98488, 98518, 98528, 98498, 98728, 98758, 98759, 98655, 98731, 98761, 98762, 
98658, 98626, 98729, 98760, 98657
34354, 98488, 98518, 98528, 98498, 31122, 31125, 31126, 31123, 98731, 98761, 98762, 98658, 31142, 31143, 31144, 
31136, 98629, 98732, 98763, 98660
34355, 31080, 31083, 31084, 31081, 98489, 98519, 98529, 98499, 31100, 31103, 31102, 31096, 98735, 98765, 98766, 
98662, 98630, 98733, 98764, 98661
34356, 98489, 98519, 98529, 98499, 98490, 98520, 98530, 98500, 98735, 98765, 98766, 98662, 98738, 98768, 98769, 
98665, 98633, 98736, 98767, 98664
34357, 98490, 98520, 98530, 98500, 98491, 98521, 98531, 98501, 98738, 98768, 98769, 98665, 98741, 98771, 98772, 
98668, 98636, 98739, 98770, 98667
34358, 98491, 98521, 98531, 98501, 98492, 98522, 98532, 98502, 98741, 98771, 98772, 98668, 98744, 98774, 98775, 
98671, 98639, 98742, 98773, 98670
34359, 98492, 98522, 98532, 98502, 98493, 98523, 98533, 98503, 98744, 98774, 98775, 98671, 98747, 98777, 98778, 
98674, 98642, 98745, 98776, 98673
34360, 98493, 98523, 98533, 98503, 98494, 98524, 98534, 98504, 98747, 98777, 98778, 98674, 98750, 98780, 98781, 
98677, 98645, 98748, 98779, 98676
34361, 98494, 98524, 98534, 98504, 98495, 98525, 98535, 98505, 98750, 98780, 98781, 98677, 98753, 98783, 98784, 
98680, 98648, 98751, 98782, 98679
34362, 98495, 98525, 98535, 98505, 98496, 98526, 98536, 98506, 98753, 98783, 98784, 98680, 98756, 98786, 98787, 
98683, 98651, 98754, 98785, 98682
34363, 98496, 98526, 98536, 98506, 98497, 98527, 98537, 98507, 98756, 98786, 98787, 98683, 98759, 98789, 98790, 
98686, 98654, 98757, 98788, 98685
34364, 98497, 98527, 98537, 98507, 98498, 98528, 98538, 98508, 98759, 98789, 98790, 98686, 98762, 98792, 98793, 
98689, 98657, 98760, 98791, 98688
34365, 98498, 98528, 98538, 98508, 31123, 31126, 31127, 31124, 98762, 98792, 98793, 98689, 31144, 31145, 31146, 
31138, 98660, 98763, 98794, 98691
34366, 31081, 31084, 3333, 3332, 98499, 98529, 31309, 31299, 31102, 31104, 3337, 31097, 98766, 98795, 31360, 
98692, 98661, 98764, 31361, 31340
34367, 98499, 98529, 31309, 31299, 98500, 98530, 31310, 31300, 98766, 98795, 31360, 98692, 98769, 98796, 31362, 
98693, 98664, 98767, 31363, 31342
34368, 98500, 98530, 31310, 31300, 98501, 98531, 31311, 31301, 98769, 98796, 31362, 98693, 98772, 98797, 31364, 
98694, 98667, 98770, 31365, 31344
34369, 98501, 98531, 31311, 31301, 98502, 98532, 31312, 31302, 98772, 98797, 31364, 98694, 98775, 98798, 31366, 
98695, 98670, 98773, 31367, 31346
34370, 98502, 98532, 31312, 31302, 98503, 98533, 31313, 31303, 98775, 98798, 31366, 98695, 98778, 98799, 31368, 
98696, 98673, 98776, 31369, 31348
34371, 98503, 98533, 31313, 31303, 98504, 98534, 31314, 31304, 98778, 98799, 31368, 98696, 98781, 98800, 31370, 
98697, 98676, 98779, 31371, 31350
34372, 98504, 98534, 31314, 31304, 98505, 98535, 31315, 31305, 98781, 98800, 31370, 98697, 98784, 98801, 31372, 
98698, 98679, 98782, 31373, 31352
34373, 98505, 98535, 31315, 31305, 98506, 98536, 31316, 31306, 98784, 98801, 31372, 98698, 98787, 98802, 31374, 
98699, 98682, 98785, 31375, 31354
34374, 98506, 98536, 31316, 31306, 98507, 98537, 31317, 31307, 98787, 98802, 31374, 98699, 98790, 98803, 31376, 
98700, 98685, 98788, 31377, 31356
34375, 98507, 98537, 31317, 31307, 98508, 98538, 31318, 31308, 98790, 98803, 31376, 98700, 98793, 98804, 31378, 
98701, 98688, 98791, 31379, 31358
34376, 98508, 98538, 31318, 31308, 31124, 31127, 3351, 3350, 98793, 98804, 31378, 98701, 31146, 31147, 3355, 
31140, 98691, 98794, 31380, 31359
34377, 3324, 3325, 31085, 31082, 31175, 31185, 98539, 98509, 3329, 31106, 31105, 31099, 31248, 98806, 98807, 
98703, 31226, 31247, 98805, 98702
34378, 31175, 31185, 98539, 98509, 31176, 31186, 98540, 98510, 31248, 98806, 98807, 98703, 31250, 98809, 98810, 
98706, 31228, 31249, 98808, 98705
34379, 31176, 31186, 98540, 98510, 31177, 31187, 98541, 98511, 31250, 98809, 98810, 98706, 31252, 98812, 98813, 
98709, 31230, 31251, 98811, 98708
34380, 31177, 31187, 98541, 98511, 31178, 31188, 98542, 98512, 31252, 98812, 98813, 98709, 31254, 98815, 98816, 
98712, 31232, 31253, 98814, 98711
34381, 31178, 31188, 98542, 98512, 31179, 31189, 98543, 98513, 31254, 98815, 98816, 98712, 31256, 98818, 98819, 
98715, 31234, 31255, 98817, 98714
34382, 31179, 31189, 98543, 98513, 31180, 31190, 98544, 98514, 31256, 98818, 98819, 98715, 31258, 98821, 98822, 
98718, 31236, 31257, 98820, 98717
34383, 31180, 31190, 98544, 98514, 31181, 31191, 98545, 98515, 31258, 98821, 98822, 98718, 31260, 98824, 98825, 
98721, 31238, 31259, 98823, 98720
34384, 31181, 31191, 98545, 98515, 31182, 31192, 98546, 98516, 31260, 98824, 98825, 98721, 31262, 98827, 98828, 
98724, 31240, 31261, 98826, 98723
34385, 31182, 31192, 98546, 98516, 31183, 31193, 98547, 98517, 31262, 98827, 98828, 98724, 31264, 98830, 98831, 
98727, 31242, 31263, 98829, 98726
34386, 31183, 31193, 98547, 98517, 31184, 31194, 98548, 98518, 31264, 98830, 98831, 98727, 31266, 98833, 98834, 
98730, 31244, 31265, 98832, 98729
34387, 31184, 31194, 98548, 98518, 3342, 3343, 31128, 31125, 31266, 98833, 98834, 98730, 3347, 31148, 31149, 
31141, 31246, 31267, 98835, 98732
34388, 31082, 31085, 31086, 31083, 98509, 98539, 98549, 98519, 31105, 31108, 31107, 31101, 98807, 98837, 98838, 
98734, 98702, 98805, 98836, 98733
34389, 98509, 98539, 98549, 98519, 98510, 98540, 98550, 98520, 98807, 98837, 98838, 98734, 98810, 98840, 98841, 
98737, 98705, 98808, 98839, 98736
34390, 98510, 98540, 98550, 98520, 98511, 98541, 98551, 98521, 98810, 98840, 98841, 98737, 98813, 98843, 98844, 
98740, 98708, 98811, 98842, 98739
34391, 98511, 98541, 98551, 98521, 98512, 98542, 98552, 98522, 98813, 98843, 98844, 98740, 98816, 98846, 98847, 
98743, 98711, 98814, 98845, 98742
34392, 98512, 98542, 98552, 98522, 98513, 98543, 98553, 98523, 98816, 98846, 98847, 98743, 98819, 98849, 98850, 
98746, 98714, 98817, 98848, 98745
34393, 98513, 98543, 98553, 98523, 98514, 98544, 98554, 98524, 98819, 98849, 98850, 98746, 98822, 98852, 98853, 
98749, 98717, 98820, 98851, 98748
34394, 98514, 98544, 98554, 98524, 98515, 98545, 98555, 98525, 98822, 98852, 98853, 98749, 98825, 98855, 98856, 
98752, 98720, 98823, 98854, 98751
34395, 98515, 98545, 98555, 98525, 98516, 98546, 98556, 98526, 98825, 98855, 98856, 98752, 98828, 98858, 98859, 
98755, 98723, 98826, 98857, 98754
34396, 98516, 98546, 98556, 98526, 98517, 98547, 98557, 98527, 98828, 98858, 98859, 98755, 98831, 98861, 98862, 
98758, 98726, 98829, 98860, 98757
34397, 98517, 98547, 98557, 98527, 98518, 98548, 98558, 98528, 98831, 98861, 98862, 98758, 98834, 98864, 98865, 
98761, 98729, 98832, 98863, 98760
34398, 98518, 98548, 98558, 98528, 31125, 31128, 31129, 31126, 98834, 98864, 98865, 98761, 31149, 31150, 31151, 
31143, 98732, 98835, 98866, 98763
34399, 31083, 31086, 31087, 31084, 98519, 98549, 98559, 98529, 31107, 31110, 31109, 31103, 98838, 98868, 98869, 
98765, 98733, 98836, 98867, 98764
34400, 98519, 98549, 98559, 98529, 98520, 98550, 98560, 98530, 98838, 98868, 98869, 98765, 98841, 98871, 98872, 
98768, 98736, 98839, 98870, 98767
34401, 98520, 98550, 98560, 98530, 98521, 98551, 98561, 98531, 98841, 98871, 98872, 98768, 98844, 98874, 98875, 
98771, 98739, 98842, 98873, 98770
34402, 98521, 98551, 98561, 98531, 98522, 98552, 98562, 98532, 98844, 98874, 98875, 98771, 98847, 98877, 98878, 
98774, 98742, 98845, 98876, 98773
34403, 98522, 98552, 98562, 98532, 98523, 98553, 98563, 98533, 98847, 98877, 98878, 98774, 98850, 98880, 98881, 
98777, 98745, 98848, 98879, 98776
34404, 98523, 98553, 98563, 98533, 98524, 98554, 98564, 98534, 98850, 98880, 98881, 98777, 98853, 98883, 98884, 
98780, 98748, 98851, 98882, 98779
34405, 98524, 98554, 98564, 98534, 98525, 98555, 98565, 98535, 98853, 98883, 98884, 98780, 98856, 98886, 98887, 
98783, 98751, 98854, 98885, 98782
34406, 98525, 98555, 98565, 98535, 98526, 98556, 98566, 98536, 98856, 98886, 98887, 98783, 98859, 98889, 98890, 
98786, 98754, 98857, 98888, 98785
34407, 98526, 98556, 98566, 98536, 98527, 98557, 98567, 98537, 98859, 98889, 98890, 98786, 98862, 98892, 98893, 
98789, 98757, 98860, 98891, 98788
34408, 98527, 98557, 98567, 98537, 98528, 98558, 98568, 98538, 98862, 98892, 98893, 98789, 98865, 98895, 98896, 
98792, 98760, 98863, 98894, 98791
34409, 98528, 98558, 98568, 98538, 31126, 31129, 31130, 31127, 98865, 98895, 98896, 98792, 31151, 31152, 31153, 
31145, 98763, 98866, 98897, 98794
34410, 31084, 31087, 3334, 3333, 98529, 98559, 31319, 31309, 31109, 31111, 3338, 31104, 98869, 98898, 31381, 
98795, 98764, 98867, 31382, 31361
34411, 98529, 98559, 31319, 31309, 98530, 98560, 31320, 31310, 98869, 98898, 31381, 98795, 98872, 98899, 31383, 
98796, 98767, 98870, 31384, 31363
34412, 98530, 98560, 31320, 31310, 98531, 98561, 31321, 31311, 98872, 98899, 31383, 98796, 98875, 98900, 31385, 
98797, 98770, 98873, 31386, 31365
34413, 98531, 98561, 31321, 31311, 98532, 98562, 31322, 31312, 98875, 98900, 31385, 98797, 98878, 98901, 31387, 
98798, 98773, 98876, 31388, 31367
34414, 98532, 98562, 31322, 31312, 98533, 98563, 31323, 31313, 98878, 98901, 31387, 98798, 98881, 98902, 31389, 
98799, 98776, 98879, 31390, 31369
34415, 98533, 98563, 31323, 31313, 98534, 98564, 31324, 31314, 98881, 98902, 31389, 98799, 98884, 98903, 31391, 
98800, 98779, 98882, 31392, 31371
34416, 98534, 98564, 31324, 31314, 98535, 98565, 31325, 31315, 98884, 98903, 31391, 98800, 98887, 98904, 31393, 
98801, 98782, 98885, 31394, 31373
34417, 98535, 98565, 31325, 31315, 98536, 98566, 31326, 31316, 98887, 98904, 31393, 98801, 98890, 98905, 31395, 
98802, 98785, 98888, 31396, 31375
34418, 98536, 98566, 31326, 31316, 98537, 98567, 31327, 31317, 98890, 98905, 31395, 98802, 98893, 98906, 31397, 
98803, 98788, 98891, 31398, 31377
34419, 98537, 98567, 31327, 31317, 98538, 98568, 31328, 31318, 98893, 98906, 31397, 98803, 98896, 98907, 31399, 
98804, 98791, 98894, 31400, 31379
34420, 98538, 98568, 31328, 31318, 31127, 31130, 3352, 3351, 98896, 98907, 31399, 98804, 31153, 31154, 3356, 
31147, 98794, 98897, 31401, 31380
34421, 3325, 3326, 31088, 31085, 31185, 31195, 98569, 98539, 3330, 31113, 31112, 31106, 31269, 98909, 98910, 
98806, 31247, 31268, 98908, 98805
34422, 31185, 31195, 98569, 98539, 31186, 31196, 98570, 98540, 31269, 98909, 98910, 98806, 31271, 98912, 98913, 
98809, 31249, 31270, 98911, 98808
34423, 31186, 31196, 98570, 98540, 31187, 31197, 98571, 98541, 31271, 98912, 98913, 98809, 31273, 98915, 98916, 
98812, 31251, 31272, 98914, 98811
34424, 31187, 31197, 98571, 98541, 31188, 31198, 98572, 98542, 31273, 98915, 98916, 98812, 31275, 98918, 98919, 
98815, 31253, 31274, 98917, 98814
34425, 31188, 31198, 98572, 98542, 31189, 31199, 98573, 98543, 31275, 98918, 98919, 98815, 31277, 98921, 98922, 
98818, 31255, 31276, 98920, 98817
34426, 31189, 31199, 98573, 98543, 31190, 31200, 98574, 98544, 31277, 98921, 98922, 98818, 31279, 98924, 98925, 
98821, 31257, 31278, 98923, 98820
34427, 31190, 31200, 98574, 98544, 31191, 31201, 98575, 98545, 31279, 98924, 98925, 98821, 31281, 98927, 98928, 
98824, 31259, 31280, 98926, 98823
34428, 31191, 31201, 98575, 98545, 31192, 31202, 98576, 98546, 31281, 98927, 98928, 98824, 31283, 98930, 98931, 
98827, 31261, 31282, 98929, 98826
34429, 31192, 31202, 98576, 98546, 31193, 31203, 98577, 98547, 31283, 98930, 98931, 98827, 31285, 98933, 98934, 
98830, 31263, 31284, 98932, 98829
34430, 31193, 31203, 98577, 98547, 31194, 31204, 98578, 98548, 31285, 98933, 98934, 98830, 31287, 98936, 98937, 
98833, 31265, 31286, 98935, 98832
34431, 31194, 31204, 98578, 98548, 3343, 3344, 31131, 31128, 31287, 98936, 98937, 98833, 3348, 31155, 31156, 
31148, 31267, 31288, 98938, 98835
34432, 31085, 31088, 31089, 31086, 98539, 98569, 98579, 98549, 31112, 31115, 31114, 31108, 98910, 98940, 98941, 
98837, 98805, 98908, 98939, 98836
34433, 98539, 98569, 98579, 98549, 98540, 98570, 98580, 98550, 98910, 98940, 98941, 98837, 98913, 98943, 98944, 
98840, 98808, 98911, 98942, 98839
34434, 98540, 98570, 98580, 98550, 98541, 98571, 98581, 98551, 98913, 98943, 98944, 98840, 98916, 98946, 98947, 
98843, 98811, 98914, 98945, 98842
34435, 98541, 98571, 98581, 98551, 98542, 98572, 98582, 98552, 98916, 98946, 98947, 98843, 98919, 98949, 98950, 
98846, 98814, 98917, 98948, 98845
34436, 98542, 98572, 98582, 98552, 98543, 98573, 98583, 98553, 98919, 98949, 98950, 98846, 98922, 98952, 98953, 
98849, 98817, 98920, 98951, 98848
34437, 98543, 98573, 98583, 98553, 98544, 98574, 98584, 98554, 98922, 98952, 98953, 98849, 98925, 98955, 98956, 
98852, 98820, 98923, 98954, 98851
34438, 98544, 98574, 98584, 98554, 98545, 98575, 98585, 98555, 98925, 98955, 98956, 98852, 98928, 98958, 98959, 
98855, 98823, 98926, 98957, 98854
34439, 98545, 98575, 98585, 98555, 98546, 98576, 98586, 98556, 98928, 98958, 98959, 98855, 98931, 98961, 98962, 
98858, 98826, 98929, 98960, 98857
34440, 98546, 98576, 98586, 98556, 98547, 98577, 98587, 98557, 98931, 98961, 98962, 98858, 98934, 98964, 98965, 
98861, 98829, 98932, 98963, 98860
34441, 98547, 98577, 98587, 98557, 98548, 98578, 98588, 98558, 98934, 98964, 98965, 98861, 98937, 98967, 98968, 
98864, 98832, 98935, 98966, 98863
34442, 98548, 98578, 98588, 98558, 31128, 31131, 31132, 31129, 98937, 98967, 98968, 98864, 31156, 31157, 31158, 
31150, 98835, 98938, 98969, 98866
34443, 31086, 31089, 31090, 31087, 98549, 98579, 98589, 98559, 31114, 31117, 31116, 31110, 98941, 98971, 98972, 
98868, 98836, 98939, 98970, 98867
34444, 98549, 98579, 98589, 98559, 98550, 98580, 98590, 98560, 98941, 98971, 98972, 98868, 98944, 98974, 98975, 
98871, 98839, 98942, 98973, 98870
34445, 98550, 98580, 98590, 98560, 98551, 98581, 98591, 98561, 98944, 98974, 98975, 98871, 98947, 98977, 98978, 
98874, 98842, 98945, 98976, 98873
34446, 98551, 98581, 98591, 98561, 98552, 98582, 98592, 98562, 98947, 98977, 98978, 98874, 98950, 98980, 98981, 
98877, 98845, 98948, 98979, 98876
34447, 98552, 98582, 98592, 98562, 98553, 98583, 98593, 98563, 98950, 98980, 98981, 98877, 98953, 98983, 98984, 
98880, 98848, 98951, 98982, 98879
34448, 98553, 98583, 98593, 98563, 98554, 98584, 98594, 98564, 98953, 98983, 98984, 98880, 98956, 98986, 98987, 
98883, 98851, 98954, 98985, 98882
34449, 98554, 98584, 98594, 98564, 98555, 98585, 98595, 98565, 98956, 98986, 98987, 98883, 98959, 98989, 98990, 
98886, 98854, 98957, 98988, 98885
34450, 98555, 98585, 98595, 98565, 98556, 98586, 98596, 98566, 98959, 98989, 98990, 98886, 98962, 98992, 98993, 
98889, 98857, 98960, 98991, 98888
34451, 98556, 98586, 98596, 98566, 98557, 98587, 98597, 98567, 98962, 98992, 98993, 98889, 98965, 98995, 98996, 
98892, 98860, 98963, 98994, 98891
34452, 98557, 98587, 98597, 98567, 98558, 98588, 98598, 98568, 98965, 98995, 98996, 98892, 98968, 98998, 98999, 
98895, 98863, 98966, 98997, 98894
34453, 98558, 98588, 98598, 98568, 31129, 31132, 31133, 31130, 98968, 98998, 98999, 98895, 31158, 31159, 31160, 
31152, 98866, 98969, 99000, 98897
34454, 31087, 31090, 3335, 3334, 98559, 98589, 31329, 31319, 31116, 31118, 3339, 31111, 98972, 99001, 31402, 
98898, 98867, 98970, 31403, 31382
34455, 98559, 98589, 31329, 31319, 98560, 98590, 31330, 31320, 98972, 99001, 31402, 98898, 98975, 99002, 31404, 
98899, 98870, 98973, 31405, 31384
34456, 98560, 98590, 31330, 31320, 98561, 98591, 31331, 31321, 98975, 99002, 31404, 98899, 98978, 99003, 31406, 
98900, 98873, 98976, 31407, 31386
34457, 98561, 98591, 31331, 31321, 98562, 98592, 31332, 31322, 98978, 99003, 31406, 98900, 98981, 99004, 31408, 
98901, 98876, 98979, 31409, 31388
34458, 98562, 98592, 31332, 31322, 98563, 98593, 31333, 31323, 98981, 99004, 31408, 98901, 98984, 99005, 31410, 
98902, 98879, 98982, 31411, 31390
34459, 98563, 98593, 31333, 31323, 98564, 98594, 31334, 31324, 98984, 99005, 31410, 98902, 98987, 99006, 31412, 
98903, 98882, 98985, 31413, 31392
34460, 98564, 98594, 31334, 31324, 98565, 98595, 31335, 31325, 98987, 99006, 31412, 98903, 98990, 99007, 31414, 
98904, 98885, 98988, 31415, 31394
34461, 98565, 98595, 31335, 31325, 98566, 98596, 31336, 31326, 98990, 99007, 31414, 98904, 98993, 99008, 31416, 
98905, 98888, 98991, 31417, 31396
34462, 98566, 98596, 31336, 31326, 98567, 98597, 31337, 31327, 98993, 99008, 31416, 98905, 98996, 99009, 31418, 
98906, 98891, 98994, 31419, 31398
34463, 98567, 98597, 31337, 31327, 98568, 98598, 31338, 31328, 98996, 99009, 31418, 98906, 98999, 99010, 31420, 
98907, 98894, 98997, 31421, 31400
34464, 98568, 98598, 31338, 31328, 31130, 31133, 3353, 3352, 98999, 99010, 31420, 98907, 31160, 31161, 3357, 
31154, 98897, 99000, 31422, 31401
34465, 3326, 85, 3198, 31088, 31195, 3186, 30284, 98569, 3331, 3201, 31119, 31113, 31289, 30314, 99011, 
98909, 31268, 3197, 30315, 98908
34466, 31195, 3186, 30284, 98569, 31196, 3185, 30285, 98570, 31289, 30314, 99011, 98909, 31290, 30316, 99012, 
98912, 31270, 3196, 30317, 98911
34467, 31196, 3185, 30285, 98570, 31197, 3184, 30286, 98571, 31290, 30316, 99012, 98912, 31291, 30318, 99013, 
98915, 31272, 3195, 30319, 98914
34468, 31197, 3184, 30286, 98571, 31198, 3183, 30287, 98572, 31291, 30318, 99013, 98915, 31292, 30320, 99014, 
98918, 31274, 3194, 30321, 98917
34469, 31198, 3183, 30287, 98572, 31199, 3182, 30288, 98573, 31292, 30320, 99014, 98918, 31293, 30322, 99015, 
98921, 31276, 3193, 30323, 98920
34470, 31199, 3182, 30288, 98573, 31200, 3181, 30289, 98574, 31293, 30322, 99015, 98921, 31294, 30324, 99016, 
98924, 31278, 3192, 30325, 98923
34471, 31200, 3181, 30289, 98574, 31201, 3180, 30290, 98575, 31294, 30324, 99016, 98924, 31295, 30326, 99017, 
98927, 31280, 3191, 30327, 98926
34472, 31201, 3180, 30290, 98575, 31202, 3179, 30291, 98576, 31295, 30326, 99017, 98927, 31296, 30328, 99018, 
98930, 31282, 3190, 30329, 98929
34473, 31202, 3179, 30291, 98576, 31203, 3178, 30292, 98577, 31296, 30328, 99018, 98930, 31297, 30330, 99019, 
98933, 31284, 3189, 30331, 98932
34474, 31203, 3178, 30292, 98577, 31204, 3177, 30293, 98578, 31297, 30330, 99019, 98933, 31298, 30332, 99020, 
98936, 31286, 3188, 30333, 98935
34475, 31204, 3177, 30293, 98578, 3344, 86, 3250, 31131, 31298, 30332, 99020, 98936, 3349, 3253, 31162, 
31155, 31288, 3187, 30334, 98938
34476, 31088, 3198, 3199, 31089, 98569, 30284, 30294, 98579, 31119, 3202, 31120, 31115, 99011, 30335, 99021, 
98940, 98908, 30315, 30336, 98939
34477, 98569, 30284, 30294, 98579, 98570, 30285, 30295, 98580, 99011, 30335, 99021, 98940, 99012, 30337, 99022, 
98943, 98911, 30317, 30338, 98942
34478, 98570, 30285, 30295, 98580, 98571, 30286, 30296, 98581, 99012, 30337, 99022, 98943, 99013, 30339, 99023, 
98946, 98914, 30319, 30340, 98945
34479, 98571, 30286, 30296, 98581, 98572, 30287, 30297, 98582, 99013, 30339, 99023, 98946, 99014, 30341, 99024, 
98949, 98917, 30321, 30342, 98948
34480, 98572, 30287, 30297, 98582, 98573, 30288, 30298, 98583, 99014, 30341, 99024, 98949, 99015, 30343, 99025, 
98952, 98920, 30323, 30344, 98951
34481, 98573, 30288, 30298, 98583, 98574, 30289, 30299, 98584, 99015, 30343, 99025, 98952, 99016, 30345, 99026, 
98955, 98923, 30325, 30346, 98954
34482, 98574, 30289, 30299, 98584, 98575, 30290, 30300, 98585, 99016, 30345, 99026, 98955, 99017, 30347, 99027, 
98958, 98926, 30327, 30348, 98957
34483, 98575, 30290, 30300, 98585, 98576, 30291, 30301, 98586, 99017, 30347, 99027, 98958, 99018, 30349, 99028, 
98961, 98929, 30329, 30350, 98960
34484, 98576, 30291, 30301, 98586, 98577, 30292, 30302, 98587, 99018, 30349, 99028, 98961, 99019, 30351, 99029, 
98964, 98932, 30331, 30352, 98963
34485, 98577, 30292, 30302, 98587, 98578, 30293, 30303, 98588, 99019, 30351, 99029, 98964, 99020, 30353, 99030, 
98967, 98935, 30333, 30354, 98966
34486, 98578, 30293, 30303, 98588, 31131, 3250, 3251, 31132, 99020, 30353, 99030, 98967, 31162, 3254, 31163, 
31157, 98938, 30334, 30355, 98969
34487, 31089, 3199, 3200, 31090, 98579, 30294, 30304, 98589, 31120, 3203, 31121, 31117, 99021, 30356, 99031, 
98971, 98939, 30336, 30357, 98970
34488, 98579, 30294, 30304, 98589, 98580, 30295, 30305, 98590, 99021, 30356, 99031, 98971, 99022, 30358, 99032, 
98974, 98942, 30338, 30359, 98973
34489, 98580, 30295, 30305, 98590, 98581, 30296, 30306, 98591, 99022, 30358, 99032, 98974, 99023, 30360, 99033, 
98977, 98945, 30340, 30361, 98976
34490, 98581, 30296, 30306, 98591, 98582, 30297, 30307, 98592, 99023, 30360, 99033, 98977, 99024, 30362, 99034, 
98980, 98948, 30342, 30363, 98979
34491, 98582, 30297, 30307, 98592, 98583, 30298, 30308, 98593, 99024, 30362, 99034, 98980, 99025, 30364, 99035, 
98983, 98951, 30344, 30365, 98982
34492, 98583, 30298, 30308, 98593, 98584, 30299, 30309, 98594, 99025, 30364, 99035, 98983, 99026, 30366, 99036, 
98986, 98954, 30346, 30367, 98985
34493, 98584, 30299, 30309, 98594, 98585, 30300, 30310, 98595, 99026, 30366, 99036, 98986, 99027, 30368, 99037, 
98989, 98957, 30348, 30369, 98988
34494, 98585, 30300, 30310, 98595, 98586, 30301, 30311, 98596, 99027, 30368, 99037, 98989, 99028, 30370, 99038, 
98992, 98960, 30350, 30371, 98991
34495, 98586, 30301, 30311, 98596, 98587, 30302, 30312, 98597, 99028, 30370, 99038, 98992, 99029, 30372, 99039, 
98995, 98963, 30352, 30373, 98994
34496, 98587, 30302, 30312, 98597, 98588, 30303, 30313, 98598, 99029, 30372, 99039, 98995, 99030, 30374, 99040, 
98998, 98966, 30354, 30375, 98997
34497, 98588, 30303, 30313, 98598, 31132, 3251, 3252, 31133, 99030, 30374, 99040, 98998, 31163, 3255, 31164, 
31159, 98969, 30355, 30376, 99000
34498, 31090, 3200, 87, 3335, 98589, 30304, 3311, 31329, 31121, 3204, 3340, 31118, 99031, 30377, 31423, 
99001, 98970, 30357, 3322, 31403
34499, 98589, 30304, 3311, 31329, 98590, 30305, 3310, 31330, 99031, 30377, 31423, 99001, 99032, 30378, 31424, 
99002, 98973, 30359, 3321, 31405
34500, 98590, 30305, 3310, 31330, 98591, 30306, 3309, 31331, 99032, 30378, 31424, 99002, 99033, 30379, 31425, 
99003, 98976, 30361, 3320, 31407
34501, 98591, 30306, 3309, 31331, 98592, 30307, 3308, 31332, 99033, 30379, 31425, 99003, 99034, 30380, 31426, 
99004, 98979, 30363, 3319, 31409
34502, 98592, 30307, 3308, 31332, 98593, 30308, 3307, 31333, 99034, 30380, 31426, 99004, 99035, 30381, 31427, 
99005, 98982, 30365, 3318, 31411
34503, 98593, 30308, 3307, 31333, 98594, 30309, 3306, 31334, 99035, 30381, 31427, 99005, 99036, 30382, 31428, 
99006, 98985, 30367, 3317, 31413
34504, 98594, 30309, 3306, 31334, 98595, 30310, 3305, 31335, 99036, 30382, 31428, 99006, 99037, 30383, 31429, 
99007, 98988, 30369, 3316, 31415
34505, 98595, 30310, 3305, 31335, 98596, 30311, 3304, 31336, 99037, 30383, 31429, 99007, 99038, 30384, 31430, 
99008, 98991, 30371, 3315, 31417
34506, 98596, 30311, 3304, 31336, 98597, 30312, 3303, 31337, 99038, 30384, 31430, 99008, 99039, 30385, 31431, 
99009, 98994, 30373, 3314, 31419
34507, 98597, 30312, 3303, 31337, 98598, 30313, 3302, 31338, 99039, 30385, 31431, 99009, 99040, 30386, 31432, 
99010, 98997, 30375, 3313, 31421
34508, 98598, 30313, 3302, 31338, 31133, 3252, 88, 3353, 99040, 30386, 31432, 99010, 31164, 3256, 3358, 
31161, 99000, 30376, 3312, 31422
*ELEMENT, type=C3D20, ELSET=Volume28
34509, 24, 2843, 27824, 2307, 1113, 27870, 99041, 23576, 2845, 27831, 27830, 2310, 27891, 99102, 99103, 
23607, 1124, 27890, 99101, 23606
34510, 1113, 27870, 99041, 23576, 1112, 27871, 99042, 23577, 27891, 99102, 99103, 23607, 27893, 99105, 99106, 
23609, 1123, 27892, 99104, 23608
34511, 1112, 27871, 99042, 23577, 1111, 27872, 99043, 23578, 27893, 99105, 99106, 23609, 27895, 99108, 99109, 
23611, 1122, 27894, 99107, 23610
34512, 1111, 27872, 99043, 23578, 1110, 27873, 99044, 23579, 27895, 99108, 99109, 23611, 27897, 99111, 99112, 
23613, 1121, 27896, 99110, 23612
34513, 1110, 27873, 99044, 23579, 1109, 27874, 99045, 23580, 27897, 99111, 99112, 23613, 27899, 99114, 99115, 
23615, 1120, 27898, 99113, 23614
34514, 1109, 27874, 99045, 23580, 1108, 27875, 99046, 23581, 27899, 99114, 99115, 23615, 27901, 99117, 99118, 
23617, 1119, 27900, 99116, 23616
34515, 1108, 27875, 99046, 23581, 1107, 27876, 99047, 23582, 27901, 99117, 99118, 23617, 27903, 99120, 99121, 
23619, 1118, 27902, 99119, 23618
34516, 1107, 27876, 99047, 23582, 1106, 27877, 99048, 23583, 27903, 99120, 99121, 23619, 27905, 99123, 99124, 
23621, 1117, 27904, 99122, 23620
34517, 1106, 27877, 99048, 23583, 1105, 27878, 99049, 23584, 27905, 99123, 99124, 23621, 27907, 99126, 99127, 
23623, 1116, 27906, 99125, 23622
34518, 1105, 27878, 99049, 23584, 1104, 27879, 99050, 23585, 27907, 99126, 99127, 23623, 27909, 99129, 99130, 
23625, 1115, 27908, 99128, 23624
34519, 1104, 27879, 99050, 23585, 22, 2860, 27847, 2227, 27909, 99129, 99130, 23625, 2862, 27853, 27854, 
2230, 1114, 27910, 99131, 23626
34520, 2307, 27824, 27825, 2308, 23576, 99041, 99051, 23586, 27830, 27833, 27832, 2311, 99103, 99133, 99134, 
23628, 23606, 99101, 99132, 23627
34521, 23576, 99041, 99051, 23586, 23577, 99042, 99052, 23587, 99103, 99133, 99134, 23628, 99106, 99136, 99137, 
23630, 23608, 99104, 99135, 23629
34522, 23577, 99042, 99052, 23587, 23578, 99043, 99053, 23588, 99106, 99136, 99137, 23630, 99109, 99139, 99140, 
23632, 23610, 99107, 99138, 23631
34523, 23578, 99043, 99053, 23588, 23579, 99044, 99054, 23589, 99109, 99139, 99140, 23632, 99112, 99142, 99143, 
23634, 23612, 99110, 99141, 23633
34524, 23579, 99044, 99054, 23589, 23580, 99045, 99055, 23590, 99112, 99142, 99143, 23634, 99115, 99145, 99146, 
23636, 23614, 99113, 99144, 23635
34525, 23580, 99045, 99055, 23590, 23581, 99046, 99056, 23591, 99115, 99145, 99146, 23636, 99118, 99148, 99149, 
23638, 23616, 99116, 99147, 23637
34526, 23581, 99046, 99056, 23591, 23582, 99047, 99057, 23592, 99118, 99148, 99149, 23638, 99121, 99151, 99152, 
23640, 23618, 99119, 99150, 23639
34527, 23582, 99047, 99057, 23592, 23583, 99048, 99058, 23593, 99121, 99151, 99152, 23640, 99124, 99154, 99155, 
23642, 23620, 99122, 99153, 23641
34528, 23583, 99048, 99058, 23593, 23584, 99049, 99059, 23594, 99124, 99154, 99155, 23642, 99127, 99157, 99158, 
23644, 23622, 99125, 99156, 23643
34529, 23584, 99049, 99059, 23594, 23585, 99050, 99060, 23595, 99127, 99157, 99158, 23644, 99130, 99160, 99161, 
23646, 23624, 99128, 99159, 23645
34530, 23585, 99050, 99060, 23595, 2227, 27847, 27848, 2228, 99130, 99160, 99161, 23646, 27854, 27855, 27856, 
2231, 23626, 99131, 99162, 23647
34531, 2308, 27825, 27826, 2309, 23586, 99051, 99061, 23596, 27832, 27835, 27834, 2312, 99134, 99164, 99165, 
23649, 23627, 99132, 99163, 23648
34532, 23586, 99051, 99061, 23596, 23587, 99052, 99062, 23597, 99134, 99164, 99165, 23649, 99137, 99167, 99168, 
23651, 23629, 99135, 99166, 23650
34533, 23587, 99052, 99062, 23597, 23588, 99053, 99063, 23598, 99137, 99167, 99168, 23651, 99140, 99170, 99171, 
23653, 23631, 99138, 99169, 23652
34534, 23588, 99053, 99063, 23598, 23589, 99054, 99064, 23599, 99140, 99170, 99171, 23653, 99143, 99173, 99174, 
23655, 23633, 99141, 99172, 23654
34535, 23589, 99054, 99064, 23599, 23590, 99055, 99065, 23600, 99143, 99173, 99174, 23655, 99146, 99176, 99177, 
23657, 23635, 99144, 99175, 23656
34536, 23590, 99055, 99065, 23600, 23591, 99056, 99066, 23601, 99146, 99176, 99177, 23657, 99149, 99179, 99180, 
23659, 23637, 99147, 99178, 23658
34537, 23591, 99056, 99066, 23601, 23592, 99057, 99067, 23602, 99149, 99179, 99180, 23659, 99152, 99182, 99183, 
23661, 23639, 99150, 99181, 23660
34538, 23592, 99057, 99067, 23602, 23593, 99058, 99068, 23603, 99152, 99182, 99183, 23661, 99155, 99185, 99186, 
23663, 23641, 99153, 99184, 23662
34539, 23593, 99058, 99068, 23603, 23594, 99059, 99069, 23604, 99155, 99185, 99186, 23663, 99158, 99188, 99189, 
23665, 23643, 99156, 99187, 23664
34540, 23594, 99059, 99069, 23604, 23595, 99060, 99070, 23605, 99158, 99188, 99189, 23665, 99161, 99191, 99192, 
23667, 23645, 99159, 99190, 23666
34541, 23595, 99060, 99070, 23605, 2228, 27848, 27849, 2229, 99161, 99191, 99192, 23667, 27856, 27857, 27858, 
2232, 23647, 99162, 99193, 23668
34542, 2309, 27826, 2848, 58, 23596, 99061, 27942, 2368, 27834, 27836, 2850, 2313, 99165, 99194, 27962, 
23669, 23648, 99163, 27963, 2379
34543, 23596, 99061, 27942, 2368, 23597, 99062, 27943, 2367, 99165, 99194, 27962, 23669, 99168, 99195, 27964, 
23670, 23650, 99166, 27965, 2378
34544, 23597, 99062, 27943, 2367, 23598, 99063, 27944, 2366, 99168, 99195, 27964, 23670, 99171, 99196, 27966, 
23671, 23652, 99169, 27967, 2377
34545, 23598, 99063, 27944, 2366, 23599, 99064, 27945, 2365, 99171, 99196, 27966, 23671, 99174, 99197, 27968, 
23672, 23654, 99172, 27969, 2376
34546, 23599, 99064, 27945, 2365, 23600, 99065, 27946, 2364, 99174, 99197, 27968, 23672, 99177, 99198, 27970, 
23673, 23656, 99175, 27971, 2375
34547, 23600, 99065, 27946, 2364, 23601, 99066, 27947, 2363, 99177, 99198, 27970, 23673, 99180, 99199, 27972, 
23674, 23658, 99178, 27973, 2374
34548, 23601, 99066, 27947, 2363, 23602, 99067, 27948, 2362, 99180, 99199, 27972, 23674, 99183, 99200, 27974, 
23675, 23660, 99181, 27975, 2373
34549, 23602, 99067, 27948, 2362, 23603, 99068, 27949, 2361, 99183, 99200, 27974, 23675, 99186, 99201, 27976, 
23676, 23662, 99184, 27977, 2372
34550, 23603, 99068, 27949, 2361, 23604, 99069, 27950, 2360, 99186, 99201, 27976, 23676, 99189, 99202, 27978, 
23677, 23664, 99187, 27979, 2371
34551, 23604, 99069, 27950, 2360, 23605, 99070, 27951, 2359, 99189, 99202, 27978, 23677, 99192, 99203, 27980, 
23678, 23666, 99190, 27981, 2370
34552, 23605, 99070, 27951, 2359, 2229, 27849, 2865, 56, 99192, 99203, 27980, 23678, 27858, 27859, 2867, 
2233, 23668, 99193, 27982, 2369
34553, 2843, 2844, 27827, 27824, 27870, 27880, 99071, 99041, 2846, 27838, 27837, 27831, 27912, 99205, 99206, 
99102, 27890, 27911, 99204, 99101
34554, 27870, 27880, 99071, 99041, 27871, 27881, 99072, 99042, 27912, 99205, 99206, 99102, 27914, 99208, 99209, 
99105, 27892, 27913, 99207, 99104
34555, 27871, 27881, 99072, 99042, 27872, 27882, 99073, 99043, 27914, 99208, 99209, 99105, 27916, 99211, 99212, 
99108, 27894, 27915, 99210, 99107
34556, 27872, 27882, 99073, 99043, 27873, 27883, 99074, 99044, 27916, 99211, 99212, 99108, 27918, 99214, 99215, 
99111, 27896, 27917, 99213, 99110
34557, 27873, 27883, 99074, 99044, 27874, 27884, 99075, 99045, 27918, 99214, 99215, 99111, 27920, 99217, 99218, 
99114, 27898, 27919, 99216, 99113
34558, 27874, 27884, 99075, 99045, 27875, 27885, 99076, 99046, 27920, 99217, 99218, 99114, 27922, 99220, 99221, 
99117, 27900, 27921, 99219, 99116
34559, 27875, 27885, 99076, 99046, 27876, 27886, 99077, 99047, 27922, 99220, 99221, 99117, 27924, 99223, 99224, 
99120, 27902, 27923, 99222, 99119
34560, 27876, 27886, 99077, 99047, 27877, 27887, 99078, 99048, 27924, 99223, 99224, 99120, 27926, 99226, 99227, 
99123, 27904, 27925, 99225, 99122
34561, 27877, 27887, 99078, 99048, 27878, 27888, 99079, 99049, 27926, 99226, 99227, 99123, 27928, 99229, 99230, 
99126, 27906, 27927, 99228, 99125
34562, 27878, 27888, 99079, 99049, 27879, 27889, 99080, 99050, 27928, 99229, 99230, 99126, 27930, 99232, 99233, 
99129, 27908, 27929, 99231, 99128
34563, 27879, 27889, 99080, 99050, 2860, 2861, 27850, 27847, 27930, 99232, 99233, 99129, 2863, 27860, 27861, 
27853, 27910, 27931, 99234, 99131
34564, 27824, 27827, 27828, 27825, 99041, 99071, 99081, 99051, 27837, 27840, 27839, 27833, 99206, 99236, 99237, 
99133, 99101, 99204, 99235, 99132
34565, 99041, 99071, 99081, 99051, 99042, 99072, 99082, 99052, 99206, 99236, 99237, 99133, 99209, 99239, 99240, 
99136, 99104, 99207, 99238, 99135
34566, 99042, 99072, 99082, 99052, 99043, 99073, 99083, 99053, 99209, 99239, 99240, 99136, 99212, 99242, 99243, 
99139, 99107, 99210, 99241, 99138
34567, 99043, 99073, 99083, 99053, 99044, 99074, 99084, 99054, 99212, 99242, 99243, 99139, 99215, 99245, 99246, 
99142, 99110, 99213, 99244, 99141
34568, 99044, 99074, 99084, 99054, 99045, 99075, 99085, 99055, 99215, 99245, 99246, 99142, 99218, 99248, 99249, 
99145, 99113, 99216, 99247, 99144
34569, 99045, 99075, 99085, 99055, 99046, 99076, 99086, 99056, 99218, 99248, 99249, 99145, 99221, 99251, 99252, 
99148, 99116, 99219, 99250, 99147
34570, 99046, 99076, 99086, 99056, 99047, 99077, 99087, 99057, 99221, 99251, 99252, 99148, 99224, 99254, 99255, 
99151, 99119, 99222, 99253, 99150
34571, 99047, 99077, 99087, 99057, 99048, 99078, 99088, 99058, 99224, 99254, 99255, 99151, 99227, 99257, 99258, 
99154, 99122, 99225, 99256, 99153
34572, 99048, 99078, 99088, 99058, 99049, 99079, 99089, 99059, 99227, 99257, 99258, 99154, 99230, 99260, 99261, 
99157, 99125, 99228, 99259, 99156
34573, 99049, 99079, 99089, 99059, 99050, 99080, 99090, 99060, 99230, 99260, 99261, 99157, 99233, 99263, 99264, 
99160, 99128, 99231, 99262, 99159
34574, 99050, 99080, 99090, 99060, 27847, 27850, 27851, 27848, 99233, 99263, 99264, 99160, 27861, 27862, 27863, 
27855, 99131, 99234, 99265, 99162
34575, 27825, 27828, 27829, 27826, 99051, 99081, 99091, 99061, 27839, 27842, 27841, 27835, 99237, 99267, 99268, 
99164, 99132, 99235, 99266, 99163
34576, 99051, 99081, 99091, 99061, 99052, 99082, 99092, 99062, 99237, 99267, 99268, 99164, 99240, 99270, 99271, 
99167, 99135, 99238, 99269, 99166
34577, 99052, 99082, 99092, 99062, 99053, 99083, 99093, 99063, 99240, 99270, 99271, 99167, 99243, 99273, 99274, 
99170, 99138, 99241, 99272, 99169
34578, 99053, 99083, 99093, 99063, 99054, 99084, 99094, 99064, 99243, 99273, 99274, 99170, 99246, 99276, 99277, 
99173, 99141, 99244, 99275, 99172
34579, 99054, 99084, 99094, 99064, 99055, 99085, 99095, 99065, 99246, 99276, 99277, 99173, 99249, 99279, 99280, 
99176, 99144, 99247, 99278, 99175
34580, 99055, 99085, 99095, 99065, 99056, 99086, 99096, 99066, 99249, 99279, 99280, 99176, 99252, 99282, 99283, 
99179, 99147, 99250, 99281, 99178
34581, 99056, 99086, 99096, 99066, 99057, 99087, 99097, 99067, 99252, 99282, 99283, 99179, 99255, 99285, 99286, 
99182, 99150, 99253, 99284, 99181
34582, 99057, 99087, 99097, 99067, 99058, 99088, 99098, 99068, 99255, 99285, 99286, 99182, 99258, 99288, 99289, 
99185, 99153, 99256, 99287, 99184
34583, 99058, 99088, 99098, 99068, 99059, 99089, 99099, 99069, 99258, 99288, 99289, 99185, 99261, 99291, 99292, 
99188, 99156, 99259, 99290, 99187
34584, 99059, 99089, 99099, 99069, 99060, 99090, 99100, 99070, 99261, 99291, 99292, 99188, 99264, 99294, 99295, 
99191, 99159, 99262, 99293, 99190
34585, 99060, 99090, 99100, 99070, 27848, 27851, 27852, 27849, 99264, 99294, 99295, 99191, 27863, 27864, 27865, 
27857, 99162, 99265, 99296, 99193
34586, 27826, 27829, 2849, 2848, 99061, 99091, 27952, 27942, 27841, 27843, 2851, 27836, 99268, 99297, 27983, 
99194, 99163, 99266, 27984, 27963
34587, 99061, 99091, 27952, 27942, 99062, 99092, 27953, 27943, 99268, 99297, 27983, 99194, 99271, 99298, 27985, 
99195, 99166, 99269, 27986, 27965
34588, 99062, 99092, 27953, 27943, 99063, 99093, 27954, 27944, 99271, 99298, 27985, 99195, 99274, 99299, 27987, 
99196, 99169, 99272, 27988, 27967
34589, 99063, 99093, 27954, 27944, 99064, 99094, 27955, 27945, 99274, 99299, 27987, 99196, 99277, 99300, 27989, 
99197, 99172, 99275, 27990, 27969
34590, 99064, 99094, 27955, 27945, 99065, 99095, 27956, 27946, 99277, 99300, 27989, 99197, 99280, 99301, 27991, 
99198, 99175, 99278, 27992, 27971
34591, 99065, 99095, 27956, 27946, 99066, 99096, 27957, 27947, 99280, 99301, 27991, 99198, 99283, 99302, 27993, 
99199, 99178, 99281, 27994, 27973
34592, 99066, 99096, 27957, 27947, 99067, 99097, 27958, 27948, 99283, 99302, 27993, 99199, 99286, 99303, 27995, 
99200, 99181, 99284, 27996, 27975
34593, 99067, 99097, 27958, 27948, 99068, 99098, 27959, 27949, 99286, 99303, 27995, 99200, 99289, 99304, 27997, 
99201, 99184, 99287, 27998, 27977
34594, 99068, 99098, 27959, 27949, 99069, 99099, 27960, 27950, 99289, 99304, 27997, 99201, 99292, 99305, 27999, 
99202, 99187, 99290, 28000, 27979
34595, 99069, 99099, 27960, 27950, 99070, 99100, 27961, 27951, 99292, 99305, 27999, 99202, 99295, 99306, 28001, 
99203, 99190, 99293, 28002, 27981
34596, 99070, 99100, 27961, 27951, 27849, 27852, 2866, 2865, 99295, 99306, 28001, 99203, 27865, 27866, 2868, 
27859, 99193, 99296, 28003, 27982
34597, 2844, 73, 2853, 27827, 27880, 2886, 28014, 99071, 2847, 2856, 27844, 27838, 27932, 28045, 99307, 
99205, 27911, 2897, 28044, 99204
34598, 27880, 2886, 28014, 99071, 27881, 2885, 28015, 99072, 27932, 28045, 99307, 99205, 27933, 28047, 99308, 
99208, 27913, 2896, 28046, 99207
34599, 27881, 2885, 28015, 99072, 27882, 2884, 28016, 99073, 27933, 28047, 99308, 99208, 27934, 28049, 99309, 
99211, 27915, 2895, 28048, 99210
34600, 27882, 2884, 28016, 99073, 27883, 2883, 28017, 99074, 27934, 28049, 99309, 99211, 27935, 28051, 99310, 
99214, 27917, 2894, 28050, 99213
34601, 27883, 2883, 28017, 99074, 27884, 2882, 28018, 99075, 27935, 28051, 99310, 99214, 27936, 28053, 99311, 
99217, 27919, 2893, 28052, 99216
34602, 27884, 2882, 28018, 99075, 27885, 2881, 28019, 99076, 27936, 28053, 99311, 99217, 27937, 28055, 99312, 
99220, 27921, 2892, 28054, 99219
34603, 27885, 2881, 28019, 99076, 27886, 2880, 28020, 99077, 27937, 28055, 99312, 99220, 27938, 28057, 99313, 
99223, 27923, 2891, 28056, 99222
34604, 27886, 2880, 28020, 99077, 27887, 2879, 28021, 99078, 27938, 28057, 99313, 99223, 27939, 28059, 99314, 
99226, 27925, 2890, 28058, 99225
34605, 27887, 2879, 28021, 99078, 27888, 2878, 28022, 99079, 27939, 28059, 99314, 99226, 27940, 28061, 99315, 
99229, 27927, 2889, 28060, 99228
34606, 27888, 2878, 28022, 99079, 27889, 2877, 28023, 99080, 27940, 28061, 99315, 99229, 27941, 28063, 99316, 
99232, 27929, 2888, 28062, 99231
34607, 27889, 2877, 28023, 99080, 2861, 75, 2870, 27850, 27941, 28063, 99316, 99232, 2864, 2873, 27867, 
27860, 27931, 2887, 28064, 99234
34608, 27827, 2853, 2854, 27828, 99071, 28014, 28024, 99081, 27844, 2857, 27845, 27840, 99307, 28066, 99317, 
99236, 99204, 28044, 28065, 99235
34609, 99071, 28014, 28024, 99081, 99072, 28015, 28025, 99082, 99307, 28066, 99317, 99236, 99308, 28068, 99318, 
99239, 99207, 28046, 28067, 99238
34610, 99072, 28015, 28025, 99082, 99073, 28016, 28026, 99083, 99308, 28068, 99318, 99239, 99309, 28070, 99319, 
99242, 99210, 28048, 28069, 99241
34611, 99073, 28016, 28026, 99083, 99074, 28017, 28027, 99084, 99309, 28070, 99319, 99242, 99310, 28072, 99320, 
99245, 99213, 28050, 28071, 99244
34612, 99074, 28017, 28027, 99084, 99075, 28018, 28028, 99085, 99310, 28072, 99320, 99245, 99311, 28074, 99321, 
99248, 99216, 28052, 28073, 99247
34613, 99075, 28018, 28028, 99085, 99076, 28019, 28029, 99086, 99311, 28074, 99321, 99248, 99312, 28076, 99322, 
99251, 99219, 28054, 28075, 99250
34614, 99076, 28019, 28029, 99086, 99077, 28020, 28030, 99087, 99312, 28076, 99322, 99251, 99313, 28078, 99323, 
99254, 99222, 28056, 28077, 99253
34615, 99077, 28020, 28030, 99087, 99078, 28021, 28031, 99088, 99313, 28078, 99323, 99254, 99314, 28080, 99324, 
99257, 99225, 28058, 28079, 99256
34616, 99078, 28021, 28031, 99088, 99079, 28022, 28032, 99089, 99314, 28080, 99324, 99257, 99315, 28082, 99325, 
99260, 99228, 28060, 28081, 99259
34617, 99079, 28022, 28032, 99089, 99080, 28023, 28033, 99090, 99315, 28082, 99325, 99260, 99316, 28084, 99326, 
99263, 99231, 28062, 28083, 99262
34618, 99080, 28023, 28033, 99090, 27850, 2870, 2871, 27851, 99316, 28084, 99326, 99263, 27867, 2874, 27868, 
27862, 99234, 28064, 28085, 99265
34619, 27828, 2854, 2855, 27829, 99081, 28024, 28034, 99091, 27845, 2858, 27846, 27842, 99317, 28087, 99327, 
99267, 99235, 28065, 28086, 99266
34620, 99081, 28024, 28034, 99091, 99082, 28025, 28035, 99092, 99317, 28087, 99327, 99267, 99318, 28089, 99328, 
99270, 99238, 28067, 28088, 99269
34621, 99082, 28025, 28035, 99092, 99083, 28026, 28036, 99093, 99318, 28089, 99328, 99270, 99319, 28091, 99329, 
99273, 99241, 28069, 28090, 99272
34622, 99083, 28026, 28036, 99093, 99084, 28027, 28037, 99094, 99319, 28091, 99329, 99273, 99320, 28093, 99330, 
99276, 99244, 28071, 28092, 99275
34623, 99084, 28027, 28037, 99094, 99085, 28028, 28038, 99095, 99320, 28093, 99330, 99276, 99321, 28095, 99331, 
99279, 99247, 28073, 28094, 99278
34624, 99085, 28028, 28038, 99095, 99086, 28029, 28039, 99096, 99321, 28095, 99331, 99279, 99322, 28097, 99332, 
99282, 99250, 28075, 28096, 99281
34625, 99086, 28029, 28039, 99096, 99087, 28030, 28040, 99097, 99322, 28097, 99332, 99282, 99323, 28099, 99333, 
99285, 99253, 28077, 28098, 99284
34626, 99087, 28030, 28040, 99097, 99088, 28031, 28041, 99098, 99323, 28099, 99333, 99285, 99324, 28101, 99334, 
99288, 99256, 28079, 28100, 99287
34627, 99088, 28031, 28041, 99098, 99089, 28032, 28042, 99099, 99324, 28101, 99334, 99288, 99325, 28103, 99335, 
99291, 99259, 28081, 28102, 99290
34628, 99089, 28032, 28042, 99099, 99090, 28033, 28043, 99100, 99325, 28103, 99335, 99291, 99326, 28105, 99336, 
99294, 99262, 28083, 28104, 99293
34629, 99090, 28033, 28043, 99100, 27851, 2871, 2872, 27852, 99326, 28105, 99336, 99294, 27868, 2875, 27869, 
27864, 99265, 28085, 28106, 99296
34630, 27829, 2855, 74, 2849, 99091, 28034, 2907, 27952, 27846, 2859, 2852, 27843, 99327, 28107, 28004, 
99297, 99266, 28086, 2918, 27984
34631, 99091, 28034, 2907, 27952, 99092, 28035, 2906, 27953, 99327, 28107, 28004, 99297, 99328, 28108, 28005, 
99298, 99269, 28088, 2917, 27986
34632, 99092, 28035, 2906, 27953, 99093, 28036, 2905, 27954, 99328, 28108, 28005, 99298, 99329, 28109, 28006, 
99299, 99272, 28090, 2916, 27988
34633, 99093, 28036, 2905, 27954, 99094, 28037, 2904, 27955, 99329, 28109, 28006, 99299, 99330, 28110, 28007, 
99300, 99275, 28092, 2915, 27990
34634, 99094, 28037, 2904, 27955, 99095, 28038, 2903, 27956, 99330, 28110, 28007, 99300, 99331, 28111, 28008, 
99301, 99278, 28094, 2914, 27992
34635, 99095, 28038, 2903, 27956, 99096, 28039, 2902, 27957, 99331, 28111, 28008, 99301, 99332, 28112, 28009, 
99302, 99281, 28096, 2913, 27994
34636, 99096, 28039, 2902, 27957, 99097, 28040, 2901, 27958, 99332, 28112, 28009, 99302, 99333, 28113, 28010, 
99303, 99284, 28098, 2912, 27996
34637, 99097, 28040, 2901, 27958, 99098, 28041, 2900, 27959, 99333, 28113, 28010, 99303, 99334, 28114, 28011, 
99304, 99287, 28100, 2911, 27998
34638, 99098, 28041, 2900, 27959, 99099, 28042, 2899, 27960, 99334, 28114, 28011, 99304, 99335, 28115, 28012, 
99305, 99290, 28102, 2910, 28000
34639, 99099, 28042, 2899, 27960, 99100, 28043, 2898, 27961, 99335, 28115, 28012, 99305, 99336, 28116, 28013, 
99306, 99293, 28104, 2909, 28002
34640, 99100, 28043, 2898, 27961, 27852, 2872, 76, 2866, 99336, 28116, 28013, 99306, 27869, 2876, 2869, 
27866, 99296, 28106, 2908, 28003
*ELEMENT, type=C3D20, ELSET=Volume29
34641, 20, 2919, 28117, 1054, 961, 28149, 99337, 12555, 2921, 28122, 28121, 1056, 28170, 99378, 99379, 
12576, 972, 28169, 99377, 12575
34642, 961, 28149, 99337, 12555, 960, 28150, 99338, 12556, 28170, 99378, 99379, 12576, 28172, 99381, 99382, 
12578, 971, 28171, 99380, 12577
34643, 960, 28150, 99338, 12556, 959, 28151, 99339, 12557, 28172, 99381, 99382, 12578, 28174, 99384, 99385, 
12580, 970, 28173, 99383, 12579
34644, 959, 28151, 99339, 12557, 958, 28152, 99340, 12558, 28174, 99384, 99385, 12580, 28176, 99387, 99388, 
12582, 969, 28175, 99386, 12581
34645, 958, 28152, 99340, 12558, 957, 28153, 99341, 12559, 28176, 99387, 99388, 12582, 28178, 99390, 99391, 
12584, 968, 28177, 99389, 12583
34646, 957, 28153, 99341, 12559, 956, 28154, 99342, 12560, 28178, 99390, 99391, 12584, 28180, 99393, 99394, 
12586, 967, 28179, 99392, 12585
34647, 956, 28154, 99342, 12560, 955, 28155, 99343, 12561, 28180, 99393, 99394, 12586, 28182, 99396, 99397, 
12588, 966, 28181, 99395, 12587
34648, 955, 28155, 99343, 12561, 954, 28156, 99344, 12562, 28182, 99396, 99397, 12588, 28184, 99399, 99400, 
12590, 965, 28183, 99398, 12589
34649, 954, 28156, 99344, 12562, 953, 28157, 99345, 12563, 28184, 99399, 99400, 12590, 28186, 99402, 99403, 
12592, 964, 28185, 99401, 12591
34650, 953, 28157, 99345, 12563, 952, 28158, 99346, 12564, 28186, 99402, 99403, 12592, 28188, 99405, 99406, 
12594, 963, 28187, 99404, 12593
34651, 952, 28158, 99346, 12564, 18, 2929, 28133, 978, 28188, 99405, 99406, 12594, 2931, 28137, 28138, 
980, 962, 28189, 99407, 12595
34652, 1054, 28117, 28118, 1055, 12555, 99337, 99347, 12565, 28121, 28124, 28123, 1057, 99379, 99409, 99410, 
12597, 12575, 99377, 99408, 12596
34653, 12555, 99337, 99347, 12565, 12556, 99338, 99348, 12566, 99379, 99409, 99410, 12597, 99382, 99412, 99413, 
12599, 12577, 99380, 99411, 12598
34654, 12556, 99338, 99348, 12566, 12557, 99339, 99349, 12567, 99382, 99412, 99413, 12599, 99385, 99415, 99416, 
12601, 12579, 99383, 99414, 12600
34655, 12557, 99339, 99349, 12567, 12558, 99340, 99350, 12568, 99385, 99415, 99416, 12601, 99388, 99418, 99419, 
12603, 12581, 99386, 99417, 12602
34656, 12558, 99340, 99350, 12568, 12559, 99341, 99351, 12569, 99388, 99418, 99419, 12603, 99391, 99421, 99422, 
12605, 12583, 99389, 99420, 12604
34657, 12559, 99341, 99351, 12569, 12560, 99342, 99352, 12570, 99391, 99421, 99422, 12605, 99394, 99424, 99425, 
12607, 12585, 99392, 99423, 12606
34658, 12560, 99342, 99352, 12570, 12561, 99343, 99353, 12571, 99394, 99424, 99425, 12607, 99397, 99427, 99428, 
12609, 12587, 99395, 99426, 12608
34659, 12561, 99343, 99353, 12571, 12562, 99344, 99354, 12572, 99397, 99427, 99428, 12609, 99400, 99430, 99431, 
12611, 12589, 99398, 99429, 12610
34660, 12562, 99344, 99354, 12572, 12563, 99345, 99355, 12573, 99400, 99430, 99431, 12611, 99403, 99433, 99434, 
12613, 12591, 99401, 99432, 12612
34661, 12563, 99345, 99355, 12573, 12564, 99346, 99356, 12574, 99403, 99433, 99434, 12613, 99406, 99436, 99437, 
12615, 12593, 99404, 99435, 12614
34662, 12564, 99346, 99356, 12574, 978, 28133, 28134, 979, 99406, 99436, 99437, 12615, 28138, 28139, 28140, 
981, 12595, 99407, 99438, 12616
34663, 1055, 28118, 2843, 24, 12565, 99347, 27870, 1113, 28123, 28125, 2845, 1058, 99410, 99439, 27891, 
12617, 12596, 99408, 27890, 1124
34664, 12565, 99347, 27870, 1113, 12566, 99348, 27871, 1112, 99410, 99439, 27891, 12617, 99413, 99440, 27893, 
12618, 12598, 99411, 27892, 1123
34665, 12566, 99348, 27871, 1112, 12567, 99349, 27872, 1111, 99413, 99440, 27893, 12618, 99416, 99441, 27895, 
12619, 12600, 99414, 27894, 1122
34666, 12567, 99349, 27872, 1111, 12568, 99350, 27873, 1110, 99416, 99441, 27895, 12619, 99419, 99442, 27897, 
12620, 12602, 99417, 27896, 1121
34667, 12568, 99350, 27873, 1110, 12569, 99351, 27874, 1109, 99419, 99442, 27897, 12620, 99422, 99443, 27899, 
12621, 12604, 99420, 27898, 1120
34668, 12569, 99351, 27874, 1109, 12570, 99352, 27875, 1108, 99422, 99443, 27899, 12621, 99425, 99444, 27901, 
12622, 12606, 99423, 27900, 1119
34669, 12570, 99352, 27875, 1108, 12571, 99353, 27876, 1107, 99425, 99444, 27901, 12622, 99428, 99445, 27903, 
12623, 12608, 99426, 27902, 1118
34670, 12571, 99353, 27876, 1107, 12572, 99354, 27877, 1106, 99428, 99445, 27903, 12623, 99431, 99446, 27905, 
12624, 12610, 99429, 27904, 1117
34671, 12572, 99354, 27877, 1106, 12573, 99355, 27878, 1105, 99431, 99446, 27905, 12624, 99434, 99447, 27907, 
12625, 12612, 99432, 27906, 1116
34672, 12573, 99355, 27878, 1105, 12574, 99356, 27879, 1104, 99434, 99447, 27907, 12625, 99437, 99448, 27909, 
12626, 12614, 99435, 27908, 1115
34673, 12574, 99356, 27879, 1104, 979, 28134, 2860, 22, 99437, 99448, 27909, 12626, 28140, 28141, 2862, 
982, 12616, 99438, 27910, 1114
34674, 2919, 2920, 28119, 28117, 28149, 28159, 99357, 99337, 2922, 28127, 28126, 28122, 28191, 99450, 99451, 
99378, 28169, 28190, 99449, 99377
34675, 28149, 28159, 99357, 99337, 28150, 28160, 99358, 99338, 28191, 99450, 99451, 99378, 28193, 99453, 99454, 
99381, 28171, 28192, 99452, 99380
34676, 28150, 28160, 99358, 99338, 28151, 28161, 99359, 99339, 28193, 99453, 99454, 99381, 28195, 99456, 99457, 
99384, 28173, 28194, 99455, 99383
34677, 28151, 28161, 99359, 99339, 28152, 28162, 99360, 99340, 28195, 99456, 99457, 99384, 28197, 99459, 99460, 
99387, 28175, 28196, 99458, 99386
34678, 28152, 28162, 99360, 99340, 28153, 28163, 99361, 99341, 28197, 99459, 99460, 99387, 28199, 99462, 99463, 
99390, 28177, 28198, 99461, 99389
34679, 28153, 28163, 99361, 99341, 28154, 28164, 99362, 99342, 28199, 99462, 99463, 99390, 28201, 99465, 99466, 
99393, 28179, 28200, 99464, 99392
34680, 28154, 28164, 99362, 99342, 28155, 28165, 99363, 99343, 28201, 99465, 99466, 99393, 28203, 99468, 99469, 
99396, 28181, 28202, 99467, 99395
34681, 28155, 28165, 99363, 99343, 28156, 28166, 99364, 99344, 28203, 99468, 99469, 99396, 28205, 99471, 99472, 
99399, 28183, 28204, 99470, 99398
34682, 28156, 28166, 99364, 99344, 28157, 28167, 99365, 99345, 28205, 99471, 99472, 99399, 28207, 99474, 99475, 
99402, 28185, 28206, 99473, 99401
34683, 28157, 28167, 99365, 99345, 28158, 28168, 99366, 99346, 28207, 99474, 99475, 99402, 28209, 99477, 99478, 
99405, 28187, 28208, 99476, 99404
34684, 28158, 28168, 99366, 99346, 2929, 2930, 28135, 28133, 28209, 99477, 99478, 99405, 2932, 28142, 28143, 
28137, 28189, 28210, 99479, 99407
34685, 28117, 28119, 28120, 28118, 99337, 99357, 99367, 99347, 28126, 28129, 28128, 28124, 99451, 99481, 99482, 
99409, 99377, 99449, 99480, 99408
34686, 99337, 99357, 99367, 99347, 99338, 99358, 99368, 99348, 99451, 99481, 99482, 99409, 99454, 99484, 99485, 
99412, 99380, 99452, 99483, 99411
34687, 99338, 99358, 99368, 99348, 99339, 99359, 99369, 99349, 99454, 99484, 99485, 99412, 99457, 99487, 99488, 
99415, 99383, 99455, 99486, 99414
34688, 99339, 99359, 99369, 99349, 99340, 99360, 99370, 99350, 99457, 99487, 99488, 99415, 99460, 99490, 99491, 
99418, 99386, 99458, 99489, 99417
34689, 99340, 99360, 99370, 99350, 99341, 99361, 99371, 99351, 99460, 99490, 99491, 99418, 99463, 99493, 99494, 
99421, 99389, 99461, 99492, 99420
34690, 99341, 99361, 99371, 99351, 99342, 99362, 99372, 99352, 99463, 99493, 99494, 99421, 99466, 99496, 99497, 
99424, 99392, 99464, 99495, 99423
34691, 99342, 99362, 99372, 99352, 99343, 99363, 99373, 99353, 99466, 99496, 99497, 99424, 99469, 99499, 99500, 
99427, 99395, 99467, 99498, 99426
34692, 99343, 99363, 99373, 99353, 99344, 99364, 99374, 99354, 99469, 99499, 99500, 99427, 99472, 99502, 99503, 
99430, 99398, 99470, 99501, 99429
34693, 99344, 99364, 99374, 99354, 99345, 99365, 99375, 99355, 99472, 99502, 99503, 99430, 99475, 99505, 99506, 
99433, 99401, 99473, 99504, 99432
34694, 99345, 99365, 99375, 99355, 99346, 99366, 99376, 99356, 99475, 99505, 99506, 99433, 99478, 99508, 99509, 
99436, 99404, 99476, 99507, 99435
34695, 99346, 99366, 99376, 99356, 28133, 28135, 28136, 28134, 99478, 99508, 99509, 99436, 28143, 28144, 28145, 
28139, 99407, 99479, 99510, 99438
34696, 28118, 28120, 2844, 2843, 99347, 99367, 27880, 27870, 28128, 28130, 2846, 28125, 99482, 99511, 27912, 
99439, 99408, 99480, 27911, 27890
34697, 99347, 99367, 27880, 27870, 99348, 99368, 27881, 27871, 99482, 99511, 27912, 99439, 99485, 99512, 27914, 
99440, 99411, 99483, 27913, 27892
34698, 99348, 99368, 27881, 27871, 99349, 99369, 27882, 27872, 99485, 99512, 27914, 99440, 99488, 99513, 27916, 
99441, 99414, 99486, 27915, 27894
34699, 99349, 99369, 27882, 27872, 99350, 99370, 27883, 27873, 99488, 99513, 27916, 99441, 99491, 99514, 27918, 
99442, 99417, 99489, 27917, 27896
34700, 99350, 99370, 27883, 27873, 99351, 99371, 27884, 27874, 99491, 99514, 27918, 99442, 99494, 99515, 27920, 
99443, 99420, 99492, 27919, 27898
34701, 99351, 99371, 27884, 27874, 99352, 99372, 27885, 27875, 99494, 99515, 27920, 99443, 99497, 99516, 27922, 
99444, 99423, 99495, 27921, 27900
34702, 99352, 99372, 27885, 27875, 99353, 99373, 27886, 27876, 99497, 99516, 27922, 99444, 99500, 99517, 27924, 
99445, 99426, 99498, 27923, 27902
34703, 99353, 99373, 27886, 27876, 99354, 99374, 27887, 27877, 99500, 99517, 27924, 99445, 99503, 99518, 27926, 
99446, 99429, 99501, 27925, 27904
34704, 99354, 99374, 27887, 27877, 99355, 99375, 27888, 27878, 99503, 99518, 27926, 99446, 99506, 99519, 27928, 
99447, 99432, 99504, 27927, 27906
34705, 99355, 99375, 27888, 27878, 99356, 99376, 27889, 27879, 99506, 99519, 27928, 99447, 99509, 99520, 27930, 
99448, 99435, 99507, 27929, 27908
34706, 99356, 99376, 27889, 27879, 28134, 28136, 2861, 2860, 99509, 99520, 27930, 99448, 28145, 28146, 2863, 
28141, 99438, 99510, 27931, 27910
34707, 2920, 77, 2924, 28119, 28159, 2948, 28221, 99357, 2923, 2926, 28131, 28127, 28211, 28242, 99521, 
99450, 28190, 2959, 28241, 99449
34708, 28159, 2948, 28221, 99357, 28160, 2947, 28222, 99358, 28211, 28242, 99521, 99450, 28212, 28244, 99522, 
99453, 28192, 2958, 28243, 99452
34709, 28160, 2947, 28222, 99358, 28161, 2946, 28223, 99359, 28212, 28244, 99522, 99453, 28213, 28246, 99523, 
