51605, 0.43478260869565, 1.0630434782609, 0.31818181818182
51606, 0.43478260869565, 1.0891304347826, 0.34090909090909
51607, 0.45652173913043, 1.0891304347826, 0.36363636363636
51608, 0.43478260869565, 1.0630434782609, 0.36363636363636
51609, 0.43478260869565, 1.0891304347826, 0.38636363636364
51610, 0.45652173913043, 1.0891304347826, 0.40909090909091
51611, 0.43478260869565, 1.0630434782609, 0.40909090909091
51612, 0.43478260869565, 1.0891304347826, 0.43181818181818
51613, 0.45652173913043, 1.0891304347826, 0.45454545454545
51614, 0.43478260869565, 1.0630434782609, 0.45454545454545
51615, 0.43478260869565, 1.0891304347826, 0.47727272727273
51616, 0.39130434782609, 1.0891304347826, 0.022727272727273
51617, 0.41304347826087, 1.0891304347826, 0.045454545454545
51618, 0.39130434782609, 1.0630434782609, 0.045454545454545
51619, 0.39130434782609, 1.0891304347826, 0.068181818181818
51620, 0.41304347826087, 1.0891304347826, 0.090909090909091
51621, 0.39130434782609, 1.0630434782609, 0.090909090909091
51622, 0.39130434782609, 1.0891304347826, 0.11363636363636
51623, 0.41304347826087, 1.0891304347826, 0.13636363636364
51624, 0.39130434782609, 1.0630434782609, 0.13636363636364
51625, 0.39130434782609, 1.0891304347826, 0.15909090909091
51626, 0.41304347826087, 1.0891304347826, 0.18181818181818
51627, 0.39130434782609, 1.0630434782609, 0.18181818181818
51628, 0.39130434782609, 1.0891304347826, 0.20454545454545
51629, 0.41304347826087, 1.0891304347826, 0.22727272727273
51630, 0.39130434782609, 1.0630434782609, 0.22727272727273
51631, 0.39130434782609, 1.0891304347826, 0.25
51632, 0.41304347826087, 1.0891304347826, 0.27272727272727
51633, 0.39130434782609, 1.0630434782609, 0.27272727272727
51634, 0.39130434782609, 1.0891304347826, 0.29545454545455
51635, 0.41304347826087, 1.0891304347826, 0.31818181818182
51636, 0.39130434782609, 1.0630434782609, 0.31818181818182
51637, 0.39130434782609, 1.0891304347826, 0.34090909090909
51638, 0.41304347826087, 1.0891304347826, 0.36363636363636
51639, 0.39130434782609, 1.0630434782609, 0.36363636363636
51640, 0.39130434782609, 1.0891304347826, 0.38636363636364
51641, 0.41304347826087, 1.0891304347826, 0.40909090909091
51642, 0.39130434782609, 1.0630434782609, 0.40909090909091
51643, 0.39130434782609, 1.0891304347826, 0.43181818181818
51644, 0.41304347826087, 1.0891304347826, 0.45454545454545
51645, 0.39130434782609, 1.0630434782609, 0.45454545454545
51646, 0.39130434782609, 1.0891304347826, 0.47727272727273
51647, 0.34782608695652, 1.0891304347826, 0.022727272727273
51648, 0.3695652173913, 1.0891304347826, 0.045454545454545
51649, 0.34782608695652, 1.0630434782609, 0.045454545454545
51650, 0.34782608695652, 1.0891304347826, 0.068181818181818
51651, 0.3695652173913, 1.0891304347826, 0.090909090909091
51652, 0.34782608695652, 1.0630434782609, 0.090909090909091
51653, 0.34782608695652, 1.0891304347826, 0.11363636363636
51654, 0.3695652173913, 1.0891304347826, 0.13636363636364
51655, 0.34782608695652, 1.0630434782609, 0.13636363636364
51656, 0.34782608695652, 1.0891304347826, 0.15909090909091
51657, 0.3695652173913, 1.0891304347826, 0.18181818181818
51658, 0.34782608695652, 1.0630434782609, 0.18181818181818
51659, 0.34782608695652, 1.0891304347826, 0.20454545454545
51660, 0.3695652173913, 1.0891304347826, 0.22727272727273
51661, 0.34782608695652, 1.0630434782609, 0.22727272727273
51662, 0.34782608695652, 1.0891304347826, 0.25
51663, 0.3695652173913, 1.0891304347826, 0.27272727272727
51664, 0.34782608695652, 1.0630434782609, 0.27272727272727
51665, 0.34782608695652, 1.0891304347826, 0.29545454545455
51666, 0.3695652173913, 1.0891304347826, 0.31818181818182
51667, 0.34782608695652, 1.0630434782609, 0.31818181818182
51668, 0.34782608695652, 1.0891304347826, 0.34090909090909
51669, 0.3695652173913, 1.0891304347826, 0.36363636363636
51670, 0.34782608695652, 1.0630434782609, 0.36363636363636
51671, 0.34782608695652, 1.0891304347826, 0.38636363636364
51672, 0.3695652173913, 1.0891304347826, 0.40909090909091
51673, 0.34782608695652, 1.0630434782609, 0.40909090909091
51674, 0.34782608695652, 1.0891304347826, 0.43181818181818
51675, 0.3695652173913, 1.0891304347826, 0.45454545454545
51676, 0.34782608695652, 1.0630434782609, 0.45454545454545
51677, 0.34782608695652, 1.0891304347826, 0.47727272727273
51678, 0.30434782608696, 1.0891304347826, 0.022727272727273
51679, 0.32608695652174, 1.0891304347826, 0.045454545454545
51680, 0.30434782608696, 1.0630434782609, 0.045454545454545
51681, 0.30434782608696, 1.0891304347826, 0.068181818181818
51682, 0.32608695652174, 1.0891304347826, 0.090909090909091
51683, 0.30434782608696, 1.0630434782609, 0.090909090909091
51684, 0.30434782608696, 1.0891304347826, 0.11363636363636
51685, 0.32608695652174, 1.0891304347826, 0.13636363636364
51686, 0.30434782608696, 1.0630434782609, 0.13636363636364
51687, 0.30434782608696, 1.0891304347826, 0.15909090909091
51688, 0.32608695652174, 1.0891304347826, 0.18181818181818
51689, 0.30434782608696, 1.0630434782609, 0.18181818181818
51690, 0.30434782608696, 1.0891304347826, 0.20454545454545
51691, 0.32608695652174, 1.0891304347826, 0.22727272727273
51692, 0.30434782608696, 1.0630434782609, 0.22727272727273
51693, 0.30434782608696, 1.0891304347826, 0.25
51694, 0.32608695652174, 1.0891304347826, 0.27272727272727
51695, 0.30434782608696, 1.0630434782609, 0.27272727272727
51696, 0.30434782608696, 1.0891304347826, 0.29545454545455
51697, 0.32608695652174, 1.0891304347826, 0.31818181818182
51698, 0.30434782608696, 1.0630434782609, 0.31818181818182
51699, 0.30434782608696, 1.0891304347826, 0.34090909090909
51700, 0.32608695652174, 1.0891304347826, 0.36363636363636
51701, 0.30434782608696, 1.0630434782609, 0.36363636363636
51702, 0.30434782608696, 1.0891304347826, 0.38636363636364
51703, 0.32608695652174, 1.0891304347826, 0.40909090909091
51704, 0.30434782608696, 1.0630434782609, 0.40909090909091
51705, 0.30434782608696, 1.0891304347826, 0.43181818181818
51706, 0.32608695652174, 1.0891304347826, 0.45454545454545
51707, 0.30434782608696, 1.0630434782609, 0.45454545454545
51708, 0.30434782608696, 1.0891304347826, 0.47727272727273
51709, 0.26086956521739, 1.0891304347826, 0.022727272727273
51710, 0.28260869565217, 1.0891304347826, 0.045454545454545
51711, 0.26086956521739, 1.0630434782609, 0.045454545454545
51712, 0.26086956521739, 1.0891304347826, 0.068181818181818
51713, 0.28260869565217, 1.0891304347826, 0.090909090909091
51714, 0.26086956521739, 1.0630434782609, 0.090909090909091
51715, 0.26086956521739, 1.0891304347826, 0.11363636363636
51716, 0.28260869565217, 1.0891304347826, 0.13636363636364
51717, 0.26086956521739, 1.0630434782609, 0.13636363636364
51718, 0.26086956521739, 1.0891304347826, 0.15909090909091
51719, 0.28260869565217, 1.0891304347826, 0.18181818181818
51720, 0.26086956521739, 1.0630434782609, 0.18181818181818
51721, 0.26086956521739, 1.0891304347826, 0.20454545454545
51722, 0.28260869565217, 1.0891304347826, 0.22727272727273
51723, 0.26086956521739, 1.0630434782609, 0.22727272727273
51724, 0.26086956521739, 1.0891304347826, 0.25
51725, 0.28260869565217, 1.0891304347826, 0.27272727272727
51726, 0.26086956521739, 1.0630434782609, 0.27272727272727
51727, 0.26086956521739, 1.0891304347826, 0.29545454545455
51728, 0.28260869565217, 1.0891304347826, 0.31818181818182
51729, 0.26086956521739, 1.0630434782609, 0.31818181818182
51730, 0.26086956521739, 1.0891304347826, 0.34090909090909
51731, 0.28260869565217, 1.0891304347826, 0.36363636363636
51732, 0.26086956521739, 1.0630434782609, 0.36363636363636
51733, 0.26086956521739, 1.0891304347826, 0.38636363636364
51734, 0.28260869565217, 1.0891304347826, 0.40909090909091
51735, 0.26086956521739, 1.0630434782609, 0.40909090909091
51736, 0.26086956521739, 1.0891304347826, 0.43181818181818
51737, 0.28260869565217, 1.0891304347826, 0.45454545454545
51738, 0.26086956521739, 1.0630434782609, 0.45454545454545
51739, 0.26086956521739, 1.0891304347826, 0.47727272727273
51740, 0.21739130434783, 1.0891304347826, 0.022727272727273
51741, 0.23913043478261, 1.0891304347826, 0.045454545454545
51742, 0.21739130434783, 1.0630434782609, 0.045454545454545
51743, 0.21739130434783, 1.0891304347826, 0.068181818181818
51744, 0.23913043478261, 1.0891304347826, 0.090909090909091
51745, 0.21739130434783, 1.0630434782609, 0.090909090909091
51746, 0.21739130434783, 1.0891304347826, 0.11363636363636
51747, 0.23913043478261, 1.0891304347826, 0.13636363636364
51748, 0.21739130434783, 1.0630434782609, 0.13636363636364
51749, 0.21739130434783, 1.0891304347826, 0.15909090909091
51750, 0.23913043478261, 1.0891304347826, 0.18181818181818
51751, 0.21739130434783, 1.0630434782609, 0.18181818181818
51752, 0.21739130434783, 1.0891304347826, 0.20454545454545
51753, 0.23913043478261, 1.0891304347826, 0.22727272727273
51754, 0.21739130434783, 1.0630434782609, 0.22727272727273
51755, 0.21739130434783, 1.0891304347826, 0.25
51756, 0.23913043478261, 1.0891304347826, 0.27272727272727
51757, 0.21739130434783, 1.0630434782609, 0.27272727272727
51758, 0.21739130434783, 1.0891304347826, 0.29545454545455
51759, 0.23913043478261, 1.0891304347826, 0.31818181818182
51760, 0.21739130434783, 1.0630434782609, 0.31818181818182
51761, 0.21739130434783, 1.0891304347826, 0.34090909090909
51762, 0.23913043478261, 1.0891304347826, 0.36363636363636
51763, 0.21739130434783, 1.0630434782609, 0.36363636363636
51764, 0.21739130434783, 1.0891304347826, 0.38636363636364
51765, 0.23913043478261, 1.0891304347826, 0.40909090909091
51766, 0.21739130434783, 1.0630434782609, 0.40909090909091
51767, 0.21739130434783, 1.0891304347826, 0.43181818181818
51768, 0.23913043478261, 1.0891304347826, 0.45454545454545
51769, 0.21739130434783, 1.0630434782609, 0.45454545454545
51770, 0.21739130434783, 1.0891304347826, 0.47727272727273
51771, 0.17391304347826, 1.0891304347826, 0.022727272727273
51772, 0.19565217391304, 1.0891304347826, 0.045454545454545
51773, 0.17391304347826, 1.0630434782609, 0.045454545454545
51774, 0.17391304347826, 1.0891304347826, 0.068181818181818
51775, 0.19565217391304, 1.0891304347826, 0.090909090909091
51776, 0.17391304347826, 1.0630434782609, 0.090909090909091
51777, 0.17391304347826, 1.0891304347826, 0.11363636363636
51778, 0.19565217391304, 1.0891304347826, 0.13636363636364
51779, 0.17391304347826, 1.0630434782609, 0.13636363636364
51780, 0.17391304347826, 1.0891304347826, 0.15909090909091
51781, 0.19565217391304, 1.0891304347826, 0.18181818181818
51782, 0.17391304347826, 1.0630434782609, 0.18181818181818
51783, 0.17391304347826, 1.0891304347826, 0.20454545454545
51784, 0.19565217391304, 1.0891304347826, 0.22727272727273
51785, 0.17391304347826, 1.0630434782609, 0.22727272727273
51786, 0.17391304347826, 1.0891304347826, 0.25
51787, 0.19565217391304, 1.0891304347826, 0.27272727272727
51788, 0.17391304347826, 1.0630434782609, 0.27272727272727
51789, 0.17391304347826, 1.0891304347826, 0.29545454545455
51790, 0.19565217391304, 1.0891304347826, 0.31818181818182
51791, 0.17391304347826, 1.0630434782609, 0.31818181818182
51792, 0.17391304347826, 1.0891304347826, 0.34090909090909
51793, 0.19565217391304, 1.0891304347826, 0.36363636363636
51794, 0.17391304347826, 1.0630434782609, 0.36363636363636
51795, 0.17391304347826, 1.0891304347826, 0.38636363636364
51796, 0.19565217391304, 1.0891304347826, 0.40909090909091
51797, 0.17391304347826, 1.0630434782609, 0.40909090909091
51798, 0.17391304347826, 1.0891304347826, 0.43181818181818
51799, 0.19565217391304, 1.0891304347826, 0.45454545454545
51800, 0.17391304347826, 1.0630434782609, 0.45454545454545
51801, 0.17391304347826, 1.0891304347826, 0.47727272727273
51802, 0.1304347826087, 1.0891304347826, 0.022727272727273
51803, 0.15217391304348, 1.0891304347826, 0.045454545454545
51804, 0.1304347826087, 1.0630434782609, 0.045454545454545
51805, 0.1304347826087, 1.0891304347826, 0.068181818181818
51806, 0.15217391304348, 1.0891304347826, 0.090909090909091
51807, 0.1304347826087, 1.0630434782609, 0.090909090909091
51808, 0.1304347826087, 1.0891304347826, 0.11363636363636
51809, 0.15217391304348, 1.0891304347826, 0.13636363636364
51810, 0.1304347826087, 1.0630434782609, 0.13636363636364
51811, 0.1304347826087, 1.0891304347826, 0.15909090909091
51812, 0.15217391304348, 1.0891304347826, 0.18181818181818
51813, 0.1304347826087, 1.0630434782609, 0.18181818181818
51814, 0.1304347826087, 1.0891304347826, 0.20454545454545
51815, 0.15217391304348, 1.0891304347826, 0.22727272727273
51816, 0.1304347826087, 1.0630434782609, 0.22727272727273
51817, 0.1304347826087, 1.0891304347826, 0.25
51818, 0.15217391304348, 1.0891304347826, 0.27272727272727
51819, 0.1304347826087, 1.0630434782609, 0.27272727272727
51820, 0.1304347826087, 1.0891304347826, 0.29545454545455
51821, 0.15217391304348, 1.0891304347826, 0.31818181818182
51822, 0.1304347826087, 1.0630434782609, 0.31818181818182
51823, 0.1304347826087, 1.0891304347826, 0.34090909090909
51824, 0.15217391304348, 1.0891304347826, 0.36363636363636
51825, 0.1304347826087, 1.0630434782609, 0.36363636363636
51826, 0.1304347826087, 1.0891304347826, 0.38636363636364
51827, 0.15217391304348, 1.0891304347826, 0.40909090909091
51828, 0.1304347826087, 1.0630434782609, 0.40909090909091
51829, 0.1304347826087, 1.0891304347826, 0.43181818181818
51830, 0.15217391304348, 1.0891304347826, 0.45454545454545
51831, 0.1304347826087, 1.0630434782609, 0.45454545454545
51832, 0.1304347826087, 1.0891304347826, 0.47727272727273
51833, 0.08695652173913, 1.0891304347826, 0.022727272727273
51834, 0.10869565217391, 1.0891304347826, 0.045454545454545
51835, 0.08695652173913, 1.0630434782609, 0.045454545454545
51836, 0.08695652173913, 1.0891304347826, 0.068181818181818
51837, 0.10869565217391, 1.0891304347826, 0.090909090909091
51838, 0.08695652173913, 1.0630434782609, 0.090909090909091
51839, 0.08695652173913, 1.0891304347826, 0.11363636363636
51840, 0.10869565217391, 1.0891304347826, 0.13636363636364
51841, 0.08695652173913, 1.0630434782609, 0.13636363636364
51842, 0.08695652173913, 1.0891304347826, 0.15909090909091
51843, 0.10869565217391, 1.0891304347826, 0.18181818181818
51844, 0.08695652173913, 1.0630434782609, 0.18181818181818
51845, 0.08695652173913, 1.0891304347826, 0.20454545454545
51846, 0.10869565217391, 1.0891304347826, 0.22727272727273
51847, 0.08695652173913, 1.0630434782609, 0.22727272727273
51848, 0.08695652173913, 1.0891304347826, 0.25
51849, 0.10869565217391, 1.0891304347826, 0.27272727272727
51850, 0.08695652173913, 1.0630434782609, 0.27272727272727
51851, 0.08695652173913, 1.0891304347826, 0.29545454545455
51852, 0.10869565217391, 1.0891304347826, 0.31818181818182
51853, 0.08695652173913, 1.0630434782609, 0.31818181818182
51854, 0.08695652173913, 1.0891304347826, 0.34090909090909
51855, 0.10869565217391, 1.0891304347826, 0.36363636363636
51856, 0.08695652173913, 1.0630434782609, 0.36363636363636
51857, 0.08695652173913, 1.0891304347826, 0.38636363636364
51858, 0.10869565217391, 1.0891304347826, 0.40909090909091
51859, 0.08695652173913, 1.0630434782609, 0.40909090909091
51860, 0.08695652173913, 1.0891304347826, 0.43181818181818
51861, 0.10869565217391, 1.0891304347826, 0.45454545454545
51862, 0.08695652173913, 1.0630434782609, 0.45454545454545
51863, 0.08695652173913, 1.0891304347826, 0.47727272727273
51864, 0.043478260869565, 1.0891304347826, 0.022727272727273
51865, 0.065217391304348, 1.0891304347826, 0.045454545454545
51866, 0.043478260869565, 1.0630434782609, 0.045454545454545
51867, 0.043478260869565, 1.0891304347826, 0.068181818181818
51868, 0.065217391304348, 1.0891304347826, 0.090909090909091
51869, 0.043478260869565, 1.0630434782609, 0.090909090909091
51870, 0.043478260869565, 1.0891304347826, 0.11363636363636
51871, 0.065217391304348, 1.0891304347826, 0.13636363636364
51872, 0.043478260869565, 1.0630434782609, 0.13636363636364
51873, 0.043478260869565, 1.0891304347826, 0.15909090909091
51874, 0.065217391304348, 1.0891304347826, 0.18181818181818
51875, 0.043478260869565, 1.0630434782609, 0.18181818181818
51876, 0.043478260869565, 1.0891304347826, 0.20454545454545
51877, 0.065217391304348, 1.0891304347826, 0.22727272727273
51878, 0.043478260869565, 1.0630434782609, 0.22727272727273
51879, 0.043478260869565, 1.0891304347826, 0.25
51880, 0.065217391304348, 1.0891304347826, 0.27272727272727
51881, 0.043478260869565, 1.0630434782609, 0.27272727272727
51882, 0.043478260869565, 1.0891304347826, 0.29545454545455
51883, 0.065217391304348, 1.0891304347826, 0.31818181818182
51884, 0.043478260869565, 1.0630434782609, 0.31818181818182
51885, 0.043478260869565, 1.0891304347826, 0.34090909090909
51886, 0.065217391304348, 1.0891304347826, 0.36363636363636
51887, 0.043478260869565, 1.0630434782609, 0.36363636363636
51888, 0.043478260869565, 1.0891304347826, 0.38636363636364
51889, 0.065217391304348, 1.0891304347826, 0.40909090909091
51890, 0.043478260869565, 1.0630434782609, 0.40909090909091
51891, 0.043478260869565, 1.0891304347826, 0.43181818181818
51892, 0.065217391304348, 1.0891304347826, 0.45454545454545
51893, 0.043478260869565, 1.0630434782609, 0.45454545454545
51894, 0.043478260869565, 1.0891304347826, 0.47727272727273
51895, 0.021739130434783, 1.0891304347826, 0.045454545454545
51896, 0.021739130434783, 1.0891304347826, 0.090909090909091
51897, 0.021739130434783, 1.0891304347826, 0.13636363636364
51898, 0.021739130434783, 1.0891304347826, 0.18181818181818
51899, 0.021739130434783, 1.0891304347826, 0.22727272727273
51900, 0.021739130434783, 1.0891304347826, 0.27272727272727
51901, 0.021739130434783, 1.0891304347826, 0.31818181818182
51902, 0.021739130434783, 1.0891304347826, 0.36363636363636
51903, 0.021739130434783, 1.0891304347826, 0.40909090909091
51904, 0.021739130434783, 1.0891304347826, 0.45454545454545
51905, 0.95652173913043, 1.1413043478261, 0.022727272727273
51906, 0.97826086956522, 1.1413043478261, 0.045454545454545
51907, 0.95652173913043, 1.1152173913043, 0.045454545454545
51908, 0.95652173913043, 1.1413043478261, 0.068181818181818
51909, 0.97826086956522, 1.1413043478261, 0.090909090909091
51910, 0.95652173913043, 1.1152173913043, 0.090909090909091
51911, 0.95652173913043, 1.1413043478261, 0.11363636363636
51912, 0.97826086956522, 1.1413043478261, 0.13636363636364
51913, 0.95652173913043, 1.1152173913043, 0.13636363636364
51914, 0.95652173913044, 1.1413043478261, 0.15909090909091
51915, 0.97826086956522, 1.1413043478261, 0.18181818181818
51916, 0.95652173913044, 1.1152173913043, 0.18181818181818
51917, 0.95652173913044, 1.1413043478261, 0.20454545454545
51918, 0.97826086956522, 1.1413043478261, 0.22727272727273
51919, 0.95652173913044, 1.1152173913043, 0.22727272727273
51920, 0.95652173913044, 1.1413043478261, 0.25
51921, 0.97826086956522, 1.1413043478261, 0.27272727272727
51922, 0.95652173913044, 1.1152173913043, 0.27272727272727
51923, 0.95652173913044, 1.1413043478261, 0.29545454545455
51924, 0.97826086956522, 1.1413043478261, 0.31818181818182
51925, 0.95652173913044, 1.1152173913043, 0.31818181818182
51926, 0.95652173913043, 1.1413043478261, 0.34090909090909
51927, 0.97826086956522, 1.1413043478261, 0.36363636363636
51928, 0.95652173913043, 1.1152173913043, 0.36363636363636
51929, 0.95652173913043, 1.1413043478261, 0.38636363636364
51930, 0.97826086956522, 1.1413043478261, 0.40909090909091
51931, 0.95652173913043, 1.1152173913043, 0.40909090909091
51932, 0.95652173913043, 1.1413043478261, 0.43181818181818
51933, 0.97826086956522, 1.1413043478261, 0.45454545454545
51934, 0.95652173913044, 1.1152173913043, 0.45454545454545
51935, 0.95652173913043, 1.1413043478261, 0.47727272727273
51936, 0.91304347826087, 1.1413043478261, 0.022727272727273
51937, 0.93478260869565, 1.1413043478261, 0.045454545454545
51938, 0.91304347826087, 1.1152173913043, 0.045454545454545
51939, 0.91304347826087, 1.1413043478261, 0.068181818181818
51940, 0.93478260869565, 1.1413043478261, 0.090909090909091
51941, 0.91304347826087, 1.1152173913043, 0.090909090909091
51942, 0.91304347826087, 1.1413043478261, 0.11363636363636
51943, 0.93478260869565, 1.1413043478261, 0.13636363636364
51944, 0.91304347826087, 1.1152173913043, 0.13636363636364
51945, 0.91304347826087, 1.1413043478261, 0.15909090909091
51946, 0.93478260869565, 1.1413043478261, 0.18181818181818
51947, 0.91304347826087, 1.1152173913043, 0.18181818181818
51948, 0.91304347826087, 1.1413043478261, 0.20454545454545
51949, 0.93478260869565, 1.1413043478261, 0.22727272727273
51950, 0.91304347826087, 1.1152173913043, 0.22727272727273
51951, 0.91304347826087, 1.1413043478261, 0.25
51952, 0.93478260869565, 1.1413043478261, 0.27272727272727
51953, 0.91304347826087, 1.1152173913043, 0.27272727272727
51954, 0.91304347826087, 1.1413043478261, 0.29545454545455
51955, 0.93478260869565, 1.1413043478261, 0.31818181818182
51956, 0.91304347826087, 1.1152173913043, 0.31818181818182
51957, 0.91304347826087, 1.1413043478261, 0.34090909090909
51958, 0.93478260869565, 1.1413043478261, 0.36363636363636
51959, 0.91304347826087, 1.1152173913043, 0.36363636363636
51960, 0.91304347826087, 1.1413043478261, 0.38636363636364
51961, 0.93478260869565, 1.1413043478261, 0.40909090909091
51962, 0.91304347826087, 1.1152173913043, 0.40909090909091
51963, 0.91304347826087, 1.1413043478261, 0.43181818181818
51964, 0.93478260869565, 1.1413043478261, 0.45454545454545
51965, 0.91304347826087, 1.1152173913043, 0.45454545454545
51966, 0.91304347826087, 1.1413043478261, 0.47727272727273
51967, 0.8695652173913, 1.1413043478261, 0.022727272727273
51968, 0.89130434782609, 1.1413043478261, 0.045454545454545
51969, 0.8695652173913, 1.1152173913043, 0.045454545454545
51970, 0.8695652173913, 1.1413043478261, 0.068181818181818
51971, 0.89130434782609, 1.1413043478261, 0.090909090909091
51972, 0.8695652173913, 1.1152173913043, 0.090909090909091
51973, 0.8695652173913, 1.1413043478261, 0.11363636363636
51974, 0.89130434782609, 1.1413043478261, 0.13636363636364
51975, 0.8695652173913, 1.1152173913043, 0.13636363636364
51976, 0.8695652173913, 1.1413043478261, 0.15909090909091
51977, 0.89130434782609, 1.1413043478261, 0.18181818181818
51978, 0.8695652173913, 1.1152173913043, 0.18181818181818
51979, 0.8695652173913, 1.1413043478261, 0.20454545454545
51980, 0.89130434782609, 1.1413043478261, 0.22727272727273
51981, 0.8695652173913, 1.1152173913043, 0.22727272727273
51982, 0.8695652173913, 1.1413043478261, 0.25
51983, 0.89130434782609, 1.1413043478261, 0.27272727272727
51984, 0.8695652173913, 1.1152173913043, 0.27272727272727
51985, 0.8695652173913, 1.1413043478261, 0.29545454545455
51986, 0.89130434782609, 1.1413043478261, 0.31818181818182
51987, 0.8695652173913, 1.1152173913043, 0.31818181818182
51988, 0.8695652173913, 1.1413043478261, 0.34090909090909
51989, 0.89130434782609, 1.1413043478261, 0.36363636363636
51990, 0.8695652173913, 1.1152173913043, 0.36363636363636
51991, 0.8695652173913, 1.1413043478261, 0.38636363636364
51992, 0.89130434782609, 1.1413043478261, 0.40909090909091
51993, 0.8695652173913, 1.1152173913043, 0.40909090909091
51994, 0.8695652173913, 1.1413043478261, 0.43181818181818
51995, 0.89130434782609, 1.1413043478261, 0.45454545454545
51996, 0.8695652173913, 1.1152173913043, 0.45454545454545
51997, 0.8695652173913, 1.1413043478261, 0.47727272727273
51998, 0.82608695652174, 1.1413043478261, 0.022727272727273
51999, 0.84782608695652, 1.1413043478261, 0.045454545454545
52000, 0.82608695652174, 1.1152173913043, 0.045454545454545
52001, 0.82608695652174, 1.1413043478261, 0.068181818181818
52002, 0.84782608695652, 1.1413043478261, 0.090909090909091
52003, 0.82608695652174, 1.1152173913043, 0.090909090909091
52004, 0.82608695652174, 1.1413043478261, 0.11363636363636
52005, 0.84782608695652, 1.1413043478261, 0.13636363636364
52006, 0.82608695652174, 1.1152173913043, 0.13636363636364
52007, 0.82608695652174, 1.1413043478261, 0.15909090909091
52008, 0.84782608695652, 1.1413043478261, 0.18181818181818
52009, 0.82608695652174, 1.1152173913043, 0.18181818181818
52010, 0.82608695652174, 1.1413043478261, 0.20454545454545
52011, 0.84782608695652, 1.1413043478261, 0.22727272727273
52012, 0.82608695652174, 1.1152173913043, 0.22727272727273
52013, 0.82608695652174, 1.1413043478261, 0.25
52014, 0.84782608695652, 1.1413043478261, 0.27272727272727
52015, 0.82608695652174, 1.1152173913043, 0.27272727272727
52016, 0.82608695652174, 1.1413043478261, 0.29545454545455
52017, 0.84782608695652, 1.1413043478261, 0.31818181818182
52018, 0.82608695652174, 1.1152173913043, 0.31818181818182
52019, 0.82608695652174, 1.1413043478261, 0.34090909090909
52020, 0.84782608695652, 1.1413043478261, 0.36363636363636
52021, 0.82608695652174, 1.1152173913043, 0.36363636363636
52022, 0.82608695652174, 1.1413043478261, 0.38636363636364
52023, 0.84782608695652, 1.1413043478261, 0.40909090909091
52024, 0.82608695652174, 1.1152173913043, 0.40909090909091
52025, 0.82608695652174, 1.1413043478261, 0.43181818181818
52026, 0.84782608695652, 1.1413043478261, 0.45454545454545
52027, 0.82608695652174, 1.1152173913043, 0.45454545454545
52028, 0.82608695652174, 1.1413043478261, 0.47727272727273
52029, 0.78260869565217, 1.1413043478261, 0.022727272727273
52030, 0.80434782608696, 1.1413043478261, 0.045454545454545
52031, 0.78260869565217, 1.1152173913043, 0.045454545454545
52032, 0.78260869565217, 1.1413043478261, 0.068181818181818
52033, 0.80434782608696, 1.1413043478261, 0.090909090909091
52034, 0.78260869565217, 1.1152173913043, 0.090909090909091
52035, 0.78260869565217, 1.1413043478261, 0.11363636363636
52036, 0.80434782608696, 1.1413043478261, 0.13636363636364
52037, 0.78260869565217, 1.1152173913043, 0.13636363636364
52038, 0.78260869565217, 1.1413043478261, 0.15909090909091
52039, 0.80434782608696, 1.1413043478261, 0.18181818181818
52040, 0.78260869565217, 1.1152173913043, 0.18181818181818
52041, 0.78260869565217, 1.1413043478261, 0.20454545454545
52042, 0.80434782608696, 1.1413043478261, 0.22727272727273
52043, 0.78260869565217, 1.1152173913043, 0.22727272727273
52044, 0.78260869565217, 1.1413043478261, 0.25
52045, 0.80434782608696, 1.1413043478261, 0.27272727272727
52046, 0.78260869565217, 1.1152173913043, 0.27272727272727
52047, 0.78260869565217, 1.1413043478261, 0.29545454545455
52048, 0.80434782608696, 1.1413043478261, 0.31818181818182
52049, 0.78260869565217, 1.1152173913043, 0.31818181818182
52050, 0.78260869565217, 1.1413043478261, 0.34090909090909
52051, 0.80434782608696, 1.1413043478261, 0.36363636363636
52052, 0.78260869565217, 1.1152173913043, 0.36363636363636
52053, 0.78260869565217, 1.1413043478261, 0.38636363636364
52054, 0.80434782608696, 1.1413043478261, 0.40909090909091
52055, 0.78260869565217, 1.1152173913043, 0.40909090909091
52056, 0.78260869565217, 1.1413043478261, 0.43181818181818
52057, 0.80434782608696, 1.1413043478261, 0.45454545454545
52058, 0.78260869565217, 1.1152173913043, 0.45454545454545
52059, 0.78260869565217, 1.1413043478261, 0.47727272727273
52060, 0.73913043478261, 1.1413043478261, 0.022727272727273
52061, 0.76086956521739, 1.1413043478261, 0.045454545454545
52062, 0.73913043478261, 1.1152173913043, 0.045454545454545
52063, 0.73913043478261, 1.1413043478261, 0.068181818181818
52064, 0.76086956521739, 1.1413043478261, 0.090909090909091
52065, 0.73913043478261, 1.1152173913043, 0.090909090909091
52066, 0.73913043478261, 1.1413043478261, 0.11363636363636
52067, 0.76086956521739, 1.1413043478261, 0.13636363636364
52068, 0.73913043478261, 1.1152173913043, 0.13636363636364
52069, 0.73913043478261, 1.1413043478261, 0.15909090909091
52070, 0.76086956521739, 1.1413043478261, 0.18181818181818
52071, 0.73913043478261, 1.1152173913043, 0.18181818181818
52072, 0.73913043478261, 1.1413043478261, 0.20454545454545
52073, 0.76086956521739, 1.1413043478261, 0.22727272727273
52074, 0.73913043478261, 1.1152173913043, 0.22727272727273
52075, 0.73913043478261, 1.1413043478261, 0.25
52076, 0.76086956521739, 1.1413043478261, 0.27272727272727
52077, 0.73913043478261, 1.1152173913043, 0.27272727272727
52078, 0.73913043478261, 1.1413043478261, 0.29545454545455
52079, 0.76086956521739, 1.1413043478261, 0.31818181818182
52080, 0.73913043478261, 1.1152173913043, 0.31818181818182
52081, 0.73913043478261, 1.1413043478261, 0.34090909090909
52082, 0.76086956521739, 1.1413043478261, 0.36363636363636
52083, 0.73913043478261, 1.1152173913043, 0.36363636363636
52084, 0.73913043478261, 1.1413043478261, 0.38636363636364
52085, 0.76086956521739, 1.1413043478261, 0.40909090909091
52086, 0.73913043478261, 1.1152173913043, 0.40909090909091
52087, 0.73913043478261, 1.1413043478261, 0.43181818181818
52088, 0.76086956521739, 1.1413043478261, 0.45454545454545
52089, 0.73913043478261, 1.1152173913043, 0.45454545454545
52090, 0.73913043478261, 1.1413043478261, 0.47727272727273
52091, 0.69565217391304, 1.1413043478261, 0.022727272727273
52092, 0.71739130434783, 1.1413043478261, 0.045454545454545
52093, 0.69565217391304, 1.1152173913043, 0.045454545454545
52094, 0.69565217391304, 1.1413043478261, 0.068181818181818
52095, 0.71739130434783, 1.1413043478261, 0.090909090909091
52096, 0.69565217391304, 1.1152173913043, 0.090909090909091
52097, 0.69565217391304, 1.1413043478261, 0.11363636363636
52098, 0.71739130434783, 1.1413043478261, 0.13636363636364
52099, 0.69565217391304, 1.1152173913043, 0.13636363636364
52100, 0.69565217391304, 1.1413043478261, 0.15909090909091
52101, 0.71739130434783, 1.1413043478261, 0.18181818181818
52102, 0.69565217391304, 1.1152173913043, 0.18181818181818
52103, 0.69565217391304, 1.1413043478261, 0.20454545454545
52104, 0.71739130434783, 1.1413043478261, 0.22727272727273
52105, 0.69565217391304, 1.1152173913043, 0.22727272727273
52106, 0.69565217391304, 1.1413043478261, 0.25
52107, 0.71739130434783, 1.1413043478261, 0.27272727272727
52108, 0.69565217391304, 1.1152173913043, 0.27272727272727
52109, 0.69565217391304, 1.1413043478261, 0.29545454545455
52110, 0.71739130434783, 1.1413043478261, 0.31818181818182
52111, 0.69565217391304, 1.1152173913043, 0.31818181818182
52112, 0.69565217391304, 1.1413043478261, 0.34090909090909
52113, 0.71739130434783, 1.1413043478261, 0.36363636363636
52114, 0.69565217391304, 1.1152173913043, 0.36363636363636
52115, 0.69565217391304, 1.1413043478261, 0.38636363636364
52116, 0.71739130434783, 1.1413043478261, 0.40909090909091
52117, 0.69565217391304, 1.1152173913043, 0.40909090909091
52118, 0.69565217391304, 1.1413043478261, 0.43181818181818
52119, 0.71739130434783, 1.1413043478261, 0.45454545454545
52120, 0.69565217391304, 1.1152173913043, 0.45454545454545
52121, 0.69565217391304, 1.1413043478261, 0.47727272727273
52122, 0.65217391304348, 1.1413043478261, 0.022727272727273
52123, 0.67391304347826, 1.1413043478261, 0.045454545454545
52124, 0.65217391304348, 1.1152173913043, 0.045454545454545
52125, 0.65217391304348, 1.1413043478261, 0.068181818181818
52126, 0.67391304347826, 1.1413043478261, 0.090909090909091
52127, 0.65217391304348, 1.1152173913043, 0.090909090909091
52128, 0.65217391304348, 1.1413043478261, 0.11363636363636
52129, 0.67391304347826, 1.1413043478261, 0.13636363636364
52130, 0.65217391304348, 1.1152173913043, 0.13636363636364
52131, 0.65217391304348, 1.1413043478261, 0.15909090909091
52132, 0.67391304347826, 1.1413043478261, 0.18181818181818
52133, 0.65217391304348, 1.1152173913043, 0.18181818181818
52134, 0.65217391304348, 1.1413043478261, 0.20454545454545
52135, 0.67391304347826, 1.1413043478261, 0.22727272727273
52136, 0.65217391304348, 1.1152173913043, 0.22727272727273
52137, 0.65217391304348, 1.1413043478261, 0.25
52138, 0.67391304347826, 1.1413043478261, 0.27272727272727
52139, 0.65217391304348, 1.1152173913043, 0.27272727272727
52140, 0.65217391304348, 1.1413043478261, 0.29545454545455
52141, 0.67391304347826, 1.1413043478261, 0.31818181818182
52142, 0.65217391304348, 1.1152173913043, 0.31818181818182
52143, 0.65217391304348, 1.1413043478261, 0.34090909090909
52144, 0.67391304347826, 1.1413043478261, 0.36363636363636
52145, 0.65217391304348, 1.1152173913043, 0.36363636363636
52146, 0.65217391304348, 1.1413043478261, 0.38636363636364
52147, 0.67391304347826, 1.1413043478261, 0.40909090909091
52148, 0.65217391304348, 1.1152173913043, 0.40909090909091
52149, 0.65217391304348, 1.1413043478261, 0.43181818181818
52150, 0.67391304347826, 1.1413043478261, 0.45454545454545
52151, 0.65217391304348, 1.1152173913043, 0.45454545454545
52152, 0.65217391304348, 1.1413043478261, 0.47727272727273
52153, 0.60869565217391, 1.1413043478261, 0.022727272727273
52154, 0.6304347826087, 1.1413043478261, 0.045454545454545
52155, 0.60869565217391, 1.1152173913043, 0.045454545454545
52156, 0.60869565217391, 1.1413043478261, 0.068181818181818
52157, 0.6304347826087, 1.1413043478261, 0.090909090909091
52158, 0.60869565217391, 1.1152173913043, 0.090909090909091
52159, 0.60869565217391, 1.1413043478261, 0.11363636363636
52160, 0.6304347826087, 1.1413043478261, 0.13636363636364
52161, 0.60869565217391, 1.1152173913043, 0.13636363636364
52162, 0.60869565217391, 1.1413043478261, 0.15909090909091
52163, 0.6304347826087, 1.1413043478261, 0.18181818181818
52164, 0.60869565217391, 1.1152173913043, 0.18181818181818
52165, 0.60869565217391, 1.1413043478261, 0.20454545454545
52166, 0.6304347826087, 1.1413043478261, 0.22727272727273
52167, 0.60869565217391, 1.1152173913043, 0.22727272727273
52168, 0.60869565217391, 1.1413043478261, 0.25
52169, 0.6304347826087, 1.1413043478261, 0.27272727272727
52170, 0.60869565217391, 1.1152173913043, 0.27272727272727
52171, 0.60869565217391, 1.1413043478261, 0.29545454545455
52172, 0.6304347826087, 1.1413043478261, 0.31818181818182
52173, 0.60869565217391, 1.1152173913043, 0.31818181818182
52174, 0.60869565217391, 1.1413043478261, 0.34090909090909
52175, 0.6304347826087, 1.1413043478261, 0.36363636363636
52176, 0.60869565217391, 1.1152173913043, 0.36363636363636
52177, 0.60869565217391, 1.1413043478261, 0.38636363636364
52178, 0.6304347826087, 1.1413043478261, 0.40909090909091
52179, 0.60869565217391, 1.1152173913043, 0.40909090909091
52180, 0.60869565217391, 1.1413043478261, 0.43181818181818
52181, 0.6304347826087, 1.1413043478261, 0.45454545454545
52182, 0.60869565217391, 1.1152173913043, 0.45454545454545
52183, 0.60869565217391, 1.1413043478261, 0.47727272727273
52184, 0.56521739130435, 1.1413043478261, 0.022727272727273
52185, 0.58695652173913, 1.1413043478261, 0.045454545454545
52186, 0.56521739130435, 1.1152173913043, 0.045454545454545
52187, 0.56521739130435, 1.1413043478261, 0.068181818181818
52188, 0.58695652173913, 1.1413043478261, 0.090909090909091
52189, 0.56521739130435, 1.1152173913043, 0.090909090909091
52190, 0.56521739130435, 1.1413043478261, 0.11363636363636
52191, 0.58695652173913, 1.1413043478261, 0.13636363636364
52192, 0.56521739130435, 1.1152173913043, 0.13636363636364
52193, 0.56521739130435, 1.1413043478261, 0.15909090909091
52194, 0.58695652173913, 1.1413043478261, 0.18181818181818
52195, 0.56521739130435, 1.1152173913043, 0.18181818181818
52196, 0.56521739130435, 1.1413043478261, 0.20454545454545
52197, 0.58695652173913, 1.1413043478261, 0.22727272727273
52198, 0.56521739130435, 1.1152173913043, 0.22727272727273
52199, 0.56521739130435, 1.1413043478261, 0.25
52200, 0.58695652173913, 1.1413043478261, 0.27272727272727
52201, 0.56521739130435, 1.1152173913043, 0.27272727272727
52202, 0.56521739130435, 1.1413043478261, 0.29545454545455
52203, 0.58695652173913, 1.1413043478261, 0.31818181818182
52204, 0.56521739130435, 1.1152173913043, 0.31818181818182
52205, 0.56521739130435, 1.1413043478261, 0.34090909090909
52206, 0.58695652173913, 1.1413043478261, 0.36363636363636
52207, 0.56521739130435, 1.1152173913043, 0.36363636363636
52208, 0.56521739130435, 1.1413043478261, 0.38636363636364
52209, 0.58695652173913, 1.1413043478261, 0.40909090909091
52210, 0.56521739130435, 1.1152173913043, 0.40909090909091
52211, 0.56521739130435, 1.1413043478261, 0.43181818181818
52212, 0.58695652173913, 1.1413043478261, 0.45454545454545
52213, 0.56521739130435, 1.1152173913043, 0.45454545454545
52214, 0.56521739130435, 1.1413043478261, 0.47727272727273
52215, 0.52173913043478, 1.1413043478261, 0.022727272727273
52216, 0.54347826086956, 1.1413043478261, 0.045454545454545
52217, 0.52173913043478, 1.1152173913043, 0.045454545454545
52218, 0.52173913043478, 1.1413043478261, 0.068181818181818
52219, 0.54347826086956, 1.1413043478261, 0.090909090909091
52220, 0.52173913043478, 1.1152173913043, 0.090909090909091
52221, 0.52173913043478, 1.1413043478261, 0.11363636363636
52222, 0.54347826086957, 1.1413043478261, 0.13636363636364
52223, 0.52173913043478, 1.1152173913043, 0.13636363636364
52224, 0.52173913043478, 1.1413043478261, 0.15909090909091
52225, 0.54347826086956, 1.1413043478261, 0.18181818181818
52226, 0.52173913043478, 1.1152173913043, 0.18181818181818
52227, 0.52173913043478, 1.1413043478261, 0.20454545454545
52228, 0.54347826086956, 1.1413043478261, 0.22727272727273
52229, 0.52173913043478, 1.1152173913043, 0.22727272727273
52230, 0.52173913043478, 1.1413043478261, 0.25
52231, 0.54347826086956, 1.1413043478261, 0.27272727272727
52232, 0.52173913043478, 1.1152173913043, 0.27272727272727
52233, 0.52173913043478, 1.1413043478261, 0.29545454545455
52234, 0.54347826086957, 1.1413043478261, 0.31818181818182
52235, 0.52173913043478, 1.1152173913043, 0.31818181818182
52236, 0.52173913043478, 1.1413043478261, 0.34090909090909
52237, 0.54347826086957, 1.1413043478261, 0.36363636363636
52238, 0.52173913043478, 1.1152173913043, 0.36363636363636
52239, 0.52173913043478, 1.1413043478261, 0.38636363636364
52240, 0.54347826086956, 1.1413043478261, 0.40909090909091
52241, 0.52173913043478, 1.1152173913043, 0.40909090909091
52242, 0.52173913043478, 1.1413043478261, 0.43181818181818
52243, 0.54347826086956, 1.1413043478261, 0.45454545454545
52244, 0.52173913043478, 1.1152173913043, 0.45454545454545
52245, 0.52173913043478, 1.1413043478261, 0.47727272727273
52246, 0.47826086956522, 1.1413043478261, 0.022727272727273
52247, 0.5, 1.1413043478261, 0.045454545454545
52248, 0.47826086956522, 1.1152173913043, 0.045454545454545
52249, 0.47826086956522, 1.1413043478261, 0.068181818181818
52250, 0.5, 1.1413043478261, 0.090909090909091
52251, 0.47826086956522, 1.1152173913043, 0.090909090909091
52252, 0.47826086956522, 1.1413043478261, 0.11363636363636
52253, 0.5, 1.1413043478261, 0.13636363636364
52254, 0.47826086956522, 1.1152173913043, 0.13636363636364
52255, 0.47826086956522, 1.1413043478261, 0.15909090909091
52256, 0.5, 1.1413043478261, 0.18181818181818
52257, 0.47826086956522, 1.1152173913043, 0.18181818181818
52258, 0.47826086956522, 1.1413043478261, 0.20454545454545
52259, 0.5, 1.1413043478261, 0.22727272727273
52260, 0.47826086956522, 1.1152173913043, 0.22727272727273
52261, 0.47826086956522, 1.1413043478261, 0.25
52262, 0.5, 1.1413043478261, 0.27272727272727
52263, 0.47826086956522, 1.1152173913043, 0.27272727272727
52264, 0.47826086956522, 1.1413043478261, 0.29545454545455
52265, 0.5, 1.1413043478261, 0.31818181818182
52266, 0.47826086956522, 1.1152173913043, 0.31818181818182
52267, 0.47826086956522, 1.1413043478261, 0.34090909090909
52268, 0.5, 1.1413043478261, 0.36363636363636
52269, 0.47826086956522, 1.1152173913043, 0.36363636363636
52270, 0.47826086956522, 1.1413043478261, 0.38636363636364
52271, 0.5, 1.1413043478261, 0.40909090909091
52272, 0.47826086956522, 1.1152173913043, 0.40909090909091
52273, 0.47826086956522, 1.1413043478261, 0.43181818181818
52274, 0.5, 1.1413043478261, 0.45454545454545
52275, 0.47826086956522, 1.1152173913043, 0.45454545454545
52276, 0.47826086956522, 1.1413043478261, 0.47727272727273
52277, 0.43478260869565, 1.1413043478261, 0.022727272727273
52278, 0.45652173913043, 1.1413043478261, 0.045454545454545
52279, 0.43478260869565, 1.1152173913043, 0.045454545454545
52280, 0.43478260869565, 1.1413043478261, 0.068181818181818
52281, 0.45652173913043, 1.1413043478261, 0.090909090909091
52282, 0.43478260869565, 1.1152173913043, 0.090909090909091
52283, 0.43478260869565, 1.1413043478261, 0.11363636363636
52284, 0.45652173913043, 1.1413043478261, 0.13636363636364
52285, 0.43478260869565, 1.1152173913043, 0.13636363636364
52286, 0.43478260869565, 1.1413043478261, 0.15909090909091
52287, 0.45652173913043, 1.1413043478261, 0.18181818181818
52288, 0.43478260869565, 1.1152173913043, 0.18181818181818
52289, 0.43478260869565, 1.1413043478261, 0.20454545454545
52290, 0.45652173913043, 1.1413043478261, 0.22727272727273
52291, 0.43478260869565, 1.1152173913043, 0.22727272727273
52292, 0.43478260869565, 1.1413043478261, 0.25
52293, 0.45652173913043, 1.1413043478261, 0.27272727272727
52294, 0.43478260869565, 1.1152173913043, 0.27272727272727
52295, 0.43478260869565, 1.1413043478261, 0.29545454545455
52296, 0.45652173913043, 1.1413043478261, 0.31818181818182
52297, 0.43478260869565, 1.1152173913043, 0.31818181818182
52298, 0.43478260869565, 1.1413043478261, 0.34090909090909
52299, 0.45652173913043, 1.1413043478261, 0.36363636363636
52300, 0.43478260869565, 1.1152173913043, 0.36363636363636
52301, 0.43478260869565, 1.1413043478261, 0.38636363636364
52302, 0.45652173913043, 1.1413043478261, 0.40909090909091
52303, 0.43478260869565, 1.1152173913043, 0.40909090909091
52304, 0.43478260869565, 1.1413043478261, 0.43181818181818
52305, 0.45652173913043, 1.1413043478261, 0.45454545454545
52306, 0.43478260869565, 1.1152173913043, 0.45454545454545
52307, 0.43478260869565, 1.1413043478261, 0.47727272727273
52308, 0.39130434782609, 1.1413043478261, 0.022727272727273
52309, 0.41304347826087, 1.1413043478261, 0.045454545454545
52310, 0.39130434782609, 1.1152173913043, 0.045454545454545
52311, 0.39130434782609, 1.1413043478261, 0.068181818181818
52312, 0.41304347826087, 1.1413043478261, 0.090909090909091
52313, 0.39130434782609, 1.1152173913043, 0.090909090909091
52314, 0.39130434782609, 1.1413043478261, 0.11363636363636
52315, 0.41304347826087, 1.1413043478261, 0.13636363636364
52316, 0.39130434782609, 1.1152173913043, 0.13636363636364
52317, 0.39130434782609, 1.1413043478261, 0.15909090909091
52318, 0.41304347826087, 1.1413043478261, 0.18181818181818
52319, 0.39130434782609, 1.1152173913043, 0.18181818181818
52320, 0.39130434782609, 1.1413043478261, 0.20454545454545
52321, 0.41304347826087, 1.1413043478261, 0.22727272727273
52322, 0.39130434782609, 1.1152173913043, 0.22727272727273
52323, 0.39130434782609, 1.1413043478261, 0.25
52324, 0.41304347826087, 1.1413043478261, 0.27272727272727
52325, 0.39130434782609, 1.1152173913043, 0.27272727272727
52326, 0.39130434782609, 1.1413043478261, 0.29545454545455
52327, 0.41304347826087, 1.1413043478261, 0.31818181818182
52328, 0.39130434782609, 1.1152173913043, 0.31818181818182
52329, 0.39130434782609, 1.1413043478261, 0.34090909090909
52330, 0.41304347826087, 1.1413043478261, 0.36363636363636
52331, 0.39130434782609, 1.1152173913043, 0.36363636363636
52332, 0.39130434782609, 1.1413043478261, 0.38636363636364
52333, 0.41304347826087, 1.1413043478261, 0.40909090909091
52334, 0.39130434782609, 1.1152173913043, 0.40909090909091
52335, 0.39130434782609, 1.1413043478261, 0.43181818181818
52336, 0.41304347826087, 1.1413043478261, 0.45454545454545
52337, 0.39130434782609, 1.1152173913043, 0.45454545454545
52338, 0.39130434782609, 1.1413043478261, 0.47727272727273
52339, 0.34782608695652, 1.1413043478261, 0.022727272727273
52340, 0.3695652173913, 1.1413043478261, 0.045454545454545
52341, 0.34782608695652, 1.1152173913043, 0.045454545454545
52342, 0.34782608695652, 1.1413043478261, 0.068181818181818
52343, 0.3695652173913, 1.1413043478261, 0.090909090909091
52344, 0.34782608695652, 1.1152173913043, 0.090909090909091
52345, 0.34782608695652, 1.1413043478261, 0.11363636363636
52346, 0.3695652173913, 1.1413043478261, 0.13636363636364
52347, 0.34782608695652, 1.1152173913043, 0.13636363636364
52348, 0.34782608695652, 1.1413043478261, 0.15909090909091
52349, 0.3695652173913, 1.1413043478261, 0.18181818181818
52350, 0.34782608695652, 1.1152173913043, 0.18181818181818
52351, 0.34782608695652, 1.1413043478261, 0.20454545454545
52352, 0.3695652173913, 1.1413043478261, 0.22727272727273
52353, 0.34782608695652, 1.1152173913043, 0.22727272727273
52354, 0.34782608695652, 1.1413043478261, 0.25
52355, 0.3695652173913, 1.1413043478261, 0.27272727272727
52356, 0.34782608695652, 1.1152173913043, 0.27272727272727
52357, 0.34782608695652, 1.1413043478261, 0.29545454545455
52358, 0.3695652173913, 1.1413043478261, 0.31818181818182
52359, 0.34782608695652, 1.1152173913043, 0.31818181818182
52360, 0.34782608695652, 1.1413043478261, 0.34090909090909
52361, 0.3695652173913, 1.1413043478261, 0.36363636363636
52362, 0.34782608695652, 1.1152173913043, 0.36363636363636
52363, 0.34782608695652, 1.1413043478261, 0.38636363636364
52364, 0.3695652173913, 1.1413043478261, 0.40909090909091
52365, 0.34782608695652, 1.1152173913043, 0.40909090909091
52366, 0.34782608695652, 1.1413043478261, 0.43181818181818
52367, 0.3695652173913, 1.1413043478261, 0.45454545454545
52368, 0.34782608695652, 1.1152173913043, 0.45454545454545
52369, 0.34782608695652, 1.1413043478261, 0.47727272727273
52370, 0.30434782608696, 1.1413043478261, 0.022727272727273
52371, 0.32608695652174, 1.1413043478261, 0.045454545454545
52372, 0.30434782608696, 1.1152173913043, 0.045454545454545
52373, 0.30434782608696, 1.1413043478261, 0.068181818181818
52374, 0.32608695652174, 1.1413043478261, 0.090909090909091
52375, 0.30434782608696, 1.1152173913043, 0.090909090909091
52376, 0.30434782608696, 1.1413043478261, 0.11363636363636
52377, 0.32608695652174, 1.1413043478261, 0.13636363636364
52378, 0.30434782608696, 1.1152173913043, 0.13636363636364
52379, 0.30434782608696, 1.1413043478261, 0.15909090909091
52380, 0.32608695652174, 1.1413043478261, 0.18181818181818
52381, 0.30434782608696, 1.1152173913043, 0.18181818181818
52382, 0.30434782608696, 1.1413043478261, 0.20454545454545
52383, 0.32608695652174, 1.1413043478261, 0.22727272727273
52384, 0.30434782608696, 1.1152173913043, 0.22727272727273
52385, 0.30434782608696, 1.1413043478261, 0.25
52386, 0.32608695652174, 1.1413043478261, 0.27272727272727
52387, 0.30434782608696, 1.1152173913043, 0.27272727272727
52388, 0.30434782608696, 1.1413043478261, 0.29545454545455
52389, 0.32608695652174, 1.1413043478261, 0.31818181818182
52390, 0.30434782608696, 1.1152173913043, 0.31818181818182
52391, 0.30434782608696, 1.1413043478261, 0.34090909090909
52392, 0.32608695652174, 1.1413043478261, 0.36363636363636
52393, 0.30434782608696, 1.1152173913043, 0.36363636363636
52394, 0.30434782608696, 1.1413043478261, 0.38636363636364
52395, 0.32608695652174, 1.1413043478261, 0.40909090909091
52396, 0.30434782608696, 1.1152173913043, 0.40909090909091
52397, 0.30434782608696, 1.1413043478261, 0.43181818181818
52398, 0.32608695652174, 1.1413043478261, 0.45454545454545
52399, 0.30434782608696, 1.1152173913043, 0.45454545454545
52400, 0.30434782608696, 1.1413043478261, 0.47727272727273
52401, 0.26086956521739, 1.1413043478261, 0.022727272727273
52402, 0.28260869565217, 1.1413043478261, 0.045454545454545
52403, 0.26086956521739, 1.1152173913043, 0.045454545454545
52404, 0.26086956521739, 1.1413043478261, 0.068181818181818
52405, 0.28260869565217, 1.1413043478261, 0.090909090909091
52406, 0.26086956521739, 1.1152173913043, 0.090909090909091
52407, 0.26086956521739, 1.1413043478261, 0.11363636363636
52408, 0.28260869565217, 1.1413043478261, 0.13636363636364
52409, 0.26086956521739, 1.1152173913043, 0.13636363636364
52410, 0.26086956521739, 1.1413043478261, 0.15909090909091
52411, 0.28260869565217, 1.1413043478261, 0.18181818181818
52412, 0.26086956521739, 1.1152173913043, 0.18181818181818
52413, 0.26086956521739, 1.1413043478261, 0.20454545454545
52414, 0.28260869565217, 1.1413043478261, 0.22727272727273
52415, 0.26086956521739, 1.1152173913043, 0.22727272727273
52416, 0.26086956521739, 1.1413043478261, 0.25
52417, 0.28260869565217, 1.1413043478261, 0.27272727272727
52418, 0.26086956521739, 1.1152173913043, 0.27272727272727
52419, 0.26086956521739, 1.1413043478261, 0.29545454545455
52420, 0.28260869565217, 1.1413043478261, 0.31818181818182
52421, 0.26086956521739, 1.1152173913043, 0.31818181818182
52422, 0.26086956521739, 1.1413043478261, 0.34090909090909
52423, 0.28260869565217, 1.1413043478261, 0.36363636363636
52424, 0.26086956521739, 1.1152173913043, 0.36363636363636
52425, 0.26086956521739, 1.1413043478261, 0.38636363636364
52426, 0.28260869565217, 1.1413043478261, 0.40909090909091
52427, 0.26086956521739, 1.1152173913043, 0.40909090909091
52428, 0.26086956521739, 1.1413043478261, 0.43181818181818
52429, 0.28260869565217, 1.1413043478261, 0.45454545454545
52430, 0.26086956521739, 1.1152173913043, 0.45454545454545
52431, 0.26086956521739, 1.1413043478261, 0.47727272727273
52432, 0.21739130434783, 1.1413043478261, 0.022727272727273
52433, 0.23913043478261, 1.1413043478261, 0.045454545454545
52434, 0.21739130434783, 1.1152173913043, 0.045454545454545
52435, 0.21739130434783, 1.1413043478261, 0.068181818181818
52436, 0.23913043478261, 1.1413043478261, 0.090909090909091
52437, 0.21739130434783, 1.1152173913043, 0.090909090909091
52438, 0.21739130434783, 1.1413043478261, 0.11363636363636
52439, 0.23913043478261, 1.1413043478261, 0.13636363636364
52440, 0.21739130434783, 1.1152173913043, 0.13636363636364
52441, 0.21739130434783, 1.1413043478261, 0.15909090909091
52442, 0.23913043478261, 1.1413043478261, 0.18181818181818
52443, 0.21739130434783, 1.1152173913043, 0.18181818181818
52444, 0.21739130434783, 1.1413043478261, 0.20454545454545
52445, 0.23913043478261, 1.1413043478261, 0.22727272727273
52446, 0.21739130434783, 1.1152173913043, 0.22727272727273
52447, 0.21739130434783, 1.1413043478261, 0.25
52448, 0.23913043478261, 1.1413043478261, 0.27272727272727
52449, 0.21739130434783, 1.1152173913043, 0.27272727272727
52450, 0.21739130434783, 1.1413043478261, 0.29545454545455
52451, 0.23913043478261, 1.1413043478261, 0.31818181818182
52452, 0.21739130434783, 1.1152173913043, 0.31818181818182
52453, 0.21739130434783, 1.1413043478261, 0.34090909090909
52454, 0.23913043478261, 1.1413043478261, 0.36363636363636
52455, 0.21739130434783, 1.1152173913043, 0.36363636363636
52456, 0.21739130434783, 1.1413043478261, 0.38636363636364
52457, 0.23913043478261, 1.1413043478261, 0.40909090909091
52458, 0.21739130434783, 1.1152173913043, 0.40909090909091
52459, 0.21739130434783, 1.1413043478261, 0.43181818181818
52460, 0.23913043478261, 1.1413043478261, 0.45454545454545
52461, 0.21739130434783, 1.1152173913043, 0.45454545454545
52462, 0.21739130434783, 1.1413043478261, 0.47727272727273
52463, 0.17391304347826, 1.1413043478261, 0.022727272727273
52464, 0.19565217391304, 1.1413043478261, 0.045454545454545
52465, 0.17391304347826, 1.1152173913043, 0.045454545454545
52466, 0.17391304347826, 1.1413043478261, 0.068181818181818
52467, 0.19565217391304, 1.1413043478261, 0.090909090909091
52468, 0.17391304347826, 1.1152173913043, 0.090909090909091
52469, 0.17391304347826, 1.1413043478261, 0.11363636363636
52470, 0.19565217391304, 1.1413043478261, 0.13636363636364
52471, 0.17391304347826, 1.1152173913043, 0.13636363636364
52472, 0.17391304347826, 1.1413043478261, 0.15909090909091
52473, 0.19565217391304, 1.1413043478261, 0.18181818181818
52474, 0.17391304347826, 1.1152173913043, 0.18181818181818
52475, 0.17391304347826, 1.1413043478261, 0.20454545454545
52476, 0.19565217391304, 1.1413043478261, 0.22727272727273
52477, 0.17391304347826, 1.1152173913043, 0.22727272727273
52478, 0.17391304347826, 1.1413043478261, 0.25
52479, 0.19565217391304, 1.1413043478261, 0.27272727272727
52480, 0.17391304347826, 1.1152173913043, 0.27272727272727
52481, 0.17391304347826, 1.1413043478261, 0.29545454545455
52482, 0.19565217391304, 1.1413043478261, 0.31818181818182
52483, 0.17391304347826, 1.1152173913043, 0.31818181818182
52484, 0.17391304347826, 1.1413043478261, 0.34090909090909
52485, 0.19565217391304, 1.1413043478261, 0.36363636363636
52486, 0.17391304347826, 1.1152173913043, 0.36363636363636
52487, 0.17391304347826, 1.1413043478261, 0.38636363636364
52488, 0.19565217391304, 1.1413043478261, 0.40909090909091
52489, 0.17391304347826, 1.1152173913043, 0.40909090909091
52490, 0.17391304347826, 1.1413043478261, 0.43181818181818
52491, 0.19565217391304, 1.1413043478261, 0.45454545454545
52492, 0.17391304347826, 1.1152173913043, 0.45454545454545
52493, 0.17391304347826, 1.1413043478261, 0.47727272727273
52494, 0.1304347826087, 1.1413043478261, 0.022727272727273
52495, 0.15217391304348, 1.1413043478261, 0.045454545454545
52496, 0.1304347826087, 1.1152173913043, 0.045454545454545
52497, 0.1304347826087, 1.1413043478261, 0.068181818181818
52498, 0.15217391304348, 1.1413043478261, 0.090909090909091
52499, 0.1304347826087, 1.1152173913043, 0.090909090909091
52500, 0.1304347826087, 1.1413043478261, 0.11363636363636
52501, 0.15217391304348, 1.1413043478261, 0.13636363636364
52502, 0.1304347826087, 1.1152173913043, 0.13636363636364
52503, 0.1304347826087, 1.1413043478261, 0.15909090909091
52504, 0.15217391304348, 1.1413043478261, 0.18181818181818
52505, 0.1304347826087, 1.1152173913043, 0.18181818181818
52506, 0.1304347826087, 1.1413043478261, 0.20454545454545
52507, 0.15217391304348, 1.1413043478261, 0.22727272727273
52508, 0.1304347826087, 1.1152173913043, 0.22727272727273
52509, 0.1304347826087, 1.1413043478261, 0.25
52510, 0.15217391304348, 1.1413043478261, 0.27272727272727
52511, 0.1304347826087, 1.1152173913043, 0.27272727272727
52512, 0.1304347826087, 1.1413043478261, 0.29545454545455
52513, 0.15217391304348, 1.1413043478261, 0.31818181818182
52514, 0.1304347826087, 1.1152173913043, 0.31818181818182
52515, 0.1304347826087, 1.1413043478261, 0.34090909090909
52516, 0.15217391304348, 1.1413043478261, 0.36363636363636
52517, 0.1304347826087, 1.1152173913043, 0.36363636363636
52518, 0.1304347826087, 1.1413043478261, 0.38636363636364
52519, 0.15217391304348, 1.1413043478261, 0.40909090909091
52520, 0.1304347826087, 1.1152173913043, 0.40909090909091
52521, 0.1304347826087, 1.1413043478261, 0.43181818181818
52522, 0.15217391304348, 1.1413043478261, 0.45454545454545
52523, 0.1304347826087, 1.1152173913043, 0.45454545454545
52524, 0.1304347826087, 1.1413043478261, 0.47727272727273
52525, 0.08695652173913, 1.1413043478261, 0.022727272727273
52526, 0.10869565217391, 1.1413043478261, 0.045454545454545
52527, 0.08695652173913, 1.1152173913043, 0.045454545454545
52528, 0.08695652173913, 1.1413043478261, 0.068181818181818
52529, 0.10869565217391, 1.1413043478261, 0.090909090909091
52530, 0.08695652173913, 1.1152173913043, 0.090909090909091
52531, 0.08695652173913, 1.1413043478261, 0.11363636363636
52532, 0.10869565217391, 1.1413043478261, 0.13636363636364
52533, 0.08695652173913, 1.1152173913043, 0.13636363636364
52534, 0.08695652173913, 1.1413043478261, 0.15909090909091
52535, 0.10869565217391, 1.1413043478261, 0.18181818181818
52536, 0.08695652173913, 1.1152173913043, 0.18181818181818
52537, 0.08695652173913, 1.1413043478261, 0.20454545454545
52538, 0.10869565217391, 1.1413043478261, 0.22727272727273
52539, 0.08695652173913, 1.1152173913043, 0.22727272727273
52540, 0.08695652173913, 1.1413043478261, 0.25
52541, 0.10869565217391, 1.1413043478261, 0.27272727272727
52542, 0.08695652173913, 1.1152173913043, 0.27272727272727
52543, 0.08695652173913, 1.1413043478261, 0.29545454545455
52544, 0.10869565217391, 1.1413043478261, 0.31818181818182
52545, 0.08695652173913, 1.1152173913043, 0.31818181818182
52546, 0.08695652173913, 1.1413043478261, 0.34090909090909
52547, 0.10869565217391, 1.1413043478261, 0.36363636363636
52548, 0.08695652173913, 1.1152173913043, 0.36363636363636
52549, 0.08695652173913, 1.1413043478261, 0.38636363636364
52550, 0.10869565217391, 1.1413043478261, 0.40909090909091
52551, 0.08695652173913, 1.1152173913043, 0.40909090909091
52552, 0.08695652173913, 1.1413043478261, 0.43181818181818
52553, 0.10869565217391, 1.1413043478261, 0.45454545454545
52554, 0.08695652173913, 1.1152173913043, 0.45454545454545
52555, 0.08695652173913, 1.1413043478261, 0.47727272727273
52556, 0.043478260869565, 1.1413043478261, 0.022727272727273
52557, 0.065217391304348, 1.1413043478261, 0.045454545454545
52558, 0.043478260869565, 1.1152173913043, 0.045454545454545
52559, 0.043478260869565, 1.1413043478261, 0.068181818181818
52560, 0.065217391304348, 1.1413043478261, 0.090909090909091
52561, 0.043478260869565, 1.1152173913043, 0.090909090909091
52562, 0.043478260869565, 1.1413043478261, 0.11363636363636
52563, 0.065217391304348, 1.1413043478261, 0.13636363636364
52564, 0.043478260869565, 1.1152173913043, 0.13636363636364
52565, 0.043478260869565, 1.1413043478261, 0.15909090909091
52566, 0.065217391304348, 1.1413043478261, 0.18181818181818
52567, 0.043478260869565, 1.1152173913043, 0.18181818181818
52568, 0.043478260869565, 1.1413043478261, 0.20454545454545
52569, 0.065217391304348, 1.1413043478261, 0.22727272727273
52570, 0.043478260869565, 1.1152173913043, 0.22727272727273
52571, 0.043478260869565, 1.1413043478261, 0.25
52572, 0.065217391304348, 1.1413043478261, 0.27272727272727
52573, 0.043478260869565, 1.1152173913043, 0.27272727272727
52574, 0.043478260869565, 1.1413043478261, 0.29545454545455
52575, 0.065217391304348, 1.1413043478261, 0.31818181818182
52576, 0.043478260869565, 1.1152173913043, 0.31818181818182
52577, 0.043478260869565, 1.1413043478261, 0.34090909090909
52578, 0.065217391304348, 1.1413043478261, 0.36363636363636
52579, 0.043478260869565, 1.1152173913043, 0.36363636363636
52580, 0.043478260869565, 1.1413043478261, 0.38636363636364
52581, 0.065217391304348, 1.1413043478261, 0.40909090909091
52582, 0.043478260869565, 1.1152173913043, 0.40909090909091
52583, 0.043478260869565, 1.1413043478261, 0.43181818181818
52584, 0.065217391304348, 1.1413043478261, 0.45454545454545
52585, 0.043478260869565, 1.1152173913043, 0.45454545454545
52586, 0.043478260869565, 1.1413043478261, 0.47727272727273
52587, 0.021739130434783, 1.1413043478261, 0.045454545454545
52588, 0.021739130434783, 1.1413043478261, 0.090909090909091
52589, 0.021739130434783, 1.1413043478261, 0.13636363636364
52590, 0.021739130434783, 1.1413043478261, 0.18181818181818
52591, 0.021739130434783, 1.1413043478261, 0.22727272727273
52592, 0.021739130434783, 1.1413043478261, 0.27272727272727
52593, 0.021739130434783, 1.1413043478261, 0.31818181818182
52594, 0.021739130434783, 1.1413043478261, 0.36363636363636
52595, 0.021739130434783, 1.1413043478261, 0.40909090909091
52596, 0.021739130434783, 1.1413043478261, 0.45454545454545
52597, 0.95652173913043, 1.1934782608696, 0.022727272727273
52598, 0.97826086956522, 1.1934782608696, 0.045454545454545
52599, 0.95652173913043, 1.1673913043478, 0.045454545454545
52600, 0.95652173913043, 1.1934782608696, 0.068181818181818
52601, 0.97826086956522, 1.1934782608696, 0.090909090909091
52602, 0.95652173913043, 1.1673913043478, 0.090909090909091
52603, 0.95652173913043, 1.1934782608696, 0.11363636363636
52604, 0.97826086956522, 1.1934782608696, 0.13636363636364
52605, 0.95652173913044, 1.1673913043478, 0.13636363636364
52606, 0.95652173913044, 1.1934782608696, 0.15909090909091
52607, 0.97826086956522, 1.1934782608696, 0.18181818181818
52608, 0.95652173913044, 1.1673913043478, 0.18181818181818
52609, 0.95652173913044, 1.1934782608696, 0.20454545454545
52610, 0.97826086956522, 1.1934782608696, 0.22727272727273
52611, 0.95652173913044, 1.1673913043478, 0.22727272727273
52612, 0.95652173913044, 1.1934782608696, 0.25
52613, 0.97826086956522, 1.1934782608696, 0.27272727272727
52614, 0.95652173913044, 1.1673913043478, 0.27272727272727
52615, 0.95652173913044, 1.1934782608696, 0.29545454545455
52616, 0.97826086956522, 1.1934782608696, 0.31818181818182
52617, 0.95652173913044, 1.1673913043478, 0.31818181818182
52618, 0.95652173913043, 1.1934782608696, 0.34090909090909
52619, 0.97826086956522, 1.1934782608696, 0.36363636363636
52620, 0.95652173913043, 1.1673913043478, 0.36363636363636
52621, 0.95652173913043, 1.1934782608696, 0.38636363636364
52622, 0.97826086956522, 1.1934782608696, 0.40909090909091
52623, 0.95652173913043, 1.1673913043478, 0.40909090909091
52624, 0.95652173913043, 1.1934782608696, 0.43181818181818
52625, 0.97826086956522, 1.1934782608696, 0.45454545454545
52626, 0.95652173913044, 1.1673913043478, 0.45454545454545
52627, 0.95652173913043, 1.1934782608696, 0.47727272727273
52628, 0.91304347826087, 1.1934782608696, 0.022727272727273
52629, 0.93478260869565, 1.1934782608696, 0.045454545454545
52630, 0.91304347826087, 1.1673913043478, 0.045454545454545
52631, 0.91304347826087, 1.1934782608696, 0.068181818181818
52632, 0.93478260869565, 1.1934782608696, 0.090909090909091
52633, 0.91304347826087, 1.1673913043478, 0.090909090909091
52634, 0.91304347826087, 1.1934782608696, 0.11363636363636
52635, 0.93478260869565, 1.1934782608696, 0.13636363636364
52636, 0.91304347826087, 1.1673913043478, 0.13636363636364
52637, 0.91304347826087, 1.1934782608696, 0.15909090909091
52638, 0.93478260869565, 1.1934782608696, 0.18181818181818
52639, 0.91304347826087, 1.1673913043478, 0.18181818181818
52640, 0.91304347826087, 1.1934782608696, 0.20454545454545
52641, 0.93478260869565, 1.1934782608696, 0.22727272727273
52642, 0.91304347826087, 1.1673913043478, 0.22727272727273
52643, 0.91304347826087, 1.1934782608696, 0.25
52644, 0.93478260869565, 1.1934782608696, 0.27272727272727
52645, 0.91304347826087, 1.1673913043478, 0.27272727272727
52646, 0.91304347826087, 1.1934782608696, 0.29545454545455
52647, 0.93478260869565, 1.1934782608696, 0.31818181818182
52648, 0.91304347826087, 1.1673913043478, 0.31818181818182
52649, 0.91304347826087, 1.1934782608696, 0.34090909090909
52650, 0.93478260869565, 1.1934782608696, 0.36363636363636
52651, 0.91304347826087, 1.1673913043478, 0.36363636363636
52652, 0.91304347826087, 1.1934782608696, 0.38636363636364
52653, 0.93478260869565, 1.1934782608696, 0.40909090909091
52654, 0.91304347826087, 1.1673913043478, 0.40909090909091
52655, 0.91304347826087, 1.1934782608696, 0.43181818181818
52656, 0.93478260869565, 1.1934782608696, 0.45454545454545
52657, 0.91304347826087, 1.1673913043478, 0.45454545454545
52658, 0.91304347826087, 1.1934782608696, 0.47727272727273
52659, 0.8695652173913, 1.1934782608696, 0.022727272727273
52660, 0.89130434782609, 1.1934782608696, 0.045454545454545
52661, 0.8695652173913, 1.1673913043478, 0.045454545454545
52662, 0.8695652173913, 1.1934782608696, 0.068181818181818
52663, 0.89130434782609, 1.1934782608696, 0.090909090909091
52664, 0.8695652173913, 1.1673913043478, 0.090909090909091
52665, 0.8695652173913, 1.1934782608696, 0.11363636363636
52666, 0.89130434782609, 1.1934782608696, 0.13636363636364
52667, 0.8695652173913, 1.1673913043478, 0.13636363636364
52668, 0.8695652173913, 1.1934782608696, 0.15909090909091
52669, 0.89130434782609, 1.1934782608696, 0.18181818181818
52670, 0.8695652173913, 1.1673913043478, 0.18181818181818
52671, 0.8695652173913, 1.1934782608696, 0.20454545454545
52672, 0.89130434782609, 1.1934782608696, 0.22727272727273
52673, 0.8695652173913, 1.1673913043478, 0.22727272727273
52674, 0.8695652173913, 1.1934782608696, 0.25
52675, 0.89130434782609, 1.1934782608696, 0.27272727272727
52676, 0.8695652173913, 1.1673913043478, 0.27272727272727
52677, 0.8695652173913, 1.1934782608696, 0.29545454545455
52678, 0.89130434782609, 1.1934782608696, 0.31818181818182
52679, 0.8695652173913, 1.1673913043478, 0.31818181818182
52680, 0.8695652173913, 1.1934782608696, 0.34090909090909
52681, 0.89130434782609, 1.1934782608696, 0.36363636363636
52682, 0.8695652173913, 1.1673913043478, 0.36363636363636
52683, 0.8695652173913, 1.1934782608696, 0.38636363636364
52684, 0.89130434782609, 1.1934782608696, 0.40909090909091
52685, 0.8695652173913, 1.1673913043478, 0.40909090909091
52686, 0.8695652173913, 1.1934782608696, 0.43181818181818
52687, 0.89130434782609, 1.1934782608696, 0.45454545454545
52688, 0.8695652173913, 1.1673913043478, 0.45454545454545
52689, 0.8695652173913, 1.1934782608696, 0.47727272727273
52690, 0.82608695652174, 1.1934782608696, 0.022727272727273
52691, 0.84782608695652, 1.1934782608696, 0.045454545454545
52692, 0.82608695652174, 1.1673913043478, 0.045454545454545
52693, 0.82608695652174, 1.1934782608696, 0.068181818181818
52694, 0.84782608695652, 1.1934782608696, 0.090909090909091
52695, 0.82608695652174, 1.1673913043478, 0.090909090909091
52696, 0.82608695652174, 1.1934782608696, 0.11363636363636
52697, 0.84782608695652, 1.1934782608696, 0.13636363636364
52698, 0.82608695652174, 1.1673913043478, 0.13636363636364
52699, 0.82608695652174, 1.1934782608696, 0.15909090909091
52700, 0.84782608695652, 1.1934782608696, 0.18181818181818
52701, 0.82608695652174, 1.1673913043478, 0.18181818181818
52702, 0.82608695652174, 1.1934782608696, 0.20454545454545
52703, 0.84782608695652, 1.1934782608696, 0.22727272727273
52704, 0.82608695652174, 1.1673913043478, 0.22727272727273
52705, 0.82608695652174, 1.1934782608696, 0.25
52706, 0.84782608695652, 1.1934782608696, 0.27272727272727
52707, 0.82608695652174, 1.1673913043478, 0.27272727272727
52708, 0.82608695652174, 1.1934782608696, 0.29545454545455
52709, 0.84782608695652, 1.1934782608696, 0.31818181818182
52710, 0.82608695652174, 1.1673913043478, 0.31818181818182
52711, 0.82608695652174, 1.1934782608696, 0.34090909090909
52712, 0.84782608695652, 1.1934782608696, 0.36363636363636
52713, 0.82608695652174, 1.1673913043478, 0.36363636363636
52714, 0.82608695652174, 1.1934782608696, 0.38636363636364
52715, 0.84782608695652, 1.1934782608696, 0.40909090909091
52716, 0.82608695652174, 1.1673913043478, 0.40909090909091
52717, 0.82608695652174, 1.1934782608696, 0.43181818181818
52718, 0.84782608695652, 1.1934782608696, 0.45454545454545
52719, 0.82608695652174, 1.1673913043478, 0.45454545454545
52720, 0.82608695652174, 1.1934782608696, 0.47727272727273
52721, 0.78260869565217, 1.1934782608696, 0.022727272727273
52722, 0.80434782608696, 1.1934782608696, 0.045454545454545
52723, 0.78260869565217, 1.1673913043478, 0.045454545454545
52724, 0.78260869565217, 1.1934782608696, 0.068181818181818
52725, 0.80434782608696, 1.1934782608696, 0.090909090909091
52726, 0.78260869565217, 1.1673913043478, 0.090909090909091
52727, 0.78260869565217, 1.1934782608696, 0.11363636363636
52728, 0.80434782608696, 1.1934782608696, 0.13636363636364
52729, 0.78260869565217, 1.1673913043478, 0.13636363636364
52730, 0.78260869565217, 1.1934782608696, 0.15909090909091
52731, 0.80434782608696, 1.1934782608696, 0.18181818181818
52732, 0.78260869565217, 1.1673913043478, 0.18181818181818
52733, 0.78260869565217, 1.1934782608696, 0.20454545454545
52734, 0.80434782608696, 1.1934782608696, 0.22727272727273
52735, 0.78260869565217, 1.1673913043478, 0.22727272727273
52736, 0.78260869565217, 1.1934782608696, 0.25
52737, 0.80434782608696, 1.1934782608696, 0.27272727272727
52738, 0.78260869565217, 1.1673913043478, 0.27272727272727
52739, 0.78260869565217, 1.1934782608696, 0.29545454545455
52740, 0.80434782608696, 1.1934782608696, 0.31818181818182
52741, 0.78260869565217, 1.1673913043478, 0.31818181818182
52742, 0.78260869565217, 1.1934782608696, 0.34090909090909
52743, 0.80434782608696, 1.1934782608696, 0.36363636363636
52744, 0.78260869565217, 1.1673913043478, 0.36363636363636
52745, 0.78260869565217, 1.1934782608696, 0.38636363636364
52746, 0.80434782608696, 1.1934782608696, 0.40909090909091
52747, 0.78260869565217, 1.1673913043478, 0.40909090909091
52748, 0.78260869565217, 1.1934782608696, 0.43181818181818
52749, 0.80434782608696, 1.1934782608696, 0.45454545454545
52750, 0.78260869565217, 1.1673913043478, 0.45454545454545
52751, 0.78260869565217, 1.1934782608696, 0.47727272727273
52752, 0.73913043478261, 1.1934782608696, 0.022727272727273
52753, 0.76086956521739, 1.1934782608696, 0.045454545454545
52754, 0.73913043478261, 1.1673913043478, 0.045454545454545
52755, 0.73913043478261, 1.1934782608696, 0.068181818181818
52756, 0.76086956521739, 1.1934782608696, 0.090909090909091
52757, 0.73913043478261, 1.1673913043478, 0.090909090909091
52758, 0.73913043478261, 1.1934782608696, 0.11363636363636
52759, 0.76086956521739, 1.1934782608696, 0.13636363636364
52760, 0.73913043478261, 1.1673913043478, 0.13636363636364
52761, 0.73913043478261, 1.1934782608696, 0.15909090909091
52762, 0.76086956521739, 1.1934782608696, 0.18181818181818
52763, 0.73913043478261, 1.1673913043478, 0.18181818181818
52764, 0.73913043478261, 1.1934782608696, 0.20454545454545
52765, 0.76086956521739, 1.1934782608696, 0.22727272727273
52766, 0.73913043478261, 1.1673913043478, 0.22727272727273
52767, 0.73913043478261, 1.1934782608696, 0.25
52768, 0.76086956521739, 1.1934782608696, 0.27272727272727
52769, 0.73913043478261, 1.1673913043478, 0.27272727272727
52770, 0.73913043478261, 1.1934782608696, 0.29545454545455
52771, 0.76086956521739, 1.1934782608696, 0.31818181818182
52772, 0.73913043478261, 1.1673913043478, 0.31818181818182
52773, 0.73913043478261, 1.1934782608696, 0.34090909090909
52774, 0.76086956521739, 1.1934782608696, 0.36363636363636
52775, 0.73913043478261, 1.1673913043478, 0.36363636363636
52776, 0.73913043478261, 1.1934782608696, 0.38636363636364
52777, 0.76086956521739, 1.1934782608696, 0.40909090909091
52778, 0.73913043478261, 1.1673913043478, 0.40909090909091
52779, 0.73913043478261, 1.1934782608696, 0.43181818181818
52780, 0.76086956521739, 1.1934782608696, 0.45454545454545
52781, 0.73913043478261, 1.1673913043478, 0.45454545454545
52782, 0.73913043478261, 1.1934782608696, 0.47727272727273
52783, 0.69565217391304, 1.1934782608696, 0.022727272727273
52784, 0.71739130434783, 1.1934782608696, 0.045454545454545
52785, 0.69565217391304, 1.1673913043478, 0.045454545454545
52786, 0.69565217391304, 1.1934782608696, 0.068181818181818
52787, 0.71739130434783, 1.1934782608696, 0.090909090909091
52788, 0.69565217391304, 1.1673913043478, 0.090909090909091
52789, 0.69565217391304, 1.1934782608696, 0.11363636363636
52790, 0.71739130434783, 1.1934782608696, 0.13636363636364
52791, 0.69565217391304, 1.1673913043478, 0.13636363636364
52792, 0.69565217391304, 1.1934782608696, 0.15909090909091
52793, 0.71739130434783, 1.1934782608696, 0.18181818181818
52794, 0.69565217391304, 1.1673913043478, 0.18181818181818
52795, 0.69565217391304, 1.1934782608696, 0.20454545454545
52796, 0.71739130434783, 1.1934782608696, 0.22727272727273
52797, 0.69565217391304, 1.1673913043478, 0.22727272727273
52798, 0.69565217391304, 1.1934782608696, 0.25
52799, 0.71739130434783, 1.1934782608696, 0.27272727272727
52800, 0.69565217391304, 1.1673913043478, 0.27272727272727
52801, 0.69565217391304, 1.1934782608696, 0.29545454545455
52802, 0.71739130434783, 1.1934782608696, 0.31818181818182
52803, 0.69565217391304, 1.1673913043478, 0.31818181818182
52804, 0.69565217391304, 1.1934782608696, 0.34090909090909
52805, 0.71739130434783, 1.1934782608696, 0.36363636363636
52806, 0.69565217391304, 1.1673913043478, 0.36363636363636
52807, 0.69565217391304, 1.1934782608696, 0.38636363636364
52808, 0.71739130434783, 1.1934782608696, 0.40909090909091
52809, 0.69565217391304, 1.1673913043478, 0.40909090909091
52810, 0.69565217391304, 1.1934782608696, 0.43181818181818
52811, 0.71739130434783, 1.1934782608696, 0.45454545454545
52812, 0.69565217391304, 1.1673913043478, 0.45454545454545
52813, 0.69565217391304, 1.1934782608696, 0.47727272727273
52814, 0.65217391304348, 1.1934782608696, 0.022727272727273
52815, 0.67391304347826, 1.1934782608696, 0.045454545454545
52816, 0.65217391304348, 1.1673913043478, 0.045454545454545
52817, 0.65217391304348, 1.1934782608696, 0.068181818181818
52818, 0.67391304347826, 1.1934782608696, 0.090909090909091
52819, 0.65217391304348, 1.1673913043478, 0.090909090909091
52820, 0.65217391304348, 1.1934782608696, 0.11363636363636
52821, 0.67391304347826, 1.1934782608696, 0.13636363636364
52822, 0.65217391304348, 1.1673913043478, 0.13636363636364
52823, 0.65217391304348, 1.1934782608696, 0.15909090909091
52824, 0.67391304347826, 1.1934782608696, 0.18181818181818
52825, 0.65217391304348, 1.1673913043478, 0.18181818181818
52826, 0.65217391304348, 1.1934782608696, 0.20454545454545
52827, 0.67391304347826, 1.1934782608696, 0.22727272727273
52828, 0.65217391304348, 1.1673913043478, 0.22727272727273
52829, 0.65217391304348, 1.1934782608696, 0.25
52830, 0.67391304347826, 1.1934782608696, 0.27272727272727
52831, 0.65217391304348, 1.1673913043478, 0.27272727272727
52832, 0.65217391304348, 1.1934782608696, 0.29545454545455
52833, 0.67391304347826, 1.1934782608696, 0.31818181818182
52834, 0.65217391304348, 1.1673913043478, 0.31818181818182
52835, 0.65217391304348, 1.1934782608696, 0.34090909090909
52836, 0.67391304347826, 1.1934782608696, 0.36363636363636
52837, 0.65217391304348, 1.1673913043478, 0.36363636363636
52838, 0.65217391304348, 1.1934782608696, 0.38636363636364
52839, 0.67391304347826, 1.1934782608696, 0.40909090909091
52840, 0.65217391304348, 1.1673913043478, 0.40909090909091
52841, 0.65217391304348, 1.1934782608696, 0.43181818181818
52842, 0.67391304347826, 1.1934782608696, 0.45454545454545
52843, 0.65217391304348, 1.1673913043478, 0.45454545454545
52844, 0.65217391304348, 1.1934782608696, 0.47727272727273
52845, 0.60869565217391, 1.1934782608696, 0.022727272727273
52846, 0.6304347826087, 1.1934782608696, 0.045454545454545
52847, 0.60869565217391, 1.1673913043478, 0.045454545454545
52848, 0.60869565217391, 1.1934782608696, 0.068181818181818
52849, 0.6304347826087, 1.1934782608696, 0.090909090909091
52850, 0.60869565217391, 1.1673913043478, 0.090909090909091
52851, 0.60869565217391, 1.1934782608696, 0.11363636363636
52852, 0.6304347826087, 1.1934782608696, 0.13636363636364
52853, 0.60869565217391, 1.1673913043478, 0.13636363636364
52854, 0.60869565217391, 1.1934782608696, 0.15909090909091
52855, 0.6304347826087, 1.1934782608696, 0.18181818181818
52856, 0.60869565217391, 1.1673913043478, 0.18181818181818
52857, 0.60869565217391, 1.1934782608696, 0.20454545454545
52858, 0.6304347826087, 1.1934782608696, 0.22727272727273
52859, 0.60869565217391, 1.1673913043478, 0.22727272727273
52860, 0.60869565217391, 1.1934782608696, 0.25
52861, 0.6304347826087, 1.1934782608696, 0.27272727272727
52862, 0.60869565217391, 1.1673913043478, 0.27272727272727
52863, 0.60869565217391, 1.1934782608696, 0.29545454545455
52864, 0.6304347826087, 1.1934782608696, 0.31818181818182
52865, 0.60869565217391, 1.1673913043478, 0.31818181818182
52866, 0.60869565217391, 1.1934782608696, 0.34090909090909
52867, 0.6304347826087, 1.1934782608696, 0.36363636363636
52868, 0.60869565217391, 1.1673913043478, 0.36363636363636
52869, 0.60869565217391, 1.1934782608696, 0.38636363636364
52870, 0.6304347826087, 1.1934782608696, 0.40909090909091
52871, 0.60869565217391, 1.1673913043478, 0.40909090909091
52872, 0.60869565217391, 1.1934782608696, 0.43181818181818
52873, 0.6304347826087, 1.1934782608696, 0.45454545454545
52874, 0.60869565217391, 1.1673913043478, 0.45454545454545
52875, 0.60869565217391, 1.1934782608696, 0.47727272727273
52876, 0.56521739130435, 1.1934782608696, 0.022727272727273
52877, 0.58695652173913, 1.1934782608696, 0.045454545454545
52878, 0.56521739130435, 1.1673913043478, 0.045454545454545
52879, 0.56521739130435, 1.1934782608696, 0.068181818181818
52880, 0.58695652173913, 1.1934782608696, 0.090909090909091
52881, 0.56521739130435, 1.1673913043478, 0.090909090909091
52882, 0.56521739130435, 1.1934782608696, 0.11363636363636
52883, 0.58695652173913, 1.1934782608696, 0.13636363636364
52884, 0.56521739130435, 1.1673913043478, 0.13636363636364
52885, 0.56521739130435, 1.1934782608696, 0.15909090909091
52886, 0.58695652173913, 1.1934782608696, 0.18181818181818
52887, 0.56521739130435, 1.1673913043478, 0.18181818181818
52888, 0.56521739130435, 1.1934782608696, 0.20454545454545
52889, 0.58695652173913, 1.1934782608696, 0.22727272727273
52890, 0.56521739130435, 1.1673913043478, 0.22727272727273
52891, 0.56521739130435, 1.1934782608696, 0.25
52892, 0.58695652173913, 1.1934782608696, 0.27272727272727
52893, 0.56521739130435, 1.1673913043478, 0.27272727272727
52894, 0.56521739130435, 1.1934782608696, 0.29545454545455
52895, 0.58695652173913, 1.1934782608696, 0.31818181818182
52896, 0.56521739130435, 1.1673913043478, 0.31818181818182
52897, 0.56521739130435, 1.1934782608696, 0.34090909090909
52898, 0.58695652173913, 1.1934782608696, 0.36363636363636
52899, 0.56521739130435, 1.1673913043478, 0.36363636363636
52900, 0.56521739130435, 1.1934782608696, 0.38636363636364
52901, 0.58695652173913, 1.1934782608696, 0.40909090909091
52902, 0.56521739130435, 1.1673913043478, 0.40909090909091
52903, 0.56521739130435, 1.1934782608696, 0.43181818181818
52904, 0.58695652173913, 1.1934782608696, 0.45454545454545
52905, 0.56521739130435, 1.1673913043478, 0.45454545454545
52906, 0.56521739130435, 1.1934782608696, 0.47727272727273
52907, 0.52173913043478, 1.1934782608696, 0.022727272727273
52908, 0.54347826086956, 1.1934782608696, 0.045454545454545
52909, 0.52173913043478, 1.1673913043478, 0.045454545454545
52910, 0.52173913043478, 1.1934782608696, 0.068181818181818
52911, 0.54347826086956, 1.1934782608696, 0.090909090909091
52912, 0.52173913043478, 1.1673913043478, 0.090909090909091
52913, 0.52173913043478, 1.1934782608696, 0.11363636363636
52914, 0.54347826086956, 1.1934782608696, 0.13636363636364
52915, 0.52173913043478, 1.1673913043478, 0.13636363636364
52916, 0.52173913043478, 1.1934782608696, 0.15909090909091
52917, 0.54347826086956, 1.1934782608696, 0.18181818181818
52918, 0.52173913043478, 1.1673913043478, 0.18181818181818
52919, 0.52173913043478, 1.1934782608696, 0.20454545454545
52920, 0.54347826086956, 1.1934782608696, 0.22727272727273
52921, 0.52173913043478, 1.1673913043478, 0.22727272727273
52922, 0.52173913043478, 1.1934782608696, 0.25
52923, 0.54347826086956, 1.1934782608696, 0.27272727272727
52924, 0.52173913043478, 1.1673913043478, 0.27272727272727
52925, 0.52173913043478, 1.1934782608696, 0.29545454545455
52926, 0.54347826086956, 1.1934782608696, 0.31818181818182
52927, 0.52173913043478, 1.1673913043478, 0.31818181818182
52928, 0.52173913043478, 1.1934782608696, 0.34090909090909
52929, 0.54347826086957, 1.1934782608696, 0.36363636363636
52930, 0.52173913043478, 1.1673913043478, 0.36363636363636
52931, 0.52173913043478, 1.1934782608696, 0.38636363636364
52932, 0.54347826086956, 1.1934782608696, 0.40909090909091
52933, 0.52173913043478, 1.1673913043478, 0.40909090909091
52934, 0.52173913043478, 1.1934782608696, 0.43181818181818
52935, 0.54347826086956, 1.1934782608696, 0.45454545454545
52936, 0.52173913043478, 1.1673913043478, 0.45454545454545
52937, 0.52173913043478, 1.1934782608696, 0.47727272727273
52938, 0.47826086956522, 1.1934782608696, 0.022727272727273
52939, 0.5, 1.1934782608696, 0.045454545454545
52940, 0.47826086956522, 1.1673913043478, 0.045454545454545
52941, 0.47826086956522, 1.1934782608696, 0.068181818181818
52942, 0.5, 1.1934782608696, 0.090909090909091
52943, 0.47826086956522, 1.1673913043478, 0.090909090909091
52944, 0.47826086956522, 1.1934782608696, 0.11363636363636
52945, 0.5, 1.1934782608696, 0.13636363636364
52946, 0.47826086956522, 1.1673913043478, 0.13636363636364
52947, 0.47826086956522, 1.1934782608696, 0.15909090909091
52948, 0.5, 1.1934782608696, 0.18181818181818
52949, 0.47826086956522, 1.1673913043478, 0.18181818181818
52950, 0.47826086956522, 1.1934782608696, 0.20454545454545
52951, 0.5, 1.1934782608696, 0.22727272727273
52952, 0.47826086956522, 1.1673913043478, 0.22727272727273
52953, 0.47826086956522, 1.1934782608696, 0.25
52954, 0.5, 1.1934782608696, 0.27272727272727
52955, 0.47826086956522, 1.1673913043478, 0.27272727272727
52956, 0.47826086956522, 1.1934782608696, 0.29545454545455
52957, 0.5, 1.1934782608696, 0.31818181818182
52958, 0.47826086956522, 1.1673913043478, 0.31818181818182
52959, 0.47826086956522, 1.1934782608696, 0.34090909090909
52960, 0.5, 1.1934782608696, 0.36363636363636
52961, 0.47826086956522, 1.1673913043478, 0.36363636363636
52962, 0.47826086956522, 1.1934782608696, 0.38636363636364
52963, 0.5, 1.1934782608696, 0.40909090909091
52964, 0.47826086956522, 1.1673913043478, 0.40909090909091
52965, 0.47826086956522, 1.1934782608696, 0.43181818181818
52966, 0.5, 1.1934782608696, 0.45454545454545
52967, 0.47826086956522, 1.1673913043478, 0.45454545454545
52968, 0.47826086956522, 1.1934782608696, 0.47727272727273
52969, 0.43478260869565, 1.1934782608696, 0.022727272727273
52970, 0.45652173913043, 1.1934782608696, 0.045454545454545
52971, 0.43478260869565, 1.1673913043478, 0.045454545454545
52972, 0.43478260869565, 1.1934782608696, 0.068181818181818
52973, 0.45652173913043, 1.1934782608696, 0.090909090909091
52974, 0.43478260869565, 1.1673913043478, 0.090909090909091
52975, 0.43478260869565, 1.1934782608696, 0.11363636363636
52976, 0.45652173913043, 1.1934782608696, 0.13636363636364
52977, 0.43478260869565, 1.1673913043478, 0.13636363636364
52978, 0.43478260869565, 1.1934782608696, 0.15909090909091
52979, 0.45652173913043, 1.1934782608696, 0.18181818181818
52980, 0.43478260869565, 1.1673913043478, 0.18181818181818
52981, 0.43478260869565, 1.1934782608696, 0.20454545454545
52982, 0.45652173913043, 1.1934782608696, 0.22727272727273
52983, 0.43478260869565, 1.1673913043478, 0.22727272727273
52984, 0.43478260869565, 1.1934782608696, 0.25
52985, 0.45652173913043, 1.1934782608696, 0.27272727272727
52986, 0.43478260869565, 1.1673913043478, 0.27272727272727
52987, 0.43478260869565, 1.1934782608696, 0.29545454545455
52988, 0.45652173913043, 1.1934782608696, 0.31818181818182
52989, 0.43478260869565, 1.1673913043478, 0.31818181818182
52990, 0.43478260869565, 1.1934782608696, 0.34090909090909
52991, 0.45652173913043, 1.1934782608696, 0.36363636363636
52992, 0.43478260869565, 1.1673913043478, 0.36363636363636
52993, 0.43478260869565, 1.1934782608696, 0.38636363636364
52994, 0.45652173913043, 1.1934782608696, 0.40909090909091
52995, 0.43478260869565, 1.1673913043478, 0.40909090909091
52996, 0.43478260869565, 1.1934782608696, 0.43181818181818
52997, 0.45652173913043, 1.1934782608696, 0.45454545454545
52998, 0.43478260869565, 1.1673913043478, 0.45454545454545
52999, 0.43478260869565, 1.1934782608696, 0.47727272727273
53000, 0.39130434782609, 1.1934782608696, 0.022727272727273
53001, 0.41304347826087, 1.1934782608696, 0.045454545454545
53002, 0.39130434782609, 1.1673913043478, 0.045454545454545
53003, 0.39130434782609, 1.1934782608696, 0.068181818181818
53004, 0.41304347826087, 1.1934782608696, 0.090909090909091
53005, 0.39130434782609, 1.1673913043478, 0.090909090909091
53006, 0.39130434782609, 1.1934782608696, 0.11363636363636
53007, 0.41304347826087, 1.1934782608696, 0.13636363636364
53008, 0.39130434782609, 1.1673913043478, 0.13636363636364
53009, 0.39130434782609, 1.1934782608696, 0.15909090909091
53010, 0.41304347826087, 1.1934782608696, 0.18181818181818
53011, 0.39130434782609, 1.1673913043478, 0.18181818181818
53012, 0.39130434782609, 1.1934782608696, 0.20454545454545
53013, 0.41304347826087, 1.1934782608696, 0.22727272727273
53014, 0.39130434782609, 1.1673913043478, 0.22727272727273
53015, 0.39130434782609, 1.1934782608696, 0.25
53016, 0.41304347826087, 1.1934782608696, 0.27272727272727
53017, 0.39130434782609, 1.1673913043478, 0.27272727272727
53018, 0.39130434782609, 1.1934782608696, 0.29545454545455
53019, 0.41304347826087, 1.1934782608696, 0.31818181818182
53020, 0.39130434782609, 1.1673913043478, 0.31818181818182
53021, 0.39130434782609, 1.1934782608696, 0.34090909090909
53022, 0.41304347826087, 1.1934782608696, 0.36363636363636
53023, 0.39130434782609, 1.1673913043478, 0.36363636363636
53024, 0.39130434782609, 1.1934782608696, 0.38636363636364
53025, 0.41304347826087, 1.1934782608696, 0.40909090909091
53026, 0.39130434782609, 1.1673913043478, 0.40909090909091
53027, 0.39130434782609, 1.1934782608696, 0.43181818181818
53028, 0.41304347826087, 1.1934782608696, 0.45454545454545
53029, 0.39130434782609, 1.1673913043478, 0.45454545454545
53030, 0.39130434782609, 1.1934782608696, 0.47727272727273
53031, 0.34782608695652, 1.1934782608696, 0.022727272727273
53032, 0.3695652173913, 1.1934782608696, 0.045454545454545
53033, 0.34782608695652, 1.1673913043478, 0.045454545454545
53034, 0.34782608695652, 1.1934782608696, 0.068181818181818
53035, 0.3695652173913, 1.1934782608696, 0.090909090909091
53036, 0.34782608695652, 1.1673913043478, 0.090909090909091
53037, 0.34782608695652, 1.1934782608696, 0.11363636363636
53038, 0.3695652173913, 1.1934782608696, 0.13636363636364
53039, 0.34782608695652, 1.1673913043478, 0.13636363636364
53040, 0.34782608695652, 1.1934782608696, 0.15909090909091
53041, 0.3695652173913, 1.1934782608696, 0.18181818181818
53042, 0.34782608695652, 1.1673913043478, 0.18181818181818
53043, 0.34782608695652, 1.1934782608696, 0.20454545454545
53044, 0.3695652173913, 1.1934782608696, 0.22727272727273
53045, 0.34782608695652, 1.1673913043478, 0.22727272727273
53046, 0.34782608695652, 1.1934782608696, 0.25
53047, 0.3695652173913, 1.1934782608696, 0.27272727272727
53048, 0.34782608695652, 1.1673913043478, 0.27272727272727
53049, 0.34782608695652, 1.1934782608696, 0.29545454545455
53050, 0.3695652173913, 1.1934782608696, 0.31818181818182
53051, 0.34782608695652, 1.1673913043478, 0.31818181818182
53052, 0.34782608695652, 1.1934782608696, 0.34090909090909
53053, 0.3695652173913, 1.1934782608696, 0.36363636363636
53054, 0.34782608695652, 1.1673913043478, 0.36363636363636
53055, 0.34782608695652, 1.1934782608696, 0.38636363636364
53056, 0.3695652173913, 1.1934782608696, 0.40909090909091
53057, 0.34782608695652, 1.1673913043478, 0.40909090909091
53058, 0.34782608695652, 1.1934782608696, 0.43181818181818
53059, 0.3695652173913, 1.1934782608696, 0.45454545454545
53060, 0.34782608695652, 1.1673913043478, 0.45454545454545
53061, 0.34782608695652, 1.1934782608696, 0.47727272727273
53062, 0.30434782608696, 1.1934782608696, 0.022727272727273
53063, 0.32608695652174, 1.1934782608696, 0.045454545454545
53064, 0.30434782608696, 1.1673913043478, 0.045454545454545
53065, 0.30434782608696, 1.1934782608696, 0.068181818181818
53066, 0.32608695652174, 1.1934782608696, 0.090909090909091
53067, 0.30434782608696, 1.1673913043478, 0.090909090909091
53068, 0.30434782608696, 1.1934782608696, 0.11363636363636
53069, 0.32608695652174, 1.1934782608696, 0.13636363636364
53070, 0.30434782608696, 1.1673913043478, 0.13636363636364
53071, 0.30434782608696, 1.1934782608696, 0.15909090909091
53072, 0.32608695652174, 1.1934782608696, 0.18181818181818
53073, 0.30434782608696, 1.1673913043478, 0.18181818181818
53074, 0.30434782608696, 1.1934782608696, 0.20454545454545
53075, 0.32608695652174, 1.1934782608696, 0.22727272727273
53076, 0.30434782608696, 1.1673913043478, 0.22727272727273
53077, 0.30434782608696, 1.1934782608696, 0.25
53078, 0.32608695652174, 1.1934782608696, 0.27272727272727
53079, 0.30434782608696, 1.1673913043478, 0.27272727272727
53080, 0.30434782608696, 1.1934782608696, 0.29545454545455
53081, 0.32608695652174, 1.1934782608696, 0.31818181818182
53082, 0.30434782608696, 1.1673913043478, 0.31818181818182
53083, 0.30434782608696, 1.1934782608696, 0.34090909090909
53084, 0.32608695652174, 1.1934782608696, 0.36363636363636
53085, 0.30434782608696, 1.1673913043478, 0.36363636363636
53086, 0.30434782608696, 1.1934782608696, 0.38636363636364
53087, 0.32608695652174, 1.1934782608696, 0.40909090909091
53088, 0.30434782608696, 1.1673913043478, 0.40909090909091
53089, 0.30434782608696, 1.1934782608696, 0.43181818181818
53090, 0.32608695652174, 1.1934782608696, 0.45454545454545
53091, 0.30434782608696, 1.1673913043478, 0.45454545454545
53092, 0.30434782608696, 1.1934782608696, 0.47727272727273
53093, 0.26086956521739, 1.1934782608696, 0.022727272727273
53094, 0.28260869565217, 1.1934782608696, 0.045454545454545
53095, 0.26086956521739, 1.1673913043478, 0.045454545454545
53096, 0.26086956521739, 1.1934782608696, 0.068181818181818
53097, 0.28260869565217, 1.1934782608696, 0.090909090909091
53098, 0.26086956521739, 1.1673913043478, 0.090909090909091
53099, 0.26086956521739, 1.1934782608696, 0.11363636363636
53100, 0.28260869565217, 1.1934782608696, 0.13636363636364
53101, 0.26086956521739, 1.1673913043478, 0.13636363636364
53102, 0.26086956521739, 1.1934782608696, 0.15909090909091
53103, 0.28260869565217, 1.1934782608696, 0.18181818181818
53104, 0.26086956521739, 1.1673913043478, 0.18181818181818
53105, 0.26086956521739, 1.1934782608696, 0.20454545454545
53106, 0.28260869565217, 1.1934782608696, 0.22727272727273
53107, 0.26086956521739, 1.1673913043478, 0.22727272727273
53108, 0.26086956521739, 1.1934782608696, 0.25
53109, 0.28260869565217, 1.1934782608696, 0.27272727272727
53110, 0.26086956521739, 1.1673913043478, 0.27272727272727
53111, 0.26086956521739, 1.1934782608696, 0.29545454545455
53112, 0.28260869565217, 1.1934782608696, 0.31818181818182
53113, 0.26086956521739, 1.1673913043478, 0.31818181818182
53114, 0.26086956521739, 1.1934782608696, 0.34090909090909
53115, 0.28260869565217, 1.1934782608696, 0.36363636363636
53116, 0.26086956521739, 1.1673913043478, 0.36363636363636
53117, 0.26086956521739, 1.1934782608696, 0.38636363636364
53118, 0.28260869565217, 1.1934782608696, 0.40909090909091
53119, 0.26086956521739, 1.1673913043478, 0.40909090909091
53120, 0.26086956521739, 1.1934782608696, 0.43181818181818
53121, 0.28260869565217, 1.1934782608696, 0.45454545454545
53122, 0.26086956521739, 1.1673913043478, 0.45454545454545
53123, 0.26086956521739, 1.1934782608696, 0.47727272727273
53124, 0.21739130434783, 1.1934782608696, 0.022727272727273
53125, 0.23913043478261, 1.1934782608696, 0.045454545454545
53126, 0.21739130434783, 1.1673913043478, 0.045454545454545
53127, 0.21739130434783, 1.1934782608696, 0.068181818181818
53128, 0.23913043478261, 1.1934782608696, 0.090909090909091
53129, 0.21739130434783, 1.1673913043478, 0.090909090909091
53130, 0.21739130434783, 1.1934782608696, 0.11363636363636
53131, 0.23913043478261, 1.1934782608696, 0.13636363636364
53132, 0.21739130434783, 1.1673913043478, 0.13636363636364
53133, 0.21739130434783, 1.1934782608696, 0.15909090909091
53134, 0.23913043478261, 1.1934782608696, 0.18181818181818
53135, 0.21739130434783, 1.1673913043478, 0.18181818181818
53136, 0.21739130434783, 1.1934782608696, 0.20454545454545
53137, 0.23913043478261, 1.1934782608696, 0.22727272727273
53138, 0.21739130434783, 1.1673913043478, 0.22727272727273
53139, 0.21739130434783, 1.1934782608696, 0.25
53140, 0.23913043478261, 1.1934782608696, 0.27272727272727
53141, 0.21739130434783, 1.1673913043478, 0.27272727272727
53142, 0.21739130434783, 1.1934782608696, 0.29545454545455
53143, 0.23913043478261, 1.1934782608696, 0.31818181818182
53144, 0.21739130434783, 1.1673913043478, 0.31818181818182
53145, 0.21739130434783, 1.1934782608696, 0.34090909090909
53146, 0.23913043478261, 1.1934782608696, 0.36363636363636
53147, 0.21739130434783, 1.1673913043478, 0.36363636363636
53148, 0.21739130434783, 1.1934782608696, 0.38636363636364
53149, 0.23913043478261, 1.1934782608696, 0.40909090909091
53150, 0.21739130434783, 1.1673913043478, 0.40909090909091
53151, 0.21739130434783, 1.1934782608696, 0.43181818181818
53152, 0.23913043478261, 1.1934782608696, 0.45454545454545
53153, 0.21739130434783, 1.1673913043478, 0.45454545454545
53154, 0.21739130434783, 1.1934782608696, 0.47727272727273
53155, 0.17391304347826, 1.1934782608696, 0.022727272727273
53156, 0.19565217391304, 1.1934782608696, 0.045454545454545
53157, 0.17391304347826, 1.1673913043478, 0.045454545454545
53158, 0.17391304347826, 1.1934782608696, 0.068181818181818
53159, 0.19565217391304, 1.1934782608696, 0.090909090909091
53160, 0.17391304347826, 1.1673913043478, 0.090909090909091
53161, 0.17391304347826, 1.1934782608696, 0.11363636363636
53162, 0.19565217391304, 1.1934782608696, 0.13636363636364
53163, 0.17391304347826, 1.1673913043478, 0.13636363636364
53164, 0.17391304347826, 1.1934782608696, 0.15909090909091
53165, 0.19565217391304, 1.1934782608696, 0.18181818181818
53166, 0.17391304347826, 1.1673913043478, 0.18181818181818
53167, 0.17391304347826, 1.1934782608696, 0.20454545454545
53168, 0.19565217391304, 1.1934782608696, 0.22727272727273
53169, 0.17391304347826, 1.1673913043478, 0.22727272727273
53170, 0.17391304347826, 1.1934782608696, 0.25
53171, 0.19565217391304, 1.1934782608696, 0.27272727272727
53172, 0.17391304347826, 1.1673913043478, 0.27272727272727
53173, 0.17391304347826, 1.1934782608696, 0.29545454545455
53174, 0.19565217391304, 1.1934782608696, 0.31818181818182
53175, 0.17391304347826, 1.1673913043478, 0.31818181818182
53176, 0.17391304347826, 1.1934782608696, 0.34090909090909
53177, 0.19565217391304, 1.1934782608696, 0.36363636363636
53178, 0.17391304347826, 1.1673913043478, 0.36363636363636
53179, 0.17391304347826, 1.1934782608696, 0.38636363636364
53180, 0.19565217391304, 1.1934782608696, 0.40909090909091
53181, 0.17391304347826, 1.1673913043478, 0.40909090909091
53182, 0.17391304347826, 1.1934782608696, 0.43181818181818
53183, 0.19565217391304, 1.1934782608696, 0.45454545454545
53184, 0.17391304347826, 1.1673913043478, 0.45454545454545
53185, 0.17391304347826, 1.1934782608696, 0.47727272727273
53186, 0.1304347826087, 1.1934782608696, 0.022727272727273
53187, 0.15217391304348, 1.1934782608696, 0.045454545454545
53188, 0.1304347826087, 1.1673913043478, 0.045454545454545
53189, 0.1304347826087, 1.1934782608696, 0.068181818181818
53190, 0.15217391304348, 1.1934782608696, 0.090909090909091
53191, 0.1304347826087, 1.1673913043478, 0.090909090909091
53192, 0.1304347826087, 1.1934782608696, 0.11363636363636
53193, 0.15217391304348, 1.1934782608696, 0.13636363636364
53194, 0.1304347826087, 1.1673913043478, 0.13636363636364
53195, 0.1304347826087, 1.1934782608696, 0.15909090909091
53196, 0.15217391304348, 1.1934782608696, 0.18181818181818
53197, 0.1304347826087, 1.1673913043478, 0.18181818181818
53198, 0.1304347826087, 1.1934782608696, 0.20454545454545
53199, 0.15217391304348, 1.1934782608696, 0.22727272727273
53200, 0.1304347826087, 1.1673913043478, 0.22727272727273
53201, 0.1304347826087, 1.1934782608696, 0.25
53202, 0.15217391304348, 1.1934782608696, 0.27272727272727
53203, 0.1304347826087, 1.1673913043478, 0.27272727272727
53204, 0.1304347826087, 1.1934782608696, 0.29545454545455
53205, 0.15217391304348, 1.1934782608696, 0.31818181818182
53206, 0.1304347826087, 1.1673913043478, 0.31818181818182
53207, 0.1304347826087, 1.1934782608696, 0.34090909090909
53208, 0.15217391304348, 1.1934782608696, 0.36363636363636
53209, 0.1304347826087, 1.1673913043478, 0.36363636363636
53210, 0.1304347826087, 1.1934782608696, 0.38636363636364
53211, 0.15217391304348, 1.1934782608696, 0.40909090909091
53212, 0.1304347826087, 1.1673913043478, 0.40909090909091
53213, 0.1304347826087, 1.1934782608696, 0.43181818181818
53214, 0.15217391304348, 1.1934782608696, 0.45454545454545
53215, 0.1304347826087, 1.1673913043478, 0.45454545454545
53216, 0.1304347826087, 1.1934782608696, 0.47727272727273
53217, 0.08695652173913, 1.1934782608696, 0.022727272727273
53218, 0.10869565217391, 1.1934782608696, 0.045454545454545
53219, 0.08695652173913, 1.1673913043478, 0.045454545454545
53220, 0.08695652173913, 1.1934782608696, 0.068181818181818
53221, 0.10869565217391, 1.1934782608696, 0.090909090909091
53222, 0.08695652173913, 1.1673913043478, 0.090909090909091
53223, 0.08695652173913, 1.1934782608696, 0.11363636363636
53224, 0.10869565217391, 1.1934782608696, 0.13636363636364
53225, 0.08695652173913, 1.1673913043478, 0.13636363636364
53226, 0.08695652173913, 1.1934782608696, 0.15909090909091
53227, 0.10869565217391, 1.1934782608696, 0.18181818181818
53228, 0.08695652173913, 1.1673913043478, 0.18181818181818
53229, 0.08695652173913, 1.1934782608696, 0.20454545454545
53230, 0.10869565217391, 1.1934782608696, 0.22727272727273
53231, 0.08695652173913, 1.1673913043478, 0.22727272727273
53232, 0.08695652173913, 1.1934782608696, 0.25
53233, 0.10869565217391, 1.1934782608696, 0.27272727272727
53234, 0.08695652173913, 1.1673913043478, 0.27272727272727
53235, 0.08695652173913, 1.1934782608696, 0.29545454545455
53236, 0.10869565217391, 1.1934782608696, 0.31818181818182
53237, 0.08695652173913, 1.1673913043478, 0.31818181818182
53238, 0.08695652173913, 1.1934782608696, 0.34090909090909
53239, 0.10869565217391, 1.1934782608696, 0.36363636363636
53240, 0.08695652173913, 1.1673913043478, 0.36363636363636
53241, 0.08695652173913, 1.1934782608696, 0.38636363636364
53242, 0.10869565217391, 1.1934782608696, 0.40909090909091
53243, 0.08695652173913, 1.1673913043478, 0.40909090909091
53244, 0.08695652173913, 1.1934782608696, 0.43181818181818
53245, 0.10869565217391, 1.1934782608696, 0.45454545454545
53246, 0.08695652173913, 1.1673913043478, 0.45454545454545
53247, 0.08695652173913, 1.1934782608696, 0.47727272727273
53248, 0.043478260869565, 1.1934782608696, 0.022727272727273
53249, 0.065217391304348, 1.1934782608696, 0.045454545454545
53250, 0.043478260869565, 1.1673913043478, 0.045454545454545
53251, 0.043478260869565, 1.1934782608696, 0.068181818181818
53252, 0.065217391304348, 1.1934782608696, 0.090909090909091
53253, 0.043478260869565, 1.1673913043478, 0.090909090909091
53254, 0.043478260869565, 1.1934782608696, 0.11363636363636
53255, 0.065217391304348, 1.1934782608696, 0.13636363636364
53256, 0.043478260869565, 1.1673913043478, 0.13636363636364
53257, 0.043478260869565, 1.1934782608696, 0.15909090909091
53258, 0.065217391304348, 1.1934782608696, 0.18181818181818
53259, 0.043478260869565, 1.1673913043478, 0.18181818181818
53260, 0.043478260869565, 1.1934782608696, 0.20454545454545
53261, 0.065217391304348, 1.1934782608696, 0.22727272727273
53262, 0.043478260869565, 1.1673913043478, 0.22727272727273
53263, 0.043478260869565, 1.1934782608696, 0.25
53264, 0.065217391304348, 1.1934782608696, 0.27272727272727
53265, 0.043478260869565, 1.1673913043478, 0.27272727272727
53266, 0.043478260869565, 1.1934782608696, 0.29545454545455
53267, 0.065217391304348, 1.1934782608696, 0.31818181818182
53268, 0.043478260869565, 1.1673913043478, 0.31818181818182
53269, 0.043478260869565, 1.1934782608696, 0.34090909090909
53270, 0.065217391304348, 1.1934782608696, 0.36363636363636
53271, 0.043478260869565, 1.1673913043478, 0.36363636363636
53272, 0.043478260869565, 1.1934782608696, 0.38636363636364
53273, 0.065217391304348, 1.1934782608696, 0.40909090909091
53274, 0.043478260869565, 1.1673913043478, 0.40909090909091
53275, 0.043478260869565, 1.1934782608696, 0.43181818181818
53276, 0.065217391304348, 1.1934782608696, 0.45454545454545
53277, 0.043478260869565, 1.1673913043478, 0.45454545454545
53278, 0.043478260869565, 1.1934782608696, 0.47727272727273
53279, 0.021739130434783, 1.1934782608696, 0.045454545454545
53280, 0.021739130434783, 1.1934782608696, 0.090909090909091
53281, 0.021739130434783, 1.1934782608696, 0.13636363636364
53282, 0.021739130434783, 1.1934782608696, 0.18181818181818
53283, 0.021739130434783, 1.1934782608696, 0.22727272727273
53284, 0.021739130434783, 1.1934782608696, 0.27272727272727
53285, 0.021739130434783, 1.1934782608696, 0.31818181818182
53286, 0.021739130434783, 1.1934782608696, 0.36363636363636
53287, 0.021739130434783, 1.1934782608696, 0.40909090909091
53288, 0.021739130434783, 1.1934782608696, 0.45454545454545
53289, 0.95652173913043, 1.245652173913, 0.022727272727273
53290, 0.97826086956522, 1.245652173913, 0.045454545454545
53291, 0.95652173913043, 1.2195652173913, 0.045454545454545
53292, 0.95652173913043, 1.245652173913, 0.068181818181818
53293, 0.97826086956522, 1.245652173913, 0.090909090909091
53294, 0.95652173913043, 1.2195652173913, 0.090909090909091
53295, 0.95652173913043, 1.245652173913, 0.11363636363636
53296, 0.97826086956522, 1.245652173913, 0.13636363636364
53297, 0.95652173913044, 1.2195652173913, 0.13636363636364
53298, 0.95652173913044, 1.245652173913, 0.15909090909091
53299, 0.97826086956522, 1.245652173913, 0.18181818181818
53300, 0.95652173913044, 1.2195652173913, 0.18181818181818
53301, 0.95652173913044, 1.245652173913, 0.20454545454545
53302, 0.97826086956522, 1.245652173913, 0.22727272727273
53303, 0.95652173913044, 1.2195652173913, 0.22727272727273
53304, 0.95652173913044, 1.245652173913, 0.25
53305, 0.97826086956522, 1.245652173913, 0.27272727272727
53306, 0.95652173913044, 1.2195652173913, 0.27272727272727
53307, 0.95652173913044, 1.245652173913, 0.29545454545455
53308, 0.97826086956522, 1.245652173913, 0.31818181818182
53309, 0.95652173913044, 1.2195652173913, 0.31818181818182
