26277, 0.26086956521739, -0.05, 0.5
26278, 0.21739130434783, -0.05, 0.5
26279, 0.17391304347826, -0.05, 0.5
26280, 0.1304347826087, -0.05, 0.5
26281, 0.08695652173913, -0.05, 0.5
26282, 0.043478260869565, -0.05, 0.5
26283, 0.95652173913043, -0.1, 0.5
26284, 0.91304347826087, -0.1, 0.5
26285, 0.8695652173913, -0.1, 0.5
26286, 0.82608695652174, -0.1, 0.5
26287, 0.78260869565217, -0.1, 0.5
26288, 0.73913043478261, -0.1, 0.5
26289, 0.69565217391304, -0.1, 0.5
26290, 0.65217391304348, -0.1, 0.5
26291, 0.60869565217391, -0.1, 0.5
26292, 0.56521739130435, -0.1, 0.5
26293, 0.52173913043478, -0.1, 0.5
26294, 0.47826086956522, -0.1, 0.5
26295, 0.43478260869565, -0.1, 0.5
26296, 0.39130434782609, -0.1, 0.5
26297, 0.34782608695652, -0.1, 0.5
26298, 0.30434782608696, -0.1, 0.5
26299, 0.26086956521739, -0.1, 0.5
26300, 0.21739130434783, -0.1, 0.5
26301, 0.17391304347826, -0.1, 0.5
26302, 0.1304347826087, -0.1, 0.5
26303, 0.08695652173913, -0.1, 0.5
26304, 0.043478260869565, -0.1, 0.5
26305, 0.95652173913043, -0.15, 0.5
26306, 0.91304347826087, -0.15, 0.5
26307, 0.8695652173913, -0.15, 0.5
26308, 0.82608695652174, -0.15, 0.5
26309, 0.78260869565217, -0.15, 0.5
26310, 0.73913043478261, -0.15, 0.5
26311, 0.69565217391304, -0.15, 0.5
26312, 0.65217391304348, -0.15, 0.5
26313, 0.60869565217391, -0.15, 0.5
26314, 0.56521739130435, -0.15, 0.5
26315, 0.52173913043478, -0.15, 0.5
26316, 0.47826086956522, -0.15, 0.5
26317, 0.43478260869565, -0.15, 0.5
26318, 0.39130434782609, -0.15, 0.5
26319, 0.34782608695652, -0.15, 0.5
26320, 0.30434782608696, -0.15, 0.5
26321, 0.26086956521739, -0.15, 0.5
26322, 0.21739130434783, -0.15, 0.5
26323, 0.17391304347826, -0.15, 0.5
26324, 0.1304347826087, -0.15, 0.5
26325, 0.08695652173913, -0.15, 0.5
26326, 0.043478260869565, -0.15, 0.5
26327, 0.95652173913043, -0.025, 0.5
26328, 0.97826086956522, -0.05, 0.5
26329, 0.91304347826087, -0.025, 0.5
26330, 0.93478260869565, -0.05, 0.5
26331, 0.8695652173913, -0.025, 0.5
26332, 0.89130434782609, -0.05, 0.5
26333, 0.82608695652174, -0.025, 0.5
26334, 0.84782608695652, -0.05, 0.5
26335, 0.78260869565217, -0.025, 0.5
26336, 0.80434782608696, -0.05, 0.5
26337, 0.73913043478261, -0.025, 0.5
26338, 0.76086956521739, -0.05, 0.5
26339, 0.69565217391304, -0.025, 0.5
26340, 0.71739130434783, -0.05, 0.5
26341, 0.65217391304348, -0.025, 0.5
26342, 0.67391304347826, -0.05, 0.5
26343, 0.60869565217391, -0.025, 0.5
26344, 0.6304347826087, -0.05, 0.5
26345, 0.56521739130435, -0.025, 0.5
26346, 0.58695652173913, -0.05, 0.5
26347, 0.52173913043478, -0.025, 0.5
26348, 0.54347826086957, -0.05, 0.5
26349, 0.47826086956522, -0.025, 0.5
26350, 0.5, -0.05, 0.5
26351, 0.43478260869565, -0.025, 0.5
26352, 0.45652173913043, -0.05, 0.5
26353, 0.39130434782609, -0.025, 0.5
26354, 0.41304347826087, -0.05, 0.5
26355, 0.34782608695652, -0.025, 0.5
26356, 0.3695652173913, -0.05, 0.5
26357, 0.30434782608696, -0.025, 0.5
26358, 0.32608695652174, -0.05, 0.5
26359, 0.26086956521739, -0.025, 0.5
26360, 0.28260869565217, -0.05, 0.5
26361, 0.21739130434783, -0.025, 0.5
26362, 0.23913043478261, -0.05, 0.5
26363, 0.17391304347826, -0.025, 0.5
26364, 0.19565217391304, -0.05, 0.5
26365, 0.1304347826087, -0.025, 0.5
26366, 0.15217391304348, -0.05, 0.5
26367, 0.08695652173913, -0.025, 0.5
26368, 0.10869565217391, -0.05, 0.5
26369, 0.043478260869565, -0.025, 0.5
26370, 0.065217391304348, -0.05, 0.5
26371, 0.021739130434783, -0.05, 0.5
26372, 0.95652173913043, -0.075, 0.5
26373, 0.97826086956522, -0.1, 0.5
26374, 0.91304347826087, -0.075, 0.5
26375, 0.93478260869565, -0.1, 0.5
26376, 0.8695652173913, -0.075, 0.5
26377, 0.89130434782609, -0.1, 0.5
26378, 0.82608695652174, -0.075, 0.5
26379, 0.84782608695652, -0.1, 0.5
26380, 0.78260869565217, -0.075, 0.5
26381, 0.80434782608696, -0.1, 0.5
26382, 0.73913043478261, -0.075, 0.5
26383, 0.76086956521739, -0.1, 0.5
26384, 0.69565217391304, -0.075, 0.5
26385, 0.71739130434783, -0.1, 0.5
26386, 0.65217391304348, -0.075, 0.5
26387, 0.67391304347826, -0.1, 0.5
26388, 0.60869565217391, -0.075, 0.5
26389, 0.6304347826087, -0.1, 0.5
26390, 0.56521739130435, -0.075, 0.5
26391, 0.58695652173913, -0.1, 0.5
26392, 0.52173913043478, -0.075, 0.5
26393, 0.54347826086957, -0.1, 0.5
26394, 0.47826086956522, -0.075, 0.5
26395, 0.5, -0.1, 0.5
26396, 0.43478260869565, -0.075, 0.5
26397, 0.45652173913043, -0.1, 0.5
26398, 0.39130434782609, -0.075, 0.5
26399, 0.41304347826087, -0.1, 0.5
26400, 0.34782608695652, -0.075, 0.5
26401, 0.3695652173913, -0.1, 0.5
26402, 0.30434782608696, -0.075, 0.5
26403, 0.32608695652174, -0.1, 0.5
26404, 0.26086956521739, -0.075, 0.5
26405, 0.28260869565217, -0.1, 0.5
26406, 0.21739130434783, -0.075, 0.5
26407, 0.23913043478261, -0.1, 0.5
26408, 0.17391304347826, -0.075, 0.5
26409, 0.19565217391304, -0.1, 0.5
26410, 0.1304347826087, -0.075, 0.5
26411, 0.15217391304348, -0.1, 0.5
26412, 0.08695652173913, -0.075, 0.5
26413, 0.10869565217391, -0.1, 0.5
26414, 0.043478260869565, -0.075, 0.5
26415, 0.065217391304348, -0.1, 0.5
26416, 0.021739130434783, -0.1, 0.5
26417, 0.95652173913043, -0.125, 0.5
26418, 0.97826086956522, -0.15, 0.5
26419, 0.91304347826087, -0.125, 0.5
26420, 0.93478260869565, -0.15, 0.5
26421, 0.8695652173913, -0.125, 0.5
26422, 0.89130434782609, -0.15, 0.5
26423, 0.82608695652174, -0.125, 0.5
26424, 0.84782608695652, -0.15, 0.5
26425, 0.78260869565217, -0.125, 0.5
26426, 0.80434782608696, -0.15, 0.5
26427, 0.73913043478261, -0.125, 0.5
26428, 0.76086956521739, -0.15, 0.5
26429, 0.69565217391304, -0.125, 0.5
26430, 0.71739130434783, -0.15, 0.5
26431, 0.65217391304348, -0.125, 0.5
26432, 0.67391304347826, -0.15, 0.5
26433, 0.60869565217391, -0.125, 0.5
26434, 0.6304347826087, -0.15, 0.5
26435, 0.56521739130435, -0.125, 0.5
26436, 0.58695652173913, -0.15, 0.5
26437, 0.52173913043478, -0.125, 0.5
26438, 0.54347826086957, -0.15, 0.5
26439, 0.47826086956522, -0.125, 0.5
26440, 0.5, -0.15, 0.5
26441, 0.43478260869565, -0.125, 0.5
26442, 0.45652173913043, -0.15, 0.5
26443, 0.39130434782609, -0.125, 0.5
26444, 0.41304347826087, -0.15, 0.5
26445, 0.34782608695652, -0.125, 0.5
26446, 0.3695652173913, -0.15, 0.5
26447, 0.30434782608696, -0.125, 0.5
26448, 0.32608695652174, -0.15, 0.5
26449, 0.26086956521739, -0.125, 0.5
26450, 0.28260869565217, -0.15, 0.5
26451, 0.21739130434783, -0.125, 0.5
26452, 0.23913043478261, -0.15, 0.5
26453, 0.17391304347826, -0.125, 0.5
26454, 0.19565217391304, -0.15, 0.5
26455, 0.1304347826087, -0.125, 0.5
26456, 0.15217391304348, -0.15, 0.5
26457, 0.08695652173913, -0.125, 0.5
26458, 0.10869565217391, -0.15, 0.5
26459, 0.043478260869565, -0.125, 0.5
26460, 0.065217391304348, -0.15, 0.5
26461, 0.021739130434783, -0.15, 0.5
26462, 0.95652173913043, -0.175, 0.5
26463, 0.91304347826087, -0.175, 0.5
26464, 0.8695652173913, -0.175, 0.5
26465, 0.82608695652174, -0.175, 0.5
26466, 0.78260869565217, -0.175, 0.5
26467, 0.73913043478261, -0.175, 0.5
26468, 0.69565217391304, -0.175, 0.5
26469, 0.65217391304348, -0.175, 0.5
26470, 0.60869565217391, -0.175, 0.5
26471, 0.56521739130435, -0.175, 0.5
26472, 0.52173913043478, -0.175, 0.5
26473, 0.47826086956522, -0.175, 0.5
26474, 0.43478260869565, -0.175, 0.5
26475, 0.39130434782609, -0.175, 0.5
26476, 0.34782608695652, -0.175, 0.5
26477, 0.30434782608696, -0.175, 0.5
26478, 0.26086956521739, -0.175, 0.5
26479, 0.21739130434783, -0.175, 0.5
26480, 0.17391304347826, -0.175, 0.5
26481, 0.1304347826087, -0.175, 0.5
26482, 0.08695652173913, -0.175, 0.5
26483, 0.043478260869565, -0.175, 0.5
26484, 0, -0.05, 0.45454545454545
26485, 0, -0.05, 0.40909090909091
26486, 0, -0.05, 0.36363636363636
26487, 0, -0.05, 0.31818181818182
26488, 0, -0.05, 0.27272727272727
26489, 0, -0.05, 0.22727272727273
26490, 0, -0.05, 0.18181818181818
26491, 0, -0.05, 0.13636363636364
26492, 0, -0.05, 0.090909090909091
26493, 0, -0.05, 0.045454545454545
26494, 0, -0.1, 0.45454545454545
26495, 0, -0.1, 0.40909090909091
26496, 0, -0.1, 0.36363636363636
26497, 0, -0.1, 0.31818181818182
26498, 0, -0.1, 0.27272727272727
26499, 0, -0.1, 0.22727272727273
26500, 0, -0.1, 0.18181818181818
26501, 0, -0.1, 0.13636363636364
26502, 0, -0.1, 0.090909090909091
26503, 0, -0.1, 0.045454545454545
26504, 0, -0.15, 0.45454545454545
26505, 0, -0.15, 0.40909090909091
26506, 0, -0.15, 0.36363636363636
26507, 0, -0.15, 0.31818181818182
26508, 0, -0.15, 0.27272727272727
26509, 0, -0.15, 0.22727272727273
26510, 0, -0.15, 0.18181818181818
26511, 0, -0.15, 0.13636363636364
26512, 0, -0.15, 0.090909090909091
26513, 0, -0.15, 0.045454545454545
26514, 0, -0.025, 0.45454545454545
26515, 0, -0.05, 0.47727272727273
26516, 0, -0.025, 0.40909090909091
26517, 0, -0.05, 0.43181818181818
26518, 0, -0.025, 0.36363636363636
26519, 0, -0.05, 0.38636363636364
26520, 0, -0.025, 0.31818181818182
26521, 0, -0.05, 0.34090909090909
26522, 0, -0.025, 0.27272727272727
26523, 0, -0.05, 0.29545454545455
26524, 0, -0.025, 0.22727272727273
26525, 0, -0.05, 0.25
26526, 0, -0.025, 0.18181818181818
26527, 0, -0.05, 0.20454545454545
26528, 0, -0.025, 0.13636363636364
26529, 0, -0.05, 0.15909090909091
26530, 0, -0.025, 0.090909090909091
26531, 0, -0.05, 0.11363636363636
26532, 0, -0.025, 0.045454545454545
26533, 0, -0.05, 0.068181818181818
26534, 0, -0.05, 0.022727272727273
26535, 0, -0.075, 0.45454545454545
26536, 0, -0.1, 0.47727272727273
26537, 0, -0.075, 0.40909090909091
26538, 0, -0.1, 0.43181818181818
26539, 0, -0.075, 0.36363636363636
26540, 0, -0.1, 0.38636363636364
26541, 0, -0.075, 0.31818181818182
26542, 0, -0.1, 0.34090909090909
26543, 0, -0.075, 0.27272727272727
26544, 0, -0.1, 0.29545454545455
26545, 0, -0.075, 0.22727272727273
26546, 0, -0.1, 0.25
26547, 0, -0.075, 0.18181818181818
26548, 0, -0.1, 0.20454545454545
26549, 0, -0.075, 0.13636363636364
26550, 0, -0.1, 0.15909090909091
26551, 0, -0.075, 0.090909090909091
26552, 0, -0.1, 0.11363636363636
26553, 0, -0.075, 0.045454545454545
26554, 0, -0.1, 0.068181818181818
26555, 0, -0.1, 0.022727272727273
26556, 0, -0.125, 0.45454545454545
26557, 0, -0.15, 0.47727272727273
26558, 0, -0.125, 0.40909090909091
26559, 0, -0.15, 0.43181818181818
26560, 0, -0.125, 0.36363636363636
26561, 0, -0.15, 0.38636363636364
26562, 0, -0.125, 0.31818181818182
26563, 0, -0.15, 0.34090909090909
26564, 0, -0.125, 0.27272727272727
26565, 0, -0.15, 0.29545454545455
26566, 0, -0.125, 0.22727272727273
26567, 0, -0.15, 0.25
26568, 0, -0.125, 0.18181818181818
26569, 0, -0.15, 0.20454545454545
26570, 0, -0.125, 0.13636363636364
26571, 0, -0.15, 0.15909090909091
26572, 0, -0.125, 0.090909090909091
26573, 0, -0.15, 0.11363636363636
26574, 0, -0.125, 0.045454545454545
26575, 0, -0.15, 0.068181818181818
26576, 0, -0.15, 0.022727272727273
26577, 0, -0.175, 0.45454545454545
26578, 0, -0.175, 0.40909090909091
26579, 0, -0.175, 0.36363636363636
26580, 0, -0.175, 0.31818181818182
26581, 0, -0.175, 0.27272727272727
26582, 0, -0.175, 0.22727272727273
26583, 0, -0.175, 0.18181818181818
26584, 0, -0.175, 0.13636363636364
26585, 0, -0.175, 0.090909090909091
26586, 0, -0.175, 0.045454545454545
26587, 0.043478260869565, -0.2, 0.045454545454545
26588, 0.043478260869565, -0.2, 0.090909090909091
26589, 0.043478260869565, -0.2, 0.13636363636364
26590, 0.043478260869565, -0.2, 0.18181818181818
26591, 0.043478260869565, -0.2, 0.22727272727273
26592, 0.043478260869565, -0.2, 0.27272727272727
26593, 0.043478260869565, -0.2, 0.31818181818182
26594, 0.043478260869565, -0.2, 0.36363636363636
26595, 0.043478260869565, -0.2, 0.40909090909091
26596, 0.043478260869565, -0.2, 0.45454545454545
26597, 0.08695652173913, -0.2, 0.045454545454545
26598, 0.08695652173913, -0.2, 0.090909090909091
26599, 0.08695652173913, -0.2, 0.13636363636364
26600, 0.08695652173913, -0.2, 0.18181818181818
26601, 0.08695652173913, -0.2, 0.22727272727273
26602, 0.08695652173913, -0.2, 0.27272727272727
26603, 0.08695652173913, -0.2, 0.31818181818182
26604, 0.08695652173913, -0.2, 0.36363636363636
26605, 0.08695652173913, -0.2, 0.40909090909091
26606, 0.08695652173913, -0.2, 0.45454545454545
26607, 0.1304347826087, -0.2, 0.045454545454545
26608, 0.1304347826087, -0.2, 0.090909090909091
26609, 0.1304347826087, -0.2, 0.13636363636364
26610, 0.1304347826087, -0.2, 0.18181818181818
26611, 0.1304347826087, -0.2, 0.22727272727273
26612, 0.1304347826087, -0.2, 0.27272727272727
26613, 0.1304347826087, -0.2, 0.31818181818182
26614, 0.1304347826087, -0.2, 0.36363636363636
26615, 0.1304347826087, -0.2, 0.40909090909091
26616, 0.1304347826087, -0.2, 0.45454545454545
26617, 0.17391304347826, -0.2, 0.045454545454545
26618, 0.17391304347826, -0.2, 0.090909090909091
26619, 0.17391304347826, -0.2, 0.13636363636364
26620, 0.17391304347826, -0.2, 0.18181818181818
26621, 0.17391304347826, -0.2, 0.22727272727273
26622, 0.17391304347826, -0.2, 0.27272727272727
26623, 0.17391304347826, -0.2, 0.31818181818182
26624, 0.17391304347826, -0.2, 0.36363636363636
26625, 0.17391304347826, -0.2, 0.40909090909091
26626, 0.17391304347826, -0.2, 0.45454545454545
26627, 0.21739130434783, -0.2, 0.045454545454545
26628, 0.21739130434783, -0.2, 0.090909090909091
26629, 0.21739130434783, -0.2, 0.13636363636364
26630, 0.21739130434783, -0.2, 0.18181818181818
26631, 0.21739130434783, -0.2, 0.22727272727273
26632, 0.21739130434783, -0.2, 0.27272727272727
26633, 0.21739130434783, -0.2, 0.31818181818182
26634, 0.21739130434783, -0.2, 0.36363636363636
26635, 0.21739130434783, -0.2, 0.40909090909091
26636, 0.21739130434783, -0.2, 0.45454545454545
26637, 0.26086956521739, -0.2, 0.045454545454545
26638, 0.26086956521739, -0.2, 0.090909090909091
26639, 0.26086956521739, -0.2, 0.13636363636364
26640, 0.26086956521739, -0.2, 0.18181818181818
26641, 0.26086956521739, -0.2, 0.22727272727273
26642, 0.26086956521739, -0.2, 0.27272727272727
26643, 0.26086956521739, -0.2, 0.31818181818182
26644, 0.26086956521739, -0.2, 0.36363636363636
26645, 0.26086956521739, -0.2, 0.40909090909091
26646, 0.26086956521739, -0.2, 0.45454545454545
26647, 0.30434782608696, -0.2, 0.045454545454545
26648, 0.30434782608696, -0.2, 0.090909090909091
26649, 0.30434782608696, -0.2, 0.13636363636364
26650, 0.30434782608696, -0.2, 0.18181818181818
26651, 0.30434782608696, -0.2, 0.22727272727273
26652, 0.30434782608696, -0.2, 0.27272727272727
26653, 0.30434782608696, -0.2, 0.31818181818182
26654, 0.30434782608696, -0.2, 0.36363636363636
26655, 0.30434782608696, -0.2, 0.40909090909091
26656, 0.30434782608696, -0.2, 0.45454545454545
26657, 0.34782608695652, -0.2, 0.045454545454545
26658, 0.34782608695652, -0.2, 0.090909090909091
26659, 0.34782608695652, -0.2, 0.13636363636364
26660, 0.34782608695652, -0.2, 0.18181818181818
26661, 0.34782608695652, -0.2, 0.22727272727273
26662, 0.34782608695652, -0.2, 0.27272727272727
26663, 0.34782608695652, -0.2, 0.31818181818182
26664, 0.34782608695652, -0.2, 0.36363636363636
26665, 0.34782608695652, -0.2, 0.40909090909091
26666, 0.34782608695652, -0.2, 0.45454545454545
26667, 0.39130434782609, -0.2, 0.045454545454545
26668, 0.39130434782609, -0.2, 0.090909090909091
26669, 0.39130434782609, -0.2, 0.13636363636364
26670, 0.39130434782609, -0.2, 0.18181818181818
26671, 0.39130434782609, -0.2, 0.22727272727273
26672, 0.39130434782609, -0.2, 0.27272727272727
26673, 0.39130434782609, -0.2, 0.31818181818182
26674, 0.39130434782609, -0.2, 0.36363636363636
26675, 0.39130434782609, -0.2, 0.40909090909091
26676, 0.39130434782609, -0.2, 0.45454545454545
26677, 0.43478260869565, -0.2, 0.045454545454545
26678, 0.43478260869565, -0.2, 0.090909090909091
26679, 0.43478260869565, -0.2, 0.13636363636364
26680, 0.43478260869565, -0.2, 0.18181818181818
26681, 0.43478260869565, -0.2, 0.22727272727273
26682, 0.43478260869565, -0.2, 0.27272727272727
26683, 0.43478260869565, -0.2, 0.31818181818182
26684, 0.43478260869565, -0.2, 0.36363636363636
26685, 0.43478260869565, -0.2, 0.40909090909091
26686, 0.43478260869565, -0.2, 0.45454545454545
26687, 0.47826086956522, -0.2, 0.045454545454545
26688, 0.47826086956522, -0.2, 0.090909090909091
26689, 0.47826086956522, -0.2, 0.13636363636364
26690, 0.47826086956522, -0.2, 0.18181818181818
26691, 0.47826086956522, -0.2, 0.22727272727273
26692, 0.47826086956522, -0.2, 0.27272727272727
26693, 0.47826086956522, -0.2, 0.31818181818182
26694, 0.47826086956522, -0.2, 0.36363636363636
26695, 0.47826086956522, -0.2, 0.40909090909091
26696, 0.47826086956522, -0.2, 0.45454545454545
26697, 0.52173913043478, -0.2, 0.045454545454545
26698, 0.52173913043478, -0.2, 0.090909090909091
26699, 0.52173913043478, -0.2, 0.13636363636364
26700, 0.52173913043478, -0.2, 0.18181818181818
26701, 0.52173913043478, -0.2, 0.22727272727273
26702, 0.52173913043478, -0.2, 0.27272727272727
26703, 0.52173913043478, -0.2, 0.31818181818182
26704, 0.52173913043478, -0.2, 0.36363636363636
26705, 0.52173913043478, -0.2, 0.40909090909091
26706, 0.52173913043478, -0.2, 0.45454545454545
26707, 0.56521739130435, -0.2, 0.045454545454545
26708, 0.56521739130435, -0.2, 0.090909090909091
26709, 0.56521739130435, -0.2, 0.13636363636364
26710, 0.56521739130435, -0.2, 0.18181818181818
26711, 0.56521739130435, -0.2, 0.22727272727273
26712, 0.56521739130435, -0.2, 0.27272727272727
26713, 0.56521739130435, -0.2, 0.31818181818182
26714, 0.56521739130435, -0.2, 0.36363636363636
26715, 0.56521739130435, -0.2, 0.40909090909091
26716, 0.56521739130435, -0.2, 0.45454545454545
26717, 0.60869565217391, -0.2, 0.045454545454545
26718, 0.60869565217391, -0.2, 0.090909090909091
26719, 0.60869565217391, -0.2, 0.13636363636364
26720, 0.60869565217391, -0.2, 0.18181818181818
26721, 0.60869565217391, -0.2, 0.22727272727273
26722, 0.60869565217391, -0.2, 0.27272727272727
26723, 0.60869565217391, -0.2, 0.31818181818182
26724, 0.60869565217391, -0.2, 0.36363636363636
26725, 0.60869565217391, -0.2, 0.40909090909091
26726, 0.60869565217391, -0.2, 0.45454545454545
26727, 0.65217391304348, -0.2, 0.045454545454545
26728, 0.65217391304348, -0.2, 0.090909090909091
26729, 0.65217391304348, -0.2, 0.13636363636364
26730, 0.65217391304348, -0.2, 0.18181818181818
26731, 0.65217391304348, -0.2, 0.22727272727273
26732, 0.65217391304348, -0.2, 0.27272727272727
26733, 0.65217391304348, -0.2, 0.31818181818182
26734, 0.65217391304348, -0.2, 0.36363636363636
26735, 0.65217391304348, -0.2, 0.40909090909091
26736, 0.65217391304348, -0.2, 0.45454545454545
26737, 0.69565217391304, -0.2, 0.045454545454545
26738, 0.69565217391304, -0.2, 0.090909090909091
26739, 0.69565217391304, -0.2, 0.13636363636364
26740, 0.69565217391304, -0.2, 0.18181818181818
26741, 0.69565217391304, -0.2, 0.22727272727273
26742, 0.69565217391304, -0.2, 0.27272727272727
26743, 0.69565217391304, -0.2, 0.31818181818182
26744, 0.69565217391304, -0.2, 0.36363636363636
26745, 0.69565217391304, -0.2, 0.40909090909091
26746, 0.69565217391304, -0.2, 0.45454545454545
26747, 0.73913043478261, -0.2, 0.045454545454545
26748, 0.73913043478261, -0.2, 0.090909090909091
26749, 0.73913043478261, -0.2, 0.13636363636364
26750, 0.73913043478261, -0.2, 0.18181818181818
26751, 0.73913043478261, -0.2, 0.22727272727273
26752, 0.73913043478261, -0.2, 0.27272727272727
26753, 0.73913043478261, -0.2, 0.31818181818182
26754, 0.73913043478261, -0.2, 0.36363636363636
26755, 0.73913043478261, -0.2, 0.40909090909091
26756, 0.73913043478261, -0.2, 0.45454545454545
26757, 0.78260869565217, -0.2, 0.045454545454545
26758, 0.78260869565217, -0.2, 0.090909090909091
26759, 0.78260869565217, -0.2, 0.13636363636364
26760, 0.78260869565217, -0.2, 0.18181818181818
26761, 0.78260869565217, -0.2, 0.22727272727273
26762, 0.78260869565217, -0.2, 0.27272727272727
26763, 0.78260869565217, -0.2, 0.31818181818182
26764, 0.78260869565217, -0.2, 0.36363636363636
26765, 0.78260869565217, -0.2, 0.40909090909091
26766, 0.78260869565217, -0.2, 0.45454545454545
26767, 0.82608695652174, -0.2, 0.045454545454545
26768, 0.82608695652174, -0.2, 0.090909090909091
26769, 0.82608695652174, -0.2, 0.13636363636364
26770, 0.82608695652174, -0.2, 0.18181818181818
26771, 0.82608695652174, -0.2, 0.22727272727273
26772, 0.82608695652174, -0.2, 0.27272727272727
26773, 0.82608695652174, -0.2, 0.31818181818182
26774, 0.82608695652174, -0.2, 0.36363636363636
26775, 0.82608695652174, -0.2, 0.40909090909091
26776, 0.82608695652174, -0.2, 0.45454545454545
26777, 0.8695652173913, -0.2, 0.045454545454545
26778, 0.8695652173913, -0.2, 0.090909090909091
26779, 0.8695652173913, -0.2, 0.13636363636364
26780, 0.8695652173913, -0.2, 0.18181818181818
26781, 0.8695652173913, -0.2, 0.22727272727273
26782, 0.8695652173913, -0.2, 0.27272727272727
26783, 0.8695652173913, -0.2, 0.31818181818182
26784, 0.8695652173913, -0.2, 0.36363636363636
26785, 0.8695652173913, -0.2, 0.40909090909091
26786, 0.8695652173913, -0.2, 0.45454545454545
26787, 0.91304347826087, -0.2, 0.045454545454545
26788, 0.91304347826087, -0.2, 0.090909090909091
26789, 0.91304347826087, -0.2, 0.13636363636364
26790, 0.91304347826087, -0.2, 0.18181818181818
26791, 0.91304347826087, -0.2, 0.22727272727273
26792, 0.91304347826087, -0.2, 0.27272727272727
26793, 0.91304347826087, -0.2, 0.31818181818182
26794, 0.91304347826087, -0.2, 0.36363636363636
26795, 0.91304347826087, -0.2, 0.40909090909091
26796, 0.91304347826087, -0.2, 0.45454545454545
26797, 0.95652173913043, -0.2, 0.045454545454545
26798, 0.95652173913043, -0.2, 0.090909090909091
26799, 0.95652173913044, -0.2, 0.13636363636364
26800, 0.95652173913043, -0.2, 0.18181818181818
26801, 0.95652173913043, -0.2, 0.22727272727273
26802, 0.95652173913043, -0.2, 0.27272727272727
26803, 0.95652173913043, -0.2, 0.31818181818182
26804, 0.95652173913043, -0.2, 0.36363636363636
26805, 0.95652173913043, -0.2, 0.40909090909091
26806, 0.95652173913043, -0.2, 0.45454545454545
26807, 0.043478260869565, -0.2, 0.022727272727273
26808, 0.021739130434783, -0.2, 0.045454545454545
26809, 0.043478260869565, -0.2, 0.068181818181818
26810, 0.021739130434783, -0.2, 0.090909090909091
26811, 0.043478260869565, -0.2, 0.11363636363636
26812, 0.021739130434783, -0.2, 0.13636363636364
26813, 0.043478260869565, -0.2, 0.15909090909091
26814, 0.021739130434783, -0.2, 0.18181818181818
26815, 0.043478260869565, -0.2, 0.20454545454545
26816, 0.021739130434783, -0.2, 0.22727272727273
26817, 0.043478260869565, -0.2, 0.25
26818, 0.021739130434783, -0.2, 0.27272727272727
26819, 0.043478260869565, -0.2, 0.29545454545455
26820, 0.021739130434783, -0.2, 0.31818181818182
26821, 0.043478260869565, -0.2, 0.34090909090909
26822, 0.021739130434783, -0.2, 0.36363636363636
26823, 0.043478260869565, -0.2, 0.38636363636364
26824, 0.021739130434783, -0.2, 0.40909090909091
26825, 0.043478260869565, -0.2, 0.43181818181818
26826, 0.021739130434783, -0.2, 0.45454545454545
26827, 0.043478260869565, -0.2, 0.47727272727273
26828, 0.08695652173913, -0.2, 0.022727272727273
26829, 0.065217391304348, -0.2, 0.045454545454545
26830, 0.08695652173913, -0.2, 0.068181818181818
26831, 0.065217391304348, -0.2, 0.090909090909091
26832, 0.08695652173913, -0.2, 0.11363636363636
26833, 0.065217391304348, -0.2, 0.13636363636364
26834, 0.08695652173913, -0.2, 0.15909090909091
26835, 0.065217391304348, -0.2, 0.18181818181818
26836, 0.08695652173913, -0.2, 0.20454545454545
26837, 0.065217391304348, -0.2, 0.22727272727273
26838, 0.08695652173913, -0.2, 0.25
26839, 0.065217391304348, -0.2, 0.27272727272727
26840, 0.08695652173913, -0.2, 0.29545454545455
26841, 0.065217391304348, -0.2, 0.31818181818182
26842, 0.08695652173913, -0.2, 0.34090909090909
26843, 0.065217391304348, -0.2, 0.36363636363636
26844, 0.08695652173913, -0.2, 0.38636363636364
26845, 0.065217391304348, -0.2, 0.40909090909091
26846, 0.08695652173913, -0.2, 0.43181818181818
26847, 0.065217391304348, -0.2, 0.45454545454545
26848, 0.08695652173913, -0.2, 0.47727272727273
26849, 0.1304347826087, -0.2, 0.022727272727273
26850, 0.10869565217391, -0.2, 0.045454545454545
26851, 0.1304347826087, -0.2, 0.068181818181818
26852, 0.10869565217391, -0.2, 0.090909090909091
26853, 0.1304347826087, -0.2, 0.11363636363636
26854, 0.10869565217391, -0.2, 0.13636363636364
26855, 0.1304347826087, -0.2, 0.15909090909091
26856, 0.10869565217391, -0.2, 0.18181818181818
26857, 0.1304347826087, -0.2, 0.20454545454545
26858, 0.10869565217391, -0.2, 0.22727272727273
26859, 0.1304347826087, -0.2, 0.25
26860, 0.10869565217391, -0.2, 0.27272727272727
26861, 0.1304347826087, -0.2, 0.29545454545455
26862, 0.10869565217391, -0.2, 0.31818181818182
26863, 0.1304347826087, -0.2, 0.34090909090909
26864, 0.10869565217391, -0.2, 0.36363636363636
26865, 0.1304347826087, -0.2, 0.38636363636364
26866, 0.10869565217391, -0.2, 0.40909090909091
26867, 0.1304347826087, -0.2, 0.43181818181818
26868, 0.10869565217391, -0.2, 0.45454545454545
26869, 0.1304347826087, -0.2, 0.47727272727273
26870, 0.17391304347826, -0.2, 0.022727272727273
26871, 0.15217391304348, -0.2, 0.045454545454545
26872, 0.17391304347826, -0.2, 0.068181818181818
26873, 0.15217391304348, -0.2, 0.090909090909091
26874, 0.17391304347826, -0.2, 0.11363636363636
26875, 0.15217391304348, -0.2, 0.13636363636364
26876, 0.17391304347826, -0.2, 0.15909090909091
26877, 0.15217391304348, -0.2, 0.18181818181818
26878, 0.17391304347826, -0.2, 0.20454545454545
26879, 0.15217391304348, -0.2, 0.22727272727273
26880, 0.17391304347826, -0.2, 0.25
26881, 0.15217391304348, -0.2, 0.27272727272727
26882, 0.17391304347826, -0.2, 0.29545454545455
26883, 0.15217391304348, -0.2, 0.31818181818182
26884, 0.17391304347826, -0.2, 0.34090909090909
26885, 0.15217391304348, -0.2, 0.36363636363636
26886, 0.17391304347826, -0.2, 0.38636363636364
26887, 0.15217391304348, -0.2, 0.40909090909091
26888, 0.17391304347826, -0.2, 0.43181818181818
26889, 0.15217391304348, -0.2, 0.45454545454545
26890, 0.17391304347826, -0.2, 0.47727272727273
26891, 0.21739130434783, -0.2, 0.022727272727273
26892, 0.19565217391304, -0.2, 0.045454545454545
26893, 0.21739130434783, -0.2, 0.068181818181818
26894, 0.19565217391304, -0.2, 0.090909090909091
26895, 0.21739130434783, -0.2, 0.11363636363636
26896, 0.19565217391304, -0.2, 0.13636363636364
26897, 0.21739130434783, -0.2, 0.15909090909091
26898, 0.19565217391304, -0.2, 0.18181818181818
26899, 0.21739130434783, -0.2, 0.20454545454545
26900, 0.19565217391304, -0.2, 0.22727272727273
26901, 0.21739130434783, -0.2, 0.25
26902, 0.19565217391304, -0.2, 0.27272727272727
26903, 0.21739130434783, -0.2, 0.29545454545455
26904, 0.19565217391304, -0.2, 0.31818181818182
26905, 0.21739130434783, -0.2, 0.34090909090909
26906, 0.19565217391304, -0.2, 0.36363636363636
26907, 0.21739130434783, -0.2, 0.38636363636364
26908, 0.19565217391304, -0.2, 0.40909090909091
26909, 0.21739130434783, -0.2, 0.43181818181818
26910, 0.19565217391304, -0.2, 0.45454545454545
26911, 0.21739130434783, -0.2, 0.47727272727273
26912, 0.26086956521739, -0.2, 0.022727272727273
26913, 0.23913043478261, -0.2, 0.045454545454545
26914, 0.26086956521739, -0.2, 0.068181818181818
26915, 0.23913043478261, -0.2, 0.090909090909091
26916, 0.26086956521739, -0.2, 0.11363636363636
26917, 0.23913043478261, -0.2, 0.13636363636364
26918, 0.26086956521739, -0.2, 0.15909090909091
26919, 0.23913043478261, -0.2, 0.18181818181818
26920, 0.26086956521739, -0.2, 0.20454545454545
26921, 0.23913043478261, -0.2, 0.22727272727273
26922, 0.26086956521739, -0.2, 0.25
26923, 0.23913043478261, -0.2, 0.27272727272727
26924, 0.26086956521739, -0.2, 0.29545454545455
26925, 0.23913043478261, -0.2, 0.31818181818182
26926, 0.26086956521739, -0.2, 0.34090909090909
26927, 0.23913043478261, -0.2, 0.36363636363636
26928, 0.26086956521739, -0.2, 0.38636363636364
26929, 0.23913043478261, -0.2, 0.40909090909091
26930, 0.26086956521739, -0.2, 0.43181818181818
26931, 0.23913043478261, -0.2, 0.45454545454545
26932, 0.26086956521739, -0.2, 0.47727272727273
26933, 0.30434782608696, -0.2, 0.022727272727273
26934, 0.28260869565217, -0.2, 0.045454545454545
26935, 0.30434782608696, -0.2, 0.068181818181818
26936, 0.28260869565217, -0.2, 0.090909090909091
26937, 0.30434782608696, -0.2, 0.11363636363636
26938, 0.28260869565217, -0.2, 0.13636363636364
26939, 0.30434782608696, -0.2, 0.15909090909091
26940, 0.28260869565217, -0.2, 0.18181818181818
26941, 0.30434782608696, -0.2, 0.20454545454545
26942, 0.28260869565217, -0.2, 0.22727272727273
26943, 0.30434782608696, -0.2, 0.25
26944, 0.28260869565217, -0.2, 0.27272727272727
26945, 0.30434782608696, -0.2, 0.29545454545455
26946, 0.28260869565217, -0.2, 0.31818181818182
26947, 0.30434782608696, -0.2, 0.34090909090909
26948, 0.28260869565217, -0.2, 0.36363636363636
26949, 0.30434782608696, -0.2, 0.38636363636364
26950, 0.28260869565217, -0.2, 0.40909090909091
26951, 0.30434782608696, -0.2, 0.43181818181818
26952, 0.28260869565217, -0.2, 0.45454545454545
26953, 0.30434782608696, -0.2, 0.47727272727273
26954, 0.34782608695652, -0.2, 0.022727272727273
26955, 0.32608695652174, -0.2, 0.045454545454545
26956, 0.34782608695652, -0.2, 0.068181818181818
26957, 0.32608695652174, -0.2, 0.090909090909091
26958, 0.34782608695652, -0.2, 0.11363636363636
26959, 0.32608695652174, -0.2, 0.13636363636364
26960, 0.34782608695652, -0.2, 0.15909090909091
26961, 0.32608695652174, -0.2, 0.18181818181818
26962, 0.34782608695652, -0.2, 0.20454545454545
26963, 0.32608695652174, -0.2, 0.22727272727273
26964, 0.34782608695652, -0.2, 0.25
26965, 0.32608695652174, -0.2, 0.27272727272727
26966, 0.34782608695652, -0.2, 0.29545454545455
26967, 0.32608695652174, -0.2, 0.31818181818182
26968, 0.34782608695652, -0.2, 0.34090909090909
26969, 0.32608695652174, -0.2, 0.36363636363636
26970, 0.34782608695652, -0.2, 0.38636363636364
26971, 0.32608695652174, -0.2, 0.40909090909091
26972, 0.34782608695652, -0.2, 0.43181818181818
26973, 0.32608695652174, -0.2, 0.45454545454545
26974, 0.34782608695652, -0.2, 0.47727272727273
26975, 0.39130434782609, -0.2, 0.022727272727273
26976, 0.3695652173913, -0.2, 0.045454545454545
26977, 0.39130434782609, -0.2, 0.068181818181818
26978, 0.3695652173913, -0.2, 0.090909090909091
26979, 0.39130434782609, -0.2, 0.11363636363636
26980, 0.3695652173913, -0.2, 0.13636363636364
26981, 0.39130434782609, -0.2, 0.15909090909091
26982, 0.3695652173913, -0.2, 0.18181818181818
26983, 0.39130434782609, -0.2, 0.20454545454545
26984, 0.3695652173913, -0.2, 0.22727272727273
26985, 0.39130434782609, -0.2, 0.25
26986, 0.3695652173913, -0.2, 0.27272727272727
26987, 0.39130434782609, -0.2, 0.29545454545455
26988, 0.3695652173913, -0.2, 0.31818181818182
26989, 0.39130434782609, -0.2, 0.34090909090909
26990, 0.3695652173913, -0.2, 0.36363636363636
26991, 0.39130434782609, -0.2, 0.38636363636364
26992, 0.3695652173913, -0.2, 0.40909090909091
26993, 0.39130434782609, -0.2, 0.43181818181818
26994, 0.3695652173913, -0.2, 0.45454545454545
26995, 0.39130434782609, -0.2, 0.47727272727273
26996, 0.43478260869565, -0.2, 0.022727272727273
26997, 0.41304347826087, -0.2, 0.045454545454545
26998, 0.43478260869565, -0.2, 0.068181818181818
26999, 0.41304347826087, -0.2, 0.090909090909091
27000, 0.43478260869565, -0.2, 0.11363636363636
27001, 0.41304347826087, -0.2, 0.13636363636364
27002, 0.43478260869565, -0.2, 0.15909090909091
27003, 0.41304347826087, -0.2, 0.18181818181818
27004, 0.43478260869565, -0.2, 0.20454545454545
27005, 0.41304347826087, -0.2, 0.22727272727273
27006, 0.43478260869565, -0.2, 0.25
27007, 0.41304347826087, -0.2, 0.27272727272727
27008, 0.43478260869565, -0.2, 0.29545454545455
27009, 0.41304347826087, -0.2, 0.31818181818182
27010, 0.43478260869565, -0.2, 0.34090909090909
27011, 0.41304347826087, -0.2, 0.36363636363636
27012, 0.43478260869565, -0.2, 0.38636363636364
27013, 0.41304347826087, -0.2, 0.40909090909091
27014, 0.43478260869565, -0.2, 0.43181818181818
27015, 0.41304347826087, -0.2, 0.45454545454545
27016, 0.43478260869565, -0.2, 0.47727272727273
27017, 0.47826086956522, -0.2, 0.022727272727273
27018, 0.45652173913043, -0.2, 0.045454545454545
27019, 0.47826086956522, -0.2, 0.068181818181818
27020, 0.45652173913043, -0.2, 0.090909090909091
27021, 0.47826086956522, -0.2, 0.11363636363636
27022, 0.45652173913043, -0.2, 0.13636363636364
27023, 0.47826086956522, -0.2, 0.15909090909091
27024, 0.45652173913043, -0.2, 0.18181818181818
27025, 0.47826086956522, -0.2, 0.20454545454545
27026, 0.45652173913043, -0.2, 0.22727272727273
27027, 0.47826086956522, -0.2, 0.25
27028, 0.45652173913043, -0.2, 0.27272727272727
27029, 0.47826086956522, -0.2, 0.29545454545455
27030, 0.45652173913043, -0.2, 0.31818181818182
27031, 0.47826086956522, -0.2, 0.34090909090909
27032, 0.45652173913043, -0.2, 0.36363636363636
27033, 0.47826086956522, -0.2, 0.38636363636364
27034, 0.45652173913043, -0.2, 0.40909090909091
27035, 0.47826086956522, -0.2, 0.43181818181818
27036, 0.45652173913043, -0.2, 0.45454545454545
27037, 0.47826086956522, -0.2, 0.47727272727273
27038, 0.52173913043478, -0.2, 0.022727272727273
27039, 0.5, -0.2, 0.045454545454545
27040, 0.52173913043478, -0.2, 0.068181818181818
27041, 0.5, -0.2, 0.090909090909091
27042, 0.52173913043478, -0.2, 0.11363636363636
27043, 0.5, -0.2, 0.13636363636364
27044, 0.52173913043478, -0.2, 0.15909090909091
27045, 0.5, -0.2, 0.18181818181818
27046, 0.52173913043478, -0.2, 0.20454545454545
27047, 0.5, -0.2, 0.22727272727273
27048, 0.52173913043478, -0.2, 0.25
27049, 0.5, -0.2, 0.27272727272727
27050, 0.52173913043478, -0.2, 0.29545454545455
27051, 0.5, -0.2, 0.31818181818182
27052, 0.52173913043478, -0.2, 0.34090909090909
27053, 0.5, -0.2, 0.36363636363636
27054, 0.52173913043478, -0.2, 0.38636363636364
27055, 0.5, -0.2, 0.40909090909091
27056, 0.52173913043478, -0.2, 0.43181818181818
27057, 0.5, -0.2, 0.45454545454545
27058, 0.52173913043478, -0.2, 0.47727272727273
27059, 0.56521739130435, -0.2, 0.022727272727273
27060, 0.54347826086957, -0.2, 0.045454545454545
27061, 0.56521739130435, -0.2, 0.068181818181818
27062, 0.54347826086957, -0.2, 0.090909090909091
27063, 0.56521739130435, -0.2, 0.11363636363636
27064, 0.54347826086957, -0.2, 0.13636363636364
27065, 0.56521739130435, -0.2, 0.15909090909091
27066, 0.54347826086957, -0.2, 0.18181818181818
27067, 0.56521739130435, -0.2, 0.20454545454545
27068, 0.54347826086957, -0.2, 0.22727272727273
27069, 0.56521739130435, -0.2, 0.25
27070, 0.54347826086957, -0.2, 0.27272727272727
27071, 0.56521739130435, -0.2, 0.29545454545455
27072, 0.54347826086957, -0.2, 0.31818181818182
27073, 0.56521739130435, -0.2, 0.34090909090909
27074, 0.54347826086957, -0.2, 0.36363636363636
27075, 0.56521739130435, -0.2, 0.38636363636364
27076, 0.54347826086957, -0.2, 0.40909090909091
27077, 0.56521739130435, -0.2, 0.43181818181818
27078, 0.54347826086957, -0.2, 0.45454545454545
27079, 0.56521739130435, -0.2, 0.47727272727273
27080, 0.60869565217391, -0.2, 0.022727272727273
27081, 0.58695652173913, -0.2, 0.045454545454545
27082, 0.60869565217391, -0.2, 0.068181818181818
27083, 0.58695652173913, -0.2, 0.090909090909091
27084, 0.60869565217391, -0.2, 0.11363636363636
27085, 0.58695652173913, -0.2, 0.13636363636364
27086, 0.60869565217391, -0.2, 0.15909090909091
27087, 0.58695652173913, -0.2, 0.18181818181818
27088, 0.60869565217391, -0.2, 0.20454545454545
27089, 0.58695652173913, -0.2, 0.22727272727273
27090, 0.60869565217391, -0.2, 0.25
27091, 0.58695652173913, -0.2, 0.27272727272727
27092, 0.60869565217391, -0.2, 0.29545454545455
27093, 0.58695652173913, -0.2, 0.31818181818182
27094, 0.60869565217391, -0.2, 0.34090909090909
27095, 0.58695652173913, -0.2, 0.36363636363636
27096, 0.60869565217391, -0.2, 0.38636363636364
27097, 0.58695652173913, -0.2, 0.40909090909091
27098, 0.60869565217391, -0.2, 0.43181818181818
27099, 0.58695652173913, -0.2, 0.45454545454545
27100, 0.60869565217391, -0.2, 0.47727272727273
27101, 0.65217391304348, -0.2, 0.022727272727273
27102, 0.6304347826087, -0.2, 0.045454545454545
27103, 0.65217391304348, -0.2, 0.068181818181818
27104, 0.6304347826087, -0.2, 0.090909090909091
27105, 0.65217391304348, -0.2, 0.11363636363636
27106, 0.6304347826087, -0.2, 0.13636363636364
27107, 0.65217391304348, -0.2, 0.15909090909091
27108, 0.6304347826087, -0.2, 0.18181818181818
27109, 0.65217391304348, -0.2, 0.20454545454545
27110, 0.6304347826087, -0.2, 0.22727272727273
27111, 0.65217391304348, -0.2, 0.25
27112, 0.6304347826087, -0.2, 0.27272727272727
27113, 0.65217391304348, -0.2, 0.29545454545455
27114, 0.6304347826087, -0.2, 0.31818181818182
27115, 0.65217391304348, -0.2, 0.34090909090909
27116, 0.6304347826087, -0.2, 0.36363636363636
27117, 0.65217391304348, -0.2, 0.38636363636364
27118, 0.6304347826087, -0.2, 0.40909090909091
27119, 0.65217391304348, -0.2, 0.43181818181818
27120, 0.6304347826087, -0.2, 0.45454545454545
27121, 0.65217391304348, -0.2, 0.47727272727273
27122, 0.69565217391304, -0.2, 0.022727272727273
27123, 0.67391304347826, -0.2, 0.045454545454545
27124, 0.69565217391304, -0.2, 0.068181818181818
27125, 0.67391304347826, -0.2, 0.090909090909091
27126, 0.69565217391304, -0.2, 0.11363636363636
27127, 0.67391304347826, -0.2, 0.13636363636364
27128, 0.69565217391304, -0.2, 0.15909090909091
27129, 0.67391304347826, -0.2, 0.18181818181818
27130, 0.69565217391304, -0.2, 0.20454545454545
27131, 0.67391304347826, -0.2, 0.22727272727273
27132, 0.69565217391304, -0.2, 0.25
27133, 0.67391304347826, -0.2, 0.27272727272727
27134, 0.69565217391304, -0.2, 0.29545454545455
27135, 0.67391304347826, -0.2, 0.31818181818182
27136, 0.69565217391304, -0.2, 0.34090909090909
27137, 0.67391304347826, -0.2, 0.36363636363636
27138, 0.69565217391304, -0.2, 0.38636363636364
27139, 0.67391304347826, -0.2, 0.40909090909091
27140, 0.69565217391304, -0.2, 0.43181818181818
27141, 0.67391304347826, -0.2, 0.45454545454545
27142, 0.69565217391304, -0.2, 0.47727272727273
27143, 0.73913043478261, -0.2, 0.022727272727273
27144, 0.71739130434783, -0.2, 0.045454545454545
27145, 0.73913043478261, -0.2, 0.068181818181818
27146, 0.71739130434783, -0.2, 0.090909090909091
27147, 0.73913043478261, -0.2, 0.11363636363636
27148, 0.71739130434783, -0.2, 0.13636363636364
27149, 0.73913043478261, -0.2, 0.15909090909091
27150, 0.71739130434783, -0.2, 0.18181818181818
27151, 0.73913043478261, -0.2, 0.20454545454545
27152, 0.71739130434783, -0.2, 0.22727272727273
27153, 0.73913043478261, -0.2, 0.25
27154, 0.71739130434783, -0.2, 0.27272727272727
27155, 0.73913043478261, -0.2, 0.29545454545455
27156, 0.71739130434783, -0.2, 0.31818181818182
27157, 0.73913043478261, -0.2, 0.34090909090909
27158, 0.71739130434783, -0.2, 0.36363636363636
27159, 0.73913043478261, -0.2, 0.38636363636364
27160, 0.71739130434783, -0.2, 0.40909090909091
27161, 0.73913043478261, -0.2, 0.43181818181818
27162, 0.71739130434783, -0.2, 0.45454545454545
27163, 0.73913043478261, -0.2, 0.47727272727273
27164, 0.78260869565217, -0.2, 0.022727272727273
27165, 0.76086956521739, -0.2, 0.045454545454545
27166, 0.78260869565217, -0.2, 0.068181818181818
27167, 0.76086956521739, -0.2, 0.090909090909091
27168, 0.78260869565217, -0.2, 0.11363636363636
27169, 0.76086956521739, -0.2, 0.13636363636364
27170, 0.78260869565217, -0.2, 0.15909090909091
27171, 0.76086956521739, -0.2, 0.18181818181818
27172, 0.78260869565217, -0.2, 0.20454545454545
27173, 0.76086956521739, -0.2, 0.22727272727273
27174, 0.78260869565217, -0.2, 0.25
27175, 0.76086956521739, -0.2, 0.27272727272727
27176, 0.78260869565217, -0.2, 0.29545454545455
27177, 0.76086956521739, -0.2, 0.31818181818182
27178, 0.78260869565217, -0.2, 0.34090909090909
27179, 0.76086956521739, -0.2, 0.36363636363636
27180, 0.78260869565217, -0.2, 0.38636363636364
27181, 0.76086956521739, -0.2, 0.40909090909091
27182, 0.78260869565217, -0.2, 0.43181818181818
27183, 0.76086956521739, -0.2, 0.45454545454545
27184, 0.78260869565217, -0.2, 0.47727272727273
27185, 0.82608695652174, -0.2, 0.022727272727273
27186, 0.80434782608696, -0.2, 0.045454545454545
27187, 0.82608695652174, -0.2, 0.068181818181818
27188, 0.80434782608696, -0.2, 0.090909090909091
27189, 0.82608695652174, -0.2, 0.11363636363636
27190, 0.80434782608696, -0.2, 0.13636363636364
27191, 0.82608695652174, -0.2, 0.15909090909091
27192, 0.80434782608696, -0.2, 0.18181818181818
27193, 0.82608695652174, -0.2, 0.20454545454545
27194, 0.80434782608696, -0.2, 0.22727272727273
27195, 0.82608695652174, -0.2, 0.25
27196, 0.80434782608696, -0.2, 0.27272727272727
27197, 0.82608695652174, -0.2, 0.29545454545455
27198, 0.80434782608696, -0.2, 0.31818181818182
27199, 0.82608695652174, -0.2, 0.34090909090909
27200, 0.80434782608696, -0.2, 0.36363636363636
27201, 0.82608695652174, -0.2, 0.38636363636364
27202, 0.80434782608696, -0.2, 0.40909090909091
27203, 0.82608695652174, -0.2, 0.43181818181818
27204, 0.80434782608696, -0.2, 0.45454545454545
27205, 0.82608695652174, -0.2, 0.47727272727273
27206, 0.8695652173913, -0.2, 0.022727272727273
27207, 0.84782608695652, -0.2, 0.045454545454545
27208, 0.8695652173913, -0.2, 0.068181818181818
27209, 0.84782608695652, -0.2, 0.090909090909091
27210, 0.8695652173913, -0.2, 0.11363636363636
27211, 0.84782608695652, -0.2, 0.13636363636364
27212, 0.8695652173913, -0.2, 0.15909090909091
27213, 0.84782608695652, -0.2, 0.18181818181818
27214, 0.8695652173913, -0.2, 0.20454545454545
27215, 0.84782608695652, -0.2, 0.22727272727273
27216, 0.8695652173913, -0.2, 0.25
27217, 0.84782608695652, -0.2, 0.27272727272727
27218, 0.8695652173913, -0.2, 0.29545454545455
27219, 0.84782608695652, -0.2, 0.31818181818182
27220, 0.8695652173913, -0.2, 0.34090909090909
27221, 0.84782608695652, -0.2, 0.36363636363636
27222, 0.8695652173913, -0.2, 0.38636363636364
27223, 0.84782608695652, -0.2, 0.40909090909091
27224, 0.8695652173913, -0.2, 0.43181818181818
27225, 0.84782608695652, -0.2, 0.45454545454545
27226, 0.8695652173913, -0.2, 0.47727272727273
27227, 0.91304347826087, -0.2, 0.022727272727273
27228, 0.89130434782609, -0.2, 0.045454545454545
27229, 0.91304347826087, -0.2, 0.068181818181818
27230, 0.89130434782609, -0.2, 0.090909090909091
27231, 0.91304347826087, -0.2, 0.11363636363636
27232, 0.89130434782609, -0.2, 0.13636363636364
27233, 0.91304347826087, -0.2, 0.15909090909091
27234, 0.89130434782609, -0.2, 0.18181818181818
27235, 0.91304347826087, -0.2, 0.20454545454545
27236, 0.89130434782609, -0.2, 0.22727272727273
27237, 0.91304347826087, -0.2, 0.25
27238, 0.89130434782609, -0.2, 0.27272727272727
27239, 0.91304347826087, -0.2, 0.29545454545455
27240, 0.89130434782609, -0.2, 0.31818181818182
27241, 0.91304347826087, -0.2, 0.34090909090909
27242, 0.89130434782609, -0.2, 0.36363636363636
27243, 0.91304347826087, -0.2, 0.38636363636364
27244, 0.89130434782609, -0.2, 0.40909090909091
27245, 0.91304347826087, -0.2, 0.43181818181818
27246, 0.89130434782609, -0.2, 0.45454545454545
27247, 0.91304347826087, -0.2, 0.47727272727273
27248, 0.95652173913043, -0.2, 0.022727272727273
27249, 0.93478260869565, -0.2, 0.045454545454545
27250, 0.95652173913043, -0.2, 0.068181818181818
27251, 0.93478260869565, -0.2, 0.090909090909091
27252, 0.95652173913044, -0.2, 0.11363636363636
27253, 0.93478260869565, -0.2, 0.13636363636364
27254, 0.95652173913043, -0.2, 0.15909090909091
27255, 0.93478260869565, -0.2, 0.18181818181818
27256, 0.95652173913043, -0.2, 0.20454545454545
27257, 0.93478260869565, -0.2, 0.22727272727273
27258, 0.95652173913043, -0.2, 0.25
27259, 0.93478260869565, -0.2, 0.27272727272727
27260, 0.95652173913043, -0.2, 0.29545454545455
27261, 0.93478260869565, -0.2, 0.31818181818182
27262, 0.95652173913043, -0.2, 0.34090909090909
27263, 0.93478260869565, -0.2, 0.36363636363636
27264, 0.95652173913043, -0.2, 0.38636363636364
27265, 0.93478260869565, -0.2, 0.40909090909091
27266, 0.95652173913043, -0.2, 0.43181818181818
27267, 0.93478260869565, -0.2, 0.45454545454545
27268, 0.95652173913043, -0.2, 0.47727272727273
27269, 0.97826086956522, -0.2, 0.045454545454545
27270, 0.97826086956522, -0.2, 0.090909090909091
27271, 0.97826086956522, -0.2, 0.13636363636364
27272, 0.97826086956522, -0.2, 0.18181818181818
27273, 0.97826086956522, -0.2, 0.22727272727273
27274, 0.97826086956522, -0.2, 0.27272727272727
27275, 0.97826086956522, -0.2, 0.31818181818182
27276, 0.97826086956522, -0.2, 0.36363636363636
27277, 0.97826086956522, -0.2, 0.40909090909091
27278, 0.97826086956522, -0.2, 0.45454545454545
27279, -0.033333333333333, -0.05, 0.5
27280, -0.066666666666667, -0.05, 0.5
27281, -0.033333333333333, -0.1, 0.5
27282, -0.066666666666667, -0.1, 0.5
27283, -0.033333333333333, -0.15, 0.5
27284, -0.066666666666667, -0.15, 0.5
27285, -0.033333333333333, -0.025, 0.5
27286, -0.016666666666667, -0.05, 0.5
27287, -0.066666666666667, -0.025, 0.5
27288, -0.05, -0.05, 0.5
27289, -0.083333333333333, -0.05, 0.5
27290, -0.033333333333333, -0.075, 0.5
27291, -0.016666666666667, -0.1, 0.5
27292, -0.066666666666667, -0.075, 0.5
27293, -0.05, -0.1, 0.5
27294, -0.083333333333333, -0.1, 0.5
27295, -0.033333333333333, -0.125, 0.5
27296, -0.016666666666667, -0.15, 0.5
27297, -0.066666666666667, -0.125, 0.5
27298, -0.05, -0.15, 0.5
27299, -0.083333333333333, -0.15, 0.5
27300, -0.033333333333333, -0.175, 0.5
27301, -0.066666666666667, -0.175, 0.5
27302, -0.033333333333333, -0.05, 0
27303, -0.066666666666667, -0.05, 0
27304, -0.033333333333333, -0.1, 0
27305, -0.066666666666667, -0.1, 0
27306, -0.033333333333333, -0.15, 0
27307, -0.066666666666667, -0.15, 0
27308, -0.016666666666667, -0.05, 0
27309, -0.033333333333333, -0.025, 0
27310, -0.05, -0.05, 0
27311, -0.066666666666667, -0.025, 0
27312, -0.083333333333333, -0.05, 0
27313, -0.016666666666667, -0.1, 0
27314, -0.033333333333333, -0.075, 0
27315, -0.05, -0.1, 0
27316, -0.066666666666667, -0.075, 0
27317, -0.083333333333333, -0.1, 0
27318, -0.016666666666667, -0.15, 0
27319, -0.033333333333333, -0.125, 0
27320, -0.05, -0.15, 0
27321, -0.066666666666667, -0.125, 0
27322, -0.083333333333333, -0.15, 0
27323, -0.033333333333333, -0.175, 0
27324, -0.066666666666667, -0.175, 0
27325, -0.1, -0.05, 0.45454545454545
27326, -0.1, -0.05, 0.40909090909091
27327, -0.1, -0.05, 0.36363636363636
27328, -0.1, -0.05, 0.31818181818182
27329, -0.1, -0.05, 0.27272727272727
27330, -0.1, -0.05, 0.22727272727273
27331, -0.1, -0.05, 0.18181818181818
27332, -0.1, -0.05, 0.13636363636364
27333, -0.1, -0.05, 0.090909090909091
27334, -0.1, -0.05, 0.045454545454545
27335, -0.1, -0.1, 0.45454545454545
27336, -0.1, -0.1, 0.40909090909091
27337, -0.1, -0.1, 0.36363636363636
27338, -0.1, -0.1, 0.31818181818182
27339, -0.1, -0.1, 0.27272727272727
27340, -0.1, -0.1, 0.22727272727273
27341, -0.1, -0.1, 0.18181818181818
27342, -0.1, -0.1, 0.13636363636364
27343, -0.1, -0.1, 0.090909090909091
27344, -0.1, -0.1, 0.045454545454545
27345, -0.1, -0.15, 0.45454545454545
27346, -0.1, -0.15, 0.40909090909091
27347, -0.1, -0.15, 0.36363636363636
27348, -0.1, -0.15, 0.31818181818182
27349, -0.1, -0.15, 0.27272727272727
27350, -0.1, -0.15, 0.22727272727273
27351, -0.1, -0.15, 0.18181818181818
27352, -0.1, -0.15, 0.13636363636364
27353, -0.1, -0.15, 0.090909090909091
27354, -0.1, -0.15, 0.045454545454545
27355, -0.1, -0.025, 0.45454545454545
27356, -0.1, -0.05, 0.47727272727273
27357, -0.1, -0.025, 0.40909090909091
27358, -0.1, -0.05, 0.43181818181818
27359, -0.1, -0.025, 0.36363636363636
27360, -0.1, -0.05, 0.38636363636364
27361, -0.1, -0.025, 0.31818181818182
27362, -0.1, -0.05, 0.34090909090909
27363, -0.1, -0.025, 0.27272727272727
27364, -0.1, -0.05, 0.29545454545455
27365, -0.1, -0.025, 0.22727272727273
27366, -0.1, -0.05, 0.25
27367, -0.1, -0.025, 0.18181818181818
27368, -0.1, -0.05, 0.20454545454545
27369, -0.1, -0.025, 0.13636363636364
27370, -0.1, -0.05, 0.15909090909091
27371, -0.1, -0.025, 0.090909090909091
27372, -0.1, -0.05, 0.11363636363636
27373, -0.1, -0.025, 0.045454545454545
27374, -0.1, -0.05, 0.068181818181818
27375, -0.1, -0.05, 0.022727272727273
27376, -0.1, -0.075, 0.45454545454545
27377, -0.1, -0.1, 0.47727272727273
27378, -0.1, -0.075, 0.40909090909091
27379, -0.1, -0.1, 0.43181818181818
27380, -0.1, -0.075, 0.36363636363636
27381, -0.1, -0.1, 0.38636363636364
27382, -0.1, -0.075, 0.31818181818182
27383, -0.1, -0.1, 0.34090909090909
27384, -0.1, -0.075, 0.27272727272727
27385, -0.1, -0.1, 0.29545454545455
27386, -0.1, -0.075, 0.22727272727273
27387, -0.1, -0.1, 0.25
27388, -0.1, -0.075, 0.18181818181818
27389, -0.1, -0.1, 0.20454545454545
27390, -0.1, -0.075, 0.13636363636364
27391, -0.1, -0.1, 0.15909090909091
27392, -0.1, -0.075, 0.090909090909091
27393, -0.1, -0.1, 0.11363636363636
27394, -0.1, -0.075, 0.045454545454545
27395, -0.1, -0.1, 0.068181818181818
27396, -0.1, -0.1, 0.022727272727273
27397, -0.1, -0.125, 0.45454545454545
27398, -0.1, -0.15, 0.47727272727273
27399, -0.1, -0.125, 0.40909090909091
27400, -0.1, -0.15, 0.43181818181818
27401, -0.1, -0.125, 0.36363636363636
27402, -0.1, -0.15, 0.38636363636364
27403, -0.1, -0.125, 0.31818181818182
27404, -0.1, -0.15, 0.34090909090909
27405, -0.1, -0.125, 0.27272727272727
27406, -0.1, -0.15, 0.29545454545455
27407, -0.1, -0.125, 0.22727272727273
27408, -0.1, -0.15, 0.25
27409, -0.1, -0.125, 0.18181818181818
27410, -0.1, -0.15, 0.20454545454545
27411, -0.1, -0.125, 0.13636363636364
27412, -0.1, -0.15, 0.15909090909091
27413, -0.1, -0.125, 0.090909090909091
27414, -0.1, -0.15, 0.11363636363636
27415, -0.1, -0.125, 0.045454545454545
27416, -0.1, -0.15, 0.068181818181818
27417, -0.1, -0.15, 0.022727272727273
27418, -0.1, -0.175, 0.45454545454545
27419, -0.1, -0.175, 0.40909090909091
27420, -0.1, -0.175, 0.36363636363636
27421, -0.1, -0.175, 0.31818181818182
27422, -0.1, -0.175, 0.27272727272727
27423, -0.1, -0.175, 0.22727272727273
27424, -0.1, -0.175, 0.18181818181818
27425, -0.1, -0.175, 0.13636363636364
27426, -0.1, -0.175, 0.090909090909091
27427, -0.1, -0.175, 0.045454545454545
27428, -0.033333333333333, -0.2, 0.45454545454545
27429, -0.033333333333333, -0.2, 0.40909090909091
27430, -0.033333333333333, -0.2, 0.36363636363636
27431, -0.033333333333333, -0.2, 0.31818181818182
27432, -0.033333333333333, -0.2, 0.27272727272727
27433, -0.033333333333333, -0.2, 0.22727272727273
27434, -0.033333333333333, -0.2, 0.18181818181818
27435, -0.033333333333333, -0.2, 0.13636363636364
27436, -0.033333333333333, -0.2, 0.090909090909091
27437, -0.033333333333333, -0.2, 0.045454545454545
27438, -0.066666666666667, -0.2, 0.45454545454545
27439, -0.066666666666667, -0.2, 0.40909090909091
27440, -0.066666666666667, -0.2, 0.36363636363636
27441, -0.066666666666667, -0.2, 0.31818181818182
27442, -0.066666666666667, -0.2, 0.27272727272727
27443, -0.066666666666667, -0.2, 0.22727272727273
27444, -0.066666666666667, -0.2, 0.18181818181818
27445, -0.066666666666667, -0.2, 0.13636363636364
27446, -0.066666666666667, -0.2, 0.090909090909091
27447, -0.066666666666667, -0.2, 0.045454545454545
27448, -0.033333333333333, -0.2, 0.47727272727273
27449, -0.016666666666667, -0.2, 0.45454545454545
27450, -0.033333333333333, -0.2, 0.43181818181818
27451, -0.016666666666667, -0.2, 0.40909090909091
27452, -0.033333333333333, -0.2, 0.38636363636364
27453, -0.016666666666667, -0.2, 0.36363636363636
27454, -0.033333333333333, -0.2, 0.34090909090909
27455, -0.016666666666667, -0.2, 0.31818181818182
27456, -0.033333333333333, -0.2, 0.29545454545455
27457, -0.016666666666667, -0.2, 0.27272727272727
27458, -0.033333333333333, -0.2, 0.25
27459, -0.016666666666667, -0.2, 0.22727272727273
27460, -0.033333333333333, -0.2, 0.20454545454545
27461, -0.016666666666667, -0.2, 0.18181818181818
27462, -0.033333333333333, -0.2, 0.15909090909091
27463, -0.016666666666667, -0.2, 0.13636363636364
27464, -0.033333333333333, -0.2, 0.11363636363636
27465, -0.016666666666667, -0.2, 0.090909090909091
27466, -0.033333333333333, -0.2, 0.068181818181818
27467, -0.016666666666667, -0.2, 0.045454545454545
27468, -0.033333333333333, -0.2, 0.022727272727273
27469, -0.066666666666667, -0.2, 0.47727272727273
27470, -0.05, -0.2, 0.45454545454545
27471, -0.066666666666667, -0.2, 0.43181818181818
27472, -0.05, -0.2, 0.40909090909091
27473, -0.066666666666667, -0.2, 0.38636363636364
27474, -0.05, -0.2, 0.36363636363636
27475, -0.066666666666667, -0.2, 0.34090909090909
27476, -0.05, -0.2, 0.31818181818182
27477, -0.066666666666667, -0.2, 0.29545454545455
27478, -0.05, -0.2, 0.27272727272727
27479, -0.066666666666667, -0.2, 0.25
27480, -0.05, -0.2, 0.22727272727273
27481, -0.066666666666667, -0.2, 0.20454545454545
27482, -0.05, -0.2, 0.18181818181818
27483, -0.066666666666667, -0.2, 0.15909090909091
27484, -0.05, -0.2, 0.13636363636364
27485, -0.066666666666667, -0.2, 0.11363636363636
27486, -0.05, -0.2, 0.090909090909091
27487, -0.066666666666667, -0.2, 0.068181818181818
27488, -0.05, -0.2, 0.045454545454545
27489, -0.066666666666667, -0.2, 0.022727272727273
27490, -0.083333333333333, -0.2, 0.45454545454545
27491, -0.083333333333333, -0.2, 0.40909090909091
27492, -0.083333333333333, -0.2, 0.36363636363636
27493, -0.083333333333333, -0.2, 0.31818181818182
27494, -0.083333333333333, -0.2, 0.27272727272727
27495, -0.083333333333333, -0.2, 0.22727272727273
27496, -0.083333333333333, -0.2, 0.18181818181818
27497, -0.083333333333333, -0.2, 0.13636363636364
27498, -0.083333333333333, -0.2, 0.090909090909091
27499, -0.083333333333333, -0.2, 0.045454545454545
27500, 2.2, -0.05, 0.45454545454545
27501, 2.2, -0.05, 0.40909090909091
27502, 2.2, -0.05, 0.36363636363636
27503, 2.2, -0.05, 0.31818181818182
27504, 2.2, -0.05, 0.27272727272727
27505, 2.2, -0.05, 0.22727272727273
27506, 2.2, -0.05, 0.18181818181818
27507, 2.2, -0.05, 0.13636363636364
27508, 2.2, -0.05, 0.090909090909091
27509, 2.2, -0.05, 0.045454545454545
27510, 2.2, -0.1, 0.45454545454545
27511, 2.2, -0.1, 0.40909090909091
27512, 2.2, -0.1, 0.36363636363636
27513, 2.2, -0.1, 0.31818181818182
27514, 2.2, -0.1, 0.27272727272727
27515, 2.2, -0.1, 0.22727272727273
27516, 2.2, -0.1, 0.18181818181818
27517, 2.2, -0.1, 0.13636363636364
27518, 2.2, -0.1, 0.090909090909091
27519, 2.2, -0.1, 0.045454545454545
27520, 2.2, -0.15, 0.45454545454545
27521, 2.2, -0.15, 0.40909090909091
27522, 2.2, -0.15, 0.36363636363636
27523, 2.2, -0.15, 0.31818181818182
27524, 2.2, -0.15, 0.27272727272727
27525, 2.2, -0.15, 0.22727272727273
27526, 2.2, -0.15, 0.18181818181818
27527, 2.2, -0.15, 0.13636363636364
27528, 2.2, -0.15, 0.090909090909091
27529, 2.2, -0.15, 0.045454545454545
27530, 2.2, -0.05, 0.47727272727273
27531, 2.2, -0.025, 0.45454545454545
27532, 2.2, -0.05, 0.43181818181818
27533, 2.2, -0.025, 0.40909090909091
27534, 2.2, -0.05, 0.38636363636364
27535, 2.2, -0.025, 0.36363636363636
27536, 2.2, -0.05, 0.34090909090909
27537, 2.2, -0.025, 0.31818181818182
27538, 2.2, -0.05, 0.29545454545455
27539, 2.2, -0.025, 0.27272727272727
27540, 2.2, -0.05, 0.25
27541, 2.2, -0.025, 0.22727272727273
27542, 2.2, -0.05, 0.20454545454545
27543, 2.2, -0.025, 0.18181818181818
27544, 2.2, -0.05, 0.15909090909091
27545, 2.2, -0.025, 0.13636363636364
27546, 2.2, -0.05, 0.11363636363636
27547, 2.2, -0.025, 0.090909090909091
27548, 2.2, -0.05, 0.068181818181818
27549, 2.2, -0.025, 0.045454545454545
27550, 2.2, -0.05, 0.022727272727273
27551, 2.2, -0.1, 0.47727272727273
27552, 2.2, -0.075, 0.45454545454545
27553, 2.2, -0.1, 0.43181818181818
27554, 2.2, -0.075, 0.40909090909091
27555, 2.2, -0.1, 0.38636363636364
27556, 2.2, -0.075, 0.36363636363636
27557, 2.2, -0.1, 0.34090909090909
27558, 2.2, -0.075, 0.31818181818182
27559, 2.2, -0.1, 0.29545454545455
27560, 2.2, -0.075, 0.27272727272727
27561, 2.2, -0.1, 0.25
27562, 2.2, -0.075, 0.22727272727273
27563, 2.2, -0.1, 0.20454545454545
27564, 2.2, -0.075, 0.18181818181818
27565, 2.2, -0.1, 0.15909090909091
27566, 2.2, -0.075, 0.13636363636364
27567, 2.2, -0.1, 0.11363636363636
27568, 2.2, -0.075, 0.090909090909091
27569, 2.2, -0.1, 0.068181818181818
27570, 2.2, -0.075, 0.045454545454545
27571, 2.2, -0.1, 0.022727272727273
27572, 2.2, -0.15, 0.47727272727273
27573, 2.2, -0.125, 0.45454545454545
27574, 2.2, -0.15, 0.43181818181818
27575, 2.2, -0.125, 0.40909090909091
27576, 2.2, -0.15, 0.38636363636364
27577, 2.2, -0.125, 0.36363636363636
27578, 2.2, -0.15, 0.34090909090909
27579, 2.2, -0.125, 0.31818181818182
27580, 2.2, -0.15, 0.29545454545455
27581, 2.2, -0.125, 0.27272727272727
27582, 2.2, -0.15, 0.25
27583, 2.2, -0.125, 0.22727272727273
27584, 2.2, -0.15, 0.20454545454545
27585, 2.2, -0.125, 0.18181818181818
27586, 2.2, -0.15, 0.15909090909091
27587, 2.2, -0.125, 0.13636363636364
27588, 2.2, -0.15, 0.11363636363636
27589, 2.2, -0.125, 0.090909090909091
27590, 2.2, -0.15, 0.068181818181818
27591, 2.2, -0.125, 0.045454545454545
27592, 2.2, -0.15, 0.022727272727273
27593, 2.2, -0.175, 0.45454545454545
27594, 2.2, -0.175, 0.40909090909091
27595, 2.2, -0.175, 0.36363636363636
27596, 2.2, -0.175, 0.31818181818182
27597, 2.2, -0.175, 0.27272727272727
27598, 2.2, -0.175, 0.22727272727273
27599, 2.2, -0.175, 0.18181818181818
27600, 2.2, -0.175, 0.13636363636364
27601, 2.2, -0.175, 0.090909090909091
27602, 2.2, -0.175, 0.045454545454545
27603, 2.2333333333333, -0.05, 0.5
27604, 2.2666666666667, -0.05, 0.5
27605, 2.2333333333333, -0.1, 0.5
27606, 2.2666666666667, -0.1, 0.5
27607, 2.2333333333333, -0.15, 0.5
27608, 2.2666666666667, -0.15, 0.5
27609, 2.2166666666667, -0.05, 0.5
27610, 2.2333333333333, -0.025, 0.5
27611, 2.25, -0.05, 0.5
27612, 2.2666666666667, -0.025, 0.5
27613, 2.2833333333333, -0.05, 0.5
27614, 2.2166666666667, -0.1, 0.5
27615, 2.2333333333333, -0.075, 0.5
27616, 2.25, -0.1, 0.5
27617, 2.2666666666667, -0.075, 0.5
27618, 2.2833333333333, -0.1, 0.5
27619, 2.2166666666667, -0.15, 0.5
27620, 2.2333333333333, -0.125, 0.5
27621, 2.25, -0.15, 0.5
27622, 2.2666666666667, -0.125, 0.5
27623, 2.2833333333333, -0.15, 0.5
27624, 2.2333333333333, -0.175, 0.5
27625, 2.2666666666667, -0.175, 0.5
27626, 2.2333333333333, -0.05, 0
27627, 2.2666666666667, -0.05, 0
27628, 2.2333333333333, -0.1, 0
27629, 2.2666666666667, -0.1, 0
27630, 2.2333333333333, -0.15, 0
27631, 2.2666666666667, -0.15, 0
27632, 2.2333333333333, -0.025, 0
27633, 2.2166666666667, -0.05, 0
27634, 2.2666666666667, -0.025, 0
27635, 2.25, -0.05, 0
27636, 2.2833333333333, -0.05, 0
27637, 2.2333333333333, -0.075, 0
27638, 2.2166666666667, -0.1, 0
27639, 2.2666666666667, -0.075, 0
27640, 2.25, -0.1, 0
27641, 2.2833333333333, -0.1, 0
27642, 2.2333333333333, -0.125, 0
27643, 2.2166666666667, -0.15, 0
27644, 2.2666666666667, -0.125, 0
27645, 2.25, -0.15, 0
27646, 2.2833333333333, -0.15, 0
27647, 2.2333333333333, -0.175, 0
27648, 2.2666666666667, -0.175, 0
27649, 2.3, -0.05, 0.45454545454545
27650, 2.3, -0.05, 0.40909090909091
27651, 2.3, -0.05, 0.36363636363636
27652, 2.3, -0.05, 0.31818181818182
27653, 2.3, -0.05, 0.27272727272727
27654, 2.3, -0.05, 0.22727272727273
27655, 2.3, -0.05, 0.18181818181818
27656, 2.3, -0.05, 0.13636363636364
27657, 2.3, -0.05, 0.090909090909091
27658, 2.3, -0.05, 0.045454545454545
27659, 2.3, -0.1, 0.45454545454545
27660, 2.3, -0.1, 0.40909090909091
27661, 2.3, -0.1, 0.36363636363636
27662, 2.3, -0.1, 0.31818181818182
27663, 2.3, -0.1, 0.27272727272727
27664, 2.3, -0.1, 0.22727272727273
27665, 2.3, -0.1, 0.18181818181818
27666, 2.3, -0.1, 0.13636363636364
27667, 2.3, -0.1, 0.090909090909091
27668, 2.3, -0.1, 0.045454545454545
27669, 2.3, -0.15, 0.45454545454545
27670, 2.3, -0.15, 0.40909090909091
27671, 2.3, -0.15, 0.36363636363636
27672, 2.3, -0.15, 0.31818181818182
27673, 2.3, -0.15, 0.27272727272727
27674, 2.3, -0.15, 0.22727272727273
27675, 2.3, -0.15, 0.18181818181818
27676, 2.3, -0.15, 0.13636363636364
27677, 2.3, -0.15, 0.090909090909091
27678, 2.3, -0.15, 0.045454545454545
27679, 2.3, -0.05, 0.47727272727273
27680, 2.3, -0.025, 0.45454545454545
27681, 2.3, -0.05, 0.43181818181818
27682, 2.3, -0.025, 0.40909090909091
27683, 2.3, -0.05, 0.38636363636364
27684, 2.3, -0.025, 0.36363636363636
27685, 2.3, -0.05, 0.34090909090909
27686, 2.3, -0.025, 0.31818181818182
27687, 2.3, -0.05, 0.29545454545455
27688, 2.3, -0.025, 0.27272727272727
27689, 2.3, -0.05, 0.25
27690, 2.3, -0.025, 0.22727272727273
27691, 2.3, -0.05, 0.20454545454545
27692, 2.3, -0.025, 0.18181818181818
27693, 2.3, -0.05, 0.15909090909091
27694, 2.3, -0.025, 0.13636363636364
27695, 2.3, -0.05, 0.11363636363636
27696, 2.3, -0.025, 0.090909090909091
27697, 2.3, -0.05, 0.068181818181818
27698, 2.3, -0.025, 0.045454545454545
27699, 2.3, -0.05, 0.022727272727273
27700, 2.3, -0.1, 0.47727272727273
27701, 2.3, -0.075, 0.45454545454545
27702, 2.3, -0.1, 0.43181818181818
27703, 2.3, -0.075, 0.40909090909091
27704, 2.3, -0.1, 0.38636363636364
27705, 2.3, -0.075, 0.36363636363636
27706, 2.3, -0.1, 0.34090909090909
27707, 2.3, -0.075, 0.31818181818182
27708, 2.3, -0.1, 0.29545454545455
27709, 2.3, -0.075, 0.27272727272727
27710, 2.3, -0.1, 0.25
27711, 2.3, -0.075, 0.22727272727273
27712, 2.3, -0.1, 0.20454545454545
27713, 2.3, -0.075, 0.18181818181818
27714, 2.3, -0.1, 0.15909090909091
27715, 2.3, -0.075, 0.13636363636364
27716, 2.3, -0.1, 0.11363636363636
27717, 2.3, -0.075, 0.090909090909091
27718, 2.3, -0.1, 0.068181818181818
27719, 2.3, -0.075, 0.045454545454545
27720, 2.3, -0.1, 0.022727272727273
27721, 2.3, -0.15, 0.47727272727273
27722, 2.3, -0.125, 0.45454545454545
27723, 2.3, -0.15, 0.43181818181818
27724, 2.3, -0.125, 0.40909090909091
27725, 2.3, -0.15, 0.38636363636364
27726, 2.3, -0.125, 0.36363636363636
27727, 2.3, -0.15, 0.34090909090909
27728, 2.3, -0.125, 0.31818181818182
27729, 2.3, -0.15, 0.29545454545455
27730, 2.3, -0.125, 0.27272727272727
27731, 2.3, -0.15, 0.25
27732, 2.3, -0.125, 0.22727272727273
27733, 2.3, -0.15, 0.20454545454545
27734, 2.3, -0.125, 0.18181818181818
27735, 2.3, -0.15, 0.15909090909091
27736, 2.3, -0.125, 0.13636363636364
27737, 2.3, -0.15, 0.11363636363636
27738, 2.3, -0.125, 0.090909090909091
27739, 2.3, -0.15, 0.068181818181818
27740, 2.3, -0.125, 0.045454545454545
27741, 2.3, -0.15, 0.022727272727273
27742, 2.3, -0.175, 0.45454545454545
27743, 2.3, -0.175, 0.40909090909091
27744, 2.3, -0.175, 0.36363636363636
27745, 2.3, -0.175, 0.31818181818182
27746, 2.3, -0.175, 0.27272727272727
27747, 2.3, -0.175, 0.22727272727273
27748, 2.3, -0.175, 0.18181818181818
27749, 2.3, -0.175, 0.13636363636364
27750, 2.3, -0.175, 0.090909090909091
27751, 2.3, -0.175, 0.045454545454545
27752, 2.2333333333333, -0.2, 0.45454545454545
27753, 2.2333333333333, -0.2, 0.40909090909091
27754, 2.2333333333333, -0.2, 0.36363636363636
27755, 2.2333333333333, -0.2, 0.31818181818182
27756, 2.2333333333333, -0.2, 0.27272727272727
27757, 2.2333333333333, -0.2, 0.22727272727273
27758, 2.2333333333333, -0.2, 0.18181818181818
27759, 2.2333333333333, -0.2, 0.13636363636364
27760, 2.2333333333333, -0.2, 0.090909090909091
27761, 2.2333333333333, -0.2, 0.045454545454545
27762, 2.2666666666667, -0.2, 0.45454545454545
27763, 2.2666666666667, -0.2, 0.40909090909091
27764, 2.2666666666667, -0.2, 0.36363636363636
27765, 2.2666666666667, -0.2, 0.31818181818182
27766, 2.2666666666667, -0.2, 0.27272727272727
27767, 2.2666666666667, -0.2, 0.22727272727273
27768, 2.2666666666667, -0.2, 0.18181818181818
27769, 2.2666666666667, -0.2, 0.13636363636364
27770, 2.2666666666667, -0.2, 0.090909090909091
27771, 2.2666666666667, -0.2, 0.045454545454545
27772, 2.2166666666667, -0.2, 0.45454545454545
27773, 2.2333333333333, -0.2, 0.47727272727273
27774, 2.2166666666667, -0.2, 0.40909090909091
27775, 2.2333333333333, -0.2, 0.43181818181818
27776, 2.2166666666667, -0.2, 0.36363636363636
27777, 2.2333333333333, -0.2, 0.38636363636364
27778, 2.2166666666667, -0.2, 0.31818181818182
27779, 2.2333333333333, -0.2, 0.34090909090909
27780, 2.2166666666667, -0.2, 0.27272727272727
27781, 2.2333333333333, -0.2, 0.29545454545455
27782, 2.2166666666667, -0.2, 0.22727272727273
27783, 2.2333333333333, -0.2, 0.25
27784, 2.2166666666667, -0.2, 0.18181818181818
27785, 2.2333333333333, -0.2, 0.20454545454545
27786, 2.2166666666667, -0.2, 0.13636363636364
27787, 2.2333333333333, -0.2, 0.15909090909091
27788, 2.2166666666667, -0.2, 0.090909090909091
27789, 2.2333333333333, -0.2, 0.11363636363636
27790, 2.2166666666667, -0.2, 0.045454545454545
27791, 2.2333333333333, -0.2, 0.068181818181818
27792, 2.2333333333333, -0.2, 0.022727272727273
27793, 2.25, -0.2, 0.45454545454545
27794, 2.2666666666667, -0.2, 0.47727272727273
27795, 2.25, -0.2, 0.40909090909091
27796, 2.2666666666667, -0.2, 0.43181818181818
27797, 2.25, -0.2, 0.36363636363636
27798, 2.2666666666667, -0.2, 0.38636363636364
27799, 2.25, -0.2, 0.31818181818182
27800, 2.2666666666667, -0.2, 0.34090909090909
27801, 2.25, -0.2, 0.27272727272727
27802, 2.2666666666667, -0.2, 0.29545454545455
27803, 2.25, -0.2, 0.22727272727273
27804, 2.2666666666667, -0.2, 0.25
27805, 2.25, -0.2, 0.18181818181818
27806, 2.2666666666667, -0.2, 0.20454545454545
27807, 2.25, -0.2, 0.13636363636364
27808, 2.2666666666667, -0.2, 0.15909090909091
27809, 2.25, -0.2, 0.090909090909091
27810, 2.2666666666667, -0.2, 0.11363636363636
27811, 2.25, -0.2, 0.045454545454545
27812, 2.2666666666667, -0.2, 0.068181818181818
27813, 2.2666666666667, -0.2, 0.022727272727273
27814, 2.2833333333333, -0.2, 0.45454545454545
27815, 2.2833333333333, -0.2, 0.40909090909091
27816, 2.2833333333333, -0.2, 0.36363636363636
27817, 2.2833333333333, -0.2, 0.31818181818182
27818, 2.2833333333333, -0.2, 0.27272727272727
27819, 2.2833333333333, -0.2, 0.22727272727273
27820, 2.2833333333333, -0.2, 0.18181818181818
27821, 2.2833333333333, -0.2, 0.13636363636364
27822, 2.2833333333333, -0.2, 0.090909090909091
27823, 2.2833333333333, -0.2, 0.045454545454545
27824, -0.033333333333333, 1.55, 0.5
27825, -0.033333333333333, 1.6, 0.5
27826, -0.033333333333333, 1.65, 0.5
27827, -0.066666666666667, 1.55, 0.5
27828, -0.066666666666667, 1.6, 0.5
27829, -0.066666666666667, 1.65, 0.5
27830, -0.016666666666667, 1.55, 0.5
27831, -0.033333333333333, 1.525, 0.5
27832, -0.016666666666667, 1.6, 0.5
27833, -0.033333333333333, 1.575, 0.5
27834, -0.016666666666667, 1.65, 0.5
27835, -0.033333333333333, 1.625, 0.5
27836, -0.033333333333333, 1.675, 0.5
27837, -0.05, 1.55, 0.5
27838, -0.066666666666667, 1.525, 0.5
27839, -0.05, 1.6, 0.5
27840, -0.066666666666667, 1.575, 0.5
27841, -0.05, 1.65, 0.5
27842, -0.066666666666667, 1.625, 0.5
27843, -0.066666666666667, 1.675, 0.5
27844, -0.083333333333333, 1.55, 0.5
27845, -0.083333333333333, 1.6, 0.5
27846, -0.083333333333333, 1.65, 0.5
27847, -0.033333333333333, 1.55, 0
27848, -0.033333333333333, 1.6, 0
27849, -0.033333333333333, 1.65, 0
27850, -0.066666666666667, 1.55, 0
27851, -0.066666666666667, 1.6, 0
27852, -0.066666666666667, 1.65, 0
27853, -0.033333333333333, 1.525, 0
27854, -0.016666666666667, 1.55, 0
27855, -0.033333333333333, 1.575, 0
27856, -0.016666666666667, 1.6, 0
27857, -0.033333333333333, 1.625, 0
27858, -0.016666666666667, 1.65, 0
27859, -0.033333333333333, 1.675, 0
27860, -0.066666666666667, 1.525, 0
27861, -0.05, 1.55, 0
27862, -0.066666666666667, 1.575, 0
27863, -0.05, 1.6, 0
27864, -0.066666666666667, 1.625, 0
27865, -0.05, 1.65, 0
27866, -0.066666666666667, 1.675, 0
27867, -0.083333333333333, 1.55, 0
27868, -0.083333333333333, 1.6, 0
27869, -0.083333333333333, 1.65, 0
27870, -0.033333333333333, 1.5, 0.45454545454545
27871, -0.033333333333333, 1.5, 0.40909090909091
27872, -0.033333333333333, 1.5, 0.36363636363636
27873, -0.033333333333333, 1.5, 0.31818181818182
27874, -0.033333333333333, 1.5, 0.27272727272727
27875, -0.033333333333333, 1.5, 0.22727272727273
27876, -0.033333333333333, 1.5, 0.18181818181818
27877, -0.033333333333333, 1.5, 0.13636363636364
27878, -0.033333333333333, 1.5, 0.090909090909091
27879, -0.033333333333333, 1.5, 0.045454545454545
27880, -0.066666666666667, 1.5, 0.45454545454545
27881, -0.066666666666667, 1.5, 0.40909090909091
27882, -0.066666666666667, 1.5, 0.36363636363636
27883, -0.066666666666667, 1.5, 0.31818181818182
27884, -0.066666666666667, 1.5, 0.27272727272727
27885, -0.066666666666667, 1.5, 0.22727272727273
27886, -0.066666666666667, 1.5, 0.18181818181818
27887, -0.066666666666667, 1.5, 0.13636363636364
27888, -0.066666666666667, 1.5, 0.090909090909091
27889, -0.066666666666667, 1.5, 0.045454545454545
27890, -0.033333333333333, 1.5, 0.47727272727273
27891, -0.016666666666667, 1.5, 0.45454545454545
27892, -0.033333333333333, 1.5, 0.43181818181818
27893, -0.016666666666667, 1.5, 0.40909090909091
27894, -0.033333333333333, 1.5, 0.38636363636364
27895, -0.016666666666667, 1.5, 0.36363636363636
27896, -0.033333333333333, 1.5, 0.34090909090909
27897, -0.016666666666667, 1.5, 0.31818181818182
27898, -0.033333333333333, 1.5, 0.29545454545455
27899, -0.016666666666667, 1.5, 0.27272727272727
27900, -0.033333333333333, 1.5, 0.25
27901, -0.016666666666667, 1.5, 0.22727272727273
27902, -0.033333333333333, 1.5, 0.20454545454545
27903, -0.016666666666667, 1.5, 0.18181818181818
27904, -0.033333333333333, 1.5, 0.15909090909091
27905, -0.016666666666667, 1.5, 0.13636363636364
27906, -0.033333333333333, 1.5, 0.11363636363636
27907, -0.016666666666667, 1.5, 0.090909090909091
27908, -0.033333333333333, 1.5, 0.068181818181818
27909, -0.016666666666667, 1.5, 0.045454545454545
27910, -0.033333333333333, 1.5, 0.022727272727273
27911, -0.066666666666667, 1.5, 0.47727272727273
27912, -0.05, 1.5, 0.45454545454545
27913, -0.066666666666667, 1.5, 0.43181818181818
27914, -0.05, 1.5, 0.40909090909091
27915, -0.066666666666667, 1.5, 0.38636363636364
27916, -0.05, 1.5, 0.36363636363636
27917, -0.066666666666667, 1.5, 0.34090909090909
27918, -0.05, 1.5, 0.31818181818182
27919, -0.066666666666667, 1.5, 0.29545454545455
27920, -0.05, 1.5, 0.27272727272727
27921, -0.066666666666667, 1.5, 0.25
27922, -0.05, 1.5, 0.22727272727273
27923, -0.066666666666667, 1.5, 0.20454545454545
27924, -0.05, 1.5, 0.18181818181818
27925, -0.066666666666667, 1.5, 0.15909090909091
27926, -0.05, 1.5, 0.13636363636364
27927, -0.066666666666667, 1.5, 0.11363636363636
27928, -0.05, 1.5, 0.090909090909091
27929, -0.066666666666667, 1.5, 0.068181818181818
27930, -0.05, 1.5, 0.045454545454545
27931, -0.066666666666667, 1.5, 0.022727272727273
27932, -0.083333333333333, 1.5, 0.45454545454545
27933, -0.083333333333333, 1.5, 0.40909090909091
27934, -0.083333333333333, 1.5, 0.36363636363636
27935, -0.083333333333333, 1.5, 0.31818181818182
27936, -0.083333333333333, 1.5, 0.27272727272727
27937, -0.083333333333333, 1.5, 0.22727272727273
27938, -0.083333333333333, 1.5, 0.18181818181818
27939, -0.083333333333333, 1.5, 0.13636363636364
27940, -0.083333333333333, 1.5, 0.090909090909091
27941, -0.083333333333333, 1.5, 0.045454545454545
27942, -0.033333333333333, 1.7, 0.45454545454545
27943, -0.033333333333333, 1.7, 0.40909090909091
27944, -0.033333333333333, 1.7, 0.36363636363636
27945, -0.033333333333333, 1.7, 0.31818181818182
27946, -0.033333333333333, 1.7, 0.27272727272727
27947, -0.033333333333333, 1.7, 0.22727272727273
27948, -0.033333333333333, 1.7, 0.18181818181818
27949, -0.033333333333333, 1.7, 0.13636363636364
27950, -0.033333333333333, 1.7, 0.090909090909091
27951, -0.033333333333333, 1.7, 0.045454545454545
27952, -0.066666666666667, 1.7, 0.45454545454545
27953, -0.066666666666667, 1.7, 0.40909090909091
27954, -0.066666666666667, 1.7, 0.36363636363636
27955, -0.066666666666667, 1.7, 0.31818181818182
27956, -0.066666666666667, 1.7, 0.27272727272727
27957, -0.066666666666667, 1.7, 0.22727272727273
27958, -0.066666666666667, 1.7, 0.18181818181818
27959, -0.066666666666667, 1.7, 0.13636363636364
27960, -0.066666666666667, 1.7, 0.090909090909091
27961, -0.066666666666667, 1.7, 0.045454545454545
27962, -0.016666666666667, 1.7, 0.45454545454545
27963, -0.033333333333333, 1.7, 0.47727272727273
27964, -0.016666666666667, 1.7, 0.40909090909091
27965, -0.033333333333333, 1.7, 0.43181818181818
27966, -0.016666666666667, 1.7, 0.36363636363636
27967, -0.033333333333333, 1.7, 0.38636363636364
27968, -0.016666666666667, 1.7, 0.31818181818182
27969, -0.033333333333333, 1.7, 0.34090909090909
27970, -0.016666666666667, 1.7, 0.27272727272727
27971, -0.033333333333333, 1.7, 0.29545454545455
27972, -0.016666666666667, 1.7, 0.22727272727273
27973, -0.033333333333333, 1.7, 0.25
27974, -0.016666666666667, 1.7, 0.18181818181818
27975, -0.033333333333333, 1.7, 0.20454545454545
27976, -0.016666666666667, 1.7, 0.13636363636364
27977, -0.033333333333333, 1.7, 0.15909090909091
27978, -0.016666666666667, 1.7, 0.090909090909091
27979, -0.033333333333333, 1.7, 0.11363636363636
27980, -0.016666666666667, 1.7, 0.045454545454545
27981, -0.033333333333333, 1.7, 0.068181818181818
27982, -0.033333333333333, 1.7, 0.022727272727273
27983, -0.05, 1.7, 0.45454545454545
27984, -0.066666666666667, 1.7, 0.47727272727273
27985, -0.05, 1.7, 0.40909090909091
27986, -0.066666666666667, 1.7, 0.43181818181818
27987, -0.05, 1.7, 0.36363636363636
27988, -0.066666666666667, 1.7, 0.38636363636364
27989, -0.05, 1.7, 0.31818181818182
27990, -0.066666666666667, 1.7, 0.34090909090909
27991, -0.05, 1.7, 0.27272727272727
27992, -0.066666666666667, 1.7, 0.29545454545455
27993, -0.05, 1.7, 0.22727272727273
27994, -0.066666666666667, 1.7, 0.25
27995, -0.05, 1.7, 0.18181818181818
27996, -0.066666666666667, 1.7, 0.20454545454545
27997, -0.05, 1.7, 0.13636363636364
27998, -0.066666666666667, 1.7, 0.15909090909091
27999, -0.05, 1.7, 0.090909090909091
28000, -0.066666666666667, 1.7, 0.11363636363636
28001, -0.05, 1.7, 0.045454545454545
28002, -0.066666666666667, 1.7, 0.068181818181818
28003, -0.066666666666667, 1.7, 0.022727272727273
28004, -0.083333333333333, 1.7, 0.45454545454545
28005, -0.083333333333333, 1.7, 0.40909090909091
28006, -0.083333333333333, 1.7, 0.36363636363636
28007, -0.083333333333333, 1.7, 0.31818181818182
28008, -0.083333333333333, 1.7, 0.27272727272727
28009, -0.083333333333333, 1.7, 0.22727272727273
28010, -0.083333333333333, 1.7, 0.18181818181818
28011, -0.083333333333333, 1.7, 0.13636363636364
28012, -0.083333333333333, 1.7, 0.090909090909091
28013, -0.083333333333333, 1.7, 0.045454545454545
28014, -0.1, 1.55, 0.45454545454545
28015, -0.1, 1.55, 0.40909090909091
28016, -0.1, 1.55, 0.36363636363636
28017, -0.1, 1.55, 0.31818181818182
28018, -0.1, 1.55, 0.27272727272727
28019, -0.1, 1.55, 0.22727272727273
28020, -0.1, 1.55, 0.18181818181818
28021, -0.1, 1.55, 0.13636363636364
28022, -0.1, 1.55, 0.090909090909091
28023, -0.1, 1.55, 0.045454545454545
28024, -0.1, 1.6, 0.45454545454545
28025, -0.1, 1.6, 0.40909090909091
28026, -0.1, 1.6, 0.36363636363636
28027, -0.1, 1.6, 0.31818181818182
28028, -0.1, 1.6, 0.27272727272727
28029, -0.1, 1.6, 0.22727272727273
28030, -0.1, 1.6, 0.18181818181818
28031, -0.1, 1.6, 0.13636363636364
28032, -0.1, 1.6, 0.090909090909091
28033, -0.1, 1.6, 0.045454545454545
28034, -0.1, 1.65, 0.45454545454545
28035, -0.1, 1.65, 0.40909090909091
28036, -0.1, 1.65, 0.36363636363636
28037, -0.1, 1.65, 0.31818181818182
28038, -0.1, 1.65, 0.27272727272727
28039, -0.1, 1.65, 0.22727272727273
28040, -0.1, 1.65, 0.18181818181818
28041, -0.1, 1.65, 0.13636363636364
28042, -0.1, 1.65, 0.090909090909091
28043, -0.1, 1.65, 0.045454545454545
28044, -0.1, 1.55, 0.47727272727273
28045, -0.1, 1.525, 0.45454545454545
28046, -0.1, 1.55, 0.43181818181818
28047, -0.1, 1.525, 0.40909090909091
28048, -0.1, 1.55, 0.38636363636364
28049, -0.1, 1.525, 0.36363636363636
28050, -0.1, 1.55, 0.34090909090909
28051, -0.1, 1.525, 0.31818181818182
28052, -0.1, 1.55, 0.29545454545455
28053, -0.1, 1.525, 0.27272727272727
28054, -0.1, 1.55, 0.25
28055, -0.1, 1.525, 0.22727272727273
28056, -0.1, 1.55, 0.20454545454545
28057, -0.1, 1.525, 0.18181818181818
28058, -0.1, 1.55, 0.15909090909091
28059, -0.1, 1.525, 0.13636363636364
28060, -0.1, 1.55, 0.11363636363636
28061, -0.1, 1.525, 0.090909090909091
28062, -0.1, 1.55, 0.068181818181818
28063, -0.1, 1.525, 0.045454545454545
28064, -0.1, 1.55, 0.022727272727273
28065, -0.1, 1.6, 0.47727272727273
28066, -0.1, 1.575, 0.45454545454545
28067, -0.1, 1.6, 0.43181818181818
28068, -0.1, 1.575, 0.40909090909091
28069, -0.1, 1.6, 0.38636363636364
28070, -0.1, 1.575, 0.36363636363636
28071, -0.1, 1.6, 0.34090909090909
28072, -0.1, 1.575, 0.31818181818182
28073, -0.1, 1.6, 0.29545454545455
28074, -0.1, 1.575, 0.27272727272727
28075, -0.1, 1.6, 0.25
28076, -0.1, 1.575, 0.22727272727273
28077, -0.1, 1.6, 0.20454545454545
28078, -0.1, 1.575, 0.18181818181818
28079, -0.1, 1.6, 0.15909090909091
28080, -0.1, 1.575, 0.13636363636364
28081, -0.1, 1.6, 0.11363636363636
28082, -0.1, 1.575, 0.090909090909091
28083, -0.1, 1.6, 0.068181818181818
28084, -0.1, 1.575, 0.045454545454545
28085, -0.1, 1.6, 0.022727272727273
28086, -0.1, 1.65, 0.47727272727273
28087, -0.1, 1.625, 0.45454545454545
28088, -0.1, 1.65, 0.43181818181818
28089, -0.1, 1.625, 0.40909090909091
28090, -0.1, 1.65, 0.38636363636364
28091, -0.1, 1.625, 0.36363636363636
28092, -0.1, 1.65, 0.34090909090909
28093, -0.1, 1.625, 0.31818181818182
28094, -0.1, 1.65, 0.29545454545455
28095, -0.1, 1.625, 0.27272727272727
28096, -0.1, 1.65, 0.25
28097, -0.1, 1.625, 0.22727272727273
28098, -0.1, 1.65, 0.20454545454545
28099, -0.1, 1.625, 0.18181818181818
28100, -0.1, 1.65, 0.15909090909091
28101, -0.1, 1.625, 0.13636363636364
28102, -0.1, 1.65, 0.11363636363636
28103, -0.1, 1.625, 0.090909090909091
28104, -0.1, 1.65, 0.068181818181818
28105, -0.1, 1.625, 0.045454545454545
28106, -0.1, 1.65, 0.022727272727273
28107, -0.1, 1.675, 0.45454545454545
28108, -0.1, 1.675, 0.40909090909091
28109, -0.1, 1.675, 0.36363636363636
28110, -0.1, 1.675, 0.31818181818182
28111, -0.1, 1.675, 0.27272727272727
28112, -0.1, 1.675, 0.22727272727273
28113, -0.1, 1.675, 0.18181818181818
28114, -0.1, 1.675, 0.13636363636364
28115, -0.1, 1.675, 0.090909090909091
28116, -0.1, 1.675, 0.045454545454545
28117, -0.033333333333333, 1.4333333333333, 0.5
28118, -0.033333333333333, 1.4666666666667, 0.5
28119, -0.066666666666667, 1.4333333333333, 0.5
28120, -0.066666666666667, 1.4666666666667, 0.5
28121, -0.016666666666667, 1.4333333333333, 0.5
28122, -0.033333333333333, 1.4166666666667, 0.5
28123, -0.016666666666667, 1.4666666666667, 0.5
28124, -0.033333333333333, 1.45, 0.5
28125, -0.033333333333333, 1.4833333333333, 0.5
28126, -0.05, 1.4333333333333, 0.5
28127, -0.066666666666667, 1.4166666666667, 0.5
28128, -0.05, 1.4666666666667, 0.5
28129, -0.066666666666667, 1.45, 0.5
28130, -0.066666666666667, 1.4833333333333, 0.5
28131, -0.083333333333333, 1.4333333333333, 0.5
28132, -0.083333333333333, 1.4666666666667, 0.5
28133, -0.033333333333333, 1.4333333333333, 0
28134, -0.033333333333333, 1.4666666666667, 0
28135, -0.066666666666667, 1.4333333333333, 0
28136, -0.066666666666667, 1.4666666666667, 0
28137, -0.033333333333333, 1.4166666666667, 0
28138, -0.016666666666667, 1.4333333333333, 0
28139, -0.033333333333333, 1.45, 0
28140, -0.016666666666667, 1.4666666666667, 0
28141, -0.033333333333333, 1.4833333333333, 0
28142, -0.066666666666667, 1.4166666666667, 0
28143, -0.05, 1.4333333333333, 0
28144, -0.066666666666667, 1.45, 0
28145, -0.05, 1.4666666666667, 0
28146, -0.066666666666667, 1.4833333333333, 0
28147, -0.083333333333333, 1.4333333333333, 0
28148, -0.083333333333333, 1.4666666666667, 0
28149, -0.033333333333333, 1.4, 0.45454545454545
28150, -0.033333333333333, 1.4, 0.40909090909091
28151, -0.033333333333333, 1.4, 0.36363636363636
28152, -0.033333333333333, 1.4, 0.31818181818182
28153, -0.033333333333333, 1.4, 0.27272727272727
28154, -0.033333333333333, 1.4, 0.22727272727273
28155, -0.033333333333333, 1.4, 0.18181818181818
28156, -0.033333333333333, 1.4, 0.13636363636364
28157, -0.033333333333333, 1.4, 0.090909090909091
28158, -0.033333333333333, 1.4, 0.045454545454545
28159, -0.066666666666667, 1.4, 0.45454545454545
28160, -0.066666666666667, 1.4, 0.40909090909091
28161, -0.066666666666667, 1.4, 0.36363636363636
28162, -0.066666666666667, 1.4, 0.31818181818182
28163, -0.066666666666667, 1.4, 0.27272727272727
28164, -0.066666666666667, 1.4, 0.22727272727273
28165, -0.066666666666667, 1.4, 0.18181818181818
28166, -0.066666666666667, 1.4, 0.13636363636364
28167, -0.066666666666667, 1.4, 0.090909090909091
28168, -0.066666666666667, 1.4, 0.045454545454545
28169, -0.033333333333333, 1.4, 0.47727272727273
28170, -0.016666666666667, 1.4, 0.45454545454545
28171, -0.033333333333333, 1.4, 0.43181818181818
28172, -0.016666666666667, 1.4, 0.40909090909091
28173, -0.033333333333333, 1.4, 0.38636363636364
28174, -0.016666666666667, 1.4, 0.36363636363636
28175, -0.033333333333333, 1.4, 0.34090909090909
28176, -0.016666666666667, 1.4, 0.31818181818182
28177, -0.033333333333333, 1.4, 0.29545454545455
28178, -0.016666666666667, 1.4, 0.27272727272727
28179, -0.033333333333333, 1.4, 0.25
28180, -0.016666666666667, 1.4, 0.22727272727273
28181, -0.033333333333333, 1.4, 0.20454545454545
28182, -0.016666666666667, 1.4, 0.18181818181818
28183, -0.033333333333333, 1.4, 0.15909090909091
28184, -0.016666666666667, 1.4, 0.13636363636364
28185, -0.033333333333333, 1.4, 0.11363636363636
28186, -0.016666666666667, 1.4, 0.090909090909091
28187, -0.033333333333333, 1.4, 0.068181818181818
28188, -0.016666666666667, 1.4, 0.045454545454545
28189, -0.033333333333333, 1.4, 0.022727272727273
28190, -0.066666666666667, 1.4, 0.47727272727273
28191, -0.05, 1.4, 0.45454545454545
28192, -0.066666666666667, 1.4, 0.43181818181818
28193, -0.05, 1.4, 0.40909090909091
28194, -0.066666666666667, 1.4, 0.38636363636364
28195, -0.05, 1.4, 0.36363636363636
28196, -0.066666666666667, 1.4, 0.34090909090909
28197, -0.05, 1.4, 0.31818181818182
28198, -0.066666666666667, 1.4, 0.29545454545455
28199, -0.05, 1.4, 0.27272727272727
28200, -0.066666666666667, 1.4, 0.25
28201, -0.05, 1.4, 0.22727272727273
28202, -0.066666666666667, 1.4, 0.20454545454545
28203, -0.05, 1.4, 0.18181818181818
28204, -0.066666666666667, 1.4, 0.15909090909091
28205, -0.05, 1.4, 0.13636363636364
28206, -0.066666666666667, 1.4, 0.11363636363636
28207, -0.05, 1.4, 0.090909090909091
28208, -0.066666666666667, 1.4, 0.068181818181818
28209, -0.05, 1.4, 0.045454545454545
28210, -0.066666666666667, 1.4, 0.022727272727273
28211, -0.083333333333333, 1.4, 0.45454545454545
28212, -0.083333333333333, 1.4, 0.40909090909091
28213, -0.083333333333333, 1.4, 0.36363636363636
28214, -0.083333333333333, 1.4, 0.31818181818182
28215, -0.083333333333333, 1.4, 0.27272727272727
28216, -0.083333333333333, 1.4, 0.22727272727273
28217, -0.083333333333333, 1.4, 0.18181818181818
28218, -0.083333333333333, 1.4, 0.13636363636364
28219, -0.083333333333333, 1.4, 0.090909090909091
28220, -0.083333333333333, 1.4, 0.045454545454545
28221, -0.1, 1.4333333333333, 0.45454545454545
28222, -0.1, 1.4333333333333, 0.40909090909091
28223, -0.1, 1.4333333333333, 0.36363636363636
28224, -0.1, 1.4333333333333, 0.31818181818182
28225, -0.1, 1.4333333333333, 0.27272727272727
28226, -0.1, 1.4333333333333, 0.22727272727273
28227, -0.1, 1.4333333333333, 0.18181818181818
28228, -0.1, 1.4333333333333, 0.13636363636364
28229, -0.1, 1.4333333333333, 0.090909090909091
28230, -0.1, 1.4333333333333, 0.045454545454545
28231, -0.1, 1.4666666666667, 0.45454545454545
28232, -0.1, 1.4666666666667, 0.40909090909091
28233, -0.1, 1.4666666666667, 0.36363636363636
28234, -0.1, 1.4666666666667, 0.31818181818182
28235, -0.1, 1.4666666666667, 0.27272727272727
28236, -0.1, 1.4666666666667, 0.22727272727273
28237, -0.1, 1.4666666666667, 0.18181818181818
28238, -0.1, 1.4666666666667, 0.13636363636364
28239, -0.1, 1.4666666666667, 0.090909090909091
28240, -0.1, 1.4666666666667, 0.045454545454545
28241, -0.1, 1.4333333333333, 0.47727272727273
28242, -0.1, 1.4166666666667, 0.45454545454545
28243, -0.1, 1.4333333333333, 0.43181818181818
28244, -0.1, 1.4166666666667, 0.40909090909091
28245, -0.1, 1.4333333333333, 0.38636363636364
28246, -0.1, 1.4166666666667, 0.36363636363636
28247, -0.1, 1.4333333333333, 0.34090909090909
28248, -0.1, 1.4166666666667, 0.31818181818182
28249, -0.1, 1.4333333333333, 0.29545454545455
28250, -0.1, 1.4166666666667, 0.27272727272727
28251, -0.1, 1.4333333333333, 0.25
28252, -0.1, 1.4166666666667, 0.22727272727273
28253, -0.1, 1.4333333333333, 0.20454545454545
28254, -0.1, 1.4166666666667, 0.18181818181818
28255, -0.1, 1.4333333333333, 0.15909090909091
28256, -0.1, 1.4166666666667, 0.13636363636364
28257, -0.1, 1.4333333333333, 0.11363636363636
28258, -0.1, 1.4166666666667, 0.090909090909091
28259, -0.1, 1.4333333333333, 0.068181818181818
28260, -0.1, 1.4166666666667, 0.045454545454545
28261, -0.1, 1.4333333333333, 0.022727272727273
28262, -0.1, 1.4666666666667, 0.47727272727273
28263, -0.1, 1.45, 0.45454545454545
28264, -0.1, 1.4666666666667, 0.43181818181818
28265, -0.1, 1.45, 0.40909090909091
28266, -0.1, 1.4666666666667, 0.38636363636364
28267, -0.1, 1.45, 0.36363636363636
28268, -0.1, 1.4666666666667, 0.34090909090909
28269, -0.1, 1.45, 0.31818181818182
28270, -0.1, 1.4666666666667, 0.29545454545455
28271, -0.1, 1.45, 0.27272727272727
28272, -0.1, 1.4666666666667, 0.25
28273, -0.1, 1.45, 0.22727272727273
28274, -0.1, 1.4666666666667, 0.20454545454545
28275, -0.1, 1.45, 0.18181818181818
28276, -0.1, 1.4666666666667, 0.15909090909091
28277, -0.1, 1.45, 0.13636363636364
28278, -0.1, 1.4666666666667, 0.11363636363636
28279, -0.1, 1.45, 0.090909090909091
28280, -0.1, 1.4666666666667, 0.068181818181818
28281, -0.1, 1.45, 0.045454545454545
28282, -0.1, 1.4666666666667, 0.022727272727273
28283, -0.1, 1.4833333333333, 0.45454545454545
28284, -0.1, 1.4833333333333, 0.40909090909091
28285, -0.1, 1.4833333333333, 0.36363636363636
28286, -0.1, 1.4833333333333, 0.31818181818182
28287, -0.1, 1.4833333333333, 0.27272727272727
28288, -0.1, 1.4833333333333, 0.22727272727273
28289, -0.1, 1.4833333333333, 0.18181818181818
28290, -0.1, 1.4833333333333, 0.13636363636364
28291, -0.1, 1.4833333333333, 0.090909090909091
28292, -0.1, 1.4833333333333, 0.045454545454545
28293, 2.2333333333333, 1.55, 0.5
28294, 2.2333333333333, 1.6, 0.5
28295, 2.2333333333333, 1.65, 0.5
28296, 2.2666666666667, 1.55, 0.5
28297, 2.2666666666667, 1.6, 0.5
28298, 2.2666666666667, 1.65, 0.5
28299, 2.2333333333333, 1.525, 0.5
28300, 2.2166666666667, 1.55, 0.5
28301, 2.2333333333333, 1.575, 0.5
28302, 2.2166666666667, 1.6, 0.5
28303, 2.2333333333333, 1.625, 0.5
28304, 2.2166666666667, 1.65, 0.5
28305, 2.2333333333333, 1.675, 0.5
28306, 2.2666666666667, 1.525, 0.5
28307, 2.25, 1.55, 0.5
28308, 2.2666666666667, 1.575, 0.5
28309, 2.25, 1.6, 0.5
28310, 2.2666666666667, 1.625, 0.5
28311, 2.25, 1.65, 0.5
28312, 2.2666666666667, 1.675, 0.5
28313, 2.2833333333333, 1.55, 0.5
28314, 2.2833333333333, 1.6, 0.5
28315, 2.2833333333333, 1.65, 0.5
28316, 2.2333333333333, 1.55, 0
28317, 2.2333333333333, 1.6, 0
28318, 2.2333333333333, 1.65, 0
28319, 2.2666666666667, 1.55, 0
28320, 2.2666666666667, 1.6, 0
28321, 2.2666666666667, 1.65, 0
28322, 2.2166666666667, 1.55, 0
28323, 2.2333333333333, 1.525, 0
28324, 2.2166666666667, 1.6, 0
28325, 2.2333333333333, 1.575, 0
28326, 2.2166666666667, 1.65, 0
28327, 2.2333333333333, 1.625, 0
28328, 2.2333333333333, 1.675, 0
28329, 2.25, 1.55, 0
28330, 2.2666666666667, 1.525, 0
28331, 2.25, 1.6, 0
28332, 2.2666666666667, 1.575, 0
28333, 2.25, 1.65, 0
28334, 2.2666666666667, 1.625, 0
28335, 2.2666666666667, 1.675, 0
28336, 2.2833333333333, 1.55, 0
28337, 2.2833333333333, 1.6, 0
28338, 2.2833333333333, 1.65, 0
28339, 2.2333333333333, 1.5, 0.45454545454545
28340, 2.2333333333333, 1.5, 0.40909090909091
28341, 2.2333333333333, 1.5, 0.36363636363636
28342, 2.2333333333333, 1.5, 0.31818181818182
28343, 2.2333333333333, 1.5, 0.27272727272727
28344, 2.2333333333333, 1.5, 0.22727272727273
28345, 2.2333333333333, 1.5, 0.18181818181818
28346, 2.2333333333333, 1.5, 0.13636363636364
28347, 2.2333333333333, 1.5, 0.090909090909091
28348, 2.2333333333333, 1.5, 0.045454545454545
28349, 2.2666666666667, 1.5, 0.45454545454545
28350, 2.2666666666667, 1.5, 0.40909090909091
28351, 2.2666666666667, 1.5, 0.36363636363636
28352, 2.2666666666667, 1.5, 0.31818181818182
28353, 2.2666666666667, 1.5, 0.27272727272727
28354, 2.2666666666667, 1.5, 0.22727272727273
28355, 2.2666666666667, 1.5, 0.18181818181818
28356, 2.2666666666667, 1.5, 0.13636363636364
28357, 2.2666666666667, 1.5, 0.090909090909091
28358, 2.2666666666667, 1.5, 0.045454545454545
28359, 2.2166666666667, 1.5, 0.45454545454545
28360, 2.2333333333333, 1.5, 0.47727272727273
28361, 2.2166666666667, 1.5, 0.40909090909091
28362, 2.2333333333333, 1.5, 0.43181818181818
28363, 2.2166666666667, 1.5, 0.36363636363636
28364, 2.2333333333333, 1.5, 0.38636363636364
28365, 2.2166666666667, 1.5, 0.31818181818182
28366, 2.2333333333333, 1.5, 0.34090909090909
28367, 2.2166666666667, 1.5, 0.27272727272727
28368, 2.2333333333333, 1.5, 0.29545454545455
28369, 2.2166666666667, 1.5, 0.22727272727273
28370, 2.2333333333333, 1.5, 0.25
28371, 2.2166666666667, 1.5, 0.18181818181818
28372, 2.2333333333333, 1.5, 0.20454545454545
28373, 2.2166666666667, 1.5, 0.13636363636364
28374, 2.2333333333333, 1.5, 0.15909090909091
28375, 2.2166666666667, 1.5, 0.090909090909091
28376, 2.2333333333333, 1.5, 0.11363636363636
28377, 2.2166666666667, 1.5, 0.045454545454545
28378, 2.2333333333333, 1.5, 0.068181818181818
28379, 2.2333333333333, 1.5, 0.022727272727273
28380, 2.25, 1.5, 0.45454545454545
28381, 2.2666666666667, 1.5, 0.47727272727273
28382, 2.25, 1.5, 0.40909090909091
28383, 2.2666666666667, 1.5, 0.43181818181818
28384, 2.25, 1.5, 0.36363636363636
28385, 2.2666666666667, 1.5, 0.38636363636364
28386, 2.25, 1.5, 0.31818181818182
28387, 2.2666666666667, 1.5, 0.34090909090909
28388, 2.25, 1.5, 0.27272727272727
28389, 2.2666666666667, 1.5, 0.29545454545455
28390, 2.25, 1.5, 0.22727272727273
28391, 2.2666666666667, 1.5, 0.25
28392, 2.25, 1.5, 0.18181818181818
28393, 2.2666666666667, 1.5, 0.20454545454545
28394, 2.25, 1.5, 0.13636363636364
28395, 2.2666666666667, 1.5, 0.15909090909091
28396, 2.25, 1.5, 0.090909090909091
28397, 2.2666666666667, 1.5, 0.11363636363636
28398, 2.25, 1.5, 0.045454545454545
28399, 2.2666666666667, 1.5, 0.068181818181818
28400, 2.2666666666667, 1.5, 0.022727272727273
28401, 2.2833333333333, 1.5, 0.45454545454545
28402, 2.2833333333333, 1.5, 0.40909090909091
28403, 2.2833333333333, 1.5, 0.36363636363636
28404, 2.2833333333333, 1.5, 0.31818181818182
28405, 2.2833333333333, 1.5, 0.27272727272727
28406, 2.2833333333333, 1.5, 0.22727272727273
28407, 2.2833333333333, 1.5, 0.18181818181818
28408, 2.2833333333333, 1.5, 0.13636363636364
28409, 2.2833333333333, 1.5, 0.090909090909091
28410, 2.2833333333333, 1.5, 0.045454545454545
28411, 2.2333333333333, 1.7, 0.45454545454545
28412, 2.2333333333333, 1.7, 0.40909090909091
28413, 2.2333333333333, 1.7, 0.36363636363636
28414, 2.2333333333333, 1.7, 0.31818181818182
28415, 2.2333333333333, 1.7, 0.27272727272727
28416, 2.2333333333333, 1.7, 0.22727272727273
28417, 2.2333333333333, 1.7, 0.18181818181818
28418, 2.2333333333333, 1.7, 0.13636363636364
28419, 2.2333333333333, 1.7, 0.090909090909091
28420, 2.2333333333333, 1.7, 0.045454545454545
28421, 2.2666666666667, 1.7, 0.45454545454545
28422, 2.2666666666667, 1.7, 0.40909090909091
28423, 2.2666666666667, 1.7, 0.36363636363636
28424, 2.2666666666667, 1.7, 0.31818181818182
28425, 2.2666666666667, 1.7, 0.27272727272727
28426, 2.2666666666667, 1.7, 0.22727272727273
28427, 2.2666666666667, 1.7, 0.18181818181818
28428, 2.2666666666667, 1.7, 0.13636363636364
28429, 2.2666666666667, 1.7, 0.090909090909091
28430, 2.2666666666667, 1.7, 0.045454545454545
28431, 2.2333333333333, 1.7, 0.47727272727273
28432, 2.2166666666667, 1.7, 0.45454545454545
28433, 2.2333333333333, 1.7, 0.43181818181818
28434, 2.2166666666667, 1.7, 0.40909090909091
28435, 2.2333333333333, 1.7, 0.38636363636364
28436, 2.2166666666667, 1.7, 0.36363636363636
28437, 2.2333333333333, 1.7, 0.34090909090909
28438, 2.2166666666667, 1.7, 0.31818181818182
28439, 2.2333333333333, 1.7, 0.29545454545455
28440, 2.2166666666667, 1.7, 0.27272727272727
28441, 2.2333333333333, 1.7, 0.25
28442, 2.2166666666667, 1.7, 0.22727272727273
28443, 2.2333333333333, 1.7, 0.20454545454545
28444, 2.2166666666667, 1.7, 0.18181818181818
28445, 2.2333333333333, 1.7, 0.15909090909091
28446, 2.2166666666667, 1.7, 0.13636363636364
28447, 2.2333333333333, 1.7, 0.11363636363636
28448, 2.2166666666667, 1.7, 0.090909090909091
28449, 2.2333333333333, 1.7, 0.068181818181818
28450, 2.2166666666667, 1.7, 0.045454545454545
28451, 2.2333333333333, 1.7, 0.022727272727273
28452, 2.2666666666667, 1.7, 0.47727272727273
28453, 2.25, 1.7, 0.45454545454545
28454, 2.2666666666667, 1.7, 0.43181818181818
28455, 2.25, 1.7, 0.40909090909091
28456, 2.2666666666667, 1.7, 0.38636363636364
28457, 2.25, 1.7, 0.36363636363636
28458, 2.2666666666667, 1.7, 0.34090909090909
28459, 2.25, 1.7, 0.31818181818182
28460, 2.2666666666667, 1.7, 0.29545454545455
28461, 2.25, 1.7, 0.27272727272727
28462, 2.2666666666667, 1.7, 0.25
28463, 2.25, 1.7, 0.22727272727273
28464, 2.2666666666667, 1.7, 0.20454545454545
28465, 2.25, 1.7, 0.18181818181818
28466, 2.2666666666667, 1.7, 0.15909090909091
28467, 2.25, 1.7, 0.13636363636364
28468, 2.2666666666667, 1.7, 0.11363636363636
28469, 2.25, 1.7, 0.090909090909091
28470, 2.2666666666667, 1.7, 0.068181818181818
28471, 2.25, 1.7, 0.045454545454545
28472, 2.2666666666667, 1.7, 0.022727272727273
28473, 2.2833333333333, 1.7, 0.45454545454545
28474, 2.2833333333333, 1.7, 0.40909090909091
28475, 2.2833333333333, 1.7, 0.36363636363636
28476, 2.2833333333333, 1.7, 0.31818181818182
28477, 2.2833333333333, 1.7, 0.27272727272727
28478, 2.2833333333333, 1.7, 0.22727272727273
28479, 2.2833333333333, 1.7, 0.18181818181818
28480, 2.2833333333333, 1.7, 0.13636363636364
28481, 2.2833333333333, 1.7, 0.090909090909091
28482, 2.2833333333333, 1.7, 0.045454545454545
28483, 2.3, 1.55, 0.45454545454545
28484, 2.3, 1.55, 0.40909090909091
28485, 2.3, 1.55, 0.36363636363636
28486, 2.3, 1.55, 0.31818181818182
28487, 2.3, 1.55, 0.27272727272727
28488, 2.3, 1.55, 0.22727272727273
28489, 2.3, 1.55, 0.18181818181818
28490, 2.3, 1.55, 0.13636363636364
28491, 2.3, 1.55, 0.090909090909091
28492, 2.3, 1.55, 0.045454545454545
28493, 2.3, 1.6, 0.45454545454545
28494, 2.3, 1.6, 0.40909090909091
28495, 2.3, 1.6, 0.36363636363636
28496, 2.3, 1.6, 0.31818181818182
28497, 2.3, 1.6, 0.27272727272727
28498, 2.3, 1.6, 0.22727272727273
28499, 2.3, 1.6, 0.18181818181818
28500, 2.3, 1.6, 0.13636363636364
28501, 2.3, 1.6, 0.090909090909091
28502, 2.3, 1.6, 0.045454545454545
28503, 2.3, 1.65, 0.45454545454545
28504, 2.3, 1.65, 0.40909090909091
28505, 2.3, 1.65, 0.36363636363636
28506, 2.3, 1.65, 0.31818181818182
28507, 2.3, 1.65, 0.27272727272727
28508, 2.3, 1.65, 0.22727272727273
28509, 2.3, 1.65, 0.18181818181818
28510, 2.3, 1.65, 0.13636363636364
28511, 2.3, 1.65, 0.090909090909091
28512, 2.3, 1.65, 0.045454545454545
28513, 2.3, 1.525, 0.45454545454545
28514, 2.3, 1.55, 0.47727272727273
28515, 2.3, 1.525, 0.40909090909091
28516, 2.3, 1.55, 0.43181818181818
28517, 2.3, 1.525, 0.36363636363636
28518, 2.3, 1.55, 0.38636363636364
28519, 2.3, 1.525, 0.31818181818182
28520, 2.3, 1.55, 0.34090909090909
28521, 2.3, 1.525, 0.27272727272727
28522, 2.3, 1.55, 0.29545454545455
28523, 2.3, 1.525, 0.22727272727273
28524, 2.3, 1.55, 0.25
28525, 2.3, 1.525, 0.18181818181818
28526, 2.3, 1.55, 0.20454545454545
28527, 2.3, 1.525, 0.13636363636364
28528, 2.3, 1.55, 0.15909090909091
28529, 2.3, 1.525, 0.090909090909091
28530, 2.3, 1.55, 0.11363636363636
28531, 2.3, 1.525, 0.045454545454545
28532, 2.3, 1.55, 0.068181818181818
28533, 2.3, 1.55, 0.022727272727273
28534, 2.3, 1.575, 0.45454545454545
28535, 2.3, 1.6, 0.47727272727273
28536, 2.3, 1.575, 0.40909090909091
28537, 2.3, 1.6, 0.43181818181818
28538, 2.3, 1.575, 0.36363636363636
28539, 2.3, 1.6, 0.38636363636364
28540, 2.3, 1.575, 0.31818181818182
28541, 2.3, 1.6, 0.34090909090909
28542, 2.3, 1.575, 0.27272727272727
28543, 2.3, 1.6, 0.29545454545455
28544, 2.3, 1.575, 0.22727272727273
28545, 2.3, 1.6, 0.25
28546, 2.3, 1.575, 0.18181818181818
28547, 2.3, 1.6, 0.20454545454545
28548, 2.3, 1.575, 0.13636363636364
28549, 2.3, 1.6, 0.15909090909091
28550, 2.3, 1.575, 0.090909090909091
28551, 2.3, 1.6, 0.11363636363636
28552, 2.3, 1.575, 0.045454545454545
28553, 2.3, 1.6, 0.068181818181818
28554, 2.3, 1.6, 0.022727272727273
28555, 2.3, 1.625, 0.45454545454545
28556, 2.3, 1.65, 0.47727272727273
28557, 2.3, 1.625, 0.40909090909091
28558, 2.3, 1.65, 0.43181818181818
28559, 2.3, 1.625, 0.36363636363636
28560, 2.3, 1.65, 0.38636363636364
28561, 2.3, 1.625, 0.31818181818182
28562, 2.3, 1.65, 0.34090909090909
28563, 2.3, 1.625, 0.27272727272727
28564, 2.3, 1.65, 0.29545454545455
28565, 2.3, 1.625, 0.22727272727273
28566, 2.3, 1.65, 0.25
28567, 2.3, 1.625, 0.18181818181818
28568, 2.3, 1.65, 0.20454545454545
28569, 2.3, 1.625, 0.13636363636364
28570, 2.3, 1.65, 0.15909090909091
28571, 2.3, 1.625, 0.090909090909091
28572, 2.3, 1.65, 0.11363636363636
28573, 2.3, 1.625, 0.045454545454545
28574, 2.3, 1.65, 0.068181818181818
28575, 2.3, 1.65, 0.022727272727273
28576, 2.3, 1.675, 0.45454545454545
28577, 2.3, 1.675, 0.40909090909091
28578, 2.3, 1.675, 0.36363636363636
28579, 2.3, 1.675, 0.31818181818182
28580, 2.3, 1.675, 0.27272727272727
28581, 2.3, 1.675, 0.22727272727273
28582, 2.3, 1.675, 0.18181818181818
28583, 2.3, 1.675, 0.13636363636364
28584, 2.3, 1.675, 0.090909090909091
28585, 2.3, 1.675, 0.045454545454545
28586, 2.2333333333333, 1.4333333333333, 0.5
28587, 2.2333333333333, 1.4666666666667, 0.5
28588, 2.2666666666667, 1.4333333333333, 0.5
28589, 2.2666666666667, 1.4666666666667, 0.5
28590, 2.2333333333333, 1.4166666666667, 0.5
28591, 2.2166666666667, 1.4333333333333, 0.5
28592, 2.2333333333333, 1.45, 0.5
28593, 2.2166666666667, 1.4666666666667, 0.5
28594, 2.2333333333333, 1.4833333333333, 0.5
28595, 2.2666666666667, 1.4166666666667, 0.5
28596, 2.25, 1.4333333333333, 0.5
28597, 2.2666666666667, 1.45, 0.5
28598, 2.25, 1.4666666666667, 0.5
28599, 2.2666666666667, 1.4833333333333, 0.5
28600, 2.2833333333333, 1.4333333333333, 0.5
28601, 2.2833333333333, 1.4666666666667, 0.5
28602, 2.2333333333333, 1.4333333333333, 0
28603, 2.2333333333333, 1.4666666666667, 0
28604, 2.2666666666667, 1.4333333333333, 0
28605, 2.2666666666667, 1.4666666666667, 0
28606, 2.2166666666667, 1.4333333333333, 0
28607, 2.2333333333333, 1.4166666666667, 0
28608, 2.2166666666667, 1.4666666666667, 0
28609, 2.2333333333333, 1.45, 0
28610, 2.2333333333333, 1.4833333333333, 0
28611, 2.25, 1.4333333333333, 0
28612, 2.2666666666667, 1.4166666666667, 0
28613, 2.25, 1.4666666666667, 0
28614, 2.2666666666667, 1.45, 0
28615, 2.2666666666667, 1.4833333333333, 0
28616, 2.2833333333333, 1.4333333333333, 0
28617, 2.2833333333333, 1.4666666666667, 0
28618, 2.2333333333333, 1.4, 0.45454545454545
28619, 2.2333333333333, 1.4, 0.40909090909091
28620, 2.2333333333333, 1.4, 0.36363636363636
28621, 2.2333333333333, 1.4, 0.31818181818182
28622, 2.2333333333333, 1.4, 0.27272727272727
28623, 2.2333333333333, 1.4, 0.22727272727273
28624, 2.2333333333333, 1.4, 0.18181818181818
28625, 2.2333333333333, 1.4, 0.13636363636364
28626, 2.2333333333333, 1.4, 0.090909090909091
28627, 2.2333333333333, 1.4, 0.045454545454545
28628, 2.2666666666667, 1.4, 0.45454545454545
28629, 2.2666666666667, 1.4, 0.40909090909091
28630, 2.2666666666667, 1.4, 0.36363636363636
28631, 2.2666666666667, 1.4, 0.31818181818182
28632, 2.2666666666667, 1.4, 0.27272727272727
28633, 2.2666666666667, 1.4, 0.22727272727273
28634, 2.2666666666667, 1.4, 0.18181818181818
28635, 2.2666666666667, 1.4, 0.13636363636364
28636, 2.2666666666667, 1.4, 0.090909090909091
28637, 2.2666666666667, 1.4, 0.045454545454545
28638, 2.2166666666667, 1.4, 0.45454545454545
28639, 2.2333333333333, 1.4, 0.47727272727273
28640, 2.2166666666667, 1.4, 0.40909090909091
28641, 2.2333333333333, 1.4, 0.43181818181818
28642, 2.2166666666667, 1.4, 0.36363636363636
28643, 2.2333333333333, 1.4, 0.38636363636364
28644, 2.2166666666667, 1.4, 0.31818181818182
28645, 2.2333333333333, 1.4, 0.34090909090909
28646, 2.2166666666667, 1.4, 0.27272727272727
28647, 2.2333333333333, 1.4, 0.29545454545455
28648, 2.2166666666667, 1.4, 0.22727272727273
28649, 2.2333333333333, 1.4, 0.25
28650, 2.2166666666667, 1.4, 0.18181818181818
28651, 2.2333333333333, 1.4, 0.20454545454545
28652, 2.2166666666667, 1.4, 0.13636363636364
28653, 2.2333333333333, 1.4, 0.15909090909091
28654, 2.2166666666667, 1.4, 0.090909090909091
28655, 2.2333333333333, 1.4, 0.11363636363636
28656, 2.2166666666667, 1.4, 0.045454545454545
28657, 2.2333333333333, 1.4, 0.068181818181818
28658, 2.2333333333333, 1.4, 0.022727272727273
28659, 2.25, 1.4, 0.45454545454545
28660, 2.2666666666667, 1.4, 0.47727272727273
28661, 2.25, 1.4, 0.40909090909091
28662, 2.2666666666667, 1.4, 0.43181818181818
28663, 2.25, 1.4, 0.36363636363636
