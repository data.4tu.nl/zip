77915, 1.7217391304348, 0.48913043478261, 0.045454545454545
77916, 1.7217391304348, 0.46304347826087, 0.022727272727273
77917, 1.7652173913043, 0.46304347826087, 0.47727272727273
77918, 1.7434782608696, 0.46304347826087, 0.45454545454545
77919, 1.7652173913043, 0.48913043478261, 0.45454545454545
77920, 1.7652173913043, 0.46304347826087, 0.43181818181818
77921, 1.7434782608696, 0.46304347826087, 0.40909090909091
77922, 1.7652173913043, 0.48913043478261, 0.40909090909091
77923, 1.7652173913043, 0.46304347826087, 0.38636363636364
77924, 1.7434782608696, 0.46304347826087, 0.36363636363636
77925, 1.7652173913043, 0.48913043478261, 0.36363636363636
77926, 1.7652173913043, 0.46304347826087, 0.34090909090909
77927, 1.7434782608696, 0.46304347826087, 0.31818181818182
77928, 1.7652173913043, 0.48913043478261, 0.31818181818182
77929, 1.7652173913043, 0.46304347826087, 0.29545454545455
77930, 1.7434782608696, 0.46304347826087, 0.27272727272727
77931, 1.7652173913043, 0.48913043478261, 0.27272727272727
77932, 1.7652173913043, 0.46304347826087, 0.25
77933, 1.7434782608696, 0.46304347826087, 0.22727272727273
77934, 1.7652173913043, 0.48913043478261, 0.22727272727273
77935, 1.7652173913043, 0.46304347826087, 0.20454545454545
77936, 1.7434782608696, 0.46304347826087, 0.18181818181818
77937, 1.7652173913043, 0.48913043478261, 0.18181818181818
77938, 1.7652173913043, 0.46304347826087, 0.15909090909091
77939, 1.7434782608696, 0.46304347826087, 0.13636363636364
77940, 1.7652173913043, 0.48913043478261, 0.13636363636364
77941, 1.7652173913043, 0.46304347826087, 0.11363636363636
77942, 1.7434782608696, 0.46304347826087, 0.090909090909091
77943, 1.7652173913043, 0.48913043478261, 0.090909090909091
77944, 1.7652173913043, 0.46304347826087, 0.068181818181818
77945, 1.7434782608696, 0.46304347826087, 0.045454545454545
77946, 1.7652173913043, 0.48913043478261, 0.045454545454545
77947, 1.7652173913043, 0.46304347826087, 0.022727272727273
77948, 1.8086956521739, 0.46304347826087, 0.47727272727273
77949, 1.7869565217391, 0.46304347826087, 0.45454545454545
77950, 1.8086956521739, 0.48913043478261, 0.45454545454545
77951, 1.8086956521739, 0.46304347826087, 0.43181818181818
77952, 1.7869565217391, 0.46304347826087, 0.40909090909091
77953, 1.8086956521739, 0.48913043478261, 0.40909090909091
77954, 1.8086956521739, 0.46304347826087, 0.38636363636364
77955, 1.7869565217391, 0.46304347826087, 0.36363636363636
77956, 1.8086956521739, 0.48913043478261, 0.36363636363636
77957, 1.8086956521739, 0.46304347826087, 0.34090909090909
77958, 1.7869565217391, 0.46304347826087, 0.31818181818182
77959, 1.8086956521739, 0.48913043478261, 0.31818181818182
77960, 1.8086956521739, 0.46304347826087, 0.29545454545455
77961, 1.7869565217391, 0.46304347826087, 0.27272727272727
77962, 1.8086956521739, 0.48913043478261, 0.27272727272727
77963, 1.8086956521739, 0.46304347826087, 0.25
77964, 1.7869565217391, 0.46304347826087, 0.22727272727273
77965, 1.8086956521739, 0.48913043478261, 0.22727272727273
77966, 1.8086956521739, 0.46304347826087, 0.20454545454545
77967, 1.7869565217391, 0.46304347826087, 0.18181818181818
77968, 1.8086956521739, 0.48913043478261, 0.18181818181818
77969, 1.8086956521739, 0.46304347826087, 0.15909090909091
77970, 1.7869565217391, 0.46304347826087, 0.13636363636364
77971, 1.8086956521739, 0.48913043478261, 0.13636363636364
77972, 1.8086956521739, 0.46304347826087, 0.11363636363636
77973, 1.7869565217391, 0.46304347826087, 0.090909090909091
77974, 1.8086956521739, 0.48913043478261, 0.090909090909091
77975, 1.8086956521739, 0.46304347826087, 0.068181818181818
77976, 1.7869565217391, 0.46304347826087, 0.045454545454545
77977, 1.8086956521739, 0.48913043478261, 0.045454545454545
77978, 1.8086956521739, 0.46304347826087, 0.022727272727273
77979, 1.8521739130435, 0.46304347826087, 0.47727272727273
77980, 1.8304347826087, 0.46304347826087, 0.45454545454545
77981, 1.8521739130435, 0.48913043478261, 0.45454545454545
77982, 1.8521739130435, 0.46304347826087, 0.43181818181818
77983, 1.8304347826087, 0.46304347826087, 0.40909090909091
77984, 1.8521739130435, 0.48913043478261, 0.40909090909091
77985, 1.8521739130435, 0.46304347826087, 0.38636363636364
77986, 1.8304347826087, 0.46304347826087, 0.36363636363636
77987, 1.8521739130435, 0.48913043478261, 0.36363636363636
77988, 1.8521739130435, 0.46304347826087, 0.34090909090909
77989, 1.8304347826087, 0.46304347826087, 0.31818181818182
77990, 1.8521739130435, 0.48913043478261, 0.31818181818182
77991, 1.8521739130435, 0.46304347826087, 0.29545454545455
77992, 1.8304347826087, 0.46304347826087, 0.27272727272727
77993, 1.8521739130435, 0.48913043478261, 0.27272727272727
77994, 1.8521739130435, 0.46304347826087, 0.25
77995, 1.8304347826087, 0.46304347826087, 0.22727272727273
77996, 1.8521739130435, 0.48913043478261, 0.22727272727273
77997, 1.8521739130435, 0.46304347826087, 0.20454545454545
77998, 1.8304347826087, 0.46304347826087, 0.18181818181818
77999, 1.8521739130435, 0.48913043478261, 0.18181818181818
78000, 1.8521739130435, 0.46304347826087, 0.15909090909091
78001, 1.8304347826087, 0.46304347826087, 0.13636363636364
78002, 1.8521739130435, 0.48913043478261, 0.13636363636364
78003, 1.8521739130435, 0.46304347826087, 0.11363636363636
78004, 1.8304347826087, 0.46304347826087, 0.090909090909091
78005, 1.8521739130435, 0.48913043478261, 0.090909090909091
78006, 1.8521739130435, 0.46304347826087, 0.068181818181818
78007, 1.8304347826087, 0.46304347826087, 0.045454545454545
78008, 1.8521739130435, 0.48913043478261, 0.045454545454545
78009, 1.8521739130435, 0.46304347826087, 0.022727272727273
78010, 1.895652173913, 0.46304347826087, 0.47727272727273
78011, 1.8739130434783, 0.46304347826087, 0.45454545454545
78012, 1.895652173913, 0.48913043478261, 0.45454545454545
78013, 1.895652173913, 0.46304347826087, 0.43181818181818
78014, 1.8739130434783, 0.46304347826087, 0.40909090909091
78015, 1.895652173913, 0.48913043478261, 0.40909090909091
78016, 1.895652173913, 0.46304347826087, 0.38636363636364
78017, 1.8739130434783, 0.46304347826087, 0.36363636363636
78018, 1.895652173913, 0.48913043478261, 0.36363636363636
78019, 1.895652173913, 0.46304347826087, 0.34090909090909
78020, 1.8739130434783, 0.46304347826087, 0.31818181818182
78021, 1.895652173913, 0.48913043478261, 0.31818181818182
78022, 1.895652173913, 0.46304347826087, 0.29545454545455
78023, 1.8739130434783, 0.46304347826087, 0.27272727272727
78024, 1.895652173913, 0.48913043478261, 0.27272727272727
78025, 1.895652173913, 0.46304347826087, 0.25
78026, 1.8739130434783, 0.46304347826087, 0.22727272727273
78027, 1.895652173913, 0.48913043478261, 0.22727272727273
78028, 1.895652173913, 0.46304347826087, 0.20454545454545
78029, 1.8739130434783, 0.46304347826087, 0.18181818181818
78030, 1.895652173913, 0.48913043478261, 0.18181818181818
78031, 1.895652173913, 0.46304347826087, 0.15909090909091
78032, 1.8739130434783, 0.46304347826087, 0.13636363636364
78033, 1.895652173913, 0.48913043478261, 0.13636363636364
78034, 1.895652173913, 0.46304347826087, 0.11363636363636
78035, 1.8739130434783, 0.46304347826087, 0.090909090909091
78036, 1.895652173913, 0.48913043478261, 0.090909090909091
78037, 1.895652173913, 0.46304347826087, 0.068181818181818
78038, 1.8739130434783, 0.46304347826087, 0.045454545454545
78039, 1.895652173913, 0.48913043478261, 0.045454545454545
78040, 1.895652173913, 0.46304347826087, 0.022727272727273
78041, 1.9391304347826, 0.46304347826087, 0.47727272727273
78042, 1.9173913043478, 0.46304347826087, 0.45454545454545
78043, 1.9391304347826, 0.48913043478261, 0.45454545454545
78044, 1.9391304347826, 0.46304347826087, 0.43181818181818
78045, 1.9173913043478, 0.46304347826087, 0.40909090909091
78046, 1.9391304347826, 0.48913043478261, 0.40909090909091
78047, 1.9391304347826, 0.46304347826087, 0.38636363636364
78048, 1.9173913043478, 0.46304347826087, 0.36363636363636
78049, 1.9391304347826, 0.48913043478261, 0.36363636363636
78050, 1.9391304347826, 0.46304347826087, 0.34090909090909
78051, 1.9173913043478, 0.46304347826087, 0.31818181818182
78052, 1.9391304347826, 0.48913043478261, 0.31818181818182
78053, 1.9391304347826, 0.46304347826087, 0.29545454545455
78054, 1.9173913043478, 0.46304347826087, 0.27272727272727
78055, 1.9391304347826, 0.48913043478261, 0.27272727272727
78056, 1.9391304347826, 0.46304347826087, 0.25
78057, 1.9173913043478, 0.46304347826087, 0.22727272727273
78058, 1.9391304347826, 0.48913043478261, 0.22727272727273
78059, 1.9391304347826, 0.46304347826087, 0.20454545454545
78060, 1.9173913043478, 0.46304347826087, 0.18181818181818
78061, 1.9391304347826, 0.48913043478261, 0.18181818181818
78062, 1.9391304347826, 0.46304347826087, 0.15909090909091
78063, 1.9173913043478, 0.46304347826087, 0.13636363636364
78064, 1.9391304347826, 0.48913043478261, 0.13636363636364
78065, 1.9391304347826, 0.46304347826087, 0.11363636363636
78066, 1.9173913043478, 0.46304347826087, 0.090909090909091
78067, 1.9391304347826, 0.48913043478261, 0.090909090909091
78068, 1.9391304347826, 0.46304347826087, 0.068181818181818
78069, 1.9173913043478, 0.46304347826087, 0.045454545454545
78070, 1.9391304347826, 0.48913043478261, 0.045454545454545
78071, 1.9391304347826, 0.46304347826087, 0.022727272727273
78072, 1.9826086956522, 0.46304347826087, 0.47727272727273
78073, 1.9608695652174, 0.46304347826087, 0.45454545454545
78074, 1.9826086956522, 0.48913043478261, 0.45454545454545
78075, 1.9826086956522, 0.46304347826087, 0.43181818181818
78076, 1.9608695652174, 0.46304347826087, 0.40909090909091
78077, 1.9826086956522, 0.48913043478261, 0.40909090909091
78078, 1.9826086956522, 0.46304347826087, 0.38636363636364
78079, 1.9608695652174, 0.46304347826087, 0.36363636363636
78080, 1.9826086956522, 0.48913043478261, 0.36363636363636
78081, 1.9826086956522, 0.46304347826087, 0.34090909090909
78082, 1.9608695652174, 0.46304347826087, 0.31818181818182
78083, 1.9826086956522, 0.48913043478261, 0.31818181818182
78084, 1.9826086956522, 0.46304347826087, 0.29545454545455
78085, 1.9608695652174, 0.46304347826087, 0.27272727272727
78086, 1.9826086956522, 0.48913043478261, 0.27272727272727
78087, 1.9826086956522, 0.46304347826087, 0.25
78088, 1.9608695652174, 0.46304347826087, 0.22727272727273
78089, 1.9826086956522, 0.48913043478261, 0.22727272727273
78090, 1.9826086956522, 0.46304347826087, 0.20454545454545
78091, 1.9608695652174, 0.46304347826087, 0.18181818181818
78092, 1.9826086956522, 0.48913043478261, 0.18181818181818
78093, 1.9826086956522, 0.46304347826087, 0.15909090909091
78094, 1.9608695652174, 0.46304347826087, 0.13636363636364
78095, 1.9826086956522, 0.48913043478261, 0.13636363636364
78096, 1.9826086956522, 0.46304347826087, 0.11363636363636
78097, 1.9608695652174, 0.46304347826087, 0.090909090909091
78098, 1.9826086956522, 0.48913043478261, 0.090909090909091
78099, 1.9826086956522, 0.46304347826087, 0.068181818181818
78100, 1.9608695652174, 0.46304347826087, 0.045454545454545
78101, 1.9826086956522, 0.48913043478261, 0.045454545454545
78102, 1.9826086956522, 0.46304347826087, 0.022727272727273
78103, 2.0260869565217, 0.46304347826087, 0.47727272727273
78104, 2.004347826087, 0.46304347826087, 0.45454545454545
78105, 2.0260869565217, 0.48913043478261, 0.45454545454545
78106, 2.0260869565217, 0.46304347826087, 0.43181818181818
78107, 2.004347826087, 0.46304347826087, 0.40909090909091
78108, 2.0260869565217, 0.48913043478261, 0.40909090909091
78109, 2.0260869565217, 0.46304347826087, 0.38636363636364
78110, 2.004347826087, 0.46304347826087, 0.36363636363636
78111, 2.0260869565217, 0.48913043478261, 0.36363636363636
78112, 2.0260869565217, 0.46304347826087, 0.34090909090909
78113, 2.004347826087, 0.46304347826087, 0.31818181818182
78114, 2.0260869565217, 0.48913043478261, 0.31818181818182
78115, 2.0260869565217, 0.46304347826087, 0.29545454545455
78116, 2.004347826087, 0.46304347826087, 0.27272727272727
78117, 2.0260869565217, 0.48913043478261, 0.27272727272727
78118, 2.0260869565217, 0.46304347826087, 0.25
78119, 2.004347826087, 0.46304347826087, 0.22727272727273
78120, 2.0260869565217, 0.48913043478261, 0.22727272727273
78121, 2.0260869565217, 0.46304347826087, 0.20454545454545
78122, 2.004347826087, 0.46304347826087, 0.18181818181818
78123, 2.0260869565217, 0.48913043478261, 0.18181818181818
78124, 2.0260869565217, 0.46304347826087, 0.15909090909091
78125, 2.004347826087, 0.46304347826087, 0.13636363636364
78126, 2.0260869565217, 0.48913043478261, 0.13636363636364
78127, 2.0260869565217, 0.46304347826087, 0.11363636363636
78128, 2.004347826087, 0.46304347826087, 0.090909090909091
78129, 2.0260869565217, 0.48913043478261, 0.090909090909091
78130, 2.0260869565217, 0.46304347826087, 0.068181818181818
78131, 2.004347826087, 0.46304347826087, 0.045454545454545
78132, 2.0260869565217, 0.48913043478261, 0.045454545454545
78133, 2.0260869565217, 0.46304347826087, 0.022727272727273
78134, 2.0695652173913, 0.46304347826087, 0.47727272727273
78135, 2.0478260869565, 0.46304347826087, 0.45454545454545
78136, 2.0695652173913, 0.48913043478261, 0.45454545454545
78137, 2.0695652173913, 0.46304347826087, 0.43181818181818
78138, 2.0478260869565, 0.46304347826087, 0.40909090909091
78139, 2.0695652173913, 0.48913043478261, 0.40909090909091
78140, 2.0695652173913, 0.46304347826087, 0.38636363636364
78141, 2.0478260869565, 0.46304347826087, 0.36363636363636
78142, 2.0695652173913, 0.48913043478261, 0.36363636363636
78143, 2.0695652173913, 0.46304347826087, 0.34090909090909
78144, 2.0478260869565, 0.46304347826087, 0.31818181818182
78145, 2.0695652173913, 0.48913043478261, 0.31818181818182
78146, 2.0695652173913, 0.46304347826087, 0.29545454545455
78147, 2.0478260869565, 0.46304347826087, 0.27272727272727
78148, 2.0695652173913, 0.48913043478261, 0.27272727272727
78149, 2.0695652173913, 0.46304347826087, 0.25
78150, 2.0478260869565, 0.46304347826087, 0.22727272727273
78151, 2.0695652173913, 0.48913043478261, 0.22727272727273
78152, 2.0695652173913, 0.46304347826087, 0.20454545454545
78153, 2.0478260869565, 0.46304347826087, 0.18181818181818
78154, 2.0695652173913, 0.48913043478261, 0.18181818181818
78155, 2.0695652173913, 0.46304347826087, 0.15909090909091
78156, 2.0478260869565, 0.46304347826087, 0.13636363636364
78157, 2.0695652173913, 0.48913043478261, 0.13636363636364
78158, 2.0695652173913, 0.46304347826087, 0.11363636363636
78159, 2.0478260869565, 0.46304347826087, 0.090909090909091
78160, 2.0695652173913, 0.48913043478261, 0.090909090909091
78161, 2.0695652173913, 0.46304347826087, 0.068181818181818
78162, 2.0478260869565, 0.46304347826087, 0.045454545454545
78163, 2.0695652173913, 0.48913043478261, 0.045454545454545
78164, 2.0695652173913, 0.46304347826087, 0.022727272727273
78165, 2.1130434782609, 0.46304347826087, 0.47727272727273
78166, 2.0913043478261, 0.46304347826087, 0.45454545454545
78167, 2.1130434782609, 0.48913043478261, 0.45454545454545
78168, 2.1130434782609, 0.46304347826087, 0.43181818181818
78169, 2.0913043478261, 0.46304347826087, 0.40909090909091
78170, 2.1130434782609, 0.48913043478261, 0.40909090909091
78171, 2.1130434782609, 0.46304347826087, 0.38636363636364
78172, 2.0913043478261, 0.46304347826087, 0.36363636363636
78173, 2.1130434782609, 0.48913043478261, 0.36363636363636
78174, 2.1130434782609, 0.46304347826087, 0.34090909090909
78175, 2.0913043478261, 0.46304347826087, 0.31818181818182
78176, 2.1130434782609, 0.48913043478261, 0.31818181818182
78177, 2.1130434782609, 0.46304347826087, 0.29545454545455
78178, 2.0913043478261, 0.46304347826087, 0.27272727272727
78179, 2.1130434782609, 0.48913043478261, 0.27272727272727
78180, 2.1130434782609, 0.46304347826087, 0.25
78181, 2.0913043478261, 0.46304347826087, 0.22727272727273
78182, 2.1130434782609, 0.48913043478261, 0.22727272727273
78183, 2.1130434782609, 0.46304347826087, 0.20454545454545
78184, 2.0913043478261, 0.46304347826087, 0.18181818181818
78185, 2.1130434782609, 0.48913043478261, 0.18181818181818
78186, 2.1130434782609, 0.46304347826087, 0.15909090909091
78187, 2.0913043478261, 0.46304347826087, 0.13636363636364
78188, 2.1130434782609, 0.48913043478261, 0.13636363636364
78189, 2.1130434782609, 0.46304347826087, 0.11363636363636
78190, 2.0913043478261, 0.46304347826087, 0.090909090909091
78191, 2.1130434782609, 0.48913043478261, 0.090909090909091
78192, 2.1130434782609, 0.46304347826087, 0.068181818181818
78193, 2.0913043478261, 0.46304347826087, 0.045454545454545
78194, 2.1130434782609, 0.48913043478261, 0.045454545454545
78195, 2.1130434782609, 0.46304347826087, 0.022727272727273
78196, 2.1565217391304, 0.46304347826087, 0.47727272727273
78197, 2.1347826086957, 0.46304347826087, 0.45454545454545
78198, 2.1565217391304, 0.48913043478261, 0.45454545454545
78199, 2.1565217391304, 0.46304347826087, 0.43181818181818
78200, 2.1347826086957, 0.46304347826087, 0.40909090909091
78201, 2.1565217391304, 0.48913043478261, 0.40909090909091
78202, 2.1565217391304, 0.46304347826087, 0.38636363636364
78203, 2.1347826086957, 0.46304347826087, 0.36363636363636
78204, 2.1565217391304, 0.48913043478261, 0.36363636363636
78205, 2.1565217391304, 0.46304347826087, 0.34090909090909
78206, 2.1347826086957, 0.46304347826087, 0.31818181818182
78207, 2.1565217391304, 0.48913043478261, 0.31818181818182
78208, 2.1565217391304, 0.46304347826087, 0.29545454545455
78209, 2.1347826086957, 0.46304347826087, 0.27272727272727
78210, 2.1565217391304, 0.48913043478261, 0.27272727272727
78211, 2.1565217391304, 0.46304347826087, 0.25
78212, 2.1347826086957, 0.46304347826087, 0.22727272727273
78213, 2.1565217391304, 0.48913043478261, 0.22727272727273
78214, 2.1565217391304, 0.46304347826087, 0.20454545454545
78215, 2.1347826086957, 0.46304347826087, 0.18181818181818
78216, 2.1565217391304, 0.48913043478261, 0.18181818181818
78217, 2.1565217391304, 0.46304347826087, 0.15909090909091
78218, 2.1347826086957, 0.46304347826087, 0.13636363636364
78219, 2.1565217391304, 0.48913043478261, 0.13636363636364
78220, 2.1565217391304, 0.46304347826087, 0.11363636363636
78221, 2.1347826086957, 0.46304347826087, 0.090909090909091
78222, 2.1565217391304, 0.48913043478261, 0.090909090909091
78223, 2.1565217391304, 0.46304347826087, 0.068181818181818
78224, 2.1347826086957, 0.46304347826087, 0.045454545454545
78225, 2.1565217391304, 0.48913043478261, 0.045454545454545
78226, 2.1565217391304, 0.46304347826087, 0.022727272727273
78227, 2.1782608695652, 0.46304347826087, 0.45454545454545
78228, 2.1782608695652, 0.46304347826087, 0.40909090909091
78229, 2.1782608695652, 0.46304347826087, 0.36363636363636
78230, 2.1782608695652, 0.46304347826087, 0.31818181818182
78231, 2.1782608695652, 0.46304347826087, 0.27272727272727
78232, 2.1782608695652, 0.46304347826087, 0.22727272727273
78233, 2.1782608695652, 0.46304347826087, 0.18181818181818
78234, 2.1782608695652, 0.46304347826087, 0.13636363636364
78235, 2.1782608695652, 0.46304347826087, 0.090909090909091
78236, 2.1782608695652, 0.46304347826087, 0.045454545454545
78237, 1.2434782608696, 0.41086956521739, 0.47727272727273
78238, 1.2217391304348, 0.41086956521739, 0.45454545454545
78239, 1.2434782608696, 0.43695652173913, 0.45454545454545
78240, 1.2434782608696, 0.41086956521739, 0.43181818181818
78241, 1.2217391304348, 0.41086956521739, 0.40909090909091
78242, 1.2434782608696, 0.43695652173913, 0.40909090909091
78243, 1.2434782608696, 0.41086956521739, 0.38636363636364
78244, 1.2217391304348, 0.41086956521739, 0.36363636363636
78245, 1.2434782608696, 0.43695652173913, 0.36363636363636
78246, 1.2434782608696, 0.41086956521739, 0.34090909090909
78247, 1.2217391304348, 0.41086956521739, 0.31818181818182
78248, 1.2434782608696, 0.43695652173913, 0.31818181818182
78249, 1.2434782608696, 0.41086956521739, 0.29545454545455
78250, 1.2217391304348, 0.41086956521739, 0.27272727272727
78251, 1.2434782608696, 0.43695652173913, 0.27272727272727
78252, 1.2434782608696, 0.41086956521739, 0.25
78253, 1.2217391304348, 0.41086956521739, 0.22727272727273
78254, 1.2434782608696, 0.43695652173913, 0.22727272727273
78255, 1.2434782608696, 0.41086956521739, 0.20454545454545
78256, 1.2217391304348, 0.41086956521739, 0.18181818181818
78257, 1.2434782608696, 0.43695652173913, 0.18181818181818
78258, 1.2434782608696, 0.41086956521739, 0.15909090909091
78259, 1.2217391304348, 0.41086956521739, 0.13636363636364
78260, 1.2434782608696, 0.43695652173913, 0.13636363636364
78261, 1.2434782608696, 0.41086956521739, 0.11363636363636
78262, 1.2217391304348, 0.41086956521739, 0.090909090909091
78263, 1.2434782608696, 0.43695652173913, 0.090909090909091
78264, 1.2434782608696, 0.41086956521739, 0.068181818181818
78265, 1.2217391304348, 0.41086956521739, 0.045454545454545
78266, 1.2434782608696, 0.43695652173913, 0.045454545454545
78267, 1.2434782608696, 0.41086956521739, 0.022727272727273
78268, 1.2869565217391, 0.41086956521739, 0.47727272727273
78269, 1.2652173913043, 0.41086956521739, 0.45454545454545
78270, 1.2869565217391, 0.43695652173913, 0.45454545454545
78271, 1.2869565217391, 0.41086956521739, 0.43181818181818
78272, 1.2652173913043, 0.41086956521739, 0.40909090909091
78273, 1.2869565217391, 0.43695652173913, 0.40909090909091
78274, 1.2869565217391, 0.41086956521739, 0.38636363636364
78275, 1.2652173913043, 0.41086956521739, 0.36363636363636
78276, 1.2869565217391, 0.43695652173913, 0.36363636363636
78277, 1.2869565217391, 0.41086956521739, 0.34090909090909
78278, 1.2652173913043, 0.41086956521739, 0.31818181818182
78279, 1.2869565217391, 0.43695652173913, 0.31818181818182
78280, 1.2869565217391, 0.41086956521739, 0.29545454545455
78281, 1.2652173913043, 0.41086956521739, 0.27272727272727
78282, 1.2869565217391, 0.43695652173913, 0.27272727272727
78283, 1.2869565217391, 0.41086956521739, 0.25
78284, 1.2652173913043, 0.41086956521739, 0.22727272727273
78285, 1.2869565217391, 0.43695652173913, 0.22727272727273
78286, 1.2869565217391, 0.41086956521739, 0.20454545454545
78287, 1.2652173913043, 0.41086956521739, 0.18181818181818
78288, 1.2869565217391, 0.43695652173913, 0.18181818181818
78289, 1.2869565217391, 0.41086956521739, 0.15909090909091
78290, 1.2652173913043, 0.41086956521739, 0.13636363636364
78291, 1.2869565217391, 0.43695652173913, 0.13636363636364
78292, 1.2869565217391, 0.41086956521739, 0.11363636363636
78293, 1.2652173913043, 0.41086956521739, 0.090909090909091
78294, 1.2869565217391, 0.43695652173913, 0.090909090909091
78295, 1.2869565217391, 0.41086956521739, 0.068181818181818
78296, 1.2652173913043, 0.41086956521739, 0.045454545454545
78297, 1.2869565217391, 0.43695652173913, 0.045454545454545
78298, 1.2869565217391, 0.41086956521739, 0.022727272727273
78299, 1.3304347826087, 0.41086956521739, 0.47727272727273
78300, 1.3086956521739, 0.41086956521739, 0.45454545454545
78301, 1.3304347826087, 0.43695652173913, 0.45454545454545
78302, 1.3304347826087, 0.41086956521739, 0.43181818181818
78303, 1.3086956521739, 0.41086956521739, 0.40909090909091
78304, 1.3304347826087, 0.43695652173913, 0.40909090909091
78305, 1.3304347826087, 0.41086956521739, 0.38636363636364
78306, 1.3086956521739, 0.41086956521739, 0.36363636363636
78307, 1.3304347826087, 0.43695652173913, 0.36363636363636
78308, 1.3304347826087, 0.41086956521739, 0.34090909090909
78309, 1.3086956521739, 0.41086956521739, 0.31818181818182
78310, 1.3304347826087, 0.43695652173913, 0.31818181818182
78311, 1.3304347826087, 0.41086956521739, 0.29545454545455
78312, 1.3086956521739, 0.41086956521739, 0.27272727272727
78313, 1.3304347826087, 0.43695652173913, 0.27272727272727
78314, 1.3304347826087, 0.41086956521739, 0.25
78315, 1.3086956521739, 0.41086956521739, 0.22727272727273
78316, 1.3304347826087, 0.43695652173913, 0.22727272727273
78317, 1.3304347826087, 0.41086956521739, 0.20454545454545
78318, 1.3086956521739, 0.41086956521739, 0.18181818181818
78319, 1.3304347826087, 0.43695652173913, 0.18181818181818
78320, 1.3304347826087, 0.41086956521739, 0.15909090909091
78321, 1.3086956521739, 0.41086956521739, 0.13636363636364
78322, 1.3304347826087, 0.43695652173913, 0.13636363636364
78323, 1.3304347826087, 0.41086956521739, 0.11363636363636
78324, 1.3086956521739, 0.41086956521739, 0.090909090909091
78325, 1.3304347826087, 0.43695652173913, 0.090909090909091
78326, 1.3304347826087, 0.41086956521739, 0.068181818181818
78327, 1.3086956521739, 0.41086956521739, 0.045454545454545
78328, 1.3304347826087, 0.43695652173913, 0.045454545454545
78329, 1.3304347826087, 0.41086956521739, 0.022727272727273
78330, 1.3739130434783, 0.41086956521739, 0.47727272727273
78331, 1.3521739130435, 0.41086956521739, 0.45454545454545
78332, 1.3739130434783, 0.43695652173913, 0.45454545454545
78333, 1.3739130434783, 0.41086956521739, 0.43181818181818
78334, 1.3521739130435, 0.41086956521739, 0.40909090909091
78335, 1.3739130434783, 0.43695652173913, 0.40909090909091
78336, 1.3739130434783, 0.41086956521739, 0.38636363636364
78337, 1.3521739130435, 0.41086956521739, 0.36363636363636
78338, 1.3739130434783, 0.43695652173913, 0.36363636363636
78339, 1.3739130434783, 0.41086956521739, 0.34090909090909
78340, 1.3521739130435, 0.41086956521739, 0.31818181818182
78341, 1.3739130434783, 0.43695652173913, 0.31818181818182
78342, 1.3739130434783, 0.41086956521739, 0.29545454545455
78343, 1.3521739130435, 0.41086956521739, 0.27272727272727
78344, 1.3739130434783, 0.43695652173913, 0.27272727272727
78345, 1.3739130434783, 0.41086956521739, 0.25
78346, 1.3521739130435, 0.41086956521739, 0.22727272727273
78347, 1.3739130434783, 0.43695652173913, 0.22727272727273
78348, 1.3739130434783, 0.41086956521739, 0.20454545454545
78349, 1.3521739130435, 0.41086956521739, 0.18181818181818
78350, 1.3739130434783, 0.43695652173913, 0.18181818181818
78351, 1.3739130434783, 0.41086956521739, 0.15909090909091
78352, 1.3521739130435, 0.41086956521739, 0.13636363636364
78353, 1.3739130434783, 0.43695652173913, 0.13636363636364
78354, 1.3739130434783, 0.41086956521739, 0.11363636363636
78355, 1.3521739130435, 0.41086956521739, 0.090909090909091
78356, 1.3739130434783, 0.43695652173913, 0.090909090909091
78357, 1.3739130434783, 0.41086956521739, 0.068181818181818
78358, 1.3521739130435, 0.41086956521739, 0.045454545454545
78359, 1.3739130434783, 0.43695652173913, 0.045454545454545
78360, 1.3739130434783, 0.41086956521739, 0.022727272727273
78361, 1.4173913043478, 0.41086956521739, 0.47727272727273
78362, 1.395652173913, 0.41086956521739, 0.45454545454545
78363, 1.4173913043478, 0.43695652173913, 0.45454545454545
78364, 1.4173913043478, 0.41086956521739, 0.43181818181818
78365, 1.395652173913, 0.41086956521739, 0.40909090909091
78366, 1.4173913043478, 0.43695652173913, 0.40909090909091
78367, 1.4173913043478, 0.41086956521739, 0.38636363636364
78368, 1.395652173913, 0.41086956521739, 0.36363636363636
78369, 1.4173913043478, 0.43695652173913, 0.36363636363636
78370, 1.4173913043478, 0.41086956521739, 0.34090909090909
78371, 1.395652173913, 0.41086956521739, 0.31818181818182
78372, 1.4173913043478, 0.43695652173913, 0.31818181818182
78373, 1.4173913043478, 0.41086956521739, 0.29545454545455
78374, 1.395652173913, 0.41086956521739, 0.27272727272727
78375, 1.4173913043478, 0.43695652173913, 0.27272727272727
78376, 1.4173913043478, 0.41086956521739, 0.25
78377, 1.395652173913, 0.41086956521739, 0.22727272727273
78378, 1.4173913043478, 0.43695652173913, 0.22727272727273
78379, 1.4173913043478, 0.41086956521739, 0.20454545454545
78380, 1.395652173913, 0.41086956521739, 0.18181818181818
78381, 1.4173913043478, 0.43695652173913, 0.18181818181818
78382, 1.4173913043478, 0.41086956521739, 0.15909090909091
78383, 1.395652173913, 0.41086956521739, 0.13636363636364
78384, 1.4173913043478, 0.43695652173913, 0.13636363636364
78385, 1.4173913043478, 0.41086956521739, 0.11363636363636
78386, 1.395652173913, 0.41086956521739, 0.090909090909091
78387, 1.4173913043478, 0.43695652173913, 0.090909090909091
78388, 1.4173913043478, 0.41086956521739, 0.068181818181818
78389, 1.395652173913, 0.41086956521739, 0.045454545454545
78390, 1.4173913043478, 0.43695652173913, 0.045454545454545
78391, 1.4173913043478, 0.41086956521739, 0.022727272727273
78392, 1.4608695652174, 0.41086956521739, 0.47727272727273
78393, 1.4391304347826, 0.41086956521739, 0.45454545454545
78394, 1.4608695652174, 0.43695652173913, 0.45454545454545
78395, 1.4608695652174, 0.41086956521739, 0.43181818181818
78396, 1.4391304347826, 0.41086956521739, 0.40909090909091
78397, 1.4608695652174, 0.43695652173913, 0.40909090909091
78398, 1.4608695652174, 0.41086956521739, 0.38636363636364
78399, 1.4391304347826, 0.41086956521739, 0.36363636363636
78400, 1.4608695652174, 0.43695652173913, 0.36363636363636
78401, 1.4608695652174, 0.41086956521739, 0.34090909090909
78402, 1.4391304347826, 0.41086956521739, 0.31818181818182
78403, 1.4608695652174, 0.43695652173913, 0.31818181818182
78404, 1.4608695652174, 0.41086956521739, 0.29545454545455
78405, 1.4391304347826, 0.41086956521739, 0.27272727272727
78406, 1.4608695652174, 0.43695652173913, 0.27272727272727
78407, 1.4608695652174, 0.41086956521739, 0.25
78408, 1.4391304347826, 0.41086956521739, 0.22727272727273
78409, 1.4608695652174, 0.43695652173913, 0.22727272727273
78410, 1.4608695652174, 0.41086956521739, 0.20454545454545
78411, 1.4391304347826, 0.41086956521739, 0.18181818181818
78412, 1.4608695652174, 0.43695652173913, 0.18181818181818
78413, 1.4608695652174, 0.41086956521739, 0.15909090909091
78414, 1.4391304347826, 0.41086956521739, 0.13636363636364
78415, 1.4608695652174, 0.43695652173913, 0.13636363636364
78416, 1.4608695652174, 0.41086956521739, 0.11363636363636
78417, 1.4391304347826, 0.41086956521739, 0.090909090909091
78418, 1.4608695652174, 0.43695652173913, 0.090909090909091
78419, 1.4608695652174, 0.41086956521739, 0.068181818181818
78420, 1.4391304347826, 0.41086956521739, 0.045454545454545
78421, 1.4608695652174, 0.43695652173913, 0.045454545454545
78422, 1.4608695652174, 0.41086956521739, 0.022727272727273
78423, 1.504347826087, 0.41086956521739, 0.47727272727273
78424, 1.4826086956522, 0.41086956521739, 0.45454545454545
78425, 1.504347826087, 0.43695652173913, 0.45454545454545
78426, 1.504347826087, 0.41086956521739, 0.43181818181818
78427, 1.4826086956522, 0.41086956521739, 0.40909090909091
78428, 1.504347826087, 0.43695652173913, 0.40909090909091
78429, 1.504347826087, 0.41086956521739, 0.38636363636364
78430, 1.4826086956522, 0.41086956521739, 0.36363636363636
78431, 1.504347826087, 0.43695652173913, 0.36363636363636
78432, 1.504347826087, 0.41086956521739, 0.34090909090909
78433, 1.4826086956522, 0.41086956521739, 0.31818181818182
78434, 1.504347826087, 0.43695652173913, 0.31818181818182
78435, 1.504347826087, 0.41086956521739, 0.29545454545455
78436, 1.4826086956522, 0.41086956521739, 0.27272727272727
78437, 1.504347826087, 0.43695652173913, 0.27272727272727
78438, 1.504347826087, 0.41086956521739, 0.25
78439, 1.4826086956522, 0.41086956521739, 0.22727272727273
78440, 1.504347826087, 0.43695652173913, 0.22727272727273
78441, 1.504347826087, 0.41086956521739, 0.20454545454545
78442, 1.4826086956522, 0.41086956521739, 0.18181818181818
78443, 1.504347826087, 0.43695652173913, 0.18181818181818
78444, 1.504347826087, 0.41086956521739, 0.15909090909091
78445, 1.4826086956522, 0.41086956521739, 0.13636363636364
78446, 1.504347826087, 0.43695652173913, 0.13636363636364
78447, 1.504347826087, 0.41086956521739, 0.11363636363636
78448, 1.4826086956522, 0.41086956521739, 0.090909090909091
78449, 1.504347826087, 0.43695652173913, 0.090909090909091
78450, 1.504347826087, 0.41086956521739, 0.068181818181818
78451, 1.4826086956522, 0.41086956521739, 0.045454545454545
78452, 1.504347826087, 0.43695652173913, 0.045454545454545
78453, 1.504347826087, 0.41086956521739, 0.022727272727273
78454, 1.5478260869565, 0.41086956521739, 0.47727272727273
78455, 1.5260869565217, 0.41086956521739, 0.45454545454545
78456, 1.5478260869565, 0.43695652173913, 0.45454545454545
78457, 1.5478260869565, 0.41086956521739, 0.43181818181818
78458, 1.5260869565217, 0.41086956521739, 0.40909090909091
78459, 1.5478260869565, 0.43695652173913, 0.40909090909091
78460, 1.5478260869565, 0.41086956521739, 0.38636363636364
78461, 1.5260869565217, 0.41086956521739, 0.36363636363636
78462, 1.5478260869565, 0.43695652173913, 0.36363636363636
78463, 1.5478260869565, 0.41086956521739, 0.34090909090909
78464, 1.5260869565217, 0.41086956521739, 0.31818181818182
78465, 1.5478260869565, 0.43695652173913, 0.31818181818182
78466, 1.5478260869565, 0.41086956521739, 0.29545454545455
78467, 1.5260869565217, 0.41086956521739, 0.27272727272727
78468, 1.5478260869565, 0.43695652173913, 0.27272727272727
78469, 1.5478260869565, 0.41086956521739, 0.25
78470, 1.5260869565217, 0.41086956521739, 0.22727272727273
78471, 1.5478260869565, 0.43695652173913, 0.22727272727273
78472, 1.5478260869565, 0.41086956521739, 0.20454545454545
78473, 1.5260869565217, 0.41086956521739, 0.18181818181818
78474, 1.5478260869565, 0.43695652173913, 0.18181818181818
78475, 1.5478260869565, 0.41086956521739, 0.15909090909091
78476, 1.5260869565217, 0.41086956521739, 0.13636363636364
78477, 1.5478260869565, 0.43695652173913, 0.13636363636364
78478, 1.5478260869565, 0.41086956521739, 0.11363636363636
78479, 1.5260869565217, 0.41086956521739, 0.090909090909091
78480, 1.5478260869565, 0.43695652173913, 0.090909090909091
78481, 1.5478260869565, 0.41086956521739, 0.068181818181818
78482, 1.5260869565217, 0.41086956521739, 0.045454545454545
78483, 1.5478260869565, 0.43695652173913, 0.045454545454545
78484, 1.5478260869565, 0.41086956521739, 0.022727272727273
78485, 1.5913043478261, 0.41086956521739, 0.47727272727273
78486, 1.5695652173913, 0.41086956521739, 0.45454545454545
78487, 1.5913043478261, 0.43695652173913, 0.45454545454545
78488, 1.5913043478261, 0.41086956521739, 0.43181818181818
78489, 1.5695652173913, 0.41086956521739, 0.40909090909091
78490, 1.5913043478261, 0.43695652173913, 0.40909090909091
78491, 1.5913043478261, 0.41086956521739, 0.38636363636364
78492, 1.5695652173913, 0.41086956521739, 0.36363636363636
78493, 1.5913043478261, 0.43695652173913, 0.36363636363636
78494, 1.5913043478261, 0.41086956521739, 0.34090909090909
78495, 1.5695652173913, 0.41086956521739, 0.31818181818182
78496, 1.5913043478261, 0.43695652173913, 0.31818181818182
78497, 1.5913043478261, 0.41086956521739, 0.29545454545455
78498, 1.5695652173913, 0.41086956521739, 0.27272727272727
78499, 1.5913043478261, 0.43695652173913, 0.27272727272727
78500, 1.5913043478261, 0.41086956521739, 0.25
78501, 1.5695652173913, 0.41086956521739, 0.22727272727273
78502, 1.5913043478261, 0.43695652173913, 0.22727272727273
78503, 1.5913043478261, 0.41086956521739, 0.20454545454545
78504, 1.5695652173913, 0.41086956521739, 0.18181818181818
78505, 1.5913043478261, 0.43695652173913, 0.18181818181818
78506, 1.5913043478261, 0.41086956521739, 0.15909090909091
78507, 1.5695652173913, 0.41086956521739, 0.13636363636364
78508, 1.5913043478261, 0.43695652173913, 0.13636363636364
78509, 1.5913043478261, 0.41086956521739, 0.11363636363636
78510, 1.5695652173913, 0.41086956521739, 0.090909090909091
78511, 1.5913043478261, 0.43695652173913, 0.090909090909091
78512, 1.5913043478261, 0.41086956521739, 0.068181818181818
78513, 1.5695652173913, 0.41086956521739, 0.045454545454545
78514, 1.5913043478261, 0.43695652173913, 0.045454545454545
78515, 1.5913043478261, 0.41086956521739, 0.022727272727273
78516, 1.6347826086957, 0.41086956521739, 0.47727272727273
78517, 1.6130434782609, 0.41086956521739, 0.45454545454545
78518, 1.6347826086957, 0.43695652173913, 0.45454545454545
78519, 1.6347826086957, 0.41086956521739, 0.43181818181818
78520, 1.6130434782609, 0.41086956521739, 0.40909090909091
78521, 1.6347826086957, 0.43695652173913, 0.40909090909091
78522, 1.6347826086957, 0.41086956521739, 0.38636363636364
78523, 1.6130434782609, 0.41086956521739, 0.36363636363636
78524, 1.6347826086957, 0.43695652173913, 0.36363636363636
78525, 1.6347826086957, 0.41086956521739, 0.34090909090909
78526, 1.6130434782609, 0.41086956521739, 0.31818181818182
78527, 1.6347826086957, 0.43695652173913, 0.31818181818182
78528, 1.6347826086957, 0.41086956521739, 0.29545454545455
78529, 1.6130434782609, 0.41086956521739, 0.27272727272727
78530, 1.6347826086957, 0.43695652173913, 0.27272727272727
78531, 1.6347826086957, 0.41086956521739, 0.25
78532, 1.6130434782609, 0.41086956521739, 0.22727272727273
78533, 1.6347826086957, 0.43695652173913, 0.22727272727273
78534, 1.6347826086957, 0.41086956521739, 0.20454545454545
78535, 1.6130434782609, 0.41086956521739, 0.18181818181818
78536, 1.6347826086957, 0.43695652173913, 0.18181818181818
78537, 1.6347826086957, 0.41086956521739, 0.15909090909091
78538, 1.6130434782609, 0.41086956521739, 0.13636363636364
78539, 1.6347826086957, 0.43695652173913, 0.13636363636364
78540, 1.6347826086957, 0.41086956521739, 0.11363636363636
78541, 1.6130434782609, 0.41086956521739, 0.090909090909091
78542, 1.6347826086957, 0.43695652173913, 0.090909090909091
78543, 1.6347826086957, 0.41086956521739, 0.068181818181818
78544, 1.6130434782609, 0.41086956521739, 0.045454545454545
78545, 1.6347826086957, 0.43695652173913, 0.045454545454545
78546, 1.6347826086957, 0.41086956521739, 0.022727272727273
78547, 1.6782608695652, 0.41086956521739, 0.47727272727273
78548, 1.6565217391304, 0.41086956521739, 0.45454545454545
78549, 1.6782608695652, 0.43695652173913, 0.45454545454545
78550, 1.6782608695652, 0.41086956521739, 0.43181818181818
78551, 1.6565217391304, 0.41086956521739, 0.40909090909091
78552, 1.6782608695652, 0.43695652173913, 0.40909090909091
78553, 1.6782608695652, 0.41086956521739, 0.38636363636364
78554, 1.6565217391304, 0.41086956521739, 0.36363636363636
78555, 1.6782608695652, 0.43695652173913, 0.36363636363636
78556, 1.6782608695652, 0.41086956521739, 0.34090909090909
78557, 1.6565217391304, 0.41086956521739, 0.31818181818182
78558, 1.6782608695652, 0.43695652173913, 0.31818181818182
78559, 1.6782608695652, 0.41086956521739, 0.29545454545455
78560, 1.6565217391304, 0.41086956521739, 0.27272727272727
78561, 1.6782608695652, 0.43695652173913, 0.27272727272727
78562, 1.6782608695652, 0.41086956521739, 0.25
78563, 1.6565217391304, 0.41086956521739, 0.22727272727273
78564, 1.6782608695652, 0.43695652173913, 0.22727272727273
78565, 1.6782608695652, 0.41086956521739, 0.20454545454545
78566, 1.6565217391304, 0.41086956521739, 0.18181818181818
78567, 1.6782608695652, 0.43695652173913, 0.18181818181818
78568, 1.6782608695652, 0.41086956521739, 0.15909090909091
78569, 1.6565217391304, 0.41086956521739, 0.13636363636364
78570, 1.6782608695652, 0.43695652173913, 0.13636363636364
78571, 1.6782608695652, 0.41086956521739, 0.11363636363636
78572, 1.6565217391304, 0.41086956521739, 0.090909090909091
78573, 1.6782608695652, 0.43695652173913, 0.090909090909091
78574, 1.6782608695652, 0.41086956521739, 0.068181818181818
78575, 1.6565217391304, 0.41086956521739, 0.045454545454545
78576, 1.6782608695652, 0.43695652173913, 0.045454545454545
78577, 1.6782608695652, 0.41086956521739, 0.022727272727273
78578, 1.7217391304348, 0.41086956521739, 0.47727272727273
78579, 1.7, 0.41086956521739, 0.45454545454545
78580, 1.7217391304348, 0.43695652173913, 0.45454545454545
78581, 1.7217391304348, 0.41086956521739, 0.43181818181818
78582, 1.7, 0.41086956521739, 0.40909090909091
78583, 1.7217391304348, 0.43695652173913, 0.40909090909091
78584, 1.7217391304348, 0.41086956521739, 0.38636363636364
78585, 1.7, 0.41086956521739, 0.36363636363636
78586, 1.7217391304348, 0.43695652173913, 0.36363636363636
78587, 1.7217391304348, 0.41086956521739, 0.34090909090909
78588, 1.7, 0.41086956521739, 0.31818181818182
78589, 1.7217391304348, 0.43695652173913, 0.31818181818182
78590, 1.7217391304348, 0.41086956521739, 0.29545454545455
78591, 1.7, 0.41086956521739, 0.27272727272727
78592, 1.7217391304348, 0.43695652173913, 0.27272727272727
78593, 1.7217391304348, 0.41086956521739, 0.25
78594, 1.7, 0.41086956521739, 0.22727272727273
78595, 1.7217391304348, 0.43695652173913, 0.22727272727273
78596, 1.7217391304348, 0.41086956521739, 0.20454545454545
78597, 1.7, 0.41086956521739, 0.18181818181818
78598, 1.7217391304348, 0.43695652173913, 0.18181818181818
78599, 1.7217391304348, 0.41086956521739, 0.15909090909091
78600, 1.7, 0.41086956521739, 0.13636363636364
78601, 1.7217391304348, 0.43695652173913, 0.13636363636364
78602, 1.7217391304348, 0.41086956521739, 0.11363636363636
78603, 1.7, 0.41086956521739, 0.090909090909091
78604, 1.7217391304348, 0.43695652173913, 0.090909090909091
78605, 1.7217391304348, 0.41086956521739, 0.068181818181818
78606, 1.7, 0.41086956521739, 0.045454545454545
78607, 1.7217391304348, 0.43695652173913, 0.045454545454545
78608, 1.7217391304348, 0.41086956521739, 0.022727272727273
78609, 1.7652173913043, 0.41086956521739, 0.47727272727273
78610, 1.7434782608696, 0.41086956521739, 0.45454545454545
78611, 1.7652173913043, 0.43695652173913, 0.45454545454545
78612, 1.7652173913043, 0.41086956521739, 0.43181818181818
78613, 1.7434782608696, 0.41086956521739, 0.40909090909091
78614, 1.7652173913043, 0.43695652173913, 0.40909090909091
78615, 1.7652173913043, 0.41086956521739, 0.38636363636364
78616, 1.7434782608696, 0.41086956521739, 0.36363636363636
78617, 1.7652173913043, 0.43695652173913, 0.36363636363636
78618, 1.7652173913043, 0.41086956521739, 0.34090909090909
78619, 1.7434782608696, 0.41086956521739, 0.31818181818182
78620, 1.7652173913043, 0.43695652173913, 0.31818181818182
78621, 1.7652173913043, 0.41086956521739, 0.29545454545455
78622, 1.7434782608696, 0.41086956521739, 0.27272727272727
78623, 1.7652173913043, 0.43695652173913, 0.27272727272727
78624, 1.7652173913043, 0.41086956521739, 0.25
78625, 1.7434782608696, 0.41086956521739, 0.22727272727273
78626, 1.7652173913043, 0.43695652173913, 0.22727272727273
78627, 1.7652173913043, 0.41086956521739, 0.20454545454545
78628, 1.7434782608696, 0.41086956521739, 0.18181818181818
78629, 1.7652173913043, 0.43695652173913, 0.18181818181818
78630, 1.7652173913043, 0.41086956521739, 0.15909090909091
78631, 1.7434782608696, 0.41086956521739, 0.13636363636364
78632, 1.7652173913043, 0.43695652173913, 0.13636363636364
78633, 1.7652173913043, 0.41086956521739, 0.11363636363636
78634, 1.7434782608696, 0.41086956521739, 0.090909090909091
78635, 1.7652173913043, 0.43695652173913, 0.090909090909091
78636, 1.7652173913043, 0.41086956521739, 0.068181818181818
78637, 1.7434782608696, 0.41086956521739, 0.045454545454545
78638, 1.7652173913043, 0.43695652173913, 0.045454545454545
78639, 1.7652173913043, 0.41086956521739, 0.022727272727273
78640, 1.8086956521739, 0.41086956521739, 0.47727272727273
78641, 1.7869565217391, 0.41086956521739, 0.45454545454545
78642, 1.8086956521739, 0.43695652173913, 0.45454545454545
78643, 1.8086956521739, 0.41086956521739, 0.43181818181818
78644, 1.7869565217391, 0.41086956521739, 0.40909090909091
78645, 1.8086956521739, 0.43695652173913, 0.40909090909091
78646, 1.8086956521739, 0.41086956521739, 0.38636363636364
78647, 1.7869565217391, 0.41086956521739, 0.36363636363636
78648, 1.8086956521739, 0.43695652173913, 0.36363636363636
78649, 1.8086956521739, 0.41086956521739, 0.34090909090909
78650, 1.7869565217391, 0.41086956521739, 0.31818181818182
78651, 1.8086956521739, 0.43695652173913, 0.31818181818182
78652, 1.8086956521739, 0.41086956521739, 0.29545454545455
78653, 1.7869565217391, 0.41086956521739, 0.27272727272727
78654, 1.8086956521739, 0.43695652173913, 0.27272727272727
78655, 1.8086956521739, 0.41086956521739, 0.25
78656, 1.7869565217391, 0.41086956521739, 0.22727272727273
78657, 1.8086956521739, 0.43695652173913, 0.22727272727273
78658, 1.8086956521739, 0.41086956521739, 0.20454545454545
78659, 1.7869565217391, 0.41086956521739, 0.18181818181818
78660, 1.8086956521739, 0.43695652173913, 0.18181818181818
78661, 1.8086956521739, 0.41086956521739, 0.15909090909091
78662, 1.7869565217391, 0.41086956521739, 0.13636363636364
78663, 1.8086956521739, 0.43695652173913, 0.13636363636364
78664, 1.8086956521739, 0.41086956521739, 0.11363636363636
78665, 1.7869565217391, 0.41086956521739, 0.090909090909091
78666, 1.8086956521739, 0.43695652173913, 0.090909090909091
78667, 1.8086956521739, 0.41086956521739, 0.068181818181818
78668, 1.7869565217391, 0.41086956521739, 0.045454545454545
78669, 1.8086956521739, 0.43695652173913, 0.045454545454545
78670, 1.8086956521739, 0.41086956521739, 0.022727272727273
78671, 1.8521739130435, 0.41086956521739, 0.47727272727273
78672, 1.8304347826087, 0.41086956521739, 0.45454545454545
78673, 1.8521739130435, 0.43695652173913, 0.45454545454545
78674, 1.8521739130435, 0.41086956521739, 0.43181818181818
78675, 1.8304347826087, 0.41086956521739, 0.40909090909091
78676, 1.8521739130435, 0.43695652173913, 0.40909090909091
78677, 1.8521739130435, 0.41086956521739, 0.38636363636364
78678, 1.8304347826087, 0.41086956521739, 0.36363636363636
78679, 1.8521739130435, 0.43695652173913, 0.36363636363636
78680, 1.8521739130435, 0.41086956521739, 0.34090909090909
78681, 1.8304347826087, 0.41086956521739, 0.31818181818182
78682, 1.8521739130435, 0.43695652173913, 0.31818181818182
78683, 1.8521739130435, 0.41086956521739, 0.29545454545455
78684, 1.8304347826087, 0.41086956521739, 0.27272727272727
78685, 1.8521739130435, 0.43695652173913, 0.27272727272727
78686, 1.8521739130435, 0.41086956521739, 0.25
78687, 1.8304347826087, 0.41086956521739, 0.22727272727273
78688, 1.8521739130435, 0.43695652173913, 0.22727272727273
78689, 1.8521739130435, 0.41086956521739, 0.20454545454545
78690, 1.8304347826087, 0.41086956521739, 0.18181818181818
78691, 1.8521739130435, 0.43695652173913, 0.18181818181818
78692, 1.8521739130435, 0.41086956521739, 0.15909090909091
78693, 1.8304347826087, 0.41086956521739, 0.13636363636364
78694, 1.8521739130435, 0.43695652173913, 0.13636363636364
78695, 1.8521739130435, 0.41086956521739, 0.11363636363636
78696, 1.8304347826087, 0.41086956521739, 0.090909090909091
78697, 1.8521739130435, 0.43695652173913, 0.090909090909091
78698, 1.8521739130435, 0.41086956521739, 0.068181818181818
78699, 1.8304347826087, 0.41086956521739, 0.045454545454545
78700, 1.8521739130435, 0.43695652173913, 0.045454545454545
78701, 1.8521739130435, 0.41086956521739, 0.022727272727273
78702, 1.895652173913, 0.41086956521739, 0.47727272727273
78703, 1.8739130434783, 0.41086956521739, 0.45454545454545
78704, 1.895652173913, 0.43695652173913, 0.45454545454545
78705, 1.895652173913, 0.41086956521739, 0.43181818181818
78706, 1.8739130434783, 0.41086956521739, 0.40909090909091
78707, 1.895652173913, 0.43695652173913, 0.40909090909091
78708, 1.895652173913, 0.41086956521739, 0.38636363636364
78709, 1.8739130434783, 0.41086956521739, 0.36363636363636
78710, 1.895652173913, 0.43695652173913, 0.36363636363636
78711, 1.895652173913, 0.41086956521739, 0.34090909090909
78712, 1.8739130434783, 0.41086956521739, 0.31818181818182
78713, 1.895652173913, 0.43695652173913, 0.31818181818182
78714, 1.895652173913, 0.41086956521739, 0.29545454545455
78715, 1.8739130434783, 0.41086956521739, 0.27272727272727
78716, 1.895652173913, 0.43695652173913, 0.27272727272727
78717, 1.895652173913, 0.41086956521739, 0.25
78718, 1.8739130434783, 0.41086956521739, 0.22727272727273
78719, 1.895652173913, 0.43695652173913, 0.22727272727273
78720, 1.895652173913, 0.41086956521739, 0.20454545454545
78721, 1.8739130434783, 0.41086956521739, 0.18181818181818
78722, 1.895652173913, 0.43695652173913, 0.18181818181818
78723, 1.895652173913, 0.41086956521739, 0.15909090909091
78724, 1.8739130434783, 0.41086956521739, 0.13636363636364
78725, 1.895652173913, 0.43695652173913, 0.13636363636364
78726, 1.895652173913, 0.41086956521739, 0.11363636363636
78727, 1.8739130434783, 0.41086956521739, 0.090909090909091
78728, 1.895652173913, 0.43695652173913, 0.090909090909091
78729, 1.895652173913, 0.41086956521739, 0.068181818181818
78730, 1.8739130434783, 0.41086956521739, 0.045454545454545
78731, 1.895652173913, 0.43695652173913, 0.045454545454545
78732, 1.895652173913, 0.41086956521739, 0.022727272727273
78733, 1.9391304347826, 0.41086956521739, 0.47727272727273
78734, 1.9173913043478, 0.41086956521739, 0.45454545454545
78735, 1.9391304347826, 0.43695652173913, 0.45454545454545
78736, 1.9391304347826, 0.41086956521739, 0.43181818181818
78737, 1.9173913043478, 0.41086956521739, 0.40909090909091
78738, 1.9391304347826, 0.43695652173913, 0.40909090909091
78739, 1.9391304347826, 0.41086956521739, 0.38636363636364
78740, 1.9173913043478, 0.41086956521739, 0.36363636363636
78741, 1.9391304347826, 0.43695652173913, 0.36363636363636
78742, 1.9391304347826, 0.41086956521739, 0.34090909090909
78743, 1.9173913043478, 0.41086956521739, 0.31818181818182
78744, 1.9391304347826, 0.43695652173913, 0.31818181818182
78745, 1.9391304347826, 0.41086956521739, 0.29545454545455
78746, 1.9173913043478, 0.41086956521739, 0.27272727272727
78747, 1.9391304347826, 0.43695652173913, 0.27272727272727
78748, 1.9391304347826, 0.41086956521739, 0.25
78749, 1.9173913043478, 0.41086956521739, 0.22727272727273
78750, 1.9391304347826, 0.43695652173913, 0.22727272727273
78751, 1.9391304347826, 0.41086956521739, 0.20454545454545
78752, 1.9173913043478, 0.41086956521739, 0.18181818181818
78753, 1.9391304347826, 0.43695652173913, 0.18181818181818
78754, 1.9391304347826, 0.41086956521739, 0.15909090909091
78755, 1.9173913043478, 0.41086956521739, 0.13636363636364
78756, 1.9391304347826, 0.43695652173913, 0.13636363636364
78757, 1.9391304347826, 0.41086956521739, 0.11363636363636
78758, 1.9173913043478, 0.41086956521739, 0.090909090909091
78759, 1.9391304347826, 0.43695652173913, 0.090909090909091
78760, 1.9391304347826, 0.41086956521739, 0.068181818181818
78761, 1.9173913043478, 0.41086956521739, 0.045454545454545
78762, 1.9391304347826, 0.43695652173913, 0.045454545454545
78763, 1.9391304347826, 0.41086956521739, 0.022727272727273
78764, 1.9826086956522, 0.41086956521739, 0.47727272727273
78765, 1.9608695652174, 0.41086956521739, 0.45454545454545
78766, 1.9826086956522, 0.43695652173913, 0.45454545454545
78767, 1.9826086956522, 0.41086956521739, 0.43181818181818
78768, 1.9608695652174, 0.41086956521739, 0.40909090909091
78769, 1.9826086956522, 0.43695652173913, 0.40909090909091
78770, 1.9826086956522, 0.41086956521739, 0.38636363636364
78771, 1.9608695652174, 0.41086956521739, 0.36363636363636
78772, 1.9826086956522, 0.43695652173913, 0.36363636363636
78773, 1.9826086956522, 0.41086956521739, 0.34090909090909
78774, 1.9608695652174, 0.41086956521739, 0.31818181818182
78775, 1.9826086956522, 0.43695652173913, 0.31818181818182
78776, 1.9826086956522, 0.41086956521739, 0.29545454545455
78777, 1.9608695652174, 0.41086956521739, 0.27272727272727
78778, 1.9826086956522, 0.43695652173913, 0.27272727272727
78779, 1.9826086956522, 0.41086956521739, 0.25
78780, 1.9608695652174, 0.41086956521739, 0.22727272727273
78781, 1.9826086956522, 0.43695652173913, 0.22727272727273
78782, 1.9826086956522, 0.41086956521739, 0.20454545454545
78783, 1.9608695652174, 0.41086956521739, 0.18181818181818
78784, 1.9826086956522, 0.43695652173913, 0.18181818181818
78785, 1.9826086956522, 0.41086956521739, 0.15909090909091
78786, 1.9608695652174, 0.41086956521739, 0.13636363636364
78787, 1.9826086956522, 0.43695652173913, 0.13636363636364
78788, 1.9826086956522, 0.41086956521739, 0.11363636363636
78789, 1.9608695652174, 0.41086956521739, 0.090909090909091
78790, 1.9826086956522, 0.43695652173913, 0.090909090909091
78791, 1.9826086956522, 0.41086956521739, 0.068181818181818
78792, 1.9608695652174, 0.41086956521739, 0.045454545454545
78793, 1.9826086956522, 0.43695652173913, 0.045454545454545
78794, 1.9826086956522, 0.41086956521739, 0.022727272727273
78795, 2.0260869565217, 0.41086956521739, 0.47727272727273
78796, 2.004347826087, 0.41086956521739, 0.45454545454545
78797, 2.0260869565217, 0.43695652173913, 0.45454545454545
78798, 2.0260869565217, 0.41086956521739, 0.43181818181818
78799, 2.004347826087, 0.41086956521739, 0.40909090909091
78800, 2.0260869565217, 0.43695652173913, 0.40909090909091
78801, 2.0260869565217, 0.41086956521739, 0.38636363636364
78802, 2.004347826087, 0.41086956521739, 0.36363636363636
78803, 2.0260869565217, 0.43695652173913, 0.36363636363636
78804, 2.0260869565217, 0.41086956521739, 0.34090909090909
78805, 2.004347826087, 0.41086956521739, 0.31818181818182
78806, 2.0260869565217, 0.43695652173913, 0.31818181818182
78807, 2.0260869565217, 0.41086956521739, 0.29545454545455
78808, 2.004347826087, 0.41086956521739, 0.27272727272727
78809, 2.0260869565217, 0.43695652173913, 0.27272727272727
78810, 2.0260869565217, 0.41086956521739, 0.25
78811, 2.004347826087, 0.41086956521739, 0.22727272727273
78812, 2.0260869565217, 0.43695652173913, 0.22727272727273
78813, 2.0260869565217, 0.41086956521739, 0.20454545454545
78814, 2.004347826087, 0.41086956521739, 0.18181818181818
78815, 2.0260869565217, 0.43695652173913, 0.18181818181818
78816, 2.0260869565217, 0.41086956521739, 0.15909090909091
78817, 2.004347826087, 0.41086956521739, 0.13636363636364
78818, 2.0260869565217, 0.43695652173913, 0.13636363636364
78819, 2.0260869565217, 0.41086956521739, 0.11363636363636
78820, 2.004347826087, 0.41086956521739, 0.090909090909091
78821, 2.0260869565217, 0.43695652173913, 0.090909090909091
78822, 2.0260869565217, 0.41086956521739, 0.068181818181818
78823, 2.004347826087, 0.41086956521739, 0.045454545454545
78824, 2.0260869565217, 0.43695652173913, 0.045454545454545
78825, 2.0260869565217, 0.41086956521739, 0.022727272727273
78826, 2.0695652173913, 0.41086956521739, 0.47727272727273
78827, 2.0478260869565, 0.41086956521739, 0.45454545454545
78828, 2.0695652173913, 0.43695652173913, 0.45454545454545
78829, 2.0695652173913, 0.41086956521739, 0.43181818181818
78830, 2.0478260869565, 0.41086956521739, 0.40909090909091
78831, 2.0695652173913, 0.43695652173913, 0.40909090909091
78832, 2.0695652173913, 0.41086956521739, 0.38636363636364
78833, 2.0478260869565, 0.41086956521739, 0.36363636363636
78834, 2.0695652173913, 0.43695652173913, 0.36363636363636
78835, 2.0695652173913, 0.41086956521739, 0.34090909090909
78836, 2.0478260869565, 0.41086956521739, 0.31818181818182
78837, 2.0695652173913, 0.43695652173913, 0.31818181818182
78838, 2.0695652173913, 0.41086956521739, 0.29545454545455
78839, 2.0478260869565, 0.41086956521739, 0.27272727272727
78840, 2.0695652173913, 0.43695652173913, 0.27272727272727
78841, 2.0695652173913, 0.41086956521739, 0.25
78842, 2.0478260869565, 0.41086956521739, 0.22727272727273
78843, 2.0695652173913, 0.43695652173913, 0.22727272727273
78844, 2.0695652173913, 0.41086956521739, 0.20454545454545
78845, 2.0478260869565, 0.41086956521739, 0.18181818181818
78846, 2.0695652173913, 0.43695652173913, 0.18181818181818
78847, 2.0695652173913, 0.41086956521739, 0.15909090909091
78848, 2.0478260869565, 0.41086956521739, 0.13636363636364
78849, 2.0695652173913, 0.43695652173913, 0.13636363636364
78850, 2.0695652173913, 0.41086956521739, 0.11363636363636
78851, 2.0478260869565, 0.41086956521739, 0.090909090909091
78852, 2.0695652173913, 0.43695652173913, 0.090909090909091
78853, 2.0695652173913, 0.41086956521739, 0.068181818181818
78854, 2.0478260869565, 0.41086956521739, 0.045454545454545
78855, 2.0695652173913, 0.43695652173913, 0.045454545454545
78856, 2.0695652173913, 0.41086956521739, 0.022727272727273
78857, 2.1130434782609, 0.41086956521739, 0.47727272727273
78858, 2.0913043478261, 0.41086956521739, 0.45454545454545
78859, 2.1130434782609, 0.43695652173913, 0.45454545454545
78860, 2.1130434782609, 0.41086956521739, 0.43181818181818
78861, 2.0913043478261, 0.41086956521739, 0.40909090909091
78862, 2.1130434782609, 0.43695652173913, 0.40909090909091
78863, 2.1130434782609, 0.41086956521739, 0.38636363636364
78864, 2.0913043478261, 0.41086956521739, 0.36363636363636
78865, 2.1130434782609, 0.43695652173913, 0.36363636363636
78866, 2.1130434782609, 0.41086956521739, 0.34090909090909
78867, 2.0913043478261, 0.41086956521739, 0.31818181818182
78868, 2.1130434782609, 0.43695652173913, 0.31818181818182
78869, 2.1130434782609, 0.41086956521739, 0.29545454545455
78870, 2.0913043478261, 0.41086956521739, 0.27272727272727
78871, 2.1130434782609, 0.43695652173913, 0.27272727272727
78872, 2.1130434782609, 0.41086956521739, 0.25
78873, 2.0913043478261, 0.41086956521739, 0.22727272727273
78874, 2.1130434782609, 0.43695652173913, 0.22727272727273
78875, 2.1130434782609, 0.41086956521739, 0.20454545454545
78876, 2.0913043478261, 0.41086956521739, 0.18181818181818
78877, 2.1130434782609, 0.43695652173913, 0.18181818181818
78878, 2.1130434782609, 0.41086956521739, 0.15909090909091
78879, 2.0913043478261, 0.41086956521739, 0.13636363636364
78880, 2.1130434782609, 0.43695652173913, 0.13636363636364
78881, 2.1130434782609, 0.41086956521739, 0.11363636363636
78882, 2.0913043478261, 0.41086956521739, 0.090909090909091
78883, 2.1130434782609, 0.43695652173913, 0.090909090909091
78884, 2.1130434782609, 0.41086956521739, 0.068181818181818
78885, 2.0913043478261, 0.41086956521739, 0.045454545454545
78886, 2.1130434782609, 0.43695652173913, 0.045454545454545
78887, 2.1130434782609, 0.41086956521739, 0.022727272727273
78888, 2.1565217391304, 0.41086956521739, 0.47727272727273
78889, 2.1347826086957, 0.41086956521739, 0.45454545454545
78890, 2.1565217391304, 0.43695652173913, 0.45454545454545
78891, 2.1565217391304, 0.41086956521739, 0.43181818181818
78892, 2.1347826086957, 0.41086956521739, 0.40909090909091
78893, 2.1565217391304, 0.43695652173913, 0.40909090909091
78894, 2.1565217391304, 0.41086956521739, 0.38636363636364
78895, 2.1347826086957, 0.41086956521739, 0.36363636363636
78896, 2.1565217391304, 0.43695652173913, 0.36363636363636
78897, 2.1565217391304, 0.41086956521739, 0.34090909090909
78898, 2.1347826086957, 0.41086956521739, 0.31818181818182
78899, 2.1565217391304, 0.43695652173913, 0.31818181818182
78900, 2.1565217391304, 0.41086956521739, 0.29545454545455
78901, 2.1347826086957, 0.41086956521739, 0.27272727272727
78902, 2.1565217391304, 0.43695652173913, 0.27272727272727
78903, 2.1565217391304, 0.41086956521739, 0.25
78904, 2.1347826086957, 0.41086956521739, 0.22727272727273
78905, 2.1565217391304, 0.43695652173913, 0.22727272727273
78906, 2.1565217391304, 0.41086956521739, 0.20454545454545
78907, 2.1347826086957, 0.41086956521739, 0.18181818181818
78908, 2.1565217391304, 0.43695652173913, 0.18181818181818
78909, 2.1565217391304, 0.41086956521739, 0.15909090909091
78910, 2.1347826086957, 0.41086956521739, 0.13636363636364
78911, 2.1565217391304, 0.43695652173913, 0.13636363636364
78912, 2.1565217391304, 0.41086956521739, 0.11363636363636
78913, 2.1347826086957, 0.41086956521739, 0.090909090909091
78914, 2.1565217391304, 0.43695652173913, 0.090909090909091
78915, 2.1565217391304, 0.41086956521739, 0.068181818181818
78916, 2.1347826086957, 0.41086956521739, 0.045454545454545
78917, 2.1565217391304, 0.43695652173913, 0.045454545454545
78918, 2.1565217391304, 0.41086956521739, 0.022727272727273
78919, 2.1782608695652, 0.41086956521739, 0.45454545454545
78920, 2.1782608695652, 0.41086956521739, 0.40909090909091
78921, 2.1782608695652, 0.41086956521739, 0.36363636363636
78922, 2.1782608695652, 0.41086956521739, 0.31818181818182
78923, 2.1782608695652, 0.41086956521739, 0.27272727272727
78924, 2.1782608695652, 0.41086956521739, 0.22727272727273
78925, 2.1782608695652, 0.41086956521739, 0.18181818181818
78926, 2.1782608695652, 0.41086956521739, 0.13636363636364
78927, 2.1782608695652, 0.41086956521739, 0.090909090909091
78928, 2.1782608695652, 0.41086956521739, 0.045454545454545
78929, 1.2434782608696, 0.35869565217391, 0.47727272727273
78930, 1.2217391304348, 0.35869565217391, 0.45454545454545
78931, 1.2434782608696, 0.38478260869565, 0.45454545454545
78932, 1.2434782608696, 0.35869565217391, 0.43181818181818
78933, 1.2217391304348, 0.35869565217391, 0.40909090909091
78934, 1.2434782608696, 0.38478260869565, 0.40909090909091
78935, 1.2434782608696, 0.35869565217391, 0.38636363636364
78936, 1.2217391304348, 0.35869565217391, 0.36363636363636
78937, 1.2434782608696, 0.38478260869565, 0.36363636363636
78938, 1.2434782608696, 0.35869565217391, 0.34090909090909
78939, 1.2217391304348, 0.35869565217391, 0.31818181818182
78940, 1.2434782608696, 0.38478260869565, 0.31818181818182
78941, 1.2434782608696, 0.35869565217391, 0.29545454545455
78942, 1.2217391304348, 0.35869565217391, 0.27272727272727
78943, 1.2434782608696, 0.38478260869565, 0.27272727272727
78944, 1.2434782608696, 0.35869565217391, 0.25
78945, 1.2217391304348, 0.35869565217391, 0.22727272727273
78946, 1.2434782608696, 0.38478260869565, 0.22727272727273
78947, 1.2434782608696, 0.35869565217391, 0.20454545454545
78948, 1.2217391304348, 0.35869565217391, 0.18181818181818
78949, 1.2434782608696, 0.38478260869565, 0.18181818181818
78950, 1.2434782608696, 0.35869565217391, 0.15909090909091
78951, 1.2217391304348, 0.35869565217391, 0.13636363636364
78952, 1.2434782608696, 0.38478260869565, 0.13636363636364
78953, 1.2434782608696, 0.35869565217391, 0.11363636363636
78954, 1.2217391304348, 0.35869565217391, 0.090909090909091
78955, 1.2434782608696, 0.38478260869565, 0.090909090909091
78956, 1.2434782608696, 0.35869565217391, 0.068181818181818
78957, 1.2217391304348, 0.35869565217391, 0.045454545454545
78958, 1.2434782608696, 0.38478260869565, 0.045454545454545
78959, 1.2434782608696, 0.35869565217391, 0.022727272727273
78960, 1.2869565217391, 0.35869565217391, 0.47727272727273
78961, 1.2652173913043, 0.35869565217391, 0.45454545454545
78962, 1.2869565217391, 0.38478260869565, 0.45454545454545
78963, 1.2869565217391, 0.35869565217391, 0.43181818181818
78964, 1.2652173913043, 0.35869565217391, 0.40909090909091
78965, 1.2869565217391, 0.38478260869565, 0.40909090909091
78966, 1.2869565217391, 0.35869565217391, 0.38636363636364
78967, 1.2652173913043, 0.35869565217391, 0.36363636363636
78968, 1.2869565217391, 0.38478260869565, 0.36363636363636
78969, 1.2869565217391, 0.35869565217391, 0.34090909090909
78970, 1.2652173913043, 0.35869565217391, 0.31818181818182
78971, 1.2869565217391, 0.38478260869565, 0.31818181818182
78972, 1.2869565217391, 0.35869565217391, 0.29545454545455
78973, 1.2652173913043, 0.35869565217391, 0.27272727272727
78974, 1.2869565217391, 0.38478260869565, 0.27272727272727
78975, 1.2869565217391, 0.35869565217391, 0.25
78976, 1.2652173913043, 0.35869565217391, 0.22727272727273
78977, 1.2869565217391, 0.38478260869565, 0.22727272727273
78978, 1.2869565217391, 0.35869565217391, 0.20454545454545
78979, 1.2652173913043, 0.35869565217391, 0.18181818181818
78980, 1.2869565217391, 0.38478260869565, 0.18181818181818
78981, 1.2869565217391, 0.35869565217391, 0.15909090909091
78982, 1.2652173913043, 0.35869565217391, 0.13636363636364
78983, 1.2869565217391, 0.38478260869565, 0.13636363636364
78984, 1.2869565217391, 0.35869565217391, 0.11363636363636
78985, 1.2652173913043, 0.35869565217391, 0.090909090909091
78986, 1.2869565217391, 0.38478260869565, 0.090909090909091
78987, 1.2869565217391, 0.35869565217391, 0.068181818181818
78988, 1.2652173913043, 0.35869565217391, 0.045454545454545
78989, 1.2869565217391, 0.38478260869565, 0.045454545454545
78990, 1.2869565217391, 0.35869565217391, 0.022727272727273
78991, 1.3304347826087, 0.35869565217391, 0.47727272727273
78992, 1.3086956521739, 0.35869565217391, 0.45454545454545
78993, 1.3304347826087, 0.38478260869565, 0.45454545454545
78994, 1.3304347826087, 0.35869565217391, 0.43181818181818
78995, 1.3086956521739, 0.35869565217391, 0.40909090909091
78996, 1.3304347826087, 0.38478260869565, 0.40909090909091
78997, 1.3304347826087, 0.35869565217391, 0.38636363636364
78998, 1.3086956521739, 0.35869565217391, 0.36363636363636
78999, 1.3304347826087, 0.38478260869565, 0.36363636363636
79000, 1.3304347826087, 0.35869565217391, 0.34090909090909
79001, 1.3086956521739, 0.35869565217391, 0.31818181818182
79002, 1.3304347826087, 0.38478260869565, 0.31818181818182
79003, 1.3304347826087, 0.35869565217391, 0.29545454545455
79004, 1.3086956521739, 0.35869565217391, 0.27272727272727
79005, 1.3304347826087, 0.38478260869565, 0.27272727272727
79006, 1.3304347826087, 0.35869565217391, 0.25
79007, 1.3086956521739, 0.35869565217391, 0.22727272727273
79008, 1.3304347826087, 0.38478260869565, 0.22727272727273
79009, 1.3304347826087, 0.35869565217391, 0.20454545454545
79010, 1.3086956521739, 0.35869565217391, 0.18181818181818
79011, 1.3304347826087, 0.38478260869565, 0.18181818181818
79012, 1.3304347826087, 0.35869565217391, 0.15909090909091
79013, 1.3086956521739, 0.35869565217391, 0.13636363636364
79014, 1.3304347826087, 0.38478260869565, 0.13636363636364
79015, 1.3304347826087, 0.35869565217391, 0.11363636363636
79016, 1.3086956521739, 0.35869565217391, 0.090909090909091
79017, 1.3304347826087, 0.38478260869565, 0.090909090909091
79018, 1.3304347826087, 0.35869565217391, 0.068181818181818
79019, 1.3086956521739, 0.35869565217391, 0.045454545454545
79020, 1.3304347826087, 0.38478260869565, 0.045454545454545
79021, 1.3304347826087, 0.35869565217391, 0.022727272727273
79022, 1.3739130434783, 0.35869565217391, 0.47727272727273
79023, 1.3521739130435, 0.35869565217391, 0.45454545454545
79024, 1.3739130434783, 0.38478260869565, 0.45454545454545
79025, 1.3739130434783, 0.35869565217391, 0.43181818181818
79026, 1.3521739130435, 0.35869565217391, 0.40909090909091
79027, 1.3739130434783, 0.38478260869565, 0.40909090909091
79028, 1.3739130434783, 0.35869565217391, 0.38636363636364
79029, 1.3521739130435, 0.35869565217391, 0.36363636363636
79030, 1.3739130434783, 0.38478260869565, 0.36363636363636
79031, 1.3739130434783, 0.35869565217391, 0.34090909090909
79032, 1.3521739130435, 0.35869565217391, 0.31818181818182
79033, 1.3739130434783, 0.38478260869565, 0.31818181818182
79034, 1.3739130434783, 0.35869565217391, 0.29545454545455
79035, 1.3521739130435, 0.35869565217391, 0.27272727272727
79036, 1.3739130434783, 0.38478260869565, 0.27272727272727
79037, 1.3739130434783, 0.35869565217391, 0.25
79038, 1.3521739130435, 0.35869565217391, 0.22727272727273
79039, 1.3739130434783, 0.38478260869565, 0.22727272727273
79040, 1.3739130434783, 0.35869565217391, 0.20454545454545
79041, 1.3521739130435, 0.35869565217391, 0.18181818181818
79042, 1.3739130434783, 0.38478260869565, 0.18181818181818
79043, 1.3739130434783, 0.35869565217391, 0.15909090909091
79044, 1.3521739130435, 0.35869565217391, 0.13636363636364
79045, 1.3739130434783, 0.38478260869565, 0.13636363636364
79046, 1.3739130434783, 0.35869565217391, 0.11363636363636
79047, 1.3521739130435, 0.35869565217391, 0.090909090909091
79048, 1.3739130434783, 0.38478260869565, 0.090909090909091
79049, 1.3739130434783, 0.35869565217391, 0.068181818181818
79050, 1.3521739130435, 0.35869565217391, 0.045454545454545
79051, 1.3739130434783, 0.38478260869565, 0.045454545454545
79052, 1.3739130434783, 0.35869565217391, 0.022727272727273
79053, 1.4173913043478, 0.35869565217391, 0.47727272727273
79054, 1.395652173913, 0.35869565217391, 0.45454545454545
79055, 1.4173913043478, 0.38478260869565, 0.45454545454545
79056, 1.4173913043478, 0.35869565217391, 0.43181818181818
79057, 1.395652173913, 0.35869565217391, 0.40909090909091
79058, 1.4173913043478, 0.38478260869565, 0.40909090909091
79059, 1.4173913043478, 0.35869565217391, 0.38636363636364
79060, 1.395652173913, 0.35869565217391, 0.36363636363636
79061, 1.4173913043478, 0.38478260869565, 0.36363636363636
79062, 1.4173913043478, 0.35869565217391, 0.34090909090909
79063, 1.395652173913, 0.35869565217391, 0.31818181818182
79064, 1.4173913043478, 0.38478260869565, 0.31818181818182
79065, 1.4173913043478, 0.35869565217391, 0.29545454545455
79066, 1.395652173913, 0.35869565217391, 0.27272727272727
79067, 1.4173913043478, 0.38478260869565, 0.27272727272727
79068, 1.4173913043478, 0.35869565217391, 0.25
79069, 1.395652173913, 0.35869565217391, 0.22727272727273
79070, 1.4173913043478, 0.38478260869565, 0.22727272727273
79071, 1.4173913043478, 0.35869565217391, 0.20454545454545
79072, 1.395652173913, 0.35869565217391, 0.18181818181818
79073, 1.4173913043478, 0.38478260869565, 0.18181818181818
79074, 1.4173913043478, 0.35869565217391, 0.15909090909091
79075, 1.395652173913, 0.35869565217391, 0.13636363636364
79076, 1.4173913043478, 0.38478260869565, 0.13636363636364
79077, 1.4173913043478, 0.35869565217391, 0.11363636363636
79078, 1.395652173913, 0.35869565217391, 0.090909090909091
79079, 1.4173913043478, 0.38478260869565, 0.090909090909091
79080, 1.4173913043478, 0.35869565217391, 0.068181818181818
79081, 1.395652173913, 0.35869565217391, 0.045454545454545
79082, 1.4173913043478, 0.38478260869565, 0.045454545454545
79083, 1.4173913043478, 0.35869565217391, 0.022727272727273
79084, 1.4608695652174, 0.35869565217391, 0.47727272727273
79085, 1.4391304347826, 0.35869565217391, 0.45454545454545
79086, 1.4608695652174, 0.38478260869565, 0.45454545454545
79087, 1.4608695652174, 0.35869565217391, 0.43181818181818
79088, 1.4391304347826, 0.35869565217391, 0.40909090909091
79089, 1.4608695652174, 0.38478260869565, 0.40909090909091
79090, 1.4608695652174, 0.35869565217391, 0.38636363636364
79091, 1.4391304347826, 0.35869565217391, 0.36363636363636
79092, 1.4608695652174, 0.38478260869565, 0.36363636363636
79093, 1.4608695652174, 0.35869565217391, 0.34090909090909
79094, 1.4391304347826, 0.35869565217391, 0.31818181818182
79095, 1.4608695652174, 0.38478260869565, 0.31818181818182
79096, 1.4608695652174, 0.35869565217391, 0.29545454545455
79097, 1.4391304347826, 0.35869565217391, 0.27272727272727
79098, 1.4608695652174, 0.38478260869565, 0.27272727272727
79099, 1.4608695652174, 0.35869565217391, 0.25
79100, 1.4391304347826, 0.35869565217391, 0.22727272727273
79101, 1.4608695652174, 0.38478260869565, 0.22727272727273
79102, 1.4608695652174, 0.35869565217391, 0.20454545454545
79103, 1.4391304347826, 0.35869565217391, 0.18181818181818
79104, 1.4608695652174, 0.38478260869565, 0.18181818181818
79105, 1.4608695652174, 0.35869565217391, 0.15909090909091
79106, 1.4391304347826, 0.35869565217391, 0.13636363636364
79107, 1.4608695652174, 0.38478260869565, 0.13636363636364
79108, 1.4608695652174, 0.35869565217391, 0.11363636363636
79109, 1.4391304347826, 0.35869565217391, 0.090909090909091
79110, 1.4608695652174, 0.38478260869565, 0.090909090909091
79111, 1.4608695652174, 0.35869565217391, 0.068181818181818
79112, 1.4391304347826, 0.35869565217391, 0.045454545454545
79113, 1.4608695652174, 0.38478260869565, 0.045454545454545
79114, 1.4608695652174, 0.35869565217391, 0.022727272727273
79115, 1.504347826087, 0.35869565217391, 0.47727272727273
79116, 1.4826086956522, 0.35869565217391, 0.45454545454545
79117, 1.504347826087, 0.38478260869565, 0.45454545454545
79118, 1.504347826087, 0.35869565217391, 0.43181818181818
79119, 1.4826086956522, 0.35869565217391, 0.40909090909091
79120, 1.504347826087, 0.38478260869565, 0.40909090909091
79121, 1.504347826087, 0.35869565217391, 0.38636363636364
79122, 1.4826086956522, 0.35869565217391, 0.36363636363636
79123, 1.504347826087, 0.38478260869565, 0.36363636363636
79124, 1.504347826087, 0.35869565217391, 0.34090909090909
79125, 1.4826086956522, 0.35869565217391, 0.31818181818182
79126, 1.504347826087, 0.38478260869565, 0.31818181818182
79127, 1.504347826087, 0.35869565217391, 0.29545454545455
79128, 1.4826086956522, 0.35869565217391, 0.27272727272727
79129, 1.504347826087, 0.38478260869565, 0.27272727272727
79130, 1.504347826087, 0.35869565217391, 0.25
79131, 1.4826086956522, 0.35869565217391, 0.22727272727273
79132, 1.504347826087, 0.38478260869565, 0.22727272727273
79133, 1.504347826087, 0.35869565217391, 0.20454545454545
79134, 1.4826086956522, 0.35869565217391, 0.18181818181818
79135, 1.504347826087, 0.38478260869565, 0.18181818181818
79136, 1.504347826087, 0.35869565217391, 0.15909090909091
79137, 1.4826086956522, 0.35869565217391, 0.13636363636364
79138, 1.504347826087, 0.38478260869565, 0.13636363636364
79139, 1.504347826087, 0.35869565217391, 0.11363636363636
79140, 1.4826086956522, 0.35869565217391, 0.090909090909091
79141, 1.504347826087, 0.38478260869565, 0.090909090909091
79142, 1.504347826087, 0.35869565217391, 0.068181818181818
79143, 1.4826086956522, 0.35869565217391, 0.045454545454545
79144, 1.504347826087, 0.38478260869565, 0.045454545454545
79145, 1.504347826087, 0.35869565217391, 0.022727272727273
79146, 1.5478260869565, 0.35869565217391, 0.47727272727273
79147, 1.5260869565217, 0.35869565217391, 0.45454545454545
79148, 1.5478260869565, 0.38478260869565, 0.45454545454545
79149, 1.5478260869565, 0.35869565217391, 0.43181818181818
79150, 1.5260869565217, 0.35869565217391, 0.40909090909091
79151, 1.5478260869565, 0.38478260869565, 0.40909090909091
79152, 1.5478260869565, 0.35869565217391, 0.38636363636364
79153, 1.5260869565217, 0.35869565217391, 0.36363636363636
79154, 1.5478260869565, 0.38478260869565, 0.36363636363636
79155, 1.5478260869565, 0.35869565217391, 0.34090909090909
79156, 1.5260869565217, 0.35869565217391, 0.31818181818182
79157, 1.5478260869565, 0.38478260869565, 0.31818181818182
79158, 1.5478260869565, 0.35869565217391, 0.29545454545455
79159, 1.5260869565217, 0.35869565217391, 0.27272727272727
79160, 1.5478260869565, 0.38478260869565, 0.27272727272727
79161, 1.5478260869565, 0.35869565217391, 0.25
79162, 1.5260869565217, 0.35869565217391, 0.22727272727273
79163, 1.5478260869565, 0.38478260869565, 0.22727272727273
79164, 1.5478260869565, 0.35869565217391, 0.20454545454545
79165, 1.5260869565217, 0.35869565217391, 0.18181818181818
79166, 1.5478260869565, 0.38478260869565, 0.18181818181818
79167, 1.5478260869565, 0.35869565217391, 0.15909090909091
79168, 1.5260869565217, 0.35869565217391, 0.13636363636364
79169, 1.5478260869565, 0.38478260869565, 0.13636363636364
79170, 1.5478260869565, 0.35869565217391, 0.11363636363636
79171, 1.5260869565217, 0.35869565217391, 0.090909090909091
79172, 1.5478260869565, 0.38478260869565, 0.090909090909091
79173, 1.5478260869565, 0.35869565217391, 0.068181818181818
79174, 1.5260869565217, 0.35869565217391, 0.045454545454545
79175, 1.5478260869565, 0.38478260869565, 0.045454545454545
79176, 1.5478260869565, 0.35869565217391, 0.022727272727273
79177, 1.5913043478261, 0.35869565217391, 0.47727272727273
79178, 1.5695652173913, 0.35869565217391, 0.45454545454545
79179, 1.5913043478261, 0.38478260869565, 0.45454545454545
79180, 1.5913043478261, 0.35869565217391, 0.43181818181818
79181, 1.5695652173913, 0.35869565217391, 0.40909090909091
79182, 1.5913043478261, 0.38478260869565, 0.40909090909091
79183, 1.5913043478261, 0.35869565217391, 0.38636363636364
79184, 1.5695652173913, 0.35869565217391, 0.36363636363636
79185, 1.5913043478261, 0.38478260869565, 0.36363636363636
79186, 1.5913043478261, 0.35869565217391, 0.34090909090909
79187, 1.5695652173913, 0.35869565217391, 0.31818181818182
79188, 1.5913043478261, 0.38478260869565, 0.31818181818182
79189, 1.5913043478261, 0.35869565217391, 0.29545454545455
79190, 1.5695652173913, 0.35869565217391, 0.27272727272727
79191, 1.5913043478261, 0.38478260869565, 0.27272727272727
79192, 1.5913043478261, 0.35869565217391, 0.25
79193, 1.5695652173913, 0.35869565217391, 0.22727272727273
79194, 1.5913043478261, 0.38478260869565, 0.22727272727273
79195, 1.5913043478261, 0.35869565217391, 0.20454545454545
79196, 1.5695652173913, 0.35869565217391, 0.18181818181818
79197, 1.5913043478261, 0.38478260869565, 0.18181818181818
79198, 1.5913043478261, 0.35869565217391, 0.15909090909091
79199, 1.5695652173913, 0.35869565217391, 0.13636363636364
79200, 1.5913043478261, 0.38478260869565, 0.13636363636364
79201, 1.5913043478261, 0.35869565217391, 0.11363636363636
79202, 1.5695652173913, 0.35869565217391, 0.090909090909091
79203, 1.5913043478261, 0.38478260869565, 0.090909090909091
79204, 1.5913043478261, 0.35869565217391, 0.068181818181818
79205, 1.5695652173913, 0.35869565217391, 0.045454545454545
79206, 1.5913043478261, 0.38478260869565, 0.045454545454545
79207, 1.5913043478261, 0.35869565217391, 0.022727272727273
79208, 1.6347826086957, 0.35869565217391, 0.47727272727273
79209, 1.6130434782609, 0.35869565217391, 0.45454545454545
79210, 1.6347826086957, 0.38478260869565, 0.45454545454545
79211, 1.6347826086957, 0.35869565217391, 0.43181818181818
79212, 1.6130434782609, 0.35869565217391, 0.40909090909091
79213, 1.6347826086957, 0.38478260869565, 0.40909090909091
79214, 1.6347826086957, 0.35869565217391, 0.38636363636364
79215, 1.6130434782609, 0.35869565217391, 0.36363636363636
79216, 1.6347826086957, 0.38478260869565, 0.36363636363636
79217, 1.6347826086957, 0.35869565217391, 0.34090909090909
79218, 1.6130434782609, 0.35869565217391, 0.31818181818182
79219, 1.6347826086957, 0.38478260869565, 0.31818181818182
79220, 1.6347826086957, 0.35869565217391, 0.29545454545455
79221, 1.6130434782609, 0.35869565217391, 0.27272727272727
79222, 1.6347826086957, 0.38478260869565, 0.27272727272727
79223, 1.6347826086957, 0.35869565217391, 0.25
79224, 1.6130434782609, 0.35869565217391, 0.22727272727273
79225, 1.6347826086957, 0.38478260869565, 0.22727272727273
79226, 1.6347826086957, 0.35869565217391, 0.20454545454545
79227, 1.6130434782609, 0.35869565217391, 0.18181818181818
79228, 1.6347826086957, 0.38478260869565, 0.18181818181818
79229, 1.6347826086957, 0.35869565217391, 0.15909090909091
79230, 1.6130434782609, 0.35869565217391, 0.13636363636364
79231, 1.6347826086957, 0.38478260869565, 0.13636363636364
79232, 1.6347826086957, 0.35869565217391, 0.11363636363636
79233, 1.6130434782609, 0.35869565217391, 0.090909090909091
79234, 1.6347826086957, 0.38478260869565, 0.090909090909091
79235, 1.6347826086957, 0.35869565217391, 0.068181818181818
79236, 1.6130434782609, 0.35869565217391, 0.045454545454545
79237, 1.6347826086957, 0.38478260869565, 0.045454545454545
79238, 1.6347826086957, 0.35869565217391, 0.022727272727273
79239, 1.6782608695652, 0.35869565217391, 0.47727272727273
79240, 1.6565217391304, 0.35869565217391, 0.45454545454545
79241, 1.6782608695652, 0.38478260869565, 0.45454545454545
79242, 1.6782608695652, 0.35869565217391, 0.43181818181818
79243, 1.6565217391304, 0.35869565217391, 0.40909090909091
79244, 1.6782608695652, 0.38478260869565, 0.40909090909091
79245, 1.6782608695652, 0.35869565217391, 0.38636363636364
79246, 1.6565217391304, 0.35869565217391, 0.36363636363636
79247, 1.6782608695652, 0.38478260869565, 0.36363636363636
79248, 1.6782608695652, 0.35869565217391, 0.34090909090909
79249, 1.6565217391304, 0.35869565217391, 0.31818181818182
79250, 1.6782608695652, 0.38478260869565, 0.31818181818182
79251, 1.6782608695652, 0.35869565217391, 0.29545454545455
79252, 1.6565217391304, 0.35869565217391, 0.27272727272727
79253, 1.6782608695652, 0.38478260869565, 0.27272727272727
79254, 1.6782608695652, 0.35869565217391, 0.25
79255, 1.6565217391304, 0.35869565217391, 0.22727272727273
79256, 1.6782608695652, 0.38478260869565, 0.22727272727273
79257, 1.6782608695652, 0.35869565217391, 0.20454545454545
79258, 1.6565217391304, 0.35869565217391, 0.18181818181818
79259, 1.6782608695652, 0.38478260869565, 0.18181818181818
79260, 1.6782608695652, 0.35869565217391, 0.15909090909091
79261, 1.6565217391304, 0.35869565217391, 0.13636363636364
79262, 1.6782608695652, 0.38478260869565, 0.13636363636364
79263, 1.6782608695652, 0.35869565217391, 0.11363636363636
79264, 1.6565217391304, 0.35869565217391, 0.090909090909091
79265, 1.6782608695652, 0.38478260869565, 0.090909090909091
79266, 1.6782608695652, 0.35869565217391, 0.068181818181818
79267, 1.6565217391304, 0.35869565217391, 0.045454545454545
79268, 1.6782608695652, 0.38478260869565, 0.045454545454545
79269, 1.6782608695652, 0.35869565217391, 0.022727272727273
79270, 1.7217391304348, 0.35869565217391, 0.47727272727273
79271, 1.7, 0.35869565217391, 0.45454545454545
79272, 1.7217391304348, 0.38478260869565, 0.45454545454545
79273, 1.7217391304348, 0.35869565217391, 0.43181818181818
79274, 1.7, 0.35869565217391, 0.40909090909091
79275, 1.7217391304348, 0.38478260869565, 0.40909090909091
79276, 1.7217391304348, 0.35869565217391, 0.38636363636364
79277, 1.7, 0.35869565217391, 0.36363636363636
79278, 1.7217391304348, 0.38478260869565, 0.36363636363636
79279, 1.7217391304348, 0.35869565217391, 0.34090909090909
79280, 1.7, 0.35869565217391, 0.31818181818182
79281, 1.7217391304348, 0.38478260869565, 0.31818181818182
79282, 1.7217391304348, 0.35869565217391, 0.29545454545455
79283, 1.7, 0.35869565217391, 0.27272727272727
79284, 1.7217391304348, 0.38478260869565, 0.27272727272727
79285, 1.7217391304348, 0.35869565217391, 0.25
79286, 1.7, 0.35869565217391, 0.22727272727273
79287, 1.7217391304348, 0.38478260869565, 0.22727272727273
79288, 1.7217391304348, 0.35869565217391, 0.20454545454545
79289, 1.7, 0.35869565217391, 0.18181818181818
79290, 1.7217391304348, 0.38478260869565, 0.18181818181818
79291, 1.7217391304348, 0.35869565217391, 0.15909090909091
79292, 1.7, 0.35869565217391, 0.13636363636364
79293, 1.7217391304348, 0.38478260869565, 0.13636363636364
79294, 1.7217391304348, 0.35869565217391, 0.11363636363636
79295, 1.7, 0.35869565217391, 0.090909090909091
79296, 1.7217391304348, 0.38478260869565, 0.090909090909091
79297, 1.7217391304348, 0.35869565217391, 0.068181818181818
79298, 1.7, 0.35869565217391, 0.045454545454545
79299, 1.7217391304348, 0.38478260869565, 0.045454545454545
79300, 1.7217391304348, 0.35869565217391, 0.022727272727273
79301, 1.7652173913043, 0.35869565217391, 0.47727272727273
79302, 1.7434782608696, 0.35869565217391, 0.45454545454545
79303, 1.7652173913043, 0.38478260869565, 0.45454545454545
79304, 1.7652173913043, 0.35869565217391, 0.43181818181818
79305, 1.7434782608696, 0.35869565217391, 0.40909090909091
79306, 1.7652173913043, 0.38478260869565, 0.40909090909091
79307, 1.7652173913043, 0.35869565217391, 0.38636363636364
79308, 1.7434782608696, 0.35869565217391, 0.36363636363636
79309, 1.7652173913043, 0.38478260869565, 0.36363636363636
79310, 1.7652173913043, 0.35869565217391, 0.34090909090909
79311, 1.7434782608696, 0.35869565217391, 0.31818181818182
79312, 1.7652173913043, 0.38478260869565, 0.31818181818182
79313, 1.7652173913043, 0.35869565217391, 0.29545454545455
79314, 1.7434782608696, 0.35869565217391, 0.27272727272727
79315, 1.7652173913043, 0.38478260869565, 0.27272727272727
79316, 1.7652173913043, 0.35869565217391, 0.25
79317, 1.7434782608696, 0.35869565217391, 0.22727272727273
79318, 1.7652173913043, 0.38478260869565, 0.22727272727273
79319, 1.7652173913043, 0.35869565217391, 0.20454545454545
79320, 1.7434782608696, 0.35869565217391, 0.18181818181818
79321, 1.7652173913043, 0.38478260869565, 0.18181818181818
79322, 1.7652173913043, 0.35869565217391, 0.15909090909091
79323, 1.7434782608696, 0.35869565217391, 0.13636363636364
79324, 1.7652173913043, 0.38478260869565, 0.13636363636364
79325, 1.7652173913043, 0.35869565217391, 0.11363636363636
79326, 1.7434782608696, 0.35869565217391, 0.090909090909091
79327, 1.7652173913043, 0.38478260869565, 0.090909090909091
79328, 1.7652173913043, 0.35869565217391, 0.068181818181818
79329, 1.7434782608696, 0.35869565217391, 0.045454545454545
79330, 1.7652173913043, 0.38478260869565, 0.045454545454545
79331, 1.7652173913043, 0.35869565217391, 0.022727272727273
79332, 1.8086956521739, 0.35869565217391, 0.47727272727273
79333, 1.7869565217391, 0.35869565217391, 0.45454545454545
79334, 1.8086956521739, 0.38478260869565, 0.45454545454545
79335, 1.8086956521739, 0.35869565217391, 0.43181818181818
79336, 1.7869565217391, 0.35869565217391, 0.40909090909091
79337, 1.8086956521739, 0.38478260869565, 0.40909090909091
79338, 1.8086956521739, 0.35869565217391, 0.38636363636364
79339, 1.7869565217391, 0.35869565217391, 0.36363636363636
79340, 1.8086956521739, 0.38478260869565, 0.36363636363636
79341, 1.8086956521739, 0.35869565217391, 0.34090909090909
79342, 1.7869565217391, 0.35869565217391, 0.31818181818182
79343, 1.8086956521739, 0.38478260869565, 0.31818181818182
79344, 1.8086956521739, 0.35869565217391, 0.29545454545455
79345, 1.7869565217391, 0.35869565217391, 0.27272727272727
79346, 1.8086956521739, 0.38478260869565, 0.27272727272727
79347, 1.8086956521739, 0.35869565217391, 0.25
79348, 1.7869565217391, 0.35869565217391, 0.22727272727273
79349, 1.8086956521739, 0.38478260869565, 0.22727272727273
79350, 1.8086956521739, 0.35869565217391, 0.20454545454545
79351, 1.7869565217391, 0.35869565217391, 0.18181818181818
79352, 1.8086956521739, 0.38478260869565, 0.18181818181818
79353, 1.8086956521739, 0.35869565217391, 0.15909090909091
79354, 1.7869565217391, 0.35869565217391, 0.13636363636364
79355, 1.8086956521739, 0.38478260869565, 0.13636363636364
79356, 1.8086956521739, 0.35869565217391, 0.11363636363636
79357, 1.7869565217391, 0.35869565217391, 0.090909090909091
79358, 1.8086956521739, 0.38478260869565, 0.090909090909091
79359, 1.8086956521739, 0.35869565217391, 0.068181818181818
79360, 1.7869565217391, 0.35869565217391, 0.045454545454545
79361, 1.8086956521739, 0.38478260869565, 0.045454545454545
79362, 1.8086956521739, 0.35869565217391, 0.022727272727273
79363, 1.8521739130435, 0.35869565217391, 0.47727272727273
79364, 1.8304347826087, 0.35869565217391, 0.45454545454545
79365, 1.8521739130435, 0.38478260869565, 0.45454545454545
79366, 1.8521739130435, 0.35869565217391, 0.43181818181818
79367, 1.8304347826087, 0.35869565217391, 0.40909090909091
79368, 1.8521739130435, 0.38478260869565, 0.40909090909091
79369, 1.8521739130435, 0.35869565217391, 0.38636363636364
79370, 1.8304347826087, 0.35869565217391, 0.36363636363636
79371, 1.8521739130435, 0.38478260869565, 0.36363636363636
79372, 1.8521739130435, 0.35869565217391, 0.34090909090909
79373, 1.8304347826087, 0.35869565217391, 0.31818181818182
79374, 1.8521739130435, 0.38478260869565, 0.31818181818182
79375, 1.8521739130435, 0.35869565217391, 0.29545454545455
79376, 1.8304347826087, 0.35869565217391, 0.27272727272727
79377, 1.8521739130435, 0.38478260869565, 0.27272727272727
79378, 1.8521739130435, 0.35869565217391, 0.25
79379, 1.8304347826087, 0.35869565217391, 0.22727272727273
79380, 1.8521739130435, 0.38478260869565, 0.22727272727273
79381, 1.8521739130435, 0.35869565217391, 0.20454545454545
79382, 1.8304347826087, 0.35869565217391, 0.18181818181818
79383, 1.8521739130435, 0.38478260869565, 0.18181818181818
79384, 1.8521739130435, 0.35869565217391, 0.15909090909091
79385, 1.8304347826087, 0.35869565217391, 0.13636363636364
79386, 1.8521739130435, 0.38478260869565, 0.13636363636364
79387, 1.8521739130435, 0.35869565217391, 0.11363636363636
79388, 1.8304347826087, 0.35869565217391, 0.090909090909091
79389, 1.8521739130435, 0.38478260869565, 0.090909090909091
79390, 1.8521739130435, 0.35869565217391, 0.068181818181818
79391, 1.8304347826087, 0.35869565217391, 0.045454545454545
79392, 1.8521739130435, 0.38478260869565, 0.045454545454545
79393, 1.8521739130435, 0.35869565217391, 0.022727272727273
79394, 1.895652173913, 0.35869565217391, 0.47727272727273
79395, 1.8739130434783, 0.35869565217391, 0.45454545454545
79396, 1.895652173913, 0.38478260869565, 0.45454545454545
79397, 1.895652173913, 0.35869565217391, 0.43181818181818
79398, 1.8739130434783, 0.35869565217391, 0.40909090909091
79399, 1.895652173913, 0.38478260869565, 0.40909090909091
79400, 1.895652173913, 0.35869565217391, 0.38636363636364
79401, 1.8739130434783, 0.35869565217391, 0.36363636363636
79402, 1.895652173913, 0.38478260869565, 0.36363636363636
79403, 1.895652173913, 0.35869565217391, 0.34090909090909
79404, 1.8739130434783, 0.35869565217391, 0.31818181818182
79405, 1.895652173913, 0.38478260869565, 0.31818181818182
79406, 1.895652173913, 0.35869565217391, 0.29545454545455
79407, 1.8739130434783, 0.35869565217391, 0.27272727272727
79408, 1.895652173913, 0.38478260869565, 0.27272727272727
79409, 1.895652173913, 0.35869565217391, 0.25
79410, 1.8739130434783, 0.35869565217391, 0.22727272727273
79411, 1.895652173913, 0.38478260869565, 0.22727272727273
79412, 1.895652173913, 0.35869565217391, 0.20454545454545
79413, 1.8739130434783, 0.35869565217391, 0.18181818181818
79414, 1.895652173913, 0.38478260869565, 0.18181818181818
79415, 1.895652173913, 0.35869565217391, 0.15909090909091
79416, 1.8739130434783, 0.35869565217391, 0.13636363636364
79417, 1.895652173913, 0.38478260869565, 0.13636363636364
79418, 1.895652173913, 0.35869565217391, 0.11363636363636
79419, 1.8739130434783, 0.35869565217391, 0.090909090909091
79420, 1.895652173913, 0.38478260869565, 0.090909090909091
79421, 1.895652173913, 0.35869565217391, 0.068181818181818
79422, 1.8739130434783, 0.35869565217391, 0.045454545454545
79423, 1.895652173913, 0.38478260869565, 0.045454545454545
79424, 1.895652173913, 0.35869565217391, 0.022727272727273
79425, 1.9391304347826, 0.35869565217391, 0.47727272727273
79426, 1.9173913043478, 0.35869565217391, 0.45454545454545
79427, 1.9391304347826, 0.38478260869565, 0.45454545454545
79428, 1.9391304347826, 0.35869565217391, 0.43181818181818
79429, 1.9173913043478, 0.35869565217391, 0.40909090909091
79430, 1.9391304347826, 0.38478260869565, 0.40909090909091
79431, 1.9391304347826, 0.35869565217391, 0.38636363636364
79432, 1.9173913043478, 0.35869565217391, 0.36363636363636
79433, 1.9391304347826, 0.38478260869565, 0.36363636363636
79434, 1.9391304347826, 0.35869565217391, 0.34090909090909
79435, 1.9173913043478, 0.35869565217391, 0.31818181818182
79436, 1.9391304347826, 0.38478260869565, 0.31818181818182
79437, 1.9391304347826, 0.35869565217391, 0.29545454545455
79438, 1.9173913043478, 0.35869565217391, 0.27272727272727
79439, 1.9391304347826, 0.38478260869565, 0.27272727272727
79440, 1.9391304347826, 0.35869565217391, 0.25
79441, 1.9173913043478, 0.35869565217391, 0.22727272727273
79442, 1.9391304347826, 0.38478260869565, 0.22727272727273
79443, 1.9391304347826, 0.35869565217391, 0.20454545454545
79444, 1.9173913043478, 0.35869565217391, 0.18181818181818
79445, 1.9391304347826, 0.38478260869565, 0.18181818181818
79446, 1.9391304347826, 0.35869565217391, 0.15909090909091
79447, 1.9173913043478, 0.35869565217391, 0.13636363636364
79448, 1.9391304347826, 0.38478260869565, 0.13636363636364
79449, 1.9391304347826, 0.35869565217391, 0.11363636363636
79450, 1.9173913043478, 0.35869565217391, 0.090909090909091
79451, 1.9391304347826, 0.38478260869565, 0.090909090909091
79452, 1.9391304347826, 0.35869565217391, 0.068181818181818
79453, 1.9173913043478, 0.35869565217391, 0.045454545454545
79454, 1.9391304347826, 0.38478260869565, 0.045454545454545
79455, 1.9391304347826, 0.35869565217391, 0.022727272727273
79456, 1.9826086956522, 0.35869565217391, 0.47727272727273
79457, 1.9608695652174, 0.35869565217391, 0.45454545454545
79458, 1.9826086956522, 0.38478260869565, 0.45454545454545
79459, 1.9826086956522, 0.35869565217391, 0.43181818181818
79460, 1.9608695652174, 0.35869565217391, 0.40909090909091
79461, 1.9826086956522, 0.38478260869565, 0.40909090909091
79462, 1.9826086956522, 0.35869565217391, 0.38636363636364
79463, 1.9608695652174, 0.35869565217391, 0.36363636363636
79464, 1.9826086956522, 0.38478260869565, 0.36363636363636
79465, 1.9826086956522, 0.35869565217391, 0.34090909090909
79466, 1.9608695652174, 0.35869565217391, 0.31818181818182
79467, 1.9826086956522, 0.38478260869565, 0.31818181818182
79468, 1.9826086956522, 0.35869565217391, 0.29545454545455
79469, 1.9608695652174, 0.35869565217391, 0.27272727272727
79470, 1.9826086956522, 0.38478260869565, 0.27272727272727
79471, 1.9826086956522, 0.35869565217391, 0.25
79472, 1.9608695652174, 0.35869565217391, 0.22727272727273
79473, 1.9826086956522, 0.38478260869565, 0.22727272727273
79474, 1.9826086956522, 0.35869565217391, 0.20454545454545
79475, 1.9608695652174, 0.35869565217391, 0.18181818181818
79476, 1.9826086956522, 0.38478260869565, 0.18181818181818
79477, 1.9826086956522, 0.35869565217391, 0.15909090909091
79478, 1.9608695652174, 0.35869565217391, 0.13636363636364
79479, 1.9826086956522, 0.38478260869565, 0.13636363636364
79480, 1.9826086956522, 0.35869565217391, 0.11363636363636
79481, 1.9608695652174, 0.35869565217391, 0.090909090909091
79482, 1.9826086956522, 0.38478260869565, 0.090909090909091
79483, 1.9826086956522, 0.35869565217391, 0.068181818181818
79484, 1.9608695652174, 0.35869565217391, 0.045454545454545
79485, 1.9826086956522, 0.38478260869565, 0.045454545454545
79486, 1.9826086956522, 0.35869565217391, 0.022727272727273
79487, 2.0260869565217, 0.35869565217391, 0.47727272727273
79488, 2.004347826087, 0.35869565217391, 0.45454545454545
79489, 2.0260869565217, 0.38478260869565, 0.45454545454545
79490, 2.0260869565217, 0.35869565217391, 0.43181818181818
79491, 2.004347826087, 0.35869565217391, 0.40909090909091
79492, 2.0260869565217, 0.38478260869565, 0.40909090909091
79493, 2.0260869565217, 0.35869565217391, 0.38636363636364
79494, 2.004347826087, 0.35869565217391, 0.36363636363636
79495, 2.0260869565217, 0.38478260869565, 0.36363636363636
79496, 2.0260869565217, 0.35869565217391, 0.34090909090909
79497, 2.004347826087, 0.35869565217391, 0.31818181818182
79498, 2.0260869565217, 0.38478260869565, 0.31818181818182
79499, 2.0260869565217, 0.35869565217391, 0.29545454545455
79500, 2.004347826087, 0.35869565217391, 0.27272727272727
79501, 2.0260869565217, 0.38478260869565, 0.27272727272727
79502, 2.0260869565217, 0.35869565217391, 0.25
79503, 2.004347826087, 0.35869565217391, 0.22727272727273
79504, 2.0260869565217, 0.38478260869565, 0.22727272727273
79505, 2.0260869565217, 0.35869565217391, 0.20454545454545
79506, 2.004347826087, 0.35869565217391, 0.18181818181818
79507, 2.0260869565217, 0.38478260869565, 0.18181818181818
79508, 2.0260869565217, 0.35869565217391, 0.15909090909091
79509, 2.004347826087, 0.35869565217391, 0.13636363636364
79510, 2.0260869565217, 0.38478260869565, 0.13636363636364
79511, 2.0260869565217, 0.35869565217391, 0.11363636363636
79512, 2.004347826087, 0.35869565217391, 0.090909090909091
79513, 2.0260869565217, 0.38478260869565, 0.090909090909091
79514, 2.0260869565217, 0.35869565217391, 0.068181818181818
79515, 2.004347826087, 0.35869565217391, 0.045454545454545
79516, 2.0260869565217, 0.38478260869565, 0.045454545454545
79517, 2.0260869565217, 0.35869565217391, 0.022727272727273
79518, 2.0695652173913, 0.35869565217391, 0.47727272727273
79519, 2.0478260869565, 0.35869565217391, 0.45454545454545
79520, 2.0695652173913, 0.38478260869565, 0.45454545454545
79521, 2.0695652173913, 0.35869565217391, 0.43181818181818
79522, 2.0478260869565, 0.35869565217391, 0.40909090909091
79523, 2.0695652173913, 0.38478260869565, 0.40909090909091
79524, 2.0695652173913, 0.35869565217391, 0.38636363636364
79525, 2.0478260869565, 0.35869565217391, 0.36363636363636
79526, 2.0695652173913, 0.38478260869565, 0.36363636363636
79527, 2.0695652173913, 0.35869565217391, 0.34090909090909
79528, 2.0478260869565, 0.35869565217391, 0.31818181818182
79529, 2.0695652173913, 0.38478260869565, 0.31818181818182
79530, 2.0695652173913, 0.35869565217391, 0.29545454545455
79531, 2.0478260869565, 0.35869565217391, 0.27272727272727
79532, 2.0695652173913, 0.38478260869565, 0.27272727272727
79533, 2.0695652173913, 0.35869565217391, 0.25
79534, 2.0478260869565, 0.35869565217391, 0.22727272727273
79535, 2.0695652173913, 0.38478260869565, 0.22727272727273
79536, 2.0695652173913, 0.35869565217391, 0.20454545454545
79537, 2.0478260869565, 0.35869565217391, 0.18181818181818
79538, 2.0695652173913, 0.38478260869565, 0.18181818181818
79539, 2.0695652173913, 0.35869565217391, 0.15909090909091
79540, 2.0478260869565, 0.35869565217391, 0.13636363636364
79541, 2.0695652173913, 0.38478260869565, 0.13636363636364
79542, 2.0695652173913, 0.35869565217391, 0.11363636363636
79543, 2.0478260869565, 0.35869565217391, 0.090909090909091
79544, 2.0695652173913, 0.38478260869565, 0.090909090909091
79545, 2.0695652173913, 0.35869565217391, 0.068181818181818
79546, 2.0478260869565, 0.35869565217391, 0.045454545454545
79547, 2.0695652173913, 0.38478260869565, 0.045454545454545
79548, 2.0695652173913, 0.35869565217391, 0.022727272727273
79549, 2.1130434782609, 0.35869565217391, 0.47727272727273
79550, 2.0913043478261, 0.35869565217391, 0.45454545454545
79551, 2.1130434782609, 0.38478260869565, 0.45454545454545
79552, 2.1130434782609, 0.35869565217391, 0.43181818181818
79553, 2.0913043478261, 0.35869565217391, 0.40909090909091
79554, 2.1130434782609, 0.38478260869565, 0.40909090909091
79555, 2.1130434782609, 0.35869565217391, 0.38636363636364
79556, 2.0913043478261, 0.35869565217391, 0.36363636363636
79557, 2.1130434782609, 0.38478260869565, 0.36363636363636
79558, 2.1130434782609, 0.35869565217391, 0.34090909090909
79559, 2.0913043478261, 0.35869565217391, 0.31818181818182
79560, 2.1130434782609, 0.38478260869565, 0.31818181818182
79561, 2.1130434782609, 0.35869565217391, 0.29545454545455
79562, 2.0913043478261, 0.35869565217391, 0.27272727272727
79563, 2.1130434782609, 0.38478260869565, 0.27272727272727
79564, 2.1130434782609, 0.35869565217391, 0.25
79565, 2.0913043478261, 0.35869565217391, 0.22727272727273
79566, 2.1130434782609, 0.38478260869565, 0.22727272727273
79567, 2.1130434782609, 0.35869565217391, 0.20454545454545
79568, 2.0913043478261, 0.35869565217391, 0.18181818181818
79569, 2.1130434782609, 0.38478260869565, 0.18181818181818
79570, 2.1130434782609, 0.35869565217391, 0.15909090909091
79571, 2.0913043478261, 0.35869565217391, 0.13636363636364
79572, 2.1130434782609, 0.38478260869565, 0.13636363636364
79573, 2.1130434782609, 0.35869565217391, 0.11363636363636
79574, 2.0913043478261, 0.35869565217391, 0.090909090909091
79575, 2.1130434782609, 0.38478260869565, 0.090909090909091
79576, 2.1130434782609, 0.35869565217391, 0.068181818181818
79577, 2.0913043478261, 0.35869565217391, 0.045454545454545
79578, 2.1130434782609, 0.38478260869565, 0.045454545454545
79579, 2.1130434782609, 0.35869565217391, 0.022727272727273
79580, 2.1565217391304, 0.35869565217391, 0.47727272727273
79581, 2.1347826086957, 0.35869565217391, 0.45454545454545
79582, 2.1565217391304, 0.38478260869565, 0.45454545454545
79583, 2.1565217391304, 0.35869565217391, 0.43181818181818
79584, 2.1347826086957, 0.35869565217391, 0.40909090909091
79585, 2.1565217391304, 0.38478260869565, 0.40909090909091
79586, 2.1565217391304, 0.35869565217391, 0.38636363636364
79587, 2.1347826086957, 0.35869565217391, 0.36363636363636
79588, 2.1565217391304, 0.38478260869565, 0.36363636363636
79589, 2.1565217391304, 0.35869565217391, 0.34090909090909
79590, 2.1347826086957, 0.35869565217391, 0.31818181818182
79591, 2.1565217391304, 0.38478260869565, 0.31818181818182
79592, 2.1565217391304, 0.35869565217391, 0.29545454545455
79593, 2.1347826086957, 0.35869565217391, 0.27272727272727
79594, 2.1565217391304, 0.38478260869565, 0.27272727272727
79595, 2.1565217391304, 0.35869565217391, 0.25
79596, 2.1347826086957, 0.35869565217391, 0.22727272727273
79597, 2.1565217391304, 0.38478260869565, 0.22727272727273
79598, 2.1565217391304, 0.35869565217391, 0.20454545454545
79599, 2.1347826086957, 0.35869565217391, 0.18181818181818
79600, 2.1565217391304, 0.38478260869565, 0.18181818181818
79601, 2.1565217391304, 0.35869565217391, 0.15909090909091
79602, 2.1347826086957, 0.35869565217391, 0.13636363636364
79603, 2.1565217391304, 0.38478260869565, 0.13636363636364
79604, 2.1565217391304, 0.35869565217391, 0.11363636363636
79605, 2.1347826086957, 0.35869565217391, 0.090909090909091
79606, 2.1565217391304, 0.38478260869565, 0.090909090909091
79607, 2.1565217391304, 0.35869565217391, 0.068181818181818
79608, 2.1347826086957, 0.35869565217391, 0.045454545454545
79609, 2.1565217391304, 0.38478260869565, 0.045454545454545
79610, 2.1565217391304, 0.35869565217391, 0.022727272727273
79611, 2.1782608695652, 0.35869565217391, 0.45454545454545
79612, 2.1782608695652, 0.35869565217391, 0.40909090909091
79613, 2.1782608695652, 0.35869565217391, 0.36363636363636
79614, 2.1782608695652, 0.35869565217391, 0.31818181818182
79615, 2.1782608695652, 0.35869565217391, 0.27272727272727
79616, 2.1782608695652, 0.35869565217391, 0.22727272727273
79617, 2.1782608695652, 0.35869565217391, 0.18181818181818
79618, 2.1782608695652, 0.35869565217391, 0.13636363636364
79619, 2.1782608695652, 0.35869565217391, 0.090909090909091
79620, 2.1782608695652, 0.35869565217391, 0.045454545454545
