72743, 1.2869565217391, 0.85434782608696, 0.31818181818182
72744, 1.2869565217391, 0.82826086956522, 0.29545454545455
72745, 1.2652173913043, 0.82826086956522, 0.27272727272727
72746, 1.2869565217391, 0.85434782608696, 0.27272727272727
72747, 1.2869565217391, 0.82826086956522, 0.25
72748, 1.2652173913043, 0.82826086956522, 0.22727272727273
72749, 1.2869565217391, 0.85434782608696, 0.22727272727273
72750, 1.2869565217391, 0.82826086956522, 0.20454545454545
72751, 1.2652173913043, 0.82826086956522, 0.18181818181818
72752, 1.2869565217391, 0.85434782608696, 0.18181818181818
72753, 1.2869565217391, 0.82826086956522, 0.15909090909091
72754, 1.2652173913043, 0.82826086956522, 0.13636363636364
72755, 1.2869565217391, 0.85434782608696, 0.13636363636364
72756, 1.2869565217391, 0.82826086956522, 0.11363636363636
72757, 1.2652173913043, 0.82826086956522, 0.090909090909091
72758, 1.2869565217391, 0.85434782608696, 0.090909090909091
72759, 1.2869565217391, 0.82826086956522, 0.068181818181818
72760, 1.2652173913043, 0.82826086956522, 0.045454545454545
72761, 1.2869565217391, 0.85434782608696, 0.045454545454545
72762, 1.2869565217391, 0.82826086956522, 0.022727272727273
72763, 1.3304347826087, 0.82826086956522, 0.47727272727273
72764, 1.3086956521739, 0.82826086956522, 0.45454545454545
72765, 1.3304347826087, 0.85434782608696, 0.45454545454545
72766, 1.3304347826087, 0.82826086956522, 0.43181818181818
72767, 1.3086956521739, 0.82826086956522, 0.40909090909091
72768, 1.3304347826087, 0.85434782608696, 0.40909090909091
72769, 1.3304347826087, 0.82826086956522, 0.38636363636364
72770, 1.3086956521739, 0.82826086956522, 0.36363636363636
72771, 1.3304347826087, 0.85434782608696, 0.36363636363636
72772, 1.3304347826087, 0.82826086956522, 0.34090909090909
72773, 1.3086956521739, 0.82826086956522, 0.31818181818182
72774, 1.3304347826087, 0.85434782608696, 0.31818181818182
72775, 1.3304347826087, 0.82826086956522, 0.29545454545455
72776, 1.3086956521739, 0.82826086956522, 0.27272727272727
72777, 1.3304347826087, 0.85434782608696, 0.27272727272727
72778, 1.3304347826087, 0.82826086956522, 0.25
72779, 1.3086956521739, 0.82826086956522, 0.22727272727273
72780, 1.3304347826087, 0.85434782608696, 0.22727272727273
72781, 1.3304347826087, 0.82826086956522, 0.20454545454545
72782, 1.3086956521739, 0.82826086956522, 0.18181818181818
72783, 1.3304347826087, 0.85434782608696, 0.18181818181818
72784, 1.3304347826087, 0.82826086956522, 0.15909090909091
72785, 1.3086956521739, 0.82826086956522, 0.13636363636364
72786, 1.3304347826087, 0.85434782608696, 0.13636363636364
72787, 1.3304347826087, 0.82826086956522, 0.11363636363636
72788, 1.3086956521739, 0.82826086956522, 0.090909090909091
72789, 1.3304347826087, 0.85434782608696, 0.090909090909091
72790, 1.3304347826087, 0.82826086956522, 0.068181818181818
72791, 1.3086956521739, 0.82826086956522, 0.045454545454545
72792, 1.3304347826087, 0.85434782608696, 0.045454545454545
72793, 1.3304347826087, 0.82826086956522, 0.022727272727273
72794, 1.3739130434783, 0.82826086956522, 0.47727272727273
72795, 1.3521739130435, 0.82826086956522, 0.45454545454545
72796, 1.3739130434783, 0.85434782608696, 0.45454545454545
72797, 1.3739130434783, 0.82826086956522, 0.43181818181818
72798, 1.3521739130435, 0.82826086956522, 0.40909090909091
72799, 1.3739130434783, 0.85434782608696, 0.40909090909091
72800, 1.3739130434783, 0.82826086956522, 0.38636363636364
72801, 1.3521739130435, 0.82826086956522, 0.36363636363636
72802, 1.3739130434783, 0.85434782608696, 0.36363636363636
72803, 1.3739130434783, 0.82826086956522, 0.34090909090909
72804, 1.3521739130435, 0.82826086956522, 0.31818181818182
72805, 1.3739130434783, 0.85434782608696, 0.31818181818182
72806, 1.3739130434783, 0.82826086956522, 0.29545454545455
72807, 1.3521739130435, 0.82826086956522, 0.27272727272727
72808, 1.3739130434783, 0.85434782608696, 0.27272727272727
72809, 1.3739130434783, 0.82826086956522, 0.25
72810, 1.3521739130435, 0.82826086956522, 0.22727272727273
72811, 1.3739130434783, 0.85434782608696, 0.22727272727273
72812, 1.3739130434783, 0.82826086956522, 0.20454545454545
72813, 1.3521739130435, 0.82826086956522, 0.18181818181818
72814, 1.3739130434783, 0.85434782608696, 0.18181818181818
72815, 1.3739130434783, 0.82826086956522, 0.15909090909091
72816, 1.3521739130435, 0.82826086956522, 0.13636363636364
72817, 1.3739130434783, 0.85434782608696, 0.13636363636364
72818, 1.3739130434783, 0.82826086956522, 0.11363636363636
72819, 1.3521739130435, 0.82826086956522, 0.090909090909091
72820, 1.3739130434783, 0.85434782608696, 0.090909090909091
72821, 1.3739130434783, 0.82826086956522, 0.068181818181818
72822, 1.3521739130435, 0.82826086956522, 0.045454545454545
72823, 1.3739130434783, 0.85434782608696, 0.045454545454545
72824, 1.3739130434783, 0.82826086956522, 0.022727272727273
72825, 1.4173913043478, 0.82826086956522, 0.47727272727273
72826, 1.395652173913, 0.82826086956522, 0.45454545454545
72827, 1.4173913043478, 0.85434782608696, 0.45454545454545
72828, 1.4173913043478, 0.82826086956522, 0.43181818181818
72829, 1.395652173913, 0.82826086956522, 0.40909090909091
72830, 1.4173913043478, 0.85434782608696, 0.40909090909091
72831, 1.4173913043478, 0.82826086956522, 0.38636363636364
72832, 1.395652173913, 0.82826086956522, 0.36363636363636
72833, 1.4173913043478, 0.85434782608696, 0.36363636363636
72834, 1.4173913043478, 0.82826086956522, 0.34090909090909
72835, 1.395652173913, 0.82826086956522, 0.31818181818182
72836, 1.4173913043478, 0.85434782608696, 0.31818181818182
72837, 1.4173913043478, 0.82826086956522, 0.29545454545455
72838, 1.395652173913, 0.82826086956522, 0.27272727272727
72839, 1.4173913043478, 0.85434782608696, 0.27272727272727
72840, 1.4173913043478, 0.82826086956522, 0.25
72841, 1.395652173913, 0.82826086956522, 0.22727272727273
72842, 1.4173913043478, 0.85434782608696, 0.22727272727273
72843, 1.4173913043478, 0.82826086956522, 0.20454545454545
72844, 1.395652173913, 0.82826086956522, 0.18181818181818
72845, 1.4173913043478, 0.85434782608696, 0.18181818181818
72846, 1.4173913043478, 0.82826086956522, 0.15909090909091
72847, 1.395652173913, 0.82826086956522, 0.13636363636364
72848, 1.4173913043478, 0.85434782608696, 0.13636363636364
72849, 1.4173913043478, 0.82826086956522, 0.11363636363636
72850, 1.395652173913, 0.82826086956522, 0.090909090909091
72851, 1.4173913043478, 0.85434782608696, 0.090909090909091
72852, 1.4173913043478, 0.82826086956522, 0.068181818181818
72853, 1.395652173913, 0.82826086956522, 0.045454545454545
72854, 1.4173913043478, 0.85434782608696, 0.045454545454545
72855, 1.4173913043478, 0.82826086956522, 0.022727272727273
72856, 1.4608695652174, 0.82826086956522, 0.47727272727273
72857, 1.4391304347826, 0.82826086956522, 0.45454545454545
72858, 1.4608695652174, 0.85434782608696, 0.45454545454545
72859, 1.4608695652174, 0.82826086956522, 0.43181818181818
72860, 1.4391304347826, 0.82826086956522, 0.40909090909091
72861, 1.4608695652174, 0.85434782608696, 0.40909090909091
72862, 1.4608695652174, 0.82826086956522, 0.38636363636364
72863, 1.4391304347826, 0.82826086956522, 0.36363636363636
72864, 1.4608695652174, 0.85434782608696, 0.36363636363636
72865, 1.4608695652174, 0.82826086956522, 0.34090909090909
72866, 1.4391304347826, 0.82826086956522, 0.31818181818182
72867, 1.4608695652174, 0.85434782608696, 0.31818181818182
72868, 1.4608695652174, 0.82826086956522, 0.29545454545455
72869, 1.4391304347826, 0.82826086956522, 0.27272727272727
72870, 1.4608695652174, 0.85434782608696, 0.27272727272727
72871, 1.4608695652174, 0.82826086956522, 0.25
72872, 1.4391304347826, 0.82826086956522, 0.22727272727273
72873, 1.4608695652174, 0.85434782608696, 0.22727272727273
72874, 1.4608695652174, 0.82826086956522, 0.20454545454545
72875, 1.4391304347826, 0.82826086956522, 0.18181818181818
72876, 1.4608695652174, 0.85434782608696, 0.18181818181818
72877, 1.4608695652174, 0.82826086956522, 0.15909090909091
72878, 1.4391304347826, 0.82826086956522, 0.13636363636364
72879, 1.4608695652174, 0.85434782608696, 0.13636363636364
72880, 1.4608695652174, 0.82826086956522, 0.11363636363636
72881, 1.4391304347826, 0.82826086956522, 0.090909090909091
72882, 1.4608695652174, 0.85434782608696, 0.090909090909091
72883, 1.4608695652174, 0.82826086956522, 0.068181818181818
72884, 1.4391304347826, 0.82826086956522, 0.045454545454545
72885, 1.4608695652174, 0.85434782608696, 0.045454545454545
72886, 1.4608695652174, 0.82826086956522, 0.022727272727273
72887, 1.504347826087, 0.82826086956522, 0.47727272727273
72888, 1.4826086956522, 0.82826086956522, 0.45454545454545
72889, 1.504347826087, 0.85434782608696, 0.45454545454545
72890, 1.504347826087, 0.82826086956522, 0.43181818181818
72891, 1.4826086956522, 0.82826086956522, 0.40909090909091
72892, 1.504347826087, 0.85434782608696, 0.40909090909091
72893, 1.504347826087, 0.82826086956522, 0.38636363636364
72894, 1.4826086956522, 0.82826086956522, 0.36363636363636
72895, 1.504347826087, 0.85434782608696, 0.36363636363636
72896, 1.504347826087, 0.82826086956522, 0.34090909090909
72897, 1.4826086956522, 0.82826086956522, 0.31818181818182
72898, 1.504347826087, 0.85434782608696, 0.31818181818182
72899, 1.504347826087, 0.82826086956522, 0.29545454545455
72900, 1.4826086956522, 0.82826086956522, 0.27272727272727
72901, 1.504347826087, 0.85434782608696, 0.27272727272727
72902, 1.504347826087, 0.82826086956522, 0.25
72903, 1.4826086956522, 0.82826086956522, 0.22727272727273
72904, 1.504347826087, 0.85434782608696, 0.22727272727273
72905, 1.504347826087, 0.82826086956522, 0.20454545454545
72906, 1.4826086956522, 0.82826086956522, 0.18181818181818
72907, 1.504347826087, 0.85434782608696, 0.18181818181818
72908, 1.504347826087, 0.82826086956522, 0.15909090909091
72909, 1.4826086956522, 0.82826086956522, 0.13636363636364
72910, 1.504347826087, 0.85434782608696, 0.13636363636364
72911, 1.504347826087, 0.82826086956522, 0.11363636363636
72912, 1.4826086956522, 0.82826086956522, 0.090909090909091
72913, 1.504347826087, 0.85434782608696, 0.090909090909091
72914, 1.504347826087, 0.82826086956522, 0.068181818181818
72915, 1.4826086956522, 0.82826086956522, 0.045454545454545
72916, 1.504347826087, 0.85434782608696, 0.045454545454545
72917, 1.504347826087, 0.82826086956522, 0.022727272727273
72918, 1.5478260869565, 0.82826086956522, 0.47727272727273
72919, 1.5260869565217, 0.82826086956522, 0.45454545454545
72920, 1.5478260869565, 0.85434782608696, 0.45454545454545
72921, 1.5478260869565, 0.82826086956522, 0.43181818181818
72922, 1.5260869565217, 0.82826086956522, 0.40909090909091
72923, 1.5478260869565, 0.85434782608696, 0.40909090909091
72924, 1.5478260869565, 0.82826086956522, 0.38636363636364
72925, 1.5260869565217, 0.82826086956522, 0.36363636363636
72926, 1.5478260869565, 0.85434782608696, 0.36363636363636
72927, 1.5478260869565, 0.82826086956522, 0.34090909090909
72928, 1.5260869565217, 0.82826086956522, 0.31818181818182
72929, 1.5478260869565, 0.85434782608696, 0.31818181818182
72930, 1.5478260869565, 0.82826086956522, 0.29545454545455
72931, 1.5260869565217, 0.82826086956522, 0.27272727272727
72932, 1.5478260869565, 0.85434782608696, 0.27272727272727
72933, 1.5478260869565, 0.82826086956522, 0.25
72934, 1.5260869565217, 0.82826086956522, 0.22727272727273
72935, 1.5478260869565, 0.85434782608696, 0.22727272727273
72936, 1.5478260869565, 0.82826086956522, 0.20454545454545
72937, 1.5260869565217, 0.82826086956522, 0.18181818181818
72938, 1.5478260869565, 0.85434782608696, 0.18181818181818
72939, 1.5478260869565, 0.82826086956522, 0.15909090909091
72940, 1.5260869565217, 0.82826086956522, 0.13636363636364
72941, 1.5478260869565, 0.85434782608696, 0.13636363636364
72942, 1.5478260869565, 0.82826086956522, 0.11363636363636
72943, 1.5260869565217, 0.82826086956522, 0.090909090909091
72944, 1.5478260869565, 0.85434782608696, 0.090909090909091
72945, 1.5478260869565, 0.82826086956522, 0.068181818181818
72946, 1.5260869565217, 0.82826086956522, 0.045454545454545
72947, 1.5478260869565, 0.85434782608696, 0.045454545454545
72948, 1.5478260869565, 0.82826086956522, 0.022727272727273
72949, 1.5913043478261, 0.82826086956522, 0.47727272727273
72950, 1.5695652173913, 0.82826086956522, 0.45454545454545
72951, 1.5913043478261, 0.85434782608696, 0.45454545454545
72952, 1.5913043478261, 0.82826086956522, 0.43181818181818
72953, 1.5695652173913, 0.82826086956522, 0.40909090909091
72954, 1.5913043478261, 0.85434782608696, 0.40909090909091
72955, 1.5913043478261, 0.82826086956522, 0.38636363636364
72956, 1.5695652173913, 0.82826086956522, 0.36363636363636
72957, 1.5913043478261, 0.85434782608696, 0.36363636363636
72958, 1.5913043478261, 0.82826086956522, 0.34090909090909
72959, 1.5695652173913, 0.82826086956522, 0.31818181818182
72960, 1.5913043478261, 0.85434782608696, 0.31818181818182
72961, 1.5913043478261, 0.82826086956522, 0.29545454545455
72962, 1.5695652173913, 0.82826086956522, 0.27272727272727
72963, 1.5913043478261, 0.85434782608696, 0.27272727272727
72964, 1.5913043478261, 0.82826086956522, 0.25
72965, 1.5695652173913, 0.82826086956522, 0.22727272727273
72966, 1.5913043478261, 0.85434782608696, 0.22727272727273
72967, 1.5913043478261, 0.82826086956522, 0.20454545454545
72968, 1.5695652173913, 0.82826086956522, 0.18181818181818
72969, 1.5913043478261, 0.85434782608696, 0.18181818181818
72970, 1.5913043478261, 0.82826086956522, 0.15909090909091
72971, 1.5695652173913, 0.82826086956522, 0.13636363636364
72972, 1.5913043478261, 0.85434782608696, 0.13636363636364
72973, 1.5913043478261, 0.82826086956522, 0.11363636363636
72974, 1.5695652173913, 0.82826086956522, 0.090909090909091
72975, 1.5913043478261, 0.85434782608696, 0.090909090909091
72976, 1.5913043478261, 0.82826086956522, 0.068181818181818
72977, 1.5695652173913, 0.82826086956522, 0.045454545454545
72978, 1.5913043478261, 0.85434782608696, 0.045454545454545
72979, 1.5913043478261, 0.82826086956522, 0.022727272727273
72980, 1.6347826086957, 0.82826086956522, 0.47727272727273
72981, 1.6130434782609, 0.82826086956522, 0.45454545454545
72982, 1.6347826086957, 0.85434782608696, 0.45454545454545
72983, 1.6347826086957, 0.82826086956522, 0.43181818181818
72984, 1.6130434782609, 0.82826086956522, 0.40909090909091
72985, 1.6347826086957, 0.85434782608696, 0.40909090909091
72986, 1.6347826086957, 0.82826086956522, 0.38636363636364
72987, 1.6130434782609, 0.82826086956522, 0.36363636363636
72988, 1.6347826086957, 0.85434782608696, 0.36363636363636
72989, 1.6347826086957, 0.82826086956522, 0.34090909090909
72990, 1.6130434782609, 0.82826086956522, 0.31818181818182
72991, 1.6347826086957, 0.85434782608696, 0.31818181818182
72992, 1.6347826086957, 0.82826086956522, 0.29545454545455
72993, 1.6130434782609, 0.82826086956522, 0.27272727272727
72994, 1.6347826086957, 0.85434782608696, 0.27272727272727
72995, 1.6347826086957, 0.82826086956522, 0.25
72996, 1.6130434782609, 0.82826086956522, 0.22727272727273
72997, 1.6347826086957, 0.85434782608696, 0.22727272727273
72998, 1.6347826086957, 0.82826086956522, 0.20454545454545
72999, 1.6130434782609, 0.82826086956522, 0.18181818181818
73000, 1.6347826086957, 0.85434782608696, 0.18181818181818
73001, 1.6347826086957, 0.82826086956522, 0.15909090909091
73002, 1.6130434782609, 0.82826086956522, 0.13636363636364
73003, 1.6347826086957, 0.85434782608696, 0.13636363636364
73004, 1.6347826086957, 0.82826086956522, 0.11363636363636
73005, 1.6130434782609, 0.82826086956522, 0.090909090909091
73006, 1.6347826086957, 0.85434782608696, 0.090909090909091
73007, 1.6347826086957, 0.82826086956522, 0.068181818181818
73008, 1.6130434782609, 0.82826086956522, 0.045454545454545
73009, 1.6347826086957, 0.85434782608696, 0.045454545454545
73010, 1.6347826086957, 0.82826086956522, 0.022727272727273
73011, 1.6782608695652, 0.82826086956522, 0.47727272727273
73012, 1.6565217391304, 0.82826086956522, 0.45454545454545
73013, 1.6782608695652, 0.85434782608696, 0.45454545454545
73014, 1.6782608695652, 0.82826086956522, 0.43181818181818
73015, 1.6565217391304, 0.82826086956522, 0.40909090909091
73016, 1.6782608695652, 0.85434782608696, 0.40909090909091
73017, 1.6782608695652, 0.82826086956522, 0.38636363636364
73018, 1.6565217391304, 0.82826086956522, 0.36363636363636
73019, 1.6782608695652, 0.85434782608696, 0.36363636363636
73020, 1.6782608695652, 0.82826086956522, 0.34090909090909
73021, 1.6565217391304, 0.82826086956522, 0.31818181818182
73022, 1.6782608695652, 0.85434782608696, 0.31818181818182
73023, 1.6782608695652, 0.82826086956522, 0.29545454545455
73024, 1.6565217391304, 0.82826086956522, 0.27272727272727
73025, 1.6782608695652, 0.85434782608696, 0.27272727272727
73026, 1.6782608695652, 0.82826086956522, 0.25
73027, 1.6565217391304, 0.82826086956522, 0.22727272727273
73028, 1.6782608695652, 0.85434782608696, 0.22727272727273
73029, 1.6782608695652, 0.82826086956522, 0.20454545454545
73030, 1.6565217391304, 0.82826086956522, 0.18181818181818
73031, 1.6782608695652, 0.85434782608696, 0.18181818181818
73032, 1.6782608695652, 0.82826086956522, 0.15909090909091
73033, 1.6565217391304, 0.82826086956522, 0.13636363636364
73034, 1.6782608695652, 0.85434782608696, 0.13636363636364
73035, 1.6782608695652, 0.82826086956522, 0.11363636363636
73036, 1.6565217391304, 0.82826086956522, 0.090909090909091
73037, 1.6782608695652, 0.85434782608696, 0.090909090909091
73038, 1.6782608695652, 0.82826086956522, 0.068181818181818
73039, 1.6565217391304, 0.82826086956522, 0.045454545454545
73040, 1.6782608695652, 0.85434782608696, 0.045454545454545
73041, 1.6782608695652, 0.82826086956522, 0.022727272727273
73042, 1.7217391304348, 0.82826086956522, 0.47727272727273
73043, 1.7, 0.82826086956522, 0.45454545454545
73044, 1.7217391304348, 0.85434782608696, 0.45454545454545
73045, 1.7217391304348, 0.82826086956522, 0.43181818181818
73046, 1.7, 0.82826086956522, 0.40909090909091
73047, 1.7217391304348, 0.85434782608696, 0.40909090909091
73048, 1.7217391304348, 0.82826086956522, 0.38636363636364
73049, 1.7, 0.82826086956522, 0.36363636363636
73050, 1.7217391304348, 0.85434782608696, 0.36363636363636
73051, 1.7217391304348, 0.82826086956522, 0.34090909090909
73052, 1.7, 0.82826086956522, 0.31818181818182
73053, 1.7217391304348, 0.85434782608696, 0.31818181818182
73054, 1.7217391304348, 0.82826086956522, 0.29545454545455
73055, 1.7, 0.82826086956522, 0.27272727272727
73056, 1.7217391304348, 0.85434782608696, 0.27272727272727
73057, 1.7217391304348, 0.82826086956522, 0.25
73058, 1.7, 0.82826086956522, 0.22727272727273
73059, 1.7217391304348, 0.85434782608696, 0.22727272727273
73060, 1.7217391304348, 0.82826086956522, 0.20454545454545
73061, 1.7, 0.82826086956522, 0.18181818181818
73062, 1.7217391304348, 0.85434782608696, 0.18181818181818
73063, 1.7217391304348, 0.82826086956522, 0.15909090909091
73064, 1.7, 0.82826086956522, 0.13636363636364
73065, 1.7217391304348, 0.85434782608696, 0.13636363636364
73066, 1.7217391304348, 0.82826086956522, 0.11363636363636
73067, 1.7, 0.82826086956522, 0.090909090909091
73068, 1.7217391304348, 0.85434782608696, 0.090909090909091
73069, 1.7217391304348, 0.82826086956522, 0.068181818181818
73070, 1.7, 0.82826086956522, 0.045454545454545
73071, 1.7217391304348, 0.85434782608696, 0.045454545454545
73072, 1.7217391304348, 0.82826086956522, 0.022727272727273
73073, 1.7652173913043, 0.82826086956522, 0.47727272727273
73074, 1.7434782608696, 0.82826086956522, 0.45454545454545
73075, 1.7652173913043, 0.85434782608696, 0.45454545454545
73076, 1.7652173913043, 0.82826086956522, 0.43181818181818
73077, 1.7434782608696, 0.82826086956522, 0.40909090909091
73078, 1.7652173913043, 0.85434782608696, 0.40909090909091
73079, 1.7652173913043, 0.82826086956522, 0.38636363636364
73080, 1.7434782608696, 0.82826086956522, 0.36363636363636
73081, 1.7652173913043, 0.85434782608696, 0.36363636363636
73082, 1.7652173913043, 0.82826086956522, 0.34090909090909
73083, 1.7434782608696, 0.82826086956522, 0.31818181818182
73084, 1.7652173913043, 0.85434782608696, 0.31818181818182
73085, 1.7652173913043, 0.82826086956522, 0.29545454545455
73086, 1.7434782608696, 0.82826086956522, 0.27272727272727
73087, 1.7652173913043, 0.85434782608696, 0.27272727272727
73088, 1.7652173913043, 0.82826086956522, 0.25
73089, 1.7434782608696, 0.82826086956522, 0.22727272727273
73090, 1.7652173913043, 0.85434782608696, 0.22727272727273
73091, 1.7652173913043, 0.82826086956522, 0.20454545454545
73092, 1.7434782608696, 0.82826086956522, 0.18181818181818
73093, 1.7652173913043, 0.85434782608696, 0.18181818181818
73094, 1.7652173913043, 0.82826086956522, 0.15909090909091
73095, 1.7434782608696, 0.82826086956522, 0.13636363636364
73096, 1.7652173913043, 0.85434782608696, 0.13636363636364
73097, 1.7652173913043, 0.82826086956522, 0.11363636363636
73098, 1.7434782608696, 0.82826086956522, 0.090909090909091
73099, 1.7652173913043, 0.85434782608696, 0.090909090909091
73100, 1.7652173913043, 0.82826086956522, 0.068181818181818
73101, 1.7434782608696, 0.82826086956522, 0.045454545454545
73102, 1.7652173913043, 0.85434782608696, 0.045454545454545
73103, 1.7652173913043, 0.82826086956522, 0.022727272727273
73104, 1.8086956521739, 0.82826086956522, 0.47727272727273
73105, 1.7869565217391, 0.82826086956522, 0.45454545454545
73106, 1.8086956521739, 0.85434782608696, 0.45454545454545
73107, 1.8086956521739, 0.82826086956522, 0.43181818181818
73108, 1.7869565217391, 0.82826086956522, 0.40909090909091
73109, 1.8086956521739, 0.85434782608696, 0.40909090909091
73110, 1.8086956521739, 0.82826086956522, 0.38636363636364
73111, 1.7869565217391, 0.82826086956522, 0.36363636363636
73112, 1.8086956521739, 0.85434782608696, 0.36363636363636
73113, 1.8086956521739, 0.82826086956522, 0.34090909090909
73114, 1.7869565217391, 0.82826086956522, 0.31818181818182
73115, 1.8086956521739, 0.85434782608696, 0.31818181818182
73116, 1.8086956521739, 0.82826086956522, 0.29545454545455
73117, 1.7869565217391, 0.82826086956522, 0.27272727272727
73118, 1.8086956521739, 0.85434782608696, 0.27272727272727
73119, 1.8086956521739, 0.82826086956522, 0.25
73120, 1.7869565217391, 0.82826086956522, 0.22727272727273
73121, 1.8086956521739, 0.85434782608696, 0.22727272727273
73122, 1.8086956521739, 0.82826086956522, 0.20454545454545
73123, 1.7869565217391, 0.82826086956522, 0.18181818181818
73124, 1.8086956521739, 0.85434782608696, 0.18181818181818
73125, 1.8086956521739, 0.82826086956522, 0.15909090909091
73126, 1.7869565217391, 0.82826086956522, 0.13636363636364
73127, 1.8086956521739, 0.85434782608696, 0.13636363636364
73128, 1.8086956521739, 0.82826086956522, 0.11363636363636
73129, 1.7869565217391, 0.82826086956522, 0.090909090909091
73130, 1.8086956521739, 0.85434782608696, 0.090909090909091
73131, 1.8086956521739, 0.82826086956522, 0.068181818181818
73132, 1.7869565217391, 0.82826086956522, 0.045454545454545
73133, 1.8086956521739, 0.85434782608696, 0.045454545454545
73134, 1.8086956521739, 0.82826086956522, 0.022727272727273
73135, 1.8521739130435, 0.82826086956522, 0.47727272727273
73136, 1.8304347826087, 0.82826086956522, 0.45454545454545
73137, 1.8521739130435, 0.85434782608696, 0.45454545454545
73138, 1.8521739130435, 0.82826086956522, 0.43181818181818
73139, 1.8304347826087, 0.82826086956522, 0.40909090909091
73140, 1.8521739130435, 0.85434782608696, 0.40909090909091
73141, 1.8521739130435, 0.82826086956522, 0.38636363636364
73142, 1.8304347826087, 0.82826086956522, 0.36363636363636
73143, 1.8521739130435, 0.85434782608696, 0.36363636363636
73144, 1.8521739130435, 0.82826086956522, 0.34090909090909
73145, 1.8304347826087, 0.82826086956522, 0.31818181818182
73146, 1.8521739130435, 0.85434782608696, 0.31818181818182
73147, 1.8521739130435, 0.82826086956522, 0.29545454545455
73148, 1.8304347826087, 0.82826086956522, 0.27272727272727
73149, 1.8521739130435, 0.85434782608696, 0.27272727272727
73150, 1.8521739130435, 0.82826086956522, 0.25
73151, 1.8304347826087, 0.82826086956522, 0.22727272727273
73152, 1.8521739130435, 0.85434782608696, 0.22727272727273
73153, 1.8521739130435, 0.82826086956522, 0.20454545454545
73154, 1.8304347826087, 0.82826086956522, 0.18181818181818
73155, 1.8521739130435, 0.85434782608696, 0.18181818181818
73156, 1.8521739130435, 0.82826086956522, 0.15909090909091
73157, 1.8304347826087, 0.82826086956522, 0.13636363636364
73158, 1.8521739130435, 0.85434782608696, 0.13636363636364
73159, 1.8521739130435, 0.82826086956522, 0.11363636363636
73160, 1.8304347826087, 0.82826086956522, 0.090909090909091
73161, 1.8521739130435, 0.85434782608696, 0.090909090909091
73162, 1.8521739130435, 0.82826086956522, 0.068181818181818
73163, 1.8304347826087, 0.82826086956522, 0.045454545454545
73164, 1.8521739130435, 0.85434782608696, 0.045454545454545
73165, 1.8521739130435, 0.82826086956522, 0.022727272727273
73166, 1.895652173913, 0.82826086956522, 0.47727272727273
73167, 1.8739130434783, 0.82826086956522, 0.45454545454545
73168, 1.895652173913, 0.85434782608696, 0.45454545454545
73169, 1.895652173913, 0.82826086956522, 0.43181818181818
73170, 1.8739130434783, 0.82826086956522, 0.40909090909091
73171, 1.895652173913, 0.85434782608696, 0.40909090909091
73172, 1.895652173913, 0.82826086956522, 0.38636363636364
73173, 1.8739130434783, 0.82826086956522, 0.36363636363636
73174, 1.895652173913, 0.85434782608696, 0.36363636363636
73175, 1.895652173913, 0.82826086956522, 0.34090909090909
73176, 1.8739130434783, 0.82826086956522, 0.31818181818182
73177, 1.895652173913, 0.85434782608696, 0.31818181818182
73178, 1.895652173913, 0.82826086956522, 0.29545454545455
73179, 1.8739130434783, 0.82826086956522, 0.27272727272727
73180, 1.895652173913, 0.85434782608696, 0.27272727272727
73181, 1.895652173913, 0.82826086956522, 0.25
73182, 1.8739130434783, 0.82826086956522, 0.22727272727273
73183, 1.895652173913, 0.85434782608696, 0.22727272727273
73184, 1.895652173913, 0.82826086956522, 0.20454545454545
73185, 1.8739130434783, 0.82826086956522, 0.18181818181818
73186, 1.895652173913, 0.85434782608696, 0.18181818181818
73187, 1.895652173913, 0.82826086956522, 0.15909090909091
73188, 1.8739130434783, 0.82826086956522, 0.13636363636364
73189, 1.895652173913, 0.85434782608696, 0.13636363636364
73190, 1.895652173913, 0.82826086956522, 0.11363636363636
73191, 1.8739130434783, 0.82826086956522, 0.090909090909091
73192, 1.895652173913, 0.85434782608696, 0.090909090909091
73193, 1.895652173913, 0.82826086956522, 0.068181818181818
73194, 1.8739130434783, 0.82826086956522, 0.045454545454545
73195, 1.895652173913, 0.85434782608696, 0.045454545454545
73196, 1.895652173913, 0.82826086956522, 0.022727272727273
73197, 1.9391304347826, 0.82826086956522, 0.47727272727273
73198, 1.9173913043478, 0.82826086956522, 0.45454545454545
73199, 1.9391304347826, 0.85434782608696, 0.45454545454545
73200, 1.9391304347826, 0.82826086956522, 0.43181818181818
73201, 1.9173913043478, 0.82826086956522, 0.40909090909091
73202, 1.9391304347826, 0.85434782608696, 0.40909090909091
73203, 1.9391304347826, 0.82826086956522, 0.38636363636364
73204, 1.9173913043478, 0.82826086956522, 0.36363636363636
73205, 1.9391304347826, 0.85434782608696, 0.36363636363636
73206, 1.9391304347826, 0.82826086956522, 0.34090909090909
73207, 1.9173913043478, 0.82826086956522, 0.31818181818182
73208, 1.9391304347826, 0.85434782608696, 0.31818181818182
73209, 1.9391304347826, 0.82826086956522, 0.29545454545455
73210, 1.9173913043478, 0.82826086956522, 0.27272727272727
73211, 1.9391304347826, 0.85434782608696, 0.27272727272727
73212, 1.9391304347826, 0.82826086956522, 0.25
73213, 1.9173913043478, 0.82826086956522, 0.22727272727273
73214, 1.9391304347826, 0.85434782608696, 0.22727272727273
73215, 1.9391304347826, 0.82826086956522, 0.20454545454545
73216, 1.9173913043478, 0.82826086956522, 0.18181818181818
73217, 1.9391304347826, 0.85434782608696, 0.18181818181818
73218, 1.9391304347826, 0.82826086956522, 0.15909090909091
73219, 1.9173913043478, 0.82826086956522, 0.13636363636364
73220, 1.9391304347826, 0.85434782608696, 0.13636363636364
73221, 1.9391304347826, 0.82826086956522, 0.11363636363636
73222, 1.9173913043478, 0.82826086956522, 0.090909090909091
73223, 1.9391304347826, 0.85434782608696, 0.090909090909091
73224, 1.9391304347826, 0.82826086956522, 0.068181818181818
73225, 1.9173913043478, 0.82826086956522, 0.045454545454545
73226, 1.9391304347826, 0.85434782608696, 0.045454545454545
73227, 1.9391304347826, 0.82826086956522, 0.022727272727273
73228, 1.9826086956522, 0.82826086956522, 0.47727272727273
73229, 1.9608695652174, 0.82826086956522, 0.45454545454545
73230, 1.9826086956522, 0.85434782608696, 0.45454545454545
73231, 1.9826086956522, 0.82826086956522, 0.43181818181818
73232, 1.9608695652174, 0.82826086956522, 0.40909090909091
73233, 1.9826086956522, 0.85434782608696, 0.40909090909091
73234, 1.9826086956522, 0.82826086956522, 0.38636363636364
73235, 1.9608695652174, 0.82826086956522, 0.36363636363636
73236, 1.9826086956522, 0.85434782608696, 0.36363636363636
73237, 1.9826086956522, 0.82826086956522, 0.34090909090909
73238, 1.9608695652174, 0.82826086956522, 0.31818181818182
73239, 1.9826086956522, 0.85434782608696, 0.31818181818182
73240, 1.9826086956522, 0.82826086956522, 0.29545454545455
73241, 1.9608695652174, 0.82826086956522, 0.27272727272727
73242, 1.9826086956522, 0.85434782608696, 0.27272727272727
73243, 1.9826086956522, 0.82826086956522, 0.25
73244, 1.9608695652174, 0.82826086956522, 0.22727272727273
73245, 1.9826086956522, 0.85434782608696, 0.22727272727273
73246, 1.9826086956522, 0.82826086956522, 0.20454545454545
73247, 1.9608695652174, 0.82826086956522, 0.18181818181818
73248, 1.9826086956522, 0.85434782608696, 0.18181818181818
73249, 1.9826086956522, 0.82826086956522, 0.15909090909091
73250, 1.9608695652174, 0.82826086956522, 0.13636363636364
73251, 1.9826086956522, 0.85434782608696, 0.13636363636364
73252, 1.9826086956522, 0.82826086956522, 0.11363636363636
73253, 1.9608695652174, 0.82826086956522, 0.090909090909091
73254, 1.9826086956522, 0.85434782608696, 0.090909090909091
73255, 1.9826086956522, 0.82826086956522, 0.068181818181818
73256, 1.9608695652174, 0.82826086956522, 0.045454545454545
73257, 1.9826086956522, 0.85434782608696, 0.045454545454545
73258, 1.9826086956522, 0.82826086956522, 0.022727272727273
73259, 2.0260869565217, 0.82826086956522, 0.47727272727273
73260, 2.004347826087, 0.82826086956522, 0.45454545454545
73261, 2.0260869565217, 0.85434782608696, 0.45454545454545
73262, 2.0260869565217, 0.82826086956522, 0.43181818181818
73263, 2.004347826087, 0.82826086956522, 0.40909090909091
73264, 2.0260869565217, 0.85434782608696, 0.40909090909091
73265, 2.0260869565217, 0.82826086956522, 0.38636363636364
73266, 2.004347826087, 0.82826086956522, 0.36363636363636
73267, 2.0260869565217, 0.85434782608696, 0.36363636363636
73268, 2.0260869565217, 0.82826086956522, 0.34090909090909
73269, 2.004347826087, 0.82826086956522, 0.31818181818182
73270, 2.0260869565217, 0.85434782608696, 0.31818181818182
73271, 2.0260869565217, 0.82826086956522, 0.29545454545455
73272, 2.004347826087, 0.82826086956522, 0.27272727272727
73273, 2.0260869565217, 0.85434782608696, 0.27272727272727
73274, 2.0260869565217, 0.82826086956522, 0.25
73275, 2.004347826087, 0.82826086956522, 0.22727272727273
73276, 2.0260869565217, 0.85434782608696, 0.22727272727273
73277, 2.0260869565217, 0.82826086956522, 0.20454545454545
73278, 2.004347826087, 0.82826086956522, 0.18181818181818
73279, 2.0260869565217, 0.85434782608696, 0.18181818181818
73280, 2.0260869565217, 0.82826086956522, 0.15909090909091
73281, 2.004347826087, 0.82826086956522, 0.13636363636364
73282, 2.0260869565217, 0.85434782608696, 0.13636363636364
73283, 2.0260869565217, 0.82826086956522, 0.11363636363636
73284, 2.004347826087, 0.82826086956522, 0.090909090909091
73285, 2.0260869565217, 0.85434782608696, 0.090909090909091
73286, 2.0260869565217, 0.82826086956522, 0.068181818181818
73287, 2.004347826087, 0.82826086956522, 0.045454545454545
73288, 2.0260869565217, 0.85434782608696, 0.045454545454545
73289, 2.0260869565217, 0.82826086956522, 0.022727272727273
73290, 2.0695652173913, 0.82826086956522, 0.47727272727273
73291, 2.0478260869565, 0.82826086956522, 0.45454545454545
73292, 2.0695652173913, 0.85434782608696, 0.45454545454545
73293, 2.0695652173913, 0.82826086956522, 0.43181818181818
73294, 2.0478260869565, 0.82826086956522, 0.40909090909091
73295, 2.0695652173913, 0.85434782608696, 0.40909090909091
73296, 2.0695652173913, 0.82826086956522, 0.38636363636364
73297, 2.0478260869565, 0.82826086956522, 0.36363636363636
73298, 2.0695652173913, 0.85434782608696, 0.36363636363636
73299, 2.0695652173913, 0.82826086956522, 0.34090909090909
73300, 2.0478260869565, 0.82826086956522, 0.31818181818182
73301, 2.0695652173913, 0.85434782608696, 0.31818181818182
73302, 2.0695652173913, 0.82826086956522, 0.29545454545455
73303, 2.0478260869565, 0.82826086956522, 0.27272727272727
73304, 2.0695652173913, 0.85434782608696, 0.27272727272727
73305, 2.0695652173913, 0.82826086956522, 0.25
73306, 2.0478260869565, 0.82826086956522, 0.22727272727273
73307, 2.0695652173913, 0.85434782608696, 0.22727272727273
73308, 2.0695652173913, 0.82826086956522, 0.20454545454545
73309, 2.0478260869565, 0.82826086956522, 0.18181818181818
73310, 2.0695652173913, 0.85434782608696, 0.18181818181818
73311, 2.0695652173913, 0.82826086956522, 0.15909090909091
73312, 2.0478260869565, 0.82826086956522, 0.13636363636364
73313, 2.0695652173913, 0.85434782608696, 0.13636363636364
73314, 2.0695652173913, 0.82826086956522, 0.11363636363636
73315, 2.0478260869565, 0.82826086956522, 0.090909090909091
73316, 2.0695652173913, 0.85434782608696, 0.090909090909091
73317, 2.0695652173913, 0.82826086956522, 0.068181818181818
73318, 2.0478260869565, 0.82826086956522, 0.045454545454545
73319, 2.0695652173913, 0.85434782608696, 0.045454545454545
73320, 2.0695652173913, 0.82826086956522, 0.022727272727273
73321, 2.1130434782609, 0.82826086956522, 0.47727272727273
73322, 2.0913043478261, 0.82826086956522, 0.45454545454545
73323, 2.1130434782609, 0.85434782608696, 0.45454545454545
73324, 2.1130434782609, 0.82826086956522, 0.43181818181818
73325, 2.0913043478261, 0.82826086956522, 0.40909090909091
73326, 2.1130434782609, 0.85434782608696, 0.40909090909091
73327, 2.1130434782609, 0.82826086956522, 0.38636363636364
73328, 2.0913043478261, 0.82826086956522, 0.36363636363636
73329, 2.1130434782609, 0.85434782608696, 0.36363636363636
73330, 2.1130434782609, 0.82826086956522, 0.34090909090909
73331, 2.0913043478261, 0.82826086956522, 0.31818181818182
73332, 2.1130434782609, 0.85434782608696, 0.31818181818182
73333, 2.1130434782609, 0.82826086956522, 0.29545454545455
73334, 2.0913043478261, 0.82826086956522, 0.27272727272727
73335, 2.1130434782609, 0.85434782608696, 0.27272727272727
73336, 2.1130434782609, 0.82826086956522, 0.25
73337, 2.0913043478261, 0.82826086956522, 0.22727272727273
73338, 2.1130434782609, 0.85434782608696, 0.22727272727273
73339, 2.1130434782609, 0.82826086956522, 0.20454545454545
73340, 2.0913043478261, 0.82826086956522, 0.18181818181818
73341, 2.1130434782609, 0.85434782608696, 0.18181818181818
73342, 2.1130434782609, 0.82826086956522, 0.15909090909091
73343, 2.0913043478261, 0.82826086956522, 0.13636363636364
73344, 2.1130434782609, 0.85434782608696, 0.13636363636364
73345, 2.1130434782609, 0.82826086956522, 0.11363636363636
73346, 2.0913043478261, 0.82826086956522, 0.090909090909091
73347, 2.1130434782609, 0.85434782608696, 0.090909090909091
73348, 2.1130434782609, 0.82826086956522, 0.068181818181818
73349, 2.0913043478261, 0.82826086956522, 0.045454545454545
73350, 2.1130434782609, 0.85434782608696, 0.045454545454545
73351, 2.1130434782609, 0.82826086956522, 0.022727272727273
73352, 2.1565217391304, 0.82826086956522, 0.47727272727273
73353, 2.1347826086957, 0.82826086956522, 0.45454545454545
73354, 2.1565217391304, 0.85434782608696, 0.45454545454545
73355, 2.1565217391304, 0.82826086956522, 0.43181818181818
73356, 2.1347826086957, 0.82826086956522, 0.40909090909091
73357, 2.1565217391304, 0.85434782608696, 0.40909090909091
73358, 2.1565217391304, 0.82826086956522, 0.38636363636364
73359, 2.1347826086957, 0.82826086956522, 0.36363636363636
73360, 2.1565217391304, 0.85434782608696, 0.36363636363636
73361, 2.1565217391304, 0.82826086956522, 0.34090909090909
73362, 2.1347826086957, 0.82826086956522, 0.31818181818182
73363, 2.1565217391304, 0.85434782608696, 0.31818181818182
73364, 2.1565217391304, 0.82826086956522, 0.29545454545455
73365, 2.1347826086957, 0.82826086956522, 0.27272727272727
73366, 2.1565217391304, 0.85434782608696, 0.27272727272727
73367, 2.1565217391304, 0.82826086956522, 0.25
73368, 2.1347826086957, 0.82826086956522, 0.22727272727273
73369, 2.1565217391304, 0.85434782608696, 0.22727272727273
73370, 2.1565217391304, 0.82826086956522, 0.20454545454545
73371, 2.1347826086957, 0.82826086956522, 0.18181818181818
73372, 2.1565217391304, 0.85434782608696, 0.18181818181818
73373, 2.1565217391304, 0.82826086956522, 0.15909090909091
73374, 2.1347826086957, 0.82826086956522, 0.13636363636364
73375, 2.1565217391304, 0.85434782608696, 0.13636363636364
73376, 2.1565217391304, 0.82826086956522, 0.11363636363636
73377, 2.1347826086957, 0.82826086956522, 0.090909090909091
73378, 2.1565217391304, 0.85434782608696, 0.090909090909091
73379, 2.1565217391304, 0.82826086956522, 0.068181818181818
73380, 2.1347826086957, 0.82826086956522, 0.045454545454545
73381, 2.1565217391304, 0.85434782608696, 0.045454545454545
73382, 2.1565217391304, 0.82826086956522, 0.022727272727273
73383, 2.1782608695652, 0.82826086956522, 0.45454545454545
73384, 2.1782608695652, 0.82826086956522, 0.40909090909091
73385, 2.1782608695652, 0.82826086956522, 0.36363636363636
73386, 2.1782608695652, 0.82826086956522, 0.31818181818182
73387, 2.1782608695652, 0.82826086956522, 0.27272727272727
73388, 2.1782608695652, 0.82826086956522, 0.22727272727273
73389, 2.1782608695652, 0.82826086956522, 0.18181818181818
73390, 2.1782608695652, 0.82826086956522, 0.13636363636364
73391, 2.1782608695652, 0.82826086956522, 0.090909090909091
73392, 2.1782608695652, 0.82826086956522, 0.045454545454545
73393, 1.2434782608696, 0.77608695652174, 0.47727272727273
73394, 1.2217391304348, 0.77608695652174, 0.45454545454545
73395, 1.2434782608696, 0.80217391304348, 0.45454545454545
73396, 1.2434782608696, 0.77608695652174, 0.43181818181818
73397, 1.2217391304348, 0.77608695652174, 0.40909090909091
73398, 1.2434782608696, 0.80217391304348, 0.40909090909091
73399, 1.2434782608696, 0.77608695652174, 0.38636363636364
73400, 1.2217391304348, 0.77608695652174, 0.36363636363636
73401, 1.2434782608696, 0.80217391304348, 0.36363636363636
73402, 1.2434782608696, 0.77608695652174, 0.34090909090909
73403, 1.2217391304348, 0.77608695652174, 0.31818181818182
73404, 1.2434782608696, 0.80217391304348, 0.31818181818182
73405, 1.2434782608696, 0.77608695652174, 0.29545454545455
73406, 1.2217391304348, 0.77608695652174, 0.27272727272727
73407, 1.2434782608696, 0.80217391304348, 0.27272727272727
73408, 1.2434782608696, 0.77608695652174, 0.25
73409, 1.2217391304348, 0.77608695652174, 0.22727272727273
73410, 1.2434782608696, 0.80217391304348, 0.22727272727273
73411, 1.2434782608696, 0.77608695652174, 0.20454545454545
73412, 1.2217391304348, 0.77608695652174, 0.18181818181818
73413, 1.2434782608696, 0.80217391304348, 0.18181818181818
73414, 1.2434782608696, 0.77608695652174, 0.15909090909091
73415, 1.2217391304348, 0.77608695652174, 0.13636363636364
73416, 1.2434782608696, 0.80217391304348, 0.13636363636364
73417, 1.2434782608696, 0.77608695652174, 0.11363636363636
73418, 1.2217391304348, 0.77608695652174, 0.090909090909091
73419, 1.2434782608696, 0.80217391304348, 0.090909090909091
73420, 1.2434782608696, 0.77608695652174, 0.068181818181818
73421, 1.2217391304348, 0.77608695652174, 0.045454545454545
73422, 1.2434782608696, 0.80217391304348, 0.045454545454545
73423, 1.2434782608696, 0.77608695652174, 0.022727272727273
73424, 1.2869565217391, 0.77608695652174, 0.47727272727273
73425, 1.2652173913043, 0.77608695652174, 0.45454545454545
73426, 1.2869565217391, 0.80217391304348, 0.45454545454545
73427, 1.2869565217391, 0.77608695652174, 0.43181818181818
73428, 1.2652173913043, 0.77608695652174, 0.40909090909091
73429, 1.2869565217391, 0.80217391304348, 0.40909090909091
73430, 1.2869565217391, 0.77608695652174, 0.38636363636364
73431, 1.2652173913043, 0.77608695652174, 0.36363636363636
73432, 1.2869565217391, 0.80217391304348, 0.36363636363636
73433, 1.2869565217391, 0.77608695652174, 0.34090909090909
73434, 1.2652173913043, 0.77608695652174, 0.31818181818182
73435, 1.2869565217391, 0.80217391304348, 0.31818181818182
73436, 1.2869565217391, 0.77608695652174, 0.29545454545455
73437, 1.2652173913043, 0.77608695652174, 0.27272727272727
73438, 1.2869565217391, 0.80217391304348, 0.27272727272727
73439, 1.2869565217391, 0.77608695652174, 0.25
73440, 1.2652173913043, 0.77608695652174, 0.22727272727273
73441, 1.2869565217391, 0.80217391304348, 0.22727272727273
73442, 1.2869565217391, 0.77608695652174, 0.20454545454545
73443, 1.2652173913043, 0.77608695652174, 0.18181818181818
73444, 1.2869565217391, 0.80217391304348, 0.18181818181818
73445, 1.2869565217391, 0.77608695652174, 0.15909090909091
73446, 1.2652173913043, 0.77608695652174, 0.13636363636364
73447, 1.2869565217391, 0.80217391304348, 0.13636363636364
73448, 1.2869565217391, 0.77608695652174, 0.11363636363636
73449, 1.2652173913043, 0.77608695652174, 0.090909090909091
73450, 1.2869565217391, 0.80217391304348, 0.090909090909091
73451, 1.2869565217391, 0.77608695652174, 0.068181818181818
73452, 1.2652173913043, 0.77608695652174, 0.045454545454545
73453, 1.2869565217391, 0.80217391304348, 0.045454545454545
73454, 1.2869565217391, 0.77608695652174, 0.022727272727273
73455, 1.3304347826087, 0.77608695652174, 0.47727272727273
73456, 1.3086956521739, 0.77608695652174, 0.45454545454545
73457, 1.3304347826087, 0.80217391304348, 0.45454545454545
73458, 1.3304347826087, 0.77608695652174, 0.43181818181818
73459, 1.3086956521739, 0.77608695652174, 0.40909090909091
73460, 1.3304347826087, 0.80217391304348, 0.40909090909091
73461, 1.3304347826087, 0.77608695652174, 0.38636363636364
73462, 1.3086956521739, 0.77608695652174, 0.36363636363636
73463, 1.3304347826087, 0.80217391304348, 0.36363636363636
73464, 1.3304347826087, 0.77608695652174, 0.34090909090909
73465, 1.3086956521739, 0.77608695652174, 0.31818181818182
73466, 1.3304347826087, 0.80217391304348, 0.31818181818182
73467, 1.3304347826087, 0.77608695652174, 0.29545454545455
73468, 1.3086956521739, 0.77608695652174, 0.27272727272727
73469, 1.3304347826087, 0.80217391304348, 0.27272727272727
73470, 1.3304347826087, 0.77608695652174, 0.25
73471, 1.3086956521739, 0.77608695652174, 0.22727272727273
73472, 1.3304347826087, 0.80217391304348, 0.22727272727273
73473, 1.3304347826087, 0.77608695652174, 0.20454545454545
73474, 1.3086956521739, 0.77608695652174, 0.18181818181818
73475, 1.3304347826087, 0.80217391304348, 0.18181818181818
73476, 1.3304347826087, 0.77608695652174, 0.15909090909091
73477, 1.3086956521739, 0.77608695652174, 0.13636363636364
73478, 1.3304347826087, 0.80217391304348, 0.13636363636364
73479, 1.3304347826087, 0.77608695652174, 0.11363636363636
73480, 1.3086956521739, 0.77608695652174, 0.090909090909091
73481, 1.3304347826087, 0.80217391304348, 0.090909090909091
73482, 1.3304347826087, 0.77608695652174, 0.068181818181818
73483, 1.3086956521739, 0.77608695652174, 0.045454545454545
73484, 1.3304347826087, 0.80217391304348, 0.045454545454545
73485, 1.3304347826087, 0.77608695652174, 0.022727272727273
73486, 1.3739130434783, 0.77608695652174, 0.47727272727273
73487, 1.3521739130435, 0.77608695652174, 0.45454545454545
73488, 1.3739130434783, 0.80217391304348, 0.45454545454545
73489, 1.3739130434783, 0.77608695652174, 0.43181818181818
73490, 1.3521739130435, 0.77608695652174, 0.40909090909091
73491, 1.3739130434783, 0.80217391304348, 0.40909090909091
73492, 1.3739130434783, 0.77608695652174, 0.38636363636364
73493, 1.3521739130435, 0.77608695652174, 0.36363636363636
73494, 1.3739130434783, 0.80217391304348, 0.36363636363636
73495, 1.3739130434783, 0.77608695652174, 0.34090909090909
73496, 1.3521739130435, 0.77608695652174, 0.31818181818182
73497, 1.3739130434783, 0.80217391304348, 0.31818181818182
73498, 1.3739130434783, 0.77608695652174, 0.29545454545455
73499, 1.3521739130435, 0.77608695652174, 0.27272727272727
73500, 1.3739130434783, 0.80217391304348, 0.27272727272727
73501, 1.3739130434783, 0.77608695652174, 0.25
73502, 1.3521739130435, 0.77608695652174, 0.22727272727273
73503, 1.3739130434783, 0.80217391304348, 0.22727272727273
73504, 1.3739130434783, 0.77608695652174, 0.20454545454545
73505, 1.3521739130435, 0.77608695652174, 0.18181818181818
73506, 1.3739130434783, 0.80217391304348, 0.18181818181818
73507, 1.3739130434783, 0.77608695652174, 0.15909090909091
73508, 1.3521739130435, 0.77608695652174, 0.13636363636364
73509, 1.3739130434783, 0.80217391304348, 0.13636363636364
73510, 1.3739130434783, 0.77608695652174, 0.11363636363636
73511, 1.3521739130435, 0.77608695652174, 0.090909090909091
73512, 1.3739130434783, 0.80217391304348, 0.090909090909091
73513, 1.3739130434783, 0.77608695652174, 0.068181818181818
73514, 1.3521739130435, 0.77608695652174, 0.045454545454545
73515, 1.3739130434783, 0.80217391304348, 0.045454545454545
73516, 1.3739130434783, 0.77608695652174, 0.022727272727273
73517, 1.4173913043478, 0.77608695652174, 0.47727272727273
73518, 1.395652173913, 0.77608695652174, 0.45454545454545
73519, 1.4173913043478, 0.80217391304348, 0.45454545454545
73520, 1.4173913043478, 0.77608695652174, 0.43181818181818
73521, 1.395652173913, 0.77608695652174, 0.40909090909091
73522, 1.4173913043478, 0.80217391304348, 0.40909090909091
73523, 1.4173913043478, 0.77608695652174, 0.38636363636364
73524, 1.395652173913, 0.77608695652174, 0.36363636363636
73525, 1.4173913043478, 0.80217391304348, 0.36363636363636
73526, 1.4173913043478, 0.77608695652174, 0.34090909090909
73527, 1.395652173913, 0.77608695652174, 0.31818181818182
73528, 1.4173913043478, 0.80217391304348, 0.31818181818182
73529, 1.4173913043478, 0.77608695652174, 0.29545454545455
73530, 1.395652173913, 0.77608695652174, 0.27272727272727
73531, 1.4173913043478, 0.80217391304348, 0.27272727272727
73532, 1.4173913043478, 0.77608695652174, 0.25
73533, 1.395652173913, 0.77608695652174, 0.22727272727273
73534, 1.4173913043478, 0.80217391304348, 0.22727272727273
73535, 1.4173913043478, 0.77608695652174, 0.20454545454545
73536, 1.395652173913, 0.77608695652174, 0.18181818181818
73537, 1.4173913043478, 0.80217391304348, 0.18181818181818
73538, 1.4173913043478, 0.77608695652174, 0.15909090909091
73539, 1.395652173913, 0.77608695652174, 0.13636363636364
73540, 1.4173913043478, 0.80217391304348, 0.13636363636364
73541, 1.4173913043478, 0.77608695652174, 0.11363636363636
73542, 1.395652173913, 0.77608695652174, 0.090909090909091
73543, 1.4173913043478, 0.80217391304348, 0.090909090909091
73544, 1.4173913043478, 0.77608695652174, 0.068181818181818
73545, 1.395652173913, 0.77608695652174, 0.045454545454545
73546, 1.4173913043478, 0.80217391304348, 0.045454545454545
73547, 1.4173913043478, 0.77608695652174, 0.022727272727273
73548, 1.4608695652174, 0.77608695652174, 0.47727272727273
73549, 1.4391304347826, 0.77608695652174, 0.45454545454545
73550, 1.4608695652174, 0.80217391304348, 0.45454545454545
73551, 1.4608695652174, 0.77608695652174, 0.43181818181818
73552, 1.4391304347826, 0.77608695652174, 0.40909090909091
73553, 1.4608695652174, 0.80217391304348, 0.40909090909091
73554, 1.4608695652174, 0.77608695652174, 0.38636363636364
73555, 1.4391304347826, 0.77608695652174, 0.36363636363636
73556, 1.4608695652174, 0.80217391304348, 0.36363636363636
73557, 1.4608695652174, 0.77608695652174, 0.34090909090909
73558, 1.4391304347826, 0.77608695652174, 0.31818181818182
73559, 1.4608695652174, 0.80217391304348, 0.31818181818182
73560, 1.4608695652174, 0.77608695652174, 0.29545454545455
73561, 1.4391304347826, 0.77608695652174, 0.27272727272727
73562, 1.4608695652174, 0.80217391304348, 0.27272727272727
73563, 1.4608695652174, 0.77608695652174, 0.25
73564, 1.4391304347826, 0.77608695652174, 0.22727272727273
73565, 1.4608695652174, 0.80217391304348, 0.22727272727273
73566, 1.4608695652174, 0.77608695652174, 0.20454545454545
73567, 1.4391304347826, 0.77608695652174, 0.18181818181818
73568, 1.4608695652174, 0.80217391304348, 0.18181818181818
73569, 1.4608695652174, 0.77608695652174, 0.15909090909091
73570, 1.4391304347826, 0.77608695652174, 0.13636363636364
73571, 1.4608695652174, 0.80217391304348, 0.13636363636364
73572, 1.4608695652174, 0.77608695652174, 0.11363636363636
73573, 1.4391304347826, 0.77608695652174, 0.090909090909091
73574, 1.4608695652174, 0.80217391304348, 0.090909090909091
73575, 1.4608695652174, 0.77608695652174, 0.068181818181818
73576, 1.4391304347826, 0.77608695652174, 0.045454545454545
73577, 1.4608695652174, 0.80217391304348, 0.045454545454545
73578, 1.4608695652174, 0.77608695652174, 0.022727272727273
73579, 1.504347826087, 0.77608695652174, 0.47727272727273
73580, 1.4826086956522, 0.77608695652174, 0.45454545454545
73581, 1.504347826087, 0.80217391304348, 0.45454545454545
73582, 1.504347826087, 0.77608695652174, 0.43181818181818
73583, 1.4826086956522, 0.77608695652174, 0.40909090909091
73584, 1.504347826087, 0.80217391304348, 0.40909090909091
73585, 1.504347826087, 0.77608695652174, 0.38636363636364
73586, 1.4826086956522, 0.77608695652174, 0.36363636363636
73587, 1.504347826087, 0.80217391304348, 0.36363636363636
73588, 1.504347826087, 0.77608695652174, 0.34090909090909
73589, 1.4826086956522, 0.77608695652174, 0.31818181818182
73590, 1.504347826087, 0.80217391304348, 0.31818181818182
73591, 1.504347826087, 0.77608695652174, 0.29545454545455
73592, 1.4826086956522, 0.77608695652174, 0.27272727272727
73593, 1.504347826087, 0.80217391304348, 0.27272727272727
73594, 1.504347826087, 0.77608695652174, 0.25
73595, 1.4826086956522, 0.77608695652174, 0.22727272727273
73596, 1.504347826087, 0.80217391304348, 0.22727272727273
73597, 1.504347826087, 0.77608695652174, 0.20454545454545
73598, 1.4826086956522, 0.77608695652174, 0.18181818181818
73599, 1.504347826087, 0.80217391304348, 0.18181818181818
73600, 1.504347826087, 0.77608695652174, 0.15909090909091
73601, 1.4826086956522, 0.77608695652174, 0.13636363636364
73602, 1.504347826087, 0.80217391304348, 0.13636363636364
73603, 1.504347826087, 0.77608695652174, 0.11363636363636
73604, 1.4826086956522, 0.77608695652174, 0.090909090909091
73605, 1.504347826087, 0.80217391304348, 0.090909090909091
73606, 1.504347826087, 0.77608695652174, 0.068181818181818
73607, 1.4826086956522, 0.77608695652174, 0.045454545454545
73608, 1.504347826087, 0.80217391304348, 0.045454545454545
73609, 1.504347826087, 0.77608695652174, 0.022727272727273
73610, 1.5478260869565, 0.77608695652174, 0.47727272727273
73611, 1.5260869565217, 0.77608695652174, 0.45454545454545
73612, 1.5478260869565, 0.80217391304348, 0.45454545454545
73613, 1.5478260869565, 0.77608695652174, 0.43181818181818
73614, 1.5260869565217, 0.77608695652174, 0.40909090909091
73615, 1.5478260869565, 0.80217391304348, 0.40909090909091
73616, 1.5478260869565, 0.77608695652174, 0.38636363636364
73617, 1.5260869565217, 0.77608695652174, 0.36363636363636
73618, 1.5478260869565, 0.80217391304348, 0.36363636363636
73619, 1.5478260869565, 0.77608695652174, 0.34090909090909
73620, 1.5260869565217, 0.77608695652174, 0.31818181818182
73621, 1.5478260869565, 0.80217391304348, 0.31818181818182
73622, 1.5478260869565, 0.77608695652174, 0.29545454545455
73623, 1.5260869565217, 0.77608695652174, 0.27272727272727
73624, 1.5478260869565, 0.80217391304348, 0.27272727272727
73625, 1.5478260869565, 0.77608695652174, 0.25
73626, 1.5260869565217, 0.77608695652174, 0.22727272727273
73627, 1.5478260869565, 0.80217391304348, 0.22727272727273
73628, 1.5478260869565, 0.77608695652174, 0.20454545454545
73629, 1.5260869565217, 0.77608695652174, 0.18181818181818
73630, 1.5478260869565, 0.80217391304348, 0.18181818181818
73631, 1.5478260869565, 0.77608695652174, 0.15909090909091
73632, 1.5260869565217, 0.77608695652174, 0.13636363636364
73633, 1.5478260869565, 0.80217391304348, 0.13636363636364
73634, 1.5478260869565, 0.77608695652174, 0.11363636363636
73635, 1.5260869565217, 0.77608695652174, 0.090909090909091
73636, 1.5478260869565, 0.80217391304348, 0.090909090909091
73637, 1.5478260869565, 0.77608695652174, 0.068181818181818
73638, 1.5260869565217, 0.77608695652174, 0.045454545454545
73639, 1.5478260869565, 0.80217391304348, 0.045454545454545
73640, 1.5478260869565, 0.77608695652174, 0.022727272727273
73641, 1.5913043478261, 0.77608695652174, 0.47727272727273
73642, 1.5695652173913, 0.77608695652174, 0.45454545454545
73643, 1.5913043478261, 0.80217391304348, 0.45454545454545
73644, 1.5913043478261, 0.77608695652174, 0.43181818181818
73645, 1.5695652173913, 0.77608695652174, 0.40909090909091
73646, 1.5913043478261, 0.80217391304348, 0.40909090909091
73647, 1.5913043478261, 0.77608695652174, 0.38636363636364
73648, 1.5695652173913, 0.77608695652174, 0.36363636363636
73649, 1.5913043478261, 0.80217391304348, 0.36363636363636
73650, 1.5913043478261, 0.77608695652174, 0.34090909090909
73651, 1.5695652173913, 0.77608695652174, 0.31818181818182
73652, 1.5913043478261, 0.80217391304348, 0.31818181818182
73653, 1.5913043478261, 0.77608695652174, 0.29545454545455
73654, 1.5695652173913, 0.77608695652174, 0.27272727272727
73655, 1.5913043478261, 0.80217391304348, 0.27272727272727
73656, 1.5913043478261, 0.77608695652174, 0.25
73657, 1.5695652173913, 0.77608695652174, 0.22727272727273
73658, 1.5913043478261, 0.80217391304348, 0.22727272727273
73659, 1.5913043478261, 0.77608695652174, 0.20454545454545
73660, 1.5695652173913, 0.77608695652174, 0.18181818181818
73661, 1.5913043478261, 0.80217391304348, 0.18181818181818
73662, 1.5913043478261, 0.77608695652174, 0.15909090909091
73663, 1.5695652173913, 0.77608695652174, 0.13636363636364
73664, 1.5913043478261, 0.80217391304348, 0.13636363636364
73665, 1.5913043478261, 0.77608695652174, 0.11363636363636
73666, 1.5695652173913, 0.77608695652174, 0.090909090909091
73667, 1.5913043478261, 0.80217391304348, 0.090909090909091
73668, 1.5913043478261, 0.77608695652174, 0.068181818181818
73669, 1.5695652173913, 0.77608695652174, 0.045454545454545
73670, 1.5913043478261, 0.80217391304348, 0.045454545454545
73671, 1.5913043478261, 0.77608695652174, 0.022727272727273
73672, 1.6347826086957, 0.77608695652174, 0.47727272727273
73673, 1.6130434782609, 0.77608695652174, 0.45454545454545
73674, 1.6347826086957, 0.80217391304348, 0.45454545454545
73675, 1.6347826086957, 0.77608695652174, 0.43181818181818
73676, 1.6130434782609, 0.77608695652174, 0.40909090909091
73677, 1.6347826086957, 0.80217391304348, 0.40909090909091
73678, 1.6347826086957, 0.77608695652174, 0.38636363636364
73679, 1.6130434782609, 0.77608695652174, 0.36363636363636
73680, 1.6347826086957, 0.80217391304348, 0.36363636363636
73681, 1.6347826086957, 0.77608695652174, 0.34090909090909
73682, 1.6130434782609, 0.77608695652174, 0.31818181818182
73683, 1.6347826086957, 0.80217391304348, 0.31818181818182
73684, 1.6347826086957, 0.77608695652174, 0.29545454545455
73685, 1.6130434782609, 0.77608695652174, 0.27272727272727
73686, 1.6347826086957, 0.80217391304348, 0.27272727272727
73687, 1.6347826086957, 0.77608695652174, 0.25
73688, 1.6130434782609, 0.77608695652174, 0.22727272727273
73689, 1.6347826086957, 0.80217391304348, 0.22727272727273
73690, 1.6347826086957, 0.77608695652174, 0.20454545454545
73691, 1.6130434782609, 0.77608695652174, 0.18181818181818
73692, 1.6347826086957, 0.80217391304348, 0.18181818181818
73693, 1.6347826086957, 0.77608695652174, 0.15909090909091
73694, 1.6130434782609, 0.77608695652174, 0.13636363636364
73695, 1.6347826086957, 0.80217391304348, 0.13636363636364
73696, 1.6347826086957, 0.77608695652174, 0.11363636363636
73697, 1.6130434782609, 0.77608695652174, 0.090909090909091
73698, 1.6347826086957, 0.80217391304348, 0.090909090909091
73699, 1.6347826086957, 0.77608695652174, 0.068181818181818
73700, 1.6130434782609, 0.77608695652174, 0.045454545454545
73701, 1.6347826086957, 0.80217391304348, 0.045454545454545
73702, 1.6347826086957, 0.77608695652174, 0.022727272727273
73703, 1.6782608695652, 0.77608695652174, 0.47727272727273
73704, 1.6565217391304, 0.77608695652174, 0.45454545454545
73705, 1.6782608695652, 0.80217391304348, 0.45454545454545
73706, 1.6782608695652, 0.77608695652174, 0.43181818181818
73707, 1.6565217391304, 0.77608695652174, 0.40909090909091
73708, 1.6782608695652, 0.80217391304348, 0.40909090909091
73709, 1.6782608695652, 0.77608695652174, 0.38636363636364
73710, 1.6565217391304, 0.77608695652174, 0.36363636363636
73711, 1.6782608695652, 0.80217391304348, 0.36363636363636
73712, 1.6782608695652, 0.77608695652174, 0.34090909090909
73713, 1.6565217391304, 0.77608695652174, 0.31818181818182
73714, 1.6782608695652, 0.80217391304348, 0.31818181818182
73715, 1.6782608695652, 0.77608695652174, 0.29545454545455
73716, 1.6565217391304, 0.77608695652174, 0.27272727272727
73717, 1.6782608695652, 0.80217391304348, 0.27272727272727
73718, 1.6782608695652, 0.77608695652174, 0.25
73719, 1.6565217391304, 0.77608695652174, 0.22727272727273
73720, 1.6782608695652, 0.80217391304348, 0.22727272727273
73721, 1.6782608695652, 0.77608695652174, 0.20454545454545
73722, 1.6565217391304, 0.77608695652174, 0.18181818181818
73723, 1.6782608695652, 0.80217391304348, 0.18181818181818
73724, 1.6782608695652, 0.77608695652174, 0.15909090909091
73725, 1.6565217391304, 0.77608695652174, 0.13636363636364
73726, 1.6782608695652, 0.80217391304348, 0.13636363636364
73727, 1.6782608695652, 0.77608695652174, 0.11363636363636
73728, 1.6565217391304, 0.77608695652174, 0.090909090909091
73729, 1.6782608695652, 0.80217391304348, 0.090909090909091
73730, 1.6782608695652, 0.77608695652174, 0.068181818181818
73731, 1.6565217391304, 0.77608695652174, 0.045454545454545
73732, 1.6782608695652, 0.80217391304348, 0.045454545454545
73733, 1.6782608695652, 0.77608695652174, 0.022727272727273
73734, 1.7217391304348, 0.77608695652174, 0.47727272727273
73735, 1.7, 0.77608695652174, 0.45454545454545
73736, 1.7217391304348, 0.80217391304348, 0.45454545454545
73737, 1.7217391304348, 0.77608695652174, 0.43181818181818
73738, 1.7, 0.77608695652174, 0.40909090909091
73739, 1.7217391304348, 0.80217391304348, 0.40909090909091
73740, 1.7217391304348, 0.77608695652174, 0.38636363636364
73741, 1.7, 0.77608695652174, 0.36363636363636
73742, 1.7217391304348, 0.80217391304348, 0.36363636363636
73743, 1.7217391304348, 0.77608695652174, 0.34090909090909
73744, 1.7, 0.77608695652174, 0.31818181818182
73745, 1.7217391304348, 0.80217391304348, 0.31818181818182
73746, 1.7217391304348, 0.77608695652174, 0.29545454545455
73747, 1.7, 0.77608695652174, 0.27272727272727
73748, 1.7217391304348, 0.80217391304348, 0.27272727272727
73749, 1.7217391304348, 0.77608695652174, 0.25
73750, 1.7, 0.77608695652174, 0.22727272727273
73751, 1.7217391304348, 0.80217391304348, 0.22727272727273
73752, 1.7217391304348, 0.77608695652174, 0.20454545454545
73753, 1.7, 0.77608695652174, 0.18181818181818
73754, 1.7217391304348, 0.80217391304348, 0.18181818181818
73755, 1.7217391304348, 0.77608695652174, 0.15909090909091
73756, 1.7, 0.77608695652174, 0.13636363636364
73757, 1.7217391304348, 0.80217391304348, 0.13636363636364
73758, 1.7217391304348, 0.77608695652174, 0.11363636363636
73759, 1.7, 0.77608695652174, 0.090909090909091
73760, 1.7217391304348, 0.80217391304348, 0.090909090909091
73761, 1.7217391304348, 0.77608695652174, 0.068181818181818
73762, 1.7, 0.77608695652174, 0.045454545454545
73763, 1.7217391304348, 0.80217391304348, 0.045454545454545
73764, 1.7217391304348, 0.77608695652174, 0.022727272727273
73765, 1.7652173913043, 0.77608695652174, 0.47727272727273
73766, 1.7434782608696, 0.77608695652174, 0.45454545454545
73767, 1.7652173913043, 0.80217391304348, 0.45454545454545
73768, 1.7652173913043, 0.77608695652174, 0.43181818181818
73769, 1.7434782608696, 0.77608695652174, 0.40909090909091
73770, 1.7652173913043, 0.80217391304348, 0.40909090909091
73771, 1.7652173913043, 0.77608695652174, 0.38636363636364
73772, 1.7434782608696, 0.77608695652174, 0.36363636363636
73773, 1.7652173913043, 0.80217391304348, 0.36363636363636
73774, 1.7652173913043, 0.77608695652174, 0.34090909090909
73775, 1.7434782608696, 0.77608695652174, 0.31818181818182
73776, 1.7652173913043, 0.80217391304348, 0.31818181818182
73777, 1.7652173913043, 0.77608695652174, 0.29545454545455
73778, 1.7434782608696, 0.77608695652174, 0.27272727272727
73779, 1.7652173913043, 0.80217391304348, 0.27272727272727
73780, 1.7652173913043, 0.77608695652174, 0.25
73781, 1.7434782608696, 0.77608695652174, 0.22727272727273
73782, 1.7652173913043, 0.80217391304348, 0.22727272727273
73783, 1.7652173913043, 0.77608695652174, 0.20454545454545
73784, 1.7434782608696, 0.77608695652174, 0.18181818181818
73785, 1.7652173913043, 0.80217391304348, 0.18181818181818
73786, 1.7652173913043, 0.77608695652174, 0.15909090909091
73787, 1.7434782608696, 0.77608695652174, 0.13636363636364
73788, 1.7652173913043, 0.80217391304348, 0.13636363636364
73789, 1.7652173913043, 0.77608695652174, 0.11363636363636
73790, 1.7434782608696, 0.77608695652174, 0.090909090909091
73791, 1.7652173913043, 0.80217391304348, 0.090909090909091
73792, 1.7652173913043, 0.77608695652174, 0.068181818181818
73793, 1.7434782608696, 0.77608695652174, 0.045454545454545
73794, 1.7652173913043, 0.80217391304348, 0.045454545454545
73795, 1.7652173913043, 0.77608695652174, 0.022727272727273
73796, 1.8086956521739, 0.77608695652174, 0.47727272727273
73797, 1.7869565217391, 0.77608695652174, 0.45454545454545
73798, 1.8086956521739, 0.80217391304348, 0.45454545454545
73799, 1.8086956521739, 0.77608695652174, 0.43181818181818
73800, 1.7869565217391, 0.77608695652174, 0.40909090909091
73801, 1.8086956521739, 0.80217391304348, 0.40909090909091
73802, 1.8086956521739, 0.77608695652174, 0.38636363636364
73803, 1.7869565217391, 0.77608695652174, 0.36363636363636
73804, 1.8086956521739, 0.80217391304348, 0.36363636363636
73805, 1.8086956521739, 0.77608695652174, 0.34090909090909
73806, 1.7869565217391, 0.77608695652174, 0.31818181818182
73807, 1.8086956521739, 0.80217391304348, 0.31818181818182
73808, 1.8086956521739, 0.77608695652174, 0.29545454545455
73809, 1.7869565217391, 0.77608695652174, 0.27272727272727
73810, 1.8086956521739, 0.80217391304348, 0.27272727272727
73811, 1.8086956521739, 0.77608695652174, 0.25
73812, 1.7869565217391, 0.77608695652174, 0.22727272727273
73813, 1.8086956521739, 0.80217391304348, 0.22727272727273
73814, 1.8086956521739, 0.77608695652174, 0.20454545454545
73815, 1.7869565217391, 0.77608695652174, 0.18181818181818
73816, 1.8086956521739, 0.80217391304348, 0.18181818181818
73817, 1.8086956521739, 0.77608695652174, 0.15909090909091
73818, 1.7869565217391, 0.77608695652174, 0.13636363636364
73819, 1.8086956521739, 0.80217391304348, 0.13636363636364
73820, 1.8086956521739, 0.77608695652174, 0.11363636363636
73821, 1.7869565217391, 0.77608695652174, 0.090909090909091
73822, 1.8086956521739, 0.80217391304348, 0.090909090909091
73823, 1.8086956521739, 0.77608695652174, 0.068181818181818
73824, 1.7869565217391, 0.77608695652174, 0.045454545454545
73825, 1.8086956521739, 0.80217391304348, 0.045454545454545
73826, 1.8086956521739, 0.77608695652174, 0.022727272727273
73827, 1.8521739130435, 0.77608695652174, 0.47727272727273
73828, 1.8304347826087, 0.77608695652174, 0.45454545454545
73829, 1.8521739130435, 0.80217391304348, 0.45454545454545
73830, 1.8521739130435, 0.77608695652174, 0.43181818181818
73831, 1.8304347826087, 0.77608695652174, 0.40909090909091
73832, 1.8521739130435, 0.80217391304348, 0.40909090909091
73833, 1.8521739130435, 0.77608695652174, 0.38636363636364
73834, 1.8304347826087, 0.77608695652174, 0.36363636363636
73835, 1.8521739130435, 0.80217391304348, 0.36363636363636
73836, 1.8521739130435, 0.77608695652174, 0.34090909090909
73837, 1.8304347826087, 0.77608695652174, 0.31818181818182
73838, 1.8521739130435, 0.80217391304348, 0.31818181818182
73839, 1.8521739130435, 0.77608695652174, 0.29545454545455
73840, 1.8304347826087, 0.77608695652174, 0.27272727272727
73841, 1.8521739130435, 0.80217391304348, 0.27272727272727
73842, 1.8521739130435, 0.77608695652174, 0.25
73843, 1.8304347826087, 0.77608695652174, 0.22727272727273
73844, 1.8521739130435, 0.80217391304348, 0.22727272727273
73845, 1.8521739130435, 0.77608695652174, 0.20454545454545
73846, 1.8304347826087, 0.77608695652174, 0.18181818181818
73847, 1.8521739130435, 0.80217391304348, 0.18181818181818
73848, 1.8521739130435, 0.77608695652174, 0.15909090909091
73849, 1.8304347826087, 0.77608695652174, 0.13636363636364
73850, 1.8521739130435, 0.80217391304348, 0.13636363636364
73851, 1.8521739130435, 0.77608695652174, 0.11363636363636
73852, 1.8304347826087, 0.77608695652174, 0.090909090909091
73853, 1.8521739130435, 0.80217391304348, 0.090909090909091
73854, 1.8521739130435, 0.77608695652174, 0.068181818181818
73855, 1.8304347826087, 0.77608695652174, 0.045454545454545
73856, 1.8521739130435, 0.80217391304348, 0.045454545454545
73857, 1.8521739130435, 0.77608695652174, 0.022727272727273
73858, 1.895652173913, 0.77608695652174, 0.47727272727273
73859, 1.8739130434783, 0.77608695652174, 0.45454545454545
73860, 1.895652173913, 0.80217391304348, 0.45454545454545
73861, 1.895652173913, 0.77608695652174, 0.43181818181818
73862, 1.8739130434783, 0.77608695652174, 0.40909090909091
73863, 1.895652173913, 0.80217391304348, 0.40909090909091
73864, 1.895652173913, 0.77608695652174, 0.38636363636364
73865, 1.8739130434783, 0.77608695652174, 0.36363636363636
73866, 1.895652173913, 0.80217391304348, 0.36363636363636
73867, 1.895652173913, 0.77608695652174, 0.34090909090909
73868, 1.8739130434783, 0.77608695652174, 0.31818181818182
73869, 1.895652173913, 0.80217391304348, 0.31818181818182
73870, 1.895652173913, 0.77608695652174, 0.29545454545455
73871, 1.8739130434783, 0.77608695652174, 0.27272727272727
73872, 1.895652173913, 0.80217391304348, 0.27272727272727
73873, 1.895652173913, 0.77608695652174, 0.25
73874, 1.8739130434783, 0.77608695652174, 0.22727272727273
73875, 1.895652173913, 0.80217391304348, 0.22727272727273
73876, 1.895652173913, 0.77608695652174, 0.20454545454545
73877, 1.8739130434783, 0.77608695652174, 0.18181818181818
73878, 1.895652173913, 0.80217391304348, 0.18181818181818
73879, 1.895652173913, 0.77608695652174, 0.15909090909091
73880, 1.8739130434783, 0.77608695652174, 0.13636363636364
73881, 1.895652173913, 0.80217391304348, 0.13636363636364
73882, 1.895652173913, 0.77608695652174, 0.11363636363636
73883, 1.8739130434783, 0.77608695652174, 0.090909090909091
73884, 1.895652173913, 0.80217391304348, 0.090909090909091
73885, 1.895652173913, 0.77608695652174, 0.068181818181818
73886, 1.8739130434783, 0.77608695652174, 0.045454545454545
73887, 1.895652173913, 0.80217391304348, 0.045454545454545
73888, 1.895652173913, 0.77608695652174, 0.022727272727273
73889, 1.9391304347826, 0.77608695652174, 0.47727272727273
73890, 1.9173913043478, 0.77608695652174, 0.45454545454545
73891, 1.9391304347826, 0.80217391304348, 0.45454545454545
73892, 1.9391304347826, 0.77608695652174, 0.43181818181818
73893, 1.9173913043478, 0.77608695652174, 0.40909090909091
73894, 1.9391304347826, 0.80217391304348, 0.40909090909091
73895, 1.9391304347826, 0.77608695652174, 0.38636363636364
73896, 1.9173913043478, 0.77608695652174, 0.36363636363636
73897, 1.9391304347826, 0.80217391304348, 0.36363636363636
73898, 1.9391304347826, 0.77608695652174, 0.34090909090909
73899, 1.9173913043478, 0.77608695652174, 0.31818181818182
73900, 1.9391304347826, 0.80217391304348, 0.31818181818182
73901, 1.9391304347826, 0.77608695652174, 0.29545454545455
73902, 1.9173913043478, 0.77608695652174, 0.27272727272727
73903, 1.9391304347826, 0.80217391304348, 0.27272727272727
73904, 1.9391304347826, 0.77608695652174, 0.25
73905, 1.9173913043478, 0.77608695652174, 0.22727272727273
73906, 1.9391304347826, 0.80217391304348, 0.22727272727273
73907, 1.9391304347826, 0.77608695652174, 0.20454545454545
73908, 1.9173913043478, 0.77608695652174, 0.18181818181818
73909, 1.9391304347826, 0.80217391304348, 0.18181818181818
73910, 1.9391304347826, 0.77608695652174, 0.15909090909091
73911, 1.9173913043478, 0.77608695652174, 0.13636363636364
73912, 1.9391304347826, 0.80217391304348, 0.13636363636364
73913, 1.9391304347826, 0.77608695652174, 0.11363636363636
73914, 1.9173913043478, 0.77608695652174, 0.090909090909091
73915, 1.9391304347826, 0.80217391304348, 0.090909090909091
73916, 1.9391304347826, 0.77608695652174, 0.068181818181818
73917, 1.9173913043478, 0.77608695652174, 0.045454545454545
73918, 1.9391304347826, 0.80217391304348, 0.045454545454545
73919, 1.9391304347826, 0.77608695652174, 0.022727272727273
73920, 1.9826086956522, 0.77608695652174, 0.47727272727273
73921, 1.9608695652174, 0.77608695652174, 0.45454545454545
73922, 1.9826086956522, 0.80217391304348, 0.45454545454545
73923, 1.9826086956522, 0.77608695652174, 0.43181818181818
73924, 1.9608695652174, 0.77608695652174, 0.40909090909091
73925, 1.9826086956522, 0.80217391304348, 0.40909090909091
73926, 1.9826086956522, 0.77608695652174, 0.38636363636364
73927, 1.9608695652174, 0.77608695652174, 0.36363636363636
73928, 1.9826086956522, 0.80217391304348, 0.36363636363636
73929, 1.9826086956522, 0.77608695652174, 0.34090909090909
73930, 1.9608695652174, 0.77608695652174, 0.31818181818182
73931, 1.9826086956522, 0.80217391304348, 0.31818181818182
73932, 1.9826086956522, 0.77608695652174, 0.29545454545455
73933, 1.9608695652174, 0.77608695652174, 0.27272727272727
73934, 1.9826086956522, 0.80217391304348, 0.27272727272727
73935, 1.9826086956522, 0.77608695652174, 0.25
73936, 1.9608695652174, 0.77608695652174, 0.22727272727273
73937, 1.9826086956522, 0.80217391304348, 0.22727272727273
73938, 1.9826086956522, 0.77608695652174, 0.20454545454545
73939, 1.9608695652174, 0.77608695652174, 0.18181818181818
73940, 1.9826086956522, 0.80217391304348, 0.18181818181818
73941, 1.9826086956522, 0.77608695652174, 0.15909090909091
73942, 1.9608695652174, 0.77608695652174, 0.13636363636364
73943, 1.9826086956522, 0.80217391304348, 0.13636363636364
73944, 1.9826086956522, 0.77608695652174, 0.11363636363636
73945, 1.9608695652174, 0.77608695652174, 0.090909090909091
73946, 1.9826086956522, 0.80217391304348, 0.090909090909091
73947, 1.9826086956522, 0.77608695652174, 0.068181818181818
73948, 1.9608695652174, 0.77608695652174, 0.045454545454545
73949, 1.9826086956522, 0.80217391304348, 0.045454545454545
73950, 1.9826086956522, 0.77608695652174, 0.022727272727273
73951, 2.0260869565217, 0.77608695652174, 0.47727272727273
73952, 2.004347826087, 0.77608695652174, 0.45454545454545
73953, 2.0260869565217, 0.80217391304348, 0.45454545454545
73954, 2.0260869565217, 0.77608695652174, 0.43181818181818
73955, 2.004347826087, 0.77608695652174, 0.40909090909091
73956, 2.0260869565217, 0.80217391304348, 0.40909090909091
73957, 2.0260869565217, 0.77608695652174, 0.38636363636364
73958, 2.004347826087, 0.77608695652174, 0.36363636363636
73959, 2.0260869565217, 0.80217391304348, 0.36363636363636
73960, 2.0260869565217, 0.77608695652174, 0.34090909090909
73961, 2.004347826087, 0.77608695652174, 0.31818181818182
73962, 2.0260869565217, 0.80217391304348, 0.31818181818182
73963, 2.0260869565217, 0.77608695652174, 0.29545454545455
73964, 2.004347826087, 0.77608695652174, 0.27272727272727
73965, 2.0260869565217, 0.80217391304348, 0.27272727272727
73966, 2.0260869565217, 0.77608695652174, 0.25
73967, 2.004347826087, 0.77608695652174, 0.22727272727273
73968, 2.0260869565217, 0.80217391304348, 0.22727272727273
73969, 2.0260869565217, 0.77608695652174, 0.20454545454545
73970, 2.004347826087, 0.77608695652174, 0.18181818181818
73971, 2.0260869565217, 0.80217391304348, 0.18181818181818
73972, 2.0260869565217, 0.77608695652174, 0.15909090909091
73973, 2.004347826087, 0.77608695652174, 0.13636363636364
73974, 2.0260869565217, 0.80217391304348, 0.13636363636364
73975, 2.0260869565217, 0.77608695652174, 0.11363636363636
73976, 2.004347826087, 0.77608695652174, 0.090909090909091
73977, 2.0260869565217, 0.80217391304348, 0.090909090909091
73978, 2.0260869565217, 0.77608695652174, 0.068181818181818
73979, 2.004347826087, 0.77608695652174, 0.045454545454545
73980, 2.0260869565217, 0.80217391304348, 0.045454545454545
73981, 2.0260869565217, 0.77608695652174, 0.022727272727273
73982, 2.0695652173913, 0.77608695652174, 0.47727272727273
73983, 2.0478260869565, 0.77608695652174, 0.45454545454545
73984, 2.0695652173913, 0.80217391304348, 0.45454545454545
73985, 2.0695652173913, 0.77608695652174, 0.43181818181818
73986, 2.0478260869565, 0.77608695652174, 0.40909090909091
73987, 2.0695652173913, 0.80217391304348, 0.40909090909091
73988, 2.0695652173913, 0.77608695652174, 0.38636363636364
73989, 2.0478260869565, 0.77608695652174, 0.36363636363636
73990, 2.0695652173913, 0.80217391304348, 0.36363636363636
73991, 2.0695652173913, 0.77608695652174, 0.34090909090909
73992, 2.0478260869565, 0.77608695652174, 0.31818181818182
73993, 2.0695652173913, 0.80217391304348, 0.31818181818182
73994, 2.0695652173913, 0.77608695652174, 0.29545454545455
73995, 2.0478260869565, 0.77608695652174, 0.27272727272727
73996, 2.0695652173913, 0.80217391304348, 0.27272727272727
73997, 2.0695652173913, 0.77608695652174, 0.25
73998, 2.0478260869565, 0.77608695652174, 0.22727272727273
73999, 2.0695652173913, 0.80217391304348, 0.22727272727273
74000, 2.0695652173913, 0.77608695652174, 0.20454545454545
74001, 2.0478260869565, 0.77608695652174, 0.18181818181818
74002, 2.0695652173913, 0.80217391304348, 0.18181818181818
74003, 2.0695652173913, 0.77608695652174, 0.15909090909091
74004, 2.0478260869565, 0.77608695652174, 0.13636363636364
74005, 2.0695652173913, 0.80217391304348, 0.13636363636364
74006, 2.0695652173913, 0.77608695652174, 0.11363636363636
74007, 2.0478260869565, 0.77608695652174, 0.090909090909091
74008, 2.0695652173913, 0.80217391304348, 0.090909090909091
74009, 2.0695652173913, 0.77608695652174, 0.068181818181818
74010, 2.0478260869565, 0.77608695652174, 0.045454545454545
74011, 2.0695652173913, 0.80217391304348, 0.045454545454545
74012, 2.0695652173913, 0.77608695652174, 0.022727272727273
74013, 2.1130434782609, 0.77608695652174, 0.47727272727273
74014, 2.0913043478261, 0.77608695652174, 0.45454545454545
74015, 2.1130434782609, 0.80217391304348, 0.45454545454545
74016, 2.1130434782609, 0.77608695652174, 0.43181818181818
74017, 2.0913043478261, 0.77608695652174, 0.40909090909091
74018, 2.1130434782609, 0.80217391304348, 0.40909090909091
74019, 2.1130434782609, 0.77608695652174, 0.38636363636364
74020, 2.0913043478261, 0.77608695652174, 0.36363636363636
74021, 2.1130434782609, 0.80217391304348, 0.36363636363636
74022, 2.1130434782609, 0.77608695652174, 0.34090909090909
74023, 2.0913043478261, 0.77608695652174, 0.31818181818182
74024, 2.1130434782609, 0.80217391304348, 0.31818181818182
74025, 2.1130434782609, 0.77608695652174, 0.29545454545455
74026, 2.0913043478261, 0.77608695652174, 0.27272727272727
74027, 2.1130434782609, 0.80217391304348, 0.27272727272727
74028, 2.1130434782609, 0.77608695652174, 0.25
74029, 2.0913043478261, 0.77608695652174, 0.22727272727273
74030, 2.1130434782609, 0.80217391304348, 0.22727272727273
74031, 2.1130434782609, 0.77608695652174, 0.20454545454545
74032, 2.0913043478261, 0.77608695652174, 0.18181818181818
74033, 2.1130434782609, 0.80217391304348, 0.18181818181818
74034, 2.1130434782609, 0.77608695652174, 0.15909090909091
74035, 2.0913043478261, 0.77608695652174, 0.13636363636364
74036, 2.1130434782609, 0.80217391304348, 0.13636363636364
74037, 2.1130434782609, 0.77608695652174, 0.11363636363636
74038, 2.0913043478261, 0.77608695652174, 0.090909090909091
74039, 2.1130434782609, 0.80217391304348, 0.090909090909091
74040, 2.1130434782609, 0.77608695652174, 0.068181818181818
74041, 2.0913043478261, 0.77608695652174, 0.045454545454545
74042, 2.1130434782609, 0.80217391304348, 0.045454545454545
74043, 2.1130434782609, 0.77608695652174, 0.022727272727273
74044, 2.1565217391304, 0.77608695652174, 0.47727272727273
74045, 2.1347826086957, 0.77608695652174, 0.45454545454545
74046, 2.1565217391304, 0.80217391304348, 0.45454545454545
74047, 2.1565217391304, 0.77608695652174, 0.43181818181818
74048, 2.1347826086957, 0.77608695652174, 0.40909090909091
74049, 2.1565217391304, 0.80217391304348, 0.40909090909091
74050, 2.1565217391304, 0.77608695652174, 0.38636363636364
74051, 2.1347826086957, 0.77608695652174, 0.36363636363636
74052, 2.1565217391304, 0.80217391304348, 0.36363636363636
74053, 2.1565217391304, 0.77608695652174, 0.34090909090909
74054, 2.1347826086957, 0.77608695652174, 0.31818181818182
74055, 2.1565217391304, 0.80217391304348, 0.31818181818182
74056, 2.1565217391304, 0.77608695652174, 0.29545454545455
74057, 2.1347826086957, 0.77608695652174, 0.27272727272727
74058, 2.1565217391304, 0.80217391304348, 0.27272727272727
74059, 2.1565217391304, 0.77608695652174, 0.25
74060, 2.1347826086957, 0.77608695652174, 0.22727272727273
74061, 2.1565217391304, 0.80217391304348, 0.22727272727273
74062, 2.1565217391304, 0.77608695652174, 0.20454545454545
74063, 2.1347826086957, 0.77608695652174, 0.18181818181818
74064, 2.1565217391304, 0.80217391304348, 0.18181818181818
74065, 2.1565217391304, 0.77608695652174, 0.15909090909091
74066, 2.1347826086957, 0.77608695652174, 0.13636363636364
74067, 2.1565217391304, 0.80217391304348, 0.13636363636364
74068, 2.1565217391304, 0.77608695652174, 0.11363636363636
74069, 2.1347826086957, 0.77608695652174, 0.090909090909091
74070, 2.1565217391304, 0.80217391304348, 0.090909090909091
74071, 2.1565217391304, 0.77608695652174, 0.068181818181818
74072, 2.1347826086957, 0.77608695652174, 0.045454545454545
74073, 2.1565217391304, 0.80217391304348, 0.045454545454545
74074, 2.1565217391304, 0.77608695652174, 0.022727272727273
74075, 2.1782608695652, 0.77608695652174, 0.45454545454545
74076, 2.1782608695652, 0.77608695652174, 0.40909090909091
74077, 2.1782608695652, 0.77608695652174, 0.36363636363636
74078, 2.1782608695652, 0.77608695652174, 0.31818181818182
74079, 2.1782608695652, 0.77608695652174, 0.27272727272727
74080, 2.1782608695652, 0.77608695652174, 0.22727272727273
74081, 2.1782608695652, 0.77608695652174, 0.18181818181818
74082, 2.1782608695652, 0.77608695652174, 0.13636363636364
74083, 2.1782608695652, 0.77608695652174, 0.090909090909091
74084, 2.1782608695652, 0.77608695652174, 0.045454545454545
74085, 1.2434782608696, 0.72391304347826, 0.47727272727273
74086, 1.2217391304348, 0.72391304347826, 0.45454545454545
74087, 1.2434782608696, 0.75, 0.45454545454545
74088, 1.2434782608696, 0.72391304347826, 0.43181818181818
74089, 1.2217391304348, 0.72391304347826, 0.40909090909091
74090, 1.2434782608696, 0.75, 0.40909090909091
74091, 1.2434782608696, 0.72391304347826, 0.38636363636364
74092, 1.2217391304348, 0.72391304347826, 0.36363636363636
74093, 1.2434782608696, 0.75, 0.36363636363636
74094, 1.2434782608696, 0.72391304347826, 0.34090909090909
74095, 1.2217391304348, 0.72391304347826, 0.31818181818182
74096, 1.2434782608696, 0.75, 0.31818181818182
74097, 1.2434782608696, 0.72391304347826, 0.29545454545455
74098, 1.2217391304348, 0.72391304347826, 0.27272727272727
74099, 1.2434782608696, 0.75, 0.27272727272727
74100, 1.2434782608696, 0.72391304347826, 0.25
74101, 1.2217391304348, 0.72391304347826, 0.22727272727273
74102, 1.2434782608696, 0.75, 0.22727272727273
74103, 1.2434782608696, 0.72391304347826, 0.20454545454545
74104, 1.2217391304348, 0.72391304347826, 0.18181818181818
74105, 1.2434782608696, 0.75, 0.18181818181818
74106, 1.2434782608696, 0.72391304347826, 0.15909090909091
74107, 1.2217391304348, 0.72391304347826, 0.13636363636364
74108, 1.2434782608696, 0.75, 0.13636363636364
74109, 1.2434782608696, 0.72391304347826, 0.11363636363636
74110, 1.2217391304348, 0.72391304347826, 0.090909090909091
74111, 1.2434782608696, 0.75, 0.090909090909091
74112, 1.2434782608696, 0.72391304347826, 0.068181818181818
74113, 1.2217391304348, 0.72391304347826, 0.045454545454545
74114, 1.2434782608696, 0.75, 0.045454545454545
74115, 1.2434782608696, 0.72391304347826, 0.022727272727273
74116, 1.2869565217391, 0.72391304347826, 0.47727272727273
74117, 1.2652173913043, 0.72391304347826, 0.45454545454545
74118, 1.2869565217391, 0.75, 0.45454545454545
74119, 1.2869565217391, 0.72391304347826, 0.43181818181818
74120, 1.2652173913043, 0.72391304347826, 0.40909090909091
74121, 1.2869565217391, 0.75, 0.40909090909091
74122, 1.2869565217391, 0.72391304347826, 0.38636363636364
74123, 1.2652173913043, 0.72391304347826, 0.36363636363636
74124, 1.2869565217391, 0.75, 0.36363636363636
74125, 1.2869565217391, 0.72391304347826, 0.34090909090909
74126, 1.2652173913043, 0.72391304347826, 0.31818181818182
74127, 1.2869565217391, 0.75, 0.31818181818182
74128, 1.2869565217391, 0.72391304347826, 0.29545454545455
74129, 1.2652173913043, 0.72391304347826, 0.27272727272727
74130, 1.2869565217391, 0.75, 0.27272727272727
74131, 1.2869565217391, 0.72391304347826, 0.25
74132, 1.2652173913043, 0.72391304347826, 0.22727272727273
74133, 1.2869565217391, 0.75, 0.22727272727273
74134, 1.2869565217391, 0.72391304347826, 0.20454545454545
74135, 1.2652173913043, 0.72391304347826, 0.18181818181818
74136, 1.2869565217391, 0.75, 0.18181818181818
74137, 1.2869565217391, 0.72391304347826, 0.15909090909091
74138, 1.2652173913043, 0.72391304347826, 0.13636363636364
74139, 1.2869565217391, 0.75, 0.13636363636364
74140, 1.2869565217391, 0.72391304347826, 0.11363636363636
74141, 1.2652173913043, 0.72391304347826, 0.090909090909091
74142, 1.2869565217391, 0.75, 0.090909090909091
74143, 1.2869565217391, 0.72391304347826, 0.068181818181818
74144, 1.2652173913043, 0.72391304347826, 0.045454545454545
74145, 1.2869565217391, 0.75, 0.045454545454545
74146, 1.2869565217391, 0.72391304347826, 0.022727272727273
74147, 1.3304347826087, 0.72391304347826, 0.47727272727273
74148, 1.3086956521739, 0.72391304347826, 0.45454545454545
74149, 1.3304347826087, 0.75, 0.45454545454545
74150, 1.3304347826087, 0.72391304347826, 0.43181818181818
74151, 1.3086956521739, 0.72391304347826, 0.40909090909091
74152, 1.3304347826087, 0.75, 0.40909090909091
74153, 1.3304347826087, 0.72391304347826, 0.38636363636364
74154, 1.3086956521739, 0.72391304347826, 0.36363636363636
74155, 1.3304347826087, 0.75, 0.36363636363636
74156, 1.3304347826087, 0.72391304347826, 0.34090909090909
74157, 1.3086956521739, 0.72391304347826, 0.31818181818182
74158, 1.3304347826087, 0.75, 0.31818181818182
74159, 1.3304347826087, 0.72391304347826, 0.29545454545455
74160, 1.3086956521739, 0.72391304347826, 0.27272727272727
74161, 1.3304347826087, 0.75, 0.27272727272727
74162, 1.3304347826087, 0.72391304347826, 0.25
74163, 1.3086956521739, 0.72391304347826, 0.22727272727273
74164, 1.3304347826087, 0.75, 0.22727272727273
74165, 1.3304347826087, 0.72391304347826, 0.20454545454545
74166, 1.3086956521739, 0.72391304347826, 0.18181818181818
74167, 1.3304347826087, 0.75, 0.18181818181818
74168, 1.3304347826087, 0.72391304347826, 0.15909090909091
74169, 1.3086956521739, 0.72391304347826, 0.13636363636364
74170, 1.3304347826087, 0.75, 0.13636363636364
74171, 1.3304347826087, 0.72391304347826, 0.11363636363636
74172, 1.3086956521739, 0.72391304347826, 0.090909090909091
74173, 1.3304347826087, 0.75, 0.090909090909091
74174, 1.3304347826087, 0.72391304347826, 0.068181818181818
74175, 1.3086956521739, 0.72391304347826, 0.045454545454545
74176, 1.3304347826087, 0.75, 0.045454545454545
74177, 1.3304347826087, 0.72391304347826, 0.022727272727273
74178, 1.3739130434783, 0.72391304347826, 0.47727272727273
74179, 1.3521739130435, 0.72391304347826, 0.45454545454545
74180, 1.3739130434783, 0.75, 0.45454545454545
74181, 1.3739130434783, 0.72391304347826, 0.43181818181818
74182, 1.3521739130435, 0.72391304347826, 0.40909090909091
74183, 1.3739130434783, 0.75, 0.40909090909091
74184, 1.3739130434783, 0.72391304347826, 0.38636363636364
74185, 1.3521739130435, 0.72391304347826, 0.36363636363636
74186, 1.3739130434783, 0.75, 0.36363636363636
74187, 1.3739130434783, 0.72391304347826, 0.34090909090909
74188, 1.3521739130435, 0.72391304347826, 0.31818181818182
74189, 1.3739130434783, 0.75, 0.31818181818182
74190, 1.3739130434783, 0.72391304347826, 0.29545454545455
74191, 1.3521739130435, 0.72391304347826, 0.27272727272727
74192, 1.3739130434783, 0.75, 0.27272727272727
74193, 1.3739130434783, 0.72391304347826, 0.25
74194, 1.3521739130435, 0.72391304347826, 0.22727272727273
74195, 1.3739130434783, 0.75, 0.22727272727273
74196, 1.3739130434783, 0.72391304347826, 0.20454545454545
74197, 1.3521739130435, 0.72391304347826, 0.18181818181818
74198, 1.3739130434783, 0.75, 0.18181818181818
74199, 1.3739130434783, 0.72391304347826, 0.15909090909091
74200, 1.3521739130435, 0.72391304347826, 0.13636363636364
74201, 1.3739130434783, 0.75, 0.13636363636364
74202, 1.3739130434783, 0.72391304347826, 0.11363636363636
74203, 1.3521739130435, 0.72391304347826, 0.090909090909091
74204, 1.3739130434783, 0.75, 0.090909090909091
74205, 1.3739130434783, 0.72391304347826, 0.068181818181818
74206, 1.3521739130435, 0.72391304347826, 0.045454545454545
74207, 1.3739130434783, 0.75, 0.045454545454545
74208, 1.3739130434783, 0.72391304347826, 0.022727272727273
74209, 1.4173913043478, 0.72391304347826, 0.47727272727273
74210, 1.395652173913, 0.72391304347826, 0.45454545454545
74211, 1.4173913043478, 0.75, 0.45454545454545
74212, 1.4173913043478, 0.72391304347826, 0.43181818181818
74213, 1.395652173913, 0.72391304347826, 0.40909090909091
74214, 1.4173913043478, 0.75, 0.40909090909091
74215, 1.4173913043478, 0.72391304347826, 0.38636363636364
74216, 1.395652173913, 0.72391304347826, 0.36363636363636
74217, 1.4173913043478, 0.75, 0.36363636363636
74218, 1.4173913043478, 0.72391304347826, 0.34090909090909
74219, 1.395652173913, 0.72391304347826, 0.31818181818182
74220, 1.4173913043478, 0.75, 0.31818181818182
74221, 1.4173913043478, 0.72391304347826, 0.29545454545455
74222, 1.395652173913, 0.72391304347826, 0.27272727272727
74223, 1.4173913043478, 0.75, 0.27272727272727
74224, 1.4173913043478, 0.72391304347826, 0.25
74225, 1.395652173913, 0.72391304347826, 0.22727272727273
74226, 1.4173913043478, 0.75, 0.22727272727273
74227, 1.4173913043478, 0.72391304347826, 0.20454545454545
74228, 1.395652173913, 0.72391304347826, 0.18181818181818
74229, 1.4173913043478, 0.75, 0.18181818181818
74230, 1.4173913043478, 0.72391304347826, 0.15909090909091
74231, 1.395652173913, 0.72391304347826, 0.13636363636364
74232, 1.4173913043478, 0.75, 0.13636363636364
74233, 1.4173913043478, 0.72391304347826, 0.11363636363636
74234, 1.395652173913, 0.72391304347826, 0.090909090909091
74235, 1.4173913043478, 0.75, 0.090909090909091
74236, 1.4173913043478, 0.72391304347826, 0.068181818181818
74237, 1.395652173913, 0.72391304347826, 0.045454545454545
74238, 1.4173913043478, 0.75, 0.045454545454545
74239, 1.4173913043478, 0.72391304347826, 0.022727272727273
74240, 1.4608695652174, 0.72391304347826, 0.47727272727273
74241, 1.4391304347826, 0.72391304347826, 0.45454545454545
74242, 1.4608695652174, 0.75, 0.45454545454545
74243, 1.4608695652174, 0.72391304347826, 0.43181818181818
74244, 1.4391304347826, 0.72391304347826, 0.40909090909091
74245, 1.4608695652174, 0.75, 0.40909090909091
74246, 1.4608695652174, 0.72391304347826, 0.38636363636364
74247, 1.4391304347826, 0.72391304347826, 0.36363636363636
74248, 1.4608695652174, 0.75, 0.36363636363636
74249, 1.4608695652174, 0.72391304347826, 0.34090909090909
74250, 1.4391304347826, 0.72391304347826, 0.31818181818182
74251, 1.4608695652174, 0.75, 0.31818181818182
74252, 1.4608695652174, 0.72391304347826, 0.29545454545455
74253, 1.4391304347826, 0.72391304347826, 0.27272727272727
74254, 1.4608695652174, 0.75, 0.27272727272727
74255, 1.4608695652174, 0.72391304347826, 0.25
74256, 1.4391304347826, 0.72391304347826, 0.22727272727273
74257, 1.4608695652174, 0.75, 0.22727272727273
74258, 1.4608695652174, 0.72391304347826, 0.20454545454545
74259, 1.4391304347826, 0.72391304347826, 0.18181818181818
74260, 1.4608695652174, 0.75, 0.18181818181818
74261, 1.4608695652174, 0.72391304347826, 0.15909090909091
74262, 1.4391304347826, 0.72391304347826, 0.13636363636364
74263, 1.4608695652174, 0.75, 0.13636363636364
74264, 1.4608695652174, 0.72391304347826, 0.11363636363636
74265, 1.4391304347826, 0.72391304347826, 0.090909090909091
74266, 1.4608695652174, 0.75, 0.090909090909091
74267, 1.4608695652174, 0.72391304347826, 0.068181818181818
74268, 1.4391304347826, 0.72391304347826, 0.045454545454545
74269, 1.4608695652174, 0.75, 0.045454545454545
74270, 1.4608695652174, 0.72391304347826, 0.022727272727273
74271, 1.504347826087, 0.72391304347826, 0.47727272727273
74272, 1.4826086956522, 0.72391304347826, 0.45454545454545
74273, 1.504347826087, 0.75, 0.45454545454545
74274, 1.504347826087, 0.72391304347826, 0.43181818181818
74275, 1.4826086956522, 0.72391304347826, 0.40909090909091
74276, 1.504347826087, 0.75, 0.40909090909091
74277, 1.504347826087, 0.72391304347826, 0.38636363636364
74278, 1.4826086956522, 0.72391304347826, 0.36363636363636
74279, 1.504347826087, 0.75, 0.36363636363636
74280, 1.504347826087, 0.72391304347826, 0.34090909090909
74281, 1.4826086956522, 0.72391304347826, 0.31818181818182
74282, 1.504347826087, 0.75, 0.31818181818182
74283, 1.504347826087, 0.72391304347826, 0.29545454545455
74284, 1.4826086956522, 0.72391304347826, 0.27272727272727
74285, 1.504347826087, 0.75, 0.27272727272727
74286, 1.504347826087, 0.72391304347826, 0.25
74287, 1.4826086956522, 0.72391304347826, 0.22727272727273
74288, 1.504347826087, 0.75, 0.22727272727273
74289, 1.504347826087, 0.72391304347826, 0.20454545454545
74290, 1.4826086956522, 0.72391304347826, 0.18181818181818
74291, 1.504347826087, 0.75, 0.18181818181818
74292, 1.504347826087, 0.72391304347826, 0.15909090909091
74293, 1.4826086956522, 0.72391304347826, 0.13636363636364
74294, 1.504347826087, 0.75, 0.13636363636364
74295, 1.504347826087, 0.72391304347826, 0.11363636363636
74296, 1.4826086956522, 0.72391304347826, 0.090909090909091
74297, 1.504347826087, 0.75, 0.090909090909091
74298, 1.504347826087, 0.72391304347826, 0.068181818181818
74299, 1.4826086956522, 0.72391304347826, 0.045454545454545
74300, 1.504347826087, 0.75, 0.045454545454545
74301, 1.504347826087, 0.72391304347826, 0.022727272727273
74302, 1.5478260869565, 0.72391304347826, 0.47727272727273
74303, 1.5260869565217, 0.72391304347826, 0.45454545454545
74304, 1.5478260869565, 0.75, 0.45454545454545
74305, 1.5478260869565, 0.72391304347826, 0.43181818181818
74306, 1.5260869565217, 0.72391304347826, 0.40909090909091
74307, 1.5478260869565, 0.75, 0.40909090909091
74308, 1.5478260869565, 0.72391304347826, 0.38636363636364
74309, 1.5260869565217, 0.72391304347826, 0.36363636363636
74310, 1.5478260869565, 0.75, 0.36363636363636
74311, 1.5478260869565, 0.72391304347826, 0.34090909090909
74312, 1.5260869565217, 0.72391304347826, 0.31818181818182
74313, 1.5478260869565, 0.75, 0.31818181818182
74314, 1.5478260869565, 0.72391304347826, 0.29545454545455
74315, 1.5260869565217, 0.72391304347826, 0.27272727272727
74316, 1.5478260869565, 0.75, 0.27272727272727
74317, 1.5478260869565, 0.72391304347826, 0.25
74318, 1.5260869565217, 0.72391304347826, 0.22727272727273
74319, 1.5478260869565, 0.75, 0.22727272727273
74320, 1.5478260869565, 0.72391304347826, 0.20454545454545
74321, 1.5260869565217, 0.72391304347826, 0.18181818181818
74322, 1.5478260869565, 0.75, 0.18181818181818
74323, 1.5478260869565, 0.72391304347826, 0.15909090909091
74324, 1.5260869565217, 0.72391304347826, 0.13636363636364
74325, 1.5478260869565, 0.75, 0.13636363636364
74326, 1.5478260869565, 0.72391304347826, 0.11363636363636
74327, 1.5260869565217, 0.72391304347826, 0.090909090909091
74328, 1.5478260869565, 0.75, 0.090909090909091
74329, 1.5478260869565, 0.72391304347826, 0.068181818181818
74330, 1.5260869565217, 0.72391304347826, 0.045454545454545
74331, 1.5478260869565, 0.75, 0.045454545454545
74332, 1.5478260869565, 0.72391304347826, 0.022727272727273
74333, 1.5913043478261, 0.72391304347826, 0.47727272727273
74334, 1.5695652173913, 0.72391304347826, 0.45454545454545
74335, 1.5913043478261, 0.75, 0.45454545454545
74336, 1.5913043478261, 0.72391304347826, 0.43181818181818
74337, 1.5695652173913, 0.72391304347826, 0.40909090909091
74338, 1.5913043478261, 0.75, 0.40909090909091
74339, 1.5913043478261, 0.72391304347826, 0.38636363636364
74340, 1.5695652173913, 0.72391304347826, 0.36363636363636
74341, 1.5913043478261, 0.75, 0.36363636363636
74342, 1.5913043478261, 0.72391304347826, 0.34090909090909
74343, 1.5695652173913, 0.72391304347826, 0.31818181818182
74344, 1.5913043478261, 0.75, 0.31818181818182
74345, 1.5913043478261, 0.72391304347826, 0.29545454545455
74346, 1.5695652173913, 0.72391304347826, 0.27272727272727
74347, 1.5913043478261, 0.75, 0.27272727272727
74348, 1.5913043478261, 0.72391304347826, 0.25
74349, 1.5695652173913, 0.72391304347826, 0.22727272727273
74350, 1.5913043478261, 0.75, 0.22727272727273
74351, 1.5913043478261, 0.72391304347826, 0.20454545454545
74352, 1.5695652173913, 0.72391304347826, 0.18181818181818
74353, 1.5913043478261, 0.75, 0.18181818181818
74354, 1.5913043478261, 0.72391304347826, 0.15909090909091
74355, 1.5695652173913, 0.72391304347826, 0.13636363636364
74356, 1.5913043478261, 0.75, 0.13636363636364
74357, 1.5913043478261, 0.72391304347826, 0.11363636363636
74358, 1.5695652173913, 0.72391304347826, 0.090909090909091
74359, 1.5913043478261, 0.75, 0.090909090909091
74360, 1.5913043478261, 0.72391304347826, 0.068181818181818
74361, 1.5695652173913, 0.72391304347826, 0.045454545454545
74362, 1.5913043478261, 0.75, 0.045454545454545
74363, 1.5913043478261, 0.72391304347826, 0.022727272727273
74364, 1.6347826086957, 0.72391304347826, 0.47727272727273
74365, 1.6130434782609, 0.72391304347826, 0.45454545454545
74366, 1.6347826086957, 0.75, 0.45454545454545
74367, 1.6347826086957, 0.72391304347826, 0.43181818181818
74368, 1.6130434782609, 0.72391304347826, 0.40909090909091
74369, 1.6347826086957, 0.75, 0.40909090909091
74370, 1.6347826086957, 0.72391304347826, 0.38636363636364
74371, 1.6130434782609, 0.72391304347826, 0.36363636363636
74372, 1.6347826086957, 0.75, 0.36363636363636
74373, 1.6347826086957, 0.72391304347826, 0.34090909090909
74374, 1.6130434782609, 0.72391304347826, 0.31818181818182
74375, 1.6347826086957, 0.75, 0.31818181818182
74376, 1.6347826086957, 0.72391304347826, 0.29545454545455
74377, 1.6130434782609, 0.72391304347826, 0.27272727272727
74378, 1.6347826086957, 0.75, 0.27272727272727
74379, 1.6347826086957, 0.72391304347826, 0.25
74380, 1.6130434782609, 0.72391304347826, 0.22727272727273
74381, 1.6347826086957, 0.75, 0.22727272727273
74382, 1.6347826086957, 0.72391304347826, 0.20454545454545
74383, 1.6130434782609, 0.72391304347826, 0.18181818181818
74384, 1.6347826086957, 0.75, 0.18181818181818
74385, 1.6347826086957, 0.72391304347826, 0.15909090909091
74386, 1.6130434782609, 0.72391304347826, 0.13636363636364
74387, 1.6347826086957, 0.75, 0.13636363636364
74388, 1.6347826086957, 0.72391304347826, 0.11363636363636
74389, 1.6130434782609, 0.72391304347826, 0.090909090909091
74390, 1.6347826086957, 0.75, 0.090909090909091
74391, 1.6347826086957, 0.72391304347826, 0.068181818181818
74392, 1.6130434782609, 0.72391304347826, 0.045454545454545
74393, 1.6347826086957, 0.75, 0.045454545454545
74394, 1.6347826086957, 0.72391304347826, 0.022727272727273
74395, 1.6782608695652, 0.72391304347826, 0.47727272727273
74396, 1.6565217391304, 0.72391304347826, 0.45454545454545
74397, 1.6782608695652, 0.75, 0.45454545454545
74398, 1.6782608695652, 0.72391304347826, 0.43181818181818
74399, 1.6565217391304, 0.72391304347826, 0.40909090909091
74400, 1.6782608695652, 0.75, 0.40909090909091
74401, 1.6782608695652, 0.72391304347826, 0.38636363636364
74402, 1.6565217391304, 0.72391304347826, 0.36363636363636
74403, 1.6782608695652, 0.75, 0.36363636363636
74404, 1.6782608695652, 0.72391304347826, 0.34090909090909
74405, 1.6565217391304, 0.72391304347826, 0.31818181818182
74406, 1.6782608695652, 0.75, 0.31818181818182
74407, 1.6782608695652, 0.72391304347826, 0.29545454545455
74408, 1.6565217391304, 0.72391304347826, 0.27272727272727
74409, 1.6782608695652, 0.75, 0.27272727272727
74410, 1.6782608695652, 0.72391304347826, 0.25
74411, 1.6565217391304, 0.72391304347826, 0.22727272727273
74412, 1.6782608695652, 0.75, 0.22727272727273
74413, 1.6782608695652, 0.72391304347826, 0.20454545454545
74414, 1.6565217391304, 0.72391304347826, 0.18181818181818
74415, 1.6782608695652, 0.75, 0.18181818181818
74416, 1.6782608695652, 0.72391304347826, 0.15909090909091
74417, 1.6565217391304, 0.72391304347826, 0.13636363636364
74418, 1.6782608695652, 0.75, 0.13636363636364
74419, 1.6782608695652, 0.72391304347826, 0.11363636363636
74420, 1.6565217391304, 0.72391304347826, 0.090909090909091
74421, 1.6782608695652, 0.75, 0.090909090909091
74422, 1.6782608695652, 0.72391304347826, 0.068181818181818
74423, 1.6565217391304, 0.72391304347826, 0.045454545454545
74424, 1.6782608695652, 0.75, 0.045454545454545
74425, 1.6782608695652, 0.72391304347826, 0.022727272727273
74426, 1.7217391304348, 0.72391304347826, 0.47727272727273
74427, 1.7, 0.72391304347826, 0.45454545454545
74428, 1.7217391304348, 0.75, 0.45454545454545
74429, 1.7217391304348, 0.72391304347826, 0.43181818181818
74430, 1.7, 0.72391304347826, 0.40909090909091
74431, 1.7217391304348, 0.75, 0.40909090909091
74432, 1.7217391304348, 0.72391304347826, 0.38636363636364
74433, 1.7, 0.72391304347826, 0.36363636363636
74434, 1.7217391304348, 0.75, 0.36363636363636
74435, 1.7217391304348, 0.72391304347826, 0.34090909090909
74436, 1.7, 0.72391304347826, 0.31818181818182
74437, 1.7217391304348, 0.75, 0.31818181818182
74438, 1.7217391304348, 0.72391304347826, 0.29545454545455
74439, 1.7, 0.72391304347826, 0.27272727272727
74440, 1.7217391304348, 0.75, 0.27272727272727
74441, 1.7217391304348, 0.72391304347826, 0.25
74442, 1.7, 0.72391304347826, 0.22727272727273
74443, 1.7217391304348, 0.75, 0.22727272727273
74444, 1.7217391304348, 0.72391304347826, 0.20454545454545
74445, 1.7, 0.72391304347826, 0.18181818181818
74446, 1.7217391304348, 0.75, 0.18181818181818
74447, 1.7217391304348, 0.72391304347826, 0.15909090909091
74448, 1.7, 0.72391304347826, 0.13636363636364
74449, 1.7217391304348, 0.75, 0.13636363636364
74450, 1.7217391304348, 0.72391304347826, 0.11363636363636
74451, 1.7, 0.72391304347826, 0.090909090909091
74452, 1.7217391304348, 0.75, 0.090909090909091
74453, 1.7217391304348, 0.72391304347826, 0.068181818181818
74454, 1.7, 0.72391304347826, 0.045454545454545
74455, 1.7217391304348, 0.75, 0.045454545454545
74456, 1.7217391304348, 0.72391304347826, 0.022727272727273
74457, 1.7652173913043, 0.72391304347826, 0.47727272727273
74458, 1.7434782608696, 0.72391304347826, 0.45454545454545
74459, 1.7652173913043, 0.75, 0.45454545454545
74460, 1.7652173913043, 0.72391304347826, 0.43181818181818
74461, 1.7434782608696, 0.72391304347826, 0.40909090909091
74462, 1.7652173913043, 0.75, 0.40909090909091
74463, 1.7652173913043, 0.72391304347826, 0.38636363636364
74464, 1.7434782608696, 0.72391304347826, 0.36363636363636
74465, 1.7652173913043, 0.75, 0.36363636363636
74466, 1.7652173913043, 0.72391304347826, 0.34090909090909
74467, 1.7434782608696, 0.72391304347826, 0.31818181818182
74468, 1.7652173913043, 0.75, 0.31818181818182
74469, 1.7652173913043, 0.72391304347826, 0.29545454545455
74470, 1.7434782608696, 0.72391304347826, 0.27272727272727
74471, 1.7652173913043, 0.75, 0.27272727272727
74472, 1.7652173913043, 0.72391304347826, 0.25
74473, 1.7434782608696, 0.72391304347826, 0.22727272727273
74474, 1.7652173913043, 0.75, 0.22727272727273
74475, 1.7652173913043, 0.72391304347826, 0.20454545454545
74476, 1.7434782608696, 0.72391304347826, 0.18181818181818
74477, 1.7652173913043, 0.75, 0.18181818181818
