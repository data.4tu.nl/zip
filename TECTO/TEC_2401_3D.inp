7793, 18341, 18342, 18364, 18363, 19252, 19296, 19297, 19294
7794, 18342, 18343, 18365, 18364, 19254, 19298, 19299, 19296
7795, 18343, 18344, 18366, 18365, 19256, 19300, 19301, 19298
7796, 18344, 18345, 18367, 18366, 19258, 19302, 19303, 19300
7797, 18345, 18346, 18368, 18367, 19260, 19304, 19305, 19302
7798, 18346, 18347, 18369, 18368, 19262, 19306, 19307, 19304
7799, 18347, 18348, 18370, 18369, 19264, 19308, 19309, 19306
7800, 18348, 18349, 18371, 18370, 19266, 19310, 19311, 19308
7801, 18349, 18350, 18372, 18371, 19268, 19312, 19313, 19310
7802, 18350, 18351, 18373, 18372, 19270, 19314, 19315, 19312
7803, 18351, 18352, 18374, 18373, 19272, 19316, 19317, 19314
7804, 18352, 1787, 1788, 18374, 19273, 1810, 19318, 19316
7805, 1743, 18353, 18375, 1744, 19275, 19319, 19320, 1766
7806, 18353, 18354, 18376, 18375, 19277, 19321, 19322, 19319
7807, 18354, 18355, 18377, 18376, 19279, 19323, 19324, 19321
7808, 18355, 18356, 18378, 18377, 19281, 19325, 19326, 19323
7809, 18356, 18357, 18379, 18378, 19283, 19327, 19328, 19325
7810, 18357, 18358, 18380, 18379, 19285, 19329, 19330, 19327
7811, 18358, 18359, 18381, 18380, 19287, 19331, 19332, 19329
7812, 18359, 18360, 18382, 18381, 19289, 19333, 19334, 19331
7813, 18360, 18361, 18383, 18382, 19291, 19335, 19336, 19333
7814, 18361, 18362, 18384, 18383, 19293, 19337, 19338, 19335
7815, 18362, 18363, 18385, 18384, 19295, 19339, 19340, 19337
7816, 18363, 18364, 18386, 18385, 19297, 19341, 19342, 19339
7817, 18364, 18365, 18387, 18386, 19299, 19343, 19344, 19341
7818, 18365, 18366, 18388, 18387, 19301, 19345, 19346, 19343
7819, 18366, 18367, 18389, 18388, 19303, 19347, 19348, 19345
7820, 18367, 18368, 18390, 18389, 19305, 19349, 19350, 19347
7821, 18368, 18369, 18391, 18390, 19307, 19351, 19352, 19349
7822, 18369, 18370, 18392, 18391, 19309, 19353, 19354, 19351
7823, 18370, 18371, 18393, 18392, 19311, 19355, 19356, 19353
7824, 18371, 18372, 18394, 18393, 19313, 19357, 19358, 19355
7825, 18372, 18373, 18395, 18394, 19315, 19359, 19360, 19357
7826, 18373, 18374, 18396, 18395, 19317, 19361, 19362, 19359
7827, 18374, 1788, 1789, 18396, 19318, 1811, 19363, 19361
7828, 1744, 18375, 18397, 1745, 19320, 19364, 19365, 1767
7829, 18375, 18376, 18398, 18397, 19322, 19366, 19367, 19364
7830, 18376, 18377, 18399, 18398, 19324, 19368, 19369, 19366
7831, 18377, 18378, 18400, 18399, 19326, 19370, 19371, 19368
7832, 18378, 18379, 18401, 18400, 19328, 19372, 19373, 19370
7833, 18379, 18380, 18402, 18401, 19330, 19374, 19375, 19372
7834, 18380, 18381, 18403, 18402, 19332, 19376, 19377, 19374
7835, 18381, 18382, 18404, 18403, 19334, 19378, 19379, 19376
7836, 18382, 18383, 18405, 18404, 19336, 19380, 19381, 19378
7837, 18383, 18384, 18406, 18405, 19338, 19382, 19383, 19380
7838, 18384, 18385, 18407, 18406, 19340, 19384, 19385, 19382
7839, 18385, 18386, 18408, 18407, 19342, 19386, 19387, 19384
7840, 18386, 18387, 18409, 18408, 19344, 19388, 19389, 19386
7841, 18387, 18388, 18410, 18409, 19346, 19390, 19391, 19388
7842, 18388, 18389, 18411, 18410, 19348, 19392, 19393, 19390
7843, 18389, 18390, 18412, 18411, 19350, 19394, 19395, 19392
7844, 18390, 18391, 18413, 18412, 19352, 19396, 19397, 19394
7845, 18391, 18392, 18414, 18413, 19354, 19398, 19399, 19396
7846, 18392, 18393, 18415, 18414, 19356, 19400, 19401, 19398
7847, 18393, 18394, 18416, 18415, 19358, 19402, 19403, 19400
7848, 18394, 18395, 18417, 18416, 19360, 19404, 19405, 19402
7849, 18395, 18396, 18418, 18417, 19362, 19406, 19407, 19404
7850, 18396, 1789, 1790, 18418, 19363, 1812, 19408, 19406
7851, 1745, 18397, 1814, 39, 19365, 19409, 1836, 1768
7852, 18397, 18398, 1815, 1814, 19367, 19410, 1837, 19409
7853, 18398, 18399, 1816, 1815, 19369, 19411, 1838, 19410
7854, 18399, 18400, 1817, 1816, 19371, 19412, 1839, 19411
7855, 18400, 18401, 1818, 1817, 19373, 19413, 1840, 19412
7856, 18401, 18402, 1819, 1818, 19375, 19414, 1841, 19413
7857, 18402, 18403, 1820, 1819, 19377, 19415, 1842, 19414
7858, 18403, 18404, 1821, 1820, 19379, 19416, 1843, 19415
7859, 18404, 18405, 1822, 1821, 19381, 19417, 1844, 19416
7860, 18405, 18406, 1823, 1822, 19383, 19418, 1845, 19417
7861, 18406, 18407, 1824, 1823, 19385, 19419, 1846, 19418
7862, 18407, 18408, 1825, 1824, 19387, 19420, 1847, 19419
7863, 18408, 18409, 1826, 1825, 19389, 19421, 1848, 19420
7864, 18409, 18410, 1827, 1826, 19391, 19422, 1849, 19421
7865, 18410, 18411, 1828, 1827, 19393, 19423, 1850, 19422
7866, 18411, 18412, 1829, 1828, 19395, 19424, 1851, 19423
7867, 18412, 18413, 1830, 1829, 19397, 19425, 1852, 19424
7868, 18413, 18414, 1831, 1830, 19399, 19426, 1853, 19425
7869, 18414, 18415, 1832, 1831, 19401, 19427, 1854, 19426
7870, 18415, 18416, 1833, 1832, 19403, 19428, 1855, 19427
7871, 18416, 18417, 1834, 1833, 19405, 19429, 1856, 19428
7872, 18417, 18418, 1835, 1834, 19407, 19430, 1857, 19429
7873, 18418, 1790, 40, 1835, 19408, 1813, 1858, 19430
*ELEMENT, type=CPS8, ELSET=Surface44
7874, 33, 1556, 19431, 1589, 1567, 19651, 19652, 1611
7875, 1556, 1555, 19432, 19431, 1566, 19653, 19654, 19651
7876, 1555, 1554, 19433, 19432, 1565, 19655, 19656, 19653
7877, 1554, 1553, 19434, 19433, 1564, 19657, 19658, 19655
7878, 1553, 1552, 19435, 19434, 1563, 19659, 19660, 19657
7879, 1552, 1551, 19436, 19435, 1562, 19661, 19662, 19659
7880, 1551, 1550, 19437, 19436, 1561, 19663, 19664, 19661
7881, 1550, 1549, 19438, 19437, 1560, 19665, 19666, 19663
7882, 1549, 1548, 19439, 19438, 1559, 19667, 19668, 19665
7883, 1548, 1547, 19440, 19439, 1558, 19669, 19670, 19667
7884, 1547, 35, 1724, 19440, 1557, 1746, 19671, 19669
7885, 1589, 19431, 19441, 1590, 19652, 19672, 19673, 1612
7886, 19431, 19432, 19442, 19441, 19654, 19674, 19675, 19672
7887, 19432, 19433, 19443, 19442, 19656, 19676, 19677, 19674
7888, 19433, 19434, 19444, 19443, 19658, 19678, 19679, 19676
7889, 19434, 19435, 19445, 19444, 19660, 19680, 19681, 19678
7890, 19435, 19436, 19446, 19445, 19662, 19682, 19683, 19680
7891, 19436, 19437, 19447, 19446, 19664, 19684, 19685, 19682
7892, 19437, 19438, 19448, 19447, 19666, 19686, 19687, 19684
7893, 19438, 19439, 19449, 19448, 19668, 19688, 19689, 19686
7894, 19439, 19440, 19450, 19449, 19670, 19690, 19691, 19688
7895, 19440, 1724, 1725, 19450, 19671, 1747, 19692, 19690
7896, 1590, 19441, 19451, 1591, 19673, 19693, 19694, 1613
7897, 19441, 19442, 19452, 19451, 19675, 19695, 19696, 19693
7898, 19442, 19443, 19453, 19452, 19677, 19697, 19698, 19695
7899, 19443, 19444, 19454, 19453, 19679, 19699, 19700, 19697
7900, 19444, 19445, 19455, 19454, 19681, 19701, 19702, 19699
7901, 19445, 19446, 19456, 19455, 19683, 19703, 19704, 19701
7902, 19446, 19447, 19457, 19456, 19685, 19705, 19706, 19703
7903, 19447, 19448, 19458, 19457, 19687, 19707, 19708, 19705
7904, 19448, 19449, 19459, 19458, 19689, 19709, 19710, 19707
7905, 19449, 19450, 19460, 19459, 19691, 19711, 19712, 19709
7906, 19450, 1725, 1726, 19460, 19692, 1748, 19713, 19711
7907, 1591, 19451, 19461, 1592, 19694, 19714, 19715, 1614
7908, 19451, 19452, 19462, 19461, 19696, 19716, 19717, 19714
7909, 19452, 19453, 19463, 19462, 19698, 19718, 19719, 19716
7910, 19453, 19454, 19464, 19463, 19700, 19720, 19721, 19718
7911, 19454, 19455, 19465, 19464, 19702, 19722, 19723, 19720
7912, 19455, 19456, 19466, 19465, 19704, 19724, 19725, 19722
7913, 19456, 19457, 19467, 19466, 19706, 19726, 19727, 19724
7914, 19457, 19458, 19468, 19467, 19708, 19728, 19729, 19726
7915, 19458, 19459, 19469, 19468, 19710, 19730, 19731, 19728
7916, 19459, 19460, 19470, 19469, 19712, 19732, 19733, 19730
7917, 19460, 1726, 1727, 19470, 19713, 1749, 19734, 19732
7918, 1592, 19461, 19471, 1593, 19715, 19735, 19736, 1615
7919, 19461, 19462, 19472, 19471, 19717, 19737, 19738, 19735
7920, 19462, 19463, 19473, 19472, 19719, 19739, 19740, 19737
7921, 19463, 19464, 19474, 19473, 19721, 19741, 19742, 19739
7922, 19464, 19465, 19475, 19474, 19723, 19743, 19744, 19741
7923, 19465, 19466, 19476, 19475, 19725, 19745, 19746, 19743
7924, 19466, 19467, 19477, 19476, 19727, 19747, 19748, 19745
7925, 19467, 19468, 19478, 19477, 19729, 19749, 19750, 19747
7926, 19468, 19469, 19479, 19478, 19731, 19751, 19752, 19749
7927, 19469, 19470, 19480, 19479, 19733, 19753, 19754, 19751
7928, 19470, 1727, 1728, 19480, 19734, 1750, 19755, 19753
7929, 1593, 19471, 19481, 1594, 19736, 19756, 19757, 1616
7930, 19471, 19472, 19482, 19481, 19738, 19758, 19759, 19756
7931, 19472, 19473, 19483, 19482, 19740, 19760, 19761, 19758
7932, 19473, 19474, 19484, 19483, 19742, 19762, 19763, 19760
7933, 19474, 19475, 19485, 19484, 19744, 19764, 19765, 19762
7934, 19475, 19476, 19486, 19485, 19746, 19766, 19767, 19764
7935, 19476, 19477, 19487, 19486, 19748, 19768, 19769, 19766
7936, 19477, 19478, 19488, 19487, 19750, 19770, 19771, 19768
7937, 19478, 19479, 19489, 19488, 19752, 19772, 19773, 19770
7938, 19479, 19480, 19490, 19489, 19754, 19774, 19775, 19772
7939, 19480, 1728, 1729, 19490, 19755, 1751, 19776, 19774
7940, 1594, 19481, 19491, 1595, 19757, 19777, 19778, 1617
7941, 19481, 19482, 19492, 19491, 19759, 19779, 19780, 19777
7942, 19482, 19483, 19493, 19492, 19761, 19781, 19782, 19779
7943, 19483, 19484, 19494, 19493, 19763, 19783, 19784, 19781
7944, 19484, 19485, 19495, 19494, 19765, 19785, 19786, 19783
7945, 19485, 19486, 19496, 19495, 19767, 19787, 19788, 19785
7946, 19486, 19487, 19497, 19496, 19769, 19789, 19790, 19787
7947, 19487, 19488, 19498, 19497, 19771, 19791, 19792, 19789
7948, 19488, 19489, 19499, 19498, 19773, 19793, 19794, 19791
7949, 19489, 19490, 19500, 19499, 19775, 19795, 19796, 19793
7950, 19490, 1729, 1730, 19500, 19776, 1752, 19797, 19795
7951, 1595, 19491, 19501, 1596, 19778, 19798, 19799, 1618
7952, 19491, 19492, 19502, 19501, 19780, 19800, 19801, 19798
7953, 19492, 19493, 19503, 19502, 19782, 19802, 19803, 19800
7954, 19493, 19494, 19504, 19503, 19784, 19804, 19805, 19802
7955, 19494, 19495, 19505, 19504, 19786, 19806, 19807, 19804
7956, 19495, 19496, 19506, 19505, 19788, 19808, 19809, 19806
7957, 19496, 19497, 19507, 19506, 19790, 19810, 19811, 19808
7958, 19497, 19498, 19508, 19507, 19792, 19812, 19813, 19810
7959, 19498, 19499, 19509, 19508, 19794, 19814, 19815, 19812
7960, 19499, 19500, 19510, 19509, 19796, 19816, 19817, 19814
7961, 19500, 1730, 1731, 19510, 19797, 1753, 19818, 19816
7962, 1596, 19501, 19511, 1597, 19799, 19819, 19820, 1619
7963, 19501, 19502, 19512, 19511, 19801, 19821, 19822, 19819
7964, 19502, 19503, 19513, 19512, 19803, 19823, 19824, 19821
7965, 19503, 19504, 19514, 19513, 19805, 19825, 19826, 19823
7966, 19504, 19505, 19515, 19514, 19807, 19827, 19828, 19825
7967, 19505, 19506, 19516, 19515, 19809, 19829, 19830, 19827
7968, 19506, 19507, 19517, 19516, 19811, 19831, 19832, 19829
7969, 19507, 19508, 19518, 19517, 19813, 19833, 19834, 19831
7970, 19508, 19509, 19519, 19518, 19815, 19835, 19836, 19833
7971, 19509, 19510, 19520, 19519, 19817, 19837, 19838, 19835
7972, 19510, 1731, 1732, 19520, 19818, 1754, 19839, 19837
7973, 1597, 19511, 19521, 1598, 19820, 19840, 19841, 1620
7974, 19511, 19512, 19522, 19521, 19822, 19842, 19843, 19840
7975, 19512, 19513, 19523, 19522, 19824, 19844, 19845, 19842
7976, 19513, 19514, 19524, 19523, 19826, 19846, 19847, 19844
7977, 19514, 19515, 19525, 19524, 19828, 19848, 19849, 19846
7978, 19515, 19516, 19526, 19525, 19830, 19850, 19851, 19848
7979, 19516, 19517, 19527, 19526, 19832, 19852, 19853, 19850
7980, 19517, 19518, 19528, 19527, 19834, 19854, 19855, 19852
7981, 19518, 19519, 19529, 19528, 19836, 19856, 19857, 19854
7982, 19519, 19520, 19530, 19529, 19838, 19858, 19859, 19856
7983, 19520, 1732, 1733, 19530, 19839, 1755, 19860, 19858
7984, 1598, 19521, 19531, 1599, 19841, 19861, 19862, 1621
7985, 19521, 19522, 19532, 19531, 19843, 19863, 19864, 19861
7986, 19522, 19523, 19533, 19532, 19845, 19865, 19866, 19863
7987, 19523, 19524, 19534, 19533, 19847, 19867, 19868, 19865
7988, 19524, 19525, 19535, 19534, 19849, 19869, 19870, 19867
7989, 19525, 19526, 19536, 19535, 19851, 19871, 19872, 19869
7990, 19526, 19527, 19537, 19536, 19853, 19873, 19874, 19871
7991, 19527, 19528, 19538, 19537, 19855, 19875, 19876, 19873
7992, 19528, 19529, 19539, 19538, 19857, 19877, 19878, 19875
7993, 19529, 19530, 19540, 19539, 19859, 19879, 19880, 19877
7994, 19530, 1733, 1734, 19540, 19860, 1756, 19881, 19879
7995, 1599, 19531, 19541, 1600, 19862, 19882, 19883, 1622
7996, 19531, 19532, 19542, 19541, 19864, 19884, 19885, 19882
7997, 19532, 19533, 19543, 19542, 19866, 19886, 19887, 19884
7998, 19533, 19534, 19544, 19543, 19868, 19888, 19889, 19886
7999, 19534, 19535, 19545, 19544, 19870, 19890, 19891, 19888
8000, 19535, 19536, 19546, 19545, 19872, 19892, 19893, 19890
8001, 19536, 19537, 19547, 19546, 19874, 19894, 19895, 19892
8002, 19537, 19538, 19548, 19547, 19876, 19896, 19897, 19894
8003, 19538, 19539, 19549, 19548, 19878, 19898, 19899, 19896
8004, 19539, 19540, 19550, 19549, 19880, 19900, 19901, 19898
8005, 19540, 1734, 1735, 19550, 19881, 1757, 19902, 19900
8006, 1600, 19541, 19551, 1601, 19883, 19903, 19904, 1623
8007, 19541, 19542, 19552, 19551, 19885, 19905, 19906, 19903
8008, 19542, 19543, 19553, 19552, 19887, 19907, 19908, 19905
8009, 19543, 19544, 19554, 19553, 19889, 19909, 19910, 19907
8010, 19544, 19545, 19555, 19554, 19891, 19911, 19912, 19909
8011, 19545, 19546, 19556, 19555, 19893, 19913, 19914, 19911
8012, 19546, 19547, 19557, 19556, 19895, 19915, 19916, 19913
8013, 19547, 19548, 19558, 19557, 19897, 19917, 19918, 19915
8014, 19548, 19549, 19559, 19558, 19899, 19919, 19920, 19917
8015, 19549, 19550, 19560, 19559, 19901, 19921, 19922, 19919
8016, 19550, 1735, 1736, 19560, 19902, 1758, 19923, 19921
8017, 1601, 19551, 19561, 1602, 19904, 19924, 19925, 1624
8018, 19551, 19552, 19562, 19561, 19906, 19926, 19927, 19924
8019, 19552, 19553, 19563, 19562, 19908, 19928, 19929, 19926
8020, 19553, 19554, 19564, 19563, 19910, 19930, 19931, 19928
8021, 19554, 19555, 19565, 19564, 19912, 19932, 19933, 19930
8022, 19555, 19556, 19566, 19565, 19914, 19934, 19935, 19932
8023, 19556, 19557, 19567, 19566, 19916, 19936, 19937, 19934
8024, 19557, 19558, 19568, 19567, 19918, 19938, 19939, 19936
8025, 19558, 19559, 19569, 19568, 19920, 19940, 19941, 19938
8026, 19559, 19560, 19570, 19569, 19922, 19942, 19943, 19940
8027, 19560, 1736, 1737, 19570, 19923, 1759, 19944, 19942
8028, 1602, 19561, 19571, 1603, 19925, 19945, 19946, 1625
8029, 19561, 19562, 19572, 19571, 19927, 19947, 19948, 19945
8030, 19562, 19563, 19573, 19572, 19929, 19949, 19950, 19947
8031, 19563, 19564, 19574, 19573, 19931, 19951, 19952, 19949
8032, 19564, 19565, 19575, 19574, 19933, 19953, 19954, 19951
8033, 19565, 19566, 19576, 19575, 19935, 19955, 19956, 19953
8034, 19566, 19567, 19577, 19576, 19937, 19957, 19958, 19955
8035, 19567, 19568, 19578, 19577, 19939, 19959, 19960, 19957
8036, 19568, 19569, 19579, 19578, 19941, 19961, 19962, 19959
8037, 19569, 19570, 19580, 19579, 19943, 19963, 19964, 19961
8038, 19570, 1737, 1738, 19580, 19944, 1760, 19965, 19963
8039, 1603, 19571, 19581, 1604, 19946, 19966, 19967, 1626
8040, 19571, 19572, 19582, 19581, 19948, 19968, 19969, 19966
8041, 19572, 19573, 19583, 19582, 19950, 19970, 19971, 19968
8042, 19573, 19574, 19584, 19583, 19952, 19972, 19973, 19970
8043, 19574, 19575, 19585, 19584, 19954, 19974, 19975, 19972
8044, 19575, 19576, 19586, 19585, 19956, 19976, 19977, 19974
8045, 19576, 19577, 19587, 19586, 19958, 19978, 19979, 19976
8046, 19577, 19578, 19588, 19587, 19960, 19980, 19981, 19978
8047, 19578, 19579, 19589, 19588, 19962, 19982, 19983, 19980
8048, 19579, 19580, 19590, 19589, 19964, 19984, 19985, 19982
8049, 19580, 1738, 1739, 19590, 19965, 1761, 19986, 19984
8050, 1604, 19581, 19591, 1605, 19967, 19987, 19988, 1627
8051, 19581, 19582, 19592, 19591, 19969, 19989, 19990, 19987
8052, 19582, 19583, 19593, 19592, 19971, 19991, 19992, 19989
8053, 19583, 19584, 19594, 19593, 19973, 19993, 19994, 19991
8054, 19584, 19585, 19595, 19594, 19975, 19995, 19996, 19993
8055, 19585, 19586, 19596, 19595, 19977, 19997, 19998, 19995
8056, 19586, 19587, 19597, 19596, 19979, 19999, 20000, 19997
8057, 19587, 19588, 19598, 19597, 19981, 20001, 20002, 19999
8058, 19588, 19589, 19599, 19598, 19983, 20003, 20004, 20001
8059, 19589, 19590, 19600, 19599, 19985, 20005, 20006, 20003
8060, 19590, 1739, 1740, 19600, 19986, 1762, 20007, 20005
8061, 1605, 19591, 19601, 1606, 19988, 20008, 20009, 1628
8062, 19591, 19592, 19602, 19601, 19990, 20010, 20011, 20008
8063, 19592, 19593, 19603, 19602, 19992, 20012, 20013, 20010
8064, 19593, 19594, 19604, 19603, 19994, 20014, 20015, 20012
8065, 19594, 19595, 19605, 19604, 19996, 20016, 20017, 20014
8066, 19595, 19596, 19606, 19605, 19998, 20018, 20019, 20016
8067, 19596, 19597, 19607, 19606, 20000, 20020, 20021, 20018
8068, 19597, 19598, 19608, 19607, 20002, 20022, 20023, 20020
8069, 19598, 19599, 19609, 19608, 20004, 20024, 20025, 20022
8070, 19599, 19600, 19610, 19609, 20006, 20026, 20027, 20024
8071, 19600, 1740, 1741, 19610, 20007, 1763, 20028, 20026
8072, 1606, 19601, 19611, 1607, 20009, 20029, 20030, 1629
8073, 19601, 19602, 19612, 19611, 20011, 20031, 20032, 20029
8074, 19602, 19603, 19613, 19612, 20013, 20033, 20034, 20031
8075, 19603, 19604, 19614, 19613, 20015, 20035, 20036, 20033
8076, 19604, 19605, 19615, 19614, 20017, 20037, 20038, 20035
8077, 19605, 19606, 19616, 19615, 20019, 20039, 20040, 20037
8078, 19606, 19607, 19617, 19616, 20021, 20041, 20042, 20039
8079, 19607, 19608, 19618, 19617, 20023, 20043, 20044, 20041
8080, 19608, 19609, 19619, 19618, 20025, 20045, 20046, 20043
8081, 19609, 19610, 19620, 19619, 20027, 20047, 20048, 20045
8082, 19610, 1741, 1742, 19620, 20028, 1764, 20049, 20047
8083, 1607, 19611, 19621, 1608, 20030, 20050, 20051, 1630
8084, 19611, 19612, 19622, 19621, 20032, 20052, 20053, 20050
8085, 19612, 19613, 19623, 19622, 20034, 20054, 20055, 20052
8086, 19613, 19614, 19624, 19623, 20036, 20056, 20057, 20054
8087, 19614, 19615, 19625, 19624, 20038, 20058, 20059, 20056
8088, 19615, 19616, 19626, 19625, 20040, 20060, 20061, 20058
8089, 19616, 19617, 19627, 19626, 20042, 20062, 20063, 20060
8090, 19617, 19618, 19628, 19627, 20044, 20064, 20065, 20062
8091, 19618, 19619, 19629, 19628, 20046, 20066, 20067, 20064
8092, 19619, 19620, 19630, 19629, 20048, 20068, 20069, 20066
8093, 19620, 1742, 1743, 19630, 20049, 1765, 20070, 20068
8094, 1608, 19621, 19631, 1609, 20051, 20071, 20072, 1631
8095, 19621, 19622, 19632, 19631, 20053, 20073, 20074, 20071
8096, 19622, 19623, 19633, 19632, 20055, 20075, 20076, 20073
8097, 19623, 19624, 19634, 19633, 20057, 20077, 20078, 20075
8098, 19624, 19625, 19635, 19634, 20059, 20079, 20080, 20077
8099, 19625, 19626, 19636, 19635, 20061, 20081, 20082, 20079
8100, 19626, 19627, 19637, 19636, 20063, 20083, 20084, 20081
8101, 19627, 19628, 19638, 19637, 20065, 20085, 20086, 20083
8102, 19628, 19629, 19639, 19638, 20067, 20087, 20088, 20085
8103, 19629, 19630, 19640, 19639, 20069, 20089, 20090, 20087
8104, 19630, 1743, 1744, 19640, 20070, 1766, 20091, 20089
8105, 1609, 19631, 19641, 1610, 20072, 20092, 20093, 1632
8106, 19631, 19632, 19642, 19641, 20074, 20094, 20095, 20092
8107, 19632, 19633, 19643, 19642, 20076, 20096, 20097, 20094
8108, 19633, 19634, 19644, 19643, 20078, 20098, 20099, 20096
8109, 19634, 19635, 19645, 19644, 20080, 20100, 20101, 20098
8110, 19635, 19636, 19646, 19645, 20082, 20102, 20103, 20100
8111, 19636, 19637, 19647, 19646, 20084, 20104, 20105, 20102
8112, 19637, 19638, 19648, 19647, 20086, 20106, 20107, 20104
8113, 19638, 19639, 19649, 19648, 20088, 20108, 20109, 20106
8114, 19639, 19640, 19650, 19649, 20090, 20110, 20111, 20108
8115, 19640, 1744, 1745, 19650, 20091, 1767, 20112, 20110
8116, 1610, 19641, 1868, 37, 20093, 20113, 1879, 1633
8117, 19641, 19642, 1867, 1868, 20095, 20114, 1878, 20113
8118, 19642, 19643, 1866, 1867, 20097, 20115, 1877, 20114
8119, 19643, 19644, 1865, 1866, 20099, 20116, 1876, 20115
8120, 19644, 19645, 1864, 1865, 20101, 20117, 1875, 20116
8121, 19645, 19646, 1863, 1864, 20103, 20118, 1874, 20117
8122, 19646, 19647, 1862, 1863, 20105, 20119, 1873, 20118
8123, 19647, 19648, 1861, 1862, 20107, 20120, 1872, 20119
8124, 19648, 19649, 1860, 1861, 20109, 20121, 1871, 20120
8125, 19649, 19650, 1859, 1860, 20111, 20122, 1870, 20121
8126, 19650, 1745, 39, 1859, 20112, 1768, 1869, 20122
*ELEMENT, type=CPS8, ELSET=Surface45
8127, 34, 1634, 20123, 1577, 1656, 20343, 20344, 1588
8128, 1577, 20123, 20124, 1576, 20344, 20345, 20346, 1587
8129, 1576, 20124, 20125, 1575, 20346, 20347, 20348, 1586
8130, 1575, 20125, 20126, 1574, 20348, 20349, 20350, 1585
8131, 1574, 20126, 20127, 1573, 20350, 20351, 20352, 1584
8132, 1573, 20127, 20128, 1572, 20352, 20353, 20354, 1583
8133, 1572, 20128, 20129, 1571, 20354, 20355, 20356, 1582
8134, 1571, 20129, 20130, 1570, 20356, 20357, 20358, 1581
8135, 1570, 20130, 20131, 1569, 20358, 20359, 20360, 1580
8136, 1569, 20131, 20132, 1568, 20360, 20361, 20362, 1579
8137, 1568, 20132, 1769, 36, 20362, 20363, 1791, 1578
8138, 1634, 1635, 20133, 20123, 1657, 20364, 20365, 20343
8139, 20123, 20133, 20134, 20124, 20365, 20366, 20367, 20345
8140, 20124, 20134, 20135, 20125, 20367, 20368, 20369, 20347
8141, 20125, 20135, 20136, 20126, 20369, 20370, 20371, 20349
8142, 20126, 20136, 20137, 20127, 20371, 20372, 20373, 20351
8143, 20127, 20137, 20138, 20128, 20373, 20374, 20375, 20353
8144, 20128, 20138, 20139, 20129, 20375, 20376, 20377, 20355
8145, 20129, 20139, 20140, 20130, 20377, 20378, 20379, 20357
8146, 20130, 20140, 20141, 20131, 20379, 20380, 20381, 20359
8147, 20131, 20141, 20142, 20132, 20381, 20382, 20383, 20361
8148, 20132, 20142, 1770, 1769, 20383, 20384, 1792, 20363
8149, 1635, 1636, 20143, 20133, 1658, 20385, 20386, 20364
8150, 20133, 20143, 20144, 20134, 20386, 20387, 20388, 20366
8151, 20134, 20144, 20145, 20135, 20388, 20389, 20390, 20368
8152, 20135, 20145, 20146, 20136, 20390, 20391, 20392, 20370
8153, 20136, 20146, 20147, 20137, 20392, 20393, 20394, 20372
8154, 20137, 20147, 20148, 20138, 20394, 20395, 20396, 20374
8155, 20138, 20148, 20149, 20139, 20396, 20397, 20398, 20376
8156, 20139, 20149, 20150, 20140, 20398, 20399, 20400, 20378
8157, 20140, 20150, 20151, 20141, 20400, 20401, 20402, 20380
8158, 20141, 20151, 20152, 20142, 20402, 20403, 20404, 20382
8159, 20142, 20152, 1771, 1770, 20404, 20405, 1793, 20384
8160, 1636, 1637, 20153, 20143, 1659, 20406, 20407, 20385
8161, 20143, 20153, 20154, 20144, 20407, 20408, 20409, 20387
8162, 20144, 20154, 20155, 20145, 20409, 20410, 20411, 20389
8163, 20145, 20155, 20156, 20146, 20411, 20412, 20413, 20391
8164, 20146, 20156, 20157, 20147, 20413, 20414, 20415, 20393
8165, 20147, 20157, 20158, 20148, 20415, 20416, 20417, 20395
8166, 20148, 20158, 20159, 20149, 20417, 20418, 20419, 20397
8167, 20149, 20159, 20160, 20150, 20419, 20420, 20421, 20399
8168, 20150, 20160, 20161, 20151, 20421, 20422, 20423, 20401
8169, 20151, 20161, 20162, 20152, 20423, 20424, 20425, 20403
8170, 20152, 20162, 1772, 1771, 20425, 20426, 1794, 20405
8171, 1637, 1638, 20163, 20153, 1660, 20427, 20428, 20406
8172, 20153, 20163, 20164, 20154, 20428, 20429, 20430, 20408
8173, 20154, 20164, 20165, 20155, 20430, 20431, 20432, 20410
8174, 20155, 20165, 20166, 20156, 20432, 20433, 20434, 20412
8175, 20156, 20166, 20167, 20157, 20434, 20435, 20436, 20414
8176, 20157, 20167, 20168, 20158, 20436, 20437, 20438, 20416
8177, 20158, 20168, 20169, 20159, 20438, 20439, 20440, 20418
8178, 20159, 20169, 20170, 20160, 20440, 20441, 20442, 20420
8179, 20160, 20170, 20171, 20161, 20442, 20443, 20444, 20422
8180, 20161, 20171, 20172, 20162, 20444, 20445, 20446, 20424
8181, 20162, 20172, 1773, 1772, 20446, 20447, 1795, 20426
8182, 1638, 1639, 20173, 20163, 1661, 20448, 20449, 20427
8183, 20163, 20173, 20174, 20164, 20449, 20450, 20451, 20429
8184, 20164, 20174, 20175, 20165, 20451, 20452, 20453, 20431
8185, 20165, 20175, 20176, 20166, 20453, 20454, 20455, 20433
8186, 20166, 20176, 20177, 20167, 20455, 20456, 20457, 20435
8187, 20167, 20177, 20178, 20168, 20457, 20458, 20459, 20437
8188, 20168, 20178, 20179, 20169, 20459, 20460, 20461, 20439
8189, 20169, 20179, 20180, 20170, 20461, 20462, 20463, 20441
8190, 20170, 20180, 20181, 20171, 20463, 20464, 20465, 20443
8191, 20171, 20181, 20182, 20172, 20465, 20466, 20467, 20445
8192, 20172, 20182, 1774, 1773, 20467, 20468, 1796, 20447
8193, 1639, 1640, 20183, 20173, 1662, 20469, 20470, 20448
8194, 20173, 20183, 20184, 20174, 20470, 20471, 20472, 20450
8195, 20174, 20184, 20185, 20175, 20472, 20473, 20474, 20452
8196, 20175, 20185, 20186, 20176, 20474, 20475, 20476, 20454
8197, 20176, 20186, 20187, 20177, 20476, 20477, 20478, 20456
8198, 20177, 20187, 20188, 20178, 20478, 20479, 20480, 20458
8199, 20178, 20188, 20189, 20179, 20480, 20481, 20482, 20460
8200, 20179, 20189, 20190, 20180, 20482, 20483, 20484, 20462
8201, 20180, 20190, 20191, 20181, 20484, 20485, 20486, 20464
8202, 20181, 20191, 20192, 20182, 20486, 20487, 20488, 20466
8203, 20182, 20192, 1775, 1774, 20488, 20489, 1797, 20468
8204, 1640, 1641, 20193, 20183, 1663, 20490, 20491, 20469
8205, 20183, 20193, 20194, 20184, 20491, 20492, 20493, 20471
8206, 20184, 20194, 20195, 20185, 20493, 20494, 20495, 20473
8207, 20185, 20195, 20196, 20186, 20495, 20496, 20497, 20475
8208, 20186, 20196, 20197, 20187, 20497, 20498, 20499, 20477
8209, 20187, 20197, 20198, 20188, 20499, 20500, 20501, 20479
8210, 20188, 20198, 20199, 20189, 20501, 20502, 20503, 20481
8211, 20189, 20199, 20200, 20190, 20503, 20504, 20505, 20483
8212, 20190, 20200, 20201, 20191, 20505, 20506, 20507, 20485
8213, 20191, 20201, 20202, 20192, 20507, 20508, 20509, 20487
8214, 20192, 20202, 1776, 1775, 20509, 20510, 1798, 20489
8215, 1641, 1642, 20203, 20193, 1664, 20511, 20512, 20490
8216, 20193, 20203, 20204, 20194, 20512, 20513, 20514, 20492
8217, 20194, 20204, 20205, 20195, 20514, 20515, 20516, 20494
8218, 20195, 20205, 20206, 20196, 20516, 20517, 20518, 20496
8219, 20196, 20206, 20207, 20197, 20518, 20519, 20520, 20498
8220, 20197, 20207, 20208, 20198, 20520, 20521, 20522, 20500
8221, 20198, 20208, 20209, 20199, 20522, 20523, 20524, 20502
8222, 20199, 20209, 20210, 20200, 20524, 20525, 20526, 20504
8223, 20200, 20210, 20211, 20201, 20526, 20527, 20528, 20506
8224, 20201, 20211, 20212, 20202, 20528, 20529, 20530, 20508
8225, 20202, 20212, 1777, 1776, 20530, 20531, 1799, 20510
8226, 1642, 1643, 20213, 20203, 1665, 20532, 20533, 20511
8227, 20203, 20213, 20214, 20204, 20533, 20534, 20535, 20513
8228, 20204, 20214, 20215, 20205, 20535, 20536, 20537, 20515
8229, 20205, 20215, 20216, 20206, 20537, 20538, 20539, 20517
8230, 20206, 20216, 20217, 20207, 20539, 20540, 20541, 20519
8231, 20207, 20217, 20218, 20208, 20541, 20542, 20543, 20521
8232, 20208, 20218, 20219, 20209, 20543, 20544, 20545, 20523
8233, 20209, 20219, 20220, 20210, 20545, 20546, 20547, 20525
8234, 20210, 20220, 20221, 20211, 20547, 20548, 20549, 20527
8235, 20211, 20221, 20222, 20212, 20549, 20550, 20551, 20529
8236, 20212, 20222, 1778, 1777, 20551, 20552, 1800, 20531
8237, 1643, 1644, 20223, 20213, 1666, 20553, 20554, 20532
8238, 20213, 20223, 20224, 20214, 20554, 20555, 20556, 20534
8239, 20214, 20224, 20225, 20215, 20556, 20557, 20558, 20536
8240, 20215, 20225, 20226, 20216, 20558, 20559, 20560, 20538
8241, 20216, 20226, 20227, 20217, 20560, 20561, 20562, 20540
8242, 20217, 20227, 20228, 20218, 20562, 20563, 20564, 20542
8243, 20218, 20228, 20229, 20219, 20564, 20565, 20566, 20544
8244, 20219, 20229, 20230, 20220, 20566, 20567, 20568, 20546
8245, 20220, 20230, 20231, 20221, 20568, 20569, 20570, 20548
8246, 20221, 20231, 20232, 20222, 20570, 20571, 20572, 20550
8247, 20222, 20232, 1779, 1778, 20572, 20573, 1801, 20552
8248, 1644, 1645, 20233, 20223, 1667, 20574, 20575, 20553
8249, 20223, 20233, 20234, 20224, 20575, 20576, 20577, 20555
8250, 20224, 20234, 20235, 20225, 20577, 20578, 20579, 20557
8251, 20225, 20235, 20236, 20226, 20579, 20580, 20581, 20559
8252, 20226, 20236, 20237, 20227, 20581, 20582, 20583, 20561
8253, 20227, 20237, 20238, 20228, 20583, 20584, 20585, 20563
8254, 20228, 20238, 20239, 20229, 20585, 20586, 20587, 20565
8255, 20229, 20239, 20240, 20230, 20587, 20588, 20589, 20567
8256, 20230, 20240, 20241, 20231, 20589, 20590, 20591, 20569
8257, 20231, 20241, 20242, 20232, 20591, 20592, 20593, 20571
8258, 20232, 20242, 1780, 1779, 20593, 20594, 1802, 20573
8259, 1645, 1646, 20243, 20233, 1668, 20595, 20596, 20574
8260, 20233, 20243, 20244, 20234, 20596, 20597, 20598, 20576
8261, 20234, 20244, 20245, 20235, 20598, 20599, 20600, 20578
8262, 20235, 20245, 20246, 20236, 20600, 20601, 20602, 20580
8263, 20236, 20246, 20247, 20237, 20602, 20603, 20604, 20582
8264, 20237, 20247, 20248, 20238, 20604, 20605, 20606, 20584
8265, 20238, 20248, 20249, 20239, 20606, 20607, 20608, 20586
8266, 20239, 20249, 20250, 20240, 20608, 20609, 20610, 20588
8267, 20240, 20250, 20251, 20241, 20610, 20611, 20612, 20590
8268, 20241, 20251, 20252, 20242, 20612, 20613, 20614, 20592
8269, 20242, 20252, 1781, 1780, 20614, 20615, 1803, 20594
8270, 1646, 1647, 20253, 20243, 1669, 20616, 20617, 20595
8271, 20243, 20253, 20254, 20244, 20617, 20618, 20619, 20597
8272, 20244, 20254, 20255, 20245, 20619, 20620, 20621, 20599
8273, 20245, 20255, 20256, 20246, 20621, 20622, 20623, 20601
8274, 20246, 20256, 20257, 20247, 20623, 20624, 20625, 20603
8275, 20247, 20257, 20258, 20248, 20625, 20626, 20627, 20605
8276, 20248, 20258, 20259, 20249, 20627, 20628, 20629, 20607
8277, 20249, 20259, 20260, 20250, 20629, 20630, 20631, 20609
8278, 20250, 20260, 20261, 20251, 20631, 20632, 20633, 20611
8279, 20251, 20261, 20262, 20252, 20633, 20634, 20635, 20613
8280, 20252, 20262, 1782, 1781, 20635, 20636, 1804, 20615
8281, 1647, 1648, 20263, 20253, 1670, 20637, 20638, 20616
8282, 20253, 20263, 20264, 20254, 20638, 20639, 20640, 20618
8283, 20254, 20264, 20265, 20255, 20640, 20641, 20642, 20620
8284, 20255, 20265, 20266, 20256, 20642, 20643, 20644, 20622
8285, 20256, 20266, 20267, 20257, 20644, 20645, 20646, 20624
8286, 20257, 20267, 20268, 20258, 20646, 20647, 20648, 20626
8287, 20258, 20268, 20269, 20259, 20648, 20649, 20650, 20628
8288, 20259, 20269, 20270, 20260, 20650, 20651, 20652, 20630
8289, 20260, 20270, 20271, 20261, 20652, 20653, 20654, 20632
8290, 20261, 20271, 20272, 20262, 20654, 20655, 20656, 20634
8291, 20262, 20272, 1783, 1782, 20656, 20657, 1805, 20636
8292, 1648, 1649, 20273, 20263, 1671, 20658, 20659, 20637
8293, 20263, 20273, 20274, 20264, 20659, 20660, 20661, 20639
8294, 20264, 20274, 20275, 20265, 20661, 20662, 20663, 20641
8295, 20265, 20275, 20276, 20266, 20663, 20664, 20665, 20643
8296, 20266, 20276, 20277, 20267, 20665, 20666, 20667, 20645
8297, 20267, 20277, 20278, 20268, 20667, 20668, 20669, 20647
8298, 20268, 20278, 20279, 20269, 20669, 20670, 20671, 20649
8299, 20269, 20279, 20280, 20270, 20671, 20672, 20673, 20651
8300, 20270, 20280, 20281, 20271, 20673, 20674, 20675, 20653
8301, 20271, 20281, 20282, 20272, 20675, 20676, 20677, 20655
8302, 20272, 20282, 1784, 1783, 20677, 20678, 1806, 20657
8303, 1649, 1650, 20283, 20273, 1672, 20679, 20680, 20658
8304, 20273, 20283, 20284, 20274, 20680, 20681, 20682, 20660
8305, 20274, 20284, 20285, 20275, 20682, 20683, 20684, 20662
8306, 20275, 20285, 20286, 20276, 20684, 20685, 20686, 20664
8307, 20276, 20286, 20287, 20277, 20686, 20687, 20688, 20666
8308, 20277, 20287, 20288, 20278, 20688, 20689, 20690, 20668
8309, 20278, 20288, 20289, 20279, 20690, 20691, 20692, 20670
8310, 20279, 20289, 20290, 20280, 20692, 20693, 20694, 20672
8311, 20280, 20290, 20291, 20281, 20694, 20695, 20696, 20674
8312, 20281, 20291, 20292, 20282, 20696, 20697, 20698, 20676
8313, 20282, 20292, 1785, 1784, 20698, 20699, 1807, 20678
8314, 1650, 1651, 20293, 20283, 1673, 20700, 20701, 20679
8315, 20283, 20293, 20294, 20284, 20701, 20702, 20703, 20681
8316, 20284, 20294, 20295, 20285, 20703, 20704, 20705, 20683
8317, 20285, 20295, 20296, 20286, 20705, 20706, 20707, 20685
8318, 20286, 20296, 20297, 20287, 20707, 20708, 20709, 20687
8319, 20287, 20297, 20298, 20288, 20709, 20710, 20711, 20689
8320, 20288, 20298, 20299, 20289, 20711, 20712, 20713, 20691
8321, 20289, 20299, 20300, 20290, 20713, 20714, 20715, 20693
8322, 20290, 20300, 20301, 20291, 20715, 20716, 20717, 20695
8323, 20291, 20301, 20302, 20292, 20717, 20718, 20719, 20697
8324, 20292, 20302, 1786, 1785, 20719, 20720, 1808, 20699
8325, 1651, 1652, 20303, 20293, 1674, 20721, 20722, 20700
8326, 20293, 20303, 20304, 20294, 20722, 20723, 20724, 20702
8327, 20294, 20304, 20305, 20295, 20724, 20725, 20726, 20704
8328, 20295, 20305, 20306, 20296, 20726, 20727, 20728, 20706
8329, 20296, 20306, 20307, 20297, 20728, 20729, 20730, 20708
8330, 20297, 20307, 20308, 20298, 20730, 20731, 20732, 20710
8331, 20298, 20308, 20309, 20299, 20732, 20733, 20734, 20712
8332, 20299, 20309, 20310, 20300, 20734, 20735, 20736, 20714
8333, 20300, 20310, 20311, 20301, 20736, 20737, 20738, 20716
8334, 20301, 20311, 20312, 20302, 20738, 20739, 20740, 20718
8335, 20302, 20312, 1787, 1786, 20740, 20741, 1809, 20720
8336, 1652, 1653, 20313, 20303, 1675, 20742, 20743, 20721
8337, 20303, 20313, 20314, 20304, 20743, 20744, 20745, 20723
8338, 20304, 20314, 20315, 20305, 20745, 20746, 20747, 20725
8339, 20305, 20315, 20316, 20306, 20747, 20748, 20749, 20727
8340, 20306, 20316, 20317, 20307, 20749, 20750, 20751, 20729
8341, 20307, 20317, 20318, 20308, 20751, 20752, 20753, 20731
8342, 20308, 20318, 20319, 20309, 20753, 20754, 20755, 20733
8343, 20309, 20319, 20320, 20310, 20755, 20756, 20757, 20735
8344, 20310, 20320, 20321, 20311, 20757, 20758, 20759, 20737
8345, 20311, 20321, 20322, 20312, 20759, 20760, 20761, 20739
8346, 20312, 20322, 1788, 1787, 20761, 20762, 1810, 20741
8347, 1653, 1654, 20323, 20313, 1676, 20763, 20764, 20742
8348, 20313, 20323, 20324, 20314, 20764, 20765, 20766, 20744
8349, 20314, 20324, 20325, 20315, 20766, 20767, 20768, 20746
8350, 20315, 20325, 20326, 20316, 20768, 20769, 20770, 20748
8351, 20316, 20326, 20327, 20317, 20770, 20771, 20772, 20750
8352, 20317, 20327, 20328, 20318, 20772, 20773, 20774, 20752
8353, 20318, 20328, 20329, 20319, 20774, 20775, 20776, 20754
8354, 20319, 20329, 20330, 20320, 20776, 20777, 20778, 20756
8355, 20320, 20330, 20331, 20321, 20778, 20779, 20780, 20758
8356, 20321, 20331, 20332, 20322, 20780, 20781, 20782, 20760
8357, 20322, 20332, 1789, 1788, 20782, 20783, 1811, 20762
8358, 1654, 1655, 20333, 20323, 1677, 20784, 20785, 20763
8359, 20323, 20333, 20334, 20324, 20785, 20786, 20787, 20765
8360, 20324, 20334, 20335, 20325, 20787, 20788, 20789, 20767
8361, 20325, 20335, 20336, 20326, 20789, 20790, 20791, 20769
8362, 20326, 20336, 20337, 20327, 20791, 20792, 20793, 20771
8363, 20327, 20337, 20338, 20328, 20793, 20794, 20795, 20773
8364, 20328, 20338, 20339, 20329, 20795, 20796, 20797, 20775
8365, 20329, 20339, 20340, 20330, 20797, 20798, 20799, 20777
8366, 20330, 20340, 20341, 20331, 20799, 20800, 20801, 20779
8367, 20331, 20341, 20342, 20332, 20801, 20802, 20803, 20781
8368, 20332, 20342, 1790, 1789, 20803, 20804, 1812, 20783
8369, 1655, 38, 1889, 20333, 1678, 1900, 20805, 20784
8370, 20333, 1889, 1888, 20334, 20805, 1899, 20806, 20786
8371, 20334, 1888, 1887, 20335, 20806, 1898, 20807, 20788
8372, 20335, 1887, 1886, 20336, 20807, 1897, 20808, 20790
8373, 20336, 1886, 1885, 20337, 20808, 1896, 20809, 20792
8374, 20337, 1885, 1884, 20338, 20809, 1895, 20810, 20794
8375, 20338, 1884, 1883, 20339, 20810, 1894, 20811, 20796
8376, 20339, 1883, 1882, 20340, 20811, 1893, 20812, 20798
8377, 20340, 1882, 1881, 20341, 20812, 1892, 20813, 20800
8378, 20341, 1881, 1880, 20342, 20813, 1891, 20814, 20802
8379, 20342, 1880, 40, 1790, 20814, 1890, 1813, 20804
*ELEMENT, type=CPS8, ELSET=Surface46
8380, 37, 1868, 20815, 1679, 1879, 21035, 21036, 1701
8381, 1868, 1867, 20816, 20815, 1878, 21037, 21038, 21035
8382, 1867, 1866, 20817, 20816, 1877, 21039, 21040, 21037
8383, 1866, 1865, 20818, 20817, 1876, 21041, 21042, 21039
8384, 1865, 1864, 20819, 20818, 1875, 21043, 21044, 21041
8385, 1864, 1863, 20820, 20819, 1874, 21045, 21046, 21043
8386, 1863, 1862, 20821, 20820, 1873, 21047, 21048, 21045
8387, 1862, 1861, 20822, 20821, 1872, 21049, 21050, 21047
8388, 1861, 1860, 20823, 20822, 1871, 21051, 21052, 21049
8389, 1860, 1859, 20824, 20823, 1870, 21053, 21054, 21051
8390, 1859, 39, 1814, 20824, 1869, 1836, 21055, 21053
8391, 1679, 20815, 20825, 1680, 21036, 21056, 21057, 1702
8392, 20815, 20816, 20826, 20825, 21038, 21058, 21059, 21056
8393, 20816, 20817, 20827, 20826, 21040, 21060, 21061, 21058
8394, 20817, 20818, 20828, 20827, 21042, 21062, 21063, 21060
8395, 20818, 20819, 20829, 20828, 21044, 21064, 21065, 21062
8396, 20819, 20820, 20830, 20829, 21046, 21066, 21067, 21064
8397, 20820, 20821, 20831, 20830, 21048, 21068, 21069, 21066
8398, 20821, 20822, 20832, 20831, 21050, 21070, 21071, 21068
8399, 20822, 20823, 20833, 20832, 21052, 21072, 21073, 21070
8400, 20823, 20824, 20834, 20833, 21054, 21074, 21075, 21072
8401, 20824, 1814, 1815, 20834, 21055, 1837, 21076, 21074
8402, 1680, 20825, 20835, 1681, 21057, 21077, 21078, 1703
8403, 20825, 20826, 20836, 20835, 21059, 21079, 21080, 21077
8404, 20826, 20827, 20837, 20836, 21061, 21081, 21082, 21079
8405, 20827, 20828, 20838, 20837, 21063, 21083, 21084, 21081
8406, 20828, 20829, 20839, 20838, 21065, 21085, 21086, 21083
8407, 20829, 20830, 20840, 20839, 21067, 21087, 21088, 21085
8408, 20830, 20831, 20841, 20840, 21069, 21089, 21090, 21087
8409, 20831, 20832, 20842, 20841, 21071, 21091, 21092, 21089
8410, 20832, 20833, 20843, 20842, 21073, 21093, 21094, 21091
8411, 20833, 20834, 20844, 20843, 21075, 21095, 21096, 21093
8412, 20834, 1815, 1816, 20844, 21076, 1838, 21097, 21095
8413, 1681, 20835, 20845, 1682, 21078, 21098, 21099, 1704
8414, 20835, 20836, 20846, 20845, 21080, 21100, 21101, 21098
8415, 20836, 20837, 20847, 20846, 21082, 21102, 21103, 21100
8416, 20837, 20838, 20848, 20847, 21084, 21104, 21105, 21102
8417, 20838, 20839, 20849, 20848, 21086, 21106, 21107, 21104
8418, 20839, 20840, 20850, 20849, 21088, 21108, 21109, 21106
8419, 20840, 20841, 20851, 20850, 21090, 21110, 21111, 21108
8420, 20841, 20842, 20852, 20851, 21092, 21112, 21113, 21110
8421, 20842, 20843, 20853, 20852, 21094, 21114, 21115, 21112
8422, 20843, 20844, 20854, 20853, 21096, 21116, 21117, 21114
8423, 20844, 1816, 1817, 20854, 21097, 1839, 21118, 21116
8424, 1682, 20845, 20855, 1683, 21099, 21119, 21120, 1705
8425, 20845, 20846, 20856, 20855, 21101, 21121, 21122, 21119
8426, 20846, 20847, 20857, 20856, 21103, 21123, 21124, 21121
8427, 20847, 20848, 20858, 20857, 21105, 21125, 21126, 21123
8428, 20848, 20849, 20859, 20858, 21107, 21127, 21128, 21125
8429, 20849, 20850, 20860, 20859, 21109, 21129, 21130, 21127
8430, 20850, 20851, 20861, 20860, 21111, 21131, 21132, 21129
8431, 20851, 20852, 20862, 20861, 21113, 21133, 21134, 21131
8432, 20852, 20853, 20863, 20862, 21115, 21135, 21136, 21133
8433, 20853, 20854, 20864, 20863, 21117, 21137, 21138, 21135
8434, 20854, 1817, 1818, 20864, 21118, 1840, 21139, 21137
8435, 1683, 20855, 20865, 1684, 21120, 21140, 21141, 1706
8436, 20855, 20856, 20866, 20865, 21122, 21142, 21143, 21140
8437, 20856, 20857, 20867, 20866, 21124, 21144, 21145, 21142
8438, 20857, 20858, 20868, 20867, 21126, 21146, 21147, 21144
8439, 20858, 20859, 20869, 20868, 21128, 21148, 21149, 21146
8440, 20859, 20860, 20870, 20869, 21130, 21150, 21151, 21148
8441, 20860, 20861, 20871, 20870, 21132, 21152, 21153, 21150
8442, 20861, 20862, 20872, 20871, 21134, 21154, 21155, 21152
8443, 20862, 20863, 20873, 20872, 21136, 21156, 21157, 21154
8444, 20863, 20864, 20874, 20873, 21138, 21158, 21159, 21156
8445, 20864, 1818, 1819, 20874, 21139, 1841, 21160, 21158
8446, 1684, 20865, 20875, 1685, 21141, 21161, 21162, 1707
8447, 20865, 20866, 20876, 20875, 21143, 21163, 21164, 21161
8448, 20866, 20867, 20877, 20876, 21145, 21165, 21166, 21163
8449, 20867, 20868, 20878, 20877, 21147, 21167, 21168, 21165
8450, 20868, 20869, 20879, 20878, 21149, 21169, 21170, 21167
8451, 20869, 20870, 20880, 20879, 21151, 21171, 21172, 21169
8452, 20870, 20871, 20881, 20880, 21153, 21173, 21174, 21171
8453, 20871, 20872, 20882, 20881, 21155, 21175, 21176, 21173
8454, 20872, 20873, 20883, 20882, 21157, 21177, 21178, 21175
8455, 20873, 20874, 20884, 20883, 21159, 21179, 21180, 21177
8456, 20874, 1819, 1820, 20884, 21160, 1842, 21181, 21179
8457, 1685, 20875, 20885, 1686, 21162, 21182, 21183, 1708
8458, 20875, 20876, 20886, 20885, 21164, 21184, 21185, 21182
8459, 20876, 20877, 20887, 20886, 21166, 21186, 21187, 21184
8460, 20877, 20878, 20888, 20887, 21168, 21188, 21189, 21186
8461, 20878, 20879, 20889, 20888, 21170, 21190, 21191, 21188
8462, 20879, 20880, 20890, 20889, 21172, 21192, 21193, 21190
8463, 20880, 20881, 20891, 20890, 21174, 21194, 21195, 21192
8464, 20881, 20882, 20892, 20891, 21176, 21196, 21197, 21194
8465, 20882, 20883, 20893, 20892, 21178, 21198, 21199, 21196
8466, 20883, 20884, 20894, 20893, 21180, 21200, 21201, 21198
8467, 20884, 1820, 1821, 20894, 21181, 1843, 21202, 21200
8468, 1686, 20885, 20895, 1687, 21183, 21203, 21204, 1709
8469, 20885, 20886, 20896, 20895, 21185, 21205, 21206, 21203
8470, 20886, 20887, 20897, 20896, 21187, 21207, 21208, 21205
8471, 20887, 20888, 20898, 20897, 21189, 21209, 21210, 21207
8472, 20888, 20889, 20899, 20898, 21191, 21211, 21212, 21209
8473, 20889, 20890, 20900, 20899, 21193, 21213, 21214, 21211
8474, 20890, 20891, 20901, 20900, 21195, 21215, 21216, 21213
8475, 20891, 20892, 20902, 20901, 21197, 21217, 21218, 21215
8476, 20892, 20893, 20903, 20902, 21199, 21219, 21220, 21217
8477, 20893, 20894, 20904, 20903, 21201, 21221, 21222, 21219
8478, 20894, 1821, 1822, 20904, 21202, 1844, 21223, 21221
8479, 1687, 20895, 20905, 1688, 21204, 21224, 21225, 1710
8480, 20895, 20896, 20906, 20905, 21206, 21226, 21227, 21224
8481, 20896, 20897, 20907, 20906, 21208, 21228, 21229, 21226
8482, 20897, 20898, 20908, 20907, 21210, 21230, 21231, 21228
8483, 20898, 20899, 20909, 20908, 21212, 21232, 21233, 21230
8484, 20899, 20900, 20910, 20909, 21214, 21234, 21235, 21232
8485, 20900, 20901, 20911, 20910, 21216, 21236, 21237, 21234
8486, 20901, 20902, 20912, 20911, 21218, 21238, 21239, 21236
8487, 20902, 20903, 20913, 20912, 21220, 21240, 21241, 21238
8488, 20903, 20904, 20914, 20913, 21222, 21242, 21243, 21240
8489, 20904, 1822, 1823, 20914, 21223, 1845, 21244, 21242
8490, 1688, 20905, 20915, 1689, 21225, 21245, 21246, 1711
8491, 20905, 20906, 20916, 20915, 21227, 21247, 21248, 21245
8492, 20906, 20907, 20917, 20916, 21229, 21249, 21250, 21247
8493, 20907, 20908, 20918, 20917, 21231, 21251, 21252, 21249
8494, 20908, 20909, 20919, 20918, 21233, 21253, 21254, 21251
8495, 20909, 20910, 20920, 20919, 21235, 21255, 21256, 21253
8496, 20910, 20911, 20921, 20920, 21237, 21257, 21258, 21255
8497, 20911, 20912, 20922, 20921, 21239, 21259, 21260, 21257
8498, 20912, 20913, 20923, 20922, 21241, 21261, 21262, 21259
8499, 20913, 20914, 20924, 20923, 21243, 21263, 21264, 21261
8500, 20914, 1823, 1824, 20924, 21244, 1846, 21265, 21263
8501, 1689, 20915, 20925, 1690, 21246, 21266, 21267, 1712
8502, 20915, 20916, 20926, 20925, 21248, 21268, 21269, 21266
8503, 20916, 20917, 20927, 20926, 21250, 21270, 21271, 21268
8504, 20917, 20918, 20928, 20927, 21252, 21272, 21273, 21270
8505, 20918, 20919, 20929, 20928, 21254, 21274, 21275, 21272
8506, 20919, 20920, 20930, 20929, 21256, 21276, 21277, 21274
8507, 20920, 20921, 20931, 20930, 21258, 21278, 21279, 21276
8508, 20921, 20922, 20932, 20931, 21260, 21280, 21281, 21278
8509, 20922, 20923, 20933, 20932, 21262, 21282, 21283, 21280
8510, 20923, 20924, 20934, 20933, 21264, 21284, 21285, 21282
8511, 20924, 1824, 1825, 20934, 21265, 1847, 21286, 21284
8512, 1690, 20925, 20935, 1691, 21267, 21287, 21288, 1713
8513, 20925, 20926, 20936, 20935, 21269, 21289, 21290, 21287
8514, 20926, 20927, 20937, 20936, 21271, 21291, 21292, 21289
8515, 20927, 20928, 20938, 20937, 21273, 21293, 21294, 21291
8516, 20928, 20929, 20939, 20938, 21275, 21295, 21296, 21293
8517, 20929, 20930, 20940, 20939, 21277, 21297, 21298, 21295
8518, 20930, 20931, 20941, 20940, 21279, 21299, 21300, 21297
8519, 20931, 20932, 20942, 20941, 21281, 21301, 21302, 21299
8520, 20932, 20933, 20943, 20942, 21283, 21303, 21304, 21301
8521, 20933, 20934, 20944, 20943, 21285, 21305, 21306, 21303
8522, 20934, 1825, 1826, 20944, 21286, 1848, 21307, 21305
8523, 1691, 20935, 20945, 1692, 21288, 21308, 21309, 1714
8524, 20935, 20936, 20946, 20945, 21290, 21310, 21311, 21308
8525, 20936, 20937, 20947, 20946, 21292, 21312, 21313, 21310
8526, 20937, 20938, 20948, 20947, 21294, 21314, 21315, 21312
8527, 20938, 20939, 20949, 20948, 21296, 21316, 21317, 21314
8528, 20939, 20940, 20950, 20949, 21298, 21318, 21319, 21316
8529, 20940, 20941, 20951, 20950, 21300, 21320, 21321, 21318
8530, 20941, 20942, 20952, 20951, 21302, 21322, 21323, 21320
8531, 20942, 20943, 20953, 20952, 21304, 21324, 21325, 21322
8532, 20943, 20944, 20954, 20953, 21306, 21326, 21327, 21324
8533, 20944, 1826, 1827, 20954, 21307, 1849, 21328, 21326
8534, 1692, 20945, 20955, 1693, 21309, 21329, 21330, 1715
8535, 20945, 20946, 20956, 20955, 21311, 21331, 21332, 21329
8536, 20946, 20947, 20957, 20956, 21313, 21333, 21334, 21331
8537, 20947, 20948, 20958, 20957, 21315, 21335, 21336, 21333
8538, 20948, 20949, 20959, 20958, 21317, 21337, 21338, 21335
8539, 20949, 20950, 20960, 20959, 21319, 21339, 21340, 21337
8540, 20950, 20951, 20961, 20960, 21321, 21341, 21342, 21339
8541, 20951, 20952, 20962, 20961, 21323, 21343, 21344, 21341
8542, 20952, 20953, 20963, 20962, 21325, 21345, 21346, 21343
8543, 20953, 20954, 20964, 20963, 21327, 21347, 21348, 21345
8544, 20954, 1827, 1828, 20964, 21328, 1850, 21349, 21347
8545, 1693, 20955, 20965, 1694, 21330, 21350, 21351, 1716
8546, 20955, 20956, 20966, 20965, 21332, 21352, 21353, 21350
8547, 20956, 20957, 20967, 20966, 21334, 21354, 21355, 21352
8548, 20957, 20958, 20968, 20967, 21336, 21356, 21357, 21354
8549, 20958, 20959, 20969, 20968, 21338, 21358, 21359, 21356
8550, 20959, 20960, 20970, 20969, 21340, 21360, 21361, 21358
8551, 20960, 20961, 20971, 20970, 21342, 21362, 21363, 21360
8552, 20961, 20962, 20972, 20971, 21344, 21364, 21365, 21362
8553, 20962, 20963, 20973, 20972, 21346, 21366, 21367, 21364
8554, 20963, 20964, 20974, 20973, 21348, 21368, 21369, 21366
8555, 20964, 1828, 1829, 20974, 21349, 1851, 21370, 21368
8556, 1694, 20965, 20975, 1695, 21351, 21371, 21372, 1717
8557, 20965, 20966, 20976, 20975, 21353, 21373, 21374, 21371
8558, 20966, 20967, 20977, 20976, 21355, 21375, 21376, 21373
8559, 20967, 20968, 20978, 20977, 21357, 21377, 21378, 21375
8560, 20968, 20969, 20979, 20978, 21359, 21379, 21380, 21377
8561, 20969, 20970, 20980, 20979, 21361, 21381, 21382, 21379
8562, 20970, 20971, 20981, 20980, 21363, 21383, 21384, 21381
8563, 20971, 20972, 20982, 20981, 21365, 21385, 21386, 21383
8564, 20972, 20973, 20983, 20982, 21367, 21387, 21388, 21385
8565, 20973, 20974, 20984, 20983, 21369, 21389, 21390, 21387
8566, 20974, 1829, 1830, 20984, 21370, 1852, 21391, 21389
8567, 1695, 20975, 20985, 1696, 21372, 21392, 21393, 1718
8568, 20975, 20976, 20986, 20985, 21374, 21394, 21395, 21392
8569, 20976, 20977, 20987, 20986, 21376, 21396, 21397, 21394
8570, 20977, 20978, 20988, 20987, 21378, 21398, 21399, 21396
8571, 20978, 20979, 20989, 20988, 21380, 21400, 21401, 21398
8572, 20979, 20980, 20990, 20989, 21382, 21402, 21403, 21400
8573, 20980, 20981, 20991, 20990, 21384, 21404, 21405, 21402
8574, 20981, 20982, 20992, 20991, 21386, 21406, 21407, 21404
8575, 20982, 20983, 20993, 20992, 21388, 21408, 21409, 21406
8576, 20983, 20984, 20994, 20993, 21390, 21410, 21411, 21408
8577, 20984, 1830, 1831, 20994, 21391, 1853, 21412, 21410
8578, 1696, 20985, 20995, 1697, 21393, 21413, 21414, 1719
8579, 20985, 20986, 20996, 20995, 21395, 21415, 21416, 21413
8580, 20986, 20987, 20997, 20996, 21397, 21417, 21418, 21415
8581, 20987, 20988, 20998, 20997, 21399, 21419, 21420, 21417
8582, 20988, 20989, 20999, 20998, 21401, 21421, 21422, 21419
8583, 20989, 20990, 21000, 20999, 21403, 21423, 21424, 21421
8584, 20990, 20991, 21001, 21000, 21405, 21425, 21426, 21423
8585, 20991, 20992, 21002, 21001, 21407, 21427, 21428, 21425
8586, 20992, 20993, 21003, 21002, 21409, 21429, 21430, 21427
8587, 20993, 20994, 21004, 21003, 21411, 21431, 21432, 21429
8588, 20994, 1831, 1832, 21004, 21412, 1854, 21433, 21431
8589, 1697, 20995, 21005, 1698, 21414, 21434, 21435, 1720
8590, 20995, 20996, 21006, 21005, 21416, 21436, 21437, 21434
8591, 20996, 20997, 21007, 21006, 21418, 21438, 21439, 21436
8592, 20997, 20998, 21008, 21007, 21420, 21440, 21441, 21438
8593, 20998, 20999, 21009, 21008, 21422, 21442, 21443, 21440
8594, 20999, 21000, 21010, 21009, 21424, 21444, 21445, 21442
8595, 21000, 21001, 21011, 21010, 21426, 21446, 21447, 21444
8596, 21001, 21002, 21012, 21011, 21428, 21448, 21449, 21446
8597, 21002, 21003, 21013, 21012, 21430, 21450, 21451, 21448
8598, 21003, 21004, 21014, 21013, 21432, 21452, 21453, 21450
8599, 21004, 1832, 1833, 21014, 21433, 1855, 21454, 21452
8600, 1698, 21005, 21015, 1699, 21435, 21455, 21456, 1721
8601, 21005, 21006, 21016, 21015, 21437, 21457, 21458, 21455
8602, 21006, 21007, 21017, 21016, 21439, 21459, 21460, 21457
8603, 21007, 21008, 21018, 21017, 21441, 21461, 21462, 21459
8604, 21008, 21009, 21019, 21018, 21443, 21463, 21464, 21461
8605, 21009, 21010, 21020, 21019, 21445, 21465, 21466, 21463
8606, 21010, 21011, 21021, 21020, 21447, 21467, 21468, 21465
8607, 21011, 21012, 21022, 21021, 21449, 21469, 21470, 21467
8608, 21012, 21013, 21023, 21022, 21451, 21471, 21472, 21469
8609, 21013, 21014, 21024, 21023, 21453, 21473, 21474, 21471
8610, 21014, 1833, 1834, 21024, 21454, 1856, 21475, 21473
8611, 1699, 21015, 21025, 1700, 21456, 21476, 21477, 1722
8612, 21015, 21016, 21026, 21025, 21458, 21478, 21479, 21476
8613, 21016, 21017, 21027, 21026, 21460, 21480, 21481, 21478
8614, 21017, 21018, 21028, 21027, 21462, 21482, 21483, 21480
8615, 21018, 21019, 21029, 21028, 21464, 21484, 21485, 21482
8616, 21019, 21020, 21030, 21029, 21466, 21486, 21487, 21484
8617, 21020, 21021, 21031, 21030, 21468, 21488, 21489, 21486
8618, 21021, 21022, 21032, 21031, 21470, 21490, 21491, 21488
8619, 21022, 21023, 21033, 21032, 21472, 21492, 21493, 21490
8620, 21023, 21024, 21034, 21033, 21474, 21494, 21495, 21492
8621, 21024, 1834, 1835, 21034, 21475, 1857, 21496, 21494
8622, 1700, 21025, 1889, 38, 21477, 21497, 1900, 1723
8623, 21025, 21026, 1888, 1889, 21479, 21498, 1899, 21497
8624, 21026, 21027, 1887, 1888, 21481, 21499, 1898, 21498
8625, 21027, 21028, 1886, 1887, 21483, 21500, 1897, 21499
8626, 21028, 21029, 1885, 1886, 21485, 21501, 1896, 21500
8627, 21029, 21030, 1884, 1885, 21487, 21502, 1895, 21501
8628, 21030, 21031, 1883, 1884, 21489, 21503, 1894, 21502
8629, 21031, 21032, 1882, 1883, 21491, 21504, 1893, 21503
8630, 21032, 21033, 1881, 1882, 21493, 21505, 1892, 21504
8631, 21033, 21034, 1880, 1881, 21495, 21506, 1891, 21505
8632, 21034, 1835, 40, 1880, 21496, 1858, 1890, 21506
*ELEMENT, type=CPS8, ELSET=Surface47
8633, 37, 1901, 21507, 1679, 1902, 21529, 21530, 1701
8634, 1679, 21507, 21508, 1680, 21530, 21531, 21532, 1702
8635, 1680, 21508, 21509, 1681, 21532, 21533, 21534, 1703
8636, 1681, 21509, 21510, 1682, 21534, 21535, 21536, 1704
8637, 1682, 21510, 21511, 1683, 21536, 21537, 21538, 1705
8638, 1683, 21511, 21512, 1684, 21538, 21539, 21540, 1706
8639, 1684, 21512, 21513, 1685, 21540, 21541, 21542, 1707
8640, 1685, 21513, 21514, 1686, 21542, 21543, 21544, 1708
8641, 1686, 21514, 21515, 1687, 21544, 21545, 21546, 1709
8642, 1687, 21515, 21516, 1688, 21546, 21547, 21548, 1710
8643, 1688, 21516, 21517, 1689, 21548, 21549, 21550, 1711
8644, 1689, 21517, 21518, 1690, 21550, 21551, 21552, 1712
8645, 1690, 21518, 21519, 1691, 21552, 21553, 21554, 1713
8646, 1691, 21519, 21520, 1692, 21554, 21555, 21556, 1714
8647, 1692, 21520, 21521, 1693, 21556, 21557, 21558, 1715
8648, 1693, 21521, 21522, 1694, 21558, 21559, 21560, 1716
8649, 1694, 21522, 21523, 1695, 21560, 21561, 21562, 1717
8650, 1695, 21523, 21524, 1696, 21562, 21563, 21564, 1718
8651, 1696, 21524, 21525, 1697, 21564, 21565, 21566, 1719
8652, 1697, 21525, 21526, 1698, 21566, 21567, 21568, 1720
8653, 1698, 21526, 21527, 1699, 21568, 21569, 21570, 1721
8654, 1699, 21527, 21528, 1700, 21570, 21571, 21572, 1722
8655, 1700, 21528, 1904, 38, 21572, 21573, 1905, 1723
8656, 1901, 41, 1907, 21507, 1903, 1929, 21574, 21529
8657, 21507, 1907, 1908, 21508, 21574, 1930, 21575, 21531
8658, 21508, 1908, 1909, 21509, 21575, 1931, 21576, 21533
8659, 21509, 1909, 1910, 21510, 21576, 1932, 21577, 21535
8660, 21510, 1910, 1911, 21511, 21577, 1933, 21578, 21537
8661, 21511, 1911, 1912, 21512, 21578, 1934, 21579, 21539
8662, 21512, 1912, 1913, 21513, 21579, 1935, 21580, 21541
8663, 21513, 1913, 1914, 21514, 21580, 1936, 21581, 21543
8664, 21514, 1914, 1915, 21515, 21581, 1937, 21582, 21545
8665, 21515, 1915, 1916, 21516, 21582, 1938, 21583, 21547
8666, 21516, 1916, 1917, 21517, 21583, 1939, 21584, 21549
8667, 21517, 1917, 1918, 21518, 21584, 1940, 21585, 21551
8668, 21518, 1918, 1919, 21519, 21585, 1941, 21586, 21553
8669, 21519, 1919, 1920, 21520, 21586, 1942, 21587, 21555
8670, 21520, 1920, 1921, 21521, 21587, 1943, 21588, 21557
8671, 21521, 1921, 1922, 21522, 21588, 1944, 21589, 21559
8672, 21522, 1922, 1923, 21523, 21589, 1945, 21590, 21561
8673, 21523, 1923, 1924, 21524, 21590, 1946, 21591, 21563
8674, 21524, 1924, 1925, 21525, 21591, 1947, 21592, 21565
8675, 21525, 1925, 1926, 21526, 21592, 1948, 21593, 21567
8676, 21526, 1926, 1927, 21527, 21593, 1949, 21594, 21569
8677, 21527, 1927, 1928, 21528, 21594, 1950, 21595, 21571
8678, 21528, 1928, 42, 1904, 21595, 1951, 1906, 21573
*ELEMENT, type=CPS8, ELSET=Surface48
8679, 39, 1814, 21596, 1952, 1836, 21618, 21619, 1953
8680, 1814, 1815, 21597, 21596, 1837, 21620, 21621, 21618
8681, 1815, 1816, 21598, 21597, 1838, 21622, 21623, 21620
8682, 1816, 1817, 21599, 21598, 1839, 21624, 21625, 21622
8683, 1817, 1818, 21600, 21599, 1840, 21626, 21627, 21624
8684, 1818, 1819, 21601, 21600, 1841, 21628, 21629, 21626
8685, 1819, 1820, 21602, 21601, 1842, 21630, 21631, 21628
8686, 1820, 1821, 21603, 21602, 1843, 21632, 21633, 21630
8687, 1821, 1822, 21604, 21603, 1844, 21634, 21635, 21632
8688, 1822, 1823, 21605, 21604, 1845, 21636, 21637, 21634
8689, 1823, 1824, 21606, 21605, 1846, 21638, 21639, 21636
8690, 1824, 1825, 21607, 21606, 1847, 21640, 21641, 21638
8691, 1825, 1826, 21608, 21607, 1848, 21642, 21643, 21640
8692, 1826, 1827, 21609, 21608, 1849, 21644, 21645, 21642
8693, 1827, 1828, 21610, 21609, 1850, 21646, 21647, 21644
8694, 1828, 1829, 21611, 21610, 1851, 21648, 21649, 21646
8695, 1829, 1830, 21612, 21611, 1852, 21650, 21651, 21648
8696, 1830, 1831, 21613, 21612, 1853, 21652, 21653, 21650
8697, 1831, 1832, 21614, 21613, 1854, 21654, 21655, 21652
8698, 1832, 1833, 21615, 21614, 1855, 21656, 21657, 21654
8699, 1833, 1834, 21616, 21615, 1856, 21658, 21659, 21656
8700, 1834, 1835, 21617, 21616, 1857, 21660, 21661, 21658
8701, 1835, 40, 1955, 21617, 1858, 1956, 21662, 21660
8702, 1952, 21596, 1958, 43, 21619, 21663, 1980, 1954
8703, 21596, 21597, 1959, 1958, 21621, 21664, 1981, 21663
8704, 21597, 21598, 1960, 1959, 21623, 21665, 1982, 21664
8705, 21598, 21599, 1961, 1960, 21625, 21666, 1983, 21665
8706, 21599, 21600, 1962, 1961, 21627, 21667, 1984, 21666
8707, 21600, 21601, 1963, 1962, 21629, 21668, 1985, 21667
8708, 21601, 21602, 1964, 1963, 21631, 21669, 1986, 21668
8709, 21602, 21603, 1965, 1964, 21633, 21670, 1987, 21669
8710, 21603, 21604, 1966, 1965, 21635, 21671, 1988, 21670
8711, 21604, 21605, 1967, 1966, 21637, 21672, 1989, 21671
8712, 21605, 21606, 1968, 1967, 21639, 21673, 1990, 21672
8713, 21606, 21607, 1969, 1968, 21641, 21674, 1991, 21673
8714, 21607, 21608, 1970, 1969, 21643, 21675, 1992, 21674
8715, 21608, 21609, 1971, 1970, 21645, 21676, 1993, 21675
8716, 21609, 21610, 1972, 1971, 21647, 21677, 1994, 21676
8717, 21610, 21611, 1973, 1972, 21649, 21678, 1995, 21677
8718, 21611, 21612, 1974, 1973, 21651, 21679, 1996, 21678
8719, 21612, 21613, 1975, 1974, 21653, 21680, 1997, 21679
8720, 21613, 21614, 1976, 1975, 21655, 21681, 1998, 21680
8721, 21614, 21615, 1977, 1976, 21657, 21682, 1999, 21681
8722, 21615, 21616, 1978, 1977, 21659, 21683, 2000, 21682
8723, 21616, 21617, 1979, 1978, 21661, 21684, 2001, 21683
8724, 21617, 1955, 44, 1979, 21662, 1957, 2002, 21684
*ELEMENT, type=CPS8, ELSET=Surface49
8725, 37, 1868, 21685, 1901, 1879, 21695, 21696, 1902
8726, 1868, 1867, 21686, 21685, 1878, 21697, 21698, 21695
8727, 1867, 1866, 21687, 21686, 1877, 21699, 21700, 21697
8728, 1866, 1865, 21688, 21687, 1876, 21701, 21702, 21699
8729, 1865, 1864, 21689, 21688, 1875, 21703, 21704, 21701
8730, 1864, 1863, 21690, 21689, 1874, 21705, 21706, 21703
8731, 1863, 1862, 21691, 21690, 1873, 21707, 21708, 21705
8732, 1862, 1861, 21692, 21691, 1872, 21709, 21710, 21707
8733, 1861, 1860, 21693, 21692, 1871, 21711, 21712, 21709
8734, 1860, 1859, 21694, 21693, 1870, 21713, 21714, 21711
8735, 1859, 39, 1952, 21694, 1869, 1953, 21715, 21713
8736, 1901, 21685, 2012, 41, 21696, 21716, 2023, 1903
8737, 21685, 21686, 2011, 2012, 21698, 21717, 2022, 21716
8738, 21686, 21687, 2010, 2011, 21700, 21718, 2021, 21717
8739, 21687, 21688, 2009, 2010, 21702, 21719, 2020, 21718
8740, 21688, 21689, 2008, 2009, 21704, 21720, 2019, 21719
8741, 21689, 21690, 2007, 2008, 21706, 21721, 2018, 21720
8742, 21690, 21691, 2006, 2007, 21708, 21722, 2017, 21721
8743, 21691, 21692, 2005, 2006, 21710, 21723, 2016, 21722
8744, 21692, 21693, 2004, 2005, 21712, 21724, 2015, 21723
8745, 21693, 21694, 2003, 2004, 21714, 21725, 2014, 21724
8746, 21694, 1952, 43, 2003, 21715, 1954, 2013, 21725
*ELEMENT, type=CPS8, ELSET=Surface50
8747, 38, 1904, 21726, 1889, 1905, 21736, 21737, 1900
8748, 1889, 21726, 21727, 1888, 21737, 21738, 21739, 1899
8749, 1888, 21727, 21728, 1887, 21739, 21740, 21741, 1898
8750, 1887, 21728, 21729, 1886, 21741, 21742, 21743, 1897
8751, 1886, 21729, 21730, 1885, 21743, 21744, 21745, 1896
8752, 1885, 21730, 21731, 1884, 21745, 21746, 21747, 1895
8753, 1884, 21731, 21732, 1883, 21747, 21748, 21749, 1894
8754, 1883, 21732, 21733, 1882, 21749, 21750, 21751, 1893
8755, 1882, 21733, 21734, 1881, 21751, 21752, 21753, 1892
8756, 1881, 21734, 21735, 1880, 21753, 21754, 21755, 1891
8757, 1880, 21735, 1955, 40, 21755, 21756, 1956, 1890
8758, 1904, 42, 2033, 21726, 1906, 2044, 21757, 21736
8759, 21726, 2033, 2032, 21727, 21757, 2043, 21758, 21738
8760, 21727, 2032, 2031, 21728, 21758, 2042, 21759, 21740
8761, 21728, 2031, 2030, 21729, 21759, 2041, 21760, 21742
8762, 21729, 2030, 2029, 21730, 21760, 2040, 21761, 21744
8763, 21730, 2029, 2028, 21731, 21761, 2039, 21762, 21746
8764, 21731, 2028, 2027, 21732, 21762, 2038, 21763, 21748
8765, 21732, 2027, 2026, 21733, 21763, 2037, 21764, 21750
8766, 21733, 2026, 2025, 21734, 21764, 2036, 21765, 21752
8767, 21734, 2025, 2024, 21735, 21765, 2035, 21766, 21754
8768, 21735, 2024, 44, 1955, 21766, 2034, 1957, 21756
*ELEMENT, type=CPS8, ELSET=Surface51
8769, 41, 2012, 21767, 1907, 2023, 21987, 21988, 1929
8770, 2012, 2011, 21768, 21767, 2022, 21989, 21990, 21987
8771, 2011, 2010, 21769, 21768, 2021, 21991, 21992, 21989
8772, 2010, 2009, 21770, 21769, 2020, 21993, 21994, 21991
8773, 2009, 2008, 21771, 21770, 2019, 21995, 21996, 21993
8774, 2008, 2007, 21772, 21771, 2018, 21997, 21998, 21995
8775, 2007, 2006, 21773, 21772, 2017, 21999, 22000, 21997
8776, 2006, 2005, 21774, 21773, 2016, 22001, 22002, 21999
8777, 2005, 2004, 21775, 21774, 2015, 22003, 22004, 22001
8778, 2004, 2003, 21776, 21775, 2014, 22005, 22006, 22003
8779, 2003, 43, 1958, 21776, 2013, 1980, 22007, 22005
8780, 1907, 21767, 21777, 1908, 21988, 22008, 22009, 1930
8781, 21767, 21768, 21778, 21777, 21990, 22010, 22011, 22008
8782, 21768, 21769, 21779, 21778, 21992, 22012, 22013, 22010
8783, 21769, 21770, 21780, 21779, 21994, 22014, 22015, 22012
8784, 21770, 21771, 21781, 21780, 21996, 22016, 22017, 22014
8785, 21771, 21772, 21782, 21781, 21998, 22018, 22019, 22016
8786, 21772, 21773, 21783, 21782, 22000, 22020, 22021, 22018
8787, 21773, 21774, 21784, 21783, 22002, 22022, 22023, 22020
8788, 21774, 21775, 21785, 21784, 22004, 22024, 22025, 22022
8789, 21775, 21776, 21786, 21785, 22006, 22026, 22027, 22024
8790, 21776, 1958, 1959, 21786, 22007, 1981, 22028, 22026
8791, 1908, 21777, 21787, 1909, 22009, 22029, 22030, 1931
8792, 21777, 21778, 21788, 21787, 22011, 22031, 22032, 22029
8793, 21778, 21779, 21789, 21788, 22013, 22033, 22034, 22031
8794, 21779, 21780, 21790, 21789, 22015, 22035, 22036, 22033
8795, 21780, 21781, 21791, 21790, 22017, 22037, 22038, 22035
8796, 21781, 21782, 21792, 21791, 22019, 22039, 22040, 22037
8797, 21782, 21783, 21793, 21792, 22021, 22041, 22042, 22039
8798, 21783, 21784, 21794, 21793, 22023, 22043, 22044, 22041
8799, 21784, 21785, 21795, 21794, 22025, 22045, 22046, 22043
8800, 21785, 21786, 21796, 21795, 22027, 22047, 22048, 22045
8801, 21786, 1959, 1960, 21796, 22028, 1982, 22049, 22047
8802, 1909, 21787, 21797, 1910, 22030, 22050, 22051, 1932
8803, 21787, 21788, 21798, 21797, 22032, 22052, 22053, 22050
8804, 21788, 21789, 21799, 21798, 22034, 22054, 22055, 22052
8805, 21789, 21790, 21800, 21799, 22036, 22056, 22057, 22054
8806, 21790, 21791, 21801, 21800, 22038, 22058, 22059, 22056
8807, 21791, 21792, 21802, 21801, 22040, 22060, 22061, 22058
8808, 21792, 21793, 21803, 21802, 22042, 22062, 22063, 22060
8809, 21793, 21794, 21804, 21803, 22044, 22064, 22065, 22062
8810, 21794, 21795, 21805, 21804, 22046, 22066, 22067, 22064
8811, 21795, 21796, 21806, 21805, 22048, 22068, 22069, 22066
8812, 21796, 1960, 1961, 21806, 22049, 1983, 22070, 22068
8813, 1910, 21797, 21807, 1911, 22051, 22071, 22072, 1933
8814, 21797, 21798, 21808, 21807, 22053, 22073, 22074, 22071
8815, 21798, 21799, 21809, 21808, 22055, 22075, 22076, 22073
8816, 21799, 21800, 21810, 21809, 22057, 22077, 22078, 22075
8817, 21800, 21801, 21811, 21810, 22059, 22079, 22080, 22077
8818, 21801, 21802, 21812, 21811, 22061, 22081, 22082, 22079
8819, 21802, 21803, 21813, 21812, 22063, 22083, 22084, 22081
8820, 21803, 21804, 21814, 21813, 22065, 22085, 22086, 22083
8821, 21804, 21805, 21815, 21814, 22067, 22087, 22088, 22085
8822, 21805, 21806, 21816, 21815, 22069, 22089, 22090, 22087
8823, 21806, 1961, 1962, 21816, 22070, 1984, 22091, 22089
8824, 1911, 21807, 21817, 1912, 22072, 22092, 22093, 1934
8825, 21807, 21808, 21818, 21817, 22074, 22094, 22095, 22092
8826, 21808, 21809, 21819, 21818, 22076, 22096, 22097, 22094
8827, 21809, 21810, 21820, 21819, 22078, 22098, 22099, 22096
8828, 21810, 21811, 21821, 21820, 22080, 22100, 22101, 22098
8829, 21811, 21812, 21822, 21821, 22082, 22102, 22103, 22100
8830, 21812, 21813, 21823, 21822, 22084, 22104, 22105, 22102
8831, 21813, 21814, 21824, 21823, 22086, 22106, 22107, 22104
8832, 21814, 21815, 21825, 21824, 22088, 22108, 22109, 22106
8833, 21815, 21816, 21826, 21825, 22090, 22110, 22111, 22108
8834, 21816, 1962, 1963, 21826, 22091, 1985, 22112, 22110
8835, 1912, 21817, 21827, 1913, 22093, 22113, 22114, 1935
8836, 21817, 21818, 21828, 21827, 22095, 22115, 22116, 22113
8837, 21818, 21819, 21829, 21828, 22097, 22117, 22118, 22115
8838, 21819, 21820, 21830, 21829, 22099, 22119, 22120, 22117
8839, 21820, 21821, 21831, 21830, 22101, 22121, 22122, 22119
8840, 21821, 21822, 21832, 21831, 22103, 22123, 22124, 22121
8841, 21822, 21823, 21833, 21832, 22105, 22125, 22126, 22123
8842, 21823, 21824, 21834, 21833, 22107, 22127, 22128, 22125
8843, 21824, 21825, 21835, 21834, 22109, 22129, 22130, 22127
8844, 21825, 21826, 21836, 21835, 22111, 22131, 22132, 22129
8845, 21826, 1963, 1964, 21836, 22112, 1986, 22133, 22131
8846, 1913, 21827, 21837, 1914, 22114, 22134, 22135, 1936
8847, 21827, 21828, 21838, 21837, 22116, 22136, 22137, 22134
8848, 21828, 21829, 21839, 21838, 22118, 22138, 22139, 22136
8849, 21829, 21830, 21840, 21839, 22120, 22140, 22141, 22138
8850, 21830, 21831, 21841, 21840, 22122, 22142, 22143, 22140
8851, 21831, 21832, 21842, 21841, 22124, 22144, 22145, 22142
8852, 21832, 21833, 21843, 21842, 22126, 22146, 22147, 22144
8853, 21833, 21834, 21844, 21843, 22128, 22148, 22149, 22146
8854, 21834, 21835, 21845, 21844, 22130, 22150, 22151, 22148
8855, 21835, 21836, 21846, 21845, 22132, 22152, 22153, 22150
8856, 21836, 1964, 1965, 21846, 22133, 1987, 22154, 22152
8857, 1914, 21837, 21847, 1915, 22135, 22155, 22156, 1937
8858, 21837, 21838, 21848, 21847, 22137, 22157, 22158, 22155
8859, 21838, 21839, 21849, 21848, 22139, 22159, 22160, 22157
8860, 21839, 21840, 21850, 21849, 22141, 22161, 22162, 22159
8861, 21840, 21841, 21851, 21850, 22143, 22163, 22164, 22161
8862, 21841, 21842, 21852, 21851, 22145, 22165, 22166, 22163
8863, 21842, 21843, 21853, 21852, 22147, 22167, 22168, 22165
8864, 21843, 21844, 21854, 21853, 22149, 22169, 22170, 22167
8865, 21844, 21845, 21855, 21854, 22151, 22171, 22172, 22169
8866, 21845, 21846, 21856, 21855, 22153, 22173, 22174, 22171
8867, 21846, 1965, 1966, 21856, 22154, 1988, 22175, 22173
8868, 1915, 21847, 21857, 1916, 22156, 22176, 22177, 1938
8869, 21847, 21848, 21858, 21857, 22158, 22178, 22179, 22176
8870, 21848, 21849, 21859, 21858, 22160, 22180, 22181, 22178
8871, 21849, 21850, 21860, 21859, 22162, 22182, 22183, 22180
8872, 21850, 21851, 21861, 21860, 22164, 22184, 22185, 22182
8873, 21851, 21852, 21862, 21861, 22166, 22186, 22187, 22184
8874, 21852, 21853, 21863, 21862, 22168, 22188, 22189, 22186
8875, 21853, 21854, 21864, 21863, 22170, 22190, 22191, 22188
8876, 21854, 21855, 21865, 21864, 22172, 22192, 22193, 22190
8877, 21855, 21856, 21866, 21865, 22174, 22194, 22195, 22192
8878, 21856, 1966, 1967, 21866, 22175, 1989, 22196, 22194
8879, 1916, 21857, 21867, 1917, 22177, 22197, 22198, 1939
8880, 21857, 21858, 21868, 21867, 22179, 22199, 22200, 22197
8881, 21858, 21859, 21869, 21868, 22181, 22201, 22202, 22199
8882, 21859, 21860, 21870, 21869, 22183, 22203, 22204, 22201
8883, 21860, 21861, 21871, 21870, 22185, 22205, 22206, 22203
8884, 21861, 21862, 21872, 21871, 22187, 22207, 22208, 22205
8885, 21862, 21863, 21873, 21872, 22189, 22209, 22210, 22207
8886, 21863, 21864, 21874, 21873, 22191, 22211, 22212, 22209
8887, 21864, 21865, 21875, 21874, 22193, 22213, 22214, 22211
8888, 21865, 21866, 21876, 21875, 22195, 22215, 22216, 22213
8889, 21866, 1967, 1968, 21876, 22196, 1990, 22217, 22215
8890, 1917, 21867, 21877, 1918, 22198, 22218, 22219, 1940
8891, 21867, 21868, 21878, 21877, 22200, 22220, 22221, 22218
8892, 21868, 21869, 21879, 21878, 22202, 22222, 22223, 22220
8893, 21869, 21870, 21880, 21879, 22204, 22224, 22225, 22222
8894, 21870, 21871, 21881, 21880, 22206, 22226, 22227, 22224
8895, 21871, 21872, 21882, 21881, 22208, 22228, 22229, 22226
8896, 21872, 21873, 21883, 21882, 22210, 22230, 22231, 22228
8897, 21873, 21874, 21884, 21883, 22212, 22232, 22233, 22230
8898, 21874, 21875, 21885, 21884, 22214, 22234, 22235, 22232
8899, 21875, 21876, 21886, 21885, 22216, 22236, 22237, 22234
8900, 21876, 1968, 1969, 21886, 22217, 1991, 22238, 22236
8901, 1918, 21877, 21887, 1919, 22219, 22239, 22240, 1941
8902, 21877, 21878, 21888, 21887, 22221, 22241, 22242, 22239
8903, 21878, 21879, 21889, 21888, 22223, 22243, 22244, 22241
8904, 21879, 21880, 21890, 21889, 22225, 22245, 22246, 22243
8905, 21880, 21881, 21891, 21890, 22227, 22247, 22248, 22245
8906, 21881, 21882, 21892, 21891, 22229, 22249, 22250, 22247
8907, 21882, 21883, 21893, 21892, 22231, 22251, 22252, 22249
8908, 21883, 21884, 21894, 21893, 22233, 22253, 22254, 22251
8909, 21884, 21885, 21895, 21894, 22235, 22255, 22256, 22253
8910, 21885, 21886, 21896, 21895, 22237, 22257, 22258, 22255
8911, 21886, 1969, 1970, 21896, 22238, 1992, 22259, 22257
8912, 1919, 21887, 21897, 1920, 22240, 22260, 22261, 1942
8913, 21887, 21888, 21898, 21897, 22242, 22262, 22263, 22260
8914, 21888, 21889, 21899, 21898, 22244, 22264, 22265, 22262
8915, 21889, 21890, 21900, 21899, 22246, 22266, 22267, 22264
8916, 21890, 21891, 21901, 21900, 22248, 22268, 22269, 22266
8917, 21891, 21892, 21902, 21901, 22250, 22270, 22271, 22268
8918, 21892, 21893, 21903, 21902, 22252, 22272, 22273, 22270
8919, 21893, 21894, 21904, 21903, 22254, 22274, 22275, 22272
8920, 21894, 21895, 21905, 21904, 22256, 22276, 22277, 22274
8921, 21895, 21896, 21906, 21905, 22258, 22278, 22279, 22276
8922, 21896, 1970, 1971, 21906, 22259, 1993, 22280, 22278
8923, 1920, 21897, 21907, 1921, 22261, 22281, 22282, 1943
8924, 21897, 21898, 21908, 21907, 22263, 22283, 22284, 22281
8925, 21898, 21899, 21909, 21908, 22265, 22285, 22286, 22283
8926, 21899, 21900, 21910, 21909, 22267, 22287, 22288, 22285
8927, 21900, 21901, 21911, 21910, 22269, 22289, 22290, 22287
8928, 21901, 21902, 21912, 21911, 22271, 22291, 22292, 22289
8929, 21902, 21903, 21913, 21912, 22273, 22293, 22294, 22291
8930, 21903, 21904, 21914, 21913, 22275, 22295, 22296, 22293
8931, 21904, 21905, 21915, 21914, 22277, 22297, 22298, 22295
8932, 21905, 21906, 21916, 21915, 22279, 22299, 22300, 22297
8933, 21906, 1971, 1972, 21916, 22280, 1994, 22301, 22299
8934, 1921, 21907, 21917, 1922, 22282, 22302, 22303, 1944
8935, 21907, 21908, 21918, 21917, 22284, 22304, 22305, 22302
8936, 21908, 21909, 21919, 21918, 22286, 22306, 22307, 22304
8937, 21909, 21910, 21920, 21919, 22288, 22308, 22309, 22306
8938, 21910, 21911, 21921, 21920, 22290, 22310, 22311, 22308
8939, 21911, 21912, 21922, 21921, 22292, 22312, 22313, 22310
8940, 21912, 21913, 21923, 21922, 22294, 22314, 22315, 22312
8941, 21913, 21914, 21924, 21923, 22296, 22316, 22317, 22314
8942, 21914, 21915, 21925, 21924, 22298, 22318, 22319, 22316
8943, 21915, 21916, 21926, 21925, 22300, 22320, 22321, 22318
8944, 21916, 1972, 1973, 21926, 22301, 1995, 22322, 22320
8945, 1922, 21917, 21927, 1923, 22303, 22323, 22324, 1945
8946, 21917, 21918, 21928, 21927, 22305, 22325, 22326, 22323
8947, 21918, 21919, 21929, 21928, 22307, 22327, 22328, 22325
8948, 21919, 21920, 21930, 21929, 22309, 22329, 22330, 22327
8949, 21920, 21921, 21931, 21930, 22311, 22331, 22332, 22329
8950, 21921, 21922, 21932, 21931, 22313, 22333, 22334, 22331
8951, 21922, 21923, 21933, 21932, 22315, 22335, 22336, 22333
8952, 21923, 21924, 21934, 21933, 22317, 22337, 22338, 22335
8953, 21924, 21925, 21935, 21934, 22319, 22339, 22340, 22337
8954, 21925, 21926, 21936, 21935, 22321, 22341, 22342, 22339
8955, 21926, 1973, 1974, 21936, 22322, 1996, 22343, 22341
8956, 1923, 21927, 21937, 1924, 22324, 22344, 22345, 1946
8957, 21927, 21928, 21938, 21937, 22326, 22346, 22347, 22344
8958, 21928, 21929, 21939, 21938, 22328, 22348, 22349, 22346
8959, 21929, 21930, 21940, 21939, 22330, 22350, 22351, 22348
8960, 21930, 21931, 21941, 21940, 22332, 22352, 22353, 22350
8961, 21931, 21932, 21942, 21941, 22334, 22354, 22355, 22352
8962, 21932, 21933, 21943, 21942, 22336, 22356, 22357, 22354
8963, 21933, 21934, 21944, 21943, 22338, 22358, 22359, 22356
8964, 21934, 21935, 21945, 21944, 22340, 22360, 22361, 22358
8965, 21935, 21936, 21946, 21945, 22342, 22362, 22363, 22360
8966, 21936, 1974, 1975, 21946, 22343, 1997, 22364, 22362
8967, 1924, 21937, 21947, 1925, 22345, 22365, 22366, 1947
8968, 21937, 21938, 21948, 21947, 22347, 22367, 22368, 22365
8969, 21938, 21939, 21949, 21948, 22349, 22369, 22370, 22367
8970, 21939, 21940, 21950, 21949, 22351, 22371, 22372, 22369
8971, 21940, 21941, 21951, 21950, 22353, 22373, 22374, 22371
8972, 21941, 21942, 21952, 21951, 22355, 22375, 22376, 22373
8973, 21942, 21943, 21953, 21952, 22357, 22377, 22378, 22375
8974, 21943, 21944, 21954, 21953, 22359, 22379, 22380, 22377
8975, 21944, 21945, 21955, 21954, 22361, 22381, 22382, 22379
8976, 21945, 21946, 21956, 21955, 22363, 22383, 22384, 22381
8977, 21946, 1975, 1976, 21956, 22364, 1998, 22385, 22383
8978, 1925, 21947, 21957, 1926, 22366, 22386, 22387, 1948
8979, 21947, 21948, 21958, 21957, 22368, 22388, 22389, 22386
8980, 21948, 21949, 21959, 21958, 22370, 22390, 22391, 22388
8981, 21949, 21950, 21960, 21959, 22372, 22392, 22393, 22390
8982, 21950, 21951, 21961, 21960, 22374, 22394, 22395, 22392
8983, 21951, 21952, 21962, 21961, 22376, 22396, 22397, 22394
8984, 21952, 21953, 21963, 21962, 22378, 22398, 22399, 22396
8985, 21953, 21954, 21964, 21963, 22380, 22400, 22401, 22398
8986, 21954, 21955, 21965, 21964, 22382, 22402, 22403, 22400
8987, 21955, 21956, 21966, 21965, 22384, 22404, 22405, 22402
8988, 21956, 1976, 1977, 21966, 22385, 1999, 22406, 22404
8989, 1926, 21957, 21967, 1927, 22387, 22407, 22408, 1949
8990, 21957, 21958, 21968, 21967, 22389, 22409, 22410, 22407
8991, 21958, 21959, 21969, 21968, 22391, 22411, 22412, 22409
8992, 21959, 21960, 21970, 21969, 22393, 22413, 22414, 22411
8993, 21960, 21961, 21971, 21970, 22395, 22415, 22416, 22413
8994, 21961, 21962, 21972, 21971, 22397, 22417, 22418, 22415
8995, 21962, 21963, 21973, 21972, 22399, 22419, 22420, 22417
8996, 21963, 21964, 21974, 21973, 22401, 22421, 22422, 22419
8997, 21964, 21965, 21975, 21974, 22403, 22423, 22424, 22421
8998, 21965, 21966, 21976, 21975, 22405, 22425, 22426, 22423
8999, 21966, 1977, 1978, 21976, 22406, 2000, 22427, 22425
9000, 1927, 21967, 21977, 1928, 22408, 22428, 22429, 1950
9001, 21967, 21968, 21978, 21977, 22410, 22430, 22431, 22428
9002, 21968, 21969, 21979, 21978, 22412, 22432, 22433, 22430
9003, 21969, 21970, 21980, 21979, 22414, 22434, 22435, 22432
9004, 21970, 21971, 21981, 21980, 22416, 22436, 22437, 22434
9005, 21971, 21972, 21982, 21981, 22418, 22438, 22439, 22436
9006, 21972, 21973, 21983, 21982, 22420, 22440, 22441, 22438
9007, 21973, 21974, 21984, 21983, 22422, 22442, 22443, 22440
9008, 21974, 21975, 21985, 21984, 22424, 22444, 22445, 22442
9009, 21975, 21976, 21986, 21985, 22426, 22446, 22447, 22444
9010, 21976, 1978, 1979, 21986, 22427, 2001, 22448, 22446
9011, 1928, 21977, 2033, 42, 22429, 22449, 2044, 1951
9012, 21977, 21978, 2032, 2033, 22431, 22450, 2043, 22449
9013, 21978, 21979, 2031, 2032, 22433, 22451, 2042, 22450
9014, 21979, 21980, 2030, 2031, 22435, 22452, 2041, 22451
9015, 21980, 21981, 2029, 2030, 22437, 22453, 2040, 22452
9016, 21981, 21982, 2028, 2029, 22439, 22454, 2039, 22453
9017, 21982, 21983, 2027, 2028, 22441, 22455, 2038, 22454
9018, 21983, 21984, 2026, 2027, 22443, 22456, 2037, 22455
9019, 21984, 21985, 2025, 2026, 22445, 22457, 2036, 22456
9020, 21985, 21986, 2024, 2025, 22447, 22458, 2035, 22457
9021, 21986, 1979, 44, 2024, 22448, 2002, 2034, 22458
*ELEMENT, type=CPS8, ELSET=Surface55
9022, 42, 2045, 22459, 2033, 2047, 22479, 22480, 2044
9023, 2033, 22459, 22460, 2032, 22480, 22481, 22482, 2043
9024, 2032, 22460, 22461, 2031, 22482, 22483, 22484, 2042
9025, 2031, 22461, 22462, 2030, 22484, 22485, 22486, 2041
9026, 2030, 22462, 22463, 2029, 22486, 22487, 22488, 2040
9027, 2029, 22463, 22464, 2028, 22488, 22489, 22490, 2039
9028, 2028, 22464, 22465, 2027, 22490, 22491, 22492, 2038
9029, 2027, 22465, 22466, 2026, 22492, 22493, 22494, 2037
9030, 2026, 22466, 22467, 2025, 22494, 22495, 22496, 2036
9031, 2025, 22467, 22468, 2024, 22496, 22497, 22498, 2035
9032, 2024, 22468, 2050, 44, 22498, 22499, 2052, 2034
9033, 2045, 2046, 22469, 22459, 2048, 22500, 22501, 22479
9034, 22459, 22469, 22470, 22460, 22501, 22502, 22503, 22481
9035, 22460, 22470, 22471, 22461, 22503, 22504, 22505, 22483
9036, 22461, 22471, 22472, 22462, 22505, 22506, 22507, 22485
9037, 22462, 22472, 22473, 22463, 22507, 22508, 22509, 22487
9038, 22463, 22473, 22474, 22464, 22509, 22510, 22511, 22489
9039, 22464, 22474, 22475, 22465, 22511, 22512, 22513, 22491
9040, 22465, 22475, 22476, 22466, 22513, 22514, 22515, 22493
9041, 22466, 22476, 22477, 22467, 22515, 22516, 22517, 22495
9042, 22467, 22477, 22478, 22468, 22517, 22518, 22519, 22497
9043, 22468, 22478, 2051, 2050, 22519, 22520, 2053, 22499
9044, 2046, 45, 2064, 22469, 2049, 2075, 22521, 22500
9045, 22469, 2064, 2063, 22470, 22521, 2074, 22522, 22502
9046, 22470, 2063, 2062, 22471, 22522, 2073, 22523, 22504
9047, 22471, 2062, 2061, 22472, 22523, 2072, 22524, 22506
9048, 22472, 2061, 2060, 22473, 22524, 2071, 22525, 22508
9049, 22473, 2060, 2059, 22474, 22525, 2070, 22526, 22510
9050, 22474, 2059, 2058, 22475, 22526, 2069, 22527, 22512
9051, 22475, 2058, 2057, 22476, 22527, 2068, 22528, 22514
9052, 22476, 2057, 2056, 22477, 22528, 2067, 22529, 22516
9053, 22477, 2056, 2055, 22478, 22529, 2066, 22530, 22518
9054, 22478, 2055, 46, 2051, 22530, 2065, 2054, 22520
*ELEMENT, type=CPS8, ELSET=Surface57
9055, 42, 2045, 22531, 2076, 2047, 22535, 22536, 2078
9056, 2045, 2046, 22532, 22531, 2048, 22537, 22538, 22535
9057, 2046, 45, 2081, 22532, 2049, 2083, 22539, 22537
9058, 2076, 22531, 22533, 2077, 22536, 22540, 22541, 2079
9059, 22531, 22532, 22534, 22533, 22538, 22542, 22543, 22540
9060, 22532, 2081, 2082, 22534, 22539, 2084, 22544, 22542
9061, 2077, 22533, 2086, 47, 22541, 22545, 2088, 2080
9062, 22533, 22534, 2087, 2086, 22543, 22546, 2089, 22545
9063, 22534, 2082, 48, 2087, 22544, 2085, 2090, 22546
*ELEMENT, type=CPS8, ELSET=Surface58
9064, 44, 2091, 22547, 2050, 2093, 22551, 22552, 2052
9065, 2050, 22547, 22548, 2051, 22552, 22553, 22554, 2053
9066, 2051, 22548, 2096, 46, 22554, 22555, 2098, 2054
9067, 2091, 2092, 22549, 22547, 2094, 22556, 22557, 22551
9068, 22547, 22549, 22550, 22548, 22557, 22558, 22559, 22553
9069, 22548, 22550, 2097, 2096, 22559, 22560, 2099, 22555
9070, 2092, 49, 2101, 22549, 2095, 2103, 22561, 22556
9071, 22549, 2101, 2102, 22550, 22561, 2104, 22562, 22558
9072, 22550, 2102, 50, 2097, 22562, 2105, 2100, 22560
*ELEMENT, type=CPS8, ELSET=Surface59
9073, 42, 2076, 22563, 2033, 2078, 22583, 22584, 2044
9074, 2033, 22563, 22564, 2032, 22584, 22585, 22586, 2043
9075, 2032, 22564, 22565, 2031, 22586, 22587, 22588, 2042
9076, 2031, 22565, 22566, 2030, 22588, 22589, 22590, 2041
9077, 2030, 22566, 22567, 2029, 22590, 22591, 22592, 2040
9078, 2029, 22567, 22568, 2028, 22592, 22593, 22594, 2039
9079, 2028, 22568, 22569, 2027, 22594, 22595, 22596, 2038
9080, 2027, 22569, 22570, 2026, 22596, 22597, 22598, 2037
9081, 2026, 22570, 22571, 2025, 22598, 22599, 22600, 2036
9082, 2025, 22571, 22572, 2024, 22600, 22601, 22602, 2035
9083, 2024, 22572, 2091, 44, 22602, 22603, 2093, 2034
9084, 2076, 2077, 22573, 22563, 2079, 22604, 22605, 22583
9085, 22563, 22573, 22574, 22564, 22605, 22606, 22607, 22585
9086, 22564, 22574, 22575, 22565, 22607, 22608, 22609, 22587
9087, 22565, 22575, 22576, 22566, 22609, 22610, 22611, 22589
9088, 22566, 22576, 22577, 22567, 22611, 22612, 22613, 22591
9089, 22567, 22577, 22578, 22568, 22613, 22614, 22615, 22593
9090, 22568, 22578, 22579, 22569, 22615, 22616, 22617, 22595
9091, 22569, 22579, 22580, 22570, 22617, 22618, 22619, 22597
9092, 22570, 22580, 22581, 22571, 22619, 22620, 22621, 22599
9093, 22571, 22581, 22582, 22572, 22621, 22622, 22623, 22601
9094, 22572, 22582, 2092, 2091, 22623, 22624, 2094, 22603
9095, 2077, 47, 2115, 22573, 2080, 2126, 22625, 22604
9096, 22573, 2115, 2114, 22574, 22625, 2125, 22626, 22606
9097, 22574, 2114, 2113, 22575, 22626, 2124, 22627, 22608
9098, 22575, 2113, 2112, 22576, 22627, 2123, 22628, 22610
9099, 22576, 2112, 2111, 22577, 22628, 2122, 22629, 22612
9100, 22577, 2111, 2110, 22578, 22629, 2121, 22630, 22614
9101, 22578, 2110, 2109, 22579, 22630, 2120, 22631, 22616
9102, 22579, 2109, 2108, 22580, 22631, 2119, 22632, 22618
9103, 22580, 2108, 2107, 22581, 22632, 2118, 22633, 22620
9104, 22581, 2107, 2106, 22582, 22633, 2117, 22634, 22622
9105, 22582, 2106, 49, 2092, 22634, 2116, 2095, 22624
*ELEMENT, type=CPS8, ELSET=Surface60
9106, 45, 2064, 22635, 2081, 2075, 22655, 22656, 2083
9107, 2064, 2063, 22636, 22635, 2074, 22657, 22658, 22655
9108, 2063, 2062, 22637, 22636, 2073, 22659, 22660, 22657
9109, 2062, 2061, 22638, 22637, 2072, 22661, 22662, 22659
9110, 2061, 2060, 22639, 22638, 2071, 22663, 22664, 22661
9111, 2060, 2059, 22640, 22639, 2070, 22665, 22666, 22663
9112, 2059, 2058, 22641, 22640, 2069, 22667, 22668, 22665
9113, 2058, 2057, 22642, 22641, 2068, 22669, 22670, 22667
9114, 2057, 2056, 22643, 22642, 2067, 22671, 22672, 22669
9115, 2056, 2055, 22644, 22643, 2066, 22673, 22674, 22671
9116, 2055, 46, 2096, 22644, 2065, 2098, 22675, 22673
9117, 2081, 22635, 22645, 2082, 22656, 22676, 22677, 2084
9118, 22635, 22636, 22646, 22645, 22658, 22678, 22679, 22676
9119, 22636, 22637, 22647, 22646, 22660, 22680, 22681, 22678
9120, 22637, 22638, 22648, 22647, 22662, 22682, 22683, 22680
9121, 22638, 22639, 22649, 22648, 22664, 22684, 22685, 22682
9122, 22639, 22640, 22650, 22649, 22666, 22686, 22687, 22684
9123, 22640, 22641, 22651, 22650, 22668, 22688, 22689, 22686
9124, 22641, 22642, 22652, 22651, 22670, 22690, 22691, 22688
9125, 22642, 22643, 22653, 22652, 22672, 22692, 22693, 22690
9126, 22643, 22644, 22654, 22653, 22674, 22694, 22695, 22692
9127, 22644, 2096, 2097, 22654, 22675, 2099, 22696, 22694
9128, 2082, 22645, 2136, 48, 22677, 22697, 2147, 2085
9129, 22645, 22646, 2135, 2136, 22679, 22698, 2146, 22697
9130, 22646, 22647, 2134, 2135, 22681, 22699, 2145, 22698
9131, 22647, 22648, 2133, 2134, 22683, 22700, 2144, 22699
9132, 22648, 22649, 2132, 2133, 22685, 22701, 2143, 22700
9133, 22649, 22650, 2131, 2132, 22687, 22702, 2142, 22701
9134, 22650, 22651, 2130, 2131, 22689, 22703, 2141, 22702
9135, 22651, 22652, 2129, 2130, 22691, 22704, 2140, 22703
9136, 22652, 22653, 2128, 2129, 22693, 22705, 2139, 22704
9137, 22653, 22654, 2127, 2128, 22695, 22706, 2138, 22705
9138, 22654, 2097, 50, 2127, 22696, 2100, 2137, 22706
*ELEMENT, type=CPS8, ELSET=Surface61
9139, 47, 2086, 22707, 2115, 2088, 22727, 22728, 2126
9140, 2115, 22707, 22708, 2114, 22728, 22729, 22730, 2125
9141, 2114, 22708, 22709, 2113, 22730, 22731, 22732, 2124
9142, 2113, 22709, 22710, 2112, 22732, 22733, 22734, 2123
9143, 2112, 22710, 22711, 2111, 22734, 22735, 22736, 2122
9144, 2111, 22711, 22712, 2110, 22736, 22737, 22738, 2121
9145, 2110, 22712, 22713, 2109, 22738, 22739, 22740, 2120
9146, 2109, 22713, 22714, 2108, 22740, 22741, 22742, 2119
9147, 2108, 22714, 22715, 2107, 22742, 22743, 22744, 2118
9148, 2107, 22715, 22716, 2106, 22744, 22745, 22746, 2117
9149, 2106, 22716, 2101, 49, 22746, 22747, 2103, 2116
9150, 2086, 2087, 22717, 22707, 2089, 22748, 22749, 22727
9151, 22707, 22717, 22718, 22708, 22749, 22750, 22751, 22729
9152, 22708, 22718, 22719, 22709, 22751, 22752, 22753, 22731
9153, 22709, 22719, 22720, 22710, 22753, 22754, 22755, 22733
9154, 22710, 22720, 22721, 22711, 22755, 22756, 22757, 22735
9155, 22711, 22721, 22722, 22712, 22757, 22758, 22759, 22737
9156, 22712, 22722, 22723, 22713, 22759, 22760, 22761, 22739
9157, 22713, 22723, 22724, 22714, 22761, 22762, 22763, 22741
9158, 22714, 22724, 22725, 22715, 22763, 22764, 22765, 22743
9159, 22715, 22725, 22726, 22716, 22765, 22766, 22767, 22745
9160, 22716, 22726, 2102, 2101, 22767, 22768, 2104, 22747
9161, 2087, 48, 2136, 22717, 2090, 2147, 22769, 22748
9162, 22717, 2136, 2135, 22718, 22769, 2146, 22770, 22750
9163, 22718, 2135, 2134, 22719, 22770, 2145, 22771, 22752
9164, 22719, 2134, 2133, 22720, 22771, 2144, 22772, 22754
9165, 22720, 2133, 2132, 22721, 22772, 2143, 22773, 22756
9166, 22721, 2132, 2131, 22722, 22773, 2142, 22774, 22758
9167, 22722, 2131, 2130, 22723, 22774, 2141, 22775, 22760
9168, 22723, 2130, 2129, 22724, 22775, 2140, 22776, 22762
9169, 22724, 2129, 2128, 22725, 22776, 2139, 22777, 22764
9170, 22725, 2128, 2127, 22726, 22777, 2138, 22778, 22766
9171, 22726, 2127, 50, 2102, 22778, 2137, 2105, 22768
*ELEMENT, type=CPS8, ELSET=Surface62
9172, 1, 2148, 22779, 98, 2150, 22799, 22800, 109
9173, 98, 22779, 22780, 97, 22800, 22801, 22802, 108
9174, 97, 22780, 22781, 96, 22802, 22803, 22804, 107
9175, 96, 22781, 22782, 95, 22804, 22805, 22806, 106
9176, 95, 22782, 22783, 94, 22806, 22807, 22808, 105
9177, 94, 22783, 22784, 93, 22808, 22809, 22810, 104
9178, 93, 22784, 22785, 92, 22810, 22811, 22812, 103
9179, 92, 22785, 22786, 91, 22812, 22813, 22814, 102
9180, 91, 22786, 22787, 90, 22814, 22815, 22816, 101
9181, 90, 22787, 22788, 89, 22816, 22817, 22818, 100
9182, 89, 22788, 2153, 2, 22818, 22819, 2155, 99
9183, 2148, 2149, 22789, 22779, 2151, 22820, 22821, 22799
9184, 22779, 22789, 22790, 22780, 22821, 22822, 22823, 22801
9185, 22780, 22790, 22791, 22781, 22823, 22824, 22825, 22803
9186, 22781, 22791, 22792, 22782, 22825, 22826, 22827, 22805
9187, 22782, 22792, 22793, 22783, 22827, 22828, 22829, 22807
9188, 22783, 22793, 22794, 22784, 22829, 22830, 22831, 22809
9189, 22784, 22794, 22795, 22785, 22831, 22832, 22833, 22811
9190, 22785, 22795, 22796, 22786, 22833, 22834, 22835, 22813
9191, 22786, 22796, 22797, 22787, 22835, 22836, 22837, 22815
9192, 22787, 22797, 22798, 22788, 22837, 22838, 22839, 22817
9193, 22788, 22798, 2154, 2153, 22839, 22840, 2156, 22819
9194, 2149, 51, 2167, 22789, 2152, 2178, 22841, 22820
9195, 22789, 2167, 2166, 22790, 22841, 2177, 22842, 22822
9196, 22790, 2166, 2165, 22791, 22842, 2176, 22843, 22824
9197, 22791, 2165, 2164, 22792, 22843, 2175, 22844, 22826
9198, 22792, 2164, 2163, 22793, 22844, 2174, 22845, 22828
9199, 22793, 2163, 2162, 22794, 22845, 2173, 22846, 22830
9200, 22794, 2162, 2161, 22795, 22846, 2172, 22847, 22832
9201, 22795, 2161, 2160, 22796, 22847, 2171, 22848, 22834
9202, 22796, 2160, 2159, 22797, 22848, 2170, 22849, 22836
9203, 22797, 2159, 2158, 22798, 22849, 2169, 22850, 22838
9204, 22798, 2158, 52, 2154, 22850, 2168, 2157, 22840
*ELEMENT, type=CPS8, ELSET=Surface63
9205, 3, 2179, 22851, 111, 2181, 22855, 22856, 114
9206, 111, 22851, 22852, 110, 22856, 22857, 22858, 113
9207, 110, 22852, 2148, 1, 22858, 22859, 2150, 112
9208, 2179, 2180, 22853, 22851, 2182, 22860, 22861, 22855
9209, 22851, 22853, 22854, 22852, 22861, 22862, 22863, 22857
9210, 22852, 22854, 2149, 2148, 22863, 22864, 2151, 22859
9211, 2180, 53, 2185, 22853, 2183, 2188, 22865, 22860
9212, 22853, 2185, 2184, 22854, 22865, 2187, 22866, 22862
9213, 22854, 2184, 51, 2149, 22866, 2186, 2152, 22864
*ELEMENT, type=CPS8, ELSET=Surface64
9214, 3, 124, 22867, 2179, 135, 22887, 22888, 2181
9215, 124, 123, 22868, 22867, 134, 22889, 22890, 22887
9216, 123, 122, 22869, 22868, 133, 22891, 22892, 22889
9217, 122, 121, 22870, 22869, 132, 22893, 22894, 22891
9218, 121, 120, 22871, 22870, 131, 22895, 22896, 22893
9219, 120, 119, 22872, 22871, 130, 22897, 22898, 22895
9220, 119, 118, 22873, 22872, 129, 22899, 22900, 22897
9221, 118, 117, 22874, 22873, 128, 22901, 22902, 22899
9222, 117, 116, 22875, 22874, 127, 22903, 22904, 22901
9223, 116, 115, 22876, 22875, 126, 22905, 22906, 22903
9224, 115, 4, 2189, 22876, 125, 2191, 22907, 22905
9225, 2179, 22867, 22877, 2180, 22888, 22908, 22909, 2182
9226, 22867, 22868, 22878, 22877, 22890, 22910, 22911, 22908
9227, 22868, 22869, 22879, 22878, 22892, 22912, 22913, 22910
9228, 22869, 22870, 22880, 22879, 22894, 22914, 22915, 22912
9229, 22870, 22871, 22881, 22880, 22896, 22916, 22917, 22914
9230, 22871, 22872, 22882, 22881, 22898, 22918, 22919, 22916
9231, 22872, 22873, 22883, 22882, 22900, 22920, 22921, 22918
9232, 22873, 22874, 22884, 22883, 22902, 22922, 22923, 22920
9233, 22874, 22875, 22885, 22884, 22904, 22924, 22925, 22922
9234, 22875, 22876, 22886, 22885, 22906, 22926, 22927, 22924
9235, 22876, 2189, 2190, 22886, 22907, 2192, 22928, 22926
9236, 2180, 22877, 2203, 53, 22909, 22929, 2214, 2183
9237, 22877, 22878, 2202, 2203, 22911, 22930, 2213, 22929
9238, 22878, 22879, 2201, 2202, 22913, 22931, 2212, 22930
9239, 22879, 22880, 2200, 2201, 22915, 22932, 2211, 22931
9240, 22880, 22881, 2199, 2200, 22917, 22933, 2210, 22932
9241, 22881, 22882, 2198, 2199, 22919, 22934, 2209, 22933
9242, 22882, 22883, 2197, 2198, 22921, 22935, 2208, 22934
9243, 22883, 22884, 2196, 2197, 22923, 22936, 2207, 22935
9244, 22884, 22885, 2195, 2196, 22925, 22937, 2206, 22936
9245, 22885, 22886, 2194, 2195, 22927, 22938, 2205, 22937
9246, 22886, 2190, 54, 2194, 22928, 2193, 2204, 22938
*ELEMENT, type=CPS8, ELSET=Surface65
9247, 4, 137, 22939, 2189, 140, 22943, 22944, 2191
9248, 137, 136, 22940, 22939, 139, 22945, 22946, 22943
9249, 136, 2, 2153, 22940, 138, 2155, 22947, 22945
9250, 2189, 22939, 22941, 2190, 22944, 22948, 22949, 2192
9251, 22939, 22940, 22942, 22941, 22946, 22950, 22951, 22948
9252, 22940, 2153, 2154, 22942, 22947, 2156, 22952, 22950
9253, 2190, 22941, 2216, 54, 22949, 22953, 2219, 2193
9254, 22941, 22942, 2215, 2216, 22951, 22954, 2218, 22953
9255, 22942, 2154, 52, 2215, 22952, 2157, 2217, 22954
*ELEMENT, type=CPS8, ELSET=Surface66
9256, 52, 2158, 22955, 2215, 2168, 22975, 22976, 2217
9257, 2215, 22955, 22956, 2216, 22976, 22977, 22978, 2218
9258, 2216, 22956, 2194, 54, 22978, 22979, 2204, 2219
9259, 2158, 2159, 22957, 22955, 2169, 22980, 22981, 22975
9260, 22955, 22957, 22958, 22956, 22981, 22982, 22983, 22977
9261, 22956, 22958, 2195, 2194, 22983, 22984, 2205, 22979
9262, 2159, 2160, 22959, 22957, 2170, 22985, 22986, 22980
9263, 22957, 22959, 22960, 22958, 22986, 22987, 22988, 22982
9264, 22958, 22960, 2196, 2195, 22988, 22989, 2206, 22984
9265, 2160, 2161, 22961, 22959, 2171, 22990, 22991, 22985
9266, 22959, 22961, 22962, 22960, 22991, 22992, 22993, 22987
9267, 22960, 22962, 2197, 2196, 22993, 22994, 2207, 22989
9268, 2161, 2162, 22963, 22961, 2172, 22995, 22996, 22990
9269, 22961, 22963, 22964, 22962, 22996, 22997, 22998, 22992
9270, 22962, 22964, 2198, 2197, 22998, 22999, 2208, 22994
9271, 2162, 2163, 22965, 22963, 2173, 23000, 23001, 22995
9272, 22963, 22965, 22966, 22964, 23001, 23002, 23003, 22997
9273, 22964, 22966, 2199, 2198, 23003, 23004, 2209, 22999
9274, 2163, 2164, 22967, 22965, 2174, 23005, 23006, 23000
9275, 22965, 22967, 22968, 22966, 23006, 23007, 23008, 23002
9276, 22966, 22968, 2200, 2199, 23008, 23009, 2210, 23004
9277, 2164, 2165, 22969, 22967, 2175, 23010, 23011, 23005
9278, 22967, 22969, 22970, 22968, 23011, 23012, 23013, 23007
9279, 22968, 22970, 2201, 2200, 23013, 23014, 2211, 23009
9280, 2165, 2166, 22971, 22969, 2176, 23015, 23016, 23010
9281, 22969, 22971, 22972, 22970, 23016, 23017, 23018, 23012
9282, 22970, 22972, 2202, 2201, 23018, 23019, 2212, 23014
9283, 2166, 2167, 22973, 22971, 2177, 23020, 23021, 23015
9284, 22971, 22973, 22974, 22972, 23021, 23022, 23023, 23017
9285, 22972, 22974, 2203, 2202, 23023, 23024, 2213, 23019
9286, 2167, 51, 2184, 22973, 2178, 2186, 23025, 23020
9287, 22973, 2184, 2185, 22974, 23025, 2187, 23026, 23022
9288, 22974, 2185, 53, 2203, 23026, 2188, 2214, 23024
*ELEMENT, type=CPS8, ELSET=Surface105
9289, 21, 1004, 23027, 2220, 1027, 23093, 23094, 2223
9290, 1004, 1003, 23028, 23027, 1026, 23095, 23096, 23093
9291, 1003, 1002, 23029, 23028, 1025, 23097, 23098, 23095
9292, 1002, 1001, 23030, 23029, 1024, 23099, 23100, 23097
9293, 1001, 1000, 23031, 23030, 1023, 23101, 23102, 23099
9294, 1000, 999, 23032, 23031, 1022, 23103, 23104, 23101
9295, 999, 998, 23033, 23032, 1021, 23105, 23106, 23103
9296, 998, 997, 23034, 23033, 1020, 23107, 23108, 23105
9297, 997, 996, 23035, 23034, 1019, 23109, 23110, 23107
9298, 996, 995, 23036, 23035, 1018, 23111, 23112, 23109
9299, 995, 994, 23037, 23036, 1017, 23113, 23114, 23111
9300, 994, 993, 23038, 23037, 1016, 23115, 23116, 23113
9301, 993, 992, 23039, 23038, 1015, 23117, 23118, 23115
9302, 992, 991, 23040, 23039, 1014, 23119, 23120, 23117
9303, 991, 990, 23041, 23040, 1013, 23121, 23122, 23119
9304, 990, 989, 23042, 23041, 1012, 23123, 23124, 23121
9305, 989, 988, 23043, 23042, 1011, 23125, 23126, 23123
9306, 988, 987, 23044, 23043, 1010, 23127, 23128, 23125
9307, 987, 986, 23045, 23044, 1009, 23129, 23130, 23127
9308, 986, 985, 23046, 23045, 1008, 23131, 23132, 23129
9309, 985, 984, 23047, 23046, 1007, 23133, 23134, 23131
9310, 984, 983, 23048, 23047, 1006, 23135, 23136, 23133
9311, 983, 22, 2227, 23048, 1005, 2230, 23137, 23135
9312, 2220, 23027, 23049, 2221, 23094, 23138, 23139, 2224
9313, 23027, 23028, 23050, 23049, 23096, 23140, 23141, 23138
9314, 23028, 23029, 23051, 23050, 23098, 23142, 23143, 23140
9315, 23029, 23030, 23052, 23051, 23100, 23144, 23145, 23142
9316, 23030, 23031, 23053, 23052, 23102, 23146, 23147, 23144
9317, 23031, 23032, 23054, 23053, 23104, 23148, 23149, 23146
9318, 23032, 23033, 23055, 23054, 23106, 23150, 23151, 23148
9319, 23033, 23034, 23056, 23055, 23108, 23152, 23153, 23150
9320, 23034, 23035, 23057, 23056, 23110, 23154, 23155, 23152
9321, 23035, 23036, 23058, 23057, 23112, 23156, 23157, 23154
9322, 23036, 23037, 23059, 23058, 23114, 23158, 23159, 23156
9323, 23037, 23038, 23060, 23059, 23116, 23160, 23161, 23158
9324, 23038, 23039, 23061, 23060, 23118, 23162, 23163, 23160
9325, 23039, 23040, 23062, 23061, 23120, 23164, 23165, 23162
9326, 23040, 23041, 23063, 23062, 23122, 23166, 23167, 23164
9327, 23041, 23042, 23064, 23063, 23124, 23168, 23169, 23166
9328, 23042, 23043, 23065, 23064, 23126, 23170, 23171, 23168
9329, 23043, 23044, 23066, 23065, 23128, 23172, 23173, 23170
9330, 23044, 23045, 23067, 23066, 23130, 23174, 23175, 23172
9331, 23045, 23046, 23068, 23067, 23132, 23176, 23177, 23174
9332, 23046, 23047, 23069, 23068, 23134, 23178, 23179, 23176
9333, 23047, 23048, 23070, 23069, 23136, 23180, 23181, 23178
9334, 23048, 2227, 2228, 23070, 23137, 2231, 23182, 23180
9335, 2221, 23049, 23071, 2222, 23139, 23183, 23184, 2225
9336, 23049, 23050, 23072, 23071, 23141, 23185, 23186, 23183
9337, 23050, 23051, 23073, 23072, 23143, 23187, 23188, 23185
9338, 23051, 23052, 23074, 23073, 23145, 23189, 23190, 23187
9339, 23052, 23053, 23075, 23074, 23147, 23191, 23192, 23189
9340, 23053, 23054, 23076, 23075, 23149, 23193, 23194, 23191
9341, 23054, 23055, 23077, 23076, 23151, 23195, 23196, 23193
9342, 23055, 23056, 23078, 23077, 23153, 23197, 23198, 23195
9343, 23056, 23057, 23079, 23078, 23155, 23199, 23200, 23197
9344, 23057, 23058, 23080, 23079, 23157, 23201, 23202, 23199
9345, 23058, 23059, 23081, 23080, 23159, 23203, 23204, 23201
9346, 23059, 23060, 23082, 23081, 23161, 23205, 23206, 23203
9347, 23060, 23061, 23083, 23082, 23163, 23207, 23208, 23205
9348, 23061, 23062, 23084, 23083, 23165, 23209, 23210, 23207
9349, 23062, 23063, 23085, 23084, 23167, 23211, 23212, 23209
9350, 23063, 23064, 23086, 23085, 23169, 23213, 23214, 23211
9351, 23064, 23065, 23087, 23086, 23171, 23215, 23216, 23213
9352, 23065, 23066, 23088, 23087, 23173, 23217, 23218, 23215
9353, 23066, 23067, 23089, 23088, 23175, 23219, 23220, 23217
9354, 23067, 23068, 23090, 23089, 23177, 23221, 23222, 23219
9355, 23068, 23069, 23091, 23090, 23179, 23223, 23224, 23221
9356, 23069, 23070, 23092, 23091, 23181, 23225, 23226, 23223
9357, 23070, 2228, 2229, 23092, 23182, 2232, 23227, 23225
9358, 2222, 23071, 2255, 55, 23184, 23228, 2278, 2226
9359, 23071, 23072, 2254, 2255, 23186, 23229, 2277, 23228
9360, 23072, 23073, 2253, 2254, 23188, 23230, 2276, 23229
9361, 23073, 23074, 2252, 2253, 23190, 23231, 2275, 23230
9362, 23074, 23075, 2251, 2252, 23192, 23232, 2274, 23231
9363, 23075, 23076, 2250, 2251, 23194, 23233, 2273, 23232
9364, 23076, 23077, 2249, 2250, 23196, 23234, 2272, 23233
9365, 23077, 23078, 2248, 2249, 23198, 23235, 2271, 23234
9366, 23078, 23079, 2247, 2248, 23200, 23236, 2270, 23235
9367, 23079, 23080, 2246, 2247, 23202, 23237, 2269, 23236
9368, 23080, 23081, 2245, 2246, 23204, 23238, 2268, 23237
9369, 23081, 23082, 2244, 2245, 23206, 23239, 2267, 23238
9370, 23082, 23083, 2243, 2244, 23208, 23240, 2266, 23239
9371, 23083, 23084, 2242, 2243, 23210, 23241, 2265, 23240
9372, 23084, 23085, 2241, 2242, 23212, 23242, 2264, 23241
9373, 23085, 23086, 2240, 2241, 23214, 23243, 2263, 23242
9374, 23086, 23087, 2239, 2240, 23216, 23244, 2262, 23243
9375, 23087, 23088, 2238, 2239, 23218, 23245, 2261, 23244
9376, 23088, 23089, 2237, 2238, 23220, 23246, 2260, 23245
9377, 23089, 23090, 2236, 2237, 23222, 23247, 2259, 23246
9378, 23090, 23091, 2235, 2236, 23224, 23248, 2258, 23247
9379, 23091, 23092, 2234, 2235, 23226, 23249, 2257, 23248
9380, 23092, 2229, 56, 2234, 23227, 2233, 2256, 23249
*ELEMENT, type=CPS8, ELSET=Surface106
9381, 23, 1042, 23250, 2279, 1053, 23280, 23281, 2282
9382, 1042, 1041, 23251, 23250, 1052, 23282, 23283, 23280
9383, 1041, 1040, 23252, 23251, 1051, 23284, 23285, 23282
9384, 1040, 1039, 23253, 23252, 1050, 23286, 23287, 23284
9385, 1039, 1038, 23254, 23253, 1049, 23288, 23289, 23286
9386, 1038, 1037, 23255, 23254, 1048, 23290, 23291, 23288
9387, 1037, 1036, 23256, 23255, 1047, 23292, 23293, 23290
9388, 1036, 1035, 23257, 23256, 1046, 23294, 23295, 23292
9389, 1035, 1034, 23258, 23257, 1045, 23296, 23297, 23294
9390, 1034, 1033, 23259, 23258, 1044, 23298, 23299, 23296
9391, 1033, 21, 2220, 23259, 1043, 2223, 23300, 23298
9392, 2279, 23250, 23260, 2280, 23281, 23301, 23302, 2283
9393, 23250, 23251, 23261, 23260, 23283, 23303, 23304, 23301
9394, 23251, 23252, 23262, 23261, 23285, 23305, 23306, 23303
9395, 23252, 23253, 23263, 23262, 23287, 23307, 23308, 23305
9396, 23253, 23254, 23264, 23263, 23289, 23309, 23310, 23307
9397, 23254, 23255, 23265, 23264, 23291, 23311, 23312, 23309
9398, 23255, 23256, 23266, 23265, 23293, 23313, 23314, 23311
9399, 23256, 23257, 23267, 23266, 23295, 23315, 23316, 23313
9400, 23257, 23258, 23268, 23267, 23297, 23317, 23318, 23315
9401, 23258, 23259, 23269, 23268, 23299, 23319, 23320, 23317
9402, 23259, 2220, 2221, 23269, 23300, 2224, 23321, 23319
9403, 2280, 23260, 23270, 2281, 23302, 23322, 23323, 2284
9404, 23260, 23261, 23271, 23270, 23304, 23324, 23325, 23322
9405, 23261, 23262, 23272, 23271, 23306, 23326, 23327, 23324
9406, 23262, 23263, 23273, 23272, 23308, 23328, 23329, 23326
9407, 23263, 23264, 23274, 23273, 23310, 23330, 23331, 23328
9408, 23264, 23265, 23275, 23274, 23312, 23332, 23333, 23330
9409, 23265, 23266, 23276, 23275, 23314, 23334, 23335, 23332
9410, 23266, 23267, 23277, 23276, 23316, 23336, 23337, 23334
9411, 23267, 23268, 23278, 23277, 23318, 23338, 23339, 23336
9412, 23268, 23269, 23279, 23278, 23320, 23340, 23341, 23338
9413, 23269, 2221, 2222, 23279, 23321, 2225, 23342, 23340
9414, 2281, 23270, 2295, 57, 23323, 23343, 2306, 2285
9415, 23270, 23271, 2294, 2295, 23325, 23344, 2305, 23343
9416, 23271, 23272, 2293, 2294, 23327, 23345, 2304, 23344
9417, 23272, 23273, 2292, 2293, 23329, 23346, 2303, 23345
9418, 23273, 23274, 2291, 2292, 23331, 23347, 2302, 23346
9419, 23274, 23275, 2290, 2291, 23333, 23348, 2301, 23347
9420, 23275, 23276, 2289, 2290, 23335, 23349, 2300, 23348
9421, 23276, 23277, 2288, 2289, 23337, 23350, 2299, 23349
9422, 23277, 23278, 2287, 2288, 23339, 23351, 2298, 23350
9423, 23278, 23279, 2286, 2287, 23341, 23352, 2297, 23351
9424, 23279, 2222, 55, 2286, 23342, 2226, 2296, 23352
*ELEMENT, type=CPS8, ELSET=Surface107
9425, 23, 2279, 23353, 1080, 2282, 23419, 23420, 1103
9426, 1080, 23353, 23354, 1079, 23420, 23421, 23422, 1102
9427, 1079, 23354, 23355, 1078, 23422, 23423, 23424, 1101
9428, 1078, 23355, 23356, 1077, 23424, 23425, 23426, 1100
9429, 1077, 23356, 23357, 1076, 23426, 23427, 23428, 1099
9430, 1076, 23357, 23358, 1075, 23428, 23429, 23430, 1098
9431, 1075, 23358, 23359, 1074, 23430, 23431, 23432, 1097
9432, 1074, 23359, 23360, 1073, 23432, 23433, 23434, 1096
9433, 1073, 23360, 23361, 1072, 23434, 23435, 23436, 1095
9434, 1072, 23361, 23362, 1071, 23436, 23437, 23438, 1094
9435, 1071, 23362, 23363, 1070, 23438, 23439, 23440, 1093
9436, 1070, 23363, 23364, 1069, 23440, 23441, 23442, 1092
9437, 1069, 23364, 23365, 1068, 23442, 23443, 23444, 1091
9438, 1068, 23365, 23366, 1067, 23444, 23445, 23446, 1090
9439, 1067, 23366, 23367, 1066, 23446, 23447, 23448, 1089
9440, 1066, 23367, 23368, 1065, 23448, 23449, 23450, 1088
9441, 1065, 23368, 23369, 1064, 23450, 23451, 23452, 1087
9442, 1064, 23369, 23370, 1063, 23452, 23453, 23454, 1086
9443, 1063, 23370, 23371, 1062, 23454, 23455, 23456, 1085
9444, 1062, 23371, 23372, 1061, 23456, 23457, 23458, 1084
9445, 1061, 23372, 23373, 1060, 23458, 23459, 23460, 1083
9446, 1060, 23373, 23374, 1059, 23460, 23461, 23462, 1082
9447, 1059, 23374, 2307, 24, 23462, 23463, 2310, 1081
9448, 2279, 2280, 23375, 23353, 2283, 23464, 23465, 23419
9449, 23353, 23375, 23376, 23354, 23465, 23466, 23467, 23421
9450, 23354, 23376, 23377, 23355, 23467, 23468, 23469, 23423
9451, 23355, 23377, 23378, 23356, 23469, 23470, 23471, 23425
9452, 23356, 23378, 23379, 23357, 23471, 23472, 23473, 23427
9453, 23357, 23379, 23380, 23358, 23473, 23474, 23475, 23429
9454, 23358, 23380, 23381, 23359, 23475, 23476, 23477, 23431
9455, 23359, 23381, 23382, 23360, 23477, 23478, 23479, 23433
9456, 23360, 23382, 23383, 23361, 23479, 23480, 23481, 23435
9457, 23361, 23383, 23384, 23362, 23481, 23482, 23483, 23437
9458, 23362, 23384, 23385, 23363, 23483, 23484, 23485, 23439
9459, 23363, 23385, 23386, 23364, 23485, 23486, 23487, 23441
9460, 23364, 23386, 23387, 23365, 23487, 23488, 23489, 23443
9461, 23365, 23387, 23388, 23366, 23489, 23490, 23491, 23445
