67554, 1.7652173913043, 1.2717391304348, 0.22727272727273
67555, 1.7652173913043, 1.245652173913, 0.20454545454545
67556, 1.7434782608696, 1.245652173913, 0.18181818181818
67557, 1.7652173913043, 1.2717391304348, 0.18181818181818
67558, 1.7652173913043, 1.245652173913, 0.15909090909091
67559, 1.7434782608696, 1.245652173913, 0.13636363636364
67560, 1.7652173913043, 1.2717391304348, 0.13636363636364
67561, 1.7652173913043, 1.245652173913, 0.11363636363636
67562, 1.7434782608696, 1.245652173913, 0.090909090909091
67563, 1.7652173913043, 1.2717391304348, 0.090909090909091
67564, 1.7652173913043, 1.245652173913, 0.068181818181818
67565, 1.7434782608696, 1.245652173913, 0.045454545454545
67566, 1.7652173913043, 1.2717391304348, 0.045454545454545
67567, 1.7652173913043, 1.245652173913, 0.022727272727273
67568, 1.8086956521739, 1.245652173913, 0.47727272727273
67569, 1.7869565217391, 1.245652173913, 0.45454545454545
67570, 1.8086956521739, 1.2717391304348, 0.45454545454545
67571, 1.8086956521739, 1.245652173913, 0.43181818181818
67572, 1.7869565217391, 1.245652173913, 0.40909090909091
67573, 1.8086956521739, 1.2717391304348, 0.40909090909091
67574, 1.8086956521739, 1.245652173913, 0.38636363636364
67575, 1.7869565217391, 1.245652173913, 0.36363636363636
67576, 1.8086956521739, 1.2717391304348, 0.36363636363636
67577, 1.8086956521739, 1.245652173913, 0.34090909090909
67578, 1.7869565217391, 1.245652173913, 0.31818181818182
67579, 1.8086956521739, 1.2717391304348, 0.31818181818182
67580, 1.8086956521739, 1.245652173913, 0.29545454545455
67581, 1.7869565217391, 1.245652173913, 0.27272727272727
67582, 1.8086956521739, 1.2717391304348, 0.27272727272727
67583, 1.8086956521739, 1.245652173913, 0.25
67584, 1.7869565217391, 1.245652173913, 0.22727272727273
67585, 1.8086956521739, 1.2717391304348, 0.22727272727273
67586, 1.8086956521739, 1.245652173913, 0.20454545454545
67587, 1.7869565217391, 1.245652173913, 0.18181818181818
67588, 1.8086956521739, 1.2717391304348, 0.18181818181818
67589, 1.8086956521739, 1.245652173913, 0.15909090909091
67590, 1.7869565217391, 1.245652173913, 0.13636363636364
67591, 1.8086956521739, 1.2717391304348, 0.13636363636364
67592, 1.8086956521739, 1.245652173913, 0.11363636363636
67593, 1.7869565217391, 1.245652173913, 0.090909090909091
67594, 1.8086956521739, 1.2717391304348, 0.090909090909091
67595, 1.8086956521739, 1.245652173913, 0.068181818181818
67596, 1.7869565217391, 1.245652173913, 0.045454545454545
67597, 1.8086956521739, 1.2717391304348, 0.045454545454545
67598, 1.8086956521739, 1.245652173913, 0.022727272727273
67599, 1.8521739130435, 1.245652173913, 0.47727272727273
67600, 1.8304347826087, 1.245652173913, 0.45454545454545
67601, 1.8521739130435, 1.2717391304348, 0.45454545454545
67602, 1.8521739130435, 1.245652173913, 0.43181818181818
67603, 1.8304347826087, 1.245652173913, 0.40909090909091
67604, 1.8521739130435, 1.2717391304348, 0.40909090909091
67605, 1.8521739130435, 1.245652173913, 0.38636363636364
67606, 1.8304347826087, 1.245652173913, 0.36363636363636
67607, 1.8521739130435, 1.2717391304348, 0.36363636363636
67608, 1.8521739130435, 1.245652173913, 0.34090909090909
67609, 1.8304347826087, 1.245652173913, 0.31818181818182
67610, 1.8521739130435, 1.2717391304348, 0.31818181818182
67611, 1.8521739130435, 1.245652173913, 0.29545454545455
67612, 1.8304347826087, 1.245652173913, 0.27272727272727
67613, 1.8521739130435, 1.2717391304348, 0.27272727272727
67614, 1.8521739130435, 1.245652173913, 0.25
67615, 1.8304347826087, 1.245652173913, 0.22727272727273
67616, 1.8521739130435, 1.2717391304348, 0.22727272727273
67617, 1.8521739130435, 1.245652173913, 0.20454545454545
67618, 1.8304347826087, 1.245652173913, 0.18181818181818
67619, 1.8521739130435, 1.2717391304348, 0.18181818181818
67620, 1.8521739130435, 1.245652173913, 0.15909090909091
67621, 1.8304347826087, 1.245652173913, 0.13636363636364
67622, 1.8521739130435, 1.2717391304348, 0.13636363636364
67623, 1.8521739130435, 1.245652173913, 0.11363636363636
67624, 1.8304347826087, 1.245652173913, 0.090909090909091
67625, 1.8521739130435, 1.2717391304348, 0.090909090909091
67626, 1.8521739130435, 1.245652173913, 0.068181818181818
67627, 1.8304347826087, 1.245652173913, 0.045454545454545
67628, 1.8521739130435, 1.2717391304348, 0.045454545454545
67629, 1.8521739130435, 1.245652173913, 0.022727272727273
67630, 1.895652173913, 1.245652173913, 0.47727272727273
67631, 1.8739130434783, 1.245652173913, 0.45454545454545
67632, 1.895652173913, 1.2717391304348, 0.45454545454545
67633, 1.895652173913, 1.245652173913, 0.43181818181818
67634, 1.8739130434783, 1.245652173913, 0.40909090909091
67635, 1.895652173913, 1.2717391304348, 0.40909090909091
67636, 1.895652173913, 1.245652173913, 0.38636363636364
67637, 1.8739130434783, 1.245652173913, 0.36363636363636
67638, 1.895652173913, 1.2717391304348, 0.36363636363636
67639, 1.895652173913, 1.245652173913, 0.34090909090909
67640, 1.8739130434783, 1.245652173913, 0.31818181818182
67641, 1.895652173913, 1.2717391304348, 0.31818181818182
67642, 1.895652173913, 1.245652173913, 0.29545454545455
67643, 1.8739130434783, 1.245652173913, 0.27272727272727
67644, 1.895652173913, 1.2717391304348, 0.27272727272727
67645, 1.895652173913, 1.245652173913, 0.25
67646, 1.8739130434783, 1.245652173913, 0.22727272727273
67647, 1.895652173913, 1.2717391304348, 0.22727272727273
67648, 1.895652173913, 1.245652173913, 0.20454545454545
67649, 1.8739130434783, 1.245652173913, 0.18181818181818
67650, 1.895652173913, 1.2717391304348, 0.18181818181818
67651, 1.895652173913, 1.245652173913, 0.15909090909091
67652, 1.8739130434783, 1.245652173913, 0.13636363636364
67653, 1.895652173913, 1.2717391304348, 0.13636363636364
67654, 1.895652173913, 1.245652173913, 0.11363636363636
67655, 1.8739130434783, 1.245652173913, 0.090909090909091
67656, 1.895652173913, 1.2717391304348, 0.090909090909091
67657, 1.895652173913, 1.245652173913, 0.068181818181818
67658, 1.8739130434783, 1.245652173913, 0.045454545454545
67659, 1.895652173913, 1.2717391304348, 0.045454545454545
67660, 1.895652173913, 1.245652173913, 0.022727272727273
67661, 1.9391304347826, 1.245652173913, 0.47727272727273
67662, 1.9173913043478, 1.245652173913, 0.45454545454545
67663, 1.9391304347826, 1.2717391304348, 0.45454545454545
67664, 1.9391304347826, 1.245652173913, 0.43181818181818
67665, 1.9173913043478, 1.245652173913, 0.40909090909091
67666, 1.9391304347826, 1.2717391304348, 0.40909090909091
67667, 1.9391304347826, 1.245652173913, 0.38636363636364
67668, 1.9173913043478, 1.245652173913, 0.36363636363636
67669, 1.9391304347826, 1.2717391304348, 0.36363636363636
67670, 1.9391304347826, 1.245652173913, 0.34090909090909
67671, 1.9173913043478, 1.245652173913, 0.31818181818182
67672, 1.9391304347826, 1.2717391304348, 0.31818181818182
67673, 1.9391304347826, 1.245652173913, 0.29545454545455
67674, 1.9173913043478, 1.245652173913, 0.27272727272727
67675, 1.9391304347826, 1.2717391304348, 0.27272727272727
67676, 1.9391304347826, 1.245652173913, 0.25
67677, 1.9173913043478, 1.245652173913, 0.22727272727273
67678, 1.9391304347826, 1.2717391304348, 0.22727272727273
67679, 1.9391304347826, 1.245652173913, 0.20454545454545
67680, 1.9173913043478, 1.245652173913, 0.18181818181818
67681, 1.9391304347826, 1.2717391304348, 0.18181818181818
67682, 1.9391304347826, 1.245652173913, 0.15909090909091
67683, 1.9173913043478, 1.245652173913, 0.13636363636364
67684, 1.9391304347826, 1.2717391304348, 0.13636363636364
67685, 1.9391304347826, 1.245652173913, 0.11363636363636
67686, 1.9173913043478, 1.245652173913, 0.090909090909091
67687, 1.9391304347826, 1.2717391304348, 0.090909090909091
67688, 1.9391304347826, 1.245652173913, 0.068181818181818
67689, 1.9173913043478, 1.245652173913, 0.045454545454545
67690, 1.9391304347826, 1.2717391304348, 0.045454545454545
67691, 1.9391304347826, 1.245652173913, 0.022727272727273
67692, 1.9826086956522, 1.245652173913, 0.47727272727273
67693, 1.9608695652174, 1.245652173913, 0.45454545454545
67694, 1.9826086956522, 1.2717391304348, 0.45454545454545
67695, 1.9826086956522, 1.245652173913, 0.43181818181818
67696, 1.9608695652174, 1.245652173913, 0.40909090909091
67697, 1.9826086956522, 1.2717391304348, 0.40909090909091
67698, 1.9826086956522, 1.245652173913, 0.38636363636364
67699, 1.9608695652174, 1.245652173913, 0.36363636363636
67700, 1.9826086956522, 1.2717391304348, 0.36363636363636
67701, 1.9826086956522, 1.245652173913, 0.34090909090909
67702, 1.9608695652174, 1.245652173913, 0.31818181818182
67703, 1.9826086956522, 1.2717391304348, 0.31818181818182
67704, 1.9826086956522, 1.245652173913, 0.29545454545455
67705, 1.9608695652174, 1.245652173913, 0.27272727272727
67706, 1.9826086956522, 1.2717391304348, 0.27272727272727
67707, 1.9826086956522, 1.245652173913, 0.25
67708, 1.9608695652174, 1.245652173913, 0.22727272727273
67709, 1.9826086956522, 1.2717391304348, 0.22727272727273
67710, 1.9826086956522, 1.245652173913, 0.20454545454545
67711, 1.9608695652174, 1.245652173913, 0.18181818181818
67712, 1.9826086956522, 1.2717391304348, 0.18181818181818
67713, 1.9826086956522, 1.245652173913, 0.15909090909091
67714, 1.9608695652174, 1.245652173913, 0.13636363636364
67715, 1.9826086956522, 1.2717391304348, 0.13636363636364
67716, 1.9826086956522, 1.245652173913, 0.11363636363636
67717, 1.9608695652174, 1.245652173913, 0.090909090909091
67718, 1.9826086956522, 1.2717391304348, 0.090909090909091
67719, 1.9826086956522, 1.245652173913, 0.068181818181818
67720, 1.9608695652174, 1.245652173913, 0.045454545454545
67721, 1.9826086956522, 1.2717391304348, 0.045454545454545
67722, 1.9826086956522, 1.245652173913, 0.022727272727273
67723, 2.0260869565217, 1.245652173913, 0.47727272727273
67724, 2.004347826087, 1.245652173913, 0.45454545454545
67725, 2.0260869565217, 1.2717391304348, 0.45454545454545
67726, 2.0260869565217, 1.245652173913, 0.43181818181818
67727, 2.004347826087, 1.245652173913, 0.40909090909091
67728, 2.0260869565217, 1.2717391304348, 0.40909090909091
67729, 2.0260869565217, 1.245652173913, 0.38636363636364
67730, 2.004347826087, 1.245652173913, 0.36363636363636
67731, 2.0260869565217, 1.2717391304348, 0.36363636363636
67732, 2.0260869565217, 1.245652173913, 0.34090909090909
67733, 2.004347826087, 1.245652173913, 0.31818181818182
67734, 2.0260869565217, 1.2717391304348, 0.31818181818182
67735, 2.0260869565217, 1.245652173913, 0.29545454545455
67736, 2.004347826087, 1.245652173913, 0.27272727272727
67737, 2.0260869565217, 1.2717391304348, 0.27272727272727
67738, 2.0260869565217, 1.245652173913, 0.25
67739, 2.004347826087, 1.245652173913, 0.22727272727273
67740, 2.0260869565217, 1.2717391304348, 0.22727272727273
67741, 2.0260869565217, 1.245652173913, 0.20454545454545
67742, 2.004347826087, 1.245652173913, 0.18181818181818
67743, 2.0260869565217, 1.2717391304348, 0.18181818181818
67744, 2.0260869565217, 1.245652173913, 0.15909090909091
67745, 2.004347826087, 1.245652173913, 0.13636363636364
67746, 2.0260869565217, 1.2717391304348, 0.13636363636364
67747, 2.0260869565217, 1.245652173913, 0.11363636363636
67748, 2.004347826087, 1.245652173913, 0.090909090909091
67749, 2.0260869565217, 1.2717391304348, 0.090909090909091
67750, 2.0260869565217, 1.245652173913, 0.068181818181818
67751, 2.004347826087, 1.245652173913, 0.045454545454545
67752, 2.0260869565217, 1.2717391304348, 0.045454545454545
67753, 2.0260869565217, 1.245652173913, 0.022727272727273
67754, 2.0695652173913, 1.245652173913, 0.47727272727273
67755, 2.0478260869565, 1.245652173913, 0.45454545454545
67756, 2.0695652173913, 1.2717391304348, 0.45454545454545
67757, 2.0695652173913, 1.245652173913, 0.43181818181818
67758, 2.0478260869565, 1.245652173913, 0.40909090909091
67759, 2.0695652173913, 1.2717391304348, 0.40909090909091
67760, 2.0695652173913, 1.245652173913, 0.38636363636364
67761, 2.0478260869565, 1.245652173913, 0.36363636363636
67762, 2.0695652173913, 1.2717391304348, 0.36363636363636
67763, 2.0695652173913, 1.245652173913, 0.34090909090909
67764, 2.0478260869565, 1.245652173913, 0.31818181818182
67765, 2.0695652173913, 1.2717391304348, 0.31818181818182
67766, 2.0695652173913, 1.245652173913, 0.29545454545455
67767, 2.0478260869565, 1.245652173913, 0.27272727272727
67768, 2.0695652173913, 1.2717391304348, 0.27272727272727
67769, 2.0695652173913, 1.245652173913, 0.25
67770, 2.0478260869565, 1.245652173913, 0.22727272727273
67771, 2.0695652173913, 1.2717391304348, 0.22727272727273
67772, 2.0695652173913, 1.245652173913, 0.20454545454545
67773, 2.0478260869565, 1.245652173913, 0.18181818181818
67774, 2.0695652173913, 1.2717391304348, 0.18181818181818
67775, 2.0695652173913, 1.245652173913, 0.15909090909091
67776, 2.0478260869565, 1.245652173913, 0.13636363636364
67777, 2.0695652173913, 1.2717391304348, 0.13636363636364
67778, 2.0695652173913, 1.245652173913, 0.11363636363636
67779, 2.0478260869565, 1.245652173913, 0.090909090909091
67780, 2.0695652173913, 1.2717391304348, 0.090909090909091
67781, 2.0695652173913, 1.245652173913, 0.068181818181818
67782, 2.0478260869565, 1.245652173913, 0.045454545454545
67783, 2.0695652173913, 1.2717391304348, 0.045454545454545
67784, 2.0695652173913, 1.245652173913, 0.022727272727273
67785, 2.1130434782609, 1.245652173913, 0.47727272727273
67786, 2.0913043478261, 1.245652173913, 0.45454545454545
67787, 2.1130434782609, 1.2717391304348, 0.45454545454545
67788, 2.1130434782609, 1.245652173913, 0.43181818181818
67789, 2.0913043478261, 1.245652173913, 0.40909090909091
67790, 2.1130434782609, 1.2717391304348, 0.40909090909091
67791, 2.1130434782609, 1.245652173913, 0.38636363636364
67792, 2.0913043478261, 1.245652173913, 0.36363636363636
67793, 2.1130434782609, 1.2717391304348, 0.36363636363636
67794, 2.1130434782609, 1.245652173913, 0.34090909090909
67795, 2.0913043478261, 1.245652173913, 0.31818181818182
67796, 2.1130434782609, 1.2717391304348, 0.31818181818182
67797, 2.1130434782609, 1.245652173913, 0.29545454545455
67798, 2.0913043478261, 1.245652173913, 0.27272727272727
67799, 2.1130434782609, 1.2717391304348, 0.27272727272727
67800, 2.1130434782609, 1.245652173913, 0.25
67801, 2.0913043478261, 1.245652173913, 0.22727272727273
67802, 2.1130434782609, 1.2717391304348, 0.22727272727273
67803, 2.1130434782609, 1.245652173913, 0.20454545454545
67804, 2.0913043478261, 1.245652173913, 0.18181818181818
67805, 2.1130434782609, 1.2717391304348, 0.18181818181818
67806, 2.1130434782609, 1.245652173913, 0.15909090909091
67807, 2.0913043478261, 1.245652173913, 0.13636363636364
67808, 2.1130434782609, 1.2717391304348, 0.13636363636364
67809, 2.1130434782609, 1.245652173913, 0.11363636363636
67810, 2.0913043478261, 1.245652173913, 0.090909090909091
67811, 2.1130434782609, 1.2717391304348, 0.090909090909091
67812, 2.1130434782609, 1.245652173913, 0.068181818181818
67813, 2.0913043478261, 1.245652173913, 0.045454545454545
67814, 2.1130434782609, 1.2717391304348, 0.045454545454545
67815, 2.1130434782609, 1.245652173913, 0.022727272727273
67816, 2.1565217391304, 1.245652173913, 0.47727272727273
67817, 2.1347826086957, 1.245652173913, 0.45454545454545
67818, 2.1565217391304, 1.2717391304348, 0.45454545454545
67819, 2.1565217391304, 1.245652173913, 0.43181818181818
67820, 2.1347826086957, 1.245652173913, 0.40909090909091
67821, 2.1565217391304, 1.2717391304348, 0.40909090909091
67822, 2.1565217391304, 1.245652173913, 0.38636363636364
67823, 2.1347826086957, 1.245652173913, 0.36363636363636
67824, 2.1565217391304, 1.2717391304348, 0.36363636363636
67825, 2.1565217391304, 1.245652173913, 0.34090909090909
67826, 2.1347826086957, 1.245652173913, 0.31818181818182
67827, 2.1565217391304, 1.2717391304348, 0.31818181818182
67828, 2.1565217391304, 1.245652173913, 0.29545454545455
67829, 2.1347826086957, 1.245652173913, 0.27272727272727
67830, 2.1565217391304, 1.2717391304348, 0.27272727272727
67831, 2.1565217391304, 1.245652173913, 0.25
67832, 2.1347826086957, 1.245652173913, 0.22727272727273
67833, 2.1565217391304, 1.2717391304348, 0.22727272727273
67834, 2.1565217391304, 1.245652173913, 0.20454545454545
67835, 2.1347826086957, 1.245652173913, 0.18181818181818
67836, 2.1565217391304, 1.2717391304348, 0.18181818181818
67837, 2.1565217391304, 1.245652173913, 0.15909090909091
67838, 2.1347826086957, 1.245652173913, 0.13636363636364
67839, 2.1565217391304, 1.2717391304348, 0.13636363636364
67840, 2.1565217391304, 1.245652173913, 0.11363636363636
67841, 2.1347826086957, 1.245652173913, 0.090909090909091
67842, 2.1565217391304, 1.2717391304348, 0.090909090909091
67843, 2.1565217391304, 1.245652173913, 0.068181818181818
67844, 2.1347826086957, 1.245652173913, 0.045454545454545
67845, 2.1565217391304, 1.2717391304348, 0.045454545454545
67846, 2.1565217391304, 1.245652173913, 0.022727272727273
67847, 2.1782608695652, 1.245652173913, 0.45454545454545
67848, 2.1782608695652, 1.245652173913, 0.40909090909091
67849, 2.1782608695652, 1.245652173913, 0.36363636363636
67850, 2.1782608695652, 1.245652173913, 0.31818181818182
67851, 2.1782608695652, 1.245652173913, 0.27272727272727
67852, 2.1782608695652, 1.245652173913, 0.22727272727273
67853, 2.1782608695652, 1.245652173913, 0.18181818181818
67854, 2.1782608695652, 1.245652173913, 0.13636363636364
67855, 2.1782608695652, 1.245652173913, 0.090909090909091
67856, 2.1782608695652, 1.245652173913, 0.045454545454545
67857, 1.2434782608696, 1.1934782608696, 0.47727272727273
67858, 1.2217391304348, 1.1934782608696, 0.45454545454545
67859, 1.2434782608696, 1.2195652173913, 0.45454545454545
67860, 1.2434782608696, 1.1934782608696, 0.43181818181818
67861, 1.2217391304348, 1.1934782608696, 0.40909090909091
67862, 1.2434782608696, 1.2195652173913, 0.40909090909091
67863, 1.2434782608696, 1.1934782608696, 0.38636363636364
67864, 1.2217391304348, 1.1934782608696, 0.36363636363636
67865, 1.2434782608696, 1.2195652173913, 0.36363636363636
67866, 1.2434782608696, 1.1934782608696, 0.34090909090909
67867, 1.2217391304348, 1.1934782608696, 0.31818181818182
67868, 1.2434782608696, 1.2195652173913, 0.31818181818182
67869, 1.2434782608696, 1.1934782608696, 0.29545454545455
67870, 1.2217391304348, 1.1934782608696, 0.27272727272727
67871, 1.2434782608696, 1.2195652173913, 0.27272727272727
67872, 1.2434782608696, 1.1934782608696, 0.25
67873, 1.2217391304348, 1.1934782608696, 0.22727272727273
67874, 1.2434782608696, 1.2195652173913, 0.22727272727273
67875, 1.2434782608696, 1.1934782608696, 0.20454545454545
67876, 1.2217391304348, 1.1934782608696, 0.18181818181818
67877, 1.2434782608696, 1.2195652173913, 0.18181818181818
67878, 1.2434782608696, 1.1934782608696, 0.15909090909091
67879, 1.2217391304348, 1.1934782608696, 0.13636363636364
67880, 1.2434782608696, 1.2195652173913, 0.13636363636364
67881, 1.2434782608696, 1.1934782608696, 0.11363636363636
67882, 1.2217391304348, 1.1934782608696, 0.090909090909091
67883, 1.2434782608696, 1.2195652173913, 0.090909090909091
67884, 1.2434782608696, 1.1934782608696, 0.068181818181818
67885, 1.2217391304348, 1.1934782608696, 0.045454545454545
67886, 1.2434782608696, 1.2195652173913, 0.045454545454545
67887, 1.2434782608696, 1.1934782608696, 0.022727272727273
67888, 1.2869565217391, 1.1934782608696, 0.47727272727273
67889, 1.2652173913043, 1.1934782608696, 0.45454545454545
67890, 1.2869565217391, 1.2195652173913, 0.45454545454545
67891, 1.2869565217391, 1.1934782608696, 0.43181818181818
67892, 1.2652173913043, 1.1934782608696, 0.40909090909091
67893, 1.2869565217391, 1.2195652173913, 0.40909090909091
67894, 1.2869565217391, 1.1934782608696, 0.38636363636364
67895, 1.2652173913043, 1.1934782608696, 0.36363636363636
67896, 1.2869565217391, 1.2195652173913, 0.36363636363636
67897, 1.2869565217391, 1.1934782608696, 0.34090909090909
67898, 1.2652173913043, 1.1934782608696, 0.31818181818182
67899, 1.2869565217391, 1.2195652173913, 0.31818181818182
67900, 1.2869565217391, 1.1934782608696, 0.29545454545455
67901, 1.2652173913043, 1.1934782608696, 0.27272727272727
67902, 1.2869565217391, 1.2195652173913, 0.27272727272727
67903, 1.2869565217391, 1.1934782608696, 0.25
67904, 1.2652173913043, 1.1934782608696, 0.22727272727273
67905, 1.2869565217391, 1.2195652173913, 0.22727272727273
67906, 1.2869565217391, 1.1934782608696, 0.20454545454545
67907, 1.2652173913043, 1.1934782608696, 0.18181818181818
67908, 1.2869565217391, 1.2195652173913, 0.18181818181818
67909, 1.2869565217391, 1.1934782608696, 0.15909090909091
67910, 1.2652173913043, 1.1934782608696, 0.13636363636364
67911, 1.2869565217391, 1.2195652173913, 0.13636363636364
67912, 1.2869565217391, 1.1934782608696, 0.11363636363636
67913, 1.2652173913043, 1.1934782608696, 0.090909090909091
67914, 1.2869565217391, 1.2195652173913, 0.090909090909091
67915, 1.2869565217391, 1.1934782608696, 0.068181818181818
67916, 1.2652173913043, 1.1934782608696, 0.045454545454545
67917, 1.2869565217391, 1.2195652173913, 0.045454545454545
67918, 1.2869565217391, 1.1934782608696, 0.022727272727273
67919, 1.3304347826087, 1.1934782608696, 0.47727272727273
67920, 1.3086956521739, 1.1934782608696, 0.45454545454545
67921, 1.3304347826087, 1.2195652173913, 0.45454545454545
67922, 1.3304347826087, 1.1934782608696, 0.43181818181818
67923, 1.3086956521739, 1.1934782608696, 0.40909090909091
67924, 1.3304347826087, 1.2195652173913, 0.40909090909091
67925, 1.3304347826087, 1.1934782608696, 0.38636363636364
67926, 1.3086956521739, 1.1934782608696, 0.36363636363636
67927, 1.3304347826087, 1.2195652173913, 0.36363636363636
67928, 1.3304347826087, 1.1934782608696, 0.34090909090909
67929, 1.3086956521739, 1.1934782608696, 0.31818181818182
67930, 1.3304347826087, 1.2195652173913, 0.31818181818182
67931, 1.3304347826087, 1.1934782608696, 0.29545454545455
67932, 1.3086956521739, 1.1934782608696, 0.27272727272727
67933, 1.3304347826087, 1.2195652173913, 0.27272727272727
67934, 1.3304347826087, 1.1934782608696, 0.25
67935, 1.3086956521739, 1.1934782608696, 0.22727272727273
67936, 1.3304347826087, 1.2195652173913, 0.22727272727273
67937, 1.3304347826087, 1.1934782608696, 0.20454545454545
67938, 1.3086956521739, 1.1934782608696, 0.18181818181818
67939, 1.3304347826087, 1.2195652173913, 0.18181818181818
67940, 1.3304347826087, 1.1934782608696, 0.15909090909091
67941, 1.3086956521739, 1.1934782608696, 0.13636363636364
67942, 1.3304347826087, 1.2195652173913, 0.13636363636364
67943, 1.3304347826087, 1.1934782608696, 0.11363636363636
67944, 1.3086956521739, 1.1934782608696, 0.090909090909091
67945, 1.3304347826087, 1.2195652173913, 0.090909090909091
67946, 1.3304347826087, 1.1934782608696, 0.068181818181818
67947, 1.3086956521739, 1.1934782608696, 0.045454545454545
67948, 1.3304347826087, 1.2195652173913, 0.045454545454545
67949, 1.3304347826087, 1.1934782608696, 0.022727272727273
67950, 1.3739130434783, 1.1934782608696, 0.47727272727273
67951, 1.3521739130435, 1.1934782608696, 0.45454545454545
67952, 1.3739130434783, 1.2195652173913, 0.45454545454545
67953, 1.3739130434783, 1.1934782608696, 0.43181818181818
67954, 1.3521739130435, 1.1934782608696, 0.40909090909091
67955, 1.3739130434783, 1.2195652173913, 0.40909090909091
67956, 1.3739130434783, 1.1934782608696, 0.38636363636364
67957, 1.3521739130435, 1.1934782608696, 0.36363636363636
67958, 1.3739130434783, 1.2195652173913, 0.36363636363636
67959, 1.3739130434783, 1.1934782608696, 0.34090909090909
67960, 1.3521739130435, 1.1934782608696, 0.31818181818182
67961, 1.3739130434783, 1.2195652173913, 0.31818181818182
67962, 1.3739130434783, 1.1934782608696, 0.29545454545455
67963, 1.3521739130435, 1.1934782608696, 0.27272727272727
67964, 1.3739130434783, 1.2195652173913, 0.27272727272727
67965, 1.3739130434783, 1.1934782608696, 0.25
67966, 1.3521739130435, 1.1934782608696, 0.22727272727273
67967, 1.3739130434783, 1.2195652173913, 0.22727272727273
67968, 1.3739130434783, 1.1934782608696, 0.20454545454545
67969, 1.3521739130435, 1.1934782608696, 0.18181818181818
67970, 1.3739130434783, 1.2195652173913, 0.18181818181818
67971, 1.3739130434783, 1.1934782608696, 0.15909090909091
67972, 1.3521739130435, 1.1934782608696, 0.13636363636364
67973, 1.3739130434783, 1.2195652173913, 0.13636363636364
67974, 1.3739130434783, 1.1934782608696, 0.11363636363636
67975, 1.3521739130435, 1.1934782608696, 0.090909090909091
67976, 1.3739130434783, 1.2195652173913, 0.090909090909091
67977, 1.3739130434783, 1.1934782608696, 0.068181818181818
67978, 1.3521739130435, 1.1934782608696, 0.045454545454545
67979, 1.3739130434783, 1.2195652173913, 0.045454545454545
67980, 1.3739130434783, 1.1934782608696, 0.022727272727273
67981, 1.4173913043478, 1.1934782608696, 0.47727272727273
67982, 1.395652173913, 1.1934782608696, 0.45454545454545
67983, 1.4173913043478, 1.2195652173913, 0.45454545454545
67984, 1.4173913043478, 1.1934782608696, 0.43181818181818
67985, 1.395652173913, 1.1934782608696, 0.40909090909091
67986, 1.4173913043478, 1.2195652173913, 0.40909090909091
67987, 1.4173913043478, 1.1934782608696, 0.38636363636364
67988, 1.395652173913, 1.1934782608696, 0.36363636363636
67989, 1.4173913043478, 1.2195652173913, 0.36363636363636
67990, 1.4173913043478, 1.1934782608696, 0.34090909090909
67991, 1.395652173913, 1.1934782608696, 0.31818181818182
67992, 1.4173913043478, 1.2195652173913, 0.31818181818182
67993, 1.4173913043478, 1.1934782608696, 0.29545454545455
67994, 1.395652173913, 1.1934782608696, 0.27272727272727
67995, 1.4173913043478, 1.2195652173913, 0.27272727272727
67996, 1.4173913043478, 1.1934782608696, 0.25
67997, 1.395652173913, 1.1934782608696, 0.22727272727273
67998, 1.4173913043478, 1.2195652173913, 0.22727272727273
67999, 1.4173913043478, 1.1934782608696, 0.20454545454545
68000, 1.395652173913, 1.1934782608696, 0.18181818181818
68001, 1.4173913043478, 1.2195652173913, 0.18181818181818
68002, 1.4173913043478, 1.1934782608696, 0.15909090909091
68003, 1.395652173913, 1.1934782608696, 0.13636363636364
68004, 1.4173913043478, 1.2195652173913, 0.13636363636364
68005, 1.4173913043478, 1.1934782608696, 0.11363636363636
68006, 1.395652173913, 1.1934782608696, 0.090909090909091
68007, 1.4173913043478, 1.2195652173913, 0.090909090909091
68008, 1.4173913043478, 1.1934782608696, 0.068181818181818
68009, 1.395652173913, 1.1934782608696, 0.045454545454545
68010, 1.4173913043478, 1.2195652173913, 0.045454545454545
68011, 1.4173913043478, 1.1934782608696, 0.022727272727273
68012, 1.4608695652174, 1.1934782608696, 0.47727272727273
68013, 1.4391304347826, 1.1934782608696, 0.45454545454545
68014, 1.4608695652174, 1.2195652173913, 0.45454545454545
68015, 1.4608695652174, 1.1934782608696, 0.43181818181818
68016, 1.4391304347826, 1.1934782608696, 0.40909090909091
68017, 1.4608695652174, 1.2195652173913, 0.40909090909091
68018, 1.4608695652174, 1.1934782608696, 0.38636363636364
68019, 1.4391304347826, 1.1934782608696, 0.36363636363636
68020, 1.4608695652174, 1.2195652173913, 0.36363636363636
68021, 1.4608695652174, 1.1934782608696, 0.34090909090909
68022, 1.4391304347826, 1.1934782608696, 0.31818181818182
68023, 1.4608695652174, 1.2195652173913, 0.31818181818182
68024, 1.4608695652174, 1.1934782608696, 0.29545454545455
68025, 1.4391304347826, 1.1934782608696, 0.27272727272727
68026, 1.4608695652174, 1.2195652173913, 0.27272727272727
68027, 1.4608695652174, 1.1934782608696, 0.25
68028, 1.4391304347826, 1.1934782608696, 0.22727272727273
68029, 1.4608695652174, 1.2195652173913, 0.22727272727273
68030, 1.4608695652174, 1.1934782608696, 0.20454545454545
68031, 1.4391304347826, 1.1934782608696, 0.18181818181818
68032, 1.4608695652174, 1.2195652173913, 0.18181818181818
68033, 1.4608695652174, 1.1934782608696, 0.15909090909091
68034, 1.4391304347826, 1.1934782608696, 0.13636363636364
68035, 1.4608695652174, 1.2195652173913, 0.13636363636364
68036, 1.4608695652174, 1.1934782608696, 0.11363636363636
68037, 1.4391304347826, 1.1934782608696, 0.090909090909091
68038, 1.4608695652174, 1.2195652173913, 0.090909090909091
68039, 1.4608695652174, 1.1934782608696, 0.068181818181818
68040, 1.4391304347826, 1.1934782608696, 0.045454545454545
68041, 1.4608695652174, 1.2195652173913, 0.045454545454545
68042, 1.4608695652174, 1.1934782608696, 0.022727272727273
68043, 1.504347826087, 1.1934782608696, 0.47727272727273
68044, 1.4826086956522, 1.1934782608696, 0.45454545454545
68045, 1.504347826087, 1.2195652173913, 0.45454545454545
68046, 1.504347826087, 1.1934782608696, 0.43181818181818
68047, 1.4826086956522, 1.1934782608696, 0.40909090909091
68048, 1.504347826087, 1.2195652173913, 0.40909090909091
68049, 1.504347826087, 1.1934782608696, 0.38636363636364
68050, 1.4826086956522, 1.1934782608696, 0.36363636363636
68051, 1.504347826087, 1.2195652173913, 0.36363636363636
68052, 1.504347826087, 1.1934782608696, 0.34090909090909
68053, 1.4826086956522, 1.1934782608696, 0.31818181818182
68054, 1.504347826087, 1.2195652173913, 0.31818181818182
68055, 1.504347826087, 1.1934782608696, 0.29545454545455
68056, 1.4826086956522, 1.1934782608696, 0.27272727272727
68057, 1.504347826087, 1.2195652173913, 0.27272727272727
68058, 1.504347826087, 1.1934782608696, 0.25
68059, 1.4826086956522, 1.1934782608696, 0.22727272727273
68060, 1.504347826087, 1.2195652173913, 0.22727272727273
68061, 1.504347826087, 1.1934782608696, 0.20454545454545
68062, 1.4826086956522, 1.1934782608696, 0.18181818181818
68063, 1.504347826087, 1.2195652173913, 0.18181818181818
68064, 1.504347826087, 1.1934782608696, 0.15909090909091
68065, 1.4826086956522, 1.1934782608696, 0.13636363636364
68066, 1.504347826087, 1.2195652173913, 0.13636363636364
68067, 1.504347826087, 1.1934782608696, 0.11363636363636
68068, 1.4826086956522, 1.1934782608696, 0.090909090909091
68069, 1.504347826087, 1.2195652173913, 0.090909090909091
68070, 1.504347826087, 1.1934782608696, 0.068181818181818
68071, 1.4826086956522, 1.1934782608696, 0.045454545454545
68072, 1.504347826087, 1.2195652173913, 0.045454545454545
68073, 1.504347826087, 1.1934782608696, 0.022727272727273
68074, 1.5478260869565, 1.1934782608696, 0.47727272727273
68075, 1.5260869565217, 1.1934782608696, 0.45454545454545
68076, 1.5478260869565, 1.2195652173913, 0.45454545454545
68077, 1.5478260869565, 1.1934782608696, 0.43181818181818
68078, 1.5260869565217, 1.1934782608696, 0.40909090909091
68079, 1.5478260869565, 1.2195652173913, 0.40909090909091
68080, 1.5478260869565, 1.1934782608696, 0.38636363636364
68081, 1.5260869565217, 1.1934782608696, 0.36363636363636
68082, 1.5478260869565, 1.2195652173913, 0.36363636363636
68083, 1.5478260869565, 1.1934782608696, 0.34090909090909
68084, 1.5260869565217, 1.1934782608696, 0.31818181818182
68085, 1.5478260869565, 1.2195652173913, 0.31818181818182
68086, 1.5478260869565, 1.1934782608696, 0.29545454545455
68087, 1.5260869565217, 1.1934782608696, 0.27272727272727
68088, 1.5478260869565, 1.2195652173913, 0.27272727272727
68089, 1.5478260869565, 1.1934782608696, 0.25
68090, 1.5260869565217, 1.1934782608696, 0.22727272727273
68091, 1.5478260869565, 1.2195652173913, 0.22727272727273
68092, 1.5478260869565, 1.1934782608696, 0.20454545454545
68093, 1.5260869565217, 1.1934782608696, 0.18181818181818
68094, 1.5478260869565, 1.2195652173913, 0.18181818181818
68095, 1.5478260869565, 1.1934782608696, 0.15909090909091
68096, 1.5260869565217, 1.1934782608696, 0.13636363636364
68097, 1.5478260869565, 1.2195652173913, 0.13636363636364
68098, 1.5478260869565, 1.1934782608696, 0.11363636363636
68099, 1.5260869565217, 1.1934782608696, 0.090909090909091
68100, 1.5478260869565, 1.2195652173913, 0.090909090909091
68101, 1.5478260869565, 1.1934782608696, 0.068181818181818
68102, 1.5260869565217, 1.1934782608696, 0.045454545454545
68103, 1.5478260869565, 1.2195652173913, 0.045454545454545
68104, 1.5478260869565, 1.1934782608696, 0.022727272727273
68105, 1.5913043478261, 1.1934782608696, 0.47727272727273
68106, 1.5695652173913, 1.1934782608696, 0.45454545454545
68107, 1.5913043478261, 1.2195652173913, 0.45454545454545
68108, 1.5913043478261, 1.1934782608696, 0.43181818181818
68109, 1.5695652173913, 1.1934782608696, 0.40909090909091
68110, 1.5913043478261, 1.2195652173913, 0.40909090909091
68111, 1.5913043478261, 1.1934782608696, 0.38636363636364
68112, 1.5695652173913, 1.1934782608696, 0.36363636363636
68113, 1.5913043478261, 1.2195652173913, 0.36363636363636
68114, 1.5913043478261, 1.1934782608696, 0.34090909090909
68115, 1.5695652173913, 1.1934782608696, 0.31818181818182
68116, 1.5913043478261, 1.2195652173913, 0.31818181818182
68117, 1.5913043478261, 1.1934782608696, 0.29545454545455
68118, 1.5695652173913, 1.1934782608696, 0.27272727272727
68119, 1.5913043478261, 1.2195652173913, 0.27272727272727
68120, 1.5913043478261, 1.1934782608696, 0.25
68121, 1.5695652173913, 1.1934782608696, 0.22727272727273
68122, 1.5913043478261, 1.2195652173913, 0.22727272727273
68123, 1.5913043478261, 1.1934782608696, 0.20454545454545
68124, 1.5695652173913, 1.1934782608696, 0.18181818181818
68125, 1.5913043478261, 1.2195652173913, 0.18181818181818
68126, 1.5913043478261, 1.1934782608696, 0.15909090909091
68127, 1.5695652173913, 1.1934782608696, 0.13636363636364
68128, 1.5913043478261, 1.2195652173913, 0.13636363636364
68129, 1.5913043478261, 1.1934782608696, 0.11363636363636
68130, 1.5695652173913, 1.1934782608696, 0.090909090909091
68131, 1.5913043478261, 1.2195652173913, 0.090909090909091
68132, 1.5913043478261, 1.1934782608696, 0.068181818181818
68133, 1.5695652173913, 1.1934782608696, 0.045454545454545
68134, 1.5913043478261, 1.2195652173913, 0.045454545454545
68135, 1.5913043478261, 1.1934782608696, 0.022727272727273
68136, 1.6347826086957, 1.1934782608696, 0.47727272727273
68137, 1.6130434782609, 1.1934782608696, 0.45454545454545
68138, 1.6347826086957, 1.2195652173913, 0.45454545454545
68139, 1.6347826086957, 1.1934782608696, 0.43181818181818
68140, 1.6130434782609, 1.1934782608696, 0.40909090909091
68141, 1.6347826086957, 1.2195652173913, 0.40909090909091
68142, 1.6347826086957, 1.1934782608696, 0.38636363636364
68143, 1.6130434782609, 1.1934782608696, 0.36363636363636
68144, 1.6347826086957, 1.2195652173913, 0.36363636363636
68145, 1.6347826086957, 1.1934782608696, 0.34090909090909
68146, 1.6130434782609, 1.1934782608696, 0.31818181818182
68147, 1.6347826086957, 1.2195652173913, 0.31818181818182
68148, 1.6347826086957, 1.1934782608696, 0.29545454545455
68149, 1.6130434782609, 1.1934782608696, 0.27272727272727
68150, 1.6347826086957, 1.2195652173913, 0.27272727272727
68151, 1.6347826086957, 1.1934782608696, 0.25
68152, 1.6130434782609, 1.1934782608696, 0.22727272727273
68153, 1.6347826086957, 1.2195652173913, 0.22727272727273
68154, 1.6347826086957, 1.1934782608696, 0.20454545454545
68155, 1.6130434782609, 1.1934782608696, 0.18181818181818
68156, 1.6347826086957, 1.2195652173913, 0.18181818181818
68157, 1.6347826086957, 1.1934782608696, 0.15909090909091
68158, 1.6130434782609, 1.1934782608696, 0.13636363636364
68159, 1.6347826086957, 1.2195652173913, 0.13636363636364
68160, 1.6347826086957, 1.1934782608696, 0.11363636363636
68161, 1.6130434782609, 1.1934782608696, 0.090909090909091
68162, 1.6347826086957, 1.2195652173913, 0.090909090909091
68163, 1.6347826086957, 1.1934782608696, 0.068181818181818
68164, 1.6130434782609, 1.1934782608696, 0.045454545454545
68165, 1.6347826086957, 1.2195652173913, 0.045454545454545
68166, 1.6347826086957, 1.1934782608696, 0.022727272727273
68167, 1.6782608695652, 1.1934782608696, 0.47727272727273
68168, 1.6565217391304, 1.1934782608696, 0.45454545454545
68169, 1.6782608695652, 1.2195652173913, 0.45454545454545
68170, 1.6782608695652, 1.1934782608696, 0.43181818181818
68171, 1.6565217391304, 1.1934782608696, 0.40909090909091
68172, 1.6782608695652, 1.2195652173913, 0.40909090909091
68173, 1.6782608695652, 1.1934782608696, 0.38636363636364
68174, 1.6565217391304, 1.1934782608696, 0.36363636363636
68175, 1.6782608695652, 1.2195652173913, 0.36363636363636
68176, 1.6782608695652, 1.1934782608696, 0.34090909090909
68177, 1.6565217391304, 1.1934782608696, 0.31818181818182
68178, 1.6782608695652, 1.2195652173913, 0.31818181818182
68179, 1.6782608695652, 1.1934782608696, 0.29545454545455
68180, 1.6565217391304, 1.1934782608696, 0.27272727272727
68181, 1.6782608695652, 1.2195652173913, 0.27272727272727
68182, 1.6782608695652, 1.1934782608696, 0.25
68183, 1.6565217391304, 1.1934782608696, 0.22727272727273
68184, 1.6782608695652, 1.2195652173913, 0.22727272727273
68185, 1.6782608695652, 1.1934782608696, 0.20454545454545
68186, 1.6565217391304, 1.1934782608696, 0.18181818181818
68187, 1.6782608695652, 1.2195652173913, 0.18181818181818
68188, 1.6782608695652, 1.1934782608696, 0.15909090909091
68189, 1.6565217391304, 1.1934782608696, 0.13636363636364
68190, 1.6782608695652, 1.2195652173913, 0.13636363636364
68191, 1.6782608695652, 1.1934782608696, 0.11363636363636
68192, 1.6565217391304, 1.1934782608696, 0.090909090909091
68193, 1.6782608695652, 1.2195652173913, 0.090909090909091
68194, 1.6782608695652, 1.1934782608696, 0.068181818181818
68195, 1.6565217391304, 1.1934782608696, 0.045454545454545
68196, 1.6782608695652, 1.2195652173913, 0.045454545454545
68197, 1.6782608695652, 1.1934782608696, 0.022727272727273
68198, 1.7217391304348, 1.1934782608696, 0.47727272727273
68199, 1.7, 1.1934782608696, 0.45454545454545
68200, 1.7217391304348, 1.2195652173913, 0.45454545454545
68201, 1.7217391304348, 1.1934782608696, 0.43181818181818
68202, 1.7, 1.1934782608696, 0.40909090909091
68203, 1.7217391304348, 1.2195652173913, 0.40909090909091
68204, 1.7217391304348, 1.1934782608696, 0.38636363636364
68205, 1.7, 1.1934782608696, 0.36363636363636
68206, 1.7217391304348, 1.2195652173913, 0.36363636363636
68207, 1.7217391304348, 1.1934782608696, 0.34090909090909
68208, 1.7, 1.1934782608696, 0.31818181818182
68209, 1.7217391304348, 1.2195652173913, 0.31818181818182
68210, 1.7217391304348, 1.1934782608696, 0.29545454545455
68211, 1.7, 1.1934782608696, 0.27272727272727
68212, 1.7217391304348, 1.2195652173913, 0.27272727272727
68213, 1.7217391304348, 1.1934782608696, 0.25
68214, 1.7, 1.1934782608696, 0.22727272727273
68215, 1.7217391304348, 1.2195652173913, 0.22727272727273
68216, 1.7217391304348, 1.1934782608696, 0.20454545454545
68217, 1.7, 1.1934782608696, 0.18181818181818
68218, 1.7217391304348, 1.2195652173913, 0.18181818181818
68219, 1.7217391304348, 1.1934782608696, 0.15909090909091
68220, 1.7, 1.1934782608696, 0.13636363636364
68221, 1.7217391304348, 1.2195652173913, 0.13636363636364
68222, 1.7217391304348, 1.1934782608696, 0.11363636363636
68223, 1.7, 1.1934782608696, 0.090909090909091
68224, 1.7217391304348, 1.2195652173913, 0.090909090909091
68225, 1.7217391304348, 1.1934782608696, 0.068181818181818
68226, 1.7, 1.1934782608696, 0.045454545454545
68227, 1.7217391304348, 1.2195652173913, 0.045454545454545
68228, 1.7217391304348, 1.1934782608696, 0.022727272727273
68229, 1.7652173913043, 1.1934782608696, 0.47727272727273
68230, 1.7434782608696, 1.1934782608696, 0.45454545454545
68231, 1.7652173913043, 1.2195652173913, 0.45454545454545
68232, 1.7652173913043, 1.1934782608696, 0.43181818181818
68233, 1.7434782608696, 1.1934782608696, 0.40909090909091
68234, 1.7652173913043, 1.2195652173913, 0.40909090909091
68235, 1.7652173913043, 1.1934782608696, 0.38636363636364
68236, 1.7434782608696, 1.1934782608696, 0.36363636363636
68237, 1.7652173913043, 1.2195652173913, 0.36363636363636
68238, 1.7652173913043, 1.1934782608696, 0.34090909090909
68239, 1.7434782608696, 1.1934782608696, 0.31818181818182
68240, 1.7652173913043, 1.2195652173913, 0.31818181818182
68241, 1.7652173913043, 1.1934782608696, 0.29545454545455
68242, 1.7434782608696, 1.1934782608696, 0.27272727272727
68243, 1.7652173913043, 1.2195652173913, 0.27272727272727
68244, 1.7652173913043, 1.1934782608696, 0.25
68245, 1.7434782608696, 1.1934782608696, 0.22727272727273
68246, 1.7652173913043, 1.2195652173913, 0.22727272727273
68247, 1.7652173913043, 1.1934782608696, 0.20454545454545
68248, 1.7434782608696, 1.1934782608696, 0.18181818181818
68249, 1.7652173913043, 1.2195652173913, 0.18181818181818
68250, 1.7652173913043, 1.1934782608696, 0.15909090909091
68251, 1.7434782608696, 1.1934782608696, 0.13636363636364
68252, 1.7652173913043, 1.2195652173913, 0.13636363636364
68253, 1.7652173913043, 1.1934782608696, 0.11363636363636
68254, 1.7434782608696, 1.1934782608696, 0.090909090909091
68255, 1.7652173913043, 1.2195652173913, 0.090909090909091
68256, 1.7652173913043, 1.1934782608696, 0.068181818181818
68257, 1.7434782608696, 1.1934782608696, 0.045454545454545
68258, 1.7652173913043, 1.2195652173913, 0.045454545454545
68259, 1.7652173913043, 1.1934782608696, 0.022727272727273
68260, 1.8086956521739, 1.1934782608696, 0.47727272727273
68261, 1.7869565217391, 1.1934782608696, 0.45454545454545
68262, 1.8086956521739, 1.2195652173913, 0.45454545454545
68263, 1.8086956521739, 1.1934782608696, 0.43181818181818
68264, 1.7869565217391, 1.1934782608696, 0.40909090909091
68265, 1.8086956521739, 1.2195652173913, 0.40909090909091
68266, 1.8086956521739, 1.1934782608696, 0.38636363636364
68267, 1.7869565217391, 1.1934782608696, 0.36363636363636
68268, 1.8086956521739, 1.2195652173913, 0.36363636363636
68269, 1.8086956521739, 1.1934782608696, 0.34090909090909
68270, 1.7869565217391, 1.1934782608696, 0.31818181818182
68271, 1.8086956521739, 1.2195652173913, 0.31818181818182
68272, 1.8086956521739, 1.1934782608696, 0.29545454545455
68273, 1.7869565217391, 1.1934782608696, 0.27272727272727
68274, 1.8086956521739, 1.2195652173913, 0.27272727272727
68275, 1.8086956521739, 1.1934782608696, 0.25
68276, 1.7869565217391, 1.1934782608696, 0.22727272727273
68277, 1.8086956521739, 1.2195652173913, 0.22727272727273
68278, 1.8086956521739, 1.1934782608696, 0.20454545454545
68279, 1.7869565217391, 1.1934782608696, 0.18181818181818
68280, 1.8086956521739, 1.2195652173913, 0.18181818181818
68281, 1.8086956521739, 1.1934782608696, 0.15909090909091
68282, 1.7869565217391, 1.1934782608696, 0.13636363636364
68283, 1.8086956521739, 1.2195652173913, 0.13636363636364
68284, 1.8086956521739, 1.1934782608696, 0.11363636363636
68285, 1.7869565217391, 1.1934782608696, 0.090909090909091
68286, 1.8086956521739, 1.2195652173913, 0.090909090909091
68287, 1.8086956521739, 1.1934782608696, 0.068181818181818
68288, 1.7869565217391, 1.1934782608696, 0.045454545454545
68289, 1.8086956521739, 1.2195652173913, 0.045454545454545
68290, 1.8086956521739, 1.1934782608696, 0.022727272727273
68291, 1.8521739130435, 1.1934782608696, 0.47727272727273
68292, 1.8304347826087, 1.1934782608696, 0.45454545454545
68293, 1.8521739130435, 1.2195652173913, 0.45454545454545
68294, 1.8521739130435, 1.1934782608696, 0.43181818181818
68295, 1.8304347826087, 1.1934782608696, 0.40909090909091
68296, 1.8521739130435, 1.2195652173913, 0.40909090909091
68297, 1.8521739130435, 1.1934782608696, 0.38636363636364
68298, 1.8304347826087, 1.1934782608696, 0.36363636363636
68299, 1.8521739130435, 1.2195652173913, 0.36363636363636
68300, 1.8521739130435, 1.1934782608696, 0.34090909090909
68301, 1.8304347826087, 1.1934782608696, 0.31818181818182
68302, 1.8521739130435, 1.2195652173913, 0.31818181818182
68303, 1.8521739130435, 1.1934782608696, 0.29545454545455
68304, 1.8304347826087, 1.1934782608696, 0.27272727272727
68305, 1.8521739130435, 1.2195652173913, 0.27272727272727
68306, 1.8521739130435, 1.1934782608696, 0.25
68307, 1.8304347826087, 1.1934782608696, 0.22727272727273
68308, 1.8521739130435, 1.2195652173913, 0.22727272727273
68309, 1.8521739130435, 1.1934782608696, 0.20454545454545
68310, 1.8304347826087, 1.1934782608696, 0.18181818181818
68311, 1.8521739130435, 1.2195652173913, 0.18181818181818
68312, 1.8521739130435, 1.1934782608696, 0.15909090909091
68313, 1.8304347826087, 1.1934782608696, 0.13636363636364
68314, 1.8521739130435, 1.2195652173913, 0.13636363636364
68315, 1.8521739130435, 1.1934782608696, 0.11363636363636
68316, 1.8304347826087, 1.1934782608696, 0.090909090909091
68317, 1.8521739130435, 1.2195652173913, 0.090909090909091
68318, 1.8521739130435, 1.1934782608696, 0.068181818181818
68319, 1.8304347826087, 1.1934782608696, 0.045454545454545
68320, 1.8521739130435, 1.2195652173913, 0.045454545454545
68321, 1.8521739130435, 1.1934782608696, 0.022727272727273
68322, 1.895652173913, 1.1934782608696, 0.47727272727273
68323, 1.8739130434783, 1.1934782608696, 0.45454545454545
68324, 1.895652173913, 1.2195652173913, 0.45454545454545
68325, 1.895652173913, 1.1934782608696, 0.43181818181818
68326, 1.8739130434783, 1.1934782608696, 0.40909090909091
68327, 1.895652173913, 1.2195652173913, 0.40909090909091
68328, 1.895652173913, 1.1934782608696, 0.38636363636364
68329, 1.8739130434783, 1.1934782608696, 0.36363636363636
68330, 1.895652173913, 1.2195652173913, 0.36363636363636
68331, 1.895652173913, 1.1934782608696, 0.34090909090909
68332, 1.8739130434783, 1.1934782608696, 0.31818181818182
68333, 1.895652173913, 1.2195652173913, 0.31818181818182
68334, 1.895652173913, 1.1934782608696, 0.29545454545455
68335, 1.8739130434783, 1.1934782608696, 0.27272727272727
68336, 1.895652173913, 1.2195652173913, 0.27272727272727
68337, 1.895652173913, 1.1934782608696, 0.25
68338, 1.8739130434783, 1.1934782608696, 0.22727272727273
68339, 1.895652173913, 1.2195652173913, 0.22727272727273
68340, 1.895652173913, 1.1934782608696, 0.20454545454545
68341, 1.8739130434783, 1.1934782608696, 0.18181818181818
68342, 1.895652173913, 1.2195652173913, 0.18181818181818
68343, 1.895652173913, 1.1934782608696, 0.15909090909091
68344, 1.8739130434783, 1.1934782608696, 0.13636363636364
68345, 1.895652173913, 1.2195652173913, 0.13636363636364
68346, 1.895652173913, 1.1934782608696, 0.11363636363636
68347, 1.8739130434783, 1.1934782608696, 0.090909090909091
68348, 1.895652173913, 1.2195652173913, 0.090909090909091
68349, 1.895652173913, 1.1934782608696, 0.068181818181818
68350, 1.8739130434783, 1.1934782608696, 0.045454545454545
68351, 1.895652173913, 1.2195652173913, 0.045454545454545
68352, 1.895652173913, 1.1934782608696, 0.022727272727273
68353, 1.9391304347826, 1.1934782608696, 0.47727272727273
68354, 1.9173913043478, 1.1934782608696, 0.45454545454545
68355, 1.9391304347826, 1.2195652173913, 0.45454545454545
68356, 1.9391304347826, 1.1934782608696, 0.43181818181818
68357, 1.9173913043478, 1.1934782608696, 0.40909090909091
68358, 1.9391304347826, 1.2195652173913, 0.40909090909091
68359, 1.9391304347826, 1.1934782608696, 0.38636363636364
68360, 1.9173913043478, 1.1934782608696, 0.36363636363636
68361, 1.9391304347826, 1.2195652173913, 0.36363636363636
68362, 1.9391304347826, 1.1934782608696, 0.34090909090909
68363, 1.9173913043478, 1.1934782608696, 0.31818181818182
68364, 1.9391304347826, 1.2195652173913, 0.31818181818182
68365, 1.9391304347826, 1.1934782608696, 0.29545454545455
68366, 1.9173913043478, 1.1934782608696, 0.27272727272727
68367, 1.9391304347826, 1.2195652173913, 0.27272727272727
68368, 1.9391304347826, 1.1934782608696, 0.25
68369, 1.9173913043478, 1.1934782608696, 0.22727272727273
68370, 1.9391304347826, 1.2195652173913, 0.22727272727273
68371, 1.9391304347826, 1.1934782608696, 0.20454545454545
68372, 1.9173913043478, 1.1934782608696, 0.18181818181818
68373, 1.9391304347826, 1.2195652173913, 0.18181818181818
68374, 1.9391304347826, 1.1934782608696, 0.15909090909091
68375, 1.9173913043478, 1.1934782608696, 0.13636363636364
68376, 1.9391304347826, 1.2195652173913, 0.13636363636364
68377, 1.9391304347826, 1.1934782608696, 0.11363636363636
68378, 1.9173913043478, 1.1934782608696, 0.090909090909091
68379, 1.9391304347826, 1.2195652173913, 0.090909090909091
68380, 1.9391304347826, 1.1934782608696, 0.068181818181818
68381, 1.9173913043478, 1.1934782608696, 0.045454545454545
68382, 1.9391304347826, 1.2195652173913, 0.045454545454545
68383, 1.9391304347826, 1.1934782608696, 0.022727272727273
68384, 1.9826086956522, 1.1934782608696, 0.47727272727273
68385, 1.9608695652174, 1.1934782608696, 0.45454545454545
68386, 1.9826086956522, 1.2195652173913, 0.45454545454545
68387, 1.9826086956522, 1.1934782608696, 0.43181818181818
68388, 1.9608695652174, 1.1934782608696, 0.40909090909091
68389, 1.9826086956522, 1.2195652173913, 0.40909090909091
68390, 1.9826086956522, 1.1934782608696, 0.38636363636364
68391, 1.9608695652174, 1.1934782608696, 0.36363636363636
68392, 1.9826086956522, 1.2195652173913, 0.36363636363636
68393, 1.9826086956522, 1.1934782608696, 0.34090909090909
68394, 1.9608695652174, 1.1934782608696, 0.31818181818182
68395, 1.9826086956522, 1.2195652173913, 0.31818181818182
68396, 1.9826086956522, 1.1934782608696, 0.29545454545455
68397, 1.9608695652174, 1.1934782608696, 0.27272727272727
68398, 1.9826086956522, 1.2195652173913, 0.27272727272727
68399, 1.9826086956522, 1.1934782608696, 0.25
68400, 1.9608695652174, 1.1934782608696, 0.22727272727273
68401, 1.9826086956522, 1.2195652173913, 0.22727272727273
68402, 1.9826086956522, 1.1934782608696, 0.20454545454545
68403, 1.9608695652174, 1.1934782608696, 0.18181818181818
68404, 1.9826086956522, 1.2195652173913, 0.18181818181818
68405, 1.9826086956522, 1.1934782608696, 0.15909090909091
68406, 1.9608695652174, 1.1934782608696, 0.13636363636364
68407, 1.9826086956522, 1.2195652173913, 0.13636363636364
68408, 1.9826086956522, 1.1934782608696, 0.11363636363636
68409, 1.9608695652174, 1.1934782608696, 0.090909090909091
68410, 1.9826086956522, 1.2195652173913, 0.090909090909091
68411, 1.9826086956522, 1.1934782608696, 0.068181818181818
68412, 1.9608695652174, 1.1934782608696, 0.045454545454545
68413, 1.9826086956522, 1.2195652173913, 0.045454545454545
68414, 1.9826086956522, 1.1934782608696, 0.022727272727273
68415, 2.0260869565217, 1.1934782608696, 0.47727272727273
68416, 2.004347826087, 1.1934782608696, 0.45454545454545
68417, 2.0260869565217, 1.2195652173913, 0.45454545454545
68418, 2.0260869565217, 1.1934782608696, 0.43181818181818
68419, 2.004347826087, 1.1934782608696, 0.40909090909091
68420, 2.0260869565217, 1.2195652173913, 0.40909090909091
68421, 2.0260869565217, 1.1934782608696, 0.38636363636364
68422, 2.004347826087, 1.1934782608696, 0.36363636363636
68423, 2.0260869565217, 1.2195652173913, 0.36363636363636
68424, 2.0260869565217, 1.1934782608696, 0.34090909090909
68425, 2.004347826087, 1.1934782608696, 0.31818181818182
68426, 2.0260869565217, 1.2195652173913, 0.31818181818182
68427, 2.0260869565217, 1.1934782608696, 0.29545454545455
68428, 2.004347826087, 1.1934782608696, 0.27272727272727
68429, 2.0260869565217, 1.2195652173913, 0.27272727272727
68430, 2.0260869565217, 1.1934782608696, 0.25
68431, 2.004347826087, 1.1934782608696, 0.22727272727273
68432, 2.0260869565217, 1.2195652173913, 0.22727272727273
68433, 2.0260869565217, 1.1934782608696, 0.20454545454545
68434, 2.004347826087, 1.1934782608696, 0.18181818181818
68435, 2.0260869565217, 1.2195652173913, 0.18181818181818
68436, 2.0260869565217, 1.1934782608696, 0.15909090909091
68437, 2.004347826087, 1.1934782608696, 0.13636363636364
68438, 2.0260869565217, 1.2195652173913, 0.13636363636364
68439, 2.0260869565217, 1.1934782608696, 0.11363636363636
68440, 2.004347826087, 1.1934782608696, 0.090909090909091
68441, 2.0260869565217, 1.2195652173913, 0.090909090909091
68442, 2.0260869565217, 1.1934782608696, 0.068181818181818
68443, 2.004347826087, 1.1934782608696, 0.045454545454545
68444, 2.0260869565217, 1.2195652173913, 0.045454545454545
68445, 2.0260869565217, 1.1934782608696, 0.022727272727273
68446, 2.0695652173913, 1.1934782608696, 0.47727272727273
68447, 2.0478260869565, 1.1934782608696, 0.45454545454545
68448, 2.0695652173913, 1.2195652173913, 0.45454545454545
68449, 2.0695652173913, 1.1934782608696, 0.43181818181818
68450, 2.0478260869565, 1.1934782608696, 0.40909090909091
68451, 2.0695652173913, 1.2195652173913, 0.40909090909091
68452, 2.0695652173913, 1.1934782608696, 0.38636363636364
68453, 2.0478260869565, 1.1934782608696, 0.36363636363636
68454, 2.0695652173913, 1.2195652173913, 0.36363636363636
68455, 2.0695652173913, 1.1934782608696, 0.34090909090909
68456, 2.0478260869565, 1.1934782608696, 0.31818181818182
68457, 2.0695652173913, 1.2195652173913, 0.31818181818182
68458, 2.0695652173913, 1.1934782608696, 0.29545454545455
68459, 2.0478260869565, 1.1934782608696, 0.27272727272727
68460, 2.0695652173913, 1.2195652173913, 0.27272727272727
68461, 2.0695652173913, 1.1934782608696, 0.25
68462, 2.0478260869565, 1.1934782608696, 0.22727272727273
68463, 2.0695652173913, 1.2195652173913, 0.22727272727273
68464, 2.0695652173913, 1.1934782608696, 0.20454545454545
68465, 2.0478260869565, 1.1934782608696, 0.18181818181818
68466, 2.0695652173913, 1.2195652173913, 0.18181818181818
68467, 2.0695652173913, 1.1934782608696, 0.15909090909091
68468, 2.0478260869565, 1.1934782608696, 0.13636363636364
68469, 2.0695652173913, 1.2195652173913, 0.13636363636364
68470, 2.0695652173913, 1.1934782608696, 0.11363636363636
68471, 2.0478260869565, 1.1934782608696, 0.090909090909091
68472, 2.0695652173913, 1.2195652173913, 0.090909090909091
68473, 2.0695652173913, 1.1934782608696, 0.068181818181818
68474, 2.0478260869565, 1.1934782608696, 0.045454545454545
68475, 2.0695652173913, 1.2195652173913, 0.045454545454545
68476, 2.0695652173913, 1.1934782608696, 0.022727272727273
68477, 2.1130434782609, 1.1934782608696, 0.47727272727273
68478, 2.0913043478261, 1.1934782608696, 0.45454545454545
68479, 2.1130434782609, 1.2195652173913, 0.45454545454545
68480, 2.1130434782609, 1.1934782608696, 0.43181818181818
68481, 2.0913043478261, 1.1934782608696, 0.40909090909091
68482, 2.1130434782609, 1.2195652173913, 0.40909090909091
68483, 2.1130434782609, 1.1934782608696, 0.38636363636364
68484, 2.0913043478261, 1.1934782608696, 0.36363636363636
68485, 2.1130434782609, 1.2195652173913, 0.36363636363636
68486, 2.1130434782609, 1.1934782608696, 0.34090909090909
68487, 2.0913043478261, 1.1934782608696, 0.31818181818182
68488, 2.1130434782609, 1.2195652173913, 0.31818181818182
68489, 2.1130434782609, 1.1934782608696, 0.29545454545455
68490, 2.0913043478261, 1.1934782608696, 0.27272727272727
68491, 2.1130434782609, 1.2195652173913, 0.27272727272727
68492, 2.1130434782609, 1.1934782608696, 0.25
68493, 2.0913043478261, 1.1934782608696, 0.22727272727273
68494, 2.1130434782609, 1.2195652173913, 0.22727272727273
68495, 2.1130434782609, 1.1934782608696, 0.20454545454545
68496, 2.0913043478261, 1.1934782608696, 0.18181818181818
68497, 2.1130434782609, 1.2195652173913, 0.18181818181818
68498, 2.1130434782609, 1.1934782608696, 0.15909090909091
68499, 2.0913043478261, 1.1934782608696, 0.13636363636364
68500, 2.1130434782609, 1.2195652173913, 0.13636363636364
68501, 2.1130434782609, 1.1934782608696, 0.11363636363636
68502, 2.0913043478261, 1.1934782608696, 0.090909090909091
68503, 2.1130434782609, 1.2195652173913, 0.090909090909091
68504, 2.1130434782609, 1.1934782608696, 0.068181818181818
68505, 2.0913043478261, 1.1934782608696, 0.045454545454545
68506, 2.1130434782609, 1.2195652173913, 0.045454545454545
68507, 2.1130434782609, 1.1934782608696, 0.022727272727273
68508, 2.1565217391304, 1.1934782608696, 0.47727272727273
68509, 2.1347826086957, 1.1934782608696, 0.45454545454545
68510, 2.1565217391304, 1.2195652173913, 0.45454545454545
68511, 2.1565217391304, 1.1934782608696, 0.43181818181818
68512, 2.1347826086957, 1.1934782608696, 0.40909090909091
68513, 2.1565217391304, 1.2195652173913, 0.40909090909091
68514, 2.1565217391304, 1.1934782608696, 0.38636363636364
68515, 2.1347826086957, 1.1934782608696, 0.36363636363636
68516, 2.1565217391304, 1.2195652173913, 0.36363636363636
68517, 2.1565217391304, 1.1934782608696, 0.34090909090909
68518, 2.1347826086957, 1.1934782608696, 0.31818181818182
68519, 2.1565217391304, 1.2195652173913, 0.31818181818182
68520, 2.1565217391304, 1.1934782608696, 0.29545454545455
68521, 2.1347826086957, 1.1934782608696, 0.27272727272727
68522, 2.1565217391304, 1.2195652173913, 0.27272727272727
68523, 2.1565217391304, 1.1934782608696, 0.25
68524, 2.1347826086957, 1.1934782608696, 0.22727272727273
68525, 2.1565217391304, 1.2195652173913, 0.22727272727273
68526, 2.1565217391304, 1.1934782608696, 0.20454545454545
68527, 2.1347826086957, 1.1934782608696, 0.18181818181818
68528, 2.1565217391304, 1.2195652173913, 0.18181818181818
68529, 2.1565217391304, 1.1934782608696, 0.15909090909091
68530, 2.1347826086957, 1.1934782608696, 0.13636363636364
68531, 2.1565217391304, 1.2195652173913, 0.13636363636364
68532, 2.1565217391304, 1.1934782608696, 0.11363636363636
68533, 2.1347826086957, 1.1934782608696, 0.090909090909091
68534, 2.1565217391304, 1.2195652173913, 0.090909090909091
68535, 2.1565217391304, 1.1934782608696, 0.068181818181818
68536, 2.1347826086957, 1.1934782608696, 0.045454545454545
68537, 2.1565217391304, 1.2195652173913, 0.045454545454545
68538, 2.1565217391304, 1.1934782608696, 0.022727272727273
68539, 2.1782608695652, 1.1934782608696, 0.45454545454545
68540, 2.1782608695652, 1.1934782608696, 0.40909090909091
68541, 2.1782608695652, 1.1934782608696, 0.36363636363636
68542, 2.1782608695652, 1.1934782608696, 0.31818181818182
68543, 2.1782608695652, 1.1934782608696, 0.27272727272727
68544, 2.1782608695652, 1.1934782608696, 0.22727272727273
68545, 2.1782608695652, 1.1934782608696, 0.18181818181818
68546, 2.1782608695652, 1.1934782608696, 0.13636363636364
68547, 2.1782608695652, 1.1934782608696, 0.090909090909091
68548, 2.1782608695652, 1.1934782608696, 0.045454545454545
68549, 1.2434782608696, 1.1413043478261, 0.47727272727273
68550, 1.2217391304348, 1.1413043478261, 0.45454545454545
68551, 1.2434782608696, 1.1673913043478, 0.45454545454545
68552, 1.2434782608696, 1.1413043478261, 0.43181818181818
68553, 1.2217391304348, 1.1413043478261, 0.40909090909091
68554, 1.2434782608696, 1.1673913043478, 0.40909090909091
68555, 1.2434782608696, 1.1413043478261, 0.38636363636364
68556, 1.2217391304348, 1.1413043478261, 0.36363636363636
68557, 1.2434782608696, 1.1673913043478, 0.36363636363636
68558, 1.2434782608696, 1.1413043478261, 0.34090909090909
68559, 1.2217391304348, 1.1413043478261, 0.31818181818182
68560, 1.2434782608696, 1.1673913043478, 0.31818181818182
68561, 1.2434782608696, 1.1413043478261, 0.29545454545455
68562, 1.2217391304348, 1.1413043478261, 0.27272727272727
68563, 1.2434782608696, 1.1673913043478, 0.27272727272727
68564, 1.2434782608696, 1.1413043478261, 0.25
68565, 1.2217391304348, 1.1413043478261, 0.22727272727273
68566, 1.2434782608696, 1.1673913043478, 0.22727272727273
68567, 1.2434782608696, 1.1413043478261, 0.20454545454545
68568, 1.2217391304348, 1.1413043478261, 0.18181818181818
68569, 1.2434782608696, 1.1673913043478, 0.18181818181818
68570, 1.2434782608696, 1.1413043478261, 0.15909090909091
68571, 1.2217391304348, 1.1413043478261, 0.13636363636364
68572, 1.2434782608696, 1.1673913043478, 0.13636363636364
68573, 1.2434782608696, 1.1413043478261, 0.11363636363636
68574, 1.2217391304348, 1.1413043478261, 0.090909090909091
68575, 1.2434782608696, 1.1673913043478, 0.090909090909091
68576, 1.2434782608696, 1.1413043478261, 0.068181818181818
68577, 1.2217391304348, 1.1413043478261, 0.045454545454545
68578, 1.2434782608696, 1.1673913043478, 0.045454545454545
68579, 1.2434782608696, 1.1413043478261, 0.022727272727273
68580, 1.2869565217391, 1.1413043478261, 0.47727272727273
68581, 1.2652173913043, 1.1413043478261, 0.45454545454545
68582, 1.2869565217391, 1.1673913043478, 0.45454545454545
68583, 1.2869565217391, 1.1413043478261, 0.43181818181818
68584, 1.2652173913043, 1.1413043478261, 0.40909090909091
68585, 1.2869565217391, 1.1673913043478, 0.40909090909091
68586, 1.2869565217391, 1.1413043478261, 0.38636363636364
68587, 1.2652173913043, 1.1413043478261, 0.36363636363636
68588, 1.2869565217391, 1.1673913043478, 0.36363636363636
68589, 1.2869565217391, 1.1413043478261, 0.34090909090909
68590, 1.2652173913043, 1.1413043478261, 0.31818181818182
68591, 1.2869565217391, 1.1673913043478, 0.31818181818182
68592, 1.2869565217391, 1.1413043478261, 0.29545454545455
68593, 1.2652173913043, 1.1413043478261, 0.27272727272727
68594, 1.2869565217391, 1.1673913043478, 0.27272727272727
68595, 1.2869565217391, 1.1413043478261, 0.25
68596, 1.2652173913043, 1.1413043478261, 0.22727272727273
68597, 1.2869565217391, 1.1673913043478, 0.22727272727273
68598, 1.2869565217391, 1.1413043478261, 0.20454545454545
68599, 1.2652173913043, 1.1413043478261, 0.18181818181818
68600, 1.2869565217391, 1.1673913043478, 0.18181818181818
68601, 1.2869565217391, 1.1413043478261, 0.15909090909091
68602, 1.2652173913043, 1.1413043478261, 0.13636363636364
68603, 1.2869565217391, 1.1673913043478, 0.13636363636364
68604, 1.2869565217391, 1.1413043478261, 0.11363636363636
68605, 1.2652173913043, 1.1413043478261, 0.090909090909091
68606, 1.2869565217391, 1.1673913043478, 0.090909090909091
68607, 1.2869565217391, 1.1413043478261, 0.068181818181818
68608, 1.2652173913043, 1.1413043478261, 0.045454545454545
68609, 1.2869565217391, 1.1673913043478, 0.045454545454545
68610, 1.2869565217391, 1.1413043478261, 0.022727272727273
68611, 1.3304347826087, 1.1413043478261, 0.47727272727273
68612, 1.3086956521739, 1.1413043478261, 0.45454545454545
68613, 1.3304347826087, 1.1673913043478, 0.45454545454545
68614, 1.3304347826087, 1.1413043478261, 0.43181818181818
68615, 1.3086956521739, 1.1413043478261, 0.40909090909091
68616, 1.3304347826087, 1.1673913043478, 0.40909090909091
68617, 1.3304347826087, 1.1413043478261, 0.38636363636364
68618, 1.3086956521739, 1.1413043478261, 0.36363636363636
68619, 1.3304347826087, 1.1673913043478, 0.36363636363636
68620, 1.3304347826087, 1.1413043478261, 0.34090909090909
68621, 1.3086956521739, 1.1413043478261, 0.31818181818182
68622, 1.3304347826087, 1.1673913043478, 0.31818181818182
68623, 1.3304347826087, 1.1413043478261, 0.29545454545455
68624, 1.3086956521739, 1.1413043478261, 0.27272727272727
68625, 1.3304347826087, 1.1673913043478, 0.27272727272727
68626, 1.3304347826087, 1.1413043478261, 0.25
68627, 1.3086956521739, 1.1413043478261, 0.22727272727273
68628, 1.3304347826087, 1.1673913043478, 0.22727272727273
68629, 1.3304347826087, 1.1413043478261, 0.20454545454545
68630, 1.3086956521739, 1.1413043478261, 0.18181818181818
68631, 1.3304347826087, 1.1673913043478, 0.18181818181818
68632, 1.3304347826087, 1.1413043478261, 0.15909090909091
68633, 1.3086956521739, 1.1413043478261, 0.13636363636364
68634, 1.3304347826087, 1.1673913043478, 0.13636363636364
68635, 1.3304347826087, 1.1413043478261, 0.11363636363636
68636, 1.3086956521739, 1.1413043478261, 0.090909090909091
68637, 1.3304347826087, 1.1673913043478, 0.090909090909091
68638, 1.3304347826087, 1.1413043478261, 0.068181818181818
68639, 1.3086956521739, 1.1413043478261, 0.045454545454545
68640, 1.3304347826087, 1.1673913043478, 0.045454545454545
68641, 1.3304347826087, 1.1413043478261, 0.022727272727273
68642, 1.3739130434783, 1.1413043478261, 0.47727272727273
68643, 1.3521739130435, 1.1413043478261, 0.45454545454545
68644, 1.3739130434783, 1.1673913043478, 0.45454545454545
68645, 1.3739130434783, 1.1413043478261, 0.43181818181818
68646, 1.3521739130435, 1.1413043478261, 0.40909090909091
68647, 1.3739130434783, 1.1673913043478, 0.40909090909091
68648, 1.3739130434783, 1.1413043478261, 0.38636363636364
68649, 1.3521739130435, 1.1413043478261, 0.36363636363636
68650, 1.3739130434783, 1.1673913043478, 0.36363636363636
68651, 1.3739130434783, 1.1413043478261, 0.34090909090909
68652, 1.3521739130435, 1.1413043478261, 0.31818181818182
68653, 1.3739130434783, 1.1673913043478, 0.31818181818182
68654, 1.3739130434783, 1.1413043478261, 0.29545454545455
68655, 1.3521739130435, 1.1413043478261, 0.27272727272727
68656, 1.3739130434783, 1.1673913043478, 0.27272727272727
68657, 1.3739130434783, 1.1413043478261, 0.25
68658, 1.3521739130435, 1.1413043478261, 0.22727272727273
68659, 1.3739130434783, 1.1673913043478, 0.22727272727273
68660, 1.3739130434783, 1.1413043478261, 0.20454545454545
68661, 1.3521739130435, 1.1413043478261, 0.18181818181818
68662, 1.3739130434783, 1.1673913043478, 0.18181818181818
68663, 1.3739130434783, 1.1413043478261, 0.15909090909091
68664, 1.3521739130435, 1.1413043478261, 0.13636363636364
68665, 1.3739130434783, 1.1673913043478, 0.13636363636364
68666, 1.3739130434783, 1.1413043478261, 0.11363636363636
68667, 1.3521739130435, 1.1413043478261, 0.090909090909091
68668, 1.3739130434783, 1.1673913043478, 0.090909090909091
68669, 1.3739130434783, 1.1413043478261, 0.068181818181818
68670, 1.3521739130435, 1.1413043478261, 0.045454545454545
68671, 1.3739130434783, 1.1673913043478, 0.045454545454545
68672, 1.3739130434783, 1.1413043478261, 0.022727272727273
68673, 1.4173913043478, 1.1413043478261, 0.47727272727273
68674, 1.395652173913, 1.1413043478261, 0.45454545454545
68675, 1.4173913043478, 1.1673913043478, 0.45454545454545
68676, 1.4173913043478, 1.1413043478261, 0.43181818181818
68677, 1.395652173913, 1.1413043478261, 0.40909090909091
68678, 1.4173913043478, 1.1673913043478, 0.40909090909091
68679, 1.4173913043478, 1.1413043478261, 0.38636363636364
68680, 1.395652173913, 1.1413043478261, 0.36363636363636
68681, 1.4173913043478, 1.1673913043478, 0.36363636363636
68682, 1.4173913043478, 1.1413043478261, 0.34090909090909
68683, 1.395652173913, 1.1413043478261, 0.31818181818182
68684, 1.4173913043478, 1.1673913043478, 0.31818181818182
68685, 1.4173913043478, 1.1413043478261, 0.29545454545455
68686, 1.395652173913, 1.1413043478261, 0.27272727272727
68687, 1.4173913043478, 1.1673913043478, 0.27272727272727
68688, 1.4173913043478, 1.1413043478261, 0.25
68689, 1.395652173913, 1.1413043478261, 0.22727272727273
68690, 1.4173913043478, 1.1673913043478, 0.22727272727273
68691, 1.4173913043478, 1.1413043478261, 0.20454545454545
68692, 1.395652173913, 1.1413043478261, 0.18181818181818
68693, 1.4173913043478, 1.1673913043478, 0.18181818181818
68694, 1.4173913043478, 1.1413043478261, 0.15909090909091
68695, 1.395652173913, 1.1413043478261, 0.13636363636364
68696, 1.4173913043478, 1.1673913043478, 0.13636363636364
68697, 1.4173913043478, 1.1413043478261, 0.11363636363636
68698, 1.395652173913, 1.1413043478261, 0.090909090909091
68699, 1.4173913043478, 1.1673913043478, 0.090909090909091
68700, 1.4173913043478, 1.1413043478261, 0.068181818181818
68701, 1.395652173913, 1.1413043478261, 0.045454545454545
68702, 1.4173913043478, 1.1673913043478, 0.045454545454545
68703, 1.4173913043478, 1.1413043478261, 0.022727272727273
68704, 1.4608695652174, 1.1413043478261, 0.47727272727273
68705, 1.4391304347826, 1.1413043478261, 0.45454545454545
68706, 1.4608695652174, 1.1673913043478, 0.45454545454545
68707, 1.4608695652174, 1.1413043478261, 0.43181818181818
68708, 1.4391304347826, 1.1413043478261, 0.40909090909091
68709, 1.4608695652174, 1.1673913043478, 0.40909090909091
68710, 1.4608695652174, 1.1413043478261, 0.38636363636364
68711, 1.4391304347826, 1.1413043478261, 0.36363636363636
68712, 1.4608695652174, 1.1673913043478, 0.36363636363636
68713, 1.4608695652174, 1.1413043478261, 0.34090909090909
68714, 1.4391304347826, 1.1413043478261, 0.31818181818182
68715, 1.4608695652174, 1.1673913043478, 0.31818181818182
68716, 1.4608695652174, 1.1413043478261, 0.29545454545455
68717, 1.4391304347826, 1.1413043478261, 0.27272727272727
68718, 1.4608695652174, 1.1673913043478, 0.27272727272727
68719, 1.4608695652174, 1.1413043478261, 0.25
68720, 1.4391304347826, 1.1413043478261, 0.22727272727273
68721, 1.4608695652174, 1.1673913043478, 0.22727272727273
68722, 1.4608695652174, 1.1413043478261, 0.20454545454545
68723, 1.4391304347826, 1.1413043478261, 0.18181818181818
68724, 1.4608695652174, 1.1673913043478, 0.18181818181818
68725, 1.4608695652174, 1.1413043478261, 0.15909090909091
68726, 1.4391304347826, 1.1413043478261, 0.13636363636364
68727, 1.4608695652174, 1.1673913043478, 0.13636363636364
68728, 1.4608695652174, 1.1413043478261, 0.11363636363636
68729, 1.4391304347826, 1.1413043478261, 0.090909090909091
68730, 1.4608695652174, 1.1673913043478, 0.090909090909091
68731, 1.4608695652174, 1.1413043478261, 0.068181818181818
68732, 1.4391304347826, 1.1413043478261, 0.045454545454545
68733, 1.4608695652174, 1.1673913043478, 0.045454545454545
68734, 1.4608695652174, 1.1413043478261, 0.022727272727273
68735, 1.504347826087, 1.1413043478261, 0.47727272727273
68736, 1.4826086956522, 1.1413043478261, 0.45454545454545
68737, 1.504347826087, 1.1673913043478, 0.45454545454545
68738, 1.504347826087, 1.1413043478261, 0.43181818181818
68739, 1.4826086956522, 1.1413043478261, 0.40909090909091
68740, 1.504347826087, 1.1673913043478, 0.40909090909091
68741, 1.504347826087, 1.1413043478261, 0.38636363636364
68742, 1.4826086956522, 1.1413043478261, 0.36363636363636
68743, 1.504347826087, 1.1673913043478, 0.36363636363636
68744, 1.504347826087, 1.1413043478261, 0.34090909090909
68745, 1.4826086956522, 1.1413043478261, 0.31818181818182
68746, 1.504347826087, 1.1673913043478, 0.31818181818182
68747, 1.504347826087, 1.1413043478261, 0.29545454545455
68748, 1.4826086956522, 1.1413043478261, 0.27272727272727
68749, 1.504347826087, 1.1673913043478, 0.27272727272727
68750, 1.504347826087, 1.1413043478261, 0.25
68751, 1.4826086956522, 1.1413043478261, 0.22727272727273
68752, 1.504347826087, 1.1673913043478, 0.22727272727273
68753, 1.504347826087, 1.1413043478261, 0.20454545454545
68754, 1.4826086956522, 1.1413043478261, 0.18181818181818
68755, 1.504347826087, 1.1673913043478, 0.18181818181818
68756, 1.504347826087, 1.1413043478261, 0.15909090909091
68757, 1.4826086956522, 1.1413043478261, 0.13636363636364
68758, 1.504347826087, 1.1673913043478, 0.13636363636364
68759, 1.504347826087, 1.1413043478261, 0.11363636363636
68760, 1.4826086956522, 1.1413043478261, 0.090909090909091
68761, 1.504347826087, 1.1673913043478, 0.090909090909091
68762, 1.504347826087, 1.1413043478261, 0.068181818181818
68763, 1.4826086956522, 1.1413043478261, 0.045454545454545
68764, 1.504347826087, 1.1673913043478, 0.045454545454545
68765, 1.504347826087, 1.1413043478261, 0.022727272727273
68766, 1.5478260869565, 1.1413043478261, 0.47727272727273
68767, 1.5260869565217, 1.1413043478261, 0.45454545454545
68768, 1.5478260869565, 1.1673913043478, 0.45454545454545
68769, 1.5478260869565, 1.1413043478261, 0.43181818181818
68770, 1.5260869565217, 1.1413043478261, 0.40909090909091
68771, 1.5478260869565, 1.1673913043478, 0.40909090909091
68772, 1.5478260869565, 1.1413043478261, 0.38636363636364
68773, 1.5260869565217, 1.1413043478261, 0.36363636363636
68774, 1.5478260869565, 1.1673913043478, 0.36363636363636
68775, 1.5478260869565, 1.1413043478261, 0.34090909090909
68776, 1.5260869565217, 1.1413043478261, 0.31818181818182
68777, 1.5478260869565, 1.1673913043478, 0.31818181818182
68778, 1.5478260869565, 1.1413043478261, 0.29545454545455
68779, 1.5260869565217, 1.1413043478261, 0.27272727272727
68780, 1.5478260869565, 1.1673913043478, 0.27272727272727
68781, 1.5478260869565, 1.1413043478261, 0.25
68782, 1.5260869565217, 1.1413043478261, 0.22727272727273
68783, 1.5478260869565, 1.1673913043478, 0.22727272727273
68784, 1.5478260869565, 1.1413043478261, 0.20454545454545
68785, 1.5260869565217, 1.1413043478261, 0.18181818181818
68786, 1.5478260869565, 1.1673913043478, 0.18181818181818
68787, 1.5478260869565, 1.1413043478261, 0.15909090909091
68788, 1.5260869565217, 1.1413043478261, 0.13636363636364
68789, 1.5478260869565, 1.1673913043478, 0.13636363636364
68790, 1.5478260869565, 1.1413043478261, 0.11363636363636
68791, 1.5260869565217, 1.1413043478261, 0.090909090909091
68792, 1.5478260869565, 1.1673913043478, 0.090909090909091
68793, 1.5478260869565, 1.1413043478261, 0.068181818181818
68794, 1.5260869565217, 1.1413043478261, 0.045454545454545
68795, 1.5478260869565, 1.1673913043478, 0.045454545454545
68796, 1.5478260869565, 1.1413043478261, 0.022727272727273
68797, 1.5913043478261, 1.1413043478261, 0.47727272727273
68798, 1.5695652173913, 1.1413043478261, 0.45454545454545
68799, 1.5913043478261, 1.1673913043478, 0.45454545454545
68800, 1.5913043478261, 1.1413043478261, 0.43181818181818
68801, 1.5695652173913, 1.1413043478261, 0.40909090909091
68802, 1.5913043478261, 1.1673913043478, 0.40909090909091
68803, 1.5913043478261, 1.1413043478261, 0.38636363636364
68804, 1.5695652173913, 1.1413043478261, 0.36363636363636
68805, 1.5913043478261, 1.1673913043478, 0.36363636363636
68806, 1.5913043478261, 1.1413043478261, 0.34090909090909
68807, 1.5695652173913, 1.1413043478261, 0.31818181818182
68808, 1.5913043478261, 1.1673913043478, 0.31818181818182
68809, 1.5913043478261, 1.1413043478261, 0.29545454545455
68810, 1.5695652173913, 1.1413043478261, 0.27272727272727
68811, 1.5913043478261, 1.1673913043478, 0.27272727272727
68812, 1.5913043478261, 1.1413043478261, 0.25
68813, 1.5695652173913, 1.1413043478261, 0.22727272727273
68814, 1.5913043478261, 1.1673913043478, 0.22727272727273
68815, 1.5913043478261, 1.1413043478261, 0.20454545454545
68816, 1.5695652173913, 1.1413043478261, 0.18181818181818
68817, 1.5913043478261, 1.1673913043478, 0.18181818181818
68818, 1.5913043478261, 1.1413043478261, 0.15909090909091
68819, 1.5695652173913, 1.1413043478261, 0.13636363636364
68820, 1.5913043478261, 1.1673913043478, 0.13636363636364
68821, 1.5913043478261, 1.1413043478261, 0.11363636363636
68822, 1.5695652173913, 1.1413043478261, 0.090909090909091
68823, 1.5913043478261, 1.1673913043478, 0.090909090909091
68824, 1.5913043478261, 1.1413043478261, 0.068181818181818
68825, 1.5695652173913, 1.1413043478261, 0.045454545454545
68826, 1.5913043478261, 1.1673913043478, 0.045454545454545
68827, 1.5913043478261, 1.1413043478261, 0.022727272727273
68828, 1.6347826086957, 1.1413043478261, 0.47727272727273
68829, 1.6130434782609, 1.1413043478261, 0.45454545454545
68830, 1.6347826086957, 1.1673913043478, 0.45454545454545
68831, 1.6347826086957, 1.1413043478261, 0.43181818181818
68832, 1.6130434782609, 1.1413043478261, 0.40909090909091
68833, 1.6347826086957, 1.1673913043478, 0.40909090909091
68834, 1.6347826086957, 1.1413043478261, 0.38636363636364
68835, 1.6130434782609, 1.1413043478261, 0.36363636363636
68836, 1.6347826086957, 1.1673913043478, 0.36363636363636
68837, 1.6347826086957, 1.1413043478261, 0.34090909090909
68838, 1.6130434782609, 1.1413043478261, 0.31818181818182
68839, 1.6347826086957, 1.1673913043478, 0.31818181818182
68840, 1.6347826086957, 1.1413043478261, 0.29545454545455
68841, 1.6130434782609, 1.1413043478261, 0.27272727272727
68842, 1.6347826086957, 1.1673913043478, 0.27272727272727
68843, 1.6347826086957, 1.1413043478261, 0.25
68844, 1.6130434782609, 1.1413043478261, 0.22727272727273
68845, 1.6347826086957, 1.1673913043478, 0.22727272727273
68846, 1.6347826086957, 1.1413043478261, 0.20454545454545
68847, 1.6130434782609, 1.1413043478261, 0.18181818181818
68848, 1.6347826086957, 1.1673913043478, 0.18181818181818
68849, 1.6347826086957, 1.1413043478261, 0.15909090909091
68850, 1.6130434782609, 1.1413043478261, 0.13636363636364
68851, 1.6347826086957, 1.1673913043478, 0.13636363636364
68852, 1.6347826086957, 1.1413043478261, 0.11363636363636
68853, 1.6130434782609, 1.1413043478261, 0.090909090909091
68854, 1.6347826086957, 1.1673913043478, 0.090909090909091
68855, 1.6347826086957, 1.1413043478261, 0.068181818181818
68856, 1.6130434782609, 1.1413043478261, 0.045454545454545
68857, 1.6347826086957, 1.1673913043478, 0.045454545454545
68858, 1.6347826086957, 1.1413043478261, 0.022727272727273
68859, 1.6782608695652, 1.1413043478261, 0.47727272727273
68860, 1.6565217391304, 1.1413043478261, 0.45454545454545
68861, 1.6782608695652, 1.1673913043478, 0.45454545454545
68862, 1.6782608695652, 1.1413043478261, 0.43181818181818
68863, 1.6565217391304, 1.1413043478261, 0.40909090909091
68864, 1.6782608695652, 1.1673913043478, 0.40909090909091
68865, 1.6782608695652, 1.1413043478261, 0.38636363636364
68866, 1.6565217391304, 1.1413043478261, 0.36363636363636
68867, 1.6782608695652, 1.1673913043478, 0.36363636363636
68868, 1.6782608695652, 1.1413043478261, 0.34090909090909
68869, 1.6565217391304, 1.1413043478261, 0.31818181818182
68870, 1.6782608695652, 1.1673913043478, 0.31818181818182
68871, 1.6782608695652, 1.1413043478261, 0.29545454545455
68872, 1.6565217391304, 1.1413043478261, 0.27272727272727
68873, 1.6782608695652, 1.1673913043478, 0.27272727272727
68874, 1.6782608695652, 1.1413043478261, 0.25
68875, 1.6565217391304, 1.1413043478261, 0.22727272727273
68876, 1.6782608695652, 1.1673913043478, 0.22727272727273
68877, 1.6782608695652, 1.1413043478261, 0.20454545454545
68878, 1.6565217391304, 1.1413043478261, 0.18181818181818
68879, 1.6782608695652, 1.1673913043478, 0.18181818181818
68880, 1.6782608695652, 1.1413043478261, 0.15909090909091
68881, 1.6565217391304, 1.1413043478261, 0.13636363636364
68882, 1.6782608695652, 1.1673913043478, 0.13636363636364
68883, 1.6782608695652, 1.1413043478261, 0.11363636363636
68884, 1.6565217391304, 1.1413043478261, 0.090909090909091
68885, 1.6782608695652, 1.1673913043478, 0.090909090909091
68886, 1.6782608695652, 1.1413043478261, 0.068181818181818
68887, 1.6565217391304, 1.1413043478261, 0.045454545454545
68888, 1.6782608695652, 1.1673913043478, 0.045454545454545
68889, 1.6782608695652, 1.1413043478261, 0.022727272727273
68890, 1.7217391304348, 1.1413043478261, 0.47727272727273
68891, 1.7, 1.1413043478261, 0.45454545454545
68892, 1.7217391304348, 1.1673913043478, 0.45454545454545
68893, 1.7217391304348, 1.1413043478261, 0.43181818181818
68894, 1.7, 1.1413043478261, 0.40909090909091
68895, 1.7217391304348, 1.1673913043478, 0.40909090909091
68896, 1.7217391304348, 1.1413043478261, 0.38636363636364
68897, 1.7, 1.1413043478261, 0.36363636363636
68898, 1.7217391304348, 1.1673913043478, 0.36363636363636
68899, 1.7217391304348, 1.1413043478261, 0.34090909090909
68900, 1.7, 1.1413043478261, 0.31818181818182
68901, 1.7217391304348, 1.1673913043478, 0.31818181818182
68902, 1.7217391304348, 1.1413043478261, 0.29545454545455
68903, 1.7, 1.1413043478261, 0.27272727272727
68904, 1.7217391304348, 1.1673913043478, 0.27272727272727
68905, 1.7217391304348, 1.1413043478261, 0.25
68906, 1.7, 1.1413043478261, 0.22727272727273
68907, 1.7217391304348, 1.1673913043478, 0.22727272727273
68908, 1.7217391304348, 1.1413043478261, 0.20454545454545
68909, 1.7, 1.1413043478261, 0.18181818181818
68910, 1.7217391304348, 1.1673913043478, 0.18181818181818
68911, 1.7217391304348, 1.1413043478261, 0.15909090909091
68912, 1.7, 1.1413043478261, 0.13636363636364
68913, 1.7217391304348, 1.1673913043478, 0.13636363636364
68914, 1.7217391304348, 1.1413043478261, 0.11363636363636
68915, 1.7, 1.1413043478261, 0.090909090909091
68916, 1.7217391304348, 1.1673913043478, 0.090909090909091
68917, 1.7217391304348, 1.1413043478261, 0.068181818181818
68918, 1.7, 1.1413043478261, 0.045454545454545
68919, 1.7217391304348, 1.1673913043478, 0.045454545454545
68920, 1.7217391304348, 1.1413043478261, 0.022727272727273
68921, 1.7652173913043, 1.1413043478261, 0.47727272727273
68922, 1.7434782608696, 1.1413043478261, 0.45454545454545
68923, 1.7652173913043, 1.1673913043478, 0.45454545454545
68924, 1.7652173913043, 1.1413043478261, 0.43181818181818
68925, 1.7434782608696, 1.1413043478261, 0.40909090909091
68926, 1.7652173913043, 1.1673913043478, 0.40909090909091
68927, 1.7652173913043, 1.1413043478261, 0.38636363636364
68928, 1.7434782608696, 1.1413043478261, 0.36363636363636
68929, 1.7652173913043, 1.1673913043478, 0.36363636363636
68930, 1.7652173913043, 1.1413043478261, 0.34090909090909
68931, 1.7434782608696, 1.1413043478261, 0.31818181818182
68932, 1.7652173913043, 1.1673913043478, 0.31818181818182
68933, 1.7652173913043, 1.1413043478261, 0.29545454545455
68934, 1.7434782608696, 1.1413043478261, 0.27272727272727
68935, 1.7652173913043, 1.1673913043478, 0.27272727272727
68936, 1.7652173913043, 1.1413043478261, 0.25
68937, 1.7434782608696, 1.1413043478261, 0.22727272727273
68938, 1.7652173913043, 1.1673913043478, 0.22727272727273
68939, 1.7652173913043, 1.1413043478261, 0.20454545454545
68940, 1.7434782608696, 1.1413043478261, 0.18181818181818
68941, 1.7652173913043, 1.1673913043478, 0.18181818181818
68942, 1.7652173913043, 1.1413043478261, 0.15909090909091
68943, 1.7434782608696, 1.1413043478261, 0.13636363636364
68944, 1.7652173913043, 1.1673913043478, 0.13636363636364
68945, 1.7652173913043, 1.1413043478261, 0.11363636363636
68946, 1.7434782608696, 1.1413043478261, 0.090909090909091
68947, 1.7652173913043, 1.1673913043478, 0.090909090909091
68948, 1.7652173913043, 1.1413043478261, 0.068181818181818
68949, 1.7434782608696, 1.1413043478261, 0.045454545454545
68950, 1.7652173913043, 1.1673913043478, 0.045454545454545
68951, 1.7652173913043, 1.1413043478261, 0.022727272727273
68952, 1.8086956521739, 1.1413043478261, 0.47727272727273
68953, 1.7869565217391, 1.1413043478261, 0.45454545454545
68954, 1.8086956521739, 1.1673913043478, 0.45454545454545
68955, 1.8086956521739, 1.1413043478261, 0.43181818181818
68956, 1.7869565217391, 1.1413043478261, 0.40909090909091
68957, 1.8086956521739, 1.1673913043478, 0.40909090909091
68958, 1.8086956521739, 1.1413043478261, 0.38636363636364
68959, 1.7869565217391, 1.1413043478261, 0.36363636363636
68960, 1.8086956521739, 1.1673913043478, 0.36363636363636
68961, 1.8086956521739, 1.1413043478261, 0.34090909090909
68962, 1.7869565217391, 1.1413043478261, 0.31818181818182
68963, 1.8086956521739, 1.1673913043478, 0.31818181818182
68964, 1.8086956521739, 1.1413043478261, 0.29545454545455
68965, 1.7869565217391, 1.1413043478261, 0.27272727272727
68966, 1.8086956521739, 1.1673913043478, 0.27272727272727
68967, 1.8086956521739, 1.1413043478261, 0.25
68968, 1.7869565217391, 1.1413043478261, 0.22727272727273
68969, 1.8086956521739, 1.1673913043478, 0.22727272727273
68970, 1.8086956521739, 1.1413043478261, 0.20454545454545
68971, 1.7869565217391, 1.1413043478261, 0.18181818181818
68972, 1.8086956521739, 1.1673913043478, 0.18181818181818
68973, 1.8086956521739, 1.1413043478261, 0.15909090909091
68974, 1.7869565217391, 1.1413043478261, 0.13636363636364
68975, 1.8086956521739, 1.1673913043478, 0.13636363636364
68976, 1.8086956521739, 1.1413043478261, 0.11363636363636
68977, 1.7869565217391, 1.1413043478261, 0.090909090909091
68978, 1.8086956521739, 1.1673913043478, 0.090909090909091
68979, 1.8086956521739, 1.1413043478261, 0.068181818181818
68980, 1.7869565217391, 1.1413043478261, 0.045454545454545
68981, 1.8086956521739, 1.1673913043478, 0.045454545454545
68982, 1.8086956521739, 1.1413043478261, 0.022727272727273
68983, 1.8521739130435, 1.1413043478261, 0.47727272727273
68984, 1.8304347826087, 1.1413043478261, 0.45454545454545
68985, 1.8521739130435, 1.1673913043478, 0.45454545454545
68986, 1.8521739130435, 1.1413043478261, 0.43181818181818
68987, 1.8304347826087, 1.1413043478261, 0.40909090909091
68988, 1.8521739130435, 1.1673913043478, 0.40909090909091
68989, 1.8521739130435, 1.1413043478261, 0.38636363636364
68990, 1.8304347826087, 1.1413043478261, 0.36363636363636
68991, 1.8521739130435, 1.1673913043478, 0.36363636363636
68992, 1.8521739130435, 1.1413043478261, 0.34090909090909
68993, 1.8304347826087, 1.1413043478261, 0.31818181818182
68994, 1.8521739130435, 1.1673913043478, 0.31818181818182
68995, 1.8521739130435, 1.1413043478261, 0.29545454545455
68996, 1.8304347826087, 1.1413043478261, 0.27272727272727
68997, 1.8521739130435, 1.1673913043478, 0.27272727272727
68998, 1.8521739130435, 1.1413043478261, 0.25
68999, 1.8304347826087, 1.1413043478261, 0.22727272727273
69000, 1.8521739130435, 1.1673913043478, 0.22727272727273
69001, 1.8521739130435, 1.1413043478261, 0.20454545454545
69002, 1.8304347826087, 1.1413043478261, 0.18181818181818
69003, 1.8521739130435, 1.1673913043478, 0.18181818181818
69004, 1.8521739130435, 1.1413043478261, 0.15909090909091
69005, 1.8304347826087, 1.1413043478261, 0.13636363636364
69006, 1.8521739130435, 1.1673913043478, 0.13636363636364
69007, 1.8521739130435, 1.1413043478261, 0.11363636363636
69008, 1.8304347826087, 1.1413043478261, 0.090909090909091
69009, 1.8521739130435, 1.1673913043478, 0.090909090909091
69010, 1.8521739130435, 1.1413043478261, 0.068181818181818
69011, 1.8304347826087, 1.1413043478261, 0.045454545454545
69012, 1.8521739130435, 1.1673913043478, 0.045454545454545
69013, 1.8521739130435, 1.1413043478261, 0.022727272727273
69014, 1.895652173913, 1.1413043478261, 0.47727272727273
69015, 1.8739130434783, 1.1413043478261, 0.45454545454545
69016, 1.895652173913, 1.1673913043478, 0.45454545454545
69017, 1.895652173913, 1.1413043478261, 0.43181818181818
69018, 1.8739130434783, 1.1413043478261, 0.40909090909091
69019, 1.895652173913, 1.1673913043478, 0.40909090909091
69020, 1.895652173913, 1.1413043478261, 0.38636363636364
69021, 1.8739130434783, 1.1413043478261, 0.36363636363636
69022, 1.895652173913, 1.1673913043478, 0.36363636363636
69023, 1.895652173913, 1.1413043478261, 0.34090909090909
69024, 1.8739130434783, 1.1413043478261, 0.31818181818182
69025, 1.895652173913, 1.1673913043478, 0.31818181818182
69026, 1.895652173913, 1.1413043478261, 0.29545454545455
69027, 1.8739130434783, 1.1413043478261, 0.27272727272727
69028, 1.895652173913, 1.1673913043478, 0.27272727272727
69029, 1.895652173913, 1.1413043478261, 0.25
69030, 1.8739130434783, 1.1413043478261, 0.22727272727273
69031, 1.895652173913, 1.1673913043478, 0.22727272727273
69032, 1.895652173913, 1.1413043478261, 0.20454545454545
69033, 1.8739130434783, 1.1413043478261, 0.18181818181818
69034, 1.895652173913, 1.1673913043478, 0.18181818181818
69035, 1.895652173913, 1.1413043478261, 0.15909090909091
69036, 1.8739130434783, 1.1413043478261, 0.13636363636364
69037, 1.895652173913, 1.1673913043478, 0.13636363636364
69038, 1.895652173913, 1.1413043478261, 0.11363636363636
69039, 1.8739130434783, 1.1413043478261, 0.090909090909091
69040, 1.895652173913, 1.1673913043478, 0.090909090909091
69041, 1.895652173913, 1.1413043478261, 0.068181818181818
69042, 1.8739130434783, 1.1413043478261, 0.045454545454545
69043, 1.895652173913, 1.1673913043478, 0.045454545454545
69044, 1.895652173913, 1.1413043478261, 0.022727272727273
69045, 1.9391304347826, 1.1413043478261, 0.47727272727273
69046, 1.9173913043478, 1.1413043478261, 0.45454545454545
69047, 1.9391304347826, 1.1673913043478, 0.45454545454545
69048, 1.9391304347826, 1.1413043478261, 0.43181818181818
69049, 1.9173913043478, 1.1413043478261, 0.40909090909091
69050, 1.9391304347826, 1.1673913043478, 0.40909090909091
69051, 1.9391304347826, 1.1413043478261, 0.38636363636364
69052, 1.9173913043478, 1.1413043478261, 0.36363636363636
69053, 1.9391304347826, 1.1673913043478, 0.36363636363636
69054, 1.9391304347826, 1.1413043478261, 0.34090909090909
69055, 1.9173913043478, 1.1413043478261, 0.31818181818182
69056, 1.9391304347826, 1.1673913043478, 0.31818181818182
69057, 1.9391304347826, 1.1413043478261, 0.29545454545455
69058, 1.9173913043478, 1.1413043478261, 0.27272727272727
69059, 1.9391304347826, 1.1673913043478, 0.27272727272727
69060, 1.9391304347826, 1.1413043478261, 0.25
69061, 1.9173913043478, 1.1413043478261, 0.22727272727273
69062, 1.9391304347826, 1.1673913043478, 0.22727272727273
69063, 1.9391304347826, 1.1413043478261, 0.20454545454545
69064, 1.9173913043478, 1.1413043478261, 0.18181818181818
69065, 1.9391304347826, 1.1673913043478, 0.18181818181818
69066, 1.9391304347826, 1.1413043478261, 0.15909090909091
69067, 1.9173913043478, 1.1413043478261, 0.13636363636364
69068, 1.9391304347826, 1.1673913043478, 0.13636363636364
69069, 1.9391304347826, 1.1413043478261, 0.11363636363636
69070, 1.9173913043478, 1.1413043478261, 0.090909090909091
69071, 1.9391304347826, 1.1673913043478, 0.090909090909091
69072, 1.9391304347826, 1.1413043478261, 0.068181818181818
69073, 1.9173913043478, 1.1413043478261, 0.045454545454545
69074, 1.9391304347826, 1.1673913043478, 0.045454545454545
69075, 1.9391304347826, 1.1413043478261, 0.022727272727273
69076, 1.9826086956522, 1.1413043478261, 0.47727272727273
69077, 1.9608695652174, 1.1413043478261, 0.45454545454545
69078, 1.9826086956522, 1.1673913043478, 0.45454545454545
69079, 1.9826086956522, 1.1413043478261, 0.43181818181818
69080, 1.9608695652174, 1.1413043478261, 0.40909090909091
69081, 1.9826086956522, 1.1673913043478, 0.40909090909091
69082, 1.9826086956522, 1.1413043478261, 0.38636363636364
69083, 1.9608695652174, 1.1413043478261, 0.36363636363636
69084, 1.9826086956522, 1.1673913043478, 0.36363636363636
69085, 1.9826086956522, 1.1413043478261, 0.34090909090909
69086, 1.9608695652174, 1.1413043478261, 0.31818181818182
69087, 1.9826086956522, 1.1673913043478, 0.31818181818182
69088, 1.9826086956522, 1.1413043478261, 0.29545454545455
69089, 1.9608695652174, 1.1413043478261, 0.27272727272727
69090, 1.9826086956522, 1.1673913043478, 0.27272727272727
69091, 1.9826086956522, 1.1413043478261, 0.25
69092, 1.9608695652174, 1.1413043478261, 0.22727272727273
69093, 1.9826086956522, 1.1673913043478, 0.22727272727273
69094, 1.9826086956522, 1.1413043478261, 0.20454545454545
69095, 1.9608695652174, 1.1413043478261, 0.18181818181818
69096, 1.9826086956522, 1.1673913043478, 0.18181818181818
69097, 1.9826086956522, 1.1413043478261, 0.15909090909091
69098, 1.9608695652174, 1.1413043478261, 0.13636363636364
69099, 1.9826086956522, 1.1673913043478, 0.13636363636364
69100, 1.9826086956522, 1.1413043478261, 0.11363636363636
69101, 1.9608695652174, 1.1413043478261, 0.090909090909091
69102, 1.9826086956522, 1.1673913043478, 0.090909090909091
69103, 1.9826086956522, 1.1413043478261, 0.068181818181818
69104, 1.9608695652174, 1.1413043478261, 0.045454545454545
69105, 1.9826086956522, 1.1673913043478, 0.045454545454545
69106, 1.9826086956522, 1.1413043478261, 0.022727272727273
69107, 2.0260869565217, 1.1413043478261, 0.47727272727273
69108, 2.004347826087, 1.1413043478261, 0.45454545454545
69109, 2.0260869565217, 1.1673913043478, 0.45454545454545
69110, 2.0260869565217, 1.1413043478261, 0.43181818181818
69111, 2.004347826087, 1.1413043478261, 0.40909090909091
69112, 2.0260869565217, 1.1673913043478, 0.40909090909091
69113, 2.0260869565217, 1.1413043478261, 0.38636363636364
69114, 2.004347826087, 1.1413043478261, 0.36363636363636
69115, 2.0260869565217, 1.1673913043478, 0.36363636363636
69116, 2.0260869565217, 1.1413043478261, 0.34090909090909
69117, 2.004347826087, 1.1413043478261, 0.31818181818182
69118, 2.0260869565217, 1.1673913043478, 0.31818181818182
69119, 2.0260869565217, 1.1413043478261, 0.29545454545455
69120, 2.004347826087, 1.1413043478261, 0.27272727272727
69121, 2.0260869565217, 1.1673913043478, 0.27272727272727
69122, 2.0260869565217, 1.1413043478261, 0.25
69123, 2.004347826087, 1.1413043478261, 0.22727272727273
69124, 2.0260869565217, 1.1673913043478, 0.22727272727273
69125, 2.0260869565217, 1.1413043478261, 0.20454545454545
69126, 2.004347826087, 1.1413043478261, 0.18181818181818
69127, 2.0260869565217, 1.1673913043478, 0.18181818181818
69128, 2.0260869565217, 1.1413043478261, 0.15909090909091
69129, 2.004347826087, 1.1413043478261, 0.13636363636364
69130, 2.0260869565217, 1.1673913043478, 0.13636363636364
69131, 2.0260869565217, 1.1413043478261, 0.11363636363636
69132, 2.004347826087, 1.1413043478261, 0.090909090909091
69133, 2.0260869565217, 1.1673913043478, 0.090909090909091
69134, 2.0260869565217, 1.1413043478261, 0.068181818181818
69135, 2.004347826087, 1.1413043478261, 0.045454545454545
69136, 2.0260869565217, 1.1673913043478, 0.045454545454545
69137, 2.0260869565217, 1.1413043478261, 0.022727272727273
69138, 2.0695652173913, 1.1413043478261, 0.47727272727273
69139, 2.0478260869565, 1.1413043478261, 0.45454545454545
69140, 2.0695652173913, 1.1673913043478, 0.45454545454545
69141, 2.0695652173913, 1.1413043478261, 0.43181818181818
69142, 2.0478260869565, 1.1413043478261, 0.40909090909091
69143, 2.0695652173913, 1.1673913043478, 0.40909090909091
69144, 2.0695652173913, 1.1413043478261, 0.38636363636364
69145, 2.0478260869565, 1.1413043478261, 0.36363636363636
69146, 2.0695652173913, 1.1673913043478, 0.36363636363636
69147, 2.0695652173913, 1.1413043478261, 0.34090909090909
69148, 2.0478260869565, 1.1413043478261, 0.31818181818182
69149, 2.0695652173913, 1.1673913043478, 0.31818181818182
69150, 2.0695652173913, 1.1413043478261, 0.29545454545455
69151, 2.0478260869565, 1.1413043478261, 0.27272727272727
69152, 2.0695652173913, 1.1673913043478, 0.27272727272727
69153, 2.0695652173913, 1.1413043478261, 0.25
69154, 2.0478260869565, 1.1413043478261, 0.22727272727273
69155, 2.0695652173913, 1.1673913043478, 0.22727272727273
69156, 2.0695652173913, 1.1413043478261, 0.20454545454545
69157, 2.0478260869565, 1.1413043478261, 0.18181818181818
69158, 2.0695652173913, 1.1673913043478, 0.18181818181818
69159, 2.0695652173913, 1.1413043478261, 0.15909090909091
69160, 2.0478260869565, 1.1413043478261, 0.13636363636364
69161, 2.0695652173913, 1.1673913043478, 0.13636363636364
69162, 2.0695652173913, 1.1413043478261, 0.11363636363636
69163, 2.0478260869565, 1.1413043478261, 0.090909090909091
69164, 2.0695652173913, 1.1673913043478, 0.090909090909091
69165, 2.0695652173913, 1.1413043478261, 0.068181818181818
69166, 2.0478260869565, 1.1413043478261, 0.045454545454545
69167, 2.0695652173913, 1.1673913043478, 0.045454545454545
69168, 2.0695652173913, 1.1413043478261, 0.022727272727273
69169, 2.1130434782609, 1.1413043478261, 0.47727272727273
69170, 2.0913043478261, 1.1413043478261, 0.45454545454545
69171, 2.1130434782609, 1.1673913043478, 0.45454545454545
69172, 2.1130434782609, 1.1413043478261, 0.43181818181818
69173, 2.0913043478261, 1.1413043478261, 0.40909090909091
69174, 2.1130434782609, 1.1673913043478, 0.40909090909091
69175, 2.1130434782609, 1.1413043478261, 0.38636363636364
69176, 2.0913043478261, 1.1413043478261, 0.36363636363636
69177, 2.1130434782609, 1.1673913043478, 0.36363636363636
69178, 2.1130434782609, 1.1413043478261, 0.34090909090909
69179, 2.0913043478261, 1.1413043478261, 0.31818181818182
69180, 2.1130434782609, 1.1673913043478, 0.31818181818182
69181, 2.1130434782609, 1.1413043478261, 0.29545454545455
69182, 2.0913043478261, 1.1413043478261, 0.27272727272727
69183, 2.1130434782609, 1.1673913043478, 0.27272727272727
69184, 2.1130434782609, 1.1413043478261, 0.25
69185, 2.0913043478261, 1.1413043478261, 0.22727272727273
69186, 2.1130434782609, 1.1673913043478, 0.22727272727273
69187, 2.1130434782609, 1.1413043478261, 0.20454545454545
69188, 2.0913043478261, 1.1413043478261, 0.18181818181818
69189, 2.1130434782609, 1.1673913043478, 0.18181818181818
69190, 2.1130434782609, 1.1413043478261, 0.15909090909091
69191, 2.0913043478261, 1.1413043478261, 0.13636363636364
69192, 2.1130434782609, 1.1673913043478, 0.13636363636364
69193, 2.1130434782609, 1.1413043478261, 0.11363636363636
69194, 2.0913043478261, 1.1413043478261, 0.090909090909091
69195, 2.1130434782609, 1.1673913043478, 0.090909090909091
69196, 2.1130434782609, 1.1413043478261, 0.068181818181818
69197, 2.0913043478261, 1.1413043478261, 0.045454545454545
69198, 2.1130434782609, 1.1673913043478, 0.045454545454545
69199, 2.1130434782609, 1.1413043478261, 0.022727272727273
69200, 2.1565217391304, 1.1413043478261, 0.47727272727273
69201, 2.1347826086957, 1.1413043478261, 0.45454545454545
69202, 2.1565217391304, 1.1673913043478, 0.45454545454545
69203, 2.1565217391304, 1.1413043478261, 0.43181818181818
69204, 2.1347826086957, 1.1413043478261, 0.40909090909091
69205, 2.1565217391304, 1.1673913043478, 0.40909090909091
69206, 2.1565217391304, 1.1413043478261, 0.38636363636364
69207, 2.1347826086957, 1.1413043478261, 0.36363636363636
69208, 2.1565217391304, 1.1673913043478, 0.36363636363636
69209, 2.1565217391304, 1.1413043478261, 0.34090909090909
69210, 2.1347826086957, 1.1413043478261, 0.31818181818182
69211, 2.1565217391304, 1.1673913043478, 0.31818181818182
69212, 2.1565217391304, 1.1413043478261, 0.29545454545455
69213, 2.1347826086957, 1.1413043478261, 0.27272727272727
69214, 2.1565217391304, 1.1673913043478, 0.27272727272727
69215, 2.1565217391304, 1.1413043478261, 0.25
69216, 2.1347826086957, 1.1413043478261, 0.22727272727273
69217, 2.1565217391304, 1.1673913043478, 0.22727272727273
69218, 2.1565217391304, 1.1413043478261, 0.20454545454545
69219, 2.1347826086957, 1.1413043478261, 0.18181818181818
69220, 2.1565217391304, 1.1673913043478, 0.18181818181818
69221, 2.1565217391304, 1.1413043478261, 0.15909090909091
69222, 2.1347826086957, 1.1413043478261, 0.13636363636364
69223, 2.1565217391304, 1.1673913043478, 0.13636363636364
69224, 2.1565217391304, 1.1413043478261, 0.11363636363636
69225, 2.1347826086957, 1.1413043478261, 0.090909090909091
69226, 2.1565217391304, 1.1673913043478, 0.090909090909091
69227, 2.1565217391304, 1.1413043478261, 0.068181818181818
69228, 2.1347826086957, 1.1413043478261, 0.045454545454545
69229, 2.1565217391304, 1.1673913043478, 0.045454545454545
69230, 2.1565217391304, 1.1413043478261, 0.022727272727273
69231, 2.1782608695652, 1.1413043478261, 0.45454545454545
69232, 2.1782608695652, 1.1413043478261, 0.40909090909091
69233, 2.1782608695652, 1.1413043478261, 0.36363636363636
69234, 2.1782608695652, 1.1413043478261, 0.31818181818182
69235, 2.1782608695652, 1.1413043478261, 0.27272727272727
69236, 2.1782608695652, 1.1413043478261, 0.22727272727273
69237, 2.1782608695652, 1.1413043478261, 0.18181818181818
69238, 2.1782608695652, 1.1413043478261, 0.13636363636364
69239, 2.1782608695652, 1.1413043478261, 0.090909090909091
69240, 2.1782608695652, 1.1413043478261, 0.045454545454545
69241, 1.2434782608696, 1.0891304347826, 0.47727272727273
69242, 1.2217391304348, 1.0891304347826, 0.45454545454545
69243, 1.2434782608696, 1.1152173913043, 0.45454545454545
69244, 1.2434782608696, 1.0891304347826, 0.43181818181818
69245, 1.2217391304348, 1.0891304347826, 0.40909090909091
69246, 1.2434782608696, 1.1152173913043, 0.40909090909091
69247, 1.2434782608696, 1.0891304347826, 0.38636363636364
69248, 1.2217391304348, 1.0891304347826, 0.36363636363636
69249, 1.2434782608696, 1.1152173913043, 0.36363636363636
69250, 1.2434782608696, 1.0891304347826, 0.34090909090909
69251, 1.2217391304348, 1.0891304347826, 0.31818181818182
69252, 1.2434782608696, 1.1152173913043, 0.31818181818182
69253, 1.2434782608696, 1.0891304347826, 0.29545454545455
69254, 1.2217391304348, 1.0891304347826, 0.27272727272727
69255, 1.2434782608696, 1.1152173913043, 0.27272727272727
69256, 1.2434782608696, 1.0891304347826, 0.25
69257, 1.2217391304348, 1.0891304347826, 0.22727272727273
69258, 1.2434782608696, 1.1152173913043, 0.22727272727273
69259, 1.2434782608696, 1.0891304347826, 0.20454545454545
69260, 1.2217391304348, 1.0891304347826, 0.18181818181818
69261, 1.2434782608696, 1.1152173913043, 0.18181818181818
69262, 1.2434782608696, 1.0891304347826, 0.15909090909091
69263, 1.2217391304348, 1.0891304347826, 0.13636363636364
69264, 1.2434782608696, 1.1152173913043, 0.13636363636364
69265, 1.2434782608696, 1.0891304347826, 0.11363636363636
69266, 1.2217391304348, 1.0891304347826, 0.090909090909091
69267, 1.2434782608696, 1.1152173913043, 0.090909090909091
69268, 1.2434782608696, 1.0891304347826, 0.068181818181818
69269, 1.2217391304348, 1.0891304347826, 0.045454545454545
69270, 1.2434782608696, 1.1152173913043, 0.045454545454545
69271, 1.2434782608696, 1.0891304347826, 0.022727272727273
69272, 1.2869565217391, 1.0891304347826, 0.47727272727273
69273, 1.2652173913043, 1.0891304347826, 0.45454545454545
69274, 1.2869565217391, 1.1152173913043, 0.45454545454545
69275, 1.2869565217391, 1.0891304347826, 0.43181818181818
69276, 1.2652173913043, 1.0891304347826, 0.40909090909091
69277, 1.2869565217391, 1.1152173913043, 0.40909090909091
69278, 1.2869565217391, 1.0891304347826, 0.38636363636364
69279, 1.2652173913043, 1.0891304347826, 0.36363636363636
69280, 1.2869565217391, 1.1152173913043, 0.36363636363636
69281, 1.2869565217391, 1.0891304347826, 0.34090909090909
69282, 1.2652173913043, 1.0891304347826, 0.31818181818182
69283, 1.2869565217391, 1.1152173913043, 0.31818181818182
69284, 1.2869565217391, 1.0891304347826, 0.29545454545455
69285, 1.2652173913043, 1.0891304347826, 0.27272727272727
69286, 1.2869565217391, 1.1152173913043, 0.27272727272727
69287, 1.2869565217391, 1.0891304347826, 0.25
69288, 1.2652173913043, 1.0891304347826, 0.22727272727273
69289, 1.2869565217391, 1.1152173913043, 0.22727272727273
69290, 1.2869565217391, 1.0891304347826, 0.20454545454545
69291, 1.2652173913043, 1.0891304347826, 0.18181818181818
69292, 1.2869565217391, 1.1152173913043, 0.18181818181818
69293, 1.2869565217391, 1.0891304347826, 0.15909090909091
