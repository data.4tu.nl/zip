81331, 1.6565217391304, 0.20217391304348, 0.22727272727273
81332, 1.6782608695652, 0.22826086956522, 0.22727272727273
81333, 1.6782608695652, 0.20217391304348, 0.20454545454545
81334, 1.6565217391304, 0.20217391304348, 0.18181818181818
81335, 1.6782608695652, 0.22826086956522, 0.18181818181818
81336, 1.6782608695652, 0.20217391304348, 0.15909090909091
81337, 1.6565217391304, 0.20217391304348, 0.13636363636364
81338, 1.6782608695652, 0.22826086956522, 0.13636363636364
81339, 1.6782608695652, 0.20217391304348, 0.11363636363636
81340, 1.6565217391304, 0.20217391304348, 0.090909090909091
81341, 1.6782608695652, 0.22826086956522, 0.090909090909091
81342, 1.6782608695652, 0.20217391304348, 0.068181818181818
81343, 1.6565217391304, 0.20217391304348, 0.045454545454545
81344, 1.6782608695652, 0.22826086956522, 0.045454545454545
81345, 1.6782608695652, 0.20217391304348, 0.022727272727273
81346, 1.7217391304348, 0.20217391304348, 0.47727272727273
81347, 1.7, 0.20217391304348, 0.45454545454545
81348, 1.7217391304348, 0.22826086956522, 0.45454545454545
81349, 1.7217391304348, 0.20217391304348, 0.43181818181818
81350, 1.7, 0.20217391304348, 0.40909090909091
81351, 1.7217391304348, 0.22826086956522, 0.40909090909091
81352, 1.7217391304348, 0.20217391304348, 0.38636363636364
81353, 1.7, 0.20217391304348, 0.36363636363636
81354, 1.7217391304348, 0.22826086956522, 0.36363636363636
81355, 1.7217391304348, 0.20217391304348, 0.34090909090909
81356, 1.7, 0.20217391304348, 0.31818181818182
81357, 1.7217391304348, 0.22826086956522, 0.31818181818182
81358, 1.7217391304348, 0.20217391304348, 0.29545454545455
81359, 1.7, 0.20217391304348, 0.27272727272727
81360, 1.7217391304348, 0.22826086956522, 0.27272727272727
81361, 1.7217391304348, 0.20217391304348, 0.25
81362, 1.7, 0.20217391304348, 0.22727272727273
81363, 1.7217391304348, 0.22826086956522, 0.22727272727273
81364, 1.7217391304348, 0.20217391304348, 0.20454545454545
81365, 1.7, 0.20217391304348, 0.18181818181818
81366, 1.7217391304348, 0.22826086956522, 0.18181818181818
81367, 1.7217391304348, 0.20217391304348, 0.15909090909091
81368, 1.7, 0.20217391304348, 0.13636363636364
81369, 1.7217391304348, 0.22826086956522, 0.13636363636364
81370, 1.7217391304348, 0.20217391304348, 0.11363636363636
81371, 1.7, 0.20217391304348, 0.090909090909091
81372, 1.7217391304348, 0.22826086956522, 0.090909090909091
81373, 1.7217391304348, 0.20217391304348, 0.068181818181818
81374, 1.7, 0.20217391304348, 0.045454545454545
81375, 1.7217391304348, 0.22826086956522, 0.045454545454545
81376, 1.7217391304348, 0.20217391304348, 0.022727272727273
81377, 1.7652173913043, 0.20217391304348, 0.47727272727273
81378, 1.7434782608696, 0.20217391304348, 0.45454545454545
81379, 1.7652173913043, 0.22826086956522, 0.45454545454545
81380, 1.7652173913043, 0.20217391304348, 0.43181818181818
81381, 1.7434782608696, 0.20217391304348, 0.40909090909091
81382, 1.7652173913043, 0.22826086956522, 0.40909090909091
81383, 1.7652173913043, 0.20217391304348, 0.38636363636364
81384, 1.7434782608696, 0.20217391304348, 0.36363636363636
81385, 1.7652173913043, 0.22826086956522, 0.36363636363636
81386, 1.7652173913043, 0.20217391304348, 0.34090909090909
81387, 1.7434782608696, 0.20217391304348, 0.31818181818182
81388, 1.7652173913043, 0.22826086956522, 0.31818181818182
81389, 1.7652173913043, 0.20217391304348, 0.29545454545455
81390, 1.7434782608696, 0.20217391304348, 0.27272727272727
81391, 1.7652173913043, 0.22826086956522, 0.27272727272727
81392, 1.7652173913043, 0.20217391304348, 0.25
81393, 1.7434782608696, 0.20217391304348, 0.22727272727273
81394, 1.7652173913043, 0.22826086956522, 0.22727272727273
81395, 1.7652173913043, 0.20217391304348, 0.20454545454545
81396, 1.7434782608696, 0.20217391304348, 0.18181818181818
81397, 1.7652173913043, 0.22826086956522, 0.18181818181818
81398, 1.7652173913043, 0.20217391304348, 0.15909090909091
81399, 1.7434782608696, 0.20217391304348, 0.13636363636364
81400, 1.7652173913043, 0.22826086956522, 0.13636363636364
81401, 1.7652173913043, 0.20217391304348, 0.11363636363636
81402, 1.7434782608696, 0.20217391304348, 0.090909090909091
81403, 1.7652173913043, 0.22826086956522, 0.090909090909091
81404, 1.7652173913043, 0.20217391304348, 0.068181818181818
81405, 1.7434782608696, 0.20217391304348, 0.045454545454545
81406, 1.7652173913043, 0.22826086956522, 0.045454545454545
81407, 1.7652173913043, 0.20217391304348, 0.022727272727273
81408, 1.8086956521739, 0.20217391304348, 0.47727272727273
81409, 1.7869565217391, 0.20217391304348, 0.45454545454545
81410, 1.8086956521739, 0.22826086956522, 0.45454545454545
81411, 1.8086956521739, 0.20217391304348, 0.43181818181818
81412, 1.7869565217391, 0.20217391304348, 0.40909090909091
81413, 1.8086956521739, 0.22826086956522, 0.40909090909091
81414, 1.8086956521739, 0.20217391304348, 0.38636363636364
81415, 1.7869565217391, 0.20217391304348, 0.36363636363636
81416, 1.8086956521739, 0.22826086956522, 0.36363636363636
81417, 1.8086956521739, 0.20217391304348, 0.34090909090909
81418, 1.7869565217391, 0.20217391304348, 0.31818181818182
81419, 1.8086956521739, 0.22826086956522, 0.31818181818182
81420, 1.8086956521739, 0.20217391304348, 0.29545454545455
81421, 1.7869565217391, 0.20217391304348, 0.27272727272727
81422, 1.8086956521739, 0.22826086956522, 0.27272727272727
81423, 1.8086956521739, 0.20217391304348, 0.25
81424, 1.7869565217391, 0.20217391304348, 0.22727272727273
81425, 1.8086956521739, 0.22826086956522, 0.22727272727273
81426, 1.8086956521739, 0.20217391304348, 0.20454545454545
81427, 1.7869565217391, 0.20217391304348, 0.18181818181818
81428, 1.8086956521739, 0.22826086956522, 0.18181818181818
81429, 1.8086956521739, 0.20217391304348, 0.15909090909091
81430, 1.7869565217391, 0.20217391304348, 0.13636363636364
81431, 1.8086956521739, 0.22826086956522, 0.13636363636364
81432, 1.8086956521739, 0.20217391304348, 0.11363636363636
81433, 1.7869565217391, 0.20217391304348, 0.090909090909091
81434, 1.8086956521739, 0.22826086956522, 0.090909090909091
81435, 1.8086956521739, 0.20217391304348, 0.068181818181818
81436, 1.7869565217391, 0.20217391304348, 0.045454545454545
81437, 1.8086956521739, 0.22826086956522, 0.045454545454545
81438, 1.8086956521739, 0.20217391304348, 0.022727272727273
81439, 1.8521739130435, 0.20217391304348, 0.47727272727273
81440, 1.8304347826087, 0.20217391304348, 0.45454545454545
81441, 1.8521739130435, 0.22826086956522, 0.45454545454545
81442, 1.8521739130435, 0.20217391304348, 0.43181818181818
81443, 1.8304347826087, 0.20217391304348, 0.40909090909091
81444, 1.8521739130435, 0.22826086956522, 0.40909090909091
81445, 1.8521739130435, 0.20217391304348, 0.38636363636364
81446, 1.8304347826087, 0.20217391304348, 0.36363636363636
81447, 1.8521739130435, 0.22826086956522, 0.36363636363636
81448, 1.8521739130435, 0.20217391304348, 0.34090909090909
81449, 1.8304347826087, 0.20217391304348, 0.31818181818182
81450, 1.8521739130435, 0.22826086956522, 0.31818181818182
81451, 1.8521739130435, 0.20217391304348, 0.29545454545455
81452, 1.8304347826087, 0.20217391304348, 0.27272727272727
81453, 1.8521739130435, 0.22826086956522, 0.27272727272727
81454, 1.8521739130435, 0.20217391304348, 0.25
81455, 1.8304347826087, 0.20217391304348, 0.22727272727273
81456, 1.8521739130435, 0.22826086956522, 0.22727272727273
81457, 1.8521739130435, 0.20217391304348, 0.20454545454545
81458, 1.8304347826087, 0.20217391304348, 0.18181818181818
81459, 1.8521739130435, 0.22826086956522, 0.18181818181818
81460, 1.8521739130435, 0.20217391304348, 0.15909090909091
81461, 1.8304347826087, 0.20217391304348, 0.13636363636364
81462, 1.8521739130435, 0.22826086956522, 0.13636363636364
81463, 1.8521739130435, 0.20217391304348, 0.11363636363636
81464, 1.8304347826087, 0.20217391304348, 0.090909090909091
81465, 1.8521739130435, 0.22826086956522, 0.090909090909091
81466, 1.8521739130435, 0.20217391304348, 0.068181818181818
81467, 1.8304347826087, 0.20217391304348, 0.045454545454545
81468, 1.8521739130435, 0.22826086956522, 0.045454545454545
81469, 1.8521739130435, 0.20217391304348, 0.022727272727273
81470, 1.895652173913, 0.20217391304348, 0.47727272727273
81471, 1.8739130434783, 0.20217391304348, 0.45454545454545
81472, 1.895652173913, 0.22826086956522, 0.45454545454545
81473, 1.895652173913, 0.20217391304348, 0.43181818181818
81474, 1.8739130434783, 0.20217391304348, 0.40909090909091
81475, 1.895652173913, 0.22826086956522, 0.40909090909091
81476, 1.895652173913, 0.20217391304348, 0.38636363636364
81477, 1.8739130434783, 0.20217391304348, 0.36363636363636
81478, 1.895652173913, 0.22826086956522, 0.36363636363636
81479, 1.895652173913, 0.20217391304348, 0.34090909090909
81480, 1.8739130434783, 0.20217391304348, 0.31818181818182
81481, 1.895652173913, 0.22826086956522, 0.31818181818182
81482, 1.895652173913, 0.20217391304348, 0.29545454545455
81483, 1.8739130434783, 0.20217391304348, 0.27272727272727
81484, 1.895652173913, 0.22826086956522, 0.27272727272727
81485, 1.895652173913, 0.20217391304348, 0.25
81486, 1.8739130434783, 0.20217391304348, 0.22727272727273
81487, 1.895652173913, 0.22826086956522, 0.22727272727273
81488, 1.895652173913, 0.20217391304348, 0.20454545454545
81489, 1.8739130434783, 0.20217391304348, 0.18181818181818
81490, 1.895652173913, 0.22826086956522, 0.18181818181818
81491, 1.895652173913, 0.20217391304348, 0.15909090909091
81492, 1.8739130434783, 0.20217391304348, 0.13636363636364
81493, 1.895652173913, 0.22826086956522, 0.13636363636364
81494, 1.895652173913, 0.20217391304348, 0.11363636363636
81495, 1.8739130434783, 0.20217391304348, 0.090909090909091
81496, 1.895652173913, 0.22826086956522, 0.090909090909091
81497, 1.895652173913, 0.20217391304348, 0.068181818181818
81498, 1.8739130434783, 0.20217391304348, 0.045454545454545
81499, 1.895652173913, 0.22826086956522, 0.045454545454545
81500, 1.895652173913, 0.20217391304348, 0.022727272727273
81501, 1.9391304347826, 0.20217391304348, 0.47727272727273
81502, 1.9173913043478, 0.20217391304348, 0.45454545454545
81503, 1.9391304347826, 0.22826086956522, 0.45454545454545
81504, 1.9391304347826, 0.20217391304348, 0.43181818181818
81505, 1.9173913043478, 0.20217391304348, 0.40909090909091
81506, 1.9391304347826, 0.22826086956522, 0.40909090909091
81507, 1.9391304347826, 0.20217391304348, 0.38636363636364
81508, 1.9173913043478, 0.20217391304348, 0.36363636363636
81509, 1.9391304347826, 0.22826086956522, 0.36363636363636
81510, 1.9391304347826, 0.20217391304348, 0.34090909090909
81511, 1.9173913043478, 0.20217391304348, 0.31818181818182
81512, 1.9391304347826, 0.22826086956522, 0.31818181818182
81513, 1.9391304347826, 0.20217391304348, 0.29545454545455
81514, 1.9173913043478, 0.20217391304348, 0.27272727272727
81515, 1.9391304347826, 0.22826086956522, 0.27272727272727
81516, 1.9391304347826, 0.20217391304348, 0.25
81517, 1.9173913043478, 0.20217391304348, 0.22727272727273
81518, 1.9391304347826, 0.22826086956522, 0.22727272727273
81519, 1.9391304347826, 0.20217391304348, 0.20454545454545
81520, 1.9173913043478, 0.20217391304348, 0.18181818181818
81521, 1.9391304347826, 0.22826086956522, 0.18181818181818
81522, 1.9391304347826, 0.20217391304348, 0.15909090909091
81523, 1.9173913043478, 0.20217391304348, 0.13636363636364
81524, 1.9391304347826, 0.22826086956522, 0.13636363636364
81525, 1.9391304347826, 0.20217391304348, 0.11363636363636
81526, 1.9173913043478, 0.20217391304348, 0.090909090909091
81527, 1.9391304347826, 0.22826086956522, 0.090909090909091
81528, 1.9391304347826, 0.20217391304348, 0.068181818181818
81529, 1.9173913043478, 0.20217391304348, 0.045454545454545
81530, 1.9391304347826, 0.22826086956522, 0.045454545454545
81531, 1.9391304347826, 0.20217391304348, 0.022727272727273
81532, 1.9826086956522, 0.20217391304348, 0.47727272727273
81533, 1.9608695652174, 0.20217391304348, 0.45454545454545
81534, 1.9826086956522, 0.22826086956522, 0.45454545454545
81535, 1.9826086956522, 0.20217391304348, 0.43181818181818
81536, 1.9608695652174, 0.20217391304348, 0.40909090909091
81537, 1.9826086956522, 0.22826086956522, 0.40909090909091
81538, 1.9826086956522, 0.20217391304348, 0.38636363636364
81539, 1.9608695652174, 0.20217391304348, 0.36363636363636
81540, 1.9826086956522, 0.22826086956522, 0.36363636363636
81541, 1.9826086956522, 0.20217391304348, 0.34090909090909
81542, 1.9608695652174, 0.20217391304348, 0.31818181818182
81543, 1.9826086956522, 0.22826086956522, 0.31818181818182
81544, 1.9826086956522, 0.20217391304348, 0.29545454545455
81545, 1.9608695652174, 0.20217391304348, 0.27272727272727
81546, 1.9826086956522, 0.22826086956522, 0.27272727272727
81547, 1.9826086956522, 0.20217391304348, 0.25
81548, 1.9608695652174, 0.20217391304348, 0.22727272727273
81549, 1.9826086956522, 0.22826086956522, 0.22727272727273
81550, 1.9826086956522, 0.20217391304348, 0.20454545454545
81551, 1.9608695652174, 0.20217391304348, 0.18181818181818
81552, 1.9826086956522, 0.22826086956522, 0.18181818181818
81553, 1.9826086956522, 0.20217391304348, 0.15909090909091
81554, 1.9608695652174, 0.20217391304348, 0.13636363636364
81555, 1.9826086956522, 0.22826086956522, 0.13636363636364
81556, 1.9826086956522, 0.20217391304348, 0.11363636363636
81557, 1.9608695652174, 0.20217391304348, 0.090909090909091
81558, 1.9826086956522, 0.22826086956522, 0.090909090909091
81559, 1.9826086956522, 0.20217391304348, 0.068181818181818
81560, 1.9608695652174, 0.20217391304348, 0.045454545454545
81561, 1.9826086956522, 0.22826086956522, 0.045454545454545
81562, 1.9826086956522, 0.20217391304348, 0.022727272727273
81563, 2.0260869565217, 0.20217391304348, 0.47727272727273
81564, 2.004347826087, 0.20217391304348, 0.45454545454545
81565, 2.0260869565217, 0.22826086956522, 0.45454545454545
81566, 2.0260869565217, 0.20217391304348, 0.43181818181818
81567, 2.004347826087, 0.20217391304348, 0.40909090909091
81568, 2.0260869565217, 0.22826086956522, 0.40909090909091
81569, 2.0260869565217, 0.20217391304348, 0.38636363636364
81570, 2.004347826087, 0.20217391304348, 0.36363636363636
81571, 2.0260869565217, 0.22826086956522, 0.36363636363636
81572, 2.0260869565217, 0.20217391304348, 0.34090909090909
81573, 2.004347826087, 0.20217391304348, 0.31818181818182
81574, 2.0260869565217, 0.22826086956522, 0.31818181818182
81575, 2.0260869565217, 0.20217391304348, 0.29545454545455
81576, 2.004347826087, 0.20217391304348, 0.27272727272727
81577, 2.0260869565217, 0.22826086956522, 0.27272727272727
81578, 2.0260869565217, 0.20217391304348, 0.25
81579, 2.004347826087, 0.20217391304348, 0.22727272727273
81580, 2.0260869565217, 0.22826086956522, 0.22727272727273
81581, 2.0260869565217, 0.20217391304348, 0.20454545454545
81582, 2.004347826087, 0.20217391304348, 0.18181818181818
81583, 2.0260869565217, 0.22826086956522, 0.18181818181818
81584, 2.0260869565217, 0.20217391304348, 0.15909090909091
81585, 2.004347826087, 0.20217391304348, 0.13636363636364
81586, 2.0260869565217, 0.22826086956522, 0.13636363636364
81587, 2.0260869565217, 0.20217391304348, 0.11363636363636
81588, 2.004347826087, 0.20217391304348, 0.090909090909091
81589, 2.0260869565217, 0.22826086956522, 0.090909090909091
81590, 2.0260869565217, 0.20217391304348, 0.068181818181818
81591, 2.004347826087, 0.20217391304348, 0.045454545454545
81592, 2.0260869565217, 0.22826086956522, 0.045454545454545
81593, 2.0260869565217, 0.20217391304348, 0.022727272727273
81594, 2.0695652173913, 0.20217391304348, 0.47727272727273
81595, 2.0478260869565, 0.20217391304348, 0.45454545454545
81596, 2.0695652173913, 0.22826086956522, 0.45454545454545
81597, 2.0695652173913, 0.20217391304348, 0.43181818181818
81598, 2.0478260869565, 0.20217391304348, 0.40909090909091
81599, 2.0695652173913, 0.22826086956522, 0.40909090909091
81600, 2.0695652173913, 0.20217391304348, 0.38636363636364
81601, 2.0478260869565, 0.20217391304348, 0.36363636363636
81602, 2.0695652173913, 0.22826086956522, 0.36363636363636
81603, 2.0695652173913, 0.20217391304348, 0.34090909090909
81604, 2.0478260869565, 0.20217391304348, 0.31818181818182
81605, 2.0695652173913, 0.22826086956522, 0.31818181818182
81606, 2.0695652173913, 0.20217391304348, 0.29545454545455
81607, 2.0478260869565, 0.20217391304348, 0.27272727272727
81608, 2.0695652173913, 0.22826086956522, 0.27272727272727
81609, 2.0695652173913, 0.20217391304348, 0.25
81610, 2.0478260869565, 0.20217391304348, 0.22727272727273
81611, 2.0695652173913, 0.22826086956522, 0.22727272727273
81612, 2.0695652173913, 0.20217391304348, 0.20454545454545
81613, 2.0478260869565, 0.20217391304348, 0.18181818181818
81614, 2.0695652173913, 0.22826086956522, 0.18181818181818
81615, 2.0695652173913, 0.20217391304348, 0.15909090909091
81616, 2.0478260869565, 0.20217391304348, 0.13636363636364
81617, 2.0695652173913, 0.22826086956522, 0.13636363636364
81618, 2.0695652173913, 0.20217391304348, 0.11363636363636
81619, 2.0478260869565, 0.20217391304348, 0.090909090909091
81620, 2.0695652173913, 0.22826086956522, 0.090909090909091
81621, 2.0695652173913, 0.20217391304348, 0.068181818181818
81622, 2.0478260869565, 0.20217391304348, 0.045454545454545
81623, 2.0695652173913, 0.22826086956522, 0.045454545454545
81624, 2.0695652173913, 0.20217391304348, 0.022727272727273
81625, 2.1130434782609, 0.20217391304348, 0.47727272727273
81626, 2.0913043478261, 0.20217391304348, 0.45454545454545
81627, 2.1130434782609, 0.22826086956522, 0.45454545454545
81628, 2.1130434782609, 0.20217391304348, 0.43181818181818
81629, 2.0913043478261, 0.20217391304348, 0.40909090909091
81630, 2.1130434782609, 0.22826086956522, 0.40909090909091
81631, 2.1130434782609, 0.20217391304348, 0.38636363636364
81632, 2.0913043478261, 0.20217391304348, 0.36363636363636
81633, 2.1130434782609, 0.22826086956522, 0.36363636363636
81634, 2.1130434782609, 0.20217391304348, 0.34090909090909
81635, 2.0913043478261, 0.20217391304348, 0.31818181818182
81636, 2.1130434782609, 0.22826086956522, 0.31818181818182
81637, 2.1130434782609, 0.20217391304348, 0.29545454545455
81638, 2.0913043478261, 0.20217391304348, 0.27272727272727
81639, 2.1130434782609, 0.22826086956522, 0.27272727272727
81640, 2.1130434782609, 0.20217391304348, 0.25
81641, 2.0913043478261, 0.20217391304348, 0.22727272727273
81642, 2.1130434782609, 0.22826086956522, 0.22727272727273
81643, 2.1130434782609, 0.20217391304348, 0.20454545454545
81644, 2.0913043478261, 0.20217391304348, 0.18181818181818
81645, 2.1130434782609, 0.22826086956522, 0.18181818181818
81646, 2.1130434782609, 0.20217391304348, 0.15909090909091
81647, 2.0913043478261, 0.20217391304348, 0.13636363636364
81648, 2.1130434782609, 0.22826086956522, 0.13636363636364
81649, 2.1130434782609, 0.20217391304348, 0.11363636363636
81650, 2.0913043478261, 0.20217391304348, 0.090909090909091
81651, 2.1130434782609, 0.22826086956522, 0.090909090909091
81652, 2.1130434782609, 0.20217391304348, 0.068181818181818
81653, 2.0913043478261, 0.20217391304348, 0.045454545454545
81654, 2.1130434782609, 0.22826086956522, 0.045454545454545
81655, 2.1130434782609, 0.20217391304348, 0.022727272727273
81656, 2.1565217391304, 0.20217391304348, 0.47727272727273
81657, 2.1347826086957, 0.20217391304348, 0.45454545454545
81658, 2.1565217391304, 0.22826086956522, 0.45454545454545
81659, 2.1565217391304, 0.20217391304348, 0.43181818181818
81660, 2.1347826086957, 0.20217391304348, 0.40909090909091
81661, 2.1565217391304, 0.22826086956522, 0.40909090909091
81662, 2.1565217391304, 0.20217391304348, 0.38636363636364
81663, 2.1347826086957, 0.20217391304348, 0.36363636363636
81664, 2.1565217391304, 0.22826086956522, 0.36363636363636
81665, 2.1565217391304, 0.20217391304348, 0.34090909090909
81666, 2.1347826086957, 0.20217391304348, 0.31818181818182
81667, 2.1565217391304, 0.22826086956522, 0.31818181818182
81668, 2.1565217391304, 0.20217391304348, 0.29545454545455
81669, 2.1347826086957, 0.20217391304348, 0.27272727272727
81670, 2.1565217391304, 0.22826086956522, 0.27272727272727
81671, 2.1565217391304, 0.20217391304348, 0.25
81672, 2.1347826086957, 0.20217391304348, 0.22727272727273
81673, 2.1565217391304, 0.22826086956522, 0.22727272727273
81674, 2.1565217391304, 0.20217391304348, 0.20454545454545
81675, 2.1347826086957, 0.20217391304348, 0.18181818181818
81676, 2.1565217391304, 0.22826086956522, 0.18181818181818
81677, 2.1565217391304, 0.20217391304348, 0.15909090909091
81678, 2.1347826086957, 0.20217391304348, 0.13636363636364
81679, 2.1565217391304, 0.22826086956522, 0.13636363636364
81680, 2.1565217391304, 0.20217391304348, 0.11363636363636
81681, 2.1347826086957, 0.20217391304348, 0.090909090909091
81682, 2.1565217391304, 0.22826086956522, 0.090909090909091
81683, 2.1565217391304, 0.20217391304348, 0.068181818181818
81684, 2.1347826086957, 0.20217391304348, 0.045454545454545
81685, 2.1565217391304, 0.22826086956522, 0.045454545454545
81686, 2.1565217391304, 0.20217391304348, 0.022727272727273
81687, 2.1782608695652, 0.20217391304348, 0.45454545454545
81688, 2.1782608695652, 0.20217391304348, 0.40909090909091
81689, 2.1782608695652, 0.20217391304348, 0.36363636363636
81690, 2.1782608695652, 0.20217391304348, 0.31818181818182
81691, 2.1782608695652, 0.20217391304348, 0.27272727272727
81692, 2.1782608695652, 0.20217391304348, 0.22727272727273
81693, 2.1782608695652, 0.20217391304348, 0.18181818181818
81694, 2.1782608695652, 0.20217391304348, 0.13636363636364
81695, 2.1782608695652, 0.20217391304348, 0.090909090909091
81696, 2.1782608695652, 0.20217391304348, 0.045454545454545
81697, 1.2434782608696, 0.17608695652174, 0.45454545454545
81698, 1.2434782608696, 0.17608695652174, 0.40909090909091
81699, 1.2434782608696, 0.17608695652174, 0.36363636363636
81700, 1.2434782608696, 0.17608695652174, 0.31818181818182
81701, 1.2434782608696, 0.17608695652174, 0.27272727272727
81702, 1.2434782608696, 0.17608695652174, 0.22727272727273
81703, 1.2434782608696, 0.17608695652174, 0.18181818181818
81704, 1.2434782608696, 0.17608695652174, 0.13636363636364
81705, 1.2434782608696, 0.17608695652174, 0.090909090909091
81706, 1.2434782608696, 0.17608695652174, 0.045454545454545
81707, 1.2869565217391, 0.17608695652174, 0.45454545454545
81708, 1.2869565217391, 0.17608695652174, 0.40909090909091
81709, 1.2869565217391, 0.17608695652174, 0.36363636363636
81710, 1.2869565217391, 0.17608695652174, 0.31818181818182
81711, 1.2869565217391, 0.17608695652174, 0.27272727272727
81712, 1.2869565217391, 0.17608695652174, 0.22727272727273
81713, 1.2869565217391, 0.17608695652174, 0.18181818181818
81714, 1.2869565217391, 0.17608695652174, 0.13636363636364
81715, 1.2869565217391, 0.17608695652174, 0.090909090909091
81716, 1.2869565217391, 0.17608695652174, 0.045454545454545
81717, 1.3304347826087, 0.17608695652174, 0.45454545454545
81718, 1.3304347826087, 0.17608695652174, 0.40909090909091
81719, 1.3304347826087, 0.17608695652174, 0.36363636363636
81720, 1.3304347826087, 0.17608695652174, 0.31818181818182
81721, 1.3304347826087, 0.17608695652174, 0.27272727272727
81722, 1.3304347826087, 0.17608695652174, 0.22727272727273
81723, 1.3304347826087, 0.17608695652174, 0.18181818181818
81724, 1.3304347826087, 0.17608695652174, 0.13636363636364
81725, 1.3304347826087, 0.17608695652174, 0.090909090909091
81726, 1.3304347826087, 0.17608695652174, 0.045454545454545
81727, 1.3739130434783, 0.17608695652174, 0.45454545454545
81728, 1.3739130434783, 0.17608695652174, 0.40909090909091
81729, 1.3739130434783, 0.17608695652174, 0.36363636363636
81730, 1.3739130434783, 0.17608695652174, 0.31818181818182
81731, 1.3739130434783, 0.17608695652174, 0.27272727272727
81732, 1.3739130434783, 0.17608695652174, 0.22727272727273
81733, 1.3739130434783, 0.17608695652174, 0.18181818181818
81734, 1.3739130434783, 0.17608695652174, 0.13636363636364
81735, 1.3739130434783, 0.17608695652174, 0.090909090909091
81736, 1.3739130434783, 0.17608695652174, 0.045454545454545
81737, 1.4173913043478, 0.17608695652174, 0.45454545454545
81738, 1.4173913043478, 0.17608695652174, 0.40909090909091
81739, 1.4173913043478, 0.17608695652174, 0.36363636363636
81740, 1.4173913043478, 0.17608695652174, 0.31818181818182
81741, 1.4173913043478, 0.17608695652174, 0.27272727272727
81742, 1.4173913043478, 0.17608695652174, 0.22727272727273
81743, 1.4173913043478, 0.17608695652174, 0.18181818181818
81744, 1.4173913043478, 0.17608695652174, 0.13636363636364
81745, 1.4173913043478, 0.17608695652174, 0.090909090909091
81746, 1.4173913043478, 0.17608695652174, 0.045454545454545
81747, 1.4608695652174, 0.17608695652174, 0.45454545454545
81748, 1.4608695652174, 0.17608695652174, 0.40909090909091
81749, 1.4608695652174, 0.17608695652174, 0.36363636363636
81750, 1.4608695652174, 0.17608695652174, 0.31818181818182
81751, 1.4608695652174, 0.17608695652174, 0.27272727272727
81752, 1.4608695652174, 0.17608695652174, 0.22727272727273
81753, 1.4608695652174, 0.17608695652174, 0.18181818181818
81754, 1.4608695652174, 0.17608695652174, 0.13636363636364
81755, 1.4608695652174, 0.17608695652174, 0.090909090909091
81756, 1.4608695652174, 0.17608695652174, 0.045454545454545
81757, 1.504347826087, 0.17608695652174, 0.45454545454545
81758, 1.504347826087, 0.17608695652174, 0.40909090909091
81759, 1.504347826087, 0.17608695652174, 0.36363636363636
81760, 1.504347826087, 0.17608695652174, 0.31818181818182
81761, 1.504347826087, 0.17608695652174, 0.27272727272727
81762, 1.504347826087, 0.17608695652174, 0.22727272727273
81763, 1.504347826087, 0.17608695652174, 0.18181818181818
81764, 1.504347826087, 0.17608695652174, 0.13636363636364
81765, 1.504347826087, 0.17608695652174, 0.090909090909091
81766, 1.504347826087, 0.17608695652174, 0.045454545454545
81767, 1.5478260869565, 0.17608695652174, 0.45454545454545
81768, 1.5478260869565, 0.17608695652174, 0.40909090909091
81769, 1.5478260869565, 0.17608695652174, 0.36363636363636
81770, 1.5478260869565, 0.17608695652174, 0.31818181818182
81771, 1.5478260869565, 0.17608695652174, 0.27272727272727
81772, 1.5478260869565, 0.17608695652174, 0.22727272727273
81773, 1.5478260869565, 0.17608695652174, 0.18181818181818
81774, 1.5478260869565, 0.17608695652174, 0.13636363636364
81775, 1.5478260869565, 0.17608695652174, 0.090909090909091
81776, 1.5478260869565, 0.17608695652174, 0.045454545454545
81777, 1.5913043478261, 0.17608695652174, 0.45454545454545
81778, 1.5913043478261, 0.17608695652174, 0.40909090909091
81779, 1.5913043478261, 0.17608695652174, 0.36363636363636
81780, 1.5913043478261, 0.17608695652174, 0.31818181818182
81781, 1.5913043478261, 0.17608695652174, 0.27272727272727
81782, 1.5913043478261, 0.17608695652174, 0.22727272727273
81783, 1.5913043478261, 0.17608695652174, 0.18181818181818
81784, 1.5913043478261, 0.17608695652174, 0.13636363636364
81785, 1.5913043478261, 0.17608695652174, 0.090909090909091
81786, 1.5913043478261, 0.17608695652174, 0.045454545454545
81787, 1.6347826086957, 0.17608695652174, 0.45454545454545
81788, 1.6347826086957, 0.17608695652174, 0.40909090909091
81789, 1.6347826086957, 0.17608695652174, 0.36363636363636
81790, 1.6347826086957, 0.17608695652174, 0.31818181818182
81791, 1.6347826086957, 0.17608695652174, 0.27272727272727
81792, 1.6347826086957, 0.17608695652174, 0.22727272727273
81793, 1.6347826086957, 0.17608695652174, 0.18181818181818
81794, 1.6347826086957, 0.17608695652174, 0.13636363636364
81795, 1.6347826086957, 0.17608695652174, 0.090909090909091
81796, 1.6347826086957, 0.17608695652174, 0.045454545454545
81797, 1.6782608695652, 0.17608695652174, 0.45454545454545
81798, 1.6782608695652, 0.17608695652174, 0.40909090909091
81799, 1.6782608695652, 0.17608695652174, 0.36363636363636
81800, 1.6782608695652, 0.17608695652174, 0.31818181818182
81801, 1.6782608695652, 0.17608695652174, 0.27272727272727
81802, 1.6782608695652, 0.17608695652174, 0.22727272727273
81803, 1.6782608695652, 0.17608695652174, 0.18181818181818
81804, 1.6782608695652, 0.17608695652174, 0.13636363636364
81805, 1.6782608695652, 0.17608695652174, 0.090909090909091
81806, 1.6782608695652, 0.17608695652174, 0.045454545454545
81807, 1.7217391304348, 0.17608695652174, 0.45454545454545
81808, 1.7217391304348, 0.17608695652174, 0.40909090909091
81809, 1.7217391304348, 0.17608695652174, 0.36363636363636
81810, 1.7217391304348, 0.17608695652174, 0.31818181818182
81811, 1.7217391304348, 0.17608695652174, 0.27272727272727
81812, 1.7217391304348, 0.17608695652174, 0.22727272727273
81813, 1.7217391304348, 0.17608695652174, 0.18181818181818
81814, 1.7217391304348, 0.17608695652174, 0.13636363636364
81815, 1.7217391304348, 0.17608695652174, 0.090909090909091
81816, 1.7217391304348, 0.17608695652174, 0.045454545454545
81817, 1.7652173913043, 0.17608695652174, 0.45454545454545
81818, 1.7652173913043, 0.17608695652174, 0.40909090909091
81819, 1.7652173913043, 0.17608695652174, 0.36363636363636
81820, 1.7652173913043, 0.17608695652174, 0.31818181818182
81821, 1.7652173913043, 0.17608695652174, 0.27272727272727
81822, 1.7652173913043, 0.17608695652174, 0.22727272727273
81823, 1.7652173913043, 0.17608695652174, 0.18181818181818
81824, 1.7652173913043, 0.17608695652174, 0.13636363636364
81825, 1.7652173913043, 0.17608695652174, 0.090909090909091
81826, 1.7652173913043, 0.17608695652174, 0.045454545454545
81827, 1.8086956521739, 0.17608695652174, 0.45454545454545
81828, 1.8086956521739, 0.17608695652174, 0.40909090909091
81829, 1.8086956521739, 0.17608695652174, 0.36363636363636
81830, 1.8086956521739, 0.17608695652174, 0.31818181818182
81831, 1.8086956521739, 0.17608695652174, 0.27272727272727
81832, 1.8086956521739, 0.17608695652174, 0.22727272727273
81833, 1.8086956521739, 0.17608695652174, 0.18181818181818
81834, 1.8086956521739, 0.17608695652174, 0.13636363636364
81835, 1.8086956521739, 0.17608695652174, 0.090909090909091
81836, 1.8086956521739, 0.17608695652174, 0.045454545454545
81837, 1.8521739130435, 0.17608695652174, 0.45454545454545
81838, 1.8521739130435, 0.17608695652174, 0.40909090909091
81839, 1.8521739130435, 0.17608695652174, 0.36363636363636
81840, 1.8521739130435, 0.17608695652174, 0.31818181818182
81841, 1.8521739130435, 0.17608695652174, 0.27272727272727
81842, 1.8521739130435, 0.17608695652174, 0.22727272727273
81843, 1.8521739130435, 0.17608695652174, 0.18181818181818
81844, 1.8521739130435, 0.17608695652174, 0.13636363636364
81845, 1.8521739130435, 0.17608695652174, 0.090909090909091
81846, 1.8521739130435, 0.17608695652174, 0.045454545454545
81847, 1.895652173913, 0.17608695652174, 0.45454545454545
81848, 1.895652173913, 0.17608695652174, 0.40909090909091
81849, 1.895652173913, 0.17608695652174, 0.36363636363636
81850, 1.895652173913, 0.17608695652174, 0.31818181818182
81851, 1.895652173913, 0.17608695652174, 0.27272727272727
81852, 1.895652173913, 0.17608695652174, 0.22727272727273
81853, 1.895652173913, 0.17608695652174, 0.18181818181818
81854, 1.895652173913, 0.17608695652174, 0.13636363636364
81855, 1.895652173913, 0.17608695652174, 0.090909090909091
81856, 1.895652173913, 0.17608695652174, 0.045454545454545
81857, 1.9391304347826, 0.17608695652174, 0.45454545454545
81858, 1.9391304347826, 0.17608695652174, 0.40909090909091
81859, 1.9391304347826, 0.17608695652174, 0.36363636363636
81860, 1.9391304347826, 0.17608695652174, 0.31818181818182
81861, 1.9391304347826, 0.17608695652174, 0.27272727272727
81862, 1.9391304347826, 0.17608695652174, 0.22727272727273
81863, 1.9391304347826, 0.17608695652174, 0.18181818181818
81864, 1.9391304347826, 0.17608695652174, 0.13636363636364
81865, 1.9391304347826, 0.17608695652174, 0.090909090909091
81866, 1.9391304347826, 0.17608695652174, 0.045454545454545
81867, 1.9826086956522, 0.17608695652174, 0.45454545454545
81868, 1.9826086956522, 0.17608695652174, 0.40909090909091
81869, 1.9826086956522, 0.17608695652174, 0.36363636363636
81870, 1.9826086956522, 0.17608695652174, 0.31818181818182
81871, 1.9826086956522, 0.17608695652174, 0.27272727272727
81872, 1.9826086956522, 0.17608695652174, 0.22727272727273
81873, 1.9826086956522, 0.17608695652174, 0.18181818181818
81874, 1.9826086956522, 0.17608695652174, 0.13636363636364
81875, 1.9826086956522, 0.17608695652174, 0.090909090909091
81876, 1.9826086956522, 0.17608695652174, 0.045454545454545
81877, 2.0260869565217, 0.17608695652174, 0.45454545454545
81878, 2.0260869565217, 0.17608695652174, 0.40909090909091
81879, 2.0260869565217, 0.17608695652174, 0.36363636363636
81880, 2.0260869565217, 0.17608695652174, 0.31818181818182
81881, 2.0260869565217, 0.17608695652174, 0.27272727272727
81882, 2.0260869565217, 0.17608695652174, 0.22727272727273
81883, 2.0260869565217, 0.17608695652174, 0.18181818181818
81884, 2.0260869565217, 0.17608695652174, 0.13636363636364
81885, 2.0260869565217, 0.17608695652174, 0.090909090909091
81886, 2.0260869565217, 0.17608695652174, 0.045454545454545
81887, 2.0695652173913, 0.17608695652174, 0.45454545454545
81888, 2.0695652173913, 0.17608695652174, 0.40909090909091
81889, 2.0695652173913, 0.17608695652174, 0.36363636363636
81890, 2.0695652173913, 0.17608695652174, 0.31818181818182
81891, 2.0695652173913, 0.17608695652174, 0.27272727272727
81892, 2.0695652173913, 0.17608695652174, 0.22727272727273
81893, 2.0695652173913, 0.17608695652174, 0.18181818181818
81894, 2.0695652173913, 0.17608695652174, 0.13636363636364
81895, 2.0695652173913, 0.17608695652174, 0.090909090909091
81896, 2.0695652173913, 0.17608695652174, 0.045454545454545
81897, 2.1130434782609, 0.17608695652174, 0.45454545454545
81898, 2.1130434782609, 0.17608695652174, 0.40909090909091
81899, 2.1130434782609, 0.17608695652174, 0.36363636363636
81900, 2.1130434782609, 0.17608695652174, 0.31818181818182
81901, 2.1130434782609, 0.17608695652174, 0.27272727272727
81902, 2.1130434782609, 0.17608695652174, 0.22727272727273
81903, 2.1130434782609, 0.17608695652174, 0.18181818181818
81904, 2.1130434782609, 0.17608695652174, 0.13636363636364
81905, 2.1130434782609, 0.17608695652174, 0.090909090909091
81906, 2.1130434782609, 0.17608695652174, 0.045454545454545
81907, 2.1565217391304, 0.17608695652174, 0.45454545454545
81908, 2.1565217391304, 0.17608695652174, 0.40909090909091
81909, 2.1565217391304, 0.17608695652174, 0.36363636363636
81910, 2.1565217391304, 0.17608695652174, 0.31818181818182
81911, 2.1565217391304, 0.17608695652174, 0.27272727272727
81912, 2.1565217391304, 0.17608695652174, 0.22727272727273
81913, 2.1565217391304, 0.17608695652174, 0.18181818181818
81914, 2.1565217391304, 0.17608695652174, 0.13636363636364
81915, 2.1565217391304, 0.17608695652174, 0.090909090909091
81916, 2.1565217391304, 0.17608695652174, 0.045454545454545
81917, 1.2434782608696, 0.125, 0.45454545454545
81918, 1.2434782608696, 0.125, 0.40909090909091
81919, 1.2434782608696, 0.125, 0.36363636363636
81920, 1.2434782608696, 0.125, 0.31818181818182
81921, 1.2434782608696, 0.125, 0.27272727272727
81922, 1.2434782608696, 0.125, 0.22727272727273
81923, 1.2434782608696, 0.125, 0.18181818181818
81924, 1.2434782608696, 0.125, 0.13636363636364
81925, 1.2434782608696, 0.125, 0.090909090909091
81926, 1.2434782608696, 0.125, 0.045454545454545
81927, 1.2869565217391, 0.125, 0.45454545454545
81928, 1.2869565217391, 0.125, 0.40909090909091
81929, 1.2869565217391, 0.125, 0.36363636363636
81930, 1.2869565217391, 0.125, 0.31818181818182
81931, 1.2869565217391, 0.125, 0.27272727272727
81932, 1.2869565217391, 0.125, 0.22727272727273
81933, 1.2869565217391, 0.125, 0.18181818181818
81934, 1.2869565217391, 0.125, 0.13636363636364
81935, 1.2869565217391, 0.125, 0.090909090909091
81936, 1.2869565217391, 0.125, 0.045454545454545
81937, 1.3304347826087, 0.125, 0.45454545454545
81938, 1.3304347826087, 0.125, 0.40909090909091
81939, 1.3304347826087, 0.125, 0.36363636363636
81940, 1.3304347826087, 0.125, 0.31818181818182
81941, 1.3304347826087, 0.125, 0.27272727272727
81942, 1.3304347826087, 0.125, 0.22727272727273
81943, 1.3304347826087, 0.125, 0.18181818181818
81944, 1.3304347826087, 0.125, 0.13636363636364
81945, 1.3304347826087, 0.125, 0.090909090909091
81946, 1.3304347826087, 0.125, 0.045454545454545
81947, 1.3739130434783, 0.125, 0.45454545454545
81948, 1.3739130434783, 0.125, 0.40909090909091
81949, 1.3739130434783, 0.125, 0.36363636363636
81950, 1.3739130434783, 0.125, 0.31818181818182
81951, 1.3739130434783, 0.125, 0.27272727272727
81952, 1.3739130434783, 0.125, 0.22727272727273
81953, 1.3739130434783, 0.125, 0.18181818181818
81954, 1.3739130434783, 0.125, 0.13636363636364
81955, 1.3739130434783, 0.125, 0.090909090909091
81956, 1.3739130434783, 0.125, 0.045454545454545
81957, 1.4173913043478, 0.125, 0.45454545454545
81958, 1.4173913043478, 0.125, 0.40909090909091
81959, 1.4173913043478, 0.125, 0.36363636363636
81960, 1.4173913043478, 0.125, 0.31818181818182
81961, 1.4173913043478, 0.125, 0.27272727272727
81962, 1.4173913043478, 0.125, 0.22727272727273
81963, 1.4173913043478, 0.125, 0.18181818181818
81964, 1.4173913043478, 0.125, 0.13636363636364
81965, 1.4173913043478, 0.125, 0.090909090909091
81966, 1.4173913043478, 0.125, 0.045454545454545
81967, 1.4608695652174, 0.125, 0.45454545454545
81968, 1.4608695652174, 0.125, 0.40909090909091
81969, 1.4608695652174, 0.125, 0.36363636363636
81970, 1.4608695652174, 0.125, 0.31818181818182
81971, 1.4608695652174, 0.125, 0.27272727272727
81972, 1.4608695652174, 0.125, 0.22727272727273
81973, 1.4608695652174, 0.125, 0.18181818181818
81974, 1.4608695652174, 0.125, 0.13636363636364
81975, 1.4608695652174, 0.125, 0.090909090909091
81976, 1.4608695652174, 0.125, 0.045454545454545
81977, 1.504347826087, 0.125, 0.45454545454545
81978, 1.504347826087, 0.125, 0.40909090909091
81979, 1.504347826087, 0.125, 0.36363636363636
81980, 1.504347826087, 0.125, 0.31818181818182
81981, 1.504347826087, 0.125, 0.27272727272727
81982, 1.504347826087, 0.125, 0.22727272727273
81983, 1.504347826087, 0.125, 0.18181818181818
81984, 1.504347826087, 0.125, 0.13636363636364
81985, 1.504347826087, 0.125, 0.090909090909091
81986, 1.504347826087, 0.125, 0.045454545454545
81987, 1.5478260869565, 0.125, 0.45454545454545
81988, 1.5478260869565, 0.125, 0.40909090909091
81989, 1.5478260869565, 0.125, 0.36363636363636
81990, 1.5478260869565, 0.125, 0.31818181818182
81991, 1.5478260869565, 0.125, 0.27272727272727
81992, 1.5478260869565, 0.125, 0.22727272727273
81993, 1.5478260869565, 0.125, 0.18181818181818
81994, 1.5478260869565, 0.125, 0.13636363636364
81995, 1.5478260869565, 0.125, 0.090909090909091
81996, 1.5478260869565, 0.125, 0.045454545454545
81997, 1.5913043478261, 0.125, 0.45454545454545
81998, 1.5913043478261, 0.125, 0.40909090909091
81999, 1.5913043478261, 0.125, 0.36363636363636
82000, 1.5913043478261, 0.125, 0.31818181818182
82001, 1.5913043478261, 0.125, 0.27272727272727
82002, 1.5913043478261, 0.125, 0.22727272727273
82003, 1.5913043478261, 0.125, 0.18181818181818
82004, 1.5913043478261, 0.125, 0.13636363636364
82005, 1.5913043478261, 0.125, 0.090909090909091
82006, 1.5913043478261, 0.125, 0.045454545454545
82007, 1.6347826086957, 0.125, 0.45454545454545
82008, 1.6347826086957, 0.125, 0.40909090909091
82009, 1.6347826086957, 0.125, 0.36363636363636
82010, 1.6347826086957, 0.125, 0.31818181818182
82011, 1.6347826086957, 0.125, 0.27272727272727
82012, 1.6347826086957, 0.125, 0.22727272727273
82013, 1.6347826086957, 0.125, 0.18181818181818
82014, 1.6347826086957, 0.125, 0.13636363636364
82015, 1.6347826086957, 0.125, 0.090909090909091
82016, 1.6347826086957, 0.125, 0.045454545454545
82017, 1.6782608695652, 0.125, 0.45454545454545
82018, 1.6782608695652, 0.125, 0.40909090909091
82019, 1.6782608695652, 0.125, 0.36363636363636
82020, 1.6782608695652, 0.125, 0.31818181818182
82021, 1.6782608695652, 0.125, 0.27272727272727
82022, 1.6782608695652, 0.125, 0.22727272727273
82023, 1.6782608695652, 0.125, 0.18181818181818
82024, 1.6782608695652, 0.125, 0.13636363636364
82025, 1.6782608695652, 0.125, 0.090909090909091
82026, 1.6782608695652, 0.125, 0.045454545454545
82027, 1.7217391304348, 0.125, 0.45454545454545
82028, 1.7217391304348, 0.125, 0.40909090909091
82029, 1.7217391304348, 0.125, 0.36363636363636
82030, 1.7217391304348, 0.125, 0.31818181818182
82031, 1.7217391304348, 0.125, 0.27272727272727
82032, 1.7217391304348, 0.125, 0.22727272727273
82033, 1.7217391304348, 0.125, 0.18181818181818
82034, 1.7217391304348, 0.125, 0.13636363636364
82035, 1.7217391304348, 0.125, 0.090909090909091
82036, 1.7217391304348, 0.125, 0.045454545454545
82037, 1.7652173913043, 0.125, 0.45454545454545
82038, 1.7652173913043, 0.125, 0.40909090909091
82039, 1.7652173913043, 0.125, 0.36363636363636
82040, 1.7652173913043, 0.125, 0.31818181818182
82041, 1.7652173913043, 0.125, 0.27272727272727
82042, 1.7652173913043, 0.125, 0.22727272727273
82043, 1.7652173913043, 0.125, 0.18181818181818
82044, 1.7652173913043, 0.125, 0.13636363636364
82045, 1.7652173913043, 0.125, 0.090909090909091
82046, 1.7652173913043, 0.125, 0.045454545454545
82047, 1.8086956521739, 0.125, 0.45454545454545
82048, 1.8086956521739, 0.125, 0.40909090909091
82049, 1.8086956521739, 0.125, 0.36363636363636
82050, 1.8086956521739, 0.125, 0.31818181818182
82051, 1.8086956521739, 0.125, 0.27272727272727
82052, 1.8086956521739, 0.125, 0.22727272727273
82053, 1.8086956521739, 0.125, 0.18181818181818
82054, 1.8086956521739, 0.125, 0.13636363636364
82055, 1.8086956521739, 0.125, 0.090909090909091
82056, 1.8086956521739, 0.125, 0.045454545454545
82057, 1.8521739130435, 0.125, 0.45454545454545
82058, 1.8521739130435, 0.125, 0.40909090909091
82059, 1.8521739130435, 0.125, 0.36363636363636
82060, 1.8521739130435, 0.125, 0.31818181818182
82061, 1.8521739130435, 0.125, 0.27272727272727
82062, 1.8521739130435, 0.125, 0.22727272727273
82063, 1.8521739130435, 0.125, 0.18181818181818
82064, 1.8521739130435, 0.125, 0.13636363636364
82065, 1.8521739130435, 0.125, 0.090909090909091
82066, 1.8521739130435, 0.125, 0.045454545454545
82067, 1.895652173913, 0.125, 0.45454545454545
82068, 1.895652173913, 0.125, 0.40909090909091
82069, 1.895652173913, 0.125, 0.36363636363636
82070, 1.895652173913, 0.125, 0.31818181818182
82071, 1.895652173913, 0.125, 0.27272727272727
82072, 1.895652173913, 0.125, 0.22727272727273
82073, 1.895652173913, 0.125, 0.18181818181818
82074, 1.895652173913, 0.125, 0.13636363636364
82075, 1.895652173913, 0.125, 0.090909090909091
82076, 1.895652173913, 0.125, 0.045454545454545
82077, 1.9391304347826, 0.125, 0.45454545454545
82078, 1.9391304347826, 0.125, 0.40909090909091
82079, 1.9391304347826, 0.125, 0.36363636363636
82080, 1.9391304347826, 0.125, 0.31818181818182
82081, 1.9391304347826, 0.125, 0.27272727272727
82082, 1.9391304347826, 0.125, 0.22727272727273
82083, 1.9391304347826, 0.125, 0.18181818181818
82084, 1.9391304347826, 0.125, 0.13636363636364
82085, 1.9391304347826, 0.125, 0.090909090909091
82086, 1.9391304347826, 0.125, 0.045454545454545
82087, 1.9826086956522, 0.125, 0.45454545454545
82088, 1.9826086956522, 0.125, 0.40909090909091
82089, 1.9826086956522, 0.125, 0.36363636363636
82090, 1.9826086956522, 0.125, 0.31818181818182
82091, 1.9826086956522, 0.125, 0.27272727272727
82092, 1.9826086956522, 0.125, 0.22727272727273
82093, 1.9826086956522, 0.125, 0.18181818181818
82094, 1.9826086956522, 0.125, 0.13636363636364
82095, 1.9826086956522, 0.125, 0.090909090909091
82096, 1.9826086956522, 0.125, 0.045454545454545
82097, 2.0260869565217, 0.125, 0.45454545454545
82098, 2.0260869565217, 0.125, 0.40909090909091
82099, 2.0260869565217, 0.125, 0.36363636363636
82100, 2.0260869565217, 0.125, 0.31818181818182
82101, 2.0260869565217, 0.125, 0.27272727272727
82102, 2.0260869565217, 0.125, 0.22727272727273
82103, 2.0260869565217, 0.125, 0.18181818181818
82104, 2.0260869565217, 0.125, 0.13636363636364
82105, 2.0260869565217, 0.125, 0.090909090909091
82106, 2.0260869565217, 0.125, 0.045454545454545
82107, 2.0695652173913, 0.125, 0.45454545454545
82108, 2.0695652173913, 0.125, 0.40909090909091
82109, 2.0695652173913, 0.125, 0.36363636363636
82110, 2.0695652173913, 0.125, 0.31818181818182
82111, 2.0695652173913, 0.125, 0.27272727272727
82112, 2.0695652173913, 0.125, 0.22727272727273
82113, 2.0695652173913, 0.125, 0.18181818181818
82114, 2.0695652173913, 0.125, 0.13636363636364
82115, 2.0695652173913, 0.125, 0.090909090909091
82116, 2.0695652173913, 0.125, 0.045454545454545
82117, 2.1130434782609, 0.125, 0.45454545454545
82118, 2.1130434782609, 0.125, 0.40909090909091
82119, 2.1130434782609, 0.125, 0.36363636363636
82120, 2.1130434782609, 0.125, 0.31818181818182
82121, 2.1130434782609, 0.125, 0.27272727272727
82122, 2.1130434782609, 0.125, 0.22727272727273
82123, 2.1130434782609, 0.125, 0.18181818181818
82124, 2.1130434782609, 0.125, 0.13636363636364
82125, 2.1130434782609, 0.125, 0.090909090909091
82126, 2.1130434782609, 0.125, 0.045454545454545
82127, 2.1565217391304, 0.125, 0.45454545454545
82128, 2.1565217391304, 0.125, 0.40909090909091
82129, 2.1565217391304, 0.125, 0.36363636363636
82130, 2.1565217391304, 0.125, 0.31818181818182
82131, 2.1565217391304, 0.125, 0.27272727272727
82132, 2.1565217391304, 0.125, 0.22727272727273
82133, 2.1565217391304, 0.125, 0.18181818181818
82134, 2.1565217391304, 0.125, 0.13636363636364
82135, 2.1565217391304, 0.125, 0.090909090909091
82136, 2.1565217391304, 0.125, 0.045454545454545
82137, 1.2434782608696, 0.125, 0.47727272727273
82138, 1.2217391304348, 0.125, 0.45454545454545
82139, 1.2434782608696, 0.1375, 0.45454545454545
82140, 1.2434782608696, 0.125, 0.43181818181818
82141, 1.2217391304348, 0.125, 0.40909090909091
82142, 1.2434782608696, 0.1375, 0.40909090909091
82143, 1.2434782608696, 0.125, 0.38636363636364
82144, 1.2217391304348, 0.125, 0.36363636363636
82145, 1.2434782608696, 0.1375, 0.36363636363636
82146, 1.2434782608696, 0.125, 0.34090909090909
82147, 1.2217391304348, 0.125, 0.31818181818182
82148, 1.2434782608696, 0.1375, 0.31818181818182
82149, 1.2434782608696, 0.125, 0.29545454545455
82150, 1.2217391304348, 0.125, 0.27272727272727
82151, 1.2434782608696, 0.1375, 0.27272727272727
82152, 1.2434782608696, 0.125, 0.25
82153, 1.2217391304348, 0.125, 0.22727272727273
82154, 1.2434782608696, 0.1375, 0.22727272727273
82155, 1.2434782608696, 0.125, 0.20454545454545
82156, 1.2217391304348, 0.125, 0.18181818181818
82157, 1.2434782608696, 0.1375, 0.18181818181818
82158, 1.2434782608696, 0.125, 0.15909090909091
82159, 1.2217391304348, 0.125, 0.13636363636364
82160, 1.2434782608696, 0.1375, 0.13636363636364
82161, 1.2434782608696, 0.125, 0.11363636363636
82162, 1.2217391304348, 0.125, 0.090909090909091
82163, 1.2434782608696, 0.1375, 0.090909090909091
82164, 1.2434782608696, 0.125, 0.068181818181818
82165, 1.2217391304348, 0.125, 0.045454545454545
82166, 1.2434782608696, 0.1375, 0.045454545454545
82167, 1.2434782608696, 0.125, 0.022727272727273
82168, 1.2869565217391, 0.125, 0.47727272727273
82169, 1.2652173913043, 0.125, 0.45454545454545
82170, 1.2869565217391, 0.1375, 0.45454545454545
82171, 1.2869565217391, 0.125, 0.43181818181818
82172, 1.2652173913043, 0.125, 0.40909090909091
82173, 1.2869565217391, 0.1375, 0.40909090909091
82174, 1.2869565217391, 0.125, 0.38636363636364
82175, 1.2652173913043, 0.125, 0.36363636363636
82176, 1.2869565217391, 0.1375, 0.36363636363636
82177, 1.2869565217391, 0.125, 0.34090909090909
82178, 1.2652173913043, 0.125, 0.31818181818182
82179, 1.2869565217391, 0.1375, 0.31818181818182
82180, 1.2869565217391, 0.125, 0.29545454545455
82181, 1.2652173913043, 0.125, 0.27272727272727
82182, 1.2869565217391, 0.1375, 0.27272727272727
82183, 1.2869565217391, 0.125, 0.25
82184, 1.2652173913043, 0.125, 0.22727272727273
82185, 1.2869565217391, 0.1375, 0.22727272727273
82186, 1.2869565217391, 0.125, 0.20454545454545
82187, 1.2652173913043, 0.125, 0.18181818181818
82188, 1.2869565217391, 0.1375, 0.18181818181818
82189, 1.2869565217391, 0.125, 0.15909090909091
82190, 1.2652173913043, 0.125, 0.13636363636364
82191, 1.2869565217391, 0.1375, 0.13636363636364
82192, 1.2869565217391, 0.125, 0.11363636363636
82193, 1.2652173913043, 0.125, 0.090909090909091
82194, 1.2869565217391, 0.1375, 0.090909090909091
82195, 1.2869565217391, 0.125, 0.068181818181818
82196, 1.2652173913043, 0.125, 0.045454545454545
82197, 1.2869565217391, 0.1375, 0.045454545454545
82198, 1.2869565217391, 0.125, 0.022727272727273
82199, 1.3304347826087, 0.125, 0.47727272727273
82200, 1.3086956521739, 0.125, 0.45454545454545
82201, 1.3304347826087, 0.1375, 0.45454545454545
82202, 1.3304347826087, 0.125, 0.43181818181818
82203, 1.3086956521739, 0.125, 0.40909090909091
82204, 1.3304347826087, 0.1375, 0.40909090909091
82205, 1.3304347826087, 0.125, 0.38636363636364
82206, 1.3086956521739, 0.125, 0.36363636363636
82207, 1.3304347826087, 0.1375, 0.36363636363636
82208, 1.3304347826087, 0.125, 0.34090909090909
82209, 1.3086956521739, 0.125, 0.31818181818182
82210, 1.3304347826087, 0.1375, 0.31818181818182
82211, 1.3304347826087, 0.125, 0.29545454545455
82212, 1.3086956521739, 0.125, 0.27272727272727
82213, 1.3304347826087, 0.1375, 0.27272727272727
82214, 1.3304347826087, 0.125, 0.25
82215, 1.3086956521739, 0.125, 0.22727272727273
82216, 1.3304347826087, 0.1375, 0.22727272727273
82217, 1.3304347826087, 0.125, 0.20454545454545
82218, 1.3086956521739, 0.125, 0.18181818181818
82219, 1.3304347826087, 0.1375, 0.18181818181818
82220, 1.3304347826087, 0.125, 0.15909090909091
82221, 1.3086956521739, 0.125, 0.13636363636364
82222, 1.3304347826087, 0.1375, 0.13636363636364
82223, 1.3304347826087, 0.125, 0.11363636363636
82224, 1.3086956521739, 0.125, 0.090909090909091
82225, 1.3304347826087, 0.1375, 0.090909090909091
82226, 1.3304347826087, 0.125, 0.068181818181818
82227, 1.3086956521739, 0.125, 0.045454545454545
82228, 1.3304347826087, 0.1375, 0.045454545454545
82229, 1.3304347826087, 0.125, 0.022727272727273
82230, 1.3739130434783, 0.125, 0.47727272727273
82231, 1.3521739130435, 0.125, 0.45454545454545
82232, 1.3739130434783, 0.1375, 0.45454545454545
82233, 1.3739130434783, 0.125, 0.43181818181818
82234, 1.3521739130435, 0.125, 0.40909090909091
82235, 1.3739130434783, 0.1375, 0.40909090909091
82236, 1.3739130434783, 0.125, 0.38636363636364
82237, 1.3521739130435, 0.125, 0.36363636363636
82238, 1.3739130434783, 0.1375, 0.36363636363636
82239, 1.3739130434783, 0.125, 0.34090909090909
82240, 1.3521739130435, 0.125, 0.31818181818182
82241, 1.3739130434783, 0.1375, 0.31818181818182
82242, 1.3739130434783, 0.125, 0.29545454545455
82243, 1.3521739130435, 0.125, 0.27272727272727
82244, 1.3739130434783, 0.1375, 0.27272727272727
82245, 1.3739130434783, 0.125, 0.25
82246, 1.3521739130435, 0.125, 0.22727272727273
82247, 1.3739130434783, 0.1375, 0.22727272727273
82248, 1.3739130434783, 0.125, 0.20454545454545
82249, 1.3521739130435, 0.125, 0.18181818181818
82250, 1.3739130434783, 0.1375, 0.18181818181818
82251, 1.3739130434783, 0.125, 0.15909090909091
82252, 1.3521739130435, 0.125, 0.13636363636364
82253, 1.3739130434783, 0.1375, 0.13636363636364
82254, 1.3739130434783, 0.125, 0.11363636363636
82255, 1.3521739130435, 0.125, 0.090909090909091
82256, 1.3739130434783, 0.1375, 0.090909090909091
82257, 1.3739130434783, 0.125, 0.068181818181818
82258, 1.3521739130435, 0.125, 0.045454545454545
82259, 1.3739130434783, 0.1375, 0.045454545454545
82260, 1.3739130434783, 0.125, 0.022727272727273
82261, 1.4173913043478, 0.125, 0.47727272727273
82262, 1.395652173913, 0.125, 0.45454545454545
82263, 1.4173913043478, 0.1375, 0.45454545454545
82264, 1.4173913043478, 0.125, 0.43181818181818
82265, 1.395652173913, 0.125, 0.40909090909091
82266, 1.4173913043478, 0.1375, 0.40909090909091
82267, 1.4173913043478, 0.125, 0.38636363636364
82268, 1.395652173913, 0.125, 0.36363636363636
82269, 1.4173913043478, 0.1375, 0.36363636363636
82270, 1.4173913043478, 0.125, 0.34090909090909
82271, 1.395652173913, 0.125, 0.31818181818182
82272, 1.4173913043478, 0.1375, 0.31818181818182
82273, 1.4173913043478, 0.125, 0.29545454545455
82274, 1.395652173913, 0.125, 0.27272727272727
82275, 1.4173913043478, 0.1375, 0.27272727272727
82276, 1.4173913043478, 0.125, 0.25
82277, 1.395652173913, 0.125, 0.22727272727273
82278, 1.4173913043478, 0.1375, 0.22727272727273
82279, 1.4173913043478, 0.125, 0.20454545454545
82280, 1.395652173913, 0.125, 0.18181818181818
82281, 1.4173913043478, 0.1375, 0.18181818181818
82282, 1.4173913043478, 0.125, 0.15909090909091
82283, 1.395652173913, 0.125, 0.13636363636364
82284, 1.4173913043478, 0.1375, 0.13636363636364
82285, 1.4173913043478, 0.125, 0.11363636363636
82286, 1.395652173913, 0.125, 0.090909090909091
82287, 1.4173913043478, 0.1375, 0.090909090909091
82288, 1.4173913043478, 0.125, 0.068181818181818
82289, 1.395652173913, 0.125, 0.045454545454545
82290, 1.4173913043478, 0.1375, 0.045454545454545
82291, 1.4173913043478, 0.125, 0.022727272727273
82292, 1.4608695652174, 0.125, 0.47727272727273
82293, 1.4391304347826, 0.125, 0.45454545454545
82294, 1.4608695652174, 0.1375, 0.45454545454545
82295, 1.4608695652174, 0.125, 0.43181818181818
82296, 1.4391304347826, 0.125, 0.40909090909091
82297, 1.4608695652174, 0.1375, 0.40909090909091
82298, 1.4608695652174, 0.125, 0.38636363636364
82299, 1.4391304347826, 0.125, 0.36363636363636
82300, 1.4608695652174, 0.1375, 0.36363636363636
82301, 1.4608695652174, 0.125, 0.34090909090909
82302, 1.4391304347826, 0.125, 0.31818181818182
82303, 1.4608695652174, 0.1375, 0.31818181818182
82304, 1.4608695652174, 0.125, 0.29545454545455
82305, 1.4391304347826, 0.125, 0.27272727272727
82306, 1.4608695652174, 0.1375, 0.27272727272727
82307, 1.4608695652174, 0.125, 0.25
82308, 1.4391304347826, 0.125, 0.22727272727273
82309, 1.4608695652174, 0.1375, 0.22727272727273
82310, 1.4608695652174, 0.125, 0.20454545454545
82311, 1.4391304347826, 0.125, 0.18181818181818
82312, 1.4608695652174, 0.1375, 0.18181818181818
82313, 1.4608695652174, 0.125, 0.15909090909091
82314, 1.4391304347826, 0.125, 0.13636363636364
82315, 1.4608695652174, 0.1375, 0.13636363636364
82316, 1.4608695652174, 0.125, 0.11363636363636
82317, 1.4391304347826, 0.125, 0.090909090909091
82318, 1.4608695652174, 0.1375, 0.090909090909091
82319, 1.4608695652174, 0.125, 0.068181818181818
82320, 1.4391304347826, 0.125, 0.045454545454545
82321, 1.4608695652174, 0.1375, 0.045454545454545
82322, 1.4608695652174, 0.125, 0.022727272727273
82323, 1.504347826087, 0.125, 0.47727272727273
82324, 1.4826086956522, 0.125, 0.45454545454545
82325, 1.504347826087, 0.1375, 0.45454545454545
82326, 1.504347826087, 0.125, 0.43181818181818
82327, 1.4826086956522, 0.125, 0.40909090909091
82328, 1.504347826087, 0.1375, 0.40909090909091
82329, 1.504347826087, 0.125, 0.38636363636364
82330, 1.4826086956522, 0.125, 0.36363636363636
82331, 1.504347826087, 0.1375, 0.36363636363636
82332, 1.504347826087, 0.125, 0.34090909090909
82333, 1.4826086956522, 0.125, 0.31818181818182
82334, 1.504347826087, 0.1375, 0.31818181818182
82335, 1.504347826087, 0.125, 0.29545454545455
82336, 1.4826086956522, 0.125, 0.27272727272727
82337, 1.504347826087, 0.1375, 0.27272727272727
82338, 1.504347826087, 0.125, 0.25
82339, 1.4826086956522, 0.125, 0.22727272727273
82340, 1.504347826087, 0.1375, 0.22727272727273
82341, 1.504347826087, 0.125, 0.20454545454545
82342, 1.4826086956522, 0.125, 0.18181818181818
82343, 1.504347826087, 0.1375, 0.18181818181818
82344, 1.504347826087, 0.125, 0.15909090909091
82345, 1.4826086956522, 0.125, 0.13636363636364
82346, 1.504347826087, 0.1375, 0.13636363636364
82347, 1.504347826087, 0.125, 0.11363636363636
82348, 1.4826086956522, 0.125, 0.090909090909091
82349, 1.504347826087, 0.1375, 0.090909090909091
82350, 1.504347826087, 0.125, 0.068181818181818
82351, 1.4826086956522, 0.125, 0.045454545454545
82352, 1.504347826087, 0.1375, 0.045454545454545
82353, 1.504347826087, 0.125, 0.022727272727273
82354, 1.5478260869565, 0.125, 0.47727272727273
82355, 1.5260869565217, 0.125, 0.45454545454545
82356, 1.5478260869565, 0.1375, 0.45454545454545
82357, 1.5478260869565, 0.125, 0.43181818181818
82358, 1.5260869565217, 0.125, 0.40909090909091
82359, 1.5478260869565, 0.1375, 0.40909090909091
82360, 1.5478260869565, 0.125, 0.38636363636364
82361, 1.5260869565217, 0.125, 0.36363636363636
82362, 1.5478260869565, 0.1375, 0.36363636363636
82363, 1.5478260869565, 0.125, 0.34090909090909
82364, 1.5260869565217, 0.125, 0.31818181818182
82365, 1.5478260869565, 0.1375, 0.31818181818182
82366, 1.5478260869565, 0.125, 0.29545454545455
82367, 1.5260869565217, 0.125, 0.27272727272727
82368, 1.5478260869565, 0.1375, 0.27272727272727
82369, 1.5478260869565, 0.125, 0.25
82370, 1.5260869565217, 0.125, 0.22727272727273
82371, 1.5478260869565, 0.1375, 0.22727272727273
82372, 1.5478260869565, 0.125, 0.20454545454545
82373, 1.5260869565217, 0.125, 0.18181818181818
82374, 1.5478260869565, 0.1375, 0.18181818181818
82375, 1.5478260869565, 0.125, 0.15909090909091
82376, 1.5260869565217, 0.125, 0.13636363636364
82377, 1.5478260869565, 0.1375, 0.13636363636364
82378, 1.5478260869565, 0.125, 0.11363636363636
82379, 1.5260869565217, 0.125, 0.090909090909091
82380, 1.5478260869565, 0.1375, 0.090909090909091
82381, 1.5478260869565, 0.125, 0.068181818181818
82382, 1.5260869565217, 0.125, 0.045454545454545
82383, 1.5478260869565, 0.1375, 0.045454545454545
82384, 1.5478260869565, 0.125, 0.022727272727273
82385, 1.5913043478261, 0.125, 0.47727272727273
82386, 1.5695652173913, 0.125, 0.45454545454545
82387, 1.5913043478261, 0.1375, 0.45454545454545
82388, 1.5913043478261, 0.125, 0.43181818181818
82389, 1.5695652173913, 0.125, 0.40909090909091
82390, 1.5913043478261, 0.1375, 0.40909090909091
82391, 1.5913043478261, 0.125, 0.38636363636364
82392, 1.5695652173913, 0.125, 0.36363636363636
82393, 1.5913043478261, 0.1375, 0.36363636363636
82394, 1.5913043478261, 0.125, 0.34090909090909
82395, 1.5695652173913, 0.125, 0.31818181818182
82396, 1.5913043478261, 0.1375, 0.31818181818182
82397, 1.5913043478261, 0.125, 0.29545454545455
82398, 1.5695652173913, 0.125, 0.27272727272727
82399, 1.5913043478261, 0.1375, 0.27272727272727
82400, 1.5913043478261, 0.125, 0.25
82401, 1.5695652173913, 0.125, 0.22727272727273
82402, 1.5913043478261, 0.1375, 0.22727272727273
82403, 1.5913043478261, 0.125, 0.20454545454545
82404, 1.5695652173913, 0.125, 0.18181818181818
82405, 1.5913043478261, 0.1375, 0.18181818181818
82406, 1.5913043478261, 0.125, 0.15909090909091
82407, 1.5695652173913, 0.125, 0.13636363636364
82408, 1.5913043478261, 0.1375, 0.13636363636364
82409, 1.5913043478261, 0.125, 0.11363636363636
82410, 1.5695652173913, 0.125, 0.090909090909091
82411, 1.5913043478261, 0.1375, 0.090909090909091
82412, 1.5913043478261, 0.125, 0.068181818181818
82413, 1.5695652173913, 0.125, 0.045454545454545
82414, 1.5913043478261, 0.1375, 0.045454545454545
82415, 1.5913043478261, 0.125, 0.022727272727273
82416, 1.6347826086957, 0.125, 0.47727272727273
82417, 1.6130434782609, 0.125, 0.45454545454545
82418, 1.6347826086957, 0.1375, 0.45454545454545
82419, 1.6347826086957, 0.125, 0.43181818181818
82420, 1.6130434782609, 0.125, 0.40909090909091
82421, 1.6347826086957, 0.1375, 0.40909090909091
82422, 1.6347826086957, 0.125, 0.38636363636364
82423, 1.6130434782609, 0.125, 0.36363636363636
82424, 1.6347826086957, 0.1375, 0.36363636363636
82425, 1.6347826086957, 0.125, 0.34090909090909
82426, 1.6130434782609, 0.125, 0.31818181818182
82427, 1.6347826086957, 0.1375, 0.31818181818182
82428, 1.6347826086957, 0.125, 0.29545454545455
82429, 1.6130434782609, 0.125, 0.27272727272727
82430, 1.6347826086957, 0.1375, 0.27272727272727
82431, 1.6347826086957, 0.125, 0.25
82432, 1.6130434782609, 0.125, 0.22727272727273
82433, 1.6347826086957, 0.1375, 0.22727272727273
82434, 1.6347826086957, 0.125, 0.20454545454545
82435, 1.6130434782609, 0.125, 0.18181818181818
82436, 1.6347826086957, 0.1375, 0.18181818181818
82437, 1.6347826086957, 0.125, 0.15909090909091
82438, 1.6130434782609, 0.125, 0.13636363636364
82439, 1.6347826086957, 0.1375, 0.13636363636364
82440, 1.6347826086957, 0.125, 0.11363636363636
82441, 1.6130434782609, 0.125, 0.090909090909091
82442, 1.6347826086957, 0.1375, 0.090909090909091
82443, 1.6347826086957, 0.125, 0.068181818181818
82444, 1.6130434782609, 0.125, 0.045454545454545
82445, 1.6347826086957, 0.1375, 0.045454545454545
82446, 1.6347826086957, 0.125, 0.022727272727273
82447, 1.6782608695652, 0.125, 0.47727272727273
82448, 1.6565217391304, 0.125, 0.45454545454545
82449, 1.6782608695652, 0.1375, 0.45454545454545
82450, 1.6782608695652, 0.125, 0.43181818181818
82451, 1.6565217391304, 0.125, 0.40909090909091
82452, 1.6782608695652, 0.1375, 0.40909090909091
82453, 1.6782608695652, 0.125, 0.38636363636364
82454, 1.6565217391304, 0.125, 0.36363636363636
82455, 1.6782608695652, 0.1375, 0.36363636363636
82456, 1.6782608695652, 0.125, 0.34090909090909
82457, 1.6565217391304, 0.125, 0.31818181818182
82458, 1.6782608695652, 0.1375, 0.31818181818182
82459, 1.6782608695652, 0.125, 0.29545454545455
82460, 1.6565217391304, 0.125, 0.27272727272727
82461, 1.6782608695652, 0.1375, 0.27272727272727
82462, 1.6782608695652, 0.125, 0.25
82463, 1.6565217391304, 0.125, 0.22727272727273
82464, 1.6782608695652, 0.1375, 0.22727272727273
82465, 1.6782608695652, 0.125, 0.20454545454545
82466, 1.6565217391304, 0.125, 0.18181818181818
82467, 1.6782608695652, 0.1375, 0.18181818181818
82468, 1.6782608695652, 0.125, 0.15909090909091
82469, 1.6565217391304, 0.125, 0.13636363636364
82470, 1.6782608695652, 0.1375, 0.13636363636364
82471, 1.6782608695652, 0.125, 0.11363636363636
82472, 1.6565217391304, 0.125, 0.090909090909091
82473, 1.6782608695652, 0.1375, 0.090909090909091
82474, 1.6782608695652, 0.125, 0.068181818181818
82475, 1.6565217391304, 0.125, 0.045454545454545
82476, 1.6782608695652, 0.1375, 0.045454545454545
82477, 1.6782608695652, 0.125, 0.022727272727273
82478, 1.7217391304348, 0.125, 0.47727272727273
82479, 1.7, 0.125, 0.45454545454545
82480, 1.7217391304348, 0.1375, 0.45454545454545
82481, 1.7217391304348, 0.125, 0.43181818181818
82482, 1.7, 0.125, 0.40909090909091
82483, 1.7217391304348, 0.1375, 0.40909090909091
82484, 1.7217391304348, 0.125, 0.38636363636364
82485, 1.7, 0.125, 0.36363636363636
82486, 1.7217391304348, 0.1375, 0.36363636363636
82487, 1.7217391304348, 0.125, 0.34090909090909
82488, 1.7, 0.125, 0.31818181818182
82489, 1.7217391304348, 0.1375, 0.31818181818182
82490, 1.7217391304348, 0.125, 0.29545454545455
82491, 1.7, 0.125, 0.27272727272727
82492, 1.7217391304348, 0.1375, 0.27272727272727
82493, 1.7217391304348, 0.125, 0.25
82494, 1.7, 0.125, 0.22727272727273
82495, 1.7217391304348, 0.1375, 0.22727272727273
82496, 1.7217391304348, 0.125, 0.20454545454545
82497, 1.7, 0.125, 0.18181818181818
82498, 1.7217391304348, 0.1375, 0.18181818181818
82499, 1.7217391304348, 0.125, 0.15909090909091
82500, 1.7, 0.125, 0.13636363636364
82501, 1.7217391304348, 0.1375, 0.13636363636364
82502, 1.7217391304348, 0.125, 0.11363636363636
82503, 1.7, 0.125, 0.090909090909091
82504, 1.7217391304348, 0.1375, 0.090909090909091
82505, 1.7217391304348, 0.125, 0.068181818181818
82506, 1.7, 0.125, 0.045454545454545
82507, 1.7217391304348, 0.1375, 0.045454545454545
82508, 1.7217391304348, 0.125, 0.022727272727273
82509, 1.7652173913043, 0.125, 0.47727272727273
82510, 1.7434782608696, 0.125, 0.45454545454545
82511, 1.7652173913043, 0.1375, 0.45454545454545
82512, 1.7652173913043, 0.125, 0.43181818181818
82513, 1.7434782608696, 0.125, 0.40909090909091
82514, 1.7652173913043, 0.1375, 0.40909090909091
82515, 1.7652173913043, 0.125, 0.38636363636364
82516, 1.7434782608696, 0.125, 0.36363636363636
82517, 1.7652173913043, 0.1375, 0.36363636363636
82518, 1.7652173913043, 0.125, 0.34090909090909
82519, 1.7434782608696, 0.125, 0.31818181818182
82520, 1.7652173913043, 0.1375, 0.31818181818182
82521, 1.7652173913043, 0.125, 0.29545454545455
82522, 1.7434782608696, 0.125, 0.27272727272727
82523, 1.7652173913043, 0.1375, 0.27272727272727
82524, 1.7652173913043, 0.125, 0.25
82525, 1.7434782608696, 0.125, 0.22727272727273
82526, 1.7652173913043, 0.1375, 0.22727272727273
82527, 1.7652173913043, 0.125, 0.20454545454545
82528, 1.7434782608696, 0.125, 0.18181818181818
82529, 1.7652173913043, 0.1375, 0.18181818181818
82530, 1.7652173913043, 0.125, 0.15909090909091
82531, 1.7434782608696, 0.125, 0.13636363636364
82532, 1.7652173913043, 0.1375, 0.13636363636364
82533, 1.7652173913043, 0.125, 0.11363636363636
82534, 1.7434782608696, 0.125, 0.090909090909091
82535, 1.7652173913043, 0.1375, 0.090909090909091
82536, 1.7652173913043, 0.125, 0.068181818181818
82537, 1.7434782608696, 0.125, 0.045454545454545
82538, 1.7652173913043, 0.1375, 0.045454545454545
82539, 1.7652173913043, 0.125, 0.022727272727273
82540, 1.8086956521739, 0.125, 0.47727272727273
82541, 1.7869565217391, 0.125, 0.45454545454545
82542, 1.8086956521739, 0.1375, 0.45454545454545
82543, 1.8086956521739, 0.125, 0.43181818181818
82544, 1.7869565217391, 0.125, 0.40909090909091
82545, 1.8086956521739, 0.1375, 0.40909090909091
82546, 1.8086956521739, 0.125, 0.38636363636364
82547, 1.7869565217391, 0.125, 0.36363636363636
82548, 1.8086956521739, 0.1375, 0.36363636363636
82549, 1.8086956521739, 0.125, 0.34090909090909
82550, 1.7869565217391, 0.125, 0.31818181818182
82551, 1.8086956521739, 0.1375, 0.31818181818182
82552, 1.8086956521739, 0.125, 0.29545454545455
82553, 1.7869565217391, 0.125, 0.27272727272727
82554, 1.8086956521739, 0.1375, 0.27272727272727
82555, 1.8086956521739, 0.125, 0.25
82556, 1.7869565217391, 0.125, 0.22727272727273
82557, 1.8086956521739, 0.1375, 0.22727272727273
82558, 1.8086956521739, 0.125, 0.20454545454545
82559, 1.7869565217391, 0.125, 0.18181818181818
82560, 1.8086956521739, 0.1375, 0.18181818181818
82561, 1.8086956521739, 0.125, 0.15909090909091
82562, 1.7869565217391, 0.125, 0.13636363636364
82563, 1.8086956521739, 0.1375, 0.13636363636364
82564, 1.8086956521739, 0.125, 0.11363636363636
82565, 1.7869565217391, 0.125, 0.090909090909091
82566, 1.8086956521739, 0.1375, 0.090909090909091
82567, 1.8086956521739, 0.125, 0.068181818181818
82568, 1.7869565217391, 0.125, 0.045454545454545
82569, 1.8086956521739, 0.1375, 0.045454545454545
82570, 1.8086956521739, 0.125, 0.022727272727273
82571, 1.8521739130435, 0.125, 0.47727272727273
82572, 1.8304347826087, 0.125, 0.45454545454545
82573, 1.8521739130435, 0.1375, 0.45454545454545
82574, 1.8521739130435, 0.125, 0.43181818181818
82575, 1.8304347826087, 0.125, 0.40909090909091
82576, 1.8521739130435, 0.1375, 0.40909090909091
82577, 1.8521739130435, 0.125, 0.38636363636364
82578, 1.8304347826087, 0.125, 0.36363636363636
82579, 1.8521739130435, 0.1375, 0.36363636363636
82580, 1.8521739130435, 0.125, 0.34090909090909
82581, 1.8304347826087, 0.125, 0.31818181818182
82582, 1.8521739130435, 0.1375, 0.31818181818182
82583, 1.8521739130435, 0.125, 0.29545454545455
82584, 1.8304347826087, 0.125, 0.27272727272727
82585, 1.8521739130435, 0.1375, 0.27272727272727
82586, 1.8521739130435, 0.125, 0.25
82587, 1.8304347826087, 0.125, 0.22727272727273
82588, 1.8521739130435, 0.1375, 0.22727272727273
82589, 1.8521739130435, 0.125, 0.20454545454545
82590, 1.8304347826087, 0.125, 0.18181818181818
82591, 1.8521739130435, 0.1375, 0.18181818181818
82592, 1.8521739130435, 0.125, 0.15909090909091
82593, 1.8304347826087, 0.125, 0.13636363636364
82594, 1.8521739130435, 0.1375, 0.13636363636364
82595, 1.8521739130435, 0.125, 0.11363636363636
82596, 1.8304347826087, 0.125, 0.090909090909091
82597, 1.8521739130435, 0.1375, 0.090909090909091
82598, 1.8521739130435, 0.125, 0.068181818181818
82599, 1.8304347826087, 0.125, 0.045454545454545
82600, 1.8521739130435, 0.1375, 0.045454545454545
82601, 1.8521739130435, 0.125, 0.022727272727273
82602, 1.895652173913, 0.125, 0.47727272727273
82603, 1.8739130434783, 0.125, 0.45454545454545
82604, 1.895652173913, 0.1375, 0.45454545454545
82605, 1.895652173913, 0.125, 0.43181818181818
82606, 1.8739130434783, 0.125, 0.40909090909091
82607, 1.895652173913, 0.1375, 0.40909090909091
82608, 1.895652173913, 0.125, 0.38636363636364
82609, 1.8739130434783, 0.125, 0.36363636363636
82610, 1.895652173913, 0.1375, 0.36363636363636
82611, 1.895652173913, 0.125, 0.34090909090909
82612, 1.8739130434783, 0.125, 0.31818181818182
82613, 1.895652173913, 0.1375, 0.31818181818182
82614, 1.895652173913, 0.125, 0.29545454545455
82615, 1.8739130434783, 0.125, 0.27272727272727
82616, 1.895652173913, 0.1375, 0.27272727272727
82617, 1.895652173913, 0.125, 0.25
82618, 1.8739130434783, 0.125, 0.22727272727273
82619, 1.895652173913, 0.1375, 0.22727272727273
82620, 1.895652173913, 0.125, 0.20454545454545
82621, 1.8739130434783, 0.125, 0.18181818181818
82622, 1.895652173913, 0.1375, 0.18181818181818
82623, 1.895652173913, 0.125, 0.15909090909091
82624, 1.8739130434783, 0.125, 0.13636363636364
82625, 1.895652173913, 0.1375, 0.13636363636364
82626, 1.895652173913, 0.125, 0.11363636363636
82627, 1.8739130434783, 0.125, 0.090909090909091
82628, 1.895652173913, 0.1375, 0.090909090909091
82629, 1.895652173913, 0.125, 0.068181818181818
82630, 1.8739130434783, 0.125, 0.045454545454545
82631, 1.895652173913, 0.1375, 0.045454545454545
82632, 1.895652173913, 0.125, 0.022727272727273
82633, 1.9391304347826, 0.125, 0.47727272727273
82634, 1.9173913043478, 0.125, 0.45454545454545
82635, 1.9391304347826, 0.1375, 0.45454545454545
82636, 1.9391304347826, 0.125, 0.43181818181818
82637, 1.9173913043478, 0.125, 0.40909090909091
82638, 1.9391304347826, 0.1375, 0.40909090909091
82639, 1.9391304347826, 0.125, 0.38636363636364
82640, 1.9173913043478, 0.125, 0.36363636363636
82641, 1.9391304347826, 0.1375, 0.36363636363636
82642, 1.9391304347826, 0.125, 0.34090909090909
82643, 1.9173913043478, 0.125, 0.31818181818182
82644, 1.9391304347826, 0.1375, 0.31818181818182
82645, 1.9391304347826, 0.125, 0.29545454545455
82646, 1.9173913043478, 0.125, 0.27272727272727
82647, 1.9391304347826, 0.1375, 0.27272727272727
82648, 1.9391304347826, 0.125, 0.25
82649, 1.9173913043478, 0.125, 0.22727272727273
82650, 1.9391304347826, 0.1375, 0.22727272727273
82651, 1.9391304347826, 0.125, 0.20454545454545
82652, 1.9173913043478, 0.125, 0.18181818181818
82653, 1.9391304347826, 0.1375, 0.18181818181818
82654, 1.9391304347826, 0.125, 0.15909090909091
82655, 1.9173913043478, 0.125, 0.13636363636364
82656, 1.9391304347826, 0.1375, 0.13636363636364
82657, 1.9391304347826, 0.125, 0.11363636363636
82658, 1.9173913043478, 0.125, 0.090909090909091
82659, 1.9391304347826, 0.1375, 0.090909090909091
82660, 1.9391304347826, 0.125, 0.068181818181818
82661, 1.9173913043478, 0.125, 0.045454545454545
82662, 1.9391304347826, 0.1375, 0.045454545454545
82663, 1.9391304347826, 0.125, 0.022727272727273
82664, 1.9826086956522, 0.125, 0.47727272727273
82665, 1.9608695652174, 0.125, 0.45454545454545
82666, 1.9826086956522, 0.1375, 0.45454545454545
82667, 1.9826086956522, 0.125, 0.43181818181818
82668, 1.9608695652174, 0.125, 0.40909090909091
82669, 1.9826086956522, 0.1375, 0.40909090909091
82670, 1.9826086956522, 0.125, 0.38636363636364
82671, 1.9608695652174, 0.125, 0.36363636363636
82672, 1.9826086956522, 0.1375, 0.36363636363636
82673, 1.9826086956522, 0.125, 0.34090909090909
82674, 1.9608695652174, 0.125, 0.31818181818182
82675, 1.9826086956522, 0.1375, 0.31818181818182
82676, 1.9826086956522, 0.125, 0.29545454545455
82677, 1.9608695652174, 0.125, 0.27272727272727
82678, 1.9826086956522, 0.1375, 0.27272727272727
82679, 1.9826086956522, 0.125, 0.25
82680, 1.9608695652174, 0.125, 0.22727272727273
82681, 1.9826086956522, 0.1375, 0.22727272727273
82682, 1.9826086956522, 0.125, 0.20454545454545
82683, 1.9608695652174, 0.125, 0.18181818181818
82684, 1.9826086956522, 0.1375, 0.18181818181818
82685, 1.9826086956522, 0.125, 0.15909090909091
82686, 1.9608695652174, 0.125, 0.13636363636364
82687, 1.9826086956522, 0.1375, 0.13636363636364
82688, 1.9826086956522, 0.125, 0.11363636363636
82689, 1.9608695652174, 0.125, 0.090909090909091
82690, 1.9826086956522, 0.1375, 0.090909090909091
82691, 1.9826086956522, 0.125, 0.068181818181818
82692, 1.9608695652174, 0.125, 0.045454545454545
82693, 1.9826086956522, 0.1375, 0.045454545454545
82694, 1.9826086956522, 0.125, 0.022727272727273
82695, 2.0260869565217, 0.125, 0.47727272727273
82696, 2.004347826087, 0.125, 0.45454545454545
82697, 2.0260869565217, 0.1375, 0.45454545454545
82698, 2.0260869565217, 0.125, 0.43181818181818
82699, 2.004347826087, 0.125, 0.40909090909091
82700, 2.0260869565217, 0.1375, 0.40909090909091
82701, 2.0260869565217, 0.125, 0.38636363636364
82702, 2.004347826087, 0.125, 0.36363636363636
82703, 2.0260869565217, 0.1375, 0.36363636363636
82704, 2.0260869565217, 0.125, 0.34090909090909
82705, 2.004347826087, 0.125, 0.31818181818182
82706, 2.0260869565217, 0.1375, 0.31818181818182
82707, 2.0260869565217, 0.125, 0.29545454545455
82708, 2.004347826087, 0.125, 0.27272727272727
82709, 2.0260869565217, 0.1375, 0.27272727272727
82710, 2.0260869565217, 0.125, 0.25
82711, 2.004347826087, 0.125, 0.22727272727273
82712, 2.0260869565217, 0.1375, 0.22727272727273
82713, 2.0260869565217, 0.125, 0.20454545454545
82714, 2.004347826087, 0.125, 0.18181818181818
82715, 2.0260869565217, 0.1375, 0.18181818181818
82716, 2.0260869565217, 0.125, 0.15909090909091
82717, 2.004347826087, 0.125, 0.13636363636364
82718, 2.0260869565217, 0.1375, 0.13636363636364
82719, 2.0260869565217, 0.125, 0.11363636363636
82720, 2.004347826087, 0.125, 0.090909090909091
82721, 2.0260869565217, 0.1375, 0.090909090909091
82722, 2.0260869565217, 0.125, 0.068181818181818
82723, 2.004347826087, 0.125, 0.045454545454545
82724, 2.0260869565217, 0.1375, 0.045454545454545
82725, 2.0260869565217, 0.125, 0.022727272727273
82726, 2.0695652173913, 0.125, 0.47727272727273
82727, 2.0478260869565, 0.125, 0.45454545454545
82728, 2.0695652173913, 0.1375, 0.45454545454545
82729, 2.0695652173913, 0.125, 0.43181818181818
82730, 2.0478260869565, 0.125, 0.40909090909091
82731, 2.0695652173913, 0.1375, 0.40909090909091
82732, 2.0695652173913, 0.125, 0.38636363636364
82733, 2.0478260869565, 0.125, 0.36363636363636
82734, 2.0695652173913, 0.1375, 0.36363636363636
82735, 2.0695652173913, 0.125, 0.34090909090909
82736, 2.0478260869565, 0.125, 0.31818181818182
82737, 2.0695652173913, 0.1375, 0.31818181818182
82738, 2.0695652173913, 0.125, 0.29545454545455
82739, 2.0478260869565, 0.125, 0.27272727272727
82740, 2.0695652173913, 0.1375, 0.27272727272727
82741, 2.0695652173913, 0.125, 0.25
82742, 2.0478260869565, 0.125, 0.22727272727273
82743, 2.0695652173913, 0.1375, 0.22727272727273
82744, 2.0695652173913, 0.125, 0.20454545454545
82745, 2.0478260869565, 0.125, 0.18181818181818
82746, 2.0695652173913, 0.1375, 0.18181818181818
82747, 2.0695652173913, 0.125, 0.15909090909091
82748, 2.0478260869565, 0.125, 0.13636363636364
82749, 2.0695652173913, 0.1375, 0.13636363636364
82750, 2.0695652173913, 0.125, 0.11363636363636
82751, 2.0478260869565, 0.125, 0.090909090909091
82752, 2.0695652173913, 0.1375, 0.090909090909091
82753, 2.0695652173913, 0.125, 0.068181818181818
82754, 2.0478260869565, 0.125, 0.045454545454545
82755, 2.0695652173913, 0.1375, 0.045454545454545
82756, 2.0695652173913, 0.125, 0.022727272727273
82757, 2.1130434782609, 0.125, 0.47727272727273
82758, 2.0913043478261, 0.125, 0.45454545454545
82759, 2.1130434782609, 0.1375, 0.45454545454545
82760, 2.1130434782609, 0.125, 0.43181818181818
82761, 2.0913043478261, 0.125, 0.40909090909091
82762, 2.1130434782609, 0.1375, 0.40909090909091
82763, 2.1130434782609, 0.125, 0.38636363636364
82764, 2.0913043478261, 0.125, 0.36363636363636
82765, 2.1130434782609, 0.1375, 0.36363636363636
82766, 2.1130434782609, 0.125, 0.34090909090909
82767, 2.0913043478261, 0.125, 0.31818181818182
82768, 2.1130434782609, 0.1375, 0.31818181818182
82769, 2.1130434782609, 0.125, 0.29545454545455
82770, 2.0913043478261, 0.125, 0.27272727272727
82771, 2.1130434782609, 0.1375, 0.27272727272727
82772, 2.1130434782609, 0.125, 0.25
82773, 2.0913043478261, 0.125, 0.22727272727273
82774, 2.1130434782609, 0.1375, 0.22727272727273
82775, 2.1130434782609, 0.125, 0.20454545454545
82776, 2.0913043478261, 0.125, 0.18181818181818
82777, 2.1130434782609, 0.1375, 0.18181818181818
82778, 2.1130434782609, 0.125, 0.15909090909091
82779, 2.0913043478261, 0.125, 0.13636363636364
82780, 2.1130434782609, 0.1375, 0.13636363636364
82781, 2.1130434782609, 0.125, 0.11363636363636
82782, 2.0913043478261, 0.125, 0.090909090909091
82783, 2.1130434782609, 0.1375, 0.090909090909091
82784, 2.1130434782609, 0.125, 0.068181818181818
82785, 2.0913043478261, 0.125, 0.045454545454545
82786, 2.1130434782609, 0.1375, 0.045454545454545
82787, 2.1130434782609, 0.125, 0.022727272727273
82788, 2.1565217391304, 0.125, 0.47727272727273
82789, 2.1347826086957, 0.125, 0.45454545454545
82790, 2.1565217391304, 0.1375, 0.45454545454545
82791, 2.1565217391304, 0.125, 0.43181818181818
82792, 2.1347826086957, 0.125, 0.40909090909091
82793, 2.1565217391304, 0.1375, 0.40909090909091
82794, 2.1565217391304, 0.125, 0.38636363636364
82795, 2.1347826086957, 0.125, 0.36363636363636
82796, 2.1565217391304, 0.1375, 0.36363636363636
82797, 2.1565217391304, 0.125, 0.34090909090909
82798, 2.1347826086957, 0.125, 0.31818181818182
82799, 2.1565217391304, 0.1375, 0.31818181818182
82800, 2.1565217391304, 0.125, 0.29545454545455
82801, 2.1347826086957, 0.125, 0.27272727272727
82802, 2.1565217391304, 0.1375, 0.27272727272727
82803, 2.1565217391304, 0.125, 0.25
82804, 2.1347826086957, 0.125, 0.22727272727273
82805, 2.1565217391304, 0.1375, 0.22727272727273
82806, 2.1565217391304, 0.125, 0.20454545454545
82807, 2.1347826086957, 0.125, 0.18181818181818
82808, 2.1565217391304, 0.1375, 0.18181818181818
82809, 2.1565217391304, 0.125, 0.15909090909091
82810, 2.1347826086957, 0.125, 0.13636363636364
82811, 2.1565217391304, 0.1375, 0.13636363636364
82812, 2.1565217391304, 0.125, 0.11363636363636
82813, 2.1347826086957, 0.125, 0.090909090909091
82814, 2.1565217391304, 0.1375, 0.090909090909091
82815, 2.1565217391304, 0.125, 0.068181818181818
82816, 2.1347826086957, 0.125, 0.045454545454545
82817, 2.1565217391304, 0.1375, 0.045454545454545
82818, 2.1565217391304, 0.125, 0.022727272727273
82819, 2.1782608695652, 0.125, 0.45454545454545
82820, 2.1782608695652, 0.125, 0.40909090909091
82821, 2.1782608695652, 0.125, 0.36363636363636
82822, 2.1782608695652, 0.125, 0.31818181818182
82823, 2.1782608695652, 0.125, 0.27272727272727
82824, 2.1782608695652, 0.125, 0.22727272727273
82825, 2.1782608695652, 0.125, 0.18181818181818
82826, 2.1782608695652, 0.125, 0.13636363636364
82827, 2.1782608695652, 0.125, 0.090909090909091
82828, 2.1782608695652, 0.125, 0.045454545454545
82829, 1.2434782608696, 0.1125, 0.45454545454545
82830, 1.2434782608696, 0.1125, 0.40909090909091
82831, 1.2434782608696, 0.1125, 0.36363636363636
82832, 1.2434782608696, 0.1125, 0.31818181818182
82833, 1.2434782608696, 0.1125, 0.27272727272727
82834, 1.2434782608696, 0.1125, 0.22727272727273
82835, 1.2434782608696, 0.1125, 0.18181818181818
82836, 1.2434782608696, 0.1125, 0.13636363636364
82837, 1.2434782608696, 0.1125, 0.090909090909091
82838, 1.2434782608696, 0.1125, 0.045454545454545
82839, 1.2869565217391, 0.1125, 0.45454545454545
82840, 1.2869565217391, 0.1125, 0.40909090909091
82841, 1.2869565217391, 0.1125, 0.36363636363636
82842, 1.2869565217391, 0.1125, 0.31818181818182
82843, 1.2869565217391, 0.1125, 0.27272727272727
82844, 1.2869565217391, 0.1125, 0.22727272727273
82845, 1.2869565217391, 0.1125, 0.18181818181818
82846, 1.2869565217391, 0.1125, 0.13636363636364
82847, 1.2869565217391, 0.1125, 0.090909090909091
82848, 1.2869565217391, 0.1125, 0.045454545454545
82849, 1.3304347826087, 0.1125, 0.45454545454545
82850, 1.3304347826087, 0.1125, 0.40909090909091
82851, 1.3304347826087, 0.1125, 0.36363636363636
82852, 1.3304347826087, 0.1125, 0.31818181818182
82853, 1.3304347826087, 0.1125, 0.27272727272727
82854, 1.3304347826087, 0.1125, 0.22727272727273
82855, 1.3304347826087, 0.1125, 0.18181818181818
82856, 1.3304347826087, 0.1125, 0.13636363636364
82857, 1.3304347826087, 0.1125, 0.090909090909091
82858, 1.3304347826087, 0.1125, 0.045454545454545
82859, 1.3739130434783, 0.1125, 0.45454545454545
82860, 1.3739130434783, 0.1125, 0.40909090909091
82861, 1.3739130434783, 0.1125, 0.36363636363636
82862, 1.3739130434783, 0.1125, 0.31818181818182
82863, 1.3739130434783, 0.1125, 0.27272727272727
82864, 1.3739130434783, 0.1125, 0.22727272727273
82865, 1.3739130434783, 0.1125, 0.18181818181818
82866, 1.3739130434783, 0.1125, 0.13636363636364
82867, 1.3739130434783, 0.1125, 0.090909090909091
82868, 1.3739130434783, 0.1125, 0.045454545454545
82869, 1.4173913043478, 0.1125, 0.45454545454545
82870, 1.4173913043478, 0.1125, 0.40909090909091
82871, 1.4173913043478, 0.1125, 0.36363636363636
82872, 1.4173913043478, 0.1125, 0.31818181818182
82873, 1.4173913043478, 0.1125, 0.27272727272727
82874, 1.4173913043478, 0.1125, 0.22727272727273
82875, 1.4173913043478, 0.1125, 0.18181818181818
82876, 1.4173913043478, 0.1125, 0.13636363636364
82877, 1.4173913043478, 0.1125, 0.090909090909091
82878, 1.4173913043478, 0.1125, 0.045454545454545
82879, 1.4608695652174, 0.1125, 0.45454545454545
82880, 1.4608695652174, 0.1125, 0.40909090909091
82881, 1.4608695652174, 0.1125, 0.36363636363636
82882, 1.4608695652174, 0.1125, 0.31818181818182
82883, 1.4608695652174, 0.1125, 0.27272727272727
82884, 1.4608695652174, 0.1125, 0.22727272727273
82885, 1.4608695652174, 0.1125, 0.18181818181818
82886, 1.4608695652174, 0.1125, 0.13636363636364
82887, 1.4608695652174, 0.1125, 0.090909090909091
82888, 1.4608695652174, 0.1125, 0.045454545454545
82889, 1.504347826087, 0.1125, 0.45454545454545
82890, 1.504347826087, 0.1125, 0.40909090909091
82891, 1.504347826087, 0.1125, 0.36363636363636
82892, 1.504347826087, 0.1125, 0.31818181818182
82893, 1.504347826087, 0.1125, 0.27272727272727
82894, 1.504347826087, 0.1125, 0.22727272727273
82895, 1.504347826087, 0.1125, 0.18181818181818
82896, 1.504347826087, 0.1125, 0.13636363636364
82897, 1.504347826087, 0.1125, 0.090909090909091
82898, 1.504347826087, 0.1125, 0.045454545454545
82899, 1.5478260869565, 0.1125, 0.45454545454545
82900, 1.5478260869565, 0.1125, 0.40909090909091
82901, 1.5478260869565, 0.1125, 0.36363636363636
82902, 1.5478260869565, 0.1125, 0.31818181818182
82903, 1.5478260869565, 0.1125, 0.27272727272727
82904, 1.5478260869565, 0.1125, 0.22727272727273
82905, 1.5478260869565, 0.1125, 0.18181818181818
82906, 1.5478260869565, 0.1125, 0.13636363636364
82907, 1.5478260869565, 0.1125, 0.090909090909091
82908, 1.5478260869565, 0.1125, 0.045454545454545
82909, 1.5913043478261, 0.1125, 0.45454545454545
82910, 1.5913043478261, 0.1125, 0.40909090909091
82911, 1.5913043478261, 0.1125, 0.36363636363636
82912, 1.5913043478261, 0.1125, 0.31818181818182
82913, 1.5913043478261, 0.1125, 0.27272727272727
82914, 1.5913043478261, 0.1125, 0.22727272727273
82915, 1.5913043478261, 0.1125, 0.18181818181818
82916, 1.5913043478261, 0.1125, 0.13636363636364
82917, 1.5913043478261, 0.1125, 0.090909090909091
82918, 1.5913043478261, 0.1125, 0.045454545454545
82919, 1.6347826086957, 0.1125, 0.45454545454545
82920, 1.6347826086957, 0.1125, 0.40909090909091
82921, 1.6347826086957, 0.1125, 0.36363636363636
82922, 1.6347826086957, 0.1125, 0.31818181818182
82923, 1.6347826086957, 0.1125, 0.27272727272727
82924, 1.6347826086957, 0.1125, 0.22727272727273
82925, 1.6347826086957, 0.1125, 0.18181818181818
82926, 1.6347826086957, 0.1125, 0.13636363636364
82927, 1.6347826086957, 0.1125, 0.090909090909091
82928, 1.6347826086957, 0.1125, 0.045454545454545
82929, 1.6782608695652, 0.1125, 0.45454545454545
82930, 1.6782608695652, 0.1125, 0.40909090909091
82931, 1.6782608695652, 0.1125, 0.36363636363636
82932, 1.6782608695652, 0.1125, 0.31818181818182
82933, 1.6782608695652, 0.1125, 0.27272727272727
82934, 1.6782608695652, 0.1125, 0.22727272727273
82935, 1.6782608695652, 0.1125, 0.18181818181818
82936, 1.6782608695652, 0.1125, 0.13636363636364
82937, 1.6782608695652, 0.1125, 0.090909090909091
82938, 1.6782608695652, 0.1125, 0.045454545454545
82939, 1.7217391304348, 0.1125, 0.45454545454545
82940, 1.7217391304348, 0.1125, 0.40909090909091
82941, 1.7217391304348, 0.1125, 0.36363636363636
82942, 1.7217391304348, 0.1125, 0.31818181818182
82943, 1.7217391304348, 0.1125, 0.27272727272727
82944, 1.7217391304348, 0.1125, 0.22727272727273
82945, 1.7217391304348, 0.1125, 0.18181818181818
82946, 1.7217391304348, 0.1125, 0.13636363636364
82947, 1.7217391304348, 0.1125, 0.090909090909091
82948, 1.7217391304348, 0.1125, 0.045454545454545
82949, 1.7652173913043, 0.1125, 0.45454545454545
82950, 1.7652173913043, 0.1125, 0.40909090909091
82951, 1.7652173913043, 0.1125, 0.36363636363636
82952, 1.7652173913043, 0.1125, 0.31818181818182
82953, 1.7652173913043, 0.1125, 0.27272727272727
82954, 1.7652173913043, 0.1125, 0.22727272727273
82955, 1.7652173913043, 0.1125, 0.18181818181818
82956, 1.7652173913043, 0.1125, 0.13636363636364
82957, 1.7652173913043, 0.1125, 0.090909090909091
82958, 1.7652173913043, 0.1125, 0.045454545454545
82959, 1.8086956521739, 0.1125, 0.45454545454545
82960, 1.8086956521739, 0.1125, 0.40909090909091
82961, 1.8086956521739, 0.1125, 0.36363636363636
82962, 1.8086956521739, 0.1125, 0.31818181818182
82963, 1.8086956521739, 0.1125, 0.27272727272727
82964, 1.8086956521739, 0.1125, 0.22727272727273
82965, 1.8086956521739, 0.1125, 0.18181818181818
82966, 1.8086956521739, 0.1125, 0.13636363636364
82967, 1.8086956521739, 0.1125, 0.090909090909091
82968, 1.8086956521739, 0.1125, 0.045454545454545
82969, 1.8521739130435, 0.1125, 0.45454545454545
82970, 1.8521739130435, 0.1125, 0.40909090909091
82971, 1.8521739130435, 0.1125, 0.36363636363636
82972, 1.8521739130435, 0.1125, 0.31818181818182
82973, 1.8521739130435, 0.1125, 0.27272727272727
82974, 1.8521739130435, 0.1125, 0.22727272727273
82975, 1.8521739130435, 0.1125, 0.18181818181818
82976, 1.8521739130435, 0.1125, 0.13636363636364
82977, 1.8521739130435, 0.1125, 0.090909090909091
82978, 1.8521739130435, 0.1125, 0.045454545454545
82979, 1.895652173913, 0.1125, 0.45454545454545
82980, 1.895652173913, 0.1125, 0.40909090909091
82981, 1.895652173913, 0.1125, 0.36363636363636
82982, 1.895652173913, 0.1125, 0.31818181818182
82983, 1.895652173913, 0.1125, 0.27272727272727
82984, 1.895652173913, 0.1125, 0.22727272727273
82985, 1.895652173913, 0.1125, 0.18181818181818
82986, 1.895652173913, 0.1125, 0.13636363636364
82987, 1.895652173913, 0.1125, 0.090909090909091
82988, 1.895652173913, 0.1125, 0.045454545454545
82989, 1.9391304347826, 0.1125, 0.45454545454545
82990, 1.9391304347826, 0.1125, 0.40909090909091
82991, 1.9391304347826, 0.1125, 0.36363636363636
82992, 1.9391304347826, 0.1125, 0.31818181818182
82993, 1.9391304347826, 0.1125, 0.27272727272727
82994, 1.9391304347826, 0.1125, 0.22727272727273
82995, 1.9391304347826, 0.1125, 0.18181818181818
82996, 1.9391304347826, 0.1125, 0.13636363636364
82997, 1.9391304347826, 0.1125, 0.090909090909091
82998, 1.9391304347826, 0.1125, 0.045454545454545
82999, 1.9826086956522, 0.1125, 0.45454545454545
83000, 1.9826086956522, 0.1125, 0.40909090909091
83001, 1.9826086956522, 0.1125, 0.36363636363636
83002, 1.9826086956522, 0.1125, 0.31818181818182
83003, 1.9826086956522, 0.1125, 0.27272727272727
83004, 1.9826086956522, 0.1125, 0.22727272727273
83005, 1.9826086956522, 0.1125, 0.18181818181818
83006, 1.9826086956522, 0.1125, 0.13636363636364
83007, 1.9826086956522, 0.1125, 0.090909090909091
83008, 1.9826086956522, 0.1125, 0.045454545454545
83009, 2.0260869565217, 0.1125, 0.45454545454545
83010, 2.0260869565217, 0.1125, 0.40909090909091
83011, 2.0260869565217, 0.1125, 0.36363636363636
83012, 2.0260869565217, 0.1125, 0.31818181818182
83013, 2.0260869565217, 0.1125, 0.27272727272727
83014, 2.0260869565217, 0.1125, 0.22727272727273
83015, 2.0260869565217, 0.1125, 0.18181818181818
83016, 2.0260869565217, 0.1125, 0.13636363636364
83017, 2.0260869565217, 0.1125, 0.090909090909091
83018, 2.0260869565217, 0.1125, 0.045454545454545
83019, 2.0695652173913, 0.1125, 0.45454545454545
83020, 2.0695652173913, 0.1125, 0.40909090909091
83021, 2.0695652173913, 0.1125, 0.36363636363636
83022, 2.0695652173913, 0.1125, 0.31818181818182
83023, 2.0695652173913, 0.1125, 0.27272727272727
83024, 2.0695652173913, 0.1125, 0.22727272727273
83025, 2.0695652173913, 0.1125, 0.18181818181818
83026, 2.0695652173913, 0.1125, 0.13636363636364
83027, 2.0695652173913, 0.1125, 0.090909090909091
83028, 2.0695652173913, 0.1125, 0.045454545454545
83029, 2.1130434782609, 0.1125, 0.45454545454545
83030, 2.1130434782609, 0.1125, 0.40909090909091
83031, 2.1130434782609, 0.1125, 0.36363636363636
83032, 2.1130434782609, 0.1125, 0.31818181818182
83033, 2.1130434782609, 0.1125, 0.27272727272727
83034, 2.1130434782609, 0.1125, 0.22727272727273
83035, 2.1130434782609, 0.1125, 0.18181818181818
83036, 2.1130434782609, 0.1125, 0.13636363636364
83037, 2.1130434782609, 0.1125, 0.090909090909091
83038, 2.1130434782609, 0.1125, 0.045454545454545
83039, 2.1565217391304, 0.1125, 0.45454545454545
83040, 2.1565217391304, 0.1125, 0.40909090909091
83041, 2.1565217391304, 0.1125, 0.36363636363636
83042, 2.1565217391304, 0.1125, 0.31818181818182
83043, 2.1565217391304, 0.1125, 0.27272727272727
83044, 2.1565217391304, 0.1125, 0.22727272727273
83045, 2.1565217391304, 0.1125, 0.18181818181818
83046, 2.1565217391304, 0.1125, 0.13636363636364
83047, 2.1565217391304, 0.1125, 0.090909090909091
83048, 2.1565217391304, 0.1125, 0.045454545454545
83049, 1.2434782608696, 0.066666666666667, 0.45454545454545
83050, 1.2434782608696, 0.066666666666667, 0.40909090909091
83051, 1.2434782608696, 0.066666666666667, 0.36363636363636
83052, 1.2434782608696, 0.066666666666667, 0.31818181818182
83053, 1.2434782608696, 0.066666666666667, 0.27272727272727
83054, 1.2434782608696, 0.066666666666667, 0.22727272727273
83055, 1.2434782608696, 0.066666666666667, 0.18181818181818
83056, 1.2434782608696, 0.066666666666667, 0.13636363636364
83057, 1.2434782608696, 0.066666666666667, 0.090909090909091
83058, 1.2434782608696, 0.066666666666667, 0.045454545454545
83059, 1.2869565217391, 0.066666666666667, 0.45454545454545
83060, 1.2869565217391, 0.066666666666667, 0.40909090909091
83061, 1.2869565217391, 0.066666666666667, 0.36363636363636
83062, 1.2869565217391, 0.066666666666667, 0.31818181818182
83063, 1.2869565217391, 0.066666666666667, 0.27272727272727
83064, 1.2869565217391, 0.066666666666667, 0.22727272727273
83065, 1.2869565217391, 0.066666666666667, 0.18181818181818
83066, 1.2869565217391, 0.066666666666667, 0.13636363636364
83067, 1.2869565217391, 0.066666666666667, 0.090909090909091
83068, 1.2869565217391, 0.066666666666667, 0.045454545454545
83069, 1.3304347826087, 0.066666666666667, 0.45454545454545
83070, 1.3304347826087, 0.066666666666667, 0.40909090909091
83071, 1.3304347826087, 0.066666666666667, 0.36363636363636
83072, 1.3304347826087, 0.066666666666667, 0.31818181818182
83073, 1.3304347826087, 0.066666666666667, 0.27272727272727
83074, 1.3304347826087, 0.066666666666667, 0.22727272727273
83075, 1.3304347826087, 0.066666666666667, 0.18181818181818
83076, 1.3304347826087, 0.066666666666667, 0.13636363636364
83077, 1.3304347826087, 0.066666666666667, 0.090909090909091
83078, 1.3304347826087, 0.066666666666667, 0.045454545454545
83079, 1.3739130434783, 0.066666666666667, 0.45454545454545
83080, 1.3739130434783, 0.066666666666667, 0.40909090909091
83081, 1.3739130434783, 0.066666666666667, 0.36363636363636
83082, 1.3739130434783, 0.066666666666667, 0.31818181818182
83083, 1.3739130434783, 0.066666666666667, 0.27272727272727
83084, 1.3739130434783, 0.066666666666667, 0.22727272727273
83085, 1.3739130434783, 0.066666666666667, 0.18181818181818
83086, 1.3739130434783, 0.066666666666667, 0.13636363636364
83087, 1.3739130434783, 0.066666666666667, 0.090909090909091
83088, 1.3739130434783, 0.066666666666667, 0.045454545454545
83089, 1.4173913043478, 0.066666666666667, 0.45454545454545
83090, 1.4173913043478, 0.066666666666667, 0.40909090909091
83091, 1.4173913043478, 0.066666666666667, 0.36363636363636
83092, 1.4173913043478, 0.066666666666667, 0.31818181818182
83093, 1.4173913043478, 0.066666666666667, 0.27272727272727
83094, 1.4173913043478, 0.066666666666667, 0.22727272727273
83095, 1.4173913043478, 0.066666666666667, 0.18181818181818
83096, 1.4173913043478, 0.066666666666667, 0.13636363636364
83097, 1.4173913043478, 0.066666666666667, 0.090909090909091
83098, 1.4173913043478, 0.066666666666667, 0.045454545454545
83099, 1.4608695652174, 0.066666666666667, 0.45454545454545
83100, 1.4608695652174, 0.066666666666667, 0.40909090909091
83101, 1.4608695652174, 0.066666666666667, 0.36363636363636
83102, 1.4608695652174, 0.066666666666667, 0.31818181818182
83103, 1.4608695652174, 0.066666666666667, 0.27272727272727
83104, 1.4608695652174, 0.066666666666667, 0.22727272727273
83105, 1.4608695652174, 0.066666666666667, 0.18181818181818
83106, 1.4608695652174, 0.066666666666667, 0.13636363636364
83107, 1.4608695652174, 0.066666666666667, 0.090909090909091
83108, 1.4608695652174, 0.066666666666667, 0.045454545454545
83109, 1.504347826087, 0.066666666666667, 0.45454545454545
83110, 1.504347826087, 0.066666666666667, 0.40909090909091
83111, 1.504347826087, 0.066666666666667, 0.36363636363636
83112, 1.504347826087, 0.066666666666667, 0.31818181818182
83113, 1.504347826087, 0.066666666666667, 0.27272727272727
83114, 1.504347826087, 0.066666666666667, 0.22727272727273
83115, 1.504347826087, 0.066666666666667, 0.18181818181818
83116, 1.504347826087, 0.066666666666667, 0.13636363636364
83117, 1.504347826087, 0.066666666666667, 0.090909090909091
83118, 1.504347826087, 0.066666666666667, 0.045454545454545
83119, 1.5478260869565, 0.066666666666667, 0.45454545454545
83120, 1.5478260869565, 0.066666666666667, 0.40909090909091
83121, 1.5478260869565, 0.066666666666667, 0.36363636363636
83122, 1.5478260869565, 0.066666666666667, 0.31818181818182
83123, 1.5478260869565, 0.066666666666667, 0.27272727272727
83124, 1.5478260869565, 0.066666666666667, 0.22727272727273
83125, 1.5478260869565, 0.066666666666667, 0.18181818181818
83126, 1.5478260869565, 0.066666666666667, 0.13636363636364
83127, 1.5478260869565, 0.066666666666667, 0.090909090909091
83128, 1.5478260869565, 0.066666666666667, 0.045454545454545
83129, 1.5913043478261, 0.066666666666667, 0.45454545454545
83130, 1.5913043478261, 0.066666666666667, 0.40909090909091
83131, 1.5913043478261, 0.066666666666667, 0.36363636363636
83132, 1.5913043478261, 0.066666666666667, 0.31818181818182
83133, 1.5913043478261, 0.066666666666667, 0.27272727272727
83134, 1.5913043478261, 0.066666666666667, 0.22727272727273
83135, 1.5913043478261, 0.066666666666667, 0.18181818181818
83136, 1.5913043478261, 0.066666666666667, 0.13636363636364
83137, 1.5913043478261, 0.066666666666667, 0.090909090909091
83138, 1.5913043478261, 0.066666666666667, 0.045454545454545
83139, 1.6347826086957, 0.066666666666667, 0.45454545454545
83140, 1.6347826086957, 0.066666666666667, 0.40909090909091
83141, 1.6347826086957, 0.066666666666667, 0.36363636363636
83142, 1.6347826086957, 0.066666666666667, 0.31818181818182
83143, 1.6347826086957, 0.066666666666667, 0.27272727272727
83144, 1.6347826086957, 0.066666666666667, 0.22727272727273
83145, 1.6347826086957, 0.066666666666667, 0.18181818181818
83146, 1.6347826086957, 0.066666666666667, 0.13636363636364
83147, 1.6347826086957, 0.066666666666667, 0.090909090909091
83148, 1.6347826086957, 0.066666666666667, 0.045454545454545
83149, 1.6782608695652, 0.066666666666667, 0.45454545454545
83150, 1.6782608695652, 0.066666666666667, 0.40909090909091
83151, 1.6782608695652, 0.066666666666667, 0.36363636363636
83152, 1.6782608695652, 0.066666666666667, 0.31818181818182
83153, 1.6782608695652, 0.066666666666667, 0.27272727272727
83154, 1.6782608695652, 0.066666666666667, 0.22727272727273
83155, 1.6782608695652, 0.066666666666667, 0.18181818181818
83156, 1.6782608695652, 0.066666666666667, 0.13636363636364
83157, 1.6782608695652, 0.066666666666667, 0.090909090909091
83158, 1.6782608695652, 0.066666666666667, 0.045454545454545
83159, 1.7217391304348, 0.066666666666667, 0.45454545454545
83160, 1.7217391304348, 0.066666666666667, 0.40909090909091
83161, 1.7217391304348, 0.066666666666667, 0.36363636363636
83162, 1.7217391304348, 0.066666666666667, 0.31818181818182
83163, 1.7217391304348, 0.066666666666667, 0.27272727272727
83164, 1.7217391304348, 0.066666666666667, 0.22727272727273
83165, 1.7217391304348, 0.066666666666667, 0.18181818181818
83166, 1.7217391304348, 0.066666666666667, 0.13636363636364
83167, 1.7217391304348, 0.066666666666667, 0.090909090909091
83168, 1.7217391304348, 0.066666666666667, 0.045454545454545
83169, 1.7652173913043, 0.066666666666667, 0.45454545454545
83170, 1.7652173913043, 0.066666666666667, 0.40909090909091
83171, 1.7652173913043, 0.066666666666667, 0.36363636363636
83172, 1.7652173913043, 0.066666666666667, 0.31818181818182
83173, 1.7652173913043, 0.066666666666667, 0.27272727272727
83174, 1.7652173913043, 0.066666666666667, 0.22727272727273
83175, 1.7652173913043, 0.066666666666667, 0.18181818181818
83176, 1.7652173913043, 0.066666666666667, 0.13636363636364
83177, 1.7652173913043, 0.066666666666667, 0.090909090909091
83178, 1.7652173913043, 0.066666666666667, 0.045454545454545
83179, 1.8086956521739, 0.066666666666667, 0.45454545454545
83180, 1.8086956521739, 0.066666666666667, 0.40909090909091
83181, 1.8086956521739, 0.066666666666667, 0.36363636363636
83182, 1.8086956521739, 0.066666666666667, 0.31818181818182
83183, 1.8086956521739, 0.066666666666667, 0.27272727272727
83184, 1.8086956521739, 0.066666666666667, 0.22727272727273
83185, 1.8086956521739, 0.066666666666667, 0.18181818181818
83186, 1.8086956521739, 0.066666666666667, 0.13636363636364
83187, 1.8086956521739, 0.066666666666667, 0.090909090909091
83188, 1.8086956521739, 0.066666666666667, 0.045454545454545
83189, 1.8521739130435, 0.066666666666667, 0.45454545454545
83190, 1.8521739130435, 0.066666666666667, 0.40909090909091
83191, 1.8521739130435, 0.066666666666667, 0.36363636363636
83192, 1.8521739130435, 0.066666666666667, 0.31818181818182
83193, 1.8521739130435, 0.066666666666667, 0.27272727272727
83194, 1.8521739130435, 0.066666666666667, 0.22727272727273
83195, 1.8521739130435, 0.066666666666667, 0.18181818181818
83196, 1.8521739130435, 0.066666666666667, 0.13636363636364
83197, 1.8521739130435, 0.066666666666667, 0.090909090909091
83198, 1.8521739130435, 0.066666666666667, 0.045454545454545
83199, 1.895652173913, 0.066666666666667, 0.45454545454545
83200, 1.895652173913, 0.066666666666667, 0.40909090909091
83201, 1.895652173913, 0.066666666666667, 0.36363636363636
83202, 1.895652173913, 0.066666666666667, 0.31818181818182
83203, 1.895652173913, 0.066666666666667, 0.27272727272727
83204, 1.895652173913, 0.066666666666667, 0.22727272727273
83205, 1.895652173913, 0.066666666666667, 0.18181818181818
83206, 1.895652173913, 0.066666666666667, 0.13636363636364
83207, 1.895652173913, 0.066666666666667, 0.090909090909091
83208, 1.895652173913, 0.066666666666667, 0.045454545454545
83209, 1.9391304347826, 0.066666666666667, 0.45454545454545
83210, 1.9391304347826, 0.066666666666667, 0.40909090909091
83211, 1.9391304347826, 0.066666666666667, 0.36363636363636
83212, 1.9391304347826, 0.066666666666667, 0.31818181818182
83213, 1.9391304347826, 0.066666666666667, 0.27272727272727
83214, 1.9391304347826, 0.066666666666667, 0.22727272727273
83215, 1.9391304347826, 0.066666666666667, 0.18181818181818
83216, 1.9391304347826, 0.066666666666667, 0.13636363636364
83217, 1.9391304347826, 0.066666666666667, 0.090909090909091
83218, 1.9391304347826, 0.066666666666667, 0.045454545454545
83219, 1.9826086956522, 0.066666666666667, 0.45454545454545
83220, 1.9826086956522, 0.066666666666667, 0.40909090909091
83221, 1.9826086956522, 0.066666666666667, 0.36363636363636
83222, 1.9826086956522, 0.066666666666667, 0.31818181818182
83223, 1.9826086956522, 0.066666666666667, 0.27272727272727
83224, 1.9826086956522, 0.066666666666667, 0.22727272727273
83225, 1.9826086956522, 0.066666666666667, 0.18181818181818
83226, 1.9826086956522, 0.066666666666667, 0.13636363636364
83227, 1.9826086956522, 0.066666666666667, 0.090909090909091
83228, 1.9826086956522, 0.066666666666667, 0.045454545454545
83229, 2.0260869565217, 0.066666666666667, 0.45454545454545
83230, 2.0260869565217, 0.066666666666667, 0.40909090909091
83231, 2.0260869565217, 0.066666666666667, 0.36363636363636
83232, 2.0260869565217, 0.066666666666667, 0.31818181818182
