9462, 23366, 23388, 23389, 23367, 23491, 23492, 23493, 23447
9463, 23367, 23389, 23390, 23368, 23493, 23494, 23495, 23449
9464, 23368, 23390, 23391, 23369, 23495, 23496, 23497, 23451
9465, 23369, 23391, 23392, 23370, 23497, 23498, 23499, 23453
9466, 23370, 23392, 23393, 23371, 23499, 23500, 23501, 23455
9467, 23371, 23393, 23394, 23372, 23501, 23502, 23503, 23457
9468, 23372, 23394, 23395, 23373, 23503, 23504, 23505, 23459
9469, 23373, 23395, 23396, 23374, 23505, 23506, 23507, 23461
9470, 23374, 23396, 2308, 2307, 23507, 23508, 2311, 23463
9471, 2280, 2281, 23397, 23375, 2284, 23509, 23510, 23464
9472, 23375, 23397, 23398, 23376, 23510, 23511, 23512, 23466
9473, 23376, 23398, 23399, 23377, 23512, 23513, 23514, 23468
9474, 23377, 23399, 23400, 23378, 23514, 23515, 23516, 23470
9475, 23378, 23400, 23401, 23379, 23516, 23517, 23518, 23472
9476, 23379, 23401, 23402, 23380, 23518, 23519, 23520, 23474
9477, 23380, 23402, 23403, 23381, 23520, 23521, 23522, 23476
9478, 23381, 23403, 23404, 23382, 23522, 23523, 23524, 23478
9479, 23382, 23404, 23405, 23383, 23524, 23525, 23526, 23480
9480, 23383, 23405, 23406, 23384, 23526, 23527, 23528, 23482
9481, 23384, 23406, 23407, 23385, 23528, 23529, 23530, 23484
9482, 23385, 23407, 23408, 23386, 23530, 23531, 23532, 23486
9483, 23386, 23408, 23409, 23387, 23532, 23533, 23534, 23488
9484, 23387, 23409, 23410, 23388, 23534, 23535, 23536, 23490
9485, 23388, 23410, 23411, 23389, 23536, 23537, 23538, 23492
9486, 23389, 23411, 23412, 23390, 23538, 23539, 23540, 23494
9487, 23390, 23412, 23413, 23391, 23540, 23541, 23542, 23496
9488, 23391, 23413, 23414, 23392, 23542, 23543, 23544, 23498
9489, 23392, 23414, 23415, 23393, 23544, 23545, 23546, 23500
9490, 23393, 23415, 23416, 23394, 23546, 23547, 23548, 23502
9491, 23394, 23416, 23417, 23395, 23548, 23549, 23550, 23504
9492, 23395, 23417, 23418, 23396, 23550, 23551, 23552, 23506
9493, 23396, 23418, 2309, 2308, 23552, 23553, 2312, 23508
9494, 2281, 57, 2335, 23397, 2285, 2358, 23554, 23509
9495, 23397, 2335, 2334, 23398, 23554, 2357, 23555, 23511
9496, 23398, 2334, 2333, 23399, 23555, 2356, 23556, 23513
9497, 23399, 2333, 2332, 23400, 23556, 2355, 23557, 23515
9498, 23400, 2332, 2331, 23401, 23557, 2354, 23558, 23517
9499, 23401, 2331, 2330, 23402, 23558, 2353, 23559, 23519
9500, 23402, 2330, 2329, 23403, 23559, 2352, 23560, 23521
9501, 23403, 2329, 2328, 23404, 23560, 2351, 23561, 23523
9502, 23404, 2328, 2327, 23405, 23561, 2350, 23562, 23525
9503, 23405, 2327, 2326, 23406, 23562, 2349, 23563, 23527
9504, 23406, 2326, 2325, 23407, 23563, 2348, 23564, 23529
9505, 23407, 2325, 2324, 23408, 23564, 2347, 23565, 23531
9506, 23408, 2324, 2323, 23409, 23565, 2346, 23566, 23533
9507, 23409, 2323, 2322, 23410, 23566, 2345, 23567, 23535
9508, 23410, 2322, 2321, 23411, 23567, 2344, 23568, 23537
9509, 23411, 2321, 2320, 23412, 23568, 2343, 23569, 23539
9510, 23412, 2320, 2319, 23413, 23569, 2342, 23570, 23541
9511, 23413, 2319, 2318, 23414, 23570, 2341, 23571, 23543
9512, 23414, 2318, 2317, 23415, 23571, 2340, 23572, 23545
9513, 23415, 2317, 2316, 23416, 23572, 2339, 23573, 23547
9514, 23416, 2316, 2315, 23417, 23573, 2338, 23574, 23549
9515, 23417, 2315, 2314, 23418, 23574, 2337, 23575, 23551
9516, 23418, 2314, 58, 2309, 23575, 2336, 2313, 23553
*ELEMENT, type=CPS8, ELSET=Surface108
9517, 24, 2307, 23576, 1113, 2310, 23606, 23607, 1124
9518, 1113, 23576, 23577, 1112, 23607, 23608, 23609, 1123
9519, 1112, 23577, 23578, 1111, 23609, 23610, 23611, 1122
9520, 1111, 23578, 23579, 1110, 23611, 23612, 23613, 1121
9521, 1110, 23579, 23580, 1109, 23613, 23614, 23615, 1120
9522, 1109, 23580, 23581, 1108, 23615, 23616, 23617, 1119
9523, 1108, 23581, 23582, 1107, 23617, 23618, 23619, 1118
9524, 1107, 23582, 23583, 1106, 23619, 23620, 23621, 1117
9525, 1106, 23583, 23584, 1105, 23621, 23622, 23623, 1116
9526, 1105, 23584, 23585, 1104, 23623, 23624, 23625, 1115
9527, 1104, 23585, 2227, 22, 23625, 23626, 2230, 1114
9528, 2307, 2308, 23586, 23576, 2311, 23627, 23628, 23606
9529, 23576, 23586, 23587, 23577, 23628, 23629, 23630, 23608
9530, 23577, 23587, 23588, 23578, 23630, 23631, 23632, 23610
9531, 23578, 23588, 23589, 23579, 23632, 23633, 23634, 23612
9532, 23579, 23589, 23590, 23580, 23634, 23635, 23636, 23614
9533, 23580, 23590, 23591, 23581, 23636, 23637, 23638, 23616
9534, 23581, 23591, 23592, 23582, 23638, 23639, 23640, 23618
9535, 23582, 23592, 23593, 23583, 23640, 23641, 23642, 23620
9536, 23583, 23593, 23594, 23584, 23642, 23643, 23644, 23622
9537, 23584, 23594, 23595, 23585, 23644, 23645, 23646, 23624
9538, 23585, 23595, 2228, 2227, 23646, 23647, 2231, 23626
9539, 2308, 2309, 23596, 23586, 2312, 23648, 23649, 23627
9540, 23586, 23596, 23597, 23587, 23649, 23650, 23651, 23629
9541, 23587, 23597, 23598, 23588, 23651, 23652, 23653, 23631
9542, 23588, 23598, 23599, 23589, 23653, 23654, 23655, 23633
9543, 23589, 23599, 23600, 23590, 23655, 23656, 23657, 23635
9544, 23590, 23600, 23601, 23591, 23657, 23658, 23659, 23637
9545, 23591, 23601, 23602, 23592, 23659, 23660, 23661, 23639
9546, 23592, 23602, 23603, 23593, 23661, 23662, 23663, 23641
9547, 23593, 23603, 23604, 23594, 23663, 23664, 23665, 23643
9548, 23594, 23604, 23605, 23595, 23665, 23666, 23667, 23645
9549, 23595, 23605, 2229, 2228, 23667, 23668, 2232, 23647
9550, 2309, 58, 2368, 23596, 2313, 2379, 23669, 23648
9551, 23596, 2368, 2367, 23597, 23669, 2378, 23670, 23650
9552, 23597, 2367, 2366, 23598, 23670, 2377, 23671, 23652
9553, 23598, 2366, 2365, 23599, 23671, 2376, 23672, 23654
9554, 23599, 2365, 2364, 23600, 23672, 2375, 23673, 23656
9555, 23600, 2364, 2363, 23601, 23673, 2374, 23674, 23658
9556, 23601, 2363, 2362, 23602, 23674, 2373, 23675, 23660
9557, 23602, 2362, 2361, 23603, 23675, 2372, 23676, 23662
9558, 23603, 2361, 2360, 23604, 23676, 2371, 23677, 23664
9559, 23604, 2360, 2359, 23605, 23677, 2370, 23678, 23666
9560, 23605, 2359, 56, 2229, 23678, 2369, 2233, 23668
*ELEMENT, type=CPS8, ELSET=Surface109
9561, 56, 2359, 23679, 2234, 2369, 23899, 23900, 2256
9562, 2359, 2360, 23680, 23679, 2370, 23901, 23902, 23899
9563, 2360, 2361, 23681, 23680, 2371, 23903, 23904, 23901
9564, 2361, 2362, 23682, 23681, 2372, 23905, 23906, 23903
9565, 2362, 2363, 23683, 23682, 2373, 23907, 23908, 23905
9566, 2363, 2364, 23684, 23683, 2374, 23909, 23910, 23907
9567, 2364, 2365, 23685, 23684, 2375, 23911, 23912, 23909
9568, 2365, 2366, 23686, 23685, 2376, 23913, 23914, 23911
9569, 2366, 2367, 23687, 23686, 2377, 23915, 23916, 23913
9570, 2367, 2368, 23688, 23687, 2378, 23917, 23918, 23915
9571, 2368, 58, 2314, 23688, 2379, 2336, 23919, 23917
9572, 2234, 23679, 23689, 2235, 23900, 23920, 23921, 2257
9573, 23679, 23680, 23690, 23689, 23902, 23922, 23923, 23920
9574, 23680, 23681, 23691, 23690, 23904, 23924, 23925, 23922
9575, 23681, 23682, 23692, 23691, 23906, 23926, 23927, 23924
9576, 23682, 23683, 23693, 23692, 23908, 23928, 23929, 23926
9577, 23683, 23684, 23694, 23693, 23910, 23930, 23931, 23928
9578, 23684, 23685, 23695, 23694, 23912, 23932, 23933, 23930
9579, 23685, 23686, 23696, 23695, 23914, 23934, 23935, 23932
9580, 23686, 23687, 23697, 23696, 23916, 23936, 23937, 23934
9581, 23687, 23688, 23698, 23697, 23918, 23938, 23939, 23936
9582, 23688, 2314, 2315, 23698, 23919, 2337, 23940, 23938
9583, 2235, 23689, 23699, 2236, 23921, 23941, 23942, 2258
9584, 23689, 23690, 23700, 23699, 23923, 23943, 23944, 23941
9585, 23690, 23691, 23701, 23700, 23925, 23945, 23946, 23943
9586, 23691, 23692, 23702, 23701, 23927, 23947, 23948, 23945
9587, 23692, 23693, 23703, 23702, 23929, 23949, 23950, 23947
9588, 23693, 23694, 23704, 23703, 23931, 23951, 23952, 23949
9589, 23694, 23695, 23705, 23704, 23933, 23953, 23954, 23951
9590, 23695, 23696, 23706, 23705, 23935, 23955, 23956, 23953
9591, 23696, 23697, 23707, 23706, 23937, 23957, 23958, 23955
9592, 23697, 23698, 23708, 23707, 23939, 23959, 23960, 23957
9593, 23698, 2315, 2316, 23708, 23940, 2338, 23961, 23959
9594, 2236, 23699, 23709, 2237, 23942, 23962, 23963, 2259
9595, 23699, 23700, 23710, 23709, 23944, 23964, 23965, 23962
9596, 23700, 23701, 23711, 23710, 23946, 23966, 23967, 23964
9597, 23701, 23702, 23712, 23711, 23948, 23968, 23969, 23966
9598, 23702, 23703, 23713, 23712, 23950, 23970, 23971, 23968
9599, 23703, 23704, 23714, 23713, 23952, 23972, 23973, 23970
9600, 23704, 23705, 23715, 23714, 23954, 23974, 23975, 23972
9601, 23705, 23706, 23716, 23715, 23956, 23976, 23977, 23974
9602, 23706, 23707, 23717, 23716, 23958, 23978, 23979, 23976
9603, 23707, 23708, 23718, 23717, 23960, 23980, 23981, 23978
9604, 23708, 2316, 2317, 23718, 23961, 2339, 23982, 23980
9605, 2237, 23709, 23719, 2238, 23963, 23983, 23984, 2260
9606, 23709, 23710, 23720, 23719, 23965, 23985, 23986, 23983
9607, 23710, 23711, 23721, 23720, 23967, 23987, 23988, 23985
9608, 23711, 23712, 23722, 23721, 23969, 23989, 23990, 23987
9609, 23712, 23713, 23723, 23722, 23971, 23991, 23992, 23989
9610, 23713, 23714, 23724, 23723, 23973, 23993, 23994, 23991
9611, 23714, 23715, 23725, 23724, 23975, 23995, 23996, 23993
9612, 23715, 23716, 23726, 23725, 23977, 23997, 23998, 23995
9613, 23716, 23717, 23727, 23726, 23979, 23999, 24000, 23997
9614, 23717, 23718, 23728, 23727, 23981, 24001, 24002, 23999
9615, 23718, 2317, 2318, 23728, 23982, 2340, 24003, 24001
9616, 2238, 23719, 23729, 2239, 23984, 24004, 24005, 2261
9617, 23719, 23720, 23730, 23729, 23986, 24006, 24007, 24004
9618, 23720, 23721, 23731, 23730, 23988, 24008, 24009, 24006
9619, 23721, 23722, 23732, 23731, 23990, 24010, 24011, 24008
9620, 23722, 23723, 23733, 23732, 23992, 24012, 24013, 24010
9621, 23723, 23724, 23734, 23733, 23994, 24014, 24015, 24012
9622, 23724, 23725, 23735, 23734, 23996, 24016, 24017, 24014
9623, 23725, 23726, 23736, 23735, 23998, 24018, 24019, 24016
9624, 23726, 23727, 23737, 23736, 24000, 24020, 24021, 24018
9625, 23727, 23728, 23738, 23737, 24002, 24022, 24023, 24020
9626, 23728, 2318, 2319, 23738, 24003, 2341, 24024, 24022
9627, 2239, 23729, 23739, 2240, 24005, 24025, 24026, 2262
9628, 23729, 23730, 23740, 23739, 24007, 24027, 24028, 24025
9629, 23730, 23731, 23741, 23740, 24009, 24029, 24030, 24027
9630, 23731, 23732, 23742, 23741, 24011, 24031, 24032, 24029
9631, 23732, 23733, 23743, 23742, 24013, 24033, 24034, 24031
9632, 23733, 23734, 23744, 23743, 24015, 24035, 24036, 24033
9633, 23734, 23735, 23745, 23744, 24017, 24037, 24038, 24035
9634, 23735, 23736, 23746, 23745, 24019, 24039, 24040, 24037
9635, 23736, 23737, 23747, 23746, 24021, 24041, 24042, 24039
9636, 23737, 23738, 23748, 23747, 24023, 24043, 24044, 24041
9637, 23738, 2319, 2320, 23748, 24024, 2342, 24045, 24043
9638, 2240, 23739, 23749, 2241, 24026, 24046, 24047, 2263
9639, 23739, 23740, 23750, 23749, 24028, 24048, 24049, 24046
9640, 23740, 23741, 23751, 23750, 24030, 24050, 24051, 24048
9641, 23741, 23742, 23752, 23751, 24032, 24052, 24053, 24050
9642, 23742, 23743, 23753, 23752, 24034, 24054, 24055, 24052
9643, 23743, 23744, 23754, 23753, 24036, 24056, 24057, 24054
9644, 23744, 23745, 23755, 23754, 24038, 24058, 24059, 24056
9645, 23745, 23746, 23756, 23755, 24040, 24060, 24061, 24058
9646, 23746, 23747, 23757, 23756, 24042, 24062, 24063, 24060
9647, 23747, 23748, 23758, 23757, 24044, 24064, 24065, 24062
9648, 23748, 2320, 2321, 23758, 24045, 2343, 24066, 24064
9649, 2241, 23749, 23759, 2242, 24047, 24067, 24068, 2264
9650, 23749, 23750, 23760, 23759, 24049, 24069, 24070, 24067
9651, 23750, 23751, 23761, 23760, 24051, 24071, 24072, 24069
9652, 23751, 23752, 23762, 23761, 24053, 24073, 24074, 24071
9653, 23752, 23753, 23763, 23762, 24055, 24075, 24076, 24073
9654, 23753, 23754, 23764, 23763, 24057, 24077, 24078, 24075
9655, 23754, 23755, 23765, 23764, 24059, 24079, 24080, 24077
9656, 23755, 23756, 23766, 23765, 24061, 24081, 24082, 24079
9657, 23756, 23757, 23767, 23766, 24063, 24083, 24084, 24081
9658, 23757, 23758, 23768, 23767, 24065, 24085, 24086, 24083
9659, 23758, 2321, 2322, 23768, 24066, 2344, 24087, 24085
9660, 2242, 23759, 23769, 2243, 24068, 24088, 24089, 2265
9661, 23759, 23760, 23770, 23769, 24070, 24090, 24091, 24088
9662, 23760, 23761, 23771, 23770, 24072, 24092, 24093, 24090
9663, 23761, 23762, 23772, 23771, 24074, 24094, 24095, 24092
9664, 23762, 23763, 23773, 23772, 24076, 24096, 24097, 24094
9665, 23763, 23764, 23774, 23773, 24078, 24098, 24099, 24096
9666, 23764, 23765, 23775, 23774, 24080, 24100, 24101, 24098
9667, 23765, 23766, 23776, 23775, 24082, 24102, 24103, 24100
9668, 23766, 23767, 23777, 23776, 24084, 24104, 24105, 24102
9669, 23767, 23768, 23778, 23777, 24086, 24106, 24107, 24104
9670, 23768, 2322, 2323, 23778, 24087, 2345, 24108, 24106
9671, 2243, 23769, 23779, 2244, 24089, 24109, 24110, 2266
9672, 23769, 23770, 23780, 23779, 24091, 24111, 24112, 24109
9673, 23770, 23771, 23781, 23780, 24093, 24113, 24114, 24111
9674, 23771, 23772, 23782, 23781, 24095, 24115, 24116, 24113
9675, 23772, 23773, 23783, 23782, 24097, 24117, 24118, 24115
9676, 23773, 23774, 23784, 23783, 24099, 24119, 24120, 24117
9677, 23774, 23775, 23785, 23784, 24101, 24121, 24122, 24119
9678, 23775, 23776, 23786, 23785, 24103, 24123, 24124, 24121
9679, 23776, 23777, 23787, 23786, 24105, 24125, 24126, 24123
9680, 23777, 23778, 23788, 23787, 24107, 24127, 24128, 24125
9681, 23778, 2323, 2324, 23788, 24108, 2346, 24129, 24127
9682, 2244, 23779, 23789, 2245, 24110, 24130, 24131, 2267
9683, 23779, 23780, 23790, 23789, 24112, 24132, 24133, 24130
9684, 23780, 23781, 23791, 23790, 24114, 24134, 24135, 24132
9685, 23781, 23782, 23792, 23791, 24116, 24136, 24137, 24134
9686, 23782, 23783, 23793, 23792, 24118, 24138, 24139, 24136
9687, 23783, 23784, 23794, 23793, 24120, 24140, 24141, 24138
9688, 23784, 23785, 23795, 23794, 24122, 24142, 24143, 24140
9689, 23785, 23786, 23796, 23795, 24124, 24144, 24145, 24142
9690, 23786, 23787, 23797, 23796, 24126, 24146, 24147, 24144
9691, 23787, 23788, 23798, 23797, 24128, 24148, 24149, 24146
9692, 23788, 2324, 2325, 23798, 24129, 2347, 24150, 24148
9693, 2245, 23789, 23799, 2246, 24131, 24151, 24152, 2268
9694, 23789, 23790, 23800, 23799, 24133, 24153, 24154, 24151
9695, 23790, 23791, 23801, 23800, 24135, 24155, 24156, 24153
9696, 23791, 23792, 23802, 23801, 24137, 24157, 24158, 24155
9697, 23792, 23793, 23803, 23802, 24139, 24159, 24160, 24157
9698, 23793, 23794, 23804, 23803, 24141, 24161, 24162, 24159
9699, 23794, 23795, 23805, 23804, 24143, 24163, 24164, 24161
9700, 23795, 23796, 23806, 23805, 24145, 24165, 24166, 24163
9701, 23796, 23797, 23807, 23806, 24147, 24167, 24168, 24165
9702, 23797, 23798, 23808, 23807, 24149, 24169, 24170, 24167
9703, 23798, 2325, 2326, 23808, 24150, 2348, 24171, 24169
9704, 2246, 23799, 23809, 2247, 24152, 24172, 24173, 2269
9705, 23799, 23800, 23810, 23809, 24154, 24174, 24175, 24172
9706, 23800, 23801, 23811, 23810, 24156, 24176, 24177, 24174
9707, 23801, 23802, 23812, 23811, 24158, 24178, 24179, 24176
9708, 23802, 23803, 23813, 23812, 24160, 24180, 24181, 24178
9709, 23803, 23804, 23814, 23813, 24162, 24182, 24183, 24180
9710, 23804, 23805, 23815, 23814, 24164, 24184, 24185, 24182
9711, 23805, 23806, 23816, 23815, 24166, 24186, 24187, 24184
9712, 23806, 23807, 23817, 23816, 24168, 24188, 24189, 24186
9713, 23807, 23808, 23818, 23817, 24170, 24190, 24191, 24188
9714, 23808, 2326, 2327, 23818, 24171, 2349, 24192, 24190
9715, 2247, 23809, 23819, 2248, 24173, 24193, 24194, 2270
9716, 23809, 23810, 23820, 23819, 24175, 24195, 24196, 24193
9717, 23810, 23811, 23821, 23820, 24177, 24197, 24198, 24195
9718, 23811, 23812, 23822, 23821, 24179, 24199, 24200, 24197
9719, 23812, 23813, 23823, 23822, 24181, 24201, 24202, 24199
9720, 23813, 23814, 23824, 23823, 24183, 24203, 24204, 24201
9721, 23814, 23815, 23825, 23824, 24185, 24205, 24206, 24203
9722, 23815, 23816, 23826, 23825, 24187, 24207, 24208, 24205
9723, 23816, 23817, 23827, 23826, 24189, 24209, 24210, 24207
9724, 23817, 23818, 23828, 23827, 24191, 24211, 24212, 24209
9725, 23818, 2327, 2328, 23828, 24192, 2350, 24213, 24211
9726, 2248, 23819, 23829, 2249, 24194, 24214, 24215, 2271
9727, 23819, 23820, 23830, 23829, 24196, 24216, 24217, 24214
9728, 23820, 23821, 23831, 23830, 24198, 24218, 24219, 24216
9729, 23821, 23822, 23832, 23831, 24200, 24220, 24221, 24218
9730, 23822, 23823, 23833, 23832, 24202, 24222, 24223, 24220
9731, 23823, 23824, 23834, 23833, 24204, 24224, 24225, 24222
9732, 23824, 23825, 23835, 23834, 24206, 24226, 24227, 24224
9733, 23825, 23826, 23836, 23835, 24208, 24228, 24229, 24226
9734, 23826, 23827, 23837, 23836, 24210, 24230, 24231, 24228
9735, 23827, 23828, 23838, 23837, 24212, 24232, 24233, 24230
9736, 23828, 2328, 2329, 23838, 24213, 2351, 24234, 24232
9737, 2249, 23829, 23839, 2250, 24215, 24235, 24236, 2272
9738, 23829, 23830, 23840, 23839, 24217, 24237, 24238, 24235
9739, 23830, 23831, 23841, 23840, 24219, 24239, 24240, 24237
9740, 23831, 23832, 23842, 23841, 24221, 24241, 24242, 24239
9741, 23832, 23833, 23843, 23842, 24223, 24243, 24244, 24241
9742, 23833, 23834, 23844, 23843, 24225, 24245, 24246, 24243
9743, 23834, 23835, 23845, 23844, 24227, 24247, 24248, 24245
9744, 23835, 23836, 23846, 23845, 24229, 24249, 24250, 24247
9745, 23836, 23837, 23847, 23846, 24231, 24251, 24252, 24249
9746, 23837, 23838, 23848, 23847, 24233, 24253, 24254, 24251
9747, 23838, 2329, 2330, 23848, 24234, 2352, 24255, 24253
9748, 2250, 23839, 23849, 2251, 24236, 24256, 24257, 2273
9749, 23839, 23840, 23850, 23849, 24238, 24258, 24259, 24256
9750, 23840, 23841, 23851, 23850, 24240, 24260, 24261, 24258
9751, 23841, 23842, 23852, 23851, 24242, 24262, 24263, 24260
9752, 23842, 23843, 23853, 23852, 24244, 24264, 24265, 24262
9753, 23843, 23844, 23854, 23853, 24246, 24266, 24267, 24264
9754, 23844, 23845, 23855, 23854, 24248, 24268, 24269, 24266
9755, 23845, 23846, 23856, 23855, 24250, 24270, 24271, 24268
9756, 23846, 23847, 23857, 23856, 24252, 24272, 24273, 24270
9757, 23847, 23848, 23858, 23857, 24254, 24274, 24275, 24272
9758, 23848, 2330, 2331, 23858, 24255, 2353, 24276, 24274
9759, 2251, 23849, 23859, 2252, 24257, 24277, 24278, 2274
9760, 23849, 23850, 23860, 23859, 24259, 24279, 24280, 24277
9761, 23850, 23851, 23861, 23860, 24261, 24281, 24282, 24279
9762, 23851, 23852, 23862, 23861, 24263, 24283, 24284, 24281
9763, 23852, 23853, 23863, 23862, 24265, 24285, 24286, 24283
9764, 23853, 23854, 23864, 23863, 24267, 24287, 24288, 24285
9765, 23854, 23855, 23865, 23864, 24269, 24289, 24290, 24287
9766, 23855, 23856, 23866, 23865, 24271, 24291, 24292, 24289
9767, 23856, 23857, 23867, 23866, 24273, 24293, 24294, 24291
9768, 23857, 23858, 23868, 23867, 24275, 24295, 24296, 24293
9769, 23858, 2331, 2332, 23868, 24276, 2354, 24297, 24295
9770, 2252, 23859, 23869, 2253, 24278, 24298, 24299, 2275
9771, 23859, 23860, 23870, 23869, 24280, 24300, 24301, 24298
9772, 23860, 23861, 23871, 23870, 24282, 24302, 24303, 24300
9773, 23861, 23862, 23872, 23871, 24284, 24304, 24305, 24302
9774, 23862, 23863, 23873, 23872, 24286, 24306, 24307, 24304
9775, 23863, 23864, 23874, 23873, 24288, 24308, 24309, 24306
9776, 23864, 23865, 23875, 23874, 24290, 24310, 24311, 24308
9777, 23865, 23866, 23876, 23875, 24292, 24312, 24313, 24310
9778, 23866, 23867, 23877, 23876, 24294, 24314, 24315, 24312
9779, 23867, 23868, 23878, 23877, 24296, 24316, 24317, 24314
9780, 23868, 2332, 2333, 23878, 24297, 2355, 24318, 24316
9781, 2253, 23869, 23879, 2254, 24299, 24319, 24320, 2276
9782, 23869, 23870, 23880, 23879, 24301, 24321, 24322, 24319
9783, 23870, 23871, 23881, 23880, 24303, 24323, 24324, 24321
9784, 23871, 23872, 23882, 23881, 24305, 24325, 24326, 24323
9785, 23872, 23873, 23883, 23882, 24307, 24327, 24328, 24325
9786, 23873, 23874, 23884, 23883, 24309, 24329, 24330, 24327
9787, 23874, 23875, 23885, 23884, 24311, 24331, 24332, 24329
9788, 23875, 23876, 23886, 23885, 24313, 24333, 24334, 24331
9789, 23876, 23877, 23887, 23886, 24315, 24335, 24336, 24333
9790, 23877, 23878, 23888, 23887, 24317, 24337, 24338, 24335
9791, 23878, 2333, 2334, 23888, 24318, 2356, 24339, 24337
9792, 2254, 23879, 23889, 2255, 24320, 24340, 24341, 2277
9793, 23879, 23880, 23890, 23889, 24322, 24342, 24343, 24340
9794, 23880, 23881, 23891, 23890, 24324, 24344, 24345, 24342
9795, 23881, 23882, 23892, 23891, 24326, 24346, 24347, 24344
9796, 23882, 23883, 23893, 23892, 24328, 24348, 24349, 24346
9797, 23883, 23884, 23894, 23893, 24330, 24350, 24351, 24348
9798, 23884, 23885, 23895, 23894, 24332, 24352, 24353, 24350
9799, 23885, 23886, 23896, 23895, 24334, 24354, 24355, 24352
9800, 23886, 23887, 23897, 23896, 24336, 24356, 24357, 24354
9801, 23887, 23888, 23898, 23897, 24338, 24358, 24359, 24356
9802, 23888, 2334, 2335, 23898, 24339, 2357, 24360, 24358
9803, 2255, 23889, 2286, 55, 24341, 24361, 2296, 2278
9804, 23889, 23890, 2287, 2286, 24343, 24362, 2297, 24361
9805, 23890, 23891, 2288, 2287, 24345, 24363, 2298, 24362
9806, 23891, 23892, 2289, 2288, 24347, 24364, 2299, 24363
9807, 23892, 23893, 2290, 2289, 24349, 24365, 2300, 24364
9808, 23893, 23894, 2291, 2290, 24351, 24366, 2301, 24365
9809, 23894, 23895, 2292, 2291, 24353, 24367, 2302, 24366
9810, 23895, 23896, 2293, 2292, 24355, 24368, 2303, 24367
9811, 23896, 23897, 2294, 2293, 24357, 24369, 2304, 24368
9812, 23897, 23898, 2295, 2294, 24359, 24370, 2305, 24369
9813, 23898, 2335, 57, 2295, 24360, 2358, 2306, 24370
*ELEMENT, type=CPS8, ELSET=Surface110
9814, 23, 1134, 24371, 2279, 1138, 24383, 24384, 2282
9815, 1134, 1135, 24372, 24371, 1139, 24385, 24386, 24383
9816, 1135, 1136, 24373, 24372, 1140, 24387, 24388, 24385
9817, 1136, 1137, 24374, 24373, 1141, 24389, 24390, 24387
9818, 1137, 26, 2380, 24374, 1142, 2383, 24391, 24389
9819, 2279, 24371, 24375, 2280, 24384, 24392, 24393, 2283
9820, 24371, 24372, 24376, 24375, 24386, 24394, 24395, 24392
9821, 24372, 24373, 24377, 24376, 24388, 24396, 24397, 24394
9822, 24373, 24374, 24378, 24377, 24390, 24398, 24399, 24396
9823, 24374, 2380, 2381, 24378, 24391, 2384, 24400, 24398
9824, 2280, 24375, 24379, 2281, 24393, 24401, 24402, 2284
9825, 24375, 24376, 24380, 24379, 24395, 24403, 24404, 24401
9826, 24376, 24377, 24381, 24380, 24397, 24405, 24406, 24403
9827, 24377, 24378, 24382, 24381, 24399, 24407, 24408, 24405
9828, 24378, 2381, 2382, 24382, 24400, 2385, 24409, 24407
9829, 2281, 24379, 2387, 57, 24402, 24410, 2391, 2285
9830, 24379, 24380, 2388, 2387, 24404, 24411, 2392, 24410
9831, 24380, 24381, 2389, 2388, 24406, 24412, 2393, 24411
9832, 24381, 24382, 2390, 2389, 24408, 24413, 2394, 24412
9833, 24382, 2382, 59, 2390, 24409, 2386, 2395, 24413
*ELEMENT, type=CPS8, ELSET=Surface111
9834, 21, 2220, 24414, 1157, 2223, 24426, 24427, 1161
9835, 1157, 24414, 24415, 1158, 24427, 24428, 24429, 1162
9836, 1158, 24415, 24416, 1159, 24429, 24430, 24431, 1163
9837, 1159, 24416, 24417, 1160, 24431, 24432, 24433, 1164
9838, 1160, 24417, 2396, 28, 24433, 24434, 2399, 1165
9839, 2220, 2221, 24418, 24414, 2224, 24435, 24436, 24426
9840, 24414, 24418, 24419, 24415, 24436, 24437, 24438, 24428
9841, 24415, 24419, 24420, 24416, 24438, 24439, 24440, 24430
9842, 24416, 24420, 24421, 24417, 24440, 24441, 24442, 24432
9843, 24417, 24421, 2397, 2396, 24442, 24443, 2400, 24434
9844, 2221, 2222, 24422, 24418, 2225, 24444, 24445, 24435
9845, 24418, 24422, 24423, 24419, 24445, 24446, 24447, 24437
9846, 24419, 24423, 24424, 24420, 24447, 24448, 24449, 24439
9847, 24420, 24424, 24425, 24421, 24449, 24450, 24451, 24441
9848, 24421, 24425, 2398, 2397, 24451, 24452, 2401, 24443
9849, 2222, 55, 2403, 24422, 2226, 2407, 24453, 24444
9850, 24422, 2403, 2404, 24423, 24453, 2408, 24454, 24446
9851, 24423, 2404, 2405, 24424, 24454, 2409, 24455, 24448
9852, 24424, 2405, 2406, 24425, 24455, 2410, 24456, 24450
9853, 24425, 2406, 60, 2398, 24456, 2411, 2402, 24452
*ELEMENT, type=CPS8, ELSET=Surface112
9854, 26, 1201, 24457, 2380, 1212, 24487, 24488, 2383
9855, 1201, 1200, 24458, 24457, 1211, 24489, 24490, 24487
9856, 1200, 1199, 24459, 24458, 1210, 24491, 24492, 24489
9857, 1199, 1198, 24460, 24459, 1209, 24493, 24494, 24491
9858, 1198, 1197, 24461, 24460, 1208, 24495, 24496, 24493
9859, 1197, 1196, 24462, 24461, 1207, 24497, 24498, 24495
9860, 1196, 1195, 24463, 24462, 1206, 24499, 24500, 24497
9861, 1195, 1194, 24464, 24463, 1205, 24501, 24502, 24499
9862, 1194, 1193, 24465, 24464, 1204, 24503, 24504, 24501
9863, 1193, 1192, 24466, 24465, 1203, 24505, 24506, 24503
9864, 1192, 28, 2396, 24466, 1202, 2399, 24507, 24505
9865, 2380, 24457, 24467, 2381, 24488, 24508, 24509, 2384
9866, 24457, 24458, 24468, 24467, 24490, 24510, 24511, 24508
9867, 24458, 24459, 24469, 24468, 24492, 24512, 24513, 24510
9868, 24459, 24460, 24470, 24469, 24494, 24514, 24515, 24512
9869, 24460, 24461, 24471, 24470, 24496, 24516, 24517, 24514
9870, 24461, 24462, 24472, 24471, 24498, 24518, 24519, 24516
9871, 24462, 24463, 24473, 24472, 24500, 24520, 24521, 24518
9872, 24463, 24464, 24474, 24473, 24502, 24522, 24523, 24520
9873, 24464, 24465, 24475, 24474, 24504, 24524, 24525, 24522
9874, 24465, 24466, 24476, 24475, 24506, 24526, 24527, 24524
9875, 24466, 2396, 2397, 24476, 24507, 2400, 24528, 24526
9876, 2381, 24467, 24477, 2382, 24509, 24529, 24530, 2385
9877, 24467, 24468, 24478, 24477, 24511, 24531, 24532, 24529
9878, 24468, 24469, 24479, 24478, 24513, 24533, 24534, 24531
9879, 24469, 24470, 24480, 24479, 24515, 24535, 24536, 24533
9880, 24470, 24471, 24481, 24480, 24517, 24537, 24538, 24535
9881, 24471, 24472, 24482, 24481, 24519, 24539, 24540, 24537
9882, 24472, 24473, 24483, 24482, 24521, 24541, 24542, 24539
9883, 24473, 24474, 24484, 24483, 24523, 24543, 24544, 24541
9884, 24474, 24475, 24485, 24484, 24525, 24545, 24546, 24543
9885, 24475, 24476, 24486, 24485, 24527, 24547, 24548, 24545
9886, 24476, 2397, 2398, 24486, 24528, 2401, 24549, 24547
9887, 2382, 24477, 2421, 59, 24530, 24550, 2432, 2386
9888, 24477, 24478, 2420, 2421, 24532, 24551, 2431, 24550
9889, 24478, 24479, 2419, 2420, 24534, 24552, 2430, 24551
9890, 24479, 24480, 2418, 2419, 24536, 24553, 2429, 24552
9891, 24480, 24481, 2417, 2418, 24538, 24554, 2428, 24553
9892, 24481, 24482, 2416, 2417, 24540, 24555, 2427, 24554
9893, 24482, 24483, 2415, 2416, 24542, 24556, 2426, 24555
9894, 24483, 24484, 2414, 2415, 24544, 24557, 2425, 24556
9895, 24484, 24485, 2413, 2414, 24546, 24558, 2424, 24557
9896, 24485, 24486, 2412, 2413, 24548, 24559, 2423, 24558
9897, 24486, 2398, 60, 2412, 24549, 2402, 2422, 24559
*ELEMENT, type=CPS8, ELSET=Surface113
9898, 57, 2387, 24560, 2295, 2391, 24600, 24601, 2306
9899, 2295, 24560, 24561, 2294, 24601, 24602, 24603, 2305
9900, 2294, 24561, 24562, 2293, 24603, 24604, 24605, 2304
9901, 2293, 24562, 24563, 2292, 24605, 24606, 24607, 2303
9902, 2292, 24563, 24564, 2291, 24607, 24608, 24609, 2302
9903, 2291, 24564, 24565, 2290, 24609, 24610, 24611, 2301
9904, 2290, 24565, 24566, 2289, 24611, 24612, 24613, 2300
9905, 2289, 24566, 24567, 2288, 24613, 24614, 24615, 2299
9906, 2288, 24567, 24568, 2287, 24615, 24616, 24617, 2298
9907, 2287, 24568, 24569, 2286, 24617, 24618, 24619, 2297
9908, 2286, 24569, 2403, 55, 24619, 24620, 2407, 2296
9909, 2387, 2388, 24570, 24560, 2392, 24621, 24622, 24600
9910, 24560, 24570, 24571, 24561, 24622, 24623, 24624, 24602
9911, 24561, 24571, 24572, 24562, 24624, 24625, 24626, 24604
9912, 24562, 24572, 24573, 24563, 24626, 24627, 24628, 24606
9913, 24563, 24573, 24574, 24564, 24628, 24629, 24630, 24608
9914, 24564, 24574, 24575, 24565, 24630, 24631, 24632, 24610
9915, 24565, 24575, 24576, 24566, 24632, 24633, 24634, 24612
9916, 24566, 24576, 24577, 24567, 24634, 24635, 24636, 24614
9917, 24567, 24577, 24578, 24568, 24636, 24637, 24638, 24616
9918, 24568, 24578, 24579, 24569, 24638, 24639, 24640, 24618
9919, 24569, 24579, 2404, 2403, 24640, 24641, 2408, 24620
9920, 2388, 2389, 24580, 24570, 2393, 24642, 24643, 24621
9921, 24570, 24580, 24581, 24571, 24643, 24644, 24645, 24623
9922, 24571, 24581, 24582, 24572, 24645, 24646, 24647, 24625
9923, 24572, 24582, 24583, 24573, 24647, 24648, 24649, 24627
9924, 24573, 24583, 24584, 24574, 24649, 24650, 24651, 24629
9925, 24574, 24584, 24585, 24575, 24651, 24652, 24653, 24631
9926, 24575, 24585, 24586, 24576, 24653, 24654, 24655, 24633
9927, 24576, 24586, 24587, 24577, 24655, 24656, 24657, 24635
9928, 24577, 24587, 24588, 24578, 24657, 24658, 24659, 24637
9929, 24578, 24588, 24589, 24579, 24659, 24660, 24661, 24639
9930, 24579, 24589, 2405, 2404, 24661, 24662, 2409, 24641
9931, 2389, 2390, 24590, 24580, 2394, 24663, 24664, 24642
9932, 24580, 24590, 24591, 24581, 24664, 24665, 24666, 24644
9933, 24581, 24591, 24592, 24582, 24666, 24667, 24668, 24646
9934, 24582, 24592, 24593, 24583, 24668, 24669, 24670, 24648
9935, 24583, 24593, 24594, 24584, 24670, 24671, 24672, 24650
9936, 24584, 24594, 24595, 24585, 24672, 24673, 24674, 24652
9937, 24585, 24595, 24596, 24586, 24674, 24675, 24676, 24654
9938, 24586, 24596, 24597, 24587, 24676, 24677, 24678, 24656
9939, 24587, 24597, 24598, 24588, 24678, 24679, 24680, 24658
9940, 24588, 24598, 24599, 24589, 24680, 24681, 24682, 24660
9941, 24589, 24599, 2406, 2405, 24682, 24683, 2410, 24662
9942, 2390, 59, 2421, 24590, 2395, 2432, 24684, 24663
9943, 24590, 2421, 2420, 24591, 24684, 2431, 24685, 24665
9944, 24591, 2420, 2419, 24592, 24685, 2430, 24686, 24667
9945, 24592, 2419, 2418, 24593, 24686, 2429, 24687, 24669
9946, 24593, 2418, 2417, 24594, 24687, 2428, 24688, 24671
9947, 24594, 2417, 2416, 24595, 24688, 2427, 24689, 24673
9948, 24595, 2416, 2415, 24596, 24689, 2426, 24690, 24675
9949, 24596, 2415, 2414, 24597, 24690, 2425, 24691, 24677
9950, 24597, 2414, 2413, 24598, 24691, 2424, 24692, 24679
9951, 24598, 2413, 2412, 24599, 24692, 2423, 24693, 24681
9952, 24599, 2412, 60, 2406, 24693, 2422, 2411, 24683
*ELEMENT, type=CPS8, ELSET=Surface114
9953, 26, 1258, 24694, 2380, 1280, 24760, 24761, 2383
9954, 1258, 1259, 24695, 24694, 1281, 24762, 24763, 24760
9955, 1259, 1260, 24696, 24695, 1282, 24764, 24765, 24762
9956, 1260, 1261, 24697, 24696, 1283, 24766, 24767, 24764
9957, 1261, 1262, 24698, 24697, 1284, 24768, 24769, 24766
9958, 1262, 1263, 24699, 24698, 1285, 24770, 24771, 24768
9959, 1263, 1264, 24700, 24699, 1286, 24772, 24773, 24770
9960, 1264, 1265, 24701, 24700, 1287, 24774, 24775, 24772
9961, 1265, 1266, 24702, 24701, 1288, 24776, 24777, 24774
9962, 1266, 1267, 24703, 24702, 1289, 24778, 24779, 24776
9963, 1267, 1268, 24704, 24703, 1290, 24780, 24781, 24778
9964, 1268, 1269, 24705, 24704, 1291, 24782, 24783, 24780
9965, 1269, 1270, 24706, 24705, 1292, 24784, 24785, 24782
9966, 1270, 1271, 24707, 24706, 1293, 24786, 24787, 24784
9967, 1271, 1272, 24708, 24707, 1294, 24788, 24789, 24786
9968, 1272, 1273, 24709, 24708, 1295, 24790, 24791, 24788
9969, 1273, 1274, 24710, 24709, 1296, 24792, 24793, 24790
9970, 1274, 1275, 24711, 24710, 1297, 24794, 24795, 24792
9971, 1275, 1276, 24712, 24711, 1298, 24796, 24797, 24794
9972, 1276, 1277, 24713, 24712, 1299, 24798, 24799, 24796
9973, 1277, 1278, 24714, 24713, 1300, 24800, 24801, 24798
9974, 1278, 1279, 24715, 24714, 1301, 24802, 24803, 24800
9975, 1279, 30, 2433, 24715, 1302, 2436, 24804, 24802
9976, 2380, 24694, 24716, 2381, 24761, 24805, 24806, 2384
9977, 24694, 24695, 24717, 24716, 24763, 24807, 24808, 24805
9978, 24695, 24696, 24718, 24717, 24765, 24809, 24810, 24807
9979, 24696, 24697, 24719, 24718, 24767, 24811, 24812, 24809
9980, 24697, 24698, 24720, 24719, 24769, 24813, 24814, 24811
9981, 24698, 24699, 24721, 24720, 24771, 24815, 24816, 24813
9982, 24699, 24700, 24722, 24721, 24773, 24817, 24818, 24815
9983, 24700, 24701, 24723, 24722, 24775, 24819, 24820, 24817
9984, 24701, 24702, 24724, 24723, 24777, 24821, 24822, 24819
9985, 24702, 24703, 24725, 24724, 24779, 24823, 24824, 24821
9986, 24703, 24704, 24726, 24725, 24781, 24825, 24826, 24823
9987, 24704, 24705, 24727, 24726, 24783, 24827, 24828, 24825
9988, 24705, 24706, 24728, 24727, 24785, 24829, 24830, 24827
9989, 24706, 24707, 24729, 24728, 24787, 24831, 24832, 24829
9990, 24707, 24708, 24730, 24729, 24789, 24833, 24834, 24831
9991, 24708, 24709, 24731, 24730, 24791, 24835, 24836, 24833
9992, 24709, 24710, 24732, 24731, 24793, 24837, 24838, 24835
9993, 24710, 24711, 24733, 24732, 24795, 24839, 24840, 24837
9994, 24711, 24712, 24734, 24733, 24797, 24841, 24842, 24839
9995, 24712, 24713, 24735, 24734, 24799, 24843, 24844, 24841
9996, 24713, 24714, 24736, 24735, 24801, 24845, 24846, 24843
9997, 24714, 24715, 24737, 24736, 24803, 24847, 24848, 24845
9998, 24715, 2433, 2434, 24737, 24804, 2437, 24849, 24847
9999, 2381, 24716, 24738, 2382, 24806, 24850, 24851, 2385
10000, 24716, 24717, 24739, 24738, 24808, 24852, 24853, 24850
10001, 24717, 24718, 24740, 24739, 24810, 24854, 24855, 24852
10002, 24718, 24719, 24741, 24740, 24812, 24856, 24857, 24854
10003, 24719, 24720, 24742, 24741, 24814, 24858, 24859, 24856
10004, 24720, 24721, 24743, 24742, 24816, 24860, 24861, 24858
10005, 24721, 24722, 24744, 24743, 24818, 24862, 24863, 24860
10006, 24722, 24723, 24745, 24744, 24820, 24864, 24865, 24862
10007, 24723, 24724, 24746, 24745, 24822, 24866, 24867, 24864
10008, 24724, 24725, 24747, 24746, 24824, 24868, 24869, 24866
10009, 24725, 24726, 24748, 24747, 24826, 24870, 24871, 24868
10010, 24726, 24727, 24749, 24748, 24828, 24872, 24873, 24870
10011, 24727, 24728, 24750, 24749, 24830, 24874, 24875, 24872
10012, 24728, 24729, 24751, 24750, 24832, 24876, 24877, 24874
10013, 24729, 24730, 24752, 24751, 24834, 24878, 24879, 24876
10014, 24730, 24731, 24753, 24752, 24836, 24880, 24881, 24878
10015, 24731, 24732, 24754, 24753, 24838, 24882, 24883, 24880
10016, 24732, 24733, 24755, 24754, 24840, 24884, 24885, 24882
10017, 24733, 24734, 24756, 24755, 24842, 24886, 24887, 24884
10018, 24734, 24735, 24757, 24756, 24844, 24888, 24889, 24886
10019, 24735, 24736, 24758, 24757, 24846, 24890, 24891, 24888
10020, 24736, 24737, 24759, 24758, 24848, 24892, 24893, 24890
10021, 24737, 2434, 2435, 24759, 24849, 2438, 24894, 24892
10022, 2382, 24738, 2440, 59, 24851, 24895, 2462, 2386
10023, 24738, 24739, 2441, 2440, 24853, 24896, 2463, 24895
10024, 24739, 24740, 2442, 2441, 24855, 24897, 2464, 24896
10025, 24740, 24741, 2443, 2442, 24857, 24898, 2465, 24897
10026, 24741, 24742, 2444, 2443, 24859, 24899, 2466, 24898
10027, 24742, 24743, 2445, 2444, 24861, 24900, 2467, 24899
10028, 24743, 24744, 2446, 2445, 24863, 24901, 2468, 24900
10029, 24744, 24745, 2447, 2446, 24865, 24902, 2469, 24901
10030, 24745, 24746, 2448, 2447, 24867, 24903, 2470, 24902
10031, 24746, 24747, 2449, 2448, 24869, 24904, 2471, 24903
10032, 24747, 24748, 2450, 2449, 24871, 24905, 2472, 24904
10033, 24748, 24749, 2451, 2450, 24873, 24906, 2473, 24905
10034, 24749, 24750, 2452, 2451, 24875, 24907, 2474, 24906
10035, 24750, 24751, 2453, 2452, 24877, 24908, 2475, 24907
10036, 24751, 24752, 2454, 2453, 24879, 24909, 2476, 24908
10037, 24752, 24753, 2455, 2454, 24881, 24910, 2477, 24909
10038, 24753, 24754, 2456, 2455, 24883, 24911, 2478, 24910
10039, 24754, 24755, 2457, 2456, 24885, 24912, 2479, 24911
10040, 24755, 24756, 2458, 2457, 24887, 24913, 2480, 24912
10041, 24756, 24757, 2459, 2458, 24889, 24914, 2481, 24913
10042, 24757, 24758, 2460, 2459, 24891, 24915, 2482, 24914
10043, 24758, 24759, 2461, 2460, 24893, 24916, 2483, 24915
10044, 24759, 2435, 61, 2461, 24894, 2439, 2484, 24916
*ELEMENT, type=CPS8, ELSET=Surface115
10045, 28, 2396, 24917, 1353, 2399, 24983, 24984, 1375
10046, 1353, 24917, 24918, 1354, 24984, 24985, 24986, 1376
10047, 1354, 24918, 24919, 1355, 24986, 24987, 24988, 1377
10048, 1355, 24919, 24920, 1356, 24988, 24989, 24990, 1378
10049, 1356, 24920, 24921, 1357, 24990, 24991, 24992, 1379
10050, 1357, 24921, 24922, 1358, 24992, 24993, 24994, 1380
10051, 1358, 24922, 24923, 1359, 24994, 24995, 24996, 1381
10052, 1359, 24923, 24924, 1360, 24996, 24997, 24998, 1382
10053, 1360, 24924, 24925, 1361, 24998, 24999, 25000, 1383
10054, 1361, 24925, 24926, 1362, 25000, 25001, 25002, 1384
10055, 1362, 24926, 24927, 1363, 25002, 25003, 25004, 1385
10056, 1363, 24927, 24928, 1364, 25004, 25005, 25006, 1386
10057, 1364, 24928, 24929, 1365, 25006, 25007, 25008, 1387
10058, 1365, 24929, 24930, 1366, 25008, 25009, 25010, 1388
10059, 1366, 24930, 24931, 1367, 25010, 25011, 25012, 1389
10060, 1367, 24931, 24932, 1368, 25012, 25013, 25014, 1390
10061, 1368, 24932, 24933, 1369, 25014, 25015, 25016, 1391
10062, 1369, 24933, 24934, 1370, 25016, 25017, 25018, 1392
10063, 1370, 24934, 24935, 1371, 25018, 25019, 25020, 1393
10064, 1371, 24935, 24936, 1372, 25020, 25021, 25022, 1394
10065, 1372, 24936, 24937, 1373, 25022, 25023, 25024, 1395
10066, 1373, 24937, 24938, 1374, 25024, 25025, 25026, 1396
10067, 1374, 24938, 2485, 32, 25026, 25027, 2488, 1397
10068, 2396, 2397, 24939, 24917, 2400, 25028, 25029, 24983
10069, 24917, 24939, 24940, 24918, 25029, 25030, 25031, 24985
10070, 24918, 24940, 24941, 24919, 25031, 25032, 25033, 24987
10071, 24919, 24941, 24942, 24920, 25033, 25034, 25035, 24989
10072, 24920, 24942, 24943, 24921, 25035, 25036, 25037, 24991
10073, 24921, 24943, 24944, 24922, 25037, 25038, 25039, 24993
10074, 24922, 24944, 24945, 24923, 25039, 25040, 25041, 24995
10075, 24923, 24945, 24946, 24924, 25041, 25042, 25043, 24997
10076, 24924, 24946, 24947, 24925, 25043, 25044, 25045, 24999
10077, 24925, 24947, 24948, 24926, 25045, 25046, 25047, 25001
10078, 24926, 24948, 24949, 24927, 25047, 25048, 25049, 25003
10079, 24927, 24949, 24950, 24928, 25049, 25050, 25051, 25005
10080, 24928, 24950, 24951, 24929, 25051, 25052, 25053, 25007
10081, 24929, 24951, 24952, 24930, 25053, 25054, 25055, 25009
10082, 24930, 24952, 24953, 24931, 25055, 25056, 25057, 25011
10083, 24931, 24953, 24954, 24932, 25057, 25058, 25059, 25013
10084, 24932, 24954, 24955, 24933, 25059, 25060, 25061, 25015
10085, 24933, 24955, 24956, 24934, 25061, 25062, 25063, 25017
10086, 24934, 24956, 24957, 24935, 25063, 25064, 25065, 25019
10087, 24935, 24957, 24958, 24936, 25065, 25066, 25067, 25021
10088, 24936, 24958, 24959, 24937, 25067, 25068, 25069, 25023
10089, 24937, 24959, 24960, 24938, 25069, 25070, 25071, 25025
10090, 24938, 24960, 2486, 2485, 25071, 25072, 2489, 25027
10091, 2397, 2398, 24961, 24939, 2401, 25073, 25074, 25028
10092, 24939, 24961, 24962, 24940, 25074, 25075, 25076, 25030
10093, 24940, 24962, 24963, 24941, 25076, 25077, 25078, 25032
10094, 24941, 24963, 24964, 24942, 25078, 25079, 25080, 25034
10095, 24942, 24964, 24965, 24943, 25080, 25081, 25082, 25036
10096, 24943, 24965, 24966, 24944, 25082, 25083, 25084, 25038
10097, 24944, 24966, 24967, 24945, 25084, 25085, 25086, 25040
10098, 24945, 24967, 24968, 24946, 25086, 25087, 25088, 25042
10099, 24946, 24968, 24969, 24947, 25088, 25089, 25090, 25044
10100, 24947, 24969, 24970, 24948, 25090, 25091, 25092, 25046
10101, 24948, 24970, 24971, 24949, 25092, 25093, 25094, 25048
10102, 24949, 24971, 24972, 24950, 25094, 25095, 25096, 25050
10103, 24950, 24972, 24973, 24951, 25096, 25097, 25098, 25052
10104, 24951, 24973, 24974, 24952, 25098, 25099, 25100, 25054
10105, 24952, 24974, 24975, 24953, 25100, 25101, 25102, 25056
10106, 24953, 24975, 24976, 24954, 25102, 25103, 25104, 25058
10107, 24954, 24976, 24977, 24955, 25104, 25105, 25106, 25060
10108, 24955, 24977, 24978, 24956, 25106, 25107, 25108, 25062
10109, 24956, 24978, 24979, 24957, 25108, 25109, 25110, 25064
10110, 24957, 24979, 24980, 24958, 25110, 25111, 25112, 25066
10111, 24958, 24980, 24981, 24959, 25112, 25113, 25114, 25068
10112, 24959, 24981, 24982, 24960, 25114, 25115, 25116, 25070
10113, 24960, 24982, 2487, 2486, 25116, 25117, 2490, 25072
10114, 2398, 60, 2492, 24961, 2402, 2514, 25118, 25073
10115, 24961, 2492, 2493, 24962, 25118, 2515, 25119, 25075
10116, 24962, 2493, 2494, 24963, 25119, 2516, 25120, 25077
10117, 24963, 2494, 2495, 24964, 25120, 2517, 25121, 25079
10118, 24964, 2495, 2496, 24965, 25121, 2518, 25122, 25081
10119, 24965, 2496, 2497, 24966, 25122, 2519, 25123, 25083
10120, 24966, 2497, 2498, 24967, 25123, 2520, 25124, 25085
10121, 24967, 2498, 2499, 24968, 25124, 2521, 25125, 25087
10122, 24968, 2499, 2500, 24969, 25125, 2522, 25126, 25089
10123, 24969, 2500, 2501, 24970, 25126, 2523, 25127, 25091
10124, 24970, 2501, 2502, 24971, 25127, 2524, 25128, 25093
10125, 24971, 2502, 2503, 24972, 25128, 2525, 25129, 25095
10126, 24972, 2503, 2504, 24973, 25129, 2526, 25130, 25097
10127, 24973, 2504, 2505, 24974, 25130, 2527, 25131, 25099
10128, 24974, 2505, 2506, 24975, 25131, 2528, 25132, 25101
10129, 24975, 2506, 2507, 24976, 25132, 2529, 25133, 25103
10130, 24976, 2507, 2508, 24977, 25133, 2530, 25134, 25105
10131, 24977, 2508, 2509, 24978, 25134, 2531, 25135, 25107
10132, 24978, 2509, 2510, 24979, 25135, 2532, 25136, 25109
10133, 24979, 2510, 2511, 24980, 25136, 2533, 25137, 25111
10134, 24980, 2511, 2512, 24981, 25137, 2534, 25138, 25113
10135, 24981, 2512, 2513, 24982, 25138, 2535, 25139, 25115
10136, 24982, 2513, 62, 2487, 25139, 2536, 2491, 25117
*ELEMENT, type=CPS8, ELSET=Surface116
10137, 30, 1433, 25140, 2433, 1444, 25170, 25171, 2436
10138, 1433, 1432, 25141, 25140, 1443, 25172, 25173, 25170
10139, 1432, 1431, 25142, 25141, 1442, 25174, 25175, 25172
10140, 1431, 1430, 25143, 25142, 1441, 25176, 25177, 25174
10141, 1430, 1429, 25144, 25143, 1440, 25178, 25179, 25176
10142, 1429, 1428, 25145, 25144, 1439, 25180, 25181, 25178
10143, 1428, 1427, 25146, 25145, 1438, 25182, 25183, 25180
10144, 1427, 1426, 25147, 25146, 1437, 25184, 25185, 25182
10145, 1426, 1425, 25148, 25147, 1436, 25186, 25187, 25184
10146, 1425, 1424, 25149, 25148, 1435, 25188, 25189, 25186
10147, 1424, 32, 2485, 25149, 1434, 2488, 25190, 25188
10148, 2433, 25140, 25150, 2434, 25171, 25191, 25192, 2437
10149, 25140, 25141, 25151, 25150, 25173, 25193, 25194, 25191
10150, 25141, 25142, 25152, 25151, 25175, 25195, 25196, 25193
10151, 25142, 25143, 25153, 25152, 25177, 25197, 25198, 25195
10152, 25143, 25144, 25154, 25153, 25179, 25199, 25200, 25197
10153, 25144, 25145, 25155, 25154, 25181, 25201, 25202, 25199
10154, 25145, 25146, 25156, 25155, 25183, 25203, 25204, 25201
10155, 25146, 25147, 25157, 25156, 25185, 25205, 25206, 25203
10156, 25147, 25148, 25158, 25157, 25187, 25207, 25208, 25205
10157, 25148, 25149, 25159, 25158, 25189, 25209, 25210, 25207
10158, 25149, 2485, 2486, 25159, 25190, 2489, 25211, 25209
10159, 2434, 25150, 25160, 2435, 25192, 25212, 25213, 2438
10160, 25150, 25151, 25161, 25160, 25194, 25214, 25215, 25212
10161, 25151, 25152, 25162, 25161, 25196, 25216, 25217, 25214
10162, 25152, 25153, 25163, 25162, 25198, 25218, 25219, 25216
10163, 25153, 25154, 25164, 25163, 25200, 25220, 25221, 25218
10164, 25154, 25155, 25165, 25164, 25202, 25222, 25223, 25220
10165, 25155, 25156, 25166, 25165, 25204, 25224, 25225, 25222
10166, 25156, 25157, 25167, 25166, 25206, 25226, 25227, 25224
10167, 25157, 25158, 25168, 25167, 25208, 25228, 25229, 25226
10168, 25158, 25159, 25169, 25168, 25210, 25230, 25231, 25228
10169, 25159, 2486, 2487, 25169, 25211, 2490, 25232, 25230
10170, 2435, 25160, 2546, 61, 25213, 25233, 2557, 2439
10171, 25160, 25161, 2545, 2546, 25215, 25234, 2556, 25233
10172, 25161, 25162, 2544, 2545, 25217, 25235, 2555, 25234
10173, 25162, 25163, 2543, 2544, 25219, 25236, 2554, 25235
10174, 25163, 25164, 2542, 2543, 25221, 25237, 2553, 25236
10175, 25164, 25165, 2541, 2542, 25223, 25238, 2552, 25237
10176, 25165, 25166, 2540, 2541, 25225, 25239, 2551, 25238
10177, 25166, 25167, 2539, 2540, 25227, 25240, 2550, 25239
10178, 25167, 25168, 2538, 2539, 25229, 25241, 2549, 25240
10179, 25168, 25169, 2537, 2538, 25231, 25242, 2548, 25241
10180, 25169, 2487, 62, 2537, 25232, 2491, 2547, 25242
*ELEMENT, type=CPS8, ELSET=Surface117
10181, 59, 2440, 25243, 2421, 2462, 25463, 25464, 2432
10182, 2421, 25243, 25244, 2420, 25464, 25465, 25466, 2431
10183, 2420, 25244, 25245, 2419, 25466, 25467, 25468, 2430
10184, 2419, 25245, 25246, 2418, 25468, 25469, 25470, 2429
10185, 2418, 25246, 25247, 2417, 25470, 25471, 25472, 2428
10186, 2417, 25247, 25248, 2416, 25472, 25473, 25474, 2427
10187, 2416, 25248, 25249, 2415, 25474, 25475, 25476, 2426
10188, 2415, 25249, 25250, 2414, 25476, 25477, 25478, 2425
10189, 2414, 25250, 25251, 2413, 25478, 25479, 25480, 2424
10190, 2413, 25251, 25252, 2412, 25480, 25481, 25482, 2423
10191, 2412, 25252, 2492, 60, 25482, 25483, 2514, 2422
10192, 2440, 2441, 25253, 25243, 2463, 25484, 25485, 25463
10193, 25243, 25253, 25254, 25244, 25485, 25486, 25487, 25465
10194, 25244, 25254, 25255, 25245, 25487, 25488, 25489, 25467
10195, 25245, 25255, 25256, 25246, 25489, 25490, 25491, 25469
10196, 25246, 25256, 25257, 25247, 25491, 25492, 25493, 25471
10197, 25247, 25257, 25258, 25248, 25493, 25494, 25495, 25473
10198, 25248, 25258, 25259, 25249, 25495, 25496, 25497, 25475
10199, 25249, 25259, 25260, 25250, 25497, 25498, 25499, 25477
10200, 25250, 25260, 25261, 25251, 25499, 25500, 25501, 25479
10201, 25251, 25261, 25262, 25252, 25501, 25502, 25503, 25481
10202, 25252, 25262, 2493, 2492, 25503, 25504, 2515, 25483
10203, 2441, 2442, 25263, 25253, 2464, 25505, 25506, 25484
10204, 25253, 25263, 25264, 25254, 25506, 25507, 25508, 25486
10205, 25254, 25264, 25265, 25255, 25508, 25509, 25510, 25488
10206, 25255, 25265, 25266, 25256, 25510, 25511, 25512, 25490
10207, 25256, 25266, 25267, 25257, 25512, 25513, 25514, 25492
10208, 25257, 25267, 25268, 25258, 25514, 25515, 25516, 25494
10209, 25258, 25268, 25269, 25259, 25516, 25517, 25518, 25496
10210, 25259, 25269, 25270, 25260, 25518, 25519, 25520, 25498
10211, 25260, 25270, 25271, 25261, 25520, 25521, 25522, 25500
10212, 25261, 25271, 25272, 25262, 25522, 25523, 25524, 25502
10213, 25262, 25272, 2494, 2493, 25524, 25525, 2516, 25504
10214, 2442, 2443, 25273, 25263, 2465, 25526, 25527, 25505
10215, 25263, 25273, 25274, 25264, 25527, 25528, 25529, 25507
10216, 25264, 25274, 25275, 25265, 25529, 25530, 25531, 25509
10217, 25265, 25275, 25276, 25266, 25531, 25532, 25533, 25511
10218, 25266, 25276, 25277, 25267, 25533, 25534, 25535, 25513
10219, 25267, 25277, 25278, 25268, 25535, 25536, 25537, 25515
10220, 25268, 25278, 25279, 25269, 25537, 25538, 25539, 25517
10221, 25269, 25279, 25280, 25270, 25539, 25540, 25541, 25519
10222, 25270, 25280, 25281, 25271, 25541, 25542, 25543, 25521
10223, 25271, 25281, 25282, 25272, 25543, 25544, 25545, 25523
10224, 25272, 25282, 2495, 2494, 25545, 25546, 2517, 25525
10225, 2443, 2444, 25283, 25273, 2466, 25547, 25548, 25526
10226, 25273, 25283, 25284, 25274, 25548, 25549, 25550, 25528
10227, 25274, 25284, 25285, 25275, 25550, 25551, 25552, 25530
10228, 25275, 25285, 25286, 25276, 25552, 25553, 25554, 25532
10229, 25276, 25286, 25287, 25277, 25554, 25555, 25556, 25534
10230, 25277, 25287, 25288, 25278, 25556, 25557, 25558, 25536
10231, 25278, 25288, 25289, 25279, 25558, 25559, 25560, 25538
10232, 25279, 25289, 25290, 25280, 25560, 25561, 25562, 25540
10233, 25280, 25290, 25291, 25281, 25562, 25563, 25564, 25542
10234, 25281, 25291, 25292, 25282, 25564, 25565, 25566, 25544
10235, 25282, 25292, 2496, 2495, 25566, 25567, 2518, 25546
10236, 2444, 2445, 25293, 25283, 2467, 25568, 25569, 25547
10237, 25283, 25293, 25294, 25284, 25569, 25570, 25571, 25549
10238, 25284, 25294, 25295, 25285, 25571, 25572, 25573, 25551
10239, 25285, 25295, 25296, 25286, 25573, 25574, 25575, 25553
10240, 25286, 25296, 25297, 25287, 25575, 25576, 25577, 25555
10241, 25287, 25297, 25298, 25288, 25577, 25578, 25579, 25557
10242, 25288, 25298, 25299, 25289, 25579, 25580, 25581, 25559
10243, 25289, 25299, 25300, 25290, 25581, 25582, 25583, 25561
10244, 25290, 25300, 25301, 25291, 25583, 25584, 25585, 25563
10245, 25291, 25301, 25302, 25292, 25585, 25586, 25587, 25565
10246, 25292, 25302, 2497, 2496, 25587, 25588, 2519, 25567
10247, 2445, 2446, 25303, 25293, 2468, 25589, 25590, 25568
10248, 25293, 25303, 25304, 25294, 25590, 25591, 25592, 25570
10249, 25294, 25304, 25305, 25295, 25592, 25593, 25594, 25572
10250, 25295, 25305, 25306, 25296, 25594, 25595, 25596, 25574
10251, 25296, 25306, 25307, 25297, 25596, 25597, 25598, 25576
10252, 25297, 25307, 25308, 25298, 25598, 25599, 25600, 25578
10253, 25298, 25308, 25309, 25299, 25600, 25601, 25602, 25580
10254, 25299, 25309, 25310, 25300, 25602, 25603, 25604, 25582
10255, 25300, 25310, 25311, 25301, 25604, 25605, 25606, 25584
10256, 25301, 25311, 25312, 25302, 25606, 25607, 25608, 25586
10257, 25302, 25312, 2498, 2497, 25608, 25609, 2520, 25588
10258, 2446, 2447, 25313, 25303, 2469, 25610, 25611, 25589
10259, 25303, 25313, 25314, 25304, 25611, 25612, 25613, 25591
10260, 25304, 25314, 25315, 25305, 25613, 25614, 25615, 25593
10261, 25305, 25315, 25316, 25306, 25615, 25616, 25617, 25595
10262, 25306, 25316, 25317, 25307, 25617, 25618, 25619, 25597
10263, 25307, 25317, 25318, 25308, 25619, 25620, 25621, 25599
10264, 25308, 25318, 25319, 25309, 25621, 25622, 25623, 25601
10265, 25309, 25319, 25320, 25310, 25623, 25624, 25625, 25603
10266, 25310, 25320, 25321, 25311, 25625, 25626, 25627, 25605
10267, 25311, 25321, 25322, 25312, 25627, 25628, 25629, 25607
10268, 25312, 25322, 2499, 2498, 25629, 25630, 2521, 25609
10269, 2447, 2448, 25323, 25313, 2470, 25631, 25632, 25610
10270, 25313, 25323, 25324, 25314, 25632, 25633, 25634, 25612
10271, 25314, 25324, 25325, 25315, 25634, 25635, 25636, 25614
10272, 25315, 25325, 25326, 25316, 25636, 25637, 25638, 25616
10273, 25316, 25326, 25327, 25317, 25638, 25639, 25640, 25618
10274, 25317, 25327, 25328, 25318, 25640, 25641, 25642, 25620
10275, 25318, 25328, 25329, 25319, 25642, 25643, 25644, 25622
10276, 25319, 25329, 25330, 25320, 25644, 25645, 25646, 25624
10277, 25320, 25330, 25331, 25321, 25646, 25647, 25648, 25626
10278, 25321, 25331, 25332, 25322, 25648, 25649, 25650, 25628
10279, 25322, 25332, 2500, 2499, 25650, 25651, 2522, 25630
10280, 2448, 2449, 25333, 25323, 2471, 25652, 25653, 25631
10281, 25323, 25333, 25334, 25324, 25653, 25654, 25655, 25633
10282, 25324, 25334, 25335, 25325, 25655, 25656, 25657, 25635
10283, 25325, 25335, 25336, 25326, 25657, 25658, 25659, 25637
10284, 25326, 25336, 25337, 25327, 25659, 25660, 25661, 25639
10285, 25327, 25337, 25338, 25328, 25661, 25662, 25663, 25641
10286, 25328, 25338, 25339, 25329, 25663, 25664, 25665, 25643
10287, 25329, 25339, 25340, 25330, 25665, 25666, 25667, 25645
10288, 25330, 25340, 25341, 25331, 25667, 25668, 25669, 25647
10289, 25331, 25341, 25342, 25332, 25669, 25670, 25671, 25649
10290, 25332, 25342, 2501, 2500, 25671, 25672, 2523, 25651
10291, 2449, 2450, 25343, 25333, 2472, 25673, 25674, 25652
10292, 25333, 25343, 25344, 25334, 25674, 25675, 25676, 25654
10293, 25334, 25344, 25345, 25335, 25676, 25677, 25678, 25656
10294, 25335, 25345, 25346, 25336, 25678, 25679, 25680, 25658
10295, 25336, 25346, 25347, 25337, 25680, 25681, 25682, 25660
10296, 25337, 25347, 25348, 25338, 25682, 25683, 25684, 25662
10297, 25338, 25348, 25349, 25339, 25684, 25685, 25686, 25664
10298, 25339, 25349, 25350, 25340, 25686, 25687, 25688, 25666
10299, 25340, 25350, 25351, 25341, 25688, 25689, 25690, 25668
10300, 25341, 25351, 25352, 25342, 25690, 25691, 25692, 25670
10301, 25342, 25352, 2502, 2501, 25692, 25693, 2524, 25672
10302, 2450, 2451, 25353, 25343, 2473, 25694, 25695, 25673
10303, 25343, 25353, 25354, 25344, 25695, 25696, 25697, 25675
10304, 25344, 25354, 25355, 25345, 25697, 25698, 25699, 25677
10305, 25345, 25355, 25356, 25346, 25699, 25700, 25701, 25679
10306, 25346, 25356, 25357, 25347, 25701, 25702, 25703, 25681
10307, 25347, 25357, 25358, 25348, 25703, 25704, 25705, 25683
10308, 25348, 25358, 25359, 25349, 25705, 25706, 25707, 25685
10309, 25349, 25359, 25360, 25350, 25707, 25708, 25709, 25687
10310, 25350, 25360, 25361, 25351, 25709, 25710, 25711, 25689
10311, 25351, 25361, 25362, 25352, 25711, 25712, 25713, 25691
10312, 25352, 25362, 2503, 2502, 25713, 25714, 2525, 25693
10313, 2451, 2452, 25363, 25353, 2474, 25715, 25716, 25694
10314, 25353, 25363, 25364, 25354, 25716, 25717, 25718, 25696
10315, 25354, 25364, 25365, 25355, 25718, 25719, 25720, 25698
10316, 25355, 25365, 25366, 25356, 25720, 25721, 25722, 25700
10317, 25356, 25366, 25367, 25357, 25722, 25723, 25724, 25702
10318, 25357, 25367, 25368, 25358, 25724, 25725, 25726, 25704
10319, 25358, 25368, 25369, 25359, 25726, 25727, 25728, 25706
10320, 25359, 25369, 25370, 25360, 25728, 25729, 25730, 25708
10321, 25360, 25370, 25371, 25361, 25730, 25731, 25732, 25710
10322, 25361, 25371, 25372, 25362, 25732, 25733, 25734, 25712
10323, 25362, 25372, 2504, 2503, 25734, 25735, 2526, 25714
10324, 2452, 2453, 25373, 25363, 2475, 25736, 25737, 25715
10325, 25363, 25373, 25374, 25364, 25737, 25738, 25739, 25717
10326, 25364, 25374, 25375, 25365, 25739, 25740, 25741, 25719
10327, 25365, 25375, 25376, 25366, 25741, 25742, 25743, 25721
10328, 25366, 25376, 25377, 25367, 25743, 25744, 25745, 25723
10329, 25367, 25377, 25378, 25368, 25745, 25746, 25747, 25725
10330, 25368, 25378, 25379, 25369, 25747, 25748, 25749, 25727
10331, 25369, 25379, 25380, 25370, 25749, 25750, 25751, 25729
10332, 25370, 25380, 25381, 25371, 25751, 25752, 25753, 25731
10333, 25371, 25381, 25382, 25372, 25753, 25754, 25755, 25733
10334, 25372, 25382, 2505, 2504, 25755, 25756, 2527, 25735
10335, 2453, 2454, 25383, 25373, 2476, 25757, 25758, 25736
10336, 25373, 25383, 25384, 25374, 25758, 25759, 25760, 25738
10337, 25374, 25384, 25385, 25375, 25760, 25761, 25762, 25740
10338, 25375, 25385, 25386, 25376, 25762, 25763, 25764, 25742
10339, 25376, 25386, 25387, 25377, 25764, 25765, 25766, 25744
10340, 25377, 25387, 25388, 25378, 25766, 25767, 25768, 25746
10341, 25378, 25388, 25389, 25379, 25768, 25769, 25770, 25748
10342, 25379, 25389, 25390, 25380, 25770, 25771, 25772, 25750
10343, 25380, 25390, 25391, 25381, 25772, 25773, 25774, 25752
10344, 25381, 25391, 25392, 25382, 25774, 25775, 25776, 25754
10345, 25382, 25392, 2506, 2505, 25776, 25777, 2528, 25756
10346, 2454, 2455, 25393, 25383, 2477, 25778, 25779, 25757
10347, 25383, 25393, 25394, 25384, 25779, 25780, 25781, 25759
10348, 25384, 25394, 25395, 25385, 25781, 25782, 25783, 25761
10349, 25385, 25395, 25396, 25386, 25783, 25784, 25785, 25763
10350, 25386, 25396, 25397, 25387, 25785, 25786, 25787, 25765
10351, 25387, 25397, 25398, 25388, 25787, 25788, 25789, 25767
10352, 25388, 25398, 25399, 25389, 25789, 25790, 25791, 25769
10353, 25389, 25399, 25400, 25390, 25791, 25792, 25793, 25771
10354, 25390, 25400, 25401, 25391, 25793, 25794, 25795, 25773
10355, 25391, 25401, 25402, 25392, 25795, 25796, 25797, 25775
10356, 25392, 25402, 2507, 2506, 25797, 25798, 2529, 25777
10357, 2455, 2456, 25403, 25393, 2478, 25799, 25800, 25778
10358, 25393, 25403, 25404, 25394, 25800, 25801, 25802, 25780
10359, 25394, 25404, 25405, 25395, 25802, 25803, 25804, 25782
10360, 25395, 25405, 25406, 25396, 25804, 25805, 25806, 25784
10361, 25396, 25406, 25407, 25397, 25806, 25807, 25808, 25786
10362, 25397, 25407, 25408, 25398, 25808, 25809, 25810, 25788
10363, 25398, 25408, 25409, 25399, 25810, 25811, 25812, 25790
10364, 25399, 25409, 25410, 25400, 25812, 25813, 25814, 25792
10365, 25400, 25410, 25411, 25401, 25814, 25815, 25816, 25794
10366, 25401, 25411, 25412, 25402, 25816, 25817, 25818, 25796
10367, 25402, 25412, 2508, 2507, 25818, 25819, 2530, 25798
10368, 2456, 2457, 25413, 25403, 2479, 25820, 25821, 25799
10369, 25403, 25413, 25414, 25404, 25821, 25822, 25823, 25801
10370, 25404, 25414, 25415, 25405, 25823, 25824, 25825, 25803
10371, 25405, 25415, 25416, 25406, 25825, 25826, 25827, 25805
10372, 25406, 25416, 25417, 25407, 25827, 25828, 25829, 25807
10373, 25407, 25417, 25418, 25408, 25829, 25830, 25831, 25809
10374, 25408, 25418, 25419, 25409, 25831, 25832, 25833, 25811
10375, 25409, 25419, 25420, 25410, 25833, 25834, 25835, 25813
10376, 25410, 25420, 25421, 25411, 25835, 25836, 25837, 25815
10377, 25411, 25421, 25422, 25412, 25837, 25838, 25839, 25817
10378, 25412, 25422, 2509, 2508, 25839, 25840, 2531, 25819
10379, 2457, 2458, 25423, 25413, 2480, 25841, 25842, 25820
10380, 25413, 25423, 25424, 25414, 25842, 25843, 25844, 25822
10381, 25414, 25424, 25425, 25415, 25844, 25845, 25846, 25824
10382, 25415, 25425, 25426, 25416, 25846, 25847, 25848, 25826
10383, 25416, 25426, 25427, 25417, 25848, 25849, 25850, 25828
10384, 25417, 25427, 25428, 25418, 25850, 25851, 25852, 25830
10385, 25418, 25428, 25429, 25419, 25852, 25853, 25854, 25832
10386, 25419, 25429, 25430, 25420, 25854, 25855, 25856, 25834
10387, 25420, 25430, 25431, 25421, 25856, 25857, 25858, 25836
10388, 25421, 25431, 25432, 25422, 25858, 25859, 25860, 25838
10389, 25422, 25432, 2510, 2509, 25860, 25861, 2532, 25840
10390, 2458, 2459, 25433, 25423, 2481, 25862, 25863, 25841
10391, 25423, 25433, 25434, 25424, 25863, 25864, 25865, 25843
10392, 25424, 25434, 25435, 25425, 25865, 25866, 25867, 25845
10393, 25425, 25435, 25436, 25426, 25867, 25868, 25869, 25847
10394, 25426, 25436, 25437, 25427, 25869, 25870, 25871, 25849
10395, 25427, 25437, 25438, 25428, 25871, 25872, 25873, 25851
10396, 25428, 25438, 25439, 25429, 25873, 25874, 25875, 25853
10397, 25429, 25439, 25440, 25430, 25875, 25876, 25877, 25855
10398, 25430, 25440, 25441, 25431, 25877, 25878, 25879, 25857
10399, 25431, 25441, 25442, 25432, 25879, 25880, 25881, 25859
10400, 25432, 25442, 2511, 2510, 25881, 25882, 2533, 25861
10401, 2459, 2460, 25443, 25433, 2482, 25883, 25884, 25862
10402, 25433, 25443, 25444, 25434, 25884, 25885, 25886, 25864
10403, 25434, 25444, 25445, 25435, 25886, 25887, 25888, 25866
10404, 25435, 25445, 25446, 25436, 25888, 25889, 25890, 25868
10405, 25436, 25446, 25447, 25437, 25890, 25891, 25892, 25870
10406, 25437, 25447, 25448, 25438, 25892, 25893, 25894, 25872
10407, 25438, 25448, 25449, 25439, 25894, 25895, 25896, 25874
10408, 25439, 25449, 25450, 25440, 25896, 25897, 25898, 25876
10409, 25440, 25450, 25451, 25441, 25898, 25899, 25900, 25878
10410, 25441, 25451, 25452, 25442, 25900, 25901, 25902, 25880
10411, 25442, 25452, 2512, 2511, 25902, 25903, 2534, 25882
10412, 2460, 2461, 25453, 25443, 2483, 25904, 25905, 25883
10413, 25443, 25453, 25454, 25444, 25905, 25906, 25907, 25885
10414, 25444, 25454, 25455, 25445, 25907, 25908, 25909, 25887
10415, 25445, 25455, 25456, 25446, 25909, 25910, 25911, 25889
10416, 25446, 25456, 25457, 25447, 25911, 25912, 25913, 25891
10417, 25447, 25457, 25458, 25448, 25913, 25914, 25915, 25893
10418, 25448, 25458, 25459, 25449, 25915, 25916, 25917, 25895
10419, 25449, 25459, 25460, 25450, 25917, 25918, 25919, 25897
10420, 25450, 25460, 25461, 25451, 25919, 25920, 25921, 25899
10421, 25451, 25461, 25462, 25452, 25921, 25922, 25923, 25901
10422, 25452, 25462, 2513, 2512, 25923, 25924, 2535, 25903
10423, 2461, 61, 2546, 25453, 2484, 2557, 25925, 25904
10424, 25453, 2546, 2545, 25454, 25925, 2556, 25926, 25906
10425, 25454, 2545, 2544, 25455, 25926, 2555, 25927, 25908
10426, 25455, 2544, 2543, 25456, 25927, 2554, 25928, 25910
10427, 25456, 2543, 2542, 25457, 25928, 2553, 25929, 25912
10428, 25457, 2542, 2541, 25458, 25929, 2552, 25930, 25914
10429, 25458, 2541, 2540, 25459, 25930, 2551, 25931, 25916
10430, 25459, 2540, 2539, 25460, 25931, 2550, 25932, 25918
10431, 25460, 2539, 2538, 25461, 25932, 2549, 25933, 25920
10432, 25461, 2538, 2537, 25462, 25933, 2548, 25934, 25922
10433, 25462, 2537, 62, 2513, 25934, 2547, 2536, 25924
*ELEMENT, type=CPS8, ELSET=Surface118
10434, 6, 2558, 25935, 214, 2561, 26001, 26002, 237
10435, 214, 25935, 25936, 213, 26002, 26003, 26004, 236
10436, 213, 25936, 25937, 212, 26004, 26005, 26006, 235
10437, 212, 25937, 25938, 211, 26006, 26007, 26008, 234
10438, 211, 25938, 25939, 210, 26008, 26009, 26010, 233
10439, 210, 25939, 25940, 209, 26010, 26011, 26012, 232
10440, 209, 25940, 25941, 208, 26012, 26013, 26014, 231
10441, 208, 25941, 25942, 207, 26014, 26015, 26016, 230
10442, 207, 25942, 25943, 206, 26016, 26017, 26018, 229
10443, 206, 25943, 25944, 205, 26018, 26019, 26020, 228
10444, 205, 25944, 25945, 204, 26020, 26021, 26022, 227
10445, 204, 25945, 25946, 203, 26022, 26023, 26024, 226
10446, 203, 25946, 25947, 202, 26024, 26025, 26026, 225
10447, 202, 25947, 25948, 201, 26026, 26027, 26028, 224
10448, 201, 25948, 25949, 200, 26028, 26029, 26030, 223
10449, 200, 25949, 25950, 199, 26030, 26031, 26032, 222
10450, 199, 25950, 25951, 198, 26032, 26033, 26034, 221
10451, 198, 25951, 25952, 197, 26034, 26035, 26036, 220
10452, 197, 25952, 25953, 196, 26036, 26037, 26038, 219
10453, 196, 25953, 25954, 195, 26038, 26039, 26040, 218
10454, 195, 25954, 25955, 194, 26040, 26041, 26042, 217
10455, 194, 25955, 25956, 193, 26042, 26043, 26044, 216
10456, 193, 25956, 2565, 2, 26044, 26045, 2568, 215
10457, 2558, 2559, 25957, 25935, 2562, 26046, 26047, 26001
10458, 25935, 25957, 25958, 25936, 26047, 26048, 26049, 26003
10459, 25936, 25958, 25959, 25937, 26049, 26050, 26051, 26005
10460, 25937, 25959, 25960, 25938, 26051, 26052, 26053, 26007
10461, 25938, 25960, 25961, 25939, 26053, 26054, 26055, 26009
10462, 25939, 25961, 25962, 25940, 26055, 26056, 26057, 26011
10463, 25940, 25962, 25963, 25941, 26057, 26058, 26059, 26013
10464, 25941, 25963, 25964, 25942, 26059, 26060, 26061, 26015
10465, 25942, 25964, 25965, 25943, 26061, 26062, 26063, 26017
10466, 25943, 25965, 25966, 25944, 26063, 26064, 26065, 26019
10467, 25944, 25966, 25967, 25945, 26065, 26066, 26067, 26021
10468, 25945, 25967, 25968, 25946, 26067, 26068, 26069, 26023
10469, 25946, 25968, 25969, 25947, 26069, 26070, 26071, 26025
10470, 25947, 25969, 25970, 25948, 26071, 26072, 26073, 26027
10471, 25948, 25970, 25971, 25949, 26073, 26074, 26075, 26029
10472, 25949, 25971, 25972, 25950, 26075, 26076, 26077, 26031
10473, 25950, 25972, 25973, 25951, 26077, 26078, 26079, 26033
10474, 25951, 25973, 25974, 25952, 26079, 26080, 26081, 26035
10475, 25952, 25974, 25975, 25953, 26081, 26082, 26083, 26037
10476, 25953, 25975, 25976, 25954, 26083, 26084, 26085, 26039
10477, 25954, 25976, 25977, 25955, 26085, 26086, 26087, 26041
10478, 25955, 25977, 25978, 25956, 26087, 26088, 26089, 26043
10479, 25956, 25978, 2566, 2565, 26089, 26090, 2569, 26045
10480, 2559, 2560, 25979, 25957, 2563, 26091, 26092, 26046
10481, 25957, 25979, 25980, 25958, 26092, 26093, 26094, 26048
10482, 25958, 25980, 25981, 25959, 26094, 26095, 26096, 26050
10483, 25959, 25981, 25982, 25960, 26096, 26097, 26098, 26052
10484, 25960, 25982, 25983, 25961, 26098, 26099, 26100, 26054
10485, 25961, 25983, 25984, 25962, 26100, 26101, 26102, 26056
10486, 25962, 25984, 25985, 25963, 26102, 26103, 26104, 26058
10487, 25963, 25985, 25986, 25964, 26104, 26105, 26106, 26060
10488, 25964, 25986, 25987, 25965, 26106, 26107, 26108, 26062
10489, 25965, 25987, 25988, 25966, 26108, 26109, 26110, 26064
10490, 25966, 25988, 25989, 25967, 26110, 26111, 26112, 26066
10491, 25967, 25989, 25990, 25968, 26112, 26113, 26114, 26068
10492, 25968, 25990, 25991, 25969, 26114, 26115, 26116, 26070
10493, 25969, 25991, 25992, 25970, 26116, 26117, 26118, 26072
10494, 25970, 25992, 25993, 25971, 26118, 26119, 26120, 26074
10495, 25971, 25993, 25994, 25972, 26120, 26121, 26122, 26076
10496, 25972, 25994, 25995, 25973, 26122, 26123, 26124, 26078
10497, 25973, 25995, 25996, 25974, 26124, 26125, 26126, 26080
10498, 25974, 25996, 25997, 25975, 26126, 26127, 26128, 26082
10499, 25975, 25997, 25998, 25976, 26128, 26129, 26130, 26084
10500, 25976, 25998, 25999, 25977, 26130, 26131, 26132, 26086
10501, 25977, 25999, 26000, 25978, 26132, 26133, 26134, 26088
10502, 25978, 26000, 2567, 2566, 26134, 26135, 2570, 26090
10503, 2560, 63, 2593, 25979, 2564, 2616, 26136, 26091
10504, 25979, 2593, 2592, 25980, 26136, 2615, 26137, 26093
10505, 25980, 2592, 2591, 25981, 26137, 2614, 26138, 26095
10506, 25981, 2591, 2590, 25982, 26138, 2613, 26139, 26097
10507, 25982, 2590, 2589, 25983, 26139, 2612, 26140, 26099
10508, 25983, 2589, 2588, 25984, 26140, 2611, 26141, 26101
10509, 25984, 2588, 2587, 25985, 26141, 2610, 26142, 26103
10510, 25985, 2587, 2586, 25986, 26142, 2609, 26143, 26105
10511, 25986, 2586, 2585, 25987, 26143, 2608, 26144, 26107
10512, 25987, 2585, 2584, 25988, 26144, 2607, 26145, 26109
10513, 25988, 2584, 2583, 25989, 26145, 2606, 26146, 26111
10514, 25989, 2583, 2582, 25990, 26146, 2605, 26147, 26113
10515, 25990, 2582, 2581, 25991, 26147, 2604, 26148, 26115
10516, 25991, 2581, 2580, 25992, 26148, 2603, 26149, 26117
10517, 25992, 2580, 2579, 25993, 26149, 2602, 26150, 26119
10518, 25993, 2579, 2578, 25994, 26150, 2601, 26151, 26121
10519, 25994, 2578, 2577, 25995, 26151, 2600, 26152, 26123
10520, 25995, 2577, 2576, 25996, 26152, 2599, 26153, 26125
10521, 25996, 2576, 2575, 25997, 26153, 2598, 26154, 26127
10522, 25997, 2575, 2574, 25998, 26154, 2597, 26155, 26129
10523, 25998, 2574, 2573, 25999, 26155, 2596, 26156, 26131
10524, 25999, 2573, 2572, 26000, 26156, 2595, 26157, 26133
10525, 26000, 2572, 64, 2567, 26157, 2594, 2571, 26135
*ELEMENT, type=CPS8, ELSET=Surface119
10526, 5, 2617, 26158, 150, 2620, 26188, 26189, 161
10527, 150, 26158, 26159, 149, 26189, 26190, 26191, 160
10528, 149, 26159, 26160, 148, 26191, 26192, 26193, 159
10529, 148, 26160, 26161, 147, 26193, 26194, 26195, 158
10530, 147, 26161, 26162, 146, 26195, 26196, 26197, 157
10531, 146, 26162, 26163, 145, 26197, 26198, 26199, 156
10532, 145, 26163, 26164, 144, 26199, 26200, 26201, 155
10533, 144, 26164, 26165, 143, 26201, 26202, 26203, 154
10534, 143, 26165, 26166, 142, 26203, 26204, 26205, 153
10535, 142, 26166, 26167, 141, 26205, 26206, 26207, 152
10536, 141, 26167, 2558, 6, 26207, 26208, 2561, 151
10537, 2617, 2618, 26168, 26158, 2621, 26209, 26210, 26188
10538, 26158, 26168, 26169, 26159, 26210, 26211, 26212, 26190
10539, 26159, 26169, 26170, 26160, 26212, 26213, 26214, 26192
10540, 26160, 26170, 26171, 26161, 26214, 26215, 26216, 26194
10541, 26161, 26171, 26172, 26162, 26216, 26217, 26218, 26196
10542, 26162, 26172, 26173, 26163, 26218, 26219, 26220, 26198
10543, 26163, 26173, 26174, 26164, 26220, 26221, 26222, 26200
10544, 26164, 26174, 26175, 26165, 26222, 26223, 26224, 26202
10545, 26165, 26175, 26176, 26166, 26224, 26225, 26226, 26204
10546, 26166, 26176, 26177, 26167, 26226, 26227, 26228, 26206
10547, 26167, 26177, 2559, 2558, 26228, 26229, 2562, 26208
10548, 2618, 2619, 26178, 26168, 2622, 26230, 26231, 26209
10549, 26168, 26178, 26179, 26169, 26231, 26232, 26233, 26211
10550, 26169, 26179, 26180, 26170, 26233, 26234, 26235, 26213
10551, 26170, 26180, 26181, 26171, 26235, 26236, 26237, 26215
10552, 26171, 26181, 26182, 26172, 26237, 26238, 26239, 26217
10553, 26172, 26182, 26183, 26173, 26239, 26240, 26241, 26219
10554, 26173, 26183, 26184, 26174, 26241, 26242, 26243, 26221
10555, 26174, 26184, 26185, 26175, 26243, 26244, 26245, 26223
10556, 26175, 26185, 26186, 26176, 26245, 26246, 26247, 26225
10557, 26176, 26186, 26187, 26177, 26247, 26248, 26249, 26227
10558, 26177, 26187, 2560, 2559, 26249, 26250, 2563, 26229
10559, 2619, 65, 2633, 26178, 2623, 2644, 26251, 26230
10560, 26178, 2633, 2632, 26179, 26251, 2643, 26252, 26232
10561, 26179, 2632, 2631, 26180, 26252, 2642, 26253, 26234
10562, 26180, 2631, 2630, 26181, 26253, 2641, 26254, 26236
10563, 26181, 2630, 2629, 26182, 26254, 2640, 26255, 26238
10564, 26182, 2629, 2628, 26183, 26255, 2639, 26256, 26240
10565, 26183, 2628, 2627, 26184, 26256, 2638, 26257, 26242
10566, 26184, 2627, 2626, 26185, 26257, 2637, 26258, 26244
10567, 26185, 2626, 2625, 26186, 26258, 2636, 26259, 26246
10568, 26186, 2625, 2624, 26187, 26259, 2635, 26260, 26248
10569, 26187, 2624, 63, 2560, 26260, 2634, 2564, 26250
*ELEMENT, type=CPS8, ELSET=Surface120
10570, 5, 259, 26261, 2617, 282, 26327, 26328, 2620
10571, 259, 258, 26262, 26261, 281, 26329, 26330, 26327
10572, 258, 257, 26263, 26262, 280, 26331, 26332, 26329
10573, 257, 256, 26264, 26263, 279, 26333, 26334, 26331
10574, 256, 255, 26265, 26264, 278, 26335, 26336, 26333
10575, 255, 254, 26266, 26265, 277, 26337, 26338, 26335
10576, 254, 253, 26267, 26266, 276, 26339, 26340, 26337
10577, 253, 252, 26268, 26267, 275, 26341, 26342, 26339
10578, 252, 251, 26269, 26268, 274, 26343, 26344, 26341
10579, 251, 250, 26270, 26269, 273, 26345, 26346, 26343
10580, 250, 249, 26271, 26270, 272, 26347, 26348, 26345
10581, 249, 248, 26272, 26271, 271, 26349, 26350, 26347
10582, 248, 247, 26273, 26272, 270, 26351, 26352, 26349
10583, 247, 246, 26274, 26273, 269, 26353, 26354, 26351
10584, 246, 245, 26275, 26274, 268, 26355, 26356, 26353
10585, 245, 244, 26276, 26275, 267, 26357, 26358, 26355
10586, 244, 243, 26277, 26276, 266, 26359, 26360, 26357
10587, 243, 242, 26278, 26277, 265, 26361, 26362, 26359
10588, 242, 241, 26279, 26278, 264, 26363, 26364, 26361
10589, 241, 240, 26280, 26279, 263, 26365, 26366, 26363
10590, 240, 239, 26281, 26280, 262, 26367, 26368, 26365
10591, 239, 238, 26282, 26281, 261, 26369, 26370, 26367
10592, 238, 1, 2645, 26282, 260, 2648, 26371, 26369
10593, 2617, 26261, 26283, 2618, 26328, 26372, 26373, 2621
10594, 26261, 26262, 26284, 26283, 26330, 26374, 26375, 26372
10595, 26262, 26263, 26285, 26284, 26332, 26376, 26377, 26374
10596, 26263, 26264, 26286, 26285, 26334, 26378, 26379, 26376
10597, 26264, 26265, 26287, 26286, 26336, 26380, 26381, 26378
10598, 26265, 26266, 26288, 26287, 26338, 26382, 26383, 26380
10599, 26266, 26267, 26289, 26288, 26340, 26384, 26385, 26382
10600, 26267, 26268, 26290, 26289, 26342, 26386, 26387, 26384
10601, 26268, 26269, 26291, 26290, 26344, 26388, 26389, 26386
10602, 26269, 26270, 26292, 26291, 26346, 26390, 26391, 26388
10603, 26270, 26271, 26293, 26292, 26348, 26392, 26393, 26390
10604, 26271, 26272, 26294, 26293, 26350, 26394, 26395, 26392
10605, 26272, 26273, 26295, 26294, 26352, 26396, 26397, 26394
10606, 26273, 26274, 26296, 26295, 26354, 26398, 26399, 26396
10607, 26274, 26275, 26297, 26296, 26356, 26400, 26401, 26398
10608, 26275, 26276, 26298, 26297, 26358, 26402, 26403, 26400
10609, 26276, 26277, 26299, 26298, 26360, 26404, 26405, 26402
10610, 26277, 26278, 26300, 26299, 26362, 26406, 26407, 26404
10611, 26278, 26279, 26301, 26300, 26364, 26408, 26409, 26406
10612, 26279, 26280, 26302, 26301, 26366, 26410, 26411, 26408
10613, 26280, 26281, 26303, 26302, 26368, 26412, 26413, 26410
10614, 26281, 26282, 26304, 26303, 26370, 26414, 26415, 26412
10615, 26282, 2645, 2646, 26304, 26371, 2649, 26416, 26414
10616, 2618, 26283, 26305, 2619, 26373, 26417, 26418, 2622
10617, 26283, 26284, 26306, 26305, 26375, 26419, 26420, 26417
10618, 26284, 26285, 26307, 26306, 26377, 26421, 26422, 26419
10619, 26285, 26286, 26308, 26307, 26379, 26423, 26424, 26421
10620, 26286, 26287, 26309, 26308, 26381, 26425, 26426, 26423
10621, 26287, 26288, 26310, 26309, 26383, 26427, 26428, 26425
10622, 26288, 26289, 26311, 26310, 26385, 26429, 26430, 26427
10623, 26289, 26290, 26312, 26311, 26387, 26431, 26432, 26429
10624, 26290, 26291, 26313, 26312, 26389, 26433, 26434, 26431
10625, 26291, 26292, 26314, 26313, 26391, 26435, 26436, 26433
10626, 26292, 26293, 26315, 26314, 26393, 26437, 26438, 26435
10627, 26293, 26294, 26316, 26315, 26395, 26439, 26440, 26437
10628, 26294, 26295, 26317, 26316, 26397, 26441, 26442, 26439
10629, 26295, 26296, 26318, 26317, 26399, 26443, 26444, 26441
10630, 26296, 26297, 26319, 26318, 26401, 26445, 26446, 26443
10631, 26297, 26298, 26320, 26319, 26403, 26447, 26448, 26445
10632, 26298, 26299, 26321, 26320, 26405, 26449, 26450, 26447
10633, 26299, 26300, 26322, 26321, 26407, 26451, 26452, 26449
10634, 26300, 26301, 26323, 26322, 26409, 26453, 26454, 26451
10635, 26301, 26302, 26324, 26323, 26411, 26455, 26456, 26453
10636, 26302, 26303, 26325, 26324, 26413, 26457, 26458, 26455
10637, 26303, 26304, 26326, 26325, 26415, 26459, 26460, 26457
10638, 26304, 2646, 2647, 26326, 26416, 2650, 26461, 26459
10639, 2619, 26305, 2673, 65, 26418, 26462, 2696, 2623
10640, 26305, 26306, 2672, 2673, 26420, 26463, 2695, 26462
10641, 26306, 26307, 2671, 2672, 26422, 26464, 2694, 26463
10642, 26307, 26308, 2670, 2671, 26424, 26465, 2693, 26464
10643, 26308, 26309, 2669, 2670, 26426, 26466, 2692, 26465
10644, 26309, 26310, 2668, 2669, 26428, 26467, 2691, 26466
10645, 26310, 26311, 2667, 2668, 26430, 26468, 2690, 26467
10646, 26311, 26312, 2666, 2667, 26432, 26469, 2689, 26468
10647, 26312, 26313, 2665, 2666, 26434, 26470, 2688, 26469
10648, 26313, 26314, 2664, 2665, 26436, 26471, 2687, 26470
10649, 26314, 26315, 2663, 2664, 26438, 26472, 2686, 26471
10650, 26315, 26316, 2662, 2663, 26440, 26473, 2685, 26472
10651, 26316, 26317, 2661, 2662, 26442, 26474, 2684, 26473
10652, 26317, 26318, 2660, 2661, 26444, 26475, 2683, 26474
10653, 26318, 26319, 2659, 2660, 26446, 26476, 2682, 26475
10654, 26319, 26320, 2658, 2659, 26448, 26477, 2681, 26476
10655, 26320, 26321, 2657, 2658, 26450, 26478, 2680, 26477
10656, 26321, 26322, 2656, 2657, 26452, 26479, 2679, 26478
10657, 26322, 26323, 2655, 2656, 26454, 26480, 2678, 26479
10658, 26323, 26324, 2654, 2655, 26456, 26481, 2677, 26480
10659, 26324, 26325, 2653, 2654, 26458, 26482, 2676, 26481
10660, 26325, 26326, 2652, 2653, 26460, 26483, 2675, 26482
10661, 26326, 2647, 66, 2652, 26461, 2651, 2674, 26483
*ELEMENT, type=CPS8, ELSET=Surface121
10662, 1, 98, 26484, 2645, 109, 26514, 26515, 2648
10663, 98, 97, 26485, 26484, 108, 26516, 26517, 26514
10664, 97, 96, 26486, 26485, 107, 26518, 26519, 26516
10665, 96, 95, 26487, 26486, 106, 26520, 26521, 26518
10666, 95, 94, 26488, 26487, 105, 26522, 26523, 26520
10667, 94, 93, 26489, 26488, 104, 26524, 26525, 26522
10668, 93, 92, 26490, 26489, 103, 26526, 26527, 26524
10669, 92, 91, 26491, 26490, 102, 26528, 26529, 26526
10670, 91, 90, 26492, 26491, 101, 26530, 26531, 26528
10671, 90, 89, 26493, 26492, 100, 26532, 26533, 26530
10672, 89, 2, 2565, 26493, 99, 2568, 26534, 26532
10673, 2645, 26484, 26494, 2646, 26515, 26535, 26536, 2649
10674, 26484, 26485, 26495, 26494, 26517, 26537, 26538, 26535
10675, 26485, 26486, 26496, 26495, 26519, 26539, 26540, 26537
10676, 26486, 26487, 26497, 26496, 26521, 26541, 26542, 26539
10677, 26487, 26488, 26498, 26497, 26523, 26543, 26544, 26541
10678, 26488, 26489, 26499, 26498, 26525, 26545, 26546, 26543
10679, 26489, 26490, 26500, 26499, 26527, 26547, 26548, 26545
10680, 26490, 26491, 26501, 26500, 26529, 26549, 26550, 26547
10681, 26491, 26492, 26502, 26501, 26531, 26551, 26552, 26549
10682, 26492, 26493, 26503, 26502, 26533, 26553, 26554, 26551
10683, 26493, 2565, 2566, 26503, 26534, 2569, 26555, 26553
10684, 2646, 26494, 26504, 2647, 26536, 26556, 26557, 2650
10685, 26494, 26495, 26505, 26504, 26538, 26558, 26559, 26556
10686, 26495, 26496, 26506, 26505, 26540, 26560, 26561, 26558
10687, 26496, 26497, 26507, 26506, 26542, 26562, 26563, 26560
10688, 26497, 26498, 26508, 26507, 26544, 26564, 26565, 26562
10689, 26498, 26499, 26509, 26508, 26546, 26566, 26567, 26564
10690, 26499, 26500, 26510, 26509, 26548, 26568, 26569, 26566
10691, 26500, 26501, 26511, 26510, 26550, 26570, 26571, 26568
10692, 26501, 26502, 26512, 26511, 26552, 26572, 26573, 26570
10693, 26502, 26503, 26513, 26512, 26554, 26574, 26575, 26572
10694, 26503, 2566, 2567, 26513, 26555, 2570, 26576, 26574
10695, 2647, 26504, 2706, 66, 26557, 26577, 2717, 2651
10696, 26504, 26505, 2705, 2706, 26559, 26578, 2716, 26577
10697, 26505, 26506, 2704, 2705, 26561, 26579, 2715, 26578
10698, 26506, 26507, 2703, 2704, 26563, 26580, 2714, 26579
10699, 26507, 26508, 2702, 2703, 26565, 26581, 2713, 26580
10700, 26508, 26509, 2701, 2702, 26567, 26582, 2712, 26581
10701, 26509, 26510, 2700, 2701, 26569, 26583, 2711, 26582
10702, 26510, 26511, 2699, 2700, 26571, 26584, 2710, 26583
10703, 26511, 26512, 2698, 2699, 26573, 26585, 2709, 26584
10704, 26512, 26513, 2697, 2698, 26575, 26586, 2708, 26585
10705, 26513, 2567, 64, 2697, 26576, 2571, 2707, 26586
*ELEMENT, type=CPS8, ELSET=Surface122
10706, 64, 2572, 26587, 2697, 2594, 26807, 26808, 2707
10707, 2697, 26587, 26588, 2698, 26808, 26809, 26810, 2708
10708, 2698, 26588, 26589, 2699, 26810, 26811, 26812, 2709
10709, 2699, 26589, 26590, 2700, 26812, 26813, 26814, 2710
10710, 2700, 26590, 26591, 2701, 26814, 26815, 26816, 2711
10711, 2701, 26591, 26592, 2702, 26816, 26817, 26818, 2712
10712, 2702, 26592, 26593, 2703, 26818, 26819, 26820, 2713
10713, 2703, 26593, 26594, 2704, 26820, 26821, 26822, 2714
10714, 2704, 26594, 26595, 2705, 26822, 26823, 26824, 2715
10715, 2705, 26595, 26596, 2706, 26824, 26825, 26826, 2716
10716, 2706, 26596, 2652, 66, 26826, 26827, 2674, 2717
10717, 2572, 2573, 26597, 26587, 2595, 26828, 26829, 26807
10718, 26587, 26597, 26598, 26588, 26829, 26830, 26831, 26809
10719, 26588, 26598, 26599, 26589, 26831, 26832, 26833, 26811
10720, 26589, 26599, 26600, 26590, 26833, 26834, 26835, 26813
10721, 26590, 26600, 26601, 26591, 26835, 26836, 26837, 26815
10722, 26591, 26601, 26602, 26592, 26837, 26838, 26839, 26817
10723, 26592, 26602, 26603, 26593, 26839, 26840, 26841, 26819
10724, 26593, 26603, 26604, 26594, 26841, 26842, 26843, 26821
10725, 26594, 26604, 26605, 26595, 26843, 26844, 26845, 26823
10726, 26595, 26605, 26606, 26596, 26845, 26846, 26847, 26825
10727, 26596, 26606, 2653, 2652, 26847, 26848, 2675, 26827
10728, 2573, 2574, 26607, 26597, 2596, 26849, 26850, 26828
10729, 26597, 26607, 26608, 26598, 26850, 26851, 26852, 26830
10730, 26598, 26608, 26609, 26599, 26852, 26853, 26854, 26832
10731, 26599, 26609, 26610, 26600, 26854, 26855, 26856, 26834
10732, 26600, 26610, 26611, 26601, 26856, 26857, 26858, 26836
10733, 26601, 26611, 26612, 26602, 26858, 26859, 26860, 26838
10734, 26602, 26612, 26613, 26603, 26860, 26861, 26862, 26840
10735, 26603, 26613, 26614, 26604, 26862, 26863, 26864, 26842
10736, 26604, 26614, 26615, 26605, 26864, 26865, 26866, 26844
10737, 26605, 26615, 26616, 26606, 26866, 26867, 26868, 26846
10738, 26606, 26616, 2654, 2653, 26868, 26869, 2676, 26848
10739, 2574, 2575, 26617, 26607, 2597, 26870, 26871, 26849
10740, 26607, 26617, 26618, 26608, 26871, 26872, 26873, 26851
10741, 26608, 26618, 26619, 26609, 26873, 26874, 26875, 26853
10742, 26609, 26619, 26620, 26610, 26875, 26876, 26877, 26855
10743, 26610, 26620, 26621, 26611, 26877, 26878, 26879, 26857
10744, 26611, 26621, 26622, 26612, 26879, 26880, 26881, 26859
10745, 26612, 26622, 26623, 26613, 26881, 26882, 26883, 26861
10746, 26613, 26623, 26624, 26614, 26883, 26884, 26885, 26863
10747, 26614, 26624, 26625, 26615, 26885, 26886, 26887, 26865
10748, 26615, 26625, 26626, 26616, 26887, 26888, 26889, 26867
10749, 26616, 26626, 2655, 2654, 26889, 26890, 2677, 26869
10750, 2575, 2576, 26627, 26617, 2598, 26891, 26892, 26870
10751, 26617, 26627, 26628, 26618, 26892, 26893, 26894, 26872
10752, 26618, 26628, 26629, 26619, 26894, 26895, 26896, 26874
10753, 26619, 26629, 26630, 26620, 26896, 26897, 26898, 26876
10754, 26620, 26630, 26631, 26621, 26898, 26899, 26900, 26878
10755, 26621, 26631, 26632, 26622, 26900, 26901, 26902, 26880
10756, 26622, 26632, 26633, 26623, 26902, 26903, 26904, 26882
10757, 26623, 26633, 26634, 26624, 26904, 26905, 26906, 26884
10758, 26624, 26634, 26635, 26625, 26906, 26907, 26908, 26886
10759, 26625, 26635, 26636, 26626, 26908, 26909, 26910, 26888
10760, 26626, 26636, 2656, 2655, 26910, 26911, 2678, 26890
10761, 2576, 2577, 26637, 26627, 2599, 26912, 26913, 26891
10762, 26627, 26637, 26638, 26628, 26913, 26914, 26915, 26893
10763, 26628, 26638, 26639, 26629, 26915, 26916, 26917, 26895
10764, 26629, 26639, 26640, 26630, 26917, 26918, 26919, 26897
10765, 26630, 26640, 26641, 26631, 26919, 26920, 26921, 26899
10766, 26631, 26641, 26642, 26632, 26921, 26922, 26923, 26901
10767, 26632, 26642, 26643, 26633, 26923, 26924, 26925, 26903
10768, 26633, 26643, 26644, 26634, 26925, 26926, 26927, 26905
10769, 26634, 26644, 26645, 26635, 26927, 26928, 26929, 26907
10770, 26635, 26645, 26646, 26636, 26929, 26930, 26931, 26909
10771, 26636, 26646, 2657, 2656, 26931, 26932, 2679, 26911
10772, 2577, 2578, 26647, 26637, 2600, 26933, 26934, 26912
10773, 26637, 26647, 26648, 26638, 26934, 26935, 26936, 26914
10774, 26638, 26648, 26649, 26639, 26936, 26937, 26938, 26916
10775, 26639, 26649, 26650, 26640, 26938, 26939, 26940, 26918
10776, 26640, 26650, 26651, 26641, 26940, 26941, 26942, 26920
10777, 26641, 26651, 26652, 26642, 26942, 26943, 26944, 26922
10778, 26642, 26652, 26653, 26643, 26944, 26945, 26946, 26924
10779, 26643, 26653, 26654, 26644, 26946, 26947, 26948, 26926
10780, 26644, 26654, 26655, 26645, 26948, 26949, 26950, 26928
10781, 26645, 26655, 26656, 26646, 26950, 26951, 26952, 26930
10782, 26646, 26656, 2658, 2657, 26952, 26953, 2680, 26932
10783, 2578, 2579, 26657, 26647, 2601, 26954, 26955, 26933
10784, 26647, 26657, 26658, 26648, 26955, 26956, 26957, 26935
10785, 26648, 26658, 26659, 26649, 26957, 26958, 26959, 26937
10786, 26649, 26659, 26660, 26650, 26959, 26960, 26961, 26939
10787, 26650, 26660, 26661, 26651, 26961, 26962, 26963, 26941
10788, 26651, 26661, 26662, 26652, 26963, 26964, 26965, 26943
10789, 26652, 26662, 26663, 26653, 26965, 26966, 26967, 26945
10790, 26653, 26663, 26664, 26654, 26967, 26968, 26969, 26947
10791, 26654, 26664, 26665, 26655, 26969, 26970, 26971, 26949
10792, 26655, 26665, 26666, 26656, 26971, 26972, 26973, 26951
10793, 26656, 26666, 2659, 2658, 26973, 26974, 2681, 26953
10794, 2579, 2580, 26667, 26657, 2602, 26975, 26976, 26954
10795, 26657, 26667, 26668, 26658, 26976, 26977, 26978, 26956
10796, 26658, 26668, 26669, 26659, 26978, 26979, 26980, 26958
10797, 26659, 26669, 26670, 26660, 26980, 26981, 26982, 26960
10798, 26660, 26670, 26671, 26661, 26982, 26983, 26984, 26962
10799, 26661, 26671, 26672, 26662, 26984, 26985, 26986, 26964
10800, 26662, 26672, 26673, 26663, 26986, 26987, 26988, 26966
10801, 26663, 26673, 26674, 26664, 26988, 26989, 26990, 26968
10802, 26664, 26674, 26675, 26665, 26990, 26991, 26992, 26970
10803, 26665, 26675, 26676, 26666, 26992, 26993, 26994, 26972
10804, 26666, 26676, 2660, 2659, 26994, 26995, 2682, 26974
10805, 2580, 2581, 26677, 26667, 2603, 26996, 26997, 26975
10806, 26667, 26677, 26678, 26668, 26997, 26998, 26999, 26977
10807, 26668, 26678, 26679, 26669, 26999, 27000, 27001, 26979
10808, 26669, 26679, 26680, 26670, 27001, 27002, 27003, 26981
10809, 26670, 26680, 26681, 26671, 27003, 27004, 27005, 26983
10810, 26671, 26681, 26682, 26672, 27005, 27006, 27007, 26985
10811, 26672, 26682, 26683, 26673, 27007, 27008, 27009, 26987
10812, 26673, 26683, 26684, 26674, 27009, 27010, 27011, 26989
10813, 26674, 26684, 26685, 26675, 27011, 27012, 27013, 26991
10814, 26675, 26685, 26686, 26676, 27013, 27014, 27015, 26993
10815, 26676, 26686, 2661, 2660, 27015, 27016, 2683, 26995
10816, 2581, 2582, 26687, 26677, 2604, 27017, 27018, 26996
10817, 26677, 26687, 26688, 26678, 27018, 27019, 27020, 26998
10818, 26678, 26688, 26689, 26679, 27020, 27021, 27022, 27000
10819, 26679, 26689, 26690, 26680, 27022, 27023, 27024, 27002
10820, 26680, 26690, 26691, 26681, 27024, 27025, 27026, 27004
10821, 26681, 26691, 26692, 26682, 27026, 27027, 27028, 27006
10822, 26682, 26692, 26693, 26683, 27028, 27029, 27030, 27008
10823, 26683, 26693, 26694, 26684, 27030, 27031, 27032, 27010
10824, 26684, 26694, 26695, 26685, 27032, 27033, 27034, 27012
10825, 26685, 26695, 26696, 26686, 27034, 27035, 27036, 27014
10826, 26686, 26696, 2662, 2661, 27036, 27037, 2684, 27016
10827, 2582, 2583, 26697, 26687, 2605, 27038, 27039, 27017
10828, 26687, 26697, 26698, 26688, 27039, 27040, 27041, 27019
10829, 26688, 26698, 26699, 26689, 27041, 27042, 27043, 27021
10830, 26689, 26699, 26700, 26690, 27043, 27044, 27045, 27023
10831, 26690, 26700, 26701, 26691, 27045, 27046, 27047, 27025
10832, 26691, 26701, 26702, 26692, 27047, 27048, 27049, 27027
10833, 26692, 26702, 26703, 26693, 27049, 27050, 27051, 27029
10834, 26693, 26703, 26704, 26694, 27051, 27052, 27053, 27031
10835, 26694, 26704, 26705, 26695, 27053, 27054, 27055, 27033
10836, 26695, 26705, 26706, 26696, 27055, 27056, 27057, 27035
10837, 26696, 26706, 2663, 2662, 27057, 27058, 2685, 27037
10838, 2583, 2584, 26707, 26697, 2606, 27059, 27060, 27038
10839, 26697, 26707, 26708, 26698, 27060, 27061, 27062, 27040
10840, 26698, 26708, 26709, 26699, 27062, 27063, 27064, 27042
10841, 26699, 26709, 26710, 26700, 27064, 27065, 27066, 27044
10842, 26700, 26710, 26711, 26701, 27066, 27067, 27068, 27046
10843, 26701, 26711, 26712, 26702, 27068, 27069, 27070, 27048
10844, 26702, 26712, 26713, 26703, 27070, 27071, 27072, 27050
10845, 26703, 26713, 26714, 26704, 27072, 27073, 27074, 27052
10846, 26704, 26714, 26715, 26705, 27074, 27075, 27076, 27054
10847, 26705, 26715, 26716, 26706, 27076, 27077, 27078, 27056
10848, 26706, 26716, 2664, 2663, 27078, 27079, 2686, 27058
10849, 2584, 2585, 26717, 26707, 2607, 27080, 27081, 27059
10850, 26707, 26717, 26718, 26708, 27081, 27082, 27083, 27061
10851, 26708, 26718, 26719, 26709, 27083, 27084, 27085, 27063
10852, 26709, 26719, 26720, 26710, 27085, 27086, 27087, 27065
10853, 26710, 26720, 26721, 26711, 27087, 27088, 27089, 27067
10854, 26711, 26721, 26722, 26712, 27089, 27090, 27091, 27069
10855, 26712, 26722, 26723, 26713, 27091, 27092, 27093, 27071
10856, 26713, 26723, 26724, 26714, 27093, 27094, 27095, 27073
10857, 26714, 26724, 26725, 26715, 27095, 27096, 27097, 27075
10858, 26715, 26725, 26726, 26716, 27097, 27098, 27099, 27077
10859, 26716, 26726, 2665, 2664, 27099, 27100, 2687, 27079
10860, 2585, 2586, 26727, 26717, 2608, 27101, 27102, 27080
10861, 26717, 26727, 26728, 26718, 27102, 27103, 27104, 27082
10862, 26718, 26728, 26729, 26719, 27104, 27105, 27106, 27084
10863, 26719, 26729, 26730, 26720, 27106, 27107, 27108, 27086
10864, 26720, 26730, 26731, 26721, 27108, 27109, 27110, 27088
10865, 26721, 26731, 26732, 26722, 27110, 27111, 27112, 27090
10866, 26722, 26732, 26733, 26723, 27112, 27113, 27114, 27092
10867, 26723, 26733, 26734, 26724, 27114, 27115, 27116, 27094
10868, 26724, 26734, 26735, 26725, 27116, 27117, 27118, 27096
10869, 26725, 26735, 26736, 26726, 27118, 27119, 27120, 27098
10870, 26726, 26736, 2666, 2665, 27120, 27121, 2688, 27100
10871, 2586, 2587, 26737, 26727, 2609, 27122, 27123, 27101
10872, 26727, 26737, 26738, 26728, 27123, 27124, 27125, 27103
10873, 26728, 26738, 26739, 26729, 27125, 27126, 27127, 27105
10874, 26729, 26739, 26740, 26730, 27127, 27128, 27129, 27107
10875, 26730, 26740, 26741, 26731, 27129, 27130, 27131, 27109
10876, 26731, 26741, 26742, 26732, 27131, 27132, 27133, 27111
10877, 26732, 26742, 26743, 26733, 27133, 27134, 27135, 27113
10878, 26733, 26743, 26744, 26734, 27135, 27136, 27137, 27115
10879, 26734, 26744, 26745, 26735, 27137, 27138, 27139, 27117
10880, 26735, 26745, 26746, 26736, 27139, 27140, 27141, 27119
10881, 26736, 26746, 2667, 2666, 27141, 27142, 2689, 27121
10882, 2587, 2588, 26747, 26737, 2610, 27143, 27144, 27122
10883, 26737, 26747, 26748, 26738, 27144, 27145, 27146, 27124
10884, 26738, 26748, 26749, 26739, 27146, 27147, 27148, 27126
10885, 26739, 26749, 26750, 26740, 27148, 27149, 27150, 27128
10886, 26740, 26750, 26751, 26741, 27150, 27151, 27152, 27130
10887, 26741, 26751, 26752, 26742, 27152, 27153, 27154, 27132
10888, 26742, 26752, 26753, 26743, 27154, 27155, 27156, 27134
10889, 26743, 26753, 26754, 26744, 27156, 27157, 27158, 27136
10890, 26744, 26754, 26755, 26745, 27158, 27159, 27160, 27138
10891, 26745, 26755, 26756, 26746, 27160, 27161, 27162, 27140
10892, 26746, 26756, 2668, 2667, 27162, 27163, 2690, 27142
10893, 2588, 2589, 26757, 26747, 2611, 27164, 27165, 27143
10894, 26747, 26757, 26758, 26748, 27165, 27166, 27167, 27145
10895, 26748, 26758, 26759, 26749, 27167, 27168, 27169, 27147
10896, 26749, 26759, 26760, 26750, 27169, 27170, 27171, 27149
10897, 26750, 26760, 26761, 26751, 27171, 27172, 27173, 27151
10898, 26751, 26761, 26762, 26752, 27173, 27174, 27175, 27153
10899, 26752, 26762, 26763, 26753, 27175, 27176, 27177, 27155
10900, 26753, 26763, 26764, 26754, 27177, 27178, 27179, 27157
10901, 26754, 26764, 26765, 26755, 27179, 27180, 27181, 27159
10902, 26755, 26765, 26766, 26756, 27181, 27182, 27183, 27161
10903, 26756, 26766, 2669, 2668, 27183, 27184, 2691, 27163
10904, 2589, 2590, 26767, 26757, 2612, 27185, 27186, 27164
10905, 26757, 26767, 26768, 26758, 27186, 27187, 27188, 27166
10906, 26758, 26768, 26769, 26759, 27188, 27189, 27190, 27168
10907, 26759, 26769, 26770, 26760, 27190, 27191, 27192, 27170
10908, 26760, 26770, 26771, 26761, 27192, 27193, 27194, 27172
10909, 26761, 26771, 26772, 26762, 27194, 27195, 27196, 27174
10910, 26762, 26772, 26773, 26763, 27196, 27197, 27198, 27176
10911, 26763, 26773, 26774, 26764, 27198, 27199, 27200, 27178
10912, 26764, 26774, 26775, 26765, 27200, 27201, 27202, 27180
10913, 26765, 26775, 26776, 26766, 27202, 27203, 27204, 27182
10914, 26766, 26776, 2670, 2669, 27204, 27205, 2692, 27184
10915, 2590, 2591, 26777, 26767, 2613, 27206, 27207, 27185
10916, 26767, 26777, 26778, 26768, 27207, 27208, 27209, 27187
10917, 26768, 26778, 26779, 26769, 27209, 27210, 27211, 27189
10918, 26769, 26779, 26780, 26770, 27211, 27212, 27213, 27191
10919, 26770, 26780, 26781, 26771, 27213, 27214, 27215, 27193
10920, 26771, 26781, 26782, 26772, 27215, 27216, 27217, 27195
10921, 26772, 26782, 26783, 26773, 27217, 27218, 27219, 27197
10922, 26773, 26783, 26784, 26774, 27219, 27220, 27221, 27199
10923, 26774, 26784, 26785, 26775, 27221, 27222, 27223, 27201
10924, 26775, 26785, 26786, 26776, 27223, 27224, 27225, 27203
10925, 26776, 26786, 2671, 2670, 27225, 27226, 2693, 27205
10926, 2591, 2592, 26787, 26777, 2614, 27227, 27228, 27206
10927, 26777, 26787, 26788, 26778, 27228, 27229, 27230, 27208
10928, 26778, 26788, 26789, 26779, 27230, 27231, 27232, 27210
10929, 26779, 26789, 26790, 26780, 27232, 27233, 27234, 27212
10930, 26780, 26790, 26791, 26781, 27234, 27235, 27236, 27214
10931, 26781, 26791, 26792, 26782, 27236, 27237, 27238, 27216
10932, 26782, 26792, 26793, 26783, 27238, 27239, 27240, 27218
10933, 26783, 26793, 26794, 26784, 27240, 27241, 27242, 27220
10934, 26784, 26794, 26795, 26785, 27242, 27243, 27244, 27222
10935, 26785, 26795, 26796, 26786, 27244, 27245, 27246, 27224
10936, 26786, 26796, 2672, 2671, 27246, 27247, 2694, 27226
10937, 2592, 2593, 26797, 26787, 2615, 27248, 27249, 27227
10938, 26787, 26797, 26798, 26788, 27249, 27250, 27251, 27229
10939, 26788, 26798, 26799, 26789, 27251, 27252, 27253, 27231
10940, 26789, 26799, 26800, 26790, 27253, 27254, 27255, 27233
10941, 26790, 26800, 26801, 26791, 27255, 27256, 27257, 27235
10942, 26791, 26801, 26802, 26792, 27257, 27258, 27259, 27237
10943, 26792, 26802, 26803, 26793, 27259, 27260, 27261, 27239
10944, 26793, 26803, 26804, 26794, 27261, 27262, 27263, 27241
10945, 26794, 26804, 26805, 26795, 27263, 27264, 27265, 27243
10946, 26795, 26805, 26806, 26796, 27265, 27266, 27267, 27245
10947, 26796, 26806, 2673, 2672, 27267, 27268, 2695, 27247
10948, 2593, 63, 2624, 26797, 2616, 2634, 27269, 27248
10949, 26797, 2624, 2625, 26798, 27269, 2635, 27270, 27250
10950, 26798, 2625, 2626, 26799, 27270, 2636, 27271, 27252
10951, 26799, 2626, 2627, 26800, 27271, 2637, 27272, 27254
10952, 26800, 2627, 2628, 26801, 27272, 2638, 27273, 27256
10953, 26801, 2628, 2629, 26802, 27273, 2639, 27274, 27258
10954, 26802, 2629, 2630, 26803, 27274, 2640, 27275, 27260
10955, 26803, 2630, 2631, 26804, 27275, 2641, 27276, 27262
10956, 26804, 2631, 2632, 26805, 27276, 2642, 27277, 27264
10957, 26805, 2632, 2633, 26806, 27277, 2643, 27278, 27266
10958, 26806, 2633, 65, 2673, 27278, 2644, 2696, 27268
*ELEMENT, type=CPS8, ELSET=Surface123
10959, 1, 2148, 27279, 2645, 2150, 27285, 27286, 2648
10960, 2148, 2149, 27280, 27279, 2151, 27287, 27288, 27285
10961, 2149, 51, 2718, 27280, 2152, 2721, 27289, 27287
10962, 2645, 27279, 27281, 2646, 27286, 27290, 27291, 2649
10963, 27279, 27280, 27282, 27281, 27288, 27292, 27293, 27290
10964, 27280, 2718, 2719, 27282, 27289, 2722, 27294, 27292
10965, 2646, 27281, 27283, 2647, 27291, 27295, 27296, 2650
10966, 27281, 27282, 27284, 27283, 27293, 27297, 27298, 27295
10967, 27282, 2719, 2720, 27284, 27294, 2723, 27299, 27297
10968, 2647, 27283, 2725, 66, 27296, 27300, 2727, 2651
10969, 27283, 27284, 2726, 2725, 27298, 27301, 2728, 27300
10970, 27284, 2720, 67, 2726, 27299, 2724, 2729, 27301
*ELEMENT, type=CPS8, ELSET=Surface124
10971, 2, 2565, 27302, 2153, 2568, 27308, 27309, 2155
10972, 2153, 27302, 27303, 2154, 27309, 27310, 27311, 2156
10973, 2154, 27303, 2730, 52, 27311, 27312, 2733, 2157
10974, 2565, 2566, 27304, 27302, 2569, 27313, 27314, 27308
10975, 27302, 27304, 27305, 27303, 27314, 27315, 27316, 27310
10976, 27303, 27305, 2731, 2730, 27316, 27317, 2734, 27312
10977, 2566, 2567, 27306, 27304, 2570, 27318, 27319, 27313
10978, 27304, 27306, 27307, 27305, 27319, 27320, 27321, 27315
10979, 27305, 27307, 2732, 2731, 27321, 27322, 2735, 27317
10980, 2567, 64, 2737, 27306, 2571, 2739, 27323, 27318
10981, 27306, 2737, 2738, 27307, 27323, 2740, 27324, 27320
10982, 27307, 2738, 68, 2732, 27324, 2741, 2736, 27322
*ELEMENT, type=CPS8, ELSET=Surface125
10983, 51, 2167, 27325, 2718, 2178, 27355, 27356, 2721
10984, 2167, 2166, 27326, 27325, 2177, 27357, 27358, 27355
10985, 2166, 2165, 27327, 27326, 2176, 27359, 27360, 27357
10986, 2165, 2164, 27328, 27327, 2175, 27361, 27362, 27359
10987, 2164, 2163, 27329, 27328, 2174, 27363, 27364, 27361
10988, 2163, 2162, 27330, 27329, 2173, 27365, 27366, 27363
10989, 2162, 2161, 27331, 27330, 2172, 27367, 27368, 27365
10990, 2161, 2160, 27332, 27331, 2171, 27369, 27370, 27367
10991, 2160, 2159, 27333, 27332, 2170, 27371, 27372, 27369
10992, 2159, 2158, 27334, 27333, 2169, 27373, 27374, 27371
10993, 2158, 52, 2730, 27334, 2168, 2733, 27375, 27373
10994, 2718, 27325, 27335, 2719, 27356, 27376, 27377, 2722
10995, 27325, 27326, 27336, 27335, 27358, 27378, 27379, 27376
10996, 27326, 27327, 27337, 27336, 27360, 27380, 27381, 27378
10997, 27327, 27328, 27338, 27337, 27362, 27382, 27383, 27380
10998, 27328, 27329, 27339, 27338, 27364, 27384, 27385, 27382
10999, 27329, 27330, 27340, 27339, 27366, 27386, 27387, 27384
11000, 27330, 27331, 27341, 27340, 27368, 27388, 27389, 27386
11001, 27331, 27332, 27342, 27341, 27370, 27390, 27391, 27388
11002, 27332, 27333, 27343, 27342, 27372, 27392, 27393, 27390
11003, 27333, 27334, 27344, 27343, 27374, 27394, 27395, 27392
11004, 27334, 2730, 2731, 27344, 27375, 2734, 27396, 27394
11005, 2719, 27335, 27345, 2720, 27377, 27397, 27398, 2723
11006, 27335, 27336, 27346, 27345, 27379, 27399, 27400, 27397
11007, 27336, 27337, 27347, 27346, 27381, 27401, 27402, 27399
11008, 27337, 27338, 27348, 27347, 27383, 27403, 27404, 27401
11009, 27338, 27339, 27349, 27348, 27385, 27405, 27406, 27403
11010, 27339, 27340, 27350, 27349, 27387, 27407, 27408, 27405
11011, 27340, 27341, 27351, 27350, 27389, 27409, 27410, 27407
11012, 27341, 27342, 27352, 27351, 27391, 27411, 27412, 27409
11013, 27342, 27343, 27353, 27352, 27393, 27413, 27414, 27411
11014, 27343, 27344, 27354, 27353, 27395, 27415, 27416, 27413
11015, 27344, 2731, 2732, 27354, 27396, 2735, 27417, 27415
11016, 2720, 27345, 2751, 67, 27398, 27418, 2762, 2724
11017, 27345, 27346, 2750, 2751, 27400, 27419, 2761, 27418
11018, 27346, 27347, 2749, 2750, 27402, 27420, 2760, 27419
11019, 27347, 27348, 2748, 2749, 27404, 27421, 2759, 27420
11020, 27348, 27349, 2747, 2748, 27406, 27422, 2758, 27421
11021, 27349, 27350, 2746, 2747, 27408, 27423, 2757, 27422
11022, 27350, 27351, 2745, 2746, 27410, 27424, 2756, 27423
11023, 27351, 27352, 2744, 2745, 27412, 27425, 2755, 27424
11024, 27352, 27353, 2743, 2744, 27414, 27426, 2754, 27425
11025, 27353, 27354, 2742, 2743, 27416, 27427, 2753, 27426
11026, 27354, 2732, 68, 2742, 27417, 2736, 2752, 27427
*ELEMENT, type=CPS8, ELSET=Surface126
11027, 66, 2725, 27428, 2706, 2727, 27448, 27449, 2717
11028, 2706, 27428, 27429, 2705, 27449, 27450, 27451, 2716
11029, 2705, 27429, 27430, 2704, 27451, 27452, 27453, 2715
11030, 2704, 27430, 27431, 2703, 27453, 27454, 27455, 2714
11031, 2703, 27431, 27432, 2702, 27455, 27456, 27457, 2713
11032, 2702, 27432, 27433, 2701, 27457, 27458, 27459, 2712
11033, 2701, 27433, 27434, 2700, 27459, 27460, 27461, 2711
11034, 2700, 27434, 27435, 2699, 27461, 27462, 27463, 2710
11035, 2699, 27435, 27436, 2698, 27463, 27464, 27465, 2709
11036, 2698, 27436, 27437, 2697, 27465, 27466, 27467, 2708
11037, 2697, 27437, 2737, 64, 27467, 27468, 2739, 2707
11038, 2725, 2726, 27438, 27428, 2728, 27469, 27470, 27448
11039, 27428, 27438, 27439, 27429, 27470, 27471, 27472, 27450
11040, 27429, 27439, 27440, 27430, 27472, 27473, 27474, 27452
11041, 27430, 27440, 27441, 27431, 27474, 27475, 27476, 27454
11042, 27431, 27441, 27442, 27432, 27476, 27477, 27478, 27456
11043, 27432, 27442, 27443, 27433, 27478, 27479, 27480, 27458
11044, 27433, 27443, 27444, 27434, 27480, 27481, 27482, 27460
11045, 27434, 27444, 27445, 27435, 27482, 27483, 27484, 27462
11046, 27435, 27445, 27446, 27436, 27484, 27485, 27486, 27464
11047, 27436, 27446, 27447, 27437, 27486, 27487, 27488, 27466
11048, 27437, 27447, 2738, 2737, 27488, 27489, 2740, 27468
11049, 2726, 67, 2751, 27438, 2729, 2762, 27490, 27469
11050, 27438, 2751, 2750, 27439, 27490, 2761, 27491, 27471
11051, 27439, 2750, 2749, 27440, 27491, 2760, 27492, 27473
11052, 27440, 2749, 2748, 27441, 27492, 2759, 27493, 27475
11053, 27441, 2748, 2747, 27442, 27493, 2758, 27494, 27477
11054, 27442, 2747, 2746, 27443, 27494, 2757, 27495, 27479
11055, 27443, 2746, 2745, 27444, 27495, 2756, 27496, 27481
11056, 27444, 2745, 2744, 27445, 27496, 2755, 27497, 27483
11057, 27445, 2744, 2743, 27446, 27497, 2754, 27498, 27485
11058, 27446, 2743, 2742, 27447, 27498, 2753, 27499, 27487
11059, 27447, 2742, 68, 2738, 27499, 2752, 2741, 27489
*ELEMENT, type=CPS8, ELSET=Surface130
11060, 45, 2763, 27500, 2064, 2766, 27530, 27531, 2075
11061, 2064, 27500, 27501, 2063, 27531, 27532, 27533, 2074
11062, 2063, 27501, 27502, 2062, 27533, 27534, 27535, 2073
11063, 2062, 27502, 27503, 2061, 27535, 27536, 27537, 2072
11064, 2061, 27503, 27504, 2060, 27537, 27538, 27539, 2071
11065, 2060, 27504, 27505, 2059, 27539, 27540, 27541, 2070
11066, 2059, 27505, 27506, 2058, 27541, 27542, 27543, 2069
11067, 2058, 27506, 27507, 2057, 27543, 27544, 27545, 2068
11068, 2057, 27507, 27508, 2056, 27545, 27546, 27547, 2067
11069, 2056, 27508, 27509, 2055, 27547, 27548, 27549, 2066
11070, 2055, 27509, 2770, 46, 27549, 27550, 2773, 2065
11071, 2763, 2764, 27510, 27500, 2767, 27551, 27552, 27530
11072, 27500, 27510, 27511, 27501, 27552, 27553, 27554, 27532
11073, 27501, 27511, 27512, 27502, 27554, 27555, 27556, 27534
11074, 27502, 27512, 27513, 27503, 27556, 27557, 27558, 27536
11075, 27503, 27513, 27514, 27504, 27558, 27559, 27560, 27538
11076, 27504, 27514, 27515, 27505, 27560, 27561, 27562, 27540
11077, 27505, 27515, 27516, 27506, 27562, 27563, 27564, 27542
11078, 27506, 27516, 27517, 27507, 27564, 27565, 27566, 27544
11079, 27507, 27517, 27518, 27508, 27566, 27567, 27568, 27546
11080, 27508, 27518, 27519, 27509, 27568, 27569, 27570, 27548
11081, 27509, 27519, 2771, 2770, 27570, 27571, 2774, 27550
11082, 2764, 2765, 27520, 27510, 2768, 27572, 27573, 27551
11083, 27510, 27520, 27521, 27511, 27573, 27574, 27575, 27553
11084, 27511, 27521, 27522, 27512, 27575, 27576, 27577, 27555
11085, 27512, 27522, 27523, 27513, 27577, 27578, 27579, 27557
11086, 27513, 27523, 27524, 27514, 27579, 27580, 27581, 27559
11087, 27514, 27524, 27525, 27515, 27581, 27582, 27583, 27561
11088, 27515, 27525, 27526, 27516, 27583, 27584, 27585, 27563
11089, 27516, 27526, 27527, 27517, 27585, 27586, 27587, 27565
11090, 27517, 27527, 27528, 27518, 27587, 27588, 27589, 27567
11091, 27518, 27528, 27529, 27519, 27589, 27590, 27591, 27569
11092, 27519, 27529, 2772, 2771, 27591, 27592, 2775, 27571
11093, 2765, 69, 2786, 27520, 2769, 2797, 27593, 27572
11094, 27520, 2786, 2785, 27521, 27593, 2796, 27594, 27574
11095, 27521, 2785, 2784, 27522, 27594, 2795, 27595, 27576
11096, 27522, 2784, 2783, 27523, 27595, 2794, 27596, 27578
11097, 27523, 2783, 2782, 27524, 27596, 2793, 27597, 27580
11098, 27524, 2782, 2781, 27525, 27597, 2792, 27598, 27582
11099, 27525, 2781, 2780, 27526, 27598, 2791, 27599, 27584
11100, 27526, 2780, 2779, 27527, 27599, 2790, 27600, 27586
11101, 27527, 2779, 2778, 27528, 27600, 2789, 27601, 27588
11102, 27528, 2778, 2777, 27529, 27601, 2788, 27602, 27590
11103, 27529, 2777, 70, 2772, 27602, 2787, 2776, 27592
*ELEMENT, type=CPS8, ELSET=Surface132
11104, 45, 2763, 27603, 2081, 2766, 27609, 27610, 2083
11105, 2081, 27603, 27604, 2082, 27610, 27611, 27612, 2084
11106, 2082, 27604, 2798, 48, 27612, 27613, 2801, 2085
11107, 2763, 2764, 27605, 27603, 2767, 27614, 27615, 27609
11108, 27603, 27605, 27606, 27604, 27615, 27616, 27617, 27611
11109, 27604, 27606, 2799, 2798, 27617, 27618, 2802, 27613
11110, 2764, 2765, 27607, 27605, 2768, 27619, 27620, 27614
11111, 27605, 27607, 27608, 27606, 27620, 27621, 27622, 27616
11112, 27606, 27608, 2800, 2799, 27622, 27623, 2803, 27618
11113, 2765, 69, 2805, 27607, 2769, 2807, 27624, 27619
