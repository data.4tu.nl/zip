11114, 27607, 2805, 2806, 27608, 27624, 2808, 27625, 27621
11115, 27608, 2806, 71, 2800, 27625, 2809, 2804, 27623
*ELEMENT, type=CPS8, ELSET=Surface133
11116, 46, 2096, 27626, 2770, 2098, 27632, 27633, 2773
11117, 2096, 2097, 27627, 27626, 2099, 27634, 27635, 27632
11118, 2097, 50, 2810, 27627, 2100, 2813, 27636, 27634
11119, 2770, 27626, 27628, 2771, 27633, 27637, 27638, 2774
11120, 27626, 27627, 27629, 27628, 27635, 27639, 27640, 27637
11121, 27627, 2810, 2811, 27629, 27636, 2814, 27641, 27639
11122, 2771, 27628, 27630, 2772, 27638, 27642, 27643, 2775
11123, 27628, 27629, 27631, 27630, 27640, 27644, 27645, 27642
11124, 27629, 2811, 2812, 27631, 27641, 2815, 27646, 27644
11125, 2772, 27630, 2817, 70, 27643, 27647, 2819, 2776
11126, 27630, 27631, 2818, 2817, 27645, 27648, 2820, 27647
11127, 27631, 2812, 72, 2818, 27646, 2816, 2821, 27648
*ELEMENT, type=CPS8, ELSET=Surface134
11128, 48, 2798, 27649, 2136, 2801, 27679, 27680, 2147
11129, 2136, 27649, 27650, 2135, 27680, 27681, 27682, 2146
11130, 2135, 27650, 27651, 2134, 27682, 27683, 27684, 2145
11131, 2134, 27651, 27652, 2133, 27684, 27685, 27686, 2144
11132, 2133, 27652, 27653, 2132, 27686, 27687, 27688, 2143
11133, 2132, 27653, 27654, 2131, 27688, 27689, 27690, 2142
11134, 2131, 27654, 27655, 2130, 27690, 27691, 27692, 2141
11135, 2130, 27655, 27656, 2129, 27692, 27693, 27694, 2140
11136, 2129, 27656, 27657, 2128, 27694, 27695, 27696, 2139
11137, 2128, 27657, 27658, 2127, 27696, 27697, 27698, 2138
11138, 2127, 27658, 2810, 50, 27698, 27699, 2813, 2137
11139, 2798, 2799, 27659, 27649, 2802, 27700, 27701, 27679
11140, 27649, 27659, 27660, 27650, 27701, 27702, 27703, 27681
11141, 27650, 27660, 27661, 27651, 27703, 27704, 27705, 27683
11142, 27651, 27661, 27662, 27652, 27705, 27706, 27707, 27685
11143, 27652, 27662, 27663, 27653, 27707, 27708, 27709, 27687
11144, 27653, 27663, 27664, 27654, 27709, 27710, 27711, 27689
11145, 27654, 27664, 27665, 27655, 27711, 27712, 27713, 27691
11146, 27655, 27665, 27666, 27656, 27713, 27714, 27715, 27693
11147, 27656, 27666, 27667, 27657, 27715, 27716, 27717, 27695
11148, 27657, 27667, 27668, 27658, 27717, 27718, 27719, 27697
11149, 27658, 27668, 2811, 2810, 27719, 27720, 2814, 27699
11150, 2799, 2800, 27669, 27659, 2803, 27721, 27722, 27700
11151, 27659, 27669, 27670, 27660, 27722, 27723, 27724, 27702
11152, 27660, 27670, 27671, 27661, 27724, 27725, 27726, 27704
11153, 27661, 27671, 27672, 27662, 27726, 27727, 27728, 27706
11154, 27662, 27672, 27673, 27663, 27728, 27729, 27730, 27708
11155, 27663, 27673, 27674, 27664, 27730, 27731, 27732, 27710
11156, 27664, 27674, 27675, 27665, 27732, 27733, 27734, 27712
11157, 27665, 27675, 27676, 27666, 27734, 27735, 27736, 27714
11158, 27666, 27676, 27677, 27667, 27736, 27737, 27738, 27716
11159, 27667, 27677, 27678, 27668, 27738, 27739, 27740, 27718
11160, 27668, 27678, 2812, 2811, 27740, 27741, 2815, 27720
11161, 2800, 71, 2831, 27669, 2804, 2842, 27742, 27721
11162, 27669, 2831, 2830, 27670, 27742, 2841, 27743, 27723
11163, 27670, 2830, 2829, 27671, 27743, 2840, 27744, 27725
11164, 27671, 2829, 2828, 27672, 27744, 2839, 27745, 27727
11165, 27672, 2828, 2827, 27673, 27745, 2838, 27746, 27729
11166, 27673, 2827, 2826, 27674, 27746, 2837, 27747, 27731
11167, 27674, 2826, 2825, 27675, 27747, 2836, 27748, 27733
11168, 27675, 2825, 2824, 27676, 27748, 2835, 27749, 27735
11169, 27676, 2824, 2823, 27677, 27749, 2834, 27750, 27737
11170, 27677, 2823, 2822, 27678, 27750, 2833, 27751, 27739
11171, 27678, 2822, 72, 2812, 27751, 2832, 2816, 27741
*ELEMENT, type=CPS8, ELSET=Surface135
11172, 69, 2786, 27752, 2805, 2797, 27772, 27773, 2807
11173, 2786, 2785, 27753, 27752, 2796, 27774, 27775, 27772
11174, 2785, 2784, 27754, 27753, 2795, 27776, 27777, 27774
11175, 2784, 2783, 27755, 27754, 2794, 27778, 27779, 27776
11176, 2783, 2782, 27756, 27755, 2793, 27780, 27781, 27778
11177, 2782, 2781, 27757, 27756, 2792, 27782, 27783, 27780
11178, 2781, 2780, 27758, 27757, 2791, 27784, 27785, 27782
11179, 2780, 2779, 27759, 27758, 2790, 27786, 27787, 27784
11180, 2779, 2778, 27760, 27759, 2789, 27788, 27789, 27786
11181, 2778, 2777, 27761, 27760, 2788, 27790, 27791, 27788
11182, 2777, 70, 2817, 27761, 2787, 2819, 27792, 27790
11183, 2805, 27752, 27762, 2806, 27773, 27793, 27794, 2808
11184, 27752, 27753, 27763, 27762, 27775, 27795, 27796, 27793
11185, 27753, 27754, 27764, 27763, 27777, 27797, 27798, 27795
11186, 27754, 27755, 27765, 27764, 27779, 27799, 27800, 27797
11187, 27755, 27756, 27766, 27765, 27781, 27801, 27802, 27799
11188, 27756, 27757, 27767, 27766, 27783, 27803, 27804, 27801
11189, 27757, 27758, 27768, 27767, 27785, 27805, 27806, 27803
11190, 27758, 27759, 27769, 27768, 27787, 27807, 27808, 27805
11191, 27759, 27760, 27770, 27769, 27789, 27809, 27810, 27807
11192, 27760, 27761, 27771, 27770, 27791, 27811, 27812, 27809
11193, 27761, 2817, 2818, 27771, 27792, 2820, 27813, 27811
11194, 2806, 27762, 2831, 71, 27794, 27814, 2842, 2809
11195, 27762, 27763, 2830, 2831, 27796, 27815, 2841, 27814
11196, 27763, 27764, 2829, 2830, 27798, 27816, 2840, 27815
11197, 27764, 27765, 2828, 2829, 27800, 27817, 2839, 27816
11198, 27765, 27766, 2827, 2828, 27802, 27818, 2838, 27817
11199, 27766, 27767, 2826, 2827, 27804, 27819, 2837, 27818
11200, 27767, 27768, 2825, 2826, 27806, 27820, 2836, 27819
11201, 27768, 27769, 2824, 2825, 27808, 27821, 2835, 27820
11202, 27769, 27770, 2823, 2824, 27810, 27822, 2834, 27821
11203, 27770, 27771, 2822, 2823, 27812, 27823, 2833, 27822
11204, 27771, 2818, 72, 2822, 27813, 2821, 2832, 27823
*ELEMENT, type=CPS8, ELSET=Surface141
11205, 24, 2307, 27824, 2843, 2310, 27830, 27831, 2845
11206, 2307, 2308, 27825, 27824, 2311, 27832, 27833, 27830
11207, 2308, 2309, 27826, 27825, 2312, 27834, 27835, 27832
11208, 2309, 58, 2848, 27826, 2313, 2850, 27836, 27834
11209, 2843, 27824, 27827, 2844, 27831, 27837, 27838, 2846
11210, 27824, 27825, 27828, 27827, 27833, 27839, 27840, 27837
11211, 27825, 27826, 27829, 27828, 27835, 27841, 27842, 27839
11212, 27826, 2848, 2849, 27829, 27836, 2851, 27843, 27841
11213, 2844, 27827, 2853, 73, 27838, 27844, 2856, 2847
11214, 27827, 27828, 2854, 2853, 27840, 27845, 2857, 27844
11215, 27828, 27829, 2855, 2854, 27842, 27846, 2858, 27845
11216, 27829, 2849, 74, 2855, 27843, 2852, 2859, 27846
*ELEMENT, type=CPS8, ELSET=Surface142
11217, 22, 2860, 27847, 2227, 2862, 27853, 27854, 2230
11218, 2227, 27847, 27848, 2228, 27854, 27855, 27856, 2231
11219, 2228, 27848, 27849, 2229, 27856, 27857, 27858, 2232
11220, 2229, 27849, 2865, 56, 27858, 27859, 2867, 2233
11221, 2860, 2861, 27850, 27847, 2863, 27860, 27861, 27853
11222, 27847, 27850, 27851, 27848, 27861, 27862, 27863, 27855
11223, 27848, 27851, 27852, 27849, 27863, 27864, 27865, 27857
11224, 27849, 27852, 2866, 2865, 27865, 27866, 2868, 27859
11225, 2861, 75, 2870, 27850, 2864, 2873, 27867, 27860
11226, 27850, 2870, 2871, 27851, 27867, 2874, 27868, 27862
11227, 27851, 2871, 2872, 27852, 27868, 2875, 27869, 27864
11228, 27852, 2872, 76, 2866, 27869, 2876, 2869, 27866
*ELEMENT, type=CPS8, ELSET=Surface143
11229, 24, 2843, 27870, 1113, 2845, 27890, 27891, 1124
11230, 1113, 27870, 27871, 1112, 27891, 27892, 27893, 1123
11231, 1112, 27871, 27872, 1111, 27893, 27894, 27895, 1122
11232, 1111, 27872, 27873, 1110, 27895, 27896, 27897, 1121
11233, 1110, 27873, 27874, 1109, 27897, 27898, 27899, 1120
11234, 1109, 27874, 27875, 1108, 27899, 27900, 27901, 1119
11235, 1108, 27875, 27876, 1107, 27901, 27902, 27903, 1118
11236, 1107, 27876, 27877, 1106, 27903, 27904, 27905, 1117
11237, 1106, 27877, 27878, 1105, 27905, 27906, 27907, 1116
11238, 1105, 27878, 27879, 1104, 27907, 27908, 27909, 1115
11239, 1104, 27879, 2860, 22, 27909, 27910, 2862, 1114
11240, 2843, 2844, 27880, 27870, 2846, 27911, 27912, 27890
11241, 27870, 27880, 27881, 27871, 27912, 27913, 27914, 27892
11242, 27871, 27881, 27882, 27872, 27914, 27915, 27916, 27894
11243, 27872, 27882, 27883, 27873, 27916, 27917, 27918, 27896
11244, 27873, 27883, 27884, 27874, 27918, 27919, 27920, 27898
11245, 27874, 27884, 27885, 27875, 27920, 27921, 27922, 27900
11246, 27875, 27885, 27886, 27876, 27922, 27923, 27924, 27902
11247, 27876, 27886, 27887, 27877, 27924, 27925, 27926, 27904
11248, 27877, 27887, 27888, 27878, 27926, 27927, 27928, 27906
11249, 27878, 27888, 27889, 27879, 27928, 27929, 27930, 27908
11250, 27879, 27889, 2861, 2860, 27930, 27931, 2863, 27910
11251, 2844, 73, 2886, 27880, 2847, 2897, 27932, 27911
11252, 27880, 2886, 2885, 27881, 27932, 2896, 27933, 27913
11253, 27881, 2885, 2884, 27882, 27933, 2895, 27934, 27915
11254, 27882, 2884, 2883, 27883, 27934, 2894, 27935, 27917
11255, 27883, 2883, 2882, 27884, 27935, 2893, 27936, 27919
11256, 27884, 2882, 2881, 27885, 27936, 2892, 27937, 27921
11257, 27885, 2881, 2880, 27886, 27937, 2891, 27938, 27923
11258, 27886, 2880, 2879, 27887, 27938, 2890, 27939, 27925
11259, 27887, 2879, 2878, 27888, 27939, 2889, 27940, 27927
11260, 27888, 2878, 2877, 27889, 27940, 2888, 27941, 27929
11261, 27889, 2877, 75, 2861, 27941, 2887, 2864, 27931
*ELEMENT, type=CPS8, ELSET=Surface144
11262, 58, 2368, 27942, 2848, 2379, 27962, 27963, 2850
11263, 2368, 2367, 27943, 27942, 2378, 27964, 27965, 27962
11264, 2367, 2366, 27944, 27943, 2377, 27966, 27967, 27964
11265, 2366, 2365, 27945, 27944, 2376, 27968, 27969, 27966
11266, 2365, 2364, 27946, 27945, 2375, 27970, 27971, 27968
11267, 2364, 2363, 27947, 27946, 2374, 27972, 27973, 27970
11268, 2363, 2362, 27948, 27947, 2373, 27974, 27975, 27972
11269, 2362, 2361, 27949, 27948, 2372, 27976, 27977, 27974
11270, 2361, 2360, 27950, 27949, 2371, 27978, 27979, 27976
11271, 2360, 2359, 27951, 27950, 2370, 27980, 27981, 27978
11272, 2359, 56, 2865, 27951, 2369, 2867, 27982, 27980
11273, 2848, 27942, 27952, 2849, 27963, 27983, 27984, 2851
11274, 27942, 27943, 27953, 27952, 27965, 27985, 27986, 27983
11275, 27943, 27944, 27954, 27953, 27967, 27987, 27988, 27985
11276, 27944, 27945, 27955, 27954, 27969, 27989, 27990, 27987
11277, 27945, 27946, 27956, 27955, 27971, 27991, 27992, 27989
11278, 27946, 27947, 27957, 27956, 27973, 27993, 27994, 27991
11279, 27947, 27948, 27958, 27957, 27975, 27995, 27996, 27993
11280, 27948, 27949, 27959, 27958, 27977, 27997, 27998, 27995
11281, 27949, 27950, 27960, 27959, 27979, 27999, 28000, 27997
11282, 27950, 27951, 27961, 27960, 27981, 28001, 28002, 27999
11283, 27951, 2865, 2866, 27961, 27982, 2868, 28003, 28001
11284, 2849, 27952, 2907, 74, 27984, 28004, 2918, 2852
11285, 27952, 27953, 2906, 2907, 27986, 28005, 2917, 28004
11286, 27953, 27954, 2905, 2906, 27988, 28006, 2916, 28005
11287, 27954, 27955, 2904, 2905, 27990, 28007, 2915, 28006
11288, 27955, 27956, 2903, 2904, 27992, 28008, 2914, 28007
11289, 27956, 27957, 2902, 2903, 27994, 28009, 2913, 28008
11290, 27957, 27958, 2901, 2902, 27996, 28010, 2912, 28009
11291, 27958, 27959, 2900, 2901, 27998, 28011, 2911, 28010
11292, 27959, 27960, 2899, 2900, 28000, 28012, 2910, 28011
11293, 27960, 27961, 2898, 2899, 28002, 28013, 2909, 28012
11294, 27961, 2866, 76, 2898, 28003, 2869, 2908, 28013
*ELEMENT, type=CPS8, ELSET=Surface145
11295, 73, 2853, 28014, 2886, 2856, 28044, 28045, 2897
11296, 2886, 28014, 28015, 2885, 28045, 28046, 28047, 2896
11297, 2885, 28015, 28016, 2884, 28047, 28048, 28049, 2895
11298, 2884, 28016, 28017, 2883, 28049, 28050, 28051, 2894
11299, 2883, 28017, 28018, 2882, 28051, 28052, 28053, 2893
11300, 2882, 28018, 28019, 2881, 28053, 28054, 28055, 2892
11301, 2881, 28019, 28020, 2880, 28055, 28056, 28057, 2891
11302, 2880, 28020, 28021, 2879, 28057, 28058, 28059, 2890
11303, 2879, 28021, 28022, 2878, 28059, 28060, 28061, 2889
11304, 2878, 28022, 28023, 2877, 28061, 28062, 28063, 2888
11305, 2877, 28023, 2870, 75, 28063, 28064, 2873, 2887
11306, 2853, 2854, 28024, 28014, 2857, 28065, 28066, 28044
11307, 28014, 28024, 28025, 28015, 28066, 28067, 28068, 28046
11308, 28015, 28025, 28026, 28016, 28068, 28069, 28070, 28048
11309, 28016, 28026, 28027, 28017, 28070, 28071, 28072, 28050
11310, 28017, 28027, 28028, 28018, 28072, 28073, 28074, 28052
11311, 28018, 28028, 28029, 28019, 28074, 28075, 28076, 28054
11312, 28019, 28029, 28030, 28020, 28076, 28077, 28078, 28056
11313, 28020, 28030, 28031, 28021, 28078, 28079, 28080, 28058
11314, 28021, 28031, 28032, 28022, 28080, 28081, 28082, 28060
11315, 28022, 28032, 28033, 28023, 28082, 28083, 28084, 28062
11316, 28023, 28033, 2871, 2870, 28084, 28085, 2874, 28064
11317, 2854, 2855, 28034, 28024, 2858, 28086, 28087, 28065
11318, 28024, 28034, 28035, 28025, 28087, 28088, 28089, 28067
11319, 28025, 28035, 28036, 28026, 28089, 28090, 28091, 28069
11320, 28026, 28036, 28037, 28027, 28091, 28092, 28093, 28071
11321, 28027, 28037, 28038, 28028, 28093, 28094, 28095, 28073
11322, 28028, 28038, 28039, 28029, 28095, 28096, 28097, 28075
11323, 28029, 28039, 28040, 28030, 28097, 28098, 28099, 28077
11324, 28030, 28040, 28041, 28031, 28099, 28100, 28101, 28079
11325, 28031, 28041, 28042, 28032, 28101, 28102, 28103, 28081
11326, 28032, 28042, 28043, 28033, 28103, 28104, 28105, 28083
11327, 28033, 28043, 2872, 2871, 28105, 28106, 2875, 28085
11328, 2855, 74, 2907, 28034, 2859, 2918, 28107, 28086
11329, 28034, 2907, 2906, 28035, 28107, 2917, 28108, 28088
11330, 28035, 2906, 2905, 28036, 28108, 2916, 28109, 28090
11331, 28036, 2905, 2904, 28037, 28109, 2915, 28110, 28092
11332, 28037, 2904, 2903, 28038, 28110, 2914, 28111, 28094
11333, 28038, 2903, 2902, 28039, 28111, 2913, 28112, 28096
11334, 28039, 2902, 2901, 28040, 28112, 2912, 28113, 28098
11335, 28040, 2901, 2900, 28041, 28113, 2911, 28114, 28100
11336, 28041, 2900, 2899, 28042, 28114, 2910, 28115, 28102
11337, 28042, 2899, 2898, 28043, 28115, 2909, 28116, 28104
11338, 28043, 2898, 76, 2872, 28116, 2908, 2876, 28106
*ELEMENT, type=CPS8, ELSET=Surface146
11339, 20, 1054, 28117, 2919, 1056, 28121, 28122, 2921
11340, 1054, 1055, 28118, 28117, 1057, 28123, 28124, 28121
11341, 1055, 24, 2843, 28118, 1058, 2845, 28125, 28123
11342, 2919, 28117, 28119, 2920, 28122, 28126, 28127, 2922
11343, 28117, 28118, 28120, 28119, 28124, 28128, 28129, 28126
11344, 28118, 2843, 2844, 28120, 28125, 2846, 28130, 28128
11345, 2920, 28119, 2924, 77, 28127, 28131, 2926, 2923
11346, 28119, 28120, 2925, 2924, 28129, 28132, 2927, 28131
11347, 28120, 2844, 73, 2925, 28130, 2847, 2928, 28132
*ELEMENT, type=CPS8, ELSET=Surface147
11348, 18, 2929, 28133, 978, 2931, 28137, 28138, 980
11349, 978, 28133, 28134, 979, 28138, 28139, 28140, 981
11350, 979, 28134, 2860, 22, 28140, 28141, 2862, 982
11351, 2929, 2930, 28135, 28133, 2932, 28142, 28143, 28137
11352, 28133, 28135, 28136, 28134, 28143, 28144, 28145, 28139
11353, 28134, 28136, 2861, 2860, 28145, 28146, 2863, 28141
11354, 2930, 78, 2934, 28135, 2933, 2936, 28147, 28142
11355, 28135, 2934, 2935, 28136, 28147, 2937, 28148, 28144
11356, 28136, 2935, 75, 2861, 28148, 2938, 2864, 28146
*ELEMENT, type=CPS8, ELSET=Surface148
11357, 20, 2919, 28149, 961, 2921, 28169, 28170, 972
11358, 961, 28149, 28150, 960, 28170, 28171, 28172, 971
11359, 960, 28150, 28151, 959, 28172, 28173, 28174, 970
11360, 959, 28151, 28152, 958, 28174, 28175, 28176, 969
11361, 958, 28152, 28153, 957, 28176, 28177, 28178, 968
11362, 957, 28153, 28154, 956, 28178, 28179, 28180, 967
11363, 956, 28154, 28155, 955, 28180, 28181, 28182, 966
11364, 955, 28155, 28156, 954, 28182, 28183, 28184, 965
11365, 954, 28156, 28157, 953, 28184, 28185, 28186, 964
11366, 953, 28157, 28158, 952, 28186, 28187, 28188, 963
11367, 952, 28158, 2929, 18, 28188, 28189, 2931, 962
11368, 2919, 2920, 28159, 28149, 2922, 28190, 28191, 28169
11369, 28149, 28159, 28160, 28150, 28191, 28192, 28193, 28171
11370, 28150, 28160, 28161, 28151, 28193, 28194, 28195, 28173
11371, 28151, 28161, 28162, 28152, 28195, 28196, 28197, 28175
11372, 28152, 28162, 28163, 28153, 28197, 28198, 28199, 28177
11373, 28153, 28163, 28164, 28154, 28199, 28200, 28201, 28179
11374, 28154, 28164, 28165, 28155, 28201, 28202, 28203, 28181
11375, 28155, 28165, 28166, 28156, 28203, 28204, 28205, 28183
11376, 28156, 28166, 28167, 28157, 28205, 28206, 28207, 28185
11377, 28157, 28167, 28168, 28158, 28207, 28208, 28209, 28187
11378, 28158, 28168, 2930, 2929, 28209, 28210, 2932, 28189
11379, 2920, 77, 2948, 28159, 2923, 2959, 28211, 28190
11380, 28159, 2948, 2947, 28160, 28211, 2958, 28212, 28192
11381, 28160, 2947, 2946, 28161, 28212, 2957, 28213, 28194
11382, 28161, 2946, 2945, 28162, 28213, 2956, 28214, 28196
11383, 28162, 2945, 2944, 28163, 28214, 2955, 28215, 28198
11384, 28163, 2944, 2943, 28164, 28215, 2954, 28216, 28200
11385, 28164, 2943, 2942, 28165, 28216, 2953, 28217, 28202
11386, 28165, 2942, 2941, 28166, 28217, 2952, 28218, 28204
11387, 28166, 2941, 2940, 28167, 28218, 2951, 28219, 28206
11388, 28167, 2940, 2939, 28168, 28219, 2950, 28220, 28208
11389, 28168, 2939, 78, 2930, 28220, 2949, 2933, 28210
*ELEMENT, type=CPS8, ELSET=Surface149
11390, 77, 2924, 28221, 2948, 2926, 28241, 28242, 2959
11391, 2948, 28221, 28222, 2947, 28242, 28243, 28244, 2958
11392, 2947, 28222, 28223, 2946, 28244, 28245, 28246, 2957
11393, 2946, 28223, 28224, 2945, 28246, 28247, 28248, 2956
11394, 2945, 28224, 28225, 2944, 28248, 28249, 28250, 2955
11395, 2944, 28225, 28226, 2943, 28250, 28251, 28252, 2954
11396, 2943, 28226, 28227, 2942, 28252, 28253, 28254, 2953
11397, 2942, 28227, 28228, 2941, 28254, 28255, 28256, 2952
11398, 2941, 28228, 28229, 2940, 28256, 28257, 28258, 2951
11399, 2940, 28229, 28230, 2939, 28258, 28259, 28260, 2950
11400, 2939, 28230, 2934, 78, 28260, 28261, 2936, 2949
11401, 2924, 2925, 28231, 28221, 2927, 28262, 28263, 28241
11402, 28221, 28231, 28232, 28222, 28263, 28264, 28265, 28243
11403, 28222, 28232, 28233, 28223, 28265, 28266, 28267, 28245
11404, 28223, 28233, 28234, 28224, 28267, 28268, 28269, 28247
11405, 28224, 28234, 28235, 28225, 28269, 28270, 28271, 28249
11406, 28225, 28235, 28236, 28226, 28271, 28272, 28273, 28251
11407, 28226, 28236, 28237, 28227, 28273, 28274, 28275, 28253
11408, 28227, 28237, 28238, 28228, 28275, 28276, 28277, 28255
11409, 28228, 28238, 28239, 28229, 28277, 28278, 28279, 28257
11410, 28229, 28239, 28240, 28230, 28279, 28280, 28281, 28259
11411, 28230, 28240, 2935, 2934, 28281, 28282, 2937, 28261
11412, 2925, 73, 2886, 28231, 2928, 2897, 28283, 28262
11413, 28231, 2886, 2885, 28232, 28283, 2896, 28284, 28264
11414, 28232, 2885, 2884, 28233, 28284, 2895, 28285, 28266
11415, 28233, 2884, 2883, 28234, 28285, 2894, 28286, 28268
11416, 28234, 2883, 2882, 28235, 28286, 2893, 28287, 28270
11417, 28235, 2882, 2881, 28236, 28287, 2892, 28288, 28272
11418, 28236, 2881, 2880, 28237, 28288, 2891, 28289, 28274
11419, 28237, 2880, 2879, 28238, 28289, 2890, 28290, 28276
11420, 28238, 2879, 2878, 28239, 28290, 2889, 28291, 28278
11421, 28239, 2878, 2877, 28240, 28291, 2888, 28292, 28280
11422, 28240, 2877, 75, 2935, 28292, 2887, 2938, 28282
*ELEMENT, type=CPS8, ELSET=Surface150
11423, 30, 2960, 28293, 2433, 2962, 28299, 28300, 2436
11424, 2433, 28293, 28294, 2434, 28300, 28301, 28302, 2437
11425, 2434, 28294, 28295, 2435, 28302, 28303, 28304, 2438
11426, 2435, 28295, 2965, 61, 28304, 28305, 2967, 2439
11427, 2960, 2961, 28296, 28293, 2963, 28306, 28307, 28299
11428, 28293, 28296, 28297, 28294, 28307, 28308, 28309, 28301
11429, 28294, 28297, 28298, 28295, 28309, 28310, 28311, 28303
11430, 28295, 28298, 2966, 2965, 28311, 28312, 2968, 28305
11431, 2961, 79, 2970, 28296, 2964, 2973, 28313, 28306
11432, 28296, 2970, 2971, 28297, 28313, 2974, 28314, 28308
11433, 28297, 2971, 2972, 28298, 28314, 2975, 28315, 28310
11434, 28298, 2972, 80, 2966, 28315, 2976, 2969, 28312
*ELEMENT, type=CPS8, ELSET=Surface151
11435, 32, 2485, 28316, 2977, 2488, 28322, 28323, 2979
11436, 2485, 2486, 28317, 28316, 2489, 28324, 28325, 28322
11437, 2486, 2487, 28318, 28317, 2490, 28326, 28327, 28324
11438, 2487, 62, 2982, 28318, 2491, 2984, 28328, 28326
11439, 2977, 28316, 28319, 2978, 28323, 28329, 28330, 2980
11440, 28316, 28317, 28320, 28319, 28325, 28331, 28332, 28329
11441, 28317, 28318, 28321, 28320, 28327, 28333, 28334, 28331
11442, 28318, 2982, 2983, 28321, 28328, 2985, 28335, 28333
11443, 2978, 28319, 2987, 81, 28330, 28336, 2990, 2981
11444, 28319, 28320, 2988, 2987, 28332, 28337, 2991, 28336
11445, 28320, 28321, 2989, 2988, 28334, 28338, 2992, 28337
11446, 28321, 2983, 82, 2989, 28335, 2986, 2993, 28338
*ELEMENT, type=CPS8, ELSET=Surface152
11447, 30, 1433, 28339, 2960, 1444, 28359, 28360, 2962
11448, 1433, 1432, 28340, 28339, 1443, 28361, 28362, 28359
11449, 1432, 1431, 28341, 28340, 1442, 28363, 28364, 28361
11450, 1431, 1430, 28342, 28341, 1441, 28365, 28366, 28363
11451, 1430, 1429, 28343, 28342, 1440, 28367, 28368, 28365
11452, 1429, 1428, 28344, 28343, 1439, 28369, 28370, 28367
11453, 1428, 1427, 28345, 28344, 1438, 28371, 28372, 28369
11454, 1427, 1426, 28346, 28345, 1437, 28373, 28374, 28371
11455, 1426, 1425, 28347, 28346, 1436, 28375, 28376, 28373
11456, 1425, 1424, 28348, 28347, 1435, 28377, 28378, 28375
11457, 1424, 32, 2977, 28348, 1434, 2979, 28379, 28377
11458, 2960, 28339, 28349, 2961, 28360, 28380, 28381, 2963
11459, 28339, 28340, 28350, 28349, 28362, 28382, 28383, 28380
11460, 28340, 28341, 28351, 28350, 28364, 28384, 28385, 28382
11461, 28341, 28342, 28352, 28351, 28366, 28386, 28387, 28384
11462, 28342, 28343, 28353, 28352, 28368, 28388, 28389, 28386
11463, 28343, 28344, 28354, 28353, 28370, 28390, 28391, 28388
11464, 28344, 28345, 28355, 28354, 28372, 28392, 28393, 28390
11465, 28345, 28346, 28356, 28355, 28374, 28394, 28395, 28392
11466, 28346, 28347, 28357, 28356, 28376, 28396, 28397, 28394
11467, 28347, 28348, 28358, 28357, 28378, 28398, 28399, 28396
11468, 28348, 2977, 2978, 28358, 28379, 2980, 28400, 28398
11469, 2961, 28349, 3003, 79, 28381, 28401, 3014, 2964
11470, 28349, 28350, 3002, 3003, 28383, 28402, 3013, 28401
11471, 28350, 28351, 3001, 3002, 28385, 28403, 3012, 28402
11472, 28351, 28352, 3000, 3001, 28387, 28404, 3011, 28403
11473, 28352, 28353, 2999, 3000, 28389, 28405, 3010, 28404
11474, 28353, 28354, 2998, 2999, 28391, 28406, 3009, 28405
11475, 28354, 28355, 2997, 2998, 28393, 28407, 3008, 28406
11476, 28355, 28356, 2996, 2997, 28395, 28408, 3007, 28407
11477, 28356, 28357, 2995, 2996, 28397, 28409, 3006, 28408
11478, 28357, 28358, 2994, 2995, 28399, 28410, 3005, 28409
11479, 28358, 2978, 81, 2994, 28400, 2981, 3004, 28410
*ELEMENT, type=CPS8, ELSET=Surface153
11480, 61, 2965, 28411, 2546, 2967, 28431, 28432, 2557
11481, 2546, 28411, 28412, 2545, 28432, 28433, 28434, 2556
11482, 2545, 28412, 28413, 2544, 28434, 28435, 28436, 2555
11483, 2544, 28413, 28414, 2543, 28436, 28437, 28438, 2554
11484, 2543, 28414, 28415, 2542, 28438, 28439, 28440, 2553
11485, 2542, 28415, 28416, 2541, 28440, 28441, 28442, 2552
11486, 2541, 28416, 28417, 2540, 28442, 28443, 28444, 2551
11487, 2540, 28417, 28418, 2539, 28444, 28445, 28446, 2550
11488, 2539, 28418, 28419, 2538, 28446, 28447, 28448, 2549
11489, 2538, 28419, 28420, 2537, 28448, 28449, 28450, 2548
11490, 2537, 28420, 2982, 62, 28450, 28451, 2984, 2547
11491, 2965, 2966, 28421, 28411, 2968, 28452, 28453, 28431
11492, 28411, 28421, 28422, 28412, 28453, 28454, 28455, 28433
11493, 28412, 28422, 28423, 28413, 28455, 28456, 28457, 28435
11494, 28413, 28423, 28424, 28414, 28457, 28458, 28459, 28437
11495, 28414, 28424, 28425, 28415, 28459, 28460, 28461, 28439
11496, 28415, 28425, 28426, 28416, 28461, 28462, 28463, 28441
11497, 28416, 28426, 28427, 28417, 28463, 28464, 28465, 28443
11498, 28417, 28427, 28428, 28418, 28465, 28466, 28467, 28445
11499, 28418, 28428, 28429, 28419, 28467, 28468, 28469, 28447
11500, 28419, 28429, 28430, 28420, 28469, 28470, 28471, 28449
11501, 28420, 28430, 2983, 2982, 28471, 28472, 2985, 28451
11502, 2966, 80, 3024, 28421, 2969, 3035, 28473, 28452
11503, 28421, 3024, 3023, 28422, 28473, 3034, 28474, 28454
11504, 28422, 3023, 3022, 28423, 28474, 3033, 28475, 28456
11505, 28423, 3022, 3021, 28424, 28475, 3032, 28476, 28458
11506, 28424, 3021, 3020, 28425, 28476, 3031, 28477, 28460
11507, 28425, 3020, 3019, 28426, 28477, 3030, 28478, 28462
11508, 28426, 3019, 3018, 28427, 28478, 3029, 28479, 28464
11509, 28427, 3018, 3017, 28428, 28479, 3028, 28480, 28466
11510, 28428, 3017, 3016, 28429, 28480, 3027, 28481, 28468
11511, 28429, 3016, 3015, 28430, 28481, 3026, 28482, 28470
11512, 28430, 3015, 82, 2983, 28482, 3025, 2986, 28472
*ELEMENT, type=CPS8, ELSET=Surface154
11513, 79, 3003, 28483, 2970, 3014, 28513, 28514, 2973
11514, 3003, 3002, 28484, 28483, 3013, 28515, 28516, 28513
11515, 3002, 3001, 28485, 28484, 3012, 28517, 28518, 28515
11516, 3001, 3000, 28486, 28485, 3011, 28519, 28520, 28517
11517, 3000, 2999, 28487, 28486, 3010, 28521, 28522, 28519
11518, 2999, 2998, 28488, 28487, 3009, 28523, 28524, 28521
11519, 2998, 2997, 28489, 28488, 3008, 28525, 28526, 28523
11520, 2997, 2996, 28490, 28489, 3007, 28527, 28528, 28525
11521, 2996, 2995, 28491, 28490, 3006, 28529, 28530, 28527
11522, 2995, 2994, 28492, 28491, 3005, 28531, 28532, 28529
11523, 2994, 81, 2987, 28492, 3004, 2990, 28533, 28531
11524, 2970, 28483, 28493, 2971, 28514, 28534, 28535, 2974
11525, 28483, 28484, 28494, 28493, 28516, 28536, 28537, 28534
11526, 28484, 28485, 28495, 28494, 28518, 28538, 28539, 28536
11527, 28485, 28486, 28496, 28495, 28520, 28540, 28541, 28538
11528, 28486, 28487, 28497, 28496, 28522, 28542, 28543, 28540
11529, 28487, 28488, 28498, 28497, 28524, 28544, 28545, 28542
11530, 28488, 28489, 28499, 28498, 28526, 28546, 28547, 28544
11531, 28489, 28490, 28500, 28499, 28528, 28548, 28549, 28546
11532, 28490, 28491, 28501, 28500, 28530, 28550, 28551, 28548
11533, 28491, 28492, 28502, 28501, 28532, 28552, 28553, 28550
11534, 28492, 2987, 2988, 28502, 28533, 2991, 28554, 28552
11535, 2971, 28493, 28503, 2972, 28535, 28555, 28556, 2975
11536, 28493, 28494, 28504, 28503, 28537, 28557, 28558, 28555
11537, 28494, 28495, 28505, 28504, 28539, 28559, 28560, 28557
11538, 28495, 28496, 28506, 28505, 28541, 28561, 28562, 28559
11539, 28496, 28497, 28507, 28506, 28543, 28563, 28564, 28561
11540, 28497, 28498, 28508, 28507, 28545, 28565, 28566, 28563
11541, 28498, 28499, 28509, 28508, 28547, 28567, 28568, 28565
11542, 28499, 28500, 28510, 28509, 28549, 28569, 28570, 28567
11543, 28500, 28501, 28511, 28510, 28551, 28571, 28572, 28569
11544, 28501, 28502, 28512, 28511, 28553, 28573, 28574, 28571
11545, 28502, 2988, 2989, 28512, 28554, 2992, 28575, 28573
11546, 2972, 28503, 3024, 80, 28556, 28576, 3035, 2976
11547, 28503, 28504, 3023, 3024, 28558, 28577, 3034, 28576
11548, 28504, 28505, 3022, 3023, 28560, 28578, 3033, 28577
11549, 28505, 28506, 3021, 3022, 28562, 28579, 3032, 28578
11550, 28506, 28507, 3020, 3021, 28564, 28580, 3031, 28579
11551, 28507, 28508, 3019, 3020, 28566, 28581, 3030, 28580
11552, 28508, 28509, 3018, 3019, 28568, 28582, 3029, 28581
11553, 28509, 28510, 3017, 3018, 28570, 28583, 3028, 28582
11554, 28510, 28511, 3016, 3017, 28572, 28584, 3027, 28583
11555, 28511, 28512, 3015, 3016, 28574, 28585, 3026, 28584
11556, 28512, 2989, 82, 3015, 28575, 2993, 3025, 28585
*ELEMENT, type=CPS8, ELSET=Surface155
11557, 29, 3036, 28586, 1303, 3038, 28590, 28591, 1305
11558, 1303, 28586, 28587, 1304, 28591, 28592, 28593, 1306
11559, 1304, 28587, 2960, 30, 28593, 28594, 2962, 1307
11560, 3036, 3037, 28588, 28586, 3039, 28595, 28596, 28590
11561, 28586, 28588, 28589, 28587, 28596, 28597, 28598, 28592
11562, 28587, 28589, 2961, 2960, 28598, 28599, 2963, 28594
11563, 3037, 83, 3041, 28588, 3040, 3043, 28600, 28595
11564, 28588, 3041, 3042, 28589, 28600, 3044, 28601, 28597
11565, 28589, 3042, 79, 2961, 28601, 3045, 2964, 28599
*ELEMENT, type=CPS8, ELSET=Surface156
11566, 31, 1398, 28602, 3046, 1400, 28606, 28607, 3048
11567, 1398, 1399, 28603, 28602, 1401, 28608, 28609, 28606
11568, 1399, 32, 2977, 28603, 1402, 2979, 28610, 28608
11569, 3046, 28602, 28604, 3047, 28607, 28611, 28612, 3049
11570, 28602, 28603, 28605, 28604, 28609, 28613, 28614, 28611
11571, 28603, 2977, 2978, 28605, 28610, 2980, 28615, 28613
11572, 3047, 28604, 3051, 84, 28612, 28616, 3053, 3050
11573, 28604, 28605, 3052, 3051, 28614, 28617, 3054, 28616
11574, 28605, 2978, 81, 3052, 28615, 2981, 3055, 28617
*ELEMENT, type=CPS8, ELSET=Surface157
11575, 29, 1412, 28618, 3036, 1423, 28638, 28639, 3038
11576, 1412, 1411, 28619, 28618, 1422, 28640, 28641, 28638
11577, 1411, 1410, 28620, 28619, 1421, 28642, 28643, 28640
11578, 1410, 1409, 28621, 28620, 1420, 28644, 28645, 28642
11579, 1409, 1408, 28622, 28621, 1419, 28646, 28647, 28644
11580, 1408, 1407, 28623, 28622, 1418, 28648, 28649, 28646
11581, 1407, 1406, 28624, 28623, 1417, 28650, 28651, 28648
11582, 1406, 1405, 28625, 28624, 1416, 28652, 28653, 28650
11583, 1405, 1404, 28626, 28625, 1415, 28654, 28655, 28652
11584, 1404, 1403, 28627, 28626, 1414, 28656, 28657, 28654
11585, 1403, 31, 3046, 28627, 1413, 3048, 28658, 28656
11586, 3036, 28618, 28628, 3037, 28639, 28659, 28660, 3039
11587, 28618, 28619, 28629, 28628, 28641, 28661, 28662, 28659
11588, 28619, 28620, 28630, 28629, 28643, 28663, 28664, 28661
11589, 28620, 28621, 28631, 28630, 28645, 28665, 28666, 28663
11590, 28621, 28622, 28632, 28631, 28647, 28667, 28668, 28665
11591, 28622, 28623, 28633, 28632, 28649, 28669, 28670, 28667
11592, 28623, 28624, 28634, 28633, 28651, 28671, 28672, 28669
11593, 28624, 28625, 28635, 28634, 28653, 28673, 28674, 28671
11594, 28625, 28626, 28636, 28635, 28655, 28675, 28676, 28673
11595, 28626, 28627, 28637, 28636, 28657, 28677, 28678, 28675
11596, 28627, 3046, 3047, 28637, 28658, 3049, 28679, 28677
11597, 3037, 28628, 3065, 83, 28660, 28680, 3076, 3040
11598, 28628, 28629, 3064, 3065, 28662, 28681, 3075, 28680
11599, 28629, 28630, 3063, 3064, 28664, 28682, 3074, 28681
11600, 28630, 28631, 3062, 3063, 28666, 28683, 3073, 28682
11601, 28631, 28632, 3061, 3062, 28668, 28684, 3072, 28683
11602, 28632, 28633, 3060, 3061, 28670, 28685, 3071, 28684
11603, 28633, 28634, 3059, 3060, 28672, 28686, 3070, 28685
11604, 28634, 28635, 3058, 3059, 28674, 28687, 3069, 28686
11605, 28635, 28636, 3057, 3058, 28676, 28688, 3068, 28687
11606, 28636, 28637, 3056, 3057, 28678, 28689, 3067, 28688
11607, 28637, 3047, 84, 3056, 28679, 3050, 3066, 28689
*ELEMENT, type=CPS8, ELSET=Surface158
11608, 83, 3065, 28690, 3041, 3076, 28710, 28711, 3043
11609, 3065, 3064, 28691, 28690, 3075, 28712, 28713, 28710
11610, 3064, 3063, 28692, 28691, 3074, 28714, 28715, 28712
11611, 3063, 3062, 28693, 28692, 3073, 28716, 28717, 28714
11612, 3062, 3061, 28694, 28693, 3072, 28718, 28719, 28716
11613, 3061, 3060, 28695, 28694, 3071, 28720, 28721, 28718
11614, 3060, 3059, 28696, 28695, 3070, 28722, 28723, 28720
11615, 3059, 3058, 28697, 28696, 3069, 28724, 28725, 28722
11616, 3058, 3057, 28698, 28697, 3068, 28726, 28727, 28724
11617, 3057, 3056, 28699, 28698, 3067, 28728, 28729, 28726
11618, 3056, 84, 3051, 28699, 3066, 3053, 28730, 28728
11619, 3041, 28690, 28700, 3042, 28711, 28731, 28732, 3044
11620, 28690, 28691, 28701, 28700, 28713, 28733, 28734, 28731
11621, 28691, 28692, 28702, 28701, 28715, 28735, 28736, 28733
11622, 28692, 28693, 28703, 28702, 28717, 28737, 28738, 28735
11623, 28693, 28694, 28704, 28703, 28719, 28739, 28740, 28737
11624, 28694, 28695, 28705, 28704, 28721, 28741, 28742, 28739
11625, 28695, 28696, 28706, 28705, 28723, 28743, 28744, 28741
11626, 28696, 28697, 28707, 28706, 28725, 28745, 28746, 28743
11627, 28697, 28698, 28708, 28707, 28727, 28747, 28748, 28745
11628, 28698, 28699, 28709, 28708, 28729, 28749, 28750, 28747
11629, 28699, 3051, 3052, 28709, 28730, 3054, 28751, 28749
11630, 3042, 28700, 3003, 79, 28732, 28752, 3014, 3045
11631, 28700, 28701, 3002, 3003, 28734, 28753, 3013, 28752
11632, 28701, 28702, 3001, 3002, 28736, 28754, 3012, 28753
11633, 28702, 28703, 3000, 3001, 28738, 28755, 3011, 28754
11634, 28703, 28704, 2999, 3000, 28740, 28756, 3010, 28755
11635, 28704, 28705, 2998, 2999, 28742, 28757, 3009, 28756
11636, 28705, 28706, 2997, 2998, 28744, 28758, 3008, 28757
11637, 28706, 28707, 2996, 2997, 28746, 28759, 3007, 28758
11638, 28707, 28708, 2995, 2996, 28748, 28760, 3006, 28759
11639, 28708, 28709, 2994, 2995, 28750, 28761, 3005, 28760
11640, 28709, 3052, 81, 2994, 28751, 3055, 3004, 28761
*ELEMENT, type=CPS8, ELSET=Surface159
11641, 41, 3077, 28762, 1907, 3079, 28806, 28807, 1929
11642, 1907, 28762, 28763, 1908, 28807, 28808, 28809, 1930
11643, 1908, 28763, 28764, 1909, 28809, 28810, 28811, 1931
11644, 1909, 28764, 28765, 1910, 28811, 28812, 28813, 1932
11645, 1910, 28765, 28766, 1911, 28813, 28814, 28815, 1933
11646, 1911, 28766, 28767, 1912, 28815, 28816, 28817, 1934
11647, 1912, 28767, 28768, 1913, 28817, 28818, 28819, 1935
11648, 1913, 28768, 28769, 1914, 28819, 28820, 28821, 1936
11649, 1914, 28769, 28770, 1915, 28821, 28822, 28823, 1937
11650, 1915, 28770, 28771, 1916, 28823, 28824, 28825, 1938
11651, 1916, 28771, 28772, 1917, 28825, 28826, 28827, 1939
11652, 1917, 28772, 28773, 1918, 28827, 28828, 28829, 1940
11653, 1918, 28773, 28774, 1919, 28829, 28830, 28831, 1941
11654, 1919, 28774, 28775, 1920, 28831, 28832, 28833, 1942
11655, 1920, 28775, 28776, 1921, 28833, 28834, 28835, 1943
11656, 1921, 28776, 28777, 1922, 28835, 28836, 28837, 1944
11657, 1922, 28777, 28778, 1923, 28837, 28838, 28839, 1945
11658, 1923, 28778, 28779, 1924, 28839, 28840, 28841, 1946
11659, 1924, 28779, 28780, 1925, 28841, 28842, 28843, 1947
11660, 1925, 28780, 28781, 1926, 28843, 28844, 28845, 1948
11661, 1926, 28781, 28782, 1927, 28845, 28846, 28847, 1949
11662, 1927, 28782, 28783, 1928, 28847, 28848, 28849, 1950
11663, 1928, 28783, 2045, 42, 28849, 28850, 2047, 1951
11664, 3077, 3078, 28784, 28762, 3080, 28851, 28852, 28806
11665, 28762, 28784, 28785, 28763, 28852, 28853, 28854, 28808
11666, 28763, 28785, 28786, 28764, 28854, 28855, 28856, 28810
11667, 28764, 28786, 28787, 28765, 28856, 28857, 28858, 28812
11668, 28765, 28787, 28788, 28766, 28858, 28859, 28860, 28814
11669, 28766, 28788, 28789, 28767, 28860, 28861, 28862, 28816
11670, 28767, 28789, 28790, 28768, 28862, 28863, 28864, 28818
11671, 28768, 28790, 28791, 28769, 28864, 28865, 28866, 28820
11672, 28769, 28791, 28792, 28770, 28866, 28867, 28868, 28822
11673, 28770, 28792, 28793, 28771, 28868, 28869, 28870, 28824
11674, 28771, 28793, 28794, 28772, 28870, 28871, 28872, 28826
11675, 28772, 28794, 28795, 28773, 28872, 28873, 28874, 28828
11676, 28773, 28795, 28796, 28774, 28874, 28875, 28876, 28830
11677, 28774, 28796, 28797, 28775, 28876, 28877, 28878, 28832
11678, 28775, 28797, 28798, 28776, 28878, 28879, 28880, 28834
11679, 28776, 28798, 28799, 28777, 28880, 28881, 28882, 28836
11680, 28777, 28799, 28800, 28778, 28882, 28883, 28884, 28838
11681, 28778, 28800, 28801, 28779, 28884, 28885, 28886, 28840
11682, 28779, 28801, 28802, 28780, 28886, 28887, 28888, 28842
11683, 28780, 28802, 28803, 28781, 28888, 28889, 28890, 28844
11684, 28781, 28803, 28804, 28782, 28890, 28891, 28892, 28846
11685, 28782, 28804, 28805, 28783, 28892, 28893, 28894, 28848
11686, 28783, 28805, 2046, 2045, 28894, 28895, 2048, 28850
11687, 3078, 85, 3082, 28784, 3081, 3104, 28896, 28851
11688, 28784, 3082, 3083, 28785, 28896, 3105, 28897, 28853
11689, 28785, 3083, 3084, 28786, 28897, 3106, 28898, 28855
11690, 28786, 3084, 3085, 28787, 28898, 3107, 28899, 28857
11691, 28787, 3085, 3086, 28788, 28899, 3108, 28900, 28859
11692, 28788, 3086, 3087, 28789, 28900, 3109, 28901, 28861
11693, 28789, 3087, 3088, 28790, 28901, 3110, 28902, 28863
11694, 28790, 3088, 3089, 28791, 28902, 3111, 28903, 28865
11695, 28791, 3089, 3090, 28792, 28903, 3112, 28904, 28867
11696, 28792, 3090, 3091, 28793, 28904, 3113, 28905, 28869
11697, 28793, 3091, 3092, 28794, 28905, 3114, 28906, 28871
11698, 28794, 3092, 3093, 28795, 28906, 3115, 28907, 28873
11699, 28795, 3093, 3094, 28796, 28907, 3116, 28908, 28875
11700, 28796, 3094, 3095, 28797, 28908, 3117, 28909, 28877
11701, 28797, 3095, 3096, 28798, 28909, 3118, 28910, 28879
11702, 28798, 3096, 3097, 28799, 28910, 3119, 28911, 28881
11703, 28799, 3097, 3098, 28800, 28911, 3120, 28912, 28883
11704, 28800, 3098, 3099, 28801, 28912, 3121, 28913, 28885
11705, 28801, 3099, 3100, 28802, 28913, 3122, 28914, 28887
11706, 28802, 3100, 3101, 28803, 28914, 3123, 28915, 28889
11707, 28803, 3101, 3102, 28804, 28915, 3124, 28916, 28891
11708, 28804, 3102, 3103, 28805, 28916, 3125, 28917, 28893
11709, 28805, 3103, 45, 2046, 28917, 3126, 2049, 28895
*ELEMENT, type=CPS8, ELSET=Surface160
11710, 43, 1958, 28918, 3127, 1980, 28962, 28963, 3129
11711, 1958, 1959, 28919, 28918, 1981, 28964, 28965, 28962
11712, 1959, 1960, 28920, 28919, 1982, 28966, 28967, 28964
11713, 1960, 1961, 28921, 28920, 1983, 28968, 28969, 28966
11714, 1961, 1962, 28922, 28921, 1984, 28970, 28971, 28968
11715, 1962, 1963, 28923, 28922, 1985, 28972, 28973, 28970
11716, 1963, 1964, 28924, 28923, 1986, 28974, 28975, 28972
11717, 1964, 1965, 28925, 28924, 1987, 28976, 28977, 28974
11718, 1965, 1966, 28926, 28925, 1988, 28978, 28979, 28976
11719, 1966, 1967, 28927, 28926, 1989, 28980, 28981, 28978
11720, 1967, 1968, 28928, 28927, 1990, 28982, 28983, 28980
11721, 1968, 1969, 28929, 28928, 1991, 28984, 28985, 28982
11722, 1969, 1970, 28930, 28929, 1992, 28986, 28987, 28984
11723, 1970, 1971, 28931, 28930, 1993, 28988, 28989, 28986
11724, 1971, 1972, 28932, 28931, 1994, 28990, 28991, 28988
11725, 1972, 1973, 28933, 28932, 1995, 28992, 28993, 28990
11726, 1973, 1974, 28934, 28933, 1996, 28994, 28995, 28992
11727, 1974, 1975, 28935, 28934, 1997, 28996, 28997, 28994
11728, 1975, 1976, 28936, 28935, 1998, 28998, 28999, 28996
11729, 1976, 1977, 28937, 28936, 1999, 29000, 29001, 28998
11730, 1977, 1978, 28938, 28937, 2000, 29002, 29003, 29000
11731, 1978, 1979, 28939, 28938, 2001, 29004, 29005, 29002
11732, 1979, 44, 2050, 28939, 2002, 2052, 29006, 29004
11733, 3127, 28918, 28940, 3128, 28963, 29007, 29008, 3130
11734, 28918, 28919, 28941, 28940, 28965, 29009, 29010, 29007
11735, 28919, 28920, 28942, 28941, 28967, 29011, 29012, 29009
11736, 28920, 28921, 28943, 28942, 28969, 29013, 29014, 29011
11737, 28921, 28922, 28944, 28943, 28971, 29015, 29016, 29013
11738, 28922, 28923, 28945, 28944, 28973, 29017, 29018, 29015
11739, 28923, 28924, 28946, 28945, 28975, 29019, 29020, 29017
11740, 28924, 28925, 28947, 28946, 28977, 29021, 29022, 29019
11741, 28925, 28926, 28948, 28947, 28979, 29023, 29024, 29021
11742, 28926, 28927, 28949, 28948, 28981, 29025, 29026, 29023
11743, 28927, 28928, 28950, 28949, 28983, 29027, 29028, 29025
11744, 28928, 28929, 28951, 28950, 28985, 29029, 29030, 29027
11745, 28929, 28930, 28952, 28951, 28987, 29031, 29032, 29029
11746, 28930, 28931, 28953, 28952, 28989, 29033, 29034, 29031
11747, 28931, 28932, 28954, 28953, 28991, 29035, 29036, 29033
11748, 28932, 28933, 28955, 28954, 28993, 29037, 29038, 29035
11749, 28933, 28934, 28956, 28955, 28995, 29039, 29040, 29037
11750, 28934, 28935, 28957, 28956, 28997, 29041, 29042, 29039
11751, 28935, 28936, 28958, 28957, 28999, 29043, 29044, 29041
11752, 28936, 28937, 28959, 28958, 29001, 29045, 29046, 29043
11753, 28937, 28938, 28960, 28959, 29003, 29047, 29048, 29045
11754, 28938, 28939, 28961, 28960, 29005, 29049, 29050, 29047
11755, 28939, 2050, 2051, 28961, 29006, 2053, 29051, 29049
11756, 3128, 28940, 3132, 86, 29008, 29052, 3154, 3131
11757, 28940, 28941, 3133, 3132, 29010, 29053, 3155, 29052
11758, 28941, 28942, 3134, 3133, 29012, 29054, 3156, 29053
11759, 28942, 28943, 3135, 3134, 29014, 29055, 3157, 29054
11760, 28943, 28944, 3136, 3135, 29016, 29056, 3158, 29055
11761, 28944, 28945, 3137, 3136, 29018, 29057, 3159, 29056
11762, 28945, 28946, 3138, 3137, 29020, 29058, 3160, 29057
11763, 28946, 28947, 3139, 3138, 29022, 29059, 3161, 29058
11764, 28947, 28948, 3140, 3139, 29024, 29060, 3162, 29059
11765, 28948, 28949, 3141, 3140, 29026, 29061, 3163, 29060
11766, 28949, 28950, 3142, 3141, 29028, 29062, 3164, 29061
11767, 28950, 28951, 3143, 3142, 29030, 29063, 3165, 29062
11768, 28951, 28952, 3144, 3143, 29032, 29064, 3166, 29063
11769, 28952, 28953, 3145, 3144, 29034, 29065, 3167, 29064
11770, 28953, 28954, 3146, 3145, 29036, 29066, 3168, 29065
11771, 28954, 28955, 3147, 3146, 29038, 29067, 3169, 29066
11772, 28955, 28956, 3148, 3147, 29040, 29068, 3170, 29067
11773, 28956, 28957, 3149, 3148, 29042, 29069, 3171, 29068
11774, 28957, 28958, 3150, 3149, 29044, 29070, 3172, 29069
11775, 28958, 28959, 3151, 3150, 29046, 29071, 3173, 29070
11776, 28959, 28960, 3152, 3151, 29048, 29072, 3174, 29071
11777, 28960, 28961, 3153, 3152, 29050, 29073, 3175, 29072
11778, 28961, 2051, 46, 3153, 29051, 2054, 3176, 29073
*ELEMENT, type=CPS8, ELSET=Surface161
11779, 41, 2012, 29074, 3077, 2023, 29094, 29095, 3079
11780, 2012, 2011, 29075, 29074, 2022, 29096, 29097, 29094
11781, 2011, 2010, 29076, 29075, 2021, 29098, 29099, 29096
11782, 2010, 2009, 29077, 29076, 2020, 29100, 29101, 29098
11783, 2009, 2008, 29078, 29077, 2019, 29102, 29103, 29100
11784, 2008, 2007, 29079, 29078, 2018, 29104, 29105, 29102
11785, 2007, 2006, 29080, 29079, 2017, 29106, 29107, 29104
11786, 2006, 2005, 29081, 29080, 2016, 29108, 29109, 29106
11787, 2005, 2004, 29082, 29081, 2015, 29110, 29111, 29108
11788, 2004, 2003, 29083, 29082, 2014, 29112, 29113, 29110
11789, 2003, 43, 3127, 29083, 2013, 3129, 29114, 29112
11790, 3077, 29074, 29084, 3078, 29095, 29115, 29116, 3080
11791, 29074, 29075, 29085, 29084, 29097, 29117, 29118, 29115
11792, 29075, 29076, 29086, 29085, 29099, 29119, 29120, 29117
11793, 29076, 29077, 29087, 29086, 29101, 29121, 29122, 29119
11794, 29077, 29078, 29088, 29087, 29103, 29123, 29124, 29121
11795, 29078, 29079, 29089, 29088, 29105, 29125, 29126, 29123
11796, 29079, 29080, 29090, 29089, 29107, 29127, 29128, 29125
11797, 29080, 29081, 29091, 29090, 29109, 29129, 29130, 29127
11798, 29081, 29082, 29092, 29091, 29111, 29131, 29132, 29129
11799, 29082, 29083, 29093, 29092, 29113, 29133, 29134, 29131
11800, 29083, 3127, 3128, 29093, 29114, 3130, 29135, 29133
11801, 3078, 29084, 3186, 85, 29116, 29136, 3197, 3081
11802, 29084, 29085, 3185, 3186, 29118, 29137, 3196, 29136
11803, 29085, 29086, 3184, 3185, 29120, 29138, 3195, 29137
11804, 29086, 29087, 3183, 3184, 29122, 29139, 3194, 29138
11805, 29087, 29088, 3182, 3183, 29124, 29140, 3193, 29139
11806, 29088, 29089, 3181, 3182, 29126, 29141, 3192, 29140
11807, 29089, 29090, 3180, 3181, 29128, 29142, 3191, 29141
11808, 29090, 29091, 3179, 3180, 29130, 29143, 3190, 29142
11809, 29091, 29092, 3178, 3179, 29132, 29144, 3189, 29143
11810, 29092, 29093, 3177, 3178, 29134, 29145, 3188, 29144
11811, 29093, 3128, 86, 3177, 29135, 3131, 3187, 29145
*ELEMENT, type=CPS8, ELSET=Surface162
11812, 85, 3186, 29146, 3082, 3197, 29366, 29367, 3104
11813, 3186, 3185, 29147, 29146, 3196, 29368, 29369, 29366
11814, 3185, 3184, 29148, 29147, 3195, 29370, 29371, 29368
11815, 3184, 3183, 29149, 29148, 3194, 29372, 29373, 29370
11816, 3183, 3182, 29150, 29149, 3193, 29374, 29375, 29372
11817, 3182, 3181, 29151, 29150, 3192, 29376, 29377, 29374
11818, 3181, 3180, 29152, 29151, 3191, 29378, 29379, 29376
11819, 3180, 3179, 29153, 29152, 3190, 29380, 29381, 29378
11820, 3179, 3178, 29154, 29153, 3189, 29382, 29383, 29380
11821, 3178, 3177, 29155, 29154, 3188, 29384, 29385, 29382
11822, 3177, 86, 3132, 29155, 3187, 3154, 29386, 29384
11823, 3082, 29146, 29156, 3083, 29367, 29387, 29388, 3105
11824, 29146, 29147, 29157, 29156, 29369, 29389, 29390, 29387
11825, 29147, 29148, 29158, 29157, 29371, 29391, 29392, 29389
11826, 29148, 29149, 29159, 29158, 29373, 29393, 29394, 29391
11827, 29149, 29150, 29160, 29159, 29375, 29395, 29396, 29393
11828, 29150, 29151, 29161, 29160, 29377, 29397, 29398, 29395
11829, 29151, 29152, 29162, 29161, 29379, 29399, 29400, 29397
11830, 29152, 29153, 29163, 29162, 29381, 29401, 29402, 29399
11831, 29153, 29154, 29164, 29163, 29383, 29403, 29404, 29401
11832, 29154, 29155, 29165, 29164, 29385, 29405, 29406, 29403
11833, 29155, 3132, 3133, 29165, 29386, 3155, 29407, 29405
11834, 3083, 29156, 29166, 3084, 29388, 29408, 29409, 3106
11835, 29156, 29157, 29167, 29166, 29390, 29410, 29411, 29408
11836, 29157, 29158, 29168, 29167, 29392, 29412, 29413, 29410
11837, 29158, 29159, 29169, 29168, 29394, 29414, 29415, 29412
11838, 29159, 29160, 29170, 29169, 29396, 29416, 29417, 29414
11839, 29160, 29161, 29171, 29170, 29398, 29418, 29419, 29416
11840, 29161, 29162, 29172, 29171, 29400, 29420, 29421, 29418
11841, 29162, 29163, 29173, 29172, 29402, 29422, 29423, 29420
11842, 29163, 29164, 29174, 29173, 29404, 29424, 29425, 29422
11843, 29164, 29165, 29175, 29174, 29406, 29426, 29427, 29424
11844, 29165, 3133, 3134, 29175, 29407, 3156, 29428, 29426
11845, 3084, 29166, 29176, 3085, 29409, 29429, 29430, 3107
11846, 29166, 29167, 29177, 29176, 29411, 29431, 29432, 29429
11847, 29167, 29168, 29178, 29177, 29413, 29433, 29434, 29431
11848, 29168, 29169, 29179, 29178, 29415, 29435, 29436, 29433
11849, 29169, 29170, 29180, 29179, 29417, 29437, 29438, 29435
11850, 29170, 29171, 29181, 29180, 29419, 29439, 29440, 29437
11851, 29171, 29172, 29182, 29181, 29421, 29441, 29442, 29439
11852, 29172, 29173, 29183, 29182, 29423, 29443, 29444, 29441
11853, 29173, 29174, 29184, 29183, 29425, 29445, 29446, 29443
11854, 29174, 29175, 29185, 29184, 29427, 29447, 29448, 29445
11855, 29175, 3134, 3135, 29185, 29428, 3157, 29449, 29447
11856, 3085, 29176, 29186, 3086, 29430, 29450, 29451, 3108
11857, 29176, 29177, 29187, 29186, 29432, 29452, 29453, 29450
11858, 29177, 29178, 29188, 29187, 29434, 29454, 29455, 29452
11859, 29178, 29179, 29189, 29188, 29436, 29456, 29457, 29454
11860, 29179, 29180, 29190, 29189, 29438, 29458, 29459, 29456
11861, 29180, 29181, 29191, 29190, 29440, 29460, 29461, 29458
11862, 29181, 29182, 29192, 29191, 29442, 29462, 29463, 29460
11863, 29182, 29183, 29193, 29192, 29444, 29464, 29465, 29462
11864, 29183, 29184, 29194, 29193, 29446, 29466, 29467, 29464
11865, 29184, 29185, 29195, 29194, 29448, 29468, 29469, 29466
11866, 29185, 3135, 3136, 29195, 29449, 3158, 29470, 29468
11867, 3086, 29186, 29196, 3087, 29451, 29471, 29472, 3109
11868, 29186, 29187, 29197, 29196, 29453, 29473, 29474, 29471
11869, 29187, 29188, 29198, 29197, 29455, 29475, 29476, 29473
11870, 29188, 29189, 29199, 29198, 29457, 29477, 29478, 29475
11871, 29189, 29190, 29200, 29199, 29459, 29479, 29480, 29477
11872, 29190, 29191, 29201, 29200, 29461, 29481, 29482, 29479
11873, 29191, 29192, 29202, 29201, 29463, 29483, 29484, 29481
11874, 29192, 29193, 29203, 29202, 29465, 29485, 29486, 29483
11875, 29193, 29194, 29204, 29203, 29467, 29487, 29488, 29485
11876, 29194, 29195, 29205, 29204, 29469, 29489, 29490, 29487
11877, 29195, 3136, 3137, 29205, 29470, 3159, 29491, 29489
11878, 3087, 29196, 29206, 3088, 29472, 29492, 29493, 3110
11879, 29196, 29197, 29207, 29206, 29474, 29494, 29495, 29492
11880, 29197, 29198, 29208, 29207, 29476, 29496, 29497, 29494
11881, 29198, 29199, 29209, 29208, 29478, 29498, 29499, 29496
11882, 29199, 29200, 29210, 29209, 29480, 29500, 29501, 29498
11883, 29200, 29201, 29211, 29210, 29482, 29502, 29503, 29500
11884, 29201, 29202, 29212, 29211, 29484, 29504, 29505, 29502
11885, 29202, 29203, 29213, 29212, 29486, 29506, 29507, 29504
11886, 29203, 29204, 29214, 29213, 29488, 29508, 29509, 29506
11887, 29204, 29205, 29215, 29214, 29490, 29510, 29511, 29508
11888, 29205, 3137, 3138, 29215, 29491, 3160, 29512, 29510
11889, 3088, 29206, 29216, 3089, 29493, 29513, 29514, 3111
11890, 29206, 29207, 29217, 29216, 29495, 29515, 29516, 29513
11891, 29207, 29208, 29218, 29217, 29497, 29517, 29518, 29515
11892, 29208, 29209, 29219, 29218, 29499, 29519, 29520, 29517
11893, 29209, 29210, 29220, 29219, 29501, 29521, 29522, 29519
11894, 29210, 29211, 29221, 29220, 29503, 29523, 29524, 29521
11895, 29211, 29212, 29222, 29221, 29505, 29525, 29526, 29523
11896, 29212, 29213, 29223, 29222, 29507, 29527, 29528, 29525
11897, 29213, 29214, 29224, 29223, 29509, 29529, 29530, 29527
11898, 29214, 29215, 29225, 29224, 29511, 29531, 29532, 29529
11899, 29215, 3138, 3139, 29225, 29512, 3161, 29533, 29531
11900, 3089, 29216, 29226, 3090, 29514, 29534, 29535, 3112
11901, 29216, 29217, 29227, 29226, 29516, 29536, 29537, 29534
11902, 29217, 29218, 29228, 29227, 29518, 29538, 29539, 29536
11903, 29218, 29219, 29229, 29228, 29520, 29540, 29541, 29538
11904, 29219, 29220, 29230, 29229, 29522, 29542, 29543, 29540
11905, 29220, 29221, 29231, 29230, 29524, 29544, 29545, 29542
11906, 29221, 29222, 29232, 29231, 29526, 29546, 29547, 29544
11907, 29222, 29223, 29233, 29232, 29528, 29548, 29549, 29546
11908, 29223, 29224, 29234, 29233, 29530, 29550, 29551, 29548
11909, 29224, 29225, 29235, 29234, 29532, 29552, 29553, 29550
11910, 29225, 3139, 3140, 29235, 29533, 3162, 29554, 29552
11911, 3090, 29226, 29236, 3091, 29535, 29555, 29556, 3113
11912, 29226, 29227, 29237, 29236, 29537, 29557, 29558, 29555
11913, 29227, 29228, 29238, 29237, 29539, 29559, 29560, 29557
11914, 29228, 29229, 29239, 29238, 29541, 29561, 29562, 29559
11915, 29229, 29230, 29240, 29239, 29543, 29563, 29564, 29561
11916, 29230, 29231, 29241, 29240, 29545, 29565, 29566, 29563
11917, 29231, 29232, 29242, 29241, 29547, 29567, 29568, 29565
11918, 29232, 29233, 29243, 29242, 29549, 29569, 29570, 29567
11919, 29233, 29234, 29244, 29243, 29551, 29571, 29572, 29569
11920, 29234, 29235, 29245, 29244, 29553, 29573, 29574, 29571
11921, 29235, 3140, 3141, 29245, 29554, 3163, 29575, 29573
11922, 3091, 29236, 29246, 3092, 29556, 29576, 29577, 3114
11923, 29236, 29237, 29247, 29246, 29558, 29578, 29579, 29576
11924, 29237, 29238, 29248, 29247, 29560, 29580, 29581, 29578
11925, 29238, 29239, 29249, 29248, 29562, 29582, 29583, 29580
11926, 29239, 29240, 29250, 29249, 29564, 29584, 29585, 29582
11927, 29240, 29241, 29251, 29250, 29566, 29586, 29587, 29584
11928, 29241, 29242, 29252, 29251, 29568, 29588, 29589, 29586
11929, 29242, 29243, 29253, 29252, 29570, 29590, 29591, 29588
11930, 29243, 29244, 29254, 29253, 29572, 29592, 29593, 29590
11931, 29244, 29245, 29255, 29254, 29574, 29594, 29595, 29592
11932, 29245, 3141, 3142, 29255, 29575, 3164, 29596, 29594
11933, 3092, 29246, 29256, 3093, 29577, 29597, 29598, 3115
11934, 29246, 29247, 29257, 29256, 29579, 29599, 29600, 29597
11935, 29247, 29248, 29258, 29257, 29581, 29601, 29602, 29599
11936, 29248, 29249, 29259, 29258, 29583, 29603, 29604, 29601
11937, 29249, 29250, 29260, 29259, 29585, 29605, 29606, 29603
11938, 29250, 29251, 29261, 29260, 29587, 29607, 29608, 29605
11939, 29251, 29252, 29262, 29261, 29589, 29609, 29610, 29607
11940, 29252, 29253, 29263, 29262, 29591, 29611, 29612, 29609
11941, 29253, 29254, 29264, 29263, 29593, 29613, 29614, 29611
11942, 29254, 29255, 29265, 29264, 29595, 29615, 29616, 29613
11943, 29255, 3142, 3143, 29265, 29596, 3165, 29617, 29615
11944, 3093, 29256, 29266, 3094, 29598, 29618, 29619, 3116
11945, 29256, 29257, 29267, 29266, 29600, 29620, 29621, 29618
11946, 29257, 29258, 29268, 29267, 29602, 29622, 29623, 29620
11947, 29258, 29259, 29269, 29268, 29604, 29624, 29625, 29622
11948, 29259, 29260, 29270, 29269, 29606, 29626, 29627, 29624
11949, 29260, 29261, 29271, 29270, 29608, 29628, 29629, 29626
11950, 29261, 29262, 29272, 29271, 29610, 29630, 29631, 29628
11951, 29262, 29263, 29273, 29272, 29612, 29632, 29633, 29630
11952, 29263, 29264, 29274, 29273, 29614, 29634, 29635, 29632
11953, 29264, 29265, 29275, 29274, 29616, 29636, 29637, 29634
11954, 29265, 3143, 3144, 29275, 29617, 3166, 29638, 29636
11955, 3094, 29266, 29276, 3095, 29619, 29639, 29640, 3117
11956, 29266, 29267, 29277, 29276, 29621, 29641, 29642, 29639
11957, 29267, 29268, 29278, 29277, 29623, 29643, 29644, 29641
11958, 29268, 29269, 29279, 29278, 29625, 29645, 29646, 29643
11959, 29269, 29270, 29280, 29279, 29627, 29647, 29648, 29645
11960, 29270, 29271, 29281, 29280, 29629, 29649, 29650, 29647
11961, 29271, 29272, 29282, 29281, 29631, 29651, 29652, 29649
11962, 29272, 29273, 29283, 29282, 29633, 29653, 29654, 29651
11963, 29273, 29274, 29284, 29283, 29635, 29655, 29656, 29653
11964, 29274, 29275, 29285, 29284, 29637, 29657, 29658, 29655
11965, 29275, 3144, 3145, 29285, 29638, 3167, 29659, 29657
11966, 3095, 29276, 29286, 3096, 29640, 29660, 29661, 3118
11967, 29276, 29277, 29287, 29286, 29642, 29662, 29663, 29660
11968, 29277, 29278, 29288, 29287, 29644, 29664, 29665, 29662
11969, 29278, 29279, 29289, 29288, 29646, 29666, 29667, 29664
11970, 29279, 29280, 29290, 29289, 29648, 29668, 29669, 29666
11971, 29280, 29281, 29291, 29290, 29650, 29670, 29671, 29668
11972, 29281, 29282, 29292, 29291, 29652, 29672, 29673, 29670
11973, 29282, 29283, 29293, 29292, 29654, 29674, 29675, 29672
11974, 29283, 29284, 29294, 29293, 29656, 29676, 29677, 29674
11975, 29284, 29285, 29295, 29294, 29658, 29678, 29679, 29676
11976, 29285, 3145, 3146, 29295, 29659, 3168, 29680, 29678
11977, 3096, 29286, 29296, 3097, 29661, 29681, 29682, 3119
11978, 29286, 29287, 29297, 29296, 29663, 29683, 29684, 29681
11979, 29287, 29288, 29298, 29297, 29665, 29685, 29686, 29683
11980, 29288, 29289, 29299, 29298, 29667, 29687, 29688, 29685
11981, 29289, 29290, 29300, 29299, 29669, 29689, 29690, 29687
11982, 29290, 29291, 29301, 29300, 29671, 29691, 29692, 29689
11983, 29291, 29292, 29302, 29301, 29673, 29693, 29694, 29691
11984, 29292, 29293, 29303, 29302, 29675, 29695, 29696, 29693
11985, 29293, 29294, 29304, 29303, 29677, 29697, 29698, 29695
11986, 29294, 29295, 29305, 29304, 29679, 29699, 29700, 29697
11987, 29295, 3146, 3147, 29305, 29680, 3169, 29701, 29699
11988, 3097, 29296, 29306, 3098, 29682, 29702, 29703, 3120
11989, 29296, 29297, 29307, 29306, 29684, 29704, 29705, 29702
11990, 29297, 29298, 29308, 29307, 29686, 29706, 29707, 29704
11991, 29298, 29299, 29309, 29308, 29688, 29708, 29709, 29706
11992, 29299, 29300, 29310, 29309, 29690, 29710, 29711, 29708
11993, 29300, 29301, 29311, 29310, 29692, 29712, 29713, 29710
11994, 29301, 29302, 29312, 29311, 29694, 29714, 29715, 29712
11995, 29302, 29303, 29313, 29312, 29696, 29716, 29717, 29714
11996, 29303, 29304, 29314, 29313, 29698, 29718, 29719, 29716
11997, 29304, 29305, 29315, 29314, 29700, 29720, 29721, 29718
11998, 29305, 3147, 3148, 29315, 29701, 3170, 29722, 29720
11999, 3098, 29306, 29316, 3099, 29703, 29723, 29724, 3121
12000, 29306, 29307, 29317, 29316, 29705, 29725, 29726, 29723
12001, 29307, 29308, 29318, 29317, 29707, 29727, 29728, 29725
12002, 29308, 29309, 29319, 29318, 29709, 29729, 29730, 29727
12003, 29309, 29310, 29320, 29319, 29711, 29731, 29732, 29729
12004, 29310, 29311, 29321, 29320, 29713, 29733, 29734, 29731
12005, 29311, 29312, 29322, 29321, 29715, 29735, 29736, 29733
12006, 29312, 29313, 29323, 29322, 29717, 29737, 29738, 29735
12007, 29313, 29314, 29324, 29323, 29719, 29739, 29740, 29737
12008, 29314, 29315, 29325, 29324, 29721, 29741, 29742, 29739
12009, 29315, 3148, 3149, 29325, 29722, 3171, 29743, 29741
12010, 3099, 29316, 29326, 3100, 29724, 29744, 29745, 3122
12011, 29316, 29317, 29327, 29326, 29726, 29746, 29747, 29744
12012, 29317, 29318, 29328, 29327, 29728, 29748, 29749, 29746
12013, 29318, 29319, 29329, 29328, 29730, 29750, 29751, 29748
12014, 29319, 29320, 29330, 29329, 29732, 29752, 29753, 29750
12015, 29320, 29321, 29331, 29330, 29734, 29754, 29755, 29752
12016, 29321, 29322, 29332, 29331, 29736, 29756, 29757, 29754
12017, 29322, 29323, 29333, 29332, 29738, 29758, 29759, 29756
12018, 29323, 29324, 29334, 29333, 29740, 29760, 29761, 29758
12019, 29324, 29325, 29335, 29334, 29742, 29762, 29763, 29760
12020, 29325, 3149, 3150, 29335, 29743, 3172, 29764, 29762
12021, 3100, 29326, 29336, 3101, 29745, 29765, 29766, 3123
12022, 29326, 29327, 29337, 29336, 29747, 29767, 29768, 29765
12023, 29327, 29328, 29338, 29337, 29749, 29769, 29770, 29767
12024, 29328, 29329, 29339, 29338, 29751, 29771, 29772, 29769
12025, 29329, 29330, 29340, 29339, 29753, 29773, 29774, 29771
12026, 29330, 29331, 29341, 29340, 29755, 29775, 29776, 29773
12027, 29331, 29332, 29342, 29341, 29757, 29777, 29778, 29775
12028, 29332, 29333, 29343, 29342, 29759, 29779, 29780, 29777
12029, 29333, 29334, 29344, 29343, 29761, 29781, 29782, 29779
12030, 29334, 29335, 29345, 29344, 29763, 29783, 29784, 29781
12031, 29335, 3150, 3151, 29345, 29764, 3173, 29785, 29783
12032, 3101, 29336, 29346, 3102, 29766, 29786, 29787, 3124
12033, 29336, 29337, 29347, 29346, 29768, 29788, 29789, 29786
12034, 29337, 29338, 29348, 29347, 29770, 29790, 29791, 29788
12035, 29338, 29339, 29349, 29348, 29772, 29792, 29793, 29790
12036, 29339, 29340, 29350, 29349, 29774, 29794, 29795, 29792
12037, 29340, 29341, 29351, 29350, 29776, 29796, 29797, 29794
12038, 29341, 29342, 29352, 29351, 29778, 29798, 29799, 29796
12039, 29342, 29343, 29353, 29352, 29780, 29800, 29801, 29798
12040, 29343, 29344, 29354, 29353, 29782, 29802, 29803, 29800
12041, 29344, 29345, 29355, 29354, 29784, 29804, 29805, 29802
12042, 29345, 3151, 3152, 29355, 29785, 3174, 29806, 29804
12043, 3102, 29346, 29356, 3103, 29787, 29807, 29808, 3125
12044, 29346, 29347, 29357, 29356, 29789, 29809, 29810, 29807
12045, 29347, 29348, 29358, 29357, 29791, 29811, 29812, 29809
12046, 29348, 29349, 29359, 29358, 29793, 29813, 29814, 29811
12047, 29349, 29350, 29360, 29359, 29795, 29815, 29816, 29813
12048, 29350, 29351, 29361, 29360, 29797, 29817, 29818, 29815
12049, 29351, 29352, 29362, 29361, 29799, 29819, 29820, 29817
12050, 29352, 29353, 29363, 29362, 29801, 29821, 29822, 29819
12051, 29353, 29354, 29364, 29363, 29803, 29823, 29824, 29821
12052, 29354, 29355, 29365, 29364, 29805, 29825, 29826, 29823
12053, 29355, 3152, 3153, 29365, 29806, 3175, 29827, 29825
12054, 3103, 29356, 2064, 45, 29808, 29828, 2075, 3126
12055, 29356, 29357, 2063, 2064, 29810, 29829, 2074, 29828
12056, 29357, 29358, 2062, 2063, 29812, 29830, 2073, 29829
12057, 29358, 29359, 2061, 2062, 29814, 29831, 2072, 29830
12058, 29359, 29360, 2060, 2061, 29816, 29832, 2071, 29831
12059, 29360, 29361, 2059, 2060, 29818, 29833, 2070, 29832
12060, 29361, 29362, 2058, 2059, 29820, 29834, 2069, 29833
12061, 29362, 29363, 2057, 2058, 29822, 29835, 2068, 29834
12062, 29363, 29364, 2056, 2057, 29824, 29836, 2067, 29835
12063, 29364, 29365, 2055, 2056, 29826, 29837, 2066, 29836
12064, 29365, 3153, 46, 2055, 29827, 3176, 2065, 29837
*ELEMENT, type=CPS8, ELSET=Surface163
12065, 85, 3198, 29838, 3082, 3201, 29904, 29905, 3104
12066, 3082, 29838, 29839, 3083, 29905, 29906, 29907, 3105
12067, 3083, 29839, 29840, 3084, 29907, 29908, 29909, 3106
12068, 3084, 29840, 29841, 3085, 29909, 29910, 29911, 3107
12069, 3085, 29841, 29842, 3086, 29911, 29912, 29913, 3108
12070, 3086, 29842, 29843, 3087, 29913, 29914, 29915, 3109
12071, 3087, 29843, 29844, 3088, 29915, 29916, 29917, 3110
12072, 3088, 29844, 29845, 3089, 29917, 29918, 29919, 3111
12073, 3089, 29845, 29846, 3090, 29919, 29920, 29921, 3112
12074, 3090, 29846, 29847, 3091, 29921, 29922, 29923, 3113
12075, 3091, 29847, 29848, 3092, 29923, 29924, 29925, 3114
12076, 3092, 29848, 29849, 3093, 29925, 29926, 29927, 3115
12077, 3093, 29849, 29850, 3094, 29927, 29928, 29929, 3116
12078, 3094, 29850, 29851, 3095, 29929, 29930, 29931, 3117
12079, 3095, 29851, 29852, 3096, 29931, 29932, 29933, 3118
12080, 3096, 29852, 29853, 3097, 29933, 29934, 29935, 3119
12081, 3097, 29853, 29854, 3098, 29935, 29936, 29937, 3120
12082, 3098, 29854, 29855, 3099, 29937, 29938, 29939, 3121
12083, 3099, 29855, 29856, 3100, 29939, 29940, 29941, 3122
12084, 3100, 29856, 29857, 3101, 29941, 29942, 29943, 3123
12085, 3101, 29857, 29858, 3102, 29943, 29944, 29945, 3124
12086, 3102, 29858, 29859, 3103, 29945, 29946, 29947, 3125
12087, 3103, 29859, 2763, 45, 29947, 29948, 2766, 3126
12088, 3198, 3199, 29860, 29838, 3202, 29949, 29950, 29904
12089, 29838, 29860, 29861, 29839, 29950, 29951, 29952, 29906
12090, 29839, 29861, 29862, 29840, 29952, 29953, 29954, 29908
12091, 29840, 29862, 29863, 29841, 29954, 29955, 29956, 29910
12092, 29841, 29863, 29864, 29842, 29956, 29957, 29958, 29912
12093, 29842, 29864, 29865, 29843, 29958, 29959, 29960, 29914
12094, 29843, 29865, 29866, 29844, 29960, 29961, 29962, 29916
12095, 29844, 29866, 29867, 29845, 29962, 29963, 29964, 29918
12096, 29845, 29867, 29868, 29846, 29964, 29965, 29966, 29920
12097, 29846, 29868, 29869, 29847, 29966, 29967, 29968, 29922
12098, 29847, 29869, 29870, 29848, 29968, 29969, 29970, 29924
12099, 29848, 29870, 29871, 29849, 29970, 29971, 29972, 29926
12100, 29849, 29871, 29872, 29850, 29972, 29973, 29974, 29928
12101, 29850, 29872, 29873, 29851, 29974, 29975, 29976, 29930
12102, 29851, 29873, 29874, 29852, 29976, 29977, 29978, 29932
12103, 29852, 29874, 29875, 29853, 29978, 29979, 29980, 29934
12104, 29853, 29875, 29876, 29854, 29980, 29981, 29982, 29936
12105, 29854, 29876, 29877, 29855, 29982, 29983, 29984, 29938
12106, 29855, 29877, 29878, 29856, 29984, 29985, 29986, 29940
12107, 29856, 29878, 29879, 29857, 29986, 29987, 29988, 29942
12108, 29857, 29879, 29880, 29858, 29988, 29989, 29990, 29944
12109, 29858, 29880, 29881, 29859, 29990, 29991, 29992, 29946
12110, 29859, 29881, 2764, 2763, 29992, 29993, 2767, 29948
12111, 3199, 3200, 29882, 29860, 3203, 29994, 29995, 29949
12112, 29860, 29882, 29883, 29861, 29995, 29996, 29997, 29951
12113, 29861, 29883, 29884, 29862, 29997, 29998, 29999, 29953
12114, 29862, 29884, 29885, 29863, 29999, 30000, 30001, 29955
12115, 29863, 29885, 29886, 29864, 30001, 30002, 30003, 29957
12116, 29864, 29886, 29887, 29865, 30003, 30004, 30005, 29959
12117, 29865, 29887, 29888, 29866, 30005, 30006, 30007, 29961
12118, 29866, 29888, 29889, 29867, 30007, 30008, 30009, 29963
12119, 29867, 29889, 29890, 29868, 30009, 30010, 30011, 29965
12120, 29868, 29890, 29891, 29869, 30011, 30012, 30013, 29967
12121, 29869, 29891, 29892, 29870, 30013, 30014, 30015, 29969
12122, 29870, 29892, 29893, 29871, 30015, 30016, 30017, 29971
12123, 29871, 29893, 29894, 29872, 30017, 30018, 30019, 29973
12124, 29872, 29894, 29895, 29873, 30019, 30020, 30021, 29975
12125, 29873, 29895, 29896, 29874, 30021, 30022, 30023, 29977
12126, 29874, 29896, 29897, 29875, 30023, 30024, 30025, 29979
12127, 29875, 29897, 29898, 29876, 30025, 30026, 30027, 29981
12128, 29876, 29898, 29899, 29877, 30027, 30028, 30029, 29983
12129, 29877, 29899, 29900, 29878, 30029, 30030, 30031, 29985
12130, 29878, 29900, 29901, 29879, 30031, 30032, 30033, 29987
12131, 29879, 29901, 29902, 29880, 30033, 30034, 30035, 29989
12132, 29880, 29902, 29903, 29881, 30035, 30036, 30037, 29991
12133, 29881, 29903, 2765, 2764, 30037, 30038, 2768, 29993
12134, 3200, 87, 3205, 29882, 3204, 3227, 30039, 29994
12135, 29882, 3205, 3206, 29883, 30039, 3228, 30040, 29996
12136, 29883, 3206, 3207, 29884, 30040, 3229, 30041, 29998
12137, 29884, 3207, 3208, 29885, 30041, 3230, 30042, 30000
12138, 29885, 3208, 3209, 29886, 30042, 3231, 30043, 30002
12139, 29886, 3209, 3210, 29887, 30043, 3232, 30044, 30004
12140, 29887, 3210, 3211, 29888, 30044, 3233, 30045, 30006
12141, 29888, 3211, 3212, 29889, 30045, 3234, 30046, 30008
12142, 29889, 3212, 3213, 29890, 30046, 3235, 30047, 30010
12143, 29890, 3213, 3214, 29891, 30047, 3236, 30048, 30012
12144, 29891, 3214, 3215, 29892, 30048, 3237, 30049, 30014
12145, 29892, 3215, 3216, 29893, 30049, 3238, 30050, 30016
12146, 29893, 3216, 3217, 29894, 30050, 3239, 30051, 30018
12147, 29894, 3217, 3218, 29895, 30051, 3240, 30052, 30020
12148, 29895, 3218, 3219, 29896, 30052, 3241, 30053, 30022
12149, 29896, 3219, 3220, 29897, 30053, 3242, 30054, 30024
12150, 29897, 3220, 3221, 29898, 30054, 3243, 30055, 30026
12151, 29898, 3221, 3222, 29899, 30055, 3244, 30056, 30028
12152, 29899, 3222, 3223, 29900, 30056, 3245, 30057, 30030
12153, 29900, 3223, 3224, 29901, 30057, 3246, 30058, 30032
12154, 29901, 3224, 3225, 29902, 30058, 3247, 30059, 30034
12155, 29902, 3225, 3226, 29903, 30059, 3248, 30060, 30036
12156, 29903, 3226, 69, 2765, 30060, 3249, 2769, 30038
*ELEMENT, type=CPS8, ELSET=Surface164
12157, 86, 3132, 30061, 3250, 3154, 30127, 30128, 3253
12158, 3132, 3133, 30062, 30061, 3155, 30129, 30130, 30127
12159, 3133, 3134, 30063, 30062, 3156, 30131, 30132, 30129
12160, 3134, 3135, 30064, 30063, 3157, 30133, 30134, 30131
12161, 3135, 3136, 30065, 30064, 3158, 30135, 30136, 30133
12162, 3136, 3137, 30066, 30065, 3159, 30137, 30138, 30135
12163, 3137, 3138, 30067, 30066, 3160, 30139, 30140, 30137
12164, 3138, 3139, 30068, 30067, 3161, 30141, 30142, 30139
12165, 3139, 3140, 30069, 30068, 3162, 30143, 30144, 30141
12166, 3140, 3141, 30070, 30069, 3163, 30145, 30146, 30143
12167, 3141, 3142, 30071, 30070, 3164, 30147, 30148, 30145
12168, 3142, 3143, 30072, 30071, 3165, 30149, 30150, 30147
12169, 3143, 3144, 30073, 30072, 3166, 30151, 30152, 30149
12170, 3144, 3145, 30074, 30073, 3167, 30153, 30154, 30151
12171, 3145, 3146, 30075, 30074, 3168, 30155, 30156, 30153
12172, 3146, 3147, 30076, 30075, 3169, 30157, 30158, 30155
12173, 3147, 3148, 30077, 30076, 3170, 30159, 30160, 30157
12174, 3148, 3149, 30078, 30077, 3171, 30161, 30162, 30159
12175, 3149, 3150, 30079, 30078, 3172, 30163, 30164, 30161
12176, 3150, 3151, 30080, 30079, 3173, 30165, 30166, 30163
12177, 3151, 3152, 30081, 30080, 3174, 30167, 30168, 30165
12178, 3152, 3153, 30082, 30081, 3175, 30169, 30170, 30167
12179, 3153, 46, 2770, 30082, 3176, 2773, 30171, 30169
12180, 3250, 30061, 30083, 3251, 30128, 30172, 30173, 3254
12181, 30061, 30062, 30084, 30083, 30130, 30174, 30175, 30172
12182, 30062, 30063, 30085, 30084, 30132, 30176, 30177, 30174
12183, 30063, 30064, 30086, 30085, 30134, 30178, 30179, 30176
12184, 30064, 30065, 30087, 30086, 30136, 30180, 30181, 30178
12185, 30065, 30066, 30088, 30087, 30138, 30182, 30183, 30180
12186, 30066, 30067, 30089, 30088, 30140, 30184, 30185, 30182
12187, 30067, 30068, 30090, 30089, 30142, 30186, 30187, 30184
12188, 30068, 30069, 30091, 30090, 30144, 30188, 30189, 30186
12189, 30069, 30070, 30092, 30091, 30146, 30190, 30191, 30188
12190, 30070, 30071, 30093, 30092, 30148, 30192, 30193, 30190
12191, 30071, 30072, 30094, 30093, 30150, 30194, 30195, 30192
12192, 30072, 30073, 30095, 30094, 30152, 30196, 30197, 30194
12193, 30073, 30074, 30096, 30095, 30154, 30198, 30199, 30196
12194, 30074, 30075, 30097, 30096, 30156, 30200, 30201, 30198
12195, 30075, 30076, 30098, 30097, 30158, 30202, 30203, 30200
12196, 30076, 30077, 30099, 30098, 30160, 30204, 30205, 30202
12197, 30077, 30078, 30100, 30099, 30162, 30206, 30207, 30204
12198, 30078, 30079, 30101, 30100, 30164, 30208, 30209, 30206
12199, 30079, 30080, 30102, 30101, 30166, 30210, 30211, 30208
12200, 30080, 30081, 30103, 30102, 30168, 30212, 30213, 30210
12201, 30081, 30082, 30104, 30103, 30170, 30214, 30215, 30212
12202, 30082, 2770, 2771, 30104, 30171, 2774, 30216, 30214
12203, 3251, 30083, 30105, 3252, 30173, 30217, 30218, 3255
12204, 30083, 30084, 30106, 30105, 30175, 30219, 30220, 30217
12205, 30084, 30085, 30107, 30106, 30177, 30221, 30222, 30219
12206, 30085, 30086, 30108, 30107, 30179, 30223, 30224, 30221
12207, 30086, 30087, 30109, 30108, 30181, 30225, 30226, 30223
12208, 30087, 30088, 30110, 30109, 30183, 30227, 30228, 30225
12209, 30088, 30089, 30111, 30110, 30185, 30229, 30230, 30227
12210, 30089, 30090, 30112, 30111, 30187, 30231, 30232, 30229
12211, 30090, 30091, 30113, 30112, 30189, 30233, 30234, 30231
12212, 30091, 30092, 30114, 30113, 30191, 30235, 30236, 30233
12213, 30092, 30093, 30115, 30114, 30193, 30237, 30238, 30235
12214, 30093, 30094, 30116, 30115, 30195, 30239, 30240, 30237
12215, 30094, 30095, 30117, 30116, 30197, 30241, 30242, 30239
12216, 30095, 30096, 30118, 30117, 30199, 30243, 30244, 30241
12217, 30096, 30097, 30119, 30118, 30201, 30245, 30246, 30243
12218, 30097, 30098, 30120, 30119, 30203, 30247, 30248, 30245
12219, 30098, 30099, 30121, 30120, 30205, 30249, 30250, 30247
12220, 30099, 30100, 30122, 30121, 30207, 30251, 30252, 30249
12221, 30100, 30101, 30123, 30122, 30209, 30253, 30254, 30251
12222, 30101, 30102, 30124, 30123, 30211, 30255, 30256, 30253
12223, 30102, 30103, 30125, 30124, 30213, 30257, 30258, 30255
12224, 30103, 30104, 30126, 30125, 30215, 30259, 30260, 30257
12225, 30104, 2771, 2772, 30126, 30216, 2775, 30261, 30259
12226, 3252, 30105, 3257, 88, 30218, 30262, 3279, 3256
12227, 30105, 30106, 3258, 3257, 30220, 30263, 3280, 30262
12228, 30106, 30107, 3259, 3258, 30222, 30264, 3281, 30263
12229, 30107, 30108, 3260, 3259, 30224, 30265, 3282, 30264
12230, 30108, 30109, 3261, 3260, 30226, 30266, 3283, 30265
12231, 30109, 30110, 3262, 3261, 30228, 30267, 3284, 30266
12232, 30110, 30111, 3263, 3262, 30230, 30268, 3285, 30267
12233, 30111, 30112, 3264, 3263, 30232, 30269, 3286, 30268
12234, 30112, 30113, 3265, 3264, 30234, 30270, 3287, 30269
12235, 30113, 30114, 3266, 3265, 30236, 30271, 3288, 30270
12236, 30114, 30115, 3267, 3266, 30238, 30272, 3289, 30271
12237, 30115, 30116, 3268, 3267, 30240, 30273, 3290, 30272
12238, 30116, 30117, 3269, 3268, 30242, 30274, 3291, 30273
12239, 30117, 30118, 3270, 3269, 30244, 30275, 3292, 30274
12240, 30118, 30119, 3271, 3270, 30246, 30276, 3293, 30275
12241, 30119, 30120, 3272, 3271, 30248, 30277, 3294, 30276
12242, 30120, 30121, 3273, 3272, 30250, 30278, 3295, 30277
12243, 30121, 30122, 3274, 3273, 30252, 30279, 3296, 30278
12244, 30122, 30123, 3275, 3274, 30254, 30280, 3297, 30279
12245, 30123, 30124, 3276, 3275, 30256, 30281, 3298, 30280
12246, 30124, 30125, 3277, 3276, 30258, 30282, 3299, 30281
12247, 30125, 30126, 3278, 3277, 30260, 30283, 3300, 30282
12248, 30126, 2772, 70, 3278, 30261, 2776, 3301, 30283
*ELEMENT, type=CPS8, ELSET=Surface165
12249, 85, 3186, 30284, 3198, 3197, 30314, 30315, 3201
12250, 3186, 3185, 30285, 30284, 3196, 30316, 30317, 30314
12251, 3185, 3184, 30286, 30285, 3195, 30318, 30319, 30316
12252, 3184, 3183, 30287, 30286, 3194, 30320, 30321, 30318
12253, 3183, 3182, 30288, 30287, 3193, 30322, 30323, 30320
12254, 3182, 3181, 30289, 30288, 3192, 30324, 30325, 30322
12255, 3181, 3180, 30290, 30289, 3191, 30326, 30327, 30324
12256, 3180, 3179, 30291, 30290, 3190, 30328, 30329, 30326
12257, 3179, 3178, 30292, 30291, 3189, 30330, 30331, 30328
12258, 3178, 3177, 30293, 30292, 3188, 30332, 30333, 30330
12259, 3177, 86, 3250, 30293, 3187, 3253, 30334, 30332
12260, 3198, 30284, 30294, 3199, 30315, 30335, 30336, 3202
12261, 30284, 30285, 30295, 30294, 30317, 30337, 30338, 30335
12262, 30285, 30286, 30296, 30295, 30319, 30339, 30340, 30337
12263, 30286, 30287, 30297, 30296, 30321, 30341, 30342, 30339
12264, 30287, 30288, 30298, 30297, 30323, 30343, 30344, 30341
12265, 30288, 30289, 30299, 30298, 30325, 30345, 30346, 30343
12266, 30289, 30290, 30300, 30299, 30327, 30347, 30348, 30345
12267, 30290, 30291, 30301, 30300, 30329, 30349, 30350, 30347
12268, 30291, 30292, 30302, 30301, 30331, 30351, 30352, 30349
12269, 30292, 30293, 30303, 30302, 30333, 30353, 30354, 30351
12270, 30293, 3250, 3251, 30303, 30334, 3254, 30355, 30353
12271, 3199, 30294, 30304, 3200, 30336, 30356, 30357, 3203
12272, 30294, 30295, 30305, 30304, 30338, 30358, 30359, 30356
12273, 30295, 30296, 30306, 30305, 30340, 30360, 30361, 30358
12274, 30296, 30297, 30307, 30306, 30342, 30362, 30363, 30360
12275, 30297, 30298, 30308, 30307, 30344, 30364, 30365, 30362
12276, 30298, 30299, 30309, 30308, 30346, 30366, 30367, 30364
12277, 30299, 30300, 30310, 30309, 30348, 30368, 30369, 30366
12278, 30300, 30301, 30311, 30310, 30350, 30370, 30371, 30368
12279, 30301, 30302, 30312, 30311, 30352, 30372, 30373, 30370
12280, 30302, 30303, 30313, 30312, 30354, 30374, 30375, 30372
12281, 30303, 3251, 3252, 30313, 30355, 3255, 30376, 30374
12282, 3200, 30304, 3311, 87, 30357, 30377, 3322, 3204
12283, 30304, 30305, 3310, 3311, 30359, 30378, 3321, 30377
12284, 30305, 30306, 3309, 3310, 30361, 30379, 3320, 30378
12285, 30306, 30307, 3308, 3309, 30363, 30380, 3319, 30379
12286, 30307, 30308, 3307, 3308, 30365, 30381, 3318, 30380
12287, 30308, 30309, 3306, 3307, 30367, 30382, 3317, 30381
12288, 30309, 30310, 3305, 3306, 30369, 30383, 3316, 30382
12289, 30310, 30311, 3304, 3305, 30371, 30384, 3315, 30383
12290, 30311, 30312, 3303, 3304, 30373, 30385, 3314, 30384
12291, 30312, 30313, 3302, 3303, 30375, 30386, 3313, 30385
12292, 30313, 3252, 88, 3302, 30376, 3256, 3312, 30386
*ELEMENT, type=CPS8, ELSET=Surface166
12293, 87, 3311, 30387, 3205, 3322, 30607, 30608, 3227
12294, 3311, 3310, 30388, 30387, 3321, 30609, 30610, 30607
12295, 3310, 3309, 30389, 30388, 3320, 30611, 30612, 30609
12296, 3309, 3308, 30390, 30389, 3319, 30613, 30614, 30611
12297, 3308, 3307, 30391, 30390, 3318, 30615, 30616, 30613
12298, 3307, 3306, 30392, 30391, 3317, 30617, 30618, 30615
12299, 3306, 3305, 30393, 30392, 3316, 30619, 30620, 30617
12300, 3305, 3304, 30394, 30393, 3315, 30621, 30622, 30619
12301, 3304, 3303, 30395, 30394, 3314, 30623, 30624, 30621
12302, 3303, 3302, 30396, 30395, 3313, 30625, 30626, 30623
12303, 3302, 88, 3257, 30396, 3312, 3279, 30627, 30625
12304, 3205, 30387, 30397, 3206, 30608, 30628, 30629, 3228
12305, 30387, 30388, 30398, 30397, 30610, 30630, 30631, 30628
12306, 30388, 30389, 30399, 30398, 30612, 30632, 30633, 30630
12307, 30389, 30390, 30400, 30399, 30614, 30634, 30635, 30632
12308, 30390, 30391, 30401, 30400, 30616, 30636, 30637, 30634
12309, 30391, 30392, 30402, 30401, 30618, 30638, 30639, 30636
12310, 30392, 30393, 30403, 30402, 30620, 30640, 30641, 30638
12311, 30393, 30394, 30404, 30403, 30622, 30642, 30643, 30640
12312, 30394, 30395, 30405, 30404, 30624, 30644, 30645, 30642
12313, 30395, 30396, 30406, 30405, 30626, 30646, 30647, 30644
12314, 30396, 3257, 3258, 30406, 30627, 3280, 30648, 30646
12315, 3206, 30397, 30407, 3207, 30629, 30649, 30650, 3229
12316, 30397, 30398, 30408, 30407, 30631, 30651, 30652, 30649
12317, 30398, 30399, 30409, 30408, 30633, 30653, 30654, 30651
12318, 30399, 30400, 30410, 30409, 30635, 30655, 30656, 30653
12319, 30400, 30401, 30411, 30410, 30637, 30657, 30658, 30655
12320, 30401, 30402, 30412, 30411, 30639, 30659, 30660, 30657
12321, 30402, 30403, 30413, 30412, 30641, 30661, 30662, 30659
12322, 30403, 30404, 30414, 30413, 30643, 30663, 30664, 30661
12323, 30404, 30405, 30415, 30414, 30645, 30665, 30666, 30663
12324, 30405, 30406, 30416, 30415, 30647, 30667, 30668, 30665
12325, 30406, 3258, 3259, 30416, 30648, 3281, 30669, 30667
12326, 3207, 30407, 30417, 3208, 30650, 30670, 30671, 3230
12327, 30407, 30408, 30418, 30417, 30652, 30672, 30673, 30670
12328, 30408, 30409, 30419, 30418, 30654, 30674, 30675, 30672
12329, 30409, 30410, 30420, 30419, 30656, 30676, 30677, 30674
12330, 30410, 30411, 30421, 30420, 30658, 30678, 30679, 30676
12331, 30411, 30412, 30422, 30421, 30660, 30680, 30681, 30678
12332, 30412, 30413, 30423, 30422, 30662, 30682, 30683, 30680
12333, 30413, 30414, 30424, 30423, 30664, 30684, 30685, 30682
12334, 30414, 30415, 30425, 30424, 30666, 30686, 30687, 30684
12335, 30415, 30416, 30426, 30425, 30668, 30688, 30689, 30686
12336, 30416, 3259, 3260, 30426, 30669, 3282, 30690, 30688
12337, 3208, 30417, 30427, 3209, 30671, 30691, 30692, 3231
12338, 30417, 30418, 30428, 30427, 30673, 30693, 30694, 30691
12339, 30418, 30419, 30429, 30428, 30675, 30695, 30696, 30693
12340, 30419, 30420, 30430, 30429, 30677, 30697, 30698, 30695
12341, 30420, 30421, 30431, 30430, 30679, 30699, 30700, 30697
12342, 30421, 30422, 30432, 30431, 30681, 30701, 30702, 30699
12343, 30422, 30423, 30433, 30432, 30683, 30703, 30704, 30701
12344, 30423, 30424, 30434, 30433, 30685, 30705, 30706, 30703
12345, 30424, 30425, 30435, 30434, 30687, 30707, 30708, 30705
12346, 30425, 30426, 30436, 30435, 30689, 30709, 30710, 30707
12347, 30426, 3260, 3261, 30436, 30690, 3283, 30711, 30709
12348, 3209, 30427, 30437, 3210, 30692, 30712, 30713, 3232
12349, 30427, 30428, 30438, 30437, 30694, 30714, 30715, 30712
12350, 30428, 30429, 30439, 30438, 30696, 30716, 30717, 30714
12351, 30429, 30430, 30440, 30439, 30698, 30718, 30719, 30716
12352, 30430, 30431, 30441, 30440, 30700, 30720, 30721, 30718
12353, 30431, 30432, 30442, 30441, 30702, 30722, 30723, 30720
12354, 30432, 30433, 30443, 30442, 30704, 30724, 30725, 30722
12355, 30433, 30434, 30444, 30443, 30706, 30726, 30727, 30724
12356, 30434, 30435, 30445, 30444, 30708, 30728, 30729, 30726
12357, 30435, 30436, 30446, 30445, 30710, 30730, 30731, 30728
12358, 30436, 3261, 3262, 30446, 30711, 3284, 30732, 30730
12359, 3210, 30437, 30447, 3211, 30713, 30733, 30734, 3233
12360, 30437, 30438, 30448, 30447, 30715, 30735, 30736, 30733
12361, 30438, 30439, 30449, 30448, 30717, 30737, 30738, 30735
12362, 30439, 30440, 30450, 30449, 30719, 30739, 30740, 30737
12363, 30440, 30441, 30451, 30450, 30721, 30741, 30742, 30739
12364, 30441, 30442, 30452, 30451, 30723, 30743, 30744, 30741
12365, 30442, 30443, 30453, 30452, 30725, 30745, 30746, 30743
12366, 30443, 30444, 30454, 30453, 30727, 30747, 30748, 30745
12367, 30444, 30445, 30455, 30454, 30729, 30749, 30750, 30747
12368, 30445, 30446, 30456, 30455, 30731, 30751, 30752, 30749
12369, 30446, 3262, 3263, 30456, 30732, 3285, 30753, 30751
12370, 3211, 30447, 30457, 3212, 30734, 30754, 30755, 3234
12371, 30447, 30448, 30458, 30457, 30736, 30756, 30757, 30754
12372, 30448, 30449, 30459, 30458, 30738, 30758, 30759, 30756
12373, 30449, 30450, 30460, 30459, 30740, 30760, 30761, 30758
12374, 30450, 30451, 30461, 30460, 30742, 30762, 30763, 30760
12375, 30451, 30452, 30462, 30461, 30744, 30764, 30765, 30762
12376, 30452, 30453, 30463, 30462, 30746, 30766, 30767, 30764
12377, 30453, 30454, 30464, 30463, 30748, 30768, 30769, 30766
12378, 30454, 30455, 30465, 30464, 30750, 30770, 30771, 30768
12379, 30455, 30456, 30466, 30465, 30752, 30772, 30773, 30770
12380, 30456, 3263, 3264, 30466, 30753, 3286, 30774, 30772
12381, 3212, 30457, 30467, 3213, 30755, 30775, 30776, 3235
12382, 30457, 30458, 30468, 30467, 30757, 30777, 30778, 30775
12383, 30458, 30459, 30469, 30468, 30759, 30779, 30780, 30777
12384, 30459, 30460, 30470, 30469, 30761, 30781, 30782, 30779
12385, 30460, 30461, 30471, 30470, 30763, 30783, 30784, 30781
12386, 30461, 30462, 30472, 30471, 30765, 30785, 30786, 30783
12387, 30462, 30463, 30473, 30472, 30767, 30787, 30788, 30785
12388, 30463, 30464, 30474, 30473, 30769, 30789, 30790, 30787
12389, 30464, 30465, 30475, 30474, 30771, 30791, 30792, 30789
12390, 30465, 30466, 30476, 30475, 30773, 30793, 30794, 30791
12391, 30466, 3264, 3265, 30476, 30774, 3287, 30795, 30793
12392, 3213, 30467, 30477, 3214, 30776, 30796, 30797, 3236
12393, 30467, 30468, 30478, 30477, 30778, 30798, 30799, 30796
12394, 30468, 30469, 30479, 30478, 30780, 30800, 30801, 30798
12395, 30469, 30470, 30480, 30479, 30782, 30802, 30803, 30800
12396, 30470, 30471, 30481, 30480, 30784, 30804, 30805, 30802
12397, 30471, 30472, 30482, 30481, 30786, 30806, 30807, 30804
12398, 30472, 30473, 30483, 30482, 30788, 30808, 30809, 30806
12399, 30473, 30474, 30484, 30483, 30790, 30810, 30811, 30808
12400, 30474, 30475, 30485, 30484, 30792, 30812, 30813, 30810
12401, 30475, 30476, 30486, 30485, 30794, 30814, 30815, 30812
12402, 30476, 3265, 3266, 30486, 30795, 3288, 30816, 30814
12403, 3214, 30477, 30487, 3215, 30797, 30817, 30818, 3237
12404, 30477, 30478, 30488, 30487, 30799, 30819, 30820, 30817
12405, 30478, 30479, 30489, 30488, 30801, 30821, 30822, 30819
12406, 30479, 30480, 30490, 30489, 30803, 30823, 30824, 30821
12407, 30480, 30481, 30491, 30490, 30805, 30825, 30826, 30823
12408, 30481, 30482, 30492, 30491, 30807, 30827, 30828, 30825
12409, 30482, 30483, 30493, 30492, 30809, 30829, 30830, 30827
12410, 30483, 30484, 30494, 30493, 30811, 30831, 30832, 30829
12411, 30484, 30485, 30495, 30494, 30813, 30833, 30834, 30831
12412, 30485, 30486, 30496, 30495, 30815, 30835, 30836, 30833
12413, 30486, 3266, 3267, 30496, 30816, 3289, 30837, 30835
12414, 3215, 30487, 30497, 3216, 30818, 30838, 30839, 3238
12415, 30487, 30488, 30498, 30497, 30820, 30840, 30841, 30838
12416, 30488, 30489, 30499, 30498, 30822, 30842, 30843, 30840
12417, 30489, 30490, 30500, 30499, 30824, 30844, 30845, 30842
12418, 30490, 30491, 30501, 30500, 30826, 30846, 30847, 30844
12419, 30491, 30492, 30502, 30501, 30828, 30848, 30849, 30846
12420, 30492, 30493, 30503, 30502, 30830, 30850, 30851, 30848
12421, 30493, 30494, 30504, 30503, 30832, 30852, 30853, 30850
12422, 30494, 30495, 30505, 30504, 30834, 30854, 30855, 30852
12423, 30495, 30496, 30506, 30505, 30836, 30856, 30857, 30854
12424, 30496, 3267, 3268, 30506, 30837, 3290, 30858, 30856
12425, 3216, 30497, 30507, 3217, 30839, 30859, 30860, 3239
12426, 30497, 30498, 30508, 30507, 30841, 30861, 30862, 30859
12427, 30498, 30499, 30509, 30508, 30843, 30863, 30864, 30861
12428, 30499, 30500, 30510, 30509, 30845, 30865, 30866, 30863
12429, 30500, 30501, 30511, 30510, 30847, 30867, 30868, 30865
12430, 30501, 30502, 30512, 30511, 30849, 30869, 30870, 30867
12431, 30502, 30503, 30513, 30512, 30851, 30871, 30872, 30869
12432, 30503, 30504, 30514, 30513, 30853, 30873, 30874, 30871
12433, 30504, 30505, 30515, 30514, 30855, 30875, 30876, 30873
12434, 30505, 30506, 30516, 30515, 30857, 30877, 30878, 30875
12435, 30506, 3268, 3269, 30516, 30858, 3291, 30879, 30877
12436, 3217, 30507, 30517, 3218, 30860, 30880, 30881, 3240
12437, 30507, 30508, 30518, 30517, 30862, 30882, 30883, 30880
12438, 30508, 30509, 30519, 30518, 30864, 30884, 30885, 30882
12439, 30509, 30510, 30520, 30519, 30866, 30886, 30887, 30884
12440, 30510, 30511, 30521, 30520, 30868, 30888, 30889, 30886
12441, 30511, 30512, 30522, 30521, 30870, 30890, 30891, 30888
12442, 30512, 30513, 30523, 30522, 30872, 30892, 30893, 30890
12443, 30513, 30514, 30524, 30523, 30874, 30894, 30895, 30892
12444, 30514, 30515, 30525, 30524, 30876, 30896, 30897, 30894
12445, 30515, 30516, 30526, 30525, 30878, 30898, 30899, 30896
12446, 30516, 3269, 3270, 30526, 30879, 3292, 30900, 30898
12447, 3218, 30517, 30527, 3219, 30881, 30901, 30902, 3241
12448, 30517, 30518, 30528, 30527, 30883, 30903, 30904, 30901
12449, 30518, 30519, 30529, 30528, 30885, 30905, 30906, 30903
12450, 30519, 30520, 30530, 30529, 30887, 30907, 30908, 30905
12451, 30520, 30521, 30531, 30530, 30889, 30909, 30910, 30907
12452, 30521, 30522, 30532, 30531, 30891, 30911, 30912, 30909
12453, 30522, 30523, 30533, 30532, 30893, 30913, 30914, 30911
12454, 30523, 30524, 30534, 30533, 30895, 30915, 30916, 30913
12455, 30524, 30525, 30535, 30534, 30897, 30917, 30918, 30915
12456, 30525, 30526, 30536, 30535, 30899, 30919, 30920, 30917
12457, 30526, 3270, 3271, 30536, 30900, 3293, 30921, 30919
12458, 3219, 30527, 30537, 3220, 30902, 30922, 30923, 3242
12459, 30527, 30528, 30538, 30537, 30904, 30924, 30925, 30922
12460, 30528, 30529, 30539, 30538, 30906, 30926, 30927, 30924
12461, 30529, 30530, 30540, 30539, 30908, 30928, 30929, 30926
12462, 30530, 30531, 30541, 30540, 30910, 30930, 30931, 30928
12463, 30531, 30532, 30542, 30541, 30912, 30932, 30933, 30930
12464, 30532, 30533, 30543, 30542, 30914, 30934, 30935, 30932
12465, 30533, 30534, 30544, 30543, 30916, 30936, 30937, 30934
12466, 30534, 30535, 30545, 30544, 30918, 30938, 30939, 30936
12467, 30535, 30536, 30546, 30545, 30920, 30940, 30941, 30938
12468, 30536, 3271, 3272, 30546, 30921, 3294, 30942, 30940
12469, 3220, 30537, 30547, 3221, 30923, 30943, 30944, 3243
12470, 30537, 30538, 30548, 30547, 30925, 30945, 30946, 30943
12471, 30538, 30539, 30549, 30548, 30927, 30947, 30948, 30945
12472, 30539, 30540, 30550, 30549, 30929, 30949, 30950, 30947
12473, 30540, 30541, 30551, 30550, 30931, 30951, 30952, 30949
12474, 30541, 30542, 30552, 30551, 30933, 30953, 30954, 30951
12475, 30542, 30543, 30553, 30552, 30935, 30955, 30956, 30953
12476, 30543, 30544, 30554, 30553, 30937, 30957, 30958, 30955
12477, 30544, 30545, 30555, 30554, 30939, 30959, 30960, 30957
12478, 30545, 30546, 30556, 30555, 30941, 30961, 30962, 30959
12479, 30546, 3272, 3273, 30556, 30942, 3295, 30963, 30961
12480, 3221, 30547, 30557, 3222, 30944, 30964, 30965, 3244
12481, 30547, 30548, 30558, 30557, 30946, 30966, 30967, 30964
12482, 30548, 30549, 30559, 30558, 30948, 30968, 30969, 30966
12483, 30549, 30550, 30560, 30559, 30950, 30970, 30971, 30968
12484, 30550, 30551, 30561, 30560, 30952, 30972, 30973, 30970
12485, 30551, 30552, 30562, 30561, 30954, 30974, 30975, 30972
12486, 30552, 30553, 30563, 30562, 30956, 30976, 30977, 30974
12487, 30553, 30554, 30564, 30563, 30958, 30978, 30979, 30976
12488, 30554, 30555, 30565, 30564, 30960, 30980, 30981, 30978
12489, 30555, 30556, 30566, 30565, 30962, 30982, 30983, 30980
12490, 30556, 3273, 3274, 30566, 30963, 3296, 30984, 30982
12491, 3222, 30557, 30567, 3223, 30965, 30985, 30986, 3245
12492, 30557, 30558, 30568, 30567, 30967, 30987, 30988, 30985
12493, 30558, 30559, 30569, 30568, 30969, 30989, 30990, 30987
12494, 30559, 30560, 30570, 30569, 30971, 30991, 30992, 30989
12495, 30560, 30561, 30571, 30570, 30973, 30993, 30994, 30991
12496, 30561, 30562, 30572, 30571, 30975, 30995, 30996, 30993
12497, 30562, 30563, 30573, 30572, 30977, 30997, 30998, 30995
12498, 30563, 30564, 30574, 30573, 30979, 30999, 31000, 30997
12499, 30564, 30565, 30575, 30574, 30981, 31001, 31002, 30999
12500, 30565, 30566, 30576, 30575, 30983, 31003, 31004, 31001
12501, 30566, 3274, 3275, 30576, 30984, 3297, 31005, 31003
12502, 3223, 30567, 30577, 3224, 30986, 31006, 31007, 3246
12503, 30567, 30568, 30578, 30577, 30988, 31008, 31009, 31006
12504, 30568, 30569, 30579, 30578, 30990, 31010, 31011, 31008
12505, 30569, 30570, 30580, 30579, 30992, 31012, 31013, 31010
12506, 30570, 30571, 30581, 30580, 30994, 31014, 31015, 31012
12507, 30571, 30572, 30582, 30581, 30996, 31016, 31017, 31014
12508, 30572, 30573, 30583, 30582, 30998, 31018, 31019, 31016
12509, 30573, 30574, 30584, 30583, 31000, 31020, 31021, 31018
12510, 30574, 30575, 30585, 30584, 31002, 31022, 31023, 31020
12511, 30575, 30576, 30586, 30585, 31004, 31024, 31025, 31022
12512, 30576, 3275, 3276, 30586, 31005, 3298, 31026, 31024
12513, 3224, 30577, 30587, 3225, 31007, 31027, 31028, 3247
12514, 30577, 30578, 30588, 30587, 31009, 31029, 31030, 31027
12515, 30578, 30579, 30589, 30588, 31011, 31031, 31032, 31029
12516, 30579, 30580, 30590, 30589, 31013, 31033, 31034, 31031
12517, 30580, 30581, 30591, 30590, 31015, 31035, 31036, 31033
12518, 30581, 30582, 30592, 30591, 31017, 31037, 31038, 31035
12519, 30582, 30583, 30593, 30592, 31019, 31039, 31040, 31037
12520, 30583, 30584, 30594, 30593, 31021, 31041, 31042, 31039
12521, 30584, 30585, 30595, 30594, 31023, 31043, 31044, 31041
12522, 30585, 30586, 30596, 30595, 31025, 31045, 31046, 31043
12523, 30586, 3276, 3277, 30596, 31026, 3299, 31047, 31045
12524, 3225, 30587, 30597, 3226, 31028, 31048, 31049, 3248
12525, 30587, 30588, 30598, 30597, 31030, 31050, 31051, 31048
12526, 30588, 30589, 30599, 30598, 31032, 31052, 31053, 31050
12527, 30589, 30590, 30600, 30599, 31034, 31054, 31055, 31052
12528, 30590, 30591, 30601, 30600, 31036, 31056, 31057, 31054
12529, 30591, 30592, 30602, 30601, 31038, 31058, 31059, 31056
12530, 30592, 30593, 30603, 30602, 31040, 31060, 31061, 31058
12531, 30593, 30594, 30604, 30603, 31042, 31062, 31063, 31060
12532, 30594, 30595, 30605, 30604, 31044, 31064, 31065, 31062
12533, 30595, 30596, 30606, 30605, 31046, 31066, 31067, 31064
12534, 30596, 3277, 3278, 30606, 31047, 3300, 31068, 31066
12535, 3226, 30597, 2786, 69, 31049, 31069, 2797, 3249
12536, 30597, 30598, 2785, 2786, 31051, 31070, 2796, 31069
12537, 30598, 30599, 2784, 2785, 31053, 31071, 2795, 31070
12538, 30599, 30600, 2783, 2784, 31055, 31072, 2794, 31071
12539, 30600, 30601, 2782, 2783, 31057, 31073, 2793, 31072
12540, 30601, 30602, 2781, 2782, 31059, 31074, 2792, 31073
12541, 30602, 30603, 2780, 2781, 31061, 31075, 2791, 31074
12542, 30603, 30604, 2779, 2780, 31063, 31076, 2790, 31075
12543, 30604, 30605, 2778, 2779, 31065, 31077, 2789, 31076
12544, 30605, 30606, 2777, 2778, 31067, 31078, 2788, 31077
12545, 30606, 3278, 70, 2777, 31068, 3301, 2787, 31078
*ELEMENT, type=CPS8, ELSET=Surface167
12546, 5, 2617, 31079, 3323, 2620, 31091, 31092, 3327
12547, 2617, 2618, 31080, 31079, 2621, 31093, 31094, 31091
12548, 2618, 2619, 31081, 31080, 2622, 31095, 31096, 31093
12549, 2619, 65, 3332, 31081, 2623, 3336, 31097, 31095
12550, 3323, 31079, 31082, 3324, 31092, 31098, 31099, 3328
12551, 31079, 31080, 31083, 31082, 31094, 31100, 31101, 31098
12552, 31080, 31081, 31084, 31083, 31096, 31102, 31103, 31100
12553, 31081, 3332, 3333, 31084, 31097, 3337, 31104, 31102
12554, 3324, 31082, 31085, 3325, 31099, 31105, 31106, 3329
12555, 31082, 31083, 31086, 31085, 31101, 31107, 31108, 31105
12556, 31083, 31084, 31087, 31086, 31103, 31109, 31110, 31107
12557, 31084, 3333, 3334, 31087, 31104, 3338, 31111, 31109
12558, 3325, 31085, 31088, 3326, 31106, 31112, 31113, 3330
12559, 31085, 31086, 31089, 31088, 31108, 31114, 31115, 31112
12560, 31086, 31087, 31090, 31089, 31110, 31116, 31117, 31114
12561, 31087, 3334, 3335, 31090, 31111, 3339, 31118, 31116
12562, 3326, 31088, 3198, 85, 31113, 31119, 3201, 3331
12563, 31088, 31089, 3199, 3198, 31115, 31120, 3202, 31119
12564, 31089, 31090, 3200, 3199, 31117, 31121, 3203, 31120
12565, 31090, 3335, 87, 3200, 31118, 3340, 3204, 31121
*ELEMENT, type=CPS8, ELSET=Surface168
12566, 6, 3341, 31122, 2558, 3345, 31134, 31135, 2561
12567, 2558, 31122, 31123, 2559, 31135, 31136, 31137, 2562
12568, 2559, 31123, 31124, 2560, 31137, 31138, 31139, 2563
12569, 2560, 31124, 3350, 63, 31139, 31140, 3354, 2564
12570, 3341, 3342, 31125, 31122, 3346, 31141, 31142, 31134
12571, 31122, 31125, 31126, 31123, 31142, 31143, 31144, 31136
12572, 31123, 31126, 31127, 31124, 31144, 31145, 31146, 31138
12573, 31124, 31127, 3351, 3350, 31146, 31147, 3355, 31140
12574, 3342, 3343, 31128, 31125, 3347, 31148, 31149, 31141
12575, 31125, 31128, 31129, 31126, 31149, 31150, 31151, 31143
12576, 31126, 31129, 31130, 31127, 31151, 31152, 31153, 31145
12577, 31127, 31130, 3352, 3351, 31153, 31154, 3356, 31147
12578, 3343, 3344, 31131, 31128, 3348, 31155, 31156, 31148
12579, 31128, 31131, 31132, 31129, 31156, 31157, 31158, 31150
12580, 31129, 31132, 31133, 31130, 31158, 31159, 31160, 31152
12581, 31130, 31133, 3353, 3352, 31160, 31161, 3357, 31154
12582, 3344, 86, 3250, 31131, 3349, 3253, 31162, 31155
12583, 31131, 3250, 3251, 31132, 31162, 3254, 31163, 31157
12584, 31132, 3251, 3252, 31133, 31163, 3255, 31164, 31159
12585, 31133, 3252, 88, 3353, 31164, 3256, 3358, 31161
*ELEMENT, type=CPS8, ELSET=Surface169
12586, 5, 3323, 31165, 150, 3327, 31205, 31206, 161
12587, 150, 31165, 31166, 149, 31206, 31207, 31208, 160
12588, 149, 31166, 31167, 148, 31208, 31209, 31210, 159
12589, 148, 31167, 31168, 147, 31210, 31211, 31212, 158
12590, 147, 31168, 31169, 146, 31212, 31213, 31214, 157
12591, 146, 31169, 31170, 145, 31214, 31215, 31216, 156
12592, 145, 31170, 31171, 144, 31216, 31217, 31218, 155
12593, 144, 31171, 31172, 143, 31218, 31219, 31220, 154
12594, 143, 31172, 31173, 142, 31220, 31221, 31222, 153
12595, 142, 31173, 31174, 141, 31222, 31223, 31224, 152
12596, 141, 31174, 3341, 6, 31224, 31225, 3345, 151
12597, 3323, 3324, 31175, 31165, 3328, 31226, 31227, 31205
12598, 31165, 31175, 31176, 31166, 31227, 31228, 31229, 31207
12599, 31166, 31176, 31177, 31167, 31229, 31230, 31231, 31209
12600, 31167, 31177, 31178, 31168, 31231, 31232, 31233, 31211
12601, 31168, 31178, 31179, 31169, 31233, 31234, 31235, 31213
12602, 31169, 31179, 31180, 31170, 31235, 31236, 31237, 31215
12603, 31170, 31180, 31181, 31171, 31237, 31238, 31239, 31217
12604, 31171, 31181, 31182, 31172, 31239, 31240, 31241, 31219
12605, 31172, 31182, 31183, 31173, 31241, 31242, 31243, 31221
12606, 31173, 31183, 31184, 31174, 31243, 31244, 31245, 31223
12607, 31174, 31184, 3342, 3341, 31245, 31246, 3346, 31225
12608, 3324, 3325, 31185, 31175, 3329, 31247, 31248, 31226
12609, 31175, 31185, 31186, 31176, 31248, 31249, 31250, 31228
12610, 31176, 31186, 31187, 31177, 31250, 31251, 31252, 31230
12611, 31177, 31187, 31188, 31178, 31252, 31253, 31254, 31232
12612, 31178, 31188, 31189, 31179, 31254, 31255, 31256, 31234
12613, 31179, 31189, 31190, 31180, 31256, 31257, 31258, 31236
12614, 31180, 31190, 31191, 31181, 31258, 31259, 31260, 31238
12615, 31181, 31191, 31192, 31182, 31260, 31261, 31262, 31240
12616, 31182, 31192, 31193, 31183, 31262, 31263, 31264, 31242
12617, 31183, 31193, 31194, 31184, 31264, 31265, 31266, 31244
12618, 31184, 31194, 3343, 3342, 31266, 31267, 3347, 31246
12619, 3325, 3326, 31195, 31185, 3330, 31268, 31269, 31247
12620, 31185, 31195, 31196, 31186, 31269, 31270, 31271, 31249
12621, 31186, 31196, 31197, 31187, 31271, 31272, 31273, 31251
12622, 31187, 31197, 31198, 31188, 31273, 31274, 31275, 31253
12623, 31188, 31198, 31199, 31189, 31275, 31276, 31277, 31255
12624, 31189, 31199, 31200, 31190, 31277, 31278, 31279, 31257
12625, 31190, 31200, 31201, 31191, 31279, 31280, 31281, 31259
12626, 31191, 31201, 31202, 31192, 31281, 31282, 31283, 31261
12627, 31192, 31202, 31203, 31193, 31283, 31284, 31285, 31263
12628, 31193, 31203, 31204, 31194, 31285, 31286, 31287, 31265
12629, 31194, 31204, 3344, 3343, 31287, 31288, 3348, 31267
12630, 3326, 85, 3186, 31195, 3331, 3197, 31289, 31268
12631, 31195, 3186, 3185, 31196, 31289, 3196, 31290, 31270
12632, 31196, 3185, 3184, 31197, 31290, 3195, 31291, 31272
12633, 31197, 3184, 3183, 31198, 31291, 3194, 31292, 31274
12634, 31198, 3183, 3182, 31199, 31292, 3193, 31293, 31276
12635, 31199, 3182, 3181, 31200, 31293, 3192, 31294, 31278
12636, 31200, 3181, 3180, 31201, 31294, 3191, 31295, 31280
12637, 31201, 3180, 3179, 31202, 31295, 3190, 31296, 31282
12638, 31202, 3179, 3178, 31203, 31296, 3189, 31297, 31284
12639, 31203, 3178, 3177, 31204, 31297, 3188, 31298, 31286
12640, 31204, 3177, 86, 3344, 31298, 3187, 3349, 31288
*ELEMENT, type=CPS8, ELSET=Surface170
12641, 65, 2633, 31299, 3332, 2644, 31339, 31340, 3336
12642, 2633, 2632, 31300, 31299, 2643, 31341, 31342, 31339
12643, 2632, 2631, 31301, 31300, 2642, 31343, 31344, 31341
12644, 2631, 2630, 31302, 31301, 2641, 31345, 31346, 31343
12645, 2630, 2629, 31303, 31302, 2640, 31347, 31348, 31345
12646, 2629, 2628, 31304, 31303, 2639, 31349, 31350, 31347
12647, 2628, 2627, 31305, 31304, 2638, 31351, 31352, 31349
12648, 2627, 2626, 31306, 31305, 2637, 31353, 31354, 31351
12649, 2626, 2625, 31307, 31306, 2636, 31355, 31356, 31353
12650, 2625, 2624, 31308, 31307, 2635, 31357, 31358, 31355
12651, 2624, 63, 3350, 31308, 2634, 3354, 31359, 31357
12652, 3332, 31299, 31309, 3333, 31340, 31360, 31361, 3337
12653, 31299, 31300, 31310, 31309, 31342, 31362, 31363, 31360
12654, 31300, 31301, 31311, 31310, 31344, 31364, 31365, 31362
12655, 31301, 31302, 31312, 31311, 31346, 31366, 31367, 31364
12656, 31302, 31303, 31313, 31312, 31348, 31368, 31369, 31366
12657, 31303, 31304, 31314, 31313, 31350, 31370, 31371, 31368
12658, 31304, 31305, 31315, 31314, 31352, 31372, 31373, 31370
12659, 31305, 31306, 31316, 31315, 31354, 31374, 31375, 31372
12660, 31306, 31307, 31317, 31316, 31356, 31376, 31377, 31374
12661, 31307, 31308, 31318, 31317, 31358, 31378, 31379, 31376
12662, 31308, 3350, 3351, 31318, 31359, 3355, 31380, 31378
12663, 3333, 31309, 31319, 3334, 31361, 31381, 31382, 3338
12664, 31309, 31310, 31320, 31319, 31363, 31383, 31384, 31381
12665, 31310, 31311, 31321, 31320, 31365, 31385, 31386, 31383
12666, 31311, 31312, 31322, 31321, 31367, 31387, 31388, 31385
12667, 31312, 31313, 31323, 31322, 31369, 31389, 31390, 31387
12668, 31313, 31314, 31324, 31323, 31371, 31391, 31392, 31389
12669, 31314, 31315, 31325, 31324, 31373, 31393, 31394, 31391
12670, 31315, 31316, 31326, 31325, 31375, 31395, 31396, 31393
12671, 31316, 31317, 31327, 31326, 31377, 31397, 31398, 31395
12672, 31317, 31318, 31328, 31327, 31379, 31399, 31400, 31397
12673, 31318, 3351, 3352, 31328, 31380, 3356, 31401, 31399
12674, 3334, 31319, 31329, 3335, 31382, 31402, 31403, 3339
12675, 31319, 31320, 31330, 31329, 31384, 31404, 31405, 31402
12676, 31320, 31321, 31331, 31330, 31386, 31406, 31407, 31404
12677, 31321, 31322, 31332, 31331, 31388, 31408, 31409, 31406
12678, 31322, 31323, 31333, 31332, 31390, 31410, 31411, 31408
12679, 31323, 31324, 31334, 31333, 31392, 31412, 31413, 31410
12680, 31324, 31325, 31335, 31334, 31394, 31414, 31415, 31412
12681, 31325, 31326, 31336, 31335, 31396, 31416, 31417, 31414
12682, 31326, 31327, 31337, 31336, 31398, 31418, 31419, 31416
12683, 31327, 31328, 31338, 31337, 31400, 31420, 31421, 31418
12684, 31328, 3352, 3353, 31338, 31401, 3357, 31422, 31420
12685, 3335, 31329, 3311, 87, 31403, 31423, 3322, 3340
12686, 31329, 31330, 3310, 3311, 31405, 31424, 3321, 31423
12687, 31330, 31331, 3309, 3310, 31407, 31425, 3320, 31424
12688, 31331, 31332, 3308, 3309, 31409, 31426, 3319, 31425
12689, 31332, 31333, 3307, 3308, 31411, 31427, 3318, 31426
12690, 31333, 31334, 3306, 3307, 31413, 31428, 3317, 31427
12691, 31334, 31335, 3305, 3306, 31415, 31429, 3316, 31428
12692, 31335, 31336, 3304, 3305, 31417, 31430, 3315, 31429
12693, 31336, 31337, 3303, 3304, 31419, 31431, 3314, 31430
12694, 31337, 31338, 3302, 3303, 31421, 31432, 3313, 31431
12695, 31338, 3353, 88, 3302, 31422, 3358, 3312, 31432
*ELEMENT, type=C3D20, ELSET=Volume1
12696, 3359, 89, 2, 136, 31433, 3503, 193, 4887, 3379, 99, 138, 3380, 31874, 3723, 4932, 
31875, 31873, 3724, 215, 4931
12697, 31433, 3503, 193, 4887, 31434, 3513, 194, 4888, 31874, 3723, 4932, 31875, 31877, 3744, 4934, 
31878, 31876, 3745, 216, 4933
12698, 31434, 3513, 194, 4888, 31435, 3523, 195, 4889, 31877, 3744, 4934, 31878, 31880, 3765, 4936, 
31881, 31879, 3766, 217, 4935
12699, 31435, 3523, 195, 4889, 31436, 3533, 196, 4890, 31880, 3765, 4936, 31881, 31883, 3786, 4938, 
31884, 31882, 3787, 218, 4937
12700, 31436, 3533, 196, 4890, 31437, 3543, 197, 4891, 31883, 3786, 4938, 31884, 31886, 3807, 4940, 
31887, 31885, 3808, 219, 4939
12701, 31437, 3543, 197, 4891, 31438, 3553, 198, 4892, 31886, 3807, 4940, 31887, 31889, 3828, 4942, 
31890, 31888, 3829, 220, 4941
12702, 31438, 3553, 198, 4892, 31439, 3563, 199, 4893, 31889, 3828, 4942, 31890, 31892, 3849, 4944, 
31893, 31891, 3850, 221, 4943
12703, 31439, 3563, 199, 4893, 31440, 3573, 200, 4894, 31892, 3849, 4944, 31893, 31895, 3870, 4946, 
31896, 31894, 3871, 222, 4945
12704, 31440, 3573, 200, 4894, 31441, 3583, 201, 4895, 31895, 3870, 4946, 31896, 31898, 3891, 4948, 
31899, 31897, 3892, 223, 4947
12705, 31441, 3583, 201, 4895, 31442, 3593, 202, 4896, 31898, 3891, 4948, 31899, 31901, 3912, 4950, 
31902, 31900, 3913, 224, 4949
12706, 31442, 3593, 202, 4896, 31443, 3603, 203, 4897, 31901, 3912, 4950, 31902, 31904, 3933, 4952, 
31905, 31903, 3934, 225, 4951
12707, 31443, 3603, 203, 4897, 31444, 3613, 204, 4898, 31904, 3933, 4952, 31905, 31907, 3954, 4954, 
31908, 31906, 3955, 226, 4953
12708, 31444, 3613, 204, 4898, 31445, 3623, 205, 4899, 31907, 3954, 4954, 31908, 31910, 3975, 4956, 
31911, 31909, 3976, 227, 4955
12709, 31445, 3623, 205, 4899, 31446, 3633, 206, 4900, 31910, 3975, 4956, 31911, 31913, 3996, 4958, 
31914, 31912, 3997, 228, 4957
12710, 31446, 3633, 206, 4900, 31447, 3643, 207, 4901, 31913, 3996, 4958, 31914, 31916, 4017, 4960, 
31917, 31915, 4018, 229, 4959
12711, 31447, 3643, 207, 4901, 31448, 3653, 208, 4902, 31916, 4017, 4960, 31917, 31919, 4038, 4962, 
31920, 31918, 4039, 230, 4961
12712, 31448, 3653, 208, 4902, 31449, 3663, 209, 4903, 31919, 4038, 4962, 31920, 31922, 4059, 4964, 
31923, 31921, 4060, 231, 4963
12713, 31449, 3663, 209, 4903, 31450, 3673, 210, 4904, 31922, 4059, 4964, 31923, 31925, 4080, 4966, 
31926, 31924, 4081, 232, 4965
12714, 31450, 3673, 210, 4904, 31451, 3683, 211, 4905, 31925, 4080, 4966, 31926, 31928, 4101, 4968, 
31929, 31927, 4102, 233, 4967
12715, 31451, 3683, 211, 4905, 31452, 3693, 212, 4906, 31928, 4101, 4968, 31929, 31931, 4122, 4970, 
31932, 31930, 4123, 234, 4969
12716, 31452, 3693, 212, 4906, 31453, 3703, 213, 4907, 31931, 4122, 4970, 31932, 31934, 4143, 4972, 
31935, 31933, 4144, 235, 4971
12717, 31453, 3703, 213, 4907, 31454, 3713, 214, 4908, 31934, 4143, 4972, 31935, 31937, 4164, 4974, 
31938, 31936, 4165, 236, 4973
12718, 31454, 3713, 214, 4908, 3431, 141, 6, 188, 31937, 4164, 4974, 31938, 3452, 151, 190, 
3451, 31939, 4185, 237, 4975
12719, 3360, 3359, 136, 137, 31455, 31433, 4887, 4909, 3381, 3380, 139, 3382, 31941, 31875, 4977, 
31942, 31940, 31873, 4931, 4976
12720, 31455, 31433, 4887, 4909, 31456, 31434, 4888, 4910, 31941, 31875, 4977, 31942, 31944, 31878, 4979, 
31945, 31943, 31876, 4933, 4978
12721, 31456, 31434, 4888, 4910, 31457, 31435, 4889, 4911, 31944, 31878, 4979, 31945, 31947, 31881, 4981, 
31948, 31946, 31879, 4935, 4980
12722, 31457, 31435, 4889, 4911, 31458, 31436, 4890, 4912, 31947, 31881, 4981, 31948, 31950, 31884, 4983, 
31951, 31949, 31882, 4937, 4982
12723, 31458, 31436, 4890, 4912, 31459, 31437, 4891, 4913, 31950, 31884, 4983, 31951, 31953, 31887, 4985, 
31954, 31952, 31885, 4939, 4984
