95409, 2.0260869565217, -0.05, 0.36363636363636
95410, 2.0260869565217, -0.05, 0.31818181818182
95411, 2.0260869565217, -0.05, 0.27272727272727
95412, 2.0260869565217, -0.05, 0.22727272727273
95413, 2.0260869565217, -0.05, 0.18181818181818
95414, 2.0260869565217, -0.05, 0.13636363636364
95415, 2.0260869565217, -0.05, 0.090909090909091
95416, 2.0260869565217, -0.05, 0.045454545454545
95417, 2.0695652173913, -0.05, 0.45454545454545
95418, 2.0695652173913, -0.05, 0.40909090909091
95419, 2.0695652173913, -0.05, 0.36363636363636
95420, 2.0695652173913, -0.05, 0.31818181818182
95421, 2.0695652173913, -0.05, 0.27272727272727
95422, 2.0695652173913, -0.05, 0.22727272727273
95423, 2.0695652173913, -0.05, 0.18181818181818
95424, 2.0695652173913, -0.05, 0.13636363636364
95425, 2.0695652173913, -0.05, 0.090909090909091
95426, 2.0695652173913, -0.05, 0.045454545454545
95427, 2.1130434782609, -0.05, 0.45454545454545
95428, 2.1130434782609, -0.05, 0.40909090909091
95429, 2.1130434782609, -0.05, 0.36363636363636
95430, 2.1130434782609, -0.05, 0.31818181818182
95431, 2.1130434782609, -0.05, 0.27272727272727
95432, 2.1130434782609, -0.05, 0.22727272727273
95433, 2.1130434782609, -0.05, 0.18181818181818
95434, 2.1130434782609, -0.05, 0.13636363636364
95435, 2.1130434782609, -0.05, 0.090909090909091
95436, 2.1130434782609, -0.05, 0.045454545454545
95437, 2.1565217391304, -0.05, 0.45454545454545
95438, 2.1565217391304, -0.05, 0.40909090909091
95439, 2.1565217391304, -0.05, 0.36363636363636
95440, 2.1565217391304, -0.05, 0.31818181818182
95441, 2.1565217391304, -0.05, 0.27272727272727
95442, 2.1565217391304, -0.05, 0.22727272727273
95443, 2.1565217391304, -0.05, 0.18181818181818
95444, 2.1565217391304, -0.05, 0.13636363636364
95445, 2.1565217391304, -0.05, 0.090909090909091
95446, 2.1565217391304, -0.05, 0.045454545454545
95447, 1.2434782608696, -0.1, 0.45454545454545
95448, 1.2434782608696, -0.1, 0.40909090909091
95449, 1.2434782608696, -0.1, 0.36363636363636
95450, 1.2434782608696, -0.1, 0.31818181818182
95451, 1.2434782608696, -0.1, 0.27272727272727
95452, 1.2434782608696, -0.1, 0.22727272727273
95453, 1.2434782608696, -0.1, 0.18181818181818
95454, 1.2434782608696, -0.1, 0.13636363636364
95455, 1.2434782608696, -0.1, 0.090909090909091
95456, 1.2434782608696, -0.1, 0.045454545454545
95457, 1.2869565217391, -0.1, 0.45454545454545
95458, 1.2869565217391, -0.1, 0.40909090909091
95459, 1.2869565217391, -0.1, 0.36363636363636
95460, 1.2869565217391, -0.1, 0.31818181818182
95461, 1.2869565217391, -0.1, 0.27272727272727
95462, 1.2869565217391, -0.1, 0.22727272727273
95463, 1.2869565217391, -0.1, 0.18181818181818
95464, 1.2869565217391, -0.1, 0.13636363636364
95465, 1.2869565217391, -0.1, 0.090909090909091
95466, 1.2869565217391, -0.1, 0.045454545454545
95467, 1.3304347826087, -0.1, 0.45454545454545
95468, 1.3304347826087, -0.1, 0.40909090909091
95469, 1.3304347826087, -0.1, 0.36363636363636
95470, 1.3304347826087, -0.1, 0.31818181818182
95471, 1.3304347826087, -0.1, 0.27272727272727
95472, 1.3304347826087, -0.1, 0.22727272727273
95473, 1.3304347826087, -0.1, 0.18181818181818
95474, 1.3304347826087, -0.1, 0.13636363636364
95475, 1.3304347826087, -0.1, 0.090909090909091
95476, 1.3304347826087, -0.1, 0.045454545454545
95477, 1.3739130434783, -0.1, 0.45454545454545
95478, 1.3739130434783, -0.1, 0.40909090909091
95479, 1.3739130434783, -0.1, 0.36363636363636
95480, 1.3739130434783, -0.1, 0.31818181818182
95481, 1.3739130434783, -0.1, 0.27272727272727
95482, 1.3739130434783, -0.1, 0.22727272727273
95483, 1.3739130434783, -0.1, 0.18181818181818
95484, 1.3739130434783, -0.1, 0.13636363636364
95485, 1.3739130434783, -0.1, 0.090909090909091
95486, 1.3739130434783, -0.1, 0.045454545454545
95487, 1.4173913043478, -0.1, 0.45454545454545
95488, 1.4173913043478, -0.1, 0.40909090909091
95489, 1.4173913043478, -0.1, 0.36363636363636
95490, 1.4173913043478, -0.1, 0.31818181818182
95491, 1.4173913043478, -0.1, 0.27272727272727
95492, 1.4173913043478, -0.1, 0.22727272727273
95493, 1.4173913043478, -0.1, 0.18181818181818
95494, 1.4173913043478, -0.1, 0.13636363636364
95495, 1.4173913043478, -0.1, 0.090909090909091
95496, 1.4173913043478, -0.1, 0.045454545454545
95497, 1.4608695652174, -0.1, 0.45454545454545
95498, 1.4608695652174, -0.1, 0.40909090909091
95499, 1.4608695652174, -0.1, 0.36363636363636
95500, 1.4608695652174, -0.1, 0.31818181818182
95501, 1.4608695652174, -0.1, 0.27272727272727
95502, 1.4608695652174, -0.1, 0.22727272727273
95503, 1.4608695652174, -0.1, 0.18181818181818
95504, 1.4608695652174, -0.1, 0.13636363636364
95505, 1.4608695652174, -0.1, 0.090909090909091
95506, 1.4608695652174, -0.1, 0.045454545454545
95507, 1.504347826087, -0.1, 0.45454545454545
95508, 1.504347826087, -0.1, 0.40909090909091
95509, 1.504347826087, -0.1, 0.36363636363636
95510, 1.504347826087, -0.1, 0.31818181818182
95511, 1.504347826087, -0.1, 0.27272727272727
95512, 1.504347826087, -0.1, 0.22727272727273
95513, 1.504347826087, -0.1, 0.18181818181818
95514, 1.504347826087, -0.1, 0.13636363636364
95515, 1.504347826087, -0.1, 0.090909090909091
95516, 1.504347826087, -0.1, 0.045454545454545
95517, 1.5478260869565, -0.1, 0.45454545454545
95518, 1.5478260869565, -0.1, 0.40909090909091
95519, 1.5478260869565, -0.1, 0.36363636363636
95520, 1.5478260869565, -0.1, 0.31818181818182
95521, 1.5478260869565, -0.1, 0.27272727272727
95522, 1.5478260869565, -0.1, 0.22727272727273
95523, 1.5478260869565, -0.1, 0.18181818181818
95524, 1.5478260869565, -0.1, 0.13636363636364
95525, 1.5478260869565, -0.1, 0.090909090909091
95526, 1.5478260869565, -0.1, 0.045454545454545
95527, 1.5913043478261, -0.1, 0.45454545454545
95528, 1.5913043478261, -0.1, 0.40909090909091
95529, 1.5913043478261, -0.1, 0.36363636363636
95530, 1.5913043478261, -0.1, 0.31818181818182
95531, 1.5913043478261, -0.1, 0.27272727272727
95532, 1.5913043478261, -0.1, 0.22727272727273
95533, 1.5913043478261, -0.1, 0.18181818181818
95534, 1.5913043478261, -0.1, 0.13636363636364
95535, 1.5913043478261, -0.1, 0.090909090909091
95536, 1.5913043478261, -0.1, 0.045454545454545
95537, 1.6347826086957, -0.1, 0.45454545454545
95538, 1.6347826086957, -0.1, 0.40909090909091
95539, 1.6347826086957, -0.1, 0.36363636363636
95540, 1.6347826086957, -0.1, 0.31818181818182
95541, 1.6347826086957, -0.1, 0.27272727272727
95542, 1.6347826086957, -0.1, 0.22727272727273
95543, 1.6347826086957, -0.1, 0.18181818181818
95544, 1.6347826086957, -0.1, 0.13636363636364
95545, 1.6347826086957, -0.1, 0.090909090909091
95546, 1.6347826086957, -0.1, 0.045454545454545
95547, 1.6782608695652, -0.1, 0.45454545454545
95548, 1.6782608695652, -0.1, 0.40909090909091
95549, 1.6782608695652, -0.1, 0.36363636363636
95550, 1.6782608695652, -0.1, 0.31818181818182
95551, 1.6782608695652, -0.1, 0.27272727272727
95552, 1.6782608695652, -0.1, 0.22727272727273
95553, 1.6782608695652, -0.1, 0.18181818181818
95554, 1.6782608695652, -0.1, 0.13636363636364
95555, 1.6782608695652, -0.1, 0.090909090909091
95556, 1.6782608695652, -0.1, 0.045454545454545
95557, 1.7217391304348, -0.1, 0.45454545454545
95558, 1.7217391304348, -0.1, 0.40909090909091
95559, 1.7217391304348, -0.1, 0.36363636363636
95560, 1.7217391304348, -0.1, 0.31818181818182
95561, 1.7217391304348, -0.1, 0.27272727272727
95562, 1.7217391304348, -0.1, 0.22727272727273
95563, 1.7217391304348, -0.1, 0.18181818181818
95564, 1.7217391304348, -0.1, 0.13636363636364
95565, 1.7217391304348, -0.1, 0.090909090909091
95566, 1.7217391304348, -0.1, 0.045454545454545
95567, 1.7652173913043, -0.1, 0.45454545454545
95568, 1.7652173913043, -0.1, 0.40909090909091
95569, 1.7652173913043, -0.1, 0.36363636363636
95570, 1.7652173913043, -0.1, 0.31818181818182
95571, 1.7652173913043, -0.1, 0.27272727272727
95572, 1.7652173913043, -0.1, 0.22727272727273
95573, 1.7652173913043, -0.1, 0.18181818181818
95574, 1.7652173913043, -0.1, 0.13636363636364
95575, 1.7652173913043, -0.1, 0.090909090909091
95576, 1.7652173913043, -0.1, 0.045454545454545
95577, 1.8086956521739, -0.1, 0.45454545454545
95578, 1.8086956521739, -0.1, 0.40909090909091
95579, 1.8086956521739, -0.1, 0.36363636363636
95580, 1.8086956521739, -0.1, 0.31818181818182
95581, 1.8086956521739, -0.1, 0.27272727272727
95582, 1.8086956521739, -0.1, 0.22727272727273
95583, 1.8086956521739, -0.1, 0.18181818181818
95584, 1.8086956521739, -0.1, 0.13636363636364
95585, 1.8086956521739, -0.1, 0.090909090909091
95586, 1.8086956521739, -0.1, 0.045454545454545
95587, 1.8521739130435, -0.1, 0.45454545454545
95588, 1.8521739130435, -0.1, 0.40909090909091
95589, 1.8521739130435, -0.1, 0.36363636363636
95590, 1.8521739130435, -0.1, 0.31818181818182
95591, 1.8521739130435, -0.1, 0.27272727272727
95592, 1.8521739130435, -0.1, 0.22727272727273
95593, 1.8521739130435, -0.1, 0.18181818181818
95594, 1.8521739130435, -0.1, 0.13636363636364
95595, 1.8521739130435, -0.1, 0.090909090909091
95596, 1.8521739130435, -0.1, 0.045454545454545
95597, 1.895652173913, -0.1, 0.45454545454545
95598, 1.895652173913, -0.1, 0.40909090909091
95599, 1.895652173913, -0.1, 0.36363636363636
95600, 1.895652173913, -0.1, 0.31818181818182
95601, 1.895652173913, -0.1, 0.27272727272727
95602, 1.895652173913, -0.1, 0.22727272727273
95603, 1.895652173913, -0.1, 0.18181818181818
95604, 1.895652173913, -0.1, 0.13636363636364
95605, 1.895652173913, -0.1, 0.090909090909091
95606, 1.895652173913, -0.1, 0.045454545454545
95607, 1.9391304347826, -0.1, 0.45454545454545
95608, 1.9391304347826, -0.1, 0.40909090909091
95609, 1.9391304347826, -0.1, 0.36363636363636
95610, 1.9391304347826, -0.1, 0.31818181818182
95611, 1.9391304347826, -0.1, 0.27272727272727
95612, 1.9391304347826, -0.1, 0.22727272727273
95613, 1.9391304347826, -0.1, 0.18181818181818
95614, 1.9391304347826, -0.1, 0.13636363636364
95615, 1.9391304347826, -0.1, 0.090909090909091
95616, 1.9391304347826, -0.1, 0.045454545454545
95617, 1.9826086956522, -0.1, 0.45454545454545
95618, 1.9826086956522, -0.1, 0.40909090909091
95619, 1.9826086956522, -0.1, 0.36363636363636
95620, 1.9826086956522, -0.1, 0.31818181818182
95621, 1.9826086956522, -0.1, 0.27272727272727
95622, 1.9826086956522, -0.1, 0.22727272727273
95623, 1.9826086956522, -0.1, 0.18181818181818
95624, 1.9826086956522, -0.1, 0.13636363636364
95625, 1.9826086956522, -0.1, 0.090909090909091
95626, 1.9826086956522, -0.1, 0.045454545454545
95627, 2.0260869565217, -0.1, 0.45454545454545
95628, 2.0260869565217, -0.1, 0.40909090909091
95629, 2.0260869565217, -0.1, 0.36363636363636
95630, 2.0260869565217, -0.1, 0.31818181818182
95631, 2.0260869565217, -0.1, 0.27272727272727
95632, 2.0260869565217, -0.1, 0.22727272727273
95633, 2.0260869565217, -0.1, 0.18181818181818
95634, 2.0260869565217, -0.1, 0.13636363636364
95635, 2.0260869565217, -0.1, 0.090909090909091
95636, 2.0260869565217, -0.1, 0.045454545454545
95637, 2.0695652173913, -0.1, 0.45454545454545
95638, 2.0695652173913, -0.1, 0.40909090909091
95639, 2.0695652173913, -0.1, 0.36363636363636
95640, 2.0695652173913, -0.1, 0.31818181818182
95641, 2.0695652173913, -0.1, 0.27272727272727
95642, 2.0695652173913, -0.1, 0.22727272727273
95643, 2.0695652173913, -0.1, 0.18181818181818
95644, 2.0695652173913, -0.1, 0.13636363636364
95645, 2.0695652173913, -0.1, 0.090909090909091
95646, 2.0695652173913, -0.1, 0.045454545454545
95647, 2.1130434782609, -0.1, 0.45454545454545
95648, 2.1130434782609, -0.1, 0.40909090909091
95649, 2.1130434782609, -0.1, 0.36363636363636
95650, 2.1130434782609, -0.1, 0.31818181818182
95651, 2.1130434782609, -0.1, 0.27272727272727
95652, 2.1130434782609, -0.1, 0.22727272727273
95653, 2.1130434782609, -0.1, 0.18181818181818
95654, 2.1130434782609, -0.1, 0.13636363636364
95655, 2.1130434782609, -0.1, 0.090909090909091
95656, 2.1130434782609, -0.1, 0.045454545454545
95657, 2.1565217391304, -0.1, 0.45454545454545
95658, 2.1565217391304, -0.1, 0.40909090909091
95659, 2.1565217391304, -0.1, 0.36363636363636
95660, 2.1565217391304, -0.1, 0.31818181818182
95661, 2.1565217391304, -0.1, 0.27272727272727
95662, 2.1565217391304, -0.1, 0.22727272727273
95663, 2.1565217391304, -0.1, 0.18181818181818
95664, 2.1565217391304, -0.1, 0.13636363636364
95665, 2.1565217391304, -0.1, 0.090909090909091
95666, 2.1565217391304, -0.1, 0.045454545454545
95667, 1.2434782608696, -0.15, 0.45454545454545
95668, 1.2434782608696, -0.15, 0.40909090909091
95669, 1.2434782608696, -0.15, 0.36363636363636
95670, 1.2434782608696, -0.15, 0.31818181818182
95671, 1.2434782608696, -0.15, 0.27272727272727
95672, 1.2434782608696, -0.15, 0.22727272727273
95673, 1.2434782608696, -0.15, 0.18181818181818
95674, 1.2434782608696, -0.15, 0.13636363636364
95675, 1.2434782608696, -0.15, 0.090909090909091
95676, 1.2434782608696, -0.15, 0.045454545454545
95677, 1.2869565217391, -0.15, 0.45454545454545
95678, 1.2869565217391, -0.15, 0.40909090909091
95679, 1.2869565217391, -0.15, 0.36363636363636
95680, 1.2869565217391, -0.15, 0.31818181818182
95681, 1.2869565217391, -0.15, 0.27272727272727
95682, 1.2869565217391, -0.15, 0.22727272727273
95683, 1.2869565217391, -0.15, 0.18181818181818
95684, 1.2869565217391, -0.15, 0.13636363636364
95685, 1.2869565217391, -0.15, 0.090909090909091
95686, 1.2869565217391, -0.15, 0.045454545454545
95687, 1.3304347826087, -0.15, 0.45454545454545
95688, 1.3304347826087, -0.15, 0.40909090909091
95689, 1.3304347826087, -0.15, 0.36363636363636
95690, 1.3304347826087, -0.15, 0.31818181818182
95691, 1.3304347826087, -0.15, 0.27272727272727
95692, 1.3304347826087, -0.15, 0.22727272727273
95693, 1.3304347826087, -0.15, 0.18181818181818
95694, 1.3304347826087, -0.15, 0.13636363636364
95695, 1.3304347826087, -0.15, 0.090909090909091
95696, 1.3304347826087, -0.15, 0.045454545454545
95697, 1.3739130434783, -0.15, 0.45454545454545
95698, 1.3739130434783, -0.15, 0.40909090909091
95699, 1.3739130434783, -0.15, 0.36363636363636
95700, 1.3739130434783, -0.15, 0.31818181818182
95701, 1.3739130434783, -0.15, 0.27272727272727
95702, 1.3739130434783, -0.15, 0.22727272727273
95703, 1.3739130434783, -0.15, 0.18181818181818
95704, 1.3739130434783, -0.15, 0.13636363636364
95705, 1.3739130434783, -0.15, 0.090909090909091
95706, 1.3739130434783, -0.15, 0.045454545454545
95707, 1.4173913043478, -0.15, 0.45454545454545
95708, 1.4173913043478, -0.15, 0.40909090909091
95709, 1.4173913043478, -0.15, 0.36363636363636
95710, 1.4173913043478, -0.15, 0.31818181818182
95711, 1.4173913043478, -0.15, 0.27272727272727
95712, 1.4173913043478, -0.15, 0.22727272727273
95713, 1.4173913043478, -0.15, 0.18181818181818
95714, 1.4173913043478, -0.15, 0.13636363636364
95715, 1.4173913043478, -0.15, 0.090909090909091
95716, 1.4173913043478, -0.15, 0.045454545454545
95717, 1.4608695652174, -0.15, 0.45454545454545
95718, 1.4608695652174, -0.15, 0.40909090909091
95719, 1.4608695652174, -0.15, 0.36363636363636
95720, 1.4608695652174, -0.15, 0.31818181818182
95721, 1.4608695652174, -0.15, 0.27272727272727
95722, 1.4608695652174, -0.15, 0.22727272727273
95723, 1.4608695652174, -0.15, 0.18181818181818
95724, 1.4608695652174, -0.15, 0.13636363636364
95725, 1.4608695652174, -0.15, 0.090909090909091
95726, 1.4608695652174, -0.15, 0.045454545454545
95727, 1.504347826087, -0.15, 0.45454545454545
95728, 1.504347826087, -0.15, 0.40909090909091
95729, 1.504347826087, -0.15, 0.36363636363636
95730, 1.504347826087, -0.15, 0.31818181818182
95731, 1.504347826087, -0.15, 0.27272727272727
95732, 1.504347826087, -0.15, 0.22727272727273
95733, 1.504347826087, -0.15, 0.18181818181818
95734, 1.504347826087, -0.15, 0.13636363636364
95735, 1.504347826087, -0.15, 0.090909090909091
95736, 1.504347826087, -0.15, 0.045454545454545
95737, 1.5478260869565, -0.15, 0.45454545454545
95738, 1.5478260869565, -0.15, 0.40909090909091
95739, 1.5478260869565, -0.15, 0.36363636363636
95740, 1.5478260869565, -0.15, 0.31818181818182
95741, 1.5478260869565, -0.15, 0.27272727272727
95742, 1.5478260869565, -0.15, 0.22727272727273
95743, 1.5478260869565, -0.15, 0.18181818181818
95744, 1.5478260869565, -0.15, 0.13636363636364
95745, 1.5478260869565, -0.15, 0.090909090909091
95746, 1.5478260869565, -0.15, 0.045454545454545
95747, 1.5913043478261, -0.15, 0.45454545454545
95748, 1.5913043478261, -0.15, 0.40909090909091
95749, 1.5913043478261, -0.15, 0.36363636363636
95750, 1.5913043478261, -0.15, 0.31818181818182
95751, 1.5913043478261, -0.15, 0.27272727272727
95752, 1.5913043478261, -0.15, 0.22727272727273
95753, 1.5913043478261, -0.15, 0.18181818181818
95754, 1.5913043478261, -0.15, 0.13636363636364
95755, 1.5913043478261, -0.15, 0.090909090909091
95756, 1.5913043478261, -0.15, 0.045454545454545
95757, 1.6347826086957, -0.15, 0.45454545454545
95758, 1.6347826086957, -0.15, 0.40909090909091
95759, 1.6347826086957, -0.15, 0.36363636363636
95760, 1.6347826086957, -0.15, 0.31818181818182
95761, 1.6347826086957, -0.15, 0.27272727272727
95762, 1.6347826086957, -0.15, 0.22727272727273
95763, 1.6347826086957, -0.15, 0.18181818181818
95764, 1.6347826086957, -0.15, 0.13636363636364
95765, 1.6347826086957, -0.15, 0.090909090909091
95766, 1.6347826086957, -0.15, 0.045454545454545
95767, 1.6782608695652, -0.15, 0.45454545454545
95768, 1.6782608695652, -0.15, 0.40909090909091
95769, 1.6782608695652, -0.15, 0.36363636363636
95770, 1.6782608695652, -0.15, 0.31818181818182
95771, 1.6782608695652, -0.15, 0.27272727272727
95772, 1.6782608695652, -0.15, 0.22727272727273
95773, 1.6782608695652, -0.15, 0.18181818181818
95774, 1.6782608695652, -0.15, 0.13636363636364
95775, 1.6782608695652, -0.15, 0.090909090909091
95776, 1.6782608695652, -0.15, 0.045454545454545
95777, 1.7217391304348, -0.15, 0.45454545454545
95778, 1.7217391304348, -0.15, 0.40909090909091
95779, 1.7217391304348, -0.15, 0.36363636363636
95780, 1.7217391304348, -0.15, 0.31818181818182
95781, 1.7217391304348, -0.15, 0.27272727272727
95782, 1.7217391304348, -0.15, 0.22727272727273
95783, 1.7217391304348, -0.15, 0.18181818181818
95784, 1.7217391304348, -0.15, 0.13636363636364
95785, 1.7217391304348, -0.15, 0.090909090909091
95786, 1.7217391304348, -0.15, 0.045454545454545
95787, 1.7652173913043, -0.15, 0.45454545454545
95788, 1.7652173913043, -0.15, 0.40909090909091
95789, 1.7652173913043, -0.15, 0.36363636363636
95790, 1.7652173913043, -0.15, 0.31818181818182
95791, 1.7652173913043, -0.15, 0.27272727272727
95792, 1.7652173913043, -0.15, 0.22727272727273
95793, 1.7652173913043, -0.15, 0.18181818181818
95794, 1.7652173913043, -0.15, 0.13636363636364
95795, 1.7652173913043, -0.15, 0.090909090909091
95796, 1.7652173913043, -0.15, 0.045454545454545
95797, 1.8086956521739, -0.15, 0.45454545454545
95798, 1.8086956521739, -0.15, 0.40909090909091
95799, 1.8086956521739, -0.15, 0.36363636363636
95800, 1.8086956521739, -0.15, 0.31818181818182
95801, 1.8086956521739, -0.15, 0.27272727272727
95802, 1.8086956521739, -0.15, 0.22727272727273
95803, 1.8086956521739, -0.15, 0.18181818181818
95804, 1.8086956521739, -0.15, 0.13636363636364
95805, 1.8086956521739, -0.15, 0.090909090909091
95806, 1.8086956521739, -0.15, 0.045454545454545
95807, 1.8521739130435, -0.15, 0.45454545454545
95808, 1.8521739130435, -0.15, 0.40909090909091
95809, 1.8521739130435, -0.15, 0.36363636363636
95810, 1.8521739130435, -0.15, 0.31818181818182
95811, 1.8521739130435, -0.15, 0.27272727272727
95812, 1.8521739130435, -0.15, 0.22727272727273
95813, 1.8521739130435, -0.15, 0.18181818181818
95814, 1.8521739130435, -0.15, 0.13636363636364
95815, 1.8521739130435, -0.15, 0.090909090909091
95816, 1.8521739130435, -0.15, 0.045454545454545
95817, 1.895652173913, -0.15, 0.45454545454545
95818, 1.895652173913, -0.15, 0.40909090909091
95819, 1.895652173913, -0.15, 0.36363636363636
95820, 1.895652173913, -0.15, 0.31818181818182
95821, 1.895652173913, -0.15, 0.27272727272727
95822, 1.895652173913, -0.15, 0.22727272727273
95823, 1.895652173913, -0.15, 0.18181818181818
95824, 1.895652173913, -0.15, 0.13636363636364
95825, 1.895652173913, -0.15, 0.090909090909091
95826, 1.895652173913, -0.15, 0.045454545454545
95827, 1.9391304347826, -0.15, 0.45454545454545
95828, 1.9391304347826, -0.15, 0.40909090909091
95829, 1.9391304347826, -0.15, 0.36363636363636
95830, 1.9391304347826, -0.15, 0.31818181818182
95831, 1.9391304347826, -0.15, 0.27272727272727
95832, 1.9391304347826, -0.15, 0.22727272727273
95833, 1.9391304347826, -0.15, 0.18181818181818
95834, 1.9391304347826, -0.15, 0.13636363636364
95835, 1.9391304347826, -0.15, 0.090909090909091
95836, 1.9391304347826, -0.15, 0.045454545454545
95837, 1.9826086956522, -0.15, 0.45454545454545
95838, 1.9826086956522, -0.15, 0.40909090909091
95839, 1.9826086956522, -0.15, 0.36363636363636
95840, 1.9826086956522, -0.15, 0.31818181818182
95841, 1.9826086956522, -0.15, 0.27272727272727
95842, 1.9826086956522, -0.15, 0.22727272727273
95843, 1.9826086956522, -0.15, 0.18181818181818
95844, 1.9826086956522, -0.15, 0.13636363636364
95845, 1.9826086956522, -0.15, 0.090909090909091
95846, 1.9826086956522, -0.15, 0.045454545454545
95847, 2.0260869565217, -0.15, 0.45454545454545
95848, 2.0260869565217, -0.15, 0.40909090909091
95849, 2.0260869565217, -0.15, 0.36363636363636
95850, 2.0260869565217, -0.15, 0.31818181818182
95851, 2.0260869565217, -0.15, 0.27272727272727
95852, 2.0260869565217, -0.15, 0.22727272727273
95853, 2.0260869565217, -0.15, 0.18181818181818
95854, 2.0260869565217, -0.15, 0.13636363636364
95855, 2.0260869565217, -0.15, 0.090909090909091
95856, 2.0260869565217, -0.15, 0.045454545454545
95857, 2.0695652173913, -0.15, 0.45454545454545
95858, 2.0695652173913, -0.15, 0.40909090909091
95859, 2.0695652173913, -0.15, 0.36363636363636
95860, 2.0695652173913, -0.15, 0.31818181818182
95861, 2.0695652173913, -0.15, 0.27272727272727
95862, 2.0695652173913, -0.15, 0.22727272727273
95863, 2.0695652173913, -0.15, 0.18181818181818
95864, 2.0695652173913, -0.15, 0.13636363636364
95865, 2.0695652173913, -0.15, 0.090909090909091
95866, 2.0695652173913, -0.15, 0.045454545454545
95867, 2.1130434782609, -0.15, 0.45454545454545
95868, 2.1130434782609, -0.15, 0.40909090909091
95869, 2.1130434782609, -0.15, 0.36363636363636
95870, 2.1130434782609, -0.15, 0.31818181818182
95871, 2.1130434782609, -0.15, 0.27272727272727
95872, 2.1130434782609, -0.15, 0.22727272727273
95873, 2.1130434782609, -0.15, 0.18181818181818
95874, 2.1130434782609, -0.15, 0.13636363636364
95875, 2.1130434782609, -0.15, 0.090909090909091
95876, 2.1130434782609, -0.15, 0.045454545454545
95877, 2.1565217391304, -0.15, 0.45454545454545
95878, 2.1565217391304, -0.15, 0.40909090909091
95879, 2.1565217391304, -0.15, 0.36363636363636
95880, 2.1565217391304, -0.15, 0.31818181818182
95881, 2.1565217391304, -0.15, 0.27272727272727
95882, 2.1565217391304, -0.15, 0.22727272727273
95883, 2.1565217391304, -0.15, 0.18181818181818
95884, 2.1565217391304, -0.15, 0.13636363636364
95885, 2.1565217391304, -0.15, 0.090909090909091
95886, 2.1565217391304, -0.15, 0.045454545454545
95887, 1.2434782608696, -0.05, 0.47727272727273
95888, 1.2217391304348, -0.05, 0.45454545454545
95889, 1.2434782608696, -0.025, 0.45454545454545
95890, 1.2434782608696, -0.05, 0.43181818181818
95891, 1.2217391304348, -0.05, 0.40909090909091
95892, 1.2434782608696, -0.025, 0.40909090909091
95893, 1.2434782608696, -0.05, 0.38636363636364
95894, 1.2217391304348, -0.05, 0.36363636363636
95895, 1.2434782608696, -0.025, 0.36363636363636
95896, 1.2434782608696, -0.05, 0.34090909090909
95897, 1.2217391304348, -0.05, 0.31818181818182
95898, 1.2434782608696, -0.025, 0.31818181818182
95899, 1.2434782608696, -0.05, 0.29545454545455
95900, 1.2217391304348, -0.05, 0.27272727272727
95901, 1.2434782608696, -0.025, 0.27272727272727
95902, 1.2434782608696, -0.05, 0.25
95903, 1.2217391304348, -0.05, 0.22727272727273
95904, 1.2434782608696, -0.025, 0.22727272727273
95905, 1.2434782608696, -0.05, 0.20454545454545
95906, 1.2217391304348, -0.05, 0.18181818181818
95907, 1.2434782608696, -0.025, 0.18181818181818
95908, 1.2434782608696, -0.05, 0.15909090909091
95909, 1.2217391304348, -0.05, 0.13636363636364
95910, 1.2434782608696, -0.025, 0.13636363636364
95911, 1.2434782608696, -0.05, 0.11363636363636
95912, 1.2217391304348, -0.05, 0.090909090909091
95913, 1.2434782608696, -0.025, 0.090909090909091
95914, 1.2434782608696, -0.05, 0.068181818181818
95915, 1.2217391304348, -0.05, 0.045454545454545
95916, 1.2434782608696, -0.025, 0.045454545454545
95917, 1.2434782608696, -0.05, 0.022727272727273
95918, 1.2869565217391, -0.05, 0.47727272727273
95919, 1.2652173913043, -0.05, 0.45454545454545
95920, 1.2869565217391, -0.025, 0.45454545454545
95921, 1.2869565217391, -0.05, 0.43181818181818
95922, 1.2652173913043, -0.05, 0.40909090909091
95923, 1.2869565217391, -0.025, 0.40909090909091
95924, 1.2869565217391, -0.05, 0.38636363636364
95925, 1.2652173913043, -0.05, 0.36363636363636
95926, 1.2869565217391, -0.025, 0.36363636363636
95927, 1.2869565217391, -0.05, 0.34090909090909
95928, 1.2652173913043, -0.05, 0.31818181818182
95929, 1.2869565217391, -0.025, 0.31818181818182
95930, 1.2869565217391, -0.05, 0.29545454545455
95931, 1.2652173913043, -0.05, 0.27272727272727
95932, 1.2869565217391, -0.025, 0.27272727272727
95933, 1.2869565217391, -0.05, 0.25
95934, 1.2652173913043, -0.05, 0.22727272727273
95935, 1.2869565217391, -0.025, 0.22727272727273
95936, 1.2869565217391, -0.05, 0.20454545454545
95937, 1.2652173913043, -0.05, 0.18181818181818
95938, 1.2869565217391, -0.025, 0.18181818181818
95939, 1.2869565217391, -0.05, 0.15909090909091
95940, 1.2652173913043, -0.05, 0.13636363636364
95941, 1.2869565217391, -0.025, 0.13636363636364
95942, 1.2869565217391, -0.05, 0.11363636363636
95943, 1.2652173913043, -0.05, 0.090909090909091
95944, 1.2869565217391, -0.025, 0.090909090909091
95945, 1.2869565217391, -0.05, 0.068181818181818
95946, 1.2652173913043, -0.05, 0.045454545454545
95947, 1.2869565217391, -0.025, 0.045454545454545
95948, 1.2869565217391, -0.05, 0.022727272727273
95949, 1.3304347826087, -0.05, 0.47727272727273
95950, 1.3086956521739, -0.05, 0.45454545454545
95951, 1.3304347826087, -0.025, 0.45454545454545
95952, 1.3304347826087, -0.05, 0.43181818181818
95953, 1.3086956521739, -0.05, 0.40909090909091
95954, 1.3304347826087, -0.025, 0.40909090909091
95955, 1.3304347826087, -0.05, 0.38636363636364
95956, 1.3086956521739, -0.05, 0.36363636363636
95957, 1.3304347826087, -0.025, 0.36363636363636
95958, 1.3304347826087, -0.05, 0.34090909090909
95959, 1.3086956521739, -0.05, 0.31818181818182
95960, 1.3304347826087, -0.025, 0.31818181818182
95961, 1.3304347826087, -0.05, 0.29545454545455
95962, 1.3086956521739, -0.05, 0.27272727272727
95963, 1.3304347826087, -0.025, 0.27272727272727
95964, 1.3304347826087, -0.05, 0.25
95965, 1.3086956521739, -0.05, 0.22727272727273
95966, 1.3304347826087, -0.025, 0.22727272727273
95967, 1.3304347826087, -0.05, 0.20454545454545
95968, 1.3086956521739, -0.05, 0.18181818181818
95969, 1.3304347826087, -0.025, 0.18181818181818
95970, 1.3304347826087, -0.05, 0.15909090909091
95971, 1.3086956521739, -0.05, 0.13636363636364
95972, 1.3304347826087, -0.025, 0.13636363636364
95973, 1.3304347826087, -0.05, 0.11363636363636
95974, 1.3086956521739, -0.05, 0.090909090909091
95975, 1.3304347826087, -0.025, 0.090909090909091
95976, 1.3304347826087, -0.05, 0.068181818181818
95977, 1.3086956521739, -0.05, 0.045454545454545
95978, 1.3304347826087, -0.025, 0.045454545454545
95979, 1.3304347826087, -0.05, 0.022727272727273
95980, 1.3739130434783, -0.05, 0.47727272727273
95981, 1.3521739130435, -0.05, 0.45454545454545
95982, 1.3739130434783, -0.025, 0.45454545454545
95983, 1.3739130434783, -0.05, 0.43181818181818
95984, 1.3521739130435, -0.05, 0.40909090909091
95985, 1.3739130434783, -0.025, 0.40909090909091
95986, 1.3739130434783, -0.05, 0.38636363636364
95987, 1.3521739130435, -0.05, 0.36363636363636
95988, 1.3739130434783, -0.025, 0.36363636363636
95989, 1.3739130434783, -0.05, 0.34090909090909
95990, 1.3521739130435, -0.05, 0.31818181818182
95991, 1.3739130434783, -0.025, 0.31818181818182
95992, 1.3739130434783, -0.05, 0.29545454545455
95993, 1.3521739130435, -0.05, 0.27272727272727
95994, 1.3739130434783, -0.025, 0.27272727272727
95995, 1.3739130434783, -0.05, 0.25
95996, 1.3521739130435, -0.05, 0.22727272727273
95997, 1.3739130434783, -0.025, 0.22727272727273
95998, 1.3739130434783, -0.05, 0.20454545454545
95999, 1.3521739130435, -0.05, 0.18181818181818
96000, 1.3739130434783, -0.025, 0.18181818181818
96001, 1.3739130434783, -0.05, 0.15909090909091
96002, 1.3521739130435, -0.05, 0.13636363636364
96003, 1.3739130434783, -0.025, 0.13636363636364
96004, 1.3739130434783, -0.05, 0.11363636363636
96005, 1.3521739130435, -0.05, 0.090909090909091
96006, 1.3739130434783, -0.025, 0.090909090909091
96007, 1.3739130434783, -0.05, 0.068181818181818
96008, 1.3521739130435, -0.05, 0.045454545454545
96009, 1.3739130434783, -0.025, 0.045454545454545
96010, 1.3739130434783, -0.05, 0.022727272727273
96011, 1.4173913043478, -0.05, 0.47727272727273
96012, 1.395652173913, -0.05, 0.45454545454545
96013, 1.4173913043478, -0.025, 0.45454545454545
96014, 1.4173913043478, -0.05, 0.43181818181818
96015, 1.395652173913, -0.05, 0.40909090909091
96016, 1.4173913043478, -0.025, 0.40909090909091
96017, 1.4173913043478, -0.05, 0.38636363636364
96018, 1.395652173913, -0.05, 0.36363636363636
96019, 1.4173913043478, -0.025, 0.36363636363636
96020, 1.4173913043478, -0.05, 0.34090909090909
96021, 1.395652173913, -0.05, 0.31818181818182
96022, 1.4173913043478, -0.025, 0.31818181818182
96023, 1.4173913043478, -0.05, 0.29545454545455
96024, 1.395652173913, -0.05, 0.27272727272727
96025, 1.4173913043478, -0.025, 0.27272727272727
96026, 1.4173913043478, -0.05, 0.25
96027, 1.395652173913, -0.05, 0.22727272727273
96028, 1.4173913043478, -0.025, 0.22727272727273
96029, 1.4173913043478, -0.05, 0.20454545454545
96030, 1.395652173913, -0.05, 0.18181818181818
96031, 1.4173913043478, -0.025, 0.18181818181818
96032, 1.4173913043478, -0.05, 0.15909090909091
96033, 1.395652173913, -0.05, 0.13636363636364
96034, 1.4173913043478, -0.025, 0.13636363636364
96035, 1.4173913043478, -0.05, 0.11363636363636
96036, 1.395652173913, -0.05, 0.090909090909091
96037, 1.4173913043478, -0.025, 0.090909090909091
96038, 1.4173913043478, -0.05, 0.068181818181818
96039, 1.395652173913, -0.05, 0.045454545454545
96040, 1.4173913043478, -0.025, 0.045454545454545
96041, 1.4173913043478, -0.05, 0.022727272727273
96042, 1.4608695652174, -0.05, 0.47727272727273
96043, 1.4391304347826, -0.05, 0.45454545454545
96044, 1.4608695652174, -0.025, 0.45454545454545
96045, 1.4608695652174, -0.05, 0.43181818181818
96046, 1.4391304347826, -0.05, 0.40909090909091
96047, 1.4608695652174, -0.025, 0.40909090909091
96048, 1.4608695652174, -0.05, 0.38636363636364
96049, 1.4391304347826, -0.05, 0.36363636363636
96050, 1.4608695652174, -0.025, 0.36363636363636
96051, 1.4608695652174, -0.05, 0.34090909090909
96052, 1.4391304347826, -0.05, 0.31818181818182
96053, 1.4608695652174, -0.025, 0.31818181818182
96054, 1.4608695652174, -0.05, 0.29545454545455
96055, 1.4391304347826, -0.05, 0.27272727272727
96056, 1.4608695652174, -0.025, 0.27272727272727
96057, 1.4608695652174, -0.05, 0.25
96058, 1.4391304347826, -0.05, 0.22727272727273
96059, 1.4608695652174, -0.025, 0.22727272727273
96060, 1.4608695652174, -0.05, 0.20454545454545
96061, 1.4391304347826, -0.05, 0.18181818181818
96062, 1.4608695652174, -0.025, 0.18181818181818
96063, 1.4608695652174, -0.05, 0.15909090909091
96064, 1.4391304347826, -0.05, 0.13636363636364
96065, 1.4608695652174, -0.025, 0.13636363636364
96066, 1.4608695652174, -0.05, 0.11363636363636
96067, 1.4391304347826, -0.05, 0.090909090909091
96068, 1.4608695652174, -0.025, 0.090909090909091
96069, 1.4608695652174, -0.05, 0.068181818181818
96070, 1.4391304347826, -0.05, 0.045454545454545
96071, 1.4608695652174, -0.025, 0.045454545454545
96072, 1.4608695652174, -0.05, 0.022727272727273
96073, 1.504347826087, -0.05, 0.47727272727273
96074, 1.4826086956522, -0.05, 0.45454545454545
96075, 1.504347826087, -0.025, 0.45454545454545
96076, 1.504347826087, -0.05, 0.43181818181818
96077, 1.4826086956522, -0.05, 0.40909090909091
96078, 1.504347826087, -0.025, 0.40909090909091
96079, 1.504347826087, -0.05, 0.38636363636364
96080, 1.4826086956522, -0.05, 0.36363636363636
96081, 1.504347826087, -0.025, 0.36363636363636
96082, 1.504347826087, -0.05, 0.34090909090909
96083, 1.4826086956522, -0.05, 0.31818181818182
96084, 1.504347826087, -0.025, 0.31818181818182
96085, 1.504347826087, -0.05, 0.29545454545455
96086, 1.4826086956522, -0.05, 0.27272727272727
96087, 1.504347826087, -0.025, 0.27272727272727
96088, 1.504347826087, -0.05, 0.25
96089, 1.4826086956522, -0.05, 0.22727272727273
96090, 1.504347826087, -0.025, 0.22727272727273
96091, 1.504347826087, -0.05, 0.20454545454545
96092, 1.4826086956522, -0.05, 0.18181818181818
96093, 1.504347826087, -0.025, 0.18181818181818
96094, 1.504347826087, -0.05, 0.15909090909091
96095, 1.4826086956522, -0.05, 0.13636363636364
96096, 1.504347826087, -0.025, 0.13636363636364
96097, 1.504347826087, -0.05, 0.11363636363636
96098, 1.4826086956522, -0.05, 0.090909090909091
96099, 1.504347826087, -0.025, 0.090909090909091
96100, 1.504347826087, -0.05, 0.068181818181818
96101, 1.4826086956522, -0.05, 0.045454545454545
96102, 1.504347826087, -0.025, 0.045454545454545
96103, 1.504347826087, -0.05, 0.022727272727273
96104, 1.5478260869565, -0.05, 0.47727272727273
96105, 1.5260869565217, -0.05, 0.45454545454545
96106, 1.5478260869565, -0.025, 0.45454545454545
96107, 1.5478260869565, -0.05, 0.43181818181818
96108, 1.5260869565217, -0.05, 0.40909090909091
96109, 1.5478260869565, -0.025, 0.40909090909091
96110, 1.5478260869565, -0.05, 0.38636363636364
96111, 1.5260869565217, -0.05, 0.36363636363636
96112, 1.5478260869565, -0.025, 0.36363636363636
96113, 1.5478260869565, -0.05, 0.34090909090909
96114, 1.5260869565217, -0.05, 0.31818181818182
96115, 1.5478260869565, -0.025, 0.31818181818182
96116, 1.5478260869565, -0.05, 0.29545454545455
96117, 1.5260869565217, -0.05, 0.27272727272727
96118, 1.5478260869565, -0.025, 0.27272727272727
96119, 1.5478260869565, -0.05, 0.25
96120, 1.5260869565217, -0.05, 0.22727272727273
96121, 1.5478260869565, -0.025, 0.22727272727273
96122, 1.5478260869565, -0.05, 0.20454545454545
96123, 1.5260869565217, -0.05, 0.18181818181818
96124, 1.5478260869565, -0.025, 0.18181818181818
96125, 1.5478260869565, -0.05, 0.15909090909091
96126, 1.5260869565217, -0.05, 0.13636363636364
96127, 1.5478260869565, -0.025, 0.13636363636364
96128, 1.5478260869565, -0.05, 0.11363636363636
96129, 1.5260869565217, -0.05, 0.090909090909091
96130, 1.5478260869565, -0.025, 0.090909090909091
96131, 1.5478260869565, -0.05, 0.068181818181818
96132, 1.5260869565217, -0.05, 0.045454545454545
96133, 1.5478260869565, -0.025, 0.045454545454545
96134, 1.5478260869565, -0.05, 0.022727272727273
96135, 1.5913043478261, -0.05, 0.47727272727273
96136, 1.5695652173913, -0.05, 0.45454545454545
96137, 1.5913043478261, -0.025, 0.45454545454545
96138, 1.5913043478261, -0.05, 0.43181818181818
96139, 1.5695652173913, -0.05, 0.40909090909091
96140, 1.5913043478261, -0.025, 0.40909090909091
96141, 1.5913043478261, -0.05, 0.38636363636364
96142, 1.5695652173913, -0.05, 0.36363636363636
96143, 1.5913043478261, -0.025, 0.36363636363636
96144, 1.5913043478261, -0.05, 0.34090909090909
96145, 1.5695652173913, -0.05, 0.31818181818182
96146, 1.5913043478261, -0.025, 0.31818181818182
96147, 1.5913043478261, -0.05, 0.29545454545455
96148, 1.5695652173913, -0.05, 0.27272727272727
96149, 1.5913043478261, -0.025, 0.27272727272727
96150, 1.5913043478261, -0.05, 0.25
96151, 1.5695652173913, -0.05, 0.22727272727273
96152, 1.5913043478261, -0.025, 0.22727272727273
96153, 1.5913043478261, -0.05, 0.20454545454545
96154, 1.5695652173913, -0.05, 0.18181818181818
96155, 1.5913043478261, -0.025, 0.18181818181818
96156, 1.5913043478261, -0.05, 0.15909090909091
96157, 1.5695652173913, -0.05, 0.13636363636364
96158, 1.5913043478261, -0.025, 0.13636363636364
96159, 1.5913043478261, -0.05, 0.11363636363636
96160, 1.5695652173913, -0.05, 0.090909090909091
96161, 1.5913043478261, -0.025, 0.090909090909091
96162, 1.5913043478261, -0.05, 0.068181818181818
96163, 1.5695652173913, -0.05, 0.045454545454545
96164, 1.5913043478261, -0.025, 0.045454545454545
96165, 1.5913043478261, -0.05, 0.022727272727273
96166, 1.6347826086957, -0.05, 0.47727272727273
96167, 1.6130434782609, -0.05, 0.45454545454545
96168, 1.6347826086957, -0.025, 0.45454545454545
96169, 1.6347826086957, -0.05, 0.43181818181818
96170, 1.6130434782609, -0.05, 0.40909090909091
96171, 1.6347826086957, -0.025, 0.40909090909091
96172, 1.6347826086957, -0.05, 0.38636363636364
96173, 1.6130434782609, -0.05, 0.36363636363636
96174, 1.6347826086957, -0.025, 0.36363636363636
96175, 1.6347826086957, -0.05, 0.34090909090909
96176, 1.6130434782609, -0.05, 0.31818181818182
96177, 1.6347826086957, -0.025, 0.31818181818182
96178, 1.6347826086957, -0.05, 0.29545454545455
96179, 1.6130434782609, -0.05, 0.27272727272727
96180, 1.6347826086957, -0.025, 0.27272727272727
96181, 1.6347826086957, -0.05, 0.25
96182, 1.6130434782609, -0.05, 0.22727272727273
96183, 1.6347826086957, -0.025, 0.22727272727273
96184, 1.6347826086957, -0.05, 0.20454545454545
96185, 1.6130434782609, -0.05, 0.18181818181818
96186, 1.6347826086957, -0.025, 0.18181818181818
96187, 1.6347826086957, -0.05, 0.15909090909091
96188, 1.6130434782609, -0.05, 0.13636363636364
96189, 1.6347826086957, -0.025, 0.13636363636364
96190, 1.6347826086957, -0.05, 0.11363636363636
96191, 1.6130434782609, -0.05, 0.090909090909091
96192, 1.6347826086957, -0.025, 0.090909090909091
96193, 1.6347826086957, -0.05, 0.068181818181818
96194, 1.6130434782609, -0.05, 0.045454545454545
96195, 1.6347826086957, -0.025, 0.045454545454545
96196, 1.6347826086957, -0.05, 0.022727272727273
96197, 1.6782608695652, -0.05, 0.47727272727273
96198, 1.6565217391304, -0.05, 0.45454545454545
96199, 1.6782608695652, -0.025, 0.45454545454545
96200, 1.6782608695652, -0.05, 0.43181818181818
96201, 1.6565217391304, -0.05, 0.40909090909091
96202, 1.6782608695652, -0.025, 0.40909090909091
96203, 1.6782608695652, -0.05, 0.38636363636364
96204, 1.6565217391304, -0.05, 0.36363636363636
96205, 1.6782608695652, -0.025, 0.36363636363636
96206, 1.6782608695652, -0.05, 0.34090909090909
96207, 1.6565217391304, -0.05, 0.31818181818182
96208, 1.6782608695652, -0.025, 0.31818181818182
96209, 1.6782608695652, -0.05, 0.29545454545455
96210, 1.6565217391304, -0.05, 0.27272727272727
96211, 1.6782608695652, -0.025, 0.27272727272727
96212, 1.6782608695652, -0.05, 0.25
96213, 1.6565217391304, -0.05, 0.22727272727273
96214, 1.6782608695652, -0.025, 0.22727272727273
96215, 1.6782608695652, -0.05, 0.20454545454545
96216, 1.6565217391304, -0.05, 0.18181818181818
96217, 1.6782608695652, -0.025, 0.18181818181818
96218, 1.6782608695652, -0.05, 0.15909090909091
96219, 1.6565217391304, -0.05, 0.13636363636364
96220, 1.6782608695652, -0.025, 0.13636363636364
96221, 1.6782608695652, -0.05, 0.11363636363636
96222, 1.6565217391304, -0.05, 0.090909090909091
96223, 1.6782608695652, -0.025, 0.090909090909091
96224, 1.6782608695652, -0.05, 0.068181818181818
96225, 1.6565217391304, -0.05, 0.045454545454545
96226, 1.6782608695652, -0.025, 0.045454545454545
96227, 1.6782608695652, -0.05, 0.022727272727273
96228, 1.7217391304348, -0.05, 0.47727272727273
96229, 1.7, -0.05, 0.45454545454545
96230, 1.7217391304348, -0.025, 0.45454545454545
96231, 1.7217391304348, -0.05, 0.43181818181818
96232, 1.7, -0.05, 0.40909090909091
96233, 1.7217391304348, -0.025, 0.40909090909091
96234, 1.7217391304348, -0.05, 0.38636363636364
96235, 1.7, -0.05, 0.36363636363636
96236, 1.7217391304348, -0.025, 0.36363636363636
96237, 1.7217391304348, -0.05, 0.34090909090909
96238, 1.7, -0.05, 0.31818181818182
96239, 1.7217391304348, -0.025, 0.31818181818182
96240, 1.7217391304348, -0.05, 0.29545454545455
96241, 1.7, -0.05, 0.27272727272727
96242, 1.7217391304348, -0.025, 0.27272727272727
96243, 1.7217391304348, -0.05, 0.25
96244, 1.7, -0.05, 0.22727272727273
96245, 1.7217391304348, -0.025, 0.22727272727273
96246, 1.7217391304348, -0.05, 0.20454545454545
96247, 1.7, -0.05, 0.18181818181818
96248, 1.7217391304348, -0.025, 0.18181818181818
96249, 1.7217391304348, -0.05, 0.15909090909091
96250, 1.7, -0.05, 0.13636363636364
96251, 1.7217391304348, -0.025, 0.13636363636364
96252, 1.7217391304348, -0.05, 0.11363636363636
96253, 1.7, -0.05, 0.090909090909091
96254, 1.7217391304348, -0.025, 0.090909090909091
96255, 1.7217391304348, -0.05, 0.068181818181818
96256, 1.7, -0.05, 0.045454545454545
96257, 1.7217391304348, -0.025, 0.045454545454545
96258, 1.7217391304348, -0.05, 0.022727272727273
96259, 1.7652173913043, -0.05, 0.47727272727273
96260, 1.7434782608696, -0.05, 0.45454545454545
96261, 1.7652173913043, -0.025, 0.45454545454545
96262, 1.7652173913043, -0.05, 0.43181818181818
96263, 1.7434782608696, -0.05, 0.40909090909091
96264, 1.7652173913043, -0.025, 0.40909090909091
96265, 1.7652173913043, -0.05, 0.38636363636364
96266, 1.7434782608696, -0.05, 0.36363636363636
96267, 1.7652173913043, -0.025, 0.36363636363636
96268, 1.7652173913043, -0.05, 0.34090909090909
96269, 1.7434782608696, -0.05, 0.31818181818182
96270, 1.7652173913043, -0.025, 0.31818181818182
96271, 1.7652173913043, -0.05, 0.29545454545455
96272, 1.7434782608696, -0.05, 0.27272727272727
96273, 1.7652173913043, -0.025, 0.27272727272727
96274, 1.7652173913043, -0.05, 0.25
96275, 1.7434782608696, -0.05, 0.22727272727273
96276, 1.7652173913043, -0.025, 0.22727272727273
96277, 1.7652173913043, -0.05, 0.20454545454545
96278, 1.7434782608696, -0.05, 0.18181818181818
96279, 1.7652173913043, -0.025, 0.18181818181818
96280, 1.7652173913043, -0.05, 0.15909090909091
96281, 1.7434782608696, -0.05, 0.13636363636364
96282, 1.7652173913043, -0.025, 0.13636363636364
96283, 1.7652173913043, -0.05, 0.11363636363636
96284, 1.7434782608696, -0.05, 0.090909090909091
96285, 1.7652173913043, -0.025, 0.090909090909091
96286, 1.7652173913043, -0.05, 0.068181818181818
96287, 1.7434782608696, -0.05, 0.045454545454545
96288, 1.7652173913043, -0.025, 0.045454545454545
96289, 1.7652173913043, -0.05, 0.022727272727273
96290, 1.8086956521739, -0.05, 0.47727272727273
96291, 1.7869565217391, -0.05, 0.45454545454545
96292, 1.8086956521739, -0.025, 0.45454545454545
96293, 1.8086956521739, -0.05, 0.43181818181818
96294, 1.7869565217391, -0.05, 0.40909090909091
96295, 1.8086956521739, -0.025, 0.40909090909091
96296, 1.8086956521739, -0.05, 0.38636363636364
96297, 1.7869565217391, -0.05, 0.36363636363636
96298, 1.8086956521739, -0.025, 0.36363636363636
96299, 1.8086956521739, -0.05, 0.34090909090909
96300, 1.7869565217391, -0.05, 0.31818181818182
96301, 1.8086956521739, -0.025, 0.31818181818182
96302, 1.8086956521739, -0.05, 0.29545454545455
96303, 1.7869565217391, -0.05, 0.27272727272727
96304, 1.8086956521739, -0.025, 0.27272727272727
96305, 1.8086956521739, -0.05, 0.25
96306, 1.7869565217391, -0.05, 0.22727272727273
96307, 1.8086956521739, -0.025, 0.22727272727273
96308, 1.8086956521739, -0.05, 0.20454545454545
96309, 1.7869565217391, -0.05, 0.18181818181818
96310, 1.8086956521739, -0.025, 0.18181818181818
96311, 1.8086956521739, -0.05, 0.15909090909091
96312, 1.7869565217391, -0.05, 0.13636363636364
96313, 1.8086956521739, -0.025, 0.13636363636364
96314, 1.8086956521739, -0.05, 0.11363636363636
96315, 1.7869565217391, -0.05, 0.090909090909091
96316, 1.8086956521739, -0.025, 0.090909090909091
96317, 1.8086956521739, -0.05, 0.068181818181818
96318, 1.7869565217391, -0.05, 0.045454545454545
96319, 1.8086956521739, -0.025, 0.045454545454545
96320, 1.8086956521739, -0.05, 0.022727272727273
96321, 1.8521739130435, -0.05, 0.47727272727273
96322, 1.8304347826087, -0.05, 0.45454545454545
96323, 1.8521739130435, -0.025, 0.45454545454545
96324, 1.8521739130435, -0.05, 0.43181818181818
96325, 1.8304347826087, -0.05, 0.40909090909091
96326, 1.8521739130435, -0.025, 0.40909090909091
96327, 1.8521739130435, -0.05, 0.38636363636364
96328, 1.8304347826087, -0.05, 0.36363636363636
96329, 1.8521739130435, -0.025, 0.36363636363636
96330, 1.8521739130435, -0.05, 0.34090909090909
96331, 1.8304347826087, -0.05, 0.31818181818182
96332, 1.8521739130435, -0.025, 0.31818181818182
96333, 1.8521739130435, -0.05, 0.29545454545455
96334, 1.8304347826087, -0.05, 0.27272727272727
96335, 1.8521739130435, -0.025, 0.27272727272727
96336, 1.8521739130435, -0.05, 0.25
96337, 1.8304347826087, -0.05, 0.22727272727273
96338, 1.8521739130435, -0.025, 0.22727272727273
96339, 1.8521739130435, -0.05, 0.20454545454545
96340, 1.8304347826087, -0.05, 0.18181818181818
96341, 1.8521739130435, -0.025, 0.18181818181818
96342, 1.8521739130435, -0.05, 0.15909090909091
96343, 1.8304347826087, -0.05, 0.13636363636364
96344, 1.8521739130435, -0.025, 0.13636363636364
96345, 1.8521739130435, -0.05, 0.11363636363636
96346, 1.8304347826087, -0.05, 0.090909090909091
96347, 1.8521739130435, -0.025, 0.090909090909091
96348, 1.8521739130435, -0.05, 0.068181818181818
96349, 1.8304347826087, -0.05, 0.045454545454545
96350, 1.8521739130435, -0.025, 0.045454545454545
96351, 1.8521739130435, -0.05, 0.022727272727273
96352, 1.895652173913, -0.05, 0.47727272727273
96353, 1.8739130434783, -0.05, 0.45454545454545
96354, 1.895652173913, -0.025, 0.45454545454545
96355, 1.895652173913, -0.05, 0.43181818181818
96356, 1.8739130434783, -0.05, 0.40909090909091
96357, 1.895652173913, -0.025, 0.40909090909091
96358, 1.895652173913, -0.05, 0.38636363636364
96359, 1.8739130434783, -0.05, 0.36363636363636
96360, 1.895652173913, -0.025, 0.36363636363636
96361, 1.895652173913, -0.05, 0.34090909090909
96362, 1.8739130434783, -0.05, 0.31818181818182
96363, 1.895652173913, -0.025, 0.31818181818182
96364, 1.895652173913, -0.05, 0.29545454545455
96365, 1.8739130434783, -0.05, 0.27272727272727
96366, 1.895652173913, -0.025, 0.27272727272727
96367, 1.895652173913, -0.05, 0.25
96368, 1.8739130434783, -0.05, 0.22727272727273
96369, 1.895652173913, -0.025, 0.22727272727273
96370, 1.895652173913, -0.05, 0.20454545454545
96371, 1.8739130434783, -0.05, 0.18181818181818
96372, 1.895652173913, -0.025, 0.18181818181818
96373, 1.895652173913, -0.05, 0.15909090909091
96374, 1.8739130434783, -0.05, 0.13636363636364
96375, 1.895652173913, -0.025, 0.13636363636364
96376, 1.895652173913, -0.05, 0.11363636363636
96377, 1.8739130434783, -0.05, 0.090909090909091
96378, 1.895652173913, -0.025, 0.090909090909091
96379, 1.895652173913, -0.05, 0.068181818181818
96380, 1.8739130434783, -0.05, 0.045454545454545
96381, 1.895652173913, -0.025, 0.045454545454545
96382, 1.895652173913, -0.05, 0.022727272727273
96383, 1.9391304347826, -0.05, 0.47727272727273
96384, 1.9173913043478, -0.05, 0.45454545454545
96385, 1.9391304347826, -0.025, 0.45454545454545
96386, 1.9391304347826, -0.05, 0.43181818181818
96387, 1.9173913043478, -0.05, 0.40909090909091
96388, 1.9391304347826, -0.025, 0.40909090909091
96389, 1.9391304347826, -0.05, 0.38636363636364
96390, 1.9173913043478, -0.05, 0.36363636363636
96391, 1.9391304347826, -0.025, 0.36363636363636
96392, 1.9391304347826, -0.05, 0.34090909090909
96393, 1.9173913043478, -0.05, 0.31818181818182
96394, 1.9391304347826, -0.025, 0.31818181818182
96395, 1.9391304347826, -0.05, 0.29545454545455
96396, 1.9173913043478, -0.05, 0.27272727272727
96397, 1.9391304347826, -0.025, 0.27272727272727
96398, 1.9391304347826, -0.05, 0.25
96399, 1.9173913043478, -0.05, 0.22727272727273
96400, 1.9391304347826, -0.025, 0.22727272727273
96401, 1.9391304347826, -0.05, 0.20454545454545
96402, 1.9173913043478, -0.05, 0.18181818181818
96403, 1.9391304347826, -0.025, 0.18181818181818
96404, 1.9391304347826, -0.05, 0.15909090909091
96405, 1.9173913043478, -0.05, 0.13636363636364
96406, 1.9391304347826, -0.025, 0.13636363636364
96407, 1.9391304347826, -0.05, 0.11363636363636
96408, 1.9173913043478, -0.05, 0.090909090909091
96409, 1.9391304347826, -0.025, 0.090909090909091
96410, 1.9391304347826, -0.05, 0.068181818181818
96411, 1.9173913043478, -0.05, 0.045454545454545
96412, 1.9391304347826, -0.025, 0.045454545454545
96413, 1.9391304347826, -0.05, 0.022727272727273
96414, 1.9826086956522, -0.05, 0.47727272727273
96415, 1.9608695652174, -0.05, 0.45454545454545
96416, 1.9826086956522, -0.025, 0.45454545454545
96417, 1.9826086956522, -0.05, 0.43181818181818
96418, 1.9608695652174, -0.05, 0.40909090909091
96419, 1.9826086956522, -0.025, 0.40909090909091
96420, 1.9826086956522, -0.05, 0.38636363636364
96421, 1.9608695652174, -0.05, 0.36363636363636
96422, 1.9826086956522, -0.025, 0.36363636363636
96423, 1.9826086956522, -0.05, 0.34090909090909
96424, 1.9608695652174, -0.05, 0.31818181818182
96425, 1.9826086956522, -0.025, 0.31818181818182
96426, 1.9826086956522, -0.05, 0.29545454545455
96427, 1.9608695652174, -0.05, 0.27272727272727
96428, 1.9826086956522, -0.025, 0.27272727272727
96429, 1.9826086956522, -0.05, 0.25
96430, 1.9608695652174, -0.05, 0.22727272727273
96431, 1.9826086956522, -0.025, 0.22727272727273
96432, 1.9826086956522, -0.05, 0.20454545454545
96433, 1.9608695652174, -0.05, 0.18181818181818
96434, 1.9826086956522, -0.025, 0.18181818181818
96435, 1.9826086956522, -0.05, 0.15909090909091
96436, 1.9608695652174, -0.05, 0.13636363636364
96437, 1.9826086956522, -0.025, 0.13636363636364
96438, 1.9826086956522, -0.05, 0.11363636363636
96439, 1.9608695652174, -0.05, 0.090909090909091
96440, 1.9826086956522, -0.025, 0.090909090909091
96441, 1.9826086956522, -0.05, 0.068181818181818
96442, 1.9608695652174, -0.05, 0.045454545454545
96443, 1.9826086956522, -0.025, 0.045454545454545
96444, 1.9826086956522, -0.05, 0.022727272727273
96445, 2.0260869565217, -0.05, 0.47727272727273
96446, 2.004347826087, -0.05, 0.45454545454545
96447, 2.0260869565217, -0.025, 0.45454545454545
96448, 2.0260869565217, -0.05, 0.43181818181818
96449, 2.004347826087, -0.05, 0.40909090909091
96450, 2.0260869565217, -0.025, 0.40909090909091
96451, 2.0260869565217, -0.05, 0.38636363636364
96452, 2.004347826087, -0.05, 0.36363636363636
96453, 2.0260869565217, -0.025, 0.36363636363636
96454, 2.0260869565217, -0.05, 0.34090909090909
96455, 2.004347826087, -0.05, 0.31818181818182
96456, 2.0260869565217, -0.025, 0.31818181818182
96457, 2.0260869565217, -0.05, 0.29545454545455
96458, 2.004347826087, -0.05, 0.27272727272727
96459, 2.0260869565217, -0.025, 0.27272727272727
96460, 2.0260869565217, -0.05, 0.25
96461, 2.004347826087, -0.05, 0.22727272727273
96462, 2.0260869565217, -0.025, 0.22727272727273
96463, 2.0260869565217, -0.05, 0.20454545454545
96464, 2.004347826087, -0.05, 0.18181818181818
96465, 2.0260869565217, -0.025, 0.18181818181818
96466, 2.0260869565217, -0.05, 0.15909090909091
96467, 2.004347826087, -0.05, 0.13636363636364
96468, 2.0260869565217, -0.025, 0.13636363636364
96469, 2.0260869565217, -0.05, 0.11363636363636
96470, 2.004347826087, -0.05, 0.090909090909091
96471, 2.0260869565217, -0.025, 0.090909090909091
96472, 2.0260869565217, -0.05, 0.068181818181818
96473, 2.004347826087, -0.05, 0.045454545454545
96474, 2.0260869565217, -0.025, 0.045454545454545
96475, 2.0260869565217, -0.05, 0.022727272727273
96476, 2.0695652173913, -0.05, 0.47727272727273
96477, 2.0478260869565, -0.05, 0.45454545454545
96478, 2.0695652173913, -0.025, 0.45454545454545
96479, 2.0695652173913, -0.05, 0.43181818181818
96480, 2.0478260869565, -0.05, 0.40909090909091
96481, 2.0695652173913, -0.025, 0.40909090909091
96482, 2.0695652173913, -0.05, 0.38636363636364
96483, 2.0478260869565, -0.05, 0.36363636363636
96484, 2.0695652173913, -0.025, 0.36363636363636
96485, 2.0695652173913, -0.05, 0.34090909090909
96486, 2.0478260869565, -0.05, 0.31818181818182
96487, 2.0695652173913, -0.025, 0.31818181818182
96488, 2.0695652173913, -0.05, 0.29545454545455
96489, 2.0478260869565, -0.05, 0.27272727272727
96490, 2.0695652173913, -0.025, 0.27272727272727
96491, 2.0695652173913, -0.05, 0.25
96492, 2.0478260869565, -0.05, 0.22727272727273
96493, 2.0695652173913, -0.025, 0.22727272727273
96494, 2.0695652173913, -0.05, 0.20454545454545
96495, 2.0478260869565, -0.05, 0.18181818181818
96496, 2.0695652173913, -0.025, 0.18181818181818
96497, 2.0695652173913, -0.05, 0.15909090909091
96498, 2.0478260869565, -0.05, 0.13636363636364
96499, 2.0695652173913, -0.025, 0.13636363636364
96500, 2.0695652173913, -0.05, 0.11363636363636
96501, 2.0478260869565, -0.05, 0.090909090909091
96502, 2.0695652173913, -0.025, 0.090909090909091
96503, 2.0695652173913, -0.05, 0.068181818181818
96504, 2.0478260869565, -0.05, 0.045454545454545
96505, 2.0695652173913, -0.025, 0.045454545454545
96506, 2.0695652173913, -0.05, 0.022727272727273
96507, 2.1130434782609, -0.05, 0.47727272727273
96508, 2.0913043478261, -0.05, 0.45454545454545
96509, 2.1130434782609, -0.025, 0.45454545454545
96510, 2.1130434782609, -0.05, 0.43181818181818
96511, 2.0913043478261, -0.05, 0.40909090909091
96512, 2.1130434782609, -0.025, 0.40909090909091
96513, 2.1130434782609, -0.05, 0.38636363636364
96514, 2.0913043478261, -0.05, 0.36363636363636
96515, 2.1130434782609, -0.025, 0.36363636363636
96516, 2.1130434782609, -0.05, 0.34090909090909
96517, 2.0913043478261, -0.05, 0.31818181818182
96518, 2.1130434782609, -0.025, 0.31818181818182
96519, 2.1130434782609, -0.05, 0.29545454545455
96520, 2.0913043478261, -0.05, 0.27272727272727
96521, 2.1130434782609, -0.025, 0.27272727272727
96522, 2.1130434782609, -0.05, 0.25
96523, 2.0913043478261, -0.05, 0.22727272727273
96524, 2.1130434782609, -0.025, 0.22727272727273
96525, 2.1130434782609, -0.05, 0.20454545454545
96526, 2.0913043478261, -0.05, 0.18181818181818
96527, 2.1130434782609, -0.025, 0.18181818181818
96528, 2.1130434782609, -0.05, 0.15909090909091
96529, 2.0913043478261, -0.05, 0.13636363636364
96530, 2.1130434782609, -0.025, 0.13636363636364
96531, 2.1130434782609, -0.05, 0.11363636363636
96532, 2.0913043478261, -0.05, 0.090909090909091
96533, 2.1130434782609, -0.025, 0.090909090909091
96534, 2.1130434782609, -0.05, 0.068181818181818
96535, 2.0913043478261, -0.05, 0.045454545454545
96536, 2.1130434782609, -0.025, 0.045454545454545
96537, 2.1130434782609, -0.05, 0.022727272727273
96538, 2.1565217391304, -0.05, 0.47727272727273
96539, 2.1347826086957, -0.05, 0.45454545454545
96540, 2.1565217391304, -0.025, 0.45454545454545
96541, 2.1565217391304, -0.05, 0.43181818181818
96542, 2.1347826086957, -0.05, 0.40909090909091
96543, 2.1565217391304, -0.025, 0.40909090909091
96544, 2.1565217391304, -0.05, 0.38636363636364
96545, 2.1347826086957, -0.05, 0.36363636363636
96546, 2.1565217391304, -0.025, 0.36363636363636
96547, 2.1565217391304, -0.05, 0.34090909090909
96548, 2.1347826086957, -0.05, 0.31818181818182
96549, 2.1565217391304, -0.025, 0.31818181818182
96550, 2.1565217391304, -0.05, 0.29545454545455
96551, 2.1347826086957, -0.05, 0.27272727272727
96552, 2.1565217391304, -0.025, 0.27272727272727
96553, 2.1565217391304, -0.05, 0.25
96554, 2.1347826086957, -0.05, 0.22727272727273
96555, 2.1565217391304, -0.025, 0.22727272727273
96556, 2.1565217391304, -0.05, 0.20454545454545
96557, 2.1347826086957, -0.05, 0.18181818181818
96558, 2.1565217391304, -0.025, 0.18181818181818
96559, 2.1565217391304, -0.05, 0.15909090909091
96560, 2.1347826086957, -0.05, 0.13636363636364
96561, 2.1565217391304, -0.025, 0.13636363636364
96562, 2.1565217391304, -0.05, 0.11363636363636
96563, 2.1347826086957, -0.05, 0.090909090909091
96564, 2.1565217391304, -0.025, 0.090909090909091
96565, 2.1565217391304, -0.05, 0.068181818181818
96566, 2.1347826086957, -0.05, 0.045454545454545
96567, 2.1565217391304, -0.025, 0.045454545454545
96568, 2.1565217391304, -0.05, 0.022727272727273
96569, 2.1782608695652, -0.05, 0.45454545454545
96570, 2.1782608695652, -0.05, 0.40909090909091
96571, 2.1782608695652, -0.05, 0.36363636363636
96572, 2.1782608695652, -0.05, 0.31818181818182
96573, 2.1782608695652, -0.05, 0.27272727272727
96574, 2.1782608695652, -0.05, 0.22727272727273
96575, 2.1782608695652, -0.05, 0.18181818181818
96576, 2.1782608695652, -0.05, 0.13636363636364
96577, 2.1782608695652, -0.05, 0.090909090909091
96578, 2.1782608695652, -0.05, 0.045454545454545
96579, 1.2434782608696, -0.1, 0.47727272727273
96580, 1.2217391304348, -0.1, 0.45454545454545
96581, 1.2434782608696, -0.075, 0.45454545454545
96582, 1.2434782608696, -0.1, 0.43181818181818
96583, 1.2217391304348, -0.1, 0.40909090909091
96584, 1.2434782608696, -0.075, 0.40909090909091
96585, 1.2434782608696, -0.1, 0.38636363636364
96586, 1.2217391304348, -0.1, 0.36363636363636
96587, 1.2434782608696, -0.075, 0.36363636363636
96588, 1.2434782608696, -0.1, 0.34090909090909
96589, 1.2217391304348, -0.1, 0.31818181818182
96590, 1.2434782608696, -0.075, 0.31818181818182
96591, 1.2434782608696, -0.1, 0.29545454545455
96592, 1.2217391304348, -0.1, 0.27272727272727
96593, 1.2434782608696, -0.075, 0.27272727272727
96594, 1.2434782608696, -0.1, 0.25
96595, 1.2217391304348, -0.1, 0.22727272727273
96596, 1.2434782608696, -0.075, 0.22727272727273
96597, 1.2434782608696, -0.1, 0.20454545454545
96598, 1.2217391304348, -0.1, 0.18181818181818
96599, 1.2434782608696, -0.075, 0.18181818181818
96600, 1.2434782608696, -0.1, 0.15909090909091
96601, 1.2217391304348, -0.1, 0.13636363636364
96602, 1.2434782608696, -0.075, 0.13636363636364
96603, 1.2434782608696, -0.1, 0.11363636363636
96604, 1.2217391304348, -0.1, 0.090909090909091
96605, 1.2434782608696, -0.075, 0.090909090909091
96606, 1.2434782608696, -0.1, 0.068181818181818
96607, 1.2217391304348, -0.1, 0.045454545454545
96608, 1.2434782608696, -0.075, 0.045454545454545
96609, 1.2434782608696, -0.1, 0.022727272727273
96610, 1.2869565217391, -0.1, 0.47727272727273
96611, 1.2652173913043, -0.1, 0.45454545454545
96612, 1.2869565217391, -0.075, 0.45454545454545
96613, 1.2869565217391, -0.1, 0.43181818181818
96614, 1.2652173913043, -0.1, 0.40909090909091
96615, 1.2869565217391, -0.075, 0.40909090909091
96616, 1.2869565217391, -0.1, 0.38636363636364
96617, 1.2652173913043, -0.1, 0.36363636363636
96618, 1.2869565217391, -0.075, 0.36363636363636
96619, 1.2869565217391, -0.1, 0.34090909090909
96620, 1.2652173913043, -0.1, 0.31818181818182
96621, 1.2869565217391, -0.075, 0.31818181818182
96622, 1.2869565217391, -0.1, 0.29545454545455
96623, 1.2652173913043, -0.1, 0.27272727272727
96624, 1.2869565217391, -0.075, 0.27272727272727
96625, 1.2869565217391, -0.1, 0.25
96626, 1.2652173913043, -0.1, 0.22727272727273
96627, 1.2869565217391, -0.075, 0.22727272727273
96628, 1.2869565217391, -0.1, 0.20454545454545
96629, 1.2652173913043, -0.1, 0.18181818181818
96630, 1.2869565217391, -0.075, 0.18181818181818
96631, 1.2869565217391, -0.1, 0.15909090909091
96632, 1.2652173913043, -0.1, 0.13636363636364
96633, 1.2869565217391, -0.075, 0.13636363636364
96634, 1.2869565217391, -0.1, 0.11363636363636
96635, 1.2652173913043, -0.1, 0.090909090909091
96636, 1.2869565217391, -0.075, 0.090909090909091
96637, 1.2869565217391, -0.1, 0.068181818181818
96638, 1.2652173913043, -0.1, 0.045454545454545
96639, 1.2869565217391, -0.075, 0.045454545454545
96640, 1.2869565217391, -0.1, 0.022727272727273
96641, 1.3304347826087, -0.1, 0.47727272727273
96642, 1.3086956521739, -0.1, 0.45454545454545
96643, 1.3304347826087, -0.075, 0.45454545454545
96644, 1.3304347826087, -0.1, 0.43181818181818
96645, 1.3086956521739, -0.1, 0.40909090909091
96646, 1.3304347826087, -0.075, 0.40909090909091
96647, 1.3304347826087, -0.1, 0.38636363636364
96648, 1.3086956521739, -0.1, 0.36363636363636
96649, 1.3304347826087, -0.075, 0.36363636363636
96650, 1.3304347826087, -0.1, 0.34090909090909
96651, 1.3086956521739, -0.1, 0.31818181818182
96652, 1.3304347826087, -0.075, 0.31818181818182
96653, 1.3304347826087, -0.1, 0.29545454545455
96654, 1.3086956521739, -0.1, 0.27272727272727
96655, 1.3304347826087, -0.075, 0.27272727272727
96656, 1.3304347826087, -0.1, 0.25
96657, 1.3086956521739, -0.1, 0.22727272727273
96658, 1.3304347826087, -0.075, 0.22727272727273
96659, 1.3304347826087, -0.1, 0.20454545454545
96660, 1.3086956521739, -0.1, 0.18181818181818
96661, 1.3304347826087, -0.075, 0.18181818181818
96662, 1.3304347826087, -0.1, 0.15909090909091
96663, 1.3086956521739, -0.1, 0.13636363636364
96664, 1.3304347826087, -0.075, 0.13636363636364
96665, 1.3304347826087, -0.1, 0.11363636363636
96666, 1.3086956521739, -0.1, 0.090909090909091
96667, 1.3304347826087, -0.075, 0.090909090909091
96668, 1.3304347826087, -0.1, 0.068181818181818
96669, 1.3086956521739, -0.1, 0.045454545454545
96670, 1.3304347826087, -0.075, 0.045454545454545
96671, 1.3304347826087, -0.1, 0.022727272727273
96672, 1.3739130434783, -0.1, 0.47727272727273
96673, 1.3521739130435, -0.1, 0.45454545454545
96674, 1.3739130434783, -0.075, 0.45454545454545
96675, 1.3739130434783, -0.1, 0.43181818181818
96676, 1.3521739130435, -0.1, 0.40909090909091
96677, 1.3739130434783, -0.075, 0.40909090909091
96678, 1.3739130434783, -0.1, 0.38636363636364
96679, 1.3521739130435, -0.1, 0.36363636363636
96680, 1.3739130434783, -0.075, 0.36363636363636
96681, 1.3739130434783, -0.1, 0.34090909090909
96682, 1.3521739130435, -0.1, 0.31818181818182
96683, 1.3739130434783, -0.075, 0.31818181818182
96684, 1.3739130434783, -0.1, 0.29545454545455
96685, 1.3521739130435, -0.1, 0.27272727272727
96686, 1.3739130434783, -0.075, 0.27272727272727
96687, 1.3739130434783, -0.1, 0.25
96688, 1.3521739130435, -0.1, 0.22727272727273
96689, 1.3739130434783, -0.075, 0.22727272727273
96690, 1.3739130434783, -0.1, 0.20454545454545
96691, 1.3521739130435, -0.1, 0.18181818181818
96692, 1.3739130434783, -0.075, 0.18181818181818
96693, 1.3739130434783, -0.1, 0.15909090909091
96694, 1.3521739130435, -0.1, 0.13636363636364
96695, 1.3739130434783, -0.075, 0.13636363636364
96696, 1.3739130434783, -0.1, 0.11363636363636
96697, 1.3521739130435, -0.1, 0.090909090909091
96698, 1.3739130434783, -0.075, 0.090909090909091
96699, 1.3739130434783, -0.1, 0.068181818181818
96700, 1.3521739130435, -0.1, 0.045454545454545
96701, 1.3739130434783, -0.075, 0.045454545454545
96702, 1.3739130434783, -0.1, 0.022727272727273
96703, 1.4173913043478, -0.1, 0.47727272727273
96704, 1.395652173913, -0.1, 0.45454545454545
96705, 1.4173913043478, -0.075, 0.45454545454545
96706, 1.4173913043478, -0.1, 0.43181818181818
96707, 1.395652173913, -0.1, 0.40909090909091
96708, 1.4173913043478, -0.075, 0.40909090909091
96709, 1.4173913043478, -0.1, 0.38636363636364
96710, 1.395652173913, -0.1, 0.36363636363636
96711, 1.4173913043478, -0.075, 0.36363636363636
96712, 1.4173913043478, -0.1, 0.34090909090909
96713, 1.395652173913, -0.1, 0.31818181818182
96714, 1.4173913043478, -0.075, 0.31818181818182
96715, 1.4173913043478, -0.1, 0.29545454545455
96716, 1.395652173913, -0.1, 0.27272727272727
96717, 1.4173913043478, -0.075, 0.27272727272727
96718, 1.4173913043478, -0.1, 0.25
96719, 1.395652173913, -0.1, 0.22727272727273
96720, 1.4173913043478, -0.075, 0.22727272727273
96721, 1.4173913043478, -0.1, 0.20454545454545
96722, 1.395652173913, -0.1, 0.18181818181818
96723, 1.4173913043478, -0.075, 0.18181818181818
96724, 1.4173913043478, -0.1, 0.15909090909091
96725, 1.395652173913, -0.1, 0.13636363636364
96726, 1.4173913043478, -0.075, 0.13636363636364
96727, 1.4173913043478, -0.1, 0.11363636363636
96728, 1.395652173913, -0.1, 0.090909090909091
96729, 1.4173913043478, -0.075, 0.090909090909091
96730, 1.4173913043478, -0.1, 0.068181818181818
96731, 1.395652173913, -0.1, 0.045454545454545
96732, 1.4173913043478, -0.075, 0.045454545454545
96733, 1.4173913043478, -0.1, 0.022727272727273
96734, 1.4608695652174, -0.1, 0.47727272727273
96735, 1.4391304347826, -0.1, 0.45454545454545
96736, 1.4608695652174, -0.075, 0.45454545454545
96737, 1.4608695652174, -0.1, 0.43181818181818
96738, 1.4391304347826, -0.1, 0.40909090909091
96739, 1.4608695652174, -0.075, 0.40909090909091
96740, 1.4608695652174, -0.1, 0.38636363636364
96741, 1.4391304347826, -0.1, 0.36363636363636
96742, 1.4608695652174, -0.075, 0.36363636363636
96743, 1.4608695652174, -0.1, 0.34090909090909
96744, 1.4391304347826, -0.1, 0.31818181818182
96745, 1.4608695652174, -0.075, 0.31818181818182
96746, 1.4608695652174, -0.1, 0.29545454545455
96747, 1.4391304347826, -0.1, 0.27272727272727
96748, 1.4608695652174, -0.075, 0.27272727272727
96749, 1.4608695652174, -0.1, 0.25
96750, 1.4391304347826, -0.1, 0.22727272727273
96751, 1.4608695652174, -0.075, 0.22727272727273
96752, 1.4608695652174, -0.1, 0.20454545454545
96753, 1.4391304347826, -0.1, 0.18181818181818
96754, 1.4608695652174, -0.075, 0.18181818181818
96755, 1.4608695652174, -0.1, 0.15909090909091
96756, 1.4391304347826, -0.1, 0.13636363636364
96757, 1.4608695652174, -0.075, 0.13636363636364
96758, 1.4608695652174, -0.1, 0.11363636363636
96759, 1.4391304347826, -0.1, 0.090909090909091
96760, 1.4608695652174, -0.075, 0.090909090909091
96761, 1.4608695652174, -0.1, 0.068181818181818
96762, 1.4391304347826, -0.1, 0.045454545454545
96763, 1.4608695652174, -0.075, 0.045454545454545
96764, 1.4608695652174, -0.1, 0.022727272727273
96765, 1.504347826087, -0.1, 0.47727272727273
96766, 1.4826086956522, -0.1, 0.45454545454545
96767, 1.504347826087, -0.075, 0.45454545454545
96768, 1.504347826087, -0.1, 0.43181818181818
96769, 1.4826086956522, -0.1, 0.40909090909091
96770, 1.504347826087, -0.075, 0.40909090909091
96771, 1.504347826087, -0.1, 0.38636363636364
96772, 1.4826086956522, -0.1, 0.36363636363636
96773, 1.504347826087, -0.075, 0.36363636363636
96774, 1.504347826087, -0.1, 0.34090909090909
96775, 1.4826086956522, -0.1, 0.31818181818182
96776, 1.504347826087, -0.075, 0.31818181818182
96777, 1.504347826087, -0.1, 0.29545454545455
96778, 1.4826086956522, -0.1, 0.27272727272727
96779, 1.504347826087, -0.075, 0.27272727272727
96780, 1.504347826087, -0.1, 0.25
96781, 1.4826086956522, -0.1, 0.22727272727273
96782, 1.504347826087, -0.075, 0.22727272727273
96783, 1.504347826087, -0.1, 0.20454545454545
96784, 1.4826086956522, -0.1, 0.18181818181818
96785, 1.504347826087, -0.075, 0.18181818181818
96786, 1.504347826087, -0.1, 0.15909090909091
96787, 1.4826086956522, -0.1, 0.13636363636364
96788, 1.504347826087, -0.075, 0.13636363636364
96789, 1.504347826087, -0.1, 0.11363636363636
96790, 1.4826086956522, -0.1, 0.090909090909091
96791, 1.504347826087, -0.075, 0.090909090909091
96792, 1.504347826087, -0.1, 0.068181818181818
96793, 1.4826086956522, -0.1, 0.045454545454545
96794, 1.504347826087, -0.075, 0.045454545454545
96795, 1.504347826087, -0.1, 0.022727272727273
96796, 1.5478260869565, -0.1, 0.47727272727273
96797, 1.5260869565217, -0.1, 0.45454545454545
96798, 1.5478260869565, -0.075, 0.45454545454545
96799, 1.5478260869565, -0.1, 0.43181818181818
96800, 1.5260869565217, -0.1, 0.40909090909091
96801, 1.5478260869565, -0.075, 0.40909090909091
96802, 1.5478260869565, -0.1, 0.38636363636364
96803, 1.5260869565217, -0.1, 0.36363636363636
96804, 1.5478260869565, -0.075, 0.36363636363636
96805, 1.5478260869565, -0.1, 0.34090909090909
96806, 1.5260869565217, -0.1, 0.31818181818182
96807, 1.5478260869565, -0.075, 0.31818181818182
96808, 1.5478260869565, -0.1, 0.29545454545455
96809, 1.5260869565217, -0.1, 0.27272727272727
96810, 1.5478260869565, -0.075, 0.27272727272727
96811, 1.5478260869565, -0.1, 0.25
96812, 1.5260869565217, -0.1, 0.22727272727273
96813, 1.5478260869565, -0.075, 0.22727272727273
96814, 1.5478260869565, -0.1, 0.20454545454545
96815, 1.5260869565217, -0.1, 0.18181818181818
96816, 1.5478260869565, -0.075, 0.18181818181818
96817, 1.5478260869565, -0.1, 0.15909090909091
96818, 1.5260869565217, -0.1, 0.13636363636364
96819, 1.5478260869565, -0.075, 0.13636363636364
96820, 1.5478260869565, -0.1, 0.11363636363636
96821, 1.5260869565217, -0.1, 0.090909090909091
96822, 1.5478260869565, -0.075, 0.090909090909091
96823, 1.5478260869565, -0.1, 0.068181818181818
96824, 1.5260869565217, -0.1, 0.045454545454545
96825, 1.5478260869565, -0.075, 0.045454545454545
96826, 1.5478260869565, -0.1, 0.022727272727273
96827, 1.5913043478261, -0.1, 0.47727272727273
96828, 1.5695652173913, -0.1, 0.45454545454545
96829, 1.5913043478261, -0.075, 0.45454545454545
96830, 1.5913043478261, -0.1, 0.43181818181818
96831, 1.5695652173913, -0.1, 0.40909090909091
96832, 1.5913043478261, -0.075, 0.40909090909091
96833, 1.5913043478261, -0.1, 0.38636363636364
96834, 1.5695652173913, -0.1, 0.36363636363636
96835, 1.5913043478261, -0.075, 0.36363636363636
96836, 1.5913043478261, -0.1, 0.34090909090909
96837, 1.5695652173913, -0.1, 0.31818181818182
96838, 1.5913043478261, -0.075, 0.31818181818182
96839, 1.5913043478261, -0.1, 0.29545454545455
96840, 1.5695652173913, -0.1, 0.27272727272727
96841, 1.5913043478261, -0.075, 0.27272727272727
96842, 1.5913043478261, -0.1, 0.25
96843, 1.5695652173913, -0.1, 0.22727272727273
96844, 1.5913043478261, -0.075, 0.22727272727273
96845, 1.5913043478261, -0.1, 0.20454545454545
96846, 1.5695652173913, -0.1, 0.18181818181818
96847, 1.5913043478261, -0.075, 0.18181818181818
96848, 1.5913043478261, -0.1, 0.15909090909091
96849, 1.5695652173913, -0.1, 0.13636363636364
96850, 1.5913043478261, -0.075, 0.13636363636364
96851, 1.5913043478261, -0.1, 0.11363636363636
96852, 1.5695652173913, -0.1, 0.090909090909091
96853, 1.5913043478261, -0.075, 0.090909090909091
96854, 1.5913043478261, -0.1, 0.068181818181818
96855, 1.5695652173913, -0.1, 0.045454545454545
96856, 1.5913043478261, -0.075, 0.045454545454545
96857, 1.5913043478261, -0.1, 0.022727272727273
96858, 1.6347826086957, -0.1, 0.47727272727273
96859, 1.6130434782609, -0.1, 0.45454545454545
96860, 1.6347826086957, -0.075, 0.45454545454545
96861, 1.6347826086957, -0.1, 0.43181818181818
96862, 1.6130434782609, -0.1, 0.40909090909091
96863, 1.6347826086957, -0.075, 0.40909090909091
96864, 1.6347826086957, -0.1, 0.38636363636364
96865, 1.6130434782609, -0.1, 0.36363636363636
96866, 1.6347826086957, -0.075, 0.36363636363636
96867, 1.6347826086957, -0.1, 0.34090909090909
96868, 1.6130434782609, -0.1, 0.31818181818182
96869, 1.6347826086957, -0.075, 0.31818181818182
96870, 1.6347826086957, -0.1, 0.29545454545455
96871, 1.6130434782609, -0.1, 0.27272727272727
96872, 1.6347826086957, -0.075, 0.27272727272727
96873, 1.6347826086957, -0.1, 0.25
96874, 1.6130434782609, -0.1, 0.22727272727273
96875, 1.6347826086957, -0.075, 0.22727272727273
96876, 1.6347826086957, -0.1, 0.20454545454545
96877, 1.6130434782609, -0.1, 0.18181818181818
96878, 1.6347826086957, -0.075, 0.18181818181818
96879, 1.6347826086957, -0.1, 0.15909090909091
96880, 1.6130434782609, -0.1, 0.13636363636364
96881, 1.6347826086957, -0.075, 0.13636363636364
96882, 1.6347826086957, -0.1, 0.11363636363636
96883, 1.6130434782609, -0.1, 0.090909090909091
96884, 1.6347826086957, -0.075, 0.090909090909091
96885, 1.6347826086957, -0.1, 0.068181818181818
96886, 1.6130434782609, -0.1, 0.045454545454545
96887, 1.6347826086957, -0.075, 0.045454545454545
96888, 1.6347826086957, -0.1, 0.022727272727273
96889, 1.6782608695652, -0.1, 0.47727272727273
96890, 1.6565217391304, -0.1, 0.45454545454545
96891, 1.6782608695652, -0.075, 0.45454545454545
96892, 1.6782608695652, -0.1, 0.43181818181818
96893, 1.6565217391304, -0.1, 0.40909090909091
96894, 1.6782608695652, -0.075, 0.40909090909091
96895, 1.6782608695652, -0.1, 0.38636363636364
96896, 1.6565217391304, -0.1, 0.36363636363636
96897, 1.6782608695652, -0.075, 0.36363636363636
96898, 1.6782608695652, -0.1, 0.34090909090909
96899, 1.6565217391304, -0.1, 0.31818181818182
96900, 1.6782608695652, -0.075, 0.31818181818182
96901, 1.6782608695652, -0.1, 0.29545454545455
96902, 1.6565217391304, -0.1, 0.27272727272727
96903, 1.6782608695652, -0.075, 0.27272727272727
96904, 1.6782608695652, -0.1, 0.25
96905, 1.6565217391304, -0.1, 0.22727272727273
96906, 1.6782608695652, -0.075, 0.22727272727273
96907, 1.6782608695652, -0.1, 0.20454545454545
96908, 1.6565217391304, -0.1, 0.18181818181818
96909, 1.6782608695652, -0.075, 0.18181818181818
96910, 1.6782608695652, -0.1, 0.15909090909091
96911, 1.6565217391304, -0.1, 0.13636363636364
96912, 1.6782608695652, -0.075, 0.13636363636364
96913, 1.6782608695652, -0.1, 0.11363636363636
96914, 1.6565217391304, -0.1, 0.090909090909091
96915, 1.6782608695652, -0.075, 0.090909090909091
96916, 1.6782608695652, -0.1, 0.068181818181818
96917, 1.6565217391304, -0.1, 0.045454545454545
96918, 1.6782608695652, -0.075, 0.045454545454545
96919, 1.6782608695652, -0.1, 0.022727272727273
96920, 1.7217391304348, -0.1, 0.47727272727273
96921, 1.7, -0.1, 0.45454545454545
96922, 1.7217391304348, -0.075, 0.45454545454545
96923, 1.7217391304348, -0.1, 0.43181818181818
96924, 1.7, -0.1, 0.40909090909091
96925, 1.7217391304348, -0.075, 0.40909090909091
96926, 1.7217391304348, -0.1, 0.38636363636364
96927, 1.7, -0.1, 0.36363636363636
96928, 1.7217391304348, -0.075, 0.36363636363636
96929, 1.7217391304348, -0.1, 0.34090909090909
96930, 1.7, -0.1, 0.31818181818182
96931, 1.7217391304348, -0.075, 0.31818181818182
96932, 1.7217391304348, -0.1, 0.29545454545455
96933, 1.7, -0.1, 0.27272727272727
96934, 1.7217391304348, -0.075, 0.27272727272727
96935, 1.7217391304348, -0.1, 0.25
96936, 1.7, -0.1, 0.22727272727273
96937, 1.7217391304348, -0.075, 0.22727272727273
96938, 1.7217391304348, -0.1, 0.20454545454545
96939, 1.7, -0.1, 0.18181818181818
96940, 1.7217391304348, -0.075, 0.18181818181818
96941, 1.7217391304348, -0.1, 0.15909090909091
96942, 1.7, -0.1, 0.13636363636364
96943, 1.7217391304348, -0.075, 0.13636363636364
96944, 1.7217391304348, -0.1, 0.11363636363636
96945, 1.7, -0.1, 0.090909090909091
96946, 1.7217391304348, -0.075, 0.090909090909091
96947, 1.7217391304348, -0.1, 0.068181818181818
96948, 1.7, -0.1, 0.045454545454545
96949, 1.7217391304348, -0.075, 0.045454545454545
96950, 1.7217391304348, -0.1, 0.022727272727273
96951, 1.7652173913043, -0.1, 0.47727272727273
96952, 1.7434782608696, -0.1, 0.45454545454545
96953, 1.7652173913043, -0.075, 0.45454545454545
96954, 1.7652173913043, -0.1, 0.43181818181818
96955, 1.7434782608696, -0.1, 0.40909090909091
96956, 1.7652173913043, -0.075, 0.40909090909091
96957, 1.7652173913043, -0.1, 0.38636363636364
96958, 1.7434782608696, -0.1, 0.36363636363636
96959, 1.7652173913043, -0.075, 0.36363636363636
96960, 1.7652173913043, -0.1, 0.34090909090909
96961, 1.7434782608696, -0.1, 0.31818181818182
96962, 1.7652173913043, -0.075, 0.31818181818182
96963, 1.7652173913043, -0.1, 0.29545454545455
96964, 1.7434782608696, -0.1, 0.27272727272727
96965, 1.7652173913043, -0.075, 0.27272727272727
96966, 1.7652173913043, -0.1, 0.25
96967, 1.7434782608696, -0.1, 0.22727272727273
96968, 1.7652173913043, -0.075, 0.22727272727273
96969, 1.7652173913043, -0.1, 0.20454545454545
96970, 1.7434782608696, -0.1, 0.18181818181818
96971, 1.7652173913043, -0.075, 0.18181818181818
96972, 1.7652173913043, -0.1, 0.15909090909091
96973, 1.7434782608696, -0.1, 0.13636363636364
96974, 1.7652173913043, -0.075, 0.13636363636364
96975, 1.7652173913043, -0.1, 0.11363636363636
96976, 1.7434782608696, -0.1, 0.090909090909091
96977, 1.7652173913043, -0.075, 0.090909090909091
96978, 1.7652173913043, -0.1, 0.068181818181818
96979, 1.7434782608696, -0.1, 0.045454545454545
96980, 1.7652173913043, -0.075, 0.045454545454545
96981, 1.7652173913043, -0.1, 0.022727272727273
96982, 1.8086956521739, -0.1, 0.47727272727273
96983, 1.7869565217391, -0.1, 0.45454545454545
96984, 1.8086956521739, -0.075, 0.45454545454545
96985, 1.8086956521739, -0.1, 0.43181818181818
96986, 1.7869565217391, -0.1, 0.40909090909091
96987, 1.8086956521739, -0.075, 0.40909090909091
96988, 1.8086956521739, -0.1, 0.38636363636364
96989, 1.7869565217391, -0.1, 0.36363636363636
96990, 1.8086956521739, -0.075, 0.36363636363636
96991, 1.8086956521739, -0.1, 0.34090909090909
96992, 1.7869565217391, -0.1, 0.31818181818182
96993, 1.8086956521739, -0.075, 0.31818181818182
96994, 1.8086956521739, -0.1, 0.29545454545455
96995, 1.7869565217391, -0.1, 0.27272727272727
96996, 1.8086956521739, -0.075, 0.27272727272727
96997, 1.8086956521739, -0.1, 0.25
96998, 1.7869565217391, -0.1, 0.22727272727273
96999, 1.8086956521739, -0.075, 0.22727272727273
97000, 1.8086956521739, -0.1, 0.20454545454545
97001, 1.7869565217391, -0.1, 0.18181818181818
97002, 1.8086956521739, -0.075, 0.18181818181818
97003, 1.8086956521739, -0.1, 0.15909090909091
97004, 1.7869565217391, -0.1, 0.13636363636364
97005, 1.8086956521739, -0.075, 0.13636363636364
97006, 1.8086956521739, -0.1, 0.11363636363636
97007, 1.7869565217391, -0.1, 0.090909090909091
97008, 1.8086956521739, -0.075, 0.090909090909091
97009, 1.8086956521739, -0.1, 0.068181818181818
97010, 1.7869565217391, -0.1, 0.045454545454545
97011, 1.8086956521739, -0.075, 0.045454545454545
97012, 1.8086956521739, -0.1, 0.022727272727273
97013, 1.8521739130435, -0.1, 0.47727272727273
97014, 1.8304347826087, -0.1, 0.45454545454545
97015, 1.8521739130435, -0.075, 0.45454545454545
97016, 1.8521739130435, -0.1, 0.43181818181818
97017, 1.8304347826087, -0.1, 0.40909090909091
97018, 1.8521739130435, -0.075, 0.40909090909091
97019, 1.8521739130435, -0.1, 0.38636363636364
97020, 1.8304347826087, -0.1, 0.36363636363636
97021, 1.8521739130435, -0.075, 0.36363636363636
97022, 1.8521739130435, -0.1, 0.34090909090909
97023, 1.8304347826087, -0.1, 0.31818181818182
97024, 1.8521739130435, -0.075, 0.31818181818182
97025, 1.8521739130435, -0.1, 0.29545454545455
97026, 1.8304347826087, -0.1, 0.27272727272727
97027, 1.8521739130435, -0.075, 0.27272727272727
97028, 1.8521739130435, -0.1, 0.25
97029, 1.8304347826087, -0.1, 0.22727272727273
97030, 1.8521739130435, -0.075, 0.22727272727273
97031, 1.8521739130435, -0.1, 0.20454545454545
97032, 1.8304347826087, -0.1, 0.18181818181818
97033, 1.8521739130435, -0.075, 0.18181818181818
97034, 1.8521739130435, -0.1, 0.15909090909091
97035, 1.8304347826087, -0.1, 0.13636363636364
97036, 1.8521739130435, -0.075, 0.13636363636364
97037, 1.8521739130435, -0.1, 0.11363636363636
97038, 1.8304347826087, -0.1, 0.090909090909091
97039, 1.8521739130435, -0.075, 0.090909090909091
97040, 1.8521739130435, -0.1, 0.068181818181818
97041, 1.8304347826087, -0.1, 0.045454545454545
97042, 1.8521739130435, -0.075, 0.045454545454545
97043, 1.8521739130435, -0.1, 0.022727272727273
97044, 1.895652173913, -0.1, 0.47727272727273
97045, 1.8739130434783, -0.1, 0.45454545454545
97046, 1.895652173913, -0.075, 0.45454545454545
97047, 1.895652173913, -0.1, 0.43181818181818
97048, 1.8739130434783, -0.1, 0.40909090909091
97049, 1.895652173913, -0.075, 0.40909090909091
97050, 1.895652173913, -0.1, 0.38636363636364
97051, 1.8739130434783, -0.1, 0.36363636363636
97052, 1.895652173913, -0.075, 0.36363636363636
97053, 1.895652173913, -0.1, 0.34090909090909
97054, 1.8739130434783, -0.1, 0.31818181818182
97055, 1.895652173913, -0.075, 0.31818181818182
97056, 1.895652173913, -0.1, 0.29545454545455
97057, 1.8739130434783, -0.1, 0.27272727272727
97058, 1.895652173913, -0.075, 0.27272727272727
97059, 1.895652173913, -0.1, 0.25
97060, 1.8739130434783, -0.1, 0.22727272727273
97061, 1.895652173913, -0.075, 0.22727272727273
97062, 1.895652173913, -0.1, 0.20454545454545
97063, 1.8739130434783, -0.1, 0.18181818181818
97064, 1.895652173913, -0.075, 0.18181818181818
97065, 1.895652173913, -0.1, 0.15909090909091
97066, 1.8739130434783, -0.1, 0.13636363636364
97067, 1.895652173913, -0.075, 0.13636363636364
97068, 1.895652173913, -0.1, 0.11363636363636
97069, 1.8739130434783, -0.1, 0.090909090909091
97070, 1.895652173913, -0.075, 0.090909090909091
97071, 1.895652173913, -0.1, 0.068181818181818
97072, 1.8739130434783, -0.1, 0.045454545454545
97073, 1.895652173913, -0.075, 0.045454545454545
97074, 1.895652173913, -0.1, 0.022727272727273
97075, 1.9391304347826, -0.1, 0.47727272727273
97076, 1.9173913043478, -0.1, 0.45454545454545
97077, 1.9391304347826, -0.075, 0.45454545454545
97078, 1.9391304347826, -0.1, 0.43181818181818
97079, 1.9173913043478, -0.1, 0.40909090909091
97080, 1.9391304347826, -0.075, 0.40909090909091
97081, 1.9391304347826, -0.1, 0.38636363636364
97082, 1.9173913043478, -0.1, 0.36363636363636
97083, 1.9391304347826, -0.075, 0.36363636363636
97084, 1.9391304347826, -0.1, 0.34090909090909
97085, 1.9173913043478, -0.1, 0.31818181818182
97086, 1.9391304347826, -0.075, 0.31818181818182
97087, 1.9391304347826, -0.1, 0.29545454545455
97088, 1.9173913043478, -0.1, 0.27272727272727
97089, 1.9391304347826, -0.075, 0.27272727272727
97090, 1.9391304347826, -0.1, 0.25
97091, 1.9173913043478, -0.1, 0.22727272727273
97092, 1.9391304347826, -0.075, 0.22727272727273
97093, 1.9391304347826, -0.1, 0.20454545454545
97094, 1.9173913043478, -0.1, 0.18181818181818
97095, 1.9391304347826, -0.075, 0.18181818181818
97096, 1.9391304347826, -0.1, 0.15909090909091
97097, 1.9173913043478, -0.1, 0.13636363636364
97098, 1.9391304347826, -0.075, 0.13636363636364
97099, 1.9391304347826, -0.1, 0.11363636363636
97100, 1.9173913043478, -0.1, 0.090909090909091
97101, 1.9391304347826, -0.075, 0.090909090909091
97102, 1.9391304347826, -0.1, 0.068181818181818
97103, 1.9173913043478, -0.1, 0.045454545454545
97104, 1.9391304347826, -0.075, 0.045454545454545
97105, 1.9391304347826, -0.1, 0.022727272727273
97106, 1.9826086956522, -0.1, 0.47727272727273
97107, 1.9608695652174, -0.1, 0.45454545454545
97108, 1.9826086956522, -0.075, 0.45454545454545
97109, 1.9826086956522, -0.1, 0.43181818181818
97110, 1.9608695652174, -0.1, 0.40909090909091
97111, 1.9826086956522, -0.075, 0.40909090909091
97112, 1.9826086956522, -0.1, 0.38636363636364
97113, 1.9608695652174, -0.1, 0.36363636363636
97114, 1.9826086956522, -0.075, 0.36363636363636
97115, 1.9826086956522, -0.1, 0.34090909090909
97116, 1.9608695652174, -0.1, 0.31818181818182
97117, 1.9826086956522, -0.075, 0.31818181818182
97118, 1.9826086956522, -0.1, 0.29545454545455
97119, 1.9608695652174, -0.1, 0.27272727272727
97120, 1.9826086956522, -0.075, 0.27272727272727
97121, 1.9826086956522, -0.1, 0.25
97122, 1.9608695652174, -0.1, 0.22727272727273
97123, 1.9826086956522, -0.075, 0.22727272727273
97124, 1.9826086956522, -0.1, 0.20454545454545
97125, 1.9608695652174, -0.1, 0.18181818181818
97126, 1.9826086956522, -0.075, 0.18181818181818
97127, 1.9826086956522, -0.1, 0.15909090909091
97128, 1.9608695652174, -0.1, 0.13636363636364
97129, 1.9826086956522, -0.075, 0.13636363636364
97130, 1.9826086956522, -0.1, 0.11363636363636
97131, 1.9608695652174, -0.1, 0.090909090909091
97132, 1.9826086956522, -0.075, 0.090909090909091
97133, 1.9826086956522, -0.1, 0.068181818181818
97134, 1.9608695652174, -0.1, 0.045454545454545
97135, 1.9826086956522, -0.075, 0.045454545454545
97136, 1.9826086956522, -0.1, 0.022727272727273
97137, 2.0260869565217, -0.1, 0.47727272727273
97138, 2.004347826087, -0.1, 0.45454545454545
97139, 2.0260869565217, -0.075, 0.45454545454545
97140, 2.0260869565217, -0.1, 0.43181818181818
97141, 2.004347826087, -0.1, 0.40909090909091
97142, 2.0260869565217, -0.075, 0.40909090909091
97143, 2.0260869565217, -0.1, 0.38636363636364
97144, 2.004347826087, -0.1, 0.36363636363636
97145, 2.0260869565217, -0.075, 0.36363636363636
97146, 2.0260869565217, -0.1, 0.34090909090909
97147, 2.004347826087, -0.1, 0.31818181818182
97148, 2.0260869565217, -0.075, 0.31818181818182
97149, 2.0260869565217, -0.1, 0.29545454545455
97150, 2.004347826087, -0.1, 0.27272727272727
97151, 2.0260869565217, -0.075, 0.27272727272727
97152, 2.0260869565217, -0.1, 0.25
97153, 2.004347826087, -0.1, 0.22727272727273
97154, 2.0260869565217, -0.075, 0.22727272727273
97155, 2.0260869565217, -0.1, 0.20454545454545
97156, 2.004347826087, -0.1, 0.18181818181818
97157, 2.0260869565217, -0.075, 0.18181818181818
97158, 2.0260869565217, -0.1, 0.15909090909091
97159, 2.004347826087, -0.1, 0.13636363636364
97160, 2.0260869565217, -0.075, 0.13636363636364
97161, 2.0260869565217, -0.1, 0.11363636363636
97162, 2.004347826087, -0.1, 0.090909090909091
97163, 2.0260869565217, -0.075, 0.090909090909091
97164, 2.0260869565217, -0.1, 0.068181818181818
97165, 2.004347826087, -0.1, 0.045454545454545
97166, 2.0260869565217, -0.075, 0.045454545454545
97167, 2.0260869565217, -0.1, 0.022727272727273
97168, 2.0695652173913, -0.1, 0.47727272727273
97169, 2.0478260869565, -0.1, 0.45454545454545
97170, 2.0695652173913, -0.075, 0.45454545454545
97171, 2.0695652173913, -0.1, 0.43181818181818
97172, 2.0478260869565, -0.1, 0.40909090909091
97173, 2.0695652173913, -0.075, 0.40909090909091
97174, 2.0695652173913, -0.1, 0.38636363636364
97175, 2.0478260869565, -0.1, 0.36363636363636
97176, 2.0695652173913, -0.075, 0.36363636363636
97177, 2.0695652173913, -0.1, 0.34090909090909
97178, 2.0478260869565, -0.1, 0.31818181818182
97179, 2.0695652173913, -0.075, 0.31818181818182
97180, 2.0695652173913, -0.1, 0.29545454545455
97181, 2.0478260869565, -0.1, 0.27272727272727
97182, 2.0695652173913, -0.075, 0.27272727272727
97183, 2.0695652173913, -0.1, 0.25
97184, 2.0478260869565, -0.1, 0.22727272727273
97185, 2.0695652173913, -0.075, 0.22727272727273
97186, 2.0695652173913, -0.1, 0.20454545454545
97187, 2.0478260869565, -0.1, 0.18181818181818
97188, 2.0695652173913, -0.075, 0.18181818181818
97189, 2.0695652173913, -0.1, 0.15909090909091
97190, 2.0478260869565, -0.1, 0.13636363636364
97191, 2.0695652173913, -0.075, 0.13636363636364
97192, 2.0695652173913, -0.1, 0.11363636363636
97193, 2.0478260869565, -0.1, 0.090909090909091
97194, 2.0695652173913, -0.075, 0.090909090909091
97195, 2.0695652173913, -0.1, 0.068181818181818
97196, 2.0478260869565, -0.1, 0.045454545454545
97197, 2.0695652173913, -0.075, 0.045454545454545
97198, 2.0695652173913, -0.1, 0.022727272727273
97199, 2.1130434782609, -0.1, 0.47727272727273
97200, 2.0913043478261, -0.1, 0.45454545454545
97201, 2.1130434782609, -0.075, 0.45454545454545
97202, 2.1130434782609, -0.1, 0.43181818181818
97203, 2.0913043478261, -0.1, 0.40909090909091
97204, 2.1130434782609, -0.075, 0.40909090909091
97205, 2.1130434782609, -0.1, 0.38636363636364
97206, 2.0913043478261, -0.1, 0.36363636363636
97207, 2.1130434782609, -0.075, 0.36363636363636
97208, 2.1130434782609, -0.1, 0.34090909090909
97209, 2.0913043478261, -0.1, 0.31818181818182
97210, 2.1130434782609, -0.075, 0.31818181818182
97211, 2.1130434782609, -0.1, 0.29545454545455
97212, 2.0913043478261, -0.1, 0.27272727272727
97213, 2.1130434782609, -0.075, 0.27272727272727
97214, 2.1130434782609, -0.1, 0.25
97215, 2.0913043478261, -0.1, 0.22727272727273
97216, 2.1130434782609, -0.075, 0.22727272727273
97217, 2.1130434782609, -0.1, 0.20454545454545
97218, 2.0913043478261, -0.1, 0.18181818181818
97219, 2.1130434782609, -0.075, 0.18181818181818
97220, 2.1130434782609, -0.1, 0.15909090909091
97221, 2.0913043478261, -0.1, 0.13636363636364
97222, 2.1130434782609, -0.075, 0.13636363636364
97223, 2.1130434782609, -0.1, 0.11363636363636
97224, 2.0913043478261, -0.1, 0.090909090909091
97225, 2.1130434782609, -0.075, 0.090909090909091
97226, 2.1130434782609, -0.1, 0.068181818181818
97227, 2.0913043478261, -0.1, 0.045454545454545
97228, 2.1130434782609, -0.075, 0.045454545454545
97229, 2.1130434782609, -0.1, 0.022727272727273
97230, 2.1565217391304, -0.1, 0.47727272727273
97231, 2.1347826086957, -0.1, 0.45454545454545
97232, 2.1565217391304, -0.075, 0.45454545454545
97233, 2.1565217391304, -0.1, 0.43181818181818
97234, 2.1347826086957, -0.1, 0.40909090909091
97235, 2.1565217391304, -0.075, 0.40909090909091
97236, 2.1565217391304, -0.1, 0.38636363636364
97237, 2.1347826086957, -0.1, 0.36363636363636
97238, 2.1565217391304, -0.075, 0.36363636363636
97239, 2.1565217391304, -0.1, 0.34090909090909
97240, 2.1347826086957, -0.1, 0.31818181818182
97241, 2.1565217391304, -0.075, 0.31818181818182
97242, 2.1565217391304, -0.1, 0.29545454545455
97243, 2.1347826086957, -0.1, 0.27272727272727
97244, 2.1565217391304, -0.075, 0.27272727272727
97245, 2.1565217391304, -0.1, 0.25
97246, 2.1347826086957, -0.1, 0.22727272727273
97247, 2.1565217391304, -0.075, 0.22727272727273
97248, 2.1565217391304, -0.1, 0.20454545454545
97249, 2.1347826086957, -0.1, 0.18181818181818
97250, 2.1565217391304, -0.075, 0.18181818181818
97251, 2.1565217391304, -0.1, 0.15909090909091
97252, 2.1347826086957, -0.1, 0.13636363636364
97253, 2.1565217391304, -0.075, 0.13636363636364
97254, 2.1565217391304, -0.1, 0.11363636363636
97255, 2.1347826086957, -0.1, 0.090909090909091
97256, 2.1565217391304, -0.075, 0.090909090909091
97257, 2.1565217391304, -0.1, 0.068181818181818
97258, 2.1347826086957, -0.1, 0.045454545454545
97259, 2.1565217391304, -0.075, 0.045454545454545
97260, 2.1565217391304, -0.1, 0.022727272727273
97261, 2.1782608695652, -0.1, 0.45454545454545
97262, 2.1782608695652, -0.1, 0.40909090909091
97263, 2.1782608695652, -0.1, 0.36363636363636
97264, 2.1782608695652, -0.1, 0.31818181818182
97265, 2.1782608695652, -0.1, 0.27272727272727
97266, 2.1782608695652, -0.1, 0.22727272727273
97267, 2.1782608695652, -0.1, 0.18181818181818
97268, 2.1782608695652, -0.1, 0.13636363636364
97269, 2.1782608695652, -0.1, 0.090909090909091
97270, 2.1782608695652, -0.1, 0.045454545454545
97271, 1.2434782608696, -0.15, 0.47727272727273
97272, 1.2217391304348, -0.15, 0.45454545454545
97273, 1.2434782608696, -0.125, 0.45454545454545
97274, 1.2434782608696, -0.15, 0.43181818181818
97275, 1.2217391304348, -0.15, 0.40909090909091
97276, 1.2434782608696, -0.125, 0.40909090909091
97277, 1.2434782608696, -0.15, 0.38636363636364
97278, 1.2217391304348, -0.15, 0.36363636363636
97279, 1.2434782608696, -0.125, 0.36363636363636
97280, 1.2434782608696, -0.15, 0.34090909090909
97281, 1.2217391304348, -0.15, 0.31818181818182
97282, 1.2434782608696, -0.125, 0.31818181818182
97283, 1.2434782608696, -0.15, 0.29545454545455
97284, 1.2217391304348, -0.15, 0.27272727272727
97285, 1.2434782608696, -0.125, 0.27272727272727
97286, 1.2434782608696, -0.15, 0.25
97287, 1.2217391304348, -0.15, 0.22727272727273
97288, 1.2434782608696, -0.125, 0.22727272727273
97289, 1.2434782608696, -0.15, 0.20454545454545
97290, 1.2217391304348, -0.15, 0.18181818181818
97291, 1.2434782608696, -0.125, 0.18181818181818
97292, 1.2434782608696, -0.15, 0.15909090909091
97293, 1.2217391304348, -0.15, 0.13636363636364
97294, 1.2434782608696, -0.125, 0.13636363636364
97295, 1.2434782608696, -0.15, 0.11363636363636
97296, 1.2217391304348, -0.15, 0.090909090909091
97297, 1.2434782608696, -0.125, 0.090909090909091
97298, 1.2434782608696, -0.15, 0.068181818181818
97299, 1.2217391304348, -0.15, 0.045454545454545
97300, 1.2434782608696, -0.125, 0.045454545454545
97301, 1.2434782608696, -0.15, 0.022727272727273
97302, 1.2869565217391, -0.15, 0.47727272727273
97303, 1.2652173913043, -0.15, 0.45454545454545
97304, 1.2869565217391, -0.125, 0.45454545454545
97305, 1.2869565217391, -0.15, 0.43181818181818
97306, 1.2652173913043, -0.15, 0.40909090909091
97307, 1.2869565217391, -0.125, 0.40909090909091
97308, 1.2869565217391, -0.15, 0.38636363636364
97309, 1.2652173913043, -0.15, 0.36363636363636
97310, 1.2869565217391, -0.125, 0.36363636363636
97311, 1.2869565217391, -0.15, 0.34090909090909
97312, 1.2652173913043, -0.15, 0.31818181818182
97313, 1.2869565217391, -0.125, 0.31818181818182
97314, 1.2869565217391, -0.15, 0.29545454545455
97315, 1.2652173913043, -0.15, 0.27272727272727
97316, 1.2869565217391, -0.125, 0.27272727272727
97317, 1.2869565217391, -0.15, 0.25
97318, 1.2652173913043, -0.15, 0.22727272727273
97319, 1.2869565217391, -0.125, 0.22727272727273
97320, 1.2869565217391, -0.15, 0.20454545454545
97321, 1.2652173913043, -0.15, 0.18181818181818
97322, 1.2869565217391, -0.125, 0.18181818181818
97323, 1.2869565217391, -0.15, 0.15909090909091
97324, 1.2652173913043, -0.15, 0.13636363636364
97325, 1.2869565217391, -0.125, 0.13636363636364
97326, 1.2869565217391, -0.15, 0.11363636363636
97327, 1.2652173913043, -0.15, 0.090909090909091
97328, 1.2869565217391, -0.125, 0.090909090909091
97329, 1.2869565217391, -0.15, 0.068181818181818
97330, 1.2652173913043, -0.15, 0.045454545454545
97331, 1.2869565217391, -0.125, 0.045454545454545
97332, 1.2869565217391, -0.15, 0.022727272727273
97333, 1.3304347826087, -0.15, 0.47727272727273
97334, 1.3086956521739, -0.15, 0.45454545454545
97335, 1.3304347826087, -0.125, 0.45454545454545
97336, 1.3304347826087, -0.15, 0.43181818181818
97337, 1.3086956521739, -0.15, 0.40909090909091
97338, 1.3304347826087, -0.125, 0.40909090909091
97339, 1.3304347826087, -0.15, 0.38636363636364
97340, 1.3086956521739, -0.15, 0.36363636363636
97341, 1.3304347826087, -0.125, 0.36363636363636
97342, 1.3304347826087, -0.15, 0.34090909090909
97343, 1.3086956521739, -0.15, 0.31818181818182
97344, 1.3304347826087, -0.125, 0.31818181818182
97345, 1.3304347826087, -0.15, 0.29545454545455
97346, 1.3086956521739, -0.15, 0.27272727272727
97347, 1.3304347826087, -0.125, 0.27272727272727
97348, 1.3304347826087, -0.15, 0.25
97349, 1.3086956521739, -0.15, 0.22727272727273
97350, 1.3304347826087, -0.125, 0.22727272727273
97351, 1.3304347826087, -0.15, 0.20454545454545
97352, 1.3086956521739, -0.15, 0.18181818181818
97353, 1.3304347826087, -0.125, 0.18181818181818
97354, 1.3304347826087, -0.15, 0.15909090909091
97355, 1.3086956521739, -0.15, 0.13636363636364
97356, 1.3304347826087, -0.125, 0.13636363636364
97357, 1.3304347826087, -0.15, 0.11363636363636
97358, 1.3086956521739, -0.15, 0.090909090909091
97359, 1.3304347826087, -0.125, 0.090909090909091
97360, 1.3304347826087, -0.15, 0.068181818181818
97361, 1.3086956521739, -0.15, 0.045454545454545
97362, 1.3304347826087, -0.125, 0.045454545454545
97363, 1.3304347826087, -0.15, 0.022727272727273
97364, 1.3739130434783, -0.15, 0.47727272727273
97365, 1.3521739130435, -0.15, 0.45454545454545
97366, 1.3739130434783, -0.125, 0.45454545454545
97367, 1.3739130434783, -0.15, 0.43181818181818
97368, 1.3521739130435, -0.15, 0.40909090909091
97369, 1.3739130434783, -0.125, 0.40909090909091
97370, 1.3739130434783, -0.15, 0.38636363636364
97371, 1.3521739130435, -0.15, 0.36363636363636
97372, 1.3739130434783, -0.125, 0.36363636363636
97373, 1.3739130434783, -0.15, 0.34090909090909
97374, 1.3521739130435, -0.15, 0.31818181818182
97375, 1.3739130434783, -0.125, 0.31818181818182
97376, 1.3739130434783, -0.15, 0.29545454545455
97377, 1.3521739130435, -0.15, 0.27272727272727
97378, 1.3739130434783, -0.125, 0.27272727272727
97379, 1.3739130434783, -0.15, 0.25
97380, 1.3521739130435, -0.15, 0.22727272727273
97381, 1.3739130434783, -0.125, 0.22727272727273
97382, 1.3739130434783, -0.15, 0.20454545454545
97383, 1.3521739130435, -0.15, 0.18181818181818
97384, 1.3739130434783, -0.125, 0.18181818181818
97385, 1.3739130434783, -0.15, 0.15909090909091
97386, 1.3521739130435, -0.15, 0.13636363636364
97387, 1.3739130434783, -0.125, 0.13636363636364
97388, 1.3739130434783, -0.15, 0.11363636363636
97389, 1.3521739130435, -0.15, 0.090909090909091
97390, 1.3739130434783, -0.125, 0.090909090909091
97391, 1.3739130434783, -0.15, 0.068181818181818
97392, 1.3521739130435, -0.15, 0.045454545454545
97393, 1.3739130434783, -0.125, 0.045454545454545
97394, 1.3739130434783, -0.15, 0.022727272727273
97395, 1.4173913043478, -0.15, 0.47727272727273
97396, 1.395652173913, -0.15, 0.45454545454545
97397, 1.4173913043478, -0.125, 0.45454545454545
97398, 1.4173913043478, -0.15, 0.43181818181818
97399, 1.395652173913, -0.15, 0.40909090909091
97400, 1.4173913043478, -0.125, 0.40909090909091
97401, 1.4173913043478, -0.15, 0.38636363636364
97402, 1.395652173913, -0.15, 0.36363636363636
97403, 1.4173913043478, -0.125, 0.36363636363636
97404, 1.4173913043478, -0.15, 0.34090909090909
97405, 1.395652173913, -0.15, 0.31818181818182
97406, 1.4173913043478, -0.125, 0.31818181818182
97407, 1.4173913043478, -0.15, 0.29545454545455
97408, 1.395652173913, -0.15, 0.27272727272727
97409, 1.4173913043478, -0.125, 0.27272727272727
97410, 1.4173913043478, -0.15, 0.25
97411, 1.395652173913, -0.15, 0.22727272727273
97412, 1.4173913043478, -0.125, 0.22727272727273
97413, 1.4173913043478, -0.15, 0.20454545454545
97414, 1.395652173913, -0.15, 0.18181818181818
97415, 1.4173913043478, -0.125, 0.18181818181818
97416, 1.4173913043478, -0.15, 0.15909090909091
97417, 1.395652173913, -0.15, 0.13636363636364
97418, 1.4173913043478, -0.125, 0.13636363636364
97419, 1.4173913043478, -0.15, 0.11363636363636
97420, 1.395652173913, -0.15, 0.090909090909091
97421, 1.4173913043478, -0.125, 0.090909090909091
97422, 1.4173913043478, -0.15, 0.068181818181818
97423, 1.395652173913, -0.15, 0.045454545454545
97424, 1.4173913043478, -0.125, 0.045454545454545
97425, 1.4173913043478, -0.15, 0.022727272727273
97426, 1.4608695652174, -0.15, 0.47727272727273
97427, 1.4391304347826, -0.15, 0.45454545454545
97428, 1.4608695652174, -0.125, 0.45454545454545
97429, 1.4608695652174, -0.15, 0.43181818181818
97430, 1.4391304347826, -0.15, 0.40909090909091
97431, 1.4608695652174, -0.125, 0.40909090909091
97432, 1.4608695652174, -0.15, 0.38636363636364
97433, 1.4391304347826, -0.15, 0.36363636363636
97434, 1.4608695652174, -0.125, 0.36363636363636
97435, 1.4608695652174, -0.15, 0.34090909090909
97436, 1.4391304347826, -0.15, 0.31818181818182
97437, 1.4608695652174, -0.125, 0.31818181818182
97438, 1.4608695652174, -0.15, 0.29545454545455
97439, 1.4391304347826, -0.15, 0.27272727272727
97440, 1.4608695652174, -0.125, 0.27272727272727
97441, 1.4608695652174, -0.15, 0.25
97442, 1.4391304347826, -0.15, 0.22727272727273
97443, 1.4608695652174, -0.125, 0.22727272727273
97444, 1.4608695652174, -0.15, 0.20454545454545
97445, 1.4391304347826, -0.15, 0.18181818181818
97446, 1.4608695652174, -0.125, 0.18181818181818
97447, 1.4608695652174, -0.15, 0.15909090909091
97448, 1.4391304347826, -0.15, 0.13636363636364
97449, 1.4608695652174, -0.125, 0.13636363636364
97450, 1.4608695652174, -0.15, 0.11363636363636
97451, 1.4391304347826, -0.15, 0.090909090909091
97452, 1.4608695652174, -0.125, 0.090909090909091
97453, 1.4608695652174, -0.15, 0.068181818181818
97454, 1.4391304347826, -0.15, 0.045454545454545
97455, 1.4608695652174, -0.125, 0.045454545454545
97456, 1.4608695652174, -0.15, 0.022727272727273
97457, 1.504347826087, -0.15, 0.47727272727273
97458, 1.4826086956522, -0.15, 0.45454545454545
97459, 1.504347826087, -0.125, 0.45454545454545
97460, 1.504347826087, -0.15, 0.43181818181818
97461, 1.4826086956522, -0.15, 0.40909090909091
97462, 1.504347826087, -0.125, 0.40909090909091
97463, 1.504347826087, -0.15, 0.38636363636364
97464, 1.4826086956522, -0.15, 0.36363636363636
97465, 1.504347826087, -0.125, 0.36363636363636
97466, 1.504347826087, -0.15, 0.34090909090909
97467, 1.4826086956522, -0.15, 0.31818181818182
97468, 1.504347826087, -0.125, 0.31818181818182
97469, 1.504347826087, -0.15, 0.29545454545455
97470, 1.4826086956522, -0.15, 0.27272727272727
97471, 1.504347826087, -0.125, 0.27272727272727
97472, 1.504347826087, -0.15, 0.25
97473, 1.4826086956522, -0.15, 0.22727272727273
97474, 1.504347826087, -0.125, 0.22727272727273
97475, 1.504347826087, -0.15, 0.20454545454545
97476, 1.4826086956522, -0.15, 0.18181818181818
97477, 1.504347826087, -0.125, 0.18181818181818
97478, 1.504347826087, -0.15, 0.15909090909091
97479, 1.4826086956522, -0.15, 0.13636363636364
97480, 1.504347826087, -0.125, 0.13636363636364
97481, 1.504347826087, -0.15, 0.11363636363636
97482, 1.4826086956522, -0.15, 0.090909090909091
97483, 1.504347826087, -0.125, 0.090909090909091
97484, 1.504347826087, -0.15, 0.068181818181818
97485, 1.4826086956522, -0.15, 0.045454545454545
97486, 1.504347826087, -0.125, 0.045454545454545
97487, 1.504347826087, -0.15, 0.022727272727273
97488, 1.5478260869565, -0.15, 0.47727272727273
97489, 1.5260869565217, -0.15, 0.45454545454545
97490, 1.5478260869565, -0.125, 0.45454545454545
97491, 1.5478260869565, -0.15, 0.43181818181818
97492, 1.5260869565217, -0.15, 0.40909090909091
97493, 1.5478260869565, -0.125, 0.40909090909091
97494, 1.5478260869565, -0.15, 0.38636363636364
97495, 1.5260869565217, -0.15, 0.36363636363636
97496, 1.5478260869565, -0.125, 0.36363636363636
97497, 1.5478260869565, -0.15, 0.34090909090909
97498, 1.5260869565217, -0.15, 0.31818181818182
97499, 1.5478260869565, -0.125, 0.31818181818182
97500, 1.5478260869565, -0.15, 0.29545454545455
97501, 1.5260869565217, -0.15, 0.27272727272727
97502, 1.5478260869565, -0.125, 0.27272727272727
97503, 1.5478260869565, -0.15, 0.25
97504, 1.5260869565217, -0.15, 0.22727272727273
97505, 1.5478260869565, -0.125, 0.22727272727273
97506, 1.5478260869565, -0.15, 0.20454545454545
97507, 1.5260869565217, -0.15, 0.18181818181818
97508, 1.5478260869565, -0.125, 0.18181818181818
