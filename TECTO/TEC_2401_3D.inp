56907, 0.34782608695652, 1.4166666666667, 0.13636363636364
56908, 0.34782608695652, 1.4333333333333, 0.15909090909091
56909, 0.3695652173913, 1.4333333333333, 0.18181818181818
56910, 0.34782608695652, 1.4166666666667, 0.18181818181818
56911, 0.34782608695652, 1.4333333333333, 0.20454545454545
56912, 0.3695652173913, 1.4333333333333, 0.22727272727273
56913, 0.34782608695652, 1.4166666666667, 0.22727272727273
56914, 0.34782608695652, 1.4333333333333, 0.25
56915, 0.3695652173913, 1.4333333333333, 0.27272727272727
56916, 0.34782608695652, 1.4166666666667, 0.27272727272727
56917, 0.34782608695652, 1.4333333333333, 0.29545454545455
56918, 0.3695652173913, 1.4333333333333, 0.31818181818182
56919, 0.34782608695652, 1.4166666666667, 0.31818181818182
56920, 0.34782608695652, 1.4333333333333, 0.34090909090909
56921, 0.3695652173913, 1.4333333333333, 0.36363636363636
56922, 0.34782608695652, 1.4166666666667, 0.36363636363636
56923, 0.34782608695652, 1.4333333333333, 0.38636363636364
56924, 0.3695652173913, 1.4333333333333, 0.40909090909091
56925, 0.34782608695652, 1.4166666666667, 0.40909090909091
56926, 0.34782608695652, 1.4333333333333, 0.43181818181818
56927, 0.3695652173913, 1.4333333333333, 0.45454545454545
56928, 0.34782608695652, 1.4166666666667, 0.45454545454545
56929, 0.34782608695652, 1.4333333333333, 0.47727272727273
56930, 0.30434782608696, 1.4333333333333, 0.022727272727273
56931, 0.32608695652174, 1.4333333333333, 0.045454545454545
56932, 0.30434782608696, 1.4166666666667, 0.045454545454545
56933, 0.30434782608696, 1.4333333333333, 0.068181818181818
56934, 0.32608695652174, 1.4333333333333, 0.090909090909091
56935, 0.30434782608696, 1.4166666666667, 0.090909090909091
56936, 0.30434782608696, 1.4333333333333, 0.11363636363636
56937, 0.32608695652174, 1.4333333333333, 0.13636363636364
56938, 0.30434782608696, 1.4166666666667, 0.13636363636364
56939, 0.30434782608696, 1.4333333333333, 0.15909090909091
56940, 0.32608695652174, 1.4333333333333, 0.18181818181818
56941, 0.30434782608696, 1.4166666666667, 0.18181818181818
56942, 0.30434782608696, 1.4333333333333, 0.20454545454545
56943, 0.32608695652174, 1.4333333333333, 0.22727272727273
56944, 0.30434782608696, 1.4166666666667, 0.22727272727273
56945, 0.30434782608696, 1.4333333333333, 0.25
56946, 0.32608695652174, 1.4333333333333, 0.27272727272727
56947, 0.30434782608696, 1.4166666666667, 0.27272727272727
56948, 0.30434782608696, 1.4333333333333, 0.29545454545455
56949, 0.32608695652174, 1.4333333333333, 0.31818181818182
56950, 0.30434782608696, 1.4166666666667, 0.31818181818182
56951, 0.30434782608696, 1.4333333333333, 0.34090909090909
56952, 0.32608695652174, 1.4333333333333, 0.36363636363636
56953, 0.30434782608696, 1.4166666666667, 0.36363636363636
56954, 0.30434782608696, 1.4333333333333, 0.38636363636364
56955, 0.32608695652174, 1.4333333333333, 0.40909090909091
56956, 0.30434782608696, 1.4166666666667, 0.40909090909091
56957, 0.30434782608696, 1.4333333333333, 0.43181818181818
56958, 0.32608695652174, 1.4333333333333, 0.45454545454545
56959, 0.30434782608696, 1.4166666666667, 0.45454545454545
56960, 0.30434782608696, 1.4333333333333, 0.47727272727273
56961, 0.26086956521739, 1.4333333333333, 0.022727272727273
56962, 0.28260869565217, 1.4333333333333, 0.045454545454545
56963, 0.26086956521739, 1.4166666666667, 0.045454545454545
56964, 0.26086956521739, 1.4333333333333, 0.068181818181818
56965, 0.28260869565217, 1.4333333333333, 0.090909090909091
56966, 0.26086956521739, 1.4166666666667, 0.090909090909091
56967, 0.26086956521739, 1.4333333333333, 0.11363636363636
56968, 0.28260869565217, 1.4333333333333, 0.13636363636364
56969, 0.26086956521739, 1.4166666666667, 0.13636363636364
56970, 0.26086956521739, 1.4333333333333, 0.15909090909091
56971, 0.28260869565217, 1.4333333333333, 0.18181818181818
56972, 0.26086956521739, 1.4166666666667, 0.18181818181818
56973, 0.26086956521739, 1.4333333333333, 0.20454545454545
56974, 0.28260869565217, 1.4333333333333, 0.22727272727273
56975, 0.26086956521739, 1.4166666666667, 0.22727272727273
56976, 0.26086956521739, 1.4333333333333, 0.25
56977, 0.28260869565217, 1.4333333333333, 0.27272727272727
56978, 0.26086956521739, 1.4166666666667, 0.27272727272727
56979, 0.26086956521739, 1.4333333333333, 0.29545454545455
56980, 0.28260869565217, 1.4333333333333, 0.31818181818182
56981, 0.26086956521739, 1.4166666666667, 0.31818181818182
56982, 0.26086956521739, 1.4333333333333, 0.34090909090909
56983, 0.28260869565217, 1.4333333333333, 0.36363636363636
56984, 0.26086956521739, 1.4166666666667, 0.36363636363636
56985, 0.26086956521739, 1.4333333333333, 0.38636363636364
56986, 0.28260869565217, 1.4333333333333, 0.40909090909091
56987, 0.26086956521739, 1.4166666666667, 0.40909090909091
56988, 0.26086956521739, 1.4333333333333, 0.43181818181818
56989, 0.28260869565217, 1.4333333333333, 0.45454545454545
56990, 0.26086956521739, 1.4166666666667, 0.45454545454545
56991, 0.26086956521739, 1.4333333333333, 0.47727272727273
56992, 0.21739130434783, 1.4333333333333, 0.022727272727273
56993, 0.23913043478261, 1.4333333333333, 0.045454545454545
56994, 0.21739130434783, 1.4166666666667, 0.045454545454545
56995, 0.21739130434783, 1.4333333333333, 0.068181818181818
56996, 0.23913043478261, 1.4333333333333, 0.090909090909091
56997, 0.21739130434783, 1.4166666666667, 0.090909090909091
56998, 0.21739130434783, 1.4333333333333, 0.11363636363636
56999, 0.23913043478261, 1.4333333333333, 0.13636363636364
57000, 0.21739130434783, 1.4166666666667, 0.13636363636364
57001, 0.21739130434783, 1.4333333333333, 0.15909090909091
57002, 0.23913043478261, 1.4333333333333, 0.18181818181818
57003, 0.21739130434783, 1.4166666666667, 0.18181818181818
57004, 0.21739130434783, 1.4333333333333, 0.20454545454545
57005, 0.23913043478261, 1.4333333333333, 0.22727272727273
57006, 0.21739130434783, 1.4166666666667, 0.22727272727273
57007, 0.21739130434783, 1.4333333333333, 0.25
57008, 0.23913043478261, 1.4333333333333, 0.27272727272727
57009, 0.21739130434783, 1.4166666666667, 0.27272727272727
57010, 0.21739130434783, 1.4333333333333, 0.29545454545455
57011, 0.23913043478261, 1.4333333333333, 0.31818181818182
57012, 0.21739130434783, 1.4166666666667, 0.31818181818182
57013, 0.21739130434783, 1.4333333333333, 0.34090909090909
57014, 0.23913043478261, 1.4333333333333, 0.36363636363636
57015, 0.21739130434783, 1.4166666666667, 0.36363636363636
57016, 0.21739130434783, 1.4333333333333, 0.38636363636364
57017, 0.23913043478261, 1.4333333333333, 0.40909090909091
57018, 0.21739130434783, 1.4166666666667, 0.40909090909091
57019, 0.21739130434783, 1.4333333333333, 0.43181818181818
57020, 0.23913043478261, 1.4333333333333, 0.45454545454545
57021, 0.21739130434783, 1.4166666666667, 0.45454545454545
57022, 0.21739130434783, 1.4333333333333, 0.47727272727273
57023, 0.17391304347826, 1.4333333333333, 0.022727272727273
57024, 0.19565217391304, 1.4333333333333, 0.045454545454545
57025, 0.17391304347826, 1.4166666666667, 0.045454545454545
57026, 0.17391304347826, 1.4333333333333, 0.068181818181818
57027, 0.19565217391304, 1.4333333333333, 0.090909090909091
57028, 0.17391304347826, 1.4166666666667, 0.090909090909091
57029, 0.17391304347826, 1.4333333333333, 0.11363636363636
57030, 0.19565217391304, 1.4333333333333, 0.13636363636364
57031, 0.17391304347826, 1.4166666666667, 0.13636363636364
57032, 0.17391304347826, 1.4333333333333, 0.15909090909091
57033, 0.19565217391304, 1.4333333333333, 0.18181818181818
57034, 0.17391304347826, 1.4166666666667, 0.18181818181818
57035, 0.17391304347826, 1.4333333333333, 0.20454545454545
57036, 0.19565217391304, 1.4333333333333, 0.22727272727273
57037, 0.17391304347826, 1.4166666666667, 0.22727272727273
57038, 0.17391304347826, 1.4333333333333, 0.25
57039, 0.19565217391304, 1.4333333333333, 0.27272727272727
57040, 0.17391304347826, 1.4166666666667, 0.27272727272727
57041, 0.17391304347826, 1.4333333333333, 0.29545454545455
57042, 0.19565217391304, 1.4333333333333, 0.31818181818182
57043, 0.17391304347826, 1.4166666666667, 0.31818181818182
57044, 0.17391304347826, 1.4333333333333, 0.34090909090909
57045, 0.19565217391304, 1.4333333333333, 0.36363636363636
57046, 0.17391304347826, 1.4166666666667, 0.36363636363636
57047, 0.17391304347826, 1.4333333333333, 0.38636363636364
57048, 0.19565217391304, 1.4333333333333, 0.40909090909091
57049, 0.17391304347826, 1.4166666666667, 0.40909090909091
57050, 0.17391304347826, 1.4333333333333, 0.43181818181818
57051, 0.19565217391304, 1.4333333333333, 0.45454545454545
57052, 0.17391304347826, 1.4166666666667, 0.45454545454545
57053, 0.17391304347826, 1.4333333333333, 0.47727272727273
57054, 0.1304347826087, 1.4333333333333, 0.022727272727273
57055, 0.15217391304348, 1.4333333333333, 0.045454545454545
57056, 0.1304347826087, 1.4166666666667, 0.045454545454545
57057, 0.1304347826087, 1.4333333333333, 0.068181818181818
57058, 0.15217391304348, 1.4333333333333, 0.090909090909091
57059, 0.1304347826087, 1.4166666666667, 0.090909090909091
57060, 0.1304347826087, 1.4333333333333, 0.11363636363636
57061, 0.15217391304348, 1.4333333333333, 0.13636363636364
57062, 0.1304347826087, 1.4166666666667, 0.13636363636364
57063, 0.1304347826087, 1.4333333333333, 0.15909090909091
57064, 0.15217391304348, 1.4333333333333, 0.18181818181818
57065, 0.1304347826087, 1.4166666666667, 0.18181818181818
57066, 0.1304347826087, 1.4333333333333, 0.20454545454545
57067, 0.15217391304348, 1.4333333333333, 0.22727272727273
57068, 0.1304347826087, 1.4166666666667, 0.22727272727273
57069, 0.1304347826087, 1.4333333333333, 0.25
57070, 0.15217391304348, 1.4333333333333, 0.27272727272727
57071, 0.1304347826087, 1.4166666666667, 0.27272727272727
57072, 0.1304347826087, 1.4333333333333, 0.29545454545455
57073, 0.15217391304348, 1.4333333333333, 0.31818181818182
57074, 0.1304347826087, 1.4166666666667, 0.31818181818182
57075, 0.1304347826087, 1.4333333333333, 0.34090909090909
57076, 0.15217391304348, 1.4333333333333, 0.36363636363636
57077, 0.1304347826087, 1.4166666666667, 0.36363636363636
57078, 0.1304347826087, 1.4333333333333, 0.38636363636364
57079, 0.15217391304348, 1.4333333333333, 0.40909090909091
57080, 0.1304347826087, 1.4166666666667, 0.40909090909091
57081, 0.1304347826087, 1.4333333333333, 0.43181818181818
57082, 0.15217391304348, 1.4333333333333, 0.45454545454545
57083, 0.1304347826087, 1.4166666666667, 0.45454545454545
57084, 0.1304347826087, 1.4333333333333, 0.47727272727273
57085, 0.08695652173913, 1.4333333333333, 0.022727272727273
57086, 0.10869565217391, 1.4333333333333, 0.045454545454545
57087, 0.08695652173913, 1.4166666666667, 0.045454545454545
57088, 0.08695652173913, 1.4333333333333, 0.068181818181818
57089, 0.10869565217391, 1.4333333333333, 0.090909090909091
57090, 0.08695652173913, 1.4166666666667, 0.090909090909091
57091, 0.08695652173913, 1.4333333333333, 0.11363636363636
57092, 0.10869565217391, 1.4333333333333, 0.13636363636364
57093, 0.08695652173913, 1.4166666666667, 0.13636363636364
57094, 0.08695652173913, 1.4333333333333, 0.15909090909091
57095, 0.10869565217391, 1.4333333333333, 0.18181818181818
57096, 0.08695652173913, 1.4166666666667, 0.18181818181818
57097, 0.08695652173913, 1.4333333333333, 0.20454545454545
57098, 0.10869565217391, 1.4333333333333, 0.22727272727273
57099, 0.08695652173913, 1.4166666666667, 0.22727272727273
57100, 0.08695652173913, 1.4333333333333, 0.25
57101, 0.10869565217391, 1.4333333333333, 0.27272727272727
57102, 0.08695652173913, 1.4166666666667, 0.27272727272727
57103, 0.08695652173913, 1.4333333333333, 0.29545454545455
57104, 0.10869565217391, 1.4333333333333, 0.31818181818182
57105, 0.08695652173913, 1.4166666666667, 0.31818181818182
57106, 0.08695652173913, 1.4333333333333, 0.34090909090909
57107, 0.10869565217391, 1.4333333333333, 0.36363636363636
57108, 0.08695652173913, 1.4166666666667, 0.36363636363636
57109, 0.08695652173913, 1.4333333333333, 0.38636363636364
57110, 0.10869565217391, 1.4333333333333, 0.40909090909091
57111, 0.08695652173913, 1.4166666666667, 0.40909090909091
57112, 0.08695652173913, 1.4333333333333, 0.43181818181818
57113, 0.10869565217391, 1.4333333333333, 0.45454545454545
57114, 0.08695652173913, 1.4166666666667, 0.45454545454545
57115, 0.08695652173913, 1.4333333333333, 0.47727272727273
57116, 0.043478260869565, 1.4333333333333, 0.022727272727273
57117, 0.065217391304348, 1.4333333333333, 0.045454545454545
57118, 0.043478260869565, 1.4166666666667, 0.045454545454545
57119, 0.043478260869565, 1.4333333333333, 0.068181818181818
57120, 0.065217391304348, 1.4333333333333, 0.090909090909091
57121, 0.043478260869565, 1.4166666666667, 0.090909090909091
57122, 0.043478260869565, 1.4333333333333, 0.11363636363636
57123, 0.065217391304348, 1.4333333333333, 0.13636363636364
57124, 0.043478260869565, 1.4166666666667, 0.13636363636364
57125, 0.043478260869565, 1.4333333333333, 0.15909090909091
57126, 0.065217391304348, 1.4333333333333, 0.18181818181818
57127, 0.043478260869565, 1.4166666666667, 0.18181818181818
57128, 0.043478260869565, 1.4333333333333, 0.20454545454545
57129, 0.065217391304348, 1.4333333333333, 0.22727272727273
57130, 0.043478260869565, 1.4166666666667, 0.22727272727273
57131, 0.043478260869565, 1.4333333333333, 0.25
57132, 0.065217391304348, 1.4333333333333, 0.27272727272727
57133, 0.043478260869565, 1.4166666666667, 0.27272727272727
57134, 0.043478260869565, 1.4333333333333, 0.29545454545455
57135, 0.065217391304348, 1.4333333333333, 0.31818181818182
57136, 0.043478260869565, 1.4166666666667, 0.31818181818182
57137, 0.043478260869565, 1.4333333333333, 0.34090909090909
57138, 0.065217391304348, 1.4333333333333, 0.36363636363636
57139, 0.043478260869565, 1.4166666666667, 0.36363636363636
57140, 0.043478260869565, 1.4333333333333, 0.38636363636364
57141, 0.065217391304348, 1.4333333333333, 0.40909090909091
57142, 0.043478260869565, 1.4166666666667, 0.40909090909091
57143, 0.043478260869565, 1.4333333333333, 0.43181818181818
57144, 0.065217391304348, 1.4333333333333, 0.45454545454545
57145, 0.043478260869565, 1.4166666666667, 0.45454545454545
57146, 0.043478260869565, 1.4333333333333, 0.47727272727273
57147, 0.021739130434783, 1.4333333333333, 0.045454545454545
57148, 0.021739130434783, 1.4333333333333, 0.090909090909091
57149, 0.021739130434783, 1.4333333333333, 0.13636363636364
57150, 0.021739130434783, 1.4333333333333, 0.18181818181818
57151, 0.021739130434783, 1.4333333333333, 0.22727272727273
57152, 0.021739130434783, 1.4333333333333, 0.27272727272727
57153, 0.021739130434783, 1.4333333333333, 0.31818181818182
57154, 0.021739130434783, 1.4333333333333, 0.36363636363636
57155, 0.021739130434783, 1.4333333333333, 0.40909090909091
57156, 0.021739130434783, 1.4333333333333, 0.45454545454545
57157, 0.95652173913043, 1.4666666666667, 0.022727272727273
57158, 0.97826086956522, 1.4666666666667, 0.045454545454545
57159, 0.95652173913043, 1.45, 0.045454545454545
57160, 0.95652173913043, 1.4666666666667, 0.068181818181818
57161, 0.97826086956522, 1.4666666666667, 0.090909090909091
57162, 0.95652173913043, 1.45, 0.090909090909091
57163, 0.95652173913043, 1.4666666666667, 0.11363636363636
57164, 0.97826086956522, 1.4666666666667, 0.13636363636364
57165, 0.95652173913044, 1.45, 0.13636363636364
57166, 0.95652173913044, 1.4666666666667, 0.15909090909091
57167, 0.97826086956522, 1.4666666666667, 0.18181818181818
57168, 0.95652173913044, 1.45, 0.18181818181818
57169, 0.95652173913044, 1.4666666666667, 0.20454545454545
57170, 0.97826086956522, 1.4666666666667, 0.22727272727273
57171, 0.95652173913044, 1.45, 0.22727272727273
57172, 0.95652173913044, 1.4666666666667, 0.25
57173, 0.97826086956522, 1.4666666666667, 0.27272727272727
57174, 0.95652173913044, 1.45, 0.27272727272727
57175, 0.95652173913044, 1.4666666666667, 0.29545454545455
57176, 0.97826086956522, 1.4666666666667, 0.31818181818182
57177, 0.95652173913044, 1.45, 0.31818181818182
57178, 0.95652173913043, 1.4666666666667, 0.34090909090909
57179, 0.97826086956522, 1.4666666666667, 0.36363636363636
57180, 0.95652173913043, 1.45, 0.36363636363636
57181, 0.95652173913043, 1.4666666666667, 0.38636363636364
57182, 0.97826086956522, 1.4666666666667, 0.40909090909091
57183, 0.95652173913043, 1.45, 0.40909090909091
57184, 0.95652173913043, 1.4666666666667, 0.43181818181818
57185, 0.97826086956522, 1.4666666666667, 0.45454545454545
57186, 0.95652173913044, 1.45, 0.45454545454545
57187, 0.95652173913043, 1.4666666666667, 0.47727272727273
57188, 0.91304347826087, 1.4666666666667, 0.022727272727273
57189, 0.93478260869565, 1.4666666666667, 0.045454545454545
57190, 0.91304347826087, 1.45, 0.045454545454545
57191, 0.91304347826087, 1.4666666666667, 0.068181818181818
57192, 0.93478260869565, 1.4666666666667, 0.090909090909091
57193, 0.91304347826087, 1.45, 0.090909090909091
57194, 0.91304347826087, 1.4666666666667, 0.11363636363636
57195, 0.93478260869565, 1.4666666666667, 0.13636363636364
57196, 0.91304347826087, 1.45, 0.13636363636364
57197, 0.91304347826087, 1.4666666666667, 0.15909090909091
57198, 0.93478260869565, 1.4666666666667, 0.18181818181818
57199, 0.91304347826087, 1.45, 0.18181818181818
57200, 0.91304347826087, 1.4666666666667, 0.20454545454545
57201, 0.93478260869565, 1.4666666666667, 0.22727272727273
57202, 0.91304347826087, 1.45, 0.22727272727273
57203, 0.91304347826087, 1.4666666666667, 0.25
57204, 0.93478260869565, 1.4666666666667, 0.27272727272727
57205, 0.91304347826087, 1.45, 0.27272727272727
57206, 0.91304347826087, 1.4666666666667, 0.29545454545455
57207, 0.93478260869565, 1.4666666666667, 0.31818181818182
57208, 0.91304347826087, 1.45, 0.31818181818182
57209, 0.91304347826087, 1.4666666666667, 0.34090909090909
57210, 0.93478260869565, 1.4666666666667, 0.36363636363636
57211, 0.91304347826087, 1.45, 0.36363636363636
57212, 0.91304347826087, 1.4666666666667, 0.38636363636364
57213, 0.93478260869565, 1.4666666666667, 0.40909090909091
57214, 0.91304347826087, 1.45, 0.40909090909091
57215, 0.91304347826087, 1.4666666666667, 0.43181818181818
57216, 0.93478260869565, 1.4666666666667, 0.45454545454545
57217, 0.91304347826087, 1.45, 0.45454545454545
57218, 0.91304347826087, 1.4666666666667, 0.47727272727273
57219, 0.8695652173913, 1.4666666666667, 0.022727272727273
57220, 0.89130434782609, 1.4666666666667, 0.045454545454545
57221, 0.8695652173913, 1.45, 0.045454545454545
57222, 0.8695652173913, 1.4666666666667, 0.068181818181818
57223, 0.89130434782609, 1.4666666666667, 0.090909090909091
57224, 0.8695652173913, 1.45, 0.090909090909091
57225, 0.8695652173913, 1.4666666666667, 0.11363636363636
57226, 0.89130434782609, 1.4666666666667, 0.13636363636364
57227, 0.8695652173913, 1.45, 0.13636363636364
57228, 0.8695652173913, 1.4666666666667, 0.15909090909091
57229, 0.89130434782609, 1.4666666666667, 0.18181818181818
57230, 0.8695652173913, 1.45, 0.18181818181818
57231, 0.8695652173913, 1.4666666666667, 0.20454545454545
57232, 0.89130434782609, 1.4666666666667, 0.22727272727273
57233, 0.8695652173913, 1.45, 0.22727272727273
57234, 0.8695652173913, 1.4666666666667, 0.25
57235, 0.89130434782609, 1.4666666666667, 0.27272727272727
57236, 0.8695652173913, 1.45, 0.27272727272727
57237, 0.8695652173913, 1.4666666666667, 0.29545454545455
57238, 0.89130434782609, 1.4666666666667, 0.31818181818182
57239, 0.8695652173913, 1.45, 0.31818181818182
57240, 0.8695652173913, 1.4666666666667, 0.34090909090909
57241, 0.89130434782609, 1.4666666666667, 0.36363636363636
57242, 0.8695652173913, 1.45, 0.36363636363636
57243, 0.8695652173913, 1.4666666666667, 0.38636363636364
57244, 0.89130434782609, 1.4666666666667, 0.40909090909091
57245, 0.8695652173913, 1.45, 0.40909090909091
57246, 0.8695652173913, 1.4666666666667, 0.43181818181818
57247, 0.89130434782609, 1.4666666666667, 0.45454545454545
57248, 0.8695652173913, 1.45, 0.45454545454545
57249, 0.8695652173913, 1.4666666666667, 0.47727272727273
57250, 0.82608695652174, 1.4666666666667, 0.022727272727273
57251, 0.84782608695652, 1.4666666666667, 0.045454545454545
57252, 0.82608695652174, 1.45, 0.045454545454545
57253, 0.82608695652174, 1.4666666666667, 0.068181818181818
57254, 0.84782608695652, 1.4666666666667, 0.090909090909091
57255, 0.82608695652174, 1.45, 0.090909090909091
57256, 0.82608695652174, 1.4666666666667, 0.11363636363636
57257, 0.84782608695652, 1.4666666666667, 0.13636363636364
57258, 0.82608695652174, 1.45, 0.13636363636364
57259, 0.82608695652174, 1.4666666666667, 0.15909090909091
57260, 0.84782608695652, 1.4666666666667, 0.18181818181818
57261, 0.82608695652174, 1.45, 0.18181818181818
57262, 0.82608695652174, 1.4666666666667, 0.20454545454545
57263, 0.84782608695652, 1.4666666666667, 0.22727272727273
57264, 0.82608695652174, 1.45, 0.22727272727273
57265, 0.82608695652174, 1.4666666666667, 0.25
57266, 0.84782608695652, 1.4666666666667, 0.27272727272727
57267, 0.82608695652174, 1.45, 0.27272727272727
57268, 0.82608695652174, 1.4666666666667, 0.29545454545455
57269, 0.84782608695652, 1.4666666666667, 0.31818181818182
57270, 0.82608695652174, 1.45, 0.31818181818182
57271, 0.82608695652174, 1.4666666666667, 0.34090909090909
57272, 0.84782608695652, 1.4666666666667, 0.36363636363636
57273, 0.82608695652174, 1.45, 0.36363636363636
57274, 0.82608695652174, 1.4666666666667, 0.38636363636364
57275, 0.84782608695652, 1.4666666666667, 0.40909090909091
57276, 0.82608695652174, 1.45, 0.40909090909091
57277, 0.82608695652174, 1.4666666666667, 0.43181818181818
57278, 0.84782608695652, 1.4666666666667, 0.45454545454545
57279, 0.82608695652174, 1.45, 0.45454545454545
57280, 0.82608695652174, 1.4666666666667, 0.47727272727273
57281, 0.78260869565217, 1.4666666666667, 0.022727272727273
57282, 0.80434782608696, 1.4666666666667, 0.045454545454545
57283, 0.78260869565217, 1.45, 0.045454545454545
57284, 0.78260869565217, 1.4666666666667, 0.068181818181818
57285, 0.80434782608696, 1.4666666666667, 0.090909090909091
57286, 0.78260869565217, 1.45, 0.090909090909091
57287, 0.78260869565217, 1.4666666666667, 0.11363636363636
57288, 0.80434782608696, 1.4666666666667, 0.13636363636364
57289, 0.78260869565217, 1.45, 0.13636363636364
57290, 0.78260869565217, 1.4666666666667, 0.15909090909091
57291, 0.80434782608696, 1.4666666666667, 0.18181818181818
57292, 0.78260869565217, 1.45, 0.18181818181818
57293, 0.78260869565217, 1.4666666666667, 0.20454545454545
57294, 0.80434782608696, 1.4666666666667, 0.22727272727273
57295, 0.78260869565217, 1.45, 0.22727272727273
57296, 0.78260869565217, 1.4666666666667, 0.25
57297, 0.80434782608696, 1.4666666666667, 0.27272727272727
57298, 0.78260869565217, 1.45, 0.27272727272727
57299, 0.78260869565217, 1.4666666666667, 0.29545454545455
57300, 0.80434782608696, 1.4666666666667, 0.31818181818182
57301, 0.78260869565217, 1.45, 0.31818181818182
57302, 0.78260869565217, 1.4666666666667, 0.34090909090909
57303, 0.80434782608696, 1.4666666666667, 0.36363636363636
57304, 0.78260869565217, 1.45, 0.36363636363636
57305, 0.78260869565217, 1.4666666666667, 0.38636363636364
57306, 0.80434782608696, 1.4666666666667, 0.40909090909091
57307, 0.78260869565217, 1.45, 0.40909090909091
57308, 0.78260869565217, 1.4666666666667, 0.43181818181818
57309, 0.80434782608696, 1.4666666666667, 0.45454545454545
57310, 0.78260869565217, 1.45, 0.45454545454545
57311, 0.78260869565217, 1.4666666666667, 0.47727272727273
57312, 0.73913043478261, 1.4666666666667, 0.022727272727273
57313, 0.76086956521739, 1.4666666666667, 0.045454545454545
57314, 0.73913043478261, 1.45, 0.045454545454545
57315, 0.73913043478261, 1.4666666666667, 0.068181818181818
57316, 0.76086956521739, 1.4666666666667, 0.090909090909091
57317, 0.73913043478261, 1.45, 0.090909090909091
57318, 0.73913043478261, 1.4666666666667, 0.11363636363636
57319, 0.76086956521739, 1.4666666666667, 0.13636363636364
57320, 0.73913043478261, 1.45, 0.13636363636364
57321, 0.73913043478261, 1.4666666666667, 0.15909090909091
57322, 0.76086956521739, 1.4666666666667, 0.18181818181818
57323, 0.73913043478261, 1.45, 0.18181818181818
57324, 0.73913043478261, 1.4666666666667, 0.20454545454545
57325, 0.76086956521739, 1.4666666666667, 0.22727272727273
57326, 0.73913043478261, 1.45, 0.22727272727273
57327, 0.73913043478261, 1.4666666666667, 0.25
57328, 0.76086956521739, 1.4666666666667, 0.27272727272727
57329, 0.73913043478261, 1.45, 0.27272727272727
57330, 0.73913043478261, 1.4666666666667, 0.29545454545455
57331, 0.76086956521739, 1.4666666666667, 0.31818181818182
57332, 0.73913043478261, 1.45, 0.31818181818182
57333, 0.73913043478261, 1.4666666666667, 0.34090909090909
57334, 0.76086956521739, 1.4666666666667, 0.36363636363636
57335, 0.73913043478261, 1.45, 0.36363636363636
57336, 0.73913043478261, 1.4666666666667, 0.38636363636364
57337, 0.76086956521739, 1.4666666666667, 0.40909090909091
57338, 0.73913043478261, 1.45, 0.40909090909091
57339, 0.73913043478261, 1.4666666666667, 0.43181818181818
57340, 0.76086956521739, 1.4666666666667, 0.45454545454545
57341, 0.73913043478261, 1.45, 0.45454545454545
57342, 0.73913043478261, 1.4666666666667, 0.47727272727273
57343, 0.69565217391304, 1.4666666666667, 0.022727272727273
57344, 0.71739130434783, 1.4666666666667, 0.045454545454545
57345, 0.69565217391304, 1.45, 0.045454545454545
57346, 0.69565217391304, 1.4666666666667, 0.068181818181818
57347, 0.71739130434783, 1.4666666666667, 0.090909090909091
57348, 0.69565217391304, 1.45, 0.090909090909091
57349, 0.69565217391304, 1.4666666666667, 0.11363636363636
57350, 0.71739130434783, 1.4666666666667, 0.13636363636364
57351, 0.69565217391304, 1.45, 0.13636363636364
57352, 0.69565217391304, 1.4666666666667, 0.15909090909091
57353, 0.71739130434783, 1.4666666666667, 0.18181818181818
57354, 0.69565217391304, 1.45, 0.18181818181818
57355, 0.69565217391304, 1.4666666666667, 0.20454545454545
57356, 0.71739130434783, 1.4666666666667, 0.22727272727273
57357, 0.69565217391304, 1.45, 0.22727272727273
57358, 0.69565217391304, 1.4666666666667, 0.25
57359, 0.71739130434783, 1.4666666666667, 0.27272727272727
57360, 0.69565217391304, 1.45, 0.27272727272727
57361, 0.69565217391304, 1.4666666666667, 0.29545454545455
57362, 0.71739130434783, 1.4666666666667, 0.31818181818182
57363, 0.69565217391304, 1.45, 0.31818181818182
57364, 0.69565217391304, 1.4666666666667, 0.34090909090909
57365, 0.71739130434783, 1.4666666666667, 0.36363636363636
57366, 0.69565217391304, 1.45, 0.36363636363636
57367, 0.69565217391304, 1.4666666666667, 0.38636363636364
57368, 0.71739130434783, 1.4666666666667, 0.40909090909091
57369, 0.69565217391304, 1.45, 0.40909090909091
57370, 0.69565217391304, 1.4666666666667, 0.43181818181818
57371, 0.71739130434783, 1.4666666666667, 0.45454545454545
57372, 0.69565217391304, 1.45, 0.45454545454545
57373, 0.69565217391304, 1.4666666666667, 0.47727272727273
57374, 0.65217391304348, 1.4666666666667, 0.022727272727273
57375, 0.67391304347826, 1.4666666666667, 0.045454545454545
57376, 0.65217391304348, 1.45, 0.045454545454545
57377, 0.65217391304348, 1.4666666666667, 0.068181818181818
57378, 0.67391304347826, 1.4666666666667, 0.090909090909091
57379, 0.65217391304348, 1.45, 0.090909090909091
57380, 0.65217391304348, 1.4666666666667, 0.11363636363636
57381, 0.67391304347826, 1.4666666666667, 0.13636363636364
57382, 0.65217391304348, 1.45, 0.13636363636364
57383, 0.65217391304348, 1.4666666666667, 0.15909090909091
57384, 0.67391304347826, 1.4666666666667, 0.18181818181818
57385, 0.65217391304348, 1.45, 0.18181818181818
57386, 0.65217391304348, 1.4666666666667, 0.20454545454545
57387, 0.67391304347826, 1.4666666666667, 0.22727272727273
57388, 0.65217391304348, 1.45, 0.22727272727273
57389, 0.65217391304348, 1.4666666666667, 0.25
57390, 0.67391304347826, 1.4666666666667, 0.27272727272727
57391, 0.65217391304348, 1.45, 0.27272727272727
57392, 0.65217391304348, 1.4666666666667, 0.29545454545455
57393, 0.67391304347826, 1.4666666666667, 0.31818181818182
57394, 0.65217391304348, 1.45, 0.31818181818182
57395, 0.65217391304348, 1.4666666666667, 0.34090909090909
57396, 0.67391304347826, 1.4666666666667, 0.36363636363636
57397, 0.65217391304348, 1.45, 0.36363636363636
57398, 0.65217391304348, 1.4666666666667, 0.38636363636364
57399, 0.67391304347826, 1.4666666666667, 0.40909090909091
57400, 0.65217391304348, 1.45, 0.40909090909091
57401, 0.65217391304348, 1.4666666666667, 0.43181818181818
57402, 0.67391304347826, 1.4666666666667, 0.45454545454545
57403, 0.65217391304348, 1.45, 0.45454545454545
57404, 0.65217391304348, 1.4666666666667, 0.47727272727273
57405, 0.60869565217391, 1.4666666666667, 0.022727272727273
57406, 0.6304347826087, 1.4666666666667, 0.045454545454545
57407, 0.60869565217391, 1.45, 0.045454545454545
57408, 0.60869565217391, 1.4666666666667, 0.068181818181818
57409, 0.6304347826087, 1.4666666666667, 0.090909090909091
57410, 0.60869565217391, 1.45, 0.090909090909091
57411, 0.60869565217391, 1.4666666666667, 0.11363636363636
57412, 0.6304347826087, 1.4666666666667, 0.13636363636364
57413, 0.60869565217391, 1.45, 0.13636363636364
57414, 0.60869565217391, 1.4666666666667, 0.15909090909091
57415, 0.6304347826087, 1.4666666666667, 0.18181818181818
57416, 0.60869565217391, 1.45, 0.18181818181818
57417, 0.60869565217391, 1.4666666666667, 0.20454545454545
57418, 0.6304347826087, 1.4666666666667, 0.22727272727273
57419, 0.60869565217391, 1.45, 0.22727272727273
57420, 0.60869565217391, 1.4666666666667, 0.25
57421, 0.6304347826087, 1.4666666666667, 0.27272727272727
57422, 0.60869565217391, 1.45, 0.27272727272727
57423, 0.60869565217391, 1.4666666666667, 0.29545454545455
57424, 0.6304347826087, 1.4666666666667, 0.31818181818182
57425, 0.60869565217391, 1.45, 0.31818181818182
57426, 0.60869565217391, 1.4666666666667, 0.34090909090909
57427, 0.6304347826087, 1.4666666666667, 0.36363636363636
57428, 0.60869565217391, 1.45, 0.36363636363636
57429, 0.60869565217391, 1.4666666666667, 0.38636363636364
57430, 0.6304347826087, 1.4666666666667, 0.40909090909091
57431, 0.60869565217391, 1.45, 0.40909090909091
57432, 0.60869565217391, 1.4666666666667, 0.43181818181818
57433, 0.6304347826087, 1.4666666666667, 0.45454545454545
57434, 0.60869565217391, 1.45, 0.45454545454545
57435, 0.60869565217391, 1.4666666666667, 0.47727272727273
57436, 0.56521739130435, 1.4666666666667, 0.022727272727273
57437, 0.58695652173913, 1.4666666666667, 0.045454545454545
57438, 0.56521739130435, 1.45, 0.045454545454545
57439, 0.56521739130435, 1.4666666666667, 0.068181818181818
57440, 0.58695652173913, 1.4666666666667, 0.090909090909091
57441, 0.56521739130435, 1.45, 0.090909090909091
57442, 0.56521739130435, 1.4666666666667, 0.11363636363636
57443, 0.58695652173913, 1.4666666666667, 0.13636363636364
57444, 0.56521739130435, 1.45, 0.13636363636364
57445, 0.56521739130435, 1.4666666666667, 0.15909090909091
57446, 0.58695652173913, 1.4666666666667, 0.18181818181818
57447, 0.56521739130435, 1.45, 0.18181818181818
57448, 0.56521739130435, 1.4666666666667, 0.20454545454545
57449, 0.58695652173913, 1.4666666666667, 0.22727272727273
57450, 0.56521739130435, 1.45, 0.22727272727273
57451, 0.56521739130435, 1.4666666666667, 0.25
57452, 0.58695652173913, 1.4666666666667, 0.27272727272727
57453, 0.56521739130435, 1.45, 0.27272727272727
57454, 0.56521739130435, 1.4666666666667, 0.29545454545455
57455, 0.58695652173913, 1.4666666666667, 0.31818181818182
57456, 0.56521739130435, 1.45, 0.31818181818182
57457, 0.56521739130435, 1.4666666666667, 0.34090909090909
57458, 0.58695652173913, 1.4666666666667, 0.36363636363636
57459, 0.56521739130435, 1.45, 0.36363636363636
57460, 0.56521739130435, 1.4666666666667, 0.38636363636364
57461, 0.58695652173913, 1.4666666666667, 0.40909090909091
57462, 0.56521739130435, 1.45, 0.40909090909091
57463, 0.56521739130435, 1.4666666666667, 0.43181818181818
57464, 0.58695652173913, 1.4666666666667, 0.45454545454545
57465, 0.56521739130435, 1.45, 0.45454545454545
57466, 0.56521739130435, 1.4666666666667, 0.47727272727273
57467, 0.52173913043478, 1.4666666666667, 0.022727272727273
57468, 0.54347826086956, 1.4666666666667, 0.045454545454545
57469, 0.52173913043478, 1.45, 0.045454545454545
57470, 0.52173913043478, 1.4666666666667, 0.068181818181818
57471, 0.54347826086956, 1.4666666666667, 0.090909090909091
57472, 0.52173913043478, 1.45, 0.090909090909091
57473, 0.52173913043478, 1.4666666666667, 0.11363636363636
57474, 0.54347826086957, 1.4666666666667, 0.13636363636364
57475, 0.52173913043478, 1.45, 0.13636363636364
57476, 0.52173913043478, 1.4666666666667, 0.15909090909091
57477, 0.54347826086956, 1.4666666666667, 0.18181818181818
57478, 0.52173913043478, 1.45, 0.18181818181818
57479, 0.52173913043478, 1.4666666666667, 0.20454545454545
57480, 0.54347826086956, 1.4666666666667, 0.22727272727273
57481, 0.52173913043478, 1.45, 0.22727272727273
57482, 0.52173913043478, 1.4666666666667, 0.25
57483, 0.54347826086956, 1.4666666666667, 0.27272727272727
57484, 0.52173913043478, 1.45, 0.27272727272727
57485, 0.52173913043478, 1.4666666666667, 0.29545454545455
57486, 0.54347826086956, 1.4666666666667, 0.31818181818182
57487, 0.52173913043478, 1.45, 0.31818181818182
57488, 0.52173913043478, 1.4666666666667, 0.34090909090909
57489, 0.54347826086957, 1.4666666666667, 0.36363636363636
57490, 0.52173913043478, 1.45, 0.36363636363636
57491, 0.52173913043478, 1.4666666666667, 0.38636363636364
57492, 0.54347826086956, 1.4666666666667, 0.40909090909091
57493, 0.52173913043478, 1.45, 0.40909090909091
57494, 0.52173913043478, 1.4666666666667, 0.43181818181818
57495, 0.54347826086956, 1.4666666666667, 0.45454545454545
57496, 0.52173913043478, 1.45, 0.45454545454545
57497, 0.52173913043478, 1.4666666666667, 0.47727272727273
57498, 0.47826086956522, 1.4666666666667, 0.022727272727273
57499, 0.5, 1.4666666666667, 0.045454545454545
57500, 0.47826086956522, 1.45, 0.045454545454545
57501, 0.47826086956522, 1.4666666666667, 0.068181818181818
57502, 0.5, 1.4666666666667, 0.090909090909091
57503, 0.47826086956522, 1.45, 0.090909090909091
57504, 0.47826086956522, 1.4666666666667, 0.11363636363636
57505, 0.5, 1.4666666666667, 0.13636363636364
57506, 0.47826086956522, 1.45, 0.13636363636364
57507, 0.47826086956522, 1.4666666666667, 0.15909090909091
57508, 0.5, 1.4666666666667, 0.18181818181818
57509, 0.47826086956522, 1.45, 0.18181818181818
57510, 0.47826086956522, 1.4666666666667, 0.20454545454545
57511, 0.5, 1.4666666666667, 0.22727272727273
57512, 0.47826086956522, 1.45, 0.22727272727273
57513, 0.47826086956522, 1.4666666666667, 0.25
57514, 0.5, 1.4666666666667, 0.27272727272727
57515, 0.47826086956522, 1.45, 0.27272727272727
57516, 0.47826086956522, 1.4666666666667, 0.29545454545455
57517, 0.5, 1.4666666666667, 0.31818181818182
57518, 0.47826086956522, 1.45, 0.31818181818182
57519, 0.47826086956522, 1.4666666666667, 0.34090909090909
57520, 0.5, 1.4666666666667, 0.36363636363636
57521, 0.47826086956522, 1.45, 0.36363636363636
57522, 0.47826086956522, 1.4666666666667, 0.38636363636364
57523, 0.5, 1.4666666666667, 0.40909090909091
57524, 0.47826086956522, 1.45, 0.40909090909091
57525, 0.47826086956522, 1.4666666666667, 0.43181818181818
57526, 0.5, 1.4666666666667, 0.45454545454545
57527, 0.47826086956522, 1.45, 0.45454545454545
57528, 0.47826086956522, 1.4666666666667, 0.47727272727273
57529, 0.43478260869565, 1.4666666666667, 0.022727272727273
57530, 0.45652173913043, 1.4666666666667, 0.045454545454545
57531, 0.43478260869565, 1.45, 0.045454545454545
57532, 0.43478260869565, 1.4666666666667, 0.068181818181818
57533, 0.45652173913043, 1.4666666666667, 0.090909090909091
57534, 0.43478260869565, 1.45, 0.090909090909091
57535, 0.43478260869565, 1.4666666666667, 0.11363636363636
57536, 0.45652173913043, 1.4666666666667, 0.13636363636364
57537, 0.43478260869565, 1.45, 0.13636363636364
57538, 0.43478260869565, 1.4666666666667, 0.15909090909091
57539, 0.45652173913043, 1.4666666666667, 0.18181818181818
57540, 0.43478260869565, 1.45, 0.18181818181818
57541, 0.43478260869565, 1.4666666666667, 0.20454545454545
57542, 0.45652173913043, 1.4666666666667, 0.22727272727273
57543, 0.43478260869565, 1.45, 0.22727272727273
57544, 0.43478260869565, 1.4666666666667, 0.25
57545, 0.45652173913043, 1.4666666666667, 0.27272727272727
57546, 0.43478260869565, 1.45, 0.27272727272727
57547, 0.43478260869565, 1.4666666666667, 0.29545454545455
57548, 0.45652173913043, 1.4666666666667, 0.31818181818182
57549, 0.43478260869565, 1.45, 0.31818181818182
57550, 0.43478260869565, 1.4666666666667, 0.34090909090909
57551, 0.45652173913043, 1.4666666666667, 0.36363636363636
57552, 0.43478260869565, 1.45, 0.36363636363636
57553, 0.43478260869565, 1.4666666666667, 0.38636363636364
57554, 0.45652173913043, 1.4666666666667, 0.40909090909091
57555, 0.43478260869565, 1.45, 0.40909090909091
57556, 0.43478260869565, 1.4666666666667, 0.43181818181818
57557, 0.45652173913043, 1.4666666666667, 0.45454545454545
57558, 0.43478260869565, 1.45, 0.45454545454545
57559, 0.43478260869565, 1.4666666666667, 0.47727272727273
57560, 0.39130434782609, 1.4666666666667, 0.022727272727273
57561, 0.41304347826087, 1.4666666666667, 0.045454545454545
57562, 0.39130434782609, 1.45, 0.045454545454545
57563, 0.39130434782609, 1.4666666666667, 0.068181818181818
57564, 0.41304347826087, 1.4666666666667, 0.090909090909091
57565, 0.39130434782609, 1.45, 0.090909090909091
57566, 0.39130434782609, 1.4666666666667, 0.11363636363636
57567, 0.41304347826087, 1.4666666666667, 0.13636363636364
57568, 0.39130434782609, 1.45, 0.13636363636364
57569, 0.39130434782609, 1.4666666666667, 0.15909090909091
57570, 0.41304347826087, 1.4666666666667, 0.18181818181818
57571, 0.39130434782609, 1.45, 0.18181818181818
57572, 0.39130434782609, 1.4666666666667, 0.20454545454545
57573, 0.41304347826087, 1.4666666666667, 0.22727272727273
57574, 0.39130434782609, 1.45, 0.22727272727273
57575, 0.39130434782609, 1.4666666666667, 0.25
57576, 0.41304347826087, 1.4666666666667, 0.27272727272727
57577, 0.39130434782609, 1.45, 0.27272727272727
57578, 0.39130434782609, 1.4666666666667, 0.29545454545455
57579, 0.41304347826087, 1.4666666666667, 0.31818181818182
57580, 0.39130434782609, 1.45, 0.31818181818182
57581, 0.39130434782609, 1.4666666666667, 0.34090909090909
57582, 0.41304347826087, 1.4666666666667, 0.36363636363636
57583, 0.39130434782609, 1.45, 0.36363636363636
57584, 0.39130434782609, 1.4666666666667, 0.38636363636364
57585, 0.41304347826087, 1.4666666666667, 0.40909090909091
57586, 0.39130434782609, 1.45, 0.40909090909091
57587, 0.39130434782609, 1.4666666666667, 0.43181818181818
57588, 0.41304347826087, 1.4666666666667, 0.45454545454545
57589, 0.39130434782609, 1.45, 0.45454545454545
57590, 0.39130434782609, 1.4666666666667, 0.47727272727273
57591, 0.34782608695652, 1.4666666666667, 0.022727272727273
57592, 0.3695652173913, 1.4666666666667, 0.045454545454545
57593, 0.34782608695652, 1.45, 0.045454545454545
57594, 0.34782608695652, 1.4666666666667, 0.068181818181818
57595, 0.3695652173913, 1.4666666666667, 0.090909090909091
57596, 0.34782608695652, 1.45, 0.090909090909091
57597, 0.34782608695652, 1.4666666666667, 0.11363636363636
57598, 0.3695652173913, 1.4666666666667, 0.13636363636364
57599, 0.34782608695652, 1.45, 0.13636363636364
57600, 0.34782608695652, 1.4666666666667, 0.15909090909091
57601, 0.3695652173913, 1.4666666666667, 0.18181818181818
57602, 0.34782608695652, 1.45, 0.18181818181818
57603, 0.34782608695652, 1.4666666666667, 0.20454545454545
57604, 0.3695652173913, 1.4666666666667, 0.22727272727273
57605, 0.34782608695652, 1.45, 0.22727272727273
57606, 0.34782608695652, 1.4666666666667, 0.25
57607, 0.3695652173913, 1.4666666666667, 0.27272727272727
57608, 0.34782608695652, 1.45, 0.27272727272727
57609, 0.34782608695652, 1.4666666666667, 0.29545454545455
57610, 0.3695652173913, 1.4666666666667, 0.31818181818182
57611, 0.34782608695652, 1.45, 0.31818181818182
57612, 0.34782608695652, 1.4666666666667, 0.34090909090909
57613, 0.3695652173913, 1.4666666666667, 0.36363636363636
57614, 0.34782608695652, 1.45, 0.36363636363636
57615, 0.34782608695652, 1.4666666666667, 0.38636363636364
57616, 0.3695652173913, 1.4666666666667, 0.40909090909091
57617, 0.34782608695652, 1.45, 0.40909090909091
57618, 0.34782608695652, 1.4666666666667, 0.43181818181818
57619, 0.3695652173913, 1.4666666666667, 0.45454545454545
57620, 0.34782608695652, 1.45, 0.45454545454545
57621, 0.34782608695652, 1.4666666666667, 0.47727272727273
57622, 0.30434782608696, 1.4666666666667, 0.022727272727273
57623, 0.32608695652174, 1.4666666666667, 0.045454545454545
57624, 0.30434782608696, 1.45, 0.045454545454545
57625, 0.30434782608696, 1.4666666666667, 0.068181818181818
57626, 0.32608695652174, 1.4666666666667, 0.090909090909091
57627, 0.30434782608696, 1.45, 0.090909090909091
57628, 0.30434782608696, 1.4666666666667, 0.11363636363636
57629, 0.32608695652174, 1.4666666666667, 0.13636363636364
57630, 0.30434782608696, 1.45, 0.13636363636364
57631, 0.30434782608696, 1.4666666666667, 0.15909090909091
57632, 0.32608695652174, 1.4666666666667, 0.18181818181818
57633, 0.30434782608696, 1.45, 0.18181818181818
57634, 0.30434782608696, 1.4666666666667, 0.20454545454545
57635, 0.32608695652174, 1.4666666666667, 0.22727272727273
57636, 0.30434782608696, 1.45, 0.22727272727273
57637, 0.30434782608696, 1.4666666666667, 0.25
57638, 0.32608695652174, 1.4666666666667, 0.27272727272727
57639, 0.30434782608696, 1.45, 0.27272727272727
57640, 0.30434782608696, 1.4666666666667, 0.29545454545455
57641, 0.32608695652174, 1.4666666666667, 0.31818181818182
57642, 0.30434782608696, 1.45, 0.31818181818182
57643, 0.30434782608696, 1.4666666666667, 0.34090909090909
57644, 0.32608695652174, 1.4666666666667, 0.36363636363636
57645, 0.30434782608696, 1.45, 0.36363636363636
57646, 0.30434782608696, 1.4666666666667, 0.38636363636364
57647, 0.32608695652174, 1.4666666666667, 0.40909090909091
57648, 0.30434782608696, 1.45, 0.40909090909091
57649, 0.30434782608696, 1.4666666666667, 0.43181818181818
57650, 0.32608695652174, 1.4666666666667, 0.45454545454545
57651, 0.30434782608696, 1.45, 0.45454545454545
57652, 0.30434782608696, 1.4666666666667, 0.47727272727273
57653, 0.26086956521739, 1.4666666666667, 0.022727272727273
57654, 0.28260869565217, 1.4666666666667, 0.045454545454545
57655, 0.26086956521739, 1.45, 0.045454545454545
57656, 0.26086956521739, 1.4666666666667, 0.068181818181818
57657, 0.28260869565217, 1.4666666666667, 0.090909090909091
57658, 0.26086956521739, 1.45, 0.090909090909091
57659, 0.26086956521739, 1.4666666666667, 0.11363636363636
57660, 0.28260869565217, 1.4666666666667, 0.13636363636364
57661, 0.26086956521739, 1.45, 0.13636363636364
57662, 0.26086956521739, 1.4666666666667, 0.15909090909091
57663, 0.28260869565217, 1.4666666666667, 0.18181818181818
57664, 0.26086956521739, 1.45, 0.18181818181818
57665, 0.26086956521739, 1.4666666666667, 0.20454545454545
57666, 0.28260869565217, 1.4666666666667, 0.22727272727273
57667, 0.26086956521739, 1.45, 0.22727272727273
57668, 0.26086956521739, 1.4666666666667, 0.25
57669, 0.28260869565217, 1.4666666666667, 0.27272727272727
57670, 0.26086956521739, 1.45, 0.27272727272727
57671, 0.26086956521739, 1.4666666666667, 0.29545454545455
57672, 0.28260869565217, 1.4666666666667, 0.31818181818182
57673, 0.26086956521739, 1.45, 0.31818181818182
57674, 0.26086956521739, 1.4666666666667, 0.34090909090909
57675, 0.28260869565217, 1.4666666666667, 0.36363636363636
57676, 0.26086956521739, 1.45, 0.36363636363636
57677, 0.26086956521739, 1.4666666666667, 0.38636363636364
57678, 0.28260869565217, 1.4666666666667, 0.40909090909091
57679, 0.26086956521739, 1.45, 0.40909090909091
57680, 0.26086956521739, 1.4666666666667, 0.43181818181818
57681, 0.28260869565217, 1.4666666666667, 0.45454545454545
57682, 0.26086956521739, 1.45, 0.45454545454545
57683, 0.26086956521739, 1.4666666666667, 0.47727272727273
57684, 0.21739130434783, 1.4666666666667, 0.022727272727273
57685, 0.23913043478261, 1.4666666666667, 0.045454545454545
57686, 0.21739130434783, 1.45, 0.045454545454545
57687, 0.21739130434783, 1.4666666666667, 0.068181818181818
57688, 0.23913043478261, 1.4666666666667, 0.090909090909091
57689, 0.21739130434783, 1.45, 0.090909090909091
57690, 0.21739130434783, 1.4666666666667, 0.11363636363636
57691, 0.23913043478261, 1.4666666666667, 0.13636363636364
57692, 0.21739130434783, 1.45, 0.13636363636364
57693, 0.21739130434783, 1.4666666666667, 0.15909090909091
57694, 0.23913043478261, 1.4666666666667, 0.18181818181818
57695, 0.21739130434783, 1.45, 0.18181818181818
57696, 0.21739130434783, 1.4666666666667, 0.20454545454545
57697, 0.23913043478261, 1.4666666666667, 0.22727272727273
57698, 0.21739130434783, 1.45, 0.22727272727273
57699, 0.21739130434783, 1.4666666666667, 0.25
57700, 0.23913043478261, 1.4666666666667, 0.27272727272727
57701, 0.21739130434783, 1.45, 0.27272727272727
57702, 0.21739130434783, 1.4666666666667, 0.29545454545455
57703, 0.23913043478261, 1.4666666666667, 0.31818181818182
57704, 0.21739130434783, 1.45, 0.31818181818182
57705, 0.21739130434783, 1.4666666666667, 0.34090909090909
57706, 0.23913043478261, 1.4666666666667, 0.36363636363636
57707, 0.21739130434783, 1.45, 0.36363636363636
57708, 0.21739130434783, 1.4666666666667, 0.38636363636364
57709, 0.23913043478261, 1.4666666666667, 0.40909090909091
57710, 0.21739130434783, 1.45, 0.40909090909091
57711, 0.21739130434783, 1.4666666666667, 0.43181818181818
57712, 0.23913043478261, 1.4666666666667, 0.45454545454545
57713, 0.21739130434783, 1.45, 0.45454545454545
57714, 0.21739130434783, 1.4666666666667, 0.47727272727273
57715, 0.17391304347826, 1.4666666666667, 0.022727272727273
57716, 0.19565217391304, 1.4666666666667, 0.045454545454545
57717, 0.17391304347826, 1.45, 0.045454545454545
57718, 0.17391304347826, 1.4666666666667, 0.068181818181818
57719, 0.19565217391304, 1.4666666666667, 0.090909090909091
57720, 0.17391304347826, 1.45, 0.090909090909091
57721, 0.17391304347826, 1.4666666666667, 0.11363636363636
57722, 0.19565217391304, 1.4666666666667, 0.13636363636364
57723, 0.17391304347826, 1.45, 0.13636363636364
57724, 0.17391304347826, 1.4666666666667, 0.15909090909091
57725, 0.19565217391304, 1.4666666666667, 0.18181818181818
57726, 0.17391304347826, 1.45, 0.18181818181818
57727, 0.17391304347826, 1.4666666666667, 0.20454545454545
57728, 0.19565217391304, 1.4666666666667, 0.22727272727273
57729, 0.17391304347826, 1.45, 0.22727272727273
57730, 0.17391304347826, 1.4666666666667, 0.25
57731, 0.19565217391304, 1.4666666666667, 0.27272727272727
57732, 0.17391304347826, 1.45, 0.27272727272727
57733, 0.17391304347826, 1.4666666666667, 0.29545454545455
57734, 0.19565217391304, 1.4666666666667, 0.31818181818182
57735, 0.17391304347826, 1.45, 0.31818181818182
57736, 0.17391304347826, 1.4666666666667, 0.34090909090909
57737, 0.19565217391304, 1.4666666666667, 0.36363636363636
57738, 0.17391304347826, 1.45, 0.36363636363636
57739, 0.17391304347826, 1.4666666666667, 0.38636363636364
57740, 0.19565217391304, 1.4666666666667, 0.40909090909091
57741, 0.17391304347826, 1.45, 0.40909090909091
57742, 0.17391304347826, 1.4666666666667, 0.43181818181818
57743, 0.19565217391304, 1.4666666666667, 0.45454545454545
57744, 0.17391304347826, 1.45, 0.45454545454545
57745, 0.17391304347826, 1.4666666666667, 0.47727272727273
57746, 0.1304347826087, 1.4666666666667, 0.022727272727273
57747, 0.15217391304348, 1.4666666666667, 0.045454545454545
57748, 0.1304347826087, 1.45, 0.045454545454545
57749, 0.1304347826087, 1.4666666666667, 0.068181818181818
57750, 0.15217391304348, 1.4666666666667, 0.090909090909091
57751, 0.1304347826087, 1.45, 0.090909090909091
57752, 0.1304347826087, 1.4666666666667, 0.11363636363636
57753, 0.15217391304348, 1.4666666666667, 0.13636363636364
57754, 0.1304347826087, 1.45, 0.13636363636364
57755, 0.1304347826087, 1.4666666666667, 0.15909090909091
57756, 0.15217391304348, 1.4666666666667, 0.18181818181818
57757, 0.1304347826087, 1.45, 0.18181818181818
57758, 0.1304347826087, 1.4666666666667, 0.20454545454545
57759, 0.15217391304348, 1.4666666666667, 0.22727272727273
57760, 0.1304347826087, 1.45, 0.22727272727273
57761, 0.1304347826087, 1.4666666666667, 0.25
57762, 0.15217391304348, 1.4666666666667, 0.27272727272727
57763, 0.1304347826087, 1.45, 0.27272727272727
57764, 0.1304347826087, 1.4666666666667, 0.29545454545455
57765, 0.15217391304348, 1.4666666666667, 0.31818181818182
57766, 0.1304347826087, 1.45, 0.31818181818182
57767, 0.1304347826087, 1.4666666666667, 0.34090909090909
57768, 0.15217391304348, 1.4666666666667, 0.36363636363636
57769, 0.1304347826087, 1.45, 0.36363636363636
57770, 0.1304347826087, 1.4666666666667, 0.38636363636364
57771, 0.15217391304348, 1.4666666666667, 0.40909090909091
57772, 0.1304347826087, 1.45, 0.40909090909091
57773, 0.1304347826087, 1.4666666666667, 0.43181818181818
57774, 0.15217391304348, 1.4666666666667, 0.45454545454545
57775, 0.1304347826087, 1.45, 0.45454545454545
57776, 0.1304347826087, 1.4666666666667, 0.47727272727273
57777, 0.08695652173913, 1.4666666666667, 0.022727272727273
57778, 0.10869565217391, 1.4666666666667, 0.045454545454545
57779, 0.08695652173913, 1.45, 0.045454545454545
57780, 0.08695652173913, 1.4666666666667, 0.068181818181818
57781, 0.10869565217391, 1.4666666666667, 0.090909090909091
57782, 0.08695652173913, 1.45, 0.090909090909091
57783, 0.08695652173913, 1.4666666666667, 0.11363636363636
57784, 0.10869565217391, 1.4666666666667, 0.13636363636364
57785, 0.08695652173913, 1.45, 0.13636363636364
57786, 0.08695652173913, 1.4666666666667, 0.15909090909091
57787, 0.10869565217391, 1.4666666666667, 0.18181818181818
57788, 0.08695652173913, 1.45, 0.18181818181818
57789, 0.08695652173913, 1.4666666666667, 0.20454545454545
57790, 0.10869565217391, 1.4666666666667, 0.22727272727273
57791, 0.08695652173913, 1.45, 0.22727272727273
57792, 0.08695652173913, 1.4666666666667, 0.25
57793, 0.10869565217391, 1.4666666666667, 0.27272727272727
57794, 0.08695652173913, 1.45, 0.27272727272727
57795, 0.08695652173913, 1.4666666666667, 0.29545454545455
57796, 0.10869565217391, 1.4666666666667, 0.31818181818182
57797, 0.08695652173913, 1.45, 0.31818181818182
57798, 0.08695652173913, 1.4666666666667, 0.34090909090909
57799, 0.10869565217391, 1.4666666666667, 0.36363636363636
57800, 0.08695652173913, 1.45, 0.36363636363636
57801, 0.08695652173913, 1.4666666666667, 0.38636363636364
57802, 0.10869565217391, 1.4666666666667, 0.40909090909091
57803, 0.08695652173913, 1.45, 0.40909090909091
57804, 0.08695652173913, 1.4666666666667, 0.43181818181818
57805, 0.10869565217391, 1.4666666666667, 0.45454545454545
57806, 0.08695652173913, 1.45, 0.45454545454545
57807, 0.08695652173913, 1.4666666666667, 0.47727272727273
57808, 0.043478260869565, 1.4666666666667, 0.022727272727273
57809, 0.065217391304348, 1.4666666666667, 0.045454545454545
57810, 0.043478260869565, 1.45, 0.045454545454545
57811, 0.043478260869565, 1.4666666666667, 0.068181818181818
57812, 0.065217391304348, 1.4666666666667, 0.090909090909091
57813, 0.043478260869565, 1.45, 0.090909090909091
57814, 0.043478260869565, 1.4666666666667, 0.11363636363636
57815, 0.065217391304348, 1.4666666666667, 0.13636363636364
57816, 0.043478260869565, 1.45, 0.13636363636364
57817, 0.043478260869565, 1.4666666666667, 0.15909090909091
57818, 0.065217391304348, 1.4666666666667, 0.18181818181818
57819, 0.043478260869565, 1.45, 0.18181818181818
57820, 0.043478260869565, 1.4666666666667, 0.20454545454545
57821, 0.065217391304348, 1.4666666666667, 0.22727272727273
57822, 0.043478260869565, 1.45, 0.22727272727273
57823, 0.043478260869565, 1.4666666666667, 0.25
57824, 0.065217391304348, 1.4666666666667, 0.27272727272727
57825, 0.043478260869565, 1.45, 0.27272727272727
57826, 0.043478260869565, 1.4666666666667, 0.29545454545455
57827, 0.065217391304348, 1.4666666666667, 0.31818181818182
57828, 0.043478260869565, 1.45, 0.31818181818182
57829, 0.043478260869565, 1.4666666666667, 0.34090909090909
57830, 0.065217391304348, 1.4666666666667, 0.36363636363636
57831, 0.043478260869565, 1.45, 0.36363636363636
57832, 0.043478260869565, 1.4666666666667, 0.38636363636364
57833, 0.065217391304348, 1.4666666666667, 0.40909090909091
57834, 0.043478260869565, 1.45, 0.40909090909091
57835, 0.043478260869565, 1.4666666666667, 0.43181818181818
57836, 0.065217391304348, 1.4666666666667, 0.45454545454545
57837, 0.043478260869565, 1.45, 0.45454545454545
57838, 0.043478260869565, 1.4666666666667, 0.47727272727273
57839, 0.021739130434783, 1.4666666666667, 0.045454545454545
57840, 0.021739130434783, 1.4666666666667, 0.090909090909091
57841, 0.021739130434783, 1.4666666666667, 0.13636363636364
57842, 0.021739130434783, 1.4666666666667, 0.18181818181818
57843, 0.021739130434783, 1.4666666666667, 0.22727272727273
57844, 0.021739130434783, 1.4666666666667, 0.27272727272727
57845, 0.021739130434783, 1.4666666666667, 0.31818181818182
57846, 0.021739130434783, 1.4666666666667, 0.36363636363636
57847, 0.021739130434783, 1.4666666666667, 0.40909090909091
57848, 0.021739130434783, 1.4666666666667, 0.45454545454545
57849, 0.95652173913043, 1.4833333333333, 0.045454545454545
57850, 0.95652173913043, 1.4833333333333, 0.090909090909091
57851, 0.95652173913044, 1.4833333333333, 0.13636363636364
57852, 0.95652173913043, 1.4833333333333, 0.18181818181818
57853, 0.95652173913043, 1.4833333333333, 0.22727272727273
57854, 0.95652173913043, 1.4833333333333, 0.27272727272727
57855, 0.95652173913043, 1.4833333333333, 0.31818181818182
57856, 0.95652173913043, 1.4833333333333, 0.36363636363636
57857, 0.95652173913043, 1.4833333333333, 0.40909090909091
57858, 0.95652173913043, 1.4833333333333, 0.45454545454545
57859, 0.91304347826087, 1.4833333333333, 0.045454545454545
57860, 0.91304347826087, 1.4833333333333, 0.090909090909091
57861, 0.91304347826087, 1.4833333333333, 0.13636363636364
57862, 0.91304347826087, 1.4833333333333, 0.18181818181818
57863, 0.91304347826087, 1.4833333333333, 0.22727272727273
57864, 0.91304347826087, 1.4833333333333, 0.27272727272727
57865, 0.91304347826087, 1.4833333333333, 0.31818181818182
57866, 0.91304347826087, 1.4833333333333, 0.36363636363636
57867, 0.91304347826087, 1.4833333333333, 0.40909090909091
57868, 0.91304347826087, 1.4833333333333, 0.45454545454545
57869, 0.8695652173913, 1.4833333333333, 0.045454545454545
57870, 0.8695652173913, 1.4833333333333, 0.090909090909091
57871, 0.8695652173913, 1.4833333333333, 0.13636363636364
57872, 0.8695652173913, 1.4833333333333, 0.18181818181818
57873, 0.8695652173913, 1.4833333333333, 0.22727272727273
57874, 0.8695652173913, 1.4833333333333, 0.27272727272727
57875, 0.8695652173913, 1.4833333333333, 0.31818181818182
57876, 0.8695652173913, 1.4833333333333, 0.36363636363636
57877, 0.8695652173913, 1.4833333333333, 0.40909090909091
57878, 0.8695652173913, 1.4833333333333, 0.45454545454545
57879, 0.82608695652174, 1.4833333333333, 0.045454545454545
57880, 0.82608695652174, 1.4833333333333, 0.090909090909091
57881, 0.82608695652174, 1.4833333333333, 0.13636363636364
57882, 0.82608695652174, 1.4833333333333, 0.18181818181818
57883, 0.82608695652174, 1.4833333333333, 0.22727272727273
57884, 0.82608695652174, 1.4833333333333, 0.27272727272727
57885, 0.82608695652174, 1.4833333333333, 0.31818181818182
57886, 0.82608695652174, 1.4833333333333, 0.36363636363636
57887, 0.82608695652174, 1.4833333333333, 0.40909090909091
57888, 0.82608695652174, 1.4833333333333, 0.45454545454545
57889, 0.78260869565217, 1.4833333333333, 0.045454545454545
57890, 0.78260869565217, 1.4833333333333, 0.090909090909091
57891, 0.78260869565217, 1.4833333333333, 0.13636363636364
57892, 0.78260869565217, 1.4833333333333, 0.18181818181818
57893, 0.78260869565217, 1.4833333333333, 0.22727272727273
57894, 0.78260869565217, 1.4833333333333, 0.27272727272727
57895, 0.78260869565217, 1.4833333333333, 0.31818181818182
57896, 0.78260869565217, 1.4833333333333, 0.36363636363636
57897, 0.78260869565217, 1.4833333333333, 0.40909090909091
57898, 0.78260869565217, 1.4833333333333, 0.45454545454545
57899, 0.73913043478261, 1.4833333333333, 0.045454545454545
57900, 0.73913043478261, 1.4833333333333, 0.090909090909091
57901, 0.73913043478261, 1.4833333333333, 0.13636363636364
57902, 0.73913043478261, 1.4833333333333, 0.18181818181818
57903, 0.73913043478261, 1.4833333333333, 0.22727272727273
57904, 0.73913043478261, 1.4833333333333, 0.27272727272727
57905, 0.73913043478261, 1.4833333333333, 0.31818181818182
57906, 0.73913043478261, 1.4833333333333, 0.36363636363636
57907, 0.73913043478261, 1.4833333333333, 0.40909090909091
57908, 0.73913043478261, 1.4833333333333, 0.45454545454545
57909, 0.69565217391304, 1.4833333333333, 0.045454545454545
57910, 0.69565217391304, 1.4833333333333, 0.090909090909091
57911, 0.69565217391304, 1.4833333333333, 0.13636363636364
57912, 0.69565217391304, 1.4833333333333, 0.18181818181818
57913, 0.69565217391304, 1.4833333333333, 0.22727272727273
57914, 0.69565217391304, 1.4833333333333, 0.27272727272727
57915, 0.69565217391304, 1.4833333333333, 0.31818181818182
57916, 0.69565217391304, 1.4833333333333, 0.36363636363636
57917, 0.69565217391304, 1.4833333333333, 0.40909090909091
57918, 0.69565217391304, 1.4833333333333, 0.45454545454545
57919, 0.65217391304348, 1.4833333333333, 0.045454545454545
57920, 0.65217391304348, 1.4833333333333, 0.090909090909091
57921, 0.65217391304348, 1.4833333333333, 0.13636363636364
57922, 0.65217391304348, 1.4833333333333, 0.18181818181818
57923, 0.65217391304348, 1.4833333333333, 0.22727272727273
57924, 0.65217391304348, 1.4833333333333, 0.27272727272727
57925, 0.65217391304348, 1.4833333333333, 0.31818181818182
57926, 0.65217391304348, 1.4833333333333, 0.36363636363636
57927, 0.65217391304348, 1.4833333333333, 0.40909090909091
57928, 0.65217391304348, 1.4833333333333, 0.45454545454545
57929, 0.60869565217391, 1.4833333333333, 0.045454545454545
57930, 0.60869565217391, 1.4833333333333, 0.090909090909091
57931, 0.60869565217391, 1.4833333333333, 0.13636363636364
57932, 0.60869565217391, 1.4833333333333, 0.18181818181818
57933, 0.60869565217391, 1.4833333333333, 0.22727272727273
57934, 0.60869565217391, 1.4833333333333, 0.27272727272727
57935, 0.60869565217391, 1.4833333333333, 0.31818181818182
57936, 0.60869565217391, 1.4833333333333, 0.36363636363636
57937, 0.60869565217391, 1.4833333333333, 0.40909090909091
57938, 0.60869565217391, 1.4833333333333, 0.45454545454545
57939, 0.56521739130435, 1.4833333333333, 0.045454545454545
57940, 0.56521739130435, 1.4833333333333, 0.090909090909091
57941, 0.56521739130435, 1.4833333333333, 0.13636363636364
57942, 0.56521739130435, 1.4833333333333, 0.18181818181818
57943, 0.56521739130435, 1.4833333333333, 0.22727272727273
57944, 0.56521739130435, 1.4833333333333, 0.27272727272727
57945, 0.56521739130435, 1.4833333333333, 0.31818181818182
57946, 0.56521739130435, 1.4833333333333, 0.36363636363636
57947, 0.56521739130435, 1.4833333333333, 0.40909090909091
57948, 0.56521739130435, 1.4833333333333, 0.45454545454545
57949, 0.52173913043478, 1.4833333333333, 0.045454545454545
57950, 0.52173913043478, 1.4833333333333, 0.090909090909091
57951, 0.52173913043478, 1.4833333333333, 0.13636363636364
57952, 0.52173913043478, 1.4833333333333, 0.18181818181818
57953, 0.52173913043478, 1.4833333333333, 0.22727272727273
57954, 0.52173913043478, 1.4833333333333, 0.27272727272727
57955, 0.52173913043478, 1.4833333333333, 0.31818181818182
57956, 0.52173913043478, 1.4833333333333, 0.36363636363636
57957, 0.52173913043478, 1.4833333333333, 0.40909090909091
57958, 0.52173913043478, 1.4833333333333, 0.45454545454545
57959, 0.47826086956522, 1.4833333333333, 0.045454545454545
57960, 0.47826086956522, 1.4833333333333, 0.090909090909091
57961, 0.47826086956522, 1.4833333333333, 0.13636363636364
57962, 0.47826086956522, 1.4833333333333, 0.18181818181818
57963, 0.47826086956522, 1.4833333333333, 0.22727272727273
57964, 0.47826086956522, 1.4833333333333, 0.27272727272727
57965, 0.47826086956522, 1.4833333333333, 0.31818181818182
57966, 0.47826086956522, 1.4833333333333, 0.36363636363636
57967, 0.47826086956522, 1.4833333333333, 0.40909090909091
57968, 0.47826086956522, 1.4833333333333, 0.45454545454545
57969, 0.43478260869565, 1.4833333333333, 0.045454545454545
57970, 0.43478260869565, 1.4833333333333, 0.090909090909091
57971, 0.43478260869565, 1.4833333333333, 0.13636363636364
57972, 0.43478260869565, 1.4833333333333, 0.18181818181818
57973, 0.43478260869565, 1.4833333333333, 0.22727272727273
57974, 0.43478260869565, 1.4833333333333, 0.27272727272727
57975, 0.43478260869565, 1.4833333333333, 0.31818181818182
57976, 0.43478260869565, 1.4833333333333, 0.36363636363636
57977, 0.43478260869565, 1.4833333333333, 0.40909090909091
57978, 0.43478260869565, 1.4833333333333, 0.45454545454545
57979, 0.39130434782609, 1.4833333333333, 0.045454545454545
57980, 0.39130434782609, 1.4833333333333, 0.090909090909091
57981, 0.39130434782609, 1.4833333333333, 0.13636363636364
57982, 0.39130434782609, 1.4833333333333, 0.18181818181818
57983, 0.39130434782609, 1.4833333333333, 0.22727272727273
57984, 0.39130434782609, 1.4833333333333, 0.27272727272727
57985, 0.39130434782609, 1.4833333333333, 0.31818181818182
57986, 0.39130434782609, 1.4833333333333, 0.36363636363636
57987, 0.39130434782609, 1.4833333333333, 0.40909090909091
57988, 0.39130434782609, 1.4833333333333, 0.45454545454545
57989, 0.34782608695652, 1.4833333333333, 0.045454545454545
57990, 0.34782608695652, 1.4833333333333, 0.090909090909091
57991, 0.34782608695652, 1.4833333333333, 0.13636363636364
57992, 0.34782608695652, 1.4833333333333, 0.18181818181818
57993, 0.34782608695652, 1.4833333333333, 0.22727272727273
57994, 0.34782608695652, 1.4833333333333, 0.27272727272727
57995, 0.34782608695652, 1.4833333333333, 0.31818181818182
57996, 0.34782608695652, 1.4833333333333, 0.36363636363636
57997, 0.34782608695652, 1.4833333333333, 0.40909090909091
57998, 0.34782608695652, 1.4833333333333, 0.45454545454545
57999, 0.30434782608696, 1.4833333333333, 0.045454545454545
58000, 0.30434782608696, 1.4833333333333, 0.090909090909091
58001, 0.30434782608696, 1.4833333333333, 0.13636363636364
58002, 0.30434782608696, 1.4833333333333, 0.18181818181818
58003, 0.30434782608696, 1.4833333333333, 0.22727272727273
58004, 0.30434782608696, 1.4833333333333, 0.27272727272727
58005, 0.30434782608696, 1.4833333333333, 0.31818181818182
58006, 0.30434782608696, 1.4833333333333, 0.36363636363636
58007, 0.30434782608696, 1.4833333333333, 0.40909090909091
58008, 0.30434782608696, 1.4833333333333, 0.45454545454545
58009, 0.26086956521739, 1.4833333333333, 0.045454545454545
58010, 0.26086956521739, 1.4833333333333, 0.090909090909091
58011, 0.26086956521739, 1.4833333333333, 0.13636363636364
58012, 0.26086956521739, 1.4833333333333, 0.18181818181818
58013, 0.26086956521739, 1.4833333333333, 0.22727272727273
58014, 0.26086956521739, 1.4833333333333, 0.27272727272727
58015, 0.26086956521739, 1.4833333333333, 0.31818181818182
58016, 0.26086956521739, 1.4833333333333, 0.36363636363636
58017, 0.26086956521739, 1.4833333333333, 0.40909090909091
58018, 0.26086956521739, 1.4833333333333, 0.45454545454545
58019, 0.21739130434783, 1.4833333333333, 0.045454545454545
58020, 0.21739130434783, 1.4833333333333, 0.090909090909091
58021, 0.21739130434783, 1.4833333333333, 0.13636363636364
58022, 0.21739130434783, 1.4833333333333, 0.18181818181818
58023, 0.21739130434783, 1.4833333333333, 0.22727272727273
58024, 0.21739130434783, 1.4833333333333, 0.27272727272727
58025, 0.21739130434783, 1.4833333333333, 0.31818181818182
58026, 0.21739130434783, 1.4833333333333, 0.36363636363636
58027, 0.21739130434783, 1.4833333333333, 0.40909090909091
58028, 0.21739130434783, 1.4833333333333, 0.45454545454545
58029, 0.17391304347826, 1.4833333333333, 0.045454545454545
58030, 0.17391304347826, 1.4833333333333, 0.090909090909091
58031, 0.17391304347826, 1.4833333333333, 0.13636363636364
58032, 0.17391304347826, 1.4833333333333, 0.18181818181818
58033, 0.17391304347826, 1.4833333333333, 0.22727272727273
58034, 0.17391304347826, 1.4833333333333, 0.27272727272727
58035, 0.17391304347826, 1.4833333333333, 0.31818181818182
58036, 0.17391304347826, 1.4833333333333, 0.36363636363636
58037, 0.17391304347826, 1.4833333333333, 0.40909090909091
58038, 0.17391304347826, 1.4833333333333, 0.45454545454545
58039, 0.1304347826087, 1.4833333333333, 0.045454545454545
58040, 0.1304347826087, 1.4833333333333, 0.090909090909091
58041, 0.1304347826087, 1.4833333333333, 0.13636363636364
58042, 0.1304347826087, 1.4833333333333, 0.18181818181818
58043, 0.1304347826087, 1.4833333333333, 0.22727272727273
58044, 0.1304347826087, 1.4833333333333, 0.27272727272727
58045, 0.1304347826087, 1.4833333333333, 0.31818181818182
58046, 0.1304347826087, 1.4833333333333, 0.36363636363636
58047, 0.1304347826087, 1.4833333333333, 0.40909090909091
58048, 0.1304347826087, 1.4833333333333, 0.45454545454545
58049, 0.08695652173913, 1.4833333333333, 0.045454545454545
58050, 0.08695652173913, 1.4833333333333, 0.090909090909091
58051, 0.08695652173913, 1.4833333333333, 0.13636363636364
58052, 0.08695652173913, 1.4833333333333, 0.18181818181818
58053, 0.08695652173913, 1.4833333333333, 0.22727272727273
58054, 0.08695652173913, 1.4833333333333, 0.27272727272727
58055, 0.08695652173913, 1.4833333333333, 0.31818181818182
58056, 0.08695652173913, 1.4833333333333, 0.36363636363636
58057, 0.08695652173913, 1.4833333333333, 0.40909090909091
58058, 0.08695652173913, 1.4833333333333, 0.45454545454545
58059, 0.043478260869565, 1.4833333333333, 0.045454545454545
58060, 0.043478260869565, 1.4833333333333, 0.090909090909091
58061, 0.043478260869565, 1.4833333333333, 0.13636363636364
58062, 0.043478260869565, 1.4833333333333, 0.18181818181818
58063, 0.043478260869565, 1.4833333333333, 0.22727272727273
58064, 0.043478260869565, 1.4833333333333, 0.27272727272727
58065, 0.043478260869565, 1.4833333333333, 0.31818181818182
58066, 0.043478260869565, 1.4833333333333, 0.36363636363636
58067, 0.043478260869565, 1.4833333333333, 0.40909090909091
58068, 0.043478260869565, 1.4833333333333, 0.45454545454545
58069, 1.04, 1.4333333333333, 0.45454545454545
58070, 1.04, 1.4333333333333, 0.40909090909091
58071, 1.04, 1.4333333333333, 0.36363636363636
58072, 1.04, 1.4333333333333, 0.31818181818182
58073, 1.04, 1.4333333333333, 0.27272727272727
58074, 1.04, 1.4333333333333, 0.22727272727273
58075, 1.04, 1.4333333333333, 0.18181818181818
58076, 1.04, 1.4333333333333, 0.13636363636364
58077, 1.04, 1.4333333333333, 0.090909090909091
58078, 1.04, 1.4333333333333, 0.045454545454545
58079, 1.04, 1.4666666666667, 0.45454545454545
58080, 1.04, 1.4666666666667, 0.40909090909091
58081, 1.04, 1.4666666666667, 0.36363636363636
58082, 1.04, 1.4666666666667, 0.31818181818182
58083, 1.04, 1.4666666666667, 0.27272727272727
58084, 1.04, 1.4666666666667, 0.22727272727273
58085, 1.04, 1.4666666666667, 0.18181818181818
58086, 1.04, 1.4666666666667, 0.13636363636364
58087, 1.04, 1.4666666666667, 0.090909090909091
58088, 1.04, 1.4666666666667, 0.045454545454545
58089, 1.08, 1.4333333333333, 0.45454545454545
58090, 1.08, 1.4333333333333, 0.40909090909091
58091, 1.08, 1.4333333333333, 0.36363636363636
58092, 1.08, 1.4333333333333, 0.31818181818182
58093, 1.08, 1.4333333333333, 0.27272727272727
58094, 1.08, 1.4333333333333, 0.22727272727273
58095, 1.08, 1.4333333333333, 0.18181818181818
58096, 1.08, 1.4333333333333, 0.13636363636364
58097, 1.08, 1.4333333333333, 0.090909090909091
58098, 1.08, 1.4333333333333, 0.045454545454545
58099, 1.08, 1.4666666666667, 0.45454545454545
58100, 1.08, 1.4666666666667, 0.40909090909091
58101, 1.08, 1.4666666666667, 0.36363636363636
58102, 1.08, 1.4666666666667, 0.31818181818182
58103, 1.08, 1.4666666666667, 0.27272727272727
58104, 1.08, 1.4666666666667, 0.22727272727273
58105, 1.08, 1.4666666666667, 0.18181818181818
58106, 1.08, 1.4666666666667, 0.13636363636364
58107, 1.08, 1.4666666666667, 0.090909090909091
58108, 1.08, 1.4666666666667, 0.045454545454545
58109, 1.12, 1.4333333333333, 0.45454545454545
58110, 1.12, 1.4333333333333, 0.40909090909091
58111, 1.12, 1.4333333333333, 0.36363636363636
58112, 1.12, 1.4333333333333, 0.31818181818182
58113, 1.12, 1.4333333333333, 0.27272727272727
58114, 1.12, 1.4333333333333, 0.22727272727273
58115, 1.12, 1.4333333333333, 0.18181818181818
58116, 1.12, 1.4333333333333, 0.13636363636364
58117, 1.12, 1.4333333333333, 0.090909090909091
58118, 1.12, 1.4333333333333, 0.045454545454545
58119, 1.12, 1.4666666666667, 0.45454545454545
58120, 1.12, 1.4666666666667, 0.40909090909091
58121, 1.12, 1.4666666666667, 0.36363636363636
58122, 1.12, 1.4666666666667, 0.31818181818182
58123, 1.12, 1.4666666666667, 0.27272727272727
58124, 1.12, 1.4666666666667, 0.22727272727273
58125, 1.12, 1.4666666666667, 0.18181818181818
58126, 1.12, 1.4666666666667, 0.13636363636364
58127, 1.12, 1.4666666666667, 0.090909090909091
58128, 1.12, 1.4666666666667, 0.045454545454545
58129, 1.16, 1.4333333333333, 0.45454545454545
58130, 1.16, 1.4333333333333, 0.40909090909091
58131, 1.16, 1.4333333333333, 0.36363636363636
58132, 1.16, 1.4333333333333, 0.31818181818182
58133, 1.16, 1.4333333333333, 0.27272727272727
58134, 1.16, 1.4333333333333, 0.22727272727273
58135, 1.16, 1.4333333333333, 0.18181818181818
58136, 1.16, 1.4333333333333, 0.13636363636364
58137, 1.16, 1.4333333333333, 0.090909090909091
58138, 1.16, 1.4333333333333, 0.045454545454545
58139, 1.16, 1.4666666666667, 0.45454545454545
58140, 1.16, 1.4666666666667, 0.40909090909091
58141, 1.16, 1.4666666666667, 0.36363636363636
58142, 1.16, 1.4666666666667, 0.31818181818182
58143, 1.16, 1.4666666666667, 0.27272727272727
58144, 1.16, 1.4666666666667, 0.22727272727273
58145, 1.16, 1.4666666666667, 0.18181818181818
58146, 1.16, 1.4666666666667, 0.13636363636364
58147, 1.16, 1.4666666666667, 0.090909090909091
58148, 1.16, 1.4666666666667, 0.045454545454545
58149, 1.04, 1.4333333333333, 0.47727272727273
58150, 1.04, 1.4166666666667, 0.45454545454545
58151, 1.02, 1.4333333333333, 0.45454545454545
58152, 1.04, 1.4333333333333, 0.43181818181818
58153, 1.04, 1.4166666666667, 0.40909090909091
58154, 1.02, 1.4333333333333, 0.40909090909091
58155, 1.04, 1.4333333333333, 0.38636363636364
58156, 1.04, 1.4166666666667, 0.36363636363636
58157, 1.02, 1.4333333333333, 0.36363636363636
58158, 1.04, 1.4333333333333, 0.34090909090909
58159, 1.04, 1.4166666666667, 0.31818181818182
58160, 1.02, 1.4333333333333, 0.31818181818182
58161, 1.04, 1.4333333333333, 0.29545454545455
58162, 1.04, 1.4166666666667, 0.27272727272727
58163, 1.02, 1.4333333333333, 0.27272727272727
58164, 1.04, 1.4333333333333, 0.25
58165, 1.04, 1.4166666666667, 0.22727272727273
58166, 1.02, 1.4333333333333, 0.22727272727273
58167, 1.04, 1.4333333333333, 0.20454545454545
58168, 1.04, 1.4166666666667, 0.18181818181818
58169, 1.02, 1.4333333333333, 0.18181818181818
58170, 1.04, 1.4333333333333, 0.15909090909091
58171, 1.04, 1.4166666666667, 0.13636363636364
58172, 1.02, 1.4333333333333, 0.13636363636364
58173, 1.04, 1.4333333333333, 0.11363636363636
58174, 1.04, 1.4166666666667, 0.090909090909091
58175, 1.02, 1.4333333333333, 0.090909090909091
58176, 1.04, 1.4333333333333, 0.068181818181818
58177, 1.04, 1.4166666666667, 0.045454545454545
58178, 1.02, 1.4333333333333, 0.045454545454545
58179, 1.04, 1.4333333333333, 0.022727272727273
58180, 1.04, 1.4666666666667, 0.47727272727273
58181, 1.04, 1.45, 0.45454545454545
58182, 1.02, 1.4666666666667, 0.45454545454545
58183, 1.04, 1.4666666666667, 0.43181818181818
58184, 1.04, 1.45, 0.40909090909091
58185, 1.02, 1.4666666666667, 0.40909090909091
58186, 1.04, 1.4666666666667, 0.38636363636364
58187, 1.04, 1.45, 0.36363636363636
58188, 1.02, 1.4666666666667, 0.36363636363636
58189, 1.04, 1.4666666666667, 0.34090909090909
58190, 1.04, 1.45, 0.31818181818182
58191, 1.02, 1.4666666666667, 0.31818181818182
58192, 1.04, 1.4666666666667, 0.29545454545455
58193, 1.04, 1.45, 0.27272727272727
58194, 1.02, 1.4666666666667, 0.27272727272727
58195, 1.04, 1.4666666666667, 0.25
58196, 1.04, 1.45, 0.22727272727273
58197, 1.02, 1.4666666666667, 0.22727272727273
58198, 1.04, 1.4666666666667, 0.20454545454545
58199, 1.04, 1.45, 0.18181818181818
58200, 1.02, 1.4666666666667, 0.18181818181818
58201, 1.04, 1.4666666666667, 0.15909090909091
58202, 1.04, 1.45, 0.13636363636364
58203, 1.02, 1.4666666666667, 0.13636363636364
58204, 1.04, 1.4666666666667, 0.11363636363636
58205, 1.04, 1.45, 0.090909090909091
58206, 1.02, 1.4666666666667, 0.090909090909091
58207, 1.04, 1.4666666666667, 0.068181818181818
58208, 1.04, 1.45, 0.045454545454545
58209, 1.02, 1.4666666666667, 0.045454545454545
58210, 1.04, 1.4666666666667, 0.022727272727273
58211, 1.04, 1.4833333333333, 0.45454545454545
58212, 1.04, 1.4833333333333, 0.40909090909091
58213, 1.04, 1.4833333333333, 0.36363636363636
58214, 1.04, 1.4833333333333, 0.31818181818182
58215, 1.04, 1.4833333333333, 0.27272727272727
58216, 1.04, 1.4833333333333, 0.22727272727273
58217, 1.04, 1.4833333333333, 0.18181818181818
58218, 1.04, 1.4833333333333, 0.13636363636364
58219, 1.04, 1.4833333333333, 0.090909090909091
58220, 1.04, 1.4833333333333, 0.045454545454545
58221, 1.08, 1.4333333333333, 0.47727272727273
58222, 1.08, 1.4166666666667, 0.45454545454545
58223, 1.06, 1.4333333333333, 0.45454545454545
58224, 1.08, 1.4333333333333, 0.43181818181818
58225, 1.08, 1.4166666666667, 0.40909090909091
58226, 1.06, 1.4333333333333, 0.40909090909091
58227, 1.08, 1.4333333333333, 0.38636363636364
58228, 1.08, 1.4166666666667, 0.36363636363636
58229, 1.06, 1.4333333333333, 0.36363636363636
58230, 1.08, 1.4333333333333, 0.34090909090909
58231, 1.08, 1.4166666666667, 0.31818181818182
58232, 1.06, 1.4333333333333, 0.31818181818182
58233, 1.08, 1.4333333333333, 0.29545454545455
58234, 1.08, 1.4166666666667, 0.27272727272727
58235, 1.06, 1.4333333333333, 0.27272727272727
58236, 1.08, 1.4333333333333, 0.25
58237, 1.08, 1.4166666666667, 0.22727272727273
58238, 1.06, 1.4333333333333, 0.22727272727273
58239, 1.08, 1.4333333333333, 0.20454545454545
58240, 1.08, 1.4166666666667, 0.18181818181818
58241, 1.06, 1.4333333333333, 0.18181818181818
58242, 1.08, 1.4333333333333, 0.15909090909091
58243, 1.08, 1.4166666666667, 0.13636363636364
58244, 1.06, 1.4333333333333, 0.13636363636364
58245, 1.08, 1.4333333333333, 0.11363636363636
58246, 1.08, 1.4166666666667, 0.090909090909091
58247, 1.06, 1.4333333333333, 0.090909090909091
58248, 1.08, 1.4333333333333, 0.068181818181818
58249, 1.08, 1.4166666666667, 0.045454545454545
58250, 1.06, 1.4333333333333, 0.045454545454545
58251, 1.08, 1.4333333333333, 0.022727272727273
58252, 1.08, 1.4666666666667, 0.47727272727273
58253, 1.08, 1.45, 0.45454545454545
58254, 1.06, 1.4666666666667, 0.45454545454545
58255, 1.08, 1.4666666666667, 0.43181818181818
58256, 1.08, 1.45, 0.40909090909091
58257, 1.06, 1.4666666666667, 0.40909090909091
58258, 1.08, 1.4666666666667, 0.38636363636364
58259, 1.08, 1.45, 0.36363636363636
58260, 1.06, 1.4666666666667, 0.36363636363636
58261, 1.08, 1.4666666666667, 0.34090909090909
58262, 1.08, 1.45, 0.31818181818182
58263, 1.06, 1.4666666666667, 0.31818181818182
58264, 1.08, 1.4666666666667, 0.29545454545455
58265, 1.08, 1.45, 0.27272727272727
58266, 1.06, 1.4666666666667, 0.27272727272727
58267, 1.08, 1.4666666666667, 0.25
58268, 1.08, 1.45, 0.22727272727273
58269, 1.06, 1.4666666666667, 0.22727272727273
58270, 1.08, 1.4666666666667, 0.20454545454545
58271, 1.08, 1.45, 0.18181818181818
58272, 1.06, 1.4666666666667, 0.18181818181818
58273, 1.08, 1.4666666666667, 0.15909090909091
58274, 1.08, 1.45, 0.13636363636364
58275, 1.06, 1.4666666666667, 0.13636363636364
58276, 1.08, 1.4666666666667, 0.11363636363636
58277, 1.08, 1.45, 0.090909090909091
58278, 1.06, 1.4666666666667, 0.090909090909091
58279, 1.08, 1.4666666666667, 0.068181818181818
58280, 1.08, 1.45, 0.045454545454545
58281, 1.06, 1.4666666666667, 0.045454545454545
58282, 1.08, 1.4666666666667, 0.022727272727273
58283, 1.08, 1.4833333333333, 0.45454545454545
58284, 1.08, 1.4833333333333, 0.40909090909091
58285, 1.08, 1.4833333333333, 0.36363636363636
58286, 1.08, 1.4833333333333, 0.31818181818182
58287, 1.08, 1.4833333333333, 0.27272727272727
58288, 1.08, 1.4833333333333, 0.22727272727273
58289, 1.08, 1.4833333333333, 0.18181818181818
58290, 1.08, 1.4833333333333, 0.13636363636364
58291, 1.08, 1.4833333333333, 0.090909090909091
58292, 1.08, 1.4833333333333, 0.045454545454545
58293, 1.12, 1.4333333333333, 0.47727272727273
58294, 1.12, 1.4166666666667, 0.45454545454545
58295, 1.1, 1.4333333333333, 0.45454545454545
58296, 1.12, 1.4333333333333, 0.43181818181818
58297, 1.12, 1.4166666666667, 0.40909090909091
58298, 1.1, 1.4333333333333, 0.40909090909091
58299, 1.12, 1.4333333333333, 0.38636363636364
58300, 1.12, 1.4166666666667, 0.36363636363636
58301, 1.1, 1.4333333333333, 0.36363636363636
58302, 1.12, 1.4333333333333, 0.34090909090909
58303, 1.12, 1.4166666666667, 0.31818181818182
58304, 1.1, 1.4333333333333, 0.31818181818182
58305, 1.12, 1.4333333333333, 0.29545454545455
58306, 1.12, 1.4166666666667, 0.27272727272727
58307, 1.1, 1.4333333333333, 0.27272727272727
58308, 1.12, 1.4333333333333, 0.25
58309, 1.12, 1.4166666666667, 0.22727272727273
58310, 1.1, 1.4333333333333, 0.22727272727273
58311, 1.12, 1.4333333333333, 0.20454545454545
58312, 1.12, 1.4166666666667, 0.18181818181818
58313, 1.1, 1.4333333333333, 0.18181818181818
58314, 1.12, 1.4333333333333, 0.15909090909091
58315, 1.12, 1.4166666666667, 0.13636363636364
58316, 1.1, 1.4333333333333, 0.13636363636364
58317, 1.12, 1.4333333333333, 0.11363636363636
58318, 1.12, 1.4166666666667, 0.090909090909091
58319, 1.1, 1.4333333333333, 0.090909090909091
58320, 1.12, 1.4333333333333, 0.068181818181818
58321, 1.12, 1.4166666666667, 0.045454545454545
58322, 1.1, 1.4333333333333, 0.045454545454545
58323, 1.12, 1.4333333333333, 0.022727272727273
58324, 1.12, 1.4666666666667, 0.47727272727273
58325, 1.12, 1.45, 0.45454545454545
58326, 1.1, 1.4666666666667, 0.45454545454545
58327, 1.12, 1.4666666666667, 0.43181818181818
58328, 1.12, 1.45, 0.40909090909091
58329, 1.1, 1.4666666666667, 0.40909090909091
58330, 1.12, 1.4666666666667, 0.38636363636364
58331, 1.12, 1.45, 0.36363636363636
58332, 1.1, 1.4666666666667, 0.36363636363636
58333, 1.12, 1.4666666666667, 0.34090909090909
58334, 1.12, 1.45, 0.31818181818182
58335, 1.1, 1.4666666666667, 0.31818181818182
58336, 1.12, 1.4666666666667, 0.29545454545455
58337, 1.12, 1.45, 0.27272727272727
58338, 1.1, 1.4666666666667, 0.27272727272727
58339, 1.12, 1.4666666666667, 0.25
58340, 1.12, 1.45, 0.22727272727273
58341, 1.1, 1.4666666666667, 0.22727272727273
58342, 1.12, 1.4666666666667, 0.20454545454545
58343, 1.12, 1.45, 0.18181818181818
58344, 1.1, 1.4666666666667, 0.18181818181818
58345, 1.12, 1.4666666666667, 0.15909090909091
58346, 1.12, 1.45, 0.13636363636364
58347, 1.1, 1.4666666666667, 0.13636363636364
58348, 1.12, 1.4666666666667, 0.11363636363636
58349, 1.12, 1.45, 0.090909090909091
58350, 1.1, 1.4666666666667, 0.090909090909091
58351, 1.12, 1.4666666666667, 0.068181818181818
58352, 1.12, 1.45, 0.045454545454545
58353, 1.1, 1.4666666666667, 0.045454545454545
58354, 1.12, 1.4666666666667, 0.022727272727273
58355, 1.12, 1.4833333333333, 0.45454545454545
58356, 1.12, 1.4833333333333, 0.40909090909091
58357, 1.12, 1.4833333333333, 0.36363636363636
58358, 1.12, 1.4833333333333, 0.31818181818182
58359, 1.12, 1.4833333333333, 0.27272727272727
58360, 1.12, 1.4833333333333, 0.22727272727273
58361, 1.12, 1.4833333333333, 0.18181818181818
58362, 1.12, 1.4833333333333, 0.13636363636364
58363, 1.12, 1.4833333333333, 0.090909090909091
58364, 1.12, 1.4833333333333, 0.045454545454545
58365, 1.16, 1.4333333333333, 0.47727272727273
58366, 1.16, 1.4166666666667, 0.45454545454545
58367, 1.14, 1.4333333333333, 0.45454545454545
58368, 1.16, 1.4333333333333, 0.43181818181818
58369, 1.16, 1.4166666666667, 0.40909090909091
58370, 1.14, 1.4333333333333, 0.40909090909091
58371, 1.16, 1.4333333333333, 0.38636363636364
58372, 1.16, 1.4166666666667, 0.36363636363636
58373, 1.14, 1.4333333333333, 0.36363636363636
58374, 1.16, 1.4333333333333, 0.34090909090909
58375, 1.16, 1.4166666666667, 0.31818181818182
58376, 1.14, 1.4333333333333, 0.31818181818182
58377, 1.16, 1.4333333333333, 0.29545454545455
58378, 1.16, 1.4166666666667, 0.27272727272727
58379, 1.14, 1.4333333333333, 0.27272727272727
58380, 1.16, 1.4333333333333, 0.25
58381, 1.16, 1.4166666666667, 0.22727272727273
58382, 1.14, 1.4333333333333, 0.22727272727273
58383, 1.16, 1.4333333333333, 0.20454545454545
58384, 1.16, 1.4166666666667, 0.18181818181818
58385, 1.14, 1.4333333333333, 0.18181818181818
58386, 1.16, 1.4333333333333, 0.15909090909091
58387, 1.16, 1.4166666666667, 0.13636363636364
58388, 1.14, 1.4333333333333, 0.13636363636364
58389, 1.16, 1.4333333333333, 0.11363636363636
58390, 1.16, 1.4166666666667, 0.090909090909091
58391, 1.14, 1.4333333333333, 0.090909090909091
58392, 1.16, 1.4333333333333, 0.068181818181818
58393, 1.16, 1.4166666666667, 0.045454545454545
58394, 1.14, 1.4333333333333, 0.045454545454545
58395, 1.16, 1.4333333333333, 0.022727272727273
58396, 1.16, 1.4666666666667, 0.47727272727273
58397, 1.16, 1.45, 0.45454545454545
58398, 1.14, 1.4666666666667, 0.45454545454545
58399, 1.16, 1.4666666666667, 0.43181818181818
58400, 1.16, 1.45, 0.40909090909091
58401, 1.14, 1.4666666666667, 0.40909090909091
58402, 1.16, 1.4666666666667, 0.38636363636364
58403, 1.16, 1.45, 0.36363636363636
58404, 1.14, 1.4666666666667, 0.36363636363636
58405, 1.16, 1.4666666666667, 0.34090909090909
58406, 1.16, 1.45, 0.31818181818182
58407, 1.14, 1.4666666666667, 0.31818181818182
58408, 1.16, 1.4666666666667, 0.29545454545455
58409, 1.16, 1.45, 0.27272727272727
58410, 1.14, 1.4666666666667, 0.27272727272727
58411, 1.16, 1.4666666666667, 0.25
58412, 1.16, 1.45, 0.22727272727273
58413, 1.14, 1.4666666666667, 0.22727272727273
58414, 1.16, 1.4666666666667, 0.20454545454545
58415, 1.16, 1.45, 0.18181818181818
58416, 1.14, 1.4666666666667, 0.18181818181818
58417, 1.16, 1.4666666666667, 0.15909090909091
58418, 1.16, 1.45, 0.13636363636364
58419, 1.14, 1.4666666666667, 0.13636363636364
58420, 1.16, 1.4666666666667, 0.11363636363636
58421, 1.16, 1.45, 0.090909090909091
58422, 1.14, 1.4666666666667, 0.090909090909091
58423, 1.16, 1.4666666666667, 0.068181818181818
58424, 1.16, 1.45, 0.045454545454545
58425, 1.14, 1.4666666666667, 0.045454545454545
58426, 1.16, 1.4666666666667, 0.022727272727273
58427, 1.16, 1.4833333333333, 0.45454545454545
58428, 1.16, 1.4833333333333, 0.40909090909091
58429, 1.16, 1.4833333333333, 0.36363636363636
58430, 1.16, 1.4833333333333, 0.31818181818182
58431, 1.16, 1.4833333333333, 0.27272727272727
58432, 1.16, 1.4833333333333, 0.22727272727273
58433, 1.16, 1.4833333333333, 0.18181818181818
58434, 1.16, 1.4833333333333, 0.13636363636364
58435, 1.16, 1.4833333333333, 0.090909090909091
58436, 1.16, 1.4833333333333, 0.045454545454545
58437, 1.18, 1.4333333333333, 0.45454545454545
58438, 1.18, 1.4333333333333, 0.40909090909091
58439, 1.18, 1.4333333333333, 0.36363636363636
58440, 1.18, 1.4333333333333, 0.31818181818182
58441, 1.18, 1.4333333333333, 0.27272727272727
58442, 1.18, 1.4333333333333, 0.22727272727273
58443, 1.18, 1.4333333333333, 0.18181818181818
58444, 1.18, 1.4333333333333, 0.13636363636364
58445, 1.18, 1.4333333333333, 0.090909090909091
58446, 1.18, 1.4333333333333, 0.045454545454545
58447, 1.18, 1.4666666666667, 0.45454545454545
58448, 1.18, 1.4666666666667, 0.40909090909091
58449, 1.18, 1.4666666666667, 0.36363636363636
58450, 1.18, 1.4666666666667, 0.31818181818182
58451, 1.18, 1.4666666666667, 0.27272727272727
58452, 1.18, 1.4666666666667, 0.22727272727273
58453, 1.18, 1.4666666666667, 0.18181818181818
58454, 1.18, 1.4666666666667, 0.13636363636364
58455, 1.18, 1.4666666666667, 0.090909090909091
58456, 1.18, 1.4666666666667, 0.045454545454545
58457, 1.2434782608696, 1.4333333333333, 0.45454545454545
58458, 1.2434782608696, 1.4333333333333, 0.40909090909091
58459, 1.2434782608696, 1.4333333333333, 0.36363636363636
58460, 1.2434782608696, 1.4333333333333, 0.31818181818182
58461, 1.2434782608696, 1.4333333333333, 0.27272727272727
58462, 1.2434782608696, 1.4333333333333, 0.22727272727273
58463, 1.2434782608696, 1.4333333333333, 0.18181818181818
58464, 1.2434782608696, 1.4333333333333, 0.13636363636364
58465, 1.2434782608696, 1.4333333333333, 0.090909090909091
58466, 1.2434782608696, 1.4333333333333, 0.045454545454545
58467, 1.2434782608696, 1.4666666666667, 0.45454545454545
58468, 1.2434782608696, 1.4666666666667, 0.40909090909091
58469, 1.2434782608696, 1.4666666666667, 0.36363636363636
58470, 1.2434782608696, 1.4666666666667, 0.31818181818182
58471, 1.2434782608696, 1.4666666666667, 0.27272727272727
58472, 1.2434782608696, 1.4666666666667, 0.22727272727273
58473, 1.2434782608696, 1.4666666666667, 0.18181818181818
58474, 1.2434782608696, 1.4666666666667, 0.13636363636364
58475, 1.2434782608696, 1.4666666666667, 0.090909090909091
58476, 1.2434782608696, 1.4666666666667, 0.045454545454545
58477, 1.2869565217391, 1.4333333333333, 0.45454545454545
58478, 1.2869565217391, 1.4333333333333, 0.40909090909091
58479, 1.2869565217391, 1.4333333333333, 0.36363636363636
58480, 1.2869565217391, 1.4333333333333, 0.31818181818182
58481, 1.2869565217391, 1.4333333333333, 0.27272727272727
58482, 1.2869565217391, 1.4333333333333, 0.22727272727273
58483, 1.2869565217391, 1.4333333333333, 0.18181818181818
58484, 1.2869565217391, 1.4333333333333, 0.13636363636364
58485, 1.2869565217391, 1.4333333333333, 0.090909090909091
58486, 1.2869565217391, 1.4333333333333, 0.045454545454545
58487, 1.2869565217391, 1.4666666666667, 0.45454545454545
58488, 1.2869565217391, 1.4666666666667, 0.40909090909091
58489, 1.2869565217391, 1.4666666666667, 0.36363636363636
58490, 1.2869565217391, 1.4666666666667, 0.31818181818182
58491, 1.2869565217391, 1.4666666666667, 0.27272727272727
58492, 1.2869565217391, 1.4666666666667, 0.22727272727273
58493, 1.2869565217391, 1.4666666666667, 0.18181818181818
58494, 1.2869565217391, 1.4666666666667, 0.13636363636364
58495, 1.2869565217391, 1.4666666666667, 0.090909090909091
58496, 1.2869565217391, 1.4666666666667, 0.045454545454545
58497, 1.3304347826087, 1.4333333333333, 0.45454545454545
58498, 1.3304347826087, 1.4333333333333, 0.40909090909091
58499, 1.3304347826087, 1.4333333333333, 0.36363636363636
58500, 1.3304347826087, 1.4333333333333, 0.31818181818182
58501, 1.3304347826087, 1.4333333333333, 0.27272727272727
58502, 1.3304347826087, 1.4333333333333, 0.22727272727273
58503, 1.3304347826087, 1.4333333333333, 0.18181818181818
58504, 1.3304347826087, 1.4333333333333, 0.13636363636364
58505, 1.3304347826087, 1.4333333333333, 0.090909090909091
58506, 1.3304347826087, 1.4333333333333, 0.045454545454545
58507, 1.3304347826087, 1.4666666666667, 0.45454545454545
58508, 1.3304347826087, 1.4666666666667, 0.40909090909091
58509, 1.3304347826087, 1.4666666666667, 0.36363636363636
58510, 1.3304347826087, 1.4666666666667, 0.31818181818182
58511, 1.3304347826087, 1.4666666666667, 0.27272727272727
58512, 1.3304347826087, 1.4666666666667, 0.22727272727273
58513, 1.3304347826087, 1.4666666666667, 0.18181818181818
58514, 1.3304347826087, 1.4666666666667, 0.13636363636364
58515, 1.3304347826087, 1.4666666666667, 0.090909090909091
58516, 1.3304347826087, 1.4666666666667, 0.045454545454545
58517, 1.3739130434783, 1.4333333333333, 0.45454545454545
58518, 1.3739130434783, 1.4333333333333, 0.40909090909091
58519, 1.3739130434783, 1.4333333333333, 0.36363636363636
58520, 1.3739130434783, 1.4333333333333, 0.31818181818182
58521, 1.3739130434783, 1.4333333333333, 0.27272727272727
58522, 1.3739130434783, 1.4333333333333, 0.22727272727273
58523, 1.3739130434783, 1.4333333333333, 0.18181818181818
58524, 1.3739130434783, 1.4333333333333, 0.13636363636364
58525, 1.3739130434783, 1.4333333333333, 0.090909090909091
58526, 1.3739130434783, 1.4333333333333, 0.045454545454545
58527, 1.3739130434783, 1.4666666666667, 0.45454545454545
58528, 1.3739130434783, 1.4666666666667, 0.40909090909091
58529, 1.3739130434783, 1.4666666666667, 0.36363636363636
58530, 1.3739130434783, 1.4666666666667, 0.31818181818182
58531, 1.3739130434783, 1.4666666666667, 0.27272727272727
58532, 1.3739130434783, 1.4666666666667, 0.22727272727273
58533, 1.3739130434783, 1.4666666666667, 0.18181818181818
58534, 1.3739130434783, 1.4666666666667, 0.13636363636364
58535, 1.3739130434783, 1.4666666666667, 0.090909090909091
58536, 1.3739130434783, 1.4666666666667, 0.045454545454545
58537, 1.4173913043478, 1.4333333333333, 0.45454545454545
58538, 1.4173913043478, 1.4333333333333, 0.40909090909091
58539, 1.4173913043478, 1.4333333333333, 0.36363636363636
58540, 1.4173913043478, 1.4333333333333, 0.31818181818182
58541, 1.4173913043478, 1.4333333333333, 0.27272727272727
58542, 1.4173913043478, 1.4333333333333, 0.22727272727273
58543, 1.4173913043478, 1.4333333333333, 0.18181818181818
58544, 1.4173913043478, 1.4333333333333, 0.13636363636364
58545, 1.4173913043478, 1.4333333333333, 0.090909090909091
58546, 1.4173913043478, 1.4333333333333, 0.045454545454545
58547, 1.4173913043478, 1.4666666666667, 0.45454545454545
58548, 1.4173913043478, 1.4666666666667, 0.40909090909091
58549, 1.4173913043478, 1.4666666666667, 0.36363636363636
58550, 1.4173913043478, 1.4666666666667, 0.31818181818182
58551, 1.4173913043478, 1.4666666666667, 0.27272727272727
58552, 1.4173913043478, 1.4666666666667, 0.22727272727273
58553, 1.4173913043478, 1.4666666666667, 0.18181818181818
58554, 1.4173913043478, 1.4666666666667, 0.13636363636364
58555, 1.4173913043478, 1.4666666666667, 0.090909090909091
58556, 1.4173913043478, 1.4666666666667, 0.045454545454545
58557, 1.4608695652174, 1.4333333333333, 0.45454545454545
58558, 1.4608695652174, 1.4333333333333, 0.40909090909091
58559, 1.4608695652174, 1.4333333333333, 0.36363636363636
58560, 1.4608695652174, 1.4333333333333, 0.31818181818182
58561, 1.4608695652174, 1.4333333333333, 0.27272727272727
58562, 1.4608695652174, 1.4333333333333, 0.22727272727273
58563, 1.4608695652174, 1.4333333333333, 0.18181818181818
58564, 1.4608695652174, 1.4333333333333, 0.13636363636364
58565, 1.4608695652174, 1.4333333333333, 0.090909090909091
58566, 1.4608695652174, 1.4333333333333, 0.045454545454545
58567, 1.4608695652174, 1.4666666666667, 0.45454545454545
58568, 1.4608695652174, 1.4666666666667, 0.40909090909091
58569, 1.4608695652174, 1.4666666666667, 0.36363636363636
58570, 1.4608695652174, 1.4666666666667, 0.31818181818182
58571, 1.4608695652174, 1.4666666666667, 0.27272727272727
58572, 1.4608695652174, 1.4666666666667, 0.22727272727273
58573, 1.4608695652174, 1.4666666666667, 0.18181818181818
58574, 1.4608695652174, 1.4666666666667, 0.13636363636364
58575, 1.4608695652174, 1.4666666666667, 0.090909090909091
58576, 1.4608695652174, 1.4666666666667, 0.045454545454545
58577, 1.504347826087, 1.4333333333333, 0.45454545454545
58578, 1.504347826087, 1.4333333333333, 0.40909090909091
58579, 1.504347826087, 1.4333333333333, 0.36363636363636
58580, 1.504347826087, 1.4333333333333, 0.31818181818182
58581, 1.504347826087, 1.4333333333333, 0.27272727272727
58582, 1.504347826087, 1.4333333333333, 0.22727272727273
58583, 1.504347826087, 1.4333333333333, 0.18181818181818
58584, 1.504347826087, 1.4333333333333, 0.13636363636364
58585, 1.504347826087, 1.4333333333333, 0.090909090909091
58586, 1.504347826087, 1.4333333333333, 0.045454545454545
58587, 1.504347826087, 1.4666666666667, 0.45454545454545
58588, 1.504347826087, 1.4666666666667, 0.40909090909091
58589, 1.504347826087, 1.4666666666667, 0.36363636363636
58590, 1.504347826087, 1.4666666666667, 0.31818181818182
58591, 1.504347826087, 1.4666666666667, 0.27272727272727
58592, 1.504347826087, 1.4666666666667, 0.22727272727273
58593, 1.504347826087, 1.4666666666667, 0.18181818181818
58594, 1.504347826087, 1.4666666666667, 0.13636363636364
58595, 1.504347826087, 1.4666666666667, 0.090909090909091
58596, 1.504347826087, 1.4666666666667, 0.045454545454545
58597, 1.5478260869565, 1.4333333333333, 0.45454545454545
58598, 1.5478260869565, 1.4333333333333, 0.40909090909091
58599, 1.5478260869565, 1.4333333333333, 0.36363636363636
58600, 1.5478260869565, 1.4333333333333, 0.31818181818182
58601, 1.5478260869565, 1.4333333333333, 0.27272727272727
58602, 1.5478260869565, 1.4333333333333, 0.22727272727273
58603, 1.5478260869565, 1.4333333333333, 0.18181818181818
58604, 1.5478260869565, 1.4333333333333, 0.13636363636364
58605, 1.5478260869565, 1.4333333333333, 0.090909090909091
58606, 1.5478260869565, 1.4333333333333, 0.045454545454545
58607, 1.5478260869565, 1.4666666666667, 0.45454545454545
58608, 1.5478260869565, 1.4666666666667, 0.40909090909091
58609, 1.5478260869565, 1.4666666666667, 0.36363636363636
58610, 1.5478260869565, 1.4666666666667, 0.31818181818182
58611, 1.5478260869565, 1.4666666666667, 0.27272727272727
58612, 1.5478260869565, 1.4666666666667, 0.22727272727273
58613, 1.5478260869565, 1.4666666666667, 0.18181818181818
58614, 1.5478260869565, 1.4666666666667, 0.13636363636364
58615, 1.5478260869565, 1.4666666666667, 0.090909090909091
58616, 1.5478260869565, 1.4666666666667, 0.045454545454545
58617, 1.5913043478261, 1.4333333333333, 0.45454545454545
58618, 1.5913043478261, 1.4333333333333, 0.40909090909091
58619, 1.5913043478261, 1.4333333333333, 0.36363636363636
58620, 1.5913043478261, 1.4333333333333, 0.31818181818182
58621, 1.5913043478261, 1.4333333333333, 0.27272727272727
58622, 1.5913043478261, 1.4333333333333, 0.22727272727273
58623, 1.5913043478261, 1.4333333333333, 0.18181818181818
58624, 1.5913043478261, 1.4333333333333, 0.13636363636364
58625, 1.5913043478261, 1.4333333333333, 0.090909090909091
58626, 1.5913043478261, 1.4333333333333, 0.045454545454545
58627, 1.5913043478261, 1.4666666666667, 0.45454545454545
58628, 1.5913043478261, 1.4666666666667, 0.40909090909091
58629, 1.5913043478261, 1.4666666666667, 0.36363636363636
58630, 1.5913043478261, 1.4666666666667, 0.31818181818182
58631, 1.5913043478261, 1.4666666666667, 0.27272727272727
58632, 1.5913043478261, 1.4666666666667, 0.22727272727273
58633, 1.5913043478261, 1.4666666666667, 0.18181818181818
58634, 1.5913043478261, 1.4666666666667, 0.13636363636364
58635, 1.5913043478261, 1.4666666666667, 0.090909090909091
58636, 1.5913043478261, 1.4666666666667, 0.045454545454545
58637, 1.6347826086957, 1.4333333333333, 0.45454545454545
58638, 1.6347826086957, 1.4333333333333, 0.40909090909091
58639, 1.6347826086957, 1.4333333333333, 0.36363636363636
58640, 1.6347826086957, 1.4333333333333, 0.31818181818182
58641, 1.6347826086957, 1.4333333333333, 0.27272727272727
58642, 1.6347826086957, 1.4333333333333, 0.22727272727273
58643, 1.6347826086957, 1.4333333333333, 0.18181818181818
58644, 1.6347826086957, 1.4333333333333, 0.13636363636364
58645, 1.6347826086957, 1.4333333333333, 0.090909090909091
58646, 1.6347826086957, 1.4333333333333, 0.045454545454545
58647, 1.6347826086957, 1.4666666666667, 0.45454545454545
58648, 1.6347826086957, 1.4666666666667, 0.40909090909091
58649, 1.6347826086957, 1.4666666666667, 0.36363636363636
58650, 1.6347826086957, 1.4666666666667, 0.31818181818182
58651, 1.6347826086957, 1.4666666666667, 0.27272727272727
58652, 1.6347826086957, 1.4666666666667, 0.22727272727273
58653, 1.6347826086957, 1.4666666666667, 0.18181818181818
58654, 1.6347826086957, 1.4666666666667, 0.13636363636364
58655, 1.6347826086957, 1.4666666666667, 0.090909090909091
58656, 1.6347826086957, 1.4666666666667, 0.045454545454545
58657, 1.6782608695652, 1.4333333333333, 0.45454545454545
58658, 1.6782608695652, 1.4333333333333, 0.40909090909091
58659, 1.6782608695652, 1.4333333333333, 0.36363636363636
58660, 1.6782608695652, 1.4333333333333, 0.31818181818182
58661, 1.6782608695652, 1.4333333333333, 0.27272727272727
58662, 1.6782608695652, 1.4333333333333, 0.22727272727273
58663, 1.6782608695652, 1.4333333333333, 0.18181818181818
58664, 1.6782608695652, 1.4333333333333, 0.13636363636364
58665, 1.6782608695652, 1.4333333333333, 0.090909090909091
58666, 1.6782608695652, 1.4333333333333, 0.045454545454545
58667, 1.6782608695652, 1.4666666666667, 0.45454545454545
58668, 1.6782608695652, 1.4666666666667, 0.40909090909091
58669, 1.6782608695652, 1.4666666666667, 0.36363636363636
58670, 1.6782608695652, 1.4666666666667, 0.31818181818182
58671, 1.6782608695652, 1.4666666666667, 0.27272727272727
58672, 1.6782608695652, 1.4666666666667, 0.22727272727273
58673, 1.6782608695652, 1.4666666666667, 0.18181818181818
58674, 1.6782608695652, 1.4666666666667, 0.13636363636364
58675, 1.6782608695652, 1.4666666666667, 0.090909090909091
58676, 1.6782608695652, 1.4666666666667, 0.045454545454545
58677, 1.7217391304348, 1.4333333333333, 0.45454545454545
58678, 1.7217391304348, 1.4333333333333, 0.40909090909091
58679, 1.7217391304348, 1.4333333333333, 0.36363636363636
58680, 1.7217391304348, 1.4333333333333, 0.31818181818182
58681, 1.7217391304348, 1.4333333333333, 0.27272727272727
58682, 1.7217391304348, 1.4333333333333, 0.22727272727273
58683, 1.7217391304348, 1.4333333333333, 0.18181818181818
58684, 1.7217391304348, 1.4333333333333, 0.13636363636364
58685, 1.7217391304348, 1.4333333333333, 0.090909090909091
58686, 1.7217391304348, 1.4333333333333, 0.045454545454545
58687, 1.7217391304348, 1.4666666666667, 0.45454545454545
58688, 1.7217391304348, 1.4666666666667, 0.40909090909091
58689, 1.7217391304348, 1.4666666666667, 0.36363636363636
58690, 1.7217391304348, 1.4666666666667, 0.31818181818182
58691, 1.7217391304348, 1.4666666666667, 0.27272727272727
58692, 1.7217391304348, 1.4666666666667, 0.22727272727273
58693, 1.7217391304348, 1.4666666666667, 0.18181818181818
58694, 1.7217391304348, 1.4666666666667, 0.13636363636364
58695, 1.7217391304348, 1.4666666666667, 0.090909090909091
58696, 1.7217391304348, 1.4666666666667, 0.045454545454545
58697, 1.7652173913043, 1.4333333333333, 0.45454545454545
58698, 1.7652173913043, 1.4333333333333, 0.40909090909091
58699, 1.7652173913043, 1.4333333333333, 0.36363636363636
58700, 1.7652173913043, 1.4333333333333, 0.31818181818182
58701, 1.7652173913043, 1.4333333333333, 0.27272727272727
58702, 1.7652173913043, 1.4333333333333, 0.22727272727273
58703, 1.7652173913043, 1.4333333333333, 0.18181818181818
58704, 1.7652173913043, 1.4333333333333, 0.13636363636364
58705, 1.7652173913043, 1.4333333333333, 0.090909090909091
58706, 1.7652173913043, 1.4333333333333, 0.045454545454545
58707, 1.7652173913043, 1.4666666666667, 0.45454545454545
58708, 1.7652173913043, 1.4666666666667, 0.40909090909091
58709, 1.7652173913043, 1.4666666666667, 0.36363636363636
58710, 1.7652173913043, 1.4666666666667, 0.31818181818182
58711, 1.7652173913043, 1.4666666666667, 0.27272727272727
58712, 1.7652173913043, 1.4666666666667, 0.22727272727273
58713, 1.7652173913043, 1.4666666666667, 0.18181818181818
58714, 1.7652173913043, 1.4666666666667, 0.13636363636364
58715, 1.7652173913043, 1.4666666666667, 0.090909090909091
58716, 1.7652173913043, 1.4666666666667, 0.045454545454545
58717, 1.8086956521739, 1.4333333333333, 0.45454545454545
58718, 1.8086956521739, 1.4333333333333, 0.40909090909091
58719, 1.8086956521739, 1.4333333333333, 0.36363636363636
58720, 1.8086956521739, 1.4333333333333, 0.31818181818182
58721, 1.8086956521739, 1.4333333333333, 0.27272727272727
58722, 1.8086956521739, 1.4333333333333, 0.22727272727273
58723, 1.8086956521739, 1.4333333333333, 0.18181818181818
58724, 1.8086956521739, 1.4333333333333, 0.13636363636364
58725, 1.8086956521739, 1.4333333333333, 0.090909090909091
58726, 1.8086956521739, 1.4333333333333, 0.045454545454545
58727, 1.8086956521739, 1.4666666666667, 0.45454545454545
58728, 1.8086956521739, 1.4666666666667, 0.40909090909091
58729, 1.8086956521739, 1.4666666666667, 0.36363636363636
58730, 1.8086956521739, 1.4666666666667, 0.31818181818182
58731, 1.8086956521739, 1.4666666666667, 0.27272727272727
58732, 1.8086956521739, 1.4666666666667, 0.22727272727273
58733, 1.8086956521739, 1.4666666666667, 0.18181818181818
58734, 1.8086956521739, 1.4666666666667, 0.13636363636364
58735, 1.8086956521739, 1.4666666666667, 0.090909090909091
58736, 1.8086956521739, 1.4666666666667, 0.045454545454545
58737, 1.8521739130435, 1.4333333333333, 0.45454545454545
58738, 1.8521739130435, 1.4333333333333, 0.40909090909091
