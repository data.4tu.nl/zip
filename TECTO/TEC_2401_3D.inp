91294, 1.5478260869565, 1.625, 0.27272727272727
91295, 1.5478260869565, 1.65, 0.25
91296, 1.5260869565217, 1.65, 0.22727272727273
91297, 1.5478260869565, 1.625, 0.22727272727273
91298, 1.5478260869565, 1.65, 0.20454545454545
91299, 1.5260869565217, 1.65, 0.18181818181818
91300, 1.5478260869565, 1.625, 0.18181818181818
91301, 1.5478260869565, 1.65, 0.15909090909091
91302, 1.5260869565217, 1.65, 0.13636363636364
91303, 1.5478260869565, 1.625, 0.13636363636364
91304, 1.5478260869565, 1.65, 0.11363636363636
91305, 1.5260869565217, 1.65, 0.090909090909091
91306, 1.5478260869565, 1.625, 0.090909090909091
91307, 1.5478260869565, 1.65, 0.068181818181818
91308, 1.5260869565217, 1.65, 0.045454545454545
91309, 1.5478260869565, 1.625, 0.045454545454545
91310, 1.5478260869565, 1.65, 0.022727272727273
91311, 1.5913043478261, 1.65, 0.47727272727273
91312, 1.5695652173913, 1.65, 0.45454545454545
91313, 1.5913043478261, 1.625, 0.45454545454545
91314, 1.5913043478261, 1.65, 0.43181818181818
91315, 1.5695652173913, 1.65, 0.40909090909091
91316, 1.5913043478261, 1.625, 0.40909090909091
91317, 1.5913043478261, 1.65, 0.38636363636364
91318, 1.5695652173913, 1.65, 0.36363636363636
91319, 1.5913043478261, 1.625, 0.36363636363636
91320, 1.5913043478261, 1.65, 0.34090909090909
91321, 1.5695652173913, 1.65, 0.31818181818182
91322, 1.5913043478261, 1.625, 0.31818181818182
91323, 1.5913043478261, 1.65, 0.29545454545455
91324, 1.5695652173913, 1.65, 0.27272727272727
91325, 1.5913043478261, 1.625, 0.27272727272727
91326, 1.5913043478261, 1.65, 0.25
91327, 1.5695652173913, 1.65, 0.22727272727273
91328, 1.5913043478261, 1.625, 0.22727272727273
91329, 1.5913043478261, 1.65, 0.20454545454545
91330, 1.5695652173913, 1.65, 0.18181818181818
91331, 1.5913043478261, 1.625, 0.18181818181818
91332, 1.5913043478261, 1.65, 0.15909090909091
91333, 1.5695652173913, 1.65, 0.13636363636364
91334, 1.5913043478261, 1.625, 0.13636363636364
91335, 1.5913043478261, 1.65, 0.11363636363636
91336, 1.5695652173913, 1.65, 0.090909090909091
91337, 1.5913043478261, 1.625, 0.090909090909091
91338, 1.5913043478261, 1.65, 0.068181818181818
91339, 1.5695652173913, 1.65, 0.045454545454545
91340, 1.5913043478261, 1.625, 0.045454545454545
91341, 1.5913043478261, 1.65, 0.022727272727273
91342, 1.6347826086957, 1.65, 0.47727272727273
91343, 1.6130434782609, 1.65, 0.45454545454545
91344, 1.6347826086957, 1.625, 0.45454545454545
91345, 1.6347826086957, 1.65, 0.43181818181818
91346, 1.6130434782609, 1.65, 0.40909090909091
91347, 1.6347826086957, 1.625, 0.40909090909091
91348, 1.6347826086957, 1.65, 0.38636363636364
91349, 1.6130434782609, 1.65, 0.36363636363636
91350, 1.6347826086957, 1.625, 0.36363636363636
91351, 1.6347826086957, 1.65, 0.34090909090909
91352, 1.6130434782609, 1.65, 0.31818181818182
91353, 1.6347826086957, 1.625, 0.31818181818182
91354, 1.6347826086957, 1.65, 0.29545454545455
91355, 1.6130434782609, 1.65, 0.27272727272727
91356, 1.6347826086957, 1.625, 0.27272727272727
91357, 1.6347826086957, 1.65, 0.25
91358, 1.6130434782609, 1.65, 0.22727272727273
91359, 1.6347826086957, 1.625, 0.22727272727273
91360, 1.6347826086957, 1.65, 0.20454545454545
91361, 1.6130434782609, 1.65, 0.18181818181818
91362, 1.6347826086957, 1.625, 0.18181818181818
91363, 1.6347826086957, 1.65, 0.15909090909091
91364, 1.6130434782609, 1.65, 0.13636363636364
91365, 1.6347826086957, 1.625, 0.13636363636364
91366, 1.6347826086957, 1.65, 0.11363636363636
91367, 1.6130434782609, 1.65, 0.090909090909091
91368, 1.6347826086957, 1.625, 0.090909090909091
91369, 1.6347826086957, 1.65, 0.068181818181818
91370, 1.6130434782609, 1.65, 0.045454545454545
91371, 1.6347826086957, 1.625, 0.045454545454545
91372, 1.6347826086957, 1.65, 0.022727272727273
91373, 1.6782608695652, 1.65, 0.47727272727273
91374, 1.6565217391304, 1.65, 0.45454545454545
91375, 1.6782608695652, 1.625, 0.45454545454545
91376, 1.6782608695652, 1.65, 0.43181818181818
91377, 1.6565217391304, 1.65, 0.40909090909091
91378, 1.6782608695652, 1.625, 0.40909090909091
91379, 1.6782608695652, 1.65, 0.38636363636364
91380, 1.6565217391304, 1.65, 0.36363636363636
91381, 1.6782608695652, 1.625, 0.36363636363636
91382, 1.6782608695652, 1.65, 0.34090909090909
91383, 1.6565217391304, 1.65, 0.31818181818182
91384, 1.6782608695652, 1.625, 0.31818181818182
91385, 1.6782608695652, 1.65, 0.29545454545455
91386, 1.6565217391304, 1.65, 0.27272727272727
91387, 1.6782608695652, 1.625, 0.27272727272727
91388, 1.6782608695652, 1.65, 0.25
91389, 1.6565217391304, 1.65, 0.22727272727273
91390, 1.6782608695652, 1.625, 0.22727272727273
91391, 1.6782608695652, 1.65, 0.20454545454545
91392, 1.6565217391304, 1.65, 0.18181818181818
91393, 1.6782608695652, 1.625, 0.18181818181818
91394, 1.6782608695652, 1.65, 0.15909090909091
91395, 1.6565217391304, 1.65, 0.13636363636364
91396, 1.6782608695652, 1.625, 0.13636363636364
91397, 1.6782608695652, 1.65, 0.11363636363636
91398, 1.6565217391304, 1.65, 0.090909090909091
91399, 1.6782608695652, 1.625, 0.090909090909091
91400, 1.6782608695652, 1.65, 0.068181818181818
91401, 1.6565217391304, 1.65, 0.045454545454545
91402, 1.6782608695652, 1.625, 0.045454545454545
91403, 1.6782608695652, 1.65, 0.022727272727273
91404, 1.7217391304348, 1.65, 0.47727272727273
91405, 1.7, 1.65, 0.45454545454545
91406, 1.7217391304348, 1.625, 0.45454545454545
91407, 1.7217391304348, 1.65, 0.43181818181818
91408, 1.7, 1.65, 0.40909090909091
91409, 1.7217391304348, 1.625, 0.40909090909091
91410, 1.7217391304348, 1.65, 0.38636363636364
91411, 1.7, 1.65, 0.36363636363636
91412, 1.7217391304348, 1.625, 0.36363636363636
91413, 1.7217391304348, 1.65, 0.34090909090909
91414, 1.7, 1.65, 0.31818181818182
91415, 1.7217391304348, 1.625, 0.31818181818182
91416, 1.7217391304348, 1.65, 0.29545454545455
91417, 1.7, 1.65, 0.27272727272727
91418, 1.7217391304348, 1.625, 0.27272727272727
91419, 1.7217391304348, 1.65, 0.25
91420, 1.7, 1.65, 0.22727272727273
91421, 1.7217391304348, 1.625, 0.22727272727273
91422, 1.7217391304348, 1.65, 0.20454545454545
91423, 1.7, 1.65, 0.18181818181818
91424, 1.7217391304348, 1.625, 0.18181818181818
91425, 1.7217391304348, 1.65, 0.15909090909091
91426, 1.7, 1.65, 0.13636363636364
91427, 1.7217391304348, 1.625, 0.13636363636364
91428, 1.7217391304348, 1.65, 0.11363636363636
91429, 1.7, 1.65, 0.090909090909091
91430, 1.7217391304348, 1.625, 0.090909090909091
91431, 1.7217391304348, 1.65, 0.068181818181818
91432, 1.7, 1.65, 0.045454545454545
91433, 1.7217391304348, 1.625, 0.045454545454545
91434, 1.7217391304348, 1.65, 0.022727272727273
91435, 1.7652173913043, 1.65, 0.47727272727273
91436, 1.7434782608696, 1.65, 0.45454545454545
91437, 1.7652173913043, 1.625, 0.45454545454545
91438, 1.7652173913043, 1.65, 0.43181818181818
91439, 1.7434782608696, 1.65, 0.40909090909091
91440, 1.7652173913043, 1.625, 0.40909090909091
91441, 1.7652173913043, 1.65, 0.38636363636364
91442, 1.7434782608696, 1.65, 0.36363636363636
91443, 1.7652173913043, 1.625, 0.36363636363636
91444, 1.7652173913043, 1.65, 0.34090909090909
91445, 1.7434782608696, 1.65, 0.31818181818182
91446, 1.7652173913043, 1.625, 0.31818181818182
91447, 1.7652173913043, 1.65, 0.29545454545455
91448, 1.7434782608696, 1.65, 0.27272727272727
91449, 1.7652173913043, 1.625, 0.27272727272727
91450, 1.7652173913043, 1.65, 0.25
91451, 1.7434782608696, 1.65, 0.22727272727273
91452, 1.7652173913043, 1.625, 0.22727272727273
91453, 1.7652173913043, 1.65, 0.20454545454545
91454, 1.7434782608696, 1.65, 0.18181818181818
91455, 1.7652173913043, 1.625, 0.18181818181818
91456, 1.7652173913043, 1.65, 0.15909090909091
91457, 1.7434782608696, 1.65, 0.13636363636364
91458, 1.7652173913043, 1.625, 0.13636363636364
91459, 1.7652173913043, 1.65, 0.11363636363636
91460, 1.7434782608696, 1.65, 0.090909090909091
91461, 1.7652173913043, 1.625, 0.090909090909091
91462, 1.7652173913043, 1.65, 0.068181818181818
91463, 1.7434782608696, 1.65, 0.045454545454545
91464, 1.7652173913043, 1.625, 0.045454545454545
91465, 1.7652173913043, 1.65, 0.022727272727273
91466, 1.8086956521739, 1.65, 0.47727272727273
91467, 1.7869565217391, 1.65, 0.45454545454545
91468, 1.8086956521739, 1.625, 0.45454545454545
91469, 1.8086956521739, 1.65, 0.43181818181818
91470, 1.7869565217391, 1.65, 0.40909090909091
91471, 1.8086956521739, 1.625, 0.40909090909091
91472, 1.8086956521739, 1.65, 0.38636363636364
91473, 1.7869565217391, 1.65, 0.36363636363636
91474, 1.8086956521739, 1.625, 0.36363636363636
91475, 1.8086956521739, 1.65, 0.34090909090909
91476, 1.7869565217391, 1.65, 0.31818181818182
91477, 1.8086956521739, 1.625, 0.31818181818182
91478, 1.8086956521739, 1.65, 0.29545454545455
91479, 1.7869565217391, 1.65, 0.27272727272727
91480, 1.8086956521739, 1.625, 0.27272727272727
91481, 1.8086956521739, 1.65, 0.25
91482, 1.7869565217391, 1.65, 0.22727272727273
91483, 1.8086956521739, 1.625, 0.22727272727273
91484, 1.8086956521739, 1.65, 0.20454545454545
91485, 1.7869565217391, 1.65, 0.18181818181818
91486, 1.8086956521739, 1.625, 0.18181818181818
91487, 1.8086956521739, 1.65, 0.15909090909091
91488, 1.7869565217391, 1.65, 0.13636363636364
91489, 1.8086956521739, 1.625, 0.13636363636364
91490, 1.8086956521739, 1.65, 0.11363636363636
91491, 1.7869565217391, 1.65, 0.090909090909091
91492, 1.8086956521739, 1.625, 0.090909090909091
91493, 1.8086956521739, 1.65, 0.068181818181818
91494, 1.7869565217391, 1.65, 0.045454545454545
91495, 1.8086956521739, 1.625, 0.045454545454545
91496, 1.8086956521739, 1.65, 0.022727272727273
91497, 1.8521739130435, 1.65, 0.47727272727273
91498, 1.8304347826087, 1.65, 0.45454545454545
91499, 1.8521739130435, 1.625, 0.45454545454545
91500, 1.8521739130435, 1.65, 0.43181818181818
91501, 1.8304347826087, 1.65, 0.40909090909091
91502, 1.8521739130435, 1.625, 0.40909090909091
91503, 1.8521739130435, 1.65, 0.38636363636364
91504, 1.8304347826087, 1.65, 0.36363636363636
91505, 1.8521739130435, 1.625, 0.36363636363636
91506, 1.8521739130435, 1.65, 0.34090909090909
91507, 1.8304347826087, 1.65, 0.31818181818182
91508, 1.8521739130435, 1.625, 0.31818181818182
91509, 1.8521739130435, 1.65, 0.29545454545455
91510, 1.8304347826087, 1.65, 0.27272727272727
91511, 1.8521739130435, 1.625, 0.27272727272727
91512, 1.8521739130435, 1.65, 0.25
91513, 1.8304347826087, 1.65, 0.22727272727273
91514, 1.8521739130435, 1.625, 0.22727272727273
91515, 1.8521739130435, 1.65, 0.20454545454545
91516, 1.8304347826087, 1.65, 0.18181818181818
91517, 1.8521739130435, 1.625, 0.18181818181818
91518, 1.8521739130435, 1.65, 0.15909090909091
91519, 1.8304347826087, 1.65, 0.13636363636364
91520, 1.8521739130435, 1.625, 0.13636363636364
91521, 1.8521739130435, 1.65, 0.11363636363636
91522, 1.8304347826087, 1.65, 0.090909090909091
91523, 1.8521739130435, 1.625, 0.090909090909091
91524, 1.8521739130435, 1.65, 0.068181818181818
91525, 1.8304347826087, 1.65, 0.045454545454545
91526, 1.8521739130435, 1.625, 0.045454545454545
91527, 1.8521739130435, 1.65, 0.022727272727273
91528, 1.895652173913, 1.65, 0.47727272727273
91529, 1.8739130434783, 1.65, 0.45454545454545
91530, 1.895652173913, 1.625, 0.45454545454545
91531, 1.895652173913, 1.65, 0.43181818181818
91532, 1.8739130434783, 1.65, 0.40909090909091
91533, 1.895652173913, 1.625, 0.40909090909091
91534, 1.895652173913, 1.65, 0.38636363636364
91535, 1.8739130434783, 1.65, 0.36363636363636
91536, 1.895652173913, 1.625, 0.36363636363636
91537, 1.895652173913, 1.65, 0.34090909090909
91538, 1.8739130434783, 1.65, 0.31818181818182
91539, 1.895652173913, 1.625, 0.31818181818182
91540, 1.895652173913, 1.65, 0.29545454545455
91541, 1.8739130434783, 1.65, 0.27272727272727
91542, 1.895652173913, 1.625, 0.27272727272727
91543, 1.895652173913, 1.65, 0.25
91544, 1.8739130434783, 1.65, 0.22727272727273
91545, 1.895652173913, 1.625, 0.22727272727273
91546, 1.895652173913, 1.65, 0.20454545454545
91547, 1.8739130434783, 1.65, 0.18181818181818
91548, 1.895652173913, 1.625, 0.18181818181818
91549, 1.895652173913, 1.65, 0.15909090909091
91550, 1.8739130434783, 1.65, 0.13636363636364
91551, 1.895652173913, 1.625, 0.13636363636364
91552, 1.895652173913, 1.65, 0.11363636363636
91553, 1.8739130434783, 1.65, 0.090909090909091
91554, 1.895652173913, 1.625, 0.090909090909091
91555, 1.895652173913, 1.65, 0.068181818181818
91556, 1.8739130434783, 1.65, 0.045454545454545
91557, 1.895652173913, 1.625, 0.045454545454545
91558, 1.895652173913, 1.65, 0.022727272727273
91559, 1.9391304347826, 1.65, 0.47727272727273
91560, 1.9173913043478, 1.65, 0.45454545454545
91561, 1.9391304347826, 1.625, 0.45454545454545
91562, 1.9391304347826, 1.65, 0.43181818181818
91563, 1.9173913043478, 1.65, 0.40909090909091
91564, 1.9391304347826, 1.625, 0.40909090909091
91565, 1.9391304347826, 1.65, 0.38636363636364
91566, 1.9173913043478, 1.65, 0.36363636363636
91567, 1.9391304347826, 1.625, 0.36363636363636
91568, 1.9391304347826, 1.65, 0.34090909090909
91569, 1.9173913043478, 1.65, 0.31818181818182
91570, 1.9391304347826, 1.625, 0.31818181818182
91571, 1.9391304347826, 1.65, 0.29545454545455
91572, 1.9173913043478, 1.65, 0.27272727272727
91573, 1.9391304347826, 1.625, 0.27272727272727
91574, 1.9391304347826, 1.65, 0.25
91575, 1.9173913043478, 1.65, 0.22727272727273
91576, 1.9391304347826, 1.625, 0.22727272727273
91577, 1.9391304347826, 1.65, 0.20454545454545
91578, 1.9173913043478, 1.65, 0.18181818181818
91579, 1.9391304347826, 1.625, 0.18181818181818
91580, 1.9391304347826, 1.65, 0.15909090909091
91581, 1.9173913043478, 1.65, 0.13636363636364
91582, 1.9391304347826, 1.625, 0.13636363636364
91583, 1.9391304347826, 1.65, 0.11363636363636
91584, 1.9173913043478, 1.65, 0.090909090909091
91585, 1.9391304347826, 1.625, 0.090909090909091
91586, 1.9391304347826, 1.65, 0.068181818181818
91587, 1.9173913043478, 1.65, 0.045454545454545
91588, 1.9391304347826, 1.625, 0.045454545454545
91589, 1.9391304347826, 1.65, 0.022727272727273
91590, 1.9826086956522, 1.65, 0.47727272727273
91591, 1.9608695652174, 1.65, 0.45454545454545
91592, 1.9826086956522, 1.625, 0.45454545454545
91593, 1.9826086956522, 1.65, 0.43181818181818
91594, 1.9608695652174, 1.65, 0.40909090909091
91595, 1.9826086956522, 1.625, 0.40909090909091
91596, 1.9826086956522, 1.65, 0.38636363636364
91597, 1.9608695652174, 1.65, 0.36363636363636
91598, 1.9826086956522, 1.625, 0.36363636363636
91599, 1.9826086956522, 1.65, 0.34090909090909
91600, 1.9608695652174, 1.65, 0.31818181818182
91601, 1.9826086956522, 1.625, 0.31818181818182
91602, 1.9826086956522, 1.65, 0.29545454545455
91603, 1.9608695652174, 1.65, 0.27272727272727
91604, 1.9826086956522, 1.625, 0.27272727272727
91605, 1.9826086956522, 1.65, 0.25
91606, 1.9608695652174, 1.65, 0.22727272727273
91607, 1.9826086956522, 1.625, 0.22727272727273
91608, 1.9826086956522, 1.65, 0.20454545454545
91609, 1.9608695652174, 1.65, 0.18181818181818
91610, 1.9826086956522, 1.625, 0.18181818181818
91611, 1.9826086956522, 1.65, 0.15909090909091
91612, 1.9608695652174, 1.65, 0.13636363636364
91613, 1.9826086956522, 1.625, 0.13636363636364
91614, 1.9826086956522, 1.65, 0.11363636363636
91615, 1.9608695652174, 1.65, 0.090909090909091
91616, 1.9826086956522, 1.625, 0.090909090909091
91617, 1.9826086956522, 1.65, 0.068181818181818
91618, 1.9608695652174, 1.65, 0.045454545454545
91619, 1.9826086956522, 1.625, 0.045454545454545
91620, 1.9826086956522, 1.65, 0.022727272727273
91621, 2.0260869565217, 1.65, 0.47727272727273
91622, 2.004347826087, 1.65, 0.45454545454545
91623, 2.0260869565217, 1.625, 0.45454545454545
91624, 2.0260869565217, 1.65, 0.43181818181818
91625, 2.004347826087, 1.65, 0.40909090909091
91626, 2.0260869565217, 1.625, 0.40909090909091
91627, 2.0260869565217, 1.65, 0.38636363636364
91628, 2.004347826087, 1.65, 0.36363636363636
91629, 2.0260869565217, 1.625, 0.36363636363636
91630, 2.0260869565217, 1.65, 0.34090909090909
91631, 2.004347826087, 1.65, 0.31818181818182
91632, 2.0260869565217, 1.625, 0.31818181818182
91633, 2.0260869565217, 1.65, 0.29545454545455
91634, 2.004347826087, 1.65, 0.27272727272727
91635, 2.0260869565217, 1.625, 0.27272727272727
91636, 2.0260869565217, 1.65, 0.25
91637, 2.004347826087, 1.65, 0.22727272727273
91638, 2.0260869565217, 1.625, 0.22727272727273
91639, 2.0260869565217, 1.65, 0.20454545454545
91640, 2.004347826087, 1.65, 0.18181818181818
91641, 2.0260869565217, 1.625, 0.18181818181818
91642, 2.0260869565217, 1.65, 0.15909090909091
91643, 2.004347826087, 1.65, 0.13636363636364
91644, 2.0260869565217, 1.625, 0.13636363636364
91645, 2.0260869565217, 1.65, 0.11363636363636
91646, 2.004347826087, 1.65, 0.090909090909091
91647, 2.0260869565217, 1.625, 0.090909090909091
91648, 2.0260869565217, 1.65, 0.068181818181818
91649, 2.004347826087, 1.65, 0.045454545454545
91650, 2.0260869565217, 1.625, 0.045454545454545
91651, 2.0260869565217, 1.65, 0.022727272727273
91652, 2.0695652173913, 1.65, 0.47727272727273
91653, 2.0478260869565, 1.65, 0.45454545454545
91654, 2.0695652173913, 1.625, 0.45454545454545
91655, 2.0695652173913, 1.65, 0.43181818181818
91656, 2.0478260869565, 1.65, 0.40909090909091
91657, 2.0695652173913, 1.625, 0.40909090909091
91658, 2.0695652173913, 1.65, 0.38636363636364
91659, 2.0478260869565, 1.65, 0.36363636363636
91660, 2.0695652173913, 1.625, 0.36363636363636
91661, 2.0695652173913, 1.65, 0.34090909090909
91662, 2.0478260869565, 1.65, 0.31818181818182
91663, 2.0695652173913, 1.625, 0.31818181818182
91664, 2.0695652173913, 1.65, 0.29545454545455
91665, 2.0478260869565, 1.65, 0.27272727272727
91666, 2.0695652173913, 1.625, 0.27272727272727
91667, 2.0695652173913, 1.65, 0.25
91668, 2.0478260869565, 1.65, 0.22727272727273
91669, 2.0695652173913, 1.625, 0.22727272727273
91670, 2.0695652173913, 1.65, 0.20454545454545
91671, 2.0478260869565, 1.65, 0.18181818181818
91672, 2.0695652173913, 1.625, 0.18181818181818
91673, 2.0695652173913, 1.65, 0.15909090909091
91674, 2.0478260869565, 1.65, 0.13636363636364
91675, 2.0695652173913, 1.625, 0.13636363636364
91676, 2.0695652173913, 1.65, 0.11363636363636
91677, 2.0478260869565, 1.65, 0.090909090909091
91678, 2.0695652173913, 1.625, 0.090909090909091
91679, 2.0695652173913, 1.65, 0.068181818181818
91680, 2.0478260869565, 1.65, 0.045454545454545
91681, 2.0695652173913, 1.625, 0.045454545454545
91682, 2.0695652173913, 1.65, 0.022727272727273
91683, 2.1130434782609, 1.65, 0.47727272727273
91684, 2.0913043478261, 1.65, 0.45454545454545
91685, 2.1130434782609, 1.625, 0.45454545454545
91686, 2.1130434782609, 1.65, 0.43181818181818
91687, 2.0913043478261, 1.65, 0.40909090909091
91688, 2.1130434782609, 1.625, 0.40909090909091
91689, 2.1130434782609, 1.65, 0.38636363636364
91690, 2.0913043478261, 1.65, 0.36363636363636
91691, 2.1130434782609, 1.625, 0.36363636363636
91692, 2.1130434782609, 1.65, 0.34090909090909
91693, 2.0913043478261, 1.65, 0.31818181818182
91694, 2.1130434782609, 1.625, 0.31818181818182
91695, 2.1130434782609, 1.65, 0.29545454545455
91696, 2.0913043478261, 1.65, 0.27272727272727
91697, 2.1130434782609, 1.625, 0.27272727272727
91698, 2.1130434782609, 1.65, 0.25
91699, 2.0913043478261, 1.65, 0.22727272727273
91700, 2.1130434782609, 1.625, 0.22727272727273
91701, 2.1130434782609, 1.65, 0.20454545454545
91702, 2.0913043478261, 1.65, 0.18181818181818
91703, 2.1130434782609, 1.625, 0.18181818181818
91704, 2.1130434782609, 1.65, 0.15909090909091
91705, 2.0913043478261, 1.65, 0.13636363636364
91706, 2.1130434782609, 1.625, 0.13636363636364
91707, 2.1130434782609, 1.65, 0.11363636363636
91708, 2.0913043478261, 1.65, 0.090909090909091
91709, 2.1130434782609, 1.625, 0.090909090909091
91710, 2.1130434782609, 1.65, 0.068181818181818
91711, 2.0913043478261, 1.65, 0.045454545454545
91712, 2.1130434782609, 1.625, 0.045454545454545
91713, 2.1130434782609, 1.65, 0.022727272727273
91714, 2.1565217391304, 1.65, 0.47727272727273
91715, 2.1347826086957, 1.65, 0.45454545454545
91716, 2.1565217391304, 1.625, 0.45454545454545
91717, 2.1565217391304, 1.65, 0.43181818181818
91718, 2.1347826086957, 1.65, 0.40909090909091
91719, 2.1565217391304, 1.625, 0.40909090909091
91720, 2.1565217391304, 1.65, 0.38636363636364
91721, 2.1347826086957, 1.65, 0.36363636363636
91722, 2.1565217391304, 1.625, 0.36363636363636
91723, 2.1565217391304, 1.65, 0.34090909090909
91724, 2.1347826086957, 1.65, 0.31818181818182
91725, 2.1565217391304, 1.625, 0.31818181818182
91726, 2.1565217391304, 1.65, 0.29545454545455
91727, 2.1347826086957, 1.65, 0.27272727272727
91728, 2.1565217391304, 1.625, 0.27272727272727
91729, 2.1565217391304, 1.65, 0.25
91730, 2.1347826086957, 1.65, 0.22727272727273
91731, 2.1565217391304, 1.625, 0.22727272727273
91732, 2.1565217391304, 1.65, 0.20454545454545
91733, 2.1347826086957, 1.65, 0.18181818181818
91734, 2.1565217391304, 1.625, 0.18181818181818
91735, 2.1565217391304, 1.65, 0.15909090909091
91736, 2.1347826086957, 1.65, 0.13636363636364
91737, 2.1565217391304, 1.625, 0.13636363636364
91738, 2.1565217391304, 1.65, 0.11363636363636
91739, 2.1347826086957, 1.65, 0.090909090909091
91740, 2.1565217391304, 1.625, 0.090909090909091
91741, 2.1565217391304, 1.65, 0.068181818181818
91742, 2.1347826086957, 1.65, 0.045454545454545
91743, 2.1565217391304, 1.625, 0.045454545454545
91744, 2.1565217391304, 1.65, 0.022727272727273
91745, 2.1782608695652, 1.65, 0.45454545454545
91746, 2.1782608695652, 1.65, 0.40909090909091
91747, 2.1782608695652, 1.65, 0.36363636363636
91748, 2.1782608695652, 1.65, 0.31818181818182
91749, 2.1782608695652, 1.65, 0.27272727272727
91750, 2.1782608695652, 1.65, 0.22727272727273
91751, 2.1782608695652, 1.65, 0.18181818181818
91752, 2.1782608695652, 1.65, 0.13636363636364
91753, 2.1782608695652, 1.65, 0.090909090909091
91754, 2.1782608695652, 1.65, 0.045454545454545
91755, 1.2434782608696, 1.675, 0.45454545454545
91756, 1.2434782608696, 1.675, 0.40909090909091
91757, 1.2434782608696, 1.675, 0.36363636363636
91758, 1.2434782608696, 1.675, 0.31818181818182
91759, 1.2434782608696, 1.675, 0.27272727272727
91760, 1.2434782608696, 1.675, 0.22727272727273
91761, 1.2434782608696, 1.675, 0.18181818181818
91762, 1.2434782608696, 1.675, 0.13636363636364
91763, 1.2434782608696, 1.675, 0.090909090909091
91764, 1.2434782608696, 1.675, 0.045454545454545
91765, 1.2869565217391, 1.675, 0.45454545454545
91766, 1.2869565217391, 1.675, 0.40909090909091
91767, 1.2869565217391, 1.675, 0.36363636363636
91768, 1.2869565217391, 1.675, 0.31818181818182
91769, 1.2869565217391, 1.675, 0.27272727272727
91770, 1.2869565217391, 1.675, 0.22727272727273
91771, 1.2869565217391, 1.675, 0.18181818181818
91772, 1.2869565217391, 1.675, 0.13636363636364
91773, 1.2869565217391, 1.675, 0.090909090909091
91774, 1.2869565217391, 1.675, 0.045454545454545
91775, 1.3304347826087, 1.675, 0.45454545454545
91776, 1.3304347826087, 1.675, 0.40909090909091
91777, 1.3304347826087, 1.675, 0.36363636363636
91778, 1.3304347826087, 1.675, 0.31818181818182
91779, 1.3304347826087, 1.675, 0.27272727272727
91780, 1.3304347826087, 1.675, 0.22727272727273
91781, 1.3304347826087, 1.675, 0.18181818181818
91782, 1.3304347826087, 1.675, 0.13636363636364
91783, 1.3304347826087, 1.675, 0.090909090909091
91784, 1.3304347826087, 1.675, 0.045454545454545
91785, 1.3739130434783, 1.675, 0.45454545454545
91786, 1.3739130434783, 1.675, 0.40909090909091
91787, 1.3739130434783, 1.675, 0.36363636363636
91788, 1.3739130434783, 1.675, 0.31818181818182
91789, 1.3739130434783, 1.675, 0.27272727272727
91790, 1.3739130434783, 1.675, 0.22727272727273
91791, 1.3739130434783, 1.675, 0.18181818181818
91792, 1.3739130434783, 1.675, 0.13636363636364
91793, 1.3739130434783, 1.675, 0.090909090909091
91794, 1.3739130434783, 1.675, 0.045454545454545
91795, 1.4173913043478, 1.675, 0.45454545454545
91796, 1.4173913043478, 1.675, 0.40909090909091
91797, 1.4173913043478, 1.675, 0.36363636363636
91798, 1.4173913043478, 1.675, 0.31818181818182
91799, 1.4173913043478, 1.675, 0.27272727272727
91800, 1.4173913043478, 1.675, 0.22727272727273
91801, 1.4173913043478, 1.675, 0.18181818181818
91802, 1.4173913043478, 1.675, 0.13636363636364
91803, 1.4173913043478, 1.675, 0.090909090909091
91804, 1.4173913043478, 1.675, 0.045454545454545
91805, 1.4608695652174, 1.675, 0.45454545454545
91806, 1.4608695652174, 1.675, 0.40909090909091
91807, 1.4608695652174, 1.675, 0.36363636363636
91808, 1.4608695652174, 1.675, 0.31818181818182
91809, 1.4608695652174, 1.675, 0.27272727272727
91810, 1.4608695652174, 1.675, 0.22727272727273
91811, 1.4608695652174, 1.675, 0.18181818181818
91812, 1.4608695652174, 1.675, 0.13636363636364
91813, 1.4608695652174, 1.675, 0.090909090909091
91814, 1.4608695652174, 1.675, 0.045454545454545
91815, 1.504347826087, 1.675, 0.45454545454545
91816, 1.504347826087, 1.675, 0.40909090909091
91817, 1.504347826087, 1.675, 0.36363636363636
91818, 1.504347826087, 1.675, 0.31818181818182
91819, 1.504347826087, 1.675, 0.27272727272727
91820, 1.504347826087, 1.675, 0.22727272727273
91821, 1.504347826087, 1.675, 0.18181818181818
91822, 1.504347826087, 1.675, 0.13636363636364
91823, 1.504347826087, 1.675, 0.090909090909091
91824, 1.504347826087, 1.675, 0.045454545454545
91825, 1.5478260869565, 1.675, 0.45454545454545
91826, 1.5478260869565, 1.675, 0.40909090909091
91827, 1.5478260869565, 1.675, 0.36363636363636
91828, 1.5478260869565, 1.675, 0.31818181818182
91829, 1.5478260869565, 1.675, 0.27272727272727
91830, 1.5478260869565, 1.675, 0.22727272727273
91831, 1.5478260869565, 1.675, 0.18181818181818
91832, 1.5478260869565, 1.675, 0.13636363636364
91833, 1.5478260869565, 1.675, 0.090909090909091
91834, 1.5478260869565, 1.675, 0.045454545454545
91835, 1.5913043478261, 1.675, 0.45454545454545
91836, 1.5913043478261, 1.675, 0.40909090909091
91837, 1.5913043478261, 1.675, 0.36363636363636
91838, 1.5913043478261, 1.675, 0.31818181818182
91839, 1.5913043478261, 1.675, 0.27272727272727
91840, 1.5913043478261, 1.675, 0.22727272727273
91841, 1.5913043478261, 1.675, 0.18181818181818
91842, 1.5913043478261, 1.675, 0.13636363636364
91843, 1.5913043478261, 1.675, 0.090909090909091
91844, 1.5913043478261, 1.675, 0.045454545454545
91845, 1.6347826086957, 1.675, 0.45454545454545
91846, 1.6347826086957, 1.675, 0.40909090909091
91847, 1.6347826086957, 1.675, 0.36363636363636
91848, 1.6347826086957, 1.675, 0.31818181818182
91849, 1.6347826086957, 1.675, 0.27272727272727
91850, 1.6347826086957, 1.675, 0.22727272727273
91851, 1.6347826086957, 1.675, 0.18181818181818
91852, 1.6347826086957, 1.675, 0.13636363636364
91853, 1.6347826086957, 1.675, 0.090909090909091
91854, 1.6347826086957, 1.675, 0.045454545454545
91855, 1.6782608695652, 1.675, 0.45454545454545
91856, 1.6782608695652, 1.675, 0.40909090909091
91857, 1.6782608695652, 1.675, 0.36363636363636
91858, 1.6782608695652, 1.675, 0.31818181818182
91859, 1.6782608695652, 1.675, 0.27272727272727
91860, 1.6782608695652, 1.675, 0.22727272727273
91861, 1.6782608695652, 1.675, 0.18181818181818
91862, 1.6782608695652, 1.675, 0.13636363636364
91863, 1.6782608695652, 1.675, 0.090909090909091
91864, 1.6782608695652, 1.675, 0.045454545454545
91865, 1.7217391304348, 1.675, 0.45454545454545
91866, 1.7217391304348, 1.675, 0.40909090909091
91867, 1.7217391304348, 1.675, 0.36363636363636
91868, 1.7217391304348, 1.675, 0.31818181818182
91869, 1.7217391304348, 1.675, 0.27272727272727
91870, 1.7217391304348, 1.675, 0.22727272727273
91871, 1.7217391304348, 1.675, 0.18181818181818
91872, 1.7217391304348, 1.675, 0.13636363636364
91873, 1.7217391304348, 1.675, 0.090909090909091
91874, 1.7217391304348, 1.675, 0.045454545454545
91875, 1.7652173913043, 1.675, 0.45454545454545
91876, 1.7652173913043, 1.675, 0.40909090909091
91877, 1.7652173913043, 1.675, 0.36363636363636
91878, 1.7652173913043, 1.675, 0.31818181818182
91879, 1.7652173913043, 1.675, 0.27272727272727
91880, 1.7652173913043, 1.675, 0.22727272727273
91881, 1.7652173913043, 1.675, 0.18181818181818
91882, 1.7652173913043, 1.675, 0.13636363636364
91883, 1.7652173913043, 1.675, 0.090909090909091
91884, 1.7652173913043, 1.675, 0.045454545454545
91885, 1.8086956521739, 1.675, 0.45454545454545
91886, 1.8086956521739, 1.675, 0.40909090909091
91887, 1.8086956521739, 1.675, 0.36363636363636
91888, 1.8086956521739, 1.675, 0.31818181818182
91889, 1.8086956521739, 1.675, 0.27272727272727
91890, 1.8086956521739, 1.675, 0.22727272727273
91891, 1.8086956521739, 1.675, 0.18181818181818
91892, 1.8086956521739, 1.675, 0.13636363636364
91893, 1.8086956521739, 1.675, 0.090909090909091
91894, 1.8086956521739, 1.675, 0.045454545454545
91895, 1.8521739130435, 1.675, 0.45454545454545
91896, 1.8521739130435, 1.675, 0.40909090909091
91897, 1.8521739130435, 1.675, 0.36363636363636
91898, 1.8521739130435, 1.675, 0.31818181818182
91899, 1.8521739130435, 1.675, 0.27272727272727
91900, 1.8521739130435, 1.675, 0.22727272727273
91901, 1.8521739130435, 1.675, 0.18181818181818
91902, 1.8521739130435, 1.675, 0.13636363636364
91903, 1.8521739130435, 1.675, 0.090909090909091
91904, 1.8521739130435, 1.675, 0.045454545454545
91905, 1.895652173913, 1.675, 0.45454545454545
91906, 1.895652173913, 1.675, 0.40909090909091
91907, 1.895652173913, 1.675, 0.36363636363636
91908, 1.895652173913, 1.675, 0.31818181818182
91909, 1.895652173913, 1.675, 0.27272727272727
91910, 1.895652173913, 1.675, 0.22727272727273
91911, 1.895652173913, 1.675, 0.18181818181818
91912, 1.895652173913, 1.675, 0.13636363636364
91913, 1.895652173913, 1.675, 0.090909090909091
91914, 1.895652173913, 1.675, 0.045454545454545
91915, 1.9391304347826, 1.675, 0.45454545454545
91916, 1.9391304347826, 1.675, 0.40909090909091
91917, 1.9391304347826, 1.675, 0.36363636363636
91918, 1.9391304347826, 1.675, 0.31818181818182
91919, 1.9391304347826, 1.675, 0.27272727272727
91920, 1.9391304347826, 1.675, 0.22727272727273
91921, 1.9391304347826, 1.675, 0.18181818181818
91922, 1.9391304347826, 1.675, 0.13636363636364
91923, 1.9391304347826, 1.675, 0.090909090909091
91924, 1.9391304347826, 1.675, 0.045454545454545
91925, 1.9826086956522, 1.675, 0.45454545454545
91926, 1.9826086956522, 1.675, 0.40909090909091
91927, 1.9826086956522, 1.675, 0.36363636363636
91928, 1.9826086956522, 1.675, 0.31818181818182
91929, 1.9826086956522, 1.675, 0.27272727272727
91930, 1.9826086956522, 1.675, 0.22727272727273
91931, 1.9826086956522, 1.675, 0.18181818181818
91932, 1.9826086956522, 1.675, 0.13636363636364
91933, 1.9826086956522, 1.675, 0.090909090909091
91934, 1.9826086956522, 1.675, 0.045454545454545
91935, 2.0260869565217, 1.675, 0.45454545454545
91936, 2.0260869565217, 1.675, 0.40909090909091
91937, 2.0260869565217, 1.675, 0.36363636363636
91938, 2.0260869565217, 1.675, 0.31818181818182
91939, 2.0260869565217, 1.675, 0.27272727272727
91940, 2.0260869565217, 1.675, 0.22727272727273
91941, 2.0260869565217, 1.675, 0.18181818181818
91942, 2.0260869565217, 1.675, 0.13636363636364
91943, 2.0260869565217, 1.675, 0.090909090909091
91944, 2.0260869565217, 1.675, 0.045454545454545
91945, 2.0695652173913, 1.675, 0.45454545454545
91946, 2.0695652173913, 1.675, 0.40909090909091
91947, 2.0695652173913, 1.675, 0.36363636363636
91948, 2.0695652173913, 1.675, 0.31818181818182
91949, 2.0695652173913, 1.675, 0.27272727272727
91950, 2.0695652173913, 1.675, 0.22727272727273
91951, 2.0695652173913, 1.675, 0.18181818181818
91952, 2.0695652173913, 1.675, 0.13636363636364
91953, 2.0695652173913, 1.675, 0.090909090909091
91954, 2.0695652173913, 1.675, 0.045454545454545
91955, 2.1130434782609, 1.675, 0.45454545454545
91956, 2.1130434782609, 1.675, 0.40909090909091
91957, 2.1130434782609, 1.675, 0.36363636363636
91958, 2.1130434782609, 1.675, 0.31818181818182
91959, 2.1130434782609, 1.675, 0.27272727272727
91960, 2.1130434782609, 1.675, 0.22727272727273
91961, 2.1130434782609, 1.675, 0.18181818181818
91962, 2.1130434782609, 1.675, 0.13636363636364
91963, 2.1130434782609, 1.675, 0.090909090909091
91964, 2.1130434782609, 1.675, 0.045454545454545
91965, 2.1565217391304, 1.675, 0.45454545454545
91966, 2.1565217391304, 1.675, 0.40909090909091
91967, 2.1565217391304, 1.675, 0.36363636363636
91968, 2.1565217391304, 1.675, 0.31818181818182
91969, 2.1565217391304, 1.675, 0.27272727272727
91970, 2.1565217391304, 1.675, 0.22727272727273
91971, 2.1565217391304, 1.675, 0.18181818181818
91972, 2.1565217391304, 1.675, 0.13636363636364
91973, 2.1565217391304, 1.675, 0.090909090909091
91974, 2.1565217391304, 1.675, 0.045454545454545
91975, 0.95652173913043, -0.05, 0.045454545454545
91976, 0.95652173913043, -0.05, 0.090909090909091
91977, 0.95652173913043, -0.05, 0.13636363636364
91978, 0.95652173913043, -0.05, 0.18181818181818
91979, 0.95652173913043, -0.05, 0.22727272727273
91980, 0.95652173913043, -0.05, 0.27272727272727
91981, 0.95652173913043, -0.05, 0.31818181818182
91982, 0.95652173913043, -0.05, 0.36363636363636
91983, 0.95652173913043, -0.05, 0.40909090909091
91984, 0.95652173913043, -0.05, 0.45454545454545
91985, 0.91304347826087, -0.05, 0.045454545454545
91986, 0.91304347826087, -0.05, 0.090909090909091
91987, 0.91304347826087, -0.05, 0.13636363636364
91988, 0.91304347826087, -0.05, 0.18181818181818
91989, 0.91304347826087, -0.05, 0.22727272727273
91990, 0.91304347826087, -0.05, 0.27272727272727
91991, 0.91304347826087, -0.05, 0.31818181818182
91992, 0.91304347826087, -0.05, 0.36363636363636
91993, 0.91304347826087, -0.05, 0.40909090909091
91994, 0.91304347826087, -0.05, 0.45454545454545
91995, 0.8695652173913, -0.05, 0.045454545454545
91996, 0.8695652173913, -0.05, 0.090909090909091
91997, 0.8695652173913, -0.05, 0.13636363636364
91998, 0.8695652173913, -0.05, 0.18181818181818
91999, 0.8695652173913, -0.05, 0.22727272727273
92000, 0.8695652173913, -0.05, 0.27272727272727
92001, 0.8695652173913, -0.05, 0.31818181818182
92002, 0.8695652173913, -0.05, 0.36363636363636
92003, 0.8695652173913, -0.05, 0.40909090909091
92004, 0.8695652173913, -0.05, 0.45454545454545
92005, 0.82608695652174, -0.05, 0.045454545454545
92006, 0.82608695652174, -0.05, 0.090909090909091
92007, 0.82608695652174, -0.05, 0.13636363636364
92008, 0.82608695652174, -0.05, 0.18181818181818
92009, 0.82608695652174, -0.05, 0.22727272727273
92010, 0.82608695652174, -0.05, 0.27272727272727
92011, 0.82608695652174, -0.05, 0.31818181818182
92012, 0.82608695652174, -0.05, 0.36363636363636
92013, 0.82608695652174, -0.05, 0.40909090909091
92014, 0.82608695652174, -0.05, 0.45454545454545
92015, 0.78260869565217, -0.05, 0.045454545454545
92016, 0.78260869565217, -0.05, 0.090909090909091
92017, 0.78260869565217, -0.05, 0.13636363636364
92018, 0.78260869565217, -0.05, 0.18181818181818
92019, 0.78260869565217, -0.05, 0.22727272727273
92020, 0.78260869565217, -0.05, 0.27272727272727
92021, 0.78260869565217, -0.05, 0.31818181818182
92022, 0.78260869565217, -0.05, 0.36363636363636
92023, 0.78260869565217, -0.05, 0.40909090909091
92024, 0.78260869565217, -0.05, 0.45454545454545
92025, 0.73913043478261, -0.05, 0.045454545454545
92026, 0.73913043478261, -0.05, 0.090909090909091
92027, 0.73913043478261, -0.05, 0.13636363636364
92028, 0.73913043478261, -0.05, 0.18181818181818
92029, 0.73913043478261, -0.05, 0.22727272727273
92030, 0.73913043478261, -0.05, 0.27272727272727
92031, 0.73913043478261, -0.05, 0.31818181818182
92032, 0.73913043478261, -0.05, 0.36363636363636
92033, 0.73913043478261, -0.05, 0.40909090909091
92034, 0.73913043478261, -0.05, 0.45454545454545
92035, 0.69565217391304, -0.05, 0.045454545454545
92036, 0.69565217391304, -0.05, 0.090909090909091
92037, 0.69565217391304, -0.05, 0.13636363636364
92038, 0.69565217391304, -0.05, 0.18181818181818
92039, 0.69565217391304, -0.05, 0.22727272727273
92040, 0.69565217391304, -0.05, 0.27272727272727
92041, 0.69565217391304, -0.05, 0.31818181818182
92042, 0.69565217391304, -0.05, 0.36363636363636
92043, 0.69565217391304, -0.05, 0.40909090909091
92044, 0.69565217391304, -0.05, 0.45454545454545
92045, 0.65217391304348, -0.05, 0.045454545454545
92046, 0.65217391304348, -0.05, 0.090909090909091
92047, 0.65217391304348, -0.05, 0.13636363636364
92048, 0.65217391304348, -0.05, 0.18181818181818
92049, 0.65217391304348, -0.05, 0.22727272727273
92050, 0.65217391304348, -0.05, 0.27272727272727
92051, 0.65217391304348, -0.05, 0.31818181818182
92052, 0.65217391304348, -0.05, 0.36363636363636
92053, 0.65217391304348, -0.05, 0.40909090909091
92054, 0.65217391304348, -0.05, 0.45454545454545
92055, 0.60869565217391, -0.05, 0.045454545454545
92056, 0.60869565217391, -0.05, 0.090909090909091
92057, 0.60869565217391, -0.05, 0.13636363636364
92058, 0.60869565217391, -0.05, 0.18181818181818
92059, 0.60869565217391, -0.05, 0.22727272727273
92060, 0.60869565217391, -0.05, 0.27272727272727
92061, 0.60869565217391, -0.05, 0.31818181818182
92062, 0.60869565217391, -0.05, 0.36363636363636
92063, 0.60869565217391, -0.05, 0.40909090909091
92064, 0.60869565217391, -0.05, 0.45454545454545
92065, 0.56521739130435, -0.05, 0.045454545454545
92066, 0.56521739130435, -0.05, 0.090909090909091
92067, 0.56521739130435, -0.05, 0.13636363636364
92068, 0.56521739130435, -0.05, 0.18181818181818
92069, 0.56521739130435, -0.05, 0.22727272727273
92070, 0.56521739130435, -0.05, 0.27272727272727
92071, 0.56521739130435, -0.05, 0.31818181818182
92072, 0.56521739130435, -0.05, 0.36363636363636
92073, 0.56521739130435, -0.05, 0.40909090909091
92074, 0.56521739130435, -0.05, 0.45454545454545
92075, 0.52173913043478, -0.05, 0.045454545454545
92076, 0.52173913043478, -0.05, 0.090909090909091
92077, 0.52173913043478, -0.05, 0.13636363636364
92078, 0.52173913043478, -0.05, 0.18181818181818
92079, 0.52173913043478, -0.05, 0.22727272727273
92080, 0.52173913043478, -0.05, 0.27272727272727
92081, 0.52173913043478, -0.05, 0.31818181818182
92082, 0.52173913043478, -0.05, 0.36363636363636
92083, 0.52173913043478, -0.05, 0.40909090909091
92084, 0.52173913043478, -0.05, 0.45454545454545
92085, 0.47826086956522, -0.05, 0.045454545454545
92086, 0.47826086956522, -0.05, 0.090909090909091
92087, 0.47826086956522, -0.05, 0.13636363636364
92088, 0.47826086956522, -0.05, 0.18181818181818
92089, 0.47826086956522, -0.05, 0.22727272727273
92090, 0.47826086956522, -0.05, 0.27272727272727
92091, 0.47826086956522, -0.05, 0.31818181818182
92092, 0.47826086956522, -0.05, 0.36363636363636
92093, 0.47826086956522, -0.05, 0.40909090909091
92094, 0.47826086956522, -0.05, 0.45454545454545
92095, 0.43478260869565, -0.05, 0.045454545454545
92096, 0.43478260869565, -0.05, 0.090909090909091
92097, 0.43478260869565, -0.05, 0.13636363636364
92098, 0.43478260869565, -0.05, 0.18181818181818
92099, 0.43478260869565, -0.05, 0.22727272727273
92100, 0.43478260869565, -0.05, 0.27272727272727
92101, 0.43478260869565, -0.05, 0.31818181818182
92102, 0.43478260869565, -0.05, 0.36363636363636
92103, 0.43478260869565, -0.05, 0.40909090909091
92104, 0.43478260869565, -0.05, 0.45454545454545
92105, 0.39130434782609, -0.05, 0.045454545454545
92106, 0.39130434782609, -0.05, 0.090909090909091
92107, 0.39130434782609, -0.05, 0.13636363636364
92108, 0.39130434782609, -0.05, 0.18181818181818
92109, 0.39130434782609, -0.05, 0.22727272727273
92110, 0.39130434782609, -0.05, 0.27272727272727
92111, 0.39130434782609, -0.05, 0.31818181818182
92112, 0.39130434782609, -0.05, 0.36363636363636
92113, 0.39130434782609, -0.05, 0.40909090909091
92114, 0.39130434782609, -0.05, 0.45454545454545
92115, 0.34782608695652, -0.05, 0.045454545454545
92116, 0.34782608695652, -0.05, 0.090909090909091
92117, 0.34782608695652, -0.05, 0.13636363636364
92118, 0.34782608695652, -0.05, 0.18181818181818
92119, 0.34782608695652, -0.05, 0.22727272727273
92120, 0.34782608695652, -0.05, 0.27272727272727
92121, 0.34782608695652, -0.05, 0.31818181818182
92122, 0.34782608695652, -0.05, 0.36363636363636
92123, 0.34782608695652, -0.05, 0.40909090909091
92124, 0.34782608695652, -0.05, 0.45454545454545
92125, 0.30434782608696, -0.05, 0.045454545454545
92126, 0.30434782608696, -0.05, 0.090909090909091
92127, 0.30434782608696, -0.05, 0.13636363636364
92128, 0.30434782608696, -0.05, 0.18181818181818
92129, 0.30434782608696, -0.05, 0.22727272727273
92130, 0.30434782608696, -0.05, 0.27272727272727
92131, 0.30434782608696, -0.05, 0.31818181818182
92132, 0.30434782608696, -0.05, 0.36363636363636
92133, 0.30434782608696, -0.05, 0.40909090909091
92134, 0.30434782608696, -0.05, 0.45454545454545
92135, 0.26086956521739, -0.05, 0.045454545454545
92136, 0.26086956521739, -0.05, 0.090909090909091
92137, 0.26086956521739, -0.05, 0.13636363636364
92138, 0.26086956521739, -0.05, 0.18181818181818
92139, 0.26086956521739, -0.05, 0.22727272727273
92140, 0.26086956521739, -0.05, 0.27272727272727
92141, 0.26086956521739, -0.05, 0.31818181818182
92142, 0.26086956521739, -0.05, 0.36363636363636
92143, 0.26086956521739, -0.05, 0.40909090909091
92144, 0.26086956521739, -0.05, 0.45454545454545
92145, 0.21739130434783, -0.05, 0.045454545454545
92146, 0.21739130434783, -0.05, 0.090909090909091
92147, 0.21739130434783, -0.05, 0.13636363636364
92148, 0.21739130434783, -0.05, 0.18181818181818
92149, 0.21739130434783, -0.05, 0.22727272727273
92150, 0.21739130434783, -0.05, 0.27272727272727
92151, 0.21739130434783, -0.05, 0.31818181818182
92152, 0.21739130434783, -0.05, 0.36363636363636
92153, 0.21739130434783, -0.05, 0.40909090909091
92154, 0.21739130434783, -0.05, 0.45454545454545
92155, 0.17391304347826, -0.05, 0.045454545454545
92156, 0.17391304347826, -0.05, 0.090909090909091
92157, 0.17391304347826, -0.05, 0.13636363636364
92158, 0.17391304347826, -0.05, 0.18181818181818
92159, 0.17391304347826, -0.05, 0.22727272727273
92160, 0.17391304347826, -0.05, 0.27272727272727
92161, 0.17391304347826, -0.05, 0.31818181818182
92162, 0.17391304347826, -0.05, 0.36363636363636
92163, 0.17391304347826, -0.05, 0.40909090909091
92164, 0.17391304347826, -0.05, 0.45454545454545
92165, 0.1304347826087, -0.05, 0.045454545454546
92166, 0.1304347826087, -0.05, 0.090909090909091
92167, 0.1304347826087, -0.05, 0.13636363636364
92168, 0.1304347826087, -0.05, 0.18181818181818
92169, 0.1304347826087, -0.05, 0.22727272727273
92170, 0.1304347826087, -0.05, 0.27272727272727
92171, 0.1304347826087, -0.05, 0.31818181818182
92172, 0.1304347826087, -0.05, 0.36363636363636
92173, 0.1304347826087, -0.05, 0.40909090909091
92174, 0.1304347826087, -0.05, 0.45454545454545
92175, 0.08695652173913, -0.05, 0.045454545454545
92176, 0.08695652173913, -0.05, 0.090909090909091
92177, 0.08695652173913, -0.05, 0.13636363636364
92178, 0.08695652173913, -0.05, 0.18181818181818
92179, 0.08695652173913, -0.05, 0.22727272727273
92180, 0.08695652173913, -0.05, 0.27272727272727
92181, 0.08695652173913, -0.05, 0.31818181818182
92182, 0.08695652173913, -0.05, 0.36363636363636
92183, 0.08695652173913, -0.05, 0.40909090909091
92184, 0.08695652173913, -0.05, 0.45454545454545
92185, 0.043478260869565, -0.05, 0.045454545454545
92186, 0.043478260869565, -0.05, 0.090909090909091
92187, 0.043478260869565, -0.05, 0.13636363636364
92188, 0.043478260869565, -0.05, 0.18181818181818
92189, 0.043478260869565, -0.05, 0.22727272727273
92190, 0.043478260869565, -0.05, 0.27272727272727
92191, 0.043478260869565, -0.05, 0.31818181818182
92192, 0.043478260869565, -0.05, 0.36363636363636
92193, 0.043478260869565, -0.05, 0.40909090909091
92194, 0.043478260869565, -0.05, 0.45454545454545
92195, 0.95652173913043, -0.1, 0.045454545454545
92196, 0.95652173913043, -0.1, 0.090909090909091
92197, 0.95652173913044, -0.1, 0.13636363636364
92198, 0.95652173913044, -0.1, 0.18181818181818
92199, 0.95652173913044, -0.1, 0.22727272727273
92200, 0.95652173913044, -0.1, 0.27272727272727
92201, 0.95652173913044, -0.1, 0.31818181818182
92202, 0.95652173913043, -0.1, 0.36363636363636
92203, 0.95652173913043, -0.1, 0.40909090909091
92204, 0.95652173913044, -0.1, 0.45454545454545
92205, 0.91304347826087, -0.1, 0.045454545454545
92206, 0.91304347826087, -0.1, 0.090909090909091
92207, 0.91304347826087, -0.1, 0.13636363636364
92208, 0.91304347826087, -0.1, 0.18181818181818
92209, 0.91304347826087, -0.1, 0.22727272727273
92210, 0.91304347826087, -0.1, 0.27272727272727
92211, 0.91304347826087, -0.1, 0.31818181818182
92212, 0.91304347826087, -0.1, 0.36363636363636
92213, 0.91304347826087, -0.1, 0.40909090909091
92214, 0.91304347826087, -0.1, 0.45454545454545
92215, 0.8695652173913, -0.1, 0.045454545454545
92216, 0.8695652173913, -0.1, 0.090909090909091
92217, 0.8695652173913, -0.1, 0.13636363636364
92218, 0.8695652173913, -0.1, 0.18181818181818
92219, 0.8695652173913, -0.1, 0.22727272727273
92220, 0.8695652173913, -0.1, 0.27272727272727
92221, 0.8695652173913, -0.1, 0.31818181818182
92222, 0.8695652173913, -0.1, 0.36363636363636
92223, 0.8695652173913, -0.1, 0.40909090909091
92224, 0.8695652173913, -0.1, 0.45454545454545
92225, 0.82608695652174, -0.1, 0.045454545454545
92226, 0.82608695652174, -0.1, 0.090909090909091
92227, 0.82608695652174, -0.1, 0.13636363636364
92228, 0.82608695652174, -0.1, 0.18181818181818
92229, 0.82608695652174, -0.1, 0.22727272727273
92230, 0.82608695652174, -0.1, 0.27272727272727
92231, 0.82608695652174, -0.1, 0.31818181818182
92232, 0.82608695652174, -0.1, 0.36363636363636
92233, 0.82608695652174, -0.1, 0.40909090909091
92234, 0.82608695652174, -0.1, 0.45454545454545
92235, 0.78260869565217, -0.1, 0.045454545454545
92236, 0.78260869565217, -0.1, 0.090909090909091
92237, 0.78260869565217, -0.1, 0.13636363636364
92238, 0.78260869565217, -0.1, 0.18181818181818
92239, 0.78260869565217, -0.1, 0.22727272727273
92240, 0.78260869565217, -0.1, 0.27272727272727
92241, 0.78260869565217, -0.1, 0.31818181818182
92242, 0.78260869565217, -0.1, 0.36363636363636
92243, 0.78260869565217, -0.1, 0.40909090909091
92244, 0.78260869565217, -0.1, 0.45454545454545
92245, 0.73913043478261, -0.1, 0.045454545454545
92246, 0.73913043478261, -0.1, 0.090909090909091
92247, 0.73913043478261, -0.1, 0.13636363636364
92248, 0.73913043478261, -0.1, 0.18181818181818
92249, 0.73913043478261, -0.1, 0.22727272727273
92250, 0.73913043478261, -0.1, 0.27272727272727
92251, 0.73913043478261, -0.1, 0.31818181818182
92252, 0.73913043478261, -0.1, 0.36363636363636
92253, 0.73913043478261, -0.1, 0.40909090909091
92254, 0.73913043478261, -0.1, 0.45454545454545
92255, 0.69565217391304, -0.1, 0.045454545454545
92256, 0.69565217391304, -0.1, 0.090909090909091
92257, 0.69565217391304, -0.1, 0.13636363636364
92258, 0.69565217391304, -0.1, 0.18181818181818
92259, 0.69565217391304, -0.1, 0.22727272727273
92260, 0.69565217391304, -0.1, 0.27272727272727
92261, 0.69565217391304, -0.1, 0.31818181818182
92262, 0.69565217391304, -0.1, 0.36363636363636
92263, 0.69565217391304, -0.1, 0.40909090909091
92264, 0.69565217391304, -0.1, 0.45454545454545
92265, 0.65217391304348, -0.1, 0.045454545454545
92266, 0.65217391304348, -0.1, 0.090909090909091
92267, 0.65217391304348, -0.1, 0.13636363636364
92268, 0.65217391304348, -0.1, 0.18181818181818
92269, 0.65217391304348, -0.1, 0.22727272727273
92270, 0.65217391304348, -0.1, 0.27272727272727
92271, 0.65217391304348, -0.1, 0.31818181818182
92272, 0.65217391304348, -0.1, 0.36363636363636
92273, 0.65217391304348, -0.1, 0.40909090909091
92274, 0.65217391304348, -0.1, 0.45454545454545
92275, 0.60869565217391, -0.1, 0.045454545454545
92276, 0.60869565217391, -0.1, 0.090909090909091
92277, 0.60869565217391, -0.1, 0.13636363636364
92278, 0.60869565217391, -0.1, 0.18181818181818
92279, 0.60869565217391, -0.1, 0.22727272727273
92280, 0.60869565217391, -0.1, 0.27272727272727
92281, 0.60869565217391, -0.1, 0.31818181818182
92282, 0.60869565217391, -0.1, 0.36363636363636
92283, 0.60869565217391, -0.1, 0.40909090909091
92284, 0.60869565217391, -0.1, 0.45454545454545
92285, 0.56521739130435, -0.1, 0.045454545454545
92286, 0.56521739130435, -0.1, 0.090909090909091
92287, 0.56521739130435, -0.1, 0.13636363636364
92288, 0.56521739130435, -0.1, 0.18181818181818
92289, 0.56521739130435, -0.1, 0.22727272727273
92290, 0.56521739130435, -0.1, 0.27272727272727
92291, 0.56521739130435, -0.1, 0.31818181818182
92292, 0.56521739130435, -0.1, 0.36363636363636
92293, 0.56521739130435, -0.1, 0.40909090909091
92294, 0.56521739130435, -0.1, 0.45454545454545
92295, 0.52173913043478, -0.1, 0.045454545454545
92296, 0.52173913043478, -0.1, 0.090909090909091
92297, 0.52173913043478, -0.1, 0.13636363636364
92298, 0.52173913043478, -0.1, 0.18181818181818
92299, 0.52173913043478, -0.1, 0.22727272727273
92300, 0.52173913043478, -0.1, 0.27272727272727
92301, 0.52173913043478, -0.1, 0.31818181818182
92302, 0.52173913043478, -0.1, 0.36363636363636
92303, 0.52173913043478, -0.1, 0.40909090909091
92304, 0.52173913043478, -0.1, 0.45454545454545
92305, 0.47826086956522, -0.1, 0.045454545454545
92306, 0.47826086956522, -0.1, 0.090909090909091
92307, 0.47826086956522, -0.1, 0.13636363636364
92308, 0.47826086956522, -0.1, 0.18181818181818
92309, 0.47826086956522, -0.1, 0.22727272727273
92310, 0.47826086956522, -0.1, 0.27272727272727
92311, 0.47826086956522, -0.1, 0.31818181818182
92312, 0.47826086956522, -0.1, 0.36363636363636
92313, 0.47826086956522, -0.1, 0.40909090909091
92314, 0.47826086956522, -0.1, 0.45454545454545
92315, 0.43478260869565, -0.1, 0.045454545454545
92316, 0.43478260869565, -0.1, 0.090909090909091
92317, 0.43478260869565, -0.1, 0.13636363636364
92318, 0.43478260869565, -0.1, 0.18181818181818
92319, 0.43478260869565, -0.1, 0.22727272727273
92320, 0.43478260869565, -0.1, 0.27272727272727
92321, 0.43478260869565, -0.1, 0.31818181818182
92322, 0.43478260869565, -0.1, 0.36363636363636
92323, 0.43478260869565, -0.1, 0.40909090909091
92324, 0.43478260869565, -0.1, 0.45454545454545
92325, 0.39130434782609, -0.1, 0.045454545454545
92326, 0.39130434782609, -0.1, 0.090909090909091
92327, 0.39130434782609, -0.1, 0.13636363636364
92328, 0.39130434782609, -0.1, 0.18181818181818
92329, 0.39130434782609, -0.1, 0.22727272727273
92330, 0.39130434782609, -0.1, 0.27272727272727
92331, 0.39130434782609, -0.1, 0.31818181818182
92332, 0.39130434782609, -0.1, 0.36363636363636
92333, 0.39130434782609, -0.1, 0.40909090909091
92334, 0.39130434782609, -0.1, 0.45454545454545
92335, 0.34782608695652, -0.1, 0.045454545454545
92336, 0.34782608695652, -0.1, 0.090909090909091
92337, 0.34782608695652, -0.1, 0.13636363636364
92338, 0.34782608695652, -0.1, 0.18181818181818
92339, 0.34782608695652, -0.1, 0.22727272727273
92340, 0.34782608695652, -0.1, 0.27272727272727
92341, 0.34782608695652, -0.1, 0.31818181818182
92342, 0.34782608695652, -0.1, 0.36363636363636
92343, 0.34782608695652, -0.1, 0.40909090909091
92344, 0.34782608695652, -0.1, 0.45454545454545
92345, 0.30434782608696, -0.1, 0.045454545454545
92346, 0.30434782608696, -0.1, 0.090909090909091
92347, 0.30434782608696, -0.1, 0.13636363636364
92348, 0.30434782608696, -0.1, 0.18181818181818
92349, 0.30434782608696, -0.1, 0.22727272727273
92350, 0.30434782608696, -0.1, 0.27272727272727
92351, 0.30434782608696, -0.1, 0.31818181818182
92352, 0.30434782608696, -0.1, 0.36363636363636
92353, 0.30434782608696, -0.1, 0.40909090909091
92354, 0.30434782608696, -0.1, 0.45454545454545
92355, 0.26086956521739, -0.1, 0.045454545454545
92356, 0.26086956521739, -0.1, 0.090909090909091
92357, 0.26086956521739, -0.1, 0.13636363636364
92358, 0.26086956521739, -0.1, 0.18181818181818
92359, 0.26086956521739, -0.1, 0.22727272727273
92360, 0.26086956521739, -0.1, 0.27272727272727
92361, 0.26086956521739, -0.1, 0.31818181818182
92362, 0.26086956521739, -0.1, 0.36363636363636
92363, 0.26086956521739, -0.1, 0.40909090909091
92364, 0.26086956521739, -0.1, 0.45454545454545
92365, 0.21739130434783, -0.1, 0.045454545454545
92366, 0.21739130434783, -0.1, 0.090909090909091
92367, 0.21739130434783, -0.1, 0.13636363636364
92368, 0.21739130434783, -0.1, 0.18181818181818
92369, 0.21739130434783, -0.1, 0.22727272727273
92370, 0.21739130434783, -0.1, 0.27272727272727
92371, 0.21739130434783, -0.1, 0.31818181818182
92372, 0.21739130434783, -0.1, 0.36363636363636
92373, 0.21739130434783, -0.1, 0.40909090909091
92374, 0.21739130434783, -0.1, 0.45454545454545
92375, 0.17391304347826, -0.1, 0.045454545454545
92376, 0.17391304347826, -0.1, 0.090909090909091
92377, 0.17391304347826, -0.1, 0.13636363636364
92378, 0.17391304347826, -0.1, 0.18181818181818
92379, 0.17391304347826, -0.1, 0.22727272727273
92380, 0.17391304347826, -0.1, 0.27272727272727
92381, 0.17391304347826, -0.1, 0.31818181818182
92382, 0.17391304347826, -0.1, 0.36363636363636
92383, 0.17391304347826, -0.1, 0.40909090909091
92384, 0.17391304347826, -0.1, 0.45454545454545
92385, 0.1304347826087, -0.1, 0.045454545454545
92386, 0.1304347826087, -0.1, 0.090909090909091
92387, 0.1304347826087, -0.1, 0.13636363636364
92388, 0.1304347826087, -0.1, 0.18181818181818
92389, 0.1304347826087, -0.1, 0.22727272727273
92390, 0.1304347826087, -0.1, 0.27272727272727
92391, 0.1304347826087, -0.1, 0.31818181818182
92392, 0.1304347826087, -0.1, 0.36363636363636
92393, 0.1304347826087, -0.1, 0.40909090909091
92394, 0.1304347826087, -0.1, 0.45454545454545
92395, 0.08695652173913, -0.1, 0.045454545454545
92396, 0.08695652173913, -0.1, 0.090909090909091
92397, 0.08695652173913, -0.1, 0.13636363636364
92398, 0.08695652173913, -0.1, 0.18181818181818
92399, 0.08695652173913, -0.1, 0.22727272727273
92400, 0.08695652173913, -0.1, 0.27272727272727
92401, 0.08695652173913, -0.1, 0.31818181818182
92402, 0.08695652173913, -0.1, 0.36363636363636
92403, 0.08695652173913, -0.1, 0.40909090909091
92404, 0.08695652173913, -0.1, 0.45454545454545
92405, 0.043478260869565, -0.1, 0.045454545454545
92406, 0.043478260869565, -0.1, 0.090909090909091
92407, 0.043478260869565, -0.1, 0.13636363636364
92408, 0.043478260869565, -0.1, 0.18181818181818
92409, 0.043478260869565, -0.1, 0.22727272727273
92410, 0.043478260869565, -0.1, 0.27272727272727
92411, 0.043478260869565, -0.1, 0.31818181818182
92412, 0.043478260869565, -0.1, 0.36363636363636
92413, 0.043478260869565, -0.1, 0.40909090909091
92414, 0.043478260869565, -0.1, 0.45454545454545
92415, 0.95652173913043, -0.15, 0.045454545454545
92416, 0.95652173913043, -0.15, 0.090909090909091
92417, 0.95652173913043, -0.15, 0.13636363636364
92418, 0.95652173913044, -0.15, 0.18181818181818
92419, 0.95652173913044, -0.15, 0.22727272727273
92420, 0.95652173913044, -0.15, 0.27272727272727
92421, 0.95652173913044, -0.15, 0.31818181818182
92422, 0.95652173913043, -0.15, 0.36363636363636
92423, 0.95652173913043, -0.15, 0.40909090909091
92424, 0.95652173913044, -0.15, 0.45454545454545
92425, 0.91304347826087, -0.15, 0.045454545454545
92426, 0.91304347826087, -0.15, 0.090909090909091
92427, 0.91304347826087, -0.15, 0.13636363636364
92428, 0.91304347826087, -0.15, 0.18181818181818
92429, 0.91304347826087, -0.15, 0.22727272727273
92430, 0.91304347826087, -0.15, 0.27272727272727
92431, 0.91304347826087, -0.15, 0.31818181818182
92432, 0.91304347826087, -0.15, 0.36363636363636
92433, 0.91304347826087, -0.15, 0.40909090909091
92434, 0.91304347826087, -0.15, 0.45454545454545
92435, 0.8695652173913, -0.15, 0.045454545454545
92436, 0.8695652173913, -0.15, 0.090909090909091
92437, 0.8695652173913, -0.15, 0.13636363636364
92438, 0.8695652173913, -0.15, 0.18181818181818
92439, 0.8695652173913, -0.15, 0.22727272727273
92440, 0.8695652173913, -0.15, 0.27272727272727
92441, 0.8695652173913, -0.15, 0.31818181818182
92442, 0.8695652173913, -0.15, 0.36363636363636
92443, 0.8695652173913, -0.15, 0.40909090909091
92444, 0.8695652173913, -0.15, 0.45454545454545
92445, 0.82608695652174, -0.15, 0.045454545454545
92446, 0.82608695652174, -0.15, 0.090909090909091
92447, 0.82608695652174, -0.15, 0.13636363636364
92448, 0.82608695652174, -0.15, 0.18181818181818
92449, 0.82608695652174, -0.15, 0.22727272727273
92450, 0.82608695652174, -0.15, 0.27272727272727
92451, 0.82608695652174, -0.15, 0.31818181818182
92452, 0.82608695652174, -0.15, 0.36363636363636
92453, 0.82608695652174, -0.15, 0.40909090909091
92454, 0.82608695652174, -0.15, 0.45454545454545
92455, 0.78260869565217, -0.15, 0.045454545454545
92456, 0.78260869565217, -0.15, 0.090909090909091
92457, 0.78260869565217, -0.15, 0.13636363636364
92458, 0.78260869565217, -0.15, 0.18181818181818
92459, 0.78260869565217, -0.15, 0.22727272727273
92460, 0.78260869565217, -0.15, 0.27272727272727
92461, 0.78260869565217, -0.15, 0.31818181818182
92462, 0.78260869565217, -0.15, 0.36363636363636
92463, 0.78260869565217, -0.15, 0.40909090909091
92464, 0.78260869565217, -0.15, 0.45454545454545
92465, 0.73913043478261, -0.15, 0.045454545454545
92466, 0.73913043478261, -0.15, 0.090909090909091
92467, 0.73913043478261, -0.15, 0.13636363636364
92468, 0.73913043478261, -0.15, 0.18181818181818
92469, 0.73913043478261, -0.15, 0.22727272727273
92470, 0.73913043478261, -0.15, 0.27272727272727
92471, 0.73913043478261, -0.15, 0.31818181818182
92472, 0.73913043478261, -0.15, 0.36363636363636
92473, 0.73913043478261, -0.15, 0.40909090909091
92474, 0.73913043478261, -0.15, 0.45454545454545
92475, 0.69565217391304, -0.15, 0.045454545454545
92476, 0.69565217391304, -0.15, 0.090909090909091
92477, 0.69565217391304, -0.15, 0.13636363636364
92478, 0.69565217391304, -0.15, 0.18181818181818
92479, 0.69565217391304, -0.15, 0.22727272727273
92480, 0.69565217391304, -0.15, 0.27272727272727
92481, 0.69565217391304, -0.15, 0.31818181818182
92482, 0.69565217391304, -0.15, 0.36363636363636
92483, 0.69565217391304, -0.15, 0.40909090909091
92484, 0.69565217391304, -0.15, 0.45454545454545
92485, 0.65217391304348, -0.15, 0.045454545454545
92486, 0.65217391304348, -0.15, 0.090909090909091
92487, 0.65217391304348, -0.15, 0.13636363636364
92488, 0.65217391304348, -0.15, 0.18181818181818
92489, 0.65217391304348, -0.15, 0.22727272727273
92490, 0.65217391304348, -0.15, 0.27272727272727
92491, 0.65217391304348, -0.15, 0.31818181818182
92492, 0.65217391304348, -0.15, 0.36363636363636
92493, 0.65217391304348, -0.15, 0.40909090909091
92494, 0.65217391304348, -0.15, 0.45454545454545
92495, 0.60869565217391, -0.15, 0.045454545454545
92496, 0.60869565217391, -0.15, 0.090909090909091
92497, 0.60869565217391, -0.15, 0.13636363636364
92498, 0.60869565217391, -0.15, 0.18181818181818
92499, 0.60869565217391, -0.15, 0.22727272727273
92500, 0.60869565217391, -0.15, 0.27272727272727
92501, 0.60869565217391, -0.15, 0.31818181818182
92502, 0.60869565217391, -0.15, 0.36363636363636
92503, 0.60869565217391, -0.15, 0.40909090909091
92504, 0.60869565217391, -0.15, 0.45454545454545
92505, 0.56521739130435, -0.15, 0.045454545454545
92506, 0.56521739130435, -0.15, 0.090909090909091
92507, 0.56521739130435, -0.15, 0.13636363636364
92508, 0.56521739130435, -0.15, 0.18181818181818
92509, 0.56521739130435, -0.15, 0.22727272727273
92510, 0.56521739130435, -0.15, 0.27272727272727
92511, 0.56521739130435, -0.15, 0.31818181818182
92512, 0.56521739130435, -0.15, 0.36363636363636
92513, 0.56521739130435, -0.15, 0.40909090909091
92514, 0.56521739130435, -0.15, 0.45454545454545
92515, 0.52173913043478, -0.15, 0.045454545454545
92516, 0.52173913043478, -0.15, 0.090909090909091
92517, 0.52173913043478, -0.15, 0.13636363636364
92518, 0.52173913043478, -0.15, 0.18181818181818
92519, 0.52173913043478, -0.15, 0.22727272727273
92520, 0.52173913043478, -0.15, 0.27272727272727
92521, 0.52173913043478, -0.15, 0.31818181818182
92522, 0.52173913043478, -0.15, 0.36363636363636
92523, 0.52173913043478, -0.15, 0.40909090909091
92524, 0.52173913043478, -0.15, 0.45454545454545
92525, 0.47826086956522, -0.15, 0.045454545454545
92526, 0.47826086956522, -0.15, 0.090909090909091
92527, 0.47826086956522, -0.15, 0.13636363636364
92528, 0.47826086956522, -0.15, 0.18181818181818
92529, 0.47826086956522, -0.15, 0.22727272727273
92530, 0.47826086956522, -0.15, 0.27272727272727
92531, 0.47826086956522, -0.15, 0.31818181818182
92532, 0.47826086956522, -0.15, 0.36363636363636
92533, 0.47826086956522, -0.15, 0.40909090909091
92534, 0.47826086956522, -0.15, 0.45454545454545
92535, 0.43478260869565, -0.15, 0.045454545454545
92536, 0.43478260869565, -0.15, 0.090909090909091
92537, 0.43478260869565, -0.15, 0.13636363636364
92538, 0.43478260869565, -0.15, 0.18181818181818
92539, 0.43478260869565, -0.15, 0.22727272727273
92540, 0.43478260869565, -0.15, 0.27272727272727
92541, 0.43478260869565, -0.15, 0.31818181818182
92542, 0.43478260869565, -0.15, 0.36363636363636
92543, 0.43478260869565, -0.15, 0.40909090909091
92544, 0.43478260869565, -0.15, 0.45454545454545
92545, 0.39130434782609, -0.15, 0.045454545454545
92546, 0.39130434782609, -0.15, 0.090909090909091
92547, 0.39130434782609, -0.15, 0.13636363636364
92548, 0.39130434782609, -0.15, 0.18181818181818
92549, 0.39130434782609, -0.15, 0.22727272727273
92550, 0.39130434782609, -0.15, 0.27272727272727
92551, 0.39130434782609, -0.15, 0.31818181818182
92552, 0.39130434782609, -0.15, 0.36363636363636
92553, 0.39130434782609, -0.15, 0.40909090909091
92554, 0.39130434782609, -0.15, 0.45454545454545
92555, 0.34782608695652, -0.15, 0.045454545454545
92556, 0.34782608695652, -0.15, 0.090909090909091
92557, 0.34782608695652, -0.15, 0.13636363636364
92558, 0.34782608695652, -0.15, 0.18181818181818
92559, 0.34782608695652, -0.15, 0.22727272727273
92560, 0.34782608695652, -0.15, 0.27272727272727
92561, 0.34782608695652, -0.15, 0.31818181818182
92562, 0.34782608695652, -0.15, 0.36363636363636
92563, 0.34782608695652, -0.15, 0.40909090909091
92564, 0.34782608695652, -0.15, 0.45454545454545
92565, 0.30434782608696, -0.15, 0.045454545454545
92566, 0.30434782608696, -0.15, 0.090909090909091
92567, 0.30434782608696, -0.15, 0.13636363636364
92568, 0.30434782608696, -0.15, 0.18181818181818
92569, 0.30434782608696, -0.15, 0.22727272727273
92570, 0.30434782608696, -0.15, 0.27272727272727
92571, 0.30434782608696, -0.15, 0.31818181818182
92572, 0.30434782608696, -0.15, 0.36363636363636
92573, 0.30434782608696, -0.15, 0.40909090909091
92574, 0.30434782608696, -0.15, 0.45454545454545
92575, 0.26086956521739, -0.15, 0.045454545454545
92576, 0.26086956521739, -0.15, 0.090909090909091
92577, 0.26086956521739, -0.15, 0.13636363636364
92578, 0.26086956521739, -0.15, 0.18181818181818
92579, 0.26086956521739, -0.15, 0.22727272727273
92580, 0.26086956521739, -0.15, 0.27272727272727
92581, 0.26086956521739, -0.15, 0.31818181818182
92582, 0.26086956521739, -0.15, 0.36363636363636
92583, 0.26086956521739, -0.15, 0.40909090909091
92584, 0.26086956521739, -0.15, 0.45454545454545
92585, 0.21739130434783, -0.15, 0.045454545454545
92586, 0.21739130434783, -0.15, 0.090909090909091
92587, 0.21739130434783, -0.15, 0.13636363636364
92588, 0.21739130434783, -0.15, 0.18181818181818
92589, 0.21739130434783, -0.15, 0.22727272727273
92590, 0.21739130434783, -0.15, 0.27272727272727
92591, 0.21739130434783, -0.15, 0.31818181818182
92592, 0.21739130434783, -0.15, 0.36363636363636
92593, 0.21739130434783, -0.15, 0.40909090909091
92594, 0.21739130434783, -0.15, 0.45454545454545
92595, 0.17391304347826, -0.15, 0.045454545454545
92596, 0.17391304347826, -0.15, 0.090909090909091
92597, 0.17391304347826, -0.15, 0.13636363636364
92598, 0.17391304347826, -0.15, 0.18181818181818
92599, 0.17391304347826, -0.15, 0.22727272727273
92600, 0.17391304347826, -0.15, 0.27272727272727
92601, 0.17391304347826, -0.15, 0.31818181818182
92602, 0.17391304347826, -0.15, 0.36363636363636
92603, 0.17391304347826, -0.15, 0.40909090909091
92604, 0.17391304347826, -0.15, 0.45454545454545
92605, 0.1304347826087, -0.15, 0.045454545454545
92606, 0.1304347826087, -0.15, 0.090909090909091
92607, 0.1304347826087, -0.15, 0.13636363636364
92608, 0.1304347826087, -0.15, 0.18181818181818
92609, 0.1304347826087, -0.15, 0.22727272727273
92610, 0.1304347826087, -0.15, 0.27272727272727
92611, 0.1304347826087, -0.15, 0.31818181818182
92612, 0.1304347826087, -0.15, 0.36363636363636
92613, 0.1304347826087, -0.15, 0.40909090909091
92614, 0.1304347826087, -0.15, 0.45454545454545
92615, 0.08695652173913, -0.15, 0.045454545454545
92616, 0.08695652173913, -0.15, 0.090909090909091
92617, 0.08695652173913, -0.15, 0.13636363636364
92618, 0.08695652173913, -0.15, 0.18181818181818
92619, 0.08695652173913, -0.15, 0.22727272727273
92620, 0.08695652173913, -0.15, 0.27272727272727
92621, 0.08695652173913, -0.15, 0.31818181818182
92622, 0.08695652173913, -0.15, 0.36363636363636
92623, 0.08695652173913, -0.15, 0.40909090909091
92624, 0.08695652173913, -0.15, 0.45454545454545
92625, 0.043478260869565, -0.15, 0.045454545454545
92626, 0.043478260869565, -0.15, 0.090909090909091
92627, 0.043478260869565, -0.15, 0.13636363636364
92628, 0.043478260869565, -0.15, 0.18181818181818
92629, 0.043478260869565, -0.15, 0.22727272727273
92630, 0.043478260869565, -0.15, 0.27272727272727
92631, 0.043478260869565, -0.15, 0.31818181818182
92632, 0.043478260869565, -0.15, 0.36363636363636
92633, 0.043478260869565, -0.15, 0.40909090909091
92634, 0.043478260869565, -0.15, 0.45454545454545
92635, 0.95652173913043, -0.05, 0.022727272727273
92636, 0.97826086956522, -0.05, 0.045454545454545
92637, 0.95652173913043, -0.025, 0.045454545454545
92638, 0.95652173913043, -0.05, 0.068181818181818
92639, 0.97826086956522, -0.05, 0.090909090909091
92640, 0.95652173913043, -0.025, 0.090909090909091
92641, 0.95652173913043, -0.05, 0.11363636363636
92642, 0.97826086956522, -0.05, 0.13636363636364
92643, 0.95652173913043, -0.025, 0.13636363636364
92644, 0.95652173913043, -0.05, 0.15909090909091
92645, 0.97826086956522, -0.05, 0.18181818181818
92646, 0.95652173913043, -0.025, 0.18181818181818
92647, 0.95652173913043, -0.05, 0.20454545454545
92648, 0.97826086956522, -0.05, 0.22727272727273
92649, 0.95652173913043, -0.025, 0.22727272727273
92650, 0.95652173913043, -0.05, 0.25
92651, 0.97826086956522, -0.05, 0.27272727272727
92652, 0.95652173913043, -0.025, 0.27272727272727
92653, 0.95652173913043, -0.05, 0.29545454545455
92654, 0.97826086956522, -0.05, 0.31818181818182
92655, 0.95652173913043, -0.025, 0.31818181818182
92656, 0.95652173913043, -0.05, 0.34090909090909
92657, 0.97826086956522, -0.05, 0.36363636363636
92658, 0.95652173913043, -0.025, 0.36363636363636
92659, 0.95652173913043, -0.05, 0.38636363636364
92660, 0.97826086956522, -0.05, 0.40909090909091
92661, 0.95652173913043, -0.025, 0.40909090909091
92662, 0.95652173913043, -0.05, 0.43181818181818
92663, 0.97826086956522, -0.05, 0.45454545454545
92664, 0.95652173913043, -0.025, 0.45454545454545
92665, 0.95652173913043, -0.05, 0.47727272727273
92666, 0.91304347826087, -0.05, 0.022727272727273
92667, 0.93478260869565, -0.05, 0.045454545454545
92668, 0.91304347826087, -0.025, 0.045454545454545
92669, 0.91304347826087, -0.05, 0.068181818181818
92670, 0.93478260869565, -0.05, 0.090909090909091
92671, 0.91304347826087, -0.025, 0.090909090909091
92672, 0.91304347826087, -0.05, 0.11363636363636
92673, 0.93478260869565, -0.05, 0.13636363636364
92674, 0.91304347826087, -0.025, 0.13636363636364
92675, 0.91304347826087, -0.05, 0.15909090909091
92676, 0.93478260869565, -0.05, 0.18181818181818
92677, 0.91304347826087, -0.025, 0.18181818181818
92678, 0.91304347826087, -0.05, 0.20454545454545
92679, 0.93478260869565, -0.05, 0.22727272727273
92680, 0.91304347826087, -0.025, 0.22727272727273
92681, 0.91304347826087, -0.05, 0.25
92682, 0.93478260869565, -0.05, 0.27272727272727
92683, 0.91304347826087, -0.025, 0.27272727272727
92684, 0.91304347826087, -0.05, 0.29545454545455
92685, 0.93478260869565, -0.05, 0.31818181818182
92686, 0.91304347826087, -0.025, 0.31818181818182
92687, 0.91304347826087, -0.05, 0.34090909090909
92688, 0.93478260869565, -0.05, 0.36363636363636
92689, 0.91304347826087, -0.025, 0.36363636363636
92690, 0.91304347826087, -0.05, 0.38636363636364
92691, 0.93478260869565, -0.05, 0.40909090909091
92692, 0.91304347826087, -0.025, 0.40909090909091
92693, 0.91304347826087, -0.05, 0.43181818181818
92694, 0.93478260869565, -0.05, 0.45454545454545
92695, 0.91304347826087, -0.025, 0.45454545454545
92696, 0.91304347826087, -0.05, 0.47727272727273
92697, 0.8695652173913, -0.05, 0.022727272727273
92698, 0.89130434782609, -0.05, 0.045454545454545
92699, 0.8695652173913, -0.025, 0.045454545454545
92700, 0.8695652173913, -0.05, 0.068181818181818
92701, 0.89130434782609, -0.05, 0.090909090909091
92702, 0.8695652173913, -0.025, 0.090909090909091
92703, 0.8695652173913, -0.05, 0.11363636363636
92704, 0.89130434782609, -0.05, 0.13636363636364
92705, 0.8695652173913, -0.025, 0.13636363636364
92706, 0.8695652173913, -0.05, 0.15909090909091
92707, 0.89130434782609, -0.05, 0.18181818181818
92708, 0.8695652173913, -0.025, 0.18181818181818
92709, 0.8695652173913, -0.05, 0.20454545454545
92710, 0.89130434782609, -0.05, 0.22727272727273
92711, 0.8695652173913, -0.025, 0.22727272727273
92712, 0.8695652173913, -0.05, 0.25
92713, 0.89130434782609, -0.05, 0.27272727272727
92714, 0.8695652173913, -0.025, 0.27272727272727
92715, 0.8695652173913, -0.05, 0.29545454545455
92716, 0.89130434782609, -0.05, 0.31818181818182
92717, 0.8695652173913, -0.025, 0.31818181818182
92718, 0.8695652173913, -0.05, 0.34090909090909
92719, 0.89130434782609, -0.05, 0.36363636363636
92720, 0.8695652173913, -0.025, 0.36363636363636
92721, 0.8695652173913, -0.05, 0.38636363636364
92722, 0.89130434782609, -0.05, 0.40909090909091
92723, 0.8695652173913, -0.025, 0.40909090909091
92724, 0.8695652173913, -0.05, 0.43181818181818
92725, 0.89130434782609, -0.05, 0.45454545454545
92726, 0.8695652173913, -0.025, 0.45454545454545
92727, 0.8695652173913, -0.05, 0.47727272727273
92728, 0.82608695652174, -0.05, 0.022727272727273
92729, 0.84782608695652, -0.05, 0.045454545454545
92730, 0.82608695652174, -0.025, 0.045454545454545
92731, 0.82608695652174, -0.05, 0.068181818181818
92732, 0.84782608695652, -0.05, 0.090909090909091
92733, 0.82608695652174, -0.025, 0.090909090909091
92734, 0.82608695652174, -0.05, 0.11363636363636
92735, 0.84782608695652, -0.05, 0.13636363636364
92736, 0.82608695652174, -0.025, 0.13636363636364
92737, 0.82608695652174, -0.05, 0.15909090909091
92738, 0.84782608695652, -0.05, 0.18181818181818
92739, 0.82608695652174, -0.025, 0.18181818181818
92740, 0.82608695652174, -0.05, 0.20454545454545
92741, 0.84782608695652, -0.05, 0.22727272727273
92742, 0.82608695652174, -0.025, 0.22727272727273
92743, 0.82608695652174, -0.05, 0.25
92744, 0.84782608695652, -0.05, 0.27272727272727
92745, 0.82608695652174, -0.025, 0.27272727272727
92746, 0.82608695652174, -0.05, 0.29545454545455
92747, 0.84782608695652, -0.05, 0.31818181818182
92748, 0.82608695652174, -0.025, 0.31818181818182
92749, 0.82608695652174, -0.05, 0.34090909090909
92750, 0.84782608695652, -0.05, 0.36363636363636
92751, 0.82608695652174, -0.025, 0.36363636363636
92752, 0.82608695652174, -0.05, 0.38636363636364
92753, 0.84782608695652, -0.05, 0.40909090909091
92754, 0.82608695652174, -0.025, 0.40909090909091
92755, 0.82608695652174, -0.05, 0.43181818181818
92756, 0.84782608695652, -0.05, 0.45454545454545
92757, 0.82608695652174, -0.025, 0.45454545454545
92758, 0.82608695652174, -0.05, 0.47727272727273
92759, 0.78260869565217, -0.05, 0.022727272727273
92760, 0.80434782608696, -0.05, 0.045454545454545
92761, 0.78260869565217, -0.025, 0.045454545454545
92762, 0.78260869565217, -0.05, 0.068181818181818
92763, 0.80434782608696, -0.05, 0.090909090909091
92764, 0.78260869565217, -0.025, 0.090909090909091
92765, 0.78260869565217, -0.05, 0.11363636363636
92766, 0.80434782608696, -0.05, 0.13636363636364
92767, 0.78260869565217, -0.025, 0.13636363636364
92768, 0.78260869565217, -0.05, 0.15909090909091
92769, 0.80434782608696, -0.05, 0.18181818181818
92770, 0.78260869565217, -0.025, 0.18181818181818
92771, 0.78260869565217, -0.05, 0.20454545454545
92772, 0.80434782608696, -0.05, 0.22727272727273
92773, 0.78260869565217, -0.025, 0.22727272727273
92774, 0.78260869565217, -0.05, 0.25
92775, 0.80434782608696, -0.05, 0.27272727272727
92776, 0.78260869565217, -0.025, 0.27272727272727
92777, 0.78260869565217, -0.05, 0.29545454545455
92778, 0.80434782608696, -0.05, 0.31818181818182
92779, 0.78260869565217, -0.025, 0.31818181818182
92780, 0.78260869565217, -0.05, 0.34090909090909
92781, 0.80434782608696, -0.05, 0.36363636363636
92782, 0.78260869565217, -0.025, 0.36363636363636
92783, 0.78260869565217, -0.05, 0.38636363636364
92784, 0.80434782608696, -0.05, 0.40909090909091
92785, 0.78260869565217, -0.025, 0.40909090909091
92786, 0.78260869565217, -0.05, 0.43181818181818
92787, 0.80434782608696, -0.05, 0.45454545454545
92788, 0.78260869565217, -0.025, 0.45454545454545
92789, 0.78260869565217, -0.05, 0.47727272727273
92790, 0.73913043478261, -0.05, 0.022727272727273
92791, 0.76086956521739, -0.05, 0.045454545454545
92792, 0.73913043478261, -0.025, 0.045454545454545
92793, 0.73913043478261, -0.05, 0.068181818181818
92794, 0.76086956521739, -0.05, 0.090909090909091
92795, 0.73913043478261, -0.025, 0.090909090909091
92796, 0.73913043478261, -0.05, 0.11363636363636
92797, 0.76086956521739, -0.05, 0.13636363636364
92798, 0.73913043478261, -0.025, 0.13636363636364
92799, 0.73913043478261, -0.05, 0.15909090909091
92800, 0.76086956521739, -0.05, 0.18181818181818
92801, 0.73913043478261, -0.025, 0.18181818181818
92802, 0.73913043478261, -0.05, 0.20454545454545
92803, 0.76086956521739, -0.05, 0.22727272727273
92804, 0.73913043478261, -0.025, 0.22727272727273
92805, 0.73913043478261, -0.05, 0.25
92806, 0.76086956521739, -0.05, 0.27272727272727
92807, 0.73913043478261, -0.025, 0.27272727272727
92808, 0.73913043478261, -0.05, 0.29545454545455
92809, 0.76086956521739, -0.05, 0.31818181818182
92810, 0.73913043478261, -0.025, 0.31818181818182
92811, 0.73913043478261, -0.05, 0.34090909090909
92812, 0.76086956521739, -0.05, 0.36363636363636
92813, 0.73913043478261, -0.025, 0.36363636363636
92814, 0.73913043478261, -0.05, 0.38636363636364
92815, 0.76086956521739, -0.05, 0.40909090909091
92816, 0.73913043478261, -0.025, 0.40909090909091
92817, 0.73913043478261, -0.05, 0.43181818181818
92818, 0.76086956521739, -0.05, 0.45454545454545
92819, 0.73913043478261, -0.025, 0.45454545454545
92820, 0.73913043478261, -0.05, 0.47727272727273
92821, 0.69565217391304, -0.05, 0.022727272727273
92822, 0.71739130434783, -0.05, 0.045454545454545
92823, 0.69565217391304, -0.025, 0.045454545454545
92824, 0.69565217391304, -0.05, 0.068181818181818
92825, 0.71739130434783, -0.05, 0.090909090909091
92826, 0.69565217391304, -0.025, 0.090909090909091
92827, 0.69565217391304, -0.05, 0.11363636363636
92828, 0.71739130434783, -0.05, 0.13636363636364
92829, 0.69565217391304, -0.025, 0.13636363636364
92830, 0.69565217391304, -0.05, 0.15909090909091
92831, 0.71739130434783, -0.05, 0.18181818181818
92832, 0.69565217391304, -0.025, 0.18181818181818
92833, 0.69565217391304, -0.05, 0.20454545454545
92834, 0.71739130434783, -0.05, 0.22727272727273
92835, 0.69565217391304, -0.025, 0.22727272727273
92836, 0.69565217391304, -0.05, 0.25
92837, 0.71739130434783, -0.05, 0.27272727272727
92838, 0.69565217391304, -0.025, 0.27272727272727
92839, 0.69565217391304, -0.05, 0.29545454545455
92840, 0.71739130434783, -0.05, 0.31818181818182
92841, 0.69565217391304, -0.025, 0.31818181818182
92842, 0.69565217391304, -0.05, 0.34090909090909
92843, 0.71739130434783, -0.05, 0.36363636363636
92844, 0.69565217391304, -0.025, 0.36363636363636
92845, 0.69565217391304, -0.05, 0.38636363636364
92846, 0.71739130434783, -0.05, 0.40909090909091
92847, 0.69565217391304, -0.025, 0.40909090909091
92848, 0.69565217391304, -0.05, 0.43181818181818
92849, 0.71739130434783, -0.05, 0.45454545454545
92850, 0.69565217391304, -0.025, 0.45454545454545
92851, 0.69565217391304, -0.05, 0.47727272727273
92852, 0.65217391304348, -0.05, 0.022727272727273
92853, 0.67391304347826, -0.05, 0.045454545454545
92854, 0.65217391304348, -0.025, 0.045454545454545
92855, 0.65217391304348, -0.05, 0.068181818181818
92856, 0.67391304347826, -0.05, 0.090909090909091
92857, 0.65217391304348, -0.025, 0.090909090909091
92858, 0.65217391304348, -0.05, 0.11363636363636
92859, 0.67391304347826, -0.05, 0.13636363636364
92860, 0.65217391304348, -0.025, 0.13636363636364
92861, 0.65217391304348, -0.05, 0.15909090909091
92862, 0.67391304347826, -0.05, 0.18181818181818
92863, 0.65217391304348, -0.025, 0.18181818181818
92864, 0.65217391304348, -0.05, 0.20454545454545
92865, 0.67391304347826, -0.05, 0.22727272727273
92866, 0.65217391304348, -0.025, 0.22727272727273
92867, 0.65217391304348, -0.05, 0.25
92868, 0.67391304347826, -0.05, 0.27272727272727
92869, 0.65217391304348, -0.025, 0.27272727272727
92870, 0.65217391304348, -0.05, 0.29545454545455
92871, 0.67391304347826, -0.05, 0.31818181818182
92872, 0.65217391304348, -0.025, 0.31818181818182
92873, 0.65217391304348, -0.05, 0.34090909090909
92874, 0.67391304347826, -0.05, 0.36363636363636
92875, 0.65217391304348, -0.025, 0.36363636363636
92876, 0.65217391304348, -0.05, 0.38636363636364
92877, 0.67391304347826, -0.05, 0.40909090909091
92878, 0.65217391304348, -0.025, 0.40909090909091
92879, 0.65217391304348, -0.05, 0.43181818181818
92880, 0.67391304347826, -0.05, 0.45454545454545
92881, 0.65217391304348, -0.025, 0.45454545454545
92882, 0.65217391304348, -0.05, 0.47727272727273
92883, 0.60869565217391, -0.05, 0.022727272727273
92884, 0.6304347826087, -0.05, 0.045454545454545
92885, 0.60869565217391, -0.025, 0.045454545454545
92886, 0.60869565217391, -0.05, 0.068181818181818
92887, 0.6304347826087, -0.05, 0.090909090909091
92888, 0.60869565217391, -0.025, 0.090909090909091
92889, 0.60869565217391, -0.05, 0.11363636363636
92890, 0.6304347826087, -0.05, 0.13636363636364
92891, 0.60869565217391, -0.025, 0.13636363636364
92892, 0.60869565217391, -0.05, 0.15909090909091
92893, 0.6304347826087, -0.05, 0.18181818181818
92894, 0.60869565217391, -0.025, 0.18181818181818
92895, 0.60869565217391, -0.05, 0.20454545454545
92896, 0.6304347826087, -0.05, 0.22727272727273
92897, 0.60869565217391, -0.025, 0.22727272727273
92898, 0.60869565217391, -0.05, 0.25
92899, 0.6304347826087, -0.05, 0.27272727272727
92900, 0.60869565217391, -0.025, 0.27272727272727
92901, 0.60869565217391, -0.05, 0.29545454545455
92902, 0.6304347826087, -0.05, 0.31818181818182
92903, 0.60869565217391, -0.025, 0.31818181818182
92904, 0.60869565217391, -0.05, 0.34090909090909
92905, 0.6304347826087, -0.05, 0.36363636363636
92906, 0.60869565217391, -0.025, 0.36363636363636
92907, 0.60869565217391, -0.05, 0.38636363636364
92908, 0.6304347826087, -0.05, 0.40909090909091
92909, 0.60869565217391, -0.025, 0.40909090909091
92910, 0.60869565217391, -0.05, 0.43181818181818
92911, 0.6304347826087, -0.05, 0.45454545454545
92912, 0.60869565217391, -0.025, 0.45454545454545
92913, 0.60869565217391, -0.05, 0.47727272727273
92914, 0.56521739130435, -0.05, 0.022727272727273
92915, 0.58695652173913, -0.05, 0.045454545454545
92916, 0.56521739130435, -0.025, 0.045454545454545
92917, 0.56521739130435, -0.05, 0.068181818181818
92918, 0.58695652173913, -0.05, 0.090909090909091
92919, 0.56521739130435, -0.025, 0.090909090909091
92920, 0.56521739130435, -0.05, 0.11363636363636
92921, 0.58695652173913, -0.05, 0.13636363636364
92922, 0.56521739130435, -0.025, 0.13636363636364
92923, 0.56521739130435, -0.05, 0.15909090909091
92924, 0.58695652173913, -0.05, 0.18181818181818
92925, 0.56521739130435, -0.025, 0.18181818181818
92926, 0.56521739130435, -0.05, 0.20454545454545
92927, 0.58695652173913, -0.05, 0.22727272727273
92928, 0.56521739130435, -0.025, 0.22727272727273
92929, 0.56521739130435, -0.05, 0.25
92930, 0.58695652173913, -0.05, 0.27272727272727
92931, 0.56521739130435, -0.025, 0.27272727272727
92932, 0.56521739130435, -0.05, 0.29545454545455
92933, 0.58695652173913, -0.05, 0.31818181818182
92934, 0.56521739130435, -0.025, 0.31818181818182
92935, 0.56521739130435, -0.05, 0.34090909090909
92936, 0.58695652173913, -0.05, 0.36363636363636
92937, 0.56521739130435, -0.025, 0.36363636363636
92938, 0.56521739130435, -0.05, 0.38636363636364
92939, 0.58695652173913, -0.05, 0.40909090909091
92940, 0.56521739130435, -0.025, 0.40909090909091
92941, 0.56521739130435, -0.05, 0.43181818181818
92942, 0.58695652173913, -0.05, 0.45454545454545
92943, 0.56521739130435, -0.025, 0.45454545454545
92944, 0.56521739130435, -0.05, 0.47727272727273
92945, 0.52173913043478, -0.05, 0.022727272727273
92946, 0.54347826086956, -0.05, 0.045454545454545
92947, 0.52173913043478, -0.025, 0.045454545454545
92948, 0.52173913043478, -0.05, 0.068181818181818
92949, 0.54347826086956, -0.05, 0.090909090909091
92950, 0.52173913043478, -0.025, 0.090909090909091
92951, 0.52173913043478, -0.05, 0.11363636363636
92952, 0.54347826086956, -0.05, 0.13636363636364
92953, 0.52173913043478, -0.025, 0.13636363636364
92954, 0.52173913043478, -0.05, 0.15909090909091
92955, 0.54347826086956, -0.05, 0.18181818181818
92956, 0.52173913043478, -0.025, 0.18181818181818
92957, 0.52173913043478, -0.05, 0.20454545454545
92958, 0.54347826086956, -0.05, 0.22727272727273
92959, 0.52173913043478, -0.025, 0.22727272727273
92960, 0.52173913043478, -0.05, 0.25
92961, 0.54347826086956, -0.05, 0.27272727272727
92962, 0.52173913043478, -0.025, 0.27272727272727
92963, 0.52173913043478, -0.05, 0.29545454545455
92964, 0.54347826086956, -0.05, 0.31818181818182
92965, 0.52173913043478, -0.025, 0.31818181818182
92966, 0.52173913043478, -0.05, 0.34090909090909
92967, 0.54347826086956, -0.05, 0.36363636363636
92968, 0.52173913043478, -0.025, 0.36363636363636
92969, 0.52173913043478, -0.05, 0.38636363636364
92970, 0.54347826086956, -0.05, 0.40909090909091
92971, 0.52173913043478, -0.025, 0.40909090909091
92972, 0.52173913043478, -0.05, 0.43181818181818
92973, 0.54347826086956, -0.05, 0.45454545454545
92974, 0.52173913043478, -0.025, 0.45454545454545
92975, 0.52173913043478, -0.05, 0.47727272727273
92976, 0.47826086956522, -0.05, 0.022727272727273
92977, 0.5, -0.05, 0.045454545454545
92978, 0.47826086956522, -0.025, 0.045454545454545
92979, 0.47826086956522, -0.05, 0.068181818181818
92980, 0.5, -0.05, 0.090909090909091
92981, 0.47826086956522, -0.025, 0.090909090909091
92982, 0.47826086956522, -0.05, 0.11363636363636
92983, 0.5, -0.05, 0.13636363636364
92984, 0.47826086956522, -0.025, 0.13636363636364
92985, 0.47826086956522, -0.05, 0.15909090909091
92986, 0.5, -0.05, 0.18181818181818
92987, 0.47826086956522, -0.025, 0.18181818181818
92988, 0.47826086956522, -0.05, 0.20454545454545
92989, 0.5, -0.05, 0.22727272727273
92990, 0.47826086956522, -0.025, 0.22727272727273
92991, 0.47826086956522, -0.05, 0.25
92992, 0.5, -0.05, 0.27272727272727
92993, 0.47826086956522, -0.025, 0.27272727272727
92994, 0.47826086956522, -0.05, 0.29545454545455
92995, 0.5, -0.05, 0.31818181818182
92996, 0.47826086956522, -0.025, 0.31818181818182
92997, 0.47826086956522, -0.05, 0.34090909090909
92998, 0.5, -0.05, 0.36363636363636
92999, 0.47826086956522, -0.025, 0.36363636363636
93000, 0.47826086956522, -0.05, 0.38636363636364
93001, 0.5, -0.05, 0.40909090909091
93002, 0.47826086956522, -0.025, 0.40909090909091
93003, 0.47826086956522, -0.05, 0.43181818181818
93004, 0.5, -0.05, 0.45454545454545
93005, 0.47826086956522, -0.025, 0.45454545454545
93006, 0.47826086956522, -0.05, 0.47727272727273
93007, 0.43478260869565, -0.05, 0.022727272727273
93008, 0.45652173913043, -0.05, 0.045454545454545
93009, 0.43478260869565, -0.025, 0.045454545454545
93010, 0.43478260869565, -0.05, 0.068181818181818
93011, 0.45652173913043, -0.05, 0.090909090909091
93012, 0.43478260869565, -0.025, 0.090909090909091
93013, 0.43478260869565, -0.05, 0.11363636363636
93014, 0.45652173913043, -0.05, 0.13636363636364
93015, 0.43478260869565, -0.025, 0.13636363636364
93016, 0.43478260869565, -0.05, 0.15909090909091
93017, 0.45652173913043, -0.05, 0.18181818181818
93018, 0.43478260869565, -0.025, 0.18181818181818
93019, 0.43478260869565, -0.05, 0.20454545454545
93020, 0.45652173913043, -0.05, 0.22727272727273
93021, 0.43478260869565, -0.025, 0.22727272727273
93022, 0.43478260869565, -0.05, 0.25
93023, 0.45652173913043, -0.05, 0.27272727272727
93024, 0.43478260869565, -0.025, 0.27272727272727
93025, 0.43478260869565, -0.05, 0.29545454545455
93026, 0.45652173913043, -0.05, 0.31818181818182
93027, 0.43478260869565, -0.025, 0.31818181818182
93028, 0.43478260869565, -0.05, 0.34090909090909
93029, 0.45652173913043, -0.05, 0.36363636363636
93030, 0.43478260869565, -0.025, 0.36363636363636
93031, 0.43478260869565, -0.05, 0.38636363636364
93032, 0.45652173913043, -0.05, 0.40909090909091
93033, 0.43478260869565, -0.025, 0.40909090909091
93034, 0.43478260869565, -0.05, 0.43181818181818
93035, 0.45652173913044, -0.05, 0.45454545454545
93036, 0.43478260869565, -0.025, 0.45454545454545
93037, 0.43478260869565, -0.05, 0.47727272727273
93038, 0.39130434782609, -0.05, 0.022727272727273
93039, 0.41304347826087, -0.05, 0.045454545454545
93040, 0.39130434782609, -0.025, 0.045454545454545
93041, 0.39130434782609, -0.05, 0.068181818181818
93042, 0.41304347826087, -0.05, 0.090909090909091
93043, 0.39130434782609, -0.025, 0.090909090909091
93044, 0.39130434782609, -0.05, 0.11363636363636
93045, 0.41304347826087, -0.05, 0.13636363636364
93046, 0.39130434782609, -0.025, 0.13636363636364
93047, 0.39130434782609, -0.05, 0.15909090909091
93048, 0.41304347826087, -0.05, 0.18181818181818
93049, 0.39130434782609, -0.025, 0.18181818181818
93050, 0.39130434782609, -0.05, 0.20454545454545
93051, 0.41304347826087, -0.05, 0.22727272727273
93052, 0.39130434782609, -0.025, 0.22727272727273
93053, 0.39130434782609, -0.05, 0.25
93054, 0.41304347826087, -0.05, 0.27272727272727
93055, 0.39130434782609, -0.025, 0.27272727272727
93056, 0.39130434782609, -0.05, 0.29545454545455
93057, 0.41304347826087, -0.05, 0.31818181818182
93058, 0.39130434782609, -0.025, 0.31818181818182
93059, 0.39130434782609, -0.05, 0.34090909090909
93060, 0.41304347826087, -0.05, 0.36363636363636
93061, 0.39130434782609, -0.025, 0.36363636363636
93062, 0.39130434782609, -0.05, 0.38636363636364
93063, 0.41304347826087, -0.05, 0.40909090909091
93064, 0.39130434782609, -0.025, 0.40909090909091
93065, 0.39130434782609, -0.05, 0.43181818181818
93066, 0.41304347826087, -0.05, 0.45454545454545
93067, 0.39130434782609, -0.025, 0.45454545454545
93068, 0.39130434782609, -0.05, 0.47727272727273
93069, 0.34782608695652, -0.05, 0.022727272727273
93070, 0.3695652173913, -0.05, 0.045454545454545
93071, 0.34782608695652, -0.025, 0.045454545454545
93072, 0.34782608695652, -0.05, 0.068181818181818
93073, 0.3695652173913, -0.05, 0.090909090909091
93074, 0.34782608695652, -0.025, 0.090909090909091
93075, 0.34782608695652, -0.05, 0.11363636363636
93076, 0.3695652173913, -0.05, 0.13636363636364
93077, 0.34782608695652, -0.025, 0.13636363636364
93078, 0.34782608695652, -0.05, 0.15909090909091
93079, 0.3695652173913, -0.05, 0.18181818181818
93080, 0.34782608695652, -0.025, 0.18181818181818
93081, 0.34782608695652, -0.05, 0.20454545454545
93082, 0.3695652173913, -0.05, 0.22727272727273
93083, 0.34782608695652, -0.025, 0.22727272727273
93084, 0.34782608695652, -0.05, 0.25
93085, 0.3695652173913, -0.05, 0.27272727272727
93086, 0.34782608695652, -0.025, 0.27272727272727
93087, 0.34782608695652, -0.05, 0.29545454545455
93088, 0.3695652173913, -0.05, 0.31818181818182
93089, 0.34782608695652, -0.025, 0.31818181818182
93090, 0.34782608695652, -0.05, 0.34090909090909
93091, 0.3695652173913, -0.05, 0.36363636363636
93092, 0.34782608695652, -0.025, 0.36363636363636
93093, 0.34782608695652, -0.05, 0.38636363636364
93094, 0.3695652173913, -0.05, 0.40909090909091
93095, 0.34782608695652, -0.025, 0.40909090909091
93096, 0.34782608695652, -0.05, 0.43181818181818
93097, 0.3695652173913, -0.05, 0.45454545454545
93098, 0.34782608695652, -0.025, 0.45454545454545
93099, 0.34782608695652, -0.05, 0.47727272727273
93100, 0.30434782608696, -0.05, 0.022727272727273
93101, 0.32608695652174, -0.05, 0.045454545454545
93102, 0.30434782608696, -0.025, 0.045454545454545
93103, 0.30434782608696, -0.05, 0.068181818181818
93104, 0.32608695652174, -0.05, 0.090909090909091
93105, 0.30434782608696, -0.025, 0.090909090909091
93106, 0.30434782608696, -0.05, 0.11363636363636
93107, 0.32608695652174, -0.05, 0.13636363636364
93108, 0.30434782608696, -0.025, 0.13636363636364
93109, 0.30434782608696, -0.05, 0.15909090909091
93110, 0.32608695652174, -0.05, 0.18181818181818
93111, 0.30434782608696, -0.025, 0.18181818181818
93112, 0.30434782608696, -0.05, 0.20454545454545
93113, 0.32608695652174, -0.05, 0.22727272727273
93114, 0.30434782608696, -0.025, 0.22727272727273
93115, 0.30434782608696, -0.05, 0.25
93116, 0.32608695652174, -0.05, 0.27272727272727
93117, 0.30434782608696, -0.025, 0.27272727272727
93118, 0.30434782608696, -0.05, 0.29545454545455
93119, 0.32608695652174, -0.05, 0.31818181818182
93120, 0.30434782608696, -0.025, 0.31818181818182
93121, 0.30434782608696, -0.05, 0.34090909090909
93122, 0.32608695652174, -0.05, 0.36363636363636
93123, 0.30434782608696, -0.025, 0.36363636363636
93124, 0.30434782608696, -0.05, 0.38636363636364
93125, 0.32608695652174, -0.05, 0.40909090909091
93126, 0.30434782608696, -0.025, 0.40909090909091
93127, 0.30434782608696, -0.05, 0.43181818181818
93128, 0.32608695652174, -0.05, 0.45454545454545
93129, 0.30434782608696, -0.025, 0.45454545454545
93130, 0.30434782608696, -0.05, 0.47727272727273
93131, 0.26086956521739, -0.05, 0.022727272727273
93132, 0.28260869565217, -0.05, 0.045454545454545
93133, 0.26086956521739, -0.025, 0.045454545454545
93134, 0.26086956521739, -0.05, 0.068181818181818
93135, 0.28260869565217, -0.05, 0.090909090909091
93136, 0.26086956521739, -0.025, 0.090909090909091
93137, 0.26086956521739, -0.05, 0.11363636363636
93138, 0.28260869565217, -0.05, 0.13636363636364
93139, 0.26086956521739, -0.025, 0.13636363636364
93140, 0.26086956521739, -0.05, 0.15909090909091
93141, 0.28260869565217, -0.05, 0.18181818181818
93142, 0.26086956521739, -0.025, 0.18181818181818
93143, 0.26086956521739, -0.05, 0.20454545454545
93144, 0.28260869565217, -0.05, 0.22727272727273
93145, 0.26086956521739, -0.025, 0.22727272727273
93146, 0.26086956521739, -0.05, 0.25
93147, 0.28260869565217, -0.05, 0.27272727272727
93148, 0.26086956521739, -0.025, 0.27272727272727
93149, 0.26086956521739, -0.05, 0.29545454545455
93150, 0.28260869565217, -0.05, 0.31818181818182
93151, 0.26086956521739, -0.025, 0.31818181818182
93152, 0.26086956521739, -0.05, 0.34090909090909
93153, 0.28260869565217, -0.05, 0.36363636363636
93154, 0.26086956521739, -0.025, 0.36363636363636
93155, 0.26086956521739, -0.05, 0.38636363636364
93156, 0.28260869565217, -0.05, 0.40909090909091
93157, 0.26086956521739, -0.025, 0.40909090909091
93158, 0.26086956521739, -0.05, 0.43181818181818
93159, 0.28260869565217, -0.05, 0.45454545454545
93160, 0.26086956521739, -0.025, 0.45454545454545
93161, 0.26086956521739, -0.05, 0.47727272727273
93162, 0.21739130434783, -0.05, 0.022727272727273
93163, 0.23913043478261, -0.05, 0.045454545454545
93164, 0.21739130434783, -0.025, 0.045454545454545
93165, 0.21739130434783, -0.05, 0.068181818181818
93166, 0.23913043478261, -0.05, 0.090909090909091
93167, 0.21739130434783, -0.025, 0.090909090909091
93168, 0.21739130434783, -0.05, 0.11363636363636
93169, 0.23913043478261, -0.05, 0.13636363636364
93170, 0.21739130434783, -0.025, 0.13636363636364
93171, 0.21739130434783, -0.05, 0.15909090909091
93172, 0.23913043478261, -0.05, 0.18181818181818
93173, 0.21739130434783, -0.025, 0.18181818181818
93174, 0.21739130434783, -0.05, 0.20454545454545
93175, 0.23913043478261, -0.05, 0.22727272727273
93176, 0.21739130434783, -0.025, 0.22727272727273
93177, 0.21739130434783, -0.05, 0.25
93178, 0.23913043478261, -0.05, 0.27272727272727
93179, 0.21739130434783, -0.025, 0.27272727272727
93180, 0.21739130434783, -0.05, 0.29545454545455
93181, 0.23913043478261, -0.05, 0.31818181818182
93182, 0.21739130434783, -0.025, 0.31818181818182
93183, 0.21739130434783, -0.05, 0.34090909090909
93184, 0.23913043478261, -0.05, 0.36363636363636
93185, 0.21739130434783, -0.025, 0.36363636363636
93186, 0.21739130434783, -0.05, 0.38636363636364
93187, 0.23913043478261, -0.05, 0.40909090909091
93188, 0.21739130434783, -0.025, 0.40909090909091
93189, 0.21739130434783, -0.05, 0.43181818181818
93190, 0.23913043478261, -0.05, 0.45454545454545
93191, 0.21739130434783, -0.025, 0.45454545454545
93192, 0.21739130434783, -0.05, 0.47727272727273
93193, 0.17391304347826, -0.05, 0.022727272727273
93194, 0.19565217391304, -0.05, 0.045454545454545
93195, 0.17391304347826, -0.025, 0.045454545454545
93196, 0.17391304347826, -0.05, 0.068181818181818
93197, 0.19565217391304, -0.05, 0.090909090909091
93198, 0.17391304347826, -0.025, 0.090909090909091
93199, 0.17391304347826, -0.05, 0.11363636363636
93200, 0.19565217391304, -0.05, 0.13636363636364
93201, 0.17391304347826, -0.025, 0.13636363636364
93202, 0.17391304347826, -0.05, 0.15909090909091
93203, 0.19565217391304, -0.05, 0.18181818181818
93204, 0.17391304347826, -0.025, 0.18181818181818
93205, 0.17391304347826, -0.05, 0.20454545454545
93206, 0.19565217391304, -0.05, 0.22727272727273
93207, 0.17391304347826, -0.025, 0.22727272727273
93208, 0.17391304347826, -0.05, 0.25
93209, 0.19565217391304, -0.05, 0.27272727272727
93210, 0.17391304347826, -0.025, 0.27272727272727
93211, 0.17391304347826, -0.05, 0.29545454545455
93212, 0.19565217391304, -0.05, 0.31818181818182
93213, 0.17391304347826, -0.025, 0.31818181818182
93214, 0.17391304347826, -0.05, 0.34090909090909
93215, 0.19565217391304, -0.05, 0.36363636363636
93216, 0.17391304347826, -0.025, 0.36363636363636
93217, 0.17391304347826, -0.05, 0.38636363636364
93218, 0.19565217391304, -0.05, 0.40909090909091
93219, 0.17391304347826, -0.025, 0.40909090909091
93220, 0.17391304347826, -0.05, 0.43181818181818
93221, 0.19565217391304, -0.05, 0.45454545454545
93222, 0.17391304347826, -0.025, 0.45454545454545
93223, 0.17391304347826, -0.05, 0.47727272727273
93224, 0.1304347826087, -0.05, 0.022727272727273
93225, 0.15217391304348, -0.05, 0.045454545454545
93226, 0.1304347826087, -0.025, 0.045454545454545
93227, 0.1304347826087, -0.05, 0.068181818181818
93228, 0.15217391304348, -0.05, 0.090909090909091
93229, 0.1304347826087, -0.025, 0.090909090909091
93230, 0.1304347826087, -0.05, 0.11363636363636
93231, 0.15217391304348, -0.05, 0.13636363636364
93232, 0.1304347826087, -0.025, 0.13636363636364
93233, 0.1304347826087, -0.05, 0.15909090909091
93234, 0.15217391304348, -0.05, 0.18181818181818
93235, 0.1304347826087, -0.025, 0.18181818181818
93236, 0.1304347826087, -0.05, 0.20454545454545
93237, 0.15217391304348, -0.05, 0.22727272727273
93238, 0.1304347826087, -0.025, 0.22727272727273
93239, 0.1304347826087, -0.05, 0.25
93240, 0.15217391304348, -0.05, 0.27272727272727
93241, 0.1304347826087, -0.025, 0.27272727272727
93242, 0.1304347826087, -0.05, 0.29545454545455
93243, 0.15217391304348, -0.05, 0.31818181818182
93244, 0.1304347826087, -0.025, 0.31818181818182
93245, 0.1304347826087, -0.05, 0.34090909090909
93246, 0.15217391304348, -0.05, 0.36363636363636
93247, 0.1304347826087, -0.025, 0.36363636363636
93248, 0.1304347826087, -0.05, 0.38636363636364
93249, 0.15217391304348, -0.05, 0.40909090909091
93250, 0.1304347826087, -0.025, 0.40909090909091
93251, 0.1304347826087, -0.05, 0.43181818181818
93252, 0.15217391304348, -0.05, 0.45454545454545
93253, 0.1304347826087, -0.025, 0.45454545454545
93254, 0.1304347826087, -0.05, 0.47727272727273
93255, 0.08695652173913, -0.05, 0.022727272727273
93256, 0.10869565217391, -0.05, 0.045454545454545
93257, 0.08695652173913, -0.025, 0.045454545454545
93258, 0.08695652173913, -0.05, 0.068181818181818
93259, 0.10869565217391, -0.05, 0.090909090909091
93260, 0.08695652173913, -0.025, 0.090909090909091
93261, 0.08695652173913, -0.05, 0.11363636363636
93262, 0.10869565217391, -0.05, 0.13636363636364
93263, 0.08695652173913, -0.025, 0.13636363636364
93264, 0.08695652173913, -0.05, 0.15909090909091
93265, 0.10869565217391, -0.05, 0.18181818181818
93266, 0.08695652173913, -0.025, 0.18181818181818
93267, 0.08695652173913, -0.05, 0.20454545454545
93268, 0.10869565217391, -0.05, 0.22727272727273
93269, 0.08695652173913, -0.025, 0.22727272727273
93270, 0.08695652173913, -0.05, 0.25
93271, 0.10869565217391, -0.05, 0.27272727272727
93272, 0.08695652173913, -0.025, 0.27272727272727
93273, 0.08695652173913, -0.05, 0.29545454545455
93274, 0.10869565217391, -0.05, 0.31818181818182
93275, 0.08695652173913, -0.025, 0.31818181818182
93276, 0.08695652173913, -0.05, 0.34090909090909
93277, 0.10869565217391, -0.05, 0.36363636363636
93278, 0.08695652173913, -0.025, 0.36363636363636
93279, 0.08695652173913, -0.05, 0.38636363636364
93280, 0.10869565217391, -0.05, 0.40909090909091
93281, 0.08695652173913, -0.025, 0.40909090909091
93282, 0.08695652173913, -0.05, 0.43181818181818
93283, 0.10869565217391, -0.05, 0.45454545454545
93284, 0.08695652173913, -0.025, 0.45454545454545
93285, 0.08695652173913, -0.05, 0.47727272727273
93286, 0.043478260869565, -0.05, 0.022727272727273
93287, 0.065217391304348, -0.05, 0.045454545454545
93288, 0.043478260869565, -0.025, 0.045454545454545
93289, 0.043478260869565, -0.05, 0.068181818181818
93290, 0.065217391304348, -0.05, 0.090909090909091
93291, 0.043478260869565, -0.025, 0.090909090909091
93292, 0.043478260869565, -0.05, 0.11363636363636
93293, 0.065217391304348, -0.05, 0.13636363636364
93294, 0.043478260869565, -0.025, 0.13636363636364
93295, 0.043478260869565, -0.05, 0.15909090909091
93296, 0.065217391304348, -0.05, 0.18181818181818
93297, 0.043478260869565, -0.025, 0.18181818181818
93298, 0.043478260869565, -0.05, 0.20454545454545
93299, 0.065217391304348, -0.05, 0.22727272727273
93300, 0.043478260869565, -0.025, 0.22727272727273
93301, 0.043478260869565, -0.05, 0.25
93302, 0.065217391304348, -0.05, 0.27272727272727
93303, 0.043478260869565, -0.025, 0.27272727272727
93304, 0.043478260869565, -0.05, 0.29545454545455
93305, 0.065217391304348, -0.05, 0.31818181818182
93306, 0.043478260869565, -0.025, 0.31818181818182
93307, 0.043478260869565, -0.05, 0.34090909090909
93308, 0.065217391304348, -0.05, 0.36363636363636
93309, 0.043478260869565, -0.025, 0.36363636363636
93310, 0.043478260869565, -0.05, 0.38636363636364
93311, 0.065217391304348, -0.05, 0.40909090909091
93312, 0.043478260869565, -0.025, 0.40909090909091
93313, 0.043478260869565, -0.05, 0.43181818181818
93314, 0.065217391304348, -0.05, 0.45454545454545
93315, 0.043478260869565, -0.025, 0.45454545454545
93316, 0.043478260869565, -0.05, 0.47727272727273
93317, 0.021739130434783, -0.05, 0.045454545454545
93318, 0.021739130434783, -0.05, 0.090909090909091
93319, 0.021739130434783, -0.05, 0.13636363636364
93320, 0.021739130434783, -0.05, 0.18181818181818
93321, 0.021739130434783, -0.05, 0.22727272727273
93322, 0.021739130434783, -0.05, 0.27272727272727
93323, 0.021739130434783, -0.05, 0.31818181818182
93324, 0.021739130434783, -0.05, 0.36363636363636
93325, 0.021739130434783, -0.05, 0.40909090909091
93326, 0.021739130434783, -0.05, 0.45454545454545
93327, 0.95652173913043, -0.1, 0.022727272727273
93328, 0.97826086956522, -0.1, 0.045454545454545
93329, 0.95652173913043, -0.075, 0.045454545454545
93330, 0.95652173913043, -0.1, 0.068181818181818
93331, 0.97826086956522, -0.1, 0.090909090909091
93332, 0.95652173913043, -0.075, 0.090909090909091
93333, 0.95652173913043, -0.1, 0.11363636363636
93334, 0.97826086956522, -0.1, 0.13636363636364
93335, 0.95652173913043, -0.075, 0.13636363636364
93336, 0.95652173913044, -0.1, 0.15909090909091
93337, 0.97826086956522, -0.1, 0.18181818181818
93338, 0.95652173913043, -0.075, 0.18181818181818
93339, 0.95652173913044, -0.1, 0.20454545454545
93340, 0.97826086956522, -0.1, 0.22727272727273
93341, 0.95652173913043, -0.075, 0.22727272727273
93342, 0.95652173913044, -0.1, 0.25
93343, 0.97826086956522, -0.1, 0.27272727272727
93344, 0.95652173913043, -0.075, 0.27272727272727
93345, 0.95652173913044, -0.1, 0.29545454545455
93346, 0.97826086956522, -0.1, 0.31818181818182
93347, 0.95652173913044, -0.075, 0.31818181818182
93348, 0.95652173913043, -0.1, 0.34090909090909
93349, 0.97826086956522, -0.1, 0.36363636363636
93350, 0.95652173913043, -0.075, 0.36363636363636
93351, 0.95652173913043, -0.1, 0.38636363636364
93352, 0.97826086956522, -0.1, 0.40909090909091
93353, 0.95652173913043, -0.075, 0.40909090909091
93354, 0.95652173913043, -0.1, 0.43181818181818
93355, 0.97826086956522, -0.1, 0.45454545454545
93356, 0.95652173913043, -0.075, 0.45454545454545
93357, 0.95652173913043, -0.1, 0.47727272727273
93358, 0.91304347826087, -0.1, 0.022727272727273
93359, 0.93478260869565, -0.1, 0.045454545454545
93360, 0.91304347826087, -0.075, 0.045454545454545
93361, 0.91304347826087, -0.1, 0.068181818181818
93362, 0.93478260869565, -0.1, 0.090909090909091
