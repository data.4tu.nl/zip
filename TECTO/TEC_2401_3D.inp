16926, 1.2869565217391, 1.3239130434783, 0.5
16927, 1.3086956521739, 1.2978260869565, 0.5
16928, 1.3304347826087, 1.3239130434783, 0.5
16929, 1.3521739130435, 1.2978260869565, 0.5
16930, 1.3739130434783, 1.3239130434783, 0.5
16931, 1.395652173913, 1.2978260869565, 0.5
16932, 1.4173913043478, 1.3239130434783, 0.5
16933, 1.4391304347826, 1.2978260869565, 0.5
16934, 1.4608695652174, 1.3239130434783, 0.5
16935, 1.4826086956522, 1.2978260869565, 0.5
16936, 1.504347826087, 1.3239130434783, 0.5
16937, 1.5260869565217, 1.2978260869565, 0.5
16938, 1.5478260869565, 1.3239130434783, 0.5
16939, 1.5695652173913, 1.2978260869565, 0.5
16940, 1.5913043478261, 1.3239130434783, 0.5
16941, 1.6130434782609, 1.2978260869565, 0.5
16942, 1.6347826086957, 1.3239130434783, 0.5
16943, 1.6565217391304, 1.2978260869565, 0.5
16944, 1.6782608695652, 1.3239130434783, 0.5
16945, 1.7, 1.2978260869565, 0.5
16946, 1.7217391304348, 1.3239130434783, 0.5
16947, 1.7434782608696, 1.2978260869565, 0.5
16948, 1.7652173913043, 1.3239130434783, 0.5
16949, 1.7869565217391, 1.2978260869565, 0.5
16950, 1.8086956521739, 1.3239130434783, 0.5
16951, 1.8304347826087, 1.2978260869565, 0.5
16952, 1.8521739130435, 1.3239130434783, 0.5
16953, 1.8739130434783, 1.2978260869565, 0.5
16954, 1.895652173913, 1.3239130434783, 0.5
16955, 1.9173913043478, 1.2978260869565, 0.5
16956, 1.9391304347826, 1.3239130434783, 0.5
16957, 1.9608695652174, 1.2978260869565, 0.5
16958, 1.9826086956522, 1.3239130434783, 0.5
16959, 2.004347826087, 1.2978260869565, 0.5
16960, 2.0260869565217, 1.3239130434783, 0.5
16961, 2.0478260869565, 1.2978260869565, 0.5
16962, 2.0695652173913, 1.3239130434783, 0.5
16963, 2.0913043478261, 1.2978260869565, 0.5
16964, 2.1130434782609, 1.3239130434783, 0.5
16965, 2.1347826086957, 1.2978260869565, 0.5
16966, 2.1565217391304, 1.3239130434783, 0.5
16967, 2.1782608695652, 1.2978260869565, 0.5
16968, 1.2217391304348, 1.245652173913, 0.5
16969, 1.2434782608696, 1.2717391304348, 0.5
16970, 1.2652173913043, 1.245652173913, 0.5
16971, 1.2869565217391, 1.2717391304348, 0.5
16972, 1.3086956521739, 1.245652173913, 0.5
16973, 1.3304347826087, 1.2717391304348, 0.5
16974, 1.3521739130435, 1.245652173913, 0.5
16975, 1.3739130434783, 1.2717391304348, 0.5
16976, 1.395652173913, 1.245652173913, 0.5
16977, 1.4173913043478, 1.2717391304348, 0.5
16978, 1.4391304347826, 1.245652173913, 0.5
16979, 1.4608695652174, 1.2717391304348, 0.5
16980, 1.4826086956522, 1.245652173913, 0.5
16981, 1.504347826087, 1.2717391304348, 0.5
16982, 1.5260869565217, 1.245652173913, 0.5
16983, 1.5478260869565, 1.2717391304348, 0.5
16984, 1.5695652173913, 1.245652173913, 0.5
16985, 1.5913043478261, 1.2717391304348, 0.5
16986, 1.6130434782609, 1.245652173913, 0.5
16987, 1.6347826086957, 1.2717391304348, 0.5
16988, 1.6565217391304, 1.245652173913, 0.5
16989, 1.6782608695652, 1.2717391304348, 0.5
16990, 1.7, 1.245652173913, 0.5
16991, 1.7217391304348, 1.2717391304348, 0.5
16992, 1.7434782608696, 1.245652173913, 0.5
16993, 1.7652173913043, 1.2717391304348, 0.5
16994, 1.7869565217391, 1.245652173913, 0.5
16995, 1.8086956521739, 1.2717391304348, 0.5
16996, 1.8304347826087, 1.245652173913, 0.5
16997, 1.8521739130435, 1.2717391304348, 0.5
16998, 1.8739130434783, 1.245652173913, 0.5
16999, 1.895652173913, 1.2717391304348, 0.5
17000, 1.9173913043478, 1.245652173913, 0.5
17001, 1.9391304347826, 1.2717391304348, 0.5
17002, 1.9608695652174, 1.245652173913, 0.5
17003, 1.9826086956522, 1.2717391304348, 0.5
17004, 2.004347826087, 1.245652173913, 0.5
17005, 2.0260869565217, 1.2717391304348, 0.5
17006, 2.0478260869565, 1.245652173913, 0.5
17007, 2.0695652173913, 1.2717391304348, 0.5
17008, 2.0913043478261, 1.245652173913, 0.5
17009, 2.1130434782609, 1.2717391304348, 0.5
17010, 2.1347826086957, 1.245652173913, 0.5
17011, 2.1565217391304, 1.2717391304348, 0.5
17012, 2.1782608695652, 1.245652173913, 0.5
17013, 1.2217391304348, 1.1934782608696, 0.5
17014, 1.2434782608696, 1.2195652173913, 0.5
17015, 1.2652173913043, 1.1934782608696, 0.5
17016, 1.2869565217391, 1.2195652173913, 0.5
17017, 1.3086956521739, 1.1934782608696, 0.5
17018, 1.3304347826087, 1.2195652173913, 0.5
17019, 1.3521739130435, 1.1934782608696, 0.5
17020, 1.3739130434783, 1.2195652173913, 0.5
17021, 1.395652173913, 1.1934782608696, 0.5
17022, 1.4173913043478, 1.2195652173913, 0.5
17023, 1.4391304347826, 1.1934782608696, 0.5
17024, 1.4608695652174, 1.2195652173913, 0.5
17025, 1.4826086956522, 1.1934782608696, 0.5
17026, 1.504347826087, 1.2195652173913, 0.5
17027, 1.5260869565217, 1.1934782608696, 0.5
17028, 1.5478260869565, 1.2195652173913, 0.5
17029, 1.5695652173913, 1.1934782608696, 0.5
17030, 1.5913043478261, 1.2195652173913, 0.5
17031, 1.6130434782609, 1.1934782608696, 0.5
17032, 1.6347826086957, 1.2195652173913, 0.5
17033, 1.6565217391304, 1.1934782608696, 0.5
17034, 1.6782608695652, 1.2195652173913, 0.5
17035, 1.7, 1.1934782608696, 0.5
17036, 1.7217391304348, 1.2195652173913, 0.5
17037, 1.7434782608696, 1.1934782608696, 0.5
17038, 1.7652173913043, 1.2195652173913, 0.5
17039, 1.7869565217391, 1.1934782608696, 0.5
17040, 1.8086956521739, 1.2195652173913, 0.5
17041, 1.8304347826087, 1.1934782608696, 0.5
17042, 1.8521739130435, 1.2195652173913, 0.5
17043, 1.8739130434783, 1.1934782608696, 0.5
17044, 1.895652173913, 1.2195652173913, 0.5
17045, 1.9173913043478, 1.1934782608696, 0.5
17046, 1.9391304347826, 1.2195652173913, 0.5
17047, 1.9608695652174, 1.1934782608696, 0.5
17048, 1.9826086956522, 1.2195652173913, 0.5
17049, 2.004347826087, 1.1934782608696, 0.5
17050, 2.0260869565217, 1.2195652173913, 0.5
17051, 2.0478260869565, 1.1934782608696, 0.5
17052, 2.0695652173913, 1.2195652173913, 0.5
17053, 2.0913043478261, 1.1934782608696, 0.5
17054, 2.1130434782609, 1.2195652173913, 0.5
17055, 2.1347826086957, 1.1934782608696, 0.5
17056, 2.1565217391304, 1.2195652173913, 0.5
17057, 2.1782608695652, 1.1934782608696, 0.5
17058, 1.2217391304348, 1.1413043478261, 0.5
17059, 1.2434782608696, 1.1673913043478, 0.5
17060, 1.2652173913043, 1.1413043478261, 0.5
17061, 1.2869565217391, 1.1673913043478, 0.5
17062, 1.3086956521739, 1.1413043478261, 0.5
17063, 1.3304347826087, 1.1673913043478, 0.5
17064, 1.3521739130435, 1.1413043478261, 0.5
17065, 1.3739130434783, 1.1673913043478, 0.5
17066, 1.395652173913, 1.1413043478261, 0.5
17067, 1.4173913043478, 1.1673913043478, 0.5
17068, 1.4391304347826, 1.1413043478261, 0.5
17069, 1.4608695652174, 1.1673913043478, 0.5
17070, 1.4826086956522, 1.1413043478261, 0.5
17071, 1.504347826087, 1.1673913043478, 0.5
17072, 1.5260869565217, 1.1413043478261, 0.5
17073, 1.5478260869565, 1.1673913043478, 0.5
17074, 1.5695652173913, 1.1413043478261, 0.5
17075, 1.5913043478261, 1.1673913043478, 0.5
17076, 1.6130434782609, 1.1413043478261, 0.5
17077, 1.6347826086957, 1.1673913043478, 0.5
17078, 1.6565217391304, 1.1413043478261, 0.5
17079, 1.6782608695652, 1.1673913043478, 0.5
17080, 1.7, 1.1413043478261, 0.5
17081, 1.7217391304348, 1.1673913043478, 0.5
17082, 1.7434782608696, 1.1413043478261, 0.5
17083, 1.7652173913043, 1.1673913043478, 0.5
17084, 1.7869565217391, 1.1413043478261, 0.5
17085, 1.8086956521739, 1.1673913043478, 0.5
17086, 1.8304347826087, 1.1413043478261, 0.5
17087, 1.8521739130435, 1.1673913043478, 0.5
17088, 1.8739130434783, 1.1413043478261, 0.5
17089, 1.895652173913, 1.1673913043478, 0.5
17090, 1.9173913043478, 1.1413043478261, 0.5
17091, 1.9391304347826, 1.1673913043478, 0.5
17092, 1.9608695652174, 1.1413043478261, 0.5
17093, 1.9826086956522, 1.1673913043478, 0.5
17094, 2.004347826087, 1.1413043478261, 0.5
17095, 2.0260869565217, 1.1673913043478, 0.5
17096, 2.0478260869565, 1.1413043478261, 0.5
17097, 2.0695652173913, 1.1673913043478, 0.5
17098, 2.0913043478261, 1.1413043478261, 0.5
17099, 2.1130434782609, 1.1673913043478, 0.5
17100, 2.1347826086957, 1.1413043478261, 0.5
17101, 2.1565217391304, 1.1673913043478, 0.5
17102, 2.1782608695652, 1.1413043478261, 0.5
17103, 1.2217391304348, 1.0891304347826, 0.5
17104, 1.2434782608696, 1.1152173913043, 0.5
17105, 1.2652173913043, 1.0891304347826, 0.5
17106, 1.2869565217391, 1.1152173913043, 0.5
17107, 1.3086956521739, 1.0891304347826, 0.5
17108, 1.3304347826087, 1.1152173913043, 0.5
17109, 1.3521739130435, 1.0891304347826, 0.5
17110, 1.3739130434783, 1.1152173913043, 0.5
17111, 1.395652173913, 1.0891304347826, 0.5
17112, 1.4173913043478, 1.1152173913043, 0.5
17113, 1.4391304347826, 1.0891304347826, 0.5
17114, 1.4608695652174, 1.1152173913043, 0.5
17115, 1.4826086956522, 1.0891304347826, 0.5
17116, 1.504347826087, 1.1152173913043, 0.5
17117, 1.5260869565217, 1.0891304347826, 0.5
17118, 1.5478260869565, 1.1152173913043, 0.5
17119, 1.5695652173913, 1.0891304347826, 0.5
17120, 1.5913043478261, 1.1152173913043, 0.5
17121, 1.6130434782609, 1.0891304347826, 0.5
17122, 1.6347826086957, 1.1152173913043, 0.5
17123, 1.6565217391304, 1.0891304347826, 0.5
17124, 1.6782608695652, 1.1152173913043, 0.5
17125, 1.7, 1.0891304347826, 0.5
17126, 1.7217391304348, 1.1152173913043, 0.5
17127, 1.7434782608696, 1.0891304347826, 0.5
17128, 1.7652173913043, 1.1152173913043, 0.5
17129, 1.7869565217391, 1.0891304347826, 0.5
17130, 1.8086956521739, 1.1152173913043, 0.5
17131, 1.8304347826087, 1.0891304347826, 0.5
17132, 1.8521739130435, 1.1152173913043, 0.5
17133, 1.8739130434783, 1.0891304347826, 0.5
17134, 1.895652173913, 1.1152173913043, 0.5
17135, 1.9173913043478, 1.0891304347826, 0.5
17136, 1.9391304347826, 1.1152173913043, 0.5
17137, 1.9608695652174, 1.0891304347826, 0.5
17138, 1.9826086956522, 1.1152173913043, 0.5
17139, 2.004347826087, 1.0891304347826, 0.5
17140, 2.0260869565217, 1.1152173913043, 0.5
17141, 2.0478260869565, 1.0891304347826, 0.5
17142, 2.0695652173913, 1.1152173913043, 0.5
17143, 2.0913043478261, 1.0891304347826, 0.5
17144, 2.1130434782609, 1.1152173913043, 0.5
17145, 2.1347826086957, 1.0891304347826, 0.5
17146, 2.1565217391304, 1.1152173913043, 0.5
17147, 2.1782608695652, 1.0891304347826, 0.5
17148, 1.2217391304348, 1.0369565217391, 0.5
17149, 1.2434782608696, 1.0630434782609, 0.5
17150, 1.2652173913043, 1.0369565217391, 0.5
17151, 1.2869565217391, 1.0630434782609, 0.5
17152, 1.3086956521739, 1.0369565217391, 0.5
17153, 1.3304347826087, 1.0630434782609, 0.5
17154, 1.3521739130435, 1.0369565217391, 0.5
17155, 1.3739130434783, 1.0630434782609, 0.5
17156, 1.395652173913, 1.0369565217391, 0.5
17157, 1.4173913043478, 1.0630434782609, 0.5
17158, 1.4391304347826, 1.0369565217391, 0.5
17159, 1.4608695652174, 1.0630434782609, 0.5
17160, 1.4826086956522, 1.0369565217391, 0.5
17161, 1.504347826087, 1.0630434782609, 0.5
17162, 1.5260869565217, 1.0369565217391, 0.5
17163, 1.5478260869565, 1.0630434782609, 0.5
17164, 1.5695652173913, 1.0369565217391, 0.5
17165, 1.5913043478261, 1.0630434782609, 0.5
17166, 1.6130434782609, 1.0369565217391, 0.5
17167, 1.6347826086957, 1.0630434782609, 0.5
17168, 1.6565217391304, 1.0369565217391, 0.5
17169, 1.6782608695652, 1.0630434782609, 0.5
17170, 1.7, 1.0369565217391, 0.5
17171, 1.7217391304348, 1.0630434782609, 0.5
17172, 1.7434782608696, 1.0369565217391, 0.5
17173, 1.7652173913043, 1.0630434782609, 0.5
17174, 1.7869565217391, 1.0369565217391, 0.5
17175, 1.8086956521739, 1.0630434782609, 0.5
17176, 1.8304347826087, 1.0369565217391, 0.5
17177, 1.8521739130435, 1.0630434782609, 0.5
17178, 1.8739130434783, 1.0369565217391, 0.5
17179, 1.895652173913, 1.0630434782609, 0.5
17180, 1.9173913043478, 1.0369565217391, 0.5
17181, 1.9391304347826, 1.0630434782609, 0.5
17182, 1.9608695652174, 1.0369565217391, 0.5
17183, 1.9826086956522, 1.0630434782609, 0.5
17184, 2.004347826087, 1.0369565217391, 0.5
17185, 2.0260869565217, 1.0630434782609, 0.5
17186, 2.0478260869565, 1.0369565217391, 0.5
17187, 2.0695652173913, 1.0630434782609, 0.5
17188, 2.0913043478261, 1.0369565217391, 0.5
17189, 2.1130434782609, 1.0630434782609, 0.5
17190, 2.1347826086957, 1.0369565217391, 0.5
17191, 2.1565217391304, 1.0630434782609, 0.5
17192, 2.1782608695652, 1.0369565217391, 0.5
17193, 1.2217391304348, 0.98478260869565, 0.5
17194, 1.2434782608696, 1.0108695652174, 0.5
17195, 1.2652173913043, 0.98478260869565, 0.5
17196, 1.2869565217391, 1.0108695652174, 0.5
17197, 1.3086956521739, 0.98478260869565, 0.5
17198, 1.3304347826087, 1.0108695652174, 0.5
17199, 1.3521739130435, 0.98478260869565, 0.5
17200, 1.3739130434783, 1.0108695652174, 0.5
17201, 1.395652173913, 0.98478260869565, 0.5
17202, 1.4173913043478, 1.0108695652174, 0.5
17203, 1.4391304347826, 0.98478260869565, 0.5
17204, 1.4608695652174, 1.0108695652174, 0.5
17205, 1.4826086956522, 0.98478260869565, 0.5
17206, 1.504347826087, 1.0108695652174, 0.5
17207, 1.5260869565217, 0.98478260869565, 0.5
17208, 1.5478260869565, 1.0108695652174, 0.5
17209, 1.5695652173913, 0.98478260869565, 0.5
17210, 1.5913043478261, 1.0108695652174, 0.5
17211, 1.6130434782609, 0.98478260869565, 0.5
17212, 1.6347826086957, 1.0108695652174, 0.5
17213, 1.6565217391304, 0.98478260869565, 0.5
17214, 1.6782608695652, 1.0108695652174, 0.5
17215, 1.7, 0.98478260869565, 0.5
17216, 1.7217391304348, 1.0108695652174, 0.5
17217, 1.7434782608696, 0.98478260869565, 0.5
17218, 1.7652173913043, 1.0108695652174, 0.5
17219, 1.7869565217391, 0.98478260869565, 0.5
17220, 1.8086956521739, 1.0108695652174, 0.5
17221, 1.8304347826087, 0.98478260869565, 0.5
17222, 1.8521739130435, 1.0108695652174, 0.5
17223, 1.8739130434783, 0.98478260869565, 0.5
17224, 1.895652173913, 1.0108695652174, 0.5
17225, 1.9173913043478, 0.98478260869565, 0.5
17226, 1.9391304347826, 1.0108695652174, 0.5
17227, 1.9608695652174, 0.98478260869565, 0.5
17228, 1.9826086956522, 1.0108695652174, 0.5
17229, 2.004347826087, 0.98478260869565, 0.5
17230, 2.0260869565217, 1.0108695652174, 0.5
17231, 2.0478260869565, 0.98478260869565, 0.5
17232, 2.0695652173913, 1.0108695652174, 0.5
17233, 2.0913043478261, 0.98478260869565, 0.5
17234, 2.1130434782609, 1.0108695652174, 0.5
17235, 2.1347826086957, 0.98478260869565, 0.5
17236, 2.1565217391304, 1.0108695652174, 0.5
17237, 2.1782608695652, 0.98478260869565, 0.5
17238, 1.2217391304348, 0.93260869565217, 0.5
17239, 1.2434782608696, 0.95869565217391, 0.5
17240, 1.2652173913043, 0.93260869565217, 0.5
17241, 1.2869565217391, 0.95869565217391, 0.5
17242, 1.3086956521739, 0.93260869565217, 0.5
17243, 1.3304347826087, 0.95869565217391, 0.5
17244, 1.3521739130435, 0.93260869565217, 0.5
17245, 1.3739130434783, 0.95869565217391, 0.5
17246, 1.395652173913, 0.93260869565217, 0.5
17247, 1.4173913043478, 0.95869565217391, 0.5
17248, 1.4391304347826, 0.93260869565217, 0.5
17249, 1.4608695652174, 0.95869565217391, 0.5
17250, 1.4826086956522, 0.93260869565217, 0.5
17251, 1.504347826087, 0.95869565217391, 0.5
17252, 1.5260869565217, 0.93260869565217, 0.5
17253, 1.5478260869565, 0.95869565217391, 0.5
17254, 1.5695652173913, 0.93260869565217, 0.5
17255, 1.5913043478261, 0.95869565217391, 0.5
17256, 1.6130434782609, 0.93260869565217, 0.5
17257, 1.6347826086957, 0.95869565217391, 0.5
17258, 1.6565217391304, 0.93260869565217, 0.5
17259, 1.6782608695652, 0.95869565217391, 0.5
17260, 1.7, 0.93260869565217, 0.5
17261, 1.7217391304348, 0.95869565217391, 0.5
17262, 1.7434782608696, 0.93260869565217, 0.5
17263, 1.7652173913043, 0.95869565217391, 0.5
17264, 1.7869565217391, 0.93260869565217, 0.5
17265, 1.8086956521739, 0.95869565217391, 0.5
17266, 1.8304347826087, 0.93260869565217, 0.5
17267, 1.8521739130435, 0.95869565217391, 0.5
17268, 1.8739130434783, 0.93260869565217, 0.5
17269, 1.895652173913, 0.95869565217391, 0.5
17270, 1.9173913043478, 0.93260869565217, 0.5
17271, 1.9391304347826, 0.95869565217391, 0.5
17272, 1.9608695652174, 0.93260869565217, 0.5
17273, 1.9826086956522, 0.95869565217391, 0.5
17274, 2.004347826087, 0.93260869565217, 0.5
17275, 2.0260869565217, 0.95869565217391, 0.5
17276, 2.0478260869565, 0.93260869565217, 0.5
17277, 2.0695652173913, 0.95869565217391, 0.5
17278, 2.0913043478261, 0.93260869565217, 0.5
17279, 2.1130434782609, 0.95869565217391, 0.5
17280, 2.1347826086957, 0.93260869565217, 0.5
17281, 2.1565217391304, 0.95869565217391, 0.5
17282, 2.1782608695652, 0.93260869565217, 0.5
17283, 1.2217391304348, 0.8804347826087, 0.5
17284, 1.2434782608696, 0.90652173913044, 0.5
17285, 1.2652173913043, 0.8804347826087, 0.5
17286, 1.2869565217391, 0.90652173913044, 0.5
17287, 1.3086956521739, 0.8804347826087, 0.5
17288, 1.3304347826087, 0.90652173913044, 0.5
17289, 1.3521739130435, 0.8804347826087, 0.5
17290, 1.3739130434783, 0.90652173913044, 0.5
17291, 1.395652173913, 0.8804347826087, 0.5
17292, 1.4173913043478, 0.90652173913044, 0.5
17293, 1.4391304347826, 0.8804347826087, 0.5
17294, 1.4608695652174, 0.90652173913044, 0.5
17295, 1.4826086956522, 0.8804347826087, 0.5
17296, 1.504347826087, 0.90652173913044, 0.5
17297, 1.5260869565217, 0.8804347826087, 0.5
17298, 1.5478260869565, 0.90652173913044, 0.5
17299, 1.5695652173913, 0.8804347826087, 0.5
17300, 1.5913043478261, 0.90652173913044, 0.5
17301, 1.6130434782609, 0.8804347826087, 0.5
17302, 1.6347826086957, 0.90652173913044, 0.5
17303, 1.6565217391304, 0.8804347826087, 0.5
17304, 1.6782608695652, 0.90652173913044, 0.5
17305, 1.7, 0.8804347826087, 0.5
17306, 1.7217391304348, 0.90652173913044, 0.5
17307, 1.7434782608696, 0.8804347826087, 0.5
17308, 1.7652173913043, 0.90652173913044, 0.5
17309, 1.7869565217391, 0.8804347826087, 0.5
17310, 1.8086956521739, 0.90652173913044, 0.5
17311, 1.8304347826087, 0.8804347826087, 0.5
17312, 1.8521739130435, 0.90652173913044, 0.5
17313, 1.8739130434783, 0.8804347826087, 0.5
17314, 1.895652173913, 0.90652173913044, 0.5
17315, 1.9173913043478, 0.8804347826087, 0.5
17316, 1.9391304347826, 0.90652173913044, 0.5
17317, 1.9608695652174, 0.8804347826087, 0.5
17318, 1.9826086956522, 0.90652173913044, 0.5
17319, 2.004347826087, 0.8804347826087, 0.5
17320, 2.0260869565217, 0.90652173913044, 0.5
17321, 2.0478260869565, 0.8804347826087, 0.5
17322, 2.0695652173913, 0.90652173913044, 0.5
17323, 2.0913043478261, 0.8804347826087, 0.5
17324, 2.1130434782609, 0.90652173913044, 0.5
17325, 2.1347826086957, 0.8804347826087, 0.5
17326, 2.1565217391304, 0.90652173913044, 0.5
17327, 2.1782608695652, 0.8804347826087, 0.5
17328, 1.2217391304348, 0.82826086956522, 0.5
17329, 1.2434782608696, 0.85434782608696, 0.5
17330, 1.2652173913043, 0.82826086956522, 0.5
17331, 1.2869565217391, 0.85434782608696, 0.5
17332, 1.3086956521739, 0.82826086956522, 0.5
17333, 1.3304347826087, 0.85434782608696, 0.5
17334, 1.3521739130435, 0.82826086956522, 0.5
17335, 1.3739130434783, 0.85434782608696, 0.5
17336, 1.395652173913, 0.82826086956522, 0.5
17337, 1.4173913043478, 0.85434782608696, 0.5
17338, 1.4391304347826, 0.82826086956522, 0.5
17339, 1.4608695652174, 0.85434782608696, 0.5
17340, 1.4826086956522, 0.82826086956522, 0.5
17341, 1.504347826087, 0.85434782608696, 0.5
17342, 1.5260869565217, 0.82826086956522, 0.5
17343, 1.5478260869565, 0.85434782608696, 0.5
17344, 1.5695652173913, 0.82826086956522, 0.5
17345, 1.5913043478261, 0.85434782608696, 0.5
17346, 1.6130434782609, 0.82826086956522, 0.5
17347, 1.6347826086957, 0.85434782608696, 0.5
17348, 1.6565217391304, 0.82826086956522, 0.5
17349, 1.6782608695652, 0.85434782608696, 0.5
17350, 1.7, 0.82826086956522, 0.5
17351, 1.7217391304348, 0.85434782608696, 0.5
17352, 1.7434782608696, 0.82826086956522, 0.5
17353, 1.7652173913043, 0.85434782608696, 0.5
17354, 1.7869565217391, 0.82826086956522, 0.5
17355, 1.8086956521739, 0.85434782608696, 0.5
17356, 1.8304347826087, 0.82826086956522, 0.5
17357, 1.8521739130435, 0.85434782608696, 0.5
17358, 1.8739130434783, 0.82826086956522, 0.5
17359, 1.895652173913, 0.85434782608696, 0.5
17360, 1.9173913043478, 0.82826086956522, 0.5
17361, 1.9391304347826, 0.85434782608696, 0.5
17362, 1.9608695652174, 0.82826086956522, 0.5
17363, 1.9826086956522, 0.85434782608696, 0.5
17364, 2.004347826087, 0.82826086956522, 0.5
17365, 2.0260869565217, 0.85434782608696, 0.5
17366, 2.0478260869565, 0.82826086956522, 0.5
17367, 2.0695652173913, 0.85434782608696, 0.5
17368, 2.0913043478261, 0.82826086956522, 0.5
17369, 2.1130434782609, 0.85434782608696, 0.5
17370, 2.1347826086957, 0.82826086956522, 0.5
17371, 2.1565217391304, 0.85434782608696, 0.5
17372, 2.1782608695652, 0.82826086956522, 0.5
17373, 1.2217391304348, 0.77608695652174, 0.5
17374, 1.2434782608696, 0.80217391304348, 0.5
17375, 1.2652173913043, 0.77608695652174, 0.5
17376, 1.2869565217391, 0.80217391304348, 0.5
17377, 1.3086956521739, 0.77608695652174, 0.5
17378, 1.3304347826087, 0.80217391304348, 0.5
17379, 1.3521739130435, 0.77608695652174, 0.5
17380, 1.3739130434783, 0.80217391304348, 0.5
17381, 1.395652173913, 0.77608695652174, 0.5
17382, 1.4173913043478, 0.80217391304348, 0.5
17383, 1.4391304347826, 0.77608695652174, 0.5
17384, 1.4608695652174, 0.80217391304348, 0.5
17385, 1.4826086956522, 0.77608695652174, 0.5
17386, 1.504347826087, 0.80217391304348, 0.5
17387, 1.5260869565217, 0.77608695652174, 0.5
17388, 1.5478260869565, 0.80217391304348, 0.5
17389, 1.5695652173913, 0.77608695652174, 0.5
17390, 1.5913043478261, 0.80217391304348, 0.5
17391, 1.6130434782609, 0.77608695652174, 0.5
17392, 1.6347826086957, 0.80217391304348, 0.5
17393, 1.6565217391304, 0.77608695652174, 0.5
17394, 1.6782608695652, 0.80217391304348, 0.5
17395, 1.7, 0.77608695652174, 0.5
17396, 1.7217391304348, 0.80217391304348, 0.5
17397, 1.7434782608696, 0.77608695652174, 0.5
17398, 1.7652173913043, 0.80217391304348, 0.5
17399, 1.7869565217391, 0.77608695652174, 0.5
17400, 1.8086956521739, 0.80217391304348, 0.5
17401, 1.8304347826087, 0.77608695652174, 0.5
17402, 1.8521739130435, 0.80217391304348, 0.5
17403, 1.8739130434783, 0.77608695652174, 0.5
17404, 1.895652173913, 0.80217391304348, 0.5
17405, 1.9173913043478, 0.77608695652174, 0.5
17406, 1.9391304347826, 0.80217391304348, 0.5
17407, 1.9608695652174, 0.77608695652174, 0.5
17408, 1.9826086956522, 0.80217391304348, 0.5
17409, 2.004347826087, 0.77608695652174, 0.5
17410, 2.0260869565217, 0.80217391304348, 0.5
17411, 2.0478260869565, 0.77608695652174, 0.5
17412, 2.0695652173913, 0.80217391304348, 0.5
17413, 2.0913043478261, 0.77608695652174, 0.5
17414, 2.1130434782609, 0.80217391304348, 0.5
17415, 2.1347826086957, 0.77608695652174, 0.5
17416, 2.1565217391304, 0.80217391304348, 0.5
17417, 2.1782608695652, 0.77608695652174, 0.5
17418, 1.2217391304348, 0.72391304347826, 0.5
17419, 1.2434782608696, 0.75, 0.5
17420, 1.2652173913043, 0.72391304347826, 0.5
17421, 1.2869565217391, 0.75, 0.5
17422, 1.3086956521739, 0.72391304347826, 0.5
17423, 1.3304347826087, 0.75, 0.5
17424, 1.3521739130435, 0.72391304347826, 0.5
17425, 1.3739130434783, 0.75, 0.5
17426, 1.395652173913, 0.72391304347826, 0.5
17427, 1.4173913043478, 0.75, 0.5
17428, 1.4391304347826, 0.72391304347826, 0.5
17429, 1.4608695652174, 0.75, 0.5
17430, 1.4826086956522, 0.72391304347826, 0.5
17431, 1.504347826087, 0.75, 0.5
17432, 1.5260869565217, 0.72391304347826, 0.5
17433, 1.5478260869565, 0.75, 0.5
17434, 1.5695652173913, 0.72391304347826, 0.5
17435, 1.5913043478261, 0.75, 0.5
17436, 1.6130434782609, 0.72391304347826, 0.5
17437, 1.6347826086957, 0.75, 0.5
17438, 1.6565217391304, 0.72391304347826, 0.5
17439, 1.6782608695652, 0.75, 0.5
17440, 1.7, 0.72391304347826, 0.5
17441, 1.7217391304348, 0.75, 0.5
17442, 1.7434782608696, 0.72391304347826, 0.5
17443, 1.7652173913043, 0.75, 0.5
17444, 1.7869565217391, 0.72391304347826, 0.5
17445, 1.8086956521739, 0.75, 0.5
17446, 1.8304347826087, 0.72391304347826, 0.5
17447, 1.8521739130435, 0.75, 0.5
17448, 1.8739130434783, 0.72391304347826, 0.5
17449, 1.895652173913, 0.75, 0.5
17450, 1.9173913043478, 0.72391304347826, 0.5
17451, 1.9391304347826, 0.75, 0.5
17452, 1.9608695652174, 0.72391304347826, 0.5
17453, 1.9826086956522, 0.75, 0.5
17454, 2.004347826087, 0.72391304347826, 0.5
17455, 2.0260869565217, 0.75, 0.5
17456, 2.0478260869565, 0.72391304347826, 0.5
17457, 2.0695652173913, 0.75, 0.5
17458, 2.0913043478261, 0.72391304347826, 0.5
17459, 2.1130434782609, 0.75, 0.5
17460, 2.1347826086957, 0.72391304347826, 0.5
17461, 2.1565217391304, 0.75, 0.5
17462, 2.1782608695652, 0.72391304347826, 0.5
17463, 1.2217391304348, 0.67173913043478, 0.5
17464, 1.2434782608696, 0.69782608695652, 0.5
17465, 1.2652173913043, 0.67173913043478, 0.5
17466, 1.2869565217391, 0.69782608695652, 0.5
17467, 1.3086956521739, 0.67173913043478, 0.5
17468, 1.3304347826087, 0.69782608695652, 0.5
17469, 1.3521739130435, 0.67173913043478, 0.5
17470, 1.3739130434783, 0.69782608695652, 0.5
17471, 1.395652173913, 0.67173913043478, 0.5
17472, 1.4173913043478, 0.69782608695652, 0.5
17473, 1.4391304347826, 0.67173913043478, 0.5
17474, 1.4608695652174, 0.69782608695652, 0.5
17475, 1.4826086956522, 0.67173913043478, 0.5
17476, 1.504347826087, 0.69782608695652, 0.5
17477, 1.5260869565217, 0.67173913043478, 0.5
17478, 1.5478260869565, 0.69782608695652, 0.5
17479, 1.5695652173913, 0.67173913043478, 0.5
17480, 1.5913043478261, 0.69782608695652, 0.5
17481, 1.6130434782609, 0.67173913043478, 0.5
17482, 1.6347826086957, 0.69782608695652, 0.5
17483, 1.6565217391304, 0.67173913043478, 0.5
17484, 1.6782608695652, 0.69782608695652, 0.5
17485, 1.7, 0.67173913043478, 0.5
17486, 1.7217391304348, 0.69782608695652, 0.5
17487, 1.7434782608696, 0.67173913043478, 0.5
17488, 1.7652173913043, 0.69782608695652, 0.5
17489, 1.7869565217391, 0.67173913043478, 0.5
17490, 1.8086956521739, 0.69782608695652, 0.5
17491, 1.8304347826087, 0.67173913043478, 0.5
17492, 1.8521739130435, 0.69782608695652, 0.5
17493, 1.8739130434783, 0.67173913043478, 0.5
17494, 1.895652173913, 0.69782608695652, 0.5
17495, 1.9173913043478, 0.67173913043478, 0.5
17496, 1.9391304347826, 0.69782608695652, 0.5
17497, 1.9608695652174, 0.67173913043478, 0.5
17498, 1.9826086956522, 0.69782608695652, 0.5
17499, 2.004347826087, 0.67173913043478, 0.5
17500, 2.0260869565217, 0.69782608695652, 0.5
17501, 2.0478260869565, 0.67173913043478, 0.5
17502, 2.0695652173913, 0.69782608695652, 0.5
17503, 2.0913043478261, 0.67173913043478, 0.5
17504, 2.1130434782609, 0.69782608695652, 0.5
17505, 2.1347826086957, 0.67173913043478, 0.5
17506, 2.1565217391304, 0.69782608695652, 0.5
17507, 2.1782608695652, 0.67173913043478, 0.5
17508, 1.2217391304348, 0.61956521739131, 0.5
17509, 1.2434782608696, 0.64565217391304, 0.5
17510, 1.2652173913043, 0.61956521739131, 0.5
17511, 1.2869565217391, 0.64565217391304, 0.5
17512, 1.3086956521739, 0.61956521739131, 0.5
17513, 1.3304347826087, 0.64565217391304, 0.5
17514, 1.3521739130435, 0.61956521739131, 0.5
17515, 1.3739130434783, 0.64565217391304, 0.5
17516, 1.395652173913, 0.61956521739131, 0.5
17517, 1.4173913043478, 0.64565217391304, 0.5
17518, 1.4391304347826, 0.61956521739131, 0.5
17519, 1.4608695652174, 0.64565217391304, 0.5
17520, 1.4826086956522, 0.61956521739131, 0.5
17521, 1.504347826087, 0.64565217391304, 0.5
17522, 1.5260869565217, 0.61956521739131, 0.5
17523, 1.5478260869565, 0.64565217391304, 0.5
17524, 1.5695652173913, 0.61956521739131, 0.5
17525, 1.5913043478261, 0.64565217391304, 0.5
17526, 1.6130434782609, 0.61956521739131, 0.5
17527, 1.6347826086957, 0.64565217391304, 0.5
17528, 1.6565217391304, 0.61956521739131, 0.5
17529, 1.6782608695652, 0.64565217391304, 0.5
17530, 1.7, 0.61956521739131, 0.5
17531, 1.7217391304348, 0.64565217391304, 0.5
17532, 1.7434782608696, 0.61956521739131, 0.5
17533, 1.7652173913043, 0.64565217391304, 0.5
17534, 1.7869565217391, 0.61956521739131, 0.5
17535, 1.8086956521739, 0.64565217391304, 0.5
17536, 1.8304347826087, 0.61956521739131, 0.5
17537, 1.8521739130435, 0.64565217391304, 0.5
17538, 1.8739130434783, 0.61956521739131, 0.5
17539, 1.895652173913, 0.64565217391304, 0.5
17540, 1.9173913043478, 0.61956521739131, 0.5
17541, 1.9391304347826, 0.64565217391304, 0.5
17542, 1.9608695652174, 0.61956521739131, 0.5
17543, 1.9826086956522, 0.64565217391304, 0.5
17544, 2.004347826087, 0.61956521739131, 0.5
17545, 2.0260869565217, 0.64565217391304, 0.5
17546, 2.0478260869565, 0.61956521739131, 0.5
17547, 2.0695652173913, 0.64565217391304, 0.5
17548, 2.0913043478261, 0.61956521739131, 0.5
17549, 2.1130434782609, 0.64565217391304, 0.5
17550, 2.1347826086957, 0.61956521739131, 0.5
17551, 2.1565217391304, 0.64565217391304, 0.5
17552, 2.1782608695652, 0.61956521739131, 0.5
17553, 1.2217391304348, 0.56739130434783, 0.5
17554, 1.2434782608696, 0.59347826086957, 0.5
17555, 1.2652173913043, 0.56739130434783, 0.5
17556, 1.2869565217391, 0.59347826086957, 0.5
17557, 1.3086956521739, 0.56739130434783, 0.5
17558, 1.3304347826087, 0.59347826086957, 0.5
17559, 1.3521739130435, 0.56739130434783, 0.5
17560, 1.3739130434783, 0.59347826086957, 0.5
17561, 1.395652173913, 0.56739130434783, 0.5
17562, 1.4173913043478, 0.59347826086957, 0.5
17563, 1.4391304347826, 0.56739130434783, 0.5
17564, 1.4608695652174, 0.59347826086957, 0.5
17565, 1.4826086956522, 0.56739130434783, 0.5
17566, 1.504347826087, 0.59347826086957, 0.5
17567, 1.5260869565217, 0.56739130434783, 0.5
17568, 1.5478260869565, 0.59347826086957, 0.5
17569, 1.5695652173913, 0.56739130434783, 0.5
17570, 1.5913043478261, 0.59347826086957, 0.5
17571, 1.6130434782609, 0.56739130434783, 0.5
17572, 1.6347826086957, 0.59347826086957, 0.5
17573, 1.6565217391304, 0.56739130434783, 0.5
17574, 1.6782608695652, 0.59347826086957, 0.5
17575, 1.7, 0.56739130434783, 0.5
17576, 1.7217391304348, 0.59347826086957, 0.5
17577, 1.7434782608696, 0.56739130434783, 0.5
17578, 1.7652173913043, 0.59347826086957, 0.5
17579, 1.7869565217391, 0.56739130434783, 0.5
17580, 1.8086956521739, 0.59347826086957, 0.5
17581, 1.8304347826087, 0.56739130434783, 0.5
17582, 1.8521739130435, 0.59347826086957, 0.5
17583, 1.8739130434783, 0.56739130434783, 0.5
17584, 1.895652173913, 0.59347826086957, 0.5
17585, 1.9173913043478, 0.56739130434783, 0.5
17586, 1.9391304347826, 0.59347826086957, 0.5
17587, 1.9608695652174, 0.56739130434783, 0.5
17588, 1.9826086956522, 0.59347826086957, 0.5
17589, 2.004347826087, 0.56739130434783, 0.5
17590, 2.0260869565217, 0.59347826086957, 0.5
17591, 2.0478260869565, 0.56739130434783, 0.5
17592, 2.0695652173913, 0.59347826086957, 0.5
17593, 2.0913043478261, 0.56739130434783, 0.5
17594, 2.1130434782609, 0.59347826086957, 0.5
17595, 2.1347826086957, 0.56739130434783, 0.5
17596, 2.1565217391304, 0.59347826086957, 0.5
17597, 2.1782608695652, 0.56739130434783, 0.5
17598, 1.2217391304348, 0.51521739130435, 0.5
17599, 1.2434782608696, 0.54130434782609, 0.5
17600, 1.2652173913043, 0.51521739130435, 0.5
17601, 1.2869565217391, 0.54130434782609, 0.5
17602, 1.3086956521739, 0.51521739130435, 0.5
17603, 1.3304347826087, 0.54130434782609, 0.5
17604, 1.3521739130435, 0.51521739130435, 0.5
17605, 1.3739130434783, 0.54130434782609, 0.5
17606, 1.395652173913, 0.51521739130435, 0.5
17607, 1.4173913043478, 0.54130434782609, 0.5
17608, 1.4391304347826, 0.51521739130435, 0.5
17609, 1.4608695652174, 0.54130434782609, 0.5
17610, 1.4826086956522, 0.51521739130435, 0.5
17611, 1.504347826087, 0.54130434782609, 0.5
17612, 1.5260869565217, 0.51521739130435, 0.5
17613, 1.5478260869565, 0.54130434782609, 0.5
17614, 1.5695652173913, 0.51521739130435, 0.5
17615, 1.5913043478261, 0.54130434782609, 0.5
17616, 1.6130434782609, 0.51521739130435, 0.5
17617, 1.6347826086957, 0.54130434782609, 0.5
17618, 1.6565217391304, 0.51521739130435, 0.5
17619, 1.6782608695652, 0.54130434782609, 0.5
17620, 1.7, 0.51521739130435, 0.5
17621, 1.7217391304348, 0.54130434782609, 0.5
17622, 1.7434782608696, 0.51521739130435, 0.5
17623, 1.7652173913043, 0.54130434782609, 0.5
17624, 1.7869565217391, 0.51521739130435, 0.5
17625, 1.8086956521739, 0.54130434782609, 0.5
17626, 1.8304347826087, 0.51521739130435, 0.5
17627, 1.8521739130435, 0.54130434782609, 0.5
17628, 1.8739130434783, 0.51521739130435, 0.5
17629, 1.895652173913, 0.54130434782609, 0.5
17630, 1.9173913043478, 0.51521739130435, 0.5
17631, 1.9391304347826, 0.54130434782609, 0.5
17632, 1.9608695652174, 0.51521739130435, 0.5
17633, 1.9826086956522, 0.54130434782609, 0.5
17634, 2.004347826087, 0.51521739130435, 0.5
17635, 2.0260869565217, 0.54130434782609, 0.5
17636, 2.0478260869565, 0.51521739130435, 0.5
17637, 2.0695652173913, 0.54130434782609, 0.5
17638, 2.0913043478261, 0.51521739130435, 0.5
17639, 2.1130434782609, 0.54130434782609, 0.5
17640, 2.1347826086957, 0.51521739130435, 0.5
17641, 2.1565217391304, 0.54130434782609, 0.5
17642, 2.1782608695652, 0.51521739130435, 0.5
17643, 1.2217391304348, 0.46304347826087, 0.5
17644, 1.2434782608696, 0.48913043478261, 0.5
17645, 1.2652173913043, 0.46304347826087, 0.5
17646, 1.2869565217391, 0.48913043478261, 0.5
17647, 1.3086956521739, 0.46304347826087, 0.5
17648, 1.3304347826087, 0.48913043478261, 0.5
17649, 1.3521739130435, 0.46304347826087, 0.5
17650, 1.3739130434783, 0.48913043478261, 0.5
17651, 1.395652173913, 0.46304347826087, 0.5
17652, 1.4173913043478, 0.48913043478261, 0.5
17653, 1.4391304347826, 0.46304347826087, 0.5
17654, 1.4608695652174, 0.48913043478261, 0.5
17655, 1.4826086956522, 0.46304347826087, 0.5
17656, 1.504347826087, 0.48913043478261, 0.5
17657, 1.5260869565217, 0.46304347826087, 0.5
17658, 1.5478260869565, 0.48913043478261, 0.5
17659, 1.5695652173913, 0.46304347826087, 0.5
17660, 1.5913043478261, 0.48913043478261, 0.5
17661, 1.6130434782609, 0.46304347826087, 0.5
17662, 1.6347826086957, 0.48913043478261, 0.5
17663, 1.6565217391304, 0.46304347826087, 0.5
17664, 1.6782608695652, 0.48913043478261, 0.5
17665, 1.7, 0.46304347826087, 0.5
17666, 1.7217391304348, 0.48913043478261, 0.5
17667, 1.7434782608696, 0.46304347826087, 0.5
17668, 1.7652173913043, 0.48913043478261, 0.5
17669, 1.7869565217391, 0.46304347826087, 0.5
17670, 1.8086956521739, 0.48913043478261, 0.5
17671, 1.8304347826087, 0.46304347826087, 0.5
17672, 1.8521739130435, 0.48913043478261, 0.5
17673, 1.8739130434783, 0.46304347826087, 0.5
17674, 1.895652173913, 0.48913043478261, 0.5
17675, 1.9173913043478, 0.46304347826087, 0.5
17676, 1.9391304347826, 0.48913043478261, 0.5
17677, 1.9608695652174, 0.46304347826087, 0.5
17678, 1.9826086956522, 0.48913043478261, 0.5
17679, 2.004347826087, 0.46304347826087, 0.5
17680, 2.0260869565217, 0.48913043478261, 0.5
17681, 2.0478260869565, 0.46304347826087, 0.5
17682, 2.0695652173913, 0.48913043478261, 0.5
17683, 2.0913043478261, 0.46304347826087, 0.5
17684, 2.1130434782609, 0.48913043478261, 0.5
17685, 2.1347826086957, 0.46304347826087, 0.5
17686, 2.1565217391304, 0.48913043478261, 0.5
17687, 2.1782608695652, 0.46304347826087, 0.5
17688, 1.2217391304348, 0.41086956521739, 0.5
17689, 1.2434782608696, 0.43695652173913, 0.5
17690, 1.2652173913043, 0.41086956521739, 0.5
17691, 1.2869565217391, 0.43695652173913, 0.5
17692, 1.3086956521739, 0.41086956521739, 0.5
17693, 1.3304347826087, 0.43695652173913, 0.5
17694, 1.3521739130435, 0.41086956521739, 0.5
17695, 1.3739130434783, 0.43695652173913, 0.5
17696, 1.395652173913, 0.41086956521739, 0.5
17697, 1.4173913043478, 0.43695652173913, 0.5
17698, 1.4391304347826, 0.41086956521739, 0.5
17699, 1.4608695652174, 0.43695652173913, 0.5
17700, 1.4826086956522, 0.41086956521739, 0.5
17701, 1.504347826087, 0.43695652173913, 0.5
17702, 1.5260869565217, 0.41086956521739, 0.5
17703, 1.5478260869565, 0.43695652173913, 0.5
17704, 1.5695652173913, 0.41086956521739, 0.5
17705, 1.5913043478261, 0.43695652173913, 0.5
17706, 1.6130434782609, 0.41086956521739, 0.5
17707, 1.6347826086957, 0.43695652173913, 0.5
17708, 1.6565217391304, 0.41086956521739, 0.5
17709, 1.6782608695652, 0.43695652173913, 0.5
17710, 1.7, 0.41086956521739, 0.5
17711, 1.7217391304348, 0.43695652173913, 0.5
17712, 1.7434782608696, 0.41086956521739, 0.5
17713, 1.7652173913043, 0.43695652173913, 0.5
17714, 1.7869565217391, 0.41086956521739, 0.5
17715, 1.8086956521739, 0.43695652173913, 0.5
17716, 1.8304347826087, 0.41086956521739, 0.5
17717, 1.8521739130435, 0.43695652173913, 0.5
17718, 1.8739130434783, 0.41086956521739, 0.5
17719, 1.895652173913, 0.43695652173913, 0.5
17720, 1.9173913043478, 0.41086956521739, 0.5
17721, 1.9391304347826, 0.43695652173913, 0.5
17722, 1.9608695652174, 0.41086956521739, 0.5
17723, 1.9826086956522, 0.43695652173913, 0.5
17724, 2.004347826087, 0.41086956521739, 0.5
17725, 2.0260869565217, 0.43695652173913, 0.5
17726, 2.0478260869565, 0.41086956521739, 0.5
17727, 2.0695652173913, 0.43695652173913, 0.5
17728, 2.0913043478261, 0.41086956521739, 0.5
17729, 2.1130434782609, 0.43695652173913, 0.5
17730, 2.1347826086957, 0.41086956521739, 0.5
17731, 2.1565217391304, 0.43695652173913, 0.5
17732, 2.1782608695652, 0.41086956521739, 0.5
17733, 1.2217391304348, 0.35869565217391, 0.5
17734, 1.2434782608696, 0.38478260869565, 0.5
17735, 1.2652173913043, 0.35869565217391, 0.5
17736, 1.2869565217391, 0.38478260869565, 0.5
17737, 1.3086956521739, 0.35869565217391, 0.5
17738, 1.3304347826087, 0.38478260869565, 0.5
17739, 1.3521739130435, 0.35869565217391, 0.5
17740, 1.3739130434783, 0.38478260869565, 0.5
17741, 1.395652173913, 0.35869565217391, 0.5
17742, 1.4173913043478, 0.38478260869565, 0.5
17743, 1.4391304347826, 0.35869565217391, 0.5
17744, 1.4608695652174, 0.38478260869565, 0.5
17745, 1.4826086956522, 0.35869565217391, 0.5
17746, 1.504347826087, 0.38478260869565, 0.5
17747, 1.5260869565217, 0.35869565217391, 0.5
17748, 1.5478260869565, 0.38478260869565, 0.5
17749, 1.5695652173913, 0.35869565217391, 0.5
17750, 1.5913043478261, 0.38478260869565, 0.5
17751, 1.6130434782609, 0.35869565217391, 0.5
17752, 1.6347826086957, 0.38478260869565, 0.5
17753, 1.6565217391304, 0.35869565217391, 0.5
17754, 1.6782608695652, 0.38478260869565, 0.5
17755, 1.7, 0.35869565217391, 0.5
17756, 1.7217391304348, 0.38478260869565, 0.5
17757, 1.7434782608696, 0.35869565217391, 0.5
17758, 1.7652173913043, 0.38478260869565, 0.5
17759, 1.7869565217391, 0.35869565217391, 0.5
17760, 1.8086956521739, 0.38478260869565, 0.5
17761, 1.8304347826087, 0.35869565217391, 0.5
17762, 1.8521739130435, 0.38478260869565, 0.5
17763, 1.8739130434783, 0.35869565217391, 0.5
17764, 1.895652173913, 0.38478260869565, 0.5
17765, 1.9173913043478, 0.35869565217391, 0.5
17766, 1.9391304347826, 0.38478260869565, 0.5
17767, 1.9608695652174, 0.35869565217391, 0.5
17768, 1.9826086956522, 0.38478260869565, 0.5
17769, 2.004347826087, 0.35869565217391, 0.5
17770, 2.0260869565217, 0.38478260869565, 0.5
17771, 2.0478260869565, 0.35869565217391, 0.5
17772, 2.0695652173913, 0.38478260869565, 0.5
17773, 2.0913043478261, 0.35869565217391, 0.5
17774, 2.1130434782609, 0.38478260869565, 0.5
17775, 2.1347826086957, 0.35869565217391, 0.5
17776, 2.1565217391304, 0.38478260869565, 0.5
17777, 2.1782608695652, 0.35869565217391, 0.5
17778, 1.2217391304348, 0.30652173913044, 0.5
17779, 1.2434782608696, 0.33260869565217, 0.5
17780, 1.2652173913043, 0.30652173913044, 0.5
17781, 1.2869565217391, 0.33260869565217, 0.5
17782, 1.3086956521739, 0.30652173913043, 0.5
17783, 1.3304347826087, 0.33260869565217, 0.5
17784, 1.3521739130435, 0.30652173913044, 0.5
17785, 1.3739130434783, 0.33260869565217, 0.5
17786, 1.395652173913, 0.30652173913044, 0.5
17787, 1.4173913043478, 0.33260869565217, 0.5
17788, 1.4391304347826, 0.30652173913044, 0.5
17789, 1.4608695652174, 0.33260869565217, 0.5
17790, 1.4826086956522, 0.30652173913044, 0.5
17791, 1.504347826087, 0.33260869565217, 0.5
17792, 1.5260869565217, 0.30652173913044, 0.5
17793, 1.5478260869565, 0.33260869565217, 0.5
17794, 1.5695652173913, 0.30652173913044, 0.5
17795, 1.5913043478261, 0.33260869565217, 0.5
17796, 1.6130434782609, 0.30652173913044, 0.5
17797, 1.6347826086957, 0.33260869565217, 0.5
17798, 1.6565217391304, 0.30652173913043, 0.5
17799, 1.6782608695652, 0.33260869565217, 0.5
17800, 1.7, 0.30652173913043, 0.5
17801, 1.7217391304348, 0.33260869565217, 0.5
17802, 1.7434782608696, 0.30652173913043, 0.5
17803, 1.7652173913043, 0.33260869565217, 0.5
17804, 1.7869565217391, 0.30652173913044, 0.5
17805, 1.8086956521739, 0.33260869565217, 0.5
17806, 1.8304347826087, 0.30652173913044, 0.5
17807, 1.8521739130435, 0.33260869565217, 0.5
17808, 1.8739130434783, 0.30652173913043, 0.5
17809, 1.895652173913, 0.33260869565217, 0.5
17810, 1.9173913043478, 0.30652173913044, 0.5
17811, 1.9391304347826, 0.33260869565217, 0.5
17812, 1.9608695652174, 0.30652173913044, 0.5
17813, 1.9826086956522, 0.33260869565217, 0.5
17814, 2.004347826087, 0.30652173913044, 0.5
17815, 2.0260869565217, 0.33260869565217, 0.5
17816, 2.0478260869565, 0.30652173913044, 0.5
17817, 2.0695652173913, 0.33260869565217, 0.5
17818, 2.0913043478261, 0.30652173913043, 0.5
17819, 2.1130434782609, 0.33260869565217, 0.5
17820, 2.1347826086957, 0.30652173913043, 0.5
17821, 2.1565217391304, 0.33260869565217, 0.5
17822, 2.1782608695652, 0.30652173913044, 0.5
17823, 1.2217391304348, 0.25434782608696, 0.5
17824, 1.2434782608696, 0.2804347826087, 0.5
17825, 1.2652173913043, 0.25434782608696, 0.5
17826, 1.2869565217391, 0.2804347826087, 0.5
17827, 1.3086956521739, 0.25434782608696, 0.5
17828, 1.3304347826087, 0.2804347826087, 0.5
17829, 1.3521739130435, 0.25434782608696, 0.5
17830, 1.3739130434783, 0.2804347826087, 0.5
17831, 1.395652173913, 0.25434782608696, 0.5
17832, 1.4173913043478, 0.2804347826087, 0.5
17833, 1.4391304347826, 0.25434782608696, 0.5
17834, 1.4608695652174, 0.2804347826087, 0.5
17835, 1.4826086956522, 0.25434782608696, 0.5
17836, 1.504347826087, 0.2804347826087, 0.5
17837, 1.5260869565217, 0.25434782608696, 0.5
17838, 1.5478260869565, 0.2804347826087, 0.5
17839, 1.5695652173913, 0.25434782608696, 0.5
17840, 1.5913043478261, 0.2804347826087, 0.5
17841, 1.6130434782609, 0.25434782608696, 0.5
17842, 1.6347826086957, 0.2804347826087, 0.5
17843, 1.6565217391304, 0.25434782608696, 0.5
17844, 1.6782608695652, 0.2804347826087, 0.5
17845, 1.7, 0.25434782608696, 0.5
17846, 1.7217391304348, 0.2804347826087, 0.5
17847, 1.7434782608696, 0.25434782608696, 0.5
17848, 1.7652173913043, 0.2804347826087, 0.5
17849, 1.7869565217391, 0.25434782608696, 0.5
17850, 1.8086956521739, 0.2804347826087, 0.5
17851, 1.8304347826087, 0.25434782608696, 0.5
17852, 1.8521739130435, 0.2804347826087, 0.5
17853, 1.8739130434783, 0.25434782608696, 0.5
17854, 1.895652173913, 0.2804347826087, 0.5
17855, 1.9173913043478, 0.25434782608696, 0.5
17856, 1.9391304347826, 0.2804347826087, 0.5
17857, 1.9608695652174, 0.25434782608696, 0.5
17858, 1.9826086956522, 0.2804347826087, 0.5
17859, 2.004347826087, 0.25434782608696, 0.5
17860, 2.0260869565217, 0.2804347826087, 0.5
17861, 2.0478260869565, 0.25434782608696, 0.5
17862, 2.0695652173913, 0.2804347826087, 0.5
17863, 2.0913043478261, 0.25434782608696, 0.5
17864, 2.1130434782609, 0.2804347826087, 0.5
17865, 2.1347826086957, 0.25434782608696, 0.5
17866, 2.1565217391304, 0.2804347826087, 0.5
17867, 2.1782608695652, 0.25434782608696, 0.5
17868, 1.2217391304348, 0.20217391304348, 0.5
17869, 1.2434782608696, 0.22826086956522, 0.5
17870, 1.2652173913043, 0.20217391304348, 0.5
17871, 1.2869565217391, 0.22826086956522, 0.5
17872, 1.3086956521739, 0.20217391304348, 0.5
17873, 1.3304347826087, 0.22826086956522, 0.5
17874, 1.3521739130435, 0.20217391304348, 0.5
17875, 1.3739130434783, 0.22826086956522, 0.5
17876, 1.395652173913, 0.20217391304348, 0.5
17877, 1.4173913043478, 0.22826086956522, 0.5
17878, 1.4391304347826, 0.20217391304348, 0.5
17879, 1.4608695652174, 0.22826086956522, 0.5
17880, 1.4826086956522, 0.20217391304348, 0.5
17881, 1.504347826087, 0.22826086956522, 0.5
17882, 1.5260869565217, 0.20217391304348, 0.5
17883, 1.5478260869565, 0.22826086956522, 0.5
17884, 1.5695652173913, 0.20217391304348, 0.5
17885, 1.5913043478261, 0.22826086956522, 0.5
17886, 1.6130434782609, 0.20217391304348, 0.5
17887, 1.6347826086957, 0.22826086956522, 0.5
17888, 1.6565217391304, 0.20217391304348, 0.5
17889, 1.6782608695652, 0.22826086956522, 0.5
17890, 1.7, 0.20217391304348, 0.5
17891, 1.7217391304348, 0.22826086956522, 0.5
17892, 1.7434782608696, 0.20217391304348, 0.5
17893, 1.7652173913043, 0.22826086956522, 0.5
17894, 1.7869565217391, 0.20217391304348, 0.5
17895, 1.8086956521739, 0.22826086956522, 0.5
17896, 1.8304347826087, 0.20217391304348, 0.5
17897, 1.8521739130435, 0.22826086956522, 0.5
17898, 1.8739130434783, 0.20217391304348, 0.5
17899, 1.895652173913, 0.22826086956522, 0.5
17900, 1.9173913043478, 0.20217391304348, 0.5
17901, 1.9391304347826, 0.22826086956522, 0.5
17902, 1.9608695652174, 0.20217391304348, 0.5
17903, 1.9826086956522, 0.22826086956522, 0.5
17904, 2.004347826087, 0.20217391304348, 0.5
17905, 2.0260869565217, 0.22826086956522, 0.5
17906, 2.0478260869565, 0.20217391304348, 0.5
17907, 2.0695652173913, 0.22826086956522, 0.5
17908, 2.0913043478261, 0.20217391304348, 0.5
17909, 2.1130434782609, 0.22826086956522, 0.5
17910, 2.1347826086957, 0.20217391304348, 0.5
17911, 2.1565217391304, 0.22826086956522, 0.5
17912, 2.1782608695652, 0.20217391304348, 0.5
17913, 1.2434782608696, 0.17608695652174, 0.5
17914, 1.2869565217391, 0.17608695652174, 0.5
17915, 1.3304347826087, 0.17608695652174, 0.5
17916, 1.3739130434783, 0.17608695652174, 0.5
17917, 1.4173913043478, 0.17608695652174, 0.5
17918, 1.4608695652174, 0.17608695652174, 0.5
17919, 1.504347826087, 0.17608695652174, 0.5
17920, 1.5478260869565, 0.17608695652174, 0.5
17921, 1.5913043478261, 0.17608695652174, 0.5
17922, 1.6347826086957, 0.17608695652174, 0.5
17923, 1.6782608695652, 0.17608695652174, 0.5
17924, 1.7217391304348, 0.17608695652174, 0.5
17925, 1.7652173913043, 0.17608695652174, 0.5
17926, 1.8086956521739, 0.17608695652174, 0.5
17927, 1.8521739130435, 0.17608695652174, 0.5
17928, 1.895652173913, 0.17608695652174, 0.5
17929, 1.9391304347826, 0.17608695652174, 0.5
17930, 1.9826086956522, 0.17608695652174, 0.5
17931, 2.0260869565217, 0.17608695652174, 0.5
17932, 2.0695652173913, 0.17608695652174, 0.5
17933, 2.1130434782609, 0.17608695652174, 0.5
17934, 2.1565217391304, 0.17608695652174, 0.5
17935, 1.2434782608696, 1.2978260869565, 0
17936, 1.2869565217391, 1.2978260869565, 0
17937, 1.3304347826087, 1.2978260869565, 0
17938, 1.3739130434783, 1.2978260869565, 0
17939, 1.4173913043478, 1.2978260869565, 0
17940, 1.4608695652174, 1.2978260869565, 0
17941, 1.504347826087, 1.2978260869565, 0
17942, 1.5478260869565, 1.2978260869565, 0
17943, 1.5913043478261, 1.2978260869565, 0
17944, 1.6347826086957, 1.2978260869565, 0
17945, 1.6782608695652, 1.2978260869565, 0
17946, 1.7217391304348, 1.2978260869565, 0
17947, 1.7652173913043, 1.2978260869565, 0
17948, 1.8086956521739, 1.2978260869565, 0
17949, 1.8521739130435, 1.2978260869565, 0
17950, 1.895652173913, 1.2978260869565, 0
17951, 1.9391304347826, 1.2978260869565, 0
17952, 1.9826086956522, 1.2978260869565, 0
17953, 2.0260869565217, 1.2978260869565, 0
17954, 2.0695652173913, 1.2978260869565, 0
17955, 2.1130434782609, 1.2978260869565, 0
17956, 2.1565217391304, 1.2978260869565, 0
17957, 1.2434782608696, 1.245652173913, 0
17958, 1.2869565217391, 1.245652173913, 0
17959, 1.3304347826087, 1.245652173913, 0
17960, 1.3739130434783, 1.245652173913, 0
17961, 1.4173913043478, 1.245652173913, 0
17962, 1.4608695652174, 1.245652173913, 0
17963, 1.504347826087, 1.245652173913, 0
17964, 1.5478260869565, 1.245652173913, 0
17965, 1.5913043478261, 1.245652173913, 0
17966, 1.6347826086957, 1.245652173913, 0
17967, 1.6782608695652, 1.245652173913, 0
17968, 1.7217391304348, 1.245652173913, 0
17969, 1.7652173913043, 1.245652173913, 0
17970, 1.8086956521739, 1.245652173913, 0
17971, 1.8521739130435, 1.245652173913, 0
17972, 1.895652173913, 1.245652173913, 0
17973, 1.9391304347826, 1.245652173913, 0
17974, 1.9826086956522, 1.245652173913, 0
17975, 2.0260869565217, 1.245652173913, 0
17976, 2.0695652173913, 1.245652173913, 0
17977, 2.1130434782609, 1.245652173913, 0
17978, 2.1565217391304, 1.245652173913, 0
17979, 1.2434782608696, 1.1934782608696, 0
17980, 1.2869565217391, 1.1934782608696, 0
17981, 1.3304347826087, 1.1934782608696, 0
17982, 1.3739130434783, 1.1934782608696, 0
17983, 1.4173913043478, 1.1934782608696, 0
17984, 1.4608695652174, 1.1934782608696, 0
17985, 1.504347826087, 1.1934782608696, 0
17986, 1.5478260869565, 1.1934782608696, 0
17987, 1.5913043478261, 1.1934782608696, 0
17988, 1.6347826086957, 1.1934782608696, 0
17989, 1.6782608695652, 1.1934782608696, 0
17990, 1.7217391304348, 1.1934782608696, 0
17991, 1.7652173913043, 1.1934782608696, 0
17992, 1.8086956521739, 1.1934782608696, 0
17993, 1.8521739130435, 1.1934782608696, 0
17994, 1.895652173913, 1.1934782608696, 0
17995, 1.9391304347826, 1.1934782608696, 0
17996, 1.9826086956522, 1.1934782608696, 0
17997, 2.0260869565217, 1.1934782608696, 0
17998, 2.0695652173913, 1.1934782608696, 0
17999, 2.1130434782609, 1.1934782608696, 0
18000, 2.1565217391304, 1.1934782608696, 0
18001, 1.2434782608696, 1.1413043478261, 0
18002, 1.2869565217391, 1.1413043478261, 0
18003, 1.3304347826087, 1.1413043478261, 0
18004, 1.3739130434783, 1.1413043478261, 0
18005, 1.4173913043478, 1.1413043478261, 0
18006, 1.4608695652174, 1.1413043478261, 0
18007, 1.504347826087, 1.1413043478261, 0
18008, 1.5478260869565, 1.1413043478261, 0
18009, 1.5913043478261, 1.1413043478261, 0
18010, 1.6347826086957, 1.1413043478261, 0
18011, 1.6782608695652, 1.1413043478261, 0
18012, 1.7217391304348, 1.1413043478261, 0
18013, 1.7652173913043, 1.1413043478261, 0
18014, 1.8086956521739, 1.1413043478261, 0
18015, 1.8521739130435, 1.1413043478261, 0
18016, 1.895652173913, 1.1413043478261, 0
18017, 1.9391304347826, 1.1413043478261, 0
18018, 1.9826086956522, 1.1413043478261, 0
18019, 2.0260869565217, 1.1413043478261, 0
18020, 2.0695652173913, 1.1413043478261, 0
18021, 2.1130434782609, 1.1413043478261, 0
18022, 2.1565217391304, 1.1413043478261, 0
18023, 1.2434782608696, 1.0891304347826, 0
18024, 1.2869565217391, 1.0891304347826, 0
18025, 1.3304347826087, 1.0891304347826, 0
18026, 1.3739130434783, 1.0891304347826, 0
18027, 1.4173913043478, 1.0891304347826, 0
18028, 1.4608695652174, 1.0891304347826, 0
18029, 1.504347826087, 1.0891304347826, 0
18030, 1.5478260869565, 1.0891304347826, 0
18031, 1.5913043478261, 1.0891304347826, 0
18032, 1.6347826086957, 1.0891304347826, 0
18033, 1.6782608695652, 1.0891304347826, 0
18034, 1.7217391304348, 1.0891304347826, 0
18035, 1.7652173913043, 1.0891304347826, 0
18036, 1.8086956521739, 1.0891304347826, 0
18037, 1.8521739130435, 1.0891304347826, 0
18038, 1.895652173913, 1.0891304347826, 0
18039, 1.9391304347826, 1.0891304347826, 0
18040, 1.9826086956522, 1.0891304347826, 0
18041, 2.0260869565217, 1.0891304347826, 0
18042, 2.0695652173913, 1.0891304347826, 0
18043, 2.1130434782609, 1.0891304347826, 0
18044, 2.1565217391304, 1.0891304347826, 0
18045, 1.2434782608696, 1.0369565217391, 0
18046, 1.2869565217391, 1.0369565217391, 0
18047, 1.3304347826087, 1.0369565217391, 0
18048, 1.3739130434783, 1.0369565217391, 0
18049, 1.4173913043478, 1.0369565217391, 0
18050, 1.4608695652174, 1.0369565217391, 0
18051, 1.504347826087, 1.0369565217391, 0
18052, 1.5478260869565, 1.0369565217391, 0
18053, 1.5913043478261, 1.0369565217391, 0
18054, 1.6347826086957, 1.0369565217391, 0
18055, 1.6782608695652, 1.0369565217391, 0
18056, 1.7217391304348, 1.0369565217391, 0
18057, 1.7652173913043, 1.0369565217391, 0
18058, 1.8086956521739, 1.0369565217391, 0
18059, 1.8521739130435, 1.0369565217391, 0
18060, 1.895652173913, 1.0369565217391, 0
18061, 1.9391304347826, 1.0369565217391, 0
18062, 1.9826086956522, 1.0369565217391, 0
18063, 2.0260869565217, 1.0369565217391, 0
18064, 2.0695652173913, 1.0369565217391, 0
18065, 2.1130434782609, 1.0369565217391, 0
18066, 2.1565217391304, 1.0369565217391, 0
18067, 1.2434782608696, 0.98478260869565, 0
18068, 1.2869565217391, 0.98478260869565, 0
18069, 1.3304347826087, 0.98478260869565, 0
18070, 1.3739130434783, 0.98478260869565, 0
18071, 1.4173913043478, 0.98478260869565, 0
18072, 1.4608695652174, 0.98478260869565, 0
18073, 1.504347826087, 0.98478260869565, 0
18074, 1.5478260869565, 0.98478260869565, 0
18075, 1.5913043478261, 0.98478260869565, 0
18076, 1.6347826086957, 0.98478260869565, 0
18077, 1.6782608695652, 0.98478260869565, 0
18078, 1.7217391304348, 0.98478260869565, 0
18079, 1.7652173913043, 0.98478260869565, 0
18080, 1.8086956521739, 0.98478260869565, 0
18081, 1.8521739130435, 0.98478260869565, 0
18082, 1.895652173913, 0.98478260869565, 0
18083, 1.9391304347826, 0.98478260869565, 0
18084, 1.9826086956522, 0.98478260869565, 0
18085, 2.0260869565217, 0.98478260869565, 0
18086, 2.0695652173913, 0.98478260869565, 0
18087, 2.1130434782609, 0.98478260869565, 0
18088, 2.1565217391304, 0.98478260869565, 0
18089, 1.2434782608696, 0.93260869565217, 0
18090, 1.2869565217391, 0.93260869565217, 0
18091, 1.3304347826087, 0.93260869565217, 0
18092, 1.3739130434783, 0.93260869565217, 0
18093, 1.4173913043478, 0.93260869565217, 0
18094, 1.4608695652174, 0.93260869565217, 0
18095, 1.504347826087, 0.93260869565217, 0
18096, 1.5478260869565, 0.93260869565217, 0
18097, 1.5913043478261, 0.93260869565217, 0
18098, 1.6347826086957, 0.93260869565217, 0
18099, 1.6782608695652, 0.93260869565217, 0
18100, 1.7217391304348, 0.93260869565217, 0
18101, 1.7652173913043, 0.93260869565217, 0
18102, 1.8086956521739, 0.93260869565217, 0
18103, 1.8521739130435, 0.93260869565217, 0
18104, 1.895652173913, 0.93260869565217, 0
18105, 1.9391304347826, 0.93260869565217, 0
18106, 1.9826086956522, 0.93260869565217, 0
18107, 2.0260869565217, 0.93260869565217, 0
18108, 2.0695652173913, 0.93260869565217, 0
18109, 2.1130434782609, 0.93260869565217, 0
18110, 2.1565217391304, 0.93260869565217, 0
18111, 1.2434782608696, 0.8804347826087, 0
18112, 1.2869565217391, 0.8804347826087, 0
18113, 1.3304347826087, 0.8804347826087, 0
18114, 1.3739130434783, 0.8804347826087, 0
18115, 1.4173913043478, 0.8804347826087, 0
18116, 1.4608695652174, 0.8804347826087, 0
18117, 1.504347826087, 0.8804347826087, 0
18118, 1.5478260869565, 0.8804347826087, 0
18119, 1.5913043478261, 0.8804347826087, 0
18120, 1.6347826086957, 0.8804347826087, 0
18121, 1.6782608695652, 0.8804347826087, 0
18122, 1.7217391304348, 0.8804347826087, 0
18123, 1.7652173913043, 0.8804347826087, 0
18124, 1.8086956521739, 0.8804347826087, 0
18125, 1.8521739130435, 0.8804347826087, 0
18126, 1.895652173913, 0.8804347826087, 0
18127, 1.9391304347826, 0.8804347826087, 0
18128, 1.9826086956522, 0.8804347826087, 0
18129, 2.0260869565217, 0.8804347826087, 0
18130, 2.0695652173913, 0.8804347826087, 0
18131, 2.1130434782609, 0.8804347826087, 0
18132, 2.1565217391304, 0.8804347826087, 0
18133, 1.2434782608696, 0.82826086956522, 0
18134, 1.2869565217391, 0.82826086956522, 0
18135, 1.3304347826087, 0.82826086956522, 0
18136, 1.3739130434783, 0.82826086956522, 0
18137, 1.4173913043478, 0.82826086956522, 0
18138, 1.4608695652174, 0.82826086956522, 0
18139, 1.504347826087, 0.82826086956522, 0
18140, 1.5478260869565, 0.82826086956522, 0
18141, 1.5913043478261, 0.82826086956522, 0
18142, 1.6347826086957, 0.82826086956522, 0
18143, 1.6782608695652, 0.82826086956522, 0
18144, 1.7217391304348, 0.82826086956522, 0
18145, 1.7652173913043, 0.82826086956522, 0
18146, 1.8086956521739, 0.82826086956522, 0
18147, 1.8521739130435, 0.82826086956522, 0
18148, 1.895652173913, 0.82826086956522, 0
18149, 1.9391304347826, 0.82826086956522, 0
18150, 1.9826086956522, 0.82826086956522, 0
18151, 2.0260869565217, 0.82826086956522, 0
18152, 2.0695652173913, 0.82826086956522, 0
18153, 2.1130434782609, 0.82826086956522, 0
18154, 2.1565217391304, 0.82826086956522, 0
18155, 1.2434782608696, 0.77608695652174, 0
18156, 1.2869565217391, 0.77608695652174, 0
18157, 1.3304347826087, 0.77608695652174, 0
18158, 1.3739130434783, 0.77608695652174, 0
18159, 1.4173913043478, 0.77608695652174, 0
18160, 1.4608695652174, 0.77608695652174, 0
18161, 1.504347826087, 0.77608695652174, 0
18162, 1.5478260869565, 0.77608695652174, 0
18163, 1.5913043478261, 0.77608695652174, 0
18164, 1.6347826086957, 0.77608695652174, 0
18165, 1.6782608695652, 0.77608695652174, 0
18166, 1.7217391304348, 0.77608695652174, 0
18167, 1.7652173913043, 0.77608695652174, 0
18168, 1.8086956521739, 0.77608695652174, 0
18169, 1.8521739130435, 0.77608695652174, 0
18170, 1.895652173913, 0.77608695652174, 0
18171, 1.9391304347826, 0.77608695652174, 0
18172, 1.9826086956522, 0.77608695652174, 0
18173, 2.0260869565217, 0.77608695652174, 0
18174, 2.0695652173913, 0.77608695652174, 0
18175, 2.1130434782609, 0.77608695652174, 0
18176, 2.1565217391304, 0.77608695652174, 0
18177, 1.2434782608696, 0.72391304347826, 0
18178, 1.2869565217391, 0.72391304347826, 0
18179, 1.3304347826087, 0.72391304347826, 0
18180, 1.3739130434783, 0.72391304347826, 0
18181, 1.4173913043478, 0.72391304347826, 0
18182, 1.4608695652174, 0.72391304347826, 0
18183, 1.504347826087, 0.72391304347826, 0
18184, 1.5478260869565, 0.72391304347826, 0
18185, 1.5913043478261, 0.72391304347826, 0
18186, 1.6347826086957, 0.72391304347826, 0
18187, 1.6782608695652, 0.72391304347826, 0
18188, 1.7217391304348, 0.72391304347826, 0
18189, 1.7652173913043, 0.72391304347826, 0
18190, 1.8086956521739, 0.72391304347826, 0
18191, 1.8521739130435, 0.72391304347826, 0
18192, 1.895652173913, 0.72391304347826, 0
18193, 1.9391304347826, 0.72391304347826, 0
18194, 1.9826086956522, 0.72391304347826, 0
18195, 2.0260869565217, 0.72391304347826, 0
18196, 2.0695652173913, 0.72391304347826, 0
18197, 2.1130434782609, 0.72391304347826, 0
18198, 2.1565217391304, 0.72391304347826, 0
18199, 1.2434782608696, 0.67173913043478, 0
18200, 1.2869565217391, 0.67173913043478, 0
18201, 1.3304347826087, 0.67173913043478, 0
18202, 1.3739130434783, 0.67173913043478, 0
18203, 1.4173913043478, 0.67173913043478, 0
18204, 1.4608695652174, 0.67173913043478, 0
18205, 1.504347826087, 0.67173913043478, 0
18206, 1.5478260869565, 0.67173913043478, 0
18207, 1.5913043478261, 0.67173913043478, 0
18208, 1.6347826086957, 0.67173913043478, 0
18209, 1.6782608695652, 0.67173913043478, 0
18210, 1.7217391304348, 0.67173913043478, 0
18211, 1.7652173913043, 0.67173913043478, 0
18212, 1.8086956521739, 0.67173913043478, 0
18213, 1.8521739130435, 0.67173913043478, 0
18214, 1.895652173913, 0.67173913043478, 0
18215, 1.9391304347826, 0.67173913043478, 0
18216, 1.9826086956522, 0.67173913043478, 0
18217, 2.0260869565217, 0.67173913043478, 0
18218, 2.0695652173913, 0.67173913043478, 0
18219, 2.1130434782609, 0.67173913043478, 0
18220, 2.1565217391304, 0.67173913043478, 0
18221, 1.2434782608696, 0.61956521739131, 0
18222, 1.2869565217391, 0.61956521739131, 0
18223, 1.3304347826087, 0.61956521739131, 0
18224, 1.3739130434783, 0.61956521739131, 0
18225, 1.4173913043478, 0.61956521739131, 0
18226, 1.4608695652174, 0.61956521739131, 0
18227, 1.504347826087, 0.6195652173913, 0
18228, 1.5478260869565, 0.61956521739131, 0
18229, 1.5913043478261, 0.61956521739131, 0
18230, 1.6347826086957, 0.61956521739131, 0
18231, 1.6782608695652, 0.61956521739131, 0
18232, 1.7217391304348, 0.61956521739131, 0
18233, 1.7652173913043, 0.61956521739131, 0
18234, 1.8086956521739, 0.61956521739131, 0
18235, 1.8521739130435, 0.61956521739131, 0
18236, 1.895652173913, 0.61956521739131, 0
18237, 1.9391304347826, 0.61956521739131, 0
18238, 1.9826086956522, 0.61956521739131, 0
18239, 2.0260869565217, 0.61956521739131, 0
18240, 2.0695652173913, 0.61956521739131, 0
18241, 2.1130434782609, 0.61956521739131, 0
18242, 2.1565217391304, 0.61956521739131, 0
18243, 1.2434782608696, 0.56739130434783, 0
18244, 1.2869565217391, 0.56739130434783, 0
18245, 1.3304347826087, 0.56739130434783, 0
18246, 1.3739130434783, 0.56739130434783, 0
18247, 1.4173913043478, 0.56739130434783, 0
18248, 1.4608695652174, 0.56739130434783, 0
18249, 1.504347826087, 0.56739130434783, 0
18250, 1.5478260869565, 0.56739130434783, 0
18251, 1.5913043478261, 0.56739130434783, 0
18252, 1.6347826086957, 0.56739130434783, 0
18253, 1.6782608695652, 0.56739130434783, 0
18254, 1.7217391304348, 0.56739130434783, 0
18255, 1.7652173913043, 0.56739130434783, 0
18256, 1.8086956521739, 0.56739130434783, 0
18257, 1.8521739130435, 0.56739130434783, 0
18258, 1.895652173913, 0.56739130434783, 0
18259, 1.9391304347826, 0.56739130434783, 0
18260, 1.9826086956522, 0.56739130434783, 0
18261, 2.0260869565217, 0.56739130434783, 0
18262, 2.0695652173913, 0.56739130434783, 0
18263, 2.1130434782609, 0.56739130434783, 0
18264, 2.1565217391304, 0.56739130434783, 0
18265, 1.2434782608696, 0.51521739130435, 0
18266, 1.2869565217391, 0.51521739130435, 0
18267, 1.3304347826087, 0.51521739130435, 0
18268, 1.3739130434783, 0.51521739130435, 0
18269, 1.4173913043478, 0.51521739130435, 0
18270, 1.4608695652174, 0.51521739130435, 0
18271, 1.504347826087, 0.51521739130435, 0
18272, 1.5478260869565, 0.51521739130435, 0
18273, 1.5913043478261, 0.51521739130435, 0
18274, 1.6347826086957, 0.51521739130435, 0
18275, 1.6782608695652, 0.51521739130435, 0
18276, 1.7217391304348, 0.51521739130435, 0
18277, 1.7652173913043, 0.51521739130435, 0
18278, 1.8086956521739, 0.51521739130435, 0
18279, 1.8521739130435, 0.51521739130435, 0
18280, 1.895652173913, 0.51521739130435, 0
18281, 1.9391304347826, 0.51521739130435, 0
18282, 1.9826086956522, 0.51521739130435, 0
18283, 2.0260869565217, 0.51521739130435, 0
18284, 2.0695652173913, 0.51521739130435, 0
18285, 2.1130434782609, 0.51521739130435, 0
18286, 2.1565217391304, 0.51521739130435, 0
18287, 1.2434782608696, 0.46304347826087, 0
18288, 1.2869565217391, 0.46304347826087, 0
18289, 1.3304347826087, 0.46304347826087, 0
18290, 1.3739130434783, 0.46304347826087, 0
18291, 1.4173913043478, 0.46304347826087, 0
18292, 1.4608695652174, 0.46304347826087, 0
18293, 1.504347826087, 0.46304347826087, 0
18294, 1.5478260869565, 0.46304347826087, 0
18295, 1.5913043478261, 0.46304347826087, 0
18296, 1.6347826086957, 0.46304347826087, 0
18297, 1.6782608695652, 0.46304347826087, 0
18298, 1.7217391304348, 0.46304347826087, 0
18299, 1.7652173913043, 0.46304347826087, 0
18300, 1.8086956521739, 0.46304347826087, 0
18301, 1.8521739130435, 0.46304347826087, 0
18302, 1.895652173913, 0.46304347826087, 0
18303, 1.9391304347826, 0.46304347826087, 0
18304, 1.9826086956522, 0.46304347826087, 0
18305, 2.0260869565217, 0.46304347826087, 0
18306, 2.0695652173913, 0.46304347826087, 0
18307, 2.1130434782609, 0.46304347826087, 0
18308, 2.1565217391304, 0.46304347826087, 0
18309, 1.2434782608696, 0.41086956521739, 0
18310, 1.2869565217391, 0.41086956521739, 0
18311, 1.3304347826087, 0.41086956521739, 0
18312, 1.3739130434783, 0.41086956521739, 0
18313, 1.4173913043478, 0.41086956521739, 0
18314, 1.4608695652174, 0.41086956521739, 0
18315, 1.504347826087, 0.41086956521739, 0
18316, 1.5478260869565, 0.41086956521739, 0
18317, 1.5913043478261, 0.41086956521739, 0
18318, 1.6347826086957, 0.41086956521739, 0
18319, 1.6782608695652, 0.41086956521739, 0
18320, 1.7217391304348, 0.41086956521739, 0
18321, 1.7652173913043, 0.41086956521739, 0
18322, 1.8086956521739, 0.41086956521739, 0
18323, 1.8521739130435, 0.41086956521739, 0
18324, 1.895652173913, 0.41086956521739, 0
18325, 1.9391304347826, 0.41086956521739, 0
18326, 1.9826086956522, 0.41086956521739, 0
18327, 2.0260869565217, 0.41086956521739, 0
18328, 2.0695652173913, 0.41086956521739, 0
18329, 2.1130434782609, 0.41086956521739, 0
18330, 2.1565217391304, 0.41086956521739, 0
18331, 1.2434782608696, 0.35869565217391, 0
18332, 1.2869565217391, 0.35869565217391, 0
18333, 1.3304347826087, 0.35869565217391, 0
18334, 1.3739130434783, 0.35869565217391, 0
18335, 1.4173913043478, 0.35869565217391, 0
18336, 1.4608695652174, 0.35869565217391, 0
18337, 1.504347826087, 0.35869565217391, 0
18338, 1.5478260869565, 0.35869565217391, 0
18339, 1.5913043478261, 0.35869565217391, 0
18340, 1.6347826086957, 0.35869565217391, 0
18341, 1.6782608695652, 0.35869565217391, 0
18342, 1.7217391304348, 0.35869565217391, 0
18343, 1.7652173913043, 0.35869565217391, 0
18344, 1.8086956521739, 0.35869565217391, 0
18345, 1.8521739130435, 0.35869565217391, 0
18346, 1.895652173913, 0.35869565217391, 0
18347, 1.9391304347826, 0.35869565217391, 0
18348, 1.9826086956522, 0.35869565217391, 0
18349, 2.0260869565217, 0.35869565217391, 0
18350, 2.0695652173913, 0.35869565217391, 0
18351, 2.1130434782609, 0.35869565217391, 0
18352, 2.1565217391304, 0.35869565217391, 0
18353, 1.2434782608696, 0.30652173913044, 0
18354, 1.2869565217391, 0.30652173913043, 0
18355, 1.3304347826087, 0.30652173913043, 0
18356, 1.3739130434783, 0.30652173913044, 0
18357, 1.4173913043478, 0.30652173913044, 0
18358, 1.4608695652174, 0.30652173913043, 0
18359, 1.504347826087, 0.30652173913044, 0
18360, 1.5478260869565, 0.30652173913044, 0
18361, 1.5913043478261, 0.30652173913044, 0
18362, 1.6347826086957, 0.30652173913043, 0
18363, 1.6782608695652, 0.30652173913043, 0
18364, 1.7217391304348, 0.30652173913043, 0
18365, 1.7652173913043, 0.30652173913043, 0
18366, 1.8086956521739, 0.30652173913044, 0
18367, 1.8521739130435, 0.30652173913043, 0
18368, 1.895652173913, 0.30652173913044, 0
18369, 1.9391304347826, 0.30652173913043, 0
18370, 1.9826086956522, 0.30652173913044, 0
18371, 2.0260869565217, 0.30652173913044, 0
18372, 2.0695652173913, 0.30652173913043, 0
18373, 2.1130434782609, 0.30652173913043, 0
18374, 2.1565217391304, 0.30652173913043, 0
18375, 1.2434782608696, 0.25434782608696, 0
18376, 1.2869565217391, 0.25434782608696, 0
18377, 1.3304347826087, 0.25434782608696, 0
18378, 1.3739130434783, 0.25434782608696, 0
18379, 1.4173913043478, 0.25434782608696, 0
18380, 1.4608695652174, 0.25434782608696, 0
18381, 1.504347826087, 0.25434782608696, 0
18382, 1.5478260869565, 0.25434782608696, 0
18383, 1.5913043478261, 0.25434782608696, 0
18384, 1.6347826086957, 0.25434782608696, 0
18385, 1.6782608695652, 0.25434782608696, 0
18386, 1.7217391304348, 0.25434782608696, 0
18387, 1.7652173913043, 0.25434782608696, 0
18388, 1.8086956521739, 0.25434782608696, 0
18389, 1.8521739130435, 0.25434782608696, 0
18390, 1.895652173913, 0.25434782608696, 0
18391, 1.9391304347826, 0.25434782608696, 0
18392, 1.9826086956522, 0.25434782608696, 0
18393, 2.0260869565217, 0.25434782608696, 0
18394, 2.0695652173913, 0.25434782608696, 0
18395, 2.1130434782609, 0.25434782608696, 0
18396, 2.1565217391304, 0.25434782608696, 0
18397, 1.2434782608696, 0.20217391304348, 0
18398, 1.2869565217391, 0.20217391304348, 0
18399, 1.3304347826087, 0.20217391304348, 0
18400, 1.3739130434783, 0.20217391304348, 0
18401, 1.4173913043478, 0.20217391304348, 0
18402, 1.4608695652174, 0.20217391304348, 0
18403, 1.504347826087, 0.20217391304348, 0
18404, 1.5478260869565, 0.20217391304348, 0
18405, 1.5913043478261, 0.20217391304348, 0
18406, 1.6347826086957, 0.20217391304348, 0
18407, 1.6782608695652, 0.20217391304348, 0
18408, 1.7217391304348, 0.20217391304348, 0
18409, 1.7652173913043, 0.20217391304348, 0
18410, 1.8086956521739, 0.20217391304348, 0
18411, 1.8521739130435, 0.20217391304348, 0
18412, 1.895652173913, 0.20217391304348, 0
18413, 1.9391304347826, 0.20217391304348, 0
18414, 1.9826086956522, 0.20217391304348, 0
18415, 2.0260869565217, 0.20217391304348, 0
18416, 2.0695652173913, 0.20217391304348, 0
18417, 2.1130434782609, 0.20217391304348, 0
18418, 2.1565217391304, 0.20217391304348, 0
18419, 1.2434782608696, 1.3239130434783, 0
18420, 1.2217391304348, 1.2978260869565, 0
18421, 1.2869565217391, 1.3239130434783, 0
18422, 1.2652173913043, 1.2978260869565, 0
18423, 1.3304347826087, 1.3239130434783, 0
18424, 1.3086956521739, 1.2978260869565, 0
18425, 1.3739130434783, 1.3239130434783, 0
18426, 1.3521739130435, 1.2978260869565, 0
18427, 1.4173913043478, 1.3239130434783, 0
18428, 1.395652173913, 1.2978260869565, 0
18429, 1.4608695652174, 1.3239130434783, 0
18430, 1.4391304347826, 1.2978260869565, 0
18431, 1.504347826087, 1.3239130434783, 0
18432, 1.4826086956522, 1.2978260869565, 0
18433, 1.5478260869565, 1.3239130434783, 0
18434, 1.5260869565217, 1.2978260869565, 0
18435, 1.5913043478261, 1.3239130434783, 0
18436, 1.5695652173913, 1.2978260869565, 0
18437, 1.6347826086957, 1.3239130434783, 0
18438, 1.6130434782609, 1.2978260869565, 0
18439, 1.6782608695652, 1.3239130434783, 0
18440, 1.6565217391304, 1.2978260869565, 0
18441, 1.7217391304348, 1.3239130434783, 0
18442, 1.7, 1.2978260869565, 0
18443, 1.7652173913043, 1.3239130434783, 0
18444, 1.7434782608696, 1.2978260869565, 0
18445, 1.8086956521739, 1.3239130434783, 0
18446, 1.7869565217391, 1.2978260869565, 0
18447, 1.8521739130435, 1.3239130434783, 0
18448, 1.8304347826087, 1.2978260869565, 0
18449, 1.895652173913, 1.3239130434783, 0
18450, 1.8739130434783, 1.2978260869565, 0
18451, 1.9391304347826, 1.3239130434783, 0
18452, 1.9173913043478, 1.2978260869565, 0
18453, 1.9826086956522, 1.3239130434783, 0
18454, 1.9608695652174, 1.2978260869565, 0
18455, 2.0260869565217, 1.3239130434783, 0
18456, 2.004347826087, 1.2978260869565, 0
18457, 2.0695652173913, 1.3239130434783, 0
18458, 2.0478260869565, 1.2978260869565, 0
18459, 2.1130434782609, 1.3239130434783, 0
18460, 2.0913043478261, 1.2978260869565, 0
18461, 2.1565217391304, 1.3239130434783, 0
18462, 2.1347826086957, 1.2978260869565, 0
18463, 2.1782608695652, 1.2978260869565, 0
18464, 1.2434782608696, 1.2717391304348, 0
18465, 1.2217391304348, 1.245652173913, 0
18466, 1.2869565217391, 1.2717391304348, 0
18467, 1.2652173913043, 1.245652173913, 0
18468, 1.3304347826087, 1.2717391304348, 0
18469, 1.3086956521739, 1.245652173913, 0
18470, 1.3739130434783, 1.2717391304348, 0
18471, 1.3521739130435, 1.245652173913, 0
18472, 1.4173913043478, 1.2717391304348, 0
18473, 1.395652173913, 1.245652173913, 0
18474, 1.4608695652174, 1.2717391304348, 0
18475, 1.4391304347826, 1.245652173913, 0
18476, 1.504347826087, 1.2717391304348, 0
18477, 1.4826086956522, 1.245652173913, 0
18478, 1.5478260869565, 1.2717391304348, 0
18479, 1.5260869565217, 1.245652173913, 0
18480, 1.5913043478261, 1.2717391304348, 0
18481, 1.5695652173913, 1.245652173913, 0
18482, 1.6347826086957, 1.2717391304348, 0
18483, 1.6130434782609, 1.245652173913, 0
18484, 1.6782608695652, 1.2717391304348, 0
18485, 1.6565217391304, 1.245652173913, 0
18486, 1.7217391304348, 1.2717391304348, 0
18487, 1.7, 1.245652173913, 0
18488, 1.7652173913043, 1.2717391304348, 0
18489, 1.7434782608696, 1.245652173913, 0
18490, 1.8086956521739, 1.2717391304348, 0
18491, 1.7869565217391, 1.245652173913, 0
18492, 1.8521739130435, 1.2717391304348, 0
18493, 1.8304347826087, 1.245652173913, 0
18494, 1.895652173913, 1.2717391304348, 0
18495, 1.8739130434783, 1.245652173913, 0
18496, 1.9391304347826, 1.2717391304348, 0
18497, 1.9173913043478, 1.245652173913, 0
18498, 1.9826086956522, 1.2717391304348, 0
18499, 1.9608695652174, 1.245652173913, 0
18500, 2.0260869565217, 1.2717391304348, 0
18501, 2.004347826087, 1.245652173913, 0
18502, 2.0695652173913, 1.2717391304348, 0
18503, 2.0478260869565, 1.245652173913, 0
18504, 2.1130434782609, 1.2717391304348, 0
18505, 2.0913043478261, 1.245652173913, 0
18506, 2.1565217391304, 1.2717391304348, 0
18507, 2.1347826086957, 1.245652173913, 0
18508, 2.1782608695652, 1.245652173913, 0
18509, 1.2434782608696, 1.2195652173913, 0
18510, 1.2217391304348, 1.1934782608696, 0
18511, 1.2869565217391, 1.2195652173913, 0
18512, 1.2652173913043, 1.1934782608696, 0
18513, 1.3304347826087, 1.2195652173913, 0
18514, 1.3086956521739, 1.1934782608696, 0
18515, 1.3739130434783, 1.2195652173913, 0
18516, 1.3521739130435, 1.1934782608696, 0
18517, 1.4173913043478, 1.2195652173913, 0
18518, 1.395652173913, 1.1934782608696, 0
18519, 1.4608695652174, 1.2195652173913, 0
18520, 1.4391304347826, 1.1934782608696, 0
18521, 1.504347826087, 1.2195652173913, 0
18522, 1.4826086956522, 1.1934782608696, 0
18523, 1.5478260869565, 1.2195652173913, 0
18524, 1.5260869565217, 1.1934782608696, 0
18525, 1.5913043478261, 1.2195652173913, 0
18526, 1.5695652173913, 1.1934782608696, 0
18527, 1.6347826086957, 1.2195652173913, 0
18528, 1.6130434782609, 1.1934782608696, 0
18529, 1.6782608695652, 1.2195652173913, 0
18530, 1.6565217391304, 1.1934782608696, 0
18531, 1.7217391304348, 1.2195652173913, 0
18532, 1.7, 1.1934782608696, 0
18533, 1.7652173913043, 1.2195652173913, 0
18534, 1.7434782608696, 1.1934782608696, 0
18535, 1.8086956521739, 1.2195652173913, 0
18536, 1.7869565217391, 1.1934782608696, 0
18537, 1.8521739130435, 1.2195652173913, 0
18538, 1.8304347826087, 1.1934782608696, 0
18539, 1.895652173913, 1.2195652173913, 0
18540, 1.8739130434783, 1.1934782608696, 0
18541, 1.9391304347826, 1.2195652173913, 0
18542, 1.9173913043478, 1.1934782608696, 0
18543, 1.9826086956522, 1.2195652173913, 0
18544, 1.9608695652174, 1.1934782608696, 0
18545, 2.0260869565217, 1.2195652173913, 0
18546, 2.004347826087, 1.1934782608696, 0
18547, 2.0695652173913, 1.2195652173913, 0
18548, 2.0478260869565, 1.1934782608696, 0
18549, 2.1130434782609, 1.2195652173913, 0
18550, 2.0913043478261, 1.1934782608696, 0
18551, 2.1565217391304, 1.2195652173913, 0
18552, 2.1347826086957, 1.1934782608696, 0
18553, 2.1782608695652, 1.1934782608696, 0
18554, 1.2434782608696, 1.1673913043478, 0
18555, 1.2217391304348, 1.1413043478261, 0
18556, 1.2869565217391, 1.1673913043478, 0
18557, 1.2652173913043, 1.1413043478261, 0
18558, 1.3304347826087, 1.1673913043478, 0
18559, 1.3086956521739, 1.1413043478261, 0
18560, 1.3739130434783, 1.1673913043478, 0
18561, 1.3521739130435, 1.1413043478261, 0
18562, 1.4173913043478, 1.1673913043478, 0
18563, 1.395652173913, 1.1413043478261, 0
18564, 1.4608695652174, 1.1673913043478, 0
18565, 1.4391304347826, 1.1413043478261, 0
18566, 1.504347826087, 1.1673913043478, 0
18567, 1.4826086956522, 1.1413043478261, 0
18568, 1.5478260869565, 1.1673913043478, 0
18569, 1.5260869565217, 1.1413043478261, 0
18570, 1.5913043478261, 1.1673913043478, 0
18571, 1.5695652173913, 1.1413043478261, 0
18572, 1.6347826086957, 1.1673913043478, 0
18573, 1.6130434782609, 1.1413043478261, 0
18574, 1.6782608695652, 1.1673913043478, 0
18575, 1.6565217391304, 1.1413043478261, 0
18576, 1.7217391304348, 1.1673913043478, 0
18577, 1.7, 1.1413043478261, 0
18578, 1.7652173913043, 1.1673913043478, 0
18579, 1.7434782608696, 1.1413043478261, 0
18580, 1.8086956521739, 1.1673913043478, 0
18581, 1.7869565217391, 1.1413043478261, 0
18582, 1.8521739130435, 1.1673913043478, 0
18583, 1.8304347826087, 1.1413043478261, 0
18584, 1.895652173913, 1.1673913043478, 0
18585, 1.8739130434783, 1.1413043478261, 0
18586, 1.9391304347826, 1.1673913043478, 0
18587, 1.9173913043478, 1.1413043478261, 0
18588, 1.9826086956522, 1.1673913043478, 0
18589, 1.9608695652174, 1.1413043478261, 0
18590, 2.0260869565217, 1.1673913043478, 0
18591, 2.004347826087, 1.1413043478261, 0
18592, 2.0695652173913, 1.1673913043478, 0
18593, 2.0478260869565, 1.1413043478261, 0
18594, 2.1130434782609, 1.1673913043478, 0
18595, 2.0913043478261, 1.1413043478261, 0
18596, 2.1565217391304, 1.1673913043478, 0
18597, 2.1347826086957, 1.1413043478261, 0
18598, 2.1782608695652, 1.1413043478261, 0
18599, 1.2434782608696, 1.1152173913043, 0
18600, 1.2217391304348, 1.0891304347826, 0
18601, 1.2869565217391, 1.1152173913043, 0
18602, 1.2652173913043, 1.0891304347826, 0
18603, 1.3304347826087, 1.1152173913043, 0
18604, 1.3086956521739, 1.0891304347826, 0
18605, 1.3739130434783, 1.1152173913043, 0
18606, 1.3521739130435, 1.0891304347826, 0
18607, 1.4173913043478, 1.1152173913043, 0
18608, 1.395652173913, 1.0891304347826, 0
18609, 1.4608695652174, 1.1152173913043, 0
18610, 1.4391304347826, 1.0891304347826, 0
18611, 1.504347826087, 1.1152173913043, 0
18612, 1.4826086956522, 1.0891304347826, 0
18613, 1.5478260869565, 1.1152173913043, 0
18614, 1.5260869565217, 1.0891304347826, 0
18615, 1.5913043478261, 1.1152173913043, 0
18616, 1.5695652173913, 1.0891304347826, 0
18617, 1.6347826086957, 1.1152173913043, 0
18618, 1.6130434782609, 1.0891304347826, 0
18619, 1.6782608695652, 1.1152173913043, 0
18620, 1.6565217391304, 1.0891304347826, 0
18621, 1.7217391304348, 1.1152173913043, 0
18622, 1.7, 1.0891304347826, 0
18623, 1.7652173913043, 1.1152173913043, 0
18624, 1.7434782608696, 1.0891304347826, 0
18625, 1.8086956521739, 1.1152173913043, 0
18626, 1.7869565217391, 1.0891304347826, 0
18627, 1.8521739130435, 1.1152173913043, 0
18628, 1.8304347826087, 1.0891304347826, 0
18629, 1.895652173913, 1.1152173913043, 0
18630, 1.8739130434783, 1.0891304347826, 0
18631, 1.9391304347826, 1.1152173913043, 0
18632, 1.9173913043478, 1.0891304347826, 0
18633, 1.9826086956522, 1.1152173913043, 0
18634, 1.9608695652174, 1.0891304347826, 0
18635, 2.0260869565217, 1.1152173913043, 0
18636, 2.004347826087, 1.0891304347826, 0
18637, 2.0695652173913, 1.1152173913043, 0
18638, 2.0478260869565, 1.0891304347826, 0
18639, 2.1130434782609, 1.1152173913043, 0
18640, 2.0913043478261, 1.0891304347826, 0
18641, 2.1565217391304, 1.1152173913043, 0
18642, 2.1347826086957, 1.0891304347826, 0
18643, 2.1782608695652, 1.0891304347826, 0
18644, 1.2434782608696, 1.0630434782609, 0
18645, 1.2217391304348, 1.0369565217391, 0
18646, 1.2869565217391, 1.0630434782609, 0
18647, 1.2652173913043, 1.0369565217391, 0
18648, 1.3304347826087, 1.0630434782609, 0
18649, 1.3086956521739, 1.0369565217391, 0
18650, 1.3739130434783, 1.0630434782609, 0
18651, 1.3521739130435, 1.0369565217391, 0
18652, 1.4173913043478, 1.0630434782609, 0
18653, 1.395652173913, 1.0369565217391, 0
18654, 1.4608695652174, 1.0630434782609, 0
18655, 1.4391304347826, 1.0369565217391, 0
18656, 1.504347826087, 1.0630434782609, 0
18657, 1.4826086956522, 1.0369565217391, 0
18658, 1.5478260869565, 1.0630434782609, 0
18659, 1.5260869565217, 1.0369565217391, 0
18660, 1.5913043478261, 1.0630434782609, 0
18661, 1.5695652173913, 1.0369565217391, 0
18662, 1.6347826086957, 1.0630434782609, 0
18663, 1.6130434782609, 1.0369565217391, 0
18664, 1.6782608695652, 1.0630434782609, 0
18665, 1.6565217391304, 1.0369565217391, 0
18666, 1.7217391304348, 1.0630434782609, 0
18667, 1.7, 1.0369565217391, 0
18668, 1.7652173913043, 1.0630434782609, 0
18669, 1.7434782608696, 1.0369565217391, 0
18670, 1.8086956521739, 1.0630434782609, 0
18671, 1.7869565217391, 1.0369565217391, 0
18672, 1.8521739130435, 1.0630434782609, 0
18673, 1.8304347826087, 1.0369565217391, 0
18674, 1.895652173913, 1.0630434782609, 0
18675, 1.8739130434783, 1.0369565217391, 0
18676, 1.9391304347826, 1.0630434782609, 0
18677, 1.9173913043478, 1.0369565217391, 0
18678, 1.9826086956522, 1.0630434782609, 0
18679, 1.9608695652174, 1.0369565217391, 0
18680, 2.0260869565217, 1.0630434782609, 0
18681, 2.004347826087, 1.0369565217391, 0
18682, 2.0695652173913, 1.0630434782609, 0
18683, 2.0478260869565, 1.0369565217391, 0
18684, 2.1130434782609, 1.0630434782609, 0
18685, 2.0913043478261, 1.0369565217391, 0
18686, 2.1565217391304, 1.0630434782609, 0
18687, 2.1347826086957, 1.0369565217391, 0
18688, 2.1782608695652, 1.0369565217391, 0
18689, 1.2434782608696, 1.0108695652174, 0
18690, 1.2217391304348, 0.98478260869565, 0
18691, 1.2869565217391, 1.0108695652174, 0
18692, 1.2652173913043, 0.98478260869565, 0
18693, 1.3304347826087, 1.0108695652174, 0
18694, 1.3086956521739, 0.98478260869565, 0
18695, 1.3739130434783, 1.0108695652174, 0
18696, 1.3521739130435, 0.98478260869565, 0
18697, 1.4173913043478, 1.0108695652174, 0
18698, 1.395652173913, 0.98478260869565, 0
18699, 1.4608695652174, 1.0108695652174, 0
18700, 1.4391304347826, 0.98478260869565, 0
18701, 1.504347826087, 1.0108695652174, 0
18702, 1.4826086956522, 0.98478260869565, 0
18703, 1.5478260869565, 1.0108695652174, 0
18704, 1.5260869565217, 0.98478260869565, 0
18705, 1.5913043478261, 1.0108695652174, 0
18706, 1.5695652173913, 0.98478260869565, 0
18707, 1.6347826086957, 1.0108695652174, 0
18708, 1.6130434782609, 0.98478260869565, 0
18709, 1.6782608695652, 1.0108695652174, 0
18710, 1.6565217391304, 0.98478260869565, 0
18711, 1.7217391304348, 1.0108695652174, 0
18712, 1.7, 0.98478260869565, 0
18713, 1.7652173913043, 1.0108695652174, 0
18714, 1.7434782608696, 0.98478260869565, 0
18715, 1.8086956521739, 1.0108695652174, 0
18716, 1.7869565217391, 0.98478260869565, 0
18717, 1.8521739130435, 1.0108695652174, 0
18718, 1.8304347826087, 0.98478260869565, 0
18719, 1.895652173913, 1.0108695652174, 0
18720, 1.8739130434783, 0.98478260869565, 0
18721, 1.9391304347826, 1.0108695652174, 0
18722, 1.9173913043478, 0.98478260869565, 0
18723, 1.9826086956522, 1.0108695652174, 0
18724, 1.9608695652174, 0.98478260869565, 0
18725, 2.0260869565217, 1.0108695652174, 0
18726, 2.004347826087, 0.98478260869565, 0
18727, 2.0695652173913, 1.0108695652174, 0
18728, 2.0478260869565, 0.98478260869565, 0
18729, 2.1130434782609, 1.0108695652174, 0
18730, 2.0913043478261, 0.98478260869565, 0
18731, 2.1565217391304, 1.0108695652174, 0
18732, 2.1347826086957, 0.98478260869565, 0
18733, 2.1782608695652, 0.98478260869565, 0
18734, 1.2434782608696, 0.95869565217391, 0
18735, 1.2217391304348, 0.93260869565217, 0
18736, 1.2869565217391, 0.95869565217391, 0
18737, 1.2652173913043, 0.93260869565217, 0
18738, 1.3304347826087, 0.95869565217391, 0
18739, 1.3086956521739, 0.93260869565217, 0
18740, 1.3739130434783, 0.95869565217391, 0
18741, 1.3521739130435, 0.93260869565217, 0
18742, 1.4173913043478, 0.95869565217391, 0
18743, 1.395652173913, 0.93260869565217, 0
18744, 1.4608695652174, 0.95869565217391, 0
18745, 1.4391304347826, 0.93260869565217, 0
18746, 1.504347826087, 0.95869565217391, 0
18747, 1.4826086956522, 0.93260869565217, 0
18748, 1.5478260869565, 0.95869565217391, 0
18749, 1.5260869565217, 0.93260869565217, 0
18750, 1.5913043478261, 0.95869565217391, 0
18751, 1.5695652173913, 0.93260869565217, 0
18752, 1.6347826086957, 0.95869565217391, 0
18753, 1.6130434782609, 0.93260869565217, 0
18754, 1.6782608695652, 0.95869565217391, 0
18755, 1.6565217391304, 0.93260869565217, 0
18756, 1.7217391304348, 0.95869565217391, 0
18757, 1.7, 0.93260869565217, 0
18758, 1.7652173913043, 0.95869565217391, 0
18759, 1.7434782608696, 0.93260869565217, 0
18760, 1.8086956521739, 0.95869565217391, 0
18761, 1.7869565217391, 0.93260869565217, 0
18762, 1.8521739130435, 0.95869565217391, 0
18763, 1.8304347826087, 0.93260869565217, 0
18764, 1.895652173913, 0.95869565217391, 0
18765, 1.8739130434783, 0.93260869565217, 0
18766, 1.9391304347826, 0.95869565217391, 0
18767, 1.9173913043478, 0.93260869565217, 0
18768, 1.9826086956522, 0.95869565217391, 0
18769, 1.9608695652174, 0.93260869565217, 0
18770, 2.0260869565217, 0.95869565217391, 0
18771, 2.004347826087, 0.93260869565217, 0
18772, 2.0695652173913, 0.95869565217391, 0
18773, 2.0478260869565, 0.93260869565217, 0
18774, 2.1130434782609, 0.95869565217391, 0
18775, 2.0913043478261, 0.93260869565217, 0
18776, 2.1565217391304, 0.95869565217391, 0
18777, 2.1347826086957, 0.93260869565217, 0
18778, 2.1782608695652, 0.93260869565217, 0
18779, 1.2434782608696, 0.90652173913044, 0
18780, 1.2217391304348, 0.8804347826087, 0
18781, 1.2869565217391, 0.90652173913044, 0
18782, 1.2652173913043, 0.8804347826087, 0
18783, 1.3304347826087, 0.90652173913044, 0
18784, 1.3086956521739, 0.8804347826087, 0
18785, 1.3739130434783, 0.90652173913044, 0
18786, 1.3521739130435, 0.8804347826087, 0
18787, 1.4173913043478, 0.90652173913044, 0
18788, 1.395652173913, 0.8804347826087, 0
18789, 1.4608695652174, 0.90652173913044, 0
18790, 1.4391304347826, 0.8804347826087, 0
18791, 1.504347826087, 0.90652173913044, 0
18792, 1.4826086956522, 0.8804347826087, 0
18793, 1.5478260869565, 0.90652173913044, 0
18794, 1.5260869565217, 0.8804347826087, 0
18795, 1.5913043478261, 0.90652173913044, 0
18796, 1.5695652173913, 0.8804347826087, 0
18797, 1.6347826086957, 0.90652173913044, 0
18798, 1.6130434782609, 0.8804347826087, 0
18799, 1.6782608695652, 0.90652173913044, 0
18800, 1.6565217391304, 0.8804347826087, 0
18801, 1.7217391304348, 0.90652173913044, 0
18802, 1.7, 0.8804347826087, 0
18803, 1.7652173913043, 0.90652173913044, 0
18804, 1.7434782608696, 0.8804347826087, 0
18805, 1.8086956521739, 0.90652173913044, 0
18806, 1.7869565217391, 0.8804347826087, 0
18807, 1.8521739130435, 0.90652173913044, 0
18808, 1.8304347826087, 0.8804347826087, 0
18809, 1.895652173913, 0.90652173913044, 0
18810, 1.8739130434783, 0.8804347826087, 0
18811, 1.9391304347826, 0.90652173913044, 0
18812, 1.9173913043478, 0.8804347826087, 0
18813, 1.9826086956522, 0.90652173913044, 0
18814, 1.9608695652174, 0.8804347826087, 0
18815, 2.0260869565217, 0.90652173913044, 0
18816, 2.004347826087, 0.8804347826087, 0
18817, 2.0695652173913, 0.90652173913044, 0
18818, 2.0478260869565, 0.8804347826087, 0
18819, 2.1130434782609, 0.90652173913044, 0
18820, 2.0913043478261, 0.8804347826087, 0
18821, 2.1565217391304, 0.90652173913044, 0
18822, 2.1347826086957, 0.8804347826087, 0
18823, 2.1782608695652, 0.8804347826087, 0
18824, 1.2434782608696, 0.85434782608696, 0
18825, 1.2217391304348, 0.82826086956522, 0
18826, 1.2869565217391, 0.85434782608696, 0
18827, 1.2652173913043, 0.82826086956522, 0
18828, 1.3304347826087, 0.85434782608696, 0
18829, 1.3086956521739, 0.82826086956522, 0
18830, 1.3739130434783, 0.85434782608696, 0
18831, 1.3521739130435, 0.82826086956522, 0
18832, 1.4173913043478, 0.85434782608696, 0
18833, 1.395652173913, 0.82826086956522, 0
18834, 1.4608695652174, 0.85434782608696, 0
18835, 1.4391304347826, 0.82826086956522, 0
18836, 1.504347826087, 0.85434782608696, 0
18837, 1.4826086956522, 0.82826086956522, 0
18838, 1.5478260869565, 0.85434782608696, 0
18839, 1.5260869565217, 0.82826086956522, 0
18840, 1.5913043478261, 0.85434782608696, 0
18841, 1.5695652173913, 0.82826086956522, 0
18842, 1.6347826086957, 0.85434782608696, 0
18843, 1.6130434782609, 0.82826086956522, 0
18844, 1.6782608695652, 0.85434782608696, 0
18845, 1.6565217391304, 0.82826086956522, 0
18846, 1.7217391304348, 0.85434782608696, 0
18847, 1.7, 0.82826086956522, 0
18848, 1.7652173913043, 0.85434782608696, 0
18849, 1.7434782608696, 0.82826086956522, 0
18850, 1.8086956521739, 0.85434782608696, 0
18851, 1.7869565217391, 0.82826086956522, 0
18852, 1.8521739130435, 0.85434782608696, 0
18853, 1.8304347826087, 0.82826086956522, 0
18854, 1.895652173913, 0.85434782608696, 0
18855, 1.8739130434783, 0.82826086956522, 0
18856, 1.9391304347826, 0.85434782608696, 0
18857, 1.9173913043478, 0.82826086956522, 0
18858, 1.9826086956522, 0.85434782608696, 0
18859, 1.9608695652174, 0.82826086956522, 0
18860, 2.0260869565217, 0.85434782608696, 0
18861, 2.004347826087, 0.82826086956522, 0
18862, 2.0695652173913, 0.85434782608696, 0
18863, 2.0478260869565, 0.82826086956522, 0
18864, 2.1130434782609, 0.85434782608696, 0
18865, 2.0913043478261, 0.82826086956522, 0
18866, 2.1565217391304, 0.85434782608696, 0
18867, 2.1347826086957, 0.82826086956522, 0
18868, 2.1782608695652, 0.82826086956522, 0
18869, 1.2434782608696, 0.80217391304348, 0
18870, 1.2217391304348, 0.77608695652174, 0
18871, 1.2869565217391, 0.80217391304348, 0
18872, 1.2652173913043, 0.77608695652174, 0
18873, 1.3304347826087, 0.80217391304348, 0
18874, 1.3086956521739, 0.77608695652174, 0
18875, 1.3739130434783, 0.80217391304348, 0
18876, 1.3521739130435, 0.77608695652174, 0
18877, 1.4173913043478, 0.80217391304348, 0
18878, 1.395652173913, 0.77608695652174, 0
18879, 1.4608695652174, 0.80217391304348, 0
18880, 1.4391304347826, 0.77608695652174, 0
18881, 1.504347826087, 0.80217391304348, 0
18882, 1.4826086956522, 0.77608695652174, 0
18883, 1.5478260869565, 0.80217391304348, 0
18884, 1.5260869565217, 0.77608695652174, 0
18885, 1.5913043478261, 0.80217391304348, 0
18886, 1.5695652173913, 0.77608695652174, 0
18887, 1.6347826086957, 0.80217391304348, 0
18888, 1.6130434782609, 0.77608695652174, 0
18889, 1.6782608695652, 0.80217391304348, 0
18890, 1.6565217391304, 0.77608695652174, 0
18891, 1.7217391304348, 0.80217391304348, 0
18892, 1.7, 0.77608695652174, 0
18893, 1.7652173913043, 0.80217391304348, 0
18894, 1.7434782608696, 0.77608695652174, 0
18895, 1.8086956521739, 0.80217391304348, 0
18896, 1.7869565217391, 0.77608695652174, 0
18897, 1.8521739130435, 0.80217391304348, 0
18898, 1.8304347826087, 0.77608695652174, 0
18899, 1.895652173913, 0.80217391304348, 0
18900, 1.8739130434783, 0.77608695652174, 0
18901, 1.9391304347826, 0.80217391304348, 0
18902, 1.9173913043478, 0.77608695652174, 0
18903, 1.9826086956522, 0.80217391304348, 0
18904, 1.9608695652174, 0.77608695652174, 0
18905, 2.0260869565217, 0.80217391304348, 0
18906, 2.004347826087, 0.77608695652174, 0
18907, 2.0695652173913, 0.80217391304348, 0
18908, 2.0478260869565, 0.77608695652174, 0
18909, 2.1130434782609, 0.80217391304348, 0
18910, 2.0913043478261, 0.77608695652174, 0
18911, 2.1565217391304, 0.80217391304348, 0
18912, 2.1347826086957, 0.77608695652174, 0
18913, 2.1782608695652, 0.77608695652174, 0
18914, 1.2434782608696, 0.75, 0
18915, 1.2217391304348, 0.72391304347826, 0
18916, 1.2869565217391, 0.75, 0
18917, 1.2652173913043, 0.72391304347826, 0
18918, 1.3304347826087, 0.75, 0
18919, 1.3086956521739, 0.72391304347826, 0
18920, 1.3739130434783, 0.75, 0
18921, 1.3521739130435, 0.72391304347826, 0
18922, 1.4173913043478, 0.75, 0
18923, 1.395652173913, 0.72391304347826, 0
18924, 1.4608695652174, 0.75, 0
18925, 1.4391304347826, 0.72391304347826, 0
18926, 1.504347826087, 0.75, 0
18927, 1.4826086956522, 0.72391304347826, 0
18928, 1.5478260869565, 0.75, 0
18929, 1.5260869565217, 0.72391304347826, 0
18930, 1.5913043478261, 0.75, 0
18931, 1.5695652173913, 0.72391304347826, 0
18932, 1.6347826086957, 0.75, 0
18933, 1.6130434782609, 0.72391304347826, 0
18934, 1.6782608695652, 0.75, 0
18935, 1.6565217391304, 0.72391304347826, 0
18936, 1.7217391304348, 0.75, 0
18937, 1.7, 0.72391304347826, 0
18938, 1.7652173913043, 0.75, 0
18939, 1.7434782608696, 0.72391304347826, 0
18940, 1.8086956521739, 0.75, 0
18941, 1.7869565217391, 0.72391304347826, 0
18942, 1.8521739130435, 0.75, 0
18943, 1.8304347826087, 0.72391304347826, 0
18944, 1.895652173913, 0.75, 0
18945, 1.8739130434783, 0.72391304347826, 0
18946, 1.9391304347826, 0.75, 0
18947, 1.9173913043478, 0.72391304347826, 0
18948, 1.9826086956522, 0.75, 0
18949, 1.9608695652174, 0.72391304347826, 0
18950, 2.0260869565217, 0.75, 0
18951, 2.004347826087, 0.72391304347826, 0
18952, 2.0695652173913, 0.75, 0
18953, 2.0478260869565, 0.72391304347826, 0
18954, 2.1130434782609, 0.75, 0
18955, 2.0913043478261, 0.72391304347826, 0
18956, 2.1565217391304, 0.75, 0
18957, 2.1347826086957, 0.72391304347826, 0
18958, 2.1782608695652, 0.72391304347826, 0
18959, 1.2434782608696, 0.69782608695652, 0
18960, 1.2217391304348, 0.67173913043478, 0
18961, 1.2869565217391, 0.69782608695652, 0
18962, 1.2652173913043, 0.67173913043478, 0
18963, 1.3304347826087, 0.69782608695652, 0
18964, 1.3086956521739, 0.67173913043478, 0
18965, 1.3739130434783, 0.69782608695652, 0
18966, 1.3521739130435, 0.67173913043478, 0
18967, 1.4173913043478, 0.69782608695652, 0
18968, 1.395652173913, 0.67173913043478, 0
18969, 1.4608695652174, 0.69782608695652, 0
18970, 1.4391304347826, 0.67173913043478, 0
18971, 1.504347826087, 0.69782608695652, 0
18972, 1.4826086956522, 0.67173913043478, 0
18973, 1.5478260869565, 0.69782608695652, 0
18974, 1.5260869565217, 0.67173913043478, 0
18975, 1.5913043478261, 0.69782608695652, 0
18976, 1.5695652173913, 0.67173913043478, 0
18977, 1.6347826086957, 0.69782608695652, 0
18978, 1.6130434782609, 0.67173913043478, 0
18979, 1.6782608695652, 0.69782608695652, 0
18980, 1.6565217391304, 0.67173913043478, 0
18981, 1.7217391304348, 0.69782608695652, 0
18982, 1.7, 0.67173913043478, 0
18983, 1.7652173913043, 0.69782608695652, 0
18984, 1.7434782608696, 0.67173913043478, 0
18985, 1.8086956521739, 0.69782608695652, 0
18986, 1.7869565217391, 0.67173913043478, 0
18987, 1.8521739130435, 0.69782608695652, 0
18988, 1.8304347826087, 0.67173913043478, 0
18989, 1.895652173913, 0.69782608695652, 0
18990, 1.8739130434783, 0.67173913043478, 0
18991, 1.9391304347826, 0.69782608695652, 0
18992, 1.9173913043478, 0.67173913043478, 0
18993, 1.9826086956522, 0.69782608695652, 0
18994, 1.9608695652174, 0.67173913043478, 0
18995, 2.0260869565217, 0.69782608695652, 0
18996, 2.004347826087, 0.67173913043478, 0
18997, 2.0695652173913, 0.69782608695652, 0
18998, 2.0478260869565, 0.67173913043478, 0
18999, 2.1130434782609, 0.69782608695652, 0
19000, 2.0913043478261, 0.67173913043478, 0
19001, 2.1565217391304, 0.69782608695652, 0
19002, 2.1347826086957, 0.67173913043478, 0
19003, 2.1782608695652, 0.67173913043478, 0
19004, 1.2434782608696, 0.64565217391304, 0
19005, 1.2217391304348, 0.61956521739131, 0
19006, 1.2869565217391, 0.64565217391304, 0
19007, 1.2652173913043, 0.61956521739131, 0
19008, 1.3304347826087, 0.64565217391304, 0
19009, 1.3086956521739, 0.61956521739131, 0
19010, 1.3739130434783, 0.64565217391304, 0
19011, 1.3521739130435, 0.61956521739131, 0
19012, 1.4173913043478, 0.64565217391304, 0
19013, 1.395652173913, 0.61956521739131, 0
19014, 1.4608695652174, 0.64565217391304, 0
19015, 1.4391304347826, 0.61956521739131, 0
19016, 1.504347826087, 0.64565217391304, 0
19017, 1.4826086956522, 0.61956521739131, 0
19018, 1.5478260869565, 0.64565217391304, 0
19019, 1.5260869565217, 0.61956521739131, 0
19020, 1.5913043478261, 0.64565217391304, 0
19021, 1.5695652173913, 0.61956521739131, 0
19022, 1.6347826086957, 0.64565217391304, 0
19023, 1.6130434782609, 0.61956521739131, 0
19024, 1.6782608695652, 0.64565217391304, 0
19025, 1.6565217391304, 0.61956521739131, 0
19026, 1.7217391304348, 0.64565217391304, 0
19027, 1.7, 0.61956521739131, 0
19028, 1.7652173913043, 0.64565217391304, 0
19029, 1.7434782608696, 0.61956521739131, 0
19030, 1.8086956521739, 0.64565217391304, 0
19031, 1.7869565217391, 0.61956521739131, 0
19032, 1.8521739130435, 0.64565217391304, 0
19033, 1.8304347826087, 0.61956521739131, 0
19034, 1.895652173913, 0.64565217391304, 0
19035, 1.8739130434783, 0.61956521739131, 0
19036, 1.9391304347826, 0.64565217391304, 0
19037, 1.9173913043478, 0.61956521739131, 0
19038, 1.9826086956522, 0.64565217391304, 0
19039, 1.9608695652174, 0.61956521739131, 0
19040, 2.0260869565217, 0.64565217391304, 0
19041, 2.004347826087, 0.61956521739131, 0
19042, 2.0695652173913, 0.64565217391304, 0
19043, 2.0478260869565, 0.61956521739131, 0
19044, 2.1130434782609, 0.64565217391304, 0
19045, 2.0913043478261, 0.61956521739131, 0
19046, 2.1565217391304, 0.64565217391304, 0
19047, 2.1347826086957, 0.61956521739131, 0
19048, 2.1782608695652, 0.61956521739131, 0
19049, 1.2434782608696, 0.59347826086957, 0
19050, 1.2217391304348, 0.56739130434783, 0
19051, 1.2869565217391, 0.59347826086957, 0
19052, 1.2652173913043, 0.56739130434783, 0
19053, 1.3304347826087, 0.59347826086957, 0
19054, 1.3086956521739, 0.56739130434783, 0
19055, 1.3739130434783, 0.59347826086957, 0
19056, 1.3521739130435, 0.56739130434783, 0
19057, 1.4173913043478, 0.59347826086957, 0
19058, 1.395652173913, 0.56739130434783, 0
19059, 1.4608695652174, 0.59347826086957, 0
19060, 1.4391304347826, 0.56739130434783, 0
19061, 1.504347826087, 0.59347826086957, 0
19062, 1.4826086956522, 0.56739130434783, 0
19063, 1.5478260869565, 0.59347826086957, 0
19064, 1.5260869565217, 0.56739130434783, 0
19065, 1.5913043478261, 0.59347826086957, 0
19066, 1.5695652173913, 0.56739130434783, 0
19067, 1.6347826086957, 0.59347826086957, 0
19068, 1.6130434782609, 0.56739130434783, 0
19069, 1.6782608695652, 0.59347826086957, 0
19070, 1.6565217391304, 0.56739130434783, 0
19071, 1.7217391304348, 0.59347826086957, 0
19072, 1.7, 0.56739130434783, 0
19073, 1.7652173913043, 0.59347826086957, 0
19074, 1.7434782608696, 0.56739130434783, 0
19075, 1.8086956521739, 0.59347826086957, 0
19076, 1.7869565217391, 0.56739130434783, 0
19077, 1.8521739130435, 0.59347826086957, 0
19078, 1.8304347826087, 0.56739130434783, 0
19079, 1.895652173913, 0.59347826086957, 0
19080, 1.8739130434783, 0.56739130434783, 0
19081, 1.9391304347826, 0.59347826086957, 0
19082, 1.9173913043478, 0.56739130434783, 0
19083, 1.9826086956522, 0.59347826086957, 0
19084, 1.9608695652174, 0.56739130434783, 0
19085, 2.0260869565217, 0.59347826086957, 0
19086, 2.004347826087, 0.56739130434783, 0
19087, 2.0695652173913, 0.59347826086957, 0
19088, 2.0478260869565, 0.56739130434783, 0
19089, 2.1130434782609, 0.59347826086957, 0
19090, 2.0913043478261, 0.56739130434783, 0
19091, 2.1565217391304, 0.59347826086957, 0
19092, 2.1347826086957, 0.56739130434783, 0
19093, 2.1782608695652, 0.56739130434783, 0
19094, 1.2434782608696, 0.54130434782609, 0
19095, 1.2217391304348, 0.51521739130435, 0
19096, 1.2869565217391, 0.54130434782609, 0
19097, 1.2652173913043, 0.51521739130435, 0
19098, 1.3304347826087, 0.54130434782609, 0
19099, 1.3086956521739, 0.51521739130435, 0
19100, 1.3739130434783, 0.54130434782609, 0
19101, 1.3521739130435, 0.51521739130435, 0
19102, 1.4173913043478, 0.54130434782609, 0
19103, 1.395652173913, 0.51521739130435, 0
19104, 1.4608695652174, 0.54130434782609, 0
19105, 1.4391304347826, 0.51521739130435, 0
19106, 1.504347826087, 0.54130434782609, 0
19107, 1.4826086956522, 0.51521739130435, 0
19108, 1.5478260869565, 0.54130434782609, 0
19109, 1.5260869565217, 0.51521739130435, 0
19110, 1.5913043478261, 0.54130434782609, 0
19111, 1.5695652173913, 0.51521739130435, 0
19112, 1.6347826086957, 0.54130434782609, 0
19113, 1.6130434782609, 0.51521739130435, 0
19114, 1.6782608695652, 0.54130434782609, 0
19115, 1.6565217391304, 0.51521739130435, 0
19116, 1.7217391304348, 0.54130434782609, 0
19117, 1.7, 0.51521739130435, 0
19118, 1.7652173913043, 0.54130434782609, 0
19119, 1.7434782608696, 0.51521739130435, 0
19120, 1.8086956521739, 0.54130434782609, 0
19121, 1.7869565217391, 0.51521739130435, 0
19122, 1.8521739130435, 0.54130434782609, 0
19123, 1.8304347826087, 0.51521739130435, 0
19124, 1.895652173913, 0.54130434782609, 0
19125, 1.8739130434783, 0.51521739130435, 0
19126, 1.9391304347826, 0.54130434782609, 0
19127, 1.9173913043478, 0.51521739130435, 0
19128, 1.9826086956522, 0.54130434782609, 0
19129, 1.9608695652174, 0.51521739130435, 0
19130, 2.0260869565217, 0.54130434782609, 0
19131, 2.004347826087, 0.51521739130435, 0
19132, 2.0695652173913, 0.54130434782609, 0
19133, 2.0478260869565, 0.51521739130435, 0
19134, 2.1130434782609, 0.54130434782609, 0
19135, 2.0913043478261, 0.51521739130435, 0
19136, 2.1565217391304, 0.54130434782609, 0
19137, 2.1347826086957, 0.51521739130435, 0
19138, 2.1782608695652, 0.51521739130435, 0
19139, 1.2434782608696, 0.48913043478261, 0
19140, 1.2217391304348, 0.46304347826087, 0
19141, 1.2869565217391, 0.48913043478261, 0
19142, 1.2652173913043, 0.46304347826087, 0
19143, 1.3304347826087, 0.48913043478261, 0
19144, 1.3086956521739, 0.46304347826087, 0
19145, 1.3739130434783, 0.48913043478261, 0
19146, 1.3521739130435, 0.46304347826087, 0
19147, 1.4173913043478, 0.48913043478261, 0
19148, 1.395652173913, 0.46304347826087, 0
19149, 1.4608695652174, 0.48913043478261, 0
19150, 1.4391304347826, 0.46304347826087, 0
19151, 1.504347826087, 0.48913043478261, 0
19152, 1.4826086956522, 0.46304347826087, 0
19153, 1.5478260869565, 0.48913043478261, 0
19154, 1.5260869565217, 0.46304347826087, 0
19155, 1.5913043478261, 0.48913043478261, 0
19156, 1.5695652173913, 0.46304347826087, 0
19157, 1.6347826086957, 0.48913043478261, 0
19158, 1.6130434782609, 0.46304347826087, 0
19159, 1.6782608695652, 0.48913043478261, 0
19160, 1.6565217391304, 0.46304347826087, 0
19161, 1.7217391304348, 0.48913043478261, 0
19162, 1.7, 0.46304347826087, 0
19163, 1.7652173913043, 0.48913043478261, 0
19164, 1.7434782608696, 0.46304347826087, 0
19165, 1.8086956521739, 0.48913043478261, 0
19166, 1.7869565217391, 0.46304347826087, 0
19167, 1.8521739130435, 0.48913043478261, 0
19168, 1.8304347826087, 0.46304347826087, 0
19169, 1.895652173913, 0.48913043478261, 0
19170, 1.8739130434783, 0.46304347826087, 0
19171, 1.9391304347826, 0.48913043478261, 0
19172, 1.9173913043478, 0.46304347826087, 0
19173, 1.9826086956522, 0.48913043478261, 0
19174, 1.9608695652174, 0.46304347826087, 0
19175, 2.0260869565217, 0.48913043478261, 0
19176, 2.004347826087, 0.46304347826087, 0
19177, 2.0695652173913, 0.48913043478261, 0
19178, 2.0478260869565, 0.46304347826087, 0
19179, 2.1130434782609, 0.48913043478261, 0
19180, 2.0913043478261, 0.46304347826087, 0
19181, 2.1565217391304, 0.48913043478261, 0
19182, 2.1347826086957, 0.46304347826087, 0
19183, 2.1782608695652, 0.46304347826087, 0
19184, 1.2434782608696, 0.43695652173913, 0
19185, 1.2217391304348, 0.41086956521739, 0
19186, 1.2869565217391, 0.43695652173913, 0
19187, 1.2652173913043, 0.41086956521739, 0
19188, 1.3304347826087, 0.43695652173913, 0
19189, 1.3086956521739, 0.41086956521739, 0
19190, 1.3739130434783, 0.43695652173913, 0
19191, 1.3521739130435, 0.41086956521739, 0
19192, 1.4173913043478, 0.43695652173913, 0
19193, 1.395652173913, 0.41086956521739, 0
19194, 1.4608695652174, 0.43695652173913, 0
19195, 1.4391304347826, 0.41086956521739, 0
19196, 1.504347826087, 0.43695652173913, 0
19197, 1.4826086956522, 0.41086956521739, 0
19198, 1.5478260869565, 0.43695652173913, 0
