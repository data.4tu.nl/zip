76206, 1.2869565217391, 0.59347826086957, 0.27272727272727
76207, 1.2869565217391, 0.56739130434783, 0.25
76208, 1.2652173913043, 0.56739130434783, 0.22727272727273
76209, 1.2869565217391, 0.59347826086957, 0.22727272727273
76210, 1.2869565217391, 0.56739130434783, 0.20454545454545
76211, 1.2652173913043, 0.56739130434783, 0.18181818181818
76212, 1.2869565217391, 0.59347826086957, 0.18181818181818
76213, 1.2869565217391, 0.56739130434783, 0.15909090909091
76214, 1.2652173913043, 0.56739130434783, 0.13636363636364
76215, 1.2869565217391, 0.59347826086957, 0.13636363636364
76216, 1.2869565217391, 0.56739130434783, 0.11363636363636
76217, 1.2652173913043, 0.56739130434783, 0.090909090909091
76218, 1.2869565217391, 0.59347826086957, 0.090909090909091
76219, 1.2869565217391, 0.56739130434783, 0.068181818181818
76220, 1.2652173913043, 0.56739130434783, 0.045454545454545
76221, 1.2869565217391, 0.59347826086957, 0.045454545454545
76222, 1.2869565217391, 0.56739130434783, 0.022727272727273
76223, 1.3304347826087, 0.56739130434783, 0.47727272727273
76224, 1.3086956521739, 0.56739130434783, 0.45454545454545
76225, 1.3304347826087, 0.59347826086957, 0.45454545454545
76226, 1.3304347826087, 0.56739130434783, 0.43181818181818
76227, 1.3086956521739, 0.56739130434783, 0.40909090909091
76228, 1.3304347826087, 0.59347826086957, 0.40909090909091
76229, 1.3304347826087, 0.56739130434783, 0.38636363636364
76230, 1.3086956521739, 0.56739130434783, 0.36363636363636
76231, 1.3304347826087, 0.59347826086957, 0.36363636363636
76232, 1.3304347826087, 0.56739130434783, 0.34090909090909
76233, 1.3086956521739, 0.56739130434783, 0.31818181818182
76234, 1.3304347826087, 0.59347826086957, 0.31818181818182
76235, 1.3304347826087, 0.56739130434783, 0.29545454545455
76236, 1.3086956521739, 0.56739130434783, 0.27272727272727
76237, 1.3304347826087, 0.59347826086957, 0.27272727272727
76238, 1.3304347826087, 0.56739130434783, 0.25
76239, 1.3086956521739, 0.56739130434783, 0.22727272727273
76240, 1.3304347826087, 0.59347826086957, 0.22727272727273
76241, 1.3304347826087, 0.56739130434783, 0.20454545454545
76242, 1.3086956521739, 0.56739130434783, 0.18181818181818
76243, 1.3304347826087, 0.59347826086957, 0.18181818181818
76244, 1.3304347826087, 0.56739130434783, 0.15909090909091
76245, 1.3086956521739, 0.56739130434783, 0.13636363636364
76246, 1.3304347826087, 0.59347826086957, 0.13636363636364
76247, 1.3304347826087, 0.56739130434783, 0.11363636363636
76248, 1.3086956521739, 0.56739130434783, 0.090909090909091
76249, 1.3304347826087, 0.59347826086957, 0.090909090909091
76250, 1.3304347826087, 0.56739130434783, 0.068181818181818
76251, 1.3086956521739, 0.56739130434783, 0.045454545454545
76252, 1.3304347826087, 0.59347826086957, 0.045454545454545
76253, 1.3304347826087, 0.56739130434783, 0.022727272727273
76254, 1.3739130434783, 0.56739130434783, 0.47727272727273
76255, 1.3521739130435, 0.56739130434783, 0.45454545454545
76256, 1.3739130434783, 0.59347826086957, 0.45454545454545
76257, 1.3739130434783, 0.56739130434783, 0.43181818181818
76258, 1.3521739130435, 0.56739130434783, 0.40909090909091
76259, 1.3739130434783, 0.59347826086957, 0.40909090909091
76260, 1.3739130434783, 0.56739130434783, 0.38636363636364
76261, 1.3521739130435, 0.56739130434783, 0.36363636363636
76262, 1.3739130434783, 0.59347826086957, 0.36363636363636
76263, 1.3739130434783, 0.56739130434783, 0.34090909090909
76264, 1.3521739130435, 0.56739130434783, 0.31818181818182
76265, 1.3739130434783, 0.59347826086957, 0.31818181818182
76266, 1.3739130434783, 0.56739130434783, 0.29545454545455
76267, 1.3521739130435, 0.56739130434783, 0.27272727272727
76268, 1.3739130434783, 0.59347826086957, 0.27272727272727
76269, 1.3739130434783, 0.56739130434783, 0.25
76270, 1.3521739130435, 0.56739130434783, 0.22727272727273
76271, 1.3739130434783, 0.59347826086957, 0.22727272727273
76272, 1.3739130434783, 0.56739130434783, 0.20454545454545
76273, 1.3521739130435, 0.56739130434783, 0.18181818181818
76274, 1.3739130434783, 0.59347826086957, 0.18181818181818
76275, 1.3739130434783, 0.56739130434783, 0.15909090909091
76276, 1.3521739130435, 0.56739130434783, 0.13636363636364
76277, 1.3739130434783, 0.59347826086957, 0.13636363636364
76278, 1.3739130434783, 0.56739130434783, 0.11363636363636
76279, 1.3521739130435, 0.56739130434783, 0.090909090909091
76280, 1.3739130434783, 0.59347826086957, 0.090909090909091
76281, 1.3739130434783, 0.56739130434783, 0.068181818181818
76282, 1.3521739130435, 0.56739130434783, 0.045454545454545
76283, 1.3739130434783, 0.59347826086957, 0.045454545454545
76284, 1.3739130434783, 0.56739130434783, 0.022727272727273
76285, 1.4173913043478, 0.56739130434783, 0.47727272727273
76286, 1.395652173913, 0.56739130434783, 0.45454545454545
76287, 1.4173913043478, 0.59347826086957, 0.45454545454545
76288, 1.4173913043478, 0.56739130434783, 0.43181818181818
76289, 1.395652173913, 0.56739130434783, 0.40909090909091
76290, 1.4173913043478, 0.59347826086957, 0.40909090909091
76291, 1.4173913043478, 0.56739130434783, 0.38636363636364
76292, 1.395652173913, 0.56739130434783, 0.36363636363636
76293, 1.4173913043478, 0.59347826086957, 0.36363636363636
76294, 1.4173913043478, 0.56739130434783, 0.34090909090909
76295, 1.395652173913, 0.56739130434783, 0.31818181818182
76296, 1.4173913043478, 0.59347826086957, 0.31818181818182
76297, 1.4173913043478, 0.56739130434783, 0.29545454545455
76298, 1.395652173913, 0.56739130434783, 0.27272727272727
76299, 1.4173913043478, 0.59347826086957, 0.27272727272727
76300, 1.4173913043478, 0.56739130434783, 0.25
76301, 1.395652173913, 0.56739130434783, 0.22727272727273
76302, 1.4173913043478, 0.59347826086957, 0.22727272727273
76303, 1.4173913043478, 0.56739130434783, 0.20454545454545
76304, 1.395652173913, 0.56739130434783, 0.18181818181818
76305, 1.4173913043478, 0.59347826086957, 0.18181818181818
76306, 1.4173913043478, 0.56739130434783, 0.15909090909091
76307, 1.395652173913, 0.56739130434783, 0.13636363636364
76308, 1.4173913043478, 0.59347826086957, 0.13636363636364
76309, 1.4173913043478, 0.56739130434783, 0.11363636363636
76310, 1.395652173913, 0.56739130434783, 0.090909090909091
76311, 1.4173913043478, 0.59347826086957, 0.090909090909091
76312, 1.4173913043478, 0.56739130434783, 0.068181818181818
76313, 1.395652173913, 0.56739130434783, 0.045454545454545
76314, 1.4173913043478, 0.59347826086957, 0.045454545454545
76315, 1.4173913043478, 0.56739130434783, 0.022727272727273
76316, 1.4608695652174, 0.56739130434783, 0.47727272727273
76317, 1.4391304347826, 0.56739130434783, 0.45454545454545
76318, 1.4608695652174, 0.59347826086957, 0.45454545454545
76319, 1.4608695652174, 0.56739130434783, 0.43181818181818
76320, 1.4391304347826, 0.56739130434783, 0.40909090909091
76321, 1.4608695652174, 0.59347826086957, 0.40909090909091
76322, 1.4608695652174, 0.56739130434783, 0.38636363636364
76323, 1.4391304347826, 0.56739130434783, 0.36363636363636
76324, 1.4608695652174, 0.59347826086957, 0.36363636363636
76325, 1.4608695652174, 0.56739130434783, 0.34090909090909
76326, 1.4391304347826, 0.56739130434783, 0.31818181818182
76327, 1.4608695652174, 0.59347826086957, 0.31818181818182
76328, 1.4608695652174, 0.56739130434783, 0.29545454545455
76329, 1.4391304347826, 0.56739130434783, 0.27272727272727
76330, 1.4608695652174, 0.59347826086957, 0.27272727272727
76331, 1.4608695652174, 0.56739130434783, 0.25
76332, 1.4391304347826, 0.56739130434783, 0.22727272727273
76333, 1.4608695652174, 0.59347826086957, 0.22727272727273
76334, 1.4608695652174, 0.56739130434783, 0.20454545454545
76335, 1.4391304347826, 0.56739130434783, 0.18181818181818
76336, 1.4608695652174, 0.59347826086957, 0.18181818181818
76337, 1.4608695652174, 0.56739130434783, 0.15909090909091
76338, 1.4391304347826, 0.56739130434783, 0.13636363636364
76339, 1.4608695652174, 0.59347826086957, 0.13636363636364
76340, 1.4608695652174, 0.56739130434783, 0.11363636363636
76341, 1.4391304347826, 0.56739130434783, 0.090909090909091
76342, 1.4608695652174, 0.59347826086957, 0.090909090909091
76343, 1.4608695652174, 0.56739130434783, 0.068181818181818
76344, 1.4391304347826, 0.56739130434783, 0.045454545454545
76345, 1.4608695652174, 0.59347826086957, 0.045454545454545
76346, 1.4608695652174, 0.56739130434783, 0.022727272727273
76347, 1.504347826087, 0.56739130434783, 0.47727272727273
76348, 1.4826086956522, 0.56739130434783, 0.45454545454545
76349, 1.504347826087, 0.59347826086957, 0.45454545454545
76350, 1.504347826087, 0.56739130434783, 0.43181818181818
76351, 1.4826086956522, 0.56739130434783, 0.40909090909091
76352, 1.504347826087, 0.59347826086957, 0.40909090909091
76353, 1.504347826087, 0.56739130434783, 0.38636363636364
76354, 1.4826086956522, 0.56739130434783, 0.36363636363636
76355, 1.504347826087, 0.59347826086957, 0.36363636363636
76356, 1.504347826087, 0.56739130434783, 0.34090909090909
76357, 1.4826086956522, 0.56739130434783, 0.31818181818182
76358, 1.504347826087, 0.59347826086957, 0.31818181818182
76359, 1.504347826087, 0.56739130434783, 0.29545454545455
76360, 1.4826086956522, 0.56739130434783, 0.27272727272727
76361, 1.504347826087, 0.59347826086957, 0.27272727272727
76362, 1.504347826087, 0.56739130434783, 0.25
76363, 1.4826086956522, 0.56739130434783, 0.22727272727273
76364, 1.504347826087, 0.59347826086957, 0.22727272727273
76365, 1.504347826087, 0.56739130434783, 0.20454545454545
76366, 1.4826086956522, 0.56739130434783, 0.18181818181818
76367, 1.504347826087, 0.59347826086957, 0.18181818181818
76368, 1.504347826087, 0.56739130434783, 0.15909090909091
76369, 1.4826086956522, 0.56739130434783, 0.13636363636364
76370, 1.504347826087, 0.59347826086957, 0.13636363636364
76371, 1.504347826087, 0.56739130434783, 0.11363636363636
76372, 1.4826086956522, 0.56739130434783, 0.090909090909091
76373, 1.504347826087, 0.59347826086957, 0.090909090909091
76374, 1.504347826087, 0.56739130434783, 0.068181818181818
76375, 1.4826086956522, 0.56739130434783, 0.045454545454545
76376, 1.504347826087, 0.59347826086957, 0.045454545454545
76377, 1.504347826087, 0.56739130434783, 0.022727272727273
76378, 1.5478260869565, 0.56739130434783, 0.47727272727273
76379, 1.5260869565217, 0.56739130434783, 0.45454545454545
76380, 1.5478260869565, 0.59347826086957, 0.45454545454545
76381, 1.5478260869565, 0.56739130434783, 0.43181818181818
76382, 1.5260869565217, 0.56739130434783, 0.40909090909091
76383, 1.5478260869565, 0.59347826086957, 0.40909090909091
76384, 1.5478260869565, 0.56739130434783, 0.38636363636364
76385, 1.5260869565217, 0.56739130434783, 0.36363636363636
76386, 1.5478260869565, 0.59347826086957, 0.36363636363636
76387, 1.5478260869565, 0.56739130434783, 0.34090909090909
76388, 1.5260869565217, 0.56739130434783, 0.31818181818182
76389, 1.5478260869565, 0.59347826086957, 0.31818181818182
76390, 1.5478260869565, 0.56739130434783, 0.29545454545455
76391, 1.5260869565217, 0.56739130434783, 0.27272727272727
76392, 1.5478260869565, 0.59347826086957, 0.27272727272727
76393, 1.5478260869565, 0.56739130434783, 0.25
76394, 1.5260869565217, 0.56739130434783, 0.22727272727273
76395, 1.5478260869565, 0.59347826086957, 0.22727272727273
76396, 1.5478260869565, 0.56739130434783, 0.20454545454545
76397, 1.5260869565217, 0.56739130434783, 0.18181818181818
76398, 1.5478260869565, 0.59347826086957, 0.18181818181818
76399, 1.5478260869565, 0.56739130434783, 0.15909090909091
76400, 1.5260869565217, 0.56739130434783, 0.13636363636364
76401, 1.5478260869565, 0.59347826086957, 0.13636363636364
76402, 1.5478260869565, 0.56739130434783, 0.11363636363636
76403, 1.5260869565217, 0.56739130434783, 0.090909090909091
76404, 1.5478260869565, 0.59347826086957, 0.090909090909091
76405, 1.5478260869565, 0.56739130434783, 0.068181818181818
76406, 1.5260869565217, 0.56739130434783, 0.045454545454545
76407, 1.5478260869565, 0.59347826086957, 0.045454545454545
76408, 1.5478260869565, 0.56739130434783, 0.022727272727273
76409, 1.5913043478261, 0.56739130434783, 0.47727272727273
76410, 1.5695652173913, 0.56739130434783, 0.45454545454545
76411, 1.5913043478261, 0.59347826086957, 0.45454545454545
76412, 1.5913043478261, 0.56739130434783, 0.43181818181818
76413, 1.5695652173913, 0.56739130434783, 0.40909090909091
76414, 1.5913043478261, 0.59347826086957, 0.40909090909091
76415, 1.5913043478261, 0.56739130434783, 0.38636363636364
76416, 1.5695652173913, 0.56739130434783, 0.36363636363636
76417, 1.5913043478261, 0.59347826086957, 0.36363636363636
76418, 1.5913043478261, 0.56739130434783, 0.34090909090909
76419, 1.5695652173913, 0.56739130434783, 0.31818181818182
76420, 1.5913043478261, 0.59347826086957, 0.31818181818182
76421, 1.5913043478261, 0.56739130434783, 0.29545454545455
76422, 1.5695652173913, 0.56739130434783, 0.27272727272727
76423, 1.5913043478261, 0.59347826086957, 0.27272727272727
76424, 1.5913043478261, 0.56739130434783, 0.25
76425, 1.5695652173913, 0.56739130434783, 0.22727272727273
76426, 1.5913043478261, 0.59347826086957, 0.22727272727273
76427, 1.5913043478261, 0.56739130434783, 0.20454545454545
76428, 1.5695652173913, 0.56739130434783, 0.18181818181818
76429, 1.5913043478261, 0.59347826086957, 0.18181818181818
76430, 1.5913043478261, 0.56739130434783, 0.15909090909091
76431, 1.5695652173913, 0.56739130434783, 0.13636363636364
76432, 1.5913043478261, 0.59347826086957, 0.13636363636364
76433, 1.5913043478261, 0.56739130434783, 0.11363636363636
76434, 1.5695652173913, 0.56739130434783, 0.090909090909091
76435, 1.5913043478261, 0.59347826086957, 0.090909090909091
76436, 1.5913043478261, 0.56739130434783, 0.068181818181818
76437, 1.5695652173913, 0.56739130434783, 0.045454545454545
76438, 1.5913043478261, 0.59347826086957, 0.045454545454545
76439, 1.5913043478261, 0.56739130434783, 0.022727272727273
76440, 1.6347826086957, 0.56739130434783, 0.47727272727273
76441, 1.6130434782609, 0.56739130434783, 0.45454545454545
76442, 1.6347826086957, 0.59347826086957, 0.45454545454545
76443, 1.6347826086957, 0.56739130434783, 0.43181818181818
76444, 1.6130434782609, 0.56739130434783, 0.40909090909091
76445, 1.6347826086957, 0.59347826086957, 0.40909090909091
76446, 1.6347826086957, 0.56739130434783, 0.38636363636364
76447, 1.6130434782609, 0.56739130434783, 0.36363636363636
76448, 1.6347826086957, 0.59347826086957, 0.36363636363636
76449, 1.6347826086957, 0.56739130434783, 0.34090909090909
76450, 1.6130434782609, 0.56739130434783, 0.31818181818182
76451, 1.6347826086957, 0.59347826086957, 0.31818181818182
76452, 1.6347826086957, 0.56739130434783, 0.29545454545455
76453, 1.6130434782609, 0.56739130434783, 0.27272727272727
76454, 1.6347826086957, 0.59347826086957, 0.27272727272727
76455, 1.6347826086957, 0.56739130434783, 0.25
76456, 1.6130434782609, 0.56739130434783, 0.22727272727273
76457, 1.6347826086957, 0.59347826086957, 0.22727272727273
76458, 1.6347826086957, 0.56739130434783, 0.20454545454545
76459, 1.6130434782609, 0.56739130434783, 0.18181818181818
76460, 1.6347826086957, 0.59347826086957, 0.18181818181818
76461, 1.6347826086957, 0.56739130434783, 0.15909090909091
76462, 1.6130434782609, 0.56739130434783, 0.13636363636364
76463, 1.6347826086957, 0.59347826086957, 0.13636363636364
76464, 1.6347826086957, 0.56739130434783, 0.11363636363636
76465, 1.6130434782609, 0.56739130434783, 0.090909090909091
76466, 1.6347826086957, 0.59347826086957, 0.090909090909091
76467, 1.6347826086957, 0.56739130434783, 0.068181818181818
76468, 1.6130434782609, 0.56739130434783, 0.045454545454545
76469, 1.6347826086957, 0.59347826086957, 0.045454545454545
76470, 1.6347826086957, 0.56739130434783, 0.022727272727273
76471, 1.6782608695652, 0.56739130434783, 0.47727272727273
76472, 1.6565217391304, 0.56739130434783, 0.45454545454545
76473, 1.6782608695652, 0.59347826086957, 0.45454545454545
76474, 1.6782608695652, 0.56739130434783, 0.43181818181818
76475, 1.6565217391304, 0.56739130434783, 0.40909090909091
76476, 1.6782608695652, 0.59347826086957, 0.40909090909091
76477, 1.6782608695652, 0.56739130434783, 0.38636363636364
76478, 1.6565217391304, 0.56739130434783, 0.36363636363636
76479, 1.6782608695652, 0.59347826086957, 0.36363636363636
76480, 1.6782608695652, 0.56739130434783, 0.34090909090909
76481, 1.6565217391304, 0.56739130434783, 0.31818181818182
76482, 1.6782608695652, 0.59347826086957, 0.31818181818182
76483, 1.6782608695652, 0.56739130434783, 0.29545454545455
76484, 1.6565217391304, 0.56739130434783, 0.27272727272727
76485, 1.6782608695652, 0.59347826086957, 0.27272727272727
76486, 1.6782608695652, 0.56739130434783, 0.25
76487, 1.6565217391304, 0.56739130434783, 0.22727272727273
76488, 1.6782608695652, 0.59347826086957, 0.22727272727273
76489, 1.6782608695652, 0.56739130434783, 0.20454545454545
76490, 1.6565217391304, 0.56739130434783, 0.18181818181818
76491, 1.6782608695652, 0.59347826086957, 0.18181818181818
76492, 1.6782608695652, 0.56739130434783, 0.15909090909091
76493, 1.6565217391304, 0.56739130434783, 0.13636363636364
76494, 1.6782608695652, 0.59347826086957, 0.13636363636364
76495, 1.6782608695652, 0.56739130434783, 0.11363636363636
76496, 1.6565217391304, 0.56739130434783, 0.090909090909091
76497, 1.6782608695652, 0.59347826086957, 0.090909090909091
76498, 1.6782608695652, 0.56739130434783, 0.068181818181818
76499, 1.6565217391304, 0.56739130434783, 0.045454545454545
76500, 1.6782608695652, 0.59347826086957, 0.045454545454545
76501, 1.6782608695652, 0.56739130434783, 0.022727272727273
76502, 1.7217391304348, 0.56739130434783, 0.47727272727273
76503, 1.7, 0.56739130434783, 0.45454545454545
76504, 1.7217391304348, 0.59347826086957, 0.45454545454545
76505, 1.7217391304348, 0.56739130434783, 0.43181818181818
76506, 1.7, 0.56739130434783, 0.40909090909091
76507, 1.7217391304348, 0.59347826086957, 0.40909090909091
76508, 1.7217391304348, 0.56739130434783, 0.38636363636364
76509, 1.7, 0.56739130434783, 0.36363636363636
76510, 1.7217391304348, 0.59347826086957, 0.36363636363636
76511, 1.7217391304348, 0.56739130434783, 0.34090909090909
76512, 1.7, 0.56739130434783, 0.31818181818182
76513, 1.7217391304348, 0.59347826086957, 0.31818181818182
76514, 1.7217391304348, 0.56739130434783, 0.29545454545455
76515, 1.7, 0.56739130434783, 0.27272727272727
76516, 1.7217391304348, 0.59347826086957, 0.27272727272727
76517, 1.7217391304348, 0.56739130434783, 0.25
76518, 1.7, 0.56739130434783, 0.22727272727273
76519, 1.7217391304348, 0.59347826086957, 0.22727272727273
76520, 1.7217391304348, 0.56739130434783, 0.20454545454545
76521, 1.7, 0.56739130434783, 0.18181818181818
76522, 1.7217391304348, 0.59347826086957, 0.18181818181818
76523, 1.7217391304348, 0.56739130434783, 0.15909090909091
76524, 1.7, 0.56739130434783, 0.13636363636364
76525, 1.7217391304348, 0.59347826086957, 0.13636363636364
76526, 1.7217391304348, 0.56739130434783, 0.11363636363636
76527, 1.7, 0.56739130434783, 0.090909090909091
76528, 1.7217391304348, 0.59347826086957, 0.090909090909091
76529, 1.7217391304348, 0.56739130434783, 0.068181818181818
76530, 1.7, 0.56739130434783, 0.045454545454545
76531, 1.7217391304348, 0.59347826086957, 0.045454545454545
76532, 1.7217391304348, 0.56739130434783, 0.022727272727273
76533, 1.7652173913043, 0.56739130434783, 0.47727272727273
76534, 1.7434782608696, 0.56739130434783, 0.45454545454545
76535, 1.7652173913043, 0.59347826086957, 0.45454545454545
76536, 1.7652173913043, 0.56739130434783, 0.43181818181818
76537, 1.7434782608696, 0.56739130434783, 0.40909090909091
76538, 1.7652173913043, 0.59347826086957, 0.40909090909091
76539, 1.7652173913043, 0.56739130434783, 0.38636363636364
76540, 1.7434782608696, 0.56739130434783, 0.36363636363636
76541, 1.7652173913043, 0.59347826086957, 0.36363636363636
76542, 1.7652173913043, 0.56739130434783, 0.34090909090909
76543, 1.7434782608696, 0.56739130434783, 0.31818181818182
76544, 1.7652173913043, 0.59347826086957, 0.31818181818182
76545, 1.7652173913043, 0.56739130434783, 0.29545454545455
76546, 1.7434782608696, 0.56739130434783, 0.27272727272727
76547, 1.7652173913043, 0.59347826086957, 0.27272727272727
76548, 1.7652173913043, 0.56739130434783, 0.25
76549, 1.7434782608696, 0.56739130434783, 0.22727272727273
76550, 1.7652173913043, 0.59347826086957, 0.22727272727273
76551, 1.7652173913043, 0.56739130434783, 0.20454545454545
76552, 1.7434782608696, 0.56739130434783, 0.18181818181818
76553, 1.7652173913043, 0.59347826086957, 0.18181818181818
76554, 1.7652173913043, 0.56739130434783, 0.15909090909091
76555, 1.7434782608696, 0.56739130434783, 0.13636363636364
76556, 1.7652173913043, 0.59347826086957, 0.13636363636364
76557, 1.7652173913043, 0.56739130434783, 0.11363636363636
76558, 1.7434782608696, 0.56739130434783, 0.090909090909091
76559, 1.7652173913043, 0.59347826086957, 0.090909090909091
76560, 1.7652173913043, 0.56739130434783, 0.068181818181818
76561, 1.7434782608696, 0.56739130434783, 0.045454545454545
76562, 1.7652173913043, 0.59347826086957, 0.045454545454545
76563, 1.7652173913043, 0.56739130434783, 0.022727272727273
76564, 1.8086956521739, 0.56739130434783, 0.47727272727273
76565, 1.7869565217391, 0.56739130434783, 0.45454545454545
76566, 1.8086956521739, 0.59347826086957, 0.45454545454545
76567, 1.8086956521739, 0.56739130434783, 0.43181818181818
76568, 1.7869565217391, 0.56739130434783, 0.40909090909091
76569, 1.8086956521739, 0.59347826086957, 0.40909090909091
76570, 1.8086956521739, 0.56739130434783, 0.38636363636364
76571, 1.7869565217391, 0.56739130434783, 0.36363636363636
76572, 1.8086956521739, 0.59347826086957, 0.36363636363636
76573, 1.8086956521739, 0.56739130434783, 0.34090909090909
76574, 1.7869565217391, 0.56739130434783, 0.31818181818182
76575, 1.8086956521739, 0.59347826086957, 0.31818181818182
76576, 1.8086956521739, 0.56739130434783, 0.29545454545455
76577, 1.7869565217391, 0.56739130434783, 0.27272727272727
76578, 1.8086956521739, 0.59347826086957, 0.27272727272727
76579, 1.8086956521739, 0.56739130434783, 0.25
76580, 1.7869565217391, 0.56739130434783, 0.22727272727273
76581, 1.8086956521739, 0.59347826086957, 0.22727272727273
76582, 1.8086956521739, 0.56739130434783, 0.20454545454545
76583, 1.7869565217391, 0.56739130434783, 0.18181818181818
76584, 1.8086956521739, 0.59347826086957, 0.18181818181818
76585, 1.8086956521739, 0.56739130434783, 0.15909090909091
76586, 1.7869565217391, 0.56739130434783, 0.13636363636364
76587, 1.8086956521739, 0.59347826086957, 0.13636363636364
76588, 1.8086956521739, 0.56739130434783, 0.11363636363636
76589, 1.7869565217391, 0.56739130434783, 0.090909090909091
76590, 1.8086956521739, 0.59347826086957, 0.090909090909091
76591, 1.8086956521739, 0.56739130434783, 0.068181818181818
76592, 1.7869565217391, 0.56739130434783, 0.045454545454545
76593, 1.8086956521739, 0.59347826086957, 0.045454545454545
76594, 1.8086956521739, 0.56739130434783, 0.022727272727273
76595, 1.8521739130435, 0.56739130434783, 0.47727272727273
76596, 1.8304347826087, 0.56739130434783, 0.45454545454545
76597, 1.8521739130435, 0.59347826086957, 0.45454545454545
76598, 1.8521739130435, 0.56739130434783, 0.43181818181818
76599, 1.8304347826087, 0.56739130434783, 0.40909090909091
76600, 1.8521739130435, 0.59347826086957, 0.40909090909091
76601, 1.8521739130435, 0.56739130434783, 0.38636363636364
76602, 1.8304347826087, 0.56739130434783, 0.36363636363636
76603, 1.8521739130435, 0.59347826086957, 0.36363636363636
76604, 1.8521739130435, 0.56739130434783, 0.34090909090909
76605, 1.8304347826087, 0.56739130434783, 0.31818181818182
76606, 1.8521739130435, 0.59347826086957, 0.31818181818182
76607, 1.8521739130435, 0.56739130434783, 0.29545454545455
76608, 1.8304347826087, 0.56739130434783, 0.27272727272727
76609, 1.8521739130435, 0.59347826086957, 0.27272727272727
76610, 1.8521739130435, 0.56739130434783, 0.25
76611, 1.8304347826087, 0.56739130434783, 0.22727272727273
76612, 1.8521739130435, 0.59347826086957, 0.22727272727273
76613, 1.8521739130435, 0.56739130434783, 0.20454545454545
76614, 1.8304347826087, 0.56739130434783, 0.18181818181818
76615, 1.8521739130435, 0.59347826086957, 0.18181818181818
76616, 1.8521739130435, 0.56739130434783, 0.15909090909091
76617, 1.8304347826087, 0.56739130434783, 0.13636363636364
76618, 1.8521739130435, 0.59347826086957, 0.13636363636364
76619, 1.8521739130435, 0.56739130434783, 0.11363636363636
76620, 1.8304347826087, 0.56739130434783, 0.090909090909091
76621, 1.8521739130435, 0.59347826086957, 0.090909090909091
76622, 1.8521739130435, 0.56739130434783, 0.068181818181818
76623, 1.8304347826087, 0.56739130434783, 0.045454545454545
76624, 1.8521739130435, 0.59347826086957, 0.045454545454545
76625, 1.8521739130435, 0.56739130434783, 0.022727272727273
76626, 1.895652173913, 0.56739130434783, 0.47727272727273
76627, 1.8739130434783, 0.56739130434783, 0.45454545454545
76628, 1.895652173913, 0.59347826086957, 0.45454545454545
76629, 1.895652173913, 0.56739130434783, 0.43181818181818
76630, 1.8739130434783, 0.56739130434783, 0.40909090909091
76631, 1.895652173913, 0.59347826086957, 0.40909090909091
76632, 1.895652173913, 0.56739130434783, 0.38636363636364
76633, 1.8739130434783, 0.56739130434783, 0.36363636363636
76634, 1.895652173913, 0.59347826086957, 0.36363636363636
76635, 1.895652173913, 0.56739130434783, 0.34090909090909
76636, 1.8739130434783, 0.56739130434783, 0.31818181818182
76637, 1.895652173913, 0.59347826086957, 0.31818181818182
76638, 1.895652173913, 0.56739130434783, 0.29545454545455
76639, 1.8739130434783, 0.56739130434783, 0.27272727272727
76640, 1.895652173913, 0.59347826086957, 0.27272727272727
76641, 1.895652173913, 0.56739130434783, 0.25
76642, 1.8739130434783, 0.56739130434783, 0.22727272727273
76643, 1.895652173913, 0.59347826086957, 0.22727272727273
76644, 1.895652173913, 0.56739130434783, 0.20454545454545
76645, 1.8739130434783, 0.56739130434783, 0.18181818181818
76646, 1.895652173913, 0.59347826086957, 0.18181818181818
76647, 1.895652173913, 0.56739130434783, 0.15909090909091
76648, 1.8739130434783, 0.56739130434783, 0.13636363636364
76649, 1.895652173913, 0.59347826086957, 0.13636363636364
76650, 1.895652173913, 0.56739130434783, 0.11363636363636
76651, 1.8739130434783, 0.56739130434783, 0.090909090909091
76652, 1.895652173913, 0.59347826086957, 0.090909090909091
76653, 1.895652173913, 0.56739130434783, 0.068181818181818
76654, 1.8739130434783, 0.56739130434783, 0.045454545454545
76655, 1.895652173913, 0.59347826086957, 0.045454545454545
76656, 1.895652173913, 0.56739130434783, 0.022727272727273
76657, 1.9391304347826, 0.56739130434783, 0.47727272727273
76658, 1.9173913043478, 0.56739130434783, 0.45454545454545
76659, 1.9391304347826, 0.59347826086957, 0.45454545454545
76660, 1.9391304347826, 0.56739130434783, 0.43181818181818
76661, 1.9173913043478, 0.56739130434783, 0.40909090909091
76662, 1.9391304347826, 0.59347826086957, 0.40909090909091
76663, 1.9391304347826, 0.56739130434783, 0.38636363636364
76664, 1.9173913043478, 0.56739130434783, 0.36363636363636
76665, 1.9391304347826, 0.59347826086957, 0.36363636363636
76666, 1.9391304347826, 0.56739130434783, 0.34090909090909
76667, 1.9173913043478, 0.56739130434783, 0.31818181818182
76668, 1.9391304347826, 0.59347826086957, 0.31818181818182
76669, 1.9391304347826, 0.56739130434783, 0.29545454545455
76670, 1.9173913043478, 0.56739130434783, 0.27272727272727
76671, 1.9391304347826, 0.59347826086957, 0.27272727272727
76672, 1.9391304347826, 0.56739130434783, 0.25
76673, 1.9173913043478, 0.56739130434783, 0.22727272727273
76674, 1.9391304347826, 0.59347826086957, 0.22727272727273
76675, 1.9391304347826, 0.56739130434783, 0.20454545454545
76676, 1.9173913043478, 0.56739130434783, 0.18181818181818
76677, 1.9391304347826, 0.59347826086957, 0.18181818181818
76678, 1.9391304347826, 0.56739130434783, 0.15909090909091
76679, 1.9173913043478, 0.56739130434783, 0.13636363636364
76680, 1.9391304347826, 0.59347826086957, 0.13636363636364
76681, 1.9391304347826, 0.56739130434783, 0.11363636363636
76682, 1.9173913043478, 0.56739130434783, 0.090909090909091
76683, 1.9391304347826, 0.59347826086957, 0.090909090909091
76684, 1.9391304347826, 0.56739130434783, 0.068181818181818
76685, 1.9173913043478, 0.56739130434783, 0.045454545454545
76686, 1.9391304347826, 0.59347826086957, 0.045454545454545
76687, 1.9391304347826, 0.56739130434783, 0.022727272727273
76688, 1.9826086956522, 0.56739130434783, 0.47727272727273
76689, 1.9608695652174, 0.56739130434783, 0.45454545454545
76690, 1.9826086956522, 0.59347826086957, 0.45454545454545
76691, 1.9826086956522, 0.56739130434783, 0.43181818181818
76692, 1.9608695652174, 0.56739130434783, 0.40909090909091
76693, 1.9826086956522, 0.59347826086957, 0.40909090909091
76694, 1.9826086956522, 0.56739130434783, 0.38636363636364
76695, 1.9608695652174, 0.56739130434783, 0.36363636363636
76696, 1.9826086956522, 0.59347826086957, 0.36363636363636
76697, 1.9826086956522, 0.56739130434783, 0.34090909090909
76698, 1.9608695652174, 0.56739130434783, 0.31818181818182
76699, 1.9826086956522, 0.59347826086957, 0.31818181818182
76700, 1.9826086956522, 0.56739130434783, 0.29545454545455
76701, 1.9608695652174, 0.56739130434783, 0.27272727272727
76702, 1.9826086956522, 0.59347826086957, 0.27272727272727
76703, 1.9826086956522, 0.56739130434783, 0.25
76704, 1.9608695652174, 0.56739130434783, 0.22727272727273
76705, 1.9826086956522, 0.59347826086957, 0.22727272727273
76706, 1.9826086956522, 0.56739130434783, 0.20454545454545
76707, 1.9608695652174, 0.56739130434783, 0.18181818181818
76708, 1.9826086956522, 0.59347826086957, 0.18181818181818
76709, 1.9826086956522, 0.56739130434783, 0.15909090909091
76710, 1.9608695652174, 0.56739130434783, 0.13636363636364
76711, 1.9826086956522, 0.59347826086957, 0.13636363636364
76712, 1.9826086956522, 0.56739130434783, 0.11363636363636
76713, 1.9608695652174, 0.56739130434783, 0.090909090909091
76714, 1.9826086956522, 0.59347826086957, 0.090909090909091
76715, 1.9826086956522, 0.56739130434783, 0.068181818181818
76716, 1.9608695652174, 0.56739130434783, 0.045454545454545
76717, 1.9826086956522, 0.59347826086957, 0.045454545454545
76718, 1.9826086956522, 0.56739130434783, 0.022727272727273
76719, 2.0260869565217, 0.56739130434783, 0.47727272727273
76720, 2.004347826087, 0.56739130434783, 0.45454545454545
76721, 2.0260869565217, 0.59347826086957, 0.45454545454545
76722, 2.0260869565217, 0.56739130434783, 0.43181818181818
76723, 2.004347826087, 0.56739130434783, 0.40909090909091
76724, 2.0260869565217, 0.59347826086957, 0.40909090909091
76725, 2.0260869565217, 0.56739130434783, 0.38636363636364
76726, 2.004347826087, 0.56739130434783, 0.36363636363636
76727, 2.0260869565217, 0.59347826086957, 0.36363636363636
76728, 2.0260869565217, 0.56739130434783, 0.34090909090909
76729, 2.004347826087, 0.56739130434783, 0.31818181818182
76730, 2.0260869565217, 0.59347826086957, 0.31818181818182
76731, 2.0260869565217, 0.56739130434783, 0.29545454545455
76732, 2.004347826087, 0.56739130434783, 0.27272727272727
76733, 2.0260869565217, 0.59347826086957, 0.27272727272727
76734, 2.0260869565217, 0.56739130434783, 0.25
76735, 2.004347826087, 0.56739130434783, 0.22727272727273
76736, 2.0260869565217, 0.59347826086957, 0.22727272727273
76737, 2.0260869565217, 0.56739130434783, 0.20454545454545
76738, 2.004347826087, 0.56739130434783, 0.18181818181818
76739, 2.0260869565217, 0.59347826086957, 0.18181818181818
76740, 2.0260869565217, 0.56739130434783, 0.15909090909091
76741, 2.004347826087, 0.56739130434783, 0.13636363636364
76742, 2.0260869565217, 0.59347826086957, 0.13636363636364
76743, 2.0260869565217, 0.56739130434783, 0.11363636363636
76744, 2.004347826087, 0.56739130434783, 0.090909090909091
76745, 2.0260869565217, 0.59347826086957, 0.090909090909091
76746, 2.0260869565217, 0.56739130434783, 0.068181818181818
76747, 2.004347826087, 0.56739130434783, 0.045454545454545
76748, 2.0260869565217, 0.59347826086957, 0.045454545454545
76749, 2.0260869565217, 0.56739130434783, 0.022727272727273
76750, 2.0695652173913, 0.56739130434783, 0.47727272727273
76751, 2.0478260869565, 0.56739130434783, 0.45454545454545
76752, 2.0695652173913, 0.59347826086957, 0.45454545454545
76753, 2.0695652173913, 0.56739130434783, 0.43181818181818
76754, 2.0478260869565, 0.56739130434783, 0.40909090909091
76755, 2.0695652173913, 0.59347826086957, 0.40909090909091
76756, 2.0695652173913, 0.56739130434783, 0.38636363636364
76757, 2.0478260869565, 0.56739130434783, 0.36363636363636
76758, 2.0695652173913, 0.59347826086957, 0.36363636363636
76759, 2.0695652173913, 0.56739130434783, 0.34090909090909
76760, 2.0478260869565, 0.56739130434783, 0.31818181818182
76761, 2.0695652173913, 0.59347826086957, 0.31818181818182
76762, 2.0695652173913, 0.56739130434783, 0.29545454545455
76763, 2.0478260869565, 0.56739130434783, 0.27272727272727
76764, 2.0695652173913, 0.59347826086957, 0.27272727272727
76765, 2.0695652173913, 0.56739130434783, 0.25
76766, 2.0478260869565, 0.56739130434783, 0.22727272727273
76767, 2.0695652173913, 0.59347826086957, 0.22727272727273
76768, 2.0695652173913, 0.56739130434783, 0.20454545454545
76769, 2.0478260869565, 0.56739130434783, 0.18181818181818
76770, 2.0695652173913, 0.59347826086957, 0.18181818181818
76771, 2.0695652173913, 0.56739130434783, 0.15909090909091
76772, 2.0478260869565, 0.56739130434783, 0.13636363636364
76773, 2.0695652173913, 0.59347826086957, 0.13636363636364
76774, 2.0695652173913, 0.56739130434783, 0.11363636363636
76775, 2.0478260869565, 0.56739130434783, 0.090909090909091
76776, 2.0695652173913, 0.59347826086957, 0.090909090909091
76777, 2.0695652173913, 0.56739130434783, 0.068181818181818
76778, 2.0478260869565, 0.56739130434783, 0.045454545454545
76779, 2.0695652173913, 0.59347826086957, 0.045454545454545
76780, 2.0695652173913, 0.56739130434783, 0.022727272727273
76781, 2.1130434782609, 0.56739130434783, 0.47727272727273
76782, 2.0913043478261, 0.56739130434783, 0.45454545454545
76783, 2.1130434782609, 0.59347826086957, 0.45454545454545
76784, 2.1130434782609, 0.56739130434783, 0.43181818181818
76785, 2.0913043478261, 0.56739130434783, 0.40909090909091
76786, 2.1130434782609, 0.59347826086957, 0.40909090909091
76787, 2.1130434782609, 0.56739130434783, 0.38636363636364
76788, 2.0913043478261, 0.56739130434783, 0.36363636363636
76789, 2.1130434782609, 0.59347826086957, 0.36363636363636
76790, 2.1130434782609, 0.56739130434783, 0.34090909090909
76791, 2.0913043478261, 0.56739130434783, 0.31818181818182
76792, 2.1130434782609, 0.59347826086957, 0.31818181818182
76793, 2.1130434782609, 0.56739130434783, 0.29545454545455
76794, 2.0913043478261, 0.56739130434783, 0.27272727272727
76795, 2.1130434782609, 0.59347826086957, 0.27272727272727
76796, 2.1130434782609, 0.56739130434783, 0.25
76797, 2.0913043478261, 0.56739130434783, 0.22727272727273
76798, 2.1130434782609, 0.59347826086957, 0.22727272727273
76799, 2.1130434782609, 0.56739130434783, 0.20454545454545
76800, 2.0913043478261, 0.56739130434783, 0.18181818181818
76801, 2.1130434782609, 0.59347826086957, 0.18181818181818
76802, 2.1130434782609, 0.56739130434783, 0.15909090909091
76803, 2.0913043478261, 0.56739130434783, 0.13636363636364
76804, 2.1130434782609, 0.59347826086957, 0.13636363636364
76805, 2.1130434782609, 0.56739130434783, 0.11363636363636
76806, 2.0913043478261, 0.56739130434783, 0.090909090909091
76807, 2.1130434782609, 0.59347826086957, 0.090909090909091
76808, 2.1130434782609, 0.56739130434783, 0.068181818181818
76809, 2.0913043478261, 0.56739130434783, 0.045454545454545
76810, 2.1130434782609, 0.59347826086957, 0.045454545454545
76811, 2.1130434782609, 0.56739130434783, 0.022727272727273
76812, 2.1565217391304, 0.56739130434783, 0.47727272727273
76813, 2.1347826086957, 0.56739130434783, 0.45454545454545
76814, 2.1565217391304, 0.59347826086957, 0.45454545454545
76815, 2.1565217391304, 0.56739130434783, 0.43181818181818
76816, 2.1347826086957, 0.56739130434783, 0.40909090909091
76817, 2.1565217391304, 0.59347826086957, 0.40909090909091
76818, 2.1565217391304, 0.56739130434783, 0.38636363636364
76819, 2.1347826086957, 0.56739130434783, 0.36363636363636
76820, 2.1565217391304, 0.59347826086957, 0.36363636363636
76821, 2.1565217391304, 0.56739130434783, 0.34090909090909
76822, 2.1347826086957, 0.56739130434783, 0.31818181818182
76823, 2.1565217391304, 0.59347826086957, 0.31818181818182
76824, 2.1565217391304, 0.56739130434783, 0.29545454545455
76825, 2.1347826086957, 0.56739130434783, 0.27272727272727
76826, 2.1565217391304, 0.59347826086957, 0.27272727272727
76827, 2.1565217391304, 0.56739130434783, 0.25
76828, 2.1347826086957, 0.56739130434783, 0.22727272727273
76829, 2.1565217391304, 0.59347826086957, 0.22727272727273
76830, 2.1565217391304, 0.56739130434783, 0.20454545454545
76831, 2.1347826086957, 0.56739130434783, 0.18181818181818
76832, 2.1565217391304, 0.59347826086957, 0.18181818181818
76833, 2.1565217391304, 0.56739130434783, 0.15909090909091
76834, 2.1347826086957, 0.56739130434783, 0.13636363636364
76835, 2.1565217391304, 0.59347826086957, 0.13636363636364
76836, 2.1565217391304, 0.56739130434783, 0.11363636363636
76837, 2.1347826086957, 0.56739130434783, 0.090909090909091
76838, 2.1565217391304, 0.59347826086957, 0.090909090909091
76839, 2.1565217391304, 0.56739130434783, 0.068181818181818
76840, 2.1347826086957, 0.56739130434783, 0.045454545454545
76841, 2.1565217391304, 0.59347826086957, 0.045454545454545
76842, 2.1565217391304, 0.56739130434783, 0.022727272727273
76843, 2.1782608695652, 0.56739130434783, 0.45454545454545
76844, 2.1782608695652, 0.56739130434783, 0.40909090909091
76845, 2.1782608695652, 0.56739130434783, 0.36363636363636
76846, 2.1782608695652, 0.56739130434783, 0.31818181818182
76847, 2.1782608695652, 0.56739130434783, 0.27272727272727
76848, 2.1782608695652, 0.56739130434783, 0.22727272727273
76849, 2.1782608695652, 0.56739130434783, 0.18181818181818
76850, 2.1782608695652, 0.56739130434783, 0.13636363636364
76851, 2.1782608695652, 0.56739130434783, 0.090909090909091
76852, 2.1782608695652, 0.56739130434783, 0.045454545454545
76853, 1.2434782608696, 0.51521739130435, 0.47727272727273
76854, 1.2217391304348, 0.51521739130435, 0.45454545454545
76855, 1.2434782608696, 0.54130434782609, 0.45454545454545
76856, 1.2434782608696, 0.51521739130435, 0.43181818181818
76857, 1.2217391304348, 0.51521739130435, 0.40909090909091
76858, 1.2434782608696, 0.54130434782609, 0.40909090909091
76859, 1.2434782608696, 0.51521739130435, 0.38636363636364
76860, 1.2217391304348, 0.51521739130435, 0.36363636363636
76861, 1.2434782608696, 0.54130434782609, 0.36363636363636
76862, 1.2434782608696, 0.51521739130435, 0.34090909090909
76863, 1.2217391304348, 0.51521739130435, 0.31818181818182
76864, 1.2434782608696, 0.54130434782609, 0.31818181818182
76865, 1.2434782608696, 0.51521739130435, 0.29545454545455
76866, 1.2217391304348, 0.51521739130435, 0.27272727272727
76867, 1.2434782608696, 0.54130434782609, 0.27272727272727
76868, 1.2434782608696, 0.51521739130435, 0.25
76869, 1.2217391304348, 0.51521739130435, 0.22727272727273
76870, 1.2434782608696, 0.54130434782609, 0.22727272727273
76871, 1.2434782608696, 0.51521739130435, 0.20454545454545
76872, 1.2217391304348, 0.51521739130435, 0.18181818181818
76873, 1.2434782608696, 0.54130434782609, 0.18181818181818
76874, 1.2434782608696, 0.51521739130435, 0.15909090909091
76875, 1.2217391304348, 0.51521739130435, 0.13636363636364
76876, 1.2434782608696, 0.54130434782609, 0.13636363636364
76877, 1.2434782608696, 0.51521739130435, 0.11363636363636
76878, 1.2217391304348, 0.51521739130435, 0.090909090909091
76879, 1.2434782608696, 0.54130434782609, 0.090909090909091
76880, 1.2434782608696, 0.51521739130435, 0.068181818181818
76881, 1.2217391304348, 0.51521739130435, 0.045454545454545
76882, 1.2434782608696, 0.54130434782609, 0.045454545454545
76883, 1.2434782608696, 0.51521739130435, 0.022727272727273
76884, 1.2869565217391, 0.51521739130435, 0.47727272727273
76885, 1.2652173913043, 0.51521739130435, 0.45454545454545
76886, 1.2869565217391, 0.54130434782609, 0.45454545454545
76887, 1.2869565217391, 0.51521739130435, 0.43181818181818
76888, 1.2652173913043, 0.51521739130435, 0.40909090909091
76889, 1.2869565217391, 0.54130434782609, 0.40909090909091
76890, 1.2869565217391, 0.51521739130435, 0.38636363636364
76891, 1.2652173913043, 0.51521739130435, 0.36363636363636
76892, 1.2869565217391, 0.54130434782609, 0.36363636363636
76893, 1.2869565217391, 0.51521739130435, 0.34090909090909
76894, 1.2652173913043, 0.51521739130435, 0.31818181818182
76895, 1.2869565217391, 0.54130434782609, 0.31818181818182
76896, 1.2869565217391, 0.51521739130435, 0.29545454545455
76897, 1.2652173913043, 0.51521739130435, 0.27272727272727
76898, 1.2869565217391, 0.54130434782609, 0.27272727272727
76899, 1.2869565217391, 0.51521739130435, 0.25
76900, 1.2652173913043, 0.51521739130435, 0.22727272727273
76901, 1.2869565217391, 0.54130434782609, 0.22727272727273
76902, 1.2869565217391, 0.51521739130435, 0.20454545454545
76903, 1.2652173913043, 0.51521739130435, 0.18181818181818
76904, 1.2869565217391, 0.54130434782609, 0.18181818181818
76905, 1.2869565217391, 0.51521739130435, 0.15909090909091
76906, 1.2652173913043, 0.51521739130435, 0.13636363636364
76907, 1.2869565217391, 0.54130434782609, 0.13636363636364
76908, 1.2869565217391, 0.51521739130435, 0.11363636363636
76909, 1.2652173913043, 0.51521739130435, 0.090909090909091
76910, 1.2869565217391, 0.54130434782609, 0.090909090909091
76911, 1.2869565217391, 0.51521739130435, 0.068181818181818
76912, 1.2652173913043, 0.51521739130435, 0.045454545454545
76913, 1.2869565217391, 0.54130434782609, 0.045454545454545
76914, 1.2869565217391, 0.51521739130435, 0.022727272727273
76915, 1.3304347826087, 0.51521739130435, 0.47727272727273
76916, 1.3086956521739, 0.51521739130435, 0.45454545454545
76917, 1.3304347826087, 0.54130434782609, 0.45454545454545
76918, 1.3304347826087, 0.51521739130435, 0.43181818181818
76919, 1.3086956521739, 0.51521739130435, 0.40909090909091
76920, 1.3304347826087, 0.54130434782609, 0.40909090909091
76921, 1.3304347826087, 0.51521739130435, 0.38636363636364
76922, 1.3086956521739, 0.51521739130435, 0.36363636363636
76923, 1.3304347826087, 0.54130434782609, 0.36363636363636
76924, 1.3304347826087, 0.51521739130435, 0.34090909090909
76925, 1.3086956521739, 0.51521739130435, 0.31818181818182
76926, 1.3304347826087, 0.54130434782609, 0.31818181818182
76927, 1.3304347826087, 0.51521739130435, 0.29545454545455
76928, 1.3086956521739, 0.51521739130435, 0.27272727272727
76929, 1.3304347826087, 0.54130434782609, 0.27272727272727
76930, 1.3304347826087, 0.51521739130435, 0.25
76931, 1.3086956521739, 0.51521739130435, 0.22727272727273
76932, 1.3304347826087, 0.54130434782609, 0.22727272727273
76933, 1.3304347826087, 0.51521739130435, 0.20454545454545
76934, 1.3086956521739, 0.51521739130435, 0.18181818181818
76935, 1.3304347826087, 0.54130434782609, 0.18181818181818
76936, 1.3304347826087, 0.51521739130435, 0.15909090909091
76937, 1.3086956521739, 0.51521739130435, 0.13636363636364
76938, 1.3304347826087, 0.54130434782609, 0.13636363636364
76939, 1.3304347826087, 0.51521739130435, 0.11363636363636
76940, 1.3086956521739, 0.51521739130435, 0.090909090909091
76941, 1.3304347826087, 0.54130434782609, 0.090909090909091
76942, 1.3304347826087, 0.51521739130435, 0.068181818181818
76943, 1.3086956521739, 0.51521739130435, 0.045454545454545
76944, 1.3304347826087, 0.54130434782609, 0.045454545454545
76945, 1.3304347826087, 0.51521739130435, 0.022727272727273
76946, 1.3739130434783, 0.51521739130435, 0.47727272727273
76947, 1.3521739130435, 0.51521739130435, 0.45454545454545
76948, 1.3739130434783, 0.54130434782609, 0.45454545454545
76949, 1.3739130434783, 0.51521739130435, 0.43181818181818
76950, 1.3521739130435, 0.51521739130435, 0.40909090909091
76951, 1.3739130434783, 0.54130434782609, 0.40909090909091
76952, 1.3739130434783, 0.51521739130435, 0.38636363636364
76953, 1.3521739130435, 0.51521739130435, 0.36363636363636
76954, 1.3739130434783, 0.54130434782609, 0.36363636363636
76955, 1.3739130434783, 0.51521739130435, 0.34090909090909
76956, 1.3521739130435, 0.51521739130435, 0.31818181818182
76957, 1.3739130434783, 0.54130434782609, 0.31818181818182
76958, 1.3739130434783, 0.51521739130435, 0.29545454545455
76959, 1.3521739130435, 0.51521739130435, 0.27272727272727
76960, 1.3739130434783, 0.54130434782609, 0.27272727272727
76961, 1.3739130434783, 0.51521739130435, 0.25
76962, 1.3521739130435, 0.51521739130435, 0.22727272727273
76963, 1.3739130434783, 0.54130434782609, 0.22727272727273
76964, 1.3739130434783, 0.51521739130435, 0.20454545454545
76965, 1.3521739130435, 0.51521739130435, 0.18181818181818
76966, 1.3739130434783, 0.54130434782609, 0.18181818181818
76967, 1.3739130434783, 0.51521739130435, 0.15909090909091
76968, 1.3521739130435, 0.51521739130435, 0.13636363636364
76969, 1.3739130434783, 0.54130434782609, 0.13636363636364
76970, 1.3739130434783, 0.51521739130435, 0.11363636363636
76971, 1.3521739130435, 0.51521739130435, 0.090909090909091
76972, 1.3739130434783, 0.54130434782609, 0.090909090909091
76973, 1.3739130434783, 0.51521739130435, 0.068181818181818
76974, 1.3521739130435, 0.51521739130435, 0.045454545454545
76975, 1.3739130434783, 0.54130434782609, 0.045454545454545
76976, 1.3739130434783, 0.51521739130435, 0.022727272727273
76977, 1.4173913043478, 0.51521739130435, 0.47727272727273
76978, 1.395652173913, 0.51521739130435, 0.45454545454545
76979, 1.4173913043478, 0.54130434782609, 0.45454545454545
76980, 1.4173913043478, 0.51521739130435, 0.43181818181818
76981, 1.395652173913, 0.51521739130435, 0.40909090909091
76982, 1.4173913043478, 0.54130434782609, 0.40909090909091
76983, 1.4173913043478, 0.51521739130435, 0.38636363636364
76984, 1.395652173913, 0.51521739130435, 0.36363636363636
76985, 1.4173913043478, 0.54130434782609, 0.36363636363636
76986, 1.4173913043478, 0.51521739130435, 0.34090909090909
76987, 1.395652173913, 0.51521739130435, 0.31818181818182
76988, 1.4173913043478, 0.54130434782609, 0.31818181818182
76989, 1.4173913043478, 0.51521739130435, 0.29545454545455
76990, 1.395652173913, 0.51521739130435, 0.27272727272727
76991, 1.4173913043478, 0.54130434782609, 0.27272727272727
76992, 1.4173913043478, 0.51521739130435, 0.25
76993, 1.395652173913, 0.51521739130435, 0.22727272727273
76994, 1.4173913043478, 0.54130434782609, 0.22727272727273
76995, 1.4173913043478, 0.51521739130435, 0.20454545454545
76996, 1.395652173913, 0.51521739130435, 0.18181818181818
76997, 1.4173913043478, 0.54130434782609, 0.18181818181818
76998, 1.4173913043478, 0.51521739130435, 0.15909090909091
76999, 1.395652173913, 0.51521739130435, 0.13636363636364
77000, 1.4173913043478, 0.54130434782609, 0.13636363636364
77001, 1.4173913043478, 0.51521739130435, 0.11363636363636
77002, 1.395652173913, 0.51521739130435, 0.090909090909091
77003, 1.4173913043478, 0.54130434782609, 0.090909090909091
77004, 1.4173913043478, 0.51521739130435, 0.068181818181818
77005, 1.395652173913, 0.51521739130435, 0.045454545454545
77006, 1.4173913043478, 0.54130434782609, 0.045454545454545
77007, 1.4173913043478, 0.51521739130435, 0.022727272727273
77008, 1.4608695652174, 0.51521739130435, 0.47727272727273
77009, 1.4391304347826, 0.51521739130435, 0.45454545454545
77010, 1.4608695652174, 0.54130434782609, 0.45454545454545
77011, 1.4608695652174, 0.51521739130435, 0.43181818181818
77012, 1.4391304347826, 0.51521739130435, 0.40909090909091
77013, 1.4608695652174, 0.54130434782609, 0.40909090909091
77014, 1.4608695652174, 0.51521739130435, 0.38636363636364
77015, 1.4391304347826, 0.51521739130435, 0.36363636363636
77016, 1.4608695652174, 0.54130434782609, 0.36363636363636
77017, 1.4608695652174, 0.51521739130435, 0.34090909090909
77018, 1.4391304347826, 0.51521739130435, 0.31818181818182
77019, 1.4608695652174, 0.54130434782609, 0.31818181818182
77020, 1.4608695652174, 0.51521739130435, 0.29545454545455
77021, 1.4391304347826, 0.51521739130435, 0.27272727272727
77022, 1.4608695652174, 0.54130434782609, 0.27272727272727
77023, 1.4608695652174, 0.51521739130435, 0.25
77024, 1.4391304347826, 0.51521739130435, 0.22727272727273
77025, 1.4608695652174, 0.54130434782609, 0.22727272727273
77026, 1.4608695652174, 0.51521739130435, 0.20454545454545
77027, 1.4391304347826, 0.51521739130435, 0.18181818181818
77028, 1.4608695652174, 0.54130434782609, 0.18181818181818
77029, 1.4608695652174, 0.51521739130435, 0.15909090909091
77030, 1.4391304347826, 0.51521739130435, 0.13636363636364
77031, 1.4608695652174, 0.54130434782609, 0.13636363636364
77032, 1.4608695652174, 0.51521739130435, 0.11363636363636
77033, 1.4391304347826, 0.51521739130435, 0.090909090909091
77034, 1.4608695652174, 0.54130434782609, 0.090909090909091
77035, 1.4608695652174, 0.51521739130435, 0.068181818181818
77036, 1.4391304347826, 0.51521739130435, 0.045454545454545
77037, 1.4608695652174, 0.54130434782609, 0.045454545454545
77038, 1.4608695652174, 0.51521739130435, 0.022727272727273
77039, 1.504347826087, 0.51521739130435, 0.47727272727273
77040, 1.4826086956522, 0.51521739130435, 0.45454545454545
77041, 1.504347826087, 0.54130434782609, 0.45454545454545
77042, 1.504347826087, 0.51521739130435, 0.43181818181818
77043, 1.4826086956522, 0.51521739130435, 0.40909090909091
77044, 1.504347826087, 0.54130434782609, 0.40909090909091
77045, 1.504347826087, 0.51521739130435, 0.38636363636364
77046, 1.4826086956522, 0.51521739130435, 0.36363636363636
77047, 1.504347826087, 0.54130434782609, 0.36363636363636
77048, 1.504347826087, 0.51521739130435, 0.34090909090909
77049, 1.4826086956522, 0.51521739130435, 0.31818181818182
77050, 1.504347826087, 0.54130434782609, 0.31818181818182
77051, 1.504347826087, 0.51521739130435, 0.29545454545455
77052, 1.4826086956522, 0.51521739130435, 0.27272727272727
77053, 1.504347826087, 0.54130434782609, 0.27272727272727
77054, 1.504347826087, 0.51521739130435, 0.25
77055, 1.4826086956522, 0.51521739130435, 0.22727272727273
77056, 1.504347826087, 0.54130434782609, 0.22727272727273
77057, 1.504347826087, 0.51521739130435, 0.20454545454545
77058, 1.4826086956522, 0.51521739130435, 0.18181818181818
77059, 1.504347826087, 0.54130434782609, 0.18181818181818
77060, 1.504347826087, 0.51521739130435, 0.15909090909091
77061, 1.4826086956522, 0.51521739130435, 0.13636363636364
77062, 1.504347826087, 0.54130434782609, 0.13636363636364
77063, 1.504347826087, 0.51521739130435, 0.11363636363636
77064, 1.4826086956522, 0.51521739130435, 0.090909090909091
77065, 1.504347826087, 0.54130434782609, 0.090909090909091
77066, 1.504347826087, 0.51521739130435, 0.068181818181818
77067, 1.4826086956522, 0.51521739130435, 0.045454545454545
77068, 1.504347826087, 0.54130434782609, 0.045454545454545
77069, 1.504347826087, 0.51521739130435, 0.022727272727273
77070, 1.5478260869565, 0.51521739130435, 0.47727272727273
77071, 1.5260869565217, 0.51521739130435, 0.45454545454545
77072, 1.5478260869565, 0.54130434782609, 0.45454545454545
77073, 1.5478260869565, 0.51521739130435, 0.43181818181818
77074, 1.5260869565217, 0.51521739130435, 0.40909090909091
77075, 1.5478260869565, 0.54130434782609, 0.40909090909091
77076, 1.5478260869565, 0.51521739130435, 0.38636363636364
77077, 1.5260869565217, 0.51521739130435, 0.36363636363636
77078, 1.5478260869565, 0.54130434782609, 0.36363636363636
77079, 1.5478260869565, 0.51521739130435, 0.34090909090909
77080, 1.5260869565217, 0.51521739130435, 0.31818181818182
77081, 1.5478260869565, 0.54130434782609, 0.31818181818182
77082, 1.5478260869565, 0.51521739130435, 0.29545454545455
77083, 1.5260869565217, 0.51521739130435, 0.27272727272727
77084, 1.5478260869565, 0.54130434782609, 0.27272727272727
77085, 1.5478260869565, 0.51521739130435, 0.25
77086, 1.5260869565217, 0.51521739130435, 0.22727272727273
77087, 1.5478260869565, 0.54130434782609, 0.22727272727273
77088, 1.5478260869565, 0.51521739130435, 0.20454545454545
77089, 1.5260869565217, 0.51521739130435, 0.18181818181818
77090, 1.5478260869565, 0.54130434782609, 0.18181818181818
77091, 1.5478260869565, 0.51521739130435, 0.15909090909091
77092, 1.5260869565217, 0.51521739130435, 0.13636363636364
77093, 1.5478260869565, 0.54130434782609, 0.13636363636364
77094, 1.5478260869565, 0.51521739130435, 0.11363636363636
77095, 1.5260869565217, 0.51521739130435, 0.090909090909091
77096, 1.5478260869565, 0.54130434782609, 0.090909090909091
77097, 1.5478260869565, 0.51521739130435, 0.068181818181818
77098, 1.5260869565217, 0.51521739130435, 0.045454545454545
77099, 1.5478260869565, 0.54130434782609, 0.045454545454545
77100, 1.5478260869565, 0.51521739130435, 0.022727272727273
77101, 1.5913043478261, 0.51521739130435, 0.47727272727273
77102, 1.5695652173913, 0.51521739130435, 0.45454545454545
77103, 1.5913043478261, 0.54130434782609, 0.45454545454545
77104, 1.5913043478261, 0.51521739130435, 0.43181818181818
77105, 1.5695652173913, 0.51521739130435, 0.40909090909091
77106, 1.5913043478261, 0.54130434782609, 0.40909090909091
77107, 1.5913043478261, 0.51521739130435, 0.38636363636364
77108, 1.5695652173913, 0.51521739130435, 0.36363636363636
77109, 1.5913043478261, 0.54130434782609, 0.36363636363636
77110, 1.5913043478261, 0.51521739130435, 0.34090909090909
77111, 1.5695652173913, 0.51521739130435, 0.31818181818182
77112, 1.5913043478261, 0.54130434782609, 0.31818181818182
77113, 1.5913043478261, 0.51521739130435, 0.29545454545455
77114, 1.5695652173913, 0.51521739130435, 0.27272727272727
77115, 1.5913043478261, 0.54130434782609, 0.27272727272727
77116, 1.5913043478261, 0.51521739130435, 0.25
77117, 1.5695652173913, 0.51521739130435, 0.22727272727273
77118, 1.5913043478261, 0.54130434782609, 0.22727272727273
77119, 1.5913043478261, 0.51521739130435, 0.20454545454545
77120, 1.5695652173913, 0.51521739130435, 0.18181818181818
77121, 1.5913043478261, 0.54130434782609, 0.18181818181818
77122, 1.5913043478261, 0.51521739130435, 0.15909090909091
77123, 1.5695652173913, 0.51521739130435, 0.13636363636364
77124, 1.5913043478261, 0.54130434782609, 0.13636363636364
77125, 1.5913043478261, 0.51521739130435, 0.11363636363636
77126, 1.5695652173913, 0.51521739130435, 0.090909090909091
77127, 1.5913043478261, 0.54130434782609, 0.090909090909091
77128, 1.5913043478261, 0.51521739130435, 0.068181818181818
77129, 1.5695652173913, 0.51521739130435, 0.045454545454545
77130, 1.5913043478261, 0.54130434782609, 0.045454545454545
77131, 1.5913043478261, 0.51521739130435, 0.022727272727273
77132, 1.6347826086957, 0.51521739130435, 0.47727272727273
77133, 1.6130434782609, 0.51521739130435, 0.45454545454545
77134, 1.6347826086957, 0.54130434782609, 0.45454545454545
77135, 1.6347826086957, 0.51521739130435, 0.43181818181818
77136, 1.6130434782609, 0.51521739130435, 0.40909090909091
77137, 1.6347826086957, 0.54130434782609, 0.40909090909091
77138, 1.6347826086957, 0.51521739130435, 0.38636363636364
77139, 1.6130434782609, 0.51521739130435, 0.36363636363636
77140, 1.6347826086957, 0.54130434782609, 0.36363636363636
77141, 1.6347826086957, 0.51521739130435, 0.34090909090909
77142, 1.6130434782609, 0.51521739130435, 0.31818181818182
77143, 1.6347826086957, 0.54130434782609, 0.31818181818182
77144, 1.6347826086957, 0.51521739130435, 0.29545454545455
77145, 1.6130434782609, 0.51521739130435, 0.27272727272727
77146, 1.6347826086957, 0.54130434782609, 0.27272727272727
77147, 1.6347826086957, 0.51521739130435, 0.25
77148, 1.6130434782609, 0.51521739130435, 0.22727272727273
77149, 1.6347826086957, 0.54130434782609, 0.22727272727273
77150, 1.6347826086957, 0.51521739130435, 0.20454545454545
77151, 1.6130434782609, 0.51521739130435, 0.18181818181818
77152, 1.6347826086957, 0.54130434782609, 0.18181818181818
77153, 1.6347826086957, 0.51521739130435, 0.15909090909091
77154, 1.6130434782609, 0.51521739130435, 0.13636363636364
77155, 1.6347826086957, 0.54130434782609, 0.13636363636364
77156, 1.6347826086957, 0.51521739130435, 0.11363636363636
77157, 1.6130434782609, 0.51521739130435, 0.090909090909091
77158, 1.6347826086957, 0.54130434782609, 0.090909090909091
77159, 1.6347826086957, 0.51521739130435, 0.068181818181818
77160, 1.6130434782609, 0.51521739130435, 0.045454545454545
77161, 1.6347826086957, 0.54130434782609, 0.045454545454545
77162, 1.6347826086957, 0.51521739130435, 0.022727272727273
77163, 1.6782608695652, 0.51521739130435, 0.47727272727273
77164, 1.6565217391304, 0.51521739130435, 0.45454545454545
77165, 1.6782608695652, 0.54130434782609, 0.45454545454545
77166, 1.6782608695652, 0.51521739130435, 0.43181818181818
77167, 1.6565217391304, 0.51521739130435, 0.40909090909091
77168, 1.6782608695652, 0.54130434782609, 0.40909090909091
77169, 1.6782608695652, 0.51521739130435, 0.38636363636364
77170, 1.6565217391304, 0.51521739130435, 0.36363636363636
77171, 1.6782608695652, 0.54130434782609, 0.36363636363636
77172, 1.6782608695652, 0.51521739130435, 0.34090909090909
77173, 1.6565217391304, 0.51521739130435, 0.31818181818182
77174, 1.6782608695652, 0.54130434782609, 0.31818181818182
77175, 1.6782608695652, 0.51521739130435, 0.29545454545455
77176, 1.6565217391304, 0.51521739130435, 0.27272727272727
77177, 1.6782608695652, 0.54130434782609, 0.27272727272727
77178, 1.6782608695652, 0.51521739130435, 0.25
77179, 1.6565217391304, 0.51521739130435, 0.22727272727273
77180, 1.6782608695652, 0.54130434782609, 0.22727272727273
77181, 1.6782608695652, 0.51521739130435, 0.20454545454545
77182, 1.6565217391304, 0.51521739130435, 0.18181818181818
77183, 1.6782608695652, 0.54130434782609, 0.18181818181818
77184, 1.6782608695652, 0.51521739130435, 0.15909090909091
77185, 1.6565217391304, 0.51521739130435, 0.13636363636364
77186, 1.6782608695652, 0.54130434782609, 0.13636363636364
77187, 1.6782608695652, 0.51521739130435, 0.11363636363636
77188, 1.6565217391304, 0.51521739130435, 0.090909090909091
77189, 1.6782608695652, 0.54130434782609, 0.090909090909091
77190, 1.6782608695652, 0.51521739130435, 0.068181818181818
77191, 1.6565217391304, 0.51521739130435, 0.045454545454545
77192, 1.6782608695652, 0.54130434782609, 0.045454545454545
77193, 1.6782608695652, 0.51521739130435, 0.022727272727273
77194, 1.7217391304348, 0.51521739130435, 0.47727272727273
77195, 1.7, 0.51521739130435, 0.45454545454545
77196, 1.7217391304348, 0.54130434782609, 0.45454545454545
77197, 1.7217391304348, 0.51521739130435, 0.43181818181818
77198, 1.7, 0.51521739130435, 0.40909090909091
77199, 1.7217391304348, 0.54130434782609, 0.40909090909091
77200, 1.7217391304348, 0.51521739130435, 0.38636363636364
77201, 1.7, 0.51521739130435, 0.36363636363636
77202, 1.7217391304348, 0.54130434782609, 0.36363636363636
77203, 1.7217391304348, 0.51521739130435, 0.34090909090909
77204, 1.7, 0.51521739130435, 0.31818181818182
77205, 1.7217391304348, 0.54130434782609, 0.31818181818182
77206, 1.7217391304348, 0.51521739130435, 0.29545454545455
77207, 1.7, 0.51521739130435, 0.27272727272727
77208, 1.7217391304348, 0.54130434782609, 0.27272727272727
77209, 1.7217391304348, 0.51521739130435, 0.25
77210, 1.7, 0.51521739130435, 0.22727272727273
77211, 1.7217391304348, 0.54130434782609, 0.22727272727273
77212, 1.7217391304348, 0.51521739130435, 0.20454545454545
77213, 1.7, 0.51521739130435, 0.18181818181818
77214, 1.7217391304348, 0.54130434782609, 0.18181818181818
77215, 1.7217391304348, 0.51521739130435, 0.15909090909091
77216, 1.7, 0.51521739130435, 0.13636363636364
77217, 1.7217391304348, 0.54130434782609, 0.13636363636364
77218, 1.7217391304348, 0.51521739130435, 0.11363636363636
77219, 1.7, 0.51521739130435, 0.090909090909091
77220, 1.7217391304348, 0.54130434782609, 0.090909090909091
77221, 1.7217391304348, 0.51521739130435, 0.068181818181818
77222, 1.7, 0.51521739130435, 0.045454545454545
77223, 1.7217391304348, 0.54130434782609, 0.045454545454545
77224, 1.7217391304348, 0.51521739130435, 0.022727272727273
77225, 1.7652173913043, 0.51521739130435, 0.47727272727273
77226, 1.7434782608696, 0.51521739130435, 0.45454545454545
77227, 1.7652173913043, 0.54130434782609, 0.45454545454545
77228, 1.7652173913043, 0.51521739130435, 0.43181818181818
77229, 1.7434782608696, 0.51521739130435, 0.40909090909091
77230, 1.7652173913043, 0.54130434782609, 0.40909090909091
77231, 1.7652173913043, 0.51521739130435, 0.38636363636364
77232, 1.7434782608696, 0.51521739130435, 0.36363636363636
77233, 1.7652173913043, 0.54130434782609, 0.36363636363636
77234, 1.7652173913043, 0.51521739130435, 0.34090909090909
77235, 1.7434782608696, 0.51521739130435, 0.31818181818182
77236, 1.7652173913043, 0.54130434782609, 0.31818181818182
77237, 1.7652173913043, 0.51521739130435, 0.29545454545455
77238, 1.7434782608696, 0.51521739130435, 0.27272727272727
77239, 1.7652173913043, 0.54130434782609, 0.27272727272727
77240, 1.7652173913043, 0.51521739130435, 0.25
77241, 1.7434782608696, 0.51521739130435, 0.22727272727273
77242, 1.7652173913043, 0.54130434782609, 0.22727272727273
77243, 1.7652173913043, 0.51521739130435, 0.20454545454545
77244, 1.7434782608696, 0.51521739130435, 0.18181818181818
77245, 1.7652173913043, 0.54130434782609, 0.18181818181818
77246, 1.7652173913043, 0.51521739130435, 0.15909090909091
77247, 1.7434782608696, 0.51521739130435, 0.13636363636364
77248, 1.7652173913043, 0.54130434782609, 0.13636363636364
77249, 1.7652173913043, 0.51521739130435, 0.11363636363636
77250, 1.7434782608696, 0.51521739130435, 0.090909090909091
77251, 1.7652173913043, 0.54130434782609, 0.090909090909091
77252, 1.7652173913043, 0.51521739130435, 0.068181818181818
77253, 1.7434782608696, 0.51521739130435, 0.045454545454545
77254, 1.7652173913043, 0.54130434782609, 0.045454545454545
77255, 1.7652173913043, 0.51521739130435, 0.022727272727273
77256, 1.8086956521739, 0.51521739130435, 0.47727272727273
77257, 1.7869565217391, 0.51521739130435, 0.45454545454545
77258, 1.8086956521739, 0.54130434782609, 0.45454545454545
77259, 1.8086956521739, 0.51521739130435, 0.43181818181818
77260, 1.7869565217391, 0.51521739130435, 0.40909090909091
77261, 1.8086956521739, 0.54130434782609, 0.40909090909091
77262, 1.8086956521739, 0.51521739130435, 0.38636363636364
77263, 1.7869565217391, 0.51521739130435, 0.36363636363636
77264, 1.8086956521739, 0.54130434782609, 0.36363636363636
77265, 1.8086956521739, 0.51521739130435, 0.34090909090909
77266, 1.7869565217391, 0.51521739130435, 0.31818181818182
77267, 1.8086956521739, 0.54130434782609, 0.31818181818182
77268, 1.8086956521739, 0.51521739130435, 0.29545454545455
77269, 1.7869565217391, 0.51521739130435, 0.27272727272727
77270, 1.8086956521739, 0.54130434782609, 0.27272727272727
77271, 1.8086956521739, 0.51521739130435, 0.25
77272, 1.7869565217391, 0.51521739130435, 0.22727272727273
77273, 1.8086956521739, 0.54130434782609, 0.22727272727273
77274, 1.8086956521739, 0.51521739130435, 0.20454545454545
77275, 1.7869565217391, 0.51521739130435, 0.18181818181818
77276, 1.8086956521739, 0.54130434782609, 0.18181818181818
77277, 1.8086956521739, 0.51521739130435, 0.15909090909091
77278, 1.7869565217391, 0.51521739130435, 0.13636363636364
77279, 1.8086956521739, 0.54130434782609, 0.13636363636364
77280, 1.8086956521739, 0.51521739130435, 0.11363636363636
77281, 1.7869565217391, 0.51521739130435, 0.090909090909091
77282, 1.8086956521739, 0.54130434782609, 0.090909090909091
77283, 1.8086956521739, 0.51521739130435, 0.068181818181818
77284, 1.7869565217391, 0.51521739130435, 0.045454545454545
77285, 1.8086956521739, 0.54130434782609, 0.045454545454545
77286, 1.8086956521739, 0.51521739130435, 0.022727272727273
77287, 1.8521739130435, 0.51521739130435, 0.47727272727273
77288, 1.8304347826087, 0.51521739130435, 0.45454545454545
77289, 1.8521739130435, 0.54130434782609, 0.45454545454545
77290, 1.8521739130435, 0.51521739130435, 0.43181818181818
77291, 1.8304347826087, 0.51521739130435, 0.40909090909091
77292, 1.8521739130435, 0.54130434782609, 0.40909090909091
77293, 1.8521739130435, 0.51521739130435, 0.38636363636364
77294, 1.8304347826087, 0.51521739130435, 0.36363636363636
77295, 1.8521739130435, 0.54130434782609, 0.36363636363636
77296, 1.8521739130435, 0.51521739130435, 0.34090909090909
77297, 1.8304347826087, 0.51521739130435, 0.31818181818182
77298, 1.8521739130435, 0.54130434782609, 0.31818181818182
77299, 1.8521739130435, 0.51521739130435, 0.29545454545455
77300, 1.8304347826087, 0.51521739130435, 0.27272727272727
77301, 1.8521739130435, 0.54130434782609, 0.27272727272727
77302, 1.8521739130435, 0.51521739130435, 0.25
77303, 1.8304347826087, 0.51521739130435, 0.22727272727273
77304, 1.8521739130435, 0.54130434782609, 0.22727272727273
77305, 1.8521739130435, 0.51521739130435, 0.20454545454545
77306, 1.8304347826087, 0.51521739130435, 0.18181818181818
77307, 1.8521739130435, 0.54130434782609, 0.18181818181818
77308, 1.8521739130435, 0.51521739130435, 0.15909090909091
77309, 1.8304347826087, 0.51521739130435, 0.13636363636364
77310, 1.8521739130435, 0.54130434782609, 0.13636363636364
77311, 1.8521739130435, 0.51521739130435, 0.11363636363636
77312, 1.8304347826087, 0.51521739130435, 0.090909090909091
77313, 1.8521739130435, 0.54130434782609, 0.090909090909091
77314, 1.8521739130435, 0.51521739130435, 0.068181818181818
77315, 1.8304347826087, 0.51521739130435, 0.045454545454545
77316, 1.8521739130435, 0.54130434782609, 0.045454545454545
77317, 1.8521739130435, 0.51521739130435, 0.022727272727273
77318, 1.895652173913, 0.51521739130435, 0.47727272727273
77319, 1.8739130434783, 0.51521739130435, 0.45454545454545
77320, 1.895652173913, 0.54130434782609, 0.45454545454545
77321, 1.895652173913, 0.51521739130435, 0.43181818181818
77322, 1.8739130434783, 0.51521739130435, 0.40909090909091
77323, 1.895652173913, 0.54130434782609, 0.40909090909091
77324, 1.895652173913, 0.51521739130435, 0.38636363636364
77325, 1.8739130434783, 0.51521739130435, 0.36363636363636
77326, 1.895652173913, 0.54130434782609, 0.36363636363636
77327, 1.895652173913, 0.51521739130435, 0.34090909090909
77328, 1.8739130434783, 0.51521739130435, 0.31818181818182
77329, 1.895652173913, 0.54130434782609, 0.31818181818182
77330, 1.895652173913, 0.51521739130435, 0.29545454545455
77331, 1.8739130434783, 0.51521739130435, 0.27272727272727
77332, 1.895652173913, 0.54130434782609, 0.27272727272727
77333, 1.895652173913, 0.51521739130435, 0.25
77334, 1.8739130434783, 0.51521739130435, 0.22727272727273
77335, 1.895652173913, 0.54130434782609, 0.22727272727273
77336, 1.895652173913, 0.51521739130435, 0.20454545454545
77337, 1.8739130434783, 0.51521739130435, 0.18181818181818
77338, 1.895652173913, 0.54130434782609, 0.18181818181818
77339, 1.895652173913, 0.51521739130435, 0.15909090909091
77340, 1.8739130434783, 0.51521739130435, 0.13636363636364
77341, 1.895652173913, 0.54130434782609, 0.13636363636364
77342, 1.895652173913, 0.51521739130435, 0.11363636363636
77343, 1.8739130434783, 0.51521739130435, 0.090909090909091
77344, 1.895652173913, 0.54130434782609, 0.090909090909091
77345, 1.895652173913, 0.51521739130435, 0.068181818181818
77346, 1.8739130434783, 0.51521739130435, 0.045454545454545
77347, 1.895652173913, 0.54130434782609, 0.045454545454545
77348, 1.895652173913, 0.51521739130435, 0.022727272727273
77349, 1.9391304347826, 0.51521739130435, 0.47727272727273
77350, 1.9173913043478, 0.51521739130435, 0.45454545454545
77351, 1.9391304347826, 0.54130434782609, 0.45454545454545
77352, 1.9391304347826, 0.51521739130435, 0.43181818181818
77353, 1.9173913043478, 0.51521739130435, 0.40909090909091
77354, 1.9391304347826, 0.54130434782609, 0.40909090909091
77355, 1.9391304347826, 0.51521739130435, 0.38636363636364
77356, 1.9173913043478, 0.51521739130435, 0.36363636363636
77357, 1.9391304347826, 0.54130434782609, 0.36363636363636
77358, 1.9391304347826, 0.51521739130435, 0.34090909090909
77359, 1.9173913043478, 0.51521739130435, 0.31818181818182
77360, 1.9391304347826, 0.54130434782609, 0.31818181818182
77361, 1.9391304347826, 0.51521739130435, 0.29545454545455
77362, 1.9173913043478, 0.51521739130435, 0.27272727272727
77363, 1.9391304347826, 0.54130434782609, 0.27272727272727
77364, 1.9391304347826, 0.51521739130435, 0.25
77365, 1.9173913043478, 0.51521739130435, 0.22727272727273
77366, 1.9391304347826, 0.54130434782609, 0.22727272727273
77367, 1.9391304347826, 0.51521739130435, 0.20454545454545
77368, 1.9173913043478, 0.51521739130435, 0.18181818181818
77369, 1.9391304347826, 0.54130434782609, 0.18181818181818
77370, 1.9391304347826, 0.51521739130435, 0.15909090909091
77371, 1.9173913043478, 0.51521739130435, 0.13636363636364
77372, 1.9391304347826, 0.54130434782609, 0.13636363636364
77373, 1.9391304347826, 0.51521739130435, 0.11363636363636
77374, 1.9173913043478, 0.51521739130435, 0.090909090909091
77375, 1.9391304347826, 0.54130434782609, 0.090909090909091
77376, 1.9391304347826, 0.51521739130435, 0.068181818181818
77377, 1.9173913043478, 0.51521739130435, 0.045454545454545
77378, 1.9391304347826, 0.54130434782609, 0.045454545454545
77379, 1.9391304347826, 0.51521739130435, 0.022727272727273
77380, 1.9826086956522, 0.51521739130435, 0.47727272727273
77381, 1.9608695652174, 0.51521739130435, 0.45454545454545
77382, 1.9826086956522, 0.54130434782609, 0.45454545454545
77383, 1.9826086956522, 0.51521739130435, 0.43181818181818
77384, 1.9608695652174, 0.51521739130435, 0.40909090909091
77385, 1.9826086956522, 0.54130434782609, 0.40909090909091
77386, 1.9826086956522, 0.51521739130435, 0.38636363636364
77387, 1.9608695652174, 0.51521739130435, 0.36363636363636
77388, 1.9826086956522, 0.54130434782609, 0.36363636363636
77389, 1.9826086956522, 0.51521739130435, 0.34090909090909
77390, 1.9608695652174, 0.51521739130435, 0.31818181818182
77391, 1.9826086956522, 0.54130434782609, 0.31818181818182
77392, 1.9826086956522, 0.51521739130435, 0.29545454545455
77393, 1.9608695652174, 0.51521739130435, 0.27272727272727
77394, 1.9826086956522, 0.54130434782609, 0.27272727272727
77395, 1.9826086956522, 0.51521739130435, 0.25
77396, 1.9608695652174, 0.51521739130435, 0.22727272727273
77397, 1.9826086956522, 0.54130434782609, 0.22727272727273
77398, 1.9826086956522, 0.51521739130435, 0.20454545454545
77399, 1.9608695652174, 0.51521739130435, 0.18181818181818
77400, 1.9826086956522, 0.54130434782609, 0.18181818181818
77401, 1.9826086956522, 0.51521739130435, 0.15909090909091
77402, 1.9608695652174, 0.51521739130435, 0.13636363636364
77403, 1.9826086956522, 0.54130434782609, 0.13636363636364
77404, 1.9826086956522, 0.51521739130435, 0.11363636363636
77405, 1.9608695652174, 0.51521739130435, 0.090909090909091
77406, 1.9826086956522, 0.54130434782609, 0.090909090909091
77407, 1.9826086956522, 0.51521739130435, 0.068181818181818
77408, 1.9608695652174, 0.51521739130435, 0.045454545454545
77409, 1.9826086956522, 0.54130434782609, 0.045454545454545
77410, 1.9826086956522, 0.51521739130435, 0.022727272727273
77411, 2.0260869565217, 0.51521739130435, 0.47727272727273
77412, 2.004347826087, 0.51521739130435, 0.45454545454545
77413, 2.0260869565217, 0.54130434782609, 0.45454545454545
77414, 2.0260869565217, 0.51521739130435, 0.43181818181818
77415, 2.004347826087, 0.51521739130435, 0.40909090909091
77416, 2.0260869565217, 0.54130434782609, 0.40909090909091
77417, 2.0260869565217, 0.51521739130435, 0.38636363636364
77418, 2.004347826087, 0.51521739130435, 0.36363636363636
77419, 2.0260869565217, 0.54130434782609, 0.36363636363636
77420, 2.0260869565217, 0.51521739130435, 0.34090909090909
77421, 2.004347826087, 0.51521739130435, 0.31818181818182
77422, 2.0260869565217, 0.54130434782609, 0.31818181818182
77423, 2.0260869565217, 0.51521739130435, 0.29545454545455
77424, 2.004347826087, 0.51521739130435, 0.27272727272727
77425, 2.0260869565217, 0.54130434782609, 0.27272727272727
77426, 2.0260869565217, 0.51521739130435, 0.25
77427, 2.004347826087, 0.51521739130435, 0.22727272727273
77428, 2.0260869565217, 0.54130434782609, 0.22727272727273
77429, 2.0260869565217, 0.51521739130435, 0.20454545454545
77430, 2.004347826087, 0.51521739130435, 0.18181818181818
77431, 2.0260869565217, 0.54130434782609, 0.18181818181818
77432, 2.0260869565217, 0.51521739130435, 0.15909090909091
77433, 2.004347826087, 0.51521739130435, 0.13636363636364
77434, 2.0260869565217, 0.54130434782609, 0.13636363636364
77435, 2.0260869565217, 0.51521739130435, 0.11363636363636
77436, 2.004347826087, 0.51521739130435, 0.090909090909091
77437, 2.0260869565217, 0.54130434782609, 0.090909090909091
77438, 2.0260869565217, 0.51521739130435, 0.068181818181818
77439, 2.004347826087, 0.51521739130435, 0.045454545454545
77440, 2.0260869565217, 0.54130434782609, 0.045454545454545
77441, 2.0260869565217, 0.51521739130435, 0.022727272727273
77442, 2.0695652173913, 0.51521739130435, 0.47727272727273
77443, 2.0478260869565, 0.51521739130435, 0.45454545454545
77444, 2.0695652173913, 0.54130434782609, 0.45454545454545
77445, 2.0695652173913, 0.51521739130435, 0.43181818181818
77446, 2.0478260869565, 0.51521739130435, 0.40909090909091
77447, 2.0695652173913, 0.54130434782609, 0.40909090909091
77448, 2.0695652173913, 0.51521739130435, 0.38636363636364
77449, 2.0478260869565, 0.51521739130435, 0.36363636363636
77450, 2.0695652173913, 0.54130434782609, 0.36363636363636
77451, 2.0695652173913, 0.51521739130435, 0.34090909090909
77452, 2.0478260869565, 0.51521739130435, 0.31818181818182
77453, 2.0695652173913, 0.54130434782609, 0.31818181818182
77454, 2.0695652173913, 0.51521739130435, 0.29545454545455
77455, 2.0478260869565, 0.51521739130435, 0.27272727272727
77456, 2.0695652173913, 0.54130434782609, 0.27272727272727
77457, 2.0695652173913, 0.51521739130435, 0.25
77458, 2.0478260869565, 0.51521739130435, 0.22727272727273
77459, 2.0695652173913, 0.54130434782609, 0.22727272727273
77460, 2.0695652173913, 0.51521739130435, 0.20454545454545
77461, 2.0478260869565, 0.51521739130435, 0.18181818181818
77462, 2.0695652173913, 0.54130434782609, 0.18181818181818
77463, 2.0695652173913, 0.51521739130435, 0.15909090909091
77464, 2.0478260869565, 0.51521739130435, 0.13636363636364
77465, 2.0695652173913, 0.54130434782609, 0.13636363636364
77466, 2.0695652173913, 0.51521739130435, 0.11363636363636
77467, 2.0478260869565, 0.51521739130435, 0.090909090909091
77468, 2.0695652173913, 0.54130434782609, 0.090909090909091
77469, 2.0695652173913, 0.51521739130435, 0.068181818181818
77470, 2.0478260869565, 0.51521739130435, 0.045454545454545
77471, 2.0695652173913, 0.54130434782609, 0.045454545454545
77472, 2.0695652173913, 0.51521739130435, 0.022727272727273
77473, 2.1130434782609, 0.51521739130435, 0.47727272727273
77474, 2.0913043478261, 0.51521739130435, 0.45454545454545
77475, 2.1130434782609, 0.54130434782609, 0.45454545454545
77476, 2.1130434782609, 0.51521739130435, 0.43181818181818
77477, 2.0913043478261, 0.51521739130435, 0.40909090909091
77478, 2.1130434782609, 0.54130434782609, 0.40909090909091
77479, 2.1130434782609, 0.51521739130435, 0.38636363636364
77480, 2.0913043478261, 0.51521739130435, 0.36363636363636
77481, 2.1130434782609, 0.54130434782609, 0.36363636363636
77482, 2.1130434782609, 0.51521739130435, 0.34090909090909
77483, 2.0913043478261, 0.51521739130435, 0.31818181818182
77484, 2.1130434782609, 0.54130434782609, 0.31818181818182
77485, 2.1130434782609, 0.51521739130435, 0.29545454545455
77486, 2.0913043478261, 0.51521739130435, 0.27272727272727
77487, 2.1130434782609, 0.54130434782609, 0.27272727272727
77488, 2.1130434782609, 0.51521739130435, 0.25
77489, 2.0913043478261, 0.51521739130435, 0.22727272727273
77490, 2.1130434782609, 0.54130434782609, 0.22727272727273
77491, 2.1130434782609, 0.51521739130435, 0.20454545454545
77492, 2.0913043478261, 0.51521739130435, 0.18181818181818
77493, 2.1130434782609, 0.54130434782609, 0.18181818181818
77494, 2.1130434782609, 0.51521739130435, 0.15909090909091
77495, 2.0913043478261, 0.51521739130435, 0.13636363636364
77496, 2.1130434782609, 0.54130434782609, 0.13636363636364
77497, 2.1130434782609, 0.51521739130435, 0.11363636363636
77498, 2.0913043478261, 0.51521739130435, 0.090909090909091
77499, 2.1130434782609, 0.54130434782609, 0.090909090909091
77500, 2.1130434782609, 0.51521739130435, 0.068181818181818
77501, 2.0913043478261, 0.51521739130435, 0.045454545454545
77502, 2.1130434782609, 0.54130434782609, 0.045454545454545
77503, 2.1130434782609, 0.51521739130435, 0.022727272727273
77504, 2.1565217391304, 0.51521739130435, 0.47727272727273
77505, 2.1347826086957, 0.51521739130435, 0.45454545454545
77506, 2.1565217391304, 0.54130434782609, 0.45454545454545
77507, 2.1565217391304, 0.51521739130435, 0.43181818181818
77508, 2.1347826086957, 0.51521739130435, 0.40909090909091
77509, 2.1565217391304, 0.54130434782609, 0.40909090909091
77510, 2.1565217391304, 0.51521739130435, 0.38636363636364
77511, 2.1347826086957, 0.51521739130435, 0.36363636363636
77512, 2.1565217391304, 0.54130434782609, 0.36363636363636
77513, 2.1565217391304, 0.51521739130435, 0.34090909090909
77514, 2.1347826086957, 0.51521739130435, 0.31818181818182
77515, 2.1565217391304, 0.54130434782609, 0.31818181818182
77516, 2.1565217391304, 0.51521739130435, 0.29545454545455
77517, 2.1347826086957, 0.51521739130435, 0.27272727272727
77518, 2.1565217391304, 0.54130434782609, 0.27272727272727
77519, 2.1565217391304, 0.51521739130435, 0.25
77520, 2.1347826086957, 0.51521739130435, 0.22727272727273
77521, 2.1565217391304, 0.54130434782609, 0.22727272727273
77522, 2.1565217391304, 0.51521739130435, 0.20454545454545
77523, 2.1347826086957, 0.51521739130435, 0.18181818181818
77524, 2.1565217391304, 0.54130434782609, 0.18181818181818
77525, 2.1565217391304, 0.51521739130435, 0.15909090909091
77526, 2.1347826086957, 0.51521739130435, 0.13636363636364
77527, 2.1565217391304, 0.54130434782609, 0.13636363636364
77528, 2.1565217391304, 0.51521739130435, 0.11363636363636
77529, 2.1347826086957, 0.51521739130435, 0.090909090909091
77530, 2.1565217391304, 0.54130434782609, 0.090909090909091
77531, 2.1565217391304, 0.51521739130435, 0.068181818181818
77532, 2.1347826086957, 0.51521739130435, 0.045454545454545
77533, 2.1565217391304, 0.54130434782609, 0.045454545454545
77534, 2.1565217391304, 0.51521739130435, 0.022727272727273
77535, 2.1782608695652, 0.51521739130435, 0.45454545454545
77536, 2.1782608695652, 0.51521739130435, 0.40909090909091
77537, 2.1782608695652, 0.51521739130435, 0.36363636363636
77538, 2.1782608695652, 0.51521739130435, 0.31818181818182
77539, 2.1782608695652, 0.51521739130435, 0.27272727272727
77540, 2.1782608695652, 0.51521739130435, 0.22727272727273
77541, 2.1782608695652, 0.51521739130435, 0.18181818181818
77542, 2.1782608695652, 0.51521739130435, 0.13636363636364
77543, 2.1782608695652, 0.51521739130435, 0.090909090909091
77544, 2.1782608695652, 0.51521739130435, 0.045454545454545
77545, 1.2434782608696, 0.46304347826087, 0.47727272727273
77546, 1.2217391304348, 0.46304347826087, 0.45454545454545
77547, 1.2434782608696, 0.48913043478261, 0.45454545454545
77548, 1.2434782608696, 0.46304347826087, 0.43181818181818
77549, 1.2217391304348, 0.46304347826087, 0.40909090909091
77550, 1.2434782608696, 0.48913043478261, 0.40909090909091
77551, 1.2434782608696, 0.46304347826087, 0.38636363636364
77552, 1.2217391304348, 0.46304347826087, 0.36363636363636
77553, 1.2434782608696, 0.48913043478261, 0.36363636363636
77554, 1.2434782608696, 0.46304347826087, 0.34090909090909
77555, 1.2217391304348, 0.46304347826087, 0.31818181818182
77556, 1.2434782608696, 0.48913043478261, 0.31818181818182
77557, 1.2434782608696, 0.46304347826087, 0.29545454545455
77558, 1.2217391304348, 0.46304347826087, 0.27272727272727
77559, 1.2434782608696, 0.48913043478261, 0.27272727272727
77560, 1.2434782608696, 0.46304347826087, 0.25
77561, 1.2217391304348, 0.46304347826087, 0.22727272727273
77562, 1.2434782608696, 0.48913043478261, 0.22727272727273
77563, 1.2434782608696, 0.46304347826087, 0.20454545454545
77564, 1.2217391304348, 0.46304347826087, 0.18181818181818
77565, 1.2434782608696, 0.48913043478261, 0.18181818181818
77566, 1.2434782608696, 0.46304347826087, 0.15909090909091
77567, 1.2217391304348, 0.46304347826087, 0.13636363636364
77568, 1.2434782608696, 0.48913043478261, 0.13636363636364
77569, 1.2434782608696, 0.46304347826087, 0.11363636363636
77570, 1.2217391304348, 0.46304347826087, 0.090909090909091
77571, 1.2434782608696, 0.48913043478261, 0.090909090909091
77572, 1.2434782608696, 0.46304347826087, 0.068181818181818
77573, 1.2217391304348, 0.46304347826087, 0.045454545454545
77574, 1.2434782608696, 0.48913043478261, 0.045454545454545
77575, 1.2434782608696, 0.46304347826087, 0.022727272727273
77576, 1.2869565217391, 0.46304347826087, 0.47727272727273
77577, 1.2652173913043, 0.46304347826087, 0.45454545454545
77578, 1.2869565217391, 0.48913043478261, 0.45454545454545
77579, 1.2869565217391, 0.46304347826087, 0.43181818181818
77580, 1.2652173913043, 0.46304347826087, 0.40909090909091
77581, 1.2869565217391, 0.48913043478261, 0.40909090909091
77582, 1.2869565217391, 0.46304347826087, 0.38636363636364
77583, 1.2652173913043, 0.46304347826087, 0.36363636363636
77584, 1.2869565217391, 0.48913043478261, 0.36363636363636
77585, 1.2869565217391, 0.46304347826087, 0.34090909090909
77586, 1.2652173913043, 0.46304347826087, 0.31818181818182
77587, 1.2869565217391, 0.48913043478261, 0.31818181818182
77588, 1.2869565217391, 0.46304347826087, 0.29545454545455
77589, 1.2652173913043, 0.46304347826087, 0.27272727272727
77590, 1.2869565217391, 0.48913043478261, 0.27272727272727
77591, 1.2869565217391, 0.46304347826087, 0.25
77592, 1.2652173913043, 0.46304347826087, 0.22727272727273
77593, 1.2869565217391, 0.48913043478261, 0.22727272727273
77594, 1.2869565217391, 0.46304347826087, 0.20454545454545
77595, 1.2652173913043, 0.46304347826087, 0.18181818181818
77596, 1.2869565217391, 0.48913043478261, 0.18181818181818
77597, 1.2869565217391, 0.46304347826087, 0.15909090909091
77598, 1.2652173913043, 0.46304347826087, 0.13636363636364
77599, 1.2869565217391, 0.48913043478261, 0.13636363636364
77600, 1.2869565217391, 0.46304347826087, 0.11363636363636
77601, 1.2652173913043, 0.46304347826087, 0.090909090909091
77602, 1.2869565217391, 0.48913043478261, 0.090909090909091
77603, 1.2869565217391, 0.46304347826087, 0.068181818181818
77604, 1.2652173913043, 0.46304347826087, 0.045454545454545
77605, 1.2869565217391, 0.48913043478261, 0.045454545454545
77606, 1.2869565217391, 0.46304347826087, 0.022727272727273
77607, 1.3304347826087, 0.46304347826087, 0.47727272727273
77608, 1.3086956521739, 0.46304347826087, 0.45454545454545
77609, 1.3304347826087, 0.48913043478261, 0.45454545454545
77610, 1.3304347826087, 0.46304347826087, 0.43181818181818
77611, 1.3086956521739, 0.46304347826087, 0.40909090909091
77612, 1.3304347826087, 0.48913043478261, 0.40909090909091
77613, 1.3304347826087, 0.46304347826087, 0.38636363636364
77614, 1.3086956521739, 0.46304347826087, 0.36363636363636
77615, 1.3304347826087, 0.48913043478261, 0.36363636363636
77616, 1.3304347826087, 0.46304347826087, 0.34090909090909
77617, 1.3086956521739, 0.46304347826087, 0.31818181818182
77618, 1.3304347826087, 0.48913043478261, 0.31818181818182
77619, 1.3304347826087, 0.46304347826087, 0.29545454545455
77620, 1.3086956521739, 0.46304347826087, 0.27272727272727
77621, 1.3304347826087, 0.48913043478261, 0.27272727272727
77622, 1.3304347826087, 0.46304347826087, 0.25
77623, 1.3086956521739, 0.46304347826087, 0.22727272727273
77624, 1.3304347826087, 0.48913043478261, 0.22727272727273
77625, 1.3304347826087, 0.46304347826087, 0.20454545454545
77626, 1.3086956521739, 0.46304347826087, 0.18181818181818
77627, 1.3304347826087, 0.48913043478261, 0.18181818181818
77628, 1.3304347826087, 0.46304347826087, 0.15909090909091
77629, 1.3086956521739, 0.46304347826087, 0.13636363636364
77630, 1.3304347826087, 0.48913043478261, 0.13636363636364
77631, 1.3304347826087, 0.46304347826087, 0.11363636363636
77632, 1.3086956521739, 0.46304347826087, 0.090909090909091
77633, 1.3304347826087, 0.48913043478261, 0.090909090909091
77634, 1.3304347826087, 0.46304347826087, 0.068181818181818
77635, 1.3086956521739, 0.46304347826087, 0.045454545454545
77636, 1.3304347826087, 0.48913043478261, 0.045454545454545
77637, 1.3304347826087, 0.46304347826087, 0.022727272727273
77638, 1.3739130434783, 0.46304347826087, 0.47727272727273
77639, 1.3521739130435, 0.46304347826087, 0.45454545454545
77640, 1.3739130434783, 0.48913043478261, 0.45454545454545
77641, 1.3739130434783, 0.46304347826087, 0.43181818181818
77642, 1.3521739130435, 0.46304347826087, 0.40909090909091
77643, 1.3739130434783, 0.48913043478261, 0.40909090909091
77644, 1.3739130434783, 0.46304347826087, 0.38636363636364
77645, 1.3521739130435, 0.46304347826087, 0.36363636363636
77646, 1.3739130434783, 0.48913043478261, 0.36363636363636
77647, 1.3739130434783, 0.46304347826087, 0.34090909090909
77648, 1.3521739130435, 0.46304347826087, 0.31818181818182
77649, 1.3739130434783, 0.48913043478261, 0.31818181818182
77650, 1.3739130434783, 0.46304347826087, 0.29545454545455
77651, 1.3521739130435, 0.46304347826087, 0.27272727272727
77652, 1.3739130434783, 0.48913043478261, 0.27272727272727
77653, 1.3739130434783, 0.46304347826087, 0.25
77654, 1.3521739130435, 0.46304347826087, 0.22727272727273
77655, 1.3739130434783, 0.48913043478261, 0.22727272727273
77656, 1.3739130434783, 0.46304347826087, 0.20454545454545
77657, 1.3521739130435, 0.46304347826087, 0.18181818181818
77658, 1.3739130434783, 0.48913043478261, 0.18181818181818
77659, 1.3739130434783, 0.46304347826087, 0.15909090909091
77660, 1.3521739130435, 0.46304347826087, 0.13636363636364
77661, 1.3739130434783, 0.48913043478261, 0.13636363636364
77662, 1.3739130434783, 0.46304347826087, 0.11363636363636
77663, 1.3521739130435, 0.46304347826087, 0.090909090909091
77664, 1.3739130434783, 0.48913043478261, 0.090909090909091
77665, 1.3739130434783, 0.46304347826087, 0.068181818181818
77666, 1.3521739130435, 0.46304347826087, 0.045454545454545
77667, 1.3739130434783, 0.48913043478261, 0.045454545454545
77668, 1.3739130434783, 0.46304347826087, 0.022727272727273
77669, 1.4173913043478, 0.46304347826087, 0.47727272727273
77670, 1.395652173913, 0.46304347826087, 0.45454545454545
77671, 1.4173913043478, 0.48913043478261, 0.45454545454545
77672, 1.4173913043478, 0.46304347826087, 0.43181818181818
77673, 1.395652173913, 0.46304347826087, 0.40909090909091
77674, 1.4173913043478, 0.48913043478261, 0.40909090909091
77675, 1.4173913043478, 0.46304347826087, 0.38636363636364
77676, 1.395652173913, 0.46304347826087, 0.36363636363636
77677, 1.4173913043478, 0.48913043478261, 0.36363636363636
77678, 1.4173913043478, 0.46304347826087, 0.34090909090909
77679, 1.395652173913, 0.46304347826087, 0.31818181818182
77680, 1.4173913043478, 0.48913043478261, 0.31818181818182
77681, 1.4173913043478, 0.46304347826087, 0.29545454545455
77682, 1.395652173913, 0.46304347826087, 0.27272727272727
77683, 1.4173913043478, 0.48913043478261, 0.27272727272727
77684, 1.4173913043478, 0.46304347826087, 0.25
77685, 1.395652173913, 0.46304347826087, 0.22727272727273
77686, 1.4173913043478, 0.48913043478261, 0.22727272727273
77687, 1.4173913043478, 0.46304347826087, 0.20454545454545
77688, 1.395652173913, 0.46304347826087, 0.18181818181818
77689, 1.4173913043478, 0.48913043478261, 0.18181818181818
77690, 1.4173913043478, 0.46304347826087, 0.15909090909091
77691, 1.395652173913, 0.46304347826087, 0.13636363636364
77692, 1.4173913043478, 0.48913043478261, 0.13636363636364
77693, 1.4173913043478, 0.46304347826087, 0.11363636363636
77694, 1.395652173913, 0.46304347826087, 0.090909090909091
77695, 1.4173913043478, 0.48913043478261, 0.090909090909091
77696, 1.4173913043478, 0.46304347826087, 0.068181818181818
77697, 1.395652173913, 0.46304347826087, 0.045454545454545
77698, 1.4173913043478, 0.48913043478261, 0.045454545454545
77699, 1.4173913043478, 0.46304347826087, 0.022727272727273
77700, 1.4608695652174, 0.46304347826087, 0.47727272727273
77701, 1.4391304347826, 0.46304347826087, 0.45454545454545
77702, 1.4608695652174, 0.48913043478261, 0.45454545454545
77703, 1.4608695652174, 0.46304347826087, 0.43181818181818
77704, 1.4391304347826, 0.46304347826087, 0.40909090909091
77705, 1.4608695652174, 0.48913043478261, 0.40909090909091
77706, 1.4608695652174, 0.46304347826087, 0.38636363636364
77707, 1.4391304347826, 0.46304347826087, 0.36363636363636
77708, 1.4608695652174, 0.48913043478261, 0.36363636363636
77709, 1.4608695652174, 0.46304347826087, 0.34090909090909
77710, 1.4391304347826, 0.46304347826087, 0.31818181818182
77711, 1.4608695652174, 0.48913043478261, 0.31818181818182
77712, 1.4608695652174, 0.46304347826087, 0.29545454545455
77713, 1.4391304347826, 0.46304347826087, 0.27272727272727
77714, 1.4608695652174, 0.48913043478261, 0.27272727272727
77715, 1.4608695652174, 0.46304347826087, 0.25
77716, 1.4391304347826, 0.46304347826087, 0.22727272727273
77717, 1.4608695652174, 0.48913043478261, 0.22727272727273
77718, 1.4608695652174, 0.46304347826087, 0.20454545454545
77719, 1.4391304347826, 0.46304347826087, 0.18181818181818
77720, 1.4608695652174, 0.48913043478261, 0.18181818181818
77721, 1.4608695652174, 0.46304347826087, 0.15909090909091
77722, 1.4391304347826, 0.46304347826087, 0.13636363636364
77723, 1.4608695652174, 0.48913043478261, 0.13636363636364
77724, 1.4608695652174, 0.46304347826087, 0.11363636363636
77725, 1.4391304347826, 0.46304347826087, 0.090909090909091
77726, 1.4608695652174, 0.48913043478261, 0.090909090909091
77727, 1.4608695652174, 0.46304347826087, 0.068181818181818
77728, 1.4391304347826, 0.46304347826087, 0.045454545454545
77729, 1.4608695652174, 0.48913043478261, 0.045454545454545
77730, 1.4608695652174, 0.46304347826087, 0.022727272727273
77731, 1.504347826087, 0.46304347826087, 0.47727272727273
77732, 1.4826086956522, 0.46304347826087, 0.45454545454545
77733, 1.504347826087, 0.48913043478261, 0.45454545454545
77734, 1.504347826087, 0.46304347826087, 0.43181818181818
77735, 1.4826086956522, 0.46304347826087, 0.40909090909091
77736, 1.504347826087, 0.48913043478261, 0.40909090909091
77737, 1.504347826087, 0.46304347826087, 0.38636363636364
77738, 1.4826086956522, 0.46304347826087, 0.36363636363636
77739, 1.504347826087, 0.48913043478261, 0.36363636363636
77740, 1.504347826087, 0.46304347826087, 0.34090909090909
77741, 1.4826086956522, 0.46304347826087, 0.31818181818182
77742, 1.504347826087, 0.48913043478261, 0.31818181818182
77743, 1.504347826087, 0.46304347826087, 0.29545454545455
77744, 1.4826086956522, 0.46304347826087, 0.27272727272727
77745, 1.504347826087, 0.48913043478261, 0.27272727272727
77746, 1.504347826087, 0.46304347826087, 0.25
77747, 1.4826086956522, 0.46304347826087, 0.22727272727273
77748, 1.504347826087, 0.48913043478261, 0.22727272727273
77749, 1.504347826087, 0.46304347826087, 0.20454545454545
77750, 1.4826086956522, 0.46304347826087, 0.18181818181818
77751, 1.504347826087, 0.48913043478261, 0.18181818181818
77752, 1.504347826087, 0.46304347826087, 0.15909090909091
77753, 1.4826086956522, 0.46304347826087, 0.13636363636364
77754, 1.504347826087, 0.48913043478261, 0.13636363636364
77755, 1.504347826087, 0.46304347826087, 0.11363636363636
77756, 1.4826086956522, 0.46304347826087, 0.090909090909091
77757, 1.504347826087, 0.48913043478261, 0.090909090909091
77758, 1.504347826087, 0.46304347826087, 0.068181818181818
77759, 1.4826086956522, 0.46304347826087, 0.045454545454545
77760, 1.504347826087, 0.48913043478261, 0.045454545454545
77761, 1.504347826087, 0.46304347826087, 0.022727272727273
77762, 1.5478260869565, 0.46304347826087, 0.47727272727273
77763, 1.5260869565217, 0.46304347826087, 0.45454545454545
77764, 1.5478260869565, 0.48913043478261, 0.45454545454545
77765, 1.5478260869565, 0.46304347826087, 0.43181818181818
77766, 1.5260869565217, 0.46304347826087, 0.40909090909091
77767, 1.5478260869565, 0.48913043478261, 0.40909090909091
77768, 1.5478260869565, 0.46304347826087, 0.38636363636364
77769, 1.5260869565217, 0.46304347826087, 0.36363636363636
77770, 1.5478260869565, 0.48913043478261, 0.36363636363636
77771, 1.5478260869565, 0.46304347826087, 0.34090909090909
77772, 1.5260869565217, 0.46304347826087, 0.31818181818182
77773, 1.5478260869565, 0.48913043478261, 0.31818181818182
77774, 1.5478260869565, 0.46304347826087, 0.29545454545455
77775, 1.5260869565217, 0.46304347826087, 0.27272727272727
77776, 1.5478260869565, 0.48913043478261, 0.27272727272727
77777, 1.5478260869565, 0.46304347826087, 0.25
77778, 1.5260869565217, 0.46304347826087, 0.22727272727273
77779, 1.5478260869565, 0.48913043478261, 0.22727272727273
77780, 1.5478260869565, 0.46304347826087, 0.20454545454545
77781, 1.5260869565217, 0.46304347826087, 0.18181818181818
77782, 1.5478260869565, 0.48913043478261, 0.18181818181818
77783, 1.5478260869565, 0.46304347826087, 0.15909090909091
77784, 1.5260869565217, 0.46304347826087, 0.13636363636364
77785, 1.5478260869565, 0.48913043478261, 0.13636363636364
77786, 1.5478260869565, 0.46304347826087, 0.11363636363636
77787, 1.5260869565217, 0.46304347826087, 0.090909090909091
77788, 1.5478260869565, 0.48913043478261, 0.090909090909091
77789, 1.5478260869565, 0.46304347826087, 0.068181818181818
77790, 1.5260869565217, 0.46304347826087, 0.045454545454545
77791, 1.5478260869565, 0.48913043478261, 0.045454545454545
77792, 1.5478260869565, 0.46304347826087, 0.022727272727273
77793, 1.5913043478261, 0.46304347826087, 0.47727272727273
77794, 1.5695652173913, 0.46304347826087, 0.45454545454545
77795, 1.5913043478261, 0.48913043478261, 0.45454545454545
77796, 1.5913043478261, 0.46304347826087, 0.43181818181818
77797, 1.5695652173913, 0.46304347826087, 0.40909090909091
77798, 1.5913043478261, 0.48913043478261, 0.40909090909091
77799, 1.5913043478261, 0.46304347826087, 0.38636363636364
77800, 1.5695652173913, 0.46304347826087, 0.36363636363636
77801, 1.5913043478261, 0.48913043478261, 0.36363636363636
77802, 1.5913043478261, 0.46304347826087, 0.34090909090909
77803, 1.5695652173913, 0.46304347826087, 0.31818181818182
77804, 1.5913043478261, 0.48913043478261, 0.31818181818182
77805, 1.5913043478261, 0.46304347826087, 0.29545454545455
77806, 1.5695652173913, 0.46304347826087, 0.27272727272727
77807, 1.5913043478261, 0.48913043478261, 0.27272727272727
77808, 1.5913043478261, 0.46304347826087, 0.25
77809, 1.5695652173913, 0.46304347826087, 0.22727272727273
77810, 1.5913043478261, 0.48913043478261, 0.22727272727273
77811, 1.5913043478261, 0.46304347826087, 0.20454545454545
77812, 1.5695652173913, 0.46304347826087, 0.18181818181818
77813, 1.5913043478261, 0.48913043478261, 0.18181818181818
77814, 1.5913043478261, 0.46304347826087, 0.15909090909091
77815, 1.5695652173913, 0.46304347826087, 0.13636363636364
77816, 1.5913043478261, 0.48913043478261, 0.13636363636364
77817, 1.5913043478261, 0.46304347826087, 0.11363636363636
77818, 1.5695652173913, 0.46304347826087, 0.090909090909091
77819, 1.5913043478261, 0.48913043478261, 0.090909090909091
77820, 1.5913043478261, 0.46304347826087, 0.068181818181818
77821, 1.5695652173913, 0.46304347826087, 0.045454545454545
77822, 1.5913043478261, 0.48913043478261, 0.045454545454545
77823, 1.5913043478261, 0.46304347826087, 0.022727272727273
77824, 1.6347826086957, 0.46304347826087, 0.47727272727273
77825, 1.6130434782609, 0.46304347826087, 0.45454545454545
77826, 1.6347826086957, 0.48913043478261, 0.45454545454545
77827, 1.6347826086957, 0.46304347826087, 0.43181818181818
77828, 1.6130434782609, 0.46304347826087, 0.40909090909091
77829, 1.6347826086957, 0.48913043478261, 0.40909090909091
77830, 1.6347826086957, 0.46304347826087, 0.38636363636364
77831, 1.6130434782609, 0.46304347826087, 0.36363636363636
77832, 1.6347826086957, 0.48913043478261, 0.36363636363636
77833, 1.6347826086957, 0.46304347826087, 0.34090909090909
77834, 1.6130434782609, 0.46304347826087, 0.31818181818182
77835, 1.6347826086957, 0.48913043478261, 0.31818181818182
77836, 1.6347826086957, 0.46304347826087, 0.29545454545455
77837, 1.6130434782609, 0.46304347826087, 0.27272727272727
77838, 1.6347826086957, 0.48913043478261, 0.27272727272727
77839, 1.6347826086957, 0.46304347826087, 0.25
77840, 1.6130434782609, 0.46304347826087, 0.22727272727273
77841, 1.6347826086957, 0.48913043478261, 0.22727272727273
77842, 1.6347826086957, 0.46304347826087, 0.20454545454545
77843, 1.6130434782609, 0.46304347826087, 0.18181818181818
77844, 1.6347826086957, 0.48913043478261, 0.18181818181818
77845, 1.6347826086957, 0.46304347826087, 0.15909090909091
77846, 1.6130434782609, 0.46304347826087, 0.13636363636364
77847, 1.6347826086957, 0.48913043478261, 0.13636363636364
77848, 1.6347826086957, 0.46304347826087, 0.11363636363636
77849, 1.6130434782609, 0.46304347826087, 0.090909090909091
77850, 1.6347826086957, 0.48913043478261, 0.090909090909091
77851, 1.6347826086957, 0.46304347826087, 0.068181818181818
77852, 1.6130434782609, 0.46304347826087, 0.045454545454545
77853, 1.6347826086957, 0.48913043478261, 0.045454545454545
77854, 1.6347826086957, 0.46304347826087, 0.022727272727273
77855, 1.6782608695652, 0.46304347826087, 0.47727272727273
77856, 1.6565217391304, 0.46304347826087, 0.45454545454545
77857, 1.6782608695652, 0.48913043478261, 0.45454545454545
77858, 1.6782608695652, 0.46304347826087, 0.43181818181818
77859, 1.6565217391304, 0.46304347826087, 0.40909090909091
77860, 1.6782608695652, 0.48913043478261, 0.40909090909091
77861, 1.6782608695652, 0.46304347826087, 0.38636363636364
77862, 1.6565217391304, 0.46304347826087, 0.36363636363636
77863, 1.6782608695652, 0.48913043478261, 0.36363636363636
77864, 1.6782608695652, 0.46304347826087, 0.34090909090909
77865, 1.6565217391304, 0.46304347826087, 0.31818181818182
77866, 1.6782608695652, 0.48913043478261, 0.31818181818182
77867, 1.6782608695652, 0.46304347826087, 0.29545454545455
77868, 1.6565217391304, 0.46304347826087, 0.27272727272727
77869, 1.6782608695652, 0.48913043478261, 0.27272727272727
77870, 1.6782608695652, 0.46304347826087, 0.25
77871, 1.6565217391304, 0.46304347826087, 0.22727272727273
77872, 1.6782608695652, 0.48913043478261, 0.22727272727273
77873, 1.6782608695652, 0.46304347826087, 0.20454545454545
77874, 1.6565217391304, 0.46304347826087, 0.18181818181818
77875, 1.6782608695652, 0.48913043478261, 0.18181818181818
77876, 1.6782608695652, 0.46304347826087, 0.15909090909091
77877, 1.6565217391304, 0.46304347826087, 0.13636363636364
77878, 1.6782608695652, 0.48913043478261, 0.13636363636364
77879, 1.6782608695652, 0.46304347826087, 0.11363636363636
77880, 1.6565217391304, 0.46304347826087, 0.090909090909091
77881, 1.6782608695652, 0.48913043478261, 0.090909090909091
77882, 1.6782608695652, 0.46304347826087, 0.068181818181818
77883, 1.6565217391304, 0.46304347826087, 0.045454545454545
77884, 1.6782608695652, 0.48913043478261, 0.045454545454545
77885, 1.6782608695652, 0.46304347826087, 0.022727272727273
77886, 1.7217391304348, 0.46304347826087, 0.47727272727273
77887, 1.7, 0.46304347826087, 0.45454545454545
77888, 1.7217391304348, 0.48913043478261, 0.45454545454545
77889, 1.7217391304348, 0.46304347826087, 0.43181818181818
77890, 1.7, 0.46304347826087, 0.40909090909091
77891, 1.7217391304348, 0.48913043478261, 0.40909090909091
77892, 1.7217391304348, 0.46304347826087, 0.38636363636364
77893, 1.7, 0.46304347826087, 0.36363636363636
77894, 1.7217391304348, 0.48913043478261, 0.36363636363636
77895, 1.7217391304348, 0.46304347826087, 0.34090909090909
77896, 1.7, 0.46304347826087, 0.31818181818182
77897, 1.7217391304348, 0.48913043478261, 0.31818181818182
77898, 1.7217391304348, 0.46304347826087, 0.29545454545455
77899, 1.7, 0.46304347826087, 0.27272727272727
77900, 1.7217391304348, 0.48913043478261, 0.27272727272727
77901, 1.7217391304348, 0.46304347826087, 0.25
77902, 1.7, 0.46304347826087, 0.22727272727273
77903, 1.7217391304348, 0.48913043478261, 0.22727272727273
77904, 1.7217391304348, 0.46304347826087, 0.20454545454545
77905, 1.7, 0.46304347826087, 0.18181818181818
77906, 1.7217391304348, 0.48913043478261, 0.18181818181818
77907, 1.7217391304348, 0.46304347826087, 0.15909090909091
77908, 1.7, 0.46304347826087, 0.13636363636364
77909, 1.7217391304348, 0.48913043478261, 0.13636363636364
77910, 1.7217391304348, 0.46304347826087, 0.11363636363636
77911, 1.7, 0.46304347826087, 0.090909090909091
77912, 1.7217391304348, 0.48913043478261, 0.090909090909091
77913, 1.7217391304348, 0.46304347826087, 0.068181818181818
77914, 1.7, 0.46304347826087, 0.045454545454545
