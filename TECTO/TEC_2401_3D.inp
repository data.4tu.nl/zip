83233, 2.0260869565217, 0.066666666666667, 0.27272727272727
83234, 2.0260869565217, 0.066666666666667, 0.22727272727273
83235, 2.0260869565217, 0.066666666666667, 0.18181818181818
83236, 2.0260869565217, 0.066666666666667, 0.13636363636364
83237, 2.0260869565217, 0.066666666666667, 0.090909090909091
83238, 2.0260869565217, 0.066666666666667, 0.045454545454545
83239, 2.0695652173913, 0.066666666666667, 0.45454545454545
83240, 2.0695652173913, 0.066666666666667, 0.40909090909091
83241, 2.0695652173913, 0.066666666666667, 0.36363636363636
83242, 2.0695652173913, 0.066666666666667, 0.31818181818182
83243, 2.0695652173913, 0.066666666666667, 0.27272727272727
83244, 2.0695652173913, 0.066666666666667, 0.22727272727273
83245, 2.0695652173913, 0.066666666666667, 0.18181818181818
83246, 2.0695652173913, 0.066666666666667, 0.13636363636364
83247, 2.0695652173913, 0.066666666666667, 0.090909090909091
83248, 2.0695652173913, 0.066666666666667, 0.045454545454545
83249, 2.1130434782609, 0.066666666666667, 0.45454545454545
83250, 2.1130434782609, 0.066666666666667, 0.40909090909091
83251, 2.1130434782609, 0.066666666666667, 0.36363636363636
83252, 2.1130434782609, 0.066666666666667, 0.31818181818182
83253, 2.1130434782609, 0.066666666666667, 0.27272727272727
83254, 2.1130434782609, 0.066666666666667, 0.22727272727273
83255, 2.1130434782609, 0.066666666666667, 0.18181818181818
83256, 2.1130434782609, 0.066666666666667, 0.13636363636364
83257, 2.1130434782609, 0.066666666666667, 0.090909090909091
83258, 2.1130434782609, 0.066666666666667, 0.045454545454545
83259, 2.1565217391304, 0.066666666666667, 0.45454545454545
83260, 2.1565217391304, 0.066666666666667, 0.40909090909091
83261, 2.1565217391304, 0.066666666666667, 0.36363636363636
83262, 2.1565217391304, 0.066666666666667, 0.31818181818182
83263, 2.1565217391304, 0.066666666666667, 0.27272727272727
83264, 2.1565217391304, 0.066666666666667, 0.22727272727273
83265, 2.1565217391304, 0.066666666666667, 0.18181818181818
83266, 2.1565217391304, 0.066666666666667, 0.13636363636364
83267, 2.1565217391304, 0.066666666666667, 0.090909090909091
83268, 2.1565217391304, 0.066666666666667, 0.045454545454545
83269, 1.2434782608696, 0.033333333333333, 0.45454545454545
83270, 1.2434782608696, 0.033333333333333, 0.40909090909091
83271, 1.2434782608696, 0.033333333333333, 0.36363636363636
83272, 1.2434782608696, 0.033333333333333, 0.31818181818182
83273, 1.2434782608696, 0.033333333333333, 0.27272727272727
83274, 1.2434782608696, 0.033333333333333, 0.22727272727273
83275, 1.2434782608696, 0.033333333333333, 0.18181818181818
83276, 1.2434782608696, 0.033333333333333, 0.13636363636364
83277, 1.2434782608696, 0.033333333333333, 0.090909090909091
83278, 1.2434782608696, 0.033333333333333, 0.045454545454545
83279, 1.2869565217391, 0.033333333333333, 0.45454545454545
83280, 1.2869565217391, 0.033333333333333, 0.40909090909091
83281, 1.2869565217391, 0.033333333333333, 0.36363636363636
83282, 1.2869565217391, 0.033333333333333, 0.31818181818182
83283, 1.2869565217391, 0.033333333333333, 0.27272727272727
83284, 1.2869565217391, 0.033333333333333, 0.22727272727273
83285, 1.2869565217391, 0.033333333333333, 0.18181818181818
83286, 1.2869565217391, 0.033333333333333, 0.13636363636364
83287, 1.2869565217391, 0.033333333333333, 0.090909090909091
83288, 1.2869565217391, 0.033333333333333, 0.045454545454545
83289, 1.3304347826087, 0.033333333333333, 0.45454545454545
83290, 1.3304347826087, 0.033333333333333, 0.40909090909091
83291, 1.3304347826087, 0.033333333333333, 0.36363636363636
83292, 1.3304347826087, 0.033333333333333, 0.31818181818182
83293, 1.3304347826087, 0.033333333333333, 0.27272727272727
83294, 1.3304347826087, 0.033333333333333, 0.22727272727273
83295, 1.3304347826087, 0.033333333333333, 0.18181818181818
83296, 1.3304347826087, 0.033333333333333, 0.13636363636364
83297, 1.3304347826087, 0.033333333333333, 0.090909090909091
83298, 1.3304347826087, 0.033333333333333, 0.045454545454545
83299, 1.3739130434783, 0.033333333333333, 0.45454545454545
83300, 1.3739130434783, 0.033333333333333, 0.40909090909091
83301, 1.3739130434783, 0.033333333333333, 0.36363636363636
83302, 1.3739130434783, 0.033333333333333, 0.31818181818182
83303, 1.3739130434783, 0.033333333333333, 0.27272727272727
83304, 1.3739130434783, 0.033333333333333, 0.22727272727273
83305, 1.3739130434783, 0.033333333333333, 0.18181818181818
83306, 1.3739130434783, 0.033333333333333, 0.13636363636364
83307, 1.3739130434783, 0.033333333333333, 0.090909090909091
83308, 1.3739130434783, 0.033333333333333, 0.045454545454545
83309, 1.4173913043478, 0.033333333333333, 0.45454545454545
83310, 1.4173913043478, 0.033333333333333, 0.40909090909091
83311, 1.4173913043478, 0.033333333333333, 0.36363636363636
83312, 1.4173913043478, 0.033333333333333, 0.31818181818182
83313, 1.4173913043478, 0.033333333333333, 0.27272727272727
83314, 1.4173913043478, 0.033333333333333, 0.22727272727273
83315, 1.4173913043478, 0.033333333333333, 0.18181818181818
83316, 1.4173913043478, 0.033333333333333, 0.13636363636364
83317, 1.4173913043478, 0.033333333333333, 0.090909090909091
83318, 1.4173913043478, 0.033333333333333, 0.045454545454545
83319, 1.4608695652174, 0.033333333333333, 0.45454545454545
83320, 1.4608695652174, 0.033333333333333, 0.40909090909091
83321, 1.4608695652174, 0.033333333333333, 0.36363636363636
83322, 1.4608695652174, 0.033333333333333, 0.31818181818182
83323, 1.4608695652174, 0.033333333333333, 0.27272727272727
83324, 1.4608695652174, 0.033333333333333, 0.22727272727273
83325, 1.4608695652174, 0.033333333333333, 0.18181818181818
83326, 1.4608695652174, 0.033333333333333, 0.13636363636364
83327, 1.4608695652174, 0.033333333333333, 0.090909090909091
83328, 1.4608695652174, 0.033333333333333, 0.045454545454545
83329, 1.504347826087, 0.033333333333333, 0.45454545454545
83330, 1.504347826087, 0.033333333333333, 0.40909090909091
83331, 1.504347826087, 0.033333333333333, 0.36363636363636
83332, 1.504347826087, 0.033333333333333, 0.31818181818182
83333, 1.504347826087, 0.033333333333333, 0.27272727272727
83334, 1.504347826087, 0.033333333333333, 0.22727272727273
83335, 1.504347826087, 0.033333333333333, 0.18181818181818
83336, 1.504347826087, 0.033333333333333, 0.13636363636364
83337, 1.504347826087, 0.033333333333333, 0.090909090909091
83338, 1.504347826087, 0.033333333333333, 0.045454545454545
83339, 1.5478260869565, 0.033333333333333, 0.45454545454545
83340, 1.5478260869565, 0.033333333333333, 0.40909090909091
83341, 1.5478260869565, 0.033333333333333, 0.36363636363636
83342, 1.5478260869565, 0.033333333333333, 0.31818181818182
83343, 1.5478260869565, 0.033333333333333, 0.27272727272727
83344, 1.5478260869565, 0.033333333333333, 0.22727272727273
83345, 1.5478260869565, 0.033333333333333, 0.18181818181818
83346, 1.5478260869565, 0.033333333333333, 0.13636363636364
83347, 1.5478260869565, 0.033333333333333, 0.090909090909091
83348, 1.5478260869565, 0.033333333333333, 0.045454545454545
83349, 1.5913043478261, 0.033333333333333, 0.45454545454545
83350, 1.5913043478261, 0.033333333333333, 0.40909090909091
83351, 1.5913043478261, 0.033333333333333, 0.36363636363636
83352, 1.5913043478261, 0.033333333333333, 0.31818181818182
83353, 1.5913043478261, 0.033333333333333, 0.27272727272727
83354, 1.5913043478261, 0.033333333333333, 0.22727272727273
83355, 1.5913043478261, 0.033333333333333, 0.18181818181818
83356, 1.5913043478261, 0.033333333333333, 0.13636363636364
83357, 1.5913043478261, 0.033333333333333, 0.090909090909091
83358, 1.5913043478261, 0.033333333333333, 0.045454545454545
83359, 1.6347826086957, 0.033333333333333, 0.45454545454545
83360, 1.6347826086957, 0.033333333333333, 0.40909090909091
83361, 1.6347826086957, 0.033333333333333, 0.36363636363636
83362, 1.6347826086957, 0.033333333333333, 0.31818181818182
83363, 1.6347826086957, 0.033333333333333, 0.27272727272727
83364, 1.6347826086957, 0.033333333333333, 0.22727272727273
83365, 1.6347826086957, 0.033333333333333, 0.18181818181818
83366, 1.6347826086957, 0.033333333333333, 0.13636363636364
83367, 1.6347826086957, 0.033333333333333, 0.090909090909091
83368, 1.6347826086957, 0.033333333333333, 0.045454545454545
83369, 1.6782608695652, 0.033333333333333, 0.45454545454545
83370, 1.6782608695652, 0.033333333333333, 0.40909090909091
83371, 1.6782608695652, 0.033333333333333, 0.36363636363636
83372, 1.6782608695652, 0.033333333333333, 0.31818181818182
83373, 1.6782608695652, 0.033333333333333, 0.27272727272727
83374, 1.6782608695652, 0.033333333333333, 0.22727272727273
83375, 1.6782608695652, 0.033333333333333, 0.18181818181818
83376, 1.6782608695652, 0.033333333333333, 0.13636363636364
83377, 1.6782608695652, 0.033333333333333, 0.090909090909091
83378, 1.6782608695652, 0.033333333333333, 0.045454545454545
83379, 1.7217391304348, 0.033333333333333, 0.45454545454545
83380, 1.7217391304348, 0.033333333333333, 0.40909090909091
83381, 1.7217391304348, 0.033333333333333, 0.36363636363636
83382, 1.7217391304348, 0.033333333333333, 0.31818181818182
83383, 1.7217391304348, 0.033333333333333, 0.27272727272727
83384, 1.7217391304348, 0.033333333333333, 0.22727272727273
83385, 1.7217391304348, 0.033333333333333, 0.18181818181818
83386, 1.7217391304348, 0.033333333333333, 0.13636363636364
83387, 1.7217391304348, 0.033333333333333, 0.090909090909091
83388, 1.7217391304348, 0.033333333333333, 0.045454545454545
83389, 1.7652173913043, 0.033333333333333, 0.45454545454545
83390, 1.7652173913043, 0.033333333333333, 0.40909090909091
83391, 1.7652173913043, 0.033333333333333, 0.36363636363636
83392, 1.7652173913043, 0.033333333333333, 0.31818181818182
83393, 1.7652173913043, 0.033333333333333, 0.27272727272727
83394, 1.7652173913043, 0.033333333333333, 0.22727272727273
83395, 1.7652173913043, 0.033333333333333, 0.18181818181818
83396, 1.7652173913043, 0.033333333333333, 0.13636363636364
83397, 1.7652173913043, 0.033333333333333, 0.090909090909091
83398, 1.7652173913043, 0.033333333333333, 0.045454545454545
83399, 1.8086956521739, 0.033333333333333, 0.45454545454545
83400, 1.8086956521739, 0.033333333333333, 0.40909090909091
83401, 1.8086956521739, 0.033333333333333, 0.36363636363636
83402, 1.8086956521739, 0.033333333333333, 0.31818181818182
83403, 1.8086956521739, 0.033333333333333, 0.27272727272727
83404, 1.8086956521739, 0.033333333333333, 0.22727272727273
83405, 1.8086956521739, 0.033333333333333, 0.18181818181818
83406, 1.8086956521739, 0.033333333333333, 0.13636363636364
83407, 1.8086956521739, 0.033333333333333, 0.090909090909091
83408, 1.8086956521739, 0.033333333333333, 0.045454545454545
83409, 1.8521739130435, 0.033333333333333, 0.45454545454545
83410, 1.8521739130435, 0.033333333333333, 0.40909090909091
83411, 1.8521739130435, 0.033333333333333, 0.36363636363636
83412, 1.8521739130435, 0.033333333333333, 0.31818181818182
83413, 1.8521739130435, 0.033333333333333, 0.27272727272727
83414, 1.8521739130435, 0.033333333333333, 0.22727272727273
83415, 1.8521739130435, 0.033333333333333, 0.18181818181818
83416, 1.8521739130435, 0.033333333333333, 0.13636363636364
83417, 1.8521739130435, 0.033333333333333, 0.090909090909091
83418, 1.8521739130435, 0.033333333333333, 0.045454545454545
83419, 1.895652173913, 0.033333333333333, 0.45454545454545
83420, 1.895652173913, 0.033333333333333, 0.40909090909091
83421, 1.895652173913, 0.033333333333333, 0.36363636363636
83422, 1.895652173913, 0.033333333333333, 0.31818181818182
83423, 1.895652173913, 0.033333333333333, 0.27272727272727
83424, 1.895652173913, 0.033333333333333, 0.22727272727273
83425, 1.895652173913, 0.033333333333333, 0.18181818181818
83426, 1.895652173913, 0.033333333333333, 0.13636363636364
83427, 1.895652173913, 0.033333333333333, 0.090909090909091
83428, 1.895652173913, 0.033333333333333, 0.045454545454545
83429, 1.9391304347826, 0.033333333333333, 0.45454545454545
83430, 1.9391304347826, 0.033333333333333, 0.40909090909091
83431, 1.9391304347826, 0.033333333333333, 0.36363636363636
83432, 1.9391304347826, 0.033333333333333, 0.31818181818182
83433, 1.9391304347826, 0.033333333333333, 0.27272727272727
83434, 1.9391304347826, 0.033333333333333, 0.22727272727273
83435, 1.9391304347826, 0.033333333333333, 0.18181818181818
83436, 1.9391304347826, 0.033333333333333, 0.13636363636364
83437, 1.9391304347826, 0.033333333333333, 0.090909090909091
83438, 1.9391304347826, 0.033333333333333, 0.045454545454545
83439, 1.9826086956522, 0.033333333333333, 0.45454545454545
83440, 1.9826086956522, 0.033333333333333, 0.40909090909091
83441, 1.9826086956522, 0.033333333333333, 0.36363636363636
83442, 1.9826086956522, 0.033333333333333, 0.31818181818182
83443, 1.9826086956522, 0.033333333333333, 0.27272727272727
83444, 1.9826086956522, 0.033333333333333, 0.22727272727273
83445, 1.9826086956522, 0.033333333333333, 0.18181818181818
83446, 1.9826086956522, 0.033333333333333, 0.13636363636364
83447, 1.9826086956522, 0.033333333333333, 0.090909090909091
83448, 1.9826086956522, 0.033333333333333, 0.045454545454545
83449, 2.0260869565217, 0.033333333333333, 0.45454545454545
83450, 2.0260869565217, 0.033333333333333, 0.40909090909091
83451, 2.0260869565217, 0.033333333333333, 0.36363636363636
83452, 2.0260869565217, 0.033333333333333, 0.31818181818182
83453, 2.0260869565217, 0.033333333333333, 0.27272727272727
83454, 2.0260869565217, 0.033333333333333, 0.22727272727273
83455, 2.0260869565217, 0.033333333333333, 0.18181818181818
83456, 2.0260869565217, 0.033333333333333, 0.13636363636364
83457, 2.0260869565217, 0.033333333333333, 0.090909090909091
83458, 2.0260869565217, 0.033333333333333, 0.045454545454545
83459, 2.0695652173913, 0.033333333333333, 0.45454545454545
83460, 2.0695652173913, 0.033333333333333, 0.40909090909091
83461, 2.0695652173913, 0.033333333333333, 0.36363636363636
83462, 2.0695652173913, 0.033333333333333, 0.31818181818182
83463, 2.0695652173913, 0.033333333333333, 0.27272727272727
83464, 2.0695652173913, 0.033333333333333, 0.22727272727273
83465, 2.0695652173913, 0.033333333333333, 0.18181818181818
83466, 2.0695652173913, 0.033333333333333, 0.13636363636364
83467, 2.0695652173913, 0.033333333333333, 0.090909090909091
83468, 2.0695652173913, 0.033333333333333, 0.045454545454545
83469, 2.1130434782609, 0.033333333333333, 0.45454545454545
83470, 2.1130434782609, 0.033333333333333, 0.40909090909091
83471, 2.1130434782609, 0.033333333333333, 0.36363636363636
83472, 2.1130434782609, 0.033333333333333, 0.31818181818182
83473, 2.1130434782609, 0.033333333333333, 0.27272727272727
83474, 2.1130434782609, 0.033333333333333, 0.22727272727273
83475, 2.1130434782609, 0.033333333333333, 0.18181818181818
83476, 2.1130434782609, 0.033333333333333, 0.13636363636364
83477, 2.1130434782609, 0.033333333333333, 0.090909090909091
83478, 2.1130434782609, 0.033333333333333, 0.045454545454545
83479, 2.1565217391304, 0.033333333333333, 0.45454545454545
83480, 2.1565217391304, 0.033333333333333, 0.40909090909091
83481, 2.1565217391304, 0.033333333333333, 0.36363636363636
83482, 2.1565217391304, 0.033333333333333, 0.31818181818182
83483, 2.1565217391304, 0.033333333333333, 0.27272727272727
83484, 2.1565217391304, 0.033333333333333, 0.22727272727273
83485, 2.1565217391304, 0.033333333333333, 0.18181818181818
83486, 2.1565217391304, 0.033333333333333, 0.13636363636364
83487, 2.1565217391304, 0.033333333333333, 0.090909090909091
83488, 2.1565217391304, 0.033333333333333, 0.045454545454545
83489, 1.2434782608696, 0.066666666666667, 0.47727272727273
83490, 1.2217391304348, 0.066666666666667, 0.45454545454545
83491, 1.2434782608696, 0.083333333333333, 0.45454545454545
83492, 1.2434782608696, 0.066666666666667, 0.43181818181818
83493, 1.2217391304348, 0.066666666666667, 0.40909090909091
83494, 1.2434782608696, 0.083333333333333, 0.40909090909091
83495, 1.2434782608696, 0.066666666666667, 0.38636363636364
83496, 1.2217391304348, 0.066666666666667, 0.36363636363636
83497, 1.2434782608696, 0.083333333333333, 0.36363636363636
83498, 1.2434782608696, 0.066666666666667, 0.34090909090909
83499, 1.2217391304348, 0.066666666666667, 0.31818181818182
83500, 1.2434782608696, 0.083333333333333, 0.31818181818182
83501, 1.2434782608696, 0.066666666666667, 0.29545454545455
83502, 1.2217391304348, 0.066666666666667, 0.27272727272727
83503, 1.2434782608696, 0.083333333333333, 0.27272727272727
83504, 1.2434782608696, 0.066666666666667, 0.25
83505, 1.2217391304348, 0.066666666666667, 0.22727272727273
83506, 1.2434782608696, 0.083333333333333, 0.22727272727273
83507, 1.2434782608696, 0.066666666666667, 0.20454545454545
83508, 1.2217391304348, 0.066666666666667, 0.18181818181818
83509, 1.2434782608696, 0.083333333333333, 0.18181818181818
83510, 1.2434782608696, 0.066666666666667, 0.15909090909091
83511, 1.2217391304348, 0.066666666666667, 0.13636363636364
83512, 1.2434782608696, 0.083333333333333, 0.13636363636364
83513, 1.2434782608696, 0.066666666666667, 0.11363636363636
83514, 1.2217391304348, 0.066666666666667, 0.090909090909091
83515, 1.2434782608696, 0.083333333333333, 0.090909090909091
83516, 1.2434782608696, 0.066666666666667, 0.068181818181818
83517, 1.2217391304348, 0.066666666666667, 0.045454545454545
83518, 1.2434782608696, 0.083333333333333, 0.045454545454545
83519, 1.2434782608696, 0.066666666666667, 0.022727272727273
83520, 1.2869565217391, 0.066666666666667, 0.47727272727273
83521, 1.2652173913043, 0.066666666666667, 0.45454545454545
83522, 1.2869565217391, 0.083333333333333, 0.45454545454545
83523, 1.2869565217391, 0.066666666666667, 0.43181818181818
83524, 1.2652173913043, 0.066666666666667, 0.40909090909091
83525, 1.2869565217391, 0.083333333333333, 0.40909090909091
83526, 1.2869565217391, 0.066666666666667, 0.38636363636364
83527, 1.2652173913043, 0.066666666666667, 0.36363636363636
83528, 1.2869565217391, 0.083333333333333, 0.36363636363636
83529, 1.2869565217391, 0.066666666666667, 0.34090909090909
83530, 1.2652173913043, 0.066666666666667, 0.31818181818182
83531, 1.2869565217391, 0.083333333333333, 0.31818181818182
83532, 1.2869565217391, 0.066666666666667, 0.29545454545455
83533, 1.2652173913043, 0.066666666666667, 0.27272727272727
83534, 1.2869565217391, 0.083333333333333, 0.27272727272727
83535, 1.2869565217391, 0.066666666666667, 0.25
83536, 1.2652173913043, 0.066666666666667, 0.22727272727273
83537, 1.2869565217391, 0.083333333333333, 0.22727272727273
83538, 1.2869565217391, 0.066666666666667, 0.20454545454545
83539, 1.2652173913043, 0.066666666666667, 0.18181818181818
83540, 1.2869565217391, 0.083333333333333, 0.18181818181818
83541, 1.2869565217391, 0.066666666666667, 0.15909090909091
83542, 1.2652173913043, 0.066666666666667, 0.13636363636364
83543, 1.2869565217391, 0.083333333333333, 0.13636363636364
83544, 1.2869565217391, 0.066666666666667, 0.11363636363636
83545, 1.2652173913043, 0.066666666666667, 0.090909090909091
83546, 1.2869565217391, 0.083333333333333, 0.090909090909091
83547, 1.2869565217391, 0.066666666666667, 0.068181818181818
83548, 1.2652173913043, 0.066666666666667, 0.045454545454545
83549, 1.2869565217391, 0.083333333333333, 0.045454545454545
83550, 1.2869565217391, 0.066666666666667, 0.022727272727273
83551, 1.3304347826087, 0.066666666666667, 0.47727272727273
83552, 1.3086956521739, 0.066666666666667, 0.45454545454545
83553, 1.3304347826087, 0.083333333333333, 0.45454545454545
83554, 1.3304347826087, 0.066666666666667, 0.43181818181818
83555, 1.3086956521739, 0.066666666666667, 0.40909090909091
83556, 1.3304347826087, 0.083333333333333, 0.40909090909091
83557, 1.3304347826087, 0.066666666666667, 0.38636363636364
83558, 1.3086956521739, 0.066666666666667, 0.36363636363636
83559, 1.3304347826087, 0.083333333333333, 0.36363636363636
83560, 1.3304347826087, 0.066666666666667, 0.34090909090909
83561, 1.3086956521739, 0.066666666666667, 0.31818181818182
83562, 1.3304347826087, 0.083333333333333, 0.31818181818182
83563, 1.3304347826087, 0.066666666666667, 0.29545454545455
83564, 1.3086956521739, 0.066666666666667, 0.27272727272727
83565, 1.3304347826087, 0.083333333333333, 0.27272727272727
83566, 1.3304347826087, 0.066666666666667, 0.25
83567, 1.3086956521739, 0.066666666666667, 0.22727272727273
83568, 1.3304347826087, 0.083333333333333, 0.22727272727273
83569, 1.3304347826087, 0.066666666666667, 0.20454545454545
83570, 1.3086956521739, 0.066666666666667, 0.18181818181818
83571, 1.3304347826087, 0.083333333333333, 0.18181818181818
83572, 1.3304347826087, 0.066666666666667, 0.15909090909091
83573, 1.3086956521739, 0.066666666666667, 0.13636363636364
83574, 1.3304347826087, 0.083333333333333, 0.13636363636364
83575, 1.3304347826087, 0.066666666666667, 0.11363636363636
83576, 1.3086956521739, 0.066666666666667, 0.090909090909091
83577, 1.3304347826087, 0.083333333333333, 0.090909090909091
83578, 1.3304347826087, 0.066666666666667, 0.068181818181818
83579, 1.3086956521739, 0.066666666666667, 0.045454545454545
83580, 1.3304347826087, 0.083333333333333, 0.045454545454545
83581, 1.3304347826087, 0.066666666666667, 0.022727272727273
83582, 1.3739130434783, 0.066666666666667, 0.47727272727273
83583, 1.3521739130435, 0.066666666666667, 0.45454545454545
83584, 1.3739130434783, 0.083333333333333, 0.45454545454545
83585, 1.3739130434783, 0.066666666666667, 0.43181818181818
83586, 1.3521739130435, 0.066666666666667, 0.40909090909091
83587, 1.3739130434783, 0.083333333333333, 0.40909090909091
83588, 1.3739130434783, 0.066666666666667, 0.38636363636364
83589, 1.3521739130435, 0.066666666666667, 0.36363636363636
83590, 1.3739130434783, 0.083333333333333, 0.36363636363636
83591, 1.3739130434783, 0.066666666666667, 0.34090909090909
83592, 1.3521739130435, 0.066666666666667, 0.31818181818182
83593, 1.3739130434783, 0.083333333333333, 0.31818181818182
83594, 1.3739130434783, 0.066666666666667, 0.29545454545455
83595, 1.3521739130435, 0.066666666666667, 0.27272727272727
83596, 1.3739130434783, 0.083333333333333, 0.27272727272727
83597, 1.3739130434783, 0.066666666666667, 0.25
83598, 1.3521739130435, 0.066666666666667, 0.22727272727273
83599, 1.3739130434783, 0.083333333333333, 0.22727272727273
83600, 1.3739130434783, 0.066666666666667, 0.20454545454545
83601, 1.3521739130435, 0.066666666666667, 0.18181818181818
83602, 1.3739130434783, 0.083333333333333, 0.18181818181818
83603, 1.3739130434783, 0.066666666666667, 0.15909090909091
83604, 1.3521739130435, 0.066666666666667, 0.13636363636364
83605, 1.3739130434783, 0.083333333333333, 0.13636363636364
83606, 1.3739130434783, 0.066666666666667, 0.11363636363636
83607, 1.3521739130435, 0.066666666666667, 0.090909090909091
83608, 1.3739130434783, 0.083333333333333, 0.090909090909091
83609, 1.3739130434783, 0.066666666666667, 0.068181818181818
83610, 1.3521739130435, 0.066666666666667, 0.045454545454545
83611, 1.3739130434783, 0.083333333333333, 0.045454545454545
83612, 1.3739130434783, 0.066666666666667, 0.022727272727273
83613, 1.4173913043478, 0.066666666666667, 0.47727272727273
83614, 1.395652173913, 0.066666666666667, 0.45454545454545
83615, 1.4173913043478, 0.083333333333333, 0.45454545454545
83616, 1.4173913043478, 0.066666666666667, 0.43181818181818
83617, 1.395652173913, 0.066666666666667, 0.40909090909091
83618, 1.4173913043478, 0.083333333333333, 0.40909090909091
83619, 1.4173913043478, 0.066666666666667, 0.38636363636364
83620, 1.395652173913, 0.066666666666667, 0.36363636363636
83621, 1.4173913043478, 0.083333333333333, 0.36363636363636
83622, 1.4173913043478, 0.066666666666667, 0.34090909090909
83623, 1.395652173913, 0.066666666666667, 0.31818181818182
83624, 1.4173913043478, 0.083333333333333, 0.31818181818182
83625, 1.4173913043478, 0.066666666666667, 0.29545454545455
83626, 1.395652173913, 0.066666666666667, 0.27272727272727
83627, 1.4173913043478, 0.083333333333333, 0.27272727272727
83628, 1.4173913043478, 0.066666666666667, 0.25
83629, 1.395652173913, 0.066666666666667, 0.22727272727273
83630, 1.4173913043478, 0.083333333333333, 0.22727272727273
83631, 1.4173913043478, 0.066666666666667, 0.20454545454545
83632, 1.395652173913, 0.066666666666667, 0.18181818181818
83633, 1.4173913043478, 0.083333333333333, 0.18181818181818
83634, 1.4173913043478, 0.066666666666667, 0.15909090909091
83635, 1.395652173913, 0.066666666666667, 0.13636363636364
83636, 1.4173913043478, 0.083333333333333, 0.13636363636364
83637, 1.4173913043478, 0.066666666666667, 0.11363636363636
83638, 1.395652173913, 0.066666666666667, 0.090909090909091
83639, 1.4173913043478, 0.083333333333333, 0.090909090909091
83640, 1.4173913043478, 0.066666666666667, 0.068181818181818
83641, 1.395652173913, 0.066666666666667, 0.045454545454545
83642, 1.4173913043478, 0.083333333333333, 0.045454545454545
83643, 1.4173913043478, 0.066666666666667, 0.022727272727273
83644, 1.4608695652174, 0.066666666666667, 0.47727272727273
83645, 1.4391304347826, 0.066666666666667, 0.45454545454545
83646, 1.4608695652174, 0.083333333333333, 0.45454545454545
83647, 1.4608695652174, 0.066666666666667, 0.43181818181818
83648, 1.4391304347826, 0.066666666666667, 0.40909090909091
83649, 1.4608695652174, 0.083333333333333, 0.40909090909091
83650, 1.4608695652174, 0.066666666666667, 0.38636363636364
83651, 1.4391304347826, 0.066666666666667, 0.36363636363636
83652, 1.4608695652174, 0.083333333333333, 0.36363636363636
83653, 1.4608695652174, 0.066666666666667, 0.34090909090909
83654, 1.4391304347826, 0.066666666666667, 0.31818181818182
83655, 1.4608695652174, 0.083333333333333, 0.31818181818182
83656, 1.4608695652174, 0.066666666666667, 0.29545454545455
83657, 1.4391304347826, 0.066666666666667, 0.27272727272727
83658, 1.4608695652174, 0.083333333333333, 0.27272727272727
83659, 1.4608695652174, 0.066666666666667, 0.25
83660, 1.4391304347826, 0.066666666666667, 0.22727272727273
83661, 1.4608695652174, 0.083333333333333, 0.22727272727273
83662, 1.4608695652174, 0.066666666666667, 0.20454545454545
83663, 1.4391304347826, 0.066666666666667, 0.18181818181818
83664, 1.4608695652174, 0.083333333333333, 0.18181818181818
83665, 1.4608695652174, 0.066666666666667, 0.15909090909091
83666, 1.4391304347826, 0.066666666666667, 0.13636363636364
83667, 1.4608695652174, 0.083333333333333, 0.13636363636364
83668, 1.4608695652174, 0.066666666666667, 0.11363636363636
83669, 1.4391304347826, 0.066666666666667, 0.090909090909091
83670, 1.4608695652174, 0.083333333333333, 0.090909090909091
83671, 1.4608695652174, 0.066666666666667, 0.068181818181818
83672, 1.4391304347826, 0.066666666666667, 0.045454545454545
83673, 1.4608695652174, 0.083333333333333, 0.045454545454545
83674, 1.4608695652174, 0.066666666666667, 0.022727272727273
83675, 1.504347826087, 0.066666666666667, 0.47727272727273
83676, 1.4826086956522, 0.066666666666667, 0.45454545454545
83677, 1.504347826087, 0.083333333333333, 0.45454545454545
83678, 1.504347826087, 0.066666666666667, 0.43181818181818
83679, 1.4826086956522, 0.066666666666667, 0.40909090909091
83680, 1.504347826087, 0.083333333333333, 0.40909090909091
83681, 1.504347826087, 0.066666666666667, 0.38636363636364
83682, 1.4826086956522, 0.066666666666667, 0.36363636363636
83683, 1.504347826087, 0.083333333333333, 0.36363636363636
83684, 1.504347826087, 0.066666666666667, 0.34090909090909
83685, 1.4826086956522, 0.066666666666667, 0.31818181818182
83686, 1.504347826087, 0.083333333333333, 0.31818181818182
83687, 1.504347826087, 0.066666666666667, 0.29545454545455
83688, 1.4826086956522, 0.066666666666667, 0.27272727272727
83689, 1.504347826087, 0.083333333333333, 0.27272727272727
83690, 1.504347826087, 0.066666666666667, 0.25
83691, 1.4826086956522, 0.066666666666667, 0.22727272727273
83692, 1.504347826087, 0.083333333333333, 0.22727272727273
83693, 1.504347826087, 0.066666666666667, 0.20454545454545
83694, 1.4826086956522, 0.066666666666667, 0.18181818181818
83695, 1.504347826087, 0.083333333333333, 0.18181818181818
83696, 1.504347826087, 0.066666666666667, 0.15909090909091
83697, 1.4826086956522, 0.066666666666667, 0.13636363636364
83698, 1.504347826087, 0.083333333333333, 0.13636363636364
83699, 1.504347826087, 0.066666666666667, 0.11363636363636
83700, 1.4826086956522, 0.066666666666667, 0.090909090909091
83701, 1.504347826087, 0.083333333333333, 0.090909090909091
83702, 1.504347826087, 0.066666666666667, 0.068181818181818
83703, 1.4826086956522, 0.066666666666667, 0.045454545454545
83704, 1.504347826087, 0.083333333333333, 0.045454545454545
83705, 1.504347826087, 0.066666666666667, 0.022727272727273
83706, 1.5478260869565, 0.066666666666667, 0.47727272727273
83707, 1.5260869565217, 0.066666666666667, 0.45454545454545
83708, 1.5478260869565, 0.083333333333333, 0.45454545454545
83709, 1.5478260869565, 0.066666666666667, 0.43181818181818
83710, 1.5260869565217, 0.066666666666667, 0.40909090909091
83711, 1.5478260869565, 0.083333333333333, 0.40909090909091
83712, 1.5478260869565, 0.066666666666667, 0.38636363636364
83713, 1.5260869565217, 0.066666666666667, 0.36363636363636
83714, 1.5478260869565, 0.083333333333333, 0.36363636363636
83715, 1.5478260869565, 0.066666666666667, 0.34090909090909
83716, 1.5260869565217, 0.066666666666667, 0.31818181818182
83717, 1.5478260869565, 0.083333333333333, 0.31818181818182
83718, 1.5478260869565, 0.066666666666667, 0.29545454545455
83719, 1.5260869565217, 0.066666666666667, 0.27272727272727
83720, 1.5478260869565, 0.083333333333333, 0.27272727272727
83721, 1.5478260869565, 0.066666666666667, 0.25
83722, 1.5260869565217, 0.066666666666667, 0.22727272727273
83723, 1.5478260869565, 0.083333333333333, 0.22727272727273
83724, 1.5478260869565, 0.066666666666667, 0.20454545454545
83725, 1.5260869565217, 0.066666666666667, 0.18181818181818
83726, 1.5478260869565, 0.083333333333333, 0.18181818181818
83727, 1.5478260869565, 0.066666666666667, 0.15909090909091
83728, 1.5260869565217, 0.066666666666667, 0.13636363636364
83729, 1.5478260869565, 0.083333333333333, 0.13636363636364
83730, 1.5478260869565, 0.066666666666667, 0.11363636363636
83731, 1.5260869565217, 0.066666666666667, 0.090909090909091
83732, 1.5478260869565, 0.083333333333333, 0.090909090909091
83733, 1.5478260869565, 0.066666666666667, 0.068181818181818
83734, 1.5260869565217, 0.066666666666667, 0.045454545454545
83735, 1.5478260869565, 0.083333333333333, 0.045454545454545
83736, 1.5478260869565, 0.066666666666667, 0.022727272727273
83737, 1.5913043478261, 0.066666666666667, 0.47727272727273
83738, 1.5695652173913, 0.066666666666667, 0.45454545454545
83739, 1.5913043478261, 0.083333333333333, 0.45454545454545
83740, 1.5913043478261, 0.066666666666667, 0.43181818181818
83741, 1.5695652173913, 0.066666666666667, 0.40909090909091
83742, 1.5913043478261, 0.083333333333333, 0.40909090909091
83743, 1.5913043478261, 0.066666666666667, 0.38636363636364
83744, 1.5695652173913, 0.066666666666667, 0.36363636363636
83745, 1.5913043478261, 0.083333333333333, 0.36363636363636
83746, 1.5913043478261, 0.066666666666667, 0.34090909090909
83747, 1.5695652173913, 0.066666666666667, 0.31818181818182
83748, 1.5913043478261, 0.083333333333333, 0.31818181818182
83749, 1.5913043478261, 0.066666666666667, 0.29545454545455
83750, 1.5695652173913, 0.066666666666667, 0.27272727272727
83751, 1.5913043478261, 0.083333333333333, 0.27272727272727
83752, 1.5913043478261, 0.066666666666667, 0.25
83753, 1.5695652173913, 0.066666666666667, 0.22727272727273
83754, 1.5913043478261, 0.083333333333333, 0.22727272727273
83755, 1.5913043478261, 0.066666666666667, 0.20454545454545
83756, 1.5695652173913, 0.066666666666667, 0.18181818181818
83757, 1.5913043478261, 0.083333333333333, 0.18181818181818
83758, 1.5913043478261, 0.066666666666667, 0.15909090909091
83759, 1.5695652173913, 0.066666666666667, 0.13636363636364
83760, 1.5913043478261, 0.083333333333333, 0.13636363636364
83761, 1.5913043478261, 0.066666666666667, 0.11363636363636
83762, 1.5695652173913, 0.066666666666667, 0.090909090909091
83763, 1.5913043478261, 0.083333333333333, 0.090909090909091
83764, 1.5913043478261, 0.066666666666667, 0.068181818181818
83765, 1.5695652173913, 0.066666666666667, 0.045454545454545
83766, 1.5913043478261, 0.083333333333333, 0.045454545454545
83767, 1.5913043478261, 0.066666666666667, 0.022727272727273
83768, 1.6347826086957, 0.066666666666667, 0.47727272727273
83769, 1.6130434782609, 0.066666666666667, 0.45454545454545
83770, 1.6347826086957, 0.083333333333333, 0.45454545454545
83771, 1.6347826086957, 0.066666666666667, 0.43181818181818
83772, 1.6130434782609, 0.066666666666667, 0.40909090909091
83773, 1.6347826086957, 0.083333333333333, 0.40909090909091
83774, 1.6347826086957, 0.066666666666667, 0.38636363636364
83775, 1.6130434782609, 0.066666666666667, 0.36363636363636
83776, 1.6347826086957, 0.083333333333333, 0.36363636363636
83777, 1.6347826086957, 0.066666666666667, 0.34090909090909
83778, 1.6130434782609, 0.066666666666667, 0.31818181818182
83779, 1.6347826086957, 0.083333333333333, 0.31818181818182
83780, 1.6347826086957, 0.066666666666667, 0.29545454545455
83781, 1.6130434782609, 0.066666666666667, 0.27272727272727
83782, 1.6347826086957, 0.083333333333333, 0.27272727272727
83783, 1.6347826086957, 0.066666666666667, 0.25
83784, 1.6130434782609, 0.066666666666667, 0.22727272727273
83785, 1.6347826086957, 0.083333333333333, 0.22727272727273
83786, 1.6347826086957, 0.066666666666667, 0.20454545454545
83787, 1.6130434782609, 0.066666666666667, 0.18181818181818
83788, 1.6347826086957, 0.083333333333333, 0.18181818181818
83789, 1.6347826086957, 0.066666666666667, 0.15909090909091
83790, 1.6130434782609, 0.066666666666667, 0.13636363636364
83791, 1.6347826086957, 0.083333333333333, 0.13636363636364
83792, 1.6347826086957, 0.066666666666667, 0.11363636363636
83793, 1.6130434782609, 0.066666666666667, 0.090909090909091
83794, 1.6347826086957, 0.083333333333333, 0.090909090909091
83795, 1.6347826086957, 0.066666666666667, 0.068181818181818
83796, 1.6130434782609, 0.066666666666667, 0.045454545454545
83797, 1.6347826086957, 0.083333333333333, 0.045454545454545
83798, 1.6347826086957, 0.066666666666667, 0.022727272727273
83799, 1.6782608695652, 0.066666666666667, 0.47727272727273
83800, 1.6565217391304, 0.066666666666667, 0.45454545454545
83801, 1.6782608695652, 0.083333333333333, 0.45454545454545
83802, 1.6782608695652, 0.066666666666667, 0.43181818181818
83803, 1.6565217391304, 0.066666666666667, 0.40909090909091
83804, 1.6782608695652, 0.083333333333333, 0.40909090909091
83805, 1.6782608695652, 0.066666666666667, 0.38636363636364
83806, 1.6565217391304, 0.066666666666667, 0.36363636363636
83807, 1.6782608695652, 0.083333333333333, 0.36363636363636
83808, 1.6782608695652, 0.066666666666667, 0.34090909090909
83809, 1.6565217391304, 0.066666666666667, 0.31818181818182
83810, 1.6782608695652, 0.083333333333333, 0.31818181818182
83811, 1.6782608695652, 0.066666666666667, 0.29545454545455
83812, 1.6565217391304, 0.066666666666667, 0.27272727272727
83813, 1.6782608695652, 0.083333333333333, 0.27272727272727
83814, 1.6782608695652, 0.066666666666667, 0.25
83815, 1.6565217391304, 0.066666666666667, 0.22727272727273
83816, 1.6782608695652, 0.083333333333333, 0.22727272727273
83817, 1.6782608695652, 0.066666666666667, 0.20454545454545
83818, 1.6565217391304, 0.066666666666667, 0.18181818181818
83819, 1.6782608695652, 0.083333333333333, 0.18181818181818
83820, 1.6782608695652, 0.066666666666667, 0.15909090909091
83821, 1.6565217391304, 0.066666666666667, 0.13636363636364
83822, 1.6782608695652, 0.083333333333333, 0.13636363636364
83823, 1.6782608695652, 0.066666666666667, 0.11363636363636
83824, 1.6565217391304, 0.066666666666667, 0.090909090909091
83825, 1.6782608695652, 0.083333333333333, 0.090909090909091
83826, 1.6782608695652, 0.066666666666667, 0.068181818181818
83827, 1.6565217391304, 0.066666666666667, 0.045454545454545
83828, 1.6782608695652, 0.083333333333333, 0.045454545454545
83829, 1.6782608695652, 0.066666666666667, 0.022727272727273
83830, 1.7217391304348, 0.066666666666667, 0.47727272727273
83831, 1.7, 0.066666666666667, 0.45454545454545
83832, 1.7217391304348, 0.083333333333333, 0.45454545454545
83833, 1.7217391304348, 0.066666666666667, 0.43181818181818
83834, 1.7, 0.066666666666667, 0.40909090909091
83835, 1.7217391304348, 0.083333333333333, 0.40909090909091
83836, 1.7217391304348, 0.066666666666667, 0.38636363636364
83837, 1.7, 0.066666666666667, 0.36363636363636
83838, 1.7217391304348, 0.083333333333333, 0.36363636363636
83839, 1.7217391304348, 0.066666666666667, 0.34090909090909
83840, 1.7, 0.066666666666667, 0.31818181818182
83841, 1.7217391304348, 0.083333333333333, 0.31818181818182
83842, 1.7217391304348, 0.066666666666667, 0.29545454545455
83843, 1.7, 0.066666666666667, 0.27272727272727
83844, 1.7217391304348, 0.083333333333333, 0.27272727272727
83845, 1.7217391304348, 0.066666666666667, 0.25
83846, 1.7, 0.066666666666667, 0.22727272727273
83847, 1.7217391304348, 0.083333333333333, 0.22727272727273
83848, 1.7217391304348, 0.066666666666667, 0.20454545454545
83849, 1.7, 0.066666666666667, 0.18181818181818
83850, 1.7217391304348, 0.083333333333333, 0.18181818181818
83851, 1.7217391304348, 0.066666666666667, 0.15909090909091
83852, 1.7, 0.066666666666667, 0.13636363636364
83853, 1.7217391304348, 0.083333333333333, 0.13636363636364
83854, 1.7217391304348, 0.066666666666667, 0.11363636363636
83855, 1.7, 0.066666666666667, 0.090909090909091
83856, 1.7217391304348, 0.083333333333333, 0.090909090909091
83857, 1.7217391304348, 0.066666666666667, 0.068181818181818
83858, 1.7, 0.066666666666667, 0.045454545454545
83859, 1.7217391304348, 0.083333333333333, 0.045454545454545
83860, 1.7217391304348, 0.066666666666667, 0.022727272727273
83861, 1.7652173913043, 0.066666666666667, 0.47727272727273
83862, 1.7434782608696, 0.066666666666667, 0.45454545454545
83863, 1.7652173913043, 0.083333333333333, 0.45454545454545
83864, 1.7652173913043, 0.066666666666667, 0.43181818181818
83865, 1.7434782608696, 0.066666666666667, 0.40909090909091
83866, 1.7652173913043, 0.083333333333333, 0.40909090909091
83867, 1.7652173913043, 0.066666666666667, 0.38636363636364
83868, 1.7434782608696, 0.066666666666667, 0.36363636363636
83869, 1.7652173913043, 0.083333333333333, 0.36363636363636
83870, 1.7652173913043, 0.066666666666667, 0.34090909090909
83871, 1.7434782608696, 0.066666666666667, 0.31818181818182
83872, 1.7652173913043, 0.083333333333333, 0.31818181818182
83873, 1.7652173913043, 0.066666666666667, 0.29545454545455
83874, 1.7434782608696, 0.066666666666667, 0.27272727272727
83875, 1.7652173913043, 0.083333333333333, 0.27272727272727
83876, 1.7652173913043, 0.066666666666667, 0.25
83877, 1.7434782608696, 0.066666666666667, 0.22727272727273
83878, 1.7652173913043, 0.083333333333333, 0.22727272727273
83879, 1.7652173913043, 0.066666666666667, 0.20454545454545
83880, 1.7434782608696, 0.066666666666667, 0.18181818181818
83881, 1.7652173913043, 0.083333333333333, 0.18181818181818
83882, 1.7652173913043, 0.066666666666667, 0.15909090909091
83883, 1.7434782608696, 0.066666666666667, 0.13636363636364
83884, 1.7652173913043, 0.083333333333333, 0.13636363636364
83885, 1.7652173913043, 0.066666666666667, 0.11363636363636
83886, 1.7434782608696, 0.066666666666667, 0.090909090909091
83887, 1.7652173913043, 0.083333333333333, 0.090909090909091
83888, 1.7652173913043, 0.066666666666667, 0.068181818181818
83889, 1.7434782608696, 0.066666666666667, 0.045454545454545
83890, 1.7652173913043, 0.083333333333333, 0.045454545454545
83891, 1.7652173913043, 0.066666666666667, 0.022727272727273
83892, 1.8086956521739, 0.066666666666667, 0.47727272727273
83893, 1.7869565217391, 0.066666666666667, 0.45454545454545
83894, 1.8086956521739, 0.083333333333333, 0.45454545454545
83895, 1.8086956521739, 0.066666666666667, 0.43181818181818
83896, 1.7869565217391, 0.066666666666667, 0.40909090909091
83897, 1.8086956521739, 0.083333333333333, 0.40909090909091
83898, 1.8086956521739, 0.066666666666667, 0.38636363636364
83899, 1.7869565217391, 0.066666666666667, 0.36363636363636
83900, 1.8086956521739, 0.083333333333333, 0.36363636363636
83901, 1.8086956521739, 0.066666666666667, 0.34090909090909
83902, 1.7869565217391, 0.066666666666667, 0.31818181818182
83903, 1.8086956521739, 0.083333333333333, 0.31818181818182
83904, 1.8086956521739, 0.066666666666667, 0.29545454545455
83905, 1.7869565217391, 0.066666666666667, 0.27272727272727
83906, 1.8086956521739, 0.083333333333333, 0.27272727272727
83907, 1.8086956521739, 0.066666666666667, 0.25
83908, 1.7869565217391, 0.066666666666667, 0.22727272727273
83909, 1.8086956521739, 0.083333333333333, 0.22727272727273
83910, 1.8086956521739, 0.066666666666667, 0.20454545454545
83911, 1.7869565217391, 0.066666666666667, 0.18181818181818
83912, 1.8086956521739, 0.083333333333333, 0.18181818181818
83913, 1.8086956521739, 0.066666666666667, 0.15909090909091
83914, 1.7869565217391, 0.066666666666667, 0.13636363636364
83915, 1.8086956521739, 0.083333333333333, 0.13636363636364
83916, 1.8086956521739, 0.066666666666667, 0.11363636363636
83917, 1.7869565217391, 0.066666666666667, 0.090909090909091
83918, 1.8086956521739, 0.083333333333333, 0.090909090909091
83919, 1.8086956521739, 0.066666666666667, 0.068181818181818
83920, 1.7869565217391, 0.066666666666667, 0.045454545454545
83921, 1.8086956521739, 0.083333333333333, 0.045454545454545
83922, 1.8086956521739, 0.066666666666667, 0.022727272727273
83923, 1.8521739130435, 0.066666666666667, 0.47727272727273
83924, 1.8304347826087, 0.066666666666667, 0.45454545454545
83925, 1.8521739130435, 0.083333333333333, 0.45454545454545
83926, 1.8521739130435, 0.066666666666667, 0.43181818181818
83927, 1.8304347826087, 0.066666666666667, 0.40909090909091
83928, 1.8521739130435, 0.083333333333333, 0.40909090909091
83929, 1.8521739130435, 0.066666666666667, 0.38636363636364
83930, 1.8304347826087, 0.066666666666667, 0.36363636363636
83931, 1.8521739130435, 0.083333333333333, 0.36363636363636
83932, 1.8521739130435, 0.066666666666667, 0.34090909090909
83933, 1.8304347826087, 0.066666666666667, 0.31818181818182
83934, 1.8521739130435, 0.083333333333333, 0.31818181818182
83935, 1.8521739130435, 0.066666666666667, 0.29545454545455
83936, 1.8304347826087, 0.066666666666667, 0.27272727272727
83937, 1.8521739130435, 0.083333333333333, 0.27272727272727
83938, 1.8521739130435, 0.066666666666667, 0.25
83939, 1.8304347826087, 0.066666666666667, 0.22727272727273
83940, 1.8521739130435, 0.083333333333333, 0.22727272727273
83941, 1.8521739130435, 0.066666666666667, 0.20454545454545
83942, 1.8304347826087, 0.066666666666667, 0.18181818181818
83943, 1.8521739130435, 0.083333333333333, 0.18181818181818
83944, 1.8521739130435, 0.066666666666667, 0.15909090909091
83945, 1.8304347826087, 0.066666666666667, 0.13636363636364
83946, 1.8521739130435, 0.083333333333333, 0.13636363636364
83947, 1.8521739130435, 0.066666666666667, 0.11363636363636
83948, 1.8304347826087, 0.066666666666667, 0.090909090909091
83949, 1.8521739130435, 0.083333333333333, 0.090909090909091
83950, 1.8521739130435, 0.066666666666667, 0.068181818181818
83951, 1.8304347826087, 0.066666666666667, 0.045454545454545
83952, 1.8521739130435, 0.083333333333333, 0.045454545454545
83953, 1.8521739130435, 0.066666666666667, 0.022727272727273
83954, 1.895652173913, 0.066666666666667, 0.47727272727273
83955, 1.8739130434783, 0.066666666666667, 0.45454545454545
83956, 1.895652173913, 0.083333333333333, 0.45454545454545
83957, 1.895652173913, 0.066666666666667, 0.43181818181818
83958, 1.8739130434783, 0.066666666666667, 0.40909090909091
83959, 1.895652173913, 0.083333333333333, 0.40909090909091
83960, 1.895652173913, 0.066666666666667, 0.38636363636364
83961, 1.8739130434783, 0.066666666666667, 0.36363636363636
83962, 1.895652173913, 0.083333333333333, 0.36363636363636
83963, 1.895652173913, 0.066666666666667, 0.34090909090909
83964, 1.8739130434783, 0.066666666666667, 0.31818181818182
83965, 1.895652173913, 0.083333333333333, 0.31818181818182
83966, 1.895652173913, 0.066666666666667, 0.29545454545455
83967, 1.8739130434783, 0.066666666666667, 0.27272727272727
83968, 1.895652173913, 0.083333333333333, 0.27272727272727
83969, 1.895652173913, 0.066666666666667, 0.25
83970, 1.8739130434783, 0.066666666666667, 0.22727272727273
83971, 1.895652173913, 0.083333333333333, 0.22727272727273
83972, 1.895652173913, 0.066666666666667, 0.20454545454545
83973, 1.8739130434783, 0.066666666666667, 0.18181818181818
83974, 1.895652173913, 0.083333333333333, 0.18181818181818
83975, 1.895652173913, 0.066666666666667, 0.15909090909091
83976, 1.8739130434783, 0.066666666666667, 0.13636363636364
83977, 1.895652173913, 0.083333333333333, 0.13636363636364
83978, 1.895652173913, 0.066666666666667, 0.11363636363636
83979, 1.8739130434783, 0.066666666666667, 0.090909090909091
83980, 1.895652173913, 0.083333333333333, 0.090909090909091
83981, 1.895652173913, 0.066666666666667, 0.068181818181818
83982, 1.8739130434783, 0.066666666666667, 0.045454545454545
83983, 1.895652173913, 0.083333333333333, 0.045454545454545
83984, 1.895652173913, 0.066666666666667, 0.022727272727273
83985, 1.9391304347826, 0.066666666666667, 0.47727272727273
83986, 1.9173913043478, 0.066666666666667, 0.45454545454545
83987, 1.9391304347826, 0.083333333333333, 0.45454545454545
83988, 1.9391304347826, 0.066666666666667, 0.43181818181818
83989, 1.9173913043478, 0.066666666666667, 0.40909090909091
83990, 1.9391304347826, 0.083333333333333, 0.40909090909091
83991, 1.9391304347826, 0.066666666666667, 0.38636363636364
83992, 1.9173913043478, 0.066666666666667, 0.36363636363636
83993, 1.9391304347826, 0.083333333333333, 0.36363636363636
83994, 1.9391304347826, 0.066666666666667, 0.34090909090909
83995, 1.9173913043478, 0.066666666666667, 0.31818181818182
83996, 1.9391304347826, 0.083333333333333, 0.31818181818182
83997, 1.9391304347826, 0.066666666666667, 0.29545454545455
83998, 1.9173913043478, 0.066666666666667, 0.27272727272727
83999, 1.9391304347826, 0.083333333333333, 0.27272727272727
84000, 1.9391304347826, 0.066666666666667, 0.25
84001, 1.9173913043478, 0.066666666666667, 0.22727272727273
84002, 1.9391304347826, 0.083333333333333, 0.22727272727273
84003, 1.9391304347826, 0.066666666666667, 0.20454545454545
84004, 1.9173913043478, 0.066666666666667, 0.18181818181818
84005, 1.9391304347826, 0.083333333333333, 0.18181818181818
84006, 1.9391304347826, 0.066666666666667, 0.15909090909091
84007, 1.9173913043478, 0.066666666666667, 0.13636363636364
84008, 1.9391304347826, 0.083333333333333, 0.13636363636364
84009, 1.9391304347826, 0.066666666666667, 0.11363636363636
84010, 1.9173913043478, 0.066666666666667, 0.090909090909091
84011, 1.9391304347826, 0.083333333333333, 0.090909090909091
84012, 1.9391304347826, 0.066666666666667, 0.068181818181818
84013, 1.9173913043478, 0.066666666666667, 0.045454545454545
84014, 1.9391304347826, 0.083333333333333, 0.045454545454545
84015, 1.9391304347826, 0.066666666666667, 0.022727272727273
84016, 1.9826086956522, 0.066666666666667, 0.47727272727273
84017, 1.9608695652174, 0.066666666666667, 0.45454545454545
84018, 1.9826086956522, 0.083333333333333, 0.45454545454545
84019, 1.9826086956522, 0.066666666666667, 0.43181818181818
84020, 1.9608695652174, 0.066666666666667, 0.40909090909091
84021, 1.9826086956522, 0.083333333333333, 0.40909090909091
84022, 1.9826086956522, 0.066666666666667, 0.38636363636364
84023, 1.9608695652174, 0.066666666666667, 0.36363636363636
84024, 1.9826086956522, 0.083333333333333, 0.36363636363636
84025, 1.9826086956522, 0.066666666666667, 0.34090909090909
84026, 1.9608695652174, 0.066666666666667, 0.31818181818182
84027, 1.9826086956522, 0.083333333333333, 0.31818181818182
84028, 1.9826086956522, 0.066666666666667, 0.29545454545455
84029, 1.9608695652174, 0.066666666666667, 0.27272727272727
84030, 1.9826086956522, 0.083333333333333, 0.27272727272727
84031, 1.9826086956522, 0.066666666666667, 0.25
84032, 1.9608695652174, 0.066666666666667, 0.22727272727273
84033, 1.9826086956522, 0.083333333333333, 0.22727272727273
84034, 1.9826086956522, 0.066666666666667, 0.20454545454545
84035, 1.9608695652174, 0.066666666666667, 0.18181818181818
84036, 1.9826086956522, 0.083333333333333, 0.18181818181818
84037, 1.9826086956522, 0.066666666666667, 0.15909090909091
84038, 1.9608695652174, 0.066666666666667, 0.13636363636364
84039, 1.9826086956522, 0.083333333333333, 0.13636363636364
84040, 1.9826086956522, 0.066666666666667, 0.11363636363636
84041, 1.9608695652174, 0.066666666666667, 0.090909090909091
84042, 1.9826086956522, 0.083333333333333, 0.090909090909091
84043, 1.9826086956522, 0.066666666666667, 0.068181818181818
84044, 1.9608695652174, 0.066666666666667, 0.045454545454545
84045, 1.9826086956522, 0.083333333333333, 0.045454545454545
84046, 1.9826086956522, 0.066666666666667, 0.022727272727273
84047, 2.0260869565217, 0.066666666666667, 0.47727272727273
84048, 2.004347826087, 0.066666666666667, 0.45454545454545
84049, 2.0260869565217, 0.083333333333333, 0.45454545454545
84050, 2.0260869565217, 0.066666666666667, 0.43181818181818
84051, 2.004347826087, 0.066666666666667, 0.40909090909091
84052, 2.0260869565217, 0.083333333333333, 0.40909090909091
84053, 2.0260869565217, 0.066666666666667, 0.38636363636364
84054, 2.004347826087, 0.066666666666667, 0.36363636363636
84055, 2.0260869565217, 0.083333333333333, 0.36363636363636
84056, 2.0260869565217, 0.066666666666667, 0.34090909090909
84057, 2.004347826087, 0.066666666666667, 0.31818181818182
84058, 2.0260869565217, 0.083333333333333, 0.31818181818182
84059, 2.0260869565217, 0.066666666666667, 0.29545454545455
84060, 2.004347826087, 0.066666666666667, 0.27272727272727
84061, 2.0260869565217, 0.083333333333333, 0.27272727272727
84062, 2.0260869565217, 0.066666666666667, 0.25
84063, 2.004347826087, 0.066666666666667, 0.22727272727273
84064, 2.0260869565217, 0.083333333333333, 0.22727272727273
84065, 2.0260869565217, 0.066666666666667, 0.20454545454545
84066, 2.004347826087, 0.066666666666667, 0.18181818181818
84067, 2.0260869565217, 0.083333333333333, 0.18181818181818
84068, 2.0260869565217, 0.066666666666667, 0.15909090909091
84069, 2.004347826087, 0.066666666666667, 0.13636363636364
84070, 2.0260869565217, 0.083333333333333, 0.13636363636364
84071, 2.0260869565217, 0.066666666666667, 0.11363636363636
84072, 2.004347826087, 0.066666666666667, 0.090909090909091
84073, 2.0260869565217, 0.083333333333333, 0.090909090909091
84074, 2.0260869565217, 0.066666666666667, 0.068181818181818
84075, 2.004347826087, 0.066666666666667, 0.045454545454545
84076, 2.0260869565217, 0.083333333333333, 0.045454545454545
84077, 2.0260869565217, 0.066666666666667, 0.022727272727273
84078, 2.0695652173913, 0.066666666666667, 0.47727272727273
84079, 2.0478260869565, 0.066666666666667, 0.45454545454545
84080, 2.0695652173913, 0.083333333333333, 0.45454545454545
84081, 2.0695652173913, 0.066666666666667, 0.43181818181818
84082, 2.0478260869565, 0.066666666666667, 0.40909090909091
84083, 2.0695652173913, 0.083333333333333, 0.40909090909091
84084, 2.0695652173913, 0.066666666666667, 0.38636363636364
84085, 2.0478260869565, 0.066666666666667, 0.36363636363636
84086, 2.0695652173913, 0.083333333333333, 0.36363636363636
84087, 2.0695652173913, 0.066666666666667, 0.34090909090909
84088, 2.0478260869565, 0.066666666666667, 0.31818181818182
84089, 2.0695652173913, 0.083333333333333, 0.31818181818182
84090, 2.0695652173913, 0.066666666666667, 0.29545454545455
84091, 2.0478260869565, 0.066666666666667, 0.27272727272727
84092, 2.0695652173913, 0.083333333333333, 0.27272727272727
84093, 2.0695652173913, 0.066666666666667, 0.25
84094, 2.0478260869565, 0.066666666666667, 0.22727272727273
84095, 2.0695652173913, 0.083333333333333, 0.22727272727273
84096, 2.0695652173913, 0.066666666666667, 0.20454545454545
84097, 2.0478260869565, 0.066666666666667, 0.18181818181818
84098, 2.0695652173913, 0.083333333333333, 0.18181818181818
84099, 2.0695652173913, 0.066666666666667, 0.15909090909091
84100, 2.0478260869565, 0.066666666666667, 0.13636363636364
84101, 2.0695652173913, 0.083333333333333, 0.13636363636364
84102, 2.0695652173913, 0.066666666666667, 0.11363636363636
84103, 2.0478260869565, 0.066666666666667, 0.090909090909091
84104, 2.0695652173913, 0.083333333333333, 0.090909090909091
84105, 2.0695652173913, 0.066666666666667, 0.068181818181818
84106, 2.0478260869565, 0.066666666666667, 0.045454545454545
84107, 2.0695652173913, 0.083333333333333, 0.045454545454545
84108, 2.0695652173913, 0.066666666666667, 0.022727272727273
84109, 2.1130434782609, 0.066666666666667, 0.47727272727273
84110, 2.0913043478261, 0.066666666666667, 0.45454545454545
84111, 2.1130434782609, 0.083333333333333, 0.45454545454545
84112, 2.1130434782609, 0.066666666666667, 0.43181818181818
84113, 2.0913043478261, 0.066666666666667, 0.40909090909091
84114, 2.1130434782609, 0.083333333333333, 0.40909090909091
84115, 2.1130434782609, 0.066666666666667, 0.38636363636364
84116, 2.0913043478261, 0.066666666666667, 0.36363636363636
84117, 2.1130434782609, 0.083333333333333, 0.36363636363636
84118, 2.1130434782609, 0.066666666666667, 0.34090909090909
84119, 2.0913043478261, 0.066666666666667, 0.31818181818182
84120, 2.1130434782609, 0.083333333333333, 0.31818181818182
84121, 2.1130434782609, 0.066666666666667, 0.29545454545455
84122, 2.0913043478261, 0.066666666666667, 0.27272727272727
84123, 2.1130434782609, 0.083333333333333, 0.27272727272727
84124, 2.1130434782609, 0.066666666666667, 0.25
84125, 2.0913043478261, 0.066666666666667, 0.22727272727273
84126, 2.1130434782609, 0.083333333333333, 0.22727272727273
84127, 2.1130434782609, 0.066666666666667, 0.20454545454545
84128, 2.0913043478261, 0.066666666666667, 0.18181818181818
84129, 2.1130434782609, 0.083333333333333, 0.18181818181818
84130, 2.1130434782609, 0.066666666666667, 0.15909090909091
84131, 2.0913043478261, 0.066666666666667, 0.13636363636364
84132, 2.1130434782609, 0.083333333333333, 0.13636363636364
84133, 2.1130434782609, 0.066666666666667, 0.11363636363636
84134, 2.0913043478261, 0.066666666666667, 0.090909090909091
84135, 2.1130434782609, 0.083333333333333, 0.090909090909091
84136, 2.1130434782609, 0.066666666666667, 0.068181818181818
84137, 2.0913043478261, 0.066666666666667, 0.045454545454545
84138, 2.1130434782609, 0.083333333333333, 0.045454545454545
84139, 2.1130434782609, 0.066666666666667, 0.022727272727273
84140, 2.1565217391304, 0.066666666666667, 0.47727272727273
84141, 2.1347826086957, 0.066666666666667, 0.45454545454545
84142, 2.1565217391304, 0.083333333333333, 0.45454545454545
84143, 2.1565217391304, 0.066666666666667, 0.43181818181818
84144, 2.1347826086957, 0.066666666666667, 0.40909090909091
84145, 2.1565217391304, 0.083333333333333, 0.40909090909091
84146, 2.1565217391304, 0.066666666666667, 0.38636363636364
84147, 2.1347826086957, 0.066666666666667, 0.36363636363636
84148, 2.1565217391304, 0.083333333333333, 0.36363636363636
84149, 2.1565217391304, 0.066666666666667, 0.34090909090909
84150, 2.1347826086957, 0.066666666666667, 0.31818181818182
84151, 2.1565217391304, 0.083333333333333, 0.31818181818182
84152, 2.1565217391304, 0.066666666666667, 0.29545454545455
84153, 2.1347826086957, 0.066666666666667, 0.27272727272727
84154, 2.1565217391304, 0.083333333333333, 0.27272727272727
84155, 2.1565217391304, 0.066666666666667, 0.25
84156, 2.1347826086957, 0.066666666666667, 0.22727272727273
84157, 2.1565217391304, 0.083333333333333, 0.22727272727273
84158, 2.1565217391304, 0.066666666666667, 0.20454545454545
84159, 2.1347826086957, 0.066666666666667, 0.18181818181818
84160, 2.1565217391304, 0.083333333333333, 0.18181818181818
84161, 2.1565217391304, 0.066666666666667, 0.15909090909091
84162, 2.1347826086957, 0.066666666666667, 0.13636363636364
84163, 2.1565217391304, 0.083333333333333, 0.13636363636364
84164, 2.1565217391304, 0.066666666666667, 0.11363636363636
84165, 2.1347826086957, 0.066666666666667, 0.090909090909091
84166, 2.1565217391304, 0.083333333333333, 0.090909090909091
84167, 2.1565217391304, 0.066666666666667, 0.068181818181818
84168, 2.1347826086957, 0.066666666666667, 0.045454545454545
84169, 2.1565217391304, 0.083333333333333, 0.045454545454545
84170, 2.1565217391304, 0.066666666666667, 0.022727272727273
84171, 2.1782608695652, 0.066666666666667, 0.45454545454545
84172, 2.1782608695652, 0.066666666666667, 0.40909090909091
84173, 2.1782608695652, 0.066666666666667, 0.36363636363636
84174, 2.1782608695652, 0.066666666666667, 0.31818181818182
84175, 2.1782608695652, 0.066666666666667, 0.27272727272727
84176, 2.1782608695652, 0.066666666666667, 0.22727272727273
84177, 2.1782608695652, 0.066666666666667, 0.18181818181818
84178, 2.1782608695652, 0.066666666666667, 0.13636363636364
84179, 2.1782608695652, 0.066666666666667, 0.090909090909091
84180, 2.1782608695652, 0.066666666666667, 0.045454545454545
84181, 1.2434782608696, 0.033333333333333, 0.47727272727273
84182, 1.2217391304348, 0.033333333333333, 0.45454545454545
84183, 1.2434782608696, 0.05, 0.45454545454545
84184, 1.2434782608696, 0.033333333333333, 0.43181818181818
84185, 1.2217391304348, 0.033333333333333, 0.40909090909091
84186, 1.2434782608696, 0.05, 0.40909090909091
84187, 1.2434782608696, 0.033333333333333, 0.38636363636364
84188, 1.2217391304348, 0.033333333333333, 0.36363636363636
84189, 1.2434782608696, 0.05, 0.36363636363636
84190, 1.2434782608696, 0.033333333333333, 0.34090909090909
84191, 1.2217391304348, 0.033333333333333, 0.31818181818182
84192, 1.2434782608696, 0.05, 0.31818181818182
84193, 1.2434782608696, 0.033333333333333, 0.29545454545455
84194, 1.2217391304348, 0.033333333333333, 0.27272727272727
84195, 1.2434782608696, 0.05, 0.27272727272727
84196, 1.2434782608696, 0.033333333333333, 0.25
84197, 1.2217391304348, 0.033333333333333, 0.22727272727273
84198, 1.2434782608696, 0.05, 0.22727272727273
84199, 1.2434782608696, 0.033333333333333, 0.20454545454545
84200, 1.2217391304348, 0.033333333333333, 0.18181818181818
84201, 1.2434782608696, 0.05, 0.18181818181818
84202, 1.2434782608696, 0.033333333333333, 0.15909090909091
84203, 1.2217391304348, 0.033333333333333, 0.13636363636364
84204, 1.2434782608696, 0.05, 0.13636363636364
84205, 1.2434782608696, 0.033333333333333, 0.11363636363636
84206, 1.2217391304348, 0.033333333333333, 0.090909090909091
84207, 1.2434782608696, 0.05, 0.090909090909091
84208, 1.2434782608696, 0.033333333333333, 0.068181818181818
84209, 1.2217391304348, 0.033333333333333, 0.045454545454545
84210, 1.2434782608696, 0.05, 0.045454545454545
84211, 1.2434782608696, 0.033333333333333, 0.022727272727273
84212, 1.2869565217391, 0.033333333333333, 0.47727272727273
84213, 1.2652173913043, 0.033333333333333, 0.45454545454545
84214, 1.2869565217391, 0.05, 0.45454545454545
84215, 1.2869565217391, 0.033333333333333, 0.43181818181818
84216, 1.2652173913043, 0.033333333333333, 0.40909090909091
84217, 1.2869565217391, 0.05, 0.40909090909091
84218, 1.2869565217391, 0.033333333333333, 0.38636363636364
84219, 1.2652173913043, 0.033333333333333, 0.36363636363636
84220, 1.2869565217391, 0.05, 0.36363636363636
84221, 1.2869565217391, 0.033333333333333, 0.34090909090909
84222, 1.2652173913043, 0.033333333333333, 0.31818181818182
84223, 1.2869565217391, 0.05, 0.31818181818182
84224, 1.2869565217391, 0.033333333333333, 0.29545454545455
84225, 1.2652173913043, 0.033333333333333, 0.27272727272727
84226, 1.2869565217391, 0.05, 0.27272727272727
84227, 1.2869565217391, 0.033333333333333, 0.25
84228, 1.2652173913043, 0.033333333333333, 0.22727272727273
84229, 1.2869565217391, 0.05, 0.22727272727273
84230, 1.2869565217391, 0.033333333333333, 0.20454545454545
84231, 1.2652173913043, 0.033333333333333, 0.18181818181818
84232, 1.2869565217391, 0.05, 0.18181818181818
84233, 1.2869565217391, 0.033333333333333, 0.15909090909091
84234, 1.2652173913043, 0.033333333333333, 0.13636363636364
84235, 1.2869565217391, 0.05, 0.13636363636364
84236, 1.2869565217391, 0.033333333333333, 0.11363636363636
84237, 1.2652173913043, 0.033333333333333, 0.090909090909091
84238, 1.2869565217391, 0.05, 0.090909090909091
84239, 1.2869565217391, 0.033333333333333, 0.068181818181818
84240, 1.2652173913043, 0.033333333333333, 0.045454545454545
84241, 1.2869565217391, 0.05, 0.045454545454545
84242, 1.2869565217391, 0.033333333333333, 0.022727272727273
84243, 1.3304347826087, 0.033333333333333, 0.47727272727273
84244, 1.3086956521739, 0.033333333333333, 0.45454545454545
84245, 1.3304347826087, 0.05, 0.45454545454545
84246, 1.3304347826087, 0.033333333333333, 0.43181818181818
84247, 1.3086956521739, 0.033333333333333, 0.40909090909091
84248, 1.3304347826087, 0.05, 0.40909090909091
84249, 1.3304347826087, 0.033333333333333, 0.38636363636364
84250, 1.3086956521739, 0.033333333333333, 0.36363636363636
84251, 1.3304347826087, 0.05, 0.36363636363636
84252, 1.3304347826087, 0.033333333333333, 0.34090909090909
84253, 1.3086956521739, 0.033333333333333, 0.31818181818182
84254, 1.3304347826087, 0.05, 0.31818181818182
84255, 1.3304347826087, 0.033333333333333, 0.29545454545455
84256, 1.3086956521739, 0.033333333333333, 0.27272727272727
84257, 1.3304347826087, 0.05, 0.27272727272727
84258, 1.3304347826087, 0.033333333333333, 0.25
84259, 1.3086956521739, 0.033333333333333, 0.22727272727273
84260, 1.3304347826087, 0.05, 0.22727272727273
84261, 1.3304347826087, 0.033333333333333, 0.20454545454545
84262, 1.3086956521739, 0.033333333333333, 0.18181818181818
84263, 1.3304347826087, 0.05, 0.18181818181818
84264, 1.3304347826087, 0.033333333333333, 0.15909090909091
84265, 1.3086956521739, 0.033333333333333, 0.13636363636364
84266, 1.3304347826087, 0.05, 0.13636363636364
84267, 1.3304347826087, 0.033333333333333, 0.11363636363636
84268, 1.3086956521739, 0.033333333333333, 0.090909090909091
84269, 1.3304347826087, 0.05, 0.090909090909091
84270, 1.3304347826087, 0.033333333333333, 0.068181818181818
84271, 1.3086956521739, 0.033333333333333, 0.045454545454545
84272, 1.3304347826087, 0.05, 0.045454545454545
84273, 1.3304347826087, 0.033333333333333, 0.022727272727273
84274, 1.3739130434783, 0.033333333333333, 0.47727272727273
84275, 1.3521739130435, 0.033333333333333, 0.45454545454545
84276, 1.3739130434783, 0.05, 0.45454545454545
84277, 1.3739130434783, 0.033333333333333, 0.43181818181818
84278, 1.3521739130435, 0.033333333333333, 0.40909090909091
84279, 1.3739130434783, 0.05, 0.40909090909091
84280, 1.3739130434783, 0.033333333333333, 0.38636363636364
84281, 1.3521739130435, 0.033333333333333, 0.36363636363636
84282, 1.3739130434783, 0.05, 0.36363636363636
84283, 1.3739130434783, 0.033333333333333, 0.34090909090909
84284, 1.3521739130435, 0.033333333333333, 0.31818181818182
84285, 1.3739130434783, 0.05, 0.31818181818182
84286, 1.3739130434783, 0.033333333333333, 0.29545454545455
84287, 1.3521739130435, 0.033333333333333, 0.27272727272727
84288, 1.3739130434783, 0.05, 0.27272727272727
84289, 1.3739130434783, 0.033333333333333, 0.25
84290, 1.3521739130435, 0.033333333333333, 0.22727272727273
84291, 1.3739130434783, 0.05, 0.22727272727273
84292, 1.3739130434783, 0.033333333333333, 0.20454545454545
84293, 1.3521739130435, 0.033333333333333, 0.18181818181818
84294, 1.3739130434783, 0.05, 0.18181818181818
84295, 1.3739130434783, 0.033333333333333, 0.15909090909091
84296, 1.3521739130435, 0.033333333333333, 0.13636363636364
84297, 1.3739130434783, 0.05, 0.13636363636364
84298, 1.3739130434783, 0.033333333333333, 0.11363636363636
84299, 1.3521739130435, 0.033333333333333, 0.090909090909091
84300, 1.3739130434783, 0.05, 0.090909090909091
84301, 1.3739130434783, 0.033333333333333, 0.068181818181818
84302, 1.3521739130435, 0.033333333333333, 0.045454545454545
84303, 1.3739130434783, 0.05, 0.045454545454545
84304, 1.3739130434783, 0.033333333333333, 0.022727272727273
84305, 1.4173913043478, 0.033333333333333, 0.47727272727273
84306, 1.395652173913, 0.033333333333333, 0.45454545454545
84307, 1.4173913043478, 0.05, 0.45454545454545
84308, 1.4173913043478, 0.033333333333333, 0.43181818181818
84309, 1.395652173913, 0.033333333333333, 0.40909090909091
84310, 1.4173913043478, 0.05, 0.40909090909091
84311, 1.4173913043478, 0.033333333333333, 0.38636363636364
84312, 1.395652173913, 0.033333333333333, 0.36363636363636
84313, 1.4173913043478, 0.05, 0.36363636363636
84314, 1.4173913043478, 0.033333333333333, 0.34090909090909
84315, 1.395652173913, 0.033333333333333, 0.31818181818182
84316, 1.4173913043478, 0.05, 0.31818181818182
84317, 1.4173913043478, 0.033333333333333, 0.29545454545455
84318, 1.395652173913, 0.033333333333333, 0.27272727272727
84319, 1.4173913043478, 0.05, 0.27272727272727
84320, 1.4173913043478, 0.033333333333333, 0.25
84321, 1.395652173913, 0.033333333333333, 0.22727272727273
84322, 1.4173913043478, 0.05, 0.22727272727273
84323, 1.4173913043478, 0.033333333333333, 0.20454545454545
84324, 1.395652173913, 0.033333333333333, 0.18181818181818
84325, 1.4173913043478, 0.05, 0.18181818181818
84326, 1.4173913043478, 0.033333333333333, 0.15909090909091
84327, 1.395652173913, 0.033333333333333, 0.13636363636364
84328, 1.4173913043478, 0.05, 0.13636363636364
84329, 1.4173913043478, 0.033333333333333, 0.11363636363636
84330, 1.395652173913, 0.033333333333333, 0.090909090909091
84331, 1.4173913043478, 0.05, 0.090909090909091
84332, 1.4173913043478, 0.033333333333333, 0.068181818181818
84333, 1.395652173913, 0.033333333333333, 0.045454545454545
84334, 1.4173913043478, 0.05, 0.045454545454545
84335, 1.4173913043478, 0.033333333333333, 0.022727272727273
84336, 1.4608695652174, 0.033333333333333, 0.47727272727273
84337, 1.4391304347826, 0.033333333333333, 0.45454545454545
84338, 1.4608695652174, 0.05, 0.45454545454545
84339, 1.4608695652174, 0.033333333333333, 0.43181818181818
84340, 1.4391304347826, 0.033333333333333, 0.40909090909091
84341, 1.4608695652174, 0.05, 0.40909090909091
84342, 1.4608695652174, 0.033333333333333, 0.38636363636364
84343, 1.4391304347826, 0.033333333333333, 0.36363636363636
84344, 1.4608695652174, 0.05, 0.36363636363636
84345, 1.4608695652174, 0.033333333333333, 0.34090909090909
84346, 1.4391304347826, 0.033333333333333, 0.31818181818182
84347, 1.4608695652174, 0.05, 0.31818181818182
84348, 1.4608695652174, 0.033333333333333, 0.29545454545455
84349, 1.4391304347826, 0.033333333333333, 0.27272727272727
84350, 1.4608695652174, 0.05, 0.27272727272727
84351, 1.4608695652174, 0.033333333333333, 0.25
84352, 1.4391304347826, 0.033333333333333, 0.22727272727273
84353, 1.4608695652174, 0.05, 0.22727272727273
84354, 1.4608695652174, 0.033333333333333, 0.20454545454545
84355, 1.4391304347826, 0.033333333333333, 0.18181818181818
84356, 1.4608695652174, 0.05, 0.18181818181818
84357, 1.4608695652174, 0.033333333333333, 0.15909090909091
84358, 1.4391304347826, 0.033333333333333, 0.13636363636364
84359, 1.4608695652174, 0.05, 0.13636363636364
84360, 1.4608695652174, 0.033333333333333, 0.11363636363636
84361, 1.4391304347826, 0.033333333333333, 0.090909090909091
84362, 1.4608695652174, 0.05, 0.090909090909091
84363, 1.4608695652174, 0.033333333333333, 0.068181818181818
84364, 1.4391304347826, 0.033333333333333, 0.045454545454545
84365, 1.4608695652174, 0.05, 0.045454545454545
84366, 1.4608695652174, 0.033333333333333, 0.022727272727273
84367, 1.504347826087, 0.033333333333333, 0.47727272727273
84368, 1.4826086956522, 0.033333333333333, 0.45454545454545
84369, 1.504347826087, 0.05, 0.45454545454545
84370, 1.504347826087, 0.033333333333333, 0.43181818181818
84371, 1.4826086956522, 0.033333333333333, 0.40909090909091
84372, 1.504347826087, 0.05, 0.40909090909091
84373, 1.504347826087, 0.033333333333333, 0.38636363636364
84374, 1.4826086956522, 0.033333333333333, 0.36363636363636
84375, 1.504347826087, 0.05, 0.36363636363636
84376, 1.504347826087, 0.033333333333333, 0.34090909090909
84377, 1.4826086956522, 0.033333333333333, 0.31818181818182
84378, 1.504347826087, 0.05, 0.31818181818182
84379, 1.504347826087, 0.033333333333333, 0.29545454545455
84380, 1.4826086956522, 0.033333333333333, 0.27272727272727
84381, 1.504347826087, 0.05, 0.27272727272727
84382, 1.504347826087, 0.033333333333333, 0.25
84383, 1.4826086956522, 0.033333333333333, 0.22727272727273
84384, 1.504347826087, 0.05, 0.22727272727273
84385, 1.504347826087, 0.033333333333333, 0.20454545454545
84386, 1.4826086956522, 0.033333333333333, 0.18181818181818
84387, 1.504347826087, 0.05, 0.18181818181818
84388, 1.504347826087, 0.033333333333333, 0.15909090909091
84389, 1.4826086956522, 0.033333333333333, 0.13636363636364
84390, 1.504347826087, 0.05, 0.13636363636364
84391, 1.504347826087, 0.033333333333333, 0.11363636363636
84392, 1.4826086956522, 0.033333333333333, 0.090909090909091
84393, 1.504347826087, 0.05, 0.090909090909091
84394, 1.504347826087, 0.033333333333333, 0.068181818181818
84395, 1.4826086956522, 0.033333333333333, 0.045454545454545
84396, 1.504347826087, 0.05, 0.045454545454545
84397, 1.504347826087, 0.033333333333333, 0.022727272727273
84398, 1.5478260869565, 0.033333333333333, 0.47727272727273
84399, 1.5260869565217, 0.033333333333333, 0.45454545454545
84400, 1.5478260869565, 0.05, 0.45454545454545
84401, 1.5478260869565, 0.033333333333333, 0.43181818181818
84402, 1.5260869565217, 0.033333333333333, 0.40909090909091
84403, 1.5478260869565, 0.05, 0.40909090909091
84404, 1.5478260869565, 0.033333333333333, 0.38636363636364
84405, 1.5260869565217, 0.033333333333333, 0.36363636363636
84406, 1.5478260869565, 0.05, 0.36363636363636
84407, 1.5478260869565, 0.033333333333333, 0.34090909090909
84408, 1.5260869565217, 0.033333333333333, 0.31818181818182
84409, 1.5478260869565, 0.05, 0.31818181818182
84410, 1.5478260869565, 0.033333333333333, 0.29545454545455
84411, 1.5260869565217, 0.033333333333333, 0.27272727272727
84412, 1.5478260869565, 0.05, 0.27272727272727
84413, 1.5478260869565, 0.033333333333333, 0.25
84414, 1.5260869565217, 0.033333333333333, 0.22727272727273
84415, 1.5478260869565, 0.05, 0.22727272727273
84416, 1.5478260869565, 0.033333333333333, 0.20454545454545
84417, 1.5260869565217, 0.033333333333333, 0.18181818181818
84418, 1.5478260869565, 0.05, 0.18181818181818
84419, 1.5478260869565, 0.033333333333333, 0.15909090909091
84420, 1.5260869565217, 0.033333333333333, 0.13636363636364
84421, 1.5478260869565, 0.05, 0.13636363636364
84422, 1.5478260869565, 0.033333333333333, 0.11363636363636
84423, 1.5260869565217, 0.033333333333333, 0.090909090909091
84424, 1.5478260869565, 0.05, 0.090909090909091
84425, 1.5478260869565, 0.033333333333333, 0.068181818181818
84426, 1.5260869565217, 0.033333333333333, 0.045454545454545
84427, 1.5478260869565, 0.05, 0.045454545454545
84428, 1.5478260869565, 0.033333333333333, 0.022727272727273
84429, 1.5913043478261, 0.033333333333333, 0.47727272727273
84430, 1.5695652173913, 0.033333333333333, 0.45454545454545
84431, 1.5913043478261, 0.05, 0.45454545454545
84432, 1.5913043478261, 0.033333333333333, 0.43181818181818
84433, 1.5695652173913, 0.033333333333333, 0.40909090909091
84434, 1.5913043478261, 0.05, 0.40909090909091
84435, 1.5913043478261, 0.033333333333333, 0.38636363636364
84436, 1.5695652173913, 0.033333333333333, 0.36363636363636
84437, 1.5913043478261, 0.05, 0.36363636363636
84438, 1.5913043478261, 0.033333333333333, 0.34090909090909
84439, 1.5695652173913, 0.033333333333333, 0.31818181818182
84440, 1.5913043478261, 0.05, 0.31818181818182
84441, 1.5913043478261, 0.033333333333333, 0.29545454545455
84442, 1.5695652173913, 0.033333333333333, 0.27272727272727
84443, 1.5913043478261, 0.05, 0.27272727272727
84444, 1.5913043478261, 0.033333333333333, 0.25
84445, 1.5695652173913, 0.033333333333333, 0.22727272727273
84446, 1.5913043478261, 0.05, 0.22727272727273
84447, 1.5913043478261, 0.033333333333333, 0.20454545454545
84448, 1.5695652173913, 0.033333333333333, 0.18181818181818
84449, 1.5913043478261, 0.05, 0.18181818181818
84450, 1.5913043478261, 0.033333333333333, 0.15909090909091
84451, 1.5695652173913, 0.033333333333333, 0.13636363636364
84452, 1.5913043478261, 0.05, 0.13636363636364
84453, 1.5913043478261, 0.033333333333333, 0.11363636363636
84454, 1.5695652173913, 0.033333333333333, 0.090909090909091
84455, 1.5913043478261, 0.05, 0.090909090909091
84456, 1.5913043478261, 0.033333333333333, 0.068181818181818
84457, 1.5695652173913, 0.033333333333333, 0.045454545454545
84458, 1.5913043478261, 0.05, 0.045454545454545
84459, 1.5913043478261, 0.033333333333333, 0.022727272727273
84460, 1.6347826086957, 0.033333333333333, 0.47727272727273
84461, 1.6130434782609, 0.033333333333333, 0.45454545454545
84462, 1.6347826086957, 0.05, 0.45454545454545
84463, 1.6347826086957, 0.033333333333333, 0.43181818181818
84464, 1.6130434782609, 0.033333333333333, 0.40909090909091
84465, 1.6347826086957, 0.05, 0.40909090909091
84466, 1.6347826086957, 0.033333333333333, 0.38636363636364
84467, 1.6130434782609, 0.033333333333333, 0.36363636363636
84468, 1.6347826086957, 0.05, 0.36363636363636
84469, 1.6347826086957, 0.033333333333333, 0.34090909090909
84470, 1.6130434782609, 0.033333333333333, 0.31818181818182
84471, 1.6347826086957, 0.05, 0.31818181818182
84472, 1.6347826086957, 0.033333333333333, 0.29545454545455
84473, 1.6130434782609, 0.033333333333333, 0.27272727272727
84474, 1.6347826086957, 0.05, 0.27272727272727
84475, 1.6347826086957, 0.033333333333333, 0.25
84476, 1.6130434782609, 0.033333333333333, 0.22727272727273
84477, 1.6347826086957, 0.05, 0.22727272727273
84478, 1.6347826086957, 0.033333333333333, 0.20454545454545
84479, 1.6130434782609, 0.033333333333333, 0.18181818181818
84480, 1.6347826086957, 0.05, 0.18181818181818
84481, 1.6347826086957, 0.033333333333333, 0.15909090909091
84482, 1.6130434782609, 0.033333333333333, 0.13636363636364
84483, 1.6347826086957, 0.05, 0.13636363636364
84484, 1.6347826086957, 0.033333333333333, 0.11363636363636
84485, 1.6130434782609, 0.033333333333333, 0.090909090909091
84486, 1.6347826086957, 0.05, 0.090909090909091
84487, 1.6347826086957, 0.033333333333333, 0.068181818181818
84488, 1.6130434782609, 0.033333333333333, 0.045454545454545
84489, 1.6347826086957, 0.05, 0.045454545454545
84490, 1.6347826086957, 0.033333333333333, 0.022727272727273
84491, 1.6782608695652, 0.033333333333333, 0.47727272727273
84492, 1.6565217391304, 0.033333333333333, 0.45454545454545
84493, 1.6782608695652, 0.05, 0.45454545454545
84494, 1.6782608695652, 0.033333333333333, 0.43181818181818
84495, 1.6565217391304, 0.033333333333333, 0.40909090909091
84496, 1.6782608695652, 0.05, 0.40909090909091
84497, 1.6782608695652, 0.033333333333333, 0.38636363636364
84498, 1.6565217391304, 0.033333333333333, 0.36363636363636
84499, 1.6782608695652, 0.05, 0.36363636363636
84500, 1.6782608695652, 0.033333333333333, 0.34090909090909
84501, 1.6565217391304, 0.033333333333333, 0.31818181818182
84502, 1.6782608695652, 0.05, 0.31818181818182
84503, 1.6782608695652, 0.033333333333333, 0.29545454545455
84504, 1.6565217391304, 0.033333333333333, 0.27272727272727
84505, 1.6782608695652, 0.05, 0.27272727272727
84506, 1.6782608695652, 0.033333333333333, 0.25
84507, 1.6565217391304, 0.033333333333333, 0.22727272727273
84508, 1.6782608695652, 0.05, 0.22727272727273
84509, 1.6782608695652, 0.033333333333333, 0.20454545454545
84510, 1.6565217391304, 0.033333333333333, 0.18181818181818
84511, 1.6782608695652, 0.05, 0.18181818181818
84512, 1.6782608695652, 0.033333333333333, 0.15909090909091
84513, 1.6565217391304, 0.033333333333333, 0.13636363636364
84514, 1.6782608695652, 0.05, 0.13636363636364
84515, 1.6782608695652, 0.033333333333333, 0.11363636363636
84516, 1.6565217391304, 0.033333333333333, 0.090909090909091
84517, 1.6782608695652, 0.05, 0.090909090909091
84518, 1.6782608695652, 0.033333333333333, 0.068181818181818
84519, 1.6565217391304, 0.033333333333333, 0.045454545454545
84520, 1.6782608695652, 0.05, 0.045454545454545
84521, 1.6782608695652, 0.033333333333333, 0.022727272727273
84522, 1.7217391304348, 0.033333333333333, 0.47727272727273
84523, 1.7, 0.033333333333333, 0.45454545454545
84524, 1.7217391304348, 0.05, 0.45454545454545
84525, 1.7217391304348, 0.033333333333333, 0.43181818181818
84526, 1.7, 0.033333333333333, 0.40909090909091
84527, 1.7217391304348, 0.05, 0.40909090909091
84528, 1.7217391304348, 0.033333333333333, 0.38636363636364
84529, 1.7, 0.033333333333333, 0.36363636363636
84530, 1.7217391304348, 0.05, 0.36363636363636
84531, 1.7217391304348, 0.033333333333333, 0.34090909090909
84532, 1.7, 0.033333333333333, 0.31818181818182
84533, 1.7217391304348, 0.05, 0.31818181818182
84534, 1.7217391304348, 0.033333333333333, 0.29545454545455
84535, 1.7, 0.033333333333333, 0.27272727272727
84536, 1.7217391304348, 0.05, 0.27272727272727
84537, 1.7217391304348, 0.033333333333333, 0.25
84538, 1.7, 0.033333333333333, 0.22727272727273
84539, 1.7217391304348, 0.05, 0.22727272727273
84540, 1.7217391304348, 0.033333333333333, 0.20454545454545
84541, 1.7, 0.033333333333333, 0.18181818181818
84542, 1.7217391304348, 0.05, 0.18181818181818
84543, 1.7217391304348, 0.033333333333333, 0.15909090909091
84544, 1.7, 0.033333333333333, 0.13636363636364
84545, 1.7217391304348, 0.05, 0.13636363636364
84546, 1.7217391304348, 0.033333333333333, 0.11363636363636
84547, 1.7, 0.033333333333333, 0.090909090909091
84548, 1.7217391304348, 0.05, 0.090909090909091
84549, 1.7217391304348, 0.033333333333333, 0.068181818181818
84550, 1.7, 0.033333333333333, 0.045454545454545
84551, 1.7217391304348, 0.05, 0.045454545454545
84552, 1.7217391304348, 0.033333333333333, 0.022727272727273
84553, 1.7652173913043, 0.033333333333333, 0.47727272727273
84554, 1.7434782608696, 0.033333333333333, 0.45454545454545
84555, 1.7652173913043, 0.05, 0.45454545454545
84556, 1.7652173913043, 0.033333333333333, 0.43181818181818
84557, 1.7434782608696, 0.033333333333333, 0.40909090909091
84558, 1.7652173913043, 0.05, 0.40909090909091
84559, 1.7652173913043, 0.033333333333333, 0.38636363636364
84560, 1.7434782608696, 0.033333333333333, 0.36363636363636
84561, 1.7652173913043, 0.05, 0.36363636363636
84562, 1.7652173913043, 0.033333333333333, 0.34090909090909
84563, 1.7434782608696, 0.033333333333333, 0.31818181818182
84564, 1.7652173913043, 0.05, 0.31818181818182
84565, 1.7652173913043, 0.033333333333333, 0.29545454545455
84566, 1.7434782608696, 0.033333333333333, 0.27272727272727
84567, 1.7652173913043, 0.05, 0.27272727272727
84568, 1.7652173913043, 0.033333333333333, 0.25
84569, 1.7434782608696, 0.033333333333333, 0.22727272727273
84570, 1.7652173913043, 0.05, 0.22727272727273
84571, 1.7652173913043, 0.033333333333333, 0.20454545454545
84572, 1.7434782608696, 0.033333333333333, 0.18181818181818
84573, 1.7652173913043, 0.05, 0.18181818181818
84574, 1.7652173913043, 0.033333333333333, 0.15909090909091
84575, 1.7434782608696, 0.033333333333333, 0.13636363636364
84576, 1.7652173913043, 0.05, 0.13636363636364
84577, 1.7652173913043, 0.033333333333333, 0.11363636363636
84578, 1.7434782608696, 0.033333333333333, 0.090909090909091
84579, 1.7652173913043, 0.05, 0.090909090909091
84580, 1.7652173913043, 0.033333333333333, 0.068181818181818
84581, 1.7434782608696, 0.033333333333333, 0.045454545454545
84582, 1.7652173913043, 0.05, 0.045454545454545
84583, 1.7652173913043, 0.033333333333333, 0.022727272727273
84584, 1.8086956521739, 0.033333333333333, 0.47727272727273
84585, 1.7869565217391, 0.033333333333333, 0.45454545454545
84586, 1.8086956521739, 0.05, 0.45454545454545
84587, 1.8086956521739, 0.033333333333333, 0.43181818181818
84588, 1.7869565217391, 0.033333333333333, 0.40909090909091
84589, 1.8086956521739, 0.05, 0.40909090909091
84590, 1.8086956521739, 0.033333333333333, 0.38636363636364
84591, 1.7869565217391, 0.033333333333333, 0.36363636363636
84592, 1.8086956521739, 0.05, 0.36363636363636
84593, 1.8086956521739, 0.033333333333333, 0.34090909090909
84594, 1.7869565217391, 0.033333333333333, 0.31818181818182
84595, 1.8086956521739, 0.05, 0.31818181818182
84596, 1.8086956521739, 0.033333333333333, 0.29545454545455
84597, 1.7869565217391, 0.033333333333333, 0.27272727272727
84598, 1.8086956521739, 0.05, 0.27272727272727
84599, 1.8086956521739, 0.033333333333333, 0.25
84600, 1.7869565217391, 0.033333333333333, 0.22727272727273
84601, 1.8086956521739, 0.05, 0.22727272727273
84602, 1.8086956521739, 0.033333333333333, 0.20454545454545
84603, 1.7869565217391, 0.033333333333333, 0.18181818181818
84604, 1.8086956521739, 0.05, 0.18181818181818
84605, 1.8086956521739, 0.033333333333333, 0.15909090909091
84606, 1.7869565217391, 0.033333333333333, 0.13636363636364
84607, 1.8086956521739, 0.05, 0.13636363636364
84608, 1.8086956521739, 0.033333333333333, 0.11363636363636
84609, 1.7869565217391, 0.033333333333333, 0.090909090909091
84610, 1.8086956521739, 0.05, 0.090909090909091
84611, 1.8086956521739, 0.033333333333333, 0.068181818181818
84612, 1.7869565217391, 0.033333333333333, 0.045454545454545
84613, 1.8086956521739, 0.05, 0.045454545454545
84614, 1.8086956521739, 0.033333333333333, 0.022727272727273
84615, 1.8521739130435, 0.033333333333333, 0.47727272727273
84616, 1.8304347826087, 0.033333333333333, 0.45454545454545
84617, 1.8521739130435, 0.05, 0.45454545454545
84618, 1.8521739130435, 0.033333333333333, 0.43181818181818
84619, 1.8304347826087, 0.033333333333333, 0.40909090909091
84620, 1.8521739130435, 0.05, 0.40909090909091
84621, 1.8521739130435, 0.033333333333333, 0.38636363636364
84622, 1.8304347826087, 0.033333333333333, 0.36363636363636
84623, 1.8521739130435, 0.05, 0.36363636363636
84624, 1.8521739130435, 0.033333333333333, 0.34090909090909
84625, 1.8304347826087, 0.033333333333333, 0.31818181818182
84626, 1.8521739130435, 0.05, 0.31818181818182
84627, 1.8521739130435, 0.033333333333333, 0.29545454545455
84628, 1.8304347826087, 0.033333333333333, 0.27272727272727
84629, 1.8521739130435, 0.05, 0.27272727272727
84630, 1.8521739130435, 0.033333333333333, 0.25
84631, 1.8304347826087, 0.033333333333333, 0.22727272727273
84632, 1.8521739130435, 0.05, 0.22727272727273
84633, 1.8521739130435, 0.033333333333333, 0.20454545454545
84634, 1.8304347826087, 0.033333333333333, 0.18181818181818
84635, 1.8521739130435, 0.05, 0.18181818181818
84636, 1.8521739130435, 0.033333333333333, 0.15909090909091
84637, 1.8304347826087, 0.033333333333333, 0.13636363636364
84638, 1.8521739130435, 0.05, 0.13636363636364
84639, 1.8521739130435, 0.033333333333333, 0.11363636363636
84640, 1.8304347826087, 0.033333333333333, 0.090909090909091
84641, 1.8521739130435, 0.05, 0.090909090909091
84642, 1.8521739130435, 0.033333333333333, 0.068181818181818
84643, 1.8304347826087, 0.033333333333333, 0.045454545454545
84644, 1.8521739130435, 0.05, 0.045454545454545
84645, 1.8521739130435, 0.033333333333333, 0.022727272727273
84646, 1.895652173913, 0.033333333333333, 0.47727272727273
84647, 1.8739130434783, 0.033333333333333, 0.45454545454545
84648, 1.895652173913, 0.05, 0.45454545454545
84649, 1.895652173913, 0.033333333333333, 0.43181818181818
84650, 1.8739130434783, 0.033333333333333, 0.40909090909091
84651, 1.895652173913, 0.05, 0.40909090909091
84652, 1.895652173913, 0.033333333333333, 0.38636363636364
84653, 1.8739130434783, 0.033333333333333, 0.36363636363636
84654, 1.895652173913, 0.05, 0.36363636363636
84655, 1.895652173913, 0.033333333333333, 0.34090909090909
84656, 1.8739130434783, 0.033333333333333, 0.31818181818182
84657, 1.895652173913, 0.05, 0.31818181818182
84658, 1.895652173913, 0.033333333333333, 0.29545454545455
84659, 1.8739130434783, 0.033333333333333, 0.27272727272727
84660, 1.895652173913, 0.05, 0.27272727272727
84661, 1.895652173913, 0.033333333333333, 0.25
84662, 1.8739130434783, 0.033333333333333, 0.22727272727273
84663, 1.895652173913, 0.05, 0.22727272727273
84664, 1.895652173913, 0.033333333333333, 0.20454545454545
84665, 1.8739130434783, 0.033333333333333, 0.18181818181818
84666, 1.895652173913, 0.05, 0.18181818181818
84667, 1.895652173913, 0.033333333333333, 0.15909090909091
84668, 1.8739130434783, 0.033333333333333, 0.13636363636364
84669, 1.895652173913, 0.05, 0.13636363636364
84670, 1.895652173913, 0.033333333333333, 0.11363636363636
84671, 1.8739130434783, 0.033333333333333, 0.090909090909091
84672, 1.895652173913, 0.05, 0.090909090909091
84673, 1.895652173913, 0.033333333333333, 0.068181818181818
84674, 1.8739130434783, 0.033333333333333, 0.045454545454545
84675, 1.895652173913, 0.05, 0.045454545454545
84676, 1.895652173913, 0.033333333333333, 0.022727272727273
84677, 1.9391304347826, 0.033333333333333, 0.47727272727273
84678, 1.9173913043478, 0.033333333333333, 0.45454545454545
84679, 1.9391304347826, 0.05, 0.45454545454545
84680, 1.9391304347826, 0.033333333333333, 0.43181818181818
84681, 1.9173913043478, 0.033333333333333, 0.40909090909091
84682, 1.9391304347826, 0.05, 0.40909090909091
84683, 1.9391304347826, 0.033333333333333, 0.38636363636364
84684, 1.9173913043478, 0.033333333333333, 0.36363636363636
84685, 1.9391304347826, 0.05, 0.36363636363636
84686, 1.9391304347826, 0.033333333333333, 0.34090909090909
84687, 1.9173913043478, 0.033333333333333, 0.31818181818182
84688, 1.9391304347826, 0.05, 0.31818181818182
84689, 1.9391304347826, 0.033333333333333, 0.29545454545455
84690, 1.9173913043478, 0.033333333333333, 0.27272727272727
84691, 1.9391304347826, 0.05, 0.27272727272727
84692, 1.9391304347826, 0.033333333333333, 0.25
84693, 1.9173913043478, 0.033333333333333, 0.22727272727273
84694, 1.9391304347826, 0.05, 0.22727272727273
84695, 1.9391304347826, 0.033333333333333, 0.20454545454545
84696, 1.9173913043478, 0.033333333333333, 0.18181818181818
84697, 1.9391304347826, 0.05, 0.18181818181818
84698, 1.9391304347826, 0.033333333333333, 0.15909090909091
84699, 1.9173913043478, 0.033333333333333, 0.13636363636364
84700, 1.9391304347826, 0.05, 0.13636363636364
84701, 1.9391304347826, 0.033333333333333, 0.11363636363636
84702, 1.9173913043478, 0.033333333333333, 0.090909090909091
84703, 1.9391304347826, 0.05, 0.090909090909091
84704, 1.9391304347826, 0.033333333333333, 0.068181818181818
84705, 1.9173913043478, 0.033333333333333, 0.045454545454545
84706, 1.9391304347826, 0.05, 0.045454545454545
84707, 1.9391304347826, 0.033333333333333, 0.022727272727273
84708, 1.9826086956522, 0.033333333333333, 0.47727272727273
84709, 1.9608695652174, 0.033333333333333, 0.45454545454545
84710, 1.9826086956522, 0.05, 0.45454545454545
84711, 1.9826086956522, 0.033333333333333, 0.43181818181818
84712, 1.9608695652174, 0.033333333333333, 0.40909090909091
84713, 1.9826086956522, 0.05, 0.40909090909091
84714, 1.9826086956522, 0.033333333333333, 0.38636363636364
84715, 1.9608695652174, 0.033333333333333, 0.36363636363636
84716, 1.9826086956522, 0.05, 0.36363636363636
84717, 1.9826086956522, 0.033333333333333, 0.34090909090909
84718, 1.9608695652174, 0.033333333333333, 0.31818181818182
84719, 1.9826086956522, 0.05, 0.31818181818182
84720, 1.9826086956522, 0.033333333333333, 0.29545454545455
84721, 1.9608695652174, 0.033333333333333, 0.27272727272727
84722, 1.9826086956522, 0.05, 0.27272727272727
84723, 1.9826086956522, 0.033333333333333, 0.25
84724, 1.9608695652174, 0.033333333333333, 0.22727272727273
84725, 1.9826086956522, 0.05, 0.22727272727273
84726, 1.9826086956522, 0.033333333333333, 0.20454545454545
84727, 1.9608695652174, 0.033333333333333, 0.18181818181818
84728, 1.9826086956522, 0.05, 0.18181818181818
84729, 1.9826086956522, 0.033333333333333, 0.15909090909091
84730, 1.9608695652174, 0.033333333333333, 0.13636363636364
84731, 1.9826086956522, 0.05, 0.13636363636364
84732, 1.9826086956522, 0.033333333333333, 0.11363636363636
84733, 1.9608695652174, 0.033333333333333, 0.090909090909091
84734, 1.9826086956522, 0.05, 0.090909090909091
84735, 1.9826086956522, 0.033333333333333, 0.068181818181818
84736, 1.9608695652174, 0.033333333333333, 0.045454545454545
84737, 1.9826086956522, 0.05, 0.045454545454545
84738, 1.9826086956522, 0.033333333333333, 0.022727272727273
84739, 2.0260869565217, 0.033333333333333, 0.47727272727273
84740, 2.004347826087, 0.033333333333333, 0.45454545454545
84741, 2.0260869565217, 0.05, 0.45454545454545
84742, 2.0260869565217, 0.033333333333333, 0.43181818181818
84743, 2.004347826087, 0.033333333333333, 0.40909090909091
84744, 2.0260869565217, 0.05, 0.40909090909091
84745, 2.0260869565217, 0.033333333333333, 0.38636363636364
84746, 2.004347826087, 0.033333333333333, 0.36363636363636
84747, 2.0260869565217, 0.05, 0.36363636363636
84748, 2.0260869565217, 0.033333333333333, 0.34090909090909
84749, 2.004347826087, 0.033333333333333, 0.31818181818182
84750, 2.0260869565217, 0.05, 0.31818181818182
84751, 2.0260869565217, 0.033333333333333, 0.29545454545455
84752, 2.004347826087, 0.033333333333333, 0.27272727272727
84753, 2.0260869565217, 0.05, 0.27272727272727
84754, 2.0260869565217, 0.033333333333333, 0.25
84755, 2.004347826087, 0.033333333333333, 0.22727272727273
84756, 2.0260869565217, 0.05, 0.22727272727273
84757, 2.0260869565217, 0.033333333333333, 0.20454545454545
84758, 2.004347826087, 0.033333333333333, 0.18181818181818
84759, 2.0260869565217, 0.05, 0.18181818181818
84760, 2.0260869565217, 0.033333333333333, 0.15909090909091
84761, 2.004347826087, 0.033333333333333, 0.13636363636364
84762, 2.0260869565217, 0.05, 0.13636363636364
84763, 2.0260869565217, 0.033333333333333, 0.11363636363636
84764, 2.004347826087, 0.033333333333333, 0.090909090909091
84765, 2.0260869565217, 0.05, 0.090909090909091
84766, 2.0260869565217, 0.033333333333333, 0.068181818181818
84767, 2.004347826087, 0.033333333333333, 0.045454545454545
84768, 2.0260869565217, 0.05, 0.045454545454545
84769, 2.0260869565217, 0.033333333333333, 0.022727272727273
84770, 2.0695652173913, 0.033333333333333, 0.47727272727273
84771, 2.0478260869565, 0.033333333333333, 0.45454545454545
84772, 2.0695652173913, 0.05, 0.45454545454545
84773, 2.0695652173913, 0.033333333333333, 0.43181818181818
84774, 2.0478260869565, 0.033333333333333, 0.40909090909091
84775, 2.0695652173913, 0.05, 0.40909090909091
84776, 2.0695652173913, 0.033333333333333, 0.38636363636364
84777, 2.0478260869565, 0.033333333333333, 0.36363636363636
84778, 2.0695652173913, 0.05, 0.36363636363636
84779, 2.0695652173913, 0.033333333333333, 0.34090909090909
84780, 2.0478260869565, 0.033333333333333, 0.31818181818182
84781, 2.0695652173913, 0.05, 0.31818181818182
84782, 2.0695652173913, 0.033333333333333, 0.29545454545455
84783, 2.0478260869565, 0.033333333333333, 0.27272727272727
84784, 2.0695652173913, 0.05, 0.27272727272727
84785, 2.0695652173913, 0.033333333333333, 0.25
84786, 2.0478260869565, 0.033333333333333, 0.22727272727273
84787, 2.0695652173913, 0.05, 0.22727272727273
84788, 2.0695652173913, 0.033333333333333, 0.20454545454545
84789, 2.0478260869565, 0.033333333333333, 0.18181818181818
84790, 2.0695652173913, 0.05, 0.18181818181818
84791, 2.0695652173913, 0.033333333333333, 0.15909090909091
84792, 2.0478260869565, 0.033333333333333, 0.13636363636364
84793, 2.0695652173913, 0.05, 0.13636363636364
84794, 2.0695652173913, 0.033333333333333, 0.11363636363636
84795, 2.0478260869565, 0.033333333333333, 0.090909090909091
84796, 2.0695652173913, 0.05, 0.090909090909091
84797, 2.0695652173913, 0.033333333333333, 0.068181818181818
84798, 2.0478260869565, 0.033333333333333, 0.045454545454545
84799, 2.0695652173913, 0.05, 0.045454545454545
84800, 2.0695652173913, 0.033333333333333, 0.022727272727273
84801, 2.1130434782609, 0.033333333333333, 0.47727272727273
84802, 2.0913043478261, 0.033333333333333, 0.45454545454545
84803, 2.1130434782609, 0.05, 0.45454545454545
84804, 2.1130434782609, 0.033333333333333, 0.43181818181818
84805, 2.0913043478261, 0.033333333333333, 0.40909090909091
84806, 2.1130434782609, 0.05, 0.40909090909091
84807, 2.1130434782609, 0.033333333333333, 0.38636363636364
84808, 2.0913043478261, 0.033333333333333, 0.36363636363636
84809, 2.1130434782609, 0.05, 0.36363636363636
84810, 2.1130434782609, 0.033333333333333, 0.34090909090909
84811, 2.0913043478261, 0.033333333333333, 0.31818181818182
84812, 2.1130434782609, 0.05, 0.31818181818182
84813, 2.1130434782609, 0.033333333333333, 0.29545454545455
84814, 2.0913043478261, 0.033333333333333, 0.27272727272727
84815, 2.1130434782609, 0.05, 0.27272727272727
84816, 2.1130434782609, 0.033333333333333, 0.25
84817, 2.0913043478261, 0.033333333333333, 0.22727272727273
84818, 2.1130434782609, 0.05, 0.22727272727273
84819, 2.1130434782609, 0.033333333333333, 0.20454545454545
84820, 2.0913043478261, 0.033333333333333, 0.18181818181818
84821, 2.1130434782609, 0.05, 0.18181818181818
84822, 2.1130434782609, 0.033333333333333, 0.15909090909091
84823, 2.0913043478261, 0.033333333333333, 0.13636363636364
84824, 2.1130434782609, 0.05, 0.13636363636364
84825, 2.1130434782609, 0.033333333333333, 0.11363636363636
84826, 2.0913043478261, 0.033333333333333, 0.090909090909091
84827, 2.1130434782609, 0.05, 0.090909090909091
84828, 2.1130434782609, 0.033333333333333, 0.068181818181818
84829, 2.0913043478261, 0.033333333333333, 0.045454545454545
84830, 2.1130434782609, 0.05, 0.045454545454545
84831, 2.1130434782609, 0.033333333333333, 0.022727272727273
84832, 2.1565217391304, 0.033333333333333, 0.47727272727273
84833, 2.1347826086957, 0.033333333333333, 0.45454545454545
84834, 2.1565217391304, 0.05, 0.45454545454545
84835, 2.1565217391304, 0.033333333333333, 0.43181818181818
84836, 2.1347826086957, 0.033333333333333, 0.40909090909091
84837, 2.1565217391304, 0.05, 0.40909090909091
84838, 2.1565217391304, 0.033333333333333, 0.38636363636364
84839, 2.1347826086957, 0.033333333333333, 0.36363636363636
84840, 2.1565217391304, 0.05, 0.36363636363636
84841, 2.1565217391304, 0.033333333333333, 0.34090909090909
84842, 2.1347826086957, 0.033333333333333, 0.31818181818182
84843, 2.1565217391304, 0.05, 0.31818181818182
84844, 2.1565217391304, 0.033333333333333, 0.29545454545455
84845, 2.1347826086957, 0.033333333333333, 0.27272727272727
84846, 2.1565217391304, 0.05, 0.27272727272727
84847, 2.1565217391304, 0.033333333333333, 0.25
84848, 2.1347826086957, 0.033333333333333, 0.22727272727273
84849, 2.1565217391304, 0.05, 0.22727272727273
84850, 2.1565217391304, 0.033333333333333, 0.20454545454545
84851, 2.1347826086957, 0.033333333333333, 0.18181818181818
84852, 2.1565217391304, 0.05, 0.18181818181818
84853, 2.1565217391304, 0.033333333333333, 0.15909090909091
84854, 2.1347826086957, 0.033333333333333, 0.13636363636364
84855, 2.1565217391304, 0.05, 0.13636363636364
84856, 2.1565217391304, 0.033333333333333, 0.11363636363636
84857, 2.1347826086957, 0.033333333333333, 0.090909090909091
84858, 2.1565217391304, 0.05, 0.090909090909091
84859, 2.1565217391304, 0.033333333333333, 0.068181818181818
84860, 2.1347826086957, 0.033333333333333, 0.045454545454545
84861, 2.1565217391304, 0.05, 0.045454545454545
84862, 2.1565217391304, 0.033333333333333, 0.022727272727273
84863, 2.1782608695652, 0.033333333333333, 0.45454545454545
84864, 2.1782608695652, 0.033333333333333, 0.40909090909091
84865, 2.1782608695652, 0.033333333333333, 0.36363636363636
84866, 2.1782608695652, 0.033333333333333, 0.31818181818182
84867, 2.1782608695652, 0.033333333333333, 0.27272727272727
84868, 2.1782608695652, 0.033333333333333, 0.22727272727273
84869, 2.1782608695652, 0.033333333333333, 0.18181818181818
84870, 2.1782608695652, 0.033333333333333, 0.13636363636364
84871, 2.1782608695652, 0.033333333333333, 0.090909090909091
84872, 2.1782608695652, 0.033333333333333, 0.045454545454545
84873, 1.2434782608696, 0.016666666666667, 0.45454545454545
84874, 1.2434782608696, 0.016666666666667, 0.40909090909091
84875, 1.2434782608696, 0.016666666666667, 0.36363636363636
84876, 1.2434782608696, 0.016666666666667, 0.31818181818182
84877, 1.2434782608696, 0.016666666666667, 0.27272727272727
84878, 1.2434782608696, 0.016666666666667, 0.22727272727273
84879, 1.2434782608696, 0.016666666666667, 0.18181818181818
84880, 1.2434782608696, 0.016666666666667, 0.13636363636364
84881, 1.2434782608696, 0.016666666666667, 0.090909090909091
84882, 1.2434782608696, 0.016666666666667, 0.045454545454545
84883, 1.2869565217391, 0.016666666666667, 0.45454545454545
84884, 1.2869565217391, 0.016666666666667, 0.40909090909091
84885, 1.2869565217391, 0.016666666666667, 0.36363636363636
84886, 1.2869565217391, 0.016666666666667, 0.31818181818182
84887, 1.2869565217391, 0.016666666666667, 0.27272727272727
84888, 1.2869565217391, 0.016666666666667, 0.22727272727273
84889, 1.2869565217391, 0.016666666666667, 0.18181818181818
84890, 1.2869565217391, 0.016666666666667, 0.13636363636364
84891, 1.2869565217391, 0.016666666666667, 0.090909090909091
84892, 1.2869565217391, 0.016666666666667, 0.045454545454545
84893, 1.3304347826087, 0.016666666666667, 0.45454545454545
84894, 1.3304347826087, 0.016666666666667, 0.40909090909091
84895, 1.3304347826087, 0.016666666666667, 0.36363636363636
84896, 1.3304347826087, 0.016666666666667, 0.31818181818182
84897, 1.3304347826087, 0.016666666666667, 0.27272727272727
84898, 1.3304347826087, 0.016666666666667, 0.22727272727273
84899, 1.3304347826087, 0.016666666666667, 0.18181818181818
84900, 1.3304347826087, 0.016666666666667, 0.13636363636364
84901, 1.3304347826087, 0.016666666666667, 0.090909090909091
84902, 1.3304347826087, 0.016666666666667, 0.045454545454545
84903, 1.3739130434783, 0.016666666666667, 0.45454545454545
84904, 1.3739130434783, 0.016666666666667, 0.40909090909091
84905, 1.3739130434783, 0.016666666666667, 0.36363636363636
84906, 1.3739130434783, 0.016666666666667, 0.31818181818182
84907, 1.3739130434783, 0.016666666666667, 0.27272727272727
84908, 1.3739130434783, 0.016666666666667, 0.22727272727273
84909, 1.3739130434783, 0.016666666666667, 0.18181818181818
84910, 1.3739130434783, 0.016666666666667, 0.13636363636364
84911, 1.3739130434783, 0.016666666666667, 0.090909090909091
84912, 1.3739130434783, 0.016666666666667, 0.045454545454545
84913, 1.4173913043478, 0.016666666666667, 0.45454545454545
84914, 1.4173913043478, 0.016666666666667, 0.40909090909091
84915, 1.4173913043478, 0.016666666666667, 0.36363636363636
84916, 1.4173913043478, 0.016666666666667, 0.31818181818182
84917, 1.4173913043478, 0.016666666666667, 0.27272727272727
84918, 1.4173913043478, 0.016666666666667, 0.22727272727273
84919, 1.4173913043478, 0.016666666666667, 0.18181818181818
84920, 1.4173913043478, 0.016666666666667, 0.13636363636364
84921, 1.4173913043478, 0.016666666666667, 0.090909090909091
84922, 1.4173913043478, 0.016666666666667, 0.045454545454545
84923, 1.4608695652174, 0.016666666666667, 0.45454545454545
84924, 1.4608695652174, 0.016666666666667, 0.40909090909091
84925, 1.4608695652174, 0.016666666666667, 0.36363636363636
84926, 1.4608695652174, 0.016666666666667, 0.31818181818182
84927, 1.4608695652174, 0.016666666666667, 0.27272727272727
84928, 1.4608695652174, 0.016666666666667, 0.22727272727273
84929, 1.4608695652174, 0.016666666666667, 0.18181818181818
84930, 1.4608695652174, 0.016666666666667, 0.13636363636364
84931, 1.4608695652174, 0.016666666666667, 0.090909090909091
84932, 1.4608695652174, 0.016666666666667, 0.045454545454545
84933, 1.504347826087, 0.016666666666667, 0.45454545454545
84934, 1.504347826087, 0.016666666666667, 0.40909090909091
84935, 1.504347826087, 0.016666666666667, 0.36363636363636
84936, 1.504347826087, 0.016666666666667, 0.31818181818182
84937, 1.504347826087, 0.016666666666667, 0.27272727272727
84938, 1.504347826087, 0.016666666666667, 0.22727272727273
84939, 1.504347826087, 0.016666666666667, 0.18181818181818
84940, 1.504347826087, 0.016666666666667, 0.13636363636364
84941, 1.504347826087, 0.016666666666667, 0.090909090909091
84942, 1.504347826087, 0.016666666666667, 0.045454545454545
84943, 1.5478260869565, 0.016666666666667, 0.45454545454545
84944, 1.5478260869565, 0.016666666666667, 0.40909090909091
84945, 1.5478260869565, 0.016666666666667, 0.36363636363636
84946, 1.5478260869565, 0.016666666666667, 0.31818181818182
84947, 1.5478260869565, 0.016666666666667, 0.27272727272727
84948, 1.5478260869565, 0.016666666666667, 0.22727272727273
84949, 1.5478260869565, 0.016666666666667, 0.18181818181818
84950, 1.5478260869565, 0.016666666666667, 0.13636363636364
84951, 1.5478260869565, 0.016666666666667, 0.090909090909091
84952, 1.5478260869565, 0.016666666666667, 0.045454545454545
84953, 1.5913043478261, 0.016666666666667, 0.45454545454545
84954, 1.5913043478261, 0.016666666666667, 0.40909090909091
84955, 1.5913043478261, 0.016666666666667, 0.36363636363636
84956, 1.5913043478261, 0.016666666666667, 0.31818181818182
