55047, 0.30434782608696, 1.375, 0.22727272727273
55048, 0.30434782608696, 1.375, 0.27272727272727
55049, 0.30434782608696, 1.375, 0.31818181818182
55050, 0.30434782608696, 1.375, 0.36363636363636
55051, 0.30434782608696, 1.375, 0.40909090909091
55052, 0.30434782608696, 1.375, 0.45454545454545
55053, 0.26086956521739, 1.375, 0.045454545454545
55054, 0.26086956521739, 1.375, 0.090909090909091
55055, 0.26086956521739, 1.375, 0.13636363636364
55056, 0.26086956521739, 1.375, 0.18181818181818
55057, 0.26086956521739, 1.375, 0.22727272727273
55058, 0.26086956521739, 1.375, 0.27272727272727
55059, 0.26086956521739, 1.375, 0.31818181818182
55060, 0.26086956521739, 1.375, 0.36363636363636
55061, 0.26086956521739, 1.375, 0.40909090909091
55062, 0.26086956521739, 1.375, 0.45454545454545
55063, 0.21739130434783, 1.375, 0.045454545454545
55064, 0.21739130434783, 1.375, 0.090909090909091
55065, 0.21739130434783, 1.375, 0.13636363636364
55066, 0.21739130434783, 1.375, 0.18181818181818
55067, 0.21739130434783, 1.375, 0.22727272727273
55068, 0.21739130434783, 1.375, 0.27272727272727
55069, 0.21739130434783, 1.375, 0.31818181818182
55070, 0.21739130434783, 1.375, 0.36363636363636
55071, 0.21739130434783, 1.375, 0.40909090909091
55072, 0.21739130434783, 1.375, 0.45454545454545
55073, 0.17391304347826, 1.375, 0.045454545454545
55074, 0.17391304347826, 1.375, 0.090909090909091
55075, 0.17391304347826, 1.375, 0.13636363636364
55076, 0.17391304347826, 1.375, 0.18181818181818
55077, 0.17391304347826, 1.375, 0.22727272727273
55078, 0.17391304347826, 1.375, 0.27272727272727
55079, 0.17391304347826, 1.375, 0.31818181818182
55080, 0.17391304347826, 1.375, 0.36363636363636
55081, 0.17391304347826, 1.375, 0.40909090909091
55082, 0.17391304347826, 1.375, 0.45454545454545
55083, 0.1304347826087, 1.375, 0.045454545454545
55084, 0.1304347826087, 1.375, 0.090909090909091
55085, 0.1304347826087, 1.375, 0.13636363636364
55086, 0.1304347826087, 1.375, 0.18181818181818
55087, 0.1304347826087, 1.375, 0.22727272727273
55088, 0.1304347826087, 1.375, 0.27272727272727
55089, 0.1304347826087, 1.375, 0.31818181818182
55090, 0.1304347826087, 1.375, 0.36363636363636
55091, 0.1304347826087, 1.375, 0.40909090909091
55092, 0.1304347826087, 1.375, 0.45454545454545
55093, 0.08695652173913, 1.375, 0.045454545454545
55094, 0.08695652173913, 1.375, 0.090909090909091
55095, 0.08695652173913, 1.375, 0.13636363636364
55096, 0.08695652173913, 1.375, 0.18181818181818
55097, 0.08695652173913, 1.375, 0.22727272727273
55098, 0.08695652173913, 1.375, 0.27272727272727
55099, 0.08695652173913, 1.375, 0.31818181818182
55100, 0.08695652173913, 1.375, 0.36363636363636
55101, 0.08695652173913, 1.375, 0.40909090909091
55102, 0.08695652173913, 1.375, 0.45454545454545
55103, 0.043478260869565, 1.375, 0.045454545454545
55104, 0.043478260869565, 1.375, 0.090909090909091
55105, 0.043478260869565, 1.375, 0.13636363636364
55106, 0.043478260869565, 1.375, 0.18181818181818
55107, 0.043478260869565, 1.375, 0.22727272727273
55108, 0.043478260869565, 1.375, 0.27272727272727
55109, 0.043478260869565, 1.375, 0.31818181818182
55110, 0.043478260869565, 1.375, 0.36363636363636
55111, 0.043478260869565, 1.375, 0.40909090909091
55112, 0.043478260869565, 1.375, 0.45454545454545
55113, 0.95652173913043, 1.375, 0.022727272727273
55114, 0.97826086956522, 1.375, 0.045454545454545
55115, 0.95652173913043, 1.3625, 0.045454545454545
55116, 0.95652173913043, 1.375, 0.068181818181818
55117, 0.97826086956522, 1.375, 0.090909090909091
55118, 0.95652173913043, 1.3625, 0.090909090909091
55119, 0.95652173913043, 1.375, 0.11363636363636
55120, 0.97826086956522, 1.375, 0.13636363636364
55121, 0.95652173913044, 1.3625, 0.13636363636364
55122, 0.95652173913044, 1.375, 0.15909090909091
55123, 0.97826086956522, 1.375, 0.18181818181818
55124, 0.95652173913043, 1.3625, 0.18181818181818
55125, 0.95652173913044, 1.375, 0.20454545454545
55126, 0.97826086956522, 1.375, 0.22727272727273
55127, 0.95652173913043, 1.3625, 0.22727272727273
55128, 0.95652173913044, 1.375, 0.25
55129, 0.97826086956522, 1.375, 0.27272727272727
55130, 0.95652173913043, 1.3625, 0.27272727272727
55131, 0.95652173913044, 1.375, 0.29545454545455
55132, 0.97826086956522, 1.375, 0.31818181818182
55133, 0.95652173913043, 1.3625, 0.31818181818182
55134, 0.95652173913043, 1.375, 0.34090909090909
55135, 0.97826086956522, 1.375, 0.36363636363636
55136, 0.95652173913043, 1.3625, 0.36363636363636
55137, 0.95652173913043, 1.375, 0.38636363636364
55138, 0.97826086956522, 1.375, 0.40909090909091
55139, 0.95652173913043, 1.3625, 0.40909090909091
55140, 0.95652173913043, 1.375, 0.43181818181818
55141, 0.97826086956522, 1.375, 0.45454545454545
55142, 0.95652173913043, 1.3625, 0.45454545454545
55143, 0.95652173913043, 1.375, 0.47727272727273
55144, 0.91304347826087, 1.375, 0.022727272727273
55145, 0.93478260869565, 1.375, 0.045454545454545
55146, 0.91304347826087, 1.3625, 0.045454545454545
55147, 0.91304347826087, 1.375, 0.068181818181818
55148, 0.93478260869565, 1.375, 0.090909090909091
55149, 0.91304347826087, 1.3625, 0.090909090909091
55150, 0.91304347826087, 1.375, 0.11363636363636
55151, 0.93478260869565, 1.375, 0.13636363636364
55152, 0.91304347826087, 1.3625, 0.13636363636364
55153, 0.91304347826087, 1.375, 0.15909090909091
55154, 0.93478260869565, 1.375, 0.18181818181818
55155, 0.91304347826087, 1.3625, 0.18181818181818
55156, 0.91304347826087, 1.375, 0.20454545454545
55157, 0.93478260869565, 1.375, 0.22727272727273
55158, 0.91304347826087, 1.3625, 0.22727272727273
55159, 0.91304347826087, 1.375, 0.25
55160, 0.93478260869565, 1.375, 0.27272727272727
55161, 0.91304347826087, 1.3625, 0.27272727272727
55162, 0.91304347826087, 1.375, 0.29545454545455
55163, 0.93478260869565, 1.375, 0.31818181818182
55164, 0.91304347826087, 1.3625, 0.31818181818182
55165, 0.91304347826087, 1.375, 0.34090909090909
55166, 0.93478260869565, 1.375, 0.36363636363636
55167, 0.91304347826087, 1.3625, 0.36363636363636
55168, 0.91304347826087, 1.375, 0.38636363636364
55169, 0.93478260869565, 1.375, 0.40909090909091
55170, 0.91304347826087, 1.3625, 0.40909090909091
55171, 0.91304347826087, 1.375, 0.43181818181818
55172, 0.93478260869565, 1.375, 0.45454545454545
55173, 0.91304347826087, 1.3625, 0.45454545454545
55174, 0.91304347826087, 1.375, 0.47727272727273
55175, 0.8695652173913, 1.375, 0.022727272727273
55176, 0.89130434782609, 1.375, 0.045454545454545
55177, 0.8695652173913, 1.3625, 0.045454545454545
55178, 0.8695652173913, 1.375, 0.068181818181818
55179, 0.89130434782609, 1.375, 0.090909090909091
55180, 0.8695652173913, 1.3625, 0.090909090909091
55181, 0.8695652173913, 1.375, 0.11363636363636
55182, 0.89130434782609, 1.375, 0.13636363636364
55183, 0.8695652173913, 1.3625, 0.13636363636364
55184, 0.8695652173913, 1.375, 0.15909090909091
55185, 0.89130434782609, 1.375, 0.18181818181818
55186, 0.8695652173913, 1.3625, 0.18181818181818
55187, 0.8695652173913, 1.375, 0.20454545454545
55188, 0.89130434782609, 1.375, 0.22727272727273
55189, 0.8695652173913, 1.3625, 0.22727272727273
55190, 0.8695652173913, 1.375, 0.25
55191, 0.89130434782609, 1.375, 0.27272727272727
55192, 0.8695652173913, 1.3625, 0.27272727272727
55193, 0.8695652173913, 1.375, 0.29545454545455
55194, 0.89130434782609, 1.375, 0.31818181818182
55195, 0.8695652173913, 1.3625, 0.31818181818182
55196, 0.8695652173913, 1.375, 0.34090909090909
55197, 0.89130434782609, 1.375, 0.36363636363636
55198, 0.8695652173913, 1.3625, 0.36363636363636
55199, 0.8695652173913, 1.375, 0.38636363636364
55200, 0.89130434782609, 1.375, 0.40909090909091
55201, 0.8695652173913, 1.3625, 0.40909090909091
55202, 0.8695652173913, 1.375, 0.43181818181818
55203, 0.89130434782609, 1.375, 0.45454545454545
55204, 0.8695652173913, 1.3625, 0.45454545454545
55205, 0.8695652173913, 1.375, 0.47727272727273
55206, 0.82608695652174, 1.375, 0.022727272727273
55207, 0.84782608695652, 1.375, 0.045454545454545
55208, 0.82608695652174, 1.3625, 0.045454545454545
55209, 0.82608695652174, 1.375, 0.068181818181818
55210, 0.84782608695652, 1.375, 0.090909090909091
55211, 0.82608695652174, 1.3625, 0.090909090909091
55212, 0.82608695652174, 1.375, 0.11363636363636
55213, 0.84782608695652, 1.375, 0.13636363636364
55214, 0.82608695652174, 1.3625, 0.13636363636364
55215, 0.82608695652174, 1.375, 0.15909090909091
55216, 0.84782608695652, 1.375, 0.18181818181818
55217, 0.82608695652174, 1.3625, 0.18181818181818
55218, 0.82608695652174, 1.375, 0.20454545454545
55219, 0.84782608695652, 1.375, 0.22727272727273
55220, 0.82608695652174, 1.3625, 0.22727272727273
55221, 0.82608695652174, 1.375, 0.25
55222, 0.84782608695652, 1.375, 0.27272727272727
55223, 0.82608695652174, 1.3625, 0.27272727272727
55224, 0.82608695652174, 1.375, 0.29545454545455
55225, 0.84782608695652, 1.375, 0.31818181818182
55226, 0.82608695652174, 1.3625, 0.31818181818182
55227, 0.82608695652174, 1.375, 0.34090909090909
55228, 0.84782608695652, 1.375, 0.36363636363636
55229, 0.82608695652174, 1.3625, 0.36363636363636
55230, 0.82608695652174, 1.375, 0.38636363636364
55231, 0.84782608695652, 1.375, 0.40909090909091
55232, 0.82608695652174, 1.3625, 0.40909090909091
55233, 0.82608695652174, 1.375, 0.43181818181818
55234, 0.84782608695652, 1.375, 0.45454545454545
55235, 0.82608695652174, 1.3625, 0.45454545454545
55236, 0.82608695652174, 1.375, 0.47727272727273
55237, 0.78260869565217, 1.375, 0.022727272727273
55238, 0.80434782608696, 1.375, 0.045454545454545
55239, 0.78260869565217, 1.3625, 0.045454545454545
55240, 0.78260869565217, 1.375, 0.068181818181818
55241, 0.80434782608696, 1.375, 0.090909090909091
55242, 0.78260869565217, 1.3625, 0.090909090909091
55243, 0.78260869565217, 1.375, 0.11363636363636
55244, 0.80434782608696, 1.375, 0.13636363636364
55245, 0.78260869565217, 1.3625, 0.13636363636364
55246, 0.78260869565217, 1.375, 0.15909090909091
55247, 0.80434782608696, 1.375, 0.18181818181818
55248, 0.78260869565217, 1.3625, 0.18181818181818
55249, 0.78260869565217, 1.375, 0.20454545454545
55250, 0.80434782608696, 1.375, 0.22727272727273
55251, 0.78260869565217, 1.3625, 0.22727272727273
55252, 0.78260869565217, 1.375, 0.25
55253, 0.80434782608696, 1.375, 0.27272727272727
55254, 0.78260869565217, 1.3625, 0.27272727272727
55255, 0.78260869565217, 1.375, 0.29545454545455
55256, 0.80434782608696, 1.375, 0.31818181818182
55257, 0.78260869565217, 1.3625, 0.31818181818182
55258, 0.78260869565217, 1.375, 0.34090909090909
55259, 0.80434782608696, 1.375, 0.36363636363636
55260, 0.78260869565217, 1.3625, 0.36363636363636
55261, 0.78260869565217, 1.375, 0.38636363636364
55262, 0.80434782608696, 1.375, 0.40909090909091
55263, 0.78260869565217, 1.3625, 0.40909090909091
55264, 0.78260869565217, 1.375, 0.43181818181818
55265, 0.80434782608696, 1.375, 0.45454545454545
55266, 0.78260869565217, 1.3625, 0.45454545454545
55267, 0.78260869565217, 1.375, 0.47727272727273
55268, 0.73913043478261, 1.375, 0.022727272727273
55269, 0.76086956521739, 1.375, 0.045454545454545
55270, 0.73913043478261, 1.3625, 0.045454545454545
55271, 0.73913043478261, 1.375, 0.068181818181818
55272, 0.76086956521739, 1.375, 0.090909090909091
55273, 0.73913043478261, 1.3625, 0.090909090909091
55274, 0.73913043478261, 1.375, 0.11363636363636
55275, 0.76086956521739, 1.375, 0.13636363636364
55276, 0.73913043478261, 1.3625, 0.13636363636364
55277, 0.73913043478261, 1.375, 0.15909090909091
55278, 0.76086956521739, 1.375, 0.18181818181818
55279, 0.73913043478261, 1.3625, 0.18181818181818
55280, 0.73913043478261, 1.375, 0.20454545454545
55281, 0.76086956521739, 1.375, 0.22727272727273
55282, 0.73913043478261, 1.3625, 0.22727272727273
55283, 0.73913043478261, 1.375, 0.25
55284, 0.76086956521739, 1.375, 0.27272727272727
55285, 0.73913043478261, 1.3625, 0.27272727272727
55286, 0.73913043478261, 1.375, 0.29545454545455
55287, 0.76086956521739, 1.375, 0.31818181818182
55288, 0.73913043478261, 1.3625, 0.31818181818182
55289, 0.73913043478261, 1.375, 0.34090909090909
55290, 0.76086956521739, 1.375, 0.36363636363636
55291, 0.73913043478261, 1.3625, 0.36363636363636
55292, 0.73913043478261, 1.375, 0.38636363636364
55293, 0.76086956521739, 1.375, 0.40909090909091
55294, 0.73913043478261, 1.3625, 0.40909090909091
55295, 0.73913043478261, 1.375, 0.43181818181818
55296, 0.76086956521739, 1.375, 0.45454545454545
55297, 0.73913043478261, 1.3625, 0.45454545454545
55298, 0.73913043478261, 1.375, 0.47727272727273
55299, 0.69565217391304, 1.375, 0.022727272727273
55300, 0.71739130434783, 1.375, 0.045454545454545
55301, 0.69565217391304, 1.3625, 0.045454545454545
55302, 0.69565217391304, 1.375, 0.068181818181818
55303, 0.71739130434783, 1.375, 0.090909090909091
55304, 0.69565217391304, 1.3625, 0.090909090909091
55305, 0.69565217391304, 1.375, 0.11363636363636
55306, 0.71739130434783, 1.375, 0.13636363636364
55307, 0.69565217391304, 1.3625, 0.13636363636364
55308, 0.69565217391304, 1.375, 0.15909090909091
55309, 0.71739130434783, 1.375, 0.18181818181818
55310, 0.69565217391304, 1.3625, 0.18181818181818
55311, 0.69565217391304, 1.375, 0.20454545454545
55312, 0.71739130434783, 1.375, 0.22727272727273
55313, 0.69565217391304, 1.3625, 0.22727272727273
55314, 0.69565217391304, 1.375, 0.25
55315, 0.71739130434783, 1.375, 0.27272727272727
55316, 0.69565217391304, 1.3625, 0.27272727272727
55317, 0.69565217391304, 1.375, 0.29545454545455
55318, 0.71739130434783, 1.375, 0.31818181818182
55319, 0.69565217391304, 1.3625, 0.31818181818182
55320, 0.69565217391304, 1.375, 0.34090909090909
55321, 0.71739130434783, 1.375, 0.36363636363636
55322, 0.69565217391304, 1.3625, 0.36363636363636
55323, 0.69565217391304, 1.375, 0.38636363636364
55324, 0.71739130434783, 1.375, 0.40909090909091
55325, 0.69565217391304, 1.3625, 0.40909090909091
55326, 0.69565217391304, 1.375, 0.43181818181818
55327, 0.71739130434783, 1.375, 0.45454545454545
55328, 0.69565217391304, 1.3625, 0.45454545454545
55329, 0.69565217391304, 1.375, 0.47727272727273
55330, 0.65217391304348, 1.375, 0.022727272727273
55331, 0.67391304347826, 1.375, 0.045454545454545
55332, 0.65217391304348, 1.3625, 0.045454545454545
55333, 0.65217391304348, 1.375, 0.068181818181818
55334, 0.67391304347826, 1.375, 0.090909090909091
55335, 0.65217391304348, 1.3625, 0.090909090909091
55336, 0.65217391304348, 1.375, 0.11363636363636
55337, 0.67391304347826, 1.375, 0.13636363636364
55338, 0.65217391304348, 1.3625, 0.13636363636364
55339, 0.65217391304348, 1.375, 0.15909090909091
55340, 0.67391304347826, 1.375, 0.18181818181818
55341, 0.65217391304348, 1.3625, 0.18181818181818
55342, 0.65217391304348, 1.375, 0.20454545454545
55343, 0.67391304347826, 1.375, 0.22727272727273
55344, 0.65217391304348, 1.3625, 0.22727272727273
55345, 0.65217391304348, 1.375, 0.25
55346, 0.67391304347826, 1.375, 0.27272727272727
55347, 0.65217391304348, 1.3625, 0.27272727272727
55348, 0.65217391304348, 1.375, 0.29545454545455
55349, 0.67391304347826, 1.375, 0.31818181818182
55350, 0.65217391304348, 1.3625, 0.31818181818182
55351, 0.65217391304348, 1.375, 0.34090909090909
55352, 0.67391304347826, 1.375, 0.36363636363636
55353, 0.65217391304348, 1.3625, 0.36363636363636
55354, 0.65217391304348, 1.375, 0.38636363636364
55355, 0.67391304347826, 1.375, 0.40909090909091
55356, 0.65217391304348, 1.3625, 0.40909090909091
55357, 0.65217391304348, 1.375, 0.43181818181818
55358, 0.67391304347826, 1.375, 0.45454545454545
55359, 0.65217391304348, 1.3625, 0.45454545454545
55360, 0.65217391304348, 1.375, 0.47727272727273
55361, 0.60869565217391, 1.375, 0.022727272727273
55362, 0.6304347826087, 1.375, 0.045454545454545
55363, 0.60869565217391, 1.3625, 0.045454545454545
55364, 0.60869565217391, 1.375, 0.068181818181818
55365, 0.6304347826087, 1.375, 0.090909090909091
55366, 0.60869565217391, 1.3625, 0.090909090909091
55367, 0.60869565217391, 1.375, 0.11363636363636
55368, 0.6304347826087, 1.375, 0.13636363636364
55369, 0.60869565217391, 1.3625, 0.13636363636364
55370, 0.60869565217391, 1.375, 0.15909090909091
55371, 0.6304347826087, 1.375, 0.18181818181818
55372, 0.60869565217391, 1.3625, 0.18181818181818
55373, 0.60869565217391, 1.375, 0.20454545454545
55374, 0.6304347826087, 1.375, 0.22727272727273
55375, 0.60869565217391, 1.3625, 0.22727272727273
55376, 0.60869565217391, 1.375, 0.25
55377, 0.6304347826087, 1.375, 0.27272727272727
55378, 0.60869565217391, 1.3625, 0.27272727272727
55379, 0.60869565217391, 1.375, 0.29545454545455
55380, 0.6304347826087, 1.375, 0.31818181818182
55381, 0.60869565217391, 1.3625, 0.31818181818182
55382, 0.60869565217391, 1.375, 0.34090909090909
55383, 0.6304347826087, 1.375, 0.36363636363636
55384, 0.60869565217391, 1.3625, 0.36363636363636
55385, 0.60869565217391, 1.375, 0.38636363636364
55386, 0.6304347826087, 1.375, 0.40909090909091
55387, 0.60869565217391, 1.3625, 0.40909090909091
55388, 0.60869565217391, 1.375, 0.43181818181818
55389, 0.6304347826087, 1.375, 0.45454545454545
55390, 0.60869565217391, 1.3625, 0.45454545454545
55391, 0.60869565217391, 1.375, 0.47727272727273
55392, 0.56521739130435, 1.375, 0.022727272727273
55393, 0.58695652173913, 1.375, 0.045454545454545
55394, 0.56521739130435, 1.3625, 0.045454545454545
55395, 0.56521739130435, 1.375, 0.068181818181818
55396, 0.58695652173913, 1.375, 0.090909090909091
55397, 0.56521739130435, 1.3625, 0.090909090909091
55398, 0.56521739130435, 1.375, 0.11363636363636
55399, 0.58695652173913, 1.375, 0.13636363636364
55400, 0.56521739130435, 1.3625, 0.13636363636364
55401, 0.56521739130435, 1.375, 0.15909090909091
55402, 0.58695652173913, 1.375, 0.18181818181818
55403, 0.56521739130435, 1.3625, 0.18181818181818
55404, 0.56521739130435, 1.375, 0.20454545454545
55405, 0.58695652173913, 1.375, 0.22727272727273
55406, 0.56521739130435, 1.3625, 0.22727272727273
55407, 0.56521739130435, 1.375, 0.25
55408, 0.58695652173913, 1.375, 0.27272727272727
55409, 0.56521739130435, 1.3625, 0.27272727272727
55410, 0.56521739130435, 1.375, 0.29545454545455
55411, 0.58695652173913, 1.375, 0.31818181818182
55412, 0.56521739130435, 1.3625, 0.31818181818182
55413, 0.56521739130435, 1.375, 0.34090909090909
55414, 0.58695652173913, 1.375, 0.36363636363636
55415, 0.56521739130435, 1.3625, 0.36363636363636
55416, 0.56521739130435, 1.375, 0.38636363636364
55417, 0.58695652173913, 1.375, 0.40909090909091
55418, 0.56521739130435, 1.3625, 0.40909090909091
55419, 0.56521739130435, 1.375, 0.43181818181818
55420, 0.58695652173913, 1.375, 0.45454545454545
55421, 0.56521739130435, 1.3625, 0.45454545454545
55422, 0.56521739130435, 1.375, 0.47727272727273
55423, 0.52173913043478, 1.375, 0.022727272727273
55424, 0.54347826086956, 1.375, 0.045454545454545
55425, 0.52173913043478, 1.3625, 0.045454545454545
55426, 0.52173913043478, 1.375, 0.068181818181818
55427, 0.54347826086956, 1.375, 0.090909090909091
55428, 0.52173913043478, 1.3625, 0.090909090909091
55429, 0.52173913043478, 1.375, 0.11363636363636
55430, 0.54347826086957, 1.375, 0.13636363636364
55431, 0.52173913043478, 1.3625, 0.13636363636364
55432, 0.52173913043478, 1.375, 0.15909090909091
55433, 0.54347826086956, 1.375, 0.18181818181818
55434, 0.52173913043478, 1.3625, 0.18181818181818
55435, 0.52173913043478, 1.375, 0.20454545454545
55436, 0.54347826086956, 1.375, 0.22727272727273
55437, 0.52173913043478, 1.3625, 0.22727272727273
55438, 0.52173913043478, 1.375, 0.25
55439, 0.54347826086956, 1.375, 0.27272727272727
55440, 0.52173913043478, 1.3625, 0.27272727272727
55441, 0.52173913043478, 1.375, 0.29545454545455
55442, 0.54347826086956, 1.375, 0.31818181818182
55443, 0.52173913043478, 1.3625, 0.31818181818182
55444, 0.52173913043478, 1.375, 0.34090909090909
55445, 0.54347826086957, 1.375, 0.36363636363636
55446, 0.52173913043478, 1.3625, 0.36363636363636
55447, 0.52173913043478, 1.375, 0.38636363636364
55448, 0.54347826086956, 1.375, 0.40909090909091
55449, 0.52173913043478, 1.3625, 0.40909090909091
55450, 0.52173913043478, 1.375, 0.43181818181818
55451, 0.54347826086956, 1.375, 0.45454545454545
55452, 0.52173913043478, 1.3625, 0.45454545454545
55453, 0.52173913043478, 1.375, 0.47727272727273
55454, 0.47826086956522, 1.375, 0.022727272727273
55455, 0.5, 1.375, 0.045454545454545
55456, 0.47826086956522, 1.3625, 0.045454545454545
55457, 0.47826086956522, 1.375, 0.068181818181818
55458, 0.5, 1.375, 0.090909090909091
55459, 0.47826086956522, 1.3625, 0.090909090909091
55460, 0.47826086956522, 1.375, 0.11363636363636
55461, 0.5, 1.375, 0.13636363636364
55462, 0.47826086956522, 1.3625, 0.13636363636364
55463, 0.47826086956522, 1.375, 0.15909090909091
55464, 0.5, 1.375, 0.18181818181818
55465, 0.47826086956522, 1.3625, 0.18181818181818
55466, 0.47826086956522, 1.375, 0.20454545454545
55467, 0.5, 1.375, 0.22727272727273
55468, 0.47826086956522, 1.3625, 0.22727272727273
55469, 0.47826086956522, 1.375, 0.25
55470, 0.5, 1.375, 0.27272727272727
55471, 0.47826086956522, 1.3625, 0.27272727272727
55472, 0.47826086956522, 1.375, 0.29545454545455
55473, 0.5, 1.375, 0.31818181818182
55474, 0.47826086956522, 1.3625, 0.31818181818182
55475, 0.47826086956522, 1.375, 0.34090909090909
55476, 0.5, 1.375, 0.36363636363636
55477, 0.47826086956522, 1.3625, 0.36363636363636
55478, 0.47826086956522, 1.375, 0.38636363636364
55479, 0.5, 1.375, 0.40909090909091
55480, 0.47826086956522, 1.3625, 0.40909090909091
55481, 0.47826086956522, 1.375, 0.43181818181818
55482, 0.5, 1.375, 0.45454545454545
55483, 0.47826086956522, 1.3625, 0.45454545454545
55484, 0.47826086956522, 1.375, 0.47727272727273
55485, 0.43478260869565, 1.375, 0.022727272727273
55486, 0.45652173913043, 1.375, 0.045454545454545
55487, 0.43478260869565, 1.3625, 0.045454545454545
55488, 0.43478260869565, 1.375, 0.068181818181818
55489, 0.45652173913043, 1.375, 0.090909090909091
55490, 0.43478260869565, 1.3625, 0.090909090909091
55491, 0.43478260869565, 1.375, 0.11363636363636
55492, 0.45652173913043, 1.375, 0.13636363636364
55493, 0.43478260869565, 1.3625, 0.13636363636364
55494, 0.43478260869565, 1.375, 0.15909090909091
55495, 0.45652173913043, 1.375, 0.18181818181818
55496, 0.43478260869565, 1.3625, 0.18181818181818
55497, 0.43478260869565, 1.375, 0.20454545454545
55498, 0.45652173913043, 1.375, 0.22727272727273
55499, 0.43478260869565, 1.3625, 0.22727272727273
55500, 0.43478260869565, 1.375, 0.25
55501, 0.45652173913043, 1.375, 0.27272727272727
55502, 0.43478260869565, 1.3625, 0.27272727272727
55503, 0.43478260869565, 1.375, 0.29545454545455
55504, 0.45652173913043, 1.375, 0.31818181818182
55505, 0.43478260869565, 1.3625, 0.31818181818182
55506, 0.43478260869565, 1.375, 0.34090909090909
55507, 0.45652173913043, 1.375, 0.36363636363636
55508, 0.43478260869565, 1.3625, 0.36363636363636
55509, 0.43478260869565, 1.375, 0.38636363636364
55510, 0.45652173913043, 1.375, 0.40909090909091
55511, 0.43478260869565, 1.3625, 0.40909090909091
55512, 0.43478260869565, 1.375, 0.43181818181818
55513, 0.45652173913043, 1.375, 0.45454545454545
55514, 0.43478260869565, 1.3625, 0.45454545454545
55515, 0.43478260869565, 1.375, 0.47727272727273
55516, 0.39130434782609, 1.375, 0.022727272727273
55517, 0.41304347826087, 1.375, 0.045454545454545
55518, 0.39130434782609, 1.3625, 0.045454545454545
55519, 0.39130434782609, 1.375, 0.068181818181818
55520, 0.41304347826087, 1.375, 0.090909090909091
55521, 0.39130434782609, 1.3625, 0.090909090909091
55522, 0.39130434782609, 1.375, 0.11363636363636
55523, 0.41304347826087, 1.375, 0.13636363636364
55524, 0.39130434782609, 1.3625, 0.13636363636364
55525, 0.39130434782609, 1.375, 0.15909090909091
55526, 0.41304347826087, 1.375, 0.18181818181818
55527, 0.39130434782609, 1.3625, 0.18181818181818
55528, 0.39130434782609, 1.375, 0.20454545454545
55529, 0.41304347826087, 1.375, 0.22727272727273
55530, 0.39130434782609, 1.3625, 0.22727272727273
55531, 0.39130434782609, 1.375, 0.25
55532, 0.41304347826087, 1.375, 0.27272727272727
55533, 0.39130434782609, 1.3625, 0.27272727272727
55534, 0.39130434782609, 1.375, 0.29545454545455
55535, 0.41304347826087, 1.375, 0.31818181818182
55536, 0.39130434782609, 1.3625, 0.31818181818182
55537, 0.39130434782609, 1.375, 0.34090909090909
55538, 0.41304347826087, 1.375, 0.36363636363636
55539, 0.39130434782609, 1.3625, 0.36363636363636
55540, 0.39130434782609, 1.375, 0.38636363636364
55541, 0.41304347826087, 1.375, 0.40909090909091
55542, 0.39130434782609, 1.3625, 0.40909090909091
55543, 0.39130434782609, 1.375, 0.43181818181818
55544, 0.41304347826087, 1.375, 0.45454545454545
55545, 0.39130434782609, 1.3625, 0.45454545454545
55546, 0.39130434782609, 1.375, 0.47727272727273
55547, 0.34782608695652, 1.375, 0.022727272727273
55548, 0.3695652173913, 1.375, 0.045454545454545
55549, 0.34782608695652, 1.3625, 0.045454545454545
55550, 0.34782608695652, 1.375, 0.068181818181818
55551, 0.3695652173913, 1.375, 0.090909090909091
55552, 0.34782608695652, 1.3625, 0.090909090909091
55553, 0.34782608695652, 1.375, 0.11363636363636
55554, 0.3695652173913, 1.375, 0.13636363636364
55555, 0.34782608695652, 1.3625, 0.13636363636364
55556, 0.34782608695652, 1.375, 0.15909090909091
55557, 0.3695652173913, 1.375, 0.18181818181818
55558, 0.34782608695652, 1.3625, 0.18181818181818
55559, 0.34782608695652, 1.375, 0.20454545454545
55560, 0.3695652173913, 1.375, 0.22727272727273
55561, 0.34782608695652, 1.3625, 0.22727272727273
55562, 0.34782608695652, 1.375, 0.25
55563, 0.3695652173913, 1.375, 0.27272727272727
55564, 0.34782608695652, 1.3625, 0.27272727272727
55565, 0.34782608695652, 1.375, 0.29545454545455
55566, 0.3695652173913, 1.375, 0.31818181818182
55567, 0.34782608695652, 1.3625, 0.31818181818182
55568, 0.34782608695652, 1.375, 0.34090909090909
55569, 0.3695652173913, 1.375, 0.36363636363636
55570, 0.34782608695652, 1.3625, 0.36363636363636
55571, 0.34782608695652, 1.375, 0.38636363636364
55572, 0.3695652173913, 1.375, 0.40909090909091
55573, 0.34782608695652, 1.3625, 0.40909090909091
55574, 0.34782608695652, 1.375, 0.43181818181818
55575, 0.3695652173913, 1.375, 0.45454545454545
55576, 0.34782608695652, 1.3625, 0.45454545454545
55577, 0.34782608695652, 1.375, 0.47727272727273
55578, 0.30434782608696, 1.375, 0.022727272727273
55579, 0.32608695652174, 1.375, 0.045454545454545
55580, 0.30434782608696, 1.3625, 0.045454545454545
55581, 0.30434782608696, 1.375, 0.068181818181818
55582, 0.32608695652174, 1.375, 0.090909090909091
55583, 0.30434782608696, 1.3625, 0.090909090909091
55584, 0.30434782608696, 1.375, 0.11363636363636
55585, 0.32608695652174, 1.375, 0.13636363636364
55586, 0.30434782608696, 1.3625, 0.13636363636364
55587, 0.30434782608696, 1.375, 0.15909090909091
55588, 0.32608695652174, 1.375, 0.18181818181818
55589, 0.30434782608696, 1.3625, 0.18181818181818
55590, 0.30434782608696, 1.375, 0.20454545454545
55591, 0.32608695652174, 1.375, 0.22727272727273
55592, 0.30434782608696, 1.3625, 0.22727272727273
55593, 0.30434782608696, 1.375, 0.25
55594, 0.32608695652174, 1.375, 0.27272727272727
55595, 0.30434782608696, 1.3625, 0.27272727272727
55596, 0.30434782608696, 1.375, 0.29545454545455
55597, 0.32608695652174, 1.375, 0.31818181818182
55598, 0.30434782608696, 1.3625, 0.31818181818182
55599, 0.30434782608696, 1.375, 0.34090909090909
55600, 0.32608695652174, 1.375, 0.36363636363636
55601, 0.30434782608696, 1.3625, 0.36363636363636
55602, 0.30434782608696, 1.375, 0.38636363636364
55603, 0.32608695652174, 1.375, 0.40909090909091
55604, 0.30434782608696, 1.3625, 0.40909090909091
55605, 0.30434782608696, 1.375, 0.43181818181818
55606, 0.32608695652174, 1.375, 0.45454545454545
55607, 0.30434782608696, 1.3625, 0.45454545454545
55608, 0.30434782608696, 1.375, 0.47727272727273
55609, 0.26086956521739, 1.375, 0.022727272727273
55610, 0.28260869565217, 1.375, 0.045454545454545
55611, 0.26086956521739, 1.3625, 0.045454545454545
55612, 0.26086956521739, 1.375, 0.068181818181818
55613, 0.28260869565217, 1.375, 0.090909090909091
55614, 0.26086956521739, 1.3625, 0.090909090909091
55615, 0.26086956521739, 1.375, 0.11363636363636
55616, 0.28260869565217, 1.375, 0.13636363636364
55617, 0.26086956521739, 1.3625, 0.13636363636364
55618, 0.26086956521739, 1.375, 0.15909090909091
55619, 0.28260869565217, 1.375, 0.18181818181818
55620, 0.26086956521739, 1.3625, 0.18181818181818
55621, 0.26086956521739, 1.375, 0.20454545454545
55622, 0.28260869565217, 1.375, 0.22727272727273
55623, 0.26086956521739, 1.3625, 0.22727272727273
55624, 0.26086956521739, 1.375, 0.25
55625, 0.28260869565217, 1.375, 0.27272727272727
55626, 0.26086956521739, 1.3625, 0.27272727272727
55627, 0.26086956521739, 1.375, 0.29545454545455
55628, 0.28260869565217, 1.375, 0.31818181818182
55629, 0.26086956521739, 1.3625, 0.31818181818182
55630, 0.26086956521739, 1.375, 0.34090909090909
55631, 0.28260869565217, 1.375, 0.36363636363636
55632, 0.26086956521739, 1.3625, 0.36363636363636
55633, 0.26086956521739, 1.375, 0.38636363636364
55634, 0.28260869565217, 1.375, 0.40909090909091
55635, 0.26086956521739, 1.3625, 0.40909090909091
55636, 0.26086956521739, 1.375, 0.43181818181818
55637, 0.28260869565217, 1.375, 0.45454545454545
55638, 0.26086956521739, 1.3625, 0.45454545454545
55639, 0.26086956521739, 1.375, 0.47727272727273
55640, 0.21739130434783, 1.375, 0.022727272727273
55641, 0.23913043478261, 1.375, 0.045454545454545
55642, 0.21739130434783, 1.3625, 0.045454545454545
55643, 0.21739130434783, 1.375, 0.068181818181818
55644, 0.23913043478261, 1.375, 0.090909090909091
55645, 0.21739130434783, 1.3625, 0.090909090909091
55646, 0.21739130434783, 1.375, 0.11363636363636
55647, 0.23913043478261, 1.375, 0.13636363636364
55648, 0.21739130434783, 1.3625, 0.13636363636364
55649, 0.21739130434783, 1.375, 0.15909090909091
55650, 0.23913043478261, 1.375, 0.18181818181818
55651, 0.21739130434783, 1.3625, 0.18181818181818
55652, 0.21739130434783, 1.375, 0.20454545454545
55653, 0.23913043478261, 1.375, 0.22727272727273
55654, 0.21739130434783, 1.3625, 0.22727272727273
55655, 0.21739130434783, 1.375, 0.25
55656, 0.23913043478261, 1.375, 0.27272727272727
55657, 0.21739130434783, 1.3625, 0.27272727272727
55658, 0.21739130434783, 1.375, 0.29545454545455
55659, 0.23913043478261, 1.375, 0.31818181818182
55660, 0.21739130434783, 1.3625, 0.31818181818182
55661, 0.21739130434783, 1.375, 0.34090909090909
55662, 0.23913043478261, 1.375, 0.36363636363636
55663, 0.21739130434783, 1.3625, 0.36363636363636
55664, 0.21739130434783, 1.375, 0.38636363636364
55665, 0.23913043478261, 1.375, 0.40909090909091
55666, 0.21739130434783, 1.3625, 0.40909090909091
55667, 0.21739130434783, 1.375, 0.43181818181818
55668, 0.23913043478261, 1.375, 0.45454545454545
55669, 0.21739130434783, 1.3625, 0.45454545454545
55670, 0.21739130434783, 1.375, 0.47727272727273
55671, 0.17391304347826, 1.375, 0.022727272727273
55672, 0.19565217391304, 1.375, 0.045454545454545
55673, 0.17391304347826, 1.3625, 0.045454545454545
55674, 0.17391304347826, 1.375, 0.068181818181818
55675, 0.19565217391304, 1.375, 0.090909090909091
55676, 0.17391304347826, 1.3625, 0.090909090909091
55677, 0.17391304347826, 1.375, 0.11363636363636
55678, 0.19565217391304, 1.375, 0.13636363636364
55679, 0.17391304347826, 1.3625, 0.13636363636364
55680, 0.17391304347826, 1.375, 0.15909090909091
55681, 0.19565217391304, 1.375, 0.18181818181818
55682, 0.17391304347826, 1.3625, 0.18181818181818
55683, 0.17391304347826, 1.375, 0.20454545454545
55684, 0.19565217391304, 1.375, 0.22727272727273
55685, 0.17391304347826, 1.3625, 0.22727272727273
55686, 0.17391304347826, 1.375, 0.25
55687, 0.19565217391304, 1.375, 0.27272727272727
55688, 0.17391304347826, 1.3625, 0.27272727272727
55689, 0.17391304347826, 1.375, 0.29545454545455
55690, 0.19565217391304, 1.375, 0.31818181818182
55691, 0.17391304347826, 1.3625, 0.31818181818182
55692, 0.17391304347826, 1.375, 0.34090909090909
55693, 0.19565217391304, 1.375, 0.36363636363636
55694, 0.17391304347826, 1.3625, 0.36363636363636
55695, 0.17391304347826, 1.375, 0.38636363636364
55696, 0.19565217391304, 1.375, 0.40909090909091
55697, 0.17391304347826, 1.3625, 0.40909090909091
55698, 0.17391304347826, 1.375, 0.43181818181818
55699, 0.19565217391304, 1.375, 0.45454545454545
55700, 0.17391304347826, 1.3625, 0.45454545454545
55701, 0.17391304347826, 1.375, 0.47727272727273
55702, 0.1304347826087, 1.375, 0.022727272727273
55703, 0.15217391304348, 1.375, 0.045454545454545
55704, 0.1304347826087, 1.3625, 0.045454545454545
55705, 0.1304347826087, 1.375, 0.068181818181818
55706, 0.15217391304348, 1.375, 0.090909090909091
55707, 0.1304347826087, 1.3625, 0.090909090909091
55708, 0.1304347826087, 1.375, 0.11363636363636
55709, 0.15217391304348, 1.375, 0.13636363636364
55710, 0.1304347826087, 1.3625, 0.13636363636364
55711, 0.1304347826087, 1.375, 0.15909090909091
55712, 0.15217391304348, 1.375, 0.18181818181818
55713, 0.1304347826087, 1.3625, 0.18181818181818
55714, 0.1304347826087, 1.375, 0.20454545454545
55715, 0.15217391304348, 1.375, 0.22727272727273
55716, 0.1304347826087, 1.3625, 0.22727272727273
55717, 0.1304347826087, 1.375, 0.25
55718, 0.15217391304348, 1.375, 0.27272727272727
55719, 0.1304347826087, 1.3625, 0.27272727272727
55720, 0.1304347826087, 1.375, 0.29545454545455
55721, 0.15217391304348, 1.375, 0.31818181818182
55722, 0.1304347826087, 1.3625, 0.31818181818182
55723, 0.1304347826087, 1.375, 0.34090909090909
55724, 0.15217391304348, 1.375, 0.36363636363636
55725, 0.1304347826087, 1.3625, 0.36363636363636
55726, 0.1304347826087, 1.375, 0.38636363636364
55727, 0.15217391304348, 1.375, 0.40909090909091
55728, 0.1304347826087, 1.3625, 0.40909090909091
55729, 0.1304347826087, 1.375, 0.43181818181818
55730, 0.15217391304348, 1.375, 0.45454545454545
55731, 0.1304347826087, 1.3625, 0.45454545454545
55732, 0.1304347826087, 1.375, 0.47727272727273
55733, 0.08695652173913, 1.375, 0.022727272727273
55734, 0.10869565217391, 1.375, 0.045454545454545
55735, 0.08695652173913, 1.3625, 0.045454545454545
55736, 0.08695652173913, 1.375, 0.068181818181818
55737, 0.10869565217391, 1.375, 0.090909090909091
55738, 0.08695652173913, 1.3625, 0.090909090909091
55739, 0.08695652173913, 1.375, 0.11363636363636
55740, 0.10869565217391, 1.375, 0.13636363636364
55741, 0.08695652173913, 1.3625, 0.13636363636364
55742, 0.08695652173913, 1.375, 0.15909090909091
55743, 0.10869565217391, 1.375, 0.18181818181818
55744, 0.08695652173913, 1.3625, 0.18181818181818
55745, 0.08695652173913, 1.375, 0.20454545454545
55746, 0.10869565217391, 1.375, 0.22727272727273
55747, 0.08695652173913, 1.3625, 0.22727272727273
55748, 0.08695652173913, 1.375, 0.25
55749, 0.10869565217391, 1.375, 0.27272727272727
55750, 0.08695652173913, 1.3625, 0.27272727272727
55751, 0.08695652173913, 1.375, 0.29545454545455
55752, 0.10869565217391, 1.375, 0.31818181818182
55753, 0.08695652173913, 1.3625, 0.31818181818182
55754, 0.08695652173913, 1.375, 0.34090909090909
55755, 0.10869565217391, 1.375, 0.36363636363636
55756, 0.08695652173913, 1.3625, 0.36363636363636
55757, 0.08695652173913, 1.375, 0.38636363636364
55758, 0.10869565217391, 1.375, 0.40909090909091
55759, 0.08695652173913, 1.3625, 0.40909090909091
55760, 0.08695652173913, 1.375, 0.43181818181818
55761, 0.10869565217391, 1.375, 0.45454545454545
55762, 0.08695652173913, 1.3625, 0.45454545454545
55763, 0.08695652173913, 1.375, 0.47727272727273
55764, 0.043478260869565, 1.375, 0.022727272727273
55765, 0.065217391304348, 1.375, 0.045454545454545
55766, 0.043478260869565, 1.3625, 0.045454545454545
55767, 0.043478260869565, 1.375, 0.068181818181818
55768, 0.065217391304348, 1.375, 0.090909090909091
55769, 0.043478260869565, 1.3625, 0.090909090909091
55770, 0.043478260869565, 1.375, 0.11363636363636
55771, 0.065217391304348, 1.375, 0.13636363636364
55772, 0.043478260869565, 1.3625, 0.13636363636364
55773, 0.043478260869565, 1.375, 0.15909090909091
55774, 0.065217391304348, 1.375, 0.18181818181818
55775, 0.043478260869565, 1.3625, 0.18181818181818
55776, 0.043478260869565, 1.375, 0.20454545454545
55777, 0.065217391304348, 1.375, 0.22727272727273
55778, 0.043478260869565, 1.3625, 0.22727272727273
55779, 0.043478260869565, 1.375, 0.25
55780, 0.065217391304348, 1.375, 0.27272727272727
55781, 0.043478260869565, 1.3625, 0.27272727272727
55782, 0.043478260869565, 1.375, 0.29545454545455
55783, 0.065217391304348, 1.375, 0.31818181818182
55784, 0.043478260869565, 1.3625, 0.31818181818182
55785, 0.043478260869565, 1.375, 0.34090909090909
55786, 0.065217391304348, 1.375, 0.36363636363636
55787, 0.043478260869565, 1.3625, 0.36363636363636
55788, 0.043478260869565, 1.375, 0.38636363636364
55789, 0.065217391304348, 1.375, 0.40909090909091
55790, 0.043478260869565, 1.3625, 0.40909090909091
55791, 0.043478260869565, 1.375, 0.43181818181818
55792, 0.065217391304348, 1.375, 0.45454545454545
55793, 0.043478260869565, 1.3625, 0.45454545454545
55794, 0.043478260869565, 1.375, 0.47727272727273
55795, 0.021739130434783, 1.375, 0.045454545454545
55796, 0.021739130434783, 1.375, 0.090909090909091
55797, 0.021739130434783, 1.375, 0.13636363636364
55798, 0.021739130434783, 1.375, 0.18181818181818
55799, 0.021739130434783, 1.375, 0.22727272727273
55800, 0.021739130434783, 1.375, 0.27272727272727
55801, 0.021739130434783, 1.375, 0.31818181818182
55802, 0.021739130434783, 1.375, 0.36363636363636
55803, 0.021739130434783, 1.375, 0.40909090909091
55804, 0.021739130434783, 1.375, 0.45454545454545
55805, 0.95652173913043, 1.3875, 0.045454545454545
55806, 0.95652173913043, 1.3875, 0.090909090909091
55807, 0.95652173913044, 1.3875, 0.13636363636364
55808, 0.95652173913043, 1.3875, 0.18181818181818
55809, 0.95652173913043, 1.3875, 0.22727272727273
55810, 0.95652173913043, 1.3875, 0.27272727272727
55811, 0.95652173913043, 1.3875, 0.31818181818182
55812, 0.95652173913043, 1.3875, 0.36363636363636
55813, 0.95652173913043, 1.3875, 0.40909090909091
55814, 0.95652173913043, 1.3875, 0.45454545454545
55815, 0.91304347826087, 1.3875, 0.045454545454545
55816, 0.91304347826087, 1.3875, 0.090909090909091
55817, 0.91304347826087, 1.3875, 0.13636363636364
55818, 0.91304347826087, 1.3875, 0.18181818181818
55819, 0.91304347826087, 1.3875, 0.22727272727273
55820, 0.91304347826087, 1.3875, 0.27272727272727
55821, 0.91304347826087, 1.3875, 0.31818181818182
55822, 0.91304347826087, 1.3875, 0.36363636363636
55823, 0.91304347826087, 1.3875, 0.40909090909091
55824, 0.91304347826087, 1.3875, 0.45454545454545
55825, 0.8695652173913, 1.3875, 0.045454545454545
55826, 0.8695652173913, 1.3875, 0.090909090909091
55827, 0.8695652173913, 1.3875, 0.13636363636364
55828, 0.8695652173913, 1.3875, 0.18181818181818
55829, 0.8695652173913, 1.3875, 0.22727272727273
55830, 0.8695652173913, 1.3875, 0.27272727272727
55831, 0.8695652173913, 1.3875, 0.31818181818182
55832, 0.8695652173913, 1.3875, 0.36363636363636
55833, 0.8695652173913, 1.3875, 0.40909090909091
55834, 0.8695652173913, 1.3875, 0.45454545454545
55835, 0.82608695652174, 1.3875, 0.045454545454545
55836, 0.82608695652174, 1.3875, 0.090909090909091
55837, 0.82608695652174, 1.3875, 0.13636363636364
55838, 0.82608695652174, 1.3875, 0.18181818181818
55839, 0.82608695652174, 1.3875, 0.22727272727273
55840, 0.82608695652174, 1.3875, 0.27272727272727
55841, 0.82608695652174, 1.3875, 0.31818181818182
55842, 0.82608695652174, 1.3875, 0.36363636363636
55843, 0.82608695652174, 1.3875, 0.40909090909091
55844, 0.82608695652174, 1.3875, 0.45454545454545
55845, 0.78260869565217, 1.3875, 0.045454545454545
55846, 0.78260869565217, 1.3875, 0.090909090909091
55847, 0.78260869565217, 1.3875, 0.13636363636364
55848, 0.78260869565217, 1.3875, 0.18181818181818
55849, 0.78260869565217, 1.3875, 0.22727272727273
55850, 0.78260869565217, 1.3875, 0.27272727272727
55851, 0.78260869565217, 1.3875, 0.31818181818182
55852, 0.78260869565217, 1.3875, 0.36363636363636
55853, 0.78260869565217, 1.3875, 0.40909090909091
55854, 0.78260869565217, 1.3875, 0.45454545454545
55855, 0.73913043478261, 1.3875, 0.045454545454545
55856, 0.73913043478261, 1.3875, 0.090909090909091
55857, 0.73913043478261, 1.3875, 0.13636363636364
55858, 0.73913043478261, 1.3875, 0.18181818181818
55859, 0.73913043478261, 1.3875, 0.22727272727273
55860, 0.73913043478261, 1.3875, 0.27272727272727
55861, 0.73913043478261, 1.3875, 0.31818181818182
55862, 0.73913043478261, 1.3875, 0.36363636363636
55863, 0.73913043478261, 1.3875, 0.40909090909091
55864, 0.73913043478261, 1.3875, 0.45454545454545
55865, 0.69565217391304, 1.3875, 0.045454545454545
55866, 0.69565217391304, 1.3875, 0.090909090909091
55867, 0.69565217391304, 1.3875, 0.13636363636364
55868, 0.69565217391304, 1.3875, 0.18181818181818
55869, 0.69565217391304, 1.3875, 0.22727272727273
55870, 0.69565217391304, 1.3875, 0.27272727272727
55871, 0.69565217391304, 1.3875, 0.31818181818182
55872, 0.69565217391304, 1.3875, 0.36363636363636
55873, 0.69565217391304, 1.3875, 0.40909090909091
55874, 0.69565217391304, 1.3875, 0.45454545454545
55875, 0.65217391304348, 1.3875, 0.045454545454545
55876, 0.65217391304348, 1.3875, 0.090909090909091
55877, 0.65217391304348, 1.3875, 0.13636363636364
55878, 0.65217391304348, 1.3875, 0.18181818181818
55879, 0.65217391304348, 1.3875, 0.22727272727273
55880, 0.65217391304348, 1.3875, 0.27272727272727
55881, 0.65217391304348, 1.3875, 0.31818181818182
55882, 0.65217391304348, 1.3875, 0.36363636363636
55883, 0.65217391304348, 1.3875, 0.40909090909091
55884, 0.65217391304348, 1.3875, 0.45454545454545
55885, 0.60869565217391, 1.3875, 0.045454545454545
55886, 0.60869565217391, 1.3875, 0.090909090909091
55887, 0.60869565217391, 1.3875, 0.13636363636364
55888, 0.60869565217391, 1.3875, 0.18181818181818
55889, 0.60869565217391, 1.3875, 0.22727272727273
55890, 0.60869565217391, 1.3875, 0.27272727272727
55891, 0.60869565217391, 1.3875, 0.31818181818182
55892, 0.60869565217391, 1.3875, 0.36363636363636
55893, 0.60869565217391, 1.3875, 0.40909090909091
55894, 0.60869565217391, 1.3875, 0.45454545454545
55895, 0.56521739130435, 1.3875, 0.045454545454545
55896, 0.56521739130435, 1.3875, 0.090909090909091
55897, 0.56521739130435, 1.3875, 0.13636363636364
55898, 0.56521739130435, 1.3875, 0.18181818181818
55899, 0.56521739130435, 1.3875, 0.22727272727273
55900, 0.56521739130435, 1.3875, 0.27272727272727
55901, 0.56521739130435, 1.3875, 0.31818181818182
55902, 0.56521739130435, 1.3875, 0.36363636363636
55903, 0.56521739130435, 1.3875, 0.40909090909091
55904, 0.56521739130435, 1.3875, 0.45454545454545
55905, 0.52173913043478, 1.3875, 0.045454545454545
55906, 0.52173913043478, 1.3875, 0.090909090909091
55907, 0.52173913043478, 1.3875, 0.13636363636364
55908, 0.52173913043478, 1.3875, 0.18181818181818
55909, 0.52173913043478, 1.3875, 0.22727272727273
55910, 0.52173913043478, 1.3875, 0.27272727272727
55911, 0.52173913043478, 1.3875, 0.31818181818182
55912, 0.52173913043478, 1.3875, 0.36363636363636
55913, 0.52173913043478, 1.3875, 0.40909090909091
55914, 0.52173913043478, 1.3875, 0.45454545454545
55915, 0.47826086956522, 1.3875, 0.045454545454545
55916, 0.47826086956522, 1.3875, 0.090909090909091
55917, 0.47826086956522, 1.3875, 0.13636363636364
55918, 0.47826086956522, 1.3875, 0.18181818181818
55919, 0.47826086956522, 1.3875, 0.22727272727273
55920, 0.47826086956522, 1.3875, 0.27272727272727
55921, 0.47826086956522, 1.3875, 0.31818181818182
55922, 0.47826086956522, 1.3875, 0.36363636363636
55923, 0.47826086956522, 1.3875, 0.40909090909091
55924, 0.47826086956522, 1.3875, 0.45454545454545
55925, 0.43478260869565, 1.3875, 0.045454545454545
55926, 0.43478260869565, 1.3875, 0.090909090909091
55927, 0.43478260869565, 1.3875, 0.13636363636364
55928, 0.43478260869565, 1.3875, 0.18181818181818
55929, 0.43478260869565, 1.3875, 0.22727272727273
55930, 0.43478260869565, 1.3875, 0.27272727272727
55931, 0.43478260869565, 1.3875, 0.31818181818182
55932, 0.43478260869565, 1.3875, 0.36363636363636
55933, 0.43478260869565, 1.3875, 0.40909090909091
55934, 0.43478260869565, 1.3875, 0.45454545454545
55935, 0.39130434782609, 1.3875, 0.045454545454545
55936, 0.39130434782609, 1.3875, 0.090909090909091
55937, 0.39130434782609, 1.3875, 0.13636363636364
55938, 0.39130434782609, 1.3875, 0.18181818181818
55939, 0.39130434782609, 1.3875, 0.22727272727273
55940, 0.39130434782609, 1.3875, 0.27272727272727
55941, 0.39130434782609, 1.3875, 0.31818181818182
55942, 0.39130434782609, 1.3875, 0.36363636363636
55943, 0.39130434782609, 1.3875, 0.40909090909091
55944, 0.39130434782609, 1.3875, 0.45454545454545
55945, 0.34782608695652, 1.3875, 0.045454545454545
55946, 0.34782608695652, 1.3875, 0.090909090909091
55947, 0.34782608695652, 1.3875, 0.13636363636364
55948, 0.34782608695652, 1.3875, 0.18181818181818
55949, 0.34782608695652, 1.3875, 0.22727272727273
55950, 0.34782608695652, 1.3875, 0.27272727272727
55951, 0.34782608695652, 1.3875, 0.31818181818182
55952, 0.34782608695652, 1.3875, 0.36363636363636
55953, 0.34782608695652, 1.3875, 0.40909090909091
55954, 0.34782608695652, 1.3875, 0.45454545454545
55955, 0.30434782608696, 1.3875, 0.045454545454545
55956, 0.30434782608696, 1.3875, 0.090909090909091
55957, 0.30434782608696, 1.3875, 0.13636363636364
55958, 0.30434782608696, 1.3875, 0.18181818181818
55959, 0.30434782608696, 1.3875, 0.22727272727273
55960, 0.30434782608696, 1.3875, 0.27272727272727
55961, 0.30434782608696, 1.3875, 0.31818181818182
55962, 0.30434782608696, 1.3875, 0.36363636363636
55963, 0.30434782608696, 1.3875, 0.40909090909091
55964, 0.30434782608696, 1.3875, 0.45454545454545
55965, 0.26086956521739, 1.3875, 0.045454545454545
55966, 0.26086956521739, 1.3875, 0.090909090909091
55967, 0.26086956521739, 1.3875, 0.13636363636364
55968, 0.26086956521739, 1.3875, 0.18181818181818
55969, 0.26086956521739, 1.3875, 0.22727272727273
55970, 0.26086956521739, 1.3875, 0.27272727272727
55971, 0.26086956521739, 1.3875, 0.31818181818182
55972, 0.26086956521739, 1.3875, 0.36363636363636
55973, 0.26086956521739, 1.3875, 0.40909090909091
55974, 0.26086956521739, 1.3875, 0.45454545454545
55975, 0.21739130434783, 1.3875, 0.045454545454545
55976, 0.21739130434783, 1.3875, 0.090909090909091
55977, 0.21739130434783, 1.3875, 0.13636363636364
55978, 0.21739130434783, 1.3875, 0.18181818181818
55979, 0.21739130434783, 1.3875, 0.22727272727273
55980, 0.21739130434783, 1.3875, 0.27272727272727
55981, 0.21739130434783, 1.3875, 0.31818181818182
55982, 0.21739130434783, 1.3875, 0.36363636363636
55983, 0.21739130434783, 1.3875, 0.40909090909091
55984, 0.21739130434783, 1.3875, 0.45454545454545
55985, 0.17391304347826, 1.3875, 0.045454545454545
55986, 0.17391304347826, 1.3875, 0.090909090909091
55987, 0.17391304347826, 1.3875, 0.13636363636364
55988, 0.17391304347826, 1.3875, 0.18181818181818
55989, 0.17391304347826, 1.3875, 0.22727272727273
55990, 0.17391304347826, 1.3875, 0.27272727272727
55991, 0.17391304347826, 1.3875, 0.31818181818182
55992, 0.17391304347826, 1.3875, 0.36363636363636
55993, 0.17391304347826, 1.3875, 0.40909090909091
55994, 0.17391304347826, 1.3875, 0.45454545454545
55995, 0.1304347826087, 1.3875, 0.045454545454545
55996, 0.1304347826087, 1.3875, 0.090909090909091
55997, 0.1304347826087, 1.3875, 0.13636363636364
55998, 0.1304347826087, 1.3875, 0.18181818181818
55999, 0.1304347826087, 1.3875, 0.22727272727273
56000, 0.1304347826087, 1.3875, 0.27272727272727
56001, 0.1304347826087, 1.3875, 0.31818181818182
56002, 0.1304347826087, 1.3875, 0.36363636363636
56003, 0.1304347826087, 1.3875, 0.40909090909091
56004, 0.1304347826087, 1.3875, 0.45454545454545
56005, 0.08695652173913, 1.3875, 0.045454545454545
56006, 0.08695652173913, 1.3875, 0.090909090909091
56007, 0.08695652173913, 1.3875, 0.13636363636364
56008, 0.08695652173913, 1.3875, 0.18181818181818
56009, 0.08695652173913, 1.3875, 0.22727272727273
56010, 0.08695652173913, 1.3875, 0.27272727272727
56011, 0.08695652173913, 1.3875, 0.31818181818182
56012, 0.08695652173913, 1.3875, 0.36363636363636
56013, 0.08695652173913, 1.3875, 0.40909090909091
56014, 0.08695652173913, 1.3875, 0.45454545454545
56015, 0.043478260869565, 1.3875, 0.045454545454545
56016, 0.043478260869565, 1.3875, 0.090909090909091
56017, 0.043478260869565, 1.3875, 0.13636363636364
56018, 0.043478260869565, 1.3875, 0.18181818181818
56019, 0.043478260869565, 1.3875, 0.22727272727273
56020, 0.043478260869565, 1.3875, 0.27272727272727
56021, 0.043478260869565, 1.3875, 0.31818181818182
56022, 0.043478260869565, 1.3875, 0.36363636363636
56023, 0.043478260869565, 1.3875, 0.40909090909091
56024, 0.043478260869565, 1.3875, 0.45454545454545
56025, 0.95652173913043, 1.4333333333333, 0.045454545454545
56026, 0.95652173913043, 1.4333333333333, 0.090909090909091
56027, 0.95652173913044, 1.4333333333333, 0.13636363636364
56028, 0.95652173913044, 1.4333333333333, 0.18181818181818
56029, 0.95652173913044, 1.4333333333333, 0.22727272727273
56030, 0.95652173913044, 1.4333333333333, 0.27272727272727
56031, 0.95652173913044, 1.4333333333333, 0.31818181818182
56032, 0.95652173913043, 1.4333333333333, 0.36363636363636
56033, 0.95652173913043, 1.4333333333333, 0.40909090909091
56034, 0.95652173913044, 1.4333333333333, 0.45454545454545
56035, 0.91304347826087, 1.4333333333333, 0.045454545454545
56036, 0.91304347826087, 1.4333333333333, 0.090909090909091
56037, 0.91304347826087, 1.4333333333333, 0.13636363636364
56038, 0.91304347826087, 1.4333333333333, 0.18181818181818
56039, 0.91304347826087, 1.4333333333333, 0.22727272727273
56040, 0.91304347826087, 1.4333333333333, 0.27272727272727
56041, 0.91304347826087, 1.4333333333333, 0.31818181818182
56042, 0.91304347826087, 1.4333333333333, 0.36363636363636
56043, 0.91304347826087, 1.4333333333333, 0.40909090909091
56044, 0.91304347826087, 1.4333333333333, 0.45454545454545
56045, 0.8695652173913, 1.4333333333333, 0.045454545454545
56046, 0.8695652173913, 1.4333333333333, 0.090909090909091
56047, 0.8695652173913, 1.4333333333333, 0.13636363636364
56048, 0.8695652173913, 1.4333333333333, 0.18181818181818
56049, 0.8695652173913, 1.4333333333333, 0.22727272727273
56050, 0.8695652173913, 1.4333333333333, 0.27272727272727
56051, 0.8695652173913, 1.4333333333333, 0.31818181818182
56052, 0.8695652173913, 1.4333333333333, 0.36363636363636
56053, 0.8695652173913, 1.4333333333333, 0.40909090909091
56054, 0.8695652173913, 1.4333333333333, 0.45454545454545
56055, 0.82608695652174, 1.4333333333333, 0.045454545454545
56056, 0.82608695652174, 1.4333333333333, 0.090909090909091
56057, 0.82608695652174, 1.4333333333333, 0.13636363636364
56058, 0.82608695652174, 1.4333333333333, 0.18181818181818
56059, 0.82608695652174, 1.4333333333333, 0.22727272727273
56060, 0.82608695652174, 1.4333333333333, 0.27272727272727
56061, 0.82608695652174, 1.4333333333333, 0.31818181818182
56062, 0.82608695652174, 1.4333333333333, 0.36363636363636
56063, 0.82608695652174, 1.4333333333333, 0.40909090909091
56064, 0.82608695652174, 1.4333333333333, 0.45454545454545
56065, 0.78260869565217, 1.4333333333333, 0.045454545454545
56066, 0.78260869565217, 1.4333333333333, 0.090909090909091
56067, 0.78260869565217, 1.4333333333333, 0.13636363636364
56068, 0.78260869565217, 1.4333333333333, 0.18181818181818
56069, 0.78260869565217, 1.4333333333333, 0.22727272727273
56070, 0.78260869565217, 1.4333333333333, 0.27272727272727
56071, 0.78260869565217, 1.4333333333333, 0.31818181818182
56072, 0.78260869565217, 1.4333333333333, 0.36363636363636
56073, 0.78260869565217, 1.4333333333333, 0.40909090909091
56074, 0.78260869565217, 1.4333333333333, 0.45454545454545
56075, 0.73913043478261, 1.4333333333333, 0.045454545454545
56076, 0.73913043478261, 1.4333333333333, 0.090909090909091
56077, 0.73913043478261, 1.4333333333333, 0.13636363636364
56078, 0.73913043478261, 1.4333333333333, 0.18181818181818
56079, 0.73913043478261, 1.4333333333333, 0.22727272727273
56080, 0.73913043478261, 1.4333333333333, 0.27272727272727
56081, 0.73913043478261, 1.4333333333333, 0.31818181818182
56082, 0.73913043478261, 1.4333333333333, 0.36363636363636
56083, 0.73913043478261, 1.4333333333333, 0.40909090909091
56084, 0.73913043478261, 1.4333333333333, 0.45454545454545
56085, 0.69565217391304, 1.4333333333333, 0.045454545454545
56086, 0.69565217391304, 1.4333333333333, 0.090909090909091
56087, 0.69565217391304, 1.4333333333333, 0.13636363636364
56088, 0.69565217391304, 1.4333333333333, 0.18181818181818
56089, 0.69565217391304, 1.4333333333333, 0.22727272727273
56090, 0.69565217391304, 1.4333333333333, 0.27272727272727
56091, 0.69565217391304, 1.4333333333333, 0.31818181818182
56092, 0.69565217391304, 1.4333333333333, 0.36363636363636
56093, 0.69565217391304, 1.4333333333333, 0.40909090909091
56094, 0.69565217391304, 1.4333333333333, 0.45454545454545
56095, 0.65217391304348, 1.4333333333333, 0.045454545454545
56096, 0.65217391304348, 1.4333333333333, 0.090909090909091
56097, 0.65217391304348, 1.4333333333333, 0.13636363636364
56098, 0.65217391304348, 1.4333333333333, 0.18181818181818
56099, 0.65217391304348, 1.4333333333333, 0.22727272727273
56100, 0.65217391304348, 1.4333333333333, 0.27272727272727
56101, 0.65217391304348, 1.4333333333333, 0.31818181818182
56102, 0.65217391304348, 1.4333333333333, 0.36363636363636
56103, 0.65217391304348, 1.4333333333333, 0.40909090909091
56104, 0.65217391304348, 1.4333333333333, 0.45454545454545
56105, 0.60869565217391, 1.4333333333333, 0.045454545454545
56106, 0.60869565217391, 1.4333333333333, 0.090909090909091
56107, 0.60869565217391, 1.4333333333333, 0.13636363636364
56108, 0.60869565217391, 1.4333333333333, 0.18181818181818
56109, 0.60869565217391, 1.4333333333333, 0.22727272727273
56110, 0.60869565217391, 1.4333333333333, 0.27272727272727
56111, 0.60869565217391, 1.4333333333333, 0.31818181818182
56112, 0.60869565217391, 1.4333333333333, 0.36363636363636
56113, 0.60869565217391, 1.4333333333333, 0.40909090909091
56114, 0.60869565217391, 1.4333333333333, 0.45454545454545
56115, 0.56521739130435, 1.4333333333333, 0.045454545454545
56116, 0.56521739130435, 1.4333333333333, 0.090909090909091
56117, 0.56521739130435, 1.4333333333333, 0.13636363636364
56118, 0.56521739130435, 1.4333333333333, 0.18181818181818
56119, 0.56521739130435, 1.4333333333333, 0.22727272727273
56120, 0.56521739130435, 1.4333333333333, 0.27272727272727
56121, 0.56521739130435, 1.4333333333333, 0.31818181818182
56122, 0.56521739130435, 1.4333333333333, 0.36363636363636
56123, 0.56521739130435, 1.4333333333333, 0.40909090909091
56124, 0.56521739130435, 1.4333333333333, 0.45454545454545
56125, 0.52173913043478, 1.4333333333333, 0.045454545454545
56126, 0.52173913043478, 1.4333333333333, 0.090909090909091
56127, 0.52173913043478, 1.4333333333333, 0.13636363636364
56128, 0.52173913043478, 1.4333333333333, 0.18181818181818
56129, 0.52173913043478, 1.4333333333333, 0.22727272727273
56130, 0.52173913043478, 1.4333333333333, 0.27272727272727
56131, 0.52173913043478, 1.4333333333333, 0.31818181818182
56132, 0.52173913043478, 1.4333333333333, 0.36363636363636
56133, 0.52173913043478, 1.4333333333333, 0.40909090909091
56134, 0.52173913043478, 1.4333333333333, 0.45454545454545
56135, 0.47826086956522, 1.4333333333333, 0.045454545454545
56136, 0.47826086956522, 1.4333333333333, 0.090909090909091
56137, 0.47826086956522, 1.4333333333333, 0.13636363636364
56138, 0.47826086956522, 1.4333333333333, 0.18181818181818
56139, 0.47826086956522, 1.4333333333333, 0.22727272727273
56140, 0.47826086956522, 1.4333333333333, 0.27272727272727
56141, 0.47826086956522, 1.4333333333333, 0.31818181818182
56142, 0.47826086956522, 1.4333333333333, 0.36363636363636
56143, 0.47826086956522, 1.4333333333333, 0.40909090909091
56144, 0.47826086956522, 1.4333333333333, 0.45454545454545
56145, 0.43478260869565, 1.4333333333333, 0.045454545454545
56146, 0.43478260869565, 1.4333333333333, 0.090909090909091
56147, 0.43478260869565, 1.4333333333333, 0.13636363636364
56148, 0.43478260869565, 1.4333333333333, 0.18181818181818
56149, 0.43478260869565, 1.4333333333333, 0.22727272727273
56150, 0.43478260869565, 1.4333333333333, 0.27272727272727
56151, 0.43478260869565, 1.4333333333333, 0.31818181818182
56152, 0.43478260869565, 1.4333333333333, 0.36363636363636
56153, 0.43478260869565, 1.4333333333333, 0.40909090909091
56154, 0.43478260869565, 1.4333333333333, 0.45454545454545
56155, 0.39130434782609, 1.4333333333333, 0.045454545454545
56156, 0.39130434782609, 1.4333333333333, 0.090909090909091
56157, 0.39130434782609, 1.4333333333333, 0.13636363636364
56158, 0.39130434782609, 1.4333333333333, 0.18181818181818
56159, 0.39130434782609, 1.4333333333333, 0.22727272727273
56160, 0.39130434782609, 1.4333333333333, 0.27272727272727
56161, 0.39130434782609, 1.4333333333333, 0.31818181818182
56162, 0.39130434782609, 1.4333333333333, 0.36363636363636
56163, 0.39130434782609, 1.4333333333333, 0.40909090909091
56164, 0.39130434782609, 1.4333333333333, 0.45454545454545
56165, 0.34782608695652, 1.4333333333333, 0.045454545454545
56166, 0.34782608695652, 1.4333333333333, 0.090909090909091
56167, 0.34782608695652, 1.4333333333333, 0.13636363636364
56168, 0.34782608695652, 1.4333333333333, 0.18181818181818
56169, 0.34782608695652, 1.4333333333333, 0.22727272727273
56170, 0.34782608695652, 1.4333333333333, 0.27272727272727
56171, 0.34782608695652, 1.4333333333333, 0.31818181818182
56172, 0.34782608695652, 1.4333333333333, 0.36363636363636
56173, 0.34782608695652, 1.4333333333333, 0.40909090909091
56174, 0.34782608695652, 1.4333333333333, 0.45454545454545
56175, 0.30434782608696, 1.4333333333333, 0.045454545454545
56176, 0.30434782608696, 1.4333333333333, 0.090909090909091
56177, 0.30434782608696, 1.4333333333333, 0.13636363636364
56178, 0.30434782608696, 1.4333333333333, 0.18181818181818
56179, 0.30434782608696, 1.4333333333333, 0.22727272727273
56180, 0.30434782608696, 1.4333333333333, 0.27272727272727
56181, 0.30434782608696, 1.4333333333333, 0.31818181818182
56182, 0.30434782608696, 1.4333333333333, 0.36363636363636
56183, 0.30434782608696, 1.4333333333333, 0.40909090909091
56184, 0.30434782608696, 1.4333333333333, 0.45454545454545
56185, 0.26086956521739, 1.4333333333333, 0.045454545454545
56186, 0.26086956521739, 1.4333333333333, 0.090909090909091
56187, 0.26086956521739, 1.4333333333333, 0.13636363636364
56188, 0.26086956521739, 1.4333333333333, 0.18181818181818
56189, 0.26086956521739, 1.4333333333333, 0.22727272727273
56190, 0.26086956521739, 1.4333333333333, 0.27272727272727
56191, 0.26086956521739, 1.4333333333333, 0.31818181818182
56192, 0.26086956521739, 1.4333333333333, 0.36363636363636
56193, 0.26086956521739, 1.4333333333333, 0.40909090909091
56194, 0.26086956521739, 1.4333333333333, 0.45454545454545
56195, 0.21739130434783, 1.4333333333333, 0.045454545454545
56196, 0.21739130434783, 1.4333333333333, 0.090909090909091
56197, 0.21739130434783, 1.4333333333333, 0.13636363636364
56198, 0.21739130434783, 1.4333333333333, 0.18181818181818
56199, 0.21739130434783, 1.4333333333333, 0.22727272727273
56200, 0.21739130434783, 1.4333333333333, 0.27272727272727
56201, 0.21739130434783, 1.4333333333333, 0.31818181818182
56202, 0.21739130434783, 1.4333333333333, 0.36363636363636
56203, 0.21739130434783, 1.4333333333333, 0.40909090909091
56204, 0.21739130434783, 1.4333333333333, 0.45454545454545
56205, 0.17391304347826, 1.4333333333333, 0.045454545454545
56206, 0.17391304347826, 1.4333333333333, 0.090909090909091
56207, 0.17391304347826, 1.4333333333333, 0.13636363636364
56208, 0.17391304347826, 1.4333333333333, 0.18181818181818
56209, 0.17391304347826, 1.4333333333333, 0.22727272727273
56210, 0.17391304347826, 1.4333333333333, 0.27272727272727
56211, 0.17391304347826, 1.4333333333333, 0.31818181818182
56212, 0.17391304347826, 1.4333333333333, 0.36363636363636
56213, 0.17391304347826, 1.4333333333333, 0.40909090909091
56214, 0.17391304347826, 1.4333333333333, 0.45454545454545
56215, 0.1304347826087, 1.4333333333333, 0.045454545454545
56216, 0.1304347826087, 1.4333333333333, 0.090909090909091
56217, 0.1304347826087, 1.4333333333333, 0.13636363636364
56218, 0.1304347826087, 1.4333333333333, 0.18181818181818
56219, 0.1304347826087, 1.4333333333333, 0.22727272727273
56220, 0.1304347826087, 1.4333333333333, 0.27272727272727
56221, 0.1304347826087, 1.4333333333333, 0.31818181818182
56222, 0.1304347826087, 1.4333333333333, 0.36363636363636
56223, 0.1304347826087, 1.4333333333333, 0.40909090909091
56224, 0.1304347826087, 1.4333333333333, 0.45454545454545
56225, 0.08695652173913, 1.4333333333333, 0.045454545454545
56226, 0.08695652173913, 1.4333333333333, 0.090909090909091
56227, 0.08695652173913, 1.4333333333333, 0.13636363636364
56228, 0.08695652173913, 1.4333333333333, 0.18181818181818
56229, 0.08695652173913, 1.4333333333333, 0.22727272727273
56230, 0.08695652173913, 1.4333333333333, 0.27272727272727
56231, 0.08695652173913, 1.4333333333333, 0.31818181818182
56232, 0.08695652173913, 1.4333333333333, 0.36363636363636
56233, 0.08695652173913, 1.4333333333333, 0.40909090909091
56234, 0.08695652173913, 1.4333333333333, 0.45454545454545
56235, 0.043478260869565, 1.4333333333333, 0.045454545454545
56236, 0.043478260869565, 1.4333333333333, 0.090909090909091
56237, 0.043478260869565, 1.4333333333333, 0.13636363636364
56238, 0.043478260869565, 1.4333333333333, 0.18181818181818
56239, 0.043478260869565, 1.4333333333333, 0.22727272727273
56240, 0.043478260869565, 1.4333333333333, 0.27272727272727
56241, 0.043478260869565, 1.4333333333333, 0.31818181818182
56242, 0.043478260869565, 1.4333333333333, 0.36363636363636
56243, 0.043478260869565, 1.4333333333333, 0.40909090909091
56244, 0.043478260869565, 1.4333333333333, 0.45454545454545
56245, 0.95652173913043, 1.4666666666667, 0.045454545454545
56246, 0.95652173913043, 1.4666666666667, 0.090909090909091
56247, 0.95652173913044, 1.4666666666667, 0.13636363636364
56248, 0.95652173913044, 1.4666666666667, 0.18181818181818
56249, 0.95652173913044, 1.4666666666667, 0.22727272727273
56250, 0.95652173913044, 1.4666666666667, 0.27272727272727
56251, 0.95652173913044, 1.4666666666667, 0.31818181818182
56252, 0.95652173913043, 1.4666666666667, 0.36363636363636
56253, 0.95652173913043, 1.4666666666667, 0.40909090909091
56254, 0.95652173913044, 1.4666666666667, 0.45454545454545
56255, 0.91304347826087, 1.4666666666667, 0.045454545454545
56256, 0.91304347826087, 1.4666666666667, 0.090909090909091
56257, 0.91304347826087, 1.4666666666667, 0.13636363636364
56258, 0.91304347826087, 1.4666666666667, 0.18181818181818
56259, 0.91304347826087, 1.4666666666667, 0.22727272727273
56260, 0.91304347826087, 1.4666666666667, 0.27272727272727
56261, 0.91304347826087, 1.4666666666667, 0.31818181818182
56262, 0.91304347826087, 1.4666666666667, 0.36363636363636
56263, 0.91304347826087, 1.4666666666667, 0.40909090909091
56264, 0.91304347826087, 1.4666666666667, 0.45454545454545
56265, 0.8695652173913, 1.4666666666667, 0.045454545454545
56266, 0.8695652173913, 1.4666666666667, 0.090909090909091
56267, 0.8695652173913, 1.4666666666667, 0.13636363636364
56268, 0.8695652173913, 1.4666666666667, 0.18181818181818
56269, 0.8695652173913, 1.4666666666667, 0.22727272727273
56270, 0.8695652173913, 1.4666666666667, 0.27272727272727
56271, 0.8695652173913, 1.4666666666667, 0.31818181818182
56272, 0.8695652173913, 1.4666666666667, 0.36363636363636
56273, 0.8695652173913, 1.4666666666667, 0.40909090909091
56274, 0.8695652173913, 1.4666666666667, 0.45454545454545
56275, 0.82608695652174, 1.4666666666667, 0.045454545454545
56276, 0.82608695652174, 1.4666666666667, 0.090909090909091
56277, 0.82608695652174, 1.4666666666667, 0.13636363636364
56278, 0.82608695652174, 1.4666666666667, 0.18181818181818
56279, 0.82608695652174, 1.4666666666667, 0.22727272727273
56280, 0.82608695652174, 1.4666666666667, 0.27272727272727
56281, 0.82608695652174, 1.4666666666667, 0.31818181818182
56282, 0.82608695652174, 1.4666666666667, 0.36363636363636
56283, 0.82608695652174, 1.4666666666667, 0.40909090909091
56284, 0.82608695652174, 1.4666666666667, 0.45454545454545
56285, 0.78260869565217, 1.4666666666667, 0.045454545454545
56286, 0.78260869565217, 1.4666666666667, 0.090909090909091
56287, 0.78260869565217, 1.4666666666667, 0.13636363636364
56288, 0.78260869565217, 1.4666666666667, 0.18181818181818
56289, 0.78260869565217, 1.4666666666667, 0.22727272727273
56290, 0.78260869565217, 1.4666666666667, 0.27272727272727
56291, 0.78260869565217, 1.4666666666667, 0.31818181818182
56292, 0.78260869565217, 1.4666666666667, 0.36363636363636
56293, 0.78260869565217, 1.4666666666667, 0.40909090909091
56294, 0.78260869565217, 1.4666666666667, 0.45454545454545
56295, 0.73913043478261, 1.4666666666667, 0.045454545454545
56296, 0.73913043478261, 1.4666666666667, 0.090909090909091
56297, 0.73913043478261, 1.4666666666667, 0.13636363636364
56298, 0.73913043478261, 1.4666666666667, 0.18181818181818
56299, 0.73913043478261, 1.4666666666667, 0.22727272727273
56300, 0.73913043478261, 1.4666666666667, 0.27272727272727
56301, 0.73913043478261, 1.4666666666667, 0.31818181818182
56302, 0.73913043478261, 1.4666666666667, 0.36363636363636
56303, 0.73913043478261, 1.4666666666667, 0.40909090909091
56304, 0.73913043478261, 1.4666666666667, 0.45454545454545
56305, 0.69565217391304, 1.4666666666667, 0.045454545454545
56306, 0.69565217391304, 1.4666666666667, 0.090909090909091
56307, 0.69565217391304, 1.4666666666667, 0.13636363636364
56308, 0.69565217391304, 1.4666666666667, 0.18181818181818
56309, 0.69565217391304, 1.4666666666667, 0.22727272727273
56310, 0.69565217391304, 1.4666666666667, 0.27272727272727
56311, 0.69565217391304, 1.4666666666667, 0.31818181818182
56312, 0.69565217391304, 1.4666666666667, 0.36363636363636
56313, 0.69565217391304, 1.4666666666667, 0.40909090909091
56314, 0.69565217391304, 1.4666666666667, 0.45454545454545
56315, 0.65217391304348, 1.4666666666667, 0.045454545454545
56316, 0.65217391304348, 1.4666666666667, 0.090909090909091
56317, 0.65217391304348, 1.4666666666667, 0.13636363636364
56318, 0.65217391304348, 1.4666666666667, 0.18181818181818
56319, 0.65217391304348, 1.4666666666667, 0.22727272727273
56320, 0.65217391304348, 1.4666666666667, 0.27272727272727
56321, 0.65217391304348, 1.4666666666667, 0.31818181818182
56322, 0.65217391304348, 1.4666666666667, 0.36363636363636
56323, 0.65217391304348, 1.4666666666667, 0.40909090909091
56324, 0.65217391304348, 1.4666666666667, 0.45454545454545
56325, 0.60869565217391, 1.4666666666667, 0.045454545454545
56326, 0.60869565217391, 1.4666666666667, 0.090909090909091
56327, 0.60869565217391, 1.4666666666667, 0.13636363636364
56328, 0.60869565217391, 1.4666666666667, 0.18181818181818
56329, 0.60869565217391, 1.4666666666667, 0.22727272727273
56330, 0.60869565217391, 1.4666666666667, 0.27272727272727
56331, 0.60869565217391, 1.4666666666667, 0.31818181818182
56332, 0.60869565217391, 1.4666666666667, 0.36363636363636
56333, 0.60869565217391, 1.4666666666667, 0.40909090909091
56334, 0.60869565217391, 1.4666666666667, 0.45454545454545
56335, 0.56521739130435, 1.4666666666667, 0.045454545454545
56336, 0.56521739130435, 1.4666666666667, 0.090909090909091
56337, 0.56521739130435, 1.4666666666667, 0.13636363636364
56338, 0.56521739130435, 1.4666666666667, 0.18181818181818
56339, 0.56521739130435, 1.4666666666667, 0.22727272727273
56340, 0.56521739130435, 1.4666666666667, 0.27272727272727
56341, 0.56521739130435, 1.4666666666667, 0.31818181818182
56342, 0.56521739130435, 1.4666666666667, 0.36363636363636
56343, 0.56521739130435, 1.4666666666667, 0.40909090909091
56344, 0.56521739130435, 1.4666666666667, 0.45454545454545
56345, 0.52173913043478, 1.4666666666667, 0.045454545454545
56346, 0.52173913043478, 1.4666666666667, 0.090909090909091
56347, 0.52173913043478, 1.4666666666667, 0.13636363636364
56348, 0.52173913043478, 1.4666666666667, 0.18181818181818
56349, 0.52173913043478, 1.4666666666667, 0.22727272727273
56350, 0.52173913043478, 1.4666666666667, 0.27272727272727
56351, 0.52173913043478, 1.4666666666667, 0.31818181818182
56352, 0.52173913043478, 1.4666666666667, 0.36363636363636
56353, 0.52173913043478, 1.4666666666667, 0.40909090909091
56354, 0.52173913043478, 1.4666666666667, 0.45454545454545
56355, 0.47826086956522, 1.4666666666667, 0.045454545454545
56356, 0.47826086956522, 1.4666666666667, 0.090909090909091
56357, 0.47826086956522, 1.4666666666667, 0.13636363636364
56358, 0.47826086956522, 1.4666666666667, 0.18181818181818
56359, 0.47826086956522, 1.4666666666667, 0.22727272727273
56360, 0.47826086956522, 1.4666666666667, 0.27272727272727
56361, 0.47826086956522, 1.4666666666667, 0.31818181818182
56362, 0.47826086956522, 1.4666666666667, 0.36363636363636
56363, 0.47826086956522, 1.4666666666667, 0.40909090909091
56364, 0.47826086956522, 1.4666666666667, 0.45454545454545
56365, 0.43478260869565, 1.4666666666667, 0.045454545454545
56366, 0.43478260869565, 1.4666666666667, 0.090909090909091
56367, 0.43478260869565, 1.4666666666667, 0.13636363636364
56368, 0.43478260869565, 1.4666666666667, 0.18181818181818
56369, 0.43478260869565, 1.4666666666667, 0.22727272727273
56370, 0.43478260869565, 1.4666666666667, 0.27272727272727
56371, 0.43478260869565, 1.4666666666667, 0.31818181818182
56372, 0.43478260869565, 1.4666666666667, 0.36363636363636
56373, 0.43478260869565, 1.4666666666667, 0.40909090909091
56374, 0.43478260869565, 1.4666666666667, 0.45454545454545
56375, 0.39130434782609, 1.4666666666667, 0.045454545454545
56376, 0.39130434782609, 1.4666666666667, 0.090909090909091
56377, 0.39130434782609, 1.4666666666667, 0.13636363636364
56378, 0.39130434782609, 1.4666666666667, 0.18181818181818
56379, 0.39130434782609, 1.4666666666667, 0.22727272727273
56380, 0.39130434782609, 1.4666666666667, 0.27272727272727
56381, 0.39130434782609, 1.4666666666667, 0.31818181818182
56382, 0.39130434782609, 1.4666666666667, 0.36363636363636
56383, 0.39130434782609, 1.4666666666667, 0.40909090909091
56384, 0.39130434782609, 1.4666666666667, 0.45454545454545
56385, 0.34782608695652, 1.4666666666667, 0.045454545454545
56386, 0.34782608695652, 1.4666666666667, 0.090909090909091
56387, 0.34782608695652, 1.4666666666667, 0.13636363636364
56388, 0.34782608695652, 1.4666666666667, 0.18181818181818
56389, 0.34782608695652, 1.4666666666667, 0.22727272727273
56390, 0.34782608695652, 1.4666666666667, 0.27272727272727
56391, 0.34782608695652, 1.4666666666667, 0.31818181818182
56392, 0.34782608695652, 1.4666666666667, 0.36363636363636
56393, 0.34782608695652, 1.4666666666667, 0.40909090909091
56394, 0.34782608695652, 1.4666666666667, 0.45454545454545
56395, 0.30434782608696, 1.4666666666667, 0.045454545454545
56396, 0.30434782608696, 1.4666666666667, 0.090909090909091
56397, 0.30434782608696, 1.4666666666667, 0.13636363636364
56398, 0.30434782608696, 1.4666666666667, 0.18181818181818
56399, 0.30434782608696, 1.4666666666667, 0.22727272727273
56400, 0.30434782608696, 1.4666666666667, 0.27272727272727
56401, 0.30434782608696, 1.4666666666667, 0.31818181818182
56402, 0.30434782608696, 1.4666666666667, 0.36363636363636
56403, 0.30434782608696, 1.4666666666667, 0.40909090909091
56404, 0.30434782608696, 1.4666666666667, 0.45454545454545
56405, 0.26086956521739, 1.4666666666667, 0.045454545454545
56406, 0.26086956521739, 1.4666666666667, 0.090909090909091
56407, 0.26086956521739, 1.4666666666667, 0.13636363636364
56408, 0.26086956521739, 1.4666666666667, 0.18181818181818
56409, 0.26086956521739, 1.4666666666667, 0.22727272727273
56410, 0.26086956521739, 1.4666666666667, 0.27272727272727
56411, 0.26086956521739, 1.4666666666667, 0.31818181818182
56412, 0.26086956521739, 1.4666666666667, 0.36363636363636
56413, 0.26086956521739, 1.4666666666667, 0.40909090909091
56414, 0.26086956521739, 1.4666666666667, 0.45454545454545
56415, 0.21739130434783, 1.4666666666667, 0.045454545454545
56416, 0.21739130434783, 1.4666666666667, 0.090909090909091
56417, 0.21739130434783, 1.4666666666667, 0.13636363636364
56418, 0.21739130434783, 1.4666666666667, 0.18181818181818
56419, 0.21739130434783, 1.4666666666667, 0.22727272727273
56420, 0.21739130434783, 1.4666666666667, 0.27272727272727
56421, 0.21739130434783, 1.4666666666667, 0.31818181818182
56422, 0.21739130434783, 1.4666666666667, 0.36363636363636
56423, 0.21739130434783, 1.4666666666667, 0.40909090909091
56424, 0.21739130434783, 1.4666666666667, 0.45454545454545
56425, 0.17391304347826, 1.4666666666667, 0.045454545454545
56426, 0.17391304347826, 1.4666666666667, 0.090909090909091
56427, 0.17391304347826, 1.4666666666667, 0.13636363636364
56428, 0.17391304347826, 1.4666666666667, 0.18181818181818
56429, 0.17391304347826, 1.4666666666667, 0.22727272727273
56430, 0.17391304347826, 1.4666666666667, 0.27272727272727
56431, 0.17391304347826, 1.4666666666667, 0.31818181818182
56432, 0.17391304347826, 1.4666666666667, 0.36363636363636
56433, 0.17391304347826, 1.4666666666667, 0.40909090909091
56434, 0.17391304347826, 1.4666666666667, 0.45454545454545
56435, 0.1304347826087, 1.4666666666667, 0.045454545454545
56436, 0.1304347826087, 1.4666666666667, 0.090909090909091
56437, 0.1304347826087, 1.4666666666667, 0.13636363636364
56438, 0.1304347826087, 1.4666666666667, 0.18181818181818
56439, 0.1304347826087, 1.4666666666667, 0.22727272727273
56440, 0.1304347826087, 1.4666666666667, 0.27272727272727
56441, 0.1304347826087, 1.4666666666667, 0.31818181818182
56442, 0.1304347826087, 1.4666666666667, 0.36363636363636
56443, 0.1304347826087, 1.4666666666667, 0.40909090909091
56444, 0.1304347826087, 1.4666666666667, 0.45454545454545
56445, 0.08695652173913, 1.4666666666667, 0.045454545454545
56446, 0.08695652173913, 1.4666666666667, 0.090909090909091
56447, 0.08695652173913, 1.4666666666667, 0.13636363636364
56448, 0.08695652173913, 1.4666666666667, 0.18181818181818
56449, 0.08695652173913, 1.4666666666667, 0.22727272727273
56450, 0.08695652173913, 1.4666666666667, 0.27272727272727
56451, 0.08695652173913, 1.4666666666667, 0.31818181818182
56452, 0.08695652173913, 1.4666666666667, 0.36363636363636
56453, 0.08695652173913, 1.4666666666667, 0.40909090909091
56454, 0.08695652173913, 1.4666666666667, 0.45454545454545
56455, 0.043478260869565, 1.4666666666667, 0.045454545454545
56456, 0.043478260869565, 1.4666666666667, 0.090909090909091
56457, 0.043478260869565, 1.4666666666667, 0.13636363636364
56458, 0.043478260869565, 1.4666666666667, 0.18181818181818
56459, 0.043478260869565, 1.4666666666667, 0.22727272727273
56460, 0.043478260869565, 1.4666666666667, 0.27272727272727
56461, 0.043478260869565, 1.4666666666667, 0.31818181818182
56462, 0.043478260869565, 1.4666666666667, 0.36363636363636
56463, 0.043478260869565, 1.4666666666667, 0.40909090909091
56464, 0.043478260869565, 1.4666666666667, 0.45454545454545
56465, 0.95652173913043, 1.4333333333333, 0.022727272727273
56466, 0.97826086956522, 1.4333333333333, 0.045454545454545
56467, 0.95652173913043, 1.4166666666667, 0.045454545454545
56468, 0.95652173913043, 1.4333333333333, 0.068181818181818
56469, 0.97826086956522, 1.4333333333333, 0.090909090909091
56470, 0.95652173913043, 1.4166666666667, 0.090909090909091
56471, 0.95652173913043, 1.4333333333333, 0.11363636363636
56472, 0.97826086956522, 1.4333333333333, 0.13636363636364
56473, 0.95652173913044, 1.4166666666667, 0.13636363636364
56474, 0.95652173913044, 1.4333333333333, 0.15909090909091
56475, 0.97826086956522, 1.4333333333333, 0.18181818181818
56476, 0.95652173913044, 1.4166666666667, 0.18181818181818
56477, 0.95652173913044, 1.4333333333333, 0.20454545454545
56478, 0.97826086956522, 1.4333333333333, 0.22727272727273
56479, 0.95652173913043, 1.4166666666667, 0.22727272727273
56480, 0.95652173913044, 1.4333333333333, 0.25
56481, 0.97826086956522, 1.4333333333333, 0.27272727272727
56482, 0.95652173913043, 1.4166666666667, 0.27272727272727
56483, 0.95652173913044, 1.4333333333333, 0.29545454545455
56484, 0.97826086956522, 1.4333333333333, 0.31818181818182
56485, 0.95652173913044, 1.4166666666667, 0.31818181818182
56486, 0.95652173913043, 1.4333333333333, 0.34090909090909
56487, 0.97826086956522, 1.4333333333333, 0.36363636363636
56488, 0.95652173913043, 1.4166666666667, 0.36363636363636
56489, 0.95652173913043, 1.4333333333333, 0.38636363636364
56490, 0.97826086956522, 1.4333333333333, 0.40909090909091
56491, 0.95652173913043, 1.4166666666667, 0.40909090909091
56492, 0.95652173913043, 1.4333333333333, 0.43181818181818
56493, 0.97826086956522, 1.4333333333333, 0.45454545454545
56494, 0.95652173913043, 1.4166666666667, 0.45454545454545
56495, 0.95652173913043, 1.4333333333333, 0.47727272727273
56496, 0.91304347826087, 1.4333333333333, 0.022727272727273
56497, 0.93478260869565, 1.4333333333333, 0.045454545454545
56498, 0.91304347826087, 1.4166666666667, 0.045454545454545
56499, 0.91304347826087, 1.4333333333333, 0.068181818181818
56500, 0.93478260869565, 1.4333333333333, 0.090909090909091
56501, 0.91304347826087, 1.4166666666667, 0.090909090909091
56502, 0.91304347826087, 1.4333333333333, 0.11363636363636
56503, 0.93478260869565, 1.4333333333333, 0.13636363636364
56504, 0.91304347826087, 1.4166666666667, 0.13636363636364
56505, 0.91304347826087, 1.4333333333333, 0.15909090909091
56506, 0.93478260869565, 1.4333333333333, 0.18181818181818
56507, 0.91304347826087, 1.4166666666667, 0.18181818181818
56508, 0.91304347826087, 1.4333333333333, 0.20454545454545
56509, 0.93478260869565, 1.4333333333333, 0.22727272727273
56510, 0.91304347826087, 1.4166666666667, 0.22727272727273
56511, 0.91304347826087, 1.4333333333333, 0.25
56512, 0.93478260869565, 1.4333333333333, 0.27272727272727
56513, 0.91304347826087, 1.4166666666667, 0.27272727272727
56514, 0.91304347826087, 1.4333333333333, 0.29545454545455
56515, 0.93478260869565, 1.4333333333333, 0.31818181818182
56516, 0.91304347826087, 1.4166666666667, 0.31818181818182
56517, 0.91304347826087, 1.4333333333333, 0.34090909090909
56518, 0.93478260869565, 1.4333333333333, 0.36363636363636
56519, 0.91304347826087, 1.4166666666667, 0.36363636363636
56520, 0.91304347826087, 1.4333333333333, 0.38636363636364
56521, 0.93478260869565, 1.4333333333333, 0.40909090909091
56522, 0.91304347826087, 1.4166666666667, 0.40909090909091
56523, 0.91304347826087, 1.4333333333333, 0.43181818181818
56524, 0.93478260869565, 1.4333333333333, 0.45454545454545
56525, 0.91304347826087, 1.4166666666667, 0.45454545454545
56526, 0.91304347826087, 1.4333333333333, 0.47727272727273
56527, 0.8695652173913, 1.4333333333333, 0.022727272727273
56528, 0.89130434782609, 1.4333333333333, 0.045454545454545
56529, 0.8695652173913, 1.4166666666667, 0.045454545454545
56530, 0.8695652173913, 1.4333333333333, 0.068181818181818
56531, 0.89130434782609, 1.4333333333333, 0.090909090909091
56532, 0.8695652173913, 1.4166666666667, 0.090909090909091
56533, 0.8695652173913, 1.4333333333333, 0.11363636363636
56534, 0.89130434782609, 1.4333333333333, 0.13636363636364
56535, 0.8695652173913, 1.4166666666667, 0.13636363636364
56536, 0.8695652173913, 1.4333333333333, 0.15909090909091
56537, 0.89130434782609, 1.4333333333333, 0.18181818181818
56538, 0.8695652173913, 1.4166666666667, 0.18181818181818
56539, 0.8695652173913, 1.4333333333333, 0.20454545454545
56540, 0.89130434782609, 1.4333333333333, 0.22727272727273
56541, 0.8695652173913, 1.4166666666667, 0.22727272727273
56542, 0.8695652173913, 1.4333333333333, 0.25
56543, 0.89130434782609, 1.4333333333333, 0.27272727272727
56544, 0.8695652173913, 1.4166666666667, 0.27272727272727
56545, 0.8695652173913, 1.4333333333333, 0.29545454545455
56546, 0.89130434782609, 1.4333333333333, 0.31818181818182
56547, 0.8695652173913, 1.4166666666667, 0.31818181818182
56548, 0.8695652173913, 1.4333333333333, 0.34090909090909
56549, 0.89130434782609, 1.4333333333333, 0.36363636363636
56550, 0.8695652173913, 1.4166666666667, 0.36363636363636
56551, 0.8695652173913, 1.4333333333333, 0.38636363636364
56552, 0.89130434782609, 1.4333333333333, 0.40909090909091
56553, 0.8695652173913, 1.4166666666667, 0.40909090909091
56554, 0.8695652173913, 1.4333333333333, 0.43181818181818
56555, 0.89130434782609, 1.4333333333333, 0.45454545454545
56556, 0.8695652173913, 1.4166666666667, 0.45454545454545
56557, 0.8695652173913, 1.4333333333333, 0.47727272727273
56558, 0.82608695652174, 1.4333333333333, 0.022727272727273
56559, 0.84782608695652, 1.4333333333333, 0.045454545454545
56560, 0.82608695652174, 1.4166666666667, 0.045454545454545
56561, 0.82608695652174, 1.4333333333333, 0.068181818181818
56562, 0.84782608695652, 1.4333333333333, 0.090909090909091
56563, 0.82608695652174, 1.4166666666667, 0.090909090909091
56564, 0.82608695652174, 1.4333333333333, 0.11363636363636
56565, 0.84782608695652, 1.4333333333333, 0.13636363636364
56566, 0.82608695652174, 1.4166666666667, 0.13636363636364
56567, 0.82608695652174, 1.4333333333333, 0.15909090909091
56568, 0.84782608695652, 1.4333333333333, 0.18181818181818
56569, 0.82608695652174, 1.4166666666667, 0.18181818181818
56570, 0.82608695652174, 1.4333333333333, 0.20454545454545
56571, 0.84782608695652, 1.4333333333333, 0.22727272727273
56572, 0.82608695652174, 1.4166666666667, 0.22727272727273
56573, 0.82608695652174, 1.4333333333333, 0.25
56574, 0.84782608695652, 1.4333333333333, 0.27272727272727
56575, 0.82608695652174, 1.4166666666667, 0.27272727272727
56576, 0.82608695652174, 1.4333333333333, 0.29545454545455
56577, 0.84782608695652, 1.4333333333333, 0.31818181818182
56578, 0.82608695652174, 1.4166666666667, 0.31818181818182
56579, 0.82608695652174, 1.4333333333333, 0.34090909090909
56580, 0.84782608695652, 1.4333333333333, 0.36363636363636
56581, 0.82608695652174, 1.4166666666667, 0.36363636363636
56582, 0.82608695652174, 1.4333333333333, 0.38636363636364
56583, 0.84782608695652, 1.4333333333333, 0.40909090909091
56584, 0.82608695652174, 1.4166666666667, 0.40909090909091
56585, 0.82608695652174, 1.4333333333333, 0.43181818181818
56586, 0.84782608695652, 1.4333333333333, 0.45454545454545
56587, 0.82608695652174, 1.4166666666667, 0.45454545454545
56588, 0.82608695652174, 1.4333333333333, 0.47727272727273
56589, 0.78260869565217, 1.4333333333333, 0.022727272727273
56590, 0.80434782608696, 1.4333333333333, 0.045454545454545
56591, 0.78260869565217, 1.4166666666667, 0.045454545454545
56592, 0.78260869565217, 1.4333333333333, 0.068181818181818
56593, 0.80434782608696, 1.4333333333333, 0.090909090909091
56594, 0.78260869565217, 1.4166666666667, 0.090909090909091
56595, 0.78260869565217, 1.4333333333333, 0.11363636363636
56596, 0.80434782608696, 1.4333333333333, 0.13636363636364
56597, 0.78260869565217, 1.4166666666667, 0.13636363636364
56598, 0.78260869565217, 1.4333333333333, 0.15909090909091
56599, 0.80434782608696, 1.4333333333333, 0.18181818181818
56600, 0.78260869565217, 1.4166666666667, 0.18181818181818
56601, 0.78260869565217, 1.4333333333333, 0.20454545454545
56602, 0.80434782608696, 1.4333333333333, 0.22727272727273
56603, 0.78260869565217, 1.4166666666667, 0.22727272727273
56604, 0.78260869565217, 1.4333333333333, 0.25
56605, 0.80434782608696, 1.4333333333333, 0.27272727272727
56606, 0.78260869565217, 1.4166666666667, 0.27272727272727
56607, 0.78260869565217, 1.4333333333333, 0.29545454545455
56608, 0.80434782608696, 1.4333333333333, 0.31818181818182
56609, 0.78260869565217, 1.4166666666667, 0.31818181818182
56610, 0.78260869565217, 1.4333333333333, 0.34090909090909
56611, 0.80434782608696, 1.4333333333333, 0.36363636363636
56612, 0.78260869565217, 1.4166666666667, 0.36363636363636
56613, 0.78260869565217, 1.4333333333333, 0.38636363636364
56614, 0.80434782608696, 1.4333333333333, 0.40909090909091
56615, 0.78260869565217, 1.4166666666667, 0.40909090909091
56616, 0.78260869565217, 1.4333333333333, 0.43181818181818
56617, 0.80434782608696, 1.4333333333333, 0.45454545454545
56618, 0.78260869565217, 1.4166666666667, 0.45454545454545
56619, 0.78260869565217, 1.4333333333333, 0.47727272727273
56620, 0.73913043478261, 1.4333333333333, 0.022727272727273
56621, 0.76086956521739, 1.4333333333333, 0.045454545454545
56622, 0.73913043478261, 1.4166666666667, 0.045454545454545
56623, 0.73913043478261, 1.4333333333333, 0.068181818181818
56624, 0.76086956521739, 1.4333333333333, 0.090909090909091
56625, 0.73913043478261, 1.4166666666667, 0.090909090909091
56626, 0.73913043478261, 1.4333333333333, 0.11363636363636
56627, 0.76086956521739, 1.4333333333333, 0.13636363636364
56628, 0.73913043478261, 1.4166666666667, 0.13636363636364
56629, 0.73913043478261, 1.4333333333333, 0.15909090909091
56630, 0.76086956521739, 1.4333333333333, 0.18181818181818
56631, 0.73913043478261, 1.4166666666667, 0.18181818181818
56632, 0.73913043478261, 1.4333333333333, 0.20454545454545
56633, 0.76086956521739, 1.4333333333333, 0.22727272727273
56634, 0.73913043478261, 1.4166666666667, 0.22727272727273
56635, 0.73913043478261, 1.4333333333333, 0.25
56636, 0.76086956521739, 1.4333333333333, 0.27272727272727
56637, 0.73913043478261, 1.4166666666667, 0.27272727272727
56638, 0.73913043478261, 1.4333333333333, 0.29545454545455
56639, 0.76086956521739, 1.4333333333333, 0.31818181818182
56640, 0.73913043478261, 1.4166666666667, 0.31818181818182
56641, 0.73913043478261, 1.4333333333333, 0.34090909090909
56642, 0.76086956521739, 1.4333333333333, 0.36363636363636
56643, 0.73913043478261, 1.4166666666667, 0.36363636363636
56644, 0.73913043478261, 1.4333333333333, 0.38636363636364
56645, 0.76086956521739, 1.4333333333333, 0.40909090909091
56646, 0.73913043478261, 1.4166666666667, 0.40909090909091
56647, 0.73913043478261, 1.4333333333333, 0.43181818181818
56648, 0.76086956521739, 1.4333333333333, 0.45454545454545
56649, 0.73913043478261, 1.4166666666667, 0.45454545454545
56650, 0.73913043478261, 1.4333333333333, 0.47727272727273
56651, 0.69565217391304, 1.4333333333333, 0.022727272727273
56652, 0.71739130434783, 1.4333333333333, 0.045454545454545
56653, 0.69565217391304, 1.4166666666667, 0.045454545454545
56654, 0.69565217391304, 1.4333333333333, 0.068181818181818
56655, 0.71739130434783, 1.4333333333333, 0.090909090909091
56656, 0.69565217391304, 1.4166666666667, 0.090909090909091
56657, 0.69565217391304, 1.4333333333333, 0.11363636363636
56658, 0.71739130434783, 1.4333333333333, 0.13636363636364
56659, 0.69565217391304, 1.4166666666667, 0.13636363636364
56660, 0.69565217391304, 1.4333333333333, 0.15909090909091
56661, 0.71739130434783, 1.4333333333333, 0.18181818181818
56662, 0.69565217391304, 1.4166666666667, 0.18181818181818
56663, 0.69565217391304, 1.4333333333333, 0.20454545454545
56664, 0.71739130434783, 1.4333333333333, 0.22727272727273
56665, 0.69565217391304, 1.4166666666667, 0.22727272727273
56666, 0.69565217391304, 1.4333333333333, 0.25
56667, 0.71739130434783, 1.4333333333333, 0.27272727272727
56668, 0.69565217391304, 1.4166666666667, 0.27272727272727
56669, 0.69565217391304, 1.4333333333333, 0.29545454545455
56670, 0.71739130434783, 1.4333333333333, 0.31818181818182
56671, 0.69565217391304, 1.4166666666667, 0.31818181818182
56672, 0.69565217391304, 1.4333333333333, 0.34090909090909
56673, 0.71739130434783, 1.4333333333333, 0.36363636363636
56674, 0.69565217391304, 1.4166666666667, 0.36363636363636
56675, 0.69565217391304, 1.4333333333333, 0.38636363636364
56676, 0.71739130434783, 1.4333333333333, 0.40909090909091
56677, 0.69565217391304, 1.4166666666667, 0.40909090909091
56678, 0.69565217391304, 1.4333333333333, 0.43181818181818
56679, 0.71739130434783, 1.4333333333333, 0.45454545454545
56680, 0.69565217391304, 1.4166666666667, 0.45454545454545
56681, 0.69565217391304, 1.4333333333333, 0.47727272727273
56682, 0.65217391304348, 1.4333333333333, 0.022727272727273
56683, 0.67391304347826, 1.4333333333333, 0.045454545454545
56684, 0.65217391304348, 1.4166666666667, 0.045454545454545
56685, 0.65217391304348, 1.4333333333333, 0.068181818181818
56686, 0.67391304347826, 1.4333333333333, 0.090909090909091
56687, 0.65217391304348, 1.4166666666667, 0.090909090909091
56688, 0.65217391304348, 1.4333333333333, 0.11363636363636
56689, 0.67391304347826, 1.4333333333333, 0.13636363636364
56690, 0.65217391304348, 1.4166666666667, 0.13636363636364
56691, 0.65217391304348, 1.4333333333333, 0.15909090909091
56692, 0.67391304347826, 1.4333333333333, 0.18181818181818
56693, 0.65217391304348, 1.4166666666667, 0.18181818181818
56694, 0.65217391304348, 1.4333333333333, 0.20454545454545
56695, 0.67391304347826, 1.4333333333333, 0.22727272727273
56696, 0.65217391304348, 1.4166666666667, 0.22727272727273
56697, 0.65217391304348, 1.4333333333333, 0.25
56698, 0.67391304347826, 1.4333333333333, 0.27272727272727
56699, 0.65217391304348, 1.4166666666667, 0.27272727272727
56700, 0.65217391304348, 1.4333333333333, 0.29545454545455
56701, 0.67391304347826, 1.4333333333333, 0.31818181818182
56702, 0.65217391304348, 1.4166666666667, 0.31818181818182
56703, 0.65217391304348, 1.4333333333333, 0.34090909090909
56704, 0.67391304347826, 1.4333333333333, 0.36363636363636
56705, 0.65217391304348, 1.4166666666667, 0.36363636363636
56706, 0.65217391304348, 1.4333333333333, 0.38636363636364
56707, 0.67391304347826, 1.4333333333333, 0.40909090909091
56708, 0.65217391304348, 1.4166666666667, 0.40909090909091
56709, 0.65217391304348, 1.4333333333333, 0.43181818181818
56710, 0.67391304347826, 1.4333333333333, 0.45454545454545
56711, 0.65217391304348, 1.4166666666667, 0.45454545454545
56712, 0.65217391304348, 1.4333333333333, 0.47727272727273
56713, 0.60869565217391, 1.4333333333333, 0.022727272727273
56714, 0.6304347826087, 1.4333333333333, 0.045454545454545
56715, 0.60869565217391, 1.4166666666667, 0.045454545454545
56716, 0.60869565217391, 1.4333333333333, 0.068181818181818
56717, 0.6304347826087, 1.4333333333333, 0.090909090909091
56718, 0.60869565217391, 1.4166666666667, 0.090909090909091
56719, 0.60869565217391, 1.4333333333333, 0.11363636363636
56720, 0.6304347826087, 1.4333333333333, 0.13636363636364
56721, 0.60869565217391, 1.4166666666667, 0.13636363636364
56722, 0.60869565217391, 1.4333333333333, 0.15909090909091
56723, 0.6304347826087, 1.4333333333333, 0.18181818181818
56724, 0.60869565217391, 1.4166666666667, 0.18181818181818
56725, 0.60869565217391, 1.4333333333333, 0.20454545454545
56726, 0.6304347826087, 1.4333333333333, 0.22727272727273
56727, 0.60869565217391, 1.4166666666667, 0.22727272727273
56728, 0.60869565217391, 1.4333333333333, 0.25
56729, 0.6304347826087, 1.4333333333333, 0.27272727272727
56730, 0.60869565217391, 1.4166666666667, 0.27272727272727
56731, 0.60869565217391, 1.4333333333333, 0.29545454545455
56732, 0.6304347826087, 1.4333333333333, 0.31818181818182
56733, 0.60869565217391, 1.4166666666667, 0.31818181818182
56734, 0.60869565217391, 1.4333333333333, 0.34090909090909
56735, 0.6304347826087, 1.4333333333333, 0.36363636363636
56736, 0.60869565217391, 1.4166666666667, 0.36363636363636
56737, 0.60869565217391, 1.4333333333333, 0.38636363636364
56738, 0.6304347826087, 1.4333333333333, 0.40909090909091
56739, 0.60869565217391, 1.4166666666667, 0.40909090909091
56740, 0.60869565217391, 1.4333333333333, 0.43181818181818
56741, 0.6304347826087, 1.4333333333333, 0.45454545454545
56742, 0.60869565217391, 1.4166666666667, 0.45454545454545
56743, 0.60869565217391, 1.4333333333333, 0.47727272727273
56744, 0.56521739130435, 1.4333333333333, 0.022727272727273
56745, 0.58695652173913, 1.4333333333333, 0.045454545454545
56746, 0.56521739130435, 1.4166666666667, 0.045454545454545
56747, 0.56521739130435, 1.4333333333333, 0.068181818181818
56748, 0.58695652173913, 1.4333333333333, 0.090909090909091
56749, 0.56521739130435, 1.4166666666667, 0.090909090909091
56750, 0.56521739130435, 1.4333333333333, 0.11363636363636
56751, 0.58695652173913, 1.4333333333333, 0.13636363636364
56752, 0.56521739130435, 1.4166666666667, 0.13636363636364
56753, 0.56521739130435, 1.4333333333333, 0.15909090909091
56754, 0.58695652173913, 1.4333333333333, 0.18181818181818
56755, 0.56521739130435, 1.4166666666667, 0.18181818181818
56756, 0.56521739130435, 1.4333333333333, 0.20454545454545
56757, 0.58695652173913, 1.4333333333333, 0.22727272727273
56758, 0.56521739130435, 1.4166666666667, 0.22727272727273
56759, 0.56521739130435, 1.4333333333333, 0.25
56760, 0.58695652173913, 1.4333333333333, 0.27272727272727
56761, 0.56521739130435, 1.4166666666667, 0.27272727272727
56762, 0.56521739130435, 1.4333333333333, 0.29545454545455
56763, 0.58695652173913, 1.4333333333333, 0.31818181818182
56764, 0.56521739130435, 1.4166666666667, 0.31818181818182
56765, 0.56521739130435, 1.4333333333333, 0.34090909090909
56766, 0.58695652173913, 1.4333333333333, 0.36363636363636
56767, 0.56521739130435, 1.4166666666667, 0.36363636363636
56768, 0.56521739130435, 1.4333333333333, 0.38636363636364
56769, 0.58695652173913, 1.4333333333333, 0.40909090909091
56770, 0.56521739130435, 1.4166666666667, 0.40909090909091
56771, 0.56521739130435, 1.4333333333333, 0.43181818181818
56772, 0.58695652173913, 1.4333333333333, 0.45454545454545
56773, 0.56521739130435, 1.4166666666667, 0.45454545454545
56774, 0.56521739130435, 1.4333333333333, 0.47727272727273
56775, 0.52173913043478, 1.4333333333333, 0.022727272727273
56776, 0.54347826086956, 1.4333333333333, 0.045454545454545
56777, 0.52173913043478, 1.4166666666667, 0.045454545454545
56778, 0.52173913043478, 1.4333333333333, 0.068181818181818
56779, 0.54347826086956, 1.4333333333333, 0.090909090909091
56780, 0.52173913043478, 1.4166666666667, 0.090909090909091
56781, 0.52173913043478, 1.4333333333333, 0.11363636363636
56782, 0.54347826086957, 1.4333333333333, 0.13636363636364
56783, 0.52173913043478, 1.4166666666667, 0.13636363636364
56784, 0.52173913043478, 1.4333333333333, 0.15909090909091
56785, 0.54347826086956, 1.4333333333333, 0.18181818181818
56786, 0.52173913043478, 1.4166666666667, 0.18181818181818
56787, 0.52173913043478, 1.4333333333333, 0.20454545454545
56788, 0.54347826086956, 1.4333333333333, 0.22727272727273
56789, 0.52173913043478, 1.4166666666667, 0.22727272727273
56790, 0.52173913043478, 1.4333333333333, 0.25
56791, 0.54347826086956, 1.4333333333333, 0.27272727272727
56792, 0.52173913043478, 1.4166666666667, 0.27272727272727
56793, 0.52173913043478, 1.4333333333333, 0.29545454545455
56794, 0.54347826086956, 1.4333333333333, 0.31818181818182
56795, 0.52173913043478, 1.4166666666667, 0.31818181818182
56796, 0.52173913043478, 1.4333333333333, 0.34090909090909
56797, 0.54347826086957, 1.4333333333333, 0.36363636363636
56798, 0.52173913043478, 1.4166666666667, 0.36363636363636
56799, 0.52173913043478, 1.4333333333333, 0.38636363636364
56800, 0.54347826086956, 1.4333333333333, 0.40909090909091
56801, 0.52173913043478, 1.4166666666667, 0.40909090909091
56802, 0.52173913043478, 1.4333333333333, 0.43181818181818
56803, 0.54347826086956, 1.4333333333333, 0.45454545454545
56804, 0.52173913043478, 1.4166666666667, 0.45454545454545
56805, 0.52173913043478, 1.4333333333333, 0.47727272727273
56806, 0.47826086956522, 1.4333333333333, 0.022727272727273
56807, 0.5, 1.4333333333333, 0.045454545454545
56808, 0.47826086956522, 1.4166666666667, 0.045454545454545
56809, 0.47826086956522, 1.4333333333333, 0.068181818181818
56810, 0.5, 1.4333333333333, 0.090909090909091
56811, 0.47826086956522, 1.4166666666667, 0.090909090909091
56812, 0.47826086956522, 1.4333333333333, 0.11363636363636
56813, 0.5, 1.4333333333333, 0.13636363636364
56814, 0.47826086956522, 1.4166666666667, 0.13636363636364
56815, 0.47826086956522, 1.4333333333333, 0.15909090909091
56816, 0.5, 1.4333333333333, 0.18181818181818
56817, 0.47826086956522, 1.4166666666667, 0.18181818181818
56818, 0.47826086956522, 1.4333333333333, 0.20454545454545
56819, 0.5, 1.4333333333333, 0.22727272727273
56820, 0.47826086956522, 1.4166666666667, 0.22727272727273
56821, 0.47826086956522, 1.4333333333333, 0.25
56822, 0.5, 1.4333333333333, 0.27272727272727
56823, 0.47826086956522, 1.4166666666667, 0.27272727272727
56824, 0.47826086956522, 1.4333333333333, 0.29545454545455
56825, 0.5, 1.4333333333333, 0.31818181818182
56826, 0.47826086956522, 1.4166666666667, 0.31818181818182
56827, 0.47826086956522, 1.4333333333333, 0.34090909090909
56828, 0.5, 1.4333333333333, 0.36363636363636
56829, 0.47826086956522, 1.4166666666667, 0.36363636363636
56830, 0.47826086956522, 1.4333333333333, 0.38636363636364
56831, 0.5, 1.4333333333333, 0.40909090909091
56832, 0.47826086956522, 1.4166666666667, 0.40909090909091
56833, 0.47826086956522, 1.4333333333333, 0.43181818181818
56834, 0.5, 1.4333333333333, 0.45454545454545
56835, 0.47826086956522, 1.4166666666667, 0.45454545454545
56836, 0.47826086956522, 1.4333333333333, 0.47727272727273
56837, 0.43478260869565, 1.4333333333333, 0.022727272727273
56838, 0.45652173913043, 1.4333333333333, 0.045454545454545
56839, 0.43478260869565, 1.4166666666667, 0.045454545454545
56840, 0.43478260869565, 1.4333333333333, 0.068181818181818
56841, 0.45652173913043, 1.4333333333333, 0.090909090909091
56842, 0.43478260869565, 1.4166666666667, 0.090909090909091
56843, 0.43478260869565, 1.4333333333333, 0.11363636363636
56844, 0.45652173913043, 1.4333333333333, 0.13636363636364
56845, 0.43478260869565, 1.4166666666667, 0.13636363636364
56846, 0.43478260869565, 1.4333333333333, 0.15909090909091
56847, 0.45652173913043, 1.4333333333333, 0.18181818181818
56848, 0.43478260869565, 1.4166666666667, 0.18181818181818
56849, 0.43478260869565, 1.4333333333333, 0.20454545454545
56850, 0.45652173913043, 1.4333333333333, 0.22727272727273
56851, 0.43478260869565, 1.4166666666667, 0.22727272727273
56852, 0.43478260869565, 1.4333333333333, 0.25
56853, 0.45652173913043, 1.4333333333333, 0.27272727272727
56854, 0.43478260869565, 1.4166666666667, 0.27272727272727
56855, 0.43478260869565, 1.4333333333333, 0.29545454545455
56856, 0.45652173913043, 1.4333333333333, 0.31818181818182
56857, 0.43478260869565, 1.4166666666667, 0.31818181818182
56858, 0.43478260869565, 1.4333333333333, 0.34090909090909
56859, 0.45652173913043, 1.4333333333333, 0.36363636363636
56860, 0.43478260869565, 1.4166666666667, 0.36363636363636
56861, 0.43478260869565, 1.4333333333333, 0.38636363636364
56862, 0.45652173913043, 1.4333333333333, 0.40909090909091
56863, 0.43478260869565, 1.4166666666667, 0.40909090909091
56864, 0.43478260869565, 1.4333333333333, 0.43181818181818
56865, 0.45652173913043, 1.4333333333333, 0.45454545454545
56866, 0.43478260869565, 1.4166666666667, 0.45454545454545
56867, 0.43478260869565, 1.4333333333333, 0.47727272727273
56868, 0.39130434782609, 1.4333333333333, 0.022727272727273
56869, 0.41304347826087, 1.4333333333333, 0.045454545454545
56870, 0.39130434782609, 1.4166666666667, 0.045454545454545
56871, 0.39130434782609, 1.4333333333333, 0.068181818181818
56872, 0.41304347826087, 1.4333333333333, 0.090909090909091
56873, 0.39130434782609, 1.4166666666667, 0.090909090909091
56874, 0.39130434782609, 1.4333333333333, 0.11363636363636
56875, 0.41304347826087, 1.4333333333333, 0.13636363636364
56876, 0.39130434782609, 1.4166666666667, 0.13636363636364
56877, 0.39130434782609, 1.4333333333333, 0.15909090909091
56878, 0.41304347826087, 1.4333333333333, 0.18181818181818
56879, 0.39130434782609, 1.4166666666667, 0.18181818181818
56880, 0.39130434782609, 1.4333333333333, 0.20454545454545
56881, 0.41304347826087, 1.4333333333333, 0.22727272727273
56882, 0.39130434782609, 1.4166666666667, 0.22727272727273
56883, 0.39130434782609, 1.4333333333333, 0.25
56884, 0.41304347826087, 1.4333333333333, 0.27272727272727
56885, 0.39130434782609, 1.4166666666667, 0.27272727272727
56886, 0.39130434782609, 1.4333333333333, 0.29545454545455
56887, 0.41304347826087, 1.4333333333333, 0.31818181818182
56888, 0.39130434782609, 1.4166666666667, 0.31818181818182
56889, 0.39130434782609, 1.4333333333333, 0.34090909090909
56890, 0.41304347826087, 1.4333333333333, 0.36363636363636
56891, 0.39130434782609, 1.4166666666667, 0.36363636363636
56892, 0.39130434782609, 1.4333333333333, 0.38636363636364
56893, 0.41304347826087, 1.4333333333333, 0.40909090909091
56894, 0.39130434782609, 1.4166666666667, 0.40909090909091
56895, 0.39130434782609, 1.4333333333333, 0.43181818181818
56896, 0.41304347826087, 1.4333333333333, 0.45454545454545
56897, 0.39130434782609, 1.4166666666667, 0.45454545454545
56898, 0.39130434782609, 1.4333333333333, 0.47727272727273
56899, 0.34782608695652, 1.4333333333333, 0.022727272727273
56900, 0.3695652173913, 1.4333333333333, 0.045454545454545
56901, 0.34782608695652, 1.4166666666667, 0.045454545454545
56902, 0.34782608695652, 1.4333333333333, 0.068181818181818
56903, 0.3695652173913, 1.4333333333333, 0.090909090909091
56904, 0.34782608695652, 1.4166666666667, 0.090909090909091
56905, 0.34782608695652, 1.4333333333333, 0.11363636363636
56906, 0.3695652173913, 1.4333333333333, 0.13636363636364
