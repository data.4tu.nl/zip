71027, 1.7652173913043, 0.98478260869565, 0.022727272727273
71028, 1.8086956521739, 0.98478260869565, 0.47727272727273
71029, 1.7869565217391, 0.98478260869565, 0.45454545454545
71030, 1.8086956521739, 1.0108695652174, 0.45454545454545
71031, 1.8086956521739, 0.98478260869565, 0.43181818181818
71032, 1.7869565217391, 0.98478260869565, 0.40909090909091
71033, 1.8086956521739, 1.0108695652174, 0.40909090909091
71034, 1.8086956521739, 0.98478260869565, 0.38636363636364
71035, 1.7869565217391, 0.98478260869565, 0.36363636363636
71036, 1.8086956521739, 1.0108695652174, 0.36363636363636
71037, 1.8086956521739, 0.98478260869565, 0.34090909090909
71038, 1.7869565217391, 0.98478260869565, 0.31818181818182
71039, 1.8086956521739, 1.0108695652174, 0.31818181818182
71040, 1.8086956521739, 0.98478260869565, 0.29545454545455
71041, 1.7869565217391, 0.98478260869565, 0.27272727272727
71042, 1.8086956521739, 1.0108695652174, 0.27272727272727
71043, 1.8086956521739, 0.98478260869565, 0.25
71044, 1.7869565217391, 0.98478260869565, 0.22727272727273
71045, 1.8086956521739, 1.0108695652174, 0.22727272727273
71046, 1.8086956521739, 0.98478260869565, 0.20454545454545
71047, 1.7869565217391, 0.98478260869565, 0.18181818181818
71048, 1.8086956521739, 1.0108695652174, 0.18181818181818
71049, 1.8086956521739, 0.98478260869565, 0.15909090909091
71050, 1.7869565217391, 0.98478260869565, 0.13636363636364
71051, 1.8086956521739, 1.0108695652174, 0.13636363636364
71052, 1.8086956521739, 0.98478260869565, 0.11363636363636
71053, 1.7869565217391, 0.98478260869565, 0.090909090909091
71054, 1.8086956521739, 1.0108695652174, 0.090909090909091
71055, 1.8086956521739, 0.98478260869565, 0.068181818181818
71056, 1.7869565217391, 0.98478260869565, 0.045454545454545
71057, 1.8086956521739, 1.0108695652174, 0.045454545454545
71058, 1.8086956521739, 0.98478260869565, 0.022727272727273
71059, 1.8521739130435, 0.98478260869565, 0.47727272727273
71060, 1.8304347826087, 0.98478260869565, 0.45454545454545
71061, 1.8521739130435, 1.0108695652174, 0.45454545454545
71062, 1.8521739130435, 0.98478260869565, 0.43181818181818
71063, 1.8304347826087, 0.98478260869565, 0.40909090909091
71064, 1.8521739130435, 1.0108695652174, 0.40909090909091
71065, 1.8521739130435, 0.98478260869565, 0.38636363636364
71066, 1.8304347826087, 0.98478260869565, 0.36363636363636
71067, 1.8521739130435, 1.0108695652174, 0.36363636363636
71068, 1.8521739130435, 0.98478260869565, 0.34090909090909
71069, 1.8304347826087, 0.98478260869565, 0.31818181818182
71070, 1.8521739130435, 1.0108695652174, 0.31818181818182
71071, 1.8521739130435, 0.98478260869565, 0.29545454545455
71072, 1.8304347826087, 0.98478260869565, 0.27272727272727
71073, 1.8521739130435, 1.0108695652174, 0.27272727272727
71074, 1.8521739130435, 0.98478260869565, 0.25
71075, 1.8304347826087, 0.98478260869565, 0.22727272727273
71076, 1.8521739130435, 1.0108695652174, 0.22727272727273
71077, 1.8521739130435, 0.98478260869565, 0.20454545454545
71078, 1.8304347826087, 0.98478260869565, 0.18181818181818
71079, 1.8521739130435, 1.0108695652174, 0.18181818181818
71080, 1.8521739130435, 0.98478260869565, 0.15909090909091
71081, 1.8304347826087, 0.98478260869565, 0.13636363636364
71082, 1.8521739130435, 1.0108695652174, 0.13636363636364
71083, 1.8521739130435, 0.98478260869565, 0.11363636363636
71084, 1.8304347826087, 0.98478260869565, 0.090909090909091
71085, 1.8521739130435, 1.0108695652174, 0.090909090909091
71086, 1.8521739130435, 0.98478260869565, 0.068181818181818
71087, 1.8304347826087, 0.98478260869565, 0.045454545454545
71088, 1.8521739130435, 1.0108695652174, 0.045454545454545
71089, 1.8521739130435, 0.98478260869565, 0.022727272727273
71090, 1.895652173913, 0.98478260869565, 0.47727272727273
71091, 1.8739130434783, 0.98478260869565, 0.45454545454545
71092, 1.895652173913, 1.0108695652174, 0.45454545454545
71093, 1.895652173913, 0.98478260869565, 0.43181818181818
71094, 1.8739130434783, 0.98478260869565, 0.40909090909091
71095, 1.895652173913, 1.0108695652174, 0.40909090909091
71096, 1.895652173913, 0.98478260869565, 0.38636363636364
71097, 1.8739130434783, 0.98478260869565, 0.36363636363636
71098, 1.895652173913, 1.0108695652174, 0.36363636363636
71099, 1.895652173913, 0.98478260869565, 0.34090909090909
71100, 1.8739130434783, 0.98478260869565, 0.31818181818182
71101, 1.895652173913, 1.0108695652174, 0.31818181818182
71102, 1.895652173913, 0.98478260869565, 0.29545454545455
71103, 1.8739130434783, 0.98478260869565, 0.27272727272727
71104, 1.895652173913, 1.0108695652174, 0.27272727272727
71105, 1.895652173913, 0.98478260869565, 0.25
71106, 1.8739130434783, 0.98478260869565, 0.22727272727273
71107, 1.895652173913, 1.0108695652174, 0.22727272727273
71108, 1.895652173913, 0.98478260869565, 0.20454545454545
71109, 1.8739130434783, 0.98478260869565, 0.18181818181818
71110, 1.895652173913, 1.0108695652174, 0.18181818181818
71111, 1.895652173913, 0.98478260869565, 0.15909090909091
71112, 1.8739130434783, 0.98478260869565, 0.13636363636364
71113, 1.895652173913, 1.0108695652174, 0.13636363636364
71114, 1.895652173913, 0.98478260869565, 0.11363636363636
71115, 1.8739130434783, 0.98478260869565, 0.090909090909091
71116, 1.895652173913, 1.0108695652174, 0.090909090909091
71117, 1.895652173913, 0.98478260869565, 0.068181818181818
71118, 1.8739130434783, 0.98478260869565, 0.045454545454545
71119, 1.895652173913, 1.0108695652174, 0.045454545454545
71120, 1.895652173913, 0.98478260869565, 0.022727272727273
71121, 1.9391304347826, 0.98478260869565, 0.47727272727273
71122, 1.9173913043478, 0.98478260869565, 0.45454545454545
71123, 1.9391304347826, 1.0108695652174, 0.45454545454545
71124, 1.9391304347826, 0.98478260869565, 0.43181818181818
71125, 1.9173913043478, 0.98478260869565, 0.40909090909091
71126, 1.9391304347826, 1.0108695652174, 0.40909090909091
71127, 1.9391304347826, 0.98478260869565, 0.38636363636364
71128, 1.9173913043478, 0.98478260869565, 0.36363636363636
71129, 1.9391304347826, 1.0108695652174, 0.36363636363636
71130, 1.9391304347826, 0.98478260869565, 0.34090909090909
71131, 1.9173913043478, 0.98478260869565, 0.31818181818182
71132, 1.9391304347826, 1.0108695652174, 0.31818181818182
71133, 1.9391304347826, 0.98478260869565, 0.29545454545455
71134, 1.9173913043478, 0.98478260869565, 0.27272727272727
71135, 1.9391304347826, 1.0108695652174, 0.27272727272727
71136, 1.9391304347826, 0.98478260869565, 0.25
71137, 1.9173913043478, 0.98478260869565, 0.22727272727273
71138, 1.9391304347826, 1.0108695652174, 0.22727272727273
71139, 1.9391304347826, 0.98478260869565, 0.20454545454545
71140, 1.9173913043478, 0.98478260869565, 0.18181818181818
71141, 1.9391304347826, 1.0108695652174, 0.18181818181818
71142, 1.9391304347826, 0.98478260869565, 0.15909090909091
71143, 1.9173913043478, 0.98478260869565, 0.13636363636364
71144, 1.9391304347826, 1.0108695652174, 0.13636363636364
71145, 1.9391304347826, 0.98478260869565, 0.11363636363636
71146, 1.9173913043478, 0.98478260869565, 0.090909090909091
71147, 1.9391304347826, 1.0108695652174, 0.090909090909091
71148, 1.9391304347826, 0.98478260869565, 0.068181818181818
71149, 1.9173913043478, 0.98478260869565, 0.045454545454545
71150, 1.9391304347826, 1.0108695652174, 0.045454545454545
71151, 1.9391304347826, 0.98478260869565, 0.022727272727273
71152, 1.9826086956522, 0.98478260869565, 0.47727272727273
71153, 1.9608695652174, 0.98478260869565, 0.45454545454545
71154, 1.9826086956522, 1.0108695652174, 0.45454545454545
71155, 1.9826086956522, 0.98478260869565, 0.43181818181818
71156, 1.9608695652174, 0.98478260869565, 0.40909090909091
71157, 1.9826086956522, 1.0108695652174, 0.40909090909091
71158, 1.9826086956522, 0.98478260869565, 0.38636363636364
71159, 1.9608695652174, 0.98478260869565, 0.36363636363636
71160, 1.9826086956522, 1.0108695652174, 0.36363636363636
71161, 1.9826086956522, 0.98478260869565, 0.34090909090909
71162, 1.9608695652174, 0.98478260869565, 0.31818181818182
71163, 1.9826086956522, 1.0108695652174, 0.31818181818182
71164, 1.9826086956522, 0.98478260869565, 0.29545454545455
71165, 1.9608695652174, 0.98478260869565, 0.27272727272727
71166, 1.9826086956522, 1.0108695652174, 0.27272727272727
71167, 1.9826086956522, 0.98478260869565, 0.25
71168, 1.9608695652174, 0.98478260869565, 0.22727272727273
71169, 1.9826086956522, 1.0108695652174, 0.22727272727273
71170, 1.9826086956522, 0.98478260869565, 0.20454545454545
71171, 1.9608695652174, 0.98478260869565, 0.18181818181818
71172, 1.9826086956522, 1.0108695652174, 0.18181818181818
71173, 1.9826086956522, 0.98478260869565, 0.15909090909091
71174, 1.9608695652174, 0.98478260869565, 0.13636363636364
71175, 1.9826086956522, 1.0108695652174, 0.13636363636364
71176, 1.9826086956522, 0.98478260869565, 0.11363636363636
71177, 1.9608695652174, 0.98478260869565, 0.090909090909091
71178, 1.9826086956522, 1.0108695652174, 0.090909090909091
71179, 1.9826086956522, 0.98478260869565, 0.068181818181818
71180, 1.9608695652174, 0.98478260869565, 0.045454545454545
71181, 1.9826086956522, 1.0108695652174, 0.045454545454545
71182, 1.9826086956522, 0.98478260869565, 0.022727272727273
71183, 2.0260869565217, 0.98478260869565, 0.47727272727273
71184, 2.004347826087, 0.98478260869565, 0.45454545454545
71185, 2.0260869565217, 1.0108695652174, 0.45454545454545
71186, 2.0260869565217, 0.98478260869565, 0.43181818181818
71187, 2.004347826087, 0.98478260869565, 0.40909090909091
71188, 2.0260869565217, 1.0108695652174, 0.40909090909091
71189, 2.0260869565217, 0.98478260869565, 0.38636363636364
71190, 2.004347826087, 0.98478260869565, 0.36363636363636
71191, 2.0260869565217, 1.0108695652174, 0.36363636363636
71192, 2.0260869565217, 0.98478260869565, 0.34090909090909
71193, 2.004347826087, 0.98478260869565, 0.31818181818182
71194, 2.0260869565217, 1.0108695652174, 0.31818181818182
71195, 2.0260869565217, 0.98478260869565, 0.29545454545455
71196, 2.004347826087, 0.98478260869565, 0.27272727272727
71197, 2.0260869565217, 1.0108695652174, 0.27272727272727
71198, 2.0260869565217, 0.98478260869565, 0.25
71199, 2.004347826087, 0.98478260869565, 0.22727272727273
71200, 2.0260869565217, 1.0108695652174, 0.22727272727273
71201, 2.0260869565217, 0.98478260869565, 0.20454545454545
71202, 2.004347826087, 0.98478260869565, 0.18181818181818
71203, 2.0260869565217, 1.0108695652174, 0.18181818181818
71204, 2.0260869565217, 0.98478260869565, 0.15909090909091
71205, 2.004347826087, 0.98478260869565, 0.13636363636364
71206, 2.0260869565217, 1.0108695652174, 0.13636363636364
71207, 2.0260869565217, 0.98478260869565, 0.11363636363636
71208, 2.004347826087, 0.98478260869565, 0.090909090909091
71209, 2.0260869565217, 1.0108695652174, 0.090909090909091
71210, 2.0260869565217, 0.98478260869565, 0.068181818181818
71211, 2.004347826087, 0.98478260869565, 0.045454545454545
71212, 2.0260869565217, 1.0108695652174, 0.045454545454545
71213, 2.0260869565217, 0.98478260869565, 0.022727272727273
71214, 2.0695652173913, 0.98478260869565, 0.47727272727273
71215, 2.0478260869565, 0.98478260869565, 0.45454545454545
71216, 2.0695652173913, 1.0108695652174, 0.45454545454545
71217, 2.0695652173913, 0.98478260869565, 0.43181818181818
71218, 2.0478260869565, 0.98478260869565, 0.40909090909091
71219, 2.0695652173913, 1.0108695652174, 0.40909090909091
71220, 2.0695652173913, 0.98478260869565, 0.38636363636364
71221, 2.0478260869565, 0.98478260869565, 0.36363636363636
71222, 2.0695652173913, 1.0108695652174, 0.36363636363636
71223, 2.0695652173913, 0.98478260869565, 0.34090909090909
71224, 2.0478260869565, 0.98478260869565, 0.31818181818182
71225, 2.0695652173913, 1.0108695652174, 0.31818181818182
71226, 2.0695652173913, 0.98478260869565, 0.29545454545455
71227, 2.0478260869565, 0.98478260869565, 0.27272727272727
71228, 2.0695652173913, 1.0108695652174, 0.27272727272727
71229, 2.0695652173913, 0.98478260869565, 0.25
71230, 2.0478260869565, 0.98478260869565, 0.22727272727273
71231, 2.0695652173913, 1.0108695652174, 0.22727272727273
71232, 2.0695652173913, 0.98478260869565, 0.20454545454545
71233, 2.0478260869565, 0.98478260869565, 0.18181818181818
71234, 2.0695652173913, 1.0108695652174, 0.18181818181818
71235, 2.0695652173913, 0.98478260869565, 0.15909090909091
71236, 2.0478260869565, 0.98478260869565, 0.13636363636364
71237, 2.0695652173913, 1.0108695652174, 0.13636363636364
71238, 2.0695652173913, 0.98478260869565, 0.11363636363636
71239, 2.0478260869565, 0.98478260869565, 0.090909090909091
71240, 2.0695652173913, 1.0108695652174, 0.090909090909091
71241, 2.0695652173913, 0.98478260869565, 0.068181818181818
71242, 2.0478260869565, 0.98478260869565, 0.045454545454545
71243, 2.0695652173913, 1.0108695652174, 0.045454545454545
71244, 2.0695652173913, 0.98478260869565, 0.022727272727273
71245, 2.1130434782609, 0.98478260869565, 0.47727272727273
71246, 2.0913043478261, 0.98478260869565, 0.45454545454545
71247, 2.1130434782609, 1.0108695652174, 0.45454545454545
71248, 2.1130434782609, 0.98478260869565, 0.43181818181818
71249, 2.0913043478261, 0.98478260869565, 0.40909090909091
71250, 2.1130434782609, 1.0108695652174, 0.40909090909091
71251, 2.1130434782609, 0.98478260869565, 0.38636363636364
71252, 2.0913043478261, 0.98478260869565, 0.36363636363636
71253, 2.1130434782609, 1.0108695652174, 0.36363636363636
71254, 2.1130434782609, 0.98478260869565, 0.34090909090909
71255, 2.0913043478261, 0.98478260869565, 0.31818181818182
71256, 2.1130434782609, 1.0108695652174, 0.31818181818182
71257, 2.1130434782609, 0.98478260869565, 0.29545454545455
71258, 2.0913043478261, 0.98478260869565, 0.27272727272727
71259, 2.1130434782609, 1.0108695652174, 0.27272727272727
71260, 2.1130434782609, 0.98478260869565, 0.25
71261, 2.0913043478261, 0.98478260869565, 0.22727272727273
71262, 2.1130434782609, 1.0108695652174, 0.22727272727273
71263, 2.1130434782609, 0.98478260869565, 0.20454545454545
71264, 2.0913043478261, 0.98478260869565, 0.18181818181818
71265, 2.1130434782609, 1.0108695652174, 0.18181818181818
71266, 2.1130434782609, 0.98478260869565, 0.15909090909091
71267, 2.0913043478261, 0.98478260869565, 0.13636363636364
71268, 2.1130434782609, 1.0108695652174, 0.13636363636364
71269, 2.1130434782609, 0.98478260869565, 0.11363636363636
71270, 2.0913043478261, 0.98478260869565, 0.090909090909091
71271, 2.1130434782609, 1.0108695652174, 0.090909090909091
71272, 2.1130434782609, 0.98478260869565, 0.068181818181818
71273, 2.0913043478261, 0.98478260869565, 0.045454545454545
71274, 2.1130434782609, 1.0108695652174, 0.045454545454545
71275, 2.1130434782609, 0.98478260869565, 0.022727272727273
71276, 2.1565217391304, 0.98478260869565, 0.47727272727273
71277, 2.1347826086957, 0.98478260869565, 0.45454545454545
71278, 2.1565217391304, 1.0108695652174, 0.45454545454545
71279, 2.1565217391304, 0.98478260869565, 0.43181818181818
71280, 2.1347826086957, 0.98478260869565, 0.40909090909091
71281, 2.1565217391304, 1.0108695652174, 0.40909090909091
71282, 2.1565217391304, 0.98478260869565, 0.38636363636364
71283, 2.1347826086957, 0.98478260869565, 0.36363636363636
71284, 2.1565217391304, 1.0108695652174, 0.36363636363636
71285, 2.1565217391304, 0.98478260869565, 0.34090909090909
71286, 2.1347826086957, 0.98478260869565, 0.31818181818182
71287, 2.1565217391304, 1.0108695652174, 0.31818181818182
71288, 2.1565217391304, 0.98478260869565, 0.29545454545455
71289, 2.1347826086957, 0.98478260869565, 0.27272727272727
71290, 2.1565217391304, 1.0108695652174, 0.27272727272727
71291, 2.1565217391304, 0.98478260869565, 0.25
71292, 2.1347826086957, 0.98478260869565, 0.22727272727273
71293, 2.1565217391304, 1.0108695652174, 0.22727272727273
71294, 2.1565217391304, 0.98478260869565, 0.20454545454545
71295, 2.1347826086957, 0.98478260869565, 0.18181818181818
71296, 2.1565217391304, 1.0108695652174, 0.18181818181818
71297, 2.1565217391304, 0.98478260869565, 0.15909090909091
71298, 2.1347826086957, 0.98478260869565, 0.13636363636364
71299, 2.1565217391304, 1.0108695652174, 0.13636363636364
71300, 2.1565217391304, 0.98478260869565, 0.11363636363636
71301, 2.1347826086957, 0.98478260869565, 0.090909090909091
71302, 2.1565217391304, 1.0108695652174, 0.090909090909091
71303, 2.1565217391304, 0.98478260869565, 0.068181818181818
71304, 2.1347826086957, 0.98478260869565, 0.045454545454545
71305, 2.1565217391304, 1.0108695652174, 0.045454545454545
71306, 2.1565217391304, 0.98478260869565, 0.022727272727273
71307, 2.1782608695652, 0.98478260869565, 0.45454545454545
71308, 2.1782608695652, 0.98478260869565, 0.40909090909091
71309, 2.1782608695652, 0.98478260869565, 0.36363636363636
71310, 2.1782608695652, 0.98478260869565, 0.31818181818182
71311, 2.1782608695652, 0.98478260869565, 0.27272727272727
71312, 2.1782608695652, 0.98478260869565, 0.22727272727273
71313, 2.1782608695652, 0.98478260869565, 0.18181818181818
71314, 2.1782608695652, 0.98478260869565, 0.13636363636364
71315, 2.1782608695652, 0.98478260869565, 0.090909090909091
71316, 2.1782608695652, 0.98478260869565, 0.045454545454545
71317, 1.2434782608696, 0.93260869565217, 0.47727272727273
71318, 1.2217391304348, 0.93260869565217, 0.45454545454545
71319, 1.2434782608696, 0.95869565217391, 0.45454545454545
71320, 1.2434782608696, 0.93260869565217, 0.43181818181818
71321, 1.2217391304348, 0.93260869565217, 0.40909090909091
71322, 1.2434782608696, 0.95869565217391, 0.40909090909091
71323, 1.2434782608696, 0.93260869565217, 0.38636363636364
71324, 1.2217391304348, 0.93260869565217, 0.36363636363636
71325, 1.2434782608696, 0.95869565217391, 0.36363636363636
71326, 1.2434782608696, 0.93260869565217, 0.34090909090909
71327, 1.2217391304348, 0.93260869565217, 0.31818181818182
71328, 1.2434782608696, 0.95869565217391, 0.31818181818182
71329, 1.2434782608696, 0.93260869565217, 0.29545454545455
71330, 1.2217391304348, 0.93260869565217, 0.27272727272727
71331, 1.2434782608696, 0.95869565217391, 0.27272727272727
71332, 1.2434782608696, 0.93260869565217, 0.25
71333, 1.2217391304348, 0.93260869565217, 0.22727272727273
71334, 1.2434782608696, 0.95869565217391, 0.22727272727273
71335, 1.2434782608696, 0.93260869565217, 0.20454545454545
71336, 1.2217391304348, 0.93260869565217, 0.18181818181818
71337, 1.2434782608696, 0.95869565217391, 0.18181818181818
71338, 1.2434782608696, 0.93260869565217, 0.15909090909091
71339, 1.2217391304348, 0.93260869565217, 0.13636363636364
71340, 1.2434782608696, 0.95869565217391, 0.13636363636364
71341, 1.2434782608696, 0.93260869565217, 0.11363636363636
71342, 1.2217391304348, 0.93260869565217, 0.090909090909091
71343, 1.2434782608696, 0.95869565217391, 0.090909090909091
71344, 1.2434782608696, 0.93260869565217, 0.068181818181818
71345, 1.2217391304348, 0.93260869565217, 0.045454545454545
71346, 1.2434782608696, 0.95869565217391, 0.045454545454545
71347, 1.2434782608696, 0.93260869565217, 0.022727272727273
71348, 1.2869565217391, 0.93260869565217, 0.47727272727273
71349, 1.2652173913043, 0.93260869565217, 0.45454545454545
71350, 1.2869565217391, 0.95869565217391, 0.45454545454545
71351, 1.2869565217391, 0.93260869565217, 0.43181818181818
71352, 1.2652173913043, 0.93260869565217, 0.40909090909091
71353, 1.2869565217391, 0.95869565217391, 0.40909090909091
71354, 1.2869565217391, 0.93260869565217, 0.38636363636364
71355, 1.2652173913043, 0.93260869565217, 0.36363636363636
71356, 1.2869565217391, 0.95869565217391, 0.36363636363636
71357, 1.2869565217391, 0.93260869565217, 0.34090909090909
71358, 1.2652173913043, 0.93260869565217, 0.31818181818182
71359, 1.2869565217391, 0.95869565217391, 0.31818181818182
71360, 1.2869565217391, 0.93260869565217, 0.29545454545455
71361, 1.2652173913043, 0.93260869565217, 0.27272727272727
71362, 1.2869565217391, 0.95869565217391, 0.27272727272727
71363, 1.2869565217391, 0.93260869565217, 0.25
71364, 1.2652173913043, 0.93260869565217, 0.22727272727273
71365, 1.2869565217391, 0.95869565217391, 0.22727272727273
71366, 1.2869565217391, 0.93260869565217, 0.20454545454545
71367, 1.2652173913043, 0.93260869565217, 0.18181818181818
71368, 1.2869565217391, 0.95869565217391, 0.18181818181818
71369, 1.2869565217391, 0.93260869565217, 0.15909090909091
71370, 1.2652173913043, 0.93260869565217, 0.13636363636364
71371, 1.2869565217391, 0.95869565217391, 0.13636363636364
71372, 1.2869565217391, 0.93260869565217, 0.11363636363636
71373, 1.2652173913043, 0.93260869565217, 0.090909090909091
71374, 1.2869565217391, 0.95869565217391, 0.090909090909091
71375, 1.2869565217391, 0.93260869565217, 0.068181818181818
71376, 1.2652173913043, 0.93260869565217, 0.045454545454545
71377, 1.2869565217391, 0.95869565217391, 0.045454545454545
71378, 1.2869565217391, 0.93260869565217, 0.022727272727273
71379, 1.3304347826087, 0.93260869565217, 0.47727272727273
71380, 1.3086956521739, 0.93260869565217, 0.45454545454545
71381, 1.3304347826087, 0.95869565217391, 0.45454545454545
71382, 1.3304347826087, 0.93260869565217, 0.43181818181818
71383, 1.3086956521739, 0.93260869565217, 0.40909090909091
71384, 1.3304347826087, 0.95869565217391, 0.40909090909091
71385, 1.3304347826087, 0.93260869565217, 0.38636363636364
71386, 1.3086956521739, 0.93260869565217, 0.36363636363636
71387, 1.3304347826087, 0.95869565217391, 0.36363636363636
71388, 1.3304347826087, 0.93260869565217, 0.34090909090909
71389, 1.3086956521739, 0.93260869565218, 0.31818181818182
71390, 1.3304347826087, 0.95869565217391, 0.31818181818182
71391, 1.3304347826087, 0.93260869565217, 0.29545454545455
71392, 1.3086956521739, 0.93260869565217, 0.27272727272727
71393, 1.3304347826087, 0.95869565217391, 0.27272727272727
71394, 1.3304347826087, 0.93260869565217, 0.25
71395, 1.3086956521739, 0.93260869565217, 0.22727272727273
71396, 1.3304347826087, 0.95869565217391, 0.22727272727273
71397, 1.3304347826087, 0.93260869565217, 0.20454545454545
71398, 1.3086956521739, 0.93260869565217, 0.18181818181818
71399, 1.3304347826087, 0.95869565217391, 0.18181818181818
71400, 1.3304347826087, 0.93260869565217, 0.15909090909091
71401, 1.3086956521739, 0.93260869565217, 0.13636363636364
71402, 1.3304347826087, 0.95869565217391, 0.13636363636364
71403, 1.3304347826087, 0.93260869565217, 0.11363636363636
71404, 1.3086956521739, 0.93260869565217, 0.090909090909091
71405, 1.3304347826087, 0.95869565217391, 0.090909090909091
71406, 1.3304347826087, 0.93260869565217, 0.068181818181818
71407, 1.3086956521739, 0.93260869565217, 0.045454545454545
71408, 1.3304347826087, 0.95869565217391, 0.045454545454545
71409, 1.3304347826087, 0.93260869565217, 0.022727272727273
71410, 1.3739130434783, 0.93260869565217, 0.47727272727273
71411, 1.3521739130435, 0.93260869565217, 0.45454545454545
71412, 1.3739130434783, 0.95869565217391, 0.45454545454545
71413, 1.3739130434783, 0.93260869565217, 0.43181818181818
71414, 1.3521739130435, 0.93260869565217, 0.40909090909091
71415, 1.3739130434783, 0.95869565217391, 0.40909090909091
71416, 1.3739130434783, 0.93260869565217, 0.38636363636364
71417, 1.3521739130435, 0.93260869565217, 0.36363636363636
71418, 1.3739130434783, 0.95869565217391, 0.36363636363636
71419, 1.3739130434783, 0.93260869565217, 0.34090909090909
71420, 1.3521739130435, 0.93260869565217, 0.31818181818182
71421, 1.3739130434783, 0.95869565217391, 0.31818181818182
71422, 1.3739130434783, 0.93260869565217, 0.29545454545455
71423, 1.3521739130435, 0.93260869565217, 0.27272727272727
71424, 1.3739130434783, 0.95869565217391, 0.27272727272727
71425, 1.3739130434783, 0.93260869565217, 0.25
71426, 1.3521739130435, 0.93260869565217, 0.22727272727273
71427, 1.3739130434783, 0.95869565217391, 0.22727272727273
71428, 1.3739130434783, 0.93260869565217, 0.20454545454545
71429, 1.3521739130435, 0.93260869565217, 0.18181818181818
71430, 1.3739130434783, 0.95869565217391, 0.18181818181818
71431, 1.3739130434783, 0.93260869565217, 0.15909090909091
71432, 1.3521739130435, 0.93260869565217, 0.13636363636364
71433, 1.3739130434783, 0.95869565217391, 0.13636363636364
71434, 1.3739130434783, 0.93260869565217, 0.11363636363636
71435, 1.3521739130435, 0.93260869565217, 0.090909090909091
71436, 1.3739130434783, 0.95869565217391, 0.090909090909091
71437, 1.3739130434783, 0.93260869565217, 0.068181818181818
71438, 1.3521739130435, 0.93260869565217, 0.045454545454545
71439, 1.3739130434783, 0.95869565217391, 0.045454545454545
71440, 1.3739130434783, 0.93260869565217, 0.022727272727273
71441, 1.4173913043478, 0.93260869565217, 0.47727272727273
71442, 1.395652173913, 0.93260869565217, 0.45454545454545
71443, 1.4173913043478, 0.95869565217391, 0.45454545454545
71444, 1.4173913043478, 0.93260869565217, 0.43181818181818
71445, 1.395652173913, 0.93260869565217, 0.40909090909091
71446, 1.4173913043478, 0.95869565217391, 0.40909090909091
71447, 1.4173913043478, 0.93260869565217, 0.38636363636364
71448, 1.395652173913, 0.93260869565217, 0.36363636363636
71449, 1.4173913043478, 0.95869565217391, 0.36363636363636
71450, 1.4173913043478, 0.93260869565217, 0.34090909090909
71451, 1.395652173913, 0.93260869565217, 0.31818181818182
71452, 1.4173913043478, 0.95869565217391, 0.31818181818182
71453, 1.4173913043478, 0.93260869565217, 0.29545454545455
71454, 1.395652173913, 0.93260869565217, 0.27272727272727
71455, 1.4173913043478, 0.95869565217391, 0.27272727272727
71456, 1.4173913043478, 0.93260869565217, 0.25
71457, 1.395652173913, 0.93260869565217, 0.22727272727273
71458, 1.4173913043478, 0.95869565217391, 0.22727272727273
71459, 1.4173913043478, 0.93260869565217, 0.20454545454545
71460, 1.395652173913, 0.93260869565217, 0.18181818181818
71461, 1.4173913043478, 0.95869565217391, 0.18181818181818
71462, 1.4173913043478, 0.93260869565217, 0.15909090909091
71463, 1.395652173913, 0.93260869565217, 0.13636363636364
71464, 1.4173913043478, 0.95869565217391, 0.13636363636364
71465, 1.4173913043478, 0.93260869565217, 0.11363636363636
71466, 1.395652173913, 0.93260869565217, 0.090909090909091
71467, 1.4173913043478, 0.95869565217391, 0.090909090909091
71468, 1.4173913043478, 0.93260869565217, 0.068181818181818
71469, 1.395652173913, 0.93260869565217, 0.045454545454545
71470, 1.4173913043478, 0.95869565217391, 0.045454545454545
71471, 1.4173913043478, 0.93260869565217, 0.022727272727273
71472, 1.4608695652174, 0.93260869565217, 0.47727272727273
71473, 1.4391304347826, 0.93260869565217, 0.45454545454545
71474, 1.4608695652174, 0.95869565217391, 0.45454545454545
71475, 1.4608695652174, 0.93260869565217, 0.43181818181818
71476, 1.4391304347826, 0.93260869565217, 0.40909090909091
71477, 1.4608695652174, 0.95869565217391, 0.40909090909091
71478, 1.4608695652174, 0.93260869565217, 0.38636363636364
71479, 1.4391304347826, 0.93260869565217, 0.36363636363636
71480, 1.4608695652174, 0.95869565217391, 0.36363636363636
71481, 1.4608695652174, 0.93260869565217, 0.34090909090909
71482, 1.4391304347826, 0.93260869565217, 0.31818181818182
71483, 1.4608695652174, 0.95869565217391, 0.31818181818182
71484, 1.4608695652174, 0.93260869565217, 0.29545454545455
71485, 1.4391304347826, 0.93260869565217, 0.27272727272727
71486, 1.4608695652174, 0.95869565217391, 0.27272727272727
71487, 1.4608695652174, 0.93260869565217, 0.25
71488, 1.4391304347826, 0.93260869565217, 0.22727272727273
71489, 1.4608695652174, 0.95869565217391, 0.22727272727273
71490, 1.4608695652174, 0.93260869565217, 0.20454545454545
71491, 1.4391304347826, 0.93260869565217, 0.18181818181818
71492, 1.4608695652174, 0.95869565217391, 0.18181818181818
71493, 1.4608695652174, 0.93260869565217, 0.15909090909091
71494, 1.4391304347826, 0.93260869565217, 0.13636363636364
71495, 1.4608695652174, 0.95869565217391, 0.13636363636364
71496, 1.4608695652174, 0.93260869565217, 0.11363636363636
71497, 1.4391304347826, 0.93260869565217, 0.090909090909091
71498, 1.4608695652174, 0.95869565217391, 0.090909090909091
71499, 1.4608695652174, 0.93260869565217, 0.068181818181818
71500, 1.4391304347826, 0.93260869565217, 0.045454545454545
71501, 1.4608695652174, 0.95869565217391, 0.045454545454545
71502, 1.4608695652174, 0.93260869565217, 0.022727272727273
71503, 1.504347826087, 0.93260869565217, 0.47727272727273
71504, 1.4826086956522, 0.93260869565217, 0.45454545454545
71505, 1.504347826087, 0.95869565217391, 0.45454545454545
71506, 1.504347826087, 0.93260869565217, 0.43181818181818
71507, 1.4826086956522, 0.93260869565217, 0.40909090909091
71508, 1.504347826087, 0.95869565217391, 0.40909090909091
71509, 1.504347826087, 0.93260869565217, 0.38636363636364
71510, 1.4826086956522, 0.93260869565217, 0.36363636363636
71511, 1.504347826087, 0.95869565217391, 0.36363636363636
71512, 1.504347826087, 0.93260869565217, 0.34090909090909
71513, 1.4826086956522, 0.93260869565217, 0.31818181818182
71514, 1.504347826087, 0.95869565217391, 0.31818181818182
71515, 1.504347826087, 0.93260869565217, 0.29545454545455
71516, 1.4826086956522, 0.93260869565217, 0.27272727272727
71517, 1.504347826087, 0.95869565217391, 0.27272727272727
71518, 1.504347826087, 0.93260869565217, 0.25
71519, 1.4826086956522, 0.93260869565217, 0.22727272727273
71520, 1.504347826087, 0.95869565217391, 0.22727272727273
71521, 1.504347826087, 0.93260869565217, 0.20454545454545
71522, 1.4826086956522, 0.93260869565217, 0.18181818181818
71523, 1.504347826087, 0.95869565217391, 0.18181818181818
71524, 1.504347826087, 0.93260869565217, 0.15909090909091
71525, 1.4826086956522, 0.93260869565217, 0.13636363636364
71526, 1.504347826087, 0.95869565217391, 0.13636363636364
71527, 1.504347826087, 0.93260869565217, 0.11363636363636
71528, 1.4826086956522, 0.93260869565217, 0.090909090909091
71529, 1.504347826087, 0.95869565217391, 0.090909090909091
71530, 1.504347826087, 0.93260869565217, 0.068181818181818
71531, 1.4826086956522, 0.93260869565217, 0.045454545454545
71532, 1.504347826087, 0.95869565217391, 0.045454545454545
71533, 1.504347826087, 0.93260869565217, 0.022727272727273
71534, 1.5478260869565, 0.93260869565217, 0.47727272727273
71535, 1.5260869565217, 0.93260869565217, 0.45454545454545
71536, 1.5478260869565, 0.95869565217391, 0.45454545454545
71537, 1.5478260869565, 0.93260869565217, 0.43181818181818
71538, 1.5260869565217, 0.93260869565217, 0.40909090909091
71539, 1.5478260869565, 0.95869565217391, 0.40909090909091
71540, 1.5478260869565, 0.93260869565217, 0.38636363636364
71541, 1.5260869565217, 0.93260869565217, 0.36363636363636
71542, 1.5478260869565, 0.95869565217391, 0.36363636363636
71543, 1.5478260869565, 0.93260869565217, 0.34090909090909
71544, 1.5260869565217, 0.93260869565217, 0.31818181818182
71545, 1.5478260869565, 0.95869565217391, 0.31818181818182
71546, 1.5478260869565, 0.93260869565217, 0.29545454545455
71547, 1.5260869565217, 0.93260869565217, 0.27272727272727
71548, 1.5478260869565, 0.95869565217391, 0.27272727272727
71549, 1.5478260869565, 0.93260869565217, 0.25
71550, 1.5260869565217, 0.93260869565217, 0.22727272727273
71551, 1.5478260869565, 0.95869565217391, 0.22727272727273
71552, 1.5478260869565, 0.93260869565217, 0.20454545454545
71553, 1.5260869565217, 0.93260869565217, 0.18181818181818
71554, 1.5478260869565, 0.95869565217391, 0.18181818181818
71555, 1.5478260869565, 0.93260869565217, 0.15909090909091
71556, 1.5260869565217, 0.93260869565217, 0.13636363636364
71557, 1.5478260869565, 0.95869565217391, 0.13636363636364
71558, 1.5478260869565, 0.93260869565217, 0.11363636363636
71559, 1.5260869565217, 0.93260869565217, 0.090909090909091
71560, 1.5478260869565, 0.95869565217391, 0.090909090909091
71561, 1.5478260869565, 0.93260869565217, 0.068181818181818
71562, 1.5260869565217, 0.93260869565217, 0.045454545454545
71563, 1.5478260869565, 0.95869565217391, 0.045454545454545
71564, 1.5478260869565, 0.93260869565217, 0.022727272727273
71565, 1.5913043478261, 0.93260869565217, 0.47727272727273
71566, 1.5695652173913, 0.93260869565217, 0.45454545454545
71567, 1.5913043478261, 0.95869565217391, 0.45454545454545
71568, 1.5913043478261, 0.93260869565217, 0.43181818181818
71569, 1.5695652173913, 0.93260869565217, 0.40909090909091
71570, 1.5913043478261, 0.95869565217391, 0.40909090909091
71571, 1.5913043478261, 0.93260869565217, 0.38636363636364
71572, 1.5695652173913, 0.93260869565217, 0.36363636363636
71573, 1.5913043478261, 0.95869565217391, 0.36363636363636
71574, 1.5913043478261, 0.93260869565217, 0.34090909090909
71575, 1.5695652173913, 0.93260869565217, 0.31818181818182
71576, 1.5913043478261, 0.95869565217391, 0.31818181818182
71577, 1.5913043478261, 0.93260869565217, 0.29545454545455
71578, 1.5695652173913, 0.93260869565217, 0.27272727272727
71579, 1.5913043478261, 0.95869565217391, 0.27272727272727
71580, 1.5913043478261, 0.93260869565217, 0.25
71581, 1.5695652173913, 0.93260869565217, 0.22727272727273
71582, 1.5913043478261, 0.95869565217391, 0.22727272727273
71583, 1.5913043478261, 0.93260869565217, 0.20454545454545
71584, 1.5695652173913, 0.93260869565217, 0.18181818181818
71585, 1.5913043478261, 0.95869565217391, 0.18181818181818
71586, 1.5913043478261, 0.93260869565217, 0.15909090909091
71587, 1.5695652173913, 0.93260869565217, 0.13636363636364
71588, 1.5913043478261, 0.95869565217391, 0.13636363636364
71589, 1.5913043478261, 0.93260869565217, 0.11363636363636
71590, 1.5695652173913, 0.93260869565217, 0.090909090909091
71591, 1.5913043478261, 0.95869565217391, 0.090909090909091
71592, 1.5913043478261, 0.93260869565217, 0.068181818181818
71593, 1.5695652173913, 0.93260869565217, 0.045454545454545
71594, 1.5913043478261, 0.95869565217391, 0.045454545454545
71595, 1.5913043478261, 0.93260869565217, 0.022727272727273
71596, 1.6347826086957, 0.93260869565217, 0.47727272727273
71597, 1.6130434782609, 0.93260869565217, 0.45454545454545
71598, 1.6347826086957, 0.95869565217391, 0.45454545454545
71599, 1.6347826086957, 0.93260869565218, 0.43181818181818
71600, 1.6130434782609, 0.93260869565217, 0.40909090909091
71601, 1.6347826086957, 0.95869565217391, 0.40909090909091
71602, 1.6347826086957, 0.93260869565217, 0.38636363636364
71603, 1.6130434782609, 0.93260869565217, 0.36363636363636
71604, 1.6347826086957, 0.95869565217391, 0.36363636363636
71605, 1.6347826086957, 0.93260869565217, 0.34090909090909
71606, 1.6130434782609, 0.93260869565217, 0.31818181818182
71607, 1.6347826086957, 0.95869565217391, 0.31818181818182
71608, 1.6347826086957, 0.93260869565217, 0.29545454545455
71609, 1.6130434782609, 0.93260869565217, 0.27272727272727
71610, 1.6347826086957, 0.95869565217391, 0.27272727272727
71611, 1.6347826086957, 0.93260869565217, 0.25
71612, 1.6130434782609, 0.93260869565217, 0.22727272727273
71613, 1.6347826086957, 0.95869565217391, 0.22727272727273
71614, 1.6347826086957, 0.93260869565217, 0.20454545454545
71615, 1.6130434782609, 0.93260869565217, 0.18181818181818
71616, 1.6347826086957, 0.95869565217391, 0.18181818181818
71617, 1.6347826086957, 0.93260869565217, 0.15909090909091
71618, 1.6130434782609, 0.93260869565217, 0.13636363636364
71619, 1.6347826086957, 0.95869565217391, 0.13636363636364
71620, 1.6347826086957, 0.93260869565217, 0.11363636363636
71621, 1.6130434782609, 0.93260869565217, 0.090909090909091
71622, 1.6347826086957, 0.95869565217391, 0.090909090909091
71623, 1.6347826086957, 0.93260869565217, 0.068181818181818
71624, 1.6130434782609, 0.93260869565217, 0.045454545454545
71625, 1.6347826086957, 0.95869565217391, 0.045454545454545
71626, 1.6347826086957, 0.93260869565217, 0.022727272727273
71627, 1.6782608695652, 0.93260869565217, 0.47727272727273
71628, 1.6565217391304, 0.93260869565217, 0.45454545454545
71629, 1.6782608695652, 0.95869565217391, 0.45454545454545
71630, 1.6782608695652, 0.93260869565217, 0.43181818181818
71631, 1.6565217391304, 0.93260869565217, 0.40909090909091
71632, 1.6782608695652, 0.95869565217391, 0.40909090909091
71633, 1.6782608695652, 0.93260869565217, 0.38636363636364
71634, 1.6565217391304, 0.93260869565217, 0.36363636363636
71635, 1.6782608695652, 0.95869565217391, 0.36363636363636
71636, 1.6782608695652, 0.93260869565217, 0.34090909090909
71637, 1.6565217391304, 0.93260869565217, 0.31818181818182
71638, 1.6782608695652, 0.95869565217391, 0.31818181818182
71639, 1.6782608695652, 0.93260869565217, 0.29545454545455
71640, 1.6565217391304, 0.93260869565217, 0.27272727272727
71641, 1.6782608695652, 0.95869565217391, 0.27272727272727
71642, 1.6782608695652, 0.93260869565217, 0.25
71643, 1.6565217391304, 0.93260869565217, 0.22727272727273
71644, 1.6782608695652, 0.95869565217391, 0.22727272727273
71645, 1.6782608695652, 0.93260869565217, 0.20454545454545
71646, 1.6565217391304, 0.93260869565217, 0.18181818181818
71647, 1.6782608695652, 0.95869565217391, 0.18181818181818
71648, 1.6782608695652, 0.93260869565217, 0.15909090909091
71649, 1.6565217391304, 0.93260869565217, 0.13636363636364
71650, 1.6782608695652, 0.95869565217391, 0.13636363636364
71651, 1.6782608695652, 0.93260869565217, 0.11363636363636
71652, 1.6565217391304, 0.93260869565217, 0.090909090909091
71653, 1.6782608695652, 0.95869565217391, 0.090909090909091
71654, 1.6782608695652, 0.93260869565217, 0.068181818181818
71655, 1.6565217391304, 0.93260869565217, 0.045454545454545
71656, 1.6782608695652, 0.95869565217391, 0.045454545454545
71657, 1.6782608695652, 0.93260869565217, 0.022727272727273
71658, 1.7217391304348, 0.93260869565217, 0.47727272727273
71659, 1.7, 0.93260869565217, 0.45454545454545
71660, 1.7217391304348, 0.95869565217391, 0.45454545454545
71661, 1.7217391304348, 0.93260869565217, 0.43181818181818
71662, 1.7, 0.93260869565217, 0.40909090909091
71663, 1.7217391304348, 0.95869565217391, 0.40909090909091
71664, 1.7217391304348, 0.93260869565217, 0.38636363636364
71665, 1.7, 0.93260869565217, 0.36363636363636
71666, 1.7217391304348, 0.95869565217391, 0.36363636363636
71667, 1.7217391304348, 0.93260869565217, 0.34090909090909
71668, 1.7, 0.93260869565217, 0.31818181818182
71669, 1.7217391304348, 0.95869565217391, 0.31818181818182
71670, 1.7217391304348, 0.93260869565217, 0.29545454545455
71671, 1.7, 0.93260869565217, 0.27272727272727
71672, 1.7217391304348, 0.95869565217391, 0.27272727272727
71673, 1.7217391304348, 0.93260869565217, 0.25
71674, 1.7, 0.93260869565217, 0.22727272727273
71675, 1.7217391304348, 0.95869565217391, 0.22727272727273
71676, 1.7217391304348, 0.93260869565217, 0.20454545454545
71677, 1.7, 0.93260869565217, 0.18181818181818
71678, 1.7217391304348, 0.95869565217391, 0.18181818181818
71679, 1.7217391304348, 0.93260869565217, 0.15909090909091
71680, 1.7, 0.93260869565217, 0.13636363636364
71681, 1.7217391304348, 0.95869565217391, 0.13636363636364
71682, 1.7217391304348, 0.93260869565217, 0.11363636363636
71683, 1.7, 0.93260869565217, 0.090909090909091
71684, 1.7217391304348, 0.95869565217391, 0.090909090909091
71685, 1.7217391304348, 0.93260869565217, 0.068181818181818
71686, 1.7, 0.93260869565217, 0.045454545454545
71687, 1.7217391304348, 0.95869565217391, 0.045454545454545
71688, 1.7217391304348, 0.93260869565217, 0.022727272727273
71689, 1.7652173913043, 0.93260869565217, 0.47727272727273
71690, 1.7434782608696, 0.93260869565217, 0.45454545454545
71691, 1.7652173913043, 0.95869565217391, 0.45454545454545
71692, 1.7652173913043, 0.93260869565217, 0.43181818181818
71693, 1.7434782608696, 0.93260869565217, 0.40909090909091
71694, 1.7652173913043, 0.95869565217391, 0.40909090909091
71695, 1.7652173913043, 0.93260869565217, 0.38636363636364
71696, 1.7434782608696, 0.93260869565217, 0.36363636363636
71697, 1.7652173913043, 0.95869565217391, 0.36363636363636
71698, 1.7652173913043, 0.93260869565217, 0.34090909090909
71699, 1.7434782608696, 0.93260869565217, 0.31818181818182
71700, 1.7652173913043, 0.95869565217391, 0.31818181818182
71701, 1.7652173913043, 0.93260869565217, 0.29545454545455
71702, 1.7434782608696, 0.93260869565217, 0.27272727272727
71703, 1.7652173913043, 0.95869565217391, 0.27272727272727
71704, 1.7652173913043, 0.93260869565217, 0.25
71705, 1.7434782608696, 0.93260869565217, 0.22727272727273
71706, 1.7652173913043, 0.95869565217391, 0.22727272727273
71707, 1.7652173913043, 0.93260869565217, 0.20454545454545
71708, 1.7434782608696, 0.93260869565217, 0.18181818181818
71709, 1.7652173913043, 0.95869565217391, 0.18181818181818
71710, 1.7652173913043, 0.93260869565217, 0.15909090909091
71711, 1.7434782608696, 0.93260869565217, 0.13636363636364
71712, 1.7652173913043, 0.95869565217391, 0.13636363636364
71713, 1.7652173913043, 0.93260869565217, 0.11363636363636
71714, 1.7434782608696, 0.93260869565217, 0.090909090909091
71715, 1.7652173913043, 0.95869565217391, 0.090909090909091
71716, 1.7652173913043, 0.93260869565217, 0.068181818181818
71717, 1.7434782608696, 0.93260869565217, 0.045454545454545
71718, 1.7652173913043, 0.95869565217391, 0.045454545454545
71719, 1.7652173913043, 0.93260869565217, 0.022727272727273
71720, 1.8086956521739, 0.93260869565217, 0.47727272727273
71721, 1.7869565217391, 0.93260869565217, 0.45454545454545
71722, 1.8086956521739, 0.95869565217391, 0.45454545454545
71723, 1.8086956521739, 0.93260869565217, 0.43181818181818
71724, 1.7869565217391, 0.93260869565217, 0.40909090909091
71725, 1.8086956521739, 0.95869565217391, 0.40909090909091
71726, 1.8086956521739, 0.93260869565217, 0.38636363636364
71727, 1.7869565217391, 0.93260869565217, 0.36363636363636
71728, 1.8086956521739, 0.95869565217391, 0.36363636363636
71729, 1.8086956521739, 0.93260869565217, 0.34090909090909
71730, 1.7869565217391, 0.93260869565217, 0.31818181818182
71731, 1.8086956521739, 0.95869565217391, 0.31818181818182
71732, 1.8086956521739, 0.93260869565217, 0.29545454545455
71733, 1.7869565217391, 0.93260869565217, 0.27272727272727
71734, 1.8086956521739, 0.95869565217391, 0.27272727272727
71735, 1.8086956521739, 0.93260869565217, 0.25
71736, 1.7869565217391, 0.93260869565217, 0.22727272727273
71737, 1.8086956521739, 0.95869565217391, 0.22727272727273
71738, 1.8086956521739, 0.93260869565217, 0.20454545454545
71739, 1.7869565217391, 0.93260869565217, 0.18181818181818
71740, 1.8086956521739, 0.95869565217391, 0.18181818181818
71741, 1.8086956521739, 0.93260869565217, 0.15909090909091
71742, 1.7869565217391, 0.93260869565217, 0.13636363636364
71743, 1.8086956521739, 0.95869565217391, 0.13636363636364
71744, 1.8086956521739, 0.93260869565217, 0.11363636363636
71745, 1.7869565217391, 0.93260869565217, 0.090909090909091
71746, 1.8086956521739, 0.95869565217391, 0.090909090909091
71747, 1.8086956521739, 0.93260869565217, 0.068181818181818
71748, 1.7869565217391, 0.93260869565217, 0.045454545454545
71749, 1.8086956521739, 0.95869565217391, 0.045454545454545
71750, 1.8086956521739, 0.93260869565217, 0.022727272727273
71751, 1.8521739130435, 0.93260869565217, 0.47727272727273
71752, 1.8304347826087, 0.93260869565217, 0.45454545454545
71753, 1.8521739130435, 0.95869565217391, 0.45454545454545
71754, 1.8521739130435, 0.93260869565217, 0.43181818181818
71755, 1.8304347826087, 0.93260869565217, 0.40909090909091
71756, 1.8521739130435, 0.95869565217391, 0.40909090909091
71757, 1.8521739130435, 0.93260869565217, 0.38636363636364
71758, 1.8304347826087, 0.93260869565217, 0.36363636363636
71759, 1.8521739130435, 0.95869565217391, 0.36363636363636
71760, 1.8521739130435, 0.93260869565217, 0.34090909090909
71761, 1.8304347826087, 0.93260869565217, 0.31818181818182
71762, 1.8521739130435, 0.95869565217391, 0.31818181818182
71763, 1.8521739130435, 0.93260869565217, 0.29545454545455
71764, 1.8304347826087, 0.93260869565217, 0.27272727272727
71765, 1.8521739130435, 0.95869565217391, 0.27272727272727
71766, 1.8521739130435, 0.93260869565217, 0.25
71767, 1.8304347826087, 0.93260869565217, 0.22727272727273
71768, 1.8521739130435, 0.95869565217391, 0.22727272727273
71769, 1.8521739130435, 0.93260869565217, 0.20454545454545
71770, 1.8304347826087, 0.93260869565217, 0.18181818181818
71771, 1.8521739130435, 0.95869565217391, 0.18181818181818
71772, 1.8521739130435, 0.93260869565217, 0.15909090909091
71773, 1.8304347826087, 0.93260869565217, 0.13636363636364
71774, 1.8521739130435, 0.95869565217391, 0.13636363636364
71775, 1.8521739130435, 0.93260869565217, 0.11363636363636
71776, 1.8304347826087, 0.93260869565217, 0.090909090909091
71777, 1.8521739130435, 0.95869565217391, 0.090909090909091
71778, 1.8521739130435, 0.93260869565217, 0.068181818181818
71779, 1.8304347826087, 0.93260869565217, 0.045454545454545
71780, 1.8521739130435, 0.95869565217391, 0.045454545454545
71781, 1.8521739130435, 0.93260869565217, 0.022727272727273
71782, 1.895652173913, 0.93260869565217, 0.47727272727273
71783, 1.8739130434783, 0.93260869565217, 0.45454545454545
71784, 1.895652173913, 0.95869565217391, 0.45454545454545
71785, 1.895652173913, 0.93260869565217, 0.43181818181818
71786, 1.8739130434783, 0.93260869565217, 0.40909090909091
71787, 1.895652173913, 0.95869565217391, 0.40909090909091
71788, 1.895652173913, 0.93260869565217, 0.38636363636364
71789, 1.8739130434783, 0.93260869565217, 0.36363636363636
71790, 1.895652173913, 0.95869565217391, 0.36363636363636
71791, 1.895652173913, 0.93260869565217, 0.34090909090909
71792, 1.8739130434783, 0.93260869565217, 0.31818181818182
71793, 1.895652173913, 0.95869565217391, 0.31818181818182
71794, 1.895652173913, 0.93260869565217, 0.29545454545455
71795, 1.8739130434783, 0.93260869565217, 0.27272727272727
71796, 1.895652173913, 0.95869565217391, 0.27272727272727
71797, 1.895652173913, 0.93260869565217, 0.25
71798, 1.8739130434783, 0.93260869565217, 0.22727272727273
71799, 1.895652173913, 0.95869565217391, 0.22727272727273
71800, 1.895652173913, 0.93260869565217, 0.20454545454545
71801, 1.8739130434783, 0.93260869565217, 0.18181818181818
71802, 1.895652173913, 0.95869565217391, 0.18181818181818
71803, 1.895652173913, 0.93260869565217, 0.15909090909091
71804, 1.8739130434783, 0.93260869565217, 0.13636363636364
71805, 1.895652173913, 0.95869565217391, 0.13636363636364
71806, 1.895652173913, 0.93260869565217, 0.11363636363636
71807, 1.8739130434783, 0.93260869565217, 0.090909090909091
71808, 1.895652173913, 0.95869565217391, 0.090909090909091
71809, 1.895652173913, 0.93260869565217, 0.068181818181818
71810, 1.8739130434783, 0.93260869565217, 0.045454545454545
71811, 1.895652173913, 0.95869565217391, 0.045454545454545
71812, 1.895652173913, 0.93260869565217, 0.022727272727273
71813, 1.9391304347826, 0.93260869565217, 0.47727272727273
71814, 1.9173913043478, 0.93260869565217, 0.45454545454545
71815, 1.9391304347826, 0.95869565217391, 0.45454545454545
71816, 1.9391304347826, 0.93260869565217, 0.43181818181818
71817, 1.9173913043478, 0.93260869565217, 0.40909090909091
71818, 1.9391304347826, 0.95869565217391, 0.40909090909091
71819, 1.9391304347826, 0.93260869565217, 0.38636363636364
71820, 1.9173913043478, 0.93260869565217, 0.36363636363636
71821, 1.9391304347826, 0.95869565217391, 0.36363636363636
71822, 1.9391304347826, 0.93260869565217, 0.34090909090909
71823, 1.9173913043478, 0.93260869565217, 0.31818181818182
71824, 1.9391304347826, 0.95869565217391, 0.31818181818182
71825, 1.9391304347826, 0.93260869565217, 0.29545454545455
71826, 1.9173913043478, 0.93260869565217, 0.27272727272727
71827, 1.9391304347826, 0.95869565217391, 0.27272727272727
71828, 1.9391304347826, 0.93260869565217, 0.25
71829, 1.9173913043478, 0.93260869565217, 0.22727272727273
71830, 1.9391304347826, 0.95869565217391, 0.22727272727273
71831, 1.9391304347826, 0.93260869565217, 0.20454545454545
71832, 1.9173913043478, 0.93260869565217, 0.18181818181818
71833, 1.9391304347826, 0.95869565217391, 0.18181818181818
71834, 1.9391304347826, 0.93260869565217, 0.15909090909091
71835, 1.9173913043478, 0.93260869565217, 0.13636363636364
71836, 1.9391304347826, 0.95869565217391, 0.13636363636364
71837, 1.9391304347826, 0.93260869565217, 0.11363636363636
71838, 1.9173913043478, 0.93260869565217, 0.090909090909091
71839, 1.9391304347826, 0.95869565217391, 0.090909090909091
71840, 1.9391304347826, 0.93260869565217, 0.068181818181818
71841, 1.9173913043478, 0.93260869565217, 0.045454545454545
71842, 1.9391304347826, 0.95869565217391, 0.045454545454545
71843, 1.9391304347826, 0.93260869565217, 0.022727272727273
71844, 1.9826086956522, 0.93260869565217, 0.47727272727273
71845, 1.9608695652174, 0.93260869565217, 0.45454545454545
71846, 1.9826086956522, 0.95869565217391, 0.45454545454545
71847, 1.9826086956522, 0.93260869565217, 0.43181818181818
71848, 1.9608695652174, 0.93260869565217, 0.40909090909091
71849, 1.9826086956522, 0.95869565217391, 0.40909090909091
71850, 1.9826086956522, 0.93260869565217, 0.38636363636364
71851, 1.9608695652174, 0.93260869565217, 0.36363636363636
71852, 1.9826086956522, 0.95869565217391, 0.36363636363636
71853, 1.9826086956522, 0.93260869565217, 0.34090909090909
71854, 1.9608695652174, 0.93260869565217, 0.31818181818182
71855, 1.9826086956522, 0.95869565217391, 0.31818181818182
71856, 1.9826086956522, 0.93260869565217, 0.29545454545455
71857, 1.9608695652174, 0.93260869565217, 0.27272727272727
71858, 1.9826086956522, 0.95869565217391, 0.27272727272727
71859, 1.9826086956522, 0.93260869565217, 0.25
71860, 1.9608695652174, 0.93260869565217, 0.22727272727273
71861, 1.9826086956522, 0.95869565217391, 0.22727272727273
71862, 1.9826086956522, 0.93260869565217, 0.20454545454545
71863, 1.9608695652174, 0.93260869565217, 0.18181818181818
71864, 1.9826086956522, 0.95869565217391, 0.18181818181818
71865, 1.9826086956522, 0.93260869565217, 0.15909090909091
71866, 1.9608695652174, 0.93260869565217, 0.13636363636364
71867, 1.9826086956522, 0.95869565217391, 0.13636363636364
71868, 1.9826086956522, 0.93260869565217, 0.11363636363636
71869, 1.9608695652174, 0.93260869565217, 0.090909090909091
71870, 1.9826086956522, 0.95869565217391, 0.090909090909091
71871, 1.9826086956522, 0.93260869565217, 0.068181818181818
71872, 1.9608695652174, 0.93260869565217, 0.045454545454545
71873, 1.9826086956522, 0.95869565217391, 0.045454545454545
71874, 1.9826086956522, 0.93260869565217, 0.022727272727273
71875, 2.0260869565217, 0.93260869565217, 0.47727272727273
71876, 2.004347826087, 0.93260869565217, 0.45454545454545
71877, 2.0260869565217, 0.95869565217391, 0.45454545454545
71878, 2.0260869565217, 0.93260869565217, 0.43181818181818
71879, 2.004347826087, 0.93260869565217, 0.40909090909091
71880, 2.0260869565217, 0.95869565217391, 0.40909090909091
71881, 2.0260869565217, 0.93260869565217, 0.38636363636364
71882, 2.004347826087, 0.93260869565217, 0.36363636363636
71883, 2.0260869565217, 0.95869565217391, 0.36363636363636
71884, 2.0260869565217, 0.93260869565217, 0.34090909090909
71885, 2.004347826087, 0.93260869565217, 0.31818181818182
71886, 2.0260869565217, 0.95869565217391, 0.31818181818182
71887, 2.0260869565217, 0.93260869565217, 0.29545454545455
71888, 2.004347826087, 0.93260869565217, 0.27272727272727
71889, 2.0260869565217, 0.95869565217391, 0.27272727272727
71890, 2.0260869565217, 0.93260869565217, 0.25
71891, 2.004347826087, 0.93260869565217, 0.22727272727273
71892, 2.0260869565217, 0.95869565217391, 0.22727272727273
71893, 2.0260869565217, 0.93260869565217, 0.20454545454545
71894, 2.004347826087, 0.93260869565217, 0.18181818181818
71895, 2.0260869565217, 0.95869565217391, 0.18181818181818
71896, 2.0260869565217, 0.93260869565217, 0.15909090909091
71897, 2.004347826087, 0.93260869565217, 0.13636363636364
71898, 2.0260869565217, 0.95869565217391, 0.13636363636364
71899, 2.0260869565217, 0.93260869565217, 0.11363636363636
71900, 2.004347826087, 0.93260869565217, 0.090909090909091
71901, 2.0260869565217, 0.95869565217391, 0.090909090909091
71902, 2.0260869565217, 0.93260869565217, 0.068181818181818
71903, 2.004347826087, 0.93260869565217, 0.045454545454545
71904, 2.0260869565217, 0.95869565217391, 0.045454545454545
71905, 2.0260869565217, 0.93260869565217, 0.022727272727273
71906, 2.0695652173913, 0.93260869565217, 0.47727272727273
71907, 2.0478260869565, 0.93260869565217, 0.45454545454545
71908, 2.0695652173913, 0.95869565217391, 0.45454545454545
71909, 2.0695652173913, 0.93260869565217, 0.43181818181818
71910, 2.0478260869565, 0.93260869565217, 0.40909090909091
71911, 2.0695652173913, 0.95869565217391, 0.40909090909091
71912, 2.0695652173913, 0.93260869565217, 0.38636363636364
71913, 2.0478260869565, 0.93260869565217, 0.36363636363636
71914, 2.0695652173913, 0.95869565217391, 0.36363636363636
71915, 2.0695652173913, 0.93260869565217, 0.34090909090909
71916, 2.0478260869565, 0.93260869565217, 0.31818181818182
71917, 2.0695652173913, 0.95869565217391, 0.31818181818182
71918, 2.0695652173913, 0.93260869565217, 0.29545454545455
71919, 2.0478260869565, 0.93260869565217, 0.27272727272727
71920, 2.0695652173913, 0.95869565217391, 0.27272727272727
71921, 2.0695652173913, 0.93260869565217, 0.25
71922, 2.0478260869565, 0.93260869565217, 0.22727272727273
71923, 2.0695652173913, 0.95869565217391, 0.22727272727273
71924, 2.0695652173913, 0.93260869565217, 0.20454545454545
71925, 2.0478260869565, 0.93260869565217, 0.18181818181818
71926, 2.0695652173913, 0.95869565217391, 0.18181818181818
71927, 2.0695652173913, 0.93260869565217, 0.15909090909091
71928, 2.0478260869565, 0.93260869565217, 0.13636363636364
71929, 2.0695652173913, 0.95869565217391, 0.13636363636364
71930, 2.0695652173913, 0.93260869565217, 0.11363636363636
71931, 2.0478260869565, 0.93260869565217, 0.090909090909091
71932, 2.0695652173913, 0.95869565217391, 0.090909090909091
71933, 2.0695652173913, 0.93260869565217, 0.068181818181818
71934, 2.0478260869565, 0.93260869565217, 0.045454545454545
71935, 2.0695652173913, 0.95869565217391, 0.045454545454545
71936, 2.0695652173913, 0.93260869565217, 0.022727272727273
71937, 2.1130434782609, 0.93260869565217, 0.47727272727273
71938, 2.0913043478261, 0.93260869565217, 0.45454545454545
71939, 2.1130434782609, 0.95869565217391, 0.45454545454545
71940, 2.1130434782609, 0.93260869565217, 0.43181818181818
71941, 2.0913043478261, 0.93260869565217, 0.40909090909091
71942, 2.1130434782609, 0.95869565217391, 0.40909090909091
71943, 2.1130434782609, 0.93260869565217, 0.38636363636364
71944, 2.0913043478261, 0.93260869565217, 0.36363636363636
71945, 2.1130434782609, 0.95869565217391, 0.36363636363636
71946, 2.1130434782609, 0.93260869565217, 0.34090909090909
71947, 2.0913043478261, 0.93260869565217, 0.31818181818182
71948, 2.1130434782609, 0.95869565217391, 0.31818181818182
71949, 2.1130434782609, 0.93260869565217, 0.29545454545455
71950, 2.0913043478261, 0.93260869565217, 0.27272727272727
71951, 2.1130434782609, 0.95869565217391, 0.27272727272727
71952, 2.1130434782609, 0.93260869565217, 0.25
71953, 2.0913043478261, 0.93260869565217, 0.22727272727273
71954, 2.1130434782609, 0.95869565217391, 0.22727272727273
71955, 2.1130434782609, 0.93260869565217, 0.20454545454545
71956, 2.0913043478261, 0.93260869565217, 0.18181818181818
71957, 2.1130434782609, 0.95869565217391, 0.18181818181818
71958, 2.1130434782609, 0.93260869565217, 0.15909090909091
71959, 2.0913043478261, 0.93260869565217, 0.13636363636364
71960, 2.1130434782609, 0.95869565217391, 0.13636363636364
71961, 2.1130434782609, 0.93260869565217, 0.11363636363636
71962, 2.0913043478261, 0.93260869565217, 0.090909090909091
71963, 2.1130434782609, 0.95869565217391, 0.090909090909091
71964, 2.1130434782609, 0.93260869565217, 0.068181818181818
71965, 2.0913043478261, 0.93260869565217, 0.045454545454545
71966, 2.1130434782609, 0.95869565217391, 0.045454545454545
71967, 2.1130434782609, 0.93260869565217, 0.022727272727273
71968, 2.1565217391304, 0.93260869565217, 0.47727272727273
71969, 2.1347826086957, 0.93260869565217, 0.45454545454545
71970, 2.1565217391304, 0.95869565217391, 0.45454545454545
71971, 2.1565217391304, 0.93260869565217, 0.43181818181818
71972, 2.1347826086957, 0.93260869565217, 0.40909090909091
71973, 2.1565217391304, 0.95869565217391, 0.40909090909091
71974, 2.1565217391304, 0.93260869565217, 0.38636363636364
71975, 2.1347826086957, 0.93260869565217, 0.36363636363636
71976, 2.1565217391304, 0.95869565217391, 0.36363636363636
71977, 2.1565217391304, 0.93260869565217, 0.34090909090909
71978, 2.1347826086957, 0.93260869565217, 0.31818181818182
71979, 2.1565217391304, 0.95869565217391, 0.31818181818182
71980, 2.1565217391304, 0.93260869565217, 0.29545454545455
71981, 2.1347826086957, 0.93260869565217, 0.27272727272727
71982, 2.1565217391304, 0.95869565217391, 0.27272727272727
71983, 2.1565217391304, 0.93260869565217, 0.25
71984, 2.1347826086957, 0.93260869565217, 0.22727272727273
71985, 2.1565217391304, 0.95869565217391, 0.22727272727273
71986, 2.1565217391304, 0.93260869565217, 0.20454545454545
71987, 2.1347826086957, 0.93260869565217, 0.18181818181818
71988, 2.1565217391304, 0.95869565217391, 0.18181818181818
71989, 2.1565217391304, 0.93260869565217, 0.15909090909091
71990, 2.1347826086957, 0.93260869565217, 0.13636363636364
71991, 2.1565217391304, 0.95869565217391, 0.13636363636364
71992, 2.1565217391304, 0.93260869565217, 0.11363636363636
71993, 2.1347826086957, 0.93260869565217, 0.090909090909091
71994, 2.1565217391304, 0.95869565217391, 0.090909090909091
71995, 2.1565217391304, 0.93260869565217, 0.068181818181818
71996, 2.1347826086957, 0.93260869565217, 0.045454545454545
71997, 2.1565217391304, 0.95869565217391, 0.045454545454545
71998, 2.1565217391304, 0.93260869565217, 0.022727272727273
71999, 2.1782608695652, 0.93260869565217, 0.45454545454545
72000, 2.1782608695652, 0.93260869565217, 0.40909090909091
72001, 2.1782608695652, 0.93260869565217, 0.36363636363636
72002, 2.1782608695652, 0.93260869565217, 0.31818181818182
72003, 2.1782608695652, 0.93260869565217, 0.27272727272727
72004, 2.1782608695652, 0.93260869565217, 0.22727272727273
72005, 2.1782608695652, 0.93260869565217, 0.18181818181818
72006, 2.1782608695652, 0.93260869565217, 0.13636363636364
72007, 2.1782608695652, 0.93260869565217, 0.090909090909091
72008, 2.1782608695652, 0.93260869565217, 0.045454545454545
72009, 1.2434782608696, 0.8804347826087, 0.47727272727273
72010, 1.2217391304348, 0.8804347826087, 0.45454545454545
72011, 1.2434782608696, 0.90652173913044, 0.45454545454545
72012, 1.2434782608696, 0.8804347826087, 0.43181818181818
72013, 1.2217391304348, 0.8804347826087, 0.40909090909091
72014, 1.2434782608696, 0.90652173913044, 0.40909090909091
72015, 1.2434782608696, 0.8804347826087, 0.38636363636364
72016, 1.2217391304348, 0.8804347826087, 0.36363636363636
72017, 1.2434782608696, 0.90652173913044, 0.36363636363636
72018, 1.2434782608696, 0.8804347826087, 0.34090909090909
72019, 1.2217391304348, 0.8804347826087, 0.31818181818182
72020, 1.2434782608696, 0.90652173913044, 0.31818181818182
72021, 1.2434782608696, 0.8804347826087, 0.29545454545455
72022, 1.2217391304348, 0.8804347826087, 0.27272727272727
72023, 1.2434782608696, 0.90652173913044, 0.27272727272727
72024, 1.2434782608696, 0.8804347826087, 0.25
72025, 1.2217391304348, 0.8804347826087, 0.22727272727273
72026, 1.2434782608696, 0.90652173913044, 0.22727272727273
72027, 1.2434782608696, 0.8804347826087, 0.20454545454545
72028, 1.2217391304348, 0.8804347826087, 0.18181818181818
72029, 1.2434782608696, 0.90652173913044, 0.18181818181818
72030, 1.2434782608696, 0.8804347826087, 0.15909090909091
72031, 1.2217391304348, 0.8804347826087, 0.13636363636364
72032, 1.2434782608696, 0.90652173913044, 0.13636363636364
72033, 1.2434782608696, 0.8804347826087, 0.11363636363636
72034, 1.2217391304348, 0.8804347826087, 0.090909090909091
72035, 1.2434782608696, 0.90652173913044, 0.090909090909091
72036, 1.2434782608696, 0.8804347826087, 0.068181818181818
72037, 1.2217391304348, 0.8804347826087, 0.045454545454545
72038, 1.2434782608696, 0.90652173913044, 0.045454545454545
72039, 1.2434782608696, 0.8804347826087, 0.022727272727273
72040, 1.2869565217391, 0.8804347826087, 0.47727272727273
72041, 1.2652173913043, 0.8804347826087, 0.45454545454545
72042, 1.2869565217391, 0.90652173913044, 0.45454545454545
72043, 1.2869565217391, 0.8804347826087, 0.43181818181818
72044, 1.2652173913043, 0.8804347826087, 0.40909090909091
72045, 1.2869565217391, 0.90652173913044, 0.40909090909091
72046, 1.2869565217391, 0.8804347826087, 0.38636363636364
72047, 1.2652173913043, 0.8804347826087, 0.36363636363636
72048, 1.2869565217391, 0.90652173913044, 0.36363636363636
72049, 1.2869565217391, 0.8804347826087, 0.34090909090909
72050, 1.2652173913043, 0.8804347826087, 0.31818181818182
72051, 1.2869565217391, 0.90652173913044, 0.31818181818182
72052, 1.2869565217391, 0.8804347826087, 0.29545454545455
72053, 1.2652173913043, 0.8804347826087, 0.27272727272727
72054, 1.2869565217391, 0.90652173913044, 0.27272727272727
72055, 1.2869565217391, 0.8804347826087, 0.25
72056, 1.2652173913043, 0.8804347826087, 0.22727272727273
72057, 1.2869565217391, 0.90652173913044, 0.22727272727273
72058, 1.2869565217391, 0.8804347826087, 0.20454545454545
72059, 1.2652173913043, 0.8804347826087, 0.18181818181818
72060, 1.2869565217391, 0.90652173913044, 0.18181818181818
72061, 1.2869565217391, 0.8804347826087, 0.15909090909091
72062, 1.2652173913043, 0.8804347826087, 0.13636363636364
72063, 1.2869565217391, 0.90652173913044, 0.13636363636364
72064, 1.2869565217391, 0.8804347826087, 0.11363636363636
72065, 1.2652173913043, 0.8804347826087, 0.090909090909091
72066, 1.2869565217391, 0.90652173913044, 0.090909090909091
72067, 1.2869565217391, 0.8804347826087, 0.068181818181818
72068, 1.2652173913043, 0.8804347826087, 0.045454545454545
72069, 1.2869565217391, 0.90652173913044, 0.045454545454545
72070, 1.2869565217391, 0.8804347826087, 0.022727272727273
72071, 1.3304347826087, 0.8804347826087, 0.47727272727273
72072, 1.3086956521739, 0.8804347826087, 0.45454545454545
72073, 1.3304347826087, 0.90652173913044, 0.45454545454545
72074, 1.3304347826087, 0.8804347826087, 0.43181818181818
72075, 1.3086956521739, 0.8804347826087, 0.40909090909091
72076, 1.3304347826087, 0.90652173913044, 0.40909090909091
72077, 1.3304347826087, 0.8804347826087, 0.38636363636364
72078, 1.3086956521739, 0.8804347826087, 0.36363636363636
72079, 1.3304347826087, 0.90652173913044, 0.36363636363636
72080, 1.3304347826087, 0.8804347826087, 0.34090909090909
72081, 1.3086956521739, 0.8804347826087, 0.31818181818182
72082, 1.3304347826087, 0.90652173913044, 0.31818181818182
72083, 1.3304347826087, 0.8804347826087, 0.29545454545455
72084, 1.3086956521739, 0.8804347826087, 0.27272727272727
72085, 1.3304347826087, 0.90652173913044, 0.27272727272727
72086, 1.3304347826087, 0.8804347826087, 0.25
72087, 1.3086956521739, 0.8804347826087, 0.22727272727273
72088, 1.3304347826087, 0.90652173913044, 0.22727272727273
72089, 1.3304347826087, 0.8804347826087, 0.20454545454545
72090, 1.3086956521739, 0.8804347826087, 0.18181818181818
72091, 1.3304347826087, 0.90652173913044, 0.18181818181818
72092, 1.3304347826087, 0.8804347826087, 0.15909090909091
72093, 1.3086956521739, 0.8804347826087, 0.13636363636364
72094, 1.3304347826087, 0.90652173913044, 0.13636363636364
72095, 1.3304347826087, 0.8804347826087, 0.11363636363636
72096, 1.3086956521739, 0.8804347826087, 0.090909090909091
72097, 1.3304347826087, 0.90652173913044, 0.090909090909091
72098, 1.3304347826087, 0.8804347826087, 0.068181818181818
72099, 1.3086956521739, 0.8804347826087, 0.045454545454545
72100, 1.3304347826087, 0.90652173913044, 0.045454545454545
72101, 1.3304347826087, 0.8804347826087, 0.022727272727273
72102, 1.3739130434783, 0.8804347826087, 0.47727272727273
72103, 1.3521739130435, 0.8804347826087, 0.45454545454545
72104, 1.3739130434783, 0.90652173913044, 0.45454545454545
72105, 1.3739130434783, 0.8804347826087, 0.43181818181818
72106, 1.3521739130435, 0.8804347826087, 0.40909090909091
72107, 1.3739130434783, 0.90652173913044, 0.40909090909091
72108, 1.3739130434783, 0.8804347826087, 0.38636363636364
72109, 1.3521739130435, 0.8804347826087, 0.36363636363636
72110, 1.3739130434783, 0.90652173913044, 0.36363636363636
72111, 1.3739130434783, 0.8804347826087, 0.34090909090909
72112, 1.3521739130435, 0.8804347826087, 0.31818181818182
72113, 1.3739130434783, 0.90652173913044, 0.31818181818182
72114, 1.3739130434783, 0.8804347826087, 0.29545454545455
72115, 1.3521739130435, 0.8804347826087, 0.27272727272727
72116, 1.3739130434783, 0.90652173913044, 0.27272727272727
72117, 1.3739130434783, 0.8804347826087, 0.25
72118, 1.3521739130435, 0.8804347826087, 0.22727272727273
72119, 1.3739130434783, 0.90652173913044, 0.22727272727273
72120, 1.3739130434783, 0.8804347826087, 0.20454545454545
72121, 1.3521739130435, 0.8804347826087, 0.18181818181818
72122, 1.3739130434783, 0.90652173913044, 0.18181818181818
72123, 1.3739130434783, 0.8804347826087, 0.15909090909091
72124, 1.3521739130435, 0.8804347826087, 0.13636363636364
72125, 1.3739130434783, 0.90652173913044, 0.13636363636364
72126, 1.3739130434783, 0.8804347826087, 0.11363636363636
72127, 1.3521739130435, 0.8804347826087, 0.090909090909091
72128, 1.3739130434783, 0.90652173913044, 0.090909090909091
72129, 1.3739130434783, 0.8804347826087, 0.068181818181818
72130, 1.3521739130435, 0.8804347826087, 0.045454545454545
72131, 1.3739130434783, 0.90652173913044, 0.045454545454545
72132, 1.3739130434783, 0.8804347826087, 0.022727272727273
72133, 1.4173913043478, 0.8804347826087, 0.47727272727273
72134, 1.395652173913, 0.8804347826087, 0.45454545454545
72135, 1.4173913043478, 0.90652173913044, 0.45454545454545
72136, 1.4173913043478, 0.8804347826087, 0.43181818181818
72137, 1.395652173913, 0.8804347826087, 0.40909090909091
72138, 1.4173913043478, 0.90652173913044, 0.40909090909091
72139, 1.4173913043478, 0.8804347826087, 0.38636363636364
72140, 1.395652173913, 0.8804347826087, 0.36363636363636
72141, 1.4173913043478, 0.90652173913044, 0.36363636363636
72142, 1.4173913043478, 0.8804347826087, 0.34090909090909
72143, 1.395652173913, 0.8804347826087, 0.31818181818182
72144, 1.4173913043478, 0.90652173913044, 0.31818181818182
72145, 1.4173913043478, 0.8804347826087, 0.29545454545455
72146, 1.395652173913, 0.8804347826087, 0.27272727272727
72147, 1.4173913043478, 0.90652173913044, 0.27272727272727
72148, 1.4173913043478, 0.8804347826087, 0.25
72149, 1.395652173913, 0.8804347826087, 0.22727272727273
72150, 1.4173913043478, 0.90652173913044, 0.22727272727273
72151, 1.4173913043478, 0.8804347826087, 0.20454545454545
72152, 1.395652173913, 0.8804347826087, 0.18181818181818
72153, 1.4173913043478, 0.90652173913044, 0.18181818181818
72154, 1.4173913043478, 0.8804347826087, 0.15909090909091
72155, 1.395652173913, 0.8804347826087, 0.13636363636364
72156, 1.4173913043478, 0.90652173913044, 0.13636363636364
72157, 1.4173913043478, 0.8804347826087, 0.11363636363636
72158, 1.395652173913, 0.8804347826087, 0.090909090909091
72159, 1.4173913043478, 0.90652173913044, 0.090909090909091
72160, 1.4173913043478, 0.8804347826087, 0.068181818181818
72161, 1.395652173913, 0.8804347826087, 0.045454545454545
72162, 1.4173913043478, 0.90652173913044, 0.045454545454545
72163, 1.4173913043478, 0.8804347826087, 0.022727272727273
72164, 1.4608695652174, 0.8804347826087, 0.47727272727273
72165, 1.4391304347826, 0.8804347826087, 0.45454545454545
72166, 1.4608695652174, 0.90652173913044, 0.45454545454545
72167, 1.4608695652174, 0.8804347826087, 0.43181818181818
72168, 1.4391304347826, 0.8804347826087, 0.40909090909091
72169, 1.4608695652174, 0.90652173913044, 0.40909090909091
72170, 1.4608695652174, 0.8804347826087, 0.38636363636364
72171, 1.4391304347826, 0.8804347826087, 0.36363636363636
72172, 1.4608695652174, 0.90652173913044, 0.36363636363636
72173, 1.4608695652174, 0.8804347826087, 0.34090909090909
72174, 1.4391304347826, 0.8804347826087, 0.31818181818182
72175, 1.4608695652174, 0.90652173913044, 0.31818181818182
72176, 1.4608695652174, 0.8804347826087, 0.29545454545455
72177, 1.4391304347826, 0.8804347826087, 0.27272727272727
72178, 1.4608695652174, 0.90652173913044, 0.27272727272727
72179, 1.4608695652174, 0.8804347826087, 0.25
72180, 1.4391304347826, 0.8804347826087, 0.22727272727273
72181, 1.4608695652174, 0.90652173913044, 0.22727272727273
72182, 1.4608695652174, 0.8804347826087, 0.20454545454545
72183, 1.4391304347826, 0.8804347826087, 0.18181818181818
72184, 1.4608695652174, 0.90652173913044, 0.18181818181818
72185, 1.4608695652174, 0.8804347826087, 0.15909090909091
72186, 1.4391304347826, 0.8804347826087, 0.13636363636364
72187, 1.4608695652174, 0.90652173913044, 0.13636363636364
72188, 1.4608695652174, 0.8804347826087, 0.11363636363636
72189, 1.4391304347826, 0.8804347826087, 0.090909090909091
72190, 1.4608695652174, 0.90652173913044, 0.090909090909091
72191, 1.4608695652174, 0.8804347826087, 0.068181818181818
72192, 1.4391304347826, 0.8804347826087, 0.045454545454545
72193, 1.4608695652174, 0.90652173913044, 0.045454545454545
72194, 1.4608695652174, 0.8804347826087, 0.022727272727273
72195, 1.504347826087, 0.8804347826087, 0.47727272727273
72196, 1.4826086956522, 0.8804347826087, 0.45454545454545
72197, 1.504347826087, 0.90652173913044, 0.45454545454545
72198, 1.504347826087, 0.8804347826087, 0.43181818181818
72199, 1.4826086956522, 0.8804347826087, 0.40909090909091
72200, 1.504347826087, 0.90652173913044, 0.40909090909091
72201, 1.504347826087, 0.8804347826087, 0.38636363636364
72202, 1.4826086956522, 0.8804347826087, 0.36363636363636
72203, 1.504347826087, 0.90652173913044, 0.36363636363636
72204, 1.504347826087, 0.8804347826087, 0.34090909090909
72205, 1.4826086956522, 0.8804347826087, 0.31818181818182
72206, 1.504347826087, 0.90652173913044, 0.31818181818182
72207, 1.504347826087, 0.8804347826087, 0.29545454545455
72208, 1.4826086956522, 0.8804347826087, 0.27272727272727
72209, 1.504347826087, 0.90652173913044, 0.27272727272727
72210, 1.504347826087, 0.8804347826087, 0.25
72211, 1.4826086956522, 0.8804347826087, 0.22727272727273
72212, 1.504347826087, 0.90652173913044, 0.22727272727273
72213, 1.504347826087, 0.8804347826087, 0.20454545454545
72214, 1.4826086956522, 0.8804347826087, 0.18181818181818
72215, 1.504347826087, 0.90652173913044, 0.18181818181818
72216, 1.504347826087, 0.8804347826087, 0.15909090909091
72217, 1.4826086956522, 0.8804347826087, 0.13636363636364
72218, 1.504347826087, 0.90652173913044, 0.13636363636364
72219, 1.504347826087, 0.8804347826087, 0.11363636363636
72220, 1.4826086956522, 0.8804347826087, 0.090909090909091
72221, 1.504347826087, 0.90652173913044, 0.090909090909091
72222, 1.504347826087, 0.8804347826087, 0.068181818181818
72223, 1.4826086956522, 0.8804347826087, 0.045454545454545
72224, 1.504347826087, 0.90652173913044, 0.045454545454545
72225, 1.504347826087, 0.8804347826087, 0.022727272727273
72226, 1.5478260869565, 0.8804347826087, 0.47727272727273
72227, 1.5260869565217, 0.8804347826087, 0.45454545454545
72228, 1.5478260869565, 0.90652173913044, 0.45454545454545
72229, 1.5478260869565, 0.8804347826087, 0.43181818181818
72230, 1.5260869565217, 0.8804347826087, 0.40909090909091
72231, 1.5478260869565, 0.90652173913044, 0.40909090909091
72232, 1.5478260869565, 0.8804347826087, 0.38636363636364
72233, 1.5260869565217, 0.8804347826087, 0.36363636363636
72234, 1.5478260869565, 0.90652173913044, 0.36363636363636
72235, 1.5478260869565, 0.8804347826087, 0.34090909090909
72236, 1.5260869565217, 0.8804347826087, 0.31818181818182
72237, 1.5478260869565, 0.90652173913044, 0.31818181818182
72238, 1.5478260869565, 0.8804347826087, 0.29545454545455
72239, 1.5260869565217, 0.8804347826087, 0.27272727272727
72240, 1.5478260869565, 0.90652173913044, 0.27272727272727
72241, 1.5478260869565, 0.8804347826087, 0.25
72242, 1.5260869565217, 0.8804347826087, 0.22727272727273
72243, 1.5478260869565, 0.90652173913044, 0.22727272727273
72244, 1.5478260869565, 0.8804347826087, 0.20454545454545
72245, 1.5260869565217, 0.8804347826087, 0.18181818181818
72246, 1.5478260869565, 0.90652173913044, 0.18181818181818
72247, 1.5478260869565, 0.8804347826087, 0.15909090909091
72248, 1.5260869565217, 0.8804347826087, 0.13636363636364
72249, 1.5478260869565, 0.90652173913044, 0.13636363636364
72250, 1.5478260869565, 0.8804347826087, 0.11363636363636
72251, 1.5260869565217, 0.8804347826087, 0.090909090909091
72252, 1.5478260869565, 0.90652173913044, 0.090909090909091
72253, 1.5478260869565, 0.8804347826087, 0.068181818181818
72254, 1.5260869565217, 0.8804347826087, 0.045454545454545
72255, 1.5478260869565, 0.90652173913044, 0.045454545454545
72256, 1.5478260869565, 0.8804347826087, 0.022727272727273
72257, 1.5913043478261, 0.8804347826087, 0.47727272727273
72258, 1.5695652173913, 0.8804347826087, 0.45454545454545
72259, 1.5913043478261, 0.90652173913044, 0.45454545454545
72260, 1.5913043478261, 0.8804347826087, 0.43181818181818
72261, 1.5695652173913, 0.8804347826087, 0.40909090909091
72262, 1.5913043478261, 0.90652173913044, 0.40909090909091
72263, 1.5913043478261, 0.8804347826087, 0.38636363636364
72264, 1.5695652173913, 0.8804347826087, 0.36363636363636
72265, 1.5913043478261, 0.90652173913044, 0.36363636363636
72266, 1.5913043478261, 0.8804347826087, 0.34090909090909
72267, 1.5695652173913, 0.8804347826087, 0.31818181818182
72268, 1.5913043478261, 0.90652173913044, 0.31818181818182
72269, 1.5913043478261, 0.8804347826087, 0.29545454545455
72270, 1.5695652173913, 0.8804347826087, 0.27272727272727
72271, 1.5913043478261, 0.90652173913044, 0.27272727272727
72272, 1.5913043478261, 0.8804347826087, 0.25
72273, 1.5695652173913, 0.8804347826087, 0.22727272727273
72274, 1.5913043478261, 0.90652173913044, 0.22727272727273
72275, 1.5913043478261, 0.8804347826087, 0.20454545454545
72276, 1.5695652173913, 0.8804347826087, 0.18181818181818
72277, 1.5913043478261, 0.90652173913044, 0.18181818181818
72278, 1.5913043478261, 0.8804347826087, 0.15909090909091
72279, 1.5695652173913, 0.8804347826087, 0.13636363636364
72280, 1.5913043478261, 0.90652173913044, 0.13636363636364
72281, 1.5913043478261, 0.8804347826087, 0.11363636363636
72282, 1.5695652173913, 0.8804347826087, 0.090909090909091
72283, 1.5913043478261, 0.90652173913044, 0.090909090909091
72284, 1.5913043478261, 0.8804347826087, 0.068181818181818
72285, 1.5695652173913, 0.8804347826087, 0.045454545454545
72286, 1.5913043478261, 0.90652173913044, 0.045454545454545
72287, 1.5913043478261, 0.8804347826087, 0.022727272727273
72288, 1.6347826086957, 0.8804347826087, 0.47727272727273
72289, 1.6130434782609, 0.8804347826087, 0.45454545454545
72290, 1.6347826086957, 0.90652173913044, 0.45454545454545
72291, 1.6347826086957, 0.8804347826087, 0.43181818181818
72292, 1.6130434782609, 0.8804347826087, 0.40909090909091
72293, 1.6347826086957, 0.90652173913044, 0.40909090909091
72294, 1.6347826086957, 0.8804347826087, 0.38636363636364
72295, 1.6130434782609, 0.8804347826087, 0.36363636363636
72296, 1.6347826086957, 0.90652173913044, 0.36363636363636
72297, 1.6347826086957, 0.8804347826087, 0.34090909090909
72298, 1.6130434782609, 0.8804347826087, 0.31818181818182
72299, 1.6347826086957, 0.90652173913044, 0.31818181818182
72300, 1.6347826086957, 0.8804347826087, 0.29545454545455
72301, 1.6130434782609, 0.8804347826087, 0.27272727272727
72302, 1.6347826086957, 0.90652173913044, 0.27272727272727
72303, 1.6347826086957, 0.8804347826087, 0.25
72304, 1.6130434782609, 0.8804347826087, 0.22727272727273
72305, 1.6347826086957, 0.90652173913044, 0.22727272727273
72306, 1.6347826086957, 0.8804347826087, 0.20454545454545
72307, 1.6130434782609, 0.8804347826087, 0.18181818181818
72308, 1.6347826086957, 0.90652173913044, 0.18181818181818
72309, 1.6347826086957, 0.8804347826087, 0.15909090909091
72310, 1.6130434782609, 0.8804347826087, 0.13636363636364
72311, 1.6347826086957, 0.90652173913044, 0.13636363636364
72312, 1.6347826086957, 0.8804347826087, 0.11363636363636
72313, 1.6130434782609, 0.8804347826087, 0.090909090909091
72314, 1.6347826086957, 0.90652173913044, 0.090909090909091
72315, 1.6347826086957, 0.8804347826087, 0.068181818181818
72316, 1.6130434782609, 0.8804347826087, 0.045454545454545
72317, 1.6347826086957, 0.90652173913044, 0.045454545454545
72318, 1.6347826086957, 0.8804347826087, 0.022727272727273
72319, 1.6782608695652, 0.8804347826087, 0.47727272727273
72320, 1.6565217391304, 0.8804347826087, 0.45454545454545
72321, 1.6782608695652, 0.90652173913044, 0.45454545454545
72322, 1.6782608695652, 0.8804347826087, 0.43181818181818
72323, 1.6565217391304, 0.8804347826087, 0.40909090909091
72324, 1.6782608695652, 0.90652173913044, 0.40909090909091
72325, 1.6782608695652, 0.8804347826087, 0.38636363636364
72326, 1.6565217391304, 0.8804347826087, 0.36363636363636
72327, 1.6782608695652, 0.90652173913044, 0.36363636363636
72328, 1.6782608695652, 0.8804347826087, 0.34090909090909
72329, 1.6565217391304, 0.8804347826087, 0.31818181818182
72330, 1.6782608695652, 0.90652173913044, 0.31818181818182
72331, 1.6782608695652, 0.8804347826087, 0.29545454545455
72332, 1.6565217391304, 0.8804347826087, 0.27272727272727
72333, 1.6782608695652, 0.90652173913044, 0.27272727272727
72334, 1.6782608695652, 0.8804347826087, 0.25
72335, 1.6565217391304, 0.8804347826087, 0.22727272727273
72336, 1.6782608695652, 0.90652173913044, 0.22727272727273
72337, 1.6782608695652, 0.8804347826087, 0.20454545454545
72338, 1.6565217391304, 0.8804347826087, 0.18181818181818
72339, 1.6782608695652, 0.90652173913044, 0.18181818181818
72340, 1.6782608695652, 0.8804347826087, 0.15909090909091
72341, 1.6565217391304, 0.8804347826087, 0.13636363636364
72342, 1.6782608695652, 0.90652173913044, 0.13636363636364
72343, 1.6782608695652, 0.8804347826087, 0.11363636363636
72344, 1.6565217391304, 0.8804347826087, 0.090909090909091
72345, 1.6782608695652, 0.90652173913044, 0.090909090909091
72346, 1.6782608695652, 0.8804347826087, 0.068181818181818
72347, 1.6565217391304, 0.8804347826087, 0.045454545454545
72348, 1.6782608695652, 0.90652173913044, 0.045454545454545
72349, 1.6782608695652, 0.8804347826087, 0.022727272727273
72350, 1.7217391304348, 0.8804347826087, 0.47727272727273
72351, 1.7, 0.8804347826087, 0.45454545454545
72352, 1.7217391304348, 0.90652173913044, 0.45454545454545
72353, 1.7217391304348, 0.8804347826087, 0.43181818181818
72354, 1.7, 0.8804347826087, 0.40909090909091
72355, 1.7217391304348, 0.90652173913044, 0.40909090909091
72356, 1.7217391304348, 0.8804347826087, 0.38636363636364
72357, 1.7, 0.8804347826087, 0.36363636363636
72358, 1.7217391304348, 0.90652173913044, 0.36363636363636
72359, 1.7217391304348, 0.8804347826087, 0.34090909090909
72360, 1.7, 0.8804347826087, 0.31818181818182
72361, 1.7217391304348, 0.90652173913044, 0.31818181818182
72362, 1.7217391304348, 0.8804347826087, 0.29545454545455
72363, 1.7, 0.8804347826087, 0.27272727272727
72364, 1.7217391304348, 0.90652173913044, 0.27272727272727
72365, 1.7217391304348, 0.8804347826087, 0.25
72366, 1.7, 0.8804347826087, 0.22727272727273
72367, 1.7217391304348, 0.90652173913044, 0.22727272727273
72368, 1.7217391304348, 0.8804347826087, 0.20454545454545
72369, 1.7, 0.8804347826087, 0.18181818181818
72370, 1.7217391304348, 0.90652173913044, 0.18181818181818
72371, 1.7217391304348, 0.8804347826087, 0.15909090909091
72372, 1.7, 0.8804347826087, 0.13636363636364
72373, 1.7217391304348, 0.90652173913044, 0.13636363636364
72374, 1.7217391304348, 0.8804347826087, 0.11363636363636
72375, 1.7, 0.8804347826087, 0.090909090909091
72376, 1.7217391304348, 0.90652173913044, 0.090909090909091
72377, 1.7217391304348, 0.8804347826087, 0.068181818181818
72378, 1.7, 0.8804347826087, 0.045454545454545
72379, 1.7217391304348, 0.90652173913044, 0.045454545454545
72380, 1.7217391304348, 0.8804347826087, 0.022727272727273
72381, 1.7652173913043, 0.8804347826087, 0.47727272727273
72382, 1.7434782608696, 0.8804347826087, 0.45454545454545
72383, 1.7652173913043, 0.90652173913044, 0.45454545454545
72384, 1.7652173913043, 0.8804347826087, 0.43181818181818
72385, 1.7434782608696, 0.8804347826087, 0.40909090909091
72386, 1.7652173913043, 0.90652173913044, 0.40909090909091
72387, 1.7652173913043, 0.8804347826087, 0.38636363636364
72388, 1.7434782608696, 0.8804347826087, 0.36363636363636
72389, 1.7652173913043, 0.90652173913044, 0.36363636363636
72390, 1.7652173913043, 0.8804347826087, 0.34090909090909
72391, 1.7434782608696, 0.8804347826087, 0.31818181818182
72392, 1.7652173913043, 0.90652173913044, 0.31818181818182
72393, 1.7652173913043, 0.8804347826087, 0.29545454545455
72394, 1.7434782608696, 0.8804347826087, 0.27272727272727
72395, 1.7652173913043, 0.90652173913044, 0.27272727272727
72396, 1.7652173913043, 0.8804347826087, 0.25
72397, 1.7434782608696, 0.8804347826087, 0.22727272727273
72398, 1.7652173913043, 0.90652173913044, 0.22727272727273
72399, 1.7652173913043, 0.8804347826087, 0.20454545454545
72400, 1.7434782608696, 0.8804347826087, 0.18181818181818
72401, 1.7652173913043, 0.90652173913044, 0.18181818181818
72402, 1.7652173913043, 0.8804347826087, 0.15909090909091
72403, 1.7434782608696, 0.8804347826087, 0.13636363636364
72404, 1.7652173913043, 0.90652173913044, 0.13636363636364
72405, 1.7652173913043, 0.8804347826087, 0.11363636363636
72406, 1.7434782608696, 0.8804347826087, 0.090909090909091
72407, 1.7652173913043, 0.90652173913044, 0.090909090909091
72408, 1.7652173913043, 0.8804347826087, 0.068181818181818
72409, 1.7434782608696, 0.8804347826087, 0.045454545454545
72410, 1.7652173913043, 0.90652173913044, 0.045454545454545
72411, 1.7652173913043, 0.8804347826087, 0.022727272727273
72412, 1.8086956521739, 0.8804347826087, 0.47727272727273
72413, 1.7869565217391, 0.8804347826087, 0.45454545454545
72414, 1.8086956521739, 0.90652173913044, 0.45454545454545
72415, 1.8086956521739, 0.8804347826087, 0.43181818181818
72416, 1.7869565217391, 0.8804347826087, 0.40909090909091
72417, 1.8086956521739, 0.90652173913044, 0.40909090909091
72418, 1.8086956521739, 0.8804347826087, 0.38636363636364
72419, 1.7869565217391, 0.8804347826087, 0.36363636363636
72420, 1.8086956521739, 0.90652173913044, 0.36363636363636
72421, 1.8086956521739, 0.8804347826087, 0.34090909090909
72422, 1.7869565217391, 0.8804347826087, 0.31818181818182
72423, 1.8086956521739, 0.90652173913044, 0.31818181818182
72424, 1.8086956521739, 0.8804347826087, 0.29545454545455
72425, 1.7869565217391, 0.8804347826087, 0.27272727272727
72426, 1.8086956521739, 0.90652173913044, 0.27272727272727
72427, 1.8086956521739, 0.8804347826087, 0.25
72428, 1.7869565217391, 0.8804347826087, 0.22727272727273
72429, 1.8086956521739, 0.90652173913044, 0.22727272727273
72430, 1.8086956521739, 0.8804347826087, 0.20454545454545
72431, 1.7869565217391, 0.8804347826087, 0.18181818181818
72432, 1.8086956521739, 0.90652173913044, 0.18181818181818
72433, 1.8086956521739, 0.8804347826087, 0.15909090909091
72434, 1.7869565217391, 0.8804347826087, 0.13636363636364
72435, 1.8086956521739, 0.90652173913044, 0.13636363636364
72436, 1.8086956521739, 0.8804347826087, 0.11363636363636
72437, 1.7869565217391, 0.8804347826087, 0.090909090909091
72438, 1.8086956521739, 0.90652173913044, 0.090909090909091
72439, 1.8086956521739, 0.8804347826087, 0.068181818181818
72440, 1.7869565217391, 0.8804347826087, 0.045454545454545
72441, 1.8086956521739, 0.90652173913044, 0.045454545454545
72442, 1.8086956521739, 0.8804347826087, 0.022727272727273
72443, 1.8521739130435, 0.8804347826087, 0.47727272727273
72444, 1.8304347826087, 0.8804347826087, 0.45454545454545
72445, 1.8521739130435, 0.90652173913044, 0.45454545454545
72446, 1.8521739130435, 0.8804347826087, 0.43181818181818
72447, 1.8304347826087, 0.8804347826087, 0.40909090909091
72448, 1.8521739130435, 0.90652173913044, 0.40909090909091
72449, 1.8521739130435, 0.8804347826087, 0.38636363636364
72450, 1.8304347826087, 0.8804347826087, 0.36363636363636
72451, 1.8521739130435, 0.90652173913044, 0.36363636363636
72452, 1.8521739130435, 0.8804347826087, 0.34090909090909
72453, 1.8304347826087, 0.8804347826087, 0.31818181818182
72454, 1.8521739130435, 0.90652173913044, 0.31818181818182
72455, 1.8521739130435, 0.8804347826087, 0.29545454545455
72456, 1.8304347826087, 0.8804347826087, 0.27272727272727
72457, 1.8521739130435, 0.90652173913044, 0.27272727272727
72458, 1.8521739130435, 0.8804347826087, 0.25
72459, 1.8304347826087, 0.8804347826087, 0.22727272727273
72460, 1.8521739130435, 0.90652173913044, 0.22727272727273
72461, 1.8521739130435, 0.8804347826087, 0.20454545454545
72462, 1.8304347826087, 0.8804347826087, 0.18181818181818
72463, 1.8521739130435, 0.90652173913044, 0.18181818181818
72464, 1.8521739130435, 0.8804347826087, 0.15909090909091
72465, 1.8304347826087, 0.8804347826087, 0.13636363636364
72466, 1.8521739130435, 0.90652173913044, 0.13636363636364
72467, 1.8521739130435, 0.8804347826087, 0.11363636363636
72468, 1.8304347826087, 0.8804347826087, 0.090909090909091
72469, 1.8521739130435, 0.90652173913044, 0.090909090909091
72470, 1.8521739130435, 0.8804347826087, 0.068181818181818
72471, 1.8304347826087, 0.8804347826087, 0.045454545454545
72472, 1.8521739130435, 0.90652173913044, 0.045454545454545
72473, 1.8521739130435, 0.8804347826087, 0.022727272727273
72474, 1.895652173913, 0.8804347826087, 0.47727272727273
72475, 1.8739130434783, 0.8804347826087, 0.45454545454545
72476, 1.895652173913, 0.90652173913044, 0.45454545454545
72477, 1.895652173913, 0.8804347826087, 0.43181818181818
72478, 1.8739130434783, 0.8804347826087, 0.40909090909091
72479, 1.895652173913, 0.90652173913044, 0.40909090909091
72480, 1.895652173913, 0.8804347826087, 0.38636363636364
72481, 1.8739130434783, 0.8804347826087, 0.36363636363636
72482, 1.895652173913, 0.90652173913044, 0.36363636363636
72483, 1.895652173913, 0.8804347826087, 0.34090909090909
72484, 1.8739130434783, 0.8804347826087, 0.31818181818182
72485, 1.895652173913, 0.90652173913044, 0.31818181818182
72486, 1.895652173913, 0.8804347826087, 0.29545454545455
72487, 1.8739130434783, 0.8804347826087, 0.27272727272727
72488, 1.895652173913, 0.90652173913044, 0.27272727272727
72489, 1.895652173913, 0.8804347826087, 0.25
72490, 1.8739130434783, 0.8804347826087, 0.22727272727273
72491, 1.895652173913, 0.90652173913044, 0.22727272727273
72492, 1.895652173913, 0.8804347826087, 0.20454545454545
72493, 1.8739130434783, 0.8804347826087, 0.18181818181818
72494, 1.895652173913, 0.90652173913044, 0.18181818181818
72495, 1.895652173913, 0.8804347826087, 0.15909090909091
72496, 1.8739130434783, 0.8804347826087, 0.13636363636364
72497, 1.895652173913, 0.90652173913044, 0.13636363636364
72498, 1.895652173913, 0.8804347826087, 0.11363636363636
72499, 1.8739130434783, 0.8804347826087, 0.090909090909091
72500, 1.895652173913, 0.90652173913044, 0.090909090909091
72501, 1.895652173913, 0.8804347826087, 0.068181818181818
72502, 1.8739130434783, 0.8804347826087, 0.045454545454545
72503, 1.895652173913, 0.90652173913044, 0.045454545454545
72504, 1.895652173913, 0.8804347826087, 0.022727272727273
72505, 1.9391304347826, 0.8804347826087, 0.47727272727273
72506, 1.9173913043478, 0.8804347826087, 0.45454545454545
72507, 1.9391304347826, 0.90652173913044, 0.45454545454545
72508, 1.9391304347826, 0.8804347826087, 0.43181818181818
72509, 1.9173913043478, 0.8804347826087, 0.40909090909091
72510, 1.9391304347826, 0.90652173913044, 0.40909090909091
72511, 1.9391304347826, 0.8804347826087, 0.38636363636364
72512, 1.9173913043478, 0.8804347826087, 0.36363636363636
72513, 1.9391304347826, 0.90652173913044, 0.36363636363636
72514, 1.9391304347826, 0.8804347826087, 0.34090909090909
72515, 1.9173913043478, 0.8804347826087, 0.31818181818182
72516, 1.9391304347826, 0.90652173913044, 0.31818181818182
72517, 1.9391304347826, 0.8804347826087, 0.29545454545455
72518, 1.9173913043478, 0.8804347826087, 0.27272727272727
72519, 1.9391304347826, 0.90652173913044, 0.27272727272727
72520, 1.9391304347826, 0.8804347826087, 0.25
72521, 1.9173913043478, 0.8804347826087, 0.22727272727273
72522, 1.9391304347826, 0.90652173913044, 0.22727272727273
72523, 1.9391304347826, 0.8804347826087, 0.20454545454545
72524, 1.9173913043478, 0.8804347826087, 0.18181818181818
72525, 1.9391304347826, 0.90652173913044, 0.18181818181818
72526, 1.9391304347826, 0.8804347826087, 0.15909090909091
72527, 1.9173913043478, 0.8804347826087, 0.13636363636364
72528, 1.9391304347826, 0.90652173913044, 0.13636363636364
72529, 1.9391304347826, 0.8804347826087, 0.11363636363636
72530, 1.9173913043478, 0.8804347826087, 0.090909090909091
72531, 1.9391304347826, 0.90652173913044, 0.090909090909091
72532, 1.9391304347826, 0.8804347826087, 0.068181818181818
72533, 1.9173913043478, 0.8804347826087, 0.045454545454545
72534, 1.9391304347826, 0.90652173913044, 0.045454545454545
72535, 1.9391304347826, 0.8804347826087, 0.022727272727273
72536, 1.9826086956522, 0.8804347826087, 0.47727272727273
72537, 1.9608695652174, 0.8804347826087, 0.45454545454545
72538, 1.9826086956522, 0.90652173913044, 0.45454545454545
72539, 1.9826086956522, 0.8804347826087, 0.43181818181818
72540, 1.9608695652174, 0.8804347826087, 0.40909090909091
72541, 1.9826086956522, 0.90652173913044, 0.40909090909091
72542, 1.9826086956522, 0.8804347826087, 0.38636363636364
72543, 1.9608695652174, 0.8804347826087, 0.36363636363636
72544, 1.9826086956522, 0.90652173913044, 0.36363636363636
72545, 1.9826086956522, 0.8804347826087, 0.34090909090909
72546, 1.9608695652174, 0.8804347826087, 0.31818181818182
72547, 1.9826086956522, 0.90652173913044, 0.31818181818182
72548, 1.9826086956522, 0.8804347826087, 0.29545454545455
72549, 1.9608695652174, 0.8804347826087, 0.27272727272727
72550, 1.9826086956522, 0.90652173913044, 0.27272727272727
72551, 1.9826086956522, 0.8804347826087, 0.25
72552, 1.9608695652174, 0.8804347826087, 0.22727272727273
72553, 1.9826086956522, 0.90652173913044, 0.22727272727273
72554, 1.9826086956522, 0.8804347826087, 0.20454545454545
72555, 1.9608695652174, 0.8804347826087, 0.18181818181818
72556, 1.9826086956522, 0.90652173913044, 0.18181818181818
72557, 1.9826086956522, 0.8804347826087, 0.15909090909091
72558, 1.9608695652174, 0.8804347826087, 0.13636363636364
72559, 1.9826086956522, 0.90652173913044, 0.13636363636364
72560, 1.9826086956522, 0.8804347826087, 0.11363636363636
72561, 1.9608695652174, 0.8804347826087, 0.090909090909091
72562, 1.9826086956522, 0.90652173913044, 0.090909090909091
72563, 1.9826086956522, 0.8804347826087, 0.068181818181818
72564, 1.9608695652174, 0.8804347826087, 0.045454545454545
72565, 1.9826086956522, 0.90652173913044, 0.045454545454545
72566, 1.9826086956522, 0.8804347826087, 0.022727272727273
72567, 2.0260869565217, 0.8804347826087, 0.47727272727273
72568, 2.004347826087, 0.8804347826087, 0.45454545454545
72569, 2.0260869565217, 0.90652173913044, 0.45454545454545
72570, 2.0260869565217, 0.8804347826087, 0.43181818181818
72571, 2.004347826087, 0.8804347826087, 0.40909090909091
72572, 2.0260869565217, 0.90652173913044, 0.40909090909091
72573, 2.0260869565217, 0.8804347826087, 0.38636363636364
72574, 2.004347826087, 0.8804347826087, 0.36363636363636
72575, 2.0260869565217, 0.90652173913044, 0.36363636363636
72576, 2.0260869565217, 0.8804347826087, 0.34090909090909
72577, 2.004347826087, 0.8804347826087, 0.31818181818182
72578, 2.0260869565217, 0.90652173913044, 0.31818181818182
72579, 2.0260869565217, 0.8804347826087, 0.29545454545455
72580, 2.004347826087, 0.8804347826087, 0.27272727272727
72581, 2.0260869565217, 0.90652173913044, 0.27272727272727
72582, 2.0260869565217, 0.8804347826087, 0.25
72583, 2.004347826087, 0.8804347826087, 0.22727272727273
72584, 2.0260869565217, 0.90652173913044, 0.22727272727273
72585, 2.0260869565217, 0.8804347826087, 0.20454545454545
72586, 2.004347826087, 0.8804347826087, 0.18181818181818
72587, 2.0260869565217, 0.90652173913044, 0.18181818181818
72588, 2.0260869565217, 0.8804347826087, 0.15909090909091
72589, 2.004347826087, 0.8804347826087, 0.13636363636364
72590, 2.0260869565217, 0.90652173913044, 0.13636363636364
72591, 2.0260869565217, 0.8804347826087, 0.11363636363636
72592, 2.004347826087, 0.8804347826087, 0.090909090909091
72593, 2.0260869565217, 0.90652173913044, 0.090909090909091
72594, 2.0260869565217, 0.8804347826087, 0.068181818181818
72595, 2.004347826087, 0.8804347826087, 0.045454545454545
72596, 2.0260869565217, 0.90652173913044, 0.045454545454545
72597, 2.0260869565217, 0.8804347826087, 0.022727272727273
72598, 2.0695652173913, 0.8804347826087, 0.47727272727273
72599, 2.0478260869565, 0.8804347826087, 0.45454545454545
72600, 2.0695652173913, 0.90652173913044, 0.45454545454545
72601, 2.0695652173913, 0.8804347826087, 0.43181818181818
72602, 2.0478260869565, 0.8804347826087, 0.40909090909091
72603, 2.0695652173913, 0.90652173913044, 0.40909090909091
72604, 2.0695652173913, 0.8804347826087, 0.38636363636364
72605, 2.0478260869565, 0.8804347826087, 0.36363636363636
72606, 2.0695652173913, 0.90652173913044, 0.36363636363636
72607, 2.0695652173913, 0.8804347826087, 0.34090909090909
72608, 2.0478260869565, 0.8804347826087, 0.31818181818182
72609, 2.0695652173913, 0.90652173913044, 0.31818181818182
72610, 2.0695652173913, 0.8804347826087, 0.29545454545455
72611, 2.0478260869565, 0.8804347826087, 0.27272727272727
72612, 2.0695652173913, 0.90652173913044, 0.27272727272727
72613, 2.0695652173913, 0.8804347826087, 0.25
72614, 2.0478260869565, 0.8804347826087, 0.22727272727273
72615, 2.0695652173913, 0.90652173913044, 0.22727272727273
72616, 2.0695652173913, 0.8804347826087, 0.20454545454545
72617, 2.0478260869565, 0.8804347826087, 0.18181818181818
72618, 2.0695652173913, 0.90652173913044, 0.18181818181818
72619, 2.0695652173913, 0.8804347826087, 0.15909090909091
72620, 2.0478260869565, 0.8804347826087, 0.13636363636364
72621, 2.0695652173913, 0.90652173913044, 0.13636363636364
72622, 2.0695652173913, 0.8804347826087, 0.11363636363636
72623, 2.0478260869565, 0.8804347826087, 0.090909090909091
72624, 2.0695652173913, 0.90652173913044, 0.090909090909091
72625, 2.0695652173913, 0.8804347826087, 0.068181818181818
72626, 2.0478260869565, 0.8804347826087, 0.045454545454545
72627, 2.0695652173913, 0.90652173913044, 0.045454545454545
72628, 2.0695652173913, 0.8804347826087, 0.022727272727273
72629, 2.1130434782609, 0.8804347826087, 0.47727272727273
72630, 2.0913043478261, 0.8804347826087, 0.45454545454545
72631, 2.1130434782609, 0.90652173913044, 0.45454545454545
72632, 2.1130434782609, 0.8804347826087, 0.43181818181818
72633, 2.0913043478261, 0.8804347826087, 0.40909090909091
72634, 2.1130434782609, 0.90652173913044, 0.40909090909091
72635, 2.1130434782609, 0.8804347826087, 0.38636363636364
72636, 2.0913043478261, 0.8804347826087, 0.36363636363636
72637, 2.1130434782609, 0.90652173913044, 0.36363636363636
72638, 2.1130434782609, 0.8804347826087, 0.34090909090909
72639, 2.0913043478261, 0.8804347826087, 0.31818181818182
72640, 2.1130434782609, 0.90652173913044, 0.31818181818182
72641, 2.1130434782609, 0.8804347826087, 0.29545454545455
72642, 2.0913043478261, 0.8804347826087, 0.27272727272727
72643, 2.1130434782609, 0.90652173913044, 0.27272727272727
72644, 2.1130434782609, 0.8804347826087, 0.25
72645, 2.0913043478261, 0.8804347826087, 0.22727272727273
72646, 2.1130434782609, 0.90652173913044, 0.22727272727273
72647, 2.1130434782609, 0.8804347826087, 0.20454545454545
72648, 2.0913043478261, 0.8804347826087, 0.18181818181818
72649, 2.1130434782609, 0.90652173913044, 0.18181818181818
72650, 2.1130434782609, 0.8804347826087, 0.15909090909091
72651, 2.0913043478261, 0.8804347826087, 0.13636363636364
72652, 2.1130434782609, 0.90652173913044, 0.13636363636364
72653, 2.1130434782609, 0.8804347826087, 0.11363636363636
72654, 2.0913043478261, 0.8804347826087, 0.090909090909091
72655, 2.1130434782609, 0.90652173913044, 0.090909090909091
72656, 2.1130434782609, 0.8804347826087, 0.068181818181818
72657, 2.0913043478261, 0.8804347826087, 0.045454545454545
72658, 2.1130434782609, 0.90652173913044, 0.045454545454545
72659, 2.1130434782609, 0.8804347826087, 0.022727272727273
72660, 2.1565217391304, 0.8804347826087, 0.47727272727273
72661, 2.1347826086957, 0.8804347826087, 0.45454545454545
72662, 2.1565217391304, 0.90652173913044, 0.45454545454545
72663, 2.1565217391304, 0.8804347826087, 0.43181818181818
72664, 2.1347826086957, 0.8804347826087, 0.40909090909091
72665, 2.1565217391304, 0.90652173913044, 0.40909090909091
72666, 2.1565217391304, 0.8804347826087, 0.38636363636364
72667, 2.1347826086957, 0.8804347826087, 0.36363636363636
72668, 2.1565217391304, 0.90652173913044, 0.36363636363636
72669, 2.1565217391304, 0.8804347826087, 0.34090909090909
72670, 2.1347826086957, 0.8804347826087, 0.31818181818182
72671, 2.1565217391304, 0.90652173913044, 0.31818181818182
72672, 2.1565217391304, 0.8804347826087, 0.29545454545455
72673, 2.1347826086957, 0.8804347826087, 0.27272727272727
72674, 2.1565217391304, 0.90652173913044, 0.27272727272727
72675, 2.1565217391304, 0.8804347826087, 0.25
72676, 2.1347826086957, 0.8804347826087, 0.22727272727273
72677, 2.1565217391304, 0.90652173913044, 0.22727272727273
72678, 2.1565217391304, 0.8804347826087, 0.20454545454545
72679, 2.1347826086957, 0.8804347826087, 0.18181818181818
72680, 2.1565217391304, 0.90652173913044, 0.18181818181818
72681, 2.1565217391304, 0.8804347826087, 0.15909090909091
72682, 2.1347826086957, 0.8804347826087, 0.13636363636364
72683, 2.1565217391304, 0.90652173913044, 0.13636363636364
72684, 2.1565217391304, 0.8804347826087, 0.11363636363636
72685, 2.1347826086957, 0.8804347826087, 0.090909090909091
72686, 2.1565217391304, 0.90652173913044, 0.090909090909091
72687, 2.1565217391304, 0.8804347826087, 0.068181818181818
72688, 2.1347826086957, 0.8804347826087, 0.045454545454545
72689, 2.1565217391304, 0.90652173913044, 0.045454545454545
72690, 2.1565217391304, 0.8804347826087, 0.022727272727273
72691, 2.1782608695652, 0.8804347826087, 0.45454545454545
72692, 2.1782608695652, 0.8804347826087, 0.40909090909091
72693, 2.1782608695652, 0.8804347826087, 0.36363636363636
72694, 2.1782608695652, 0.8804347826087, 0.31818181818182
72695, 2.1782608695652, 0.8804347826087, 0.27272727272727
72696, 2.1782608695652, 0.8804347826087, 0.22727272727273
72697, 2.1782608695652, 0.8804347826087, 0.18181818181818
72698, 2.1782608695652, 0.8804347826087, 0.13636363636364
72699, 2.1782608695652, 0.8804347826087, 0.090909090909091
72700, 2.1782608695652, 0.8804347826087, 0.045454545454545
72701, 1.2434782608696, 0.82826086956522, 0.47727272727273
72702, 1.2217391304348, 0.82826086956522, 0.45454545454545
72703, 1.2434782608696, 0.85434782608696, 0.45454545454545
72704, 1.2434782608696, 0.82826086956522, 0.43181818181818
72705, 1.2217391304348, 0.82826086956522, 0.40909090909091
72706, 1.2434782608696, 0.85434782608696, 0.40909090909091
72707, 1.2434782608696, 0.82826086956522, 0.38636363636364
72708, 1.2217391304348, 0.82826086956522, 0.36363636363636
72709, 1.2434782608696, 0.85434782608696, 0.36363636363636
72710, 1.2434782608696, 0.82826086956522, 0.34090909090909
72711, 1.2217391304348, 0.82826086956522, 0.31818181818182
72712, 1.2434782608696, 0.85434782608696, 0.31818181818182
72713, 1.2434782608696, 0.82826086956522, 0.29545454545455
72714, 1.2217391304348, 0.82826086956522, 0.27272727272727
72715, 1.2434782608696, 0.85434782608696, 0.27272727272727
72716, 1.2434782608696, 0.82826086956522, 0.25
72717, 1.2217391304348, 0.82826086956522, 0.22727272727273
72718, 1.2434782608696, 0.85434782608696, 0.22727272727273
72719, 1.2434782608696, 0.82826086956522, 0.20454545454545
72720, 1.2217391304348, 0.82826086956522, 0.18181818181818
72721, 1.2434782608696, 0.85434782608696, 0.18181818181818
72722, 1.2434782608696, 0.82826086956522, 0.15909090909091
72723, 1.2217391304348, 0.82826086956522, 0.13636363636364
72724, 1.2434782608696, 0.85434782608696, 0.13636363636364
72725, 1.2434782608696, 0.82826086956522, 0.11363636363636
72726, 1.2217391304348, 0.82826086956522, 0.090909090909091
72727, 1.2434782608696, 0.85434782608696, 0.090909090909091
72728, 1.2434782608696, 0.82826086956522, 0.068181818181818
72729, 1.2217391304348, 0.82826086956522, 0.045454545454545
72730, 1.2434782608696, 0.85434782608696, 0.045454545454545
72731, 1.2434782608696, 0.82826086956522, 0.022727272727273
72732, 1.2869565217391, 0.82826086956522, 0.47727272727273
72733, 1.2652173913043, 0.82826086956522, 0.45454545454545
72734, 1.2869565217391, 0.85434782608696, 0.45454545454545
72735, 1.2869565217391, 0.82826086956522, 0.43181818181818
72736, 1.2652173913043, 0.82826086956522, 0.40909090909091
72737, 1.2869565217391, 0.85434782608696, 0.40909090909091
72738, 1.2869565217391, 0.82826086956522, 0.38636363636364
72739, 1.2652173913043, 0.82826086956522, 0.36363636363636
72740, 1.2869565217391, 0.85434782608696, 0.36363636363636
72741, 1.2869565217391, 0.82826086956522, 0.34090909090909
72742, 1.2652173913043, 0.82826086956522, 0.31818181818182
