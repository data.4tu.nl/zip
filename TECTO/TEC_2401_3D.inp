3313, 1.2, -0.2, 0.068181818181818
3314, 1.2, -0.2, 0.11363636363636
3315, 1.2, -0.2, 0.15909090909091
3316, 1.2, -0.2, 0.20454545454545
3317, 1.2, -0.2, 0.25
3318, 1.2, -0.2, 0.29545454545455
3319, 1.2, -0.2, 0.34090909090909
3320, 1.2, -0.2, 0.38636363636364
3321, 1.2, -0.2, 0.43181818181818
3322, 1.2, -0.2, 0.47727272727273
3323, 1.04, 0, 0.5
3324, 1.08, 0, 0.5
3325, 1.12, 0, 0.5
3326, 1.16, 0, 0.5
3327, 1.02, 0, 0.5
3328, 1.06, 0, 0.5
3329, 1.1, 0, 0.5
3330, 1.14, 0, 0.5
3331, 1.18, 0, 0.5
3332, 1.04, -0.2, 0.5
3333, 1.08, -0.2, 0.5
3334, 1.12, -0.2, 0.5
3335, 1.16, -0.2, 0.5
3336, 1.02, -0.2, 0.5
3337, 1.06, -0.2, 0.5
3338, 1.1, -0.2, 0.5
3339, 1.14, -0.2, 0.5
3340, 1.18, -0.2, 0.5
3341, 1.04, 0, 0
3342, 1.08, 0, 0
3343, 1.12, 0, 0
3344, 1.16, 0, 0
3345, 1.02, 0, 0
3346, 1.06, 0, 0
3347, 1.1, 0, 0
3348, 1.14, 0, 0
3349, 1.18, 0, 0
3350, 1.04, -0.2, 0
3351, 1.08, -0.2, 0
3352, 1.12, -0.2, 0
3353, 1.16, -0.2, 0
3354, 1.02, -0.2, 0
3355, 1.06, -0.2, 0
3356, 1.1, -0.2, 0
3357, 1.14, -0.2, 0
3358, 1.18, -0.2, 0
3359, 0, 0.033333333333333, 0.045454545454545
3360, 0, 0.066666666666667, 0.045454545454545
3361, 0, 0.033333333333333, 0.090909090909091
3362, 0, 0.066666666666667, 0.090909090909091
3363, 0, 0.033333333333333, 0.13636363636364
3364, 0, 0.066666666666667, 0.13636363636364
3365, 0, 0.033333333333333, 0.18181818181818
3366, 0, 0.066666666666667, 0.18181818181818
3367, 0, 0.033333333333333, 0.22727272727273
3368, 0, 0.066666666666667, 0.22727272727273
3369, 0, 0.033333333333333, 0.27272727272727
3370, 0, 0.066666666666667, 0.27272727272727
3371, 0, 0.033333333333333, 0.31818181818182
3372, 0, 0.066666666666667, 0.31818181818182
3373, 0, 0.033333333333333, 0.36363636363636
3374, 0, 0.066666666666667, 0.36363636363636
3375, 0, 0.033333333333333, 0.40909090909091
3376, 0, 0.066666666666667, 0.40909090909091
3377, 0, 0.033333333333333, 0.45454545454545
3378, 0, 0.066666666666667, 0.45454545454545
3379, 0, 0.016666666666667, 0.045454545454545
3380, 0, 0.033333333333333, 0.022727272727273
3381, 0, 0.05, 0.045454545454545
3382, 0, 0.066666666666667, 0.022727272727273
3383, 0, 0.083333333333333, 0.045454545454545
3384, 0, 0.016666666666667, 0.090909090909091
3385, 0, 0.033333333333333, 0.068181818181818
3386, 0, 0.05, 0.090909090909091
3387, 0, 0.066666666666667, 0.068181818181818
3388, 0, 0.083333333333333, 0.090909090909091
3389, 0, 0.016666666666667, 0.13636363636364
3390, 0, 0.033333333333333, 0.11363636363636
3391, 0, 0.05, 0.13636363636364
3392, 0, 0.066666666666667, 0.11363636363636
3393, 0, 0.083333333333333, 0.13636363636364
3394, 0, 0.016666666666667, 0.18181818181818
3395, 0, 0.033333333333333, 0.15909090909091
3396, 0, 0.05, 0.18181818181818
3397, 0, 0.066666666666667, 0.15909090909091
3398, 0, 0.083333333333333, 0.18181818181818
3399, 0, 0.016666666666667, 0.22727272727273
3400, 0, 0.033333333333333, 0.20454545454545
3401, 0, 0.05, 0.22727272727273
3402, 0, 0.066666666666667, 0.20454545454545
3403, 0, 0.083333333333333, 0.22727272727273
3404, 0, 0.016666666666667, 0.27272727272727
3405, 0, 0.033333333333333, 0.25
3406, 0, 0.05, 0.27272727272727
3407, 0, 0.066666666666667, 0.25
3408, 0, 0.083333333333333, 0.27272727272727
3409, 0, 0.016666666666667, 0.31818181818182
3410, 0, 0.033333333333333, 0.29545454545455
3411, 0, 0.05, 0.31818181818182
3412, 0, 0.066666666666667, 0.29545454545455
3413, 0, 0.083333333333333, 0.31818181818182
3414, 0, 0.016666666666667, 0.36363636363636
3415, 0, 0.033333333333333, 0.34090909090909
3416, 0, 0.05, 0.36363636363636
3417, 0, 0.066666666666667, 0.34090909090909
3418, 0, 0.083333333333333, 0.36363636363636
3419, 0, 0.016666666666667, 0.40909090909091
3420, 0, 0.033333333333333, 0.38636363636364
3421, 0, 0.05, 0.40909090909091
3422, 0, 0.066666666666667, 0.38636363636364
3423, 0, 0.083333333333333, 0.40909090909091
3424, 0, 0.016666666666667, 0.45454545454545
3425, 0, 0.033333333333333, 0.43181818181818
3426, 0, 0.05, 0.45454545454545
3427, 0, 0.066666666666667, 0.43181818181818
3428, 0, 0.083333333333333, 0.45454545454545
3429, 0, 0.033333333333333, 0.47727272727273
3430, 0, 0.066666666666667, 0.47727272727273
3431, 1, 0.033333333333333, 0.045454545454545
3432, 1, 0.066666666666667, 0.045454545454545
3433, 1, 0.033333333333333, 0.090909090909091
3434, 1, 0.066666666666667, 0.090909090909091
3435, 1, 0.033333333333333, 0.13636363636364
3436, 1, 0.066666666666667, 0.13636363636364
3437, 1, 0.033333333333333, 0.18181818181818
3438, 1, 0.066666666666667, 0.18181818181818
3439, 1, 0.033333333333333, 0.22727272727273
3440, 1, 0.066666666666667, 0.22727272727273
3441, 1, 0.033333333333333, 0.27272727272727
3442, 1, 0.066666666666667, 0.27272727272727
3443, 1, 0.033333333333333, 0.31818181818182
3444, 1, 0.066666666666667, 0.31818181818182
3445, 1, 0.033333333333333, 0.36363636363636
3446, 1, 0.066666666666667, 0.36363636363636
3447, 1, 0.033333333333333, 0.40909090909091
3448, 1, 0.066666666666667, 0.40909090909091
3449, 1, 0.033333333333333, 0.45454545454545
3450, 1, 0.066666666666667, 0.45454545454545
3451, 1, 0.033333333333333, 0.022727272727273
3452, 1, 0.016666666666667, 0.045454545454545
3453, 1, 0.066666666666667, 0.022727272727273
3454, 1, 0.05, 0.045454545454545
3455, 1, 0.083333333333333, 0.045454545454545
3456, 1, 0.033333333333333, 0.068181818181818
3457, 1, 0.016666666666667, 0.090909090909091
3458, 1, 0.066666666666667, 0.068181818181818
3459, 1, 0.05, 0.090909090909091
3460, 1, 0.083333333333333, 0.090909090909091
3461, 1, 0.033333333333333, 0.11363636363636
3462, 1, 0.016666666666667, 0.13636363636364
3463, 1, 0.066666666666667, 0.11363636363636
3464, 1, 0.05, 0.13636363636364
3465, 1, 0.083333333333333, 0.13636363636364
3466, 1, 0.033333333333333, 0.15909090909091
3467, 1, 0.016666666666667, 0.18181818181818
3468, 1, 0.066666666666667, 0.15909090909091
3469, 1, 0.05, 0.18181818181818
3470, 1, 0.083333333333333, 0.18181818181818
3471, 1, 0.033333333333333, 0.20454545454545
3472, 1, 0.016666666666667, 0.22727272727273
3473, 1, 0.066666666666667, 0.20454545454545
3474, 1, 0.05, 0.22727272727273
3475, 1, 0.083333333333333, 0.22727272727273
3476, 1, 0.033333333333333, 0.25
3477, 1, 0.016666666666667, 0.27272727272727
3478, 1, 0.066666666666667, 0.25
3479, 1, 0.05, 0.27272727272727
3480, 1, 0.083333333333333, 0.27272727272727
3481, 1, 0.033333333333333, 0.29545454545455
3482, 1, 0.016666666666667, 0.31818181818182
3483, 1, 0.066666666666667, 0.29545454545455
3484, 1, 0.05, 0.31818181818182
3485, 1, 0.083333333333333, 0.31818181818182
3486, 1, 0.033333333333333, 0.34090909090909
3487, 1, 0.016666666666667, 0.36363636363636
3488, 1, 0.066666666666667, 0.34090909090909
3489, 1, 0.05, 0.36363636363636
3490, 1, 0.083333333333333, 0.36363636363636
3491, 1, 0.033333333333333, 0.38636363636364
3492, 1, 0.016666666666667, 0.40909090909091
3493, 1, 0.066666666666667, 0.38636363636364
3494, 1, 0.05, 0.40909090909091
3495, 1, 0.083333333333333, 0.40909090909091
3496, 1, 0.033333333333333, 0.43181818181818
3497, 1, 0.016666666666667, 0.45454545454545
3498, 1, 0.066666666666667, 0.43181818181818
3499, 1, 0.05, 0.45454545454545
3500, 1, 0.083333333333333, 0.45454545454545
3501, 1, 0.033333333333333, 0.47727272727273
3502, 1, 0.066666666666667, 0.47727272727273
3503, 0.043478260869565, 0, 0.045454545454545
3504, 0.043478260869565, 0, 0.090909090909091
3505, 0.043478260869565, 0, 0.13636363636364
3506, 0.043478260869565, 0, 0.18181818181818
3507, 0.043478260869565, 0, 0.22727272727273
3508, 0.043478260869565, 0, 0.27272727272727
3509, 0.043478260869565, 0, 0.31818181818182
3510, 0.043478260869565, 0, 0.36363636363636
3511, 0.043478260869565, 0, 0.40909090909091
3512, 0.043478260869565, 0, 0.45454545454545
3513, 0.08695652173913, 0, 0.045454545454545
3514, 0.08695652173913, 0, 0.090909090909091
3515, 0.08695652173913, 0, 0.13636363636364
3516, 0.08695652173913, 0, 0.18181818181818
3517, 0.08695652173913, 0, 0.22727272727273
3518, 0.08695652173913, 0, 0.27272727272727
3519, 0.08695652173913, 0, 0.31818181818182
3520, 0.08695652173913, 0, 0.36363636363636
3521, 0.08695652173913, 0, 0.40909090909091
3522, 0.08695652173913, 0, 0.45454545454545
3523, 0.1304347826087, 0, 0.045454545454545
3524, 0.1304347826087, 0, 0.090909090909091
3525, 0.1304347826087, 0, 0.13636363636364
3526, 0.1304347826087, 0, 0.18181818181818
3527, 0.1304347826087, 0, 0.22727272727273
3528, 0.1304347826087, 0, 0.27272727272727
3529, 0.1304347826087, 0, 0.31818181818182
3530, 0.1304347826087, 0, 0.36363636363636
3531, 0.1304347826087, 0, 0.40909090909091
3532, 0.1304347826087, 0, 0.45454545454545
3533, 0.17391304347826, 0, 0.045454545454545
3534, 0.17391304347826, 0, 0.090909090909091
3535, 0.17391304347826, 0, 0.13636363636364
3536, 0.17391304347826, 0, 0.18181818181818
3537, 0.17391304347826, 0, 0.22727272727273
3538, 0.17391304347826, 0, 0.27272727272727
3539, 0.17391304347826, 0, 0.31818181818182
3540, 0.17391304347826, 0, 0.36363636363636
3541, 0.17391304347826, 0, 0.40909090909091
3542, 0.17391304347826, 0, 0.45454545454545
3543, 0.21739130434783, 0, 0.045454545454545
3544, 0.21739130434783, 0, 0.090909090909091
3545, 0.21739130434783, 0, 0.13636363636364
3546, 0.21739130434783, 0, 0.18181818181818
3547, 0.21739130434783, 0, 0.22727272727273
3548, 0.21739130434783, 0, 0.27272727272727
3549, 0.21739130434783, 0, 0.31818181818182
3550, 0.21739130434783, 0, 0.36363636363636
3551, 0.21739130434783, 0, 0.40909090909091
3552, 0.21739130434783, 0, 0.45454545454545
3553, 0.26086956521739, 0, 0.045454545454545
3554, 0.26086956521739, 0, 0.090909090909091
3555, 0.26086956521739, 0, 0.13636363636364
3556, 0.26086956521739, 0, 0.18181818181818
3557, 0.26086956521739, 0, 0.22727272727273
3558, 0.26086956521739, 0, 0.27272727272727
3559, 0.26086956521739, 0, 0.31818181818182
3560, 0.26086956521739, 0, 0.36363636363636
3561, 0.26086956521739, 0, 0.40909090909091
3562, 0.26086956521739, 0, 0.45454545454545
3563, 0.30434782608696, 0, 0.045454545454545
3564, 0.30434782608696, 0, 0.090909090909091
3565, 0.30434782608696, 0, 0.13636363636364
3566, 0.30434782608696, 0, 0.18181818181818
3567, 0.30434782608696, 0, 0.22727272727273
3568, 0.30434782608696, 0, 0.27272727272727
3569, 0.30434782608696, 0, 0.31818181818182
3570, 0.30434782608696, 0, 0.36363636363636
3571, 0.30434782608696, 0, 0.40909090909091
3572, 0.30434782608696, 0, 0.45454545454545
3573, 0.34782608695652, 0, 0.045454545454545
3574, 0.34782608695652, 0, 0.090909090909091
3575, 0.34782608695652, 0, 0.13636363636364
3576, 0.34782608695652, 0, 0.18181818181818
3577, 0.34782608695652, 0, 0.22727272727273
3578, 0.34782608695652, 0, 0.27272727272727
3579, 0.34782608695652, 0, 0.31818181818182
3580, 0.34782608695652, 0, 0.36363636363636
3581, 0.34782608695652, 0, 0.40909090909091
3582, 0.34782608695652, 0, 0.45454545454545
3583, 0.39130434782609, 0, 0.045454545454545
3584, 0.39130434782609, 0, 0.090909090909091
3585, 0.39130434782609, 0, 0.13636363636364
3586, 0.39130434782609, 0, 0.18181818181818
3587, 0.39130434782609, 0, 0.22727272727273
3588, 0.39130434782609, 0, 0.27272727272727
3589, 0.39130434782609, 0, 0.31818181818182
3590, 0.39130434782609, 0, 0.36363636363636
3591, 0.39130434782609, 0, 0.40909090909091
3592, 0.39130434782609, 0, 0.45454545454545
3593, 0.43478260869565, 0, 0.045454545454545
3594, 0.43478260869565, 0, 0.090909090909091
3595, 0.43478260869565, 0, 0.13636363636364
3596, 0.43478260869565, 0, 0.18181818181818
3597, 0.43478260869565, 0, 0.22727272727273
3598, 0.43478260869565, 0, 0.27272727272727
3599, 0.43478260869565, 0, 0.31818181818182
3600, 0.43478260869565, 0, 0.36363636363636
3601, 0.43478260869565, 0, 0.40909090909091
3602, 0.43478260869565, 0, 0.45454545454545
3603, 0.47826086956522, 0, 0.045454545454545
3604, 0.47826086956522, 0, 0.090909090909091
3605, 0.47826086956522, 0, 0.13636363636364
3606, 0.47826086956522, 0, 0.18181818181818
3607, 0.47826086956522, 0, 0.22727272727273
3608, 0.47826086956522, 0, 0.27272727272727
3609, 0.47826086956522, 0, 0.31818181818182
3610, 0.47826086956522, 0, 0.36363636363636
3611, 0.47826086956522, 0, 0.40909090909091
3612, 0.47826086956522, 0, 0.45454545454545
3613, 0.52173913043478, 0, 0.045454545454545
3614, 0.52173913043478, 0, 0.090909090909091
3615, 0.52173913043478, 0, 0.13636363636364
3616, 0.52173913043478, 0, 0.18181818181818
3617, 0.52173913043478, 0, 0.22727272727273
3618, 0.52173913043478, 0, 0.27272727272727
3619, 0.52173913043478, 0, 0.31818181818182
3620, 0.52173913043478, 0, 0.36363636363636
3621, 0.52173913043478, 0, 0.40909090909091
3622, 0.52173913043478, 0, 0.45454545454545
3623, 0.56521739130435, 0, 0.045454545454545
3624, 0.56521739130435, 0, 0.090909090909091
3625, 0.56521739130435, 0, 0.13636363636364
3626, 0.56521739130435, 0, 0.18181818181818
3627, 0.56521739130435, 0, 0.22727272727273
3628, 0.56521739130435, 0, 0.27272727272727
3629, 0.56521739130435, 0, 0.31818181818182
3630, 0.56521739130435, 0, 0.36363636363636
3631, 0.56521739130435, 0, 0.40909090909091
3632, 0.56521739130435, 0, 0.45454545454545
3633, 0.60869565217391, 0, 0.045454545454545
3634, 0.60869565217391, 0, 0.090909090909091
3635, 0.60869565217391, 0, 0.13636363636364
3636, 0.60869565217391, 0, 0.18181818181818
3637, 0.60869565217391, 0, 0.22727272727273
3638, 0.60869565217391, 0, 0.27272727272727
3639, 0.60869565217391, 0, 0.31818181818182
3640, 0.60869565217391, 0, 0.36363636363636
3641, 0.60869565217391, 0, 0.40909090909091
3642, 0.60869565217391, 0, 0.45454545454545
3643, 0.65217391304348, 0, 0.045454545454545
3644, 0.65217391304348, 0, 0.090909090909091
3645, 0.65217391304348, 0, 0.13636363636364
3646, 0.65217391304348, 0, 0.18181818181818
3647, 0.65217391304348, 0, 0.22727272727273
3648, 0.65217391304348, 0, 0.27272727272727
3649, 0.65217391304348, 0, 0.31818181818182
3650, 0.65217391304348, 0, 0.36363636363636
3651, 0.65217391304348, 0, 0.40909090909091
3652, 0.65217391304348, 0, 0.45454545454545
3653, 0.69565217391304, 0, 0.045454545454545
3654, 0.69565217391304, 0, 0.090909090909091
3655, 0.69565217391304, 0, 0.13636363636364
3656, 0.69565217391304, 0, 0.18181818181818
3657, 0.69565217391304, 0, 0.22727272727273
3658, 0.69565217391304, 0, 0.27272727272727
3659, 0.69565217391304, 0, 0.31818181818182
3660, 0.69565217391304, 0, 0.36363636363636
3661, 0.69565217391304, 0, 0.40909090909091
3662, 0.69565217391304, 0, 0.45454545454545
3663, 0.73913043478261, 0, 0.045454545454545
3664, 0.73913043478261, 0, 0.090909090909091
3665, 0.73913043478261, 0, 0.13636363636364
3666, 0.73913043478261, 0, 0.18181818181818
3667, 0.73913043478261, 0, 0.22727272727273
3668, 0.73913043478261, 0, 0.27272727272727
3669, 0.73913043478261, 0, 0.31818181818182
3670, 0.73913043478261, 0, 0.36363636363636
3671, 0.73913043478261, 0, 0.40909090909091
3672, 0.73913043478261, 0, 0.45454545454545
3673, 0.78260869565217, 0, 0.045454545454545
3674, 0.78260869565217, 0, 0.090909090909091
3675, 0.78260869565217, 0, 0.13636363636364
3676, 0.78260869565217, 0, 0.18181818181818
3677, 0.78260869565217, 0, 0.22727272727273
3678, 0.78260869565217, 0, 0.27272727272727
3679, 0.78260869565217, 0, 0.31818181818182
3680, 0.78260869565217, 0, 0.36363636363636
3681, 0.78260869565217, 0, 0.40909090909091
3682, 0.78260869565217, 0, 0.45454545454545
3683, 0.82608695652174, 0, 0.045454545454545
3684, 0.82608695652174, 0, 0.090909090909091
3685, 0.82608695652174, 0, 0.13636363636364
3686, 0.82608695652174, 0, 0.18181818181818
3687, 0.82608695652174, 0, 0.22727272727273
3688, 0.82608695652174, 0, 0.27272727272727
3689, 0.82608695652174, 0, 0.31818181818182
3690, 0.82608695652174, 0, 0.36363636363636
3691, 0.82608695652174, 0, 0.40909090909091
3692, 0.82608695652174, 0, 0.45454545454545
3693, 0.8695652173913, 0, 0.045454545454545
3694, 0.8695652173913, 0, 0.090909090909091
3695, 0.8695652173913, 0, 0.13636363636364
3696, 0.8695652173913, 0, 0.18181818181818
3697, 0.8695652173913, 0, 0.22727272727273
3698, 0.8695652173913, 0, 0.27272727272727
3699, 0.8695652173913, 0, 0.31818181818182
3700, 0.8695652173913, 0, 0.36363636363636
3701, 0.8695652173913, 0, 0.40909090909091
3702, 0.8695652173913, 0, 0.45454545454545
3703, 0.91304347826087, 0, 0.045454545454545
3704, 0.91304347826087, 0, 0.090909090909091
3705, 0.91304347826087, 0, 0.13636363636364
3706, 0.91304347826087, 0, 0.18181818181818
3707, 0.91304347826087, 0, 0.22727272727273
3708, 0.91304347826087, 0, 0.27272727272727
3709, 0.91304347826087, 0, 0.31818181818182
3710, 0.91304347826087, 0, 0.36363636363636
3711, 0.91304347826087, 0, 0.40909090909091
3712, 0.91304347826087, 0, 0.45454545454545
3713, 0.95652173913043, 0, 0.045454545454545
3714, 0.95652173913043, 0, 0.090909090909091
3715, 0.95652173913044, 0, 0.13636363636364
3716, 0.95652173913043, 0, 0.18181818181818
3717, 0.95652173913043, 0, 0.22727272727273
3718, 0.95652173913043, 0, 0.27272727272727
3719, 0.95652173913043, 0, 0.31818181818182
3720, 0.95652173913043, 0, 0.36363636363636
3721, 0.95652173913043, 0, 0.40909090909091
3722, 0.95652173913043, 0, 0.45454545454545
3723, 0.043478260869565, 0, 0.022727272727273
3724, 0.021739130434783, 0, 0.045454545454545
3725, 0.043478260869565, 0, 0.068181818181818
3726, 0.021739130434783, 0, 0.090909090909091
3727, 0.043478260869565, 0, 0.11363636363636
3728, 0.021739130434783, 0, 0.13636363636364
3729, 0.043478260869565, 0, 0.15909090909091
3730, 0.021739130434783, 0, 0.18181818181818
3731, 0.043478260869565, 0, 0.20454545454545
3732, 0.021739130434783, 0, 0.22727272727273
3733, 0.043478260869565, 0, 0.25
3734, 0.021739130434783, 0, 0.27272727272727
3735, 0.043478260869565, 0, 0.29545454545455
3736, 0.021739130434783, 0, 0.31818181818182
3737, 0.043478260869565, 0, 0.34090909090909
3738, 0.021739130434783, 0, 0.36363636363636
3739, 0.043478260869565, 0, 0.38636363636364
3740, 0.021739130434783, 0, 0.40909090909091
3741, 0.043478260869565, 0, 0.43181818181818
3742, 0.021739130434783, 0, 0.45454545454545
3743, 0.043478260869565, 0, 0.47727272727273
3744, 0.08695652173913, 0, 0.022727272727273
3745, 0.065217391304348, 0, 0.045454545454545
3746, 0.08695652173913, 0, 0.068181818181818
3747, 0.065217391304348, 0, 0.090909090909091
3748, 0.08695652173913, 0, 0.11363636363636
3749, 0.065217391304348, 0, 0.13636363636364
3750, 0.08695652173913, 0, 0.15909090909091
3751, 0.065217391304348, 0, 0.18181818181818
3752, 0.08695652173913, 0, 0.20454545454545
3753, 0.065217391304348, 0, 0.22727272727273
3754, 0.08695652173913, 0, 0.25
3755, 0.065217391304348, 0, 0.27272727272727
3756, 0.08695652173913, 0, 0.29545454545455
3757, 0.065217391304348, 0, 0.31818181818182
3758, 0.08695652173913, 0, 0.34090909090909
3759, 0.065217391304348, 0, 0.36363636363636
3760, 0.08695652173913, 0, 0.38636363636364
3761, 0.065217391304348, 0, 0.40909090909091
3762, 0.08695652173913, 0, 0.43181818181818
3763, 0.065217391304348, 0, 0.45454545454545
3764, 0.08695652173913, 0, 0.47727272727273
3765, 0.1304347826087, 0, 0.022727272727273
3766, 0.10869565217391, 0, 0.045454545454545
3767, 0.1304347826087, 0, 0.068181818181818
3768, 0.10869565217391, 0, 0.090909090909091
3769, 0.1304347826087, 0, 0.11363636363636
3770, 0.10869565217391, 0, 0.13636363636364
3771, 0.1304347826087, 0, 0.15909090909091
3772, 0.10869565217391, 0, 0.18181818181818
3773, 0.1304347826087, 0, 0.20454545454545
3774, 0.10869565217391, 0, 0.22727272727273
3775, 0.1304347826087, 0, 0.25
3776, 0.10869565217391, 0, 0.27272727272727
3777, 0.1304347826087, 0, 0.29545454545455
3778, 0.10869565217391, 0, 0.31818181818182
3779, 0.1304347826087, 0, 0.34090909090909
3780, 0.10869565217391, 0, 0.36363636363636
3781, 0.1304347826087, 0, 0.38636363636364
3782, 0.10869565217391, 0, 0.40909090909091
3783, 0.1304347826087, 0, 0.43181818181818
3784, 0.10869565217391, 0, 0.45454545454545
3785, 0.1304347826087, 0, 0.47727272727273
3786, 0.17391304347826, 0, 0.022727272727273
3787, 0.15217391304348, 0, 0.045454545454545
3788, 0.17391304347826, 0, 0.068181818181818
3789, 0.15217391304348, 0, 0.090909090909091
3790, 0.17391304347826, 0, 0.11363636363636
3791, 0.15217391304348, 0, 0.13636363636364
3792, 0.17391304347826, 0, 0.15909090909091
3793, 0.15217391304348, 0, 0.18181818181818
3794, 0.17391304347826, 0, 0.20454545454545
3795, 0.15217391304348, 0, 0.22727272727273
3796, 0.17391304347826, 0, 0.25
3797, 0.15217391304348, 0, 0.27272727272727
3798, 0.17391304347826, 0, 0.29545454545455
3799, 0.15217391304348, 0, 0.31818181818182
3800, 0.17391304347826, 0, 0.34090909090909
3801, 0.15217391304348, 0, 0.36363636363636
3802, 0.17391304347826, 0, 0.38636363636364
3803, 0.15217391304348, 0, 0.40909090909091
3804, 0.17391304347826, 0, 0.43181818181818
3805, 0.15217391304348, 0, 0.45454545454545
3806, 0.17391304347826, 0, 0.47727272727273
3807, 0.21739130434783, 0, 0.022727272727273
3808, 0.19565217391304, 0, 0.045454545454545
3809, 0.21739130434783, 0, 0.068181818181818
3810, 0.19565217391304, 0, 0.090909090909091
3811, 0.21739130434783, 0, 0.11363636363636
3812, 0.19565217391304, 0, 0.13636363636364
3813, 0.21739130434783, 0, 0.15909090909091
3814, 0.19565217391304, 0, 0.18181818181818
3815, 0.21739130434783, 0, 0.20454545454545
3816, 0.19565217391304, 0, 0.22727272727273
3817, 0.21739130434783, 0, 0.25
3818, 0.19565217391304, 0, 0.27272727272727
3819, 0.21739130434783, 0, 0.29545454545455
3820, 0.19565217391304, 0, 0.31818181818182
3821, 0.21739130434783, 0, 0.34090909090909
3822, 0.19565217391304, 0, 0.36363636363636
3823, 0.21739130434783, 0, 0.38636363636364
3824, 0.19565217391304, 0, 0.40909090909091
3825, 0.21739130434783, 0, 0.43181818181818
3826, 0.19565217391304, 0, 0.45454545454545
3827, 0.21739130434783, 0, 0.47727272727273
3828, 0.26086956521739, 0, 0.022727272727273
3829, 0.23913043478261, 0, 0.045454545454545
3830, 0.26086956521739, 0, 0.068181818181818
3831, 0.23913043478261, 0, 0.090909090909091
3832, 0.26086956521739, 0, 0.11363636363636
3833, 0.23913043478261, 0, 0.13636363636364
3834, 0.26086956521739, 0, 0.15909090909091
3835, 0.23913043478261, 0, 0.18181818181818
3836, 0.26086956521739, 0, 0.20454545454545
3837, 0.23913043478261, 0, 0.22727272727273
3838, 0.26086956521739, 0, 0.25
3839, 0.23913043478261, 0, 0.27272727272727
3840, 0.26086956521739, 0, 0.29545454545455
3841, 0.23913043478261, 0, 0.31818181818182
3842, 0.26086956521739, 0, 0.34090909090909
3843, 0.23913043478261, 0, 0.36363636363636
3844, 0.26086956521739, 0, 0.38636363636364
3845, 0.23913043478261, 0, 0.40909090909091
3846, 0.26086956521739, 0, 0.43181818181818
3847, 0.23913043478261, 0, 0.45454545454545
3848, 0.26086956521739, 0, 0.47727272727273
3849, 0.30434782608696, 0, 0.022727272727273
3850, 0.28260869565217, 0, 0.045454545454545
3851, 0.30434782608696, 0, 0.068181818181818
3852, 0.28260869565217, 0, 0.090909090909091
3853, 0.30434782608696, 0, 0.11363636363636
3854, 0.28260869565217, 0, 0.13636363636364
3855, 0.30434782608696, 0, 0.15909090909091
3856, 0.28260869565217, 0, 0.18181818181818
3857, 0.30434782608696, 0, 0.20454545454545
3858, 0.28260869565217, 0, 0.22727272727273
3859, 0.30434782608696, 0, 0.25
3860, 0.28260869565217, 0, 0.27272727272727
3861, 0.30434782608696, 0, 0.29545454545455
3862, 0.28260869565217, 0, 0.31818181818182
3863, 0.30434782608696, 0, 0.34090909090909
3864, 0.28260869565217, 0, 0.36363636363636
3865, 0.30434782608696, 0, 0.38636363636364
3866, 0.28260869565217, 0, 0.40909090909091
3867, 0.30434782608696, 0, 0.43181818181818
3868, 0.28260869565217, 0, 0.45454545454545
3869, 0.30434782608696, 0, 0.47727272727273
3870, 0.34782608695652, 0, 0.022727272727273
3871, 0.32608695652174, 0, 0.045454545454545
3872, 0.34782608695652, 0, 0.068181818181818
3873, 0.32608695652174, 0, 0.090909090909091
3874, 0.34782608695652, 0, 0.11363636363636
3875, 0.32608695652174, 0, 0.13636363636364
3876, 0.34782608695652, 0, 0.15909090909091
3877, 0.32608695652174, 0, 0.18181818181818
3878, 0.34782608695652, 0, 0.20454545454545
3879, 0.32608695652174, 0, 0.22727272727273
3880, 0.34782608695652, 0, 0.25
3881, 0.32608695652174, 0, 0.27272727272727
3882, 0.34782608695652, 0, 0.29545454545455
3883, 0.32608695652174, 0, 0.31818181818182
3884, 0.34782608695652, 0, 0.34090909090909
3885, 0.32608695652174, 0, 0.36363636363636
3886, 0.34782608695652, 0, 0.38636363636364
3887, 0.32608695652174, 0, 0.40909090909091
3888, 0.34782608695652, 0, 0.43181818181818
3889, 0.32608695652174, 0, 0.45454545454545
3890, 0.34782608695652, 0, 0.47727272727273
3891, 0.39130434782609, 0, 0.022727272727273
3892, 0.3695652173913, 0, 0.045454545454545
3893, 0.39130434782609, 0, 0.068181818181818
3894, 0.3695652173913, 0, 0.090909090909091
3895, 0.39130434782609, 0, 0.11363636363636
3896, 0.3695652173913, 0, 0.13636363636364
3897, 0.39130434782609, 0, 0.15909090909091
3898, 0.3695652173913, 0, 0.18181818181818
3899, 0.39130434782609, 0, 0.20454545454545
3900, 0.3695652173913, 0, 0.22727272727273
3901, 0.39130434782609, 0, 0.25
3902, 0.3695652173913, 0, 0.27272727272727
3903, 0.39130434782609, 0, 0.29545454545455
3904, 0.3695652173913, 0, 0.31818181818182
3905, 0.39130434782609, 0, 0.34090909090909
3906, 0.3695652173913, 0, 0.36363636363636
3907, 0.39130434782609, 0, 0.38636363636364
3908, 0.3695652173913, 0, 0.40909090909091
3909, 0.39130434782609, 0, 0.43181818181818
3910, 0.3695652173913, 0, 0.45454545454545
3911, 0.39130434782609, 0, 0.47727272727273
3912, 0.43478260869565, 0, 0.022727272727273
3913, 0.41304347826087, 0, 0.045454545454545
3914, 0.43478260869565, 0, 0.068181818181818
3915, 0.41304347826087, 0, 0.090909090909091
3916, 0.43478260869565, 0, 0.11363636363636
3917, 0.41304347826087, 0, 0.13636363636364
3918, 0.43478260869565, 0, 0.15909090909091
3919, 0.41304347826087, 0, 0.18181818181818
3920, 0.43478260869565, 0, 0.20454545454545
3921, 0.41304347826087, 0, 0.22727272727273
3922, 0.43478260869565, 0, 0.25
3923, 0.41304347826087, 0, 0.27272727272727
3924, 0.43478260869565, 0, 0.29545454545455
3925, 0.41304347826087, 0, 0.31818181818182
3926, 0.43478260869565, 0, 0.34090909090909
3927, 0.41304347826087, 0, 0.36363636363636
3928, 0.43478260869565, 0, 0.38636363636364
3929, 0.41304347826087, 0, 0.40909090909091
3930, 0.43478260869565, 0, 0.43181818181818
3931, 0.41304347826087, 0, 0.45454545454545
3932, 0.43478260869565, 0, 0.47727272727273
3933, 0.47826086956522, 0, 0.022727272727273
3934, 0.45652173913043, 0, 0.045454545454545
3935, 0.47826086956522, 0, 0.068181818181818
3936, 0.45652173913043, 0, 0.090909090909091
3937, 0.47826086956522, 0, 0.11363636363636
3938, 0.45652173913043, 0, 0.13636363636364
3939, 0.47826086956522, 0, 0.15909090909091
3940, 0.45652173913043, 0, 0.18181818181818
3941, 0.47826086956522, 0, 0.20454545454545
3942, 0.45652173913043, 0, 0.22727272727273
3943, 0.47826086956522, 0, 0.25
3944, 0.45652173913043, 0, 0.27272727272727
3945, 0.47826086956522, 0, 0.29545454545455
3946, 0.45652173913043, 0, 0.31818181818182
3947, 0.47826086956522, 0, 0.34090909090909
3948, 0.45652173913043, 0, 0.36363636363636
3949, 0.47826086956522, 0, 0.38636363636364
3950, 0.45652173913043, 0, 0.40909090909091
3951, 0.47826086956522, 0, 0.43181818181818
3952, 0.45652173913043, 0, 0.45454545454545
3953, 0.47826086956522, 0, 0.47727272727273
3954, 0.52173913043478, 0, 0.022727272727273
3955, 0.5, 0, 0.045454545454545
3956, 0.52173913043478, 0, 0.068181818181818
3957, 0.5, 0, 0.090909090909091
3958, 0.52173913043478, 0, 0.11363636363636
3959, 0.5, 0, 0.13636363636364
3960, 0.52173913043478, 0, 0.15909090909091
3961, 0.5, 0, 0.18181818181818
3962, 0.52173913043478, 0, 0.20454545454545
3963, 0.5, 0, 0.22727272727273
3964, 0.52173913043478, 0, 0.25
3965, 0.5, 0, 0.27272727272727
3966, 0.52173913043478, 0, 0.29545454545455
3967, 0.5, 0, 0.31818181818182
3968, 0.52173913043478, 0, 0.34090909090909
3969, 0.5, 0, 0.36363636363636
3970, 0.52173913043478, 0, 0.38636363636364
3971, 0.5, 0, 0.40909090909091
3972, 0.52173913043478, 0, 0.43181818181818
3973, 0.5, 0, 0.45454545454545
3974, 0.52173913043478, 0, 0.47727272727273
3975, 0.56521739130435, 0, 0.022727272727273
3976, 0.54347826086957, 0, 0.045454545454545
3977, 0.56521739130435, 0, 0.068181818181818
3978, 0.54347826086957, 0, 0.090909090909091
3979, 0.56521739130435, 0, 0.11363636363636
3980, 0.54347826086957, 0, 0.13636363636364
3981, 0.56521739130435, 0, 0.15909090909091
3982, 0.54347826086957, 0, 0.18181818181818
3983, 0.56521739130435, 0, 0.20454545454545
3984, 0.54347826086957, 0, 0.22727272727273
3985, 0.56521739130435, 0, 0.25
3986, 0.54347826086957, 0, 0.27272727272727
3987, 0.56521739130435, 0, 0.29545454545455
3988, 0.54347826086957, 0, 0.31818181818182
3989, 0.56521739130435, 0, 0.34090909090909
3990, 0.54347826086957, 0, 0.36363636363636
3991, 0.56521739130435, 0, 0.38636363636364
3992, 0.54347826086957, 0, 0.40909090909091
3993, 0.56521739130435, 0, 0.43181818181818
3994, 0.54347826086957, 0, 0.45454545454545
3995, 0.56521739130435, 0, 0.47727272727273
3996, 0.60869565217391, 0, 0.022727272727273
3997, 0.58695652173913, 0, 0.045454545454545
3998, 0.60869565217391, 0, 0.068181818181818
3999, 0.58695652173913, 0, 0.090909090909091
4000, 0.60869565217391, 0, 0.11363636363636
4001, 0.58695652173913, 0, 0.13636363636364
4002, 0.60869565217391, 0, 0.15909090909091
4003, 0.58695652173913, 0, 0.18181818181818
4004, 0.60869565217391, 0, 0.20454545454545
4005, 0.58695652173913, 0, 0.22727272727273
4006, 0.60869565217391, 0, 0.25
4007, 0.58695652173913, 0, 0.27272727272727
4008, 0.60869565217391, 0, 0.29545454545455
4009, 0.58695652173913, 0, 0.31818181818182
4010, 0.60869565217391, 0, 0.34090909090909
4011, 0.58695652173913, 0, 0.36363636363636
4012, 0.60869565217391, 0, 0.38636363636364
4013, 0.58695652173913, 0, 0.40909090909091
4014, 0.60869565217391, 0, 0.43181818181818
4015, 0.58695652173913, 0, 0.45454545454545
4016, 0.60869565217391, 0, 0.47727272727273
4017, 0.65217391304348, 0, 0.022727272727273
4018, 0.6304347826087, 0, 0.045454545454545
4019, 0.65217391304348, 0, 0.068181818181818
4020, 0.6304347826087, 0, 0.090909090909091
4021, 0.65217391304348, 0, 0.11363636363636
4022, 0.6304347826087, 0, 0.13636363636364
4023, 0.65217391304348, 0, 0.15909090909091
4024, 0.6304347826087, 0, 0.18181818181818
4025, 0.65217391304348, 0, 0.20454545454545
4026, 0.6304347826087, 0, 0.22727272727273
4027, 0.65217391304348, 0, 0.25
4028, 0.6304347826087, 0, 0.27272727272727
4029, 0.65217391304348, 0, 0.29545454545455
4030, 0.6304347826087, 0, 0.31818181818182
4031, 0.65217391304348, 0, 0.34090909090909
4032, 0.6304347826087, 0, 0.36363636363636
4033, 0.65217391304348, 0, 0.38636363636364
4034, 0.6304347826087, 0, 0.40909090909091
4035, 0.65217391304348, 0, 0.43181818181818
4036, 0.6304347826087, 0, 0.45454545454545
4037, 0.65217391304348, 0, 0.47727272727273
4038, 0.69565217391304, 0, 0.022727272727273
4039, 0.67391304347826, 0, 0.045454545454545
4040, 0.69565217391304, 0, 0.068181818181818
4041, 0.67391304347826, 0, 0.090909090909091
4042, 0.69565217391304, 0, 0.11363636363636
4043, 0.67391304347826, 0, 0.13636363636364
4044, 0.69565217391304, 0, 0.15909090909091
4045, 0.67391304347826, 0, 0.18181818181818
4046, 0.69565217391304, 0, 0.20454545454545
4047, 0.67391304347826, 0, 0.22727272727273
4048, 0.69565217391304, 0, 0.25
4049, 0.67391304347826, 0, 0.27272727272727
4050, 0.69565217391304, 0, 0.29545454545455
4051, 0.67391304347826, 0, 0.31818181818182
4052, 0.69565217391304, 0, 0.34090909090909
4053, 0.67391304347826, 0, 0.36363636363636
4054, 0.69565217391304, 0, 0.38636363636364
4055, 0.67391304347826, 0, 0.40909090909091
4056, 0.69565217391304, 0, 0.43181818181818
4057, 0.67391304347826, 0, 0.45454545454545
4058, 0.69565217391304, 0, 0.47727272727273
4059, 0.73913043478261, 0, 0.022727272727273
4060, 0.71739130434783, 0, 0.045454545454545
4061, 0.73913043478261, 0, 0.068181818181818
4062, 0.71739130434783, 0, 0.090909090909091
4063, 0.73913043478261, 0, 0.11363636363636
4064, 0.71739130434783, 0, 0.13636363636364
4065, 0.73913043478261, 0, 0.15909090909091
4066, 0.71739130434783, 0, 0.18181818181818
4067, 0.73913043478261, 0, 0.20454545454545
4068, 0.71739130434783, 0, 0.22727272727273
4069, 0.73913043478261, 0, 0.25
4070, 0.71739130434783, 0, 0.27272727272727
4071, 0.73913043478261, 0, 0.29545454545455
4072, 0.71739130434783, 0, 0.31818181818182
4073, 0.73913043478261, 0, 0.34090909090909
4074, 0.71739130434783, 0, 0.36363636363636
4075, 0.73913043478261, 0, 0.38636363636364
4076, 0.71739130434783, 0, 0.40909090909091
4077, 0.73913043478261, 0, 0.43181818181818
4078, 0.71739130434783, 0, 0.45454545454545
4079, 0.73913043478261, 0, 0.47727272727273
4080, 0.78260869565217, 0, 0.022727272727273
4081, 0.76086956521739, 0, 0.045454545454545
4082, 0.78260869565217, 0, 0.068181818181818
4083, 0.76086956521739, 0, 0.090909090909091
4084, 0.78260869565217, 0, 0.11363636363636
4085, 0.76086956521739, 0, 0.13636363636364
4086, 0.78260869565217, 0, 0.15909090909091
4087, 0.76086956521739, 0, 0.18181818181818
4088, 0.78260869565217, 0, 0.20454545454545
4089, 0.76086956521739, 0, 0.22727272727273
4090, 0.78260869565217, 0, 0.25
4091, 0.76086956521739, 0, 0.27272727272727
4092, 0.78260869565217, 0, 0.29545454545455
4093, 0.76086956521739, 0, 0.31818181818182
4094, 0.78260869565217, 0, 0.34090909090909
4095, 0.76086956521739, 0, 0.36363636363636
4096, 0.78260869565217, 0, 0.38636363636364
4097, 0.76086956521739, 0, 0.40909090909091
4098, 0.78260869565217, 0, 0.43181818181818
4099, 0.76086956521739, 0, 0.45454545454545
4100, 0.78260869565217, 0, 0.47727272727273
4101, 0.82608695652174, 0, 0.022727272727273
4102, 0.80434782608696, 0, 0.045454545454545
4103, 0.82608695652174, 0, 0.068181818181818
4104, 0.80434782608696, 0, 0.090909090909091
4105, 0.82608695652174, 0, 0.11363636363636
4106, 0.80434782608696, 0, 0.13636363636364
4107, 0.82608695652174, 0, 0.15909090909091
4108, 0.80434782608696, 0, 0.18181818181818
4109, 0.82608695652174, 0, 0.20454545454545
4110, 0.80434782608696, 0, 0.22727272727273
4111, 0.82608695652174, 0, 0.25
4112, 0.80434782608696, 0, 0.27272727272727
4113, 0.82608695652174, 0, 0.29545454545455
4114, 0.80434782608696, 0, 0.31818181818182
4115, 0.82608695652174, 0, 0.34090909090909
4116, 0.80434782608696, 0, 0.36363636363636
4117, 0.82608695652174, 0, 0.38636363636364
4118, 0.80434782608696, 0, 0.40909090909091
4119, 0.82608695652174, 0, 0.43181818181818
4120, 0.80434782608696, 0, 0.45454545454545
4121, 0.82608695652174, 0, 0.47727272727273
4122, 0.8695652173913, 0, 0.022727272727273
4123, 0.84782608695652, 0, 0.045454545454545
4124, 0.8695652173913, 0, 0.068181818181818
4125, 0.84782608695652, 0, 0.090909090909091
4126, 0.8695652173913, 0, 0.11363636363636
4127, 0.84782608695652, 0, 0.13636363636364
4128, 0.8695652173913, 0, 0.15909090909091
4129, 0.84782608695652, 0, 0.18181818181818
4130, 0.8695652173913, 0, 0.20454545454545
4131, 0.84782608695652, 0, 0.22727272727273
4132, 0.8695652173913, 0, 0.25
4133, 0.84782608695652, 0, 0.27272727272727
4134, 0.8695652173913, 0, 0.29545454545455
4135, 0.84782608695652, 0, 0.31818181818182
4136, 0.8695652173913, 0, 0.34090909090909
4137, 0.84782608695652, 0, 0.36363636363636
4138, 0.8695652173913, 0, 0.38636363636364
4139, 0.84782608695652, 0, 0.40909090909091
4140, 0.8695652173913, 0, 0.43181818181818
4141, 0.84782608695652, 0, 0.45454545454545
4142, 0.8695652173913, 0, 0.47727272727273
4143, 0.91304347826087, 0, 0.022727272727273
4144, 0.89130434782609, 0, 0.045454545454545
4145, 0.91304347826087, 0, 0.068181818181818
4146, 0.89130434782609, 0, 0.090909090909091
4147, 0.91304347826087, 0, 0.11363636363636
4148, 0.89130434782609, 0, 0.13636363636364
4149, 0.91304347826087, 0, 0.15909090909091
4150, 0.89130434782609, 0, 0.18181818181818
4151, 0.91304347826087, 0, 0.20454545454545
4152, 0.89130434782609, 0, 0.22727272727273
4153, 0.91304347826087, 0, 0.25
4154, 0.89130434782609, 0, 0.27272727272727
4155, 0.91304347826087, 0, 0.29545454545455
4156, 0.89130434782609, 0, 0.31818181818182
4157, 0.91304347826087, 0, 0.34090909090909
4158, 0.89130434782609, 0, 0.36363636363636
4159, 0.91304347826087, 0, 0.38636363636364
4160, 0.89130434782609, 0, 0.40909090909091
4161, 0.91304347826087, 0, 0.43181818181818
4162, 0.89130434782609, 0, 0.45454545454545
4163, 0.91304347826087, 0, 0.47727272727273
4164, 0.95652173913043, 0, 0.022727272727273
4165, 0.93478260869565, 0, 0.045454545454545
4166, 0.95652173913043, 0, 0.068181818181818
4167, 0.93478260869565, 0, 0.090909090909091
4168, 0.95652173913044, 0, 0.11363636363636
4169, 0.93478260869565, 0, 0.13636363636364
4170, 0.95652173913043, 0, 0.15909090909091
4171, 0.93478260869565, 0, 0.18181818181818
4172, 0.95652173913043, 0, 0.20454545454545
4173, 0.93478260869565, 0, 0.22727272727273
4174, 0.95652173913043, 0, 0.25
4175, 0.93478260869565, 0, 0.27272727272727
4176, 0.95652173913043, 0, 0.29545454545455
4177, 0.93478260869565, 0, 0.31818181818182
4178, 0.95652173913043, 0, 0.34090909090909
4179, 0.93478260869565, 0, 0.36363636363636
4180, 0.95652173913043, 0, 0.38636363636364
4181, 0.93478260869565, 0, 0.40909090909091
4182, 0.95652173913043, 0, 0.43181818181818
4183, 0.93478260869565, 0, 0.45454545454545
4184, 0.95652173913043, 0, 0.47727272727273
4185, 0.97826086956522, 0, 0.045454545454545
4186, 0.97826086956522, 0, 0.090909090909091
4187, 0.97826086956522, 0, 0.13636363636364
4188, 0.97826086956522, 0, 0.18181818181818
4189, 0.97826086956522, 0, 0.22727272727273
4190, 0.97826086956522, 0, 0.27272727272727
4191, 0.97826086956522, 0, 0.31818181818182
4192, 0.97826086956522, 0, 0.36363636363636
4193, 0.97826086956522, 0, 0.40909090909091
4194, 0.97826086956522, 0, 0.45454545454545
4195, 0.043478260869565, 0.1, 0.045454545454545
4196, 0.043478260869565, 0.1, 0.090909090909091
4197, 0.043478260869565, 0.1, 0.13636363636364
4198, 0.043478260869565, 0.1, 0.18181818181818
4199, 0.043478260869565, 0.1, 0.22727272727273
4200, 0.043478260869565, 0.1, 0.27272727272727
4201, 0.043478260869565, 0.1, 0.31818181818182
4202, 0.043478260869565, 0.1, 0.36363636363636
4203, 0.043478260869565, 0.1, 0.40909090909091
4204, 0.043478260869565, 0.1, 0.45454545454545
4205, 0.08695652173913, 0.1, 0.045454545454545
4206, 0.08695652173913, 0.1, 0.090909090909091
4207, 0.08695652173913, 0.1, 0.13636363636364
4208, 0.08695652173913, 0.1, 0.18181818181818
4209, 0.08695652173913, 0.1, 0.22727272727273
4210, 0.08695652173913, 0.1, 0.27272727272727
4211, 0.08695652173913, 0.1, 0.31818181818182
4212, 0.08695652173913, 0.1, 0.36363636363636
4213, 0.08695652173913, 0.1, 0.40909090909091
4214, 0.08695652173913, 0.1, 0.45454545454545
4215, 0.1304347826087, 0.1, 0.045454545454545
4216, 0.1304347826087, 0.1, 0.090909090909091
4217, 0.1304347826087, 0.1, 0.13636363636364
4218, 0.1304347826087, 0.1, 0.18181818181818
4219, 0.1304347826087, 0.1, 0.22727272727273
4220, 0.1304347826087, 0.1, 0.27272727272727
4221, 0.1304347826087, 0.1, 0.31818181818182
4222, 0.1304347826087, 0.1, 0.36363636363636
4223, 0.1304347826087, 0.1, 0.40909090909091
4224, 0.1304347826087, 0.1, 0.45454545454545
4225, 0.17391304347826, 0.1, 0.045454545454545
4226, 0.17391304347826, 0.1, 0.090909090909091
4227, 0.17391304347826, 0.1, 0.13636363636364
4228, 0.17391304347826, 0.1, 0.18181818181818
4229, 0.17391304347826, 0.1, 0.22727272727273
4230, 0.17391304347826, 0.1, 0.27272727272727
4231, 0.17391304347826, 0.1, 0.31818181818182
4232, 0.17391304347826, 0.1, 0.36363636363636
4233, 0.17391304347826, 0.1, 0.40909090909091
4234, 0.17391304347826, 0.1, 0.45454545454545
4235, 0.21739130434783, 0.1, 0.045454545454545
4236, 0.21739130434783, 0.1, 0.090909090909091
4237, 0.21739130434783, 0.1, 0.13636363636364
4238, 0.21739130434783, 0.1, 0.18181818181818
4239, 0.21739130434783, 0.1, 0.22727272727273
4240, 0.21739130434783, 0.1, 0.27272727272727
4241, 0.21739130434783, 0.1, 0.31818181818182
4242, 0.21739130434783, 0.1, 0.36363636363636
4243, 0.21739130434783, 0.1, 0.40909090909091
4244, 0.21739130434783, 0.1, 0.45454545454545
4245, 0.26086956521739, 0.1, 0.045454545454545
4246, 0.26086956521739, 0.1, 0.090909090909091
4247, 0.26086956521739, 0.1, 0.13636363636364
4248, 0.26086956521739, 0.1, 0.18181818181818
4249, 0.26086956521739, 0.1, 0.22727272727273
4250, 0.26086956521739, 0.1, 0.27272727272727
4251, 0.26086956521739, 0.1, 0.31818181818182
4252, 0.26086956521739, 0.1, 0.36363636363636
4253, 0.26086956521739, 0.1, 0.40909090909091
4254, 0.26086956521739, 0.1, 0.45454545454545
4255, 0.30434782608696, 0.1, 0.045454545454545
4256, 0.30434782608696, 0.1, 0.090909090909091
4257, 0.30434782608696, 0.1, 0.13636363636364
4258, 0.30434782608696, 0.1, 0.18181818181818
4259, 0.30434782608696, 0.1, 0.22727272727273
4260, 0.30434782608696, 0.1, 0.27272727272727
4261, 0.30434782608696, 0.1, 0.31818181818182
4262, 0.30434782608696, 0.1, 0.36363636363636
4263, 0.30434782608696, 0.1, 0.40909090909091
4264, 0.30434782608696, 0.1, 0.45454545454545
4265, 0.34782608695652, 0.1, 0.045454545454545
4266, 0.34782608695652, 0.1, 0.090909090909091
4267, 0.34782608695652, 0.1, 0.13636363636364
4268, 0.34782608695652, 0.1, 0.18181818181818
4269, 0.34782608695652, 0.1, 0.22727272727273
4270, 0.34782608695652, 0.1, 0.27272727272727
4271, 0.34782608695652, 0.1, 0.31818181818182
4272, 0.34782608695652, 0.1, 0.36363636363636
4273, 0.34782608695652, 0.1, 0.40909090909091
4274, 0.34782608695652, 0.1, 0.45454545454545
4275, 0.39130434782609, 0.1, 0.045454545454545
4276, 0.39130434782609, 0.1, 0.090909090909091
4277, 0.39130434782609, 0.1, 0.13636363636364
4278, 0.39130434782609, 0.1, 0.18181818181818
4279, 0.39130434782609, 0.1, 0.22727272727273
4280, 0.39130434782609, 0.1, 0.27272727272727
4281, 0.39130434782609, 0.1, 0.31818181818182
4282, 0.39130434782609, 0.1, 0.36363636363636
4283, 0.39130434782609, 0.1, 0.40909090909091
4284, 0.39130434782609, 0.1, 0.45454545454545
4285, 0.43478260869565, 0.1, 0.045454545454545
4286, 0.43478260869565, 0.1, 0.090909090909091
4287, 0.43478260869565, 0.1, 0.13636363636364
4288, 0.43478260869565, 0.1, 0.18181818181818
4289, 0.43478260869565, 0.1, 0.22727272727273
4290, 0.43478260869565, 0.1, 0.27272727272727
4291, 0.43478260869565, 0.1, 0.31818181818182
4292, 0.43478260869565, 0.1, 0.36363636363636
4293, 0.43478260869565, 0.1, 0.40909090909091
4294, 0.43478260869565, 0.1, 0.45454545454545
4295, 0.47826086956522, 0.1, 0.045454545454545
4296, 0.47826086956522, 0.1, 0.090909090909091
4297, 0.47826086956522, 0.1, 0.13636363636364
4298, 0.47826086956522, 0.1, 0.18181818181818
4299, 0.47826086956522, 0.1, 0.22727272727273
4300, 0.47826086956522, 0.1, 0.27272727272727
4301, 0.47826086956522, 0.1, 0.31818181818182
4302, 0.47826086956522, 0.1, 0.36363636363636
4303, 0.47826086956522, 0.1, 0.40909090909091
4304, 0.47826086956522, 0.1, 0.45454545454545
4305, 0.52173913043478, 0.1, 0.045454545454545
4306, 0.52173913043478, 0.1, 0.090909090909091
4307, 0.52173913043478, 0.1, 0.13636363636364
4308, 0.52173913043478, 0.1, 0.18181818181818
4309, 0.52173913043478, 0.1, 0.22727272727273
4310, 0.52173913043478, 0.1, 0.27272727272727
4311, 0.52173913043478, 0.1, 0.31818181818182
4312, 0.52173913043478, 0.1, 0.36363636363636
4313, 0.52173913043478, 0.1, 0.40909090909091
4314, 0.52173913043478, 0.1, 0.45454545454545
4315, 0.56521739130435, 0.1, 0.045454545454545
4316, 0.56521739130435, 0.1, 0.090909090909091
4317, 0.56521739130435, 0.1, 0.13636363636364
4318, 0.56521739130435, 0.1, 0.18181818181818
4319, 0.56521739130435, 0.1, 0.22727272727273
4320, 0.56521739130435, 0.1, 0.27272727272727
4321, 0.56521739130435, 0.1, 0.31818181818182
4322, 0.56521739130435, 0.1, 0.36363636363636
4323, 0.56521739130435, 0.1, 0.40909090909091
4324, 0.56521739130435, 0.1, 0.45454545454545
4325, 0.60869565217391, 0.1, 0.045454545454545
4326, 0.60869565217391, 0.1, 0.090909090909091
4327, 0.60869565217391, 0.1, 0.13636363636364
4328, 0.60869565217391, 0.1, 0.18181818181818
4329, 0.60869565217391, 0.1, 0.22727272727273
4330, 0.60869565217391, 0.1, 0.27272727272727
4331, 0.60869565217391, 0.1, 0.31818181818182
4332, 0.60869565217391, 0.1, 0.36363636363636
4333, 0.60869565217391, 0.1, 0.40909090909091
4334, 0.60869565217391, 0.1, 0.45454545454545
4335, 0.65217391304348, 0.1, 0.045454545454545
4336, 0.65217391304348, 0.1, 0.090909090909091
4337, 0.65217391304348, 0.1, 0.13636363636364
4338, 0.65217391304348, 0.1, 0.18181818181818
4339, 0.65217391304348, 0.1, 0.22727272727273
4340, 0.65217391304348, 0.1, 0.27272727272727
4341, 0.65217391304348, 0.1, 0.31818181818182
4342, 0.65217391304348, 0.1, 0.36363636363636
4343, 0.65217391304348, 0.1, 0.40909090909091
4344, 0.65217391304348, 0.1, 0.45454545454545
4345, 0.69565217391304, 0.1, 0.045454545454545
4346, 0.69565217391304, 0.1, 0.090909090909091
4347, 0.69565217391304, 0.1, 0.13636363636364
4348, 0.69565217391304, 0.1, 0.18181818181818
4349, 0.69565217391304, 0.1, 0.22727272727273
4350, 0.69565217391304, 0.1, 0.27272727272727
4351, 0.69565217391304, 0.1, 0.31818181818182
4352, 0.69565217391304, 0.1, 0.36363636363636
4353, 0.69565217391304, 0.1, 0.40909090909091
4354, 0.69565217391304, 0.1, 0.45454545454545
4355, 0.73913043478261, 0.1, 0.045454545454545
4356, 0.73913043478261, 0.1, 0.090909090909091
4357, 0.73913043478261, 0.1, 0.13636363636364
4358, 0.73913043478261, 0.1, 0.18181818181818
4359, 0.73913043478261, 0.1, 0.22727272727273
4360, 0.73913043478261, 0.1, 0.27272727272727
4361, 0.73913043478261, 0.1, 0.31818181818182
4362, 0.73913043478261, 0.1, 0.36363636363636
4363, 0.73913043478261, 0.1, 0.40909090909091
4364, 0.73913043478261, 0.1, 0.45454545454545
4365, 0.78260869565217, 0.1, 0.045454545454545
4366, 0.78260869565217, 0.1, 0.090909090909091
4367, 0.78260869565217, 0.1, 0.13636363636364
4368, 0.78260869565217, 0.1, 0.18181818181818
4369, 0.78260869565217, 0.1, 0.22727272727273
4370, 0.78260869565217, 0.1, 0.27272727272727
4371, 0.78260869565217, 0.1, 0.31818181818182
4372, 0.78260869565217, 0.1, 0.36363636363636
4373, 0.78260869565217, 0.1, 0.40909090909091
4374, 0.78260869565217, 0.1, 0.45454545454545
4375, 0.82608695652174, 0.1, 0.045454545454545
4376, 0.82608695652174, 0.1, 0.090909090909091
4377, 0.82608695652174, 0.1, 0.13636363636364
4378, 0.82608695652174, 0.1, 0.18181818181818
4379, 0.82608695652174, 0.1, 0.22727272727273
4380, 0.82608695652174, 0.1, 0.27272727272727
4381, 0.82608695652174, 0.1, 0.31818181818182
4382, 0.82608695652174, 0.1, 0.36363636363636
4383, 0.82608695652174, 0.1, 0.40909090909091
4384, 0.82608695652174, 0.1, 0.45454545454545
4385, 0.8695652173913, 0.1, 0.045454545454545
4386, 0.8695652173913, 0.1, 0.090909090909091
4387, 0.8695652173913, 0.1, 0.13636363636364
4388, 0.8695652173913, 0.1, 0.18181818181818
4389, 0.8695652173913, 0.1, 0.22727272727273
4390, 0.8695652173913, 0.1, 0.27272727272727
4391, 0.8695652173913, 0.1, 0.31818181818182
4392, 0.8695652173913, 0.1, 0.36363636363636
4393, 0.8695652173913, 0.1, 0.40909090909091
4394, 0.8695652173913, 0.1, 0.45454545454545
4395, 0.91304347826087, 0.1, 0.045454545454545
4396, 0.91304347826087, 0.1, 0.090909090909091
4397, 0.91304347826087, 0.1, 0.13636363636364
4398, 0.91304347826087, 0.1, 0.18181818181818
4399, 0.91304347826087, 0.1, 0.22727272727273
4400, 0.91304347826087, 0.1, 0.27272727272727
4401, 0.91304347826087, 0.1, 0.31818181818182
4402, 0.91304347826087, 0.1, 0.36363636363636
4403, 0.91304347826087, 0.1, 0.40909090909091
4404, 0.91304347826087, 0.1, 0.45454545454545
4405, 0.95652173913043, 0.1, 0.045454545454545
4406, 0.95652173913043, 0.1, 0.090909090909091
4407, 0.95652173913044, 0.1, 0.13636363636364
4408, 0.95652173913043, 0.1, 0.18181818181818
4409, 0.95652173913043, 0.1, 0.22727272727273
4410, 0.95652173913043, 0.1, 0.27272727272727
4411, 0.95652173913043, 0.1, 0.31818181818182
4412, 0.95652173913043, 0.1, 0.36363636363636
4413, 0.95652173913043, 0.1, 0.40909090909091
4414, 0.95652173913043, 0.1, 0.45454545454545
4415, 0.021739130434783, 0.1, 0.045454545454545
4416, 0.043478260869565, 0.1, 0.022727272727273
4417, 0.021739130434783, 0.1, 0.090909090909091
4418, 0.043478260869565, 0.1, 0.068181818181818
4419, 0.021739130434783, 0.1, 0.13636363636364
4420, 0.043478260869565, 0.1, 0.11363636363636
4421, 0.021739130434783, 0.1, 0.18181818181818
4422, 0.043478260869565, 0.1, 0.15909090909091
4423, 0.021739130434783, 0.1, 0.22727272727273
4424, 0.043478260869565, 0.1, 0.20454545454545
4425, 0.021739130434783, 0.1, 0.27272727272727
4426, 0.043478260869565, 0.1, 0.25
4427, 0.021739130434783, 0.1, 0.31818181818182
4428, 0.043478260869565, 0.1, 0.29545454545455
4429, 0.021739130434783, 0.1, 0.36363636363636
4430, 0.043478260869565, 0.1, 0.34090909090909
4431, 0.021739130434783, 0.1, 0.40909090909091
4432, 0.043478260869565, 0.1, 0.38636363636364
4433, 0.021739130434783, 0.1, 0.45454545454545
4434, 0.043478260869565, 0.1, 0.43181818181818
4435, 0.043478260869565, 0.1, 0.47727272727273
4436, 0.065217391304348, 0.1, 0.045454545454545
4437, 0.08695652173913, 0.1, 0.022727272727273
4438, 0.065217391304348, 0.1, 0.090909090909091
4439, 0.08695652173913, 0.1, 0.068181818181818
4440, 0.065217391304348, 0.1, 0.13636363636364
4441, 0.08695652173913, 0.1, 0.11363636363636
4442, 0.065217391304348, 0.1, 0.18181818181818
4443, 0.08695652173913, 0.1, 0.15909090909091
4444, 0.065217391304348, 0.1, 0.22727272727273
4445, 0.08695652173913, 0.1, 0.20454545454545
4446, 0.065217391304348, 0.1, 0.27272727272727
4447, 0.08695652173913, 0.1, 0.25
4448, 0.065217391304348, 0.1, 0.31818181818182
4449, 0.08695652173913, 0.1, 0.29545454545455
4450, 0.065217391304348, 0.1, 0.36363636363636
4451, 0.08695652173913, 0.1, 0.34090909090909
4452, 0.065217391304348, 0.1, 0.40909090909091
4453, 0.08695652173913, 0.1, 0.38636363636364
4454, 0.065217391304348, 0.1, 0.45454545454545
4455, 0.08695652173913, 0.1, 0.43181818181818
4456, 0.08695652173913, 0.1, 0.47727272727273
4457, 0.10869565217391, 0.1, 0.045454545454545
4458, 0.1304347826087, 0.1, 0.022727272727273
4459, 0.10869565217391, 0.1, 0.090909090909091
4460, 0.1304347826087, 0.1, 0.068181818181818
4461, 0.10869565217391, 0.1, 0.13636363636364
4462, 0.1304347826087, 0.1, 0.11363636363636
4463, 0.10869565217391, 0.1, 0.18181818181818
4464, 0.1304347826087, 0.1, 0.15909090909091
4465, 0.10869565217391, 0.1, 0.22727272727273
4466, 0.1304347826087, 0.1, 0.20454545454545
4467, 0.10869565217391, 0.1, 0.27272727272727
4468, 0.1304347826087, 0.1, 0.25
4469, 0.10869565217391, 0.1, 0.31818181818182
4470, 0.1304347826087, 0.1, 0.29545454545455
4471, 0.10869565217391, 0.1, 0.36363636363636
4472, 0.1304347826087, 0.1, 0.34090909090909
4473, 0.10869565217391, 0.1, 0.40909090909091
4474, 0.1304347826087, 0.1, 0.38636363636364
4475, 0.10869565217391, 0.1, 0.45454545454545
4476, 0.1304347826087, 0.1, 0.43181818181818
4477, 0.1304347826087, 0.1, 0.47727272727273
4478, 0.15217391304348, 0.1, 0.045454545454545
4479, 0.17391304347826, 0.1, 0.022727272727273
4480, 0.15217391304348, 0.1, 0.090909090909091
4481, 0.17391304347826, 0.1, 0.068181818181818
4482, 0.15217391304348, 0.1, 0.13636363636364
4483, 0.17391304347826, 0.1, 0.11363636363636
4484, 0.15217391304348, 0.1, 0.18181818181818
4485, 0.17391304347826, 0.1, 0.15909090909091
4486, 0.15217391304348, 0.1, 0.22727272727273
4487, 0.17391304347826, 0.1, 0.20454545454545
4488, 0.15217391304348, 0.1, 0.27272727272727
4489, 0.17391304347826, 0.1, 0.25
4490, 0.15217391304348, 0.1, 0.31818181818182
4491, 0.17391304347826, 0.1, 0.29545454545455
4492, 0.15217391304348, 0.1, 0.36363636363636
4493, 0.17391304347826, 0.1, 0.34090909090909
4494, 0.15217391304348, 0.1, 0.40909090909091
4495, 0.17391304347826, 0.1, 0.38636363636364
4496, 0.15217391304348, 0.1, 0.45454545454545
4497, 0.17391304347826, 0.1, 0.43181818181818
4498, 0.17391304347826, 0.1, 0.47727272727273
4499, 0.19565217391304, 0.1, 0.045454545454545
4500, 0.21739130434783, 0.1, 0.022727272727273
4501, 0.19565217391304, 0.1, 0.090909090909091
4502, 0.21739130434783, 0.1, 0.068181818181818
4503, 0.19565217391304, 0.1, 0.13636363636364
4504, 0.21739130434783, 0.1, 0.11363636363636
4505, 0.19565217391304, 0.1, 0.18181818181818
4506, 0.21739130434783, 0.1, 0.15909090909091
4507, 0.19565217391304, 0.1, 0.22727272727273
4508, 0.21739130434783, 0.1, 0.20454545454545
4509, 0.19565217391304, 0.1, 0.27272727272727
4510, 0.21739130434783, 0.1, 0.25
4511, 0.19565217391304, 0.1, 0.31818181818182
4512, 0.21739130434783, 0.1, 0.29545454545455
4513, 0.19565217391304, 0.1, 0.36363636363636
4514, 0.21739130434783, 0.1, 0.34090909090909
4515, 0.19565217391304, 0.1, 0.40909090909091
4516, 0.21739130434783, 0.1, 0.38636363636364
4517, 0.19565217391304, 0.1, 0.45454545454545
4518, 0.21739130434783, 0.1, 0.43181818181818
4519, 0.21739130434783, 0.1, 0.47727272727273
4520, 0.23913043478261, 0.1, 0.045454545454545
4521, 0.26086956521739, 0.1, 0.022727272727273
4522, 0.23913043478261, 0.1, 0.090909090909091
4523, 0.26086956521739, 0.1, 0.068181818181818
4524, 0.23913043478261, 0.1, 0.13636363636364
4525, 0.26086956521739, 0.1, 0.11363636363636
4526, 0.23913043478261, 0.1, 0.18181818181818
4527, 0.26086956521739, 0.1, 0.15909090909091
4528, 0.23913043478261, 0.1, 0.22727272727273
4529, 0.26086956521739, 0.1, 0.20454545454545
4530, 0.23913043478261, 0.1, 0.27272727272727
4531, 0.26086956521739, 0.1, 0.25
4532, 0.23913043478261, 0.1, 0.31818181818182
4533, 0.26086956521739, 0.1, 0.29545454545455
4534, 0.23913043478261, 0.1, 0.36363636363636
4535, 0.26086956521739, 0.1, 0.34090909090909
4536, 0.23913043478261, 0.1, 0.40909090909091
4537, 0.26086956521739, 0.1, 0.38636363636364
4538, 0.23913043478261, 0.1, 0.45454545454545
4539, 0.26086956521739, 0.1, 0.43181818181818
4540, 0.26086956521739, 0.1, 0.47727272727273
4541, 0.28260869565217, 0.1, 0.045454545454545
4542, 0.30434782608696, 0.1, 0.022727272727273
4543, 0.28260869565217, 0.1, 0.090909090909091
4544, 0.30434782608696, 0.1, 0.068181818181818
4545, 0.28260869565217, 0.1, 0.13636363636364
4546, 0.30434782608696, 0.1, 0.11363636363636
4547, 0.28260869565217, 0.1, 0.18181818181818
4548, 0.30434782608696, 0.1, 0.15909090909091
4549, 0.28260869565217, 0.1, 0.22727272727273
4550, 0.30434782608696, 0.1, 0.20454545454545
4551, 0.28260869565217, 0.1, 0.27272727272727
4552, 0.30434782608696, 0.1, 0.25
4553, 0.28260869565217, 0.1, 0.31818181818182
4554, 0.30434782608696, 0.1, 0.29545454545455
4555, 0.28260869565217, 0.1, 0.36363636363636
4556, 0.30434782608696, 0.1, 0.34090909090909
4557, 0.28260869565217, 0.1, 0.40909090909091
4558, 0.30434782608696, 0.1, 0.38636363636364
4559, 0.28260869565217, 0.1, 0.45454545454545
4560, 0.30434782608696, 0.1, 0.43181818181818
4561, 0.30434782608696, 0.1, 0.47727272727273
4562, 0.32608695652174, 0.1, 0.045454545454545
4563, 0.34782608695652, 0.1, 0.022727272727273
4564, 0.32608695652174, 0.1, 0.090909090909091
4565, 0.34782608695652, 0.1, 0.068181818181818
4566, 0.32608695652174, 0.1, 0.13636363636364
4567, 0.34782608695652, 0.1, 0.11363636363636
4568, 0.32608695652174, 0.1, 0.18181818181818
4569, 0.34782608695652, 0.1, 0.15909090909091
4570, 0.32608695652174, 0.1, 0.22727272727273
4571, 0.34782608695652, 0.1, 0.20454545454545
4572, 0.32608695652174, 0.1, 0.27272727272727
4573, 0.34782608695652, 0.1, 0.25
4574, 0.32608695652174, 0.1, 0.31818181818182
4575, 0.34782608695652, 0.1, 0.29545454545455
4576, 0.32608695652174, 0.1, 0.36363636363636
4577, 0.34782608695652, 0.1, 0.34090909090909
4578, 0.32608695652174, 0.1, 0.40909090909091
4579, 0.34782608695652, 0.1, 0.38636363636364
4580, 0.32608695652174, 0.1, 0.45454545454545
4581, 0.34782608695652, 0.1, 0.43181818181818
4582, 0.34782608695652, 0.1, 0.47727272727273
4583, 0.3695652173913, 0.1, 0.045454545454545
4584, 0.39130434782609, 0.1, 0.022727272727273
4585, 0.3695652173913, 0.1, 0.090909090909091
4586, 0.39130434782609, 0.1, 0.068181818181818
4587, 0.3695652173913, 0.1, 0.13636363636364
4588, 0.39130434782609, 0.1, 0.11363636363636
4589, 0.3695652173913, 0.1, 0.18181818181818
4590, 0.39130434782609, 0.1, 0.15909090909091
4591, 0.3695652173913, 0.1, 0.22727272727273
4592, 0.39130434782609, 0.1, 0.20454545454545
4593, 0.3695652173913, 0.1, 0.27272727272727
4594, 0.39130434782609, 0.1, 0.25
4595, 0.3695652173913, 0.1, 0.31818181818182
4596, 0.39130434782609, 0.1, 0.29545454545455
4597, 0.3695652173913, 0.1, 0.36363636363636
4598, 0.39130434782609, 0.1, 0.34090909090909
4599, 0.3695652173913, 0.1, 0.40909090909091
4600, 0.39130434782609, 0.1, 0.38636363636364
4601, 0.3695652173913, 0.1, 0.45454545454545
4602, 0.39130434782609, 0.1, 0.43181818181818
4603, 0.39130434782609, 0.1, 0.47727272727273
4604, 0.41304347826087, 0.1, 0.045454545454545
4605, 0.43478260869565, 0.1, 0.022727272727273
4606, 0.41304347826087, 0.1, 0.090909090909091
4607, 0.43478260869565, 0.1, 0.068181818181818
4608, 0.41304347826087, 0.1, 0.13636363636364
4609, 0.43478260869565, 0.1, 0.11363636363636
4610, 0.41304347826087, 0.1, 0.18181818181818
4611, 0.43478260869565, 0.1, 0.15909090909091
4612, 0.41304347826087, 0.1, 0.22727272727273
4613, 0.43478260869565, 0.1, 0.20454545454545
4614, 0.41304347826087, 0.1, 0.27272727272727
4615, 0.43478260869565, 0.1, 0.25
4616, 0.41304347826087, 0.1, 0.31818181818182
4617, 0.43478260869565, 0.1, 0.29545454545455
4618, 0.41304347826087, 0.1, 0.36363636363636
4619, 0.43478260869565, 0.1, 0.34090909090909
4620, 0.41304347826087, 0.1, 0.40909090909091
4621, 0.43478260869565, 0.1, 0.38636363636364
4622, 0.41304347826087, 0.1, 0.45454545454545
4623, 0.43478260869565, 0.1, 0.43181818181818
4624, 0.43478260869565, 0.1, 0.47727272727273
4625, 0.45652173913043, 0.1, 0.045454545454545
4626, 0.47826086956522, 0.1, 0.022727272727273
4627, 0.45652173913043, 0.1, 0.090909090909091
4628, 0.47826086956522, 0.1, 0.068181818181818
4629, 0.45652173913043, 0.1, 0.13636363636364
4630, 0.47826086956522, 0.1, 0.11363636363636
4631, 0.45652173913043, 0.1, 0.18181818181818
4632, 0.47826086956522, 0.1, 0.15909090909091
4633, 0.45652173913043, 0.1, 0.22727272727273
4634, 0.47826086956522, 0.1, 0.20454545454545
4635, 0.45652173913043, 0.1, 0.27272727272727
4636, 0.47826086956522, 0.1, 0.25
4637, 0.45652173913043, 0.1, 0.31818181818182
4638, 0.47826086956522, 0.1, 0.29545454545455
4639, 0.45652173913043, 0.1, 0.36363636363636
4640, 0.47826086956522, 0.1, 0.34090909090909
4641, 0.45652173913043, 0.1, 0.40909090909091
4642, 0.47826086956522, 0.1, 0.38636363636364
4643, 0.45652173913043, 0.1, 0.45454545454545
4644, 0.47826086956522, 0.1, 0.43181818181818
4645, 0.47826086956522, 0.1, 0.47727272727273
4646, 0.5, 0.1, 0.045454545454545
4647, 0.52173913043478, 0.1, 0.022727272727273
4648, 0.5, 0.1, 0.090909090909091
4649, 0.52173913043478, 0.1, 0.068181818181818
4650, 0.5, 0.1, 0.13636363636364
4651, 0.52173913043478, 0.1, 0.11363636363636
4652, 0.5, 0.1, 0.18181818181818
4653, 0.52173913043478, 0.1, 0.15909090909091
4654, 0.5, 0.1, 0.22727272727273
4655, 0.52173913043478, 0.1, 0.20454545454545
4656, 0.5, 0.1, 0.27272727272727
4657, 0.52173913043478, 0.1, 0.25
4658, 0.5, 0.1, 0.31818181818182
4659, 0.52173913043478, 0.1, 0.29545454545455
4660, 0.5, 0.1, 0.36363636363636
4661, 0.52173913043478, 0.1, 0.34090909090909
4662, 0.5, 0.1, 0.40909090909091
4663, 0.52173913043478, 0.1, 0.38636363636364
4664, 0.5, 0.1, 0.45454545454545
4665, 0.52173913043478, 0.1, 0.43181818181818
4666, 0.52173913043478, 0.1, 0.47727272727273
4667, 0.54347826086957, 0.1, 0.045454545454545
4668, 0.56521739130435, 0.1, 0.022727272727273
4669, 0.54347826086957, 0.1, 0.090909090909091
4670, 0.56521739130435, 0.1, 0.068181818181818
4671, 0.54347826086957, 0.1, 0.13636363636364
4672, 0.56521739130435, 0.1, 0.11363636363636
4673, 0.54347826086957, 0.1, 0.18181818181818
4674, 0.56521739130435, 0.1, 0.15909090909091
4675, 0.54347826086957, 0.1, 0.22727272727273
4676, 0.56521739130435, 0.1, 0.20454545454545
4677, 0.54347826086957, 0.1, 0.27272727272727
4678, 0.56521739130435, 0.1, 0.25
4679, 0.54347826086957, 0.1, 0.31818181818182
4680, 0.56521739130435, 0.1, 0.29545454545455
4681, 0.54347826086957, 0.1, 0.36363636363636
4682, 0.56521739130435, 0.1, 0.34090909090909
4683, 0.54347826086957, 0.1, 0.40909090909091
4684, 0.56521739130435, 0.1, 0.38636363636364
4685, 0.54347826086957, 0.1, 0.45454545454545
4686, 0.56521739130435, 0.1, 0.43181818181818
4687, 0.56521739130435, 0.1, 0.47727272727273
4688, 0.58695652173913, 0.1, 0.045454545454545
4689, 0.60869565217391, 0.1, 0.022727272727273
4690, 0.58695652173913, 0.1, 0.090909090909091
4691, 0.60869565217391, 0.1, 0.068181818181818
4692, 0.58695652173913, 0.1, 0.13636363636364
4693, 0.60869565217391, 0.1, 0.11363636363636
4694, 0.58695652173913, 0.1, 0.18181818181818
4695, 0.60869565217391, 0.1, 0.15909090909091
4696, 0.58695652173913, 0.1, 0.22727272727273
4697, 0.60869565217391, 0.1, 0.20454545454545
4698, 0.58695652173913, 0.1, 0.27272727272727
4699, 0.60869565217391, 0.1, 0.25
4700, 0.58695652173913, 0.1, 0.31818181818182
4701, 0.60869565217391, 0.1, 0.29545454545455
4702, 0.58695652173913, 0.1, 0.36363636363636
4703, 0.60869565217391, 0.1, 0.34090909090909
4704, 0.58695652173913, 0.1, 0.40909090909091
4705, 0.60869565217391, 0.1, 0.38636363636364
4706, 0.58695652173913, 0.1, 0.45454545454545
4707, 0.60869565217391, 0.1, 0.43181818181818
4708, 0.60869565217391, 0.1, 0.47727272727273
4709, 0.6304347826087, 0.1, 0.045454545454545
4710, 0.65217391304348, 0.1, 0.022727272727273
4711, 0.6304347826087, 0.1, 0.090909090909091
4712, 0.65217391304348, 0.1, 0.068181818181818
4713, 0.6304347826087, 0.1, 0.13636363636364
4714, 0.65217391304348, 0.1, 0.11363636363636
4715, 0.6304347826087, 0.1, 0.18181818181818
4716, 0.65217391304348, 0.1, 0.15909090909091
4717, 0.6304347826087, 0.1, 0.22727272727273
4718, 0.65217391304348, 0.1, 0.20454545454545
4719, 0.6304347826087, 0.1, 0.27272727272727
4720, 0.65217391304348, 0.1, 0.25
4721, 0.6304347826087, 0.1, 0.31818181818182
4722, 0.65217391304348, 0.1, 0.29545454545455
4723, 0.6304347826087, 0.1, 0.36363636363636
4724, 0.65217391304348, 0.1, 0.34090909090909
4725, 0.6304347826087, 0.1, 0.40909090909091
4726, 0.65217391304348, 0.1, 0.38636363636364
4727, 0.6304347826087, 0.1, 0.45454545454545
4728, 0.65217391304348, 0.1, 0.43181818181818
4729, 0.65217391304348, 0.1, 0.47727272727273
4730, 0.67391304347826, 0.1, 0.045454545454545
4731, 0.69565217391304, 0.1, 0.022727272727273
4732, 0.67391304347826, 0.1, 0.090909090909091
4733, 0.69565217391304, 0.1, 0.068181818181818
4734, 0.67391304347826, 0.1, 0.13636363636364
4735, 0.69565217391304, 0.1, 0.11363636363636
4736, 0.67391304347826, 0.1, 0.18181818181818
4737, 0.69565217391304, 0.1, 0.15909090909091
4738, 0.67391304347826, 0.1, 0.22727272727273
4739, 0.69565217391304, 0.1, 0.20454545454545
4740, 0.67391304347826, 0.1, 0.27272727272727
4741, 0.69565217391304, 0.1, 0.25
4742, 0.67391304347826, 0.1, 0.31818181818182
4743, 0.69565217391304, 0.1, 0.29545454545455
4744, 0.67391304347826, 0.1, 0.36363636363636
4745, 0.69565217391304, 0.1, 0.34090909090909
4746, 0.67391304347826, 0.1, 0.40909090909091
4747, 0.69565217391304, 0.1, 0.38636363636364
4748, 0.67391304347826, 0.1, 0.45454545454545
4749, 0.69565217391304, 0.1, 0.43181818181818
4750, 0.69565217391304, 0.1, 0.47727272727273
4751, 0.71739130434783, 0.1, 0.045454545454545
4752, 0.73913043478261, 0.1, 0.022727272727273
4753, 0.71739130434783, 0.1, 0.090909090909091
4754, 0.73913043478261, 0.1, 0.068181818181818
4755, 0.71739130434783, 0.1, 0.13636363636364
4756, 0.73913043478261, 0.1, 0.11363636363636
4757, 0.71739130434783, 0.1, 0.18181818181818
4758, 0.73913043478261, 0.1, 0.15909090909091
4759, 0.71739130434783, 0.1, 0.22727272727273
4760, 0.73913043478261, 0.1, 0.20454545454545
4761, 0.71739130434783, 0.1, 0.27272727272727
4762, 0.73913043478261, 0.1, 0.25
4763, 0.71739130434783, 0.1, 0.31818181818182
4764, 0.73913043478261, 0.1, 0.29545454545455
4765, 0.71739130434783, 0.1, 0.36363636363636
4766, 0.73913043478261, 0.1, 0.34090909090909
4767, 0.71739130434783, 0.1, 0.40909090909091
4768, 0.73913043478261, 0.1, 0.38636363636364
4769, 0.71739130434783, 0.1, 0.45454545454545
4770, 0.73913043478261, 0.1, 0.43181818181818
4771, 0.73913043478261, 0.1, 0.47727272727273
4772, 0.76086956521739, 0.1, 0.045454545454545
4773, 0.78260869565217, 0.1, 0.022727272727273
4774, 0.76086956521739, 0.1, 0.090909090909091
4775, 0.78260869565217, 0.1, 0.068181818181818
4776, 0.76086956521739, 0.1, 0.13636363636364
4777, 0.78260869565217, 0.1, 0.11363636363636
4778, 0.76086956521739, 0.1, 0.18181818181818
4779, 0.78260869565217, 0.1, 0.15909090909091
4780, 0.76086956521739, 0.1, 0.22727272727273
4781, 0.78260869565217, 0.1, 0.20454545454545
4782, 0.76086956521739, 0.1, 0.27272727272727
4783, 0.78260869565217, 0.1, 0.25
4784, 0.76086956521739, 0.1, 0.31818181818182
4785, 0.78260869565217, 0.1, 0.29545454545455
4786, 0.76086956521739, 0.1, 0.36363636363636
4787, 0.78260869565217, 0.1, 0.34090909090909
4788, 0.76086956521739, 0.1, 0.40909090909091
4789, 0.78260869565217, 0.1, 0.38636363636364
4790, 0.76086956521739, 0.1, 0.45454545454545
4791, 0.78260869565217, 0.1, 0.43181818181818
4792, 0.78260869565217, 0.1, 0.47727272727273
4793, 0.80434782608696, 0.1, 0.045454545454545
4794, 0.82608695652174, 0.1, 0.022727272727273
4795, 0.80434782608696, 0.1, 0.090909090909091
4796, 0.82608695652174, 0.1, 0.068181818181818
4797, 0.80434782608696, 0.1, 0.13636363636364
4798, 0.82608695652174, 0.1, 0.11363636363636
4799, 0.80434782608696, 0.1, 0.18181818181818
4800, 0.82608695652174, 0.1, 0.15909090909091
4801, 0.80434782608696, 0.1, 0.22727272727273
4802, 0.82608695652174, 0.1, 0.20454545454545
4803, 0.80434782608696, 0.1, 0.27272727272727
4804, 0.82608695652174, 0.1, 0.25
4805, 0.80434782608696, 0.1, 0.31818181818182
4806, 0.82608695652174, 0.1, 0.29545454545455
4807, 0.80434782608696, 0.1, 0.36363636363636
4808, 0.82608695652174, 0.1, 0.34090909090909
4809, 0.80434782608696, 0.1, 0.40909090909091
4810, 0.82608695652174, 0.1, 0.38636363636364
4811, 0.80434782608696, 0.1, 0.45454545454545
4812, 0.82608695652174, 0.1, 0.43181818181818
4813, 0.82608695652174, 0.1, 0.47727272727273
4814, 0.84782608695652, 0.1, 0.045454545454545
4815, 0.8695652173913, 0.1, 0.022727272727273
4816, 0.84782608695652, 0.1, 0.090909090909091
4817, 0.8695652173913, 0.1, 0.068181818181818
4818, 0.84782608695652, 0.1, 0.13636363636364
4819, 0.8695652173913, 0.1, 0.11363636363636
4820, 0.84782608695652, 0.1, 0.18181818181818
4821, 0.8695652173913, 0.1, 0.15909090909091
4822, 0.84782608695652, 0.1, 0.22727272727273
4823, 0.8695652173913, 0.1, 0.20454545454545
4824, 0.84782608695652, 0.1, 0.27272727272727
4825, 0.8695652173913, 0.1, 0.25
4826, 0.84782608695652, 0.1, 0.31818181818182
4827, 0.8695652173913, 0.1, 0.29545454545455
4828, 0.84782608695652, 0.1, 0.36363636363636
4829, 0.8695652173913, 0.1, 0.34090909090909
4830, 0.84782608695652, 0.1, 0.40909090909091
4831, 0.8695652173913, 0.1, 0.38636363636364
4832, 0.84782608695652, 0.1, 0.45454545454545
4833, 0.8695652173913, 0.1, 0.43181818181818
4834, 0.8695652173913, 0.1, 0.47727272727273
4835, 0.89130434782609, 0.1, 0.045454545454545
4836, 0.91304347826087, 0.1, 0.022727272727273
4837, 0.89130434782609, 0.1, 0.090909090909091
4838, 0.91304347826087, 0.1, 0.068181818181818
4839, 0.89130434782609, 0.1, 0.13636363636364
4840, 0.91304347826087, 0.1, 0.11363636363636
4841, 0.89130434782609, 0.1, 0.18181818181818
4842, 0.91304347826087, 0.1, 0.15909090909091
4843, 0.89130434782609, 0.1, 0.22727272727273
4844, 0.91304347826087, 0.1, 0.20454545454545
4845, 0.89130434782609, 0.1, 0.27272727272727
4846, 0.91304347826087, 0.1, 0.25
4847, 0.89130434782609, 0.1, 0.31818181818182
4848, 0.91304347826087, 0.1, 0.29545454545455
4849, 0.89130434782609, 0.1, 0.36363636363636
4850, 0.91304347826087, 0.1, 0.34090909090909
4851, 0.89130434782609, 0.1, 0.40909090909091
4852, 0.91304347826087, 0.1, 0.38636363636364
4853, 0.89130434782609, 0.1, 0.45454545454545
4854, 0.91304347826087, 0.1, 0.43181818181818
4855, 0.91304347826087, 0.1, 0.47727272727273
4856, 0.93478260869565, 0.1, 0.045454545454545
4857, 0.95652173913043, 0.1, 0.022727272727273
4858, 0.93478260869565, 0.1, 0.090909090909091
4859, 0.95652173913043, 0.1, 0.068181818181818
4860, 0.93478260869565, 0.1, 0.13636363636364
4861, 0.95652173913044, 0.1, 0.11363636363636
4862, 0.93478260869565, 0.1, 0.18181818181818
4863, 0.95652173913043, 0.1, 0.15909090909091
4864, 0.93478260869565, 0.1, 0.22727272727273
4865, 0.95652173913043, 0.1, 0.20454545454545
4866, 0.93478260869565, 0.1, 0.27272727272727
4867, 0.95652173913043, 0.1, 0.25
4868, 0.93478260869565, 0.1, 0.31818181818182
4869, 0.95652173913043, 0.1, 0.29545454545455
4870, 0.93478260869565, 0.1, 0.36363636363636
4871, 0.95652173913043, 0.1, 0.34090909090909
4872, 0.93478260869565, 0.1, 0.40909090909091
4873, 0.95652173913043, 0.1, 0.38636363636364
4874, 0.93478260869565, 0.1, 0.45454545454545
4875, 0.95652173913043, 0.1, 0.43181818181818
4876, 0.95652173913043, 0.1, 0.47727272727273
4877, 0.97826086956522, 0.1, 0.045454545454545
4878, 0.97826086956522, 0.1, 0.090909090909091
4879, 0.97826086956522, 0.1, 0.13636363636364
4880, 0.97826086956522, 0.1, 0.18181818181818
4881, 0.97826086956522, 0.1, 0.22727272727273
4882, 0.97826086956522, 0.1, 0.27272727272727
4883, 0.97826086956522, 0.1, 0.31818181818182
4884, 0.97826086956522, 0.1, 0.36363636363636
4885, 0.97826086956522, 0.1, 0.40909090909091
4886, 0.97826086956522, 0.1, 0.45454545454545
4887, 0.043478260869565, 0.033333333333333, 0
4888, 0.08695652173913, 0.033333333333333, 0
4889, 0.1304347826087, 0.033333333333333, 0
4890, 0.17391304347826, 0.033333333333333, 0
4891, 0.21739130434783, 0.033333333333333, 0
4892, 0.26086956521739, 0.033333333333333, 0
4893, 0.30434782608696, 0.033333333333333, 0
4894, 0.34782608695652, 0.033333333333333, 0
4895, 0.39130434782609, 0.033333333333333, 0
4896, 0.43478260869565, 0.033333333333333, 0
4897, 0.47826086956522, 0.033333333333333, 0
4898, 0.52173913043478, 0.033333333333333, 0
4899, 0.56521739130435, 0.033333333333333, 0
4900, 0.60869565217391, 0.033333333333333, 0
4901, 0.65217391304348, 0.033333333333333, 0
4902, 0.69565217391304, 0.033333333333333, 0
4903, 0.73913043478261, 0.033333333333333, 0
4904, 0.78260869565217, 0.033333333333333, 0
4905, 0.82608695652174, 0.033333333333333, 0
4906, 0.8695652173913, 0.033333333333333, 0
4907, 0.91304347826087, 0.033333333333333, 0
4908, 0.95652173913043, 0.033333333333333, 0
4909, 0.043478260869565, 0.066666666666667, 0
4910, 0.08695652173913, 0.066666666666667, 0
4911, 0.1304347826087, 0.066666666666667, 0
4912, 0.17391304347826, 0.066666666666667, 0
4913, 0.21739130434783, 0.066666666666667, 0
4914, 0.26086956521739, 0.066666666666667, 0
4915, 0.30434782608696, 0.066666666666667, 0
4916, 0.34782608695652, 0.066666666666667, 0
4917, 0.39130434782609, 0.066666666666667, 0
4918, 0.43478260869565, 0.066666666666667, 0
4919, 0.47826086956522, 0.066666666666667, 0
4920, 0.52173913043478, 0.066666666666667, 0
4921, 0.56521739130435, 0.066666666666667, 0
4922, 0.60869565217391, 0.066666666666667, 0
4923, 0.65217391304348, 0.066666666666667, 0
4924, 0.69565217391304, 0.066666666666667, 0
4925, 0.73913043478261, 0.066666666666667, 0
4926, 0.78260869565217, 0.066666666666667, 0
4927, 0.82608695652174, 0.066666666666667, 0
4928, 0.8695652173913, 0.066666666666667, 0
4929, 0.91304347826087, 0.066666666666667, 0
4930, 0.95652173913043, 0.066666666666667, 0
4931, 0.021739130434783, 0.033333333333333, 0
4932, 0.043478260869565, 0.016666666666667, 0
4933, 0.065217391304348, 0.033333333333333, 0
4934, 0.08695652173913, 0.016666666666667, 0
4935, 0.10869565217391, 0.033333333333333, 0
4936, 0.1304347826087, 0.016666666666667, 0
4937, 0.15217391304348, 0.033333333333333, 0
4938, 0.17391304347826, 0.016666666666667, 0
4939, 0.19565217391304, 0.033333333333333, 0
4940, 0.21739130434783, 0.016666666666667, 0
4941, 0.23913043478261, 0.033333333333333, 0
4942, 0.26086956521739, 0.016666666666667, 0
4943, 0.28260869565217, 0.033333333333333, 0
4944, 0.30434782608696, 0.016666666666667, 0
4945, 0.32608695652174, 0.033333333333333, 0
4946, 0.34782608695652, 0.016666666666667, 0
4947, 0.3695652173913, 0.033333333333333, 0
4948, 0.39130434782609, 0.016666666666667, 0
4949, 0.41304347826087, 0.033333333333333, 0
4950, 0.43478260869565, 0.016666666666667, 0
4951, 0.45652173913043, 0.033333333333333, 0
4952, 0.47826086956522, 0.016666666666667, 0
4953, 0.5, 0.033333333333333, 0
4954, 0.52173913043478, 0.016666666666667, 0
4955, 0.54347826086957, 0.033333333333333, 0
4956, 0.56521739130435, 0.016666666666667, 0
4957, 0.58695652173913, 0.033333333333333, 0
4958, 0.60869565217391, 0.016666666666667, 0
4959, 0.6304347826087, 0.033333333333333, 0
4960, 0.65217391304348, 0.016666666666667, 0
4961, 0.67391304347826, 0.033333333333333, 0
4962, 0.69565217391304, 0.016666666666667, 0
4963, 0.71739130434783, 0.033333333333333, 0
4964, 0.73913043478261, 0.016666666666667, 0
4965, 0.76086956521739, 0.033333333333333, 0
4966, 0.78260869565217, 0.016666666666667, 0
4967, 0.80434782608696, 0.033333333333333, 0
4968, 0.82608695652174, 0.016666666666667, 0
4969, 0.84782608695652, 0.033333333333333, 0
4970, 0.8695652173913, 0.016666666666667, 0
4971, 0.89130434782609, 0.033333333333333, 0
4972, 0.91304347826087, 0.016666666666667, 0
4973, 0.93478260869565, 0.033333333333333, 0
4974, 0.95652173913043, 0.016666666666667, 0
4975, 0.97826086956522, 0.033333333333333, 0
4976, 0.021739130434783, 0.066666666666667, 0
4977, 0.043478260869565, 0.05, 0
4978, 0.065217391304348, 0.066666666666667, 0
4979, 0.08695652173913, 0.05, 0
4980, 0.10869565217391, 0.066666666666667, 0
4981, 0.1304347826087, 0.05, 0
4982, 0.15217391304348, 0.066666666666667, 0
4983, 0.17391304347826, 0.05, 0
4984, 0.19565217391304, 0.066666666666667, 0
4985, 0.21739130434783, 0.05, 0
4986, 0.23913043478261, 0.066666666666667, 0
4987, 0.26086956521739, 0.05, 0
4988, 0.28260869565217, 0.066666666666667, 0
4989, 0.30434782608696, 0.05, 0
4990, 0.32608695652174, 0.066666666666667, 0
4991, 0.34782608695652, 0.05, 0
4992, 0.3695652173913, 0.066666666666667, 0
4993, 0.39130434782609, 0.05, 0
4994, 0.41304347826087, 0.066666666666667, 0
4995, 0.43478260869565, 0.05, 0
4996, 0.45652173913043, 0.066666666666667, 0
4997, 0.47826086956522, 0.05, 0
4998, 0.5, 0.066666666666667, 0
4999, 0.52173913043478, 0.05, 0
5000, 0.54347826086957, 0.066666666666667, 0
5001, 0.56521739130435, 0.05, 0
5002, 0.58695652173913, 0.066666666666667, 0
5003, 0.60869565217391, 0.05, 0
5004, 0.6304347826087, 0.066666666666667, 0
5005, 0.65217391304348, 0.05, 0
5006, 0.67391304347826, 0.066666666666667, 0
5007, 0.69565217391304, 0.05, 0
5008, 0.71739130434783, 0.066666666666667, 0
5009, 0.73913043478261, 0.05, 0
5010, 0.76086956521739, 0.066666666666667, 0
5011, 0.78260869565217, 0.05, 0
5012, 0.80434782608696, 0.066666666666667, 0
5013, 0.82608695652174, 0.05, 0
5014, 0.84782608695652, 0.066666666666667, 0
5015, 0.8695652173913, 0.05, 0
5016, 0.89130434782609, 0.066666666666667, 0
5017, 0.91304347826087, 0.05, 0
5018, 0.93478260869565, 0.066666666666667, 0
5019, 0.95652173913043, 0.05, 0
5020, 0.97826086956522, 0.066666666666667, 0
5021, 0.043478260869565, 0.083333333333333, 0
5022, 0.08695652173913, 0.083333333333333, 0
5023, 0.1304347826087, 0.083333333333333, 0
5024, 0.17391304347826, 0.083333333333333, 0
5025, 0.21739130434783, 0.083333333333333, 0
5026, 0.26086956521739, 0.083333333333333, 0
5027, 0.30434782608696, 0.083333333333333, 0
5028, 0.34782608695652, 0.083333333333333, 0
5029, 0.39130434782609, 0.083333333333333, 0
5030, 0.43478260869565, 0.083333333333333, 0
5031, 0.47826086956522, 0.083333333333333, 0
5032, 0.52173913043478, 0.083333333333333, 0
5033, 0.56521739130435, 0.083333333333333, 0
5034, 0.60869565217391, 0.083333333333333, 0
5035, 0.65217391304348, 0.083333333333333, 0
5036, 0.69565217391304, 0.083333333333333, 0
5037, 0.73913043478261, 0.083333333333333, 0
5038, 0.78260869565217, 0.083333333333333, 0
5039, 0.82608695652174, 0.083333333333333, 0
5040, 0.8695652173913, 0.083333333333333, 0
5041, 0.91304347826087, 0.083333333333333, 0
5042, 0.95652173913043, 0.083333333333333, 0
5043, 0.043478260869565, 0.033333333333333, 0.5
5044, 0.08695652173913, 0.033333333333333, 0.5
5045, 0.1304347826087, 0.033333333333333, 0.5
5046, 0.17391304347826, 0.033333333333333, 0.5
5047, 0.21739130434783, 0.033333333333333, 0.5
5048, 0.26086956521739, 0.033333333333333, 0.5
5049, 0.30434782608696, 0.033333333333333, 0.5
5050, 0.34782608695652, 0.033333333333333, 0.5
5051, 0.39130434782609, 0.033333333333333, 0.5
5052, 0.43478260869565, 0.033333333333333, 0.5
5053, 0.47826086956522, 0.033333333333333, 0.5
5054, 0.52173913043478, 0.033333333333333, 0.5
5055, 0.56521739130435, 0.033333333333333, 0.5
5056, 0.60869565217391, 0.033333333333333, 0.5
5057, 0.65217391304348, 0.033333333333333, 0.5
5058, 0.69565217391304, 0.033333333333333, 0.5
5059, 0.73913043478261, 0.033333333333333, 0.5
5060, 0.78260869565217, 0.033333333333333, 0.5
5061, 0.82608695652174, 0.033333333333333, 0.5
5062, 0.8695652173913, 0.033333333333333, 0.5
5063, 0.91304347826087, 0.033333333333333, 0.5
5064, 0.95652173913043, 0.033333333333333, 0.5
5065, 0.043478260869565, 0.066666666666667, 0.5
5066, 0.08695652173913, 0.066666666666667, 0.5
5067, 0.1304347826087, 0.066666666666667, 0.5
5068, 0.17391304347826, 0.066666666666667, 0.5
5069, 0.21739130434783, 0.066666666666667, 0.5
5070, 0.26086956521739, 0.066666666666667, 0.5
5071, 0.30434782608696, 0.066666666666667, 0.5
5072, 0.34782608695652, 0.066666666666667, 0.5
5073, 0.39130434782609, 0.066666666666667, 0.5
5074, 0.43478260869565, 0.066666666666667, 0.5
5075, 0.47826086956522, 0.066666666666667, 0.5
5076, 0.52173913043478, 0.066666666666667, 0.5
5077, 0.56521739130435, 0.066666666666667, 0.5
5078, 0.60869565217391, 0.066666666666667, 0.5
5079, 0.65217391304348, 0.066666666666667, 0.5
5080, 0.69565217391304, 0.066666666666667, 0.5
5081, 0.73913043478261, 0.066666666666667, 0.5
5082, 0.78260869565217, 0.066666666666667, 0.5
5083, 0.82608695652174, 0.066666666666667, 0.5
5084, 0.8695652173913, 0.066666666666667, 0.5
5085, 0.91304347826087, 0.066666666666667, 0.5
5086, 0.95652173913043, 0.066666666666667, 0.5
5087, 0.043478260869565, 0.016666666666667, 0.5
5088, 0.021739130434783, 0.033333333333333, 0.5
5089, 0.08695652173913, 0.016666666666667, 0.5
5090, 0.065217391304348, 0.033333333333333, 0.5
5091, 0.1304347826087, 0.016666666666667, 0.5
5092, 0.10869565217391, 0.033333333333333, 0.5
5093, 0.17391304347826, 0.016666666666667, 0.5
5094, 0.15217391304348, 0.033333333333333, 0.5
5095, 0.21739130434783, 0.016666666666667, 0.5
5096, 0.19565217391304, 0.033333333333333, 0.5
5097, 0.26086956521739, 0.016666666666667, 0.5
5098, 0.23913043478261, 0.033333333333333, 0.5
5099, 0.30434782608696, 0.016666666666667, 0.5
5100, 0.28260869565217, 0.033333333333333, 0.5
5101, 0.34782608695652, 0.016666666666667, 0.5
5102, 0.32608695652174, 0.033333333333333, 0.5
5103, 0.39130434782609, 0.016666666666667, 0.5
5104, 0.3695652173913, 0.033333333333333, 0.5
5105, 0.43478260869565, 0.016666666666667, 0.5
5106, 0.41304347826087, 0.033333333333333, 0.5
5107, 0.47826086956522, 0.016666666666667, 0.5
5108, 0.45652173913043, 0.033333333333333, 0.5
5109, 0.52173913043478, 0.016666666666667, 0.5
5110, 0.5, 0.033333333333333, 0.5
5111, 0.56521739130435, 0.016666666666667, 0.5
5112, 0.54347826086957, 0.033333333333333, 0.5
5113, 0.60869565217391, 0.016666666666667, 0.5
5114, 0.58695652173913, 0.033333333333333, 0.5
5115, 0.65217391304348, 0.016666666666667, 0.5
5116, 0.6304347826087, 0.033333333333333, 0.5
5117, 0.69565217391304, 0.016666666666667, 0.5
5118, 0.67391304347826, 0.033333333333333, 0.5
5119, 0.73913043478261, 0.016666666666667, 0.5
5120, 0.71739130434783, 0.033333333333333, 0.5
5121, 0.78260869565217, 0.016666666666667, 0.5
5122, 0.76086956521739, 0.033333333333333, 0.5
5123, 0.82608695652174, 0.016666666666667, 0.5
5124, 0.80434782608696, 0.033333333333333, 0.5
5125, 0.8695652173913, 0.016666666666667, 0.5
5126, 0.84782608695652, 0.033333333333333, 0.5
5127, 0.91304347826087, 0.016666666666667, 0.5
5128, 0.89130434782609, 0.033333333333333, 0.5
5129, 0.95652173913043, 0.016666666666667, 0.5
5130, 0.93478260869565, 0.033333333333333, 0.5
5131, 0.97826086956522, 0.033333333333333, 0.5
5132, 0.043478260869565, 0.05, 0.5
5133, 0.021739130434783, 0.066666666666667, 0.5
5134, 0.08695652173913, 0.05, 0.5
5135, 0.065217391304348, 0.066666666666667, 0.5
5136, 0.1304347826087, 0.05, 0.5
5137, 0.10869565217391, 0.066666666666667, 0.5
5138, 0.17391304347826, 0.05, 0.5
5139, 0.15217391304348, 0.066666666666667, 0.5
5140, 0.21739130434783, 0.05, 0.5
5141, 0.19565217391304, 0.066666666666667, 0.5
5142, 0.26086956521739, 0.05, 0.5
5143, 0.23913043478261, 0.066666666666667, 0.5
5144, 0.30434782608696, 0.05, 0.5
5145, 0.28260869565217, 0.066666666666667, 0.5
5146, 0.34782608695652, 0.05, 0.5
5147, 0.32608695652174, 0.066666666666667, 0.5
5148, 0.39130434782609, 0.05, 0.5
5149, 0.3695652173913, 0.066666666666667, 0.5
5150, 0.43478260869565, 0.05, 0.5
5151, 0.41304347826087, 0.066666666666667, 0.5
5152, 0.47826086956522, 0.05, 0.5
5153, 0.45652173913043, 0.066666666666667, 0.5
5154, 0.52173913043478, 0.05, 0.5
5155, 0.5, 0.066666666666667, 0.5
5156, 0.56521739130435, 0.05, 0.5
5157, 0.54347826086957, 0.066666666666667, 0.5
5158, 0.60869565217391, 0.05, 0.5
5159, 0.58695652173913, 0.066666666666667, 0.5
5160, 0.65217391304348, 0.05, 0.5
5161, 0.6304347826087, 0.066666666666667, 0.5
5162, 0.69565217391304, 0.05, 0.5
5163, 0.67391304347826, 0.066666666666667, 0.5
5164, 0.73913043478261, 0.05, 0.5
5165, 0.71739130434783, 0.066666666666667, 0.5
5166, 0.78260869565217, 0.05, 0.5
5167, 0.76086956521739, 0.066666666666667, 0.5
5168, 0.82608695652174, 0.05, 0.5
5169, 0.80434782608696, 0.066666666666667, 0.5
5170, 0.8695652173913, 0.05, 0.5
5171, 0.84782608695652, 0.066666666666667, 0.5
5172, 0.91304347826087, 0.05, 0.5
5173, 0.89130434782609, 0.066666666666667, 0.5
5174, 0.95652173913043, 0.05, 0.5
5175, 0.93478260869565, 0.066666666666667, 0.5
5176, 0.97826086956522, 0.066666666666667, 0.5
5177, 0.043478260869565, 0.083333333333333, 0.5
5178, 0.08695652173913, 0.083333333333333, 0.5
5179, 0.1304347826087, 0.083333333333333, 0.5
5180, 0.17391304347826, 0.083333333333333, 0.5
5181, 0.21739130434783, 0.083333333333333, 0.5
5182, 0.26086956521739, 0.083333333333333, 0.5
5183, 0.30434782608696, 0.083333333333333, 0.5
5184, 0.34782608695652, 0.083333333333333, 0.5
5185, 0.39130434782609, 0.083333333333333, 0.5
5186, 0.43478260869565, 0.083333333333333, 0.5
5187, 0.47826086956522, 0.083333333333333, 0.5
5188, 0.52173913043478, 0.083333333333333, 0.5
5189, 0.56521739130435, 0.083333333333333, 0.5
5190, 0.60869565217391, 0.083333333333333, 0.5
5191, 0.65217391304348, 0.083333333333333, 0.5
5192, 0.69565217391304, 0.083333333333333, 0.5
5193, 0.73913043478261, 0.083333333333333, 0.5
5194, 0.78260869565217, 0.083333333333333, 0.5
5195, 0.82608695652174, 0.083333333333333, 0.5
5196, 0.8695652173913, 0.083333333333333, 0.5
5197, 0.91304347826087, 0.083333333333333, 0.5
5198, 0.95652173913043, 0.083333333333333, 0.5
5199, 0.95652173913043, 0.125, 0
5200, 0.91304347826087, 0.125, 0
5201, 0.8695652173913, 0.125, 0
5202, 0.82608695652174, 0.125, 0
5203, 0.78260869565217, 0.125, 0
5204, 0.73913043478261, 0.125, 0
5205, 0.69565217391304, 0.125, 0
5206, 0.65217391304348, 0.125, 0
5207, 0.60869565217391, 0.125, 0
5208, 0.56521739130435, 0.125, 0
5209, 0.52173913043478, 0.125, 0
5210, 0.47826086956522, 0.125, 0
5211, 0.43478260869565, 0.125, 0
5212, 0.39130434782609, 0.125, 0
5213, 0.34782608695652, 0.125, 0
5214, 0.30434782608696, 0.125, 0
5215, 0.26086956521739, 0.125, 0
5216, 0.21739130434783, 0.125, 0
5217, 0.17391304347826, 0.125, 0
5218, 0.1304347826087, 0.125, 0
5219, 0.08695652173913, 0.125, 0
5220, 0.043478260869565, 0.125, 0
5221, 0.95652173913043, 0.1125, 0
5222, 0.97826086956522, 0.125, 0
5223, 0.91304347826087, 0.1125, 0
5224, 0.93478260869565, 0.125, 0
5225, 0.8695652173913, 0.1125, 0
5226, 0.89130434782609, 0.125, 0
5227, 0.82608695652174, 0.1125, 0
5228, 0.84782608695652, 0.125, 0
5229, 0.78260869565217, 0.1125, 0
5230, 0.80434782608696, 0.125, 0
5231, 0.73913043478261, 0.1125, 0
5232, 0.76086956521739, 0.125, 0
5233, 0.69565217391304, 0.1125, 0
5234, 0.71739130434783, 0.125, 0
5235, 0.65217391304348, 0.1125, 0
5236, 0.67391304347826, 0.125, 0
5237, 0.60869565217391, 0.1125, 0
5238, 0.6304347826087, 0.125, 0
5239, 0.56521739130435, 0.1125, 0
5240, 0.58695652173913, 0.125, 0
5241, 0.52173913043478, 0.1125, 0
5242, 0.54347826086957, 0.125, 0
5243, 0.47826086956522, 0.1125, 0
5244, 0.5, 0.125, 0
5245, 0.43478260869565, 0.1125, 0
5246, 0.45652173913043, 0.125, 0
5247, 0.39130434782609, 0.1125, 0
5248, 0.41304347826087, 0.125, 0
5249, 0.34782608695652, 0.1125, 0
5250, 0.3695652173913, 0.125, 0
5251, 0.30434782608696, 0.1125, 0
5252, 0.32608695652174, 0.125, 0
5253, 0.26086956521739, 0.1125, 0
5254, 0.28260869565217, 0.125, 0
5255, 0.21739130434783, 0.1125, 0
5256, 0.23913043478261, 0.125, 0
5257, 0.17391304347826, 0.1125, 0
5258, 0.19565217391304, 0.125, 0
5259, 0.1304347826087, 0.1125, 0
5260, 0.15217391304348, 0.125, 0
5261, 0.08695652173913, 0.1125, 0
5262, 0.10869565217391, 0.125, 0
5263, 0.043478260869565, 0.1125, 0
5264, 0.065217391304348, 0.125, 0
5265, 0.021739130434783, 0.125, 0
5266, 0.95652173913043, 0.1375, 0
5267, 0.91304347826087, 0.1375, 0
5268, 0.8695652173913, 0.1375, 0
5269, 0.82608695652174, 0.1375, 0
5270, 0.78260869565217, 0.1375, 0
5271, 0.73913043478261, 0.1375, 0
5272, 0.69565217391304, 0.1375, 0
5273, 0.65217391304348, 0.1375, 0
5274, 0.60869565217391, 0.1375, 0
5275, 0.56521739130435, 0.1375, 0
5276, 0.52173913043478, 0.1375, 0
5277, 0.47826086956522, 0.1375, 0
5278, 0.43478260869565, 0.1375, 0
5279, 0.39130434782609, 0.1375, 0
5280, 0.34782608695652, 0.1375, 0
5281, 0.30434782608696, 0.1375, 0
5282, 0.26086956521739, 0.1375, 0
5283, 0.21739130434783, 0.1375, 0
5284, 0.17391304347826, 0.1375, 0
5285, 0.1304347826087, 0.1375, 0
5286, 0.08695652173913, 0.1375, 0
5287, 0.043478260869565, 0.1375, 0
5288, 1, 0.125, 0.45454545454545
5289, 1, 0.125, 0.40909090909091
5290, 1, 0.125, 0.36363636363636
5291, 1, 0.125, 0.31818181818182
5292, 1, 0.125, 0.27272727272727
5293, 1, 0.125, 0.22727272727273
5294, 1, 0.125, 0.18181818181818
5295, 1, 0.125, 0.13636363636364
5296, 1, 0.125, 0.090909090909091
5297, 1, 0.125, 0.045454545454545
5298, 1, 0.1125, 0.45454545454545
5299, 1, 0.125, 0.47727272727273
5300, 1, 0.1125, 0.40909090909091
5301, 1, 0.125, 0.43181818181818
5302, 1, 0.1125, 0.36363636363636
5303, 1, 0.125, 0.38636363636364
5304, 1, 0.1125, 0.31818181818182
5305, 1, 0.125, 0.34090909090909
5306, 1, 0.1125, 0.27272727272727
5307, 1, 0.125, 0.29545454545455
5308, 1, 0.1125, 0.22727272727273
5309, 1, 0.125, 0.25
5310, 1, 0.1125, 0.18181818181818
5311, 1, 0.125, 0.20454545454545
5312, 1, 0.1125, 0.13636363636364
5313, 1, 0.125, 0.15909090909091
5314, 1, 0.1125, 0.090909090909091
5315, 1, 0.125, 0.11363636363636
5316, 1, 0.1125, 0.045454545454545
5317, 1, 0.125, 0.068181818181818
5318, 1, 0.125, 0.022727272727273
5319, 1, 0.1375, 0.45454545454545
5320, 1, 0.1375, 0.40909090909091
5321, 1, 0.1375, 0.36363636363636
5322, 1, 0.1375, 0.31818181818182
5323, 1, 0.1375, 0.27272727272727
5324, 1, 0.1375, 0.22727272727273
5325, 1, 0.1375, 0.18181818181818
5326, 1, 0.1375, 0.13636363636364
5327, 1, 0.1375, 0.090909090909091
5328, 1, 0.1375, 0.045454545454545
5329, 0.95652173913043, 0.125, 0.5
5330, 0.91304347826087, 0.125, 0.5
5331, 0.8695652173913, 0.125, 0.5
5332, 0.82608695652174, 0.125, 0.5
5333, 0.78260869565217, 0.125, 0.5
5334, 0.73913043478261, 0.125, 0.5
5335, 0.69565217391304, 0.125, 0.5
5336, 0.65217391304348, 0.125, 0.5
5337, 0.60869565217391, 0.125, 0.5
5338, 0.56521739130435, 0.125, 0.5
5339, 0.52173913043478, 0.125, 0.5
5340, 0.47826086956522, 0.125, 0.5
5341, 0.43478260869565, 0.125, 0.5
5342, 0.39130434782609, 0.125, 0.5
5343, 0.34782608695652, 0.125, 0.5
5344, 0.30434782608696, 0.125, 0.5
5345, 0.26086956521739, 0.125, 0.5
5346, 0.21739130434783, 0.125, 0.5
5347, 0.17391304347826, 0.125, 0.5
5348, 0.1304347826087, 0.125, 0.5
5349, 0.08695652173913, 0.125, 0.5
5350, 0.043478260869565, 0.125, 0.5
5351, 0.97826086956522, 0.125, 0.5
5352, 0.95652173913043, 0.1125, 0.5
5353, 0.93478260869565, 0.125, 0.5
5354, 0.91304347826087, 0.1125, 0.5
5355, 0.89130434782609, 0.125, 0.5
5356, 0.8695652173913, 0.1125, 0.5
5357, 0.84782608695652, 0.125, 0.5
5358, 0.82608695652174, 0.1125, 0.5
5359, 0.80434782608696, 0.125, 0.5
5360, 0.78260869565217, 0.1125, 0.5
5361, 0.76086956521739, 0.125, 0.5
5362, 0.73913043478261, 0.1125, 0.5
5363, 0.71739130434783, 0.125, 0.5
5364, 0.69565217391304, 0.1125, 0.5
5365, 0.67391304347826, 0.125, 0.5
5366, 0.65217391304348, 0.1125, 0.5
5367, 0.6304347826087, 0.125, 0.5
5368, 0.60869565217391, 0.1125, 0.5
5369, 0.58695652173913, 0.125, 0.5
5370, 0.56521739130435, 0.1125, 0.5
5371, 0.54347826086957, 0.125, 0.5
5372, 0.52173913043478, 0.1125, 0.5
5373, 0.5, 0.125, 0.5
5374, 0.47826086956522, 0.1125, 0.5
5375, 0.45652173913043, 0.125, 0.5
5376, 0.43478260869565, 0.1125, 0.5
5377, 0.41304347826087, 0.125, 0.5
5378, 0.39130434782609, 0.1125, 0.5
5379, 0.3695652173913, 0.125, 0.5
5380, 0.34782608695652, 0.1125, 0.5
5381, 0.32608695652174, 0.125, 0.5
5382, 0.30434782608696, 0.1125, 0.5
5383, 0.28260869565217, 0.125, 0.5
5384, 0.26086956521739, 0.1125, 0.5
5385, 0.23913043478261, 0.125, 0.5
5386, 0.21739130434783, 0.1125, 0.5
5387, 0.19565217391304, 0.125, 0.5
5388, 0.17391304347826, 0.1125, 0.5
5389, 0.15217391304348, 0.125, 0.5
5390, 0.1304347826087, 0.1125, 0.5
5391, 0.10869565217391, 0.125, 0.5
5392, 0.08695652173913, 0.1125, 0.5
5393, 0.065217391304348, 0.125, 0.5
5394, 0.043478260869565, 0.1125, 0.5
5395, 0.021739130434783, 0.125, 0.5
5396, 0.95652173913043, 0.1375, 0.5
5397, 0.91304347826087, 0.1375, 0.5
5398, 0.8695652173913, 0.1375, 0.5
5399, 0.82608695652174, 0.1375, 0.5
5400, 0.78260869565217, 0.1375, 0.5
5401, 0.73913043478261, 0.1375, 0.5
5402, 0.69565217391304, 0.1375, 0.5
5403, 0.65217391304348, 0.1375, 0.5
5404, 0.60869565217391, 0.1375, 0.5
5405, 0.56521739130435, 0.1375, 0.5
5406, 0.52173913043478, 0.1375, 0.5
5407, 0.47826086956522, 0.1375, 0.5
5408, 0.43478260869565, 0.1375, 0.5
5409, 0.39130434782609, 0.1375, 0.5
5410, 0.34782608695652, 0.1375, 0.5
5411, 0.30434782608696, 0.1375, 0.5
5412, 0.26086956521739, 0.1375, 0.5
5413, 0.21739130434783, 0.1375, 0.5
5414, 0.17391304347826, 0.1375, 0.5
5415, 0.1304347826087, 0.1375, 0.5
5416, 0.08695652173913, 0.1375, 0.5
5417, 0.043478260869565, 0.1375, 0.5
5418, 0, 0.125, 0.45454545454545
5419, 0, 0.125, 0.40909090909091
5420, 0, 0.125, 0.36363636363636
5421, 0, 0.125, 0.31818181818182
5422, 0, 0.125, 0.27272727272727
5423, 0, 0.125, 0.22727272727273
5424, 0, 0.125, 0.18181818181818
5425, 0, 0.125, 0.13636363636364
5426, 0, 0.125, 0.090909090909091
5427, 0, 0.125, 0.045454545454545
5428, 0, 0.125, 0.47727272727273
5429, 0, 0.1125, 0.45454545454545
5430, 0, 0.125, 0.43181818181818
5431, 0, 0.1125, 0.40909090909091
5432, 0, 0.125, 0.38636363636364
5433, 0, 0.1125, 0.36363636363636
5434, 0, 0.125, 0.34090909090909
5435, 0, 0.1125, 0.31818181818182
5436, 0, 0.125, 0.29545454545455
5437, 0, 0.1125, 0.27272727272727
5438, 0, 0.125, 0.25
5439, 0, 0.1125, 0.22727272727273
5440, 0, 0.125, 0.20454545454545
5441, 0, 0.1125, 0.18181818181818
5442, 0, 0.125, 0.15909090909091
5443, 0, 0.1125, 0.13636363636364
5444, 0, 0.125, 0.11363636363636
5445, 0, 0.1125, 0.090909090909091
5446, 0, 0.125, 0.068181818181818
5447, 0, 0.1125, 0.045454545454545
5448, 0, 0.125, 0.022727272727273
5449, 0, 0.1375, 0.45454545454545
5450, 0, 0.1375, 0.40909090909091
5451, 0, 0.1375, 0.36363636363636
5452, 0, 0.1375, 0.31818181818182
5453, 0, 0.1375, 0.27272727272727
5454, 0, 0.1375, 0.22727272727273
5455, 0, 0.1375, 0.18181818181818
5456, 0, 0.1375, 0.13636363636364
5457, 0, 0.1375, 0.090909090909091
5458, 0, 0.1375, 0.045454545454545
5459, 0.043478260869565, 0.15, 0.045454545454545
5460, 0.043478260869565, 0.15, 0.090909090909091
5461, 0.043478260869565, 0.15, 0.13636363636364
5462, 0.043478260869565, 0.15, 0.18181818181818
5463, 0.043478260869565, 0.15, 0.22727272727273
5464, 0.043478260869565, 0.15, 0.27272727272727
5465, 0.043478260869565, 0.15, 0.31818181818182
5466, 0.043478260869565, 0.15, 0.36363636363636
5467, 0.043478260869565, 0.15, 0.40909090909091
5468, 0.043478260869565, 0.15, 0.45454545454545
5469, 0.08695652173913, 0.15, 0.045454545454545
5470, 0.08695652173913, 0.15, 0.090909090909091
5471, 0.08695652173913, 0.15, 0.13636363636364
5472, 0.08695652173913, 0.15, 0.18181818181818
5473, 0.08695652173913, 0.15, 0.22727272727273
5474, 0.08695652173913, 0.15, 0.27272727272727
5475, 0.08695652173913, 0.15, 0.31818181818182
5476, 0.08695652173913, 0.15, 0.36363636363636
5477, 0.08695652173913, 0.15, 0.40909090909091
5478, 0.08695652173913, 0.15, 0.45454545454545
5479, 0.1304347826087, 0.15, 0.045454545454545
5480, 0.1304347826087, 0.15, 0.090909090909091
5481, 0.1304347826087, 0.15, 0.13636363636364
5482, 0.1304347826087, 0.15, 0.18181818181818
5483, 0.1304347826087, 0.15, 0.22727272727273
5484, 0.1304347826087, 0.15, 0.27272727272727
5485, 0.1304347826087, 0.15, 0.31818181818182
5486, 0.1304347826087, 0.15, 0.36363636363636
5487, 0.1304347826087, 0.15, 0.40909090909091
5488, 0.1304347826087, 0.15, 0.45454545454545
5489, 0.17391304347826, 0.15, 0.045454545454545
5490, 0.17391304347826, 0.15, 0.090909090909091
5491, 0.17391304347826, 0.15, 0.13636363636364
5492, 0.17391304347826, 0.15, 0.18181818181818
5493, 0.17391304347826, 0.15, 0.22727272727273
5494, 0.17391304347826, 0.15, 0.27272727272727
5495, 0.17391304347826, 0.15, 0.31818181818182
5496, 0.17391304347826, 0.15, 0.36363636363636
5497, 0.17391304347826, 0.15, 0.40909090909091
5498, 0.17391304347826, 0.15, 0.45454545454545
5499, 0.21739130434783, 0.15, 0.045454545454545
5500, 0.21739130434783, 0.15, 0.090909090909091
5501, 0.21739130434783, 0.15, 0.13636363636364
5502, 0.21739130434783, 0.15, 0.18181818181818
5503, 0.21739130434783, 0.15, 0.22727272727273
5504, 0.21739130434783, 0.15, 0.27272727272727
5505, 0.21739130434783, 0.15, 0.31818181818182
5506, 0.21739130434783, 0.15, 0.36363636363636
5507, 0.21739130434783, 0.15, 0.40909090909091
5508, 0.21739130434783, 0.15, 0.45454545454545
5509, 0.26086956521739, 0.15, 0.045454545454545
5510, 0.26086956521739, 0.15, 0.090909090909091
5511, 0.26086956521739, 0.15, 0.13636363636364
5512, 0.26086956521739, 0.15, 0.18181818181818
5513, 0.26086956521739, 0.15, 0.22727272727273
5514, 0.26086956521739, 0.15, 0.27272727272727
5515, 0.26086956521739, 0.15, 0.31818181818182
5516, 0.26086956521739, 0.15, 0.36363636363636
5517, 0.26086956521739, 0.15, 0.40909090909091
5518, 0.26086956521739, 0.15, 0.45454545454545
5519, 0.30434782608696, 0.15, 0.045454545454545
5520, 0.30434782608696, 0.15, 0.090909090909091
5521, 0.30434782608696, 0.15, 0.13636363636364
5522, 0.30434782608696, 0.15, 0.18181818181818
5523, 0.30434782608696, 0.15, 0.22727272727273
5524, 0.30434782608696, 0.15, 0.27272727272727
5525, 0.30434782608696, 0.15, 0.31818181818182
5526, 0.30434782608696, 0.15, 0.36363636363636
5527, 0.30434782608696, 0.15, 0.40909090909091
5528, 0.30434782608696, 0.15, 0.45454545454545
5529, 0.34782608695652, 0.15, 0.045454545454545
5530, 0.34782608695652, 0.15, 0.090909090909091
5531, 0.34782608695652, 0.15, 0.13636363636364
5532, 0.34782608695652, 0.15, 0.18181818181818
5533, 0.34782608695652, 0.15, 0.22727272727273
5534, 0.34782608695652, 0.15, 0.27272727272727
5535, 0.34782608695652, 0.15, 0.31818181818182
5536, 0.34782608695652, 0.15, 0.36363636363636
5537, 0.34782608695652, 0.15, 0.40909090909091
5538, 0.34782608695652, 0.15, 0.45454545454545
5539, 0.39130434782609, 0.15, 0.045454545454545
5540, 0.39130434782609, 0.15, 0.090909090909091
5541, 0.39130434782609, 0.15, 0.13636363636364
5542, 0.39130434782609, 0.15, 0.18181818181818
5543, 0.39130434782609, 0.15, 0.22727272727273
5544, 0.39130434782609, 0.15, 0.27272727272727
5545, 0.39130434782609, 0.15, 0.31818181818182
5546, 0.39130434782609, 0.15, 0.36363636363636
5547, 0.39130434782609, 0.15, 0.40909090909091
5548, 0.39130434782609, 0.15, 0.45454545454545
5549, 0.43478260869565, 0.15, 0.045454545454545
5550, 0.43478260869565, 0.15, 0.090909090909091
5551, 0.43478260869565, 0.15, 0.13636363636364
5552, 0.43478260869565, 0.15, 0.18181818181818
5553, 0.43478260869565, 0.15, 0.22727272727273
5554, 0.43478260869565, 0.15, 0.27272727272727
5555, 0.43478260869565, 0.15, 0.31818181818182
5556, 0.43478260869565, 0.15, 0.36363636363636
5557, 0.43478260869565, 0.15, 0.40909090909091
5558, 0.43478260869565, 0.15, 0.45454545454545
5559, 0.47826086956522, 0.15, 0.045454545454545
5560, 0.47826086956522, 0.15, 0.090909090909091
5561, 0.47826086956522, 0.15, 0.13636363636364
5562, 0.47826086956522, 0.15, 0.18181818181818
5563, 0.47826086956522, 0.15, 0.22727272727273
5564, 0.47826086956522, 0.15, 0.27272727272727
5565, 0.47826086956522, 0.15, 0.31818181818182
5566, 0.47826086956522, 0.15, 0.36363636363636
5567, 0.47826086956522, 0.15, 0.40909090909091
5568, 0.47826086956522, 0.15, 0.45454545454545
5569, 0.52173913043478, 0.15, 0.045454545454545
5570, 0.52173913043478, 0.15, 0.090909090909091
5571, 0.52173913043478, 0.15, 0.13636363636364
5572, 0.52173913043478, 0.15, 0.18181818181818
5573, 0.52173913043478, 0.15, 0.22727272727273
5574, 0.52173913043478, 0.15, 0.27272727272727
5575, 0.52173913043478, 0.15, 0.31818181818182
5576, 0.52173913043478, 0.15, 0.36363636363636
5577, 0.52173913043478, 0.15, 0.40909090909091
5578, 0.52173913043478, 0.15, 0.45454545454545
5579, 0.56521739130435, 0.15, 0.045454545454545
5580, 0.56521739130435, 0.15, 0.090909090909091
5581, 0.56521739130435, 0.15, 0.13636363636364
5582, 0.56521739130435, 0.15, 0.18181818181818
5583, 0.56521739130435, 0.15, 0.22727272727273
5584, 0.56521739130435, 0.15, 0.27272727272727
5585, 0.56521739130435, 0.15, 0.31818181818182
5586, 0.56521739130435, 0.15, 0.36363636363636
5587, 0.56521739130435, 0.15, 0.40909090909091
5588, 0.56521739130435, 0.15, 0.45454545454545
5589, 0.60869565217391, 0.15, 0.045454545454545
5590, 0.60869565217391, 0.15, 0.090909090909091
5591, 0.60869565217391, 0.15, 0.13636363636364
5592, 0.60869565217391, 0.15, 0.18181818181818
5593, 0.60869565217391, 0.15, 0.22727272727273
5594, 0.60869565217391, 0.15, 0.27272727272727
5595, 0.60869565217391, 0.15, 0.31818181818182
5596, 0.60869565217391, 0.15, 0.36363636363636
5597, 0.60869565217391, 0.15, 0.40909090909091
5598, 0.60869565217391, 0.15, 0.45454545454545
5599, 0.65217391304348, 0.15, 0.045454545454545
5600, 0.65217391304348, 0.15, 0.090909090909091
5601, 0.65217391304348, 0.15, 0.13636363636364
5602, 0.65217391304348, 0.15, 0.18181818181818
5603, 0.65217391304348, 0.15, 0.22727272727273
5604, 0.65217391304348, 0.15, 0.27272727272727
5605, 0.65217391304348, 0.15, 0.31818181818182
5606, 0.65217391304348, 0.15, 0.36363636363636
5607, 0.65217391304348, 0.15, 0.40909090909091
5608, 0.65217391304348, 0.15, 0.45454545454545
5609, 0.69565217391304, 0.15, 0.045454545454545
5610, 0.69565217391304, 0.15, 0.090909090909091
5611, 0.69565217391304, 0.15, 0.13636363636364
5612, 0.69565217391304, 0.15, 0.18181818181818
5613, 0.69565217391304, 0.15, 0.22727272727273
5614, 0.69565217391304, 0.15, 0.27272727272727
5615, 0.69565217391304, 0.15, 0.31818181818182
5616, 0.69565217391304, 0.15, 0.36363636363636
5617, 0.69565217391304, 0.15, 0.40909090909091
5618, 0.69565217391304, 0.15, 0.45454545454545
5619, 0.73913043478261, 0.15, 0.045454545454545
5620, 0.73913043478261, 0.15, 0.090909090909091
5621, 0.73913043478261, 0.15, 0.13636363636364
5622, 0.73913043478261, 0.15, 0.18181818181818
5623, 0.73913043478261, 0.15, 0.22727272727273
5624, 0.73913043478261, 0.15, 0.27272727272727
5625, 0.73913043478261, 0.15, 0.31818181818182
5626, 0.73913043478261, 0.15, 0.36363636363636
5627, 0.73913043478261, 0.15, 0.40909090909091
5628, 0.73913043478261, 0.15, 0.45454545454545
5629, 0.78260869565217, 0.15, 0.045454545454545
5630, 0.78260869565217, 0.15, 0.090909090909091
5631, 0.78260869565217, 0.15, 0.13636363636364
5632, 0.78260869565217, 0.15, 0.18181818181818
5633, 0.78260869565217, 0.15, 0.22727272727273
5634, 0.78260869565217, 0.15, 0.27272727272727
5635, 0.78260869565217, 0.15, 0.31818181818182
5636, 0.78260869565217, 0.15, 0.36363636363636
5637, 0.78260869565217, 0.15, 0.40909090909091
