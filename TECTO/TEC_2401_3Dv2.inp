56491, 0.34782608695652, 1.425, 0.19444444444444
56492, 0.3695652173913, 1.425, 0.22222222222222
56493, 0.34782608695652, 1.4125, 0.22222222222222
56494, 0.34782608695652, 1.425, 0.25
56495, 0.3695652173913, 1.425, 0.27777777777778
56496, 0.34782608695652, 1.4125, 0.27777777777778
56497, 0.34782608695652, 1.425, 0.30555555555556
56498, 0.3695652173913, 1.425, 0.33333333333333
56499, 0.34782608695652, 1.4125, 0.33333333333333
56500, 0.34782608695652, 1.425, 0.36111111111111
56501, 0.3695652173913, 1.425, 0.38888888888889
56502, 0.34782608695652, 1.4125, 0.38888888888889
56503, 0.34782608695652, 1.425, 0.41666666666667
56504, 0.3695652173913, 1.425, 0.44444444444444
56505, 0.34782608695652, 1.4125, 0.44444444444444
56506, 0.34782608695652, 1.425, 0.47222222222222
56507, 0.30434782608696, 1.425, 0.027777777777778
56508, 0.32608695652174, 1.425, 0.055555555555556
56509, 0.30434782608696, 1.4125, 0.055555555555556
56510, 0.30434782608696, 1.425, 0.083333333333333
56511, 0.32608695652174, 1.425, 0.11111111111111
56512, 0.30434782608696, 1.4125, 0.11111111111111
56513, 0.30434782608696, 1.425, 0.13888888888889
56514, 0.32608695652174, 1.425, 0.16666666666667
56515, 0.30434782608696, 1.4125, 0.16666666666667
56516, 0.30434782608696, 1.425, 0.19444444444444
56517, 0.32608695652174, 1.425, 0.22222222222222
56518, 0.30434782608696, 1.4125, 0.22222222222222
56519, 0.30434782608696, 1.425, 0.25
56520, 0.32608695652174, 1.425, 0.27777777777778
56521, 0.30434782608696, 1.4125, 0.27777777777778
56522, 0.30434782608696, 1.425, 0.30555555555556
56523, 0.32608695652174, 1.425, 0.33333333333333
56524, 0.30434782608696, 1.4125, 0.33333333333333
56525, 0.30434782608696, 1.425, 0.36111111111111
56526, 0.32608695652174, 1.425, 0.38888888888889
56527, 0.30434782608696, 1.4125, 0.38888888888889
56528, 0.30434782608696, 1.425, 0.41666666666667
56529, 0.32608695652174, 1.425, 0.44444444444444
56530, 0.30434782608696, 1.4125, 0.44444444444444
56531, 0.30434782608696, 1.425, 0.47222222222222
56532, 0.26086956521739, 1.425, 0.027777777777778
56533, 0.28260869565217, 1.425, 0.055555555555556
56534, 0.26086956521739, 1.4125, 0.055555555555556
56535, 0.26086956521739, 1.425, 0.083333333333333
56536, 0.28260869565217, 1.425, 0.11111111111111
56537, 0.26086956521739, 1.4125, 0.11111111111111
56538, 0.26086956521739, 1.425, 0.13888888888889
56539, 0.28260869565217, 1.425, 0.16666666666667
56540, 0.26086956521739, 1.4125, 0.16666666666667
56541, 0.26086956521739, 1.425, 0.19444444444444
56542, 0.28260869565217, 1.425, 0.22222222222222
56543, 0.26086956521739, 1.4125, 0.22222222222222
56544, 0.26086956521739, 1.425, 0.25
56545, 0.28260869565217, 1.425, 0.27777777777778
56546, 0.26086956521739, 1.4125, 0.27777777777778
56547, 0.26086956521739, 1.425, 0.30555555555556
56548, 0.28260869565217, 1.425, 0.33333333333333
56549, 0.26086956521739, 1.4125, 0.33333333333333
56550, 0.26086956521739, 1.425, 0.36111111111111
56551, 0.28260869565217, 1.425, 0.38888888888889
56552, 0.26086956521739, 1.4125, 0.38888888888889
56553, 0.26086956521739, 1.425, 0.41666666666667
56554, 0.28260869565217, 1.425, 0.44444444444444
56555, 0.26086956521739, 1.4125, 0.44444444444444
56556, 0.26086956521739, 1.425, 0.47222222222222
56557, 0.21739130434783, 1.425, 0.027777777777778
56558, 0.23913043478261, 1.425, 0.055555555555556
56559, 0.21739130434783, 1.4125, 0.055555555555556
56560, 0.21739130434783, 1.425, 0.083333333333333
56561, 0.23913043478261, 1.425, 0.11111111111111
56562, 0.21739130434783, 1.4125, 0.11111111111111
56563, 0.21739130434783, 1.425, 0.13888888888889
56564, 0.23913043478261, 1.425, 0.16666666666667
56565, 0.21739130434783, 1.4125, 0.16666666666667
56566, 0.21739130434783, 1.425, 0.19444444444444
56567, 0.23913043478261, 1.425, 0.22222222222222
56568, 0.21739130434783, 1.4125, 0.22222222222222
56569, 0.21739130434783, 1.425, 0.25
56570, 0.23913043478261, 1.425, 0.27777777777778
56571, 0.21739130434783, 1.4125, 0.27777777777778
56572, 0.21739130434783, 1.425, 0.30555555555556
56573, 0.23913043478261, 1.425, 0.33333333333333
56574, 0.21739130434783, 1.4125, 0.33333333333333
56575, 0.21739130434783, 1.425, 0.36111111111111
56576, 0.23913043478261, 1.425, 0.38888888888889
56577, 0.21739130434783, 1.4125, 0.38888888888889
56578, 0.21739130434783, 1.425, 0.41666666666667
56579, 0.23913043478261, 1.425, 0.44444444444444
56580, 0.21739130434783, 1.4125, 0.44444444444444
56581, 0.21739130434783, 1.425, 0.47222222222222
56582, 0.17391304347826, 1.425, 0.027777777777778
56583, 0.19565217391304, 1.425, 0.055555555555556
56584, 0.17391304347826, 1.4125, 0.055555555555556
56585, 0.17391304347826, 1.425, 0.083333333333333
56586, 0.19565217391304, 1.425, 0.11111111111111
56587, 0.17391304347826, 1.4125, 0.11111111111111
56588, 0.17391304347826, 1.425, 0.13888888888889
56589, 0.19565217391304, 1.425, 0.16666666666667
56590, 0.17391304347826, 1.4125, 0.16666666666667
56591, 0.17391304347826, 1.425, 0.19444444444444
56592, 0.19565217391304, 1.425, 0.22222222222222
56593, 0.17391304347826, 1.4125, 0.22222222222222
56594, 0.17391304347826, 1.425, 0.25
56595, 0.19565217391304, 1.425, 0.27777777777778
56596, 0.17391304347826, 1.4125, 0.27777777777778
56597, 0.17391304347826, 1.425, 0.30555555555556
56598, 0.19565217391304, 1.425, 0.33333333333333
56599, 0.17391304347826, 1.4125, 0.33333333333333
56600, 0.17391304347826, 1.425, 0.36111111111111
56601, 0.19565217391304, 1.425, 0.38888888888889
56602, 0.17391304347826, 1.4125, 0.38888888888889
56603, 0.17391304347826, 1.425, 0.41666666666667
56604, 0.19565217391304, 1.425, 0.44444444444444
56605, 0.17391304347826, 1.4125, 0.44444444444444
56606, 0.17391304347826, 1.425, 0.47222222222222
56607, 0.1304347826087, 1.425, 0.027777777777778
56608, 0.15217391304348, 1.425, 0.055555555555556
56609, 0.1304347826087, 1.4125, 0.055555555555556
56610, 0.1304347826087, 1.425, 0.083333333333333
56611, 0.15217391304348, 1.425, 0.11111111111111
56612, 0.1304347826087, 1.4125, 0.11111111111111
56613, 0.1304347826087, 1.425, 0.13888888888889
56614, 0.15217391304348, 1.425, 0.16666666666667
56615, 0.1304347826087, 1.4125, 0.16666666666667
56616, 0.1304347826087, 1.425, 0.19444444444444
56617, 0.15217391304348, 1.425, 0.22222222222222
56618, 0.1304347826087, 1.4125, 0.22222222222222
56619, 0.1304347826087, 1.425, 0.25
56620, 0.15217391304348, 1.425, 0.27777777777778
56621, 0.1304347826087, 1.4125, 0.27777777777778
56622, 0.1304347826087, 1.425, 0.30555555555556
56623, 0.15217391304348, 1.425, 0.33333333333333
56624, 0.1304347826087, 1.4125, 0.33333333333333
56625, 0.1304347826087, 1.425, 0.36111111111111
56626, 0.15217391304348, 1.425, 0.38888888888889
56627, 0.1304347826087, 1.4125, 0.38888888888889
56628, 0.1304347826087, 1.425, 0.41666666666667
56629, 0.15217391304348, 1.425, 0.44444444444444
56630, 0.1304347826087, 1.4125, 0.44444444444444
56631, 0.1304347826087, 1.425, 0.47222222222222
56632, 0.08695652173913, 1.425, 0.027777777777778
56633, 0.10869565217391, 1.425, 0.055555555555556
56634, 0.08695652173913, 1.4125, 0.055555555555556
56635, 0.08695652173913, 1.425, 0.083333333333333
56636, 0.10869565217391, 1.425, 0.11111111111111
56637, 0.08695652173913, 1.4125, 0.11111111111111
56638, 0.08695652173913, 1.425, 0.13888888888889
56639, 0.10869565217391, 1.425, 0.16666666666667
56640, 0.08695652173913, 1.4125, 0.16666666666667
56641, 0.08695652173913, 1.425, 0.19444444444444
56642, 0.10869565217391, 1.425, 0.22222222222222
56643, 0.08695652173913, 1.4125, 0.22222222222222
56644, 0.08695652173913, 1.425, 0.25
56645, 0.10869565217391, 1.425, 0.27777777777778
56646, 0.08695652173913, 1.4125, 0.27777777777778
56647, 0.08695652173913, 1.425, 0.30555555555556
56648, 0.10869565217391, 1.425, 0.33333333333333
56649, 0.08695652173913, 1.4125, 0.33333333333333
56650, 0.08695652173913, 1.425, 0.36111111111111
56651, 0.10869565217391, 1.425, 0.38888888888889
56652, 0.08695652173913, 1.4125, 0.38888888888889
56653, 0.08695652173913, 1.425, 0.41666666666667
56654, 0.10869565217391, 1.425, 0.44444444444444
56655, 0.08695652173913, 1.4125, 0.44444444444444
56656, 0.08695652173913, 1.425, 0.47222222222222
56657, 0.043478260869565, 1.425, 0.027777777777778
56658, 0.065217391304348, 1.425, 0.055555555555556
56659, 0.043478260869565, 1.4125, 0.055555555555556
56660, 0.043478260869565, 1.425, 0.083333333333333
56661, 0.065217391304348, 1.425, 0.11111111111111
56662, 0.043478260869565, 1.4125, 0.11111111111111
56663, 0.043478260869565, 1.425, 0.13888888888889
56664, 0.065217391304348, 1.425, 0.16666666666667
56665, 0.043478260869565, 1.4125, 0.16666666666667
56666, 0.043478260869565, 1.425, 0.19444444444444
56667, 0.065217391304348, 1.425, 0.22222222222222
56668, 0.043478260869565, 1.4125, 0.22222222222222
56669, 0.043478260869565, 1.425, 0.25
56670, 0.065217391304348, 1.425, 0.27777777777778
56671, 0.043478260869565, 1.4125, 0.27777777777778
56672, 0.043478260869565, 1.425, 0.30555555555556
56673, 0.065217391304348, 1.425, 0.33333333333333
56674, 0.043478260869565, 1.4125, 0.33333333333333
56675, 0.043478260869565, 1.425, 0.36111111111111
56676, 0.065217391304348, 1.425, 0.38888888888889
56677, 0.043478260869565, 1.4125, 0.38888888888889
56678, 0.043478260869565, 1.425, 0.41666666666667
56679, 0.065217391304348, 1.425, 0.44444444444444
56680, 0.043478260869565, 1.4125, 0.44444444444444
56681, 0.043478260869565, 1.425, 0.47222222222222
56682, 0.021739130434783, 1.425, 0.055555555555556
56683, 0.021739130434783, 1.425, 0.11111111111111
56684, 0.021739130434783, 1.425, 0.16666666666667
56685, 0.021739130434783, 1.425, 0.22222222222222
56686, 0.021739130434783, 1.425, 0.27777777777778
56687, 0.021739130434783, 1.425, 0.33333333333333
56688, 0.021739130434783, 1.425, 0.38888888888889
56689, 0.021739130434783, 1.425, 0.44444444444444
56690, 0.95652173913043, 1.4375, 0.055555555555556
56691, 0.95652173913044, 1.4375, 0.11111111111111
56692, 0.95652173913044, 1.4375, 0.16666666666667
56693, 0.95652173913043, 1.4375, 0.22222222222222
56694, 0.95652173913043, 1.4375, 0.27777777777778
56695, 0.95652173913043, 1.4375, 0.33333333333333
56696, 0.95652173913043, 1.4375, 0.38888888888889
56697, 0.95652173913043, 1.4375, 0.44444444444444
56698, 0.91304347826087, 1.4375, 0.055555555555556
56699, 0.91304347826087, 1.4375, 0.11111111111111
56700, 0.91304347826087, 1.4375, 0.16666666666667
56701, 0.91304347826087, 1.4375, 0.22222222222222
56702, 0.91304347826087, 1.4375, 0.27777777777778
56703, 0.91304347826087, 1.4375, 0.33333333333333
56704, 0.91304347826087, 1.4375, 0.38888888888889
56705, 0.91304347826087, 1.4375, 0.44444444444444
56706, 0.8695652173913, 1.4375, 0.055555555555556
56707, 0.8695652173913, 1.4375, 0.11111111111111
56708, 0.8695652173913, 1.4375, 0.16666666666667
56709, 0.8695652173913, 1.4375, 0.22222222222222
56710, 0.8695652173913, 1.4375, 0.27777777777778
56711, 0.8695652173913, 1.4375, 0.33333333333333
56712, 0.8695652173913, 1.4375, 0.38888888888889
56713, 0.8695652173913, 1.4375, 0.44444444444444
56714, 0.82608695652174, 1.4375, 0.055555555555556
56715, 0.82608695652174, 1.4375, 0.11111111111111
56716, 0.82608695652174, 1.4375, 0.16666666666667
56717, 0.82608695652174, 1.4375, 0.22222222222222
56718, 0.82608695652174, 1.4375, 0.27777777777778
56719, 0.82608695652174, 1.4375, 0.33333333333333
56720, 0.82608695652174, 1.4375, 0.38888888888889
56721, 0.82608695652174, 1.4375, 0.44444444444444
56722, 0.78260869565217, 1.4375, 0.055555555555556
56723, 0.78260869565217, 1.4375, 0.11111111111111
56724, 0.78260869565217, 1.4375, 0.16666666666667
56725, 0.78260869565217, 1.4375, 0.22222222222222
56726, 0.78260869565217, 1.4375, 0.27777777777778
56727, 0.78260869565217, 1.4375, 0.33333333333333
56728, 0.78260869565217, 1.4375, 0.38888888888889
56729, 0.78260869565217, 1.4375, 0.44444444444444
56730, 0.73913043478261, 1.4375, 0.055555555555556
56731, 0.73913043478261, 1.4375, 0.11111111111111
56732, 0.73913043478261, 1.4375, 0.16666666666667
56733, 0.73913043478261, 1.4375, 0.22222222222222
56734, 0.73913043478261, 1.4375, 0.27777777777778
56735, 0.73913043478261, 1.4375, 0.33333333333333
56736, 0.73913043478261, 1.4375, 0.38888888888889
56737, 0.73913043478261, 1.4375, 0.44444444444444
56738, 0.69565217391304, 1.4375, 0.055555555555556
56739, 0.69565217391304, 1.4375, 0.11111111111111
56740, 0.69565217391304, 1.4375, 0.16666666666667
56741, 0.69565217391304, 1.4375, 0.22222222222222
56742, 0.69565217391304, 1.4375, 0.27777777777778
56743, 0.69565217391304, 1.4375, 0.33333333333333
56744, 0.69565217391304, 1.4375, 0.38888888888889
56745, 0.69565217391304, 1.4375, 0.44444444444444
56746, 0.65217391304348, 1.4375, 0.055555555555556
56747, 0.65217391304348, 1.4375, 0.11111111111111
56748, 0.65217391304348, 1.4375, 0.16666666666667
56749, 0.65217391304348, 1.4375, 0.22222222222222
56750, 0.65217391304348, 1.4375, 0.27777777777778
56751, 0.65217391304348, 1.4375, 0.33333333333333
56752, 0.65217391304348, 1.4375, 0.38888888888889
56753, 0.65217391304348, 1.4375, 0.44444444444444
56754, 0.60869565217391, 1.4375, 0.055555555555556
56755, 0.60869565217391, 1.4375, 0.11111111111111
56756, 0.60869565217391, 1.4375, 0.16666666666667
56757, 0.60869565217391, 1.4375, 0.22222222222222
56758, 0.60869565217391, 1.4375, 0.27777777777778
56759, 0.60869565217391, 1.4375, 0.33333333333333
56760, 0.60869565217391, 1.4375, 0.38888888888889
56761, 0.60869565217391, 1.4375, 0.44444444444444
56762, 0.56521739130435, 1.4375, 0.055555555555556
56763, 0.56521739130435, 1.4375, 0.11111111111111
56764, 0.56521739130435, 1.4375, 0.16666666666667
56765, 0.56521739130435, 1.4375, 0.22222222222222
56766, 0.56521739130435, 1.4375, 0.27777777777778
56767, 0.56521739130435, 1.4375, 0.33333333333333
56768, 0.56521739130435, 1.4375, 0.38888888888889
56769, 0.56521739130435, 1.4375, 0.44444444444444
56770, 0.52173913043478, 1.4375, 0.055555555555556
56771, 0.52173913043478, 1.4375, 0.11111111111111
56772, 0.52173913043478, 1.4375, 0.16666666666667
56773, 0.52173913043478, 1.4375, 0.22222222222222
56774, 0.52173913043478, 1.4375, 0.27777777777778
56775, 0.52173913043478, 1.4375, 0.33333333333333
56776, 0.52173913043478, 1.4375, 0.38888888888889
56777, 0.52173913043478, 1.4375, 0.44444444444444
56778, 0.47826086956522, 1.4375, 0.055555555555556
56779, 0.47826086956522, 1.4375, 0.11111111111111
56780, 0.47826086956522, 1.4375, 0.16666666666667
56781, 0.47826086956522, 1.4375, 0.22222222222222
56782, 0.47826086956522, 1.4375, 0.27777777777778
56783, 0.47826086956522, 1.4375, 0.33333333333333
56784, 0.47826086956522, 1.4375, 0.38888888888889
56785, 0.47826086956522, 1.4375, 0.44444444444444
56786, 0.43478260869565, 1.4375, 0.055555555555556
56787, 0.43478260869565, 1.4375, 0.11111111111111
56788, 0.43478260869565, 1.4375, 0.16666666666667
56789, 0.43478260869565, 1.4375, 0.22222222222222
56790, 0.43478260869565, 1.4375, 0.27777777777778
56791, 0.43478260869565, 1.4375, 0.33333333333333
56792, 0.43478260869565, 1.4375, 0.38888888888889
56793, 0.43478260869565, 1.4375, 0.44444444444444
56794, 0.39130434782609, 1.4375, 0.055555555555556
56795, 0.39130434782609, 1.4375, 0.11111111111111
56796, 0.39130434782609, 1.4375, 0.16666666666667
56797, 0.39130434782609, 1.4375, 0.22222222222222
56798, 0.39130434782609, 1.4375, 0.27777777777778
56799, 0.39130434782609, 1.4375, 0.33333333333333
56800, 0.39130434782609, 1.4375, 0.38888888888889
56801, 0.39130434782609, 1.4375, 0.44444444444444
56802, 0.34782608695652, 1.4375, 0.055555555555556
56803, 0.34782608695652, 1.4375, 0.11111111111111
56804, 0.34782608695652, 1.4375, 0.16666666666667
56805, 0.34782608695652, 1.4375, 0.22222222222222
56806, 0.34782608695652, 1.4375, 0.27777777777778
56807, 0.34782608695652, 1.4375, 0.33333333333333
56808, 0.34782608695652, 1.4375, 0.38888888888889
56809, 0.34782608695652, 1.4375, 0.44444444444444
56810, 0.30434782608696, 1.4375, 0.055555555555556
56811, 0.30434782608696, 1.4375, 0.11111111111111
56812, 0.30434782608696, 1.4375, 0.16666666666667
56813, 0.30434782608696, 1.4375, 0.22222222222222
56814, 0.30434782608696, 1.4375, 0.27777777777778
56815, 0.30434782608696, 1.4375, 0.33333333333333
56816, 0.30434782608696, 1.4375, 0.38888888888889
56817, 0.30434782608696, 1.4375, 0.44444444444444
56818, 0.26086956521739, 1.4375, 0.055555555555556
56819, 0.26086956521739, 1.4375, 0.11111111111111
56820, 0.26086956521739, 1.4375, 0.16666666666667
56821, 0.26086956521739, 1.4375, 0.22222222222222
56822, 0.26086956521739, 1.4375, 0.27777777777778
56823, 0.26086956521739, 1.4375, 0.33333333333333
56824, 0.26086956521739, 1.4375, 0.38888888888889
56825, 0.26086956521739, 1.4375, 0.44444444444444
56826, 0.21739130434783, 1.4375, 0.055555555555556
56827, 0.21739130434783, 1.4375, 0.11111111111111
56828, 0.21739130434783, 1.4375, 0.16666666666667
56829, 0.21739130434783, 1.4375, 0.22222222222222
56830, 0.21739130434783, 1.4375, 0.27777777777778
56831, 0.21739130434783, 1.4375, 0.33333333333333
56832, 0.21739130434783, 1.4375, 0.38888888888889
56833, 0.21739130434783, 1.4375, 0.44444444444444
56834, 0.17391304347826, 1.4375, 0.055555555555556
56835, 0.17391304347826, 1.4375, 0.11111111111111
56836, 0.17391304347826, 1.4375, 0.16666666666667
56837, 0.17391304347826, 1.4375, 0.22222222222222
56838, 0.17391304347826, 1.4375, 0.27777777777778
56839, 0.17391304347826, 1.4375, 0.33333333333333
56840, 0.17391304347826, 1.4375, 0.38888888888889
56841, 0.17391304347826, 1.4375, 0.44444444444444
56842, 0.1304347826087, 1.4375, 0.055555555555556
56843, 0.1304347826087, 1.4375, 0.11111111111111
56844, 0.1304347826087, 1.4375, 0.16666666666667
56845, 0.1304347826087, 1.4375, 0.22222222222222
56846, 0.1304347826087, 1.4375, 0.27777777777778
56847, 0.1304347826087, 1.4375, 0.33333333333333
56848, 0.1304347826087, 1.4375, 0.38888888888889
56849, 0.1304347826087, 1.4375, 0.44444444444444
56850, 0.08695652173913, 1.4375, 0.055555555555556
56851, 0.08695652173913, 1.4375, 0.11111111111111
56852, 0.08695652173913, 1.4375, 0.16666666666667
56853, 0.08695652173913, 1.4375, 0.22222222222222
56854, 0.08695652173913, 1.4375, 0.27777777777778
56855, 0.08695652173913, 1.4375, 0.33333333333333
56856, 0.08695652173913, 1.4375, 0.38888888888889
56857, 0.08695652173913, 1.4375, 0.44444444444444
56858, 0.043478260869565, 1.4375, 0.055555555555556
56859, 0.043478260869565, 1.4375, 0.11111111111111
56860, 0.043478260869565, 1.4375, 0.16666666666667
56861, 0.043478260869565, 1.4375, 0.22222222222222
56862, 0.043478260869565, 1.4375, 0.27777777777778
56863, 0.043478260869565, 1.4375, 0.33333333333333
56864, 0.043478260869565, 1.4375, 0.38888888888889
56865, 0.043478260869565, 1.4375, 0.44444444444444
56866, 0.95652173913043, 1.4833333333333, 0.055555555555556
56867, 0.95652173913044, 1.4833333333333, 0.11111111111111
56868, 0.95652173913044, 1.4833333333333, 0.16666666666667
56869, 0.95652173913044, 1.4833333333333, 0.22222222222222
56870, 0.95652173913044, 1.4833333333333, 0.27777777777778
56871, 0.95652173913044, 1.4833333333333, 0.33333333333333
56872, 0.95652173913044, 1.4833333333333, 0.38888888888889
56873, 0.95652173913044, 1.4833333333333, 0.44444444444444
56874, 0.91304347826087, 1.4833333333333, 0.055555555555556
56875, 0.91304347826087, 1.4833333333333, 0.11111111111111
56876, 0.91304347826087, 1.4833333333333, 0.16666666666667
56877, 0.91304347826087, 1.4833333333333, 0.22222222222222
56878, 0.91304347826087, 1.4833333333333, 0.27777777777778
56879, 0.91304347826087, 1.4833333333333, 0.33333333333333
56880, 0.91304347826087, 1.4833333333333, 0.38888888888889
56881, 0.91304347826087, 1.4833333333333, 0.44444444444444
56882, 0.8695652173913, 1.4833333333333, 0.055555555555556
56883, 0.8695652173913, 1.4833333333333, 0.11111111111111
56884, 0.8695652173913, 1.4833333333333, 0.16666666666667
56885, 0.8695652173913, 1.4833333333333, 0.22222222222222
56886, 0.8695652173913, 1.4833333333333, 0.27777777777778
56887, 0.8695652173913, 1.4833333333333, 0.33333333333333
56888, 0.8695652173913, 1.4833333333333, 0.38888888888889
56889, 0.8695652173913, 1.4833333333333, 0.44444444444444
56890, 0.82608695652174, 1.4833333333333, 0.055555555555556
56891, 0.82608695652174, 1.4833333333333, 0.11111111111111
56892, 0.82608695652174, 1.4833333333333, 0.16666666666667
56893, 0.82608695652174, 1.4833333333333, 0.22222222222222
56894, 0.82608695652174, 1.4833333333333, 0.27777777777778
56895, 0.82608695652174, 1.4833333333333, 0.33333333333333
56896, 0.82608695652174, 1.4833333333333, 0.38888888888889
56897, 0.82608695652174, 1.4833333333333, 0.44444444444444
56898, 0.78260869565217, 1.4833333333333, 0.055555555555556
56899, 0.78260869565217, 1.4833333333333, 0.11111111111111
56900, 0.78260869565217, 1.4833333333333, 0.16666666666667
56901, 0.78260869565217, 1.4833333333333, 0.22222222222222
56902, 0.78260869565217, 1.4833333333333, 0.27777777777778
56903, 0.78260869565217, 1.4833333333333, 0.33333333333333
56904, 0.78260869565217, 1.4833333333333, 0.38888888888889
56905, 0.78260869565217, 1.4833333333333, 0.44444444444444
56906, 0.73913043478261, 1.4833333333333, 0.055555555555556
56907, 0.73913043478261, 1.4833333333333, 0.11111111111111
56908, 0.73913043478261, 1.4833333333333, 0.16666666666667
56909, 0.73913043478261, 1.4833333333333, 0.22222222222222
56910, 0.73913043478261, 1.4833333333333, 0.27777777777778
56911, 0.73913043478261, 1.4833333333333, 0.33333333333333
56912, 0.73913043478261, 1.4833333333333, 0.38888888888889
56913, 0.73913043478261, 1.4833333333333, 0.44444444444444
56914, 0.69565217391304, 1.4833333333333, 0.055555555555556
56915, 0.69565217391304, 1.4833333333333, 0.11111111111111
56916, 0.69565217391304, 1.4833333333333, 0.16666666666667
56917, 0.69565217391304, 1.4833333333333, 0.22222222222222
56918, 0.69565217391304, 1.4833333333333, 0.27777777777778
56919, 0.69565217391304, 1.4833333333333, 0.33333333333333
56920, 0.69565217391304, 1.4833333333333, 0.38888888888889
56921, 0.69565217391304, 1.4833333333333, 0.44444444444444
56922, 0.65217391304348, 1.4833333333333, 0.055555555555556
56923, 0.65217391304348, 1.4833333333333, 0.11111111111111
56924, 0.65217391304348, 1.4833333333333, 0.16666666666667
56925, 0.65217391304348, 1.4833333333333, 0.22222222222222
56926, 0.65217391304348, 1.4833333333333, 0.27777777777778
56927, 0.65217391304348, 1.4833333333333, 0.33333333333333
56928, 0.65217391304348, 1.4833333333333, 0.38888888888889
56929, 0.65217391304348, 1.4833333333333, 0.44444444444444
56930, 0.60869565217391, 1.4833333333333, 0.055555555555556
56931, 0.60869565217391, 1.4833333333333, 0.11111111111111
56932, 0.60869565217391, 1.4833333333333, 0.16666666666667
56933, 0.60869565217391, 1.4833333333333, 0.22222222222222
56934, 0.60869565217391, 1.4833333333333, 0.27777777777778
56935, 0.60869565217391, 1.4833333333333, 0.33333333333333
56936, 0.60869565217391, 1.4833333333333, 0.38888888888889
56937, 0.60869565217391, 1.4833333333333, 0.44444444444444
56938, 0.56521739130435, 1.4833333333333, 0.055555555555556
56939, 0.56521739130435, 1.4833333333333, 0.11111111111111
56940, 0.56521739130435, 1.4833333333333, 0.16666666666667
56941, 0.56521739130435, 1.4833333333333, 0.22222222222222
56942, 0.56521739130435, 1.4833333333333, 0.27777777777778
56943, 0.56521739130435, 1.4833333333333, 0.33333333333333
56944, 0.56521739130435, 1.4833333333333, 0.38888888888889
56945, 0.56521739130435, 1.4833333333333, 0.44444444444444
56946, 0.52173913043478, 1.4833333333333, 0.055555555555556
56947, 0.52173913043478, 1.4833333333333, 0.11111111111111
56948, 0.52173913043478, 1.4833333333333, 0.16666666666667
56949, 0.52173913043478, 1.4833333333333, 0.22222222222222
56950, 0.52173913043478, 1.4833333333333, 0.27777777777778
56951, 0.52173913043478, 1.4833333333333, 0.33333333333333
56952, 0.52173913043478, 1.4833333333333, 0.38888888888889
56953, 0.52173913043478, 1.4833333333333, 0.44444444444444
56954, 0.47826086956522, 1.4833333333333, 0.055555555555556
56955, 0.47826086956522, 1.4833333333333, 0.11111111111111
56956, 0.47826086956522, 1.4833333333333, 0.16666666666667
56957, 0.47826086956522, 1.4833333333333, 0.22222222222222
56958, 0.47826086956522, 1.4833333333333, 0.27777777777778
56959, 0.47826086956522, 1.4833333333333, 0.33333333333333
56960, 0.47826086956522, 1.4833333333333, 0.38888888888889
56961, 0.47826086956522, 1.4833333333333, 0.44444444444444
56962, 0.43478260869565, 1.4833333333333, 0.055555555555556
56963, 0.43478260869565, 1.4833333333333, 0.11111111111111
56964, 0.43478260869565, 1.4833333333333, 0.16666666666667
56965, 0.43478260869565, 1.4833333333333, 0.22222222222222
56966, 0.43478260869565, 1.4833333333333, 0.27777777777778
56967, 0.43478260869565, 1.4833333333333, 0.33333333333333
56968, 0.43478260869565, 1.4833333333333, 0.38888888888889
56969, 0.43478260869565, 1.4833333333333, 0.44444444444444
56970, 0.39130434782609, 1.4833333333333, 0.055555555555556
56971, 0.39130434782609, 1.4833333333333, 0.11111111111111
56972, 0.39130434782609, 1.4833333333333, 0.16666666666667
56973, 0.39130434782609, 1.4833333333333, 0.22222222222222
56974, 0.39130434782609, 1.4833333333333, 0.27777777777778
56975, 0.39130434782609, 1.4833333333333, 0.33333333333333
56976, 0.39130434782609, 1.4833333333333, 0.38888888888889
56977, 0.39130434782609, 1.4833333333333, 0.44444444444444
56978, 0.34782608695652, 1.4833333333333, 0.055555555555556
56979, 0.34782608695652, 1.4833333333333, 0.11111111111111
56980, 0.34782608695652, 1.4833333333333, 0.16666666666667
56981, 0.34782608695652, 1.4833333333333, 0.22222222222222
56982, 0.34782608695652, 1.4833333333333, 0.27777777777778
56983, 0.34782608695652, 1.4833333333333, 0.33333333333333
56984, 0.34782608695652, 1.4833333333333, 0.38888888888889
56985, 0.34782608695652, 1.4833333333333, 0.44444444444444
56986, 0.30434782608696, 1.4833333333333, 0.055555555555556
56987, 0.30434782608696, 1.4833333333333, 0.11111111111111
56988, 0.30434782608696, 1.4833333333333, 0.16666666666667
56989, 0.30434782608696, 1.4833333333333, 0.22222222222222
56990, 0.30434782608696, 1.4833333333333, 0.27777777777778
56991, 0.30434782608696, 1.4833333333333, 0.33333333333333
56992, 0.30434782608696, 1.4833333333333, 0.38888888888889
56993, 0.30434782608696, 1.4833333333333, 0.44444444444444
56994, 0.26086956521739, 1.4833333333333, 0.055555555555556
56995, 0.26086956521739, 1.4833333333333, 0.11111111111111
56996, 0.26086956521739, 1.4833333333333, 0.16666666666667
56997, 0.26086956521739, 1.4833333333333, 0.22222222222222
56998, 0.26086956521739, 1.4833333333333, 0.27777777777778
56999, 0.26086956521739, 1.4833333333333, 0.33333333333333
57000, 0.26086956521739, 1.4833333333333, 0.38888888888889
57001, 0.26086956521739, 1.4833333333333, 0.44444444444444
57002, 0.21739130434783, 1.4833333333333, 0.055555555555556
57003, 0.21739130434783, 1.4833333333333, 0.11111111111111
57004, 0.21739130434783, 1.4833333333333, 0.16666666666667
57005, 0.21739130434783, 1.4833333333333, 0.22222222222222
57006, 0.21739130434783, 1.4833333333333, 0.27777777777778
57007, 0.21739130434783, 1.4833333333333, 0.33333333333333
57008, 0.21739130434783, 1.4833333333333, 0.38888888888889
57009, 0.21739130434783, 1.4833333333333, 0.44444444444444
57010, 0.17391304347826, 1.4833333333333, 0.055555555555556
57011, 0.17391304347826, 1.4833333333333, 0.11111111111111
57012, 0.17391304347826, 1.4833333333333, 0.16666666666667
57013, 0.17391304347826, 1.4833333333333, 0.22222222222222
57014, 0.17391304347826, 1.4833333333333, 0.27777777777778
57015, 0.17391304347826, 1.4833333333333, 0.33333333333333
57016, 0.17391304347826, 1.4833333333333, 0.38888888888889
57017, 0.17391304347826, 1.4833333333333, 0.44444444444444
57018, 0.1304347826087, 1.4833333333333, 0.055555555555556
57019, 0.1304347826087, 1.4833333333333, 0.11111111111111
57020, 0.1304347826087, 1.4833333333333, 0.16666666666667
57021, 0.1304347826087, 1.4833333333333, 0.22222222222222
57022, 0.1304347826087, 1.4833333333333, 0.27777777777778
57023, 0.1304347826087, 1.4833333333333, 0.33333333333333
57024, 0.1304347826087, 1.4833333333333, 0.38888888888889
57025, 0.1304347826087, 1.4833333333333, 0.44444444444444
57026, 0.08695652173913, 1.4833333333333, 0.055555555555556
57027, 0.08695652173913, 1.4833333333333, 0.11111111111111
57028, 0.08695652173913, 1.4833333333333, 0.16666666666667
57029, 0.08695652173913, 1.4833333333333, 0.22222222222222
57030, 0.08695652173913, 1.4833333333333, 0.27777777777778
57031, 0.08695652173913, 1.4833333333333, 0.33333333333333
57032, 0.08695652173913, 1.4833333333333, 0.38888888888889
57033, 0.08695652173913, 1.4833333333333, 0.44444444444444
57034, 0.043478260869565, 1.4833333333333, 0.055555555555556
57035, 0.043478260869565, 1.4833333333333, 0.11111111111111
57036, 0.043478260869565, 1.4833333333333, 0.16666666666667
57037, 0.043478260869565, 1.4833333333333, 0.22222222222222
57038, 0.043478260869565, 1.4833333333333, 0.27777777777778
57039, 0.043478260869565, 1.4833333333333, 0.33333333333333
57040, 0.043478260869565, 1.4833333333333, 0.38888888888889
57041, 0.043478260869565, 1.4833333333333, 0.44444444444444
57042, 0.95652173913043, 1.5166666666667, 0.055555555555556
57043, 0.95652173913044, 1.5166666666667, 0.11111111111111
57044, 0.95652173913044, 1.5166666666667, 0.16666666666667
57045, 0.95652173913044, 1.5166666666667, 0.22222222222222
57046, 0.95652173913044, 1.5166666666667, 0.27777777777778
57047, 0.95652173913044, 1.5166666666667, 0.33333333333333
57048, 0.95652173913044, 1.5166666666667, 0.38888888888889
57049, 0.95652173913044, 1.5166666666667, 0.44444444444444
57050, 0.91304347826087, 1.5166666666667, 0.055555555555556
57051, 0.91304347826087, 1.5166666666667, 0.11111111111111
57052, 0.91304347826087, 1.5166666666667, 0.16666666666667
57053, 0.91304347826087, 1.5166666666667, 0.22222222222222
57054, 0.91304347826087, 1.5166666666667, 0.27777777777778
57055, 0.91304347826087, 1.5166666666667, 0.33333333333333
57056, 0.91304347826087, 1.5166666666667, 0.38888888888889
57057, 0.91304347826087, 1.5166666666667, 0.44444444444444
57058, 0.8695652173913, 1.5166666666667, 0.055555555555556
57059, 0.8695652173913, 1.5166666666667, 0.11111111111111
57060, 0.8695652173913, 1.5166666666667, 0.16666666666667
57061, 0.8695652173913, 1.5166666666667, 0.22222222222222
57062, 0.8695652173913, 1.5166666666667, 0.27777777777778
57063, 0.8695652173913, 1.5166666666667, 0.33333333333333
57064, 0.8695652173913, 1.5166666666667, 0.38888888888889
57065, 0.8695652173913, 1.5166666666667, 0.44444444444444
57066, 0.82608695652174, 1.5166666666667, 0.055555555555556
57067, 0.82608695652174, 1.5166666666667, 0.11111111111111
57068, 0.82608695652174, 1.5166666666667, 0.16666666666667
57069, 0.82608695652174, 1.5166666666667, 0.22222222222222
57070, 0.82608695652174, 1.5166666666667, 0.27777777777778
57071, 0.82608695652174, 1.5166666666667, 0.33333333333333
57072, 0.82608695652174, 1.5166666666667, 0.38888888888889
57073, 0.82608695652174, 1.5166666666667, 0.44444444444444
57074, 0.78260869565217, 1.5166666666667, 0.055555555555556
57075, 0.78260869565217, 1.5166666666667, 0.11111111111111
57076, 0.78260869565217, 1.5166666666667, 0.16666666666667
57077, 0.78260869565217, 1.5166666666667, 0.22222222222222
57078, 0.78260869565217, 1.5166666666667, 0.27777777777778
57079, 0.78260869565217, 1.5166666666667, 0.33333333333333
57080, 0.78260869565217, 1.5166666666667, 0.38888888888889
57081, 0.78260869565217, 1.5166666666667, 0.44444444444444
57082, 0.73913043478261, 1.5166666666667, 0.055555555555556
57083, 0.73913043478261, 1.5166666666667, 0.11111111111111
57084, 0.73913043478261, 1.5166666666667, 0.16666666666667
57085, 0.73913043478261, 1.5166666666667, 0.22222222222222
57086, 0.73913043478261, 1.5166666666667, 0.27777777777778
57087, 0.73913043478261, 1.5166666666667, 0.33333333333333
57088, 0.73913043478261, 1.5166666666667, 0.38888888888889
57089, 0.73913043478261, 1.5166666666667, 0.44444444444444
57090, 0.69565217391304, 1.5166666666667, 0.055555555555556
57091, 0.69565217391304, 1.5166666666667, 0.11111111111111
57092, 0.69565217391304, 1.5166666666667, 0.16666666666667
57093, 0.69565217391304, 1.5166666666667, 0.22222222222222
57094, 0.69565217391304, 1.5166666666667, 0.27777777777778
57095, 0.69565217391304, 1.5166666666667, 0.33333333333333
57096, 0.69565217391304, 1.5166666666667, 0.38888888888889
57097, 0.69565217391304, 1.5166666666667, 0.44444444444444
57098, 0.65217391304348, 1.5166666666667, 0.055555555555556
57099, 0.65217391304348, 1.5166666666667, 0.11111111111111
57100, 0.65217391304348, 1.5166666666667, 0.16666666666667
57101, 0.65217391304348, 1.5166666666667, 0.22222222222222
57102, 0.65217391304348, 1.5166666666667, 0.27777777777778
57103, 0.65217391304348, 1.5166666666667, 0.33333333333333
57104, 0.65217391304348, 1.5166666666667, 0.38888888888889
57105, 0.65217391304348, 1.5166666666667, 0.44444444444444
57106, 0.60869565217391, 1.5166666666667, 0.055555555555556
57107, 0.60869565217391, 1.5166666666667, 0.11111111111111
57108, 0.60869565217391, 1.5166666666667, 0.16666666666667
57109, 0.60869565217391, 1.5166666666667, 0.22222222222222
57110, 0.60869565217391, 1.5166666666667, 0.27777777777778
57111, 0.60869565217391, 1.5166666666667, 0.33333333333333
57112, 0.60869565217391, 1.5166666666667, 0.38888888888889
57113, 0.60869565217391, 1.5166666666667, 0.44444444444444
57114, 0.56521739130435, 1.5166666666667, 0.055555555555556
57115, 0.56521739130435, 1.5166666666667, 0.11111111111111
57116, 0.56521739130435, 1.5166666666667, 0.16666666666667
57117, 0.56521739130435, 1.5166666666667, 0.22222222222222
57118, 0.56521739130435, 1.5166666666667, 0.27777777777778
57119, 0.56521739130435, 1.5166666666667, 0.33333333333333
57120, 0.56521739130435, 1.5166666666667, 0.38888888888889
57121, 0.56521739130435, 1.5166666666667, 0.44444444444444
57122, 0.52173913043478, 1.5166666666667, 0.055555555555556
57123, 0.52173913043478, 1.5166666666667, 0.11111111111111
57124, 0.52173913043478, 1.5166666666667, 0.16666666666667
57125, 0.52173913043478, 1.5166666666667, 0.22222222222222
57126, 0.52173913043478, 1.5166666666667, 0.27777777777778
57127, 0.52173913043478, 1.5166666666667, 0.33333333333333
57128, 0.52173913043478, 1.5166666666667, 0.38888888888889
57129, 0.52173913043478, 1.5166666666667, 0.44444444444444
57130, 0.47826086956522, 1.5166666666667, 0.055555555555556
57131, 0.47826086956522, 1.5166666666667, 0.11111111111111
57132, 0.47826086956522, 1.5166666666667, 0.16666666666667
57133, 0.47826086956522, 1.5166666666667, 0.22222222222222
57134, 0.47826086956522, 1.5166666666667, 0.27777777777778
57135, 0.47826086956522, 1.5166666666667, 0.33333333333333
57136, 0.47826086956522, 1.5166666666667, 0.38888888888889
57137, 0.47826086956522, 1.5166666666667, 0.44444444444444
57138, 0.43478260869565, 1.5166666666667, 0.055555555555556
57139, 0.43478260869565, 1.5166666666667, 0.11111111111111
57140, 0.43478260869565, 1.5166666666667, 0.16666666666667
57141, 0.43478260869565, 1.5166666666667, 0.22222222222222
57142, 0.43478260869565, 1.5166666666667, 0.27777777777778
57143, 0.43478260869565, 1.5166666666667, 0.33333333333333
57144, 0.43478260869565, 1.5166666666667, 0.38888888888889
57145, 0.43478260869565, 1.5166666666667, 0.44444444444444
57146, 0.39130434782609, 1.5166666666667, 0.055555555555556
57147, 0.39130434782609, 1.5166666666667, 0.11111111111111
57148, 0.39130434782609, 1.5166666666667, 0.16666666666667
57149, 0.39130434782609, 1.5166666666667, 0.22222222222222
57150, 0.39130434782609, 1.5166666666667, 0.27777777777778
57151, 0.39130434782609, 1.5166666666667, 0.33333333333333
57152, 0.39130434782609, 1.5166666666667, 0.38888888888889
57153, 0.39130434782609, 1.5166666666667, 0.44444444444444
57154, 0.34782608695652, 1.5166666666667, 0.055555555555556
57155, 0.34782608695652, 1.5166666666667, 0.11111111111111
57156, 0.34782608695652, 1.5166666666667, 0.16666666666667
57157, 0.34782608695652, 1.5166666666667, 0.22222222222222
57158, 0.34782608695652, 1.5166666666667, 0.27777777777778
57159, 0.34782608695652, 1.5166666666667, 0.33333333333333
57160, 0.34782608695652, 1.5166666666667, 0.38888888888889
57161, 0.34782608695652, 1.5166666666667, 0.44444444444444
57162, 0.30434782608696, 1.5166666666667, 0.055555555555556
57163, 0.30434782608696, 1.5166666666667, 0.11111111111111
57164, 0.30434782608696, 1.5166666666667, 0.16666666666667
57165, 0.30434782608696, 1.5166666666667, 0.22222222222222
57166, 0.30434782608696, 1.5166666666667, 0.27777777777778
57167, 0.30434782608696, 1.5166666666667, 0.33333333333333
57168, 0.30434782608696, 1.5166666666667, 0.38888888888889
57169, 0.30434782608696, 1.5166666666667, 0.44444444444444
57170, 0.26086956521739, 1.5166666666667, 0.055555555555556
57171, 0.26086956521739, 1.5166666666667, 0.11111111111111
57172, 0.26086956521739, 1.5166666666667, 0.16666666666667
57173, 0.26086956521739, 1.5166666666667, 0.22222222222222
57174, 0.26086956521739, 1.5166666666667, 0.27777777777778
57175, 0.26086956521739, 1.5166666666667, 0.33333333333333
57176, 0.26086956521739, 1.5166666666667, 0.38888888888889
57177, 0.26086956521739, 1.5166666666667, 0.44444444444444
57178, 0.21739130434783, 1.5166666666667, 0.055555555555556
57179, 0.21739130434783, 1.5166666666667, 0.11111111111111
57180, 0.21739130434783, 1.5166666666667, 0.16666666666667
57181, 0.21739130434783, 1.5166666666667, 0.22222222222222
57182, 0.21739130434783, 1.5166666666667, 0.27777777777778
57183, 0.21739130434783, 1.5166666666667, 0.33333333333333
57184, 0.21739130434783, 1.5166666666667, 0.38888888888889
57185, 0.21739130434783, 1.5166666666667, 0.44444444444444
57186, 0.17391304347826, 1.5166666666667, 0.055555555555556
57187, 0.17391304347826, 1.5166666666667, 0.11111111111111
57188, 0.17391304347826, 1.5166666666667, 0.16666666666667
57189, 0.17391304347826, 1.5166666666667, 0.22222222222222
57190, 0.17391304347826, 1.5166666666667, 0.27777777777778
57191, 0.17391304347826, 1.5166666666667, 0.33333333333333
57192, 0.17391304347826, 1.5166666666667, 0.38888888888889
57193, 0.17391304347826, 1.5166666666667, 0.44444444444444
57194, 0.1304347826087, 1.5166666666667, 0.055555555555556
57195, 0.1304347826087, 1.5166666666667, 0.11111111111111
57196, 0.1304347826087, 1.5166666666667, 0.16666666666667
57197, 0.1304347826087, 1.5166666666667, 0.22222222222222
57198, 0.1304347826087, 1.5166666666667, 0.27777777777778
57199, 0.1304347826087, 1.5166666666667, 0.33333333333333
57200, 0.1304347826087, 1.5166666666667, 0.38888888888889
57201, 0.1304347826087, 1.5166666666667, 0.44444444444444
57202, 0.08695652173913, 1.5166666666667, 0.055555555555556
57203, 0.08695652173913, 1.5166666666667, 0.11111111111111
57204, 0.08695652173913, 1.5166666666667, 0.16666666666667
57205, 0.08695652173913, 1.5166666666667, 0.22222222222222
57206, 0.08695652173913, 1.5166666666667, 0.27777777777778
57207, 0.08695652173913, 1.5166666666667, 0.33333333333333
57208, 0.08695652173913, 1.5166666666667, 0.38888888888889
57209, 0.08695652173913, 1.5166666666667, 0.44444444444444
57210, 0.043478260869565, 1.5166666666667, 0.055555555555556
57211, 0.043478260869565, 1.5166666666667, 0.11111111111111
57212, 0.043478260869565, 1.5166666666667, 0.16666666666667
57213, 0.043478260869565, 1.5166666666667, 0.22222222222222
57214, 0.043478260869565, 1.5166666666667, 0.27777777777778
57215, 0.043478260869565, 1.5166666666667, 0.33333333333333
57216, 0.043478260869565, 1.5166666666667, 0.38888888888889
57217, 0.043478260869565, 1.5166666666667, 0.44444444444444
57218, 0.95652173913043, 1.4833333333333, 0.027777777777778
57219, 0.97826086956522, 1.4833333333333, 0.055555555555556
57220, 0.95652173913043, 1.4666666666667, 0.055555555555556
57221, 0.95652173913043, 1.4833333333333, 0.083333333333333
57222, 0.97826086956522, 1.4833333333333, 0.11111111111111
57223, 0.95652173913043, 1.4666666666667, 0.11111111111111
57224, 0.95652173913044, 1.4833333333333, 0.13888888888889
57225, 0.97826086956522, 1.4833333333333, 0.16666666666667
57226, 0.95652173913043, 1.4666666666667, 0.16666666666667
57227, 0.95652173913044, 1.4833333333333, 0.19444444444444
57228, 0.97826086956522, 1.4833333333333, 0.22222222222222
57229, 0.95652173913043, 1.4666666666667, 0.22222222222222
57230, 0.95652173913044, 1.4833333333333, 0.25
57231, 0.97826086956522, 1.4833333333333, 0.27777777777778
57232, 0.95652173913043, 1.4666666666667, 0.27777777777778
57233, 0.95652173913044, 1.4833333333333, 0.30555555555556
57234, 0.97826086956522, 1.4833333333333, 0.33333333333333
57235, 0.95652173913043, 1.4666666666667, 0.33333333333333
57236, 0.95652173913044, 1.4833333333333, 0.36111111111111
57237, 0.97826086956522, 1.4833333333333, 0.38888888888889
57238, 0.95652173913043, 1.4666666666667, 0.38888888888889
57239, 0.95652173913044, 1.4833333333333, 0.41666666666667
57240, 0.97826086956522, 1.4833333333333, 0.44444444444444
57241, 0.95652173913043, 1.4666666666667, 0.44444444444444
57242, 0.95652173913043, 1.4833333333333, 0.47222222222222
57243, 0.91304347826087, 1.4833333333333, 0.027777777777778
57244, 0.93478260869565, 1.4833333333333, 0.055555555555556
57245, 0.91304347826087, 1.4666666666667, 0.055555555555556
57246, 0.91304347826087, 1.4833333333333, 0.083333333333333
57247, 0.93478260869565, 1.4833333333333, 0.11111111111111
57248, 0.91304347826087, 1.4666666666667, 0.11111111111111
57249, 0.91304347826087, 1.4833333333333, 0.13888888888889
57250, 0.93478260869565, 1.4833333333333, 0.16666666666667
57251, 0.91304347826087, 1.4666666666667, 0.16666666666667
57252, 0.91304347826087, 1.4833333333333, 0.19444444444444
57253, 0.93478260869565, 1.4833333333333, 0.22222222222222
57254, 0.91304347826087, 1.4666666666667, 0.22222222222222
57255, 0.91304347826087, 1.4833333333333, 0.25
57256, 0.93478260869565, 1.4833333333333, 0.27777777777778
57257, 0.91304347826087, 1.4666666666667, 0.27777777777778
57258, 0.91304347826087, 1.4833333333333, 0.30555555555556
57259, 0.93478260869565, 1.4833333333333, 0.33333333333333
57260, 0.91304347826087, 1.4666666666667, 0.33333333333333
57261, 0.91304347826087, 1.4833333333333, 0.36111111111111
57262, 0.93478260869565, 1.4833333333333, 0.38888888888889
57263, 0.91304347826087, 1.4666666666667, 0.38888888888889
57264, 0.91304347826087, 1.4833333333333, 0.41666666666667
57265, 0.93478260869565, 1.4833333333333, 0.44444444444444
57266, 0.91304347826087, 1.4666666666667, 0.44444444444444
57267, 0.91304347826087, 1.4833333333333, 0.47222222222222
57268, 0.8695652173913, 1.4833333333333, 0.027777777777778
57269, 0.89130434782609, 1.4833333333333, 0.055555555555556
57270, 0.8695652173913, 1.4666666666667, 0.055555555555556
57271, 0.8695652173913, 1.4833333333333, 0.083333333333333
57272, 0.89130434782609, 1.4833333333333, 0.11111111111111
57273, 0.8695652173913, 1.4666666666667, 0.11111111111111
57274, 0.8695652173913, 1.4833333333333, 0.13888888888889
57275, 0.89130434782609, 1.4833333333333, 0.16666666666667
57276, 0.8695652173913, 1.4666666666667, 0.16666666666667
57277, 0.8695652173913, 1.4833333333333, 0.19444444444444
57278, 0.89130434782609, 1.4833333333333, 0.22222222222222
57279, 0.8695652173913, 1.4666666666667, 0.22222222222222
57280, 0.8695652173913, 1.4833333333333, 0.25
57281, 0.89130434782609, 1.4833333333333, 0.27777777777778
57282, 0.8695652173913, 1.4666666666667, 0.27777777777778
57283, 0.8695652173913, 1.4833333333333, 0.30555555555556
57284, 0.89130434782609, 1.4833333333333, 0.33333333333333
57285, 0.8695652173913, 1.4666666666667, 0.33333333333333
57286, 0.8695652173913, 1.4833333333333, 0.36111111111111
57287, 0.89130434782609, 1.4833333333333, 0.38888888888889
57288, 0.8695652173913, 1.4666666666667, 0.38888888888889
57289, 0.8695652173913, 1.4833333333333, 0.41666666666667
57290, 0.89130434782609, 1.4833333333333, 0.44444444444444
57291, 0.8695652173913, 1.4666666666667, 0.44444444444444
57292, 0.8695652173913, 1.4833333333333, 0.47222222222222
57293, 0.82608695652174, 1.4833333333333, 0.027777777777778
57294, 0.84782608695652, 1.4833333333333, 0.055555555555556
57295, 0.82608695652174, 1.4666666666667, 0.055555555555556
57296, 0.82608695652174, 1.4833333333333, 0.083333333333333
57297, 0.84782608695652, 1.4833333333333, 0.11111111111111
57298, 0.82608695652174, 1.4666666666667, 0.11111111111111
57299, 0.82608695652174, 1.4833333333333, 0.13888888888889
57300, 0.84782608695652, 1.4833333333333, 0.16666666666667
57301, 0.82608695652174, 1.4666666666667, 0.16666666666667
57302, 0.82608695652174, 1.4833333333333, 0.19444444444444
57303, 0.84782608695652, 1.4833333333333, 0.22222222222222
57304, 0.82608695652174, 1.4666666666667, 0.22222222222222
57305, 0.82608695652174, 1.4833333333333, 0.25
57306, 0.84782608695652, 1.4833333333333, 0.27777777777778
57307, 0.82608695652174, 1.4666666666667, 0.27777777777778
57308, 0.82608695652174, 1.4833333333333, 0.30555555555556
57309, 0.84782608695652, 1.4833333333333, 0.33333333333333
57310, 0.82608695652174, 1.4666666666667, 0.33333333333333
57311, 0.82608695652174, 1.4833333333333, 0.36111111111111
57312, 0.84782608695652, 1.4833333333333, 0.38888888888889
57313, 0.82608695652174, 1.4666666666667, 0.38888888888889
57314, 0.82608695652174, 1.4833333333333, 0.41666666666667
57315, 0.84782608695652, 1.4833333333333, 0.44444444444444
57316, 0.82608695652174, 1.4666666666667, 0.44444444444444
57317, 0.82608695652174, 1.4833333333333, 0.47222222222222
57318, 0.78260869565217, 1.4833333333333, 0.027777777777778
57319, 0.80434782608696, 1.4833333333333, 0.055555555555556
57320, 0.78260869565217, 1.4666666666667, 0.055555555555556
57321, 0.78260869565217, 1.4833333333333, 0.083333333333333
57322, 0.80434782608696, 1.4833333333333, 0.11111111111111
57323, 0.78260869565217, 1.4666666666667, 0.11111111111111
57324, 0.78260869565217, 1.4833333333333, 0.13888888888889
57325, 0.80434782608696, 1.4833333333333, 0.16666666666667
57326, 0.78260869565217, 1.4666666666667, 0.16666666666667
57327, 0.78260869565217, 1.4833333333333, 0.19444444444444
57328, 0.80434782608696, 1.4833333333333, 0.22222222222222
57329, 0.78260869565217, 1.4666666666667, 0.22222222222222
57330, 0.78260869565217, 1.4833333333333, 0.25
57331, 0.80434782608696, 1.4833333333333, 0.27777777777778
57332, 0.78260869565217, 1.4666666666667, 0.27777777777778
57333, 0.78260869565217, 1.4833333333333, 0.30555555555556
57334, 0.80434782608696, 1.4833333333333, 0.33333333333333
57335, 0.78260869565217, 1.4666666666667, 0.33333333333333
57336, 0.78260869565217, 1.4833333333333, 0.36111111111111
57337, 0.80434782608696, 1.4833333333333, 0.38888888888889
57338, 0.78260869565217, 1.4666666666667, 0.38888888888889
57339, 0.78260869565217, 1.4833333333333, 0.41666666666667
57340, 0.80434782608696, 1.4833333333333, 0.44444444444444
57341, 0.78260869565217, 1.4666666666667, 0.44444444444444
57342, 0.78260869565217, 1.4833333333333, 0.47222222222222
57343, 0.73913043478261, 1.4833333333333, 0.027777777777778
57344, 0.76086956521739, 1.4833333333333, 0.055555555555556
57345, 0.73913043478261, 1.4666666666667, 0.055555555555556
57346, 0.73913043478261, 1.4833333333333, 0.083333333333333
57347, 0.76086956521739, 1.4833333333333, 0.11111111111111
57348, 0.73913043478261, 1.4666666666667, 0.11111111111111
57349, 0.73913043478261, 1.4833333333333, 0.13888888888889
57350, 0.76086956521739, 1.4833333333333, 0.16666666666667
57351, 0.73913043478261, 1.4666666666667, 0.16666666666667
57352, 0.73913043478261, 1.4833333333333, 0.19444444444444
57353, 0.76086956521739, 1.4833333333333, 0.22222222222222
57354, 0.73913043478261, 1.4666666666667, 0.22222222222222
57355, 0.73913043478261, 1.4833333333333, 0.25
57356, 0.76086956521739, 1.4833333333333, 0.27777777777778
57357, 0.73913043478261, 1.4666666666667, 0.27777777777778
57358, 0.73913043478261, 1.4833333333333, 0.30555555555556
57359, 0.76086956521739, 1.4833333333333, 0.33333333333333
57360, 0.73913043478261, 1.4666666666667, 0.33333333333333
57361, 0.73913043478261, 1.4833333333333, 0.36111111111111
57362, 0.76086956521739, 1.4833333333333, 0.38888888888889
57363, 0.73913043478261, 1.4666666666667, 0.38888888888889
57364, 0.73913043478261, 1.4833333333333, 0.41666666666667
57365, 0.76086956521739, 1.4833333333333, 0.44444444444444
57366, 0.73913043478261, 1.4666666666667, 0.44444444444444
57367, 0.73913043478261, 1.4833333333333, 0.47222222222222
57368, 0.69565217391304, 1.4833333333333, 0.027777777777778
57369, 0.71739130434783, 1.4833333333333, 0.055555555555556
57370, 0.69565217391304, 1.4666666666667, 0.055555555555556
57371, 0.69565217391304, 1.4833333333333, 0.083333333333333
57372, 0.71739130434783, 1.4833333333333, 0.11111111111111
57373, 0.69565217391304, 1.4666666666667, 0.11111111111111
57374, 0.69565217391304, 1.4833333333333, 0.13888888888889
57375, 0.71739130434783, 1.4833333333333, 0.16666666666667
57376, 0.69565217391304, 1.4666666666667, 0.16666666666667
57377, 0.69565217391304, 1.4833333333333, 0.19444444444444
57378, 0.71739130434783, 1.4833333333333, 0.22222222222222
57379, 0.69565217391304, 1.4666666666667, 0.22222222222222
57380, 0.69565217391304, 1.4833333333333, 0.25
57381, 0.71739130434783, 1.4833333333333, 0.27777777777778
57382, 0.69565217391304, 1.4666666666667, 0.27777777777778
57383, 0.69565217391304, 1.4833333333333, 0.30555555555556
57384, 0.71739130434783, 1.4833333333333, 0.33333333333333
57385, 0.69565217391304, 1.4666666666667, 0.33333333333333
57386, 0.69565217391304, 1.4833333333333, 0.36111111111111
57387, 0.71739130434783, 1.4833333333333, 0.38888888888889
57388, 0.69565217391304, 1.4666666666667, 0.38888888888889
57389, 0.69565217391304, 1.4833333333333, 0.41666666666667
57390, 0.71739130434783, 1.4833333333333, 0.44444444444444
57391, 0.69565217391304, 1.4666666666667, 0.44444444444444
57392, 0.69565217391304, 1.4833333333333, 0.47222222222222
57393, 0.65217391304348, 1.4833333333333, 0.027777777777778
57394, 0.67391304347826, 1.4833333333333, 0.055555555555556
57395, 0.65217391304348, 1.4666666666667, 0.055555555555556
57396, 0.65217391304348, 1.4833333333333, 0.083333333333333
57397, 0.67391304347826, 1.4833333333333, 0.11111111111111
57398, 0.65217391304348, 1.4666666666667, 0.11111111111111
57399, 0.65217391304348, 1.4833333333333, 0.13888888888889
57400, 0.67391304347826, 1.4833333333333, 0.16666666666667
57401, 0.65217391304348, 1.4666666666667, 0.16666666666667
57402, 0.65217391304348, 1.4833333333333, 0.19444444444444
57403, 0.67391304347826, 1.4833333333333, 0.22222222222222
57404, 0.65217391304348, 1.4666666666667, 0.22222222222222
57405, 0.65217391304348, 1.4833333333333, 0.25
57406, 0.67391304347826, 1.4833333333333, 0.27777777777778
57407, 0.65217391304348, 1.4666666666667, 0.27777777777778
57408, 0.65217391304348, 1.4833333333333, 0.30555555555556
57409, 0.67391304347826, 1.4833333333333, 0.33333333333333
57410, 0.65217391304348, 1.4666666666667, 0.33333333333333
57411, 0.65217391304348, 1.4833333333333, 0.36111111111111
57412, 0.67391304347826, 1.4833333333333, 0.38888888888889
57413, 0.65217391304348, 1.4666666666667, 0.38888888888889
57414, 0.65217391304348, 1.4833333333333, 0.41666666666667
57415, 0.67391304347826, 1.4833333333333, 0.44444444444444
57416, 0.65217391304348, 1.4666666666667, 0.44444444444444
57417, 0.65217391304348, 1.4833333333333, 0.47222222222222
57418, 0.60869565217391, 1.4833333333333, 0.027777777777778
57419, 0.6304347826087, 1.4833333333333, 0.055555555555556
57420, 0.60869565217391, 1.4666666666667, 0.055555555555556
57421, 0.60869565217391, 1.4833333333333, 0.083333333333333
57422, 0.6304347826087, 1.4833333333333, 0.11111111111111
57423, 0.60869565217391, 1.4666666666667, 0.11111111111111
57424, 0.60869565217391, 1.4833333333333, 0.13888888888889
57425, 0.6304347826087, 1.4833333333333, 0.16666666666667
57426, 0.60869565217391, 1.4666666666667, 0.16666666666667
57427, 0.60869565217391, 1.4833333333333, 0.19444444444444
57428, 0.6304347826087, 1.4833333333333, 0.22222222222222
57429, 0.60869565217391, 1.4666666666667, 0.22222222222222
57430, 0.60869565217391, 1.4833333333333, 0.25
57431, 0.6304347826087, 1.4833333333333, 0.27777777777778
57432, 0.60869565217391, 1.4666666666667, 0.27777777777778
57433, 0.60869565217391, 1.4833333333333, 0.30555555555556
57434, 0.6304347826087, 1.4833333333333, 0.33333333333333
57435, 0.60869565217391, 1.4666666666667, 0.33333333333333
57436, 0.60869565217391, 1.4833333333333, 0.36111111111111
57437, 0.6304347826087, 1.4833333333333, 0.38888888888889
57438, 0.60869565217391, 1.4666666666667, 0.38888888888889
57439, 0.60869565217391, 1.4833333333333, 0.41666666666667
57440, 0.6304347826087, 1.4833333333333, 0.44444444444444
57441, 0.60869565217391, 1.4666666666667, 0.44444444444444
57442, 0.60869565217391, 1.4833333333333, 0.47222222222222
57443, 0.56521739130435, 1.4833333333333, 0.027777777777778
57444, 0.58695652173913, 1.4833333333333, 0.055555555555556
57445, 0.56521739130435, 1.4666666666667, 0.055555555555556
57446, 0.56521739130435, 1.4833333333333, 0.083333333333333
57447, 0.58695652173913, 1.4833333333333, 0.11111111111111
57448, 0.56521739130435, 1.4666666666667, 0.11111111111111
57449, 0.56521739130435, 1.4833333333333, 0.13888888888889
57450, 0.58695652173913, 1.4833333333333, 0.16666666666667
57451, 0.56521739130435, 1.4666666666667, 0.16666666666667
57452, 0.56521739130435, 1.4833333333333, 0.19444444444444
57453, 0.58695652173913, 1.4833333333333, 0.22222222222222
57454, 0.56521739130435, 1.4666666666667, 0.22222222222222
57455, 0.56521739130435, 1.4833333333333, 0.25
57456, 0.58695652173913, 1.4833333333333, 0.27777777777778
57457, 0.56521739130435, 1.4666666666667, 0.27777777777778
57458, 0.56521739130435, 1.4833333333333, 0.30555555555556
57459, 0.58695652173913, 1.4833333333333, 0.33333333333333
57460, 0.56521739130435, 1.4666666666667, 0.33333333333333
57461, 0.56521739130435, 1.4833333333333, 0.36111111111111
57462, 0.58695652173913, 1.4833333333333, 0.38888888888889
57463, 0.56521739130435, 1.4666666666667, 0.38888888888889
57464, 0.56521739130435, 1.4833333333333, 0.41666666666667
57465, 0.58695652173913, 1.4833333333333, 0.44444444444444
57466, 0.56521739130435, 1.4666666666667, 0.44444444444444
57467, 0.56521739130435, 1.4833333333333, 0.47222222222222
57468, 0.52173913043478, 1.4833333333333, 0.027777777777778
57469, 0.54347826086957, 1.4833333333333, 0.055555555555556
57470, 0.52173913043478, 1.4666666666667, 0.055555555555556
57471, 0.52173913043478, 1.4833333333333, 0.083333333333333
57472, 0.54347826086957, 1.4833333333333, 0.11111111111111
57473, 0.52173913043478, 1.4666666666667, 0.11111111111111
57474, 0.52173913043478, 1.4833333333333, 0.13888888888889
57475, 0.54347826086957, 1.4833333333333, 0.16666666666667
57476, 0.52173913043478, 1.4666666666667, 0.16666666666667
57477, 0.52173913043478, 1.4833333333333, 0.19444444444444
57478, 0.54347826086956, 1.4833333333333, 0.22222222222222
57479, 0.52173913043478, 1.4666666666667, 0.22222222222222
57480, 0.52173913043478, 1.4833333333333, 0.25
57481, 0.54347826086956, 1.4833333333333, 0.27777777777778
57482, 0.52173913043478, 1.4666666666667, 0.27777777777778
57483, 0.52173913043478, 1.4833333333333, 0.30555555555556
57484, 0.54347826086956, 1.4833333333333, 0.33333333333333
57485, 0.52173913043478, 1.4666666666667, 0.33333333333333
57486, 0.52173913043478, 1.4833333333333, 0.36111111111111
57487, 0.54347826086956, 1.4833333333333, 0.38888888888889
57488, 0.52173913043478, 1.4666666666667, 0.38888888888889
57489, 0.52173913043478, 1.4833333333333, 0.41666666666667
57490, 0.54347826086956, 1.4833333333333, 0.44444444444444
57491, 0.52173913043478, 1.4666666666667, 0.44444444444444
57492, 0.52173913043478, 1.4833333333333, 0.47222222222222
57493, 0.47826086956522, 1.4833333333333, 0.027777777777778
57494, 0.5, 1.4833333333333, 0.055555555555556
57495, 0.47826086956522, 1.4666666666667, 0.055555555555556
57496, 0.47826086956522, 1.4833333333333, 0.083333333333333
57497, 0.5, 1.4833333333333, 0.11111111111111
57498, 0.47826086956522, 1.4666666666667, 0.11111111111111
57499, 0.47826086956522, 1.4833333333333, 0.13888888888889
57500, 0.5, 1.4833333333333, 0.16666666666667
57501, 0.47826086956522, 1.4666666666667, 0.16666666666667
57502, 0.47826086956522, 1.4833333333333, 0.19444444444444
57503, 0.5, 1.4833333333333, 0.22222222222222
57504, 0.47826086956522, 1.4666666666667, 0.22222222222222
57505, 0.47826086956522, 1.4833333333333, 0.25
57506, 0.5, 1.4833333333333, 0.27777777777778
57507, 0.47826086956522, 1.4666666666667, 0.27777777777778
57508, 0.47826086956522, 1.4833333333333, 0.30555555555556
57509, 0.5, 1.4833333333333, 0.33333333333333
57510, 0.47826086956522, 1.4666666666667, 0.33333333333333
57511, 0.47826086956522, 1.4833333333333, 0.36111111111111
57512, 0.5, 1.4833333333333, 0.38888888888889
57513, 0.47826086956522, 1.4666666666667, 0.38888888888889
57514, 0.47826086956522, 1.4833333333333, 0.41666666666667
57515, 0.5, 1.4833333333333, 0.44444444444444
57516, 0.47826086956522, 1.4666666666667, 0.44444444444444
57517, 0.47826086956522, 1.4833333333333, 0.47222222222222
57518, 0.43478260869565, 1.4833333333333, 0.027777777777778
57519, 0.45652173913043, 1.4833333333333, 0.055555555555556
57520, 0.43478260869565, 1.4666666666667, 0.055555555555556
57521, 0.43478260869565, 1.4833333333333, 0.083333333333333
57522, 0.45652173913043, 1.4833333333333, 0.11111111111111
57523, 0.43478260869565, 1.4666666666667, 0.11111111111111
57524, 0.43478260869565, 1.4833333333333, 0.13888888888889
57525, 0.45652173913043, 1.4833333333333, 0.16666666666667
57526, 0.43478260869565, 1.4666666666667, 0.16666666666667
57527, 0.43478260869565, 1.4833333333333, 0.19444444444444
57528, 0.45652173913043, 1.4833333333333, 0.22222222222222
57529, 0.43478260869565, 1.4666666666667, 0.22222222222222
57530, 0.43478260869565, 1.4833333333333, 0.25
57531, 0.45652173913043, 1.4833333333333, 0.27777777777778
57532, 0.43478260869565, 1.4666666666667, 0.27777777777778
57533, 0.43478260869565, 1.4833333333333, 0.30555555555556
57534, 0.45652173913043, 1.4833333333333, 0.33333333333333
57535, 0.43478260869565, 1.4666666666667, 0.33333333333333
57536, 0.43478260869565, 1.4833333333333, 0.36111111111111
57537, 0.45652173913044, 1.4833333333333, 0.38888888888889
57538, 0.43478260869565, 1.4666666666667, 0.38888888888889
57539, 0.43478260869565, 1.4833333333333, 0.41666666666667
57540, 0.45652173913043, 1.4833333333333, 0.44444444444444
57541, 0.43478260869565, 1.4666666666667, 0.44444444444444
57542, 0.43478260869565, 1.4833333333333, 0.47222222222222
57543, 0.39130434782609, 1.4833333333333, 0.027777777777778
57544, 0.41304347826087, 1.4833333333333, 0.055555555555556
57545, 0.39130434782609, 1.4666666666667, 0.055555555555556
57546, 0.39130434782609, 1.4833333333333, 0.083333333333333
57547, 0.41304347826087, 1.4833333333333, 0.11111111111111
57548, 0.39130434782609, 1.4666666666667, 0.11111111111111
57549, 0.39130434782609, 1.4833333333333, 0.13888888888889
57550, 0.41304347826087, 1.4833333333333, 0.16666666666667
57551, 0.39130434782609, 1.4666666666667, 0.16666666666667
57552, 0.39130434782609, 1.4833333333333, 0.19444444444444
57553, 0.41304347826087, 1.4833333333333, 0.22222222222222
57554, 0.39130434782609, 1.4666666666667, 0.22222222222222
57555, 0.39130434782609, 1.4833333333333, 0.25
57556, 0.41304347826087, 1.4833333333333, 0.27777777777778
57557, 0.39130434782609, 1.4666666666667, 0.27777777777778
57558, 0.39130434782609, 1.4833333333333, 0.30555555555556
57559, 0.41304347826087, 1.4833333333333, 0.33333333333333
57560, 0.39130434782609, 1.4666666666667, 0.33333333333333
57561, 0.39130434782609, 1.4833333333333, 0.36111111111111
57562, 0.41304347826087, 1.4833333333333, 0.38888888888889
57563, 0.39130434782609, 1.4666666666667, 0.38888888888889
57564, 0.39130434782609, 1.4833333333333, 0.41666666666667
57565, 0.41304347826087, 1.4833333333333, 0.44444444444444
57566, 0.39130434782609, 1.4666666666667, 0.44444444444444
57567, 0.39130434782609, 1.4833333333333, 0.47222222222222
57568, 0.34782608695652, 1.4833333333333, 0.027777777777778
57569, 0.3695652173913, 1.4833333333333, 0.055555555555556
57570, 0.34782608695652, 1.4666666666667, 0.055555555555556
57571, 0.34782608695652, 1.4833333333333, 0.083333333333333
57572, 0.3695652173913, 1.4833333333333, 0.11111111111111
57573, 0.34782608695652, 1.4666666666667, 0.11111111111111
57574, 0.34782608695652, 1.4833333333333, 0.13888888888889
57575, 0.3695652173913, 1.4833333333333, 0.16666666666667
57576, 0.34782608695652, 1.4666666666667, 0.16666666666667
57577, 0.34782608695652, 1.4833333333333, 0.19444444444444
57578, 0.3695652173913, 1.4833333333333, 0.22222222222222
57579, 0.34782608695652, 1.4666666666667, 0.22222222222222
57580, 0.34782608695652, 1.4833333333333, 0.25
57581, 0.3695652173913, 1.4833333333333, 0.27777777777778
57582, 0.34782608695652, 1.4666666666667, 0.27777777777778
57583, 0.34782608695652, 1.4833333333333, 0.30555555555556
57584, 0.3695652173913, 1.4833333333333, 0.33333333333333
57585, 0.34782608695652, 1.4666666666667, 0.33333333333333
57586, 0.34782608695652, 1.4833333333333, 0.36111111111111
57587, 0.3695652173913, 1.4833333333333, 0.38888888888889
57588, 0.34782608695652, 1.4666666666667, 0.38888888888889
57589, 0.34782608695652, 1.4833333333333, 0.41666666666667
57590, 0.3695652173913, 1.4833333333333, 0.44444444444444
57591, 0.34782608695652, 1.4666666666667, 0.44444444444444
57592, 0.34782608695652, 1.4833333333333, 0.47222222222222
57593, 0.30434782608696, 1.4833333333333, 0.027777777777778
57594, 0.32608695652174, 1.4833333333333, 0.055555555555556
57595, 0.30434782608696, 1.4666666666667, 0.055555555555556
57596, 0.30434782608696, 1.4833333333333, 0.083333333333333
57597, 0.32608695652174, 1.4833333333333, 0.11111111111111
57598, 0.30434782608696, 1.4666666666667, 0.11111111111111
57599, 0.30434782608696, 1.4833333333333, 0.13888888888889
57600, 0.32608695652174, 1.4833333333333, 0.16666666666667
57601, 0.30434782608696, 1.4666666666667, 0.16666666666667
57602, 0.30434782608696, 1.4833333333333, 0.19444444444444
57603, 0.32608695652174, 1.4833333333333, 0.22222222222222
57604, 0.30434782608696, 1.4666666666667, 0.22222222222222
57605, 0.30434782608696, 1.4833333333333, 0.25
57606, 0.32608695652174, 1.4833333333333, 0.27777777777778
57607, 0.30434782608696, 1.4666666666667, 0.27777777777778
57608, 0.30434782608696, 1.4833333333333, 0.30555555555556
57609, 0.32608695652174, 1.4833333333333, 0.33333333333333
57610, 0.30434782608696, 1.4666666666667, 0.33333333333333
57611, 0.30434782608696, 1.4833333333333, 0.36111111111111
57612, 0.32608695652174, 1.4833333333333, 0.38888888888889
57613, 0.30434782608696, 1.4666666666667, 0.38888888888889
57614, 0.30434782608696, 1.4833333333333, 0.41666666666667
57615, 0.32608695652174, 1.4833333333333, 0.44444444444444
57616, 0.30434782608696, 1.4666666666667, 0.44444444444444
57617, 0.30434782608696, 1.4833333333333, 0.47222222222222
57618, 0.26086956521739, 1.4833333333333, 0.027777777777778
57619, 0.28260869565217, 1.4833333333333, 0.055555555555556
57620, 0.26086956521739, 1.4666666666667, 0.055555555555556
57621, 0.26086956521739, 1.4833333333333, 0.083333333333333
57622, 0.28260869565217, 1.4833333333333, 0.11111111111111
57623, 0.26086956521739, 1.4666666666667, 0.11111111111111
57624, 0.26086956521739, 1.4833333333333, 0.13888888888889
57625, 0.28260869565217, 1.4833333333333, 0.16666666666667
57626, 0.26086956521739, 1.4666666666667, 0.16666666666667
57627, 0.26086956521739, 1.4833333333333, 0.19444444444444
57628, 0.28260869565217, 1.4833333333333, 0.22222222222222
57629, 0.26086956521739, 1.4666666666667, 0.22222222222222
57630, 0.26086956521739, 1.4833333333333, 0.25
57631, 0.28260869565217, 1.4833333333333, 0.27777777777778
57632, 0.26086956521739, 1.4666666666667, 0.27777777777778
57633, 0.26086956521739, 1.4833333333333, 0.30555555555556
57634, 0.28260869565217, 1.4833333333333, 0.33333333333333
57635, 0.26086956521739, 1.4666666666667, 0.33333333333333
57636, 0.26086956521739, 1.4833333333333, 0.36111111111111
57637, 0.28260869565217, 1.4833333333333, 0.38888888888889
57638, 0.26086956521739, 1.4666666666667, 0.38888888888889
57639, 0.26086956521739, 1.4833333333333, 0.41666666666667
57640, 0.28260869565217, 1.4833333333333, 0.44444444444444
57641, 0.26086956521739, 1.4666666666667, 0.44444444444444
57642, 0.26086956521739, 1.4833333333333, 0.47222222222222
57643, 0.21739130434783, 1.4833333333333, 0.027777777777778
57644, 0.23913043478261, 1.4833333333333, 0.055555555555556
57645, 0.21739130434783, 1.4666666666667, 0.055555555555556
57646, 0.21739130434783, 1.4833333333333, 0.083333333333333
57647, 0.23913043478261, 1.4833333333333, 0.11111111111111
57648, 0.21739130434783, 1.4666666666667, 0.11111111111111
57649, 0.21739130434783, 1.4833333333333, 0.13888888888889
57650, 0.23913043478261, 1.4833333333333, 0.16666666666667
57651, 0.21739130434783, 1.4666666666667, 0.16666666666667
57652, 0.21739130434783, 1.4833333333333, 0.19444444444444
57653, 0.23913043478261, 1.4833333333333, 0.22222222222222
57654, 0.21739130434783, 1.4666666666667, 0.22222222222222
57655, 0.21739130434783, 1.4833333333333, 0.25
57656, 0.23913043478261, 1.4833333333333, 0.27777777777778
57657, 0.21739130434783, 1.4666666666667, 0.27777777777778
57658, 0.21739130434783, 1.4833333333333, 0.30555555555556
57659, 0.23913043478261, 1.4833333333333, 0.33333333333333
57660, 0.21739130434783, 1.4666666666667, 0.33333333333333
57661, 0.21739130434783, 1.4833333333333, 0.36111111111111
57662, 0.23913043478261, 1.4833333333333, 0.38888888888889
57663, 0.21739130434783, 1.4666666666667, 0.38888888888889
57664, 0.21739130434783, 1.4833333333333, 0.41666666666667
57665, 0.23913043478261, 1.4833333333333, 0.44444444444444
57666, 0.21739130434783, 1.4666666666667, 0.44444444444444
57667, 0.21739130434783, 1.4833333333333, 0.47222222222222
57668, 0.17391304347826, 1.4833333333333, 0.027777777777778
57669, 0.19565217391304, 1.4833333333333, 0.055555555555556
57670, 0.17391304347826, 1.4666666666667, 0.055555555555556
57671, 0.17391304347826, 1.4833333333333, 0.083333333333333
57672, 0.19565217391304, 1.4833333333333, 0.11111111111111
57673, 0.17391304347826, 1.4666666666667, 0.11111111111111
57674, 0.17391304347826, 1.4833333333333, 0.13888888888889
57675, 0.19565217391304, 1.4833333333333, 0.16666666666667
57676, 0.17391304347826, 1.4666666666667, 0.16666666666667
57677, 0.17391304347826, 1.4833333333333, 0.19444444444444
57678, 0.19565217391304, 1.4833333333333, 0.22222222222222
57679, 0.17391304347826, 1.4666666666667, 0.22222222222222
57680, 0.17391304347826, 1.4833333333333, 0.25
57681, 0.19565217391304, 1.4833333333333, 0.27777777777778
57682, 0.17391304347826, 1.4666666666667, 0.27777777777778
57683, 0.17391304347826, 1.4833333333333, 0.30555555555556
57684, 0.19565217391304, 1.4833333333333, 0.33333333333333
57685, 0.17391304347826, 1.4666666666667, 0.33333333333333
57686, 0.17391304347826, 1.4833333333333, 0.36111111111111
57687, 0.19565217391304, 1.4833333333333, 0.38888888888889
57688, 0.17391304347826, 1.4666666666667, 0.38888888888889
57689, 0.17391304347826, 1.4833333333333, 0.41666666666667
57690, 0.19565217391304, 1.4833333333333, 0.44444444444444
57691, 0.17391304347826, 1.4666666666667, 0.44444444444444
57692, 0.17391304347826, 1.4833333333333, 0.47222222222222
57693, 0.1304347826087, 1.4833333333333, 0.027777777777778
57694, 0.15217391304348, 1.4833333333333, 0.055555555555556
57695, 0.1304347826087, 1.4666666666667, 0.055555555555556
57696, 0.1304347826087, 1.4833333333333, 0.083333333333333
57697, 0.15217391304348, 1.4833333333333, 0.11111111111111
57698, 0.1304347826087, 1.4666666666667, 0.11111111111111
57699, 0.1304347826087, 1.4833333333333, 0.13888888888889
57700, 0.15217391304348, 1.4833333333333, 0.16666666666667
57701, 0.1304347826087, 1.4666666666667, 0.16666666666667
57702, 0.1304347826087, 1.4833333333333, 0.19444444444444
57703, 0.15217391304348, 1.4833333333333, 0.22222222222222
57704, 0.1304347826087, 1.4666666666667, 0.22222222222222
57705, 0.1304347826087, 1.4833333333333, 0.25
57706, 0.15217391304348, 1.4833333333333, 0.27777777777778
57707, 0.1304347826087, 1.4666666666667, 0.27777777777778
57708, 0.1304347826087, 1.4833333333333, 0.30555555555556
57709, 0.15217391304348, 1.4833333333333, 0.33333333333333
57710, 0.1304347826087, 1.4666666666667, 0.33333333333333
57711, 0.1304347826087, 1.4833333333333, 0.36111111111111
57712, 0.15217391304348, 1.4833333333333, 0.38888888888889
57713, 0.1304347826087, 1.4666666666667, 0.38888888888889
57714, 0.1304347826087, 1.4833333333333, 0.41666666666667
57715, 0.15217391304348, 1.4833333333333, 0.44444444444444
57716, 0.1304347826087, 1.4666666666667, 0.44444444444444
57717, 0.1304347826087, 1.4833333333333, 0.47222222222222
57718, 0.08695652173913, 1.4833333333333, 0.027777777777778
57719, 0.10869565217391, 1.4833333333333, 0.055555555555556
57720, 0.08695652173913, 1.4666666666667, 0.055555555555556
57721, 0.08695652173913, 1.4833333333333, 0.083333333333333
57722, 0.10869565217391, 1.4833333333333, 0.11111111111111
57723, 0.08695652173913, 1.4666666666667, 0.11111111111111
57724, 0.08695652173913, 1.4833333333333, 0.13888888888889
57725, 0.10869565217391, 1.4833333333333, 0.16666666666667
57726, 0.08695652173913, 1.4666666666667, 0.16666666666667
57727, 0.08695652173913, 1.4833333333333, 0.19444444444444
57728, 0.10869565217391, 1.4833333333333, 0.22222222222222
57729, 0.08695652173913, 1.4666666666667, 0.22222222222222
57730, 0.08695652173913, 1.4833333333333, 0.25
57731, 0.10869565217391, 1.4833333333333, 0.27777777777778
57732, 0.08695652173913, 1.4666666666667, 0.27777777777778
57733, 0.08695652173913, 1.4833333333333, 0.30555555555556
57734, 0.10869565217391, 1.4833333333333, 0.33333333333333
57735, 0.08695652173913, 1.4666666666667, 0.33333333333333
57736, 0.08695652173913, 1.4833333333333, 0.36111111111111
57737, 0.10869565217391, 1.4833333333333, 0.38888888888889
57738, 0.08695652173913, 1.4666666666667, 0.38888888888889
57739, 0.08695652173913, 1.4833333333333, 0.41666666666667
57740, 0.10869565217391, 1.4833333333333, 0.44444444444444
57741, 0.08695652173913, 1.4666666666667, 0.44444444444444
57742, 0.08695652173913, 1.4833333333333, 0.47222222222222
57743, 0.043478260869565, 1.4833333333333, 0.027777777777778
57744, 0.065217391304348, 1.4833333333333, 0.055555555555556
57745, 0.043478260869565, 1.4666666666667, 0.055555555555556
57746, 0.043478260869565, 1.4833333333333, 0.083333333333333
57747, 0.065217391304348, 1.4833333333333, 0.11111111111111
57748, 0.043478260869565, 1.4666666666667, 0.11111111111111
57749, 0.043478260869565, 1.4833333333333, 0.13888888888889
57750, 0.065217391304348, 1.4833333333333, 0.16666666666667
57751, 0.043478260869565, 1.4666666666667, 0.16666666666667
57752, 0.043478260869565, 1.4833333333333, 0.19444444444444
57753, 0.065217391304348, 1.4833333333333, 0.22222222222222
57754, 0.043478260869565, 1.4666666666667, 0.22222222222222
57755, 0.043478260869565, 1.4833333333333, 0.25
57756, 0.065217391304348, 1.4833333333333, 0.27777777777778
57757, 0.043478260869565, 1.4666666666667, 0.27777777777778
57758, 0.043478260869565, 1.4833333333333, 0.30555555555556
57759, 0.065217391304348, 1.4833333333333, 0.33333333333333
57760, 0.043478260869565, 1.4666666666667, 0.33333333333333
57761, 0.043478260869565, 1.4833333333333, 0.36111111111111
57762, 0.065217391304348, 1.4833333333333, 0.38888888888889
57763, 0.043478260869565, 1.4666666666667, 0.38888888888889
57764, 0.043478260869565, 1.4833333333333, 0.41666666666667
57765, 0.065217391304348, 1.4833333333333, 0.44444444444444
57766, 0.043478260869565, 1.4666666666667, 0.44444444444444
57767, 0.043478260869565, 1.4833333333333, 0.47222222222222
57768, 0.021739130434783, 1.4833333333333, 0.055555555555556
57769, 0.021739130434783, 1.4833333333333, 0.11111111111111
57770, 0.021739130434783, 1.4833333333333, 0.16666666666667
57771, 0.021739130434783, 1.4833333333333, 0.22222222222222
57772, 0.021739130434783, 1.4833333333333, 0.27777777777778
57773, 0.021739130434783, 1.4833333333333, 0.33333333333333
57774, 0.021739130434783, 1.4833333333333, 0.38888888888889
57775, 0.021739130434783, 1.4833333333333, 0.44444444444444
57776, 0.95652173913043, 1.5166666666667, 0.027777777777778
57777, 0.97826086956522, 1.5166666666667, 0.055555555555556
57778, 0.95652173913043, 1.5, 0.055555555555556
57779, 0.95652173913043, 1.5166666666667, 0.083333333333333
57780, 0.97826086956522, 1.5166666666667, 0.11111111111111
57781, 0.95652173913044, 1.5, 0.11111111111111
57782, 0.95652173913044, 1.5166666666667, 0.13888888888889
57783, 0.97826086956522, 1.5166666666667, 0.16666666666667
57784, 0.95652173913044, 1.5, 0.16666666666667
57785, 0.95652173913044, 1.5166666666667, 0.19444444444444
57786, 0.97826086956522, 1.5166666666667, 0.22222222222222
57787, 0.95652173913044, 1.5, 0.22222222222222
57788, 0.95652173913044, 1.5166666666667, 0.25
57789, 0.97826086956522, 1.5166666666667, 0.27777777777778
57790, 0.95652173913044, 1.5, 0.27777777777778
57791, 0.95652173913044, 1.5166666666667, 0.30555555555556
57792, 0.97826086956522, 1.5166666666667, 0.33333333333333
57793, 0.95652173913044, 1.5, 0.33333333333333
57794, 0.95652173913044, 1.5166666666667, 0.36111111111111
57795, 0.97826086956522, 1.5166666666667, 0.38888888888889
57796, 0.95652173913044, 1.5, 0.38888888888889
57797, 0.95652173913044, 1.5166666666667, 0.41666666666667
57798, 0.97826086956522, 1.5166666666667, 0.44444444444444
57799, 0.95652173913044, 1.5, 0.44444444444444
57800, 0.95652173913043, 1.5166666666667, 0.47222222222222
57801, 0.91304347826087, 1.5166666666667, 0.027777777777778
57802, 0.93478260869565, 1.5166666666667, 0.055555555555556
57803, 0.91304347826087, 1.5, 0.055555555555556
57804, 0.91304347826087, 1.5166666666667, 0.083333333333333
57805, 0.93478260869565, 1.5166666666667, 0.11111111111111
57806, 0.91304347826087, 1.5, 0.11111111111111
57807, 0.91304347826087, 1.5166666666667, 0.13888888888889
57808, 0.93478260869565, 1.5166666666667, 0.16666666666667
57809, 0.91304347826087, 1.5, 0.16666666666667
57810, 0.91304347826087, 1.5166666666667, 0.19444444444444
57811, 0.93478260869565, 1.5166666666667, 0.22222222222222
57812, 0.91304347826087, 1.5, 0.22222222222222
57813, 0.91304347826087, 1.5166666666667, 0.25
57814, 0.93478260869565, 1.5166666666667, 0.27777777777778
57815, 0.91304347826087, 1.5, 0.27777777777778
57816, 0.91304347826087, 1.5166666666667, 0.30555555555556
57817, 0.93478260869565, 1.5166666666667, 0.33333333333333
57818, 0.91304347826087, 1.5, 0.33333333333333
57819, 0.91304347826087, 1.5166666666667, 0.36111111111111
57820, 0.93478260869565, 1.5166666666667, 0.38888888888889
57821, 0.91304347826087, 1.5, 0.38888888888889
57822, 0.91304347826087, 1.5166666666667, 0.41666666666667
57823, 0.93478260869565, 1.5166666666667, 0.44444444444444
57824, 0.91304347826087, 1.5, 0.44444444444444
57825, 0.91304347826087, 1.5166666666667, 0.47222222222222
57826, 0.8695652173913, 1.5166666666667, 0.027777777777778
57827, 0.89130434782609, 1.5166666666667, 0.055555555555556
57828, 0.8695652173913, 1.5, 0.055555555555556
57829, 0.8695652173913, 1.5166666666667, 0.083333333333333
57830, 0.89130434782609, 1.5166666666667, 0.11111111111111
57831, 0.8695652173913, 1.5, 0.11111111111111
57832, 0.8695652173913, 1.5166666666667, 0.13888888888889
57833, 0.89130434782609, 1.5166666666667, 0.16666666666667
57834, 0.8695652173913, 1.5, 0.16666666666667
57835, 0.8695652173913, 1.5166666666667, 0.19444444444444
57836, 0.89130434782609, 1.5166666666667, 0.22222222222222
57837, 0.8695652173913, 1.5, 0.22222222222222
57838, 0.8695652173913, 1.5166666666667, 0.25
57839, 0.89130434782609, 1.5166666666667, 0.27777777777778
57840, 0.8695652173913, 1.5, 0.27777777777778
57841, 0.8695652173913, 1.5166666666667, 0.30555555555556
57842, 0.89130434782609, 1.5166666666667, 0.33333333333333
57843, 0.8695652173913, 1.5, 0.33333333333333
57844, 0.8695652173913, 1.5166666666667, 0.36111111111111
57845, 0.89130434782609, 1.5166666666667, 0.38888888888889
57846, 0.8695652173913, 1.5, 0.38888888888889
57847, 0.8695652173913, 1.5166666666667, 0.41666666666667
57848, 0.89130434782609, 1.5166666666667, 0.44444444444444
57849, 0.8695652173913, 1.5, 0.44444444444444
57850, 0.8695652173913, 1.5166666666667, 0.47222222222222
57851, 0.82608695652174, 1.5166666666667, 0.027777777777778
57852, 0.84782608695652, 1.5166666666667, 0.055555555555556
57853, 0.82608695652174, 1.5, 0.055555555555556
57854, 0.82608695652174, 1.5166666666667, 0.083333333333333
57855, 0.84782608695652, 1.5166666666667, 0.11111111111111
57856, 0.82608695652174, 1.5, 0.11111111111111
57857, 0.82608695652174, 1.5166666666667, 0.13888888888889
57858, 0.84782608695652, 1.5166666666667, 0.16666666666667
57859, 0.82608695652174, 1.5, 0.16666666666667
57860, 0.82608695652174, 1.5166666666667, 0.19444444444444
57861, 0.84782608695652, 1.5166666666667, 0.22222222222222
57862, 0.82608695652174, 1.5, 0.22222222222222
57863, 0.82608695652174, 1.5166666666667, 0.25
57864, 0.84782608695652, 1.5166666666667, 0.27777777777778
57865, 0.82608695652174, 1.5, 0.27777777777778
57866, 0.82608695652174, 1.5166666666667, 0.30555555555556
57867, 0.84782608695652, 1.5166666666667, 0.33333333333333
57868, 0.82608695652174, 1.5, 0.33333333333333
57869, 0.82608695652174, 1.5166666666667, 0.36111111111111
57870, 0.84782608695652, 1.5166666666667, 0.38888888888889
57871, 0.82608695652174, 1.5, 0.38888888888889
57872, 0.82608695652174, 1.5166666666667, 0.41666666666667
57873, 0.84782608695652, 1.5166666666667, 0.44444444444444
57874, 0.82608695652174, 1.5, 0.44444444444444
57875, 0.82608695652174, 1.5166666666667, 0.47222222222222
57876, 0.78260869565217, 1.5166666666667, 0.027777777777778
57877, 0.80434782608696, 1.5166666666667, 0.055555555555556
57878, 0.78260869565217, 1.5, 0.055555555555556
57879, 0.78260869565217, 1.5166666666667, 0.083333333333333
57880, 0.80434782608696, 1.5166666666667, 0.11111111111111
57881, 0.78260869565217, 1.5, 0.11111111111111
57882, 0.78260869565217, 1.5166666666667, 0.13888888888889
57883, 0.80434782608696, 1.5166666666667, 0.16666666666667
57884, 0.78260869565217, 1.5, 0.16666666666667
57885, 0.78260869565217, 1.5166666666667, 0.19444444444444
57886, 0.80434782608696, 1.5166666666667, 0.22222222222222
57887, 0.78260869565217, 1.5, 0.22222222222222
57888, 0.78260869565217, 1.5166666666667, 0.25
57889, 0.80434782608696, 1.5166666666667, 0.27777777777778
57890, 0.78260869565217, 1.5, 0.27777777777778
57891, 0.78260869565217, 1.5166666666667, 0.30555555555556
57892, 0.80434782608696, 1.5166666666667, 0.33333333333333
57893, 0.78260869565217, 1.5, 0.33333333333333
57894, 0.78260869565217, 1.5166666666667, 0.36111111111111
57895, 0.80434782608696, 1.5166666666667, 0.38888888888889
57896, 0.78260869565217, 1.5, 0.38888888888889
57897, 0.78260869565217, 1.5166666666667, 0.41666666666667
57898, 0.80434782608696, 1.5166666666667, 0.44444444444444
57899, 0.78260869565217, 1.5, 0.44444444444444
57900, 0.78260869565217, 1.5166666666667, 0.47222222222222
57901, 0.73913043478261, 1.5166666666667, 0.027777777777778
57902, 0.76086956521739, 1.5166666666667, 0.055555555555556
57903, 0.73913043478261, 1.5, 0.055555555555556
57904, 0.73913043478261, 1.5166666666667, 0.083333333333333
57905, 0.76086956521739, 1.5166666666667, 0.11111111111111
57906, 0.73913043478261, 1.5, 0.11111111111111
57907, 0.73913043478261, 1.5166666666667, 0.13888888888889
57908, 0.76086956521739, 1.5166666666667, 0.16666666666667
57909, 0.73913043478261, 1.5, 0.16666666666667
57910, 0.73913043478261, 1.5166666666667, 0.19444444444444
57911, 0.76086956521739, 1.5166666666667, 0.22222222222222
57912, 0.73913043478261, 1.5, 0.22222222222222
57913, 0.73913043478261, 1.5166666666667, 0.25
57914, 0.76086956521739, 1.5166666666667, 0.27777777777778
57915, 0.73913043478261, 1.5, 0.27777777777778
57916, 0.73913043478261, 1.5166666666667, 0.30555555555556
57917, 0.76086956521739, 1.5166666666667, 0.33333333333333
57918, 0.73913043478261, 1.5, 0.33333333333333
57919, 0.73913043478261, 1.5166666666667, 0.36111111111111
57920, 0.76086956521739, 1.5166666666667, 0.38888888888889
57921, 0.73913043478261, 1.5, 0.38888888888889
57922, 0.73913043478261, 1.5166666666667, 0.41666666666667
57923, 0.76086956521739, 1.5166666666667, 0.44444444444444
57924, 0.73913043478261, 1.5, 0.44444444444444
57925, 0.73913043478261, 1.5166666666667, 0.47222222222222
57926, 0.69565217391304, 1.5166666666667, 0.027777777777778
57927, 0.71739130434783, 1.5166666666667, 0.055555555555556
57928, 0.69565217391304, 1.5, 0.055555555555556
57929, 0.69565217391304, 1.5166666666667, 0.083333333333333
57930, 0.71739130434783, 1.5166666666667, 0.11111111111111
57931, 0.69565217391304, 1.5, 0.11111111111111
57932, 0.69565217391304, 1.5166666666667, 0.13888888888889
57933, 0.71739130434783, 1.5166666666667, 0.16666666666667
57934, 0.69565217391304, 1.5, 0.16666666666667
57935, 0.69565217391304, 1.5166666666667, 0.19444444444444
57936, 0.71739130434783, 1.5166666666667, 0.22222222222222
57937, 0.69565217391304, 1.5, 0.22222222222222
57938, 0.69565217391304, 1.5166666666667, 0.25
57939, 0.71739130434783, 1.5166666666667, 0.27777777777778
57940, 0.69565217391304, 1.5, 0.27777777777778
57941, 0.69565217391304, 1.5166666666667, 0.30555555555556
57942, 0.71739130434783, 1.5166666666667, 0.33333333333333
57943, 0.69565217391304, 1.5, 0.33333333333333
57944, 0.69565217391304, 1.5166666666667, 0.36111111111111
57945, 0.71739130434783, 1.5166666666667, 0.38888888888889
57946, 0.69565217391304, 1.5, 0.38888888888889
57947, 0.69565217391304, 1.5166666666667, 0.41666666666667
57948, 0.71739130434783, 1.5166666666667, 0.44444444444444
57949, 0.69565217391304, 1.5, 0.44444444444444
57950, 0.69565217391304, 1.5166666666667, 0.47222222222222
57951, 0.65217391304348, 1.5166666666667, 0.027777777777778
57952, 0.67391304347826, 1.5166666666667, 0.055555555555556
57953, 0.65217391304348, 1.5, 0.055555555555556
57954, 0.65217391304348, 1.5166666666667, 0.083333333333333
57955, 0.67391304347826, 1.5166666666667, 0.11111111111111
57956, 0.65217391304348, 1.5, 0.11111111111111
57957, 0.65217391304348, 1.5166666666667, 0.13888888888889
57958, 0.67391304347826, 1.5166666666667, 0.16666666666667
57959, 0.65217391304348, 1.5, 0.16666666666667
57960, 0.65217391304348, 1.5166666666667, 0.19444444444444
57961, 0.67391304347826, 1.5166666666667, 0.22222222222222
57962, 0.65217391304348, 1.5, 0.22222222222222
57963, 0.65217391304348, 1.5166666666667, 0.25
57964, 0.67391304347826, 1.5166666666667, 0.27777777777778
57965, 0.65217391304348, 1.5, 0.27777777777778
57966, 0.65217391304348, 1.5166666666667, 0.30555555555556
57967, 0.67391304347826, 1.5166666666667, 0.33333333333333
57968, 0.65217391304348, 1.5, 0.33333333333333
57969, 0.65217391304348, 1.5166666666667, 0.36111111111111
57970, 0.67391304347826, 1.5166666666667, 0.38888888888889
57971, 0.65217391304348, 1.5, 0.38888888888889
57972, 0.65217391304348, 1.5166666666667, 0.41666666666667
57973, 0.67391304347826, 1.5166666666667, 0.44444444444444
57974, 0.65217391304348, 1.5, 0.44444444444444
57975, 0.65217391304348, 1.5166666666667, 0.47222222222222
57976, 0.60869565217391, 1.5166666666667, 0.027777777777778
57977, 0.6304347826087, 1.5166666666667, 0.055555555555556
57978, 0.60869565217391, 1.5, 0.055555555555556
57979, 0.60869565217391, 1.5166666666667, 0.083333333333333
57980, 0.6304347826087, 1.5166666666667, 0.11111111111111
57981, 0.60869565217391, 1.5, 0.11111111111111
57982, 0.60869565217391, 1.5166666666667, 0.13888888888889
57983, 0.6304347826087, 1.5166666666667, 0.16666666666667
57984, 0.60869565217391, 1.5, 0.16666666666667
57985, 0.60869565217391, 1.5166666666667, 0.19444444444444
57986, 0.6304347826087, 1.5166666666667, 0.22222222222222
57987, 0.60869565217391, 1.5, 0.22222222222222
57988, 0.60869565217391, 1.5166666666667, 0.25
57989, 0.6304347826087, 1.5166666666667, 0.27777777777778
57990, 0.60869565217391, 1.5, 0.27777777777778
57991, 0.60869565217391, 1.5166666666667, 0.30555555555556
57992, 0.6304347826087, 1.5166666666667, 0.33333333333333
57993, 0.60869565217391, 1.5, 0.33333333333333
57994, 0.60869565217391, 1.5166666666667, 0.36111111111111
57995, 0.6304347826087, 1.5166666666667, 0.38888888888889
57996, 0.60869565217391, 1.5, 0.38888888888889
57997, 0.60869565217391, 1.5166666666667, 0.41666666666667
57998, 0.6304347826087, 1.5166666666667, 0.44444444444444
57999, 0.60869565217391, 1.5, 0.44444444444444
58000, 0.60869565217391, 1.5166666666667, 0.47222222222222
58001, 0.56521739130435, 1.5166666666667, 0.027777777777778
58002, 0.58695652173913, 1.5166666666667, 0.055555555555556
58003, 0.56521739130435, 1.5, 0.055555555555556
58004, 0.56521739130435, 1.5166666666667, 0.083333333333333
58005, 0.58695652173913, 1.5166666666667, 0.11111111111111
58006, 0.56521739130435, 1.5, 0.11111111111111
58007, 0.56521739130435, 1.5166666666667, 0.13888888888889
58008, 0.58695652173913, 1.5166666666667, 0.16666666666667
58009, 0.56521739130435, 1.5, 0.16666666666667
58010, 0.56521739130435, 1.5166666666667, 0.19444444444444
58011, 0.58695652173913, 1.5166666666667, 0.22222222222222
58012, 0.56521739130435, 1.5, 0.22222222222222
58013, 0.56521739130435, 1.5166666666667, 0.25
58014, 0.58695652173913, 1.5166666666667, 0.27777777777778
58015, 0.56521739130435, 1.5, 0.27777777777778
58016, 0.56521739130435, 1.5166666666667, 0.30555555555556
58017, 0.58695652173913, 1.5166666666667, 0.33333333333333
58018, 0.56521739130435, 1.5, 0.33333333333333
58019, 0.56521739130435, 1.5166666666667, 0.36111111111111
58020, 0.58695652173913, 1.5166666666667, 0.38888888888889
58021, 0.56521739130435, 1.5, 0.38888888888889
58022, 0.56521739130435, 1.5166666666667, 0.41666666666667
58023, 0.58695652173913, 1.5166666666667, 0.44444444444444
58024, 0.56521739130435, 1.5, 0.44444444444444
58025, 0.56521739130435, 1.5166666666667, 0.47222222222222
58026, 0.52173913043478, 1.5166666666667, 0.027777777777778
58027, 0.54347826086957, 1.5166666666667, 0.055555555555556
58028, 0.52173913043478, 1.5, 0.055555555555556
58029, 0.52173913043478, 1.5166666666667, 0.083333333333333
58030, 0.54347826086956, 1.5166666666667, 0.11111111111111
58031, 0.52173913043478, 1.5, 0.11111111111111
58032, 0.52173913043478, 1.5166666666667, 0.13888888888889
58033, 0.54347826086957, 1.5166666666667, 0.16666666666667
58034, 0.52173913043478, 1.5, 0.16666666666667
58035, 0.52173913043478, 1.5166666666667, 0.19444444444444
58036, 0.54347826086956, 1.5166666666667, 0.22222222222222
58037, 0.52173913043478, 1.5, 0.22222222222222
58038, 0.52173913043478, 1.5166666666667, 0.25
58039, 0.54347826086956, 1.5166666666667, 0.27777777777778
58040, 0.52173913043478, 1.5, 0.27777777777778
58041, 0.52173913043478, 1.5166666666667, 0.30555555555556
58042, 0.54347826086956, 1.5166666666667, 0.33333333333333
58043, 0.52173913043478, 1.5, 0.33333333333333
58044, 0.52173913043478, 1.5166666666667, 0.36111111111111
58045, 0.54347826086957, 1.5166666666667, 0.38888888888889
58046, 0.52173913043478, 1.5, 0.38888888888889
58047, 0.52173913043478, 1.5166666666667, 0.41666666666667
58048, 0.54347826086956, 1.5166666666667, 0.44444444444444
58049, 0.52173913043478, 1.5, 0.44444444444444
58050, 0.52173913043478, 1.5166666666667, 0.47222222222222
58051, 0.47826086956522, 1.5166666666667, 0.027777777777778
58052, 0.5, 1.5166666666667, 0.055555555555556
58053, 0.47826086956522, 1.5, 0.055555555555556
58054, 0.47826086956522, 1.5166666666667, 0.083333333333333
58055, 0.5, 1.5166666666667, 0.11111111111111
58056, 0.47826086956522, 1.5, 0.11111111111111
58057, 0.47826086956522, 1.5166666666667, 0.13888888888889
58058, 0.5, 1.5166666666667, 0.16666666666667
58059, 0.47826086956522, 1.5, 0.16666666666667
58060, 0.47826086956522, 1.5166666666667, 0.19444444444444
58061, 0.5, 1.5166666666667, 0.22222222222222
58062, 0.47826086956522, 1.5, 0.22222222222222
58063, 0.47826086956522, 1.5166666666667, 0.25
58064, 0.5, 1.5166666666667, 0.27777777777778
58065, 0.47826086956522, 1.5, 0.27777777777778
58066, 0.47826086956522, 1.5166666666667, 0.30555555555556
58067, 0.5, 1.5166666666667, 0.33333333333333
58068, 0.47826086956522, 1.5, 0.33333333333333
58069, 0.47826086956522, 1.5166666666667, 0.36111111111111
58070, 0.5, 1.5166666666667, 0.38888888888889
58071, 0.47826086956522, 1.5, 0.38888888888889
58072, 0.47826086956522, 1.5166666666667, 0.41666666666667
58073, 0.5, 1.5166666666667, 0.44444444444444
58074, 0.47826086956522, 1.5, 0.44444444444444
58075, 0.47826086956522, 1.5166666666667, 0.47222222222222
58076, 0.43478260869565, 1.5166666666667, 0.027777777777778
58077, 0.45652173913043, 1.5166666666667, 0.055555555555556
58078, 0.43478260869565, 1.5, 0.055555555555556
58079, 0.43478260869565, 1.5166666666667, 0.083333333333333
58080, 0.45652173913043, 1.5166666666667, 0.11111111111111
58081, 0.43478260869565, 1.5, 0.11111111111111
58082, 0.43478260869565, 1.5166666666667, 0.13888888888889
58083, 0.45652173913043, 1.5166666666667, 0.16666666666667
58084, 0.43478260869565, 1.5, 0.16666666666667
58085, 0.43478260869565, 1.5166666666667, 0.19444444444444
58086, 0.45652173913043, 1.5166666666667, 0.22222222222222
58087, 0.43478260869565, 1.5, 0.22222222222222
58088, 0.43478260869565, 1.5166666666667, 0.25
58089, 0.45652173913043, 1.5166666666667, 0.27777777777778
58090, 0.43478260869565, 1.5, 0.27777777777778
58091, 0.43478260869565, 1.5166666666667, 0.30555555555556
58092, 0.45652173913043, 1.5166666666667, 0.33333333333333
58093, 0.43478260869565, 1.5, 0.33333333333333
58094, 0.43478260869565, 1.5166666666667, 0.36111111111111
58095, 0.45652173913043, 1.5166666666667, 0.38888888888889
58096, 0.43478260869565, 1.5, 0.38888888888889
58097, 0.43478260869565, 1.5166666666667, 0.41666666666667
58098, 0.45652173913043, 1.5166666666667, 0.44444444444444
58099, 0.43478260869565, 1.5, 0.44444444444444
58100, 0.43478260869565, 1.5166666666667, 0.47222222222222
58101, 0.39130434782609, 1.5166666666667, 0.027777777777778
58102, 0.41304347826087, 1.5166666666667, 0.055555555555556
58103, 0.39130434782609, 1.5, 0.055555555555556
58104, 0.39130434782609, 1.5166666666667, 0.083333333333333
58105, 0.41304347826087, 1.5166666666667, 0.11111111111111
58106, 0.39130434782609, 1.5, 0.11111111111111
58107, 0.39130434782609, 1.5166666666667, 0.13888888888889
58108, 0.41304347826087, 1.5166666666667, 0.16666666666667
58109, 0.39130434782609, 1.5, 0.16666666666667
58110, 0.39130434782609, 1.5166666666667, 0.19444444444444
58111, 0.41304347826087, 1.5166666666667, 0.22222222222222
58112, 0.39130434782609, 1.5, 0.22222222222222
58113, 0.39130434782609, 1.5166666666667, 0.25
58114, 0.41304347826087, 1.5166666666667, 0.27777777777778
58115, 0.39130434782609, 1.5, 0.27777777777778
58116, 0.39130434782609, 1.5166666666667, 0.30555555555556
58117, 0.41304347826087, 1.5166666666667, 0.33333333333333
58118, 0.39130434782609, 1.5, 0.33333333333333
58119, 0.39130434782609, 1.5166666666667, 0.36111111111111
58120, 0.41304347826087, 1.5166666666667, 0.38888888888889
58121, 0.39130434782609, 1.5, 0.38888888888889
58122, 0.39130434782609, 1.5166666666667, 0.41666666666667
58123, 0.41304347826087, 1.5166666666667, 0.44444444444444
58124, 0.39130434782609, 1.5, 0.44444444444444
58125, 0.39130434782609, 1.5166666666667, 0.47222222222222
58126, 0.34782608695652, 1.5166666666667, 0.027777777777778
58127, 0.3695652173913, 1.5166666666667, 0.055555555555556
58128, 0.34782608695652, 1.5, 0.055555555555556
58129, 0.34782608695652, 1.5166666666667, 0.083333333333333
58130, 0.3695652173913, 1.5166666666667, 0.11111111111111
58131, 0.34782608695652, 1.5, 0.11111111111111
58132, 0.34782608695652, 1.5166666666667, 0.13888888888889
58133, 0.3695652173913, 1.5166666666667, 0.16666666666667
58134, 0.34782608695652, 1.5, 0.16666666666667
58135, 0.34782608695652, 1.5166666666667, 0.19444444444444
58136, 0.3695652173913, 1.5166666666667, 0.22222222222222
58137, 0.34782608695652, 1.5, 0.22222222222222
58138, 0.34782608695652, 1.5166666666667, 0.25
58139, 0.3695652173913, 1.5166666666667, 0.27777777777778
58140, 0.34782608695652, 1.5, 0.27777777777778
58141, 0.34782608695652, 1.5166666666667, 0.30555555555556
58142, 0.3695652173913, 1.5166666666667, 0.33333333333333
58143, 0.34782608695652, 1.5, 0.33333333333333
58144, 0.34782608695652, 1.5166666666667, 0.36111111111111
58145, 0.3695652173913, 1.5166666666667, 0.38888888888889
58146, 0.34782608695652, 1.5, 0.38888888888889
58147, 0.34782608695652, 1.5166666666667, 0.41666666666667
58148, 0.3695652173913, 1.5166666666667, 0.44444444444444
58149, 0.34782608695652, 1.5, 0.44444444444444
58150, 0.34782608695652, 1.5166666666667, 0.47222222222222
58151, 0.30434782608696, 1.5166666666667, 0.027777777777778
58152, 0.32608695652174, 1.5166666666667, 0.055555555555556
58153, 0.30434782608696, 1.5, 0.055555555555556
58154, 0.30434782608696, 1.5166666666667, 0.083333333333333
58155, 0.32608695652174, 1.5166666666667, 0.11111111111111
58156, 0.30434782608696, 1.5, 0.11111111111111
58157, 0.30434782608696, 1.5166666666667, 0.13888888888889
58158, 0.32608695652174, 1.5166666666667, 0.16666666666667
58159, 0.30434782608696, 1.5, 0.16666666666667
58160, 0.30434782608696, 1.5166666666667, 0.19444444444444
58161, 0.32608695652174, 1.5166666666667, 0.22222222222222
58162, 0.30434782608696, 1.5, 0.22222222222222
58163, 0.30434782608696, 1.5166666666667, 0.25
58164, 0.32608695652174, 1.5166666666667, 0.27777777777778
58165, 0.30434782608696, 1.5, 0.27777777777778
58166, 0.30434782608696, 1.5166666666667, 0.30555555555556
58167, 0.32608695652174, 1.5166666666667, 0.33333333333333
58168, 0.30434782608696, 1.5, 0.33333333333333
58169, 0.30434782608696, 1.5166666666667, 0.36111111111111
58170, 0.32608695652174, 1.5166666666667, 0.38888888888889
58171, 0.30434782608696, 1.5, 0.38888888888889
58172, 0.30434782608696, 1.5166666666667, 0.41666666666667
58173, 0.32608695652174, 1.5166666666667, 0.44444444444444
58174, 0.30434782608696, 1.5, 0.44444444444444
58175, 0.30434782608696, 1.5166666666667, 0.47222222222222
58176, 0.26086956521739, 1.5166666666667, 0.027777777777778
58177, 0.28260869565217, 1.5166666666667, 0.055555555555556
58178, 0.26086956521739, 1.5, 0.055555555555556
58179, 0.26086956521739, 1.5166666666667, 0.083333333333333
58180, 0.28260869565217, 1.5166666666667, 0.11111111111111
58181, 0.26086956521739, 1.5, 0.11111111111111
58182, 0.26086956521739, 1.5166666666667, 0.13888888888889
58183, 0.28260869565217, 1.5166666666667, 0.16666666666667
58184, 0.26086956521739, 1.5, 0.16666666666667
58185, 0.26086956521739, 1.5166666666667, 0.19444444444444
58186, 0.28260869565217, 1.5166666666667, 0.22222222222222
58187, 0.26086956521739, 1.5, 0.22222222222222
58188, 0.26086956521739, 1.5166666666667, 0.25
58189, 0.28260869565217, 1.5166666666667, 0.27777777777778
58190, 0.26086956521739, 1.5, 0.27777777777778
58191, 0.26086956521739, 1.5166666666667, 0.30555555555556
58192, 0.28260869565217, 1.5166666666667, 0.33333333333333
58193, 0.26086956521739, 1.5, 0.33333333333333
58194, 0.26086956521739, 1.5166666666667, 0.36111111111111
58195, 0.28260869565217, 1.5166666666667, 0.38888888888889
58196, 0.26086956521739, 1.5, 0.38888888888889
58197, 0.26086956521739, 1.5166666666667, 0.41666666666667
58198, 0.28260869565217, 1.5166666666667, 0.44444444444444
58199, 0.26086956521739, 1.5, 0.44444444444444
58200, 0.26086956521739, 1.5166666666667, 0.47222222222222
58201, 0.21739130434783, 1.5166666666667, 0.027777777777778
58202, 0.23913043478261, 1.5166666666667, 0.055555555555556
58203, 0.21739130434783, 1.5, 0.055555555555556
58204, 0.21739130434783, 1.5166666666667, 0.083333333333333
58205, 0.23913043478261, 1.5166666666667, 0.11111111111111
58206, 0.21739130434783, 1.5, 0.11111111111111
58207, 0.21739130434783, 1.5166666666667, 0.13888888888889
58208, 0.23913043478261, 1.5166666666667, 0.16666666666667
58209, 0.21739130434783, 1.5, 0.16666666666667
58210, 0.21739130434783, 1.5166666666667, 0.19444444444444
58211, 0.23913043478261, 1.5166666666667, 0.22222222222222
58212, 0.21739130434783, 1.5, 0.22222222222222
58213, 0.21739130434783, 1.5166666666667, 0.25
58214, 0.23913043478261, 1.5166666666667, 0.27777777777778
58215, 0.21739130434783, 1.5, 0.27777777777778
58216, 0.21739130434783, 1.5166666666667, 0.30555555555556
58217, 0.23913043478261, 1.5166666666667, 0.33333333333333
58218, 0.21739130434783, 1.5, 0.33333333333333
58219, 0.21739130434783, 1.5166666666667, 0.36111111111111
58220, 0.23913043478261, 1.5166666666667, 0.38888888888889
58221, 0.21739130434783, 1.5, 0.38888888888889
58222, 0.21739130434783, 1.5166666666667, 0.41666666666667
58223, 0.23913043478261, 1.5166666666667, 0.44444444444444
58224, 0.21739130434783, 1.5, 0.44444444444444
58225, 0.21739130434783, 1.5166666666667, 0.47222222222222
58226, 0.17391304347826, 1.5166666666667, 0.027777777777778
58227, 0.19565217391304, 1.5166666666667, 0.055555555555556
58228, 0.17391304347826, 1.5, 0.055555555555556
58229, 0.17391304347826, 1.5166666666667, 0.083333333333333
58230, 0.19565217391304, 1.5166666666667, 0.11111111111111
58231, 0.17391304347826, 1.5, 0.11111111111111
58232, 0.17391304347826, 1.5166666666667, 0.13888888888889
58233, 0.19565217391304, 1.5166666666667, 0.16666666666667
58234, 0.17391304347826, 1.5, 0.16666666666667
58235, 0.17391304347826, 1.5166666666667, 0.19444444444444
58236, 0.19565217391304, 1.5166666666667, 0.22222222222222
58237, 0.17391304347826, 1.5, 0.22222222222222
58238, 0.17391304347826, 1.5166666666667, 0.25
58239, 0.19565217391304, 1.5166666666667, 0.27777777777778
58240, 0.17391304347826, 1.5, 0.27777777777778
58241, 0.17391304347826, 1.5166666666667, 0.30555555555556
58242, 0.19565217391304, 1.5166666666667, 0.33333333333333
58243, 0.17391304347826, 1.5, 0.33333333333333
58244, 0.17391304347826, 1.5166666666667, 0.36111111111111
58245, 0.19565217391304, 1.5166666666667, 0.38888888888889
58246, 0.17391304347826, 1.5, 0.38888888888889
58247, 0.17391304347826, 1.5166666666667, 0.41666666666667
58248, 0.19565217391304, 1.5166666666667, 0.44444444444444
58249, 0.17391304347826, 1.5, 0.44444444444444
58250, 0.17391304347826, 1.5166666666667, 0.47222222222222
58251, 0.1304347826087, 1.5166666666667, 0.027777777777778
58252, 0.15217391304348, 1.5166666666667, 0.055555555555556
58253, 0.1304347826087, 1.5, 0.055555555555556
58254, 0.1304347826087, 1.5166666666667, 0.083333333333333
58255, 0.15217391304348, 1.5166666666667, 0.11111111111111
58256, 0.1304347826087, 1.5, 0.11111111111111
58257, 0.1304347826087, 1.5166666666667, 0.13888888888889
58258, 0.15217391304348, 1.5166666666667, 0.16666666666667
58259, 0.1304347826087, 1.5, 0.16666666666667
58260, 0.1304347826087, 1.5166666666667, 0.19444444444444
58261, 0.15217391304348, 1.5166666666667, 0.22222222222222
58262, 0.1304347826087, 1.5, 0.22222222222222
58263, 0.1304347826087, 1.5166666666667, 0.25
58264, 0.15217391304348, 1.5166666666667, 0.27777777777778
58265, 0.1304347826087, 1.5, 0.27777777777778
58266, 0.1304347826087, 1.5166666666667, 0.30555555555556
58267, 0.15217391304348, 1.5166666666667, 0.33333333333333
58268, 0.1304347826087, 1.5, 0.33333333333333
58269, 0.1304347826087, 1.5166666666667, 0.36111111111111
58270, 0.15217391304348, 1.5166666666667, 0.38888888888889
58271, 0.1304347826087, 1.5, 0.38888888888889
58272, 0.1304347826087, 1.5166666666667, 0.41666666666667
58273, 0.15217391304348, 1.5166666666667, 0.44444444444444
58274, 0.1304347826087, 1.5, 0.44444444444444
58275, 0.1304347826087, 1.5166666666667, 0.47222222222222
58276, 0.08695652173913, 1.5166666666667, 0.027777777777778
58277, 0.10869565217391, 1.5166666666667, 0.055555555555556
58278, 0.08695652173913, 1.5, 0.055555555555556
58279, 0.08695652173913, 1.5166666666667, 0.083333333333333
58280, 0.10869565217391, 1.5166666666667, 0.11111111111111
58281, 0.08695652173913, 1.5, 0.11111111111111
58282, 0.08695652173913, 1.5166666666667, 0.13888888888889
58283, 0.10869565217391, 1.5166666666667, 0.16666666666667
58284, 0.08695652173913, 1.5, 0.16666666666667
58285, 0.08695652173913, 1.5166666666667, 0.19444444444444
58286, 0.10869565217391, 1.5166666666667, 0.22222222222222
58287, 0.08695652173913, 1.5, 0.22222222222222
58288, 0.08695652173913, 1.5166666666667, 0.25
