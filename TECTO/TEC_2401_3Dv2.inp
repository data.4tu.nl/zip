42828, 0.82608695652174, 1.1413043478261, 0.27777777777778
42829, 0.82608695652174, 1.1413043478261, 0.33333333333333
42830, 0.82608695652174, 1.1413043478261, 0.38888888888889
42831, 0.82608695652174, 1.1413043478261, 0.44444444444444
42832, 0.78260869565217, 1.1413043478261, 0.055555555555556
42833, 0.78260869565217, 1.1413043478261, 0.11111111111111
42834, 0.78260869565217, 1.1413043478261, 0.16666666666667
42835, 0.78260869565217, 1.1413043478261, 0.22222222222222
42836, 0.78260869565217, 1.1413043478261, 0.27777777777778
42837, 0.78260869565217, 1.1413043478261, 0.33333333333333
42838, 0.78260869565217, 1.1413043478261, 0.38888888888889
42839, 0.78260869565217, 1.1413043478261, 0.44444444444444
42840, 0.73913043478261, 1.1413043478261, 0.055555555555556
42841, 0.73913043478261, 1.1413043478261, 0.11111111111111
42842, 0.73913043478261, 1.1413043478261, 0.16666666666667
42843, 0.73913043478261, 1.1413043478261, 0.22222222222222
42844, 0.73913043478261, 1.1413043478261, 0.27777777777778
42845, 0.73913043478261, 1.1413043478261, 0.33333333333333
42846, 0.73913043478261, 1.1413043478261, 0.38888888888889
42847, 0.73913043478261, 1.1413043478261, 0.44444444444444
42848, 0.69565217391304, 1.1413043478261, 0.055555555555556
42849, 0.69565217391304, 1.1413043478261, 0.11111111111111
42850, 0.69565217391304, 1.1413043478261, 0.16666666666667
42851, 0.69565217391304, 1.1413043478261, 0.22222222222222
42852, 0.69565217391304, 1.1413043478261, 0.27777777777778
42853, 0.69565217391304, 1.1413043478261, 0.33333333333333
42854, 0.69565217391304, 1.1413043478261, 0.38888888888889
42855, 0.69565217391304, 1.1413043478261, 0.44444444444444
42856, 0.65217391304348, 1.1413043478261, 0.055555555555556
42857, 0.65217391304348, 1.1413043478261, 0.11111111111111
42858, 0.65217391304348, 1.1413043478261, 0.16666666666667
42859, 0.65217391304348, 1.1413043478261, 0.22222222222222
42860, 0.65217391304348, 1.1413043478261, 0.27777777777778
42861, 0.65217391304348, 1.1413043478261, 0.33333333333333
42862, 0.65217391304348, 1.1413043478261, 0.38888888888889
42863, 0.65217391304348, 1.1413043478261, 0.44444444444444
42864, 0.60869565217391, 1.1413043478261, 0.055555555555556
42865, 0.60869565217391, 1.1413043478261, 0.11111111111111
42866, 0.60869565217391, 1.1413043478261, 0.16666666666667
42867, 0.60869565217391, 1.1413043478261, 0.22222222222222
42868, 0.60869565217391, 1.1413043478261, 0.27777777777778
42869, 0.60869565217391, 1.1413043478261, 0.33333333333333
42870, 0.60869565217391, 1.1413043478261, 0.38888888888889
42871, 0.60869565217391, 1.1413043478261, 0.44444444444444
42872, 0.56521739130435, 1.1413043478261, 0.055555555555556
42873, 0.56521739130435, 1.1413043478261, 0.11111111111111
42874, 0.56521739130435, 1.1413043478261, 0.16666666666667
42875, 0.56521739130435, 1.1413043478261, 0.22222222222222
42876, 0.56521739130435, 1.1413043478261, 0.27777777777778
42877, 0.56521739130435, 1.1413043478261, 0.33333333333333
42878, 0.56521739130435, 1.1413043478261, 0.38888888888889
42879, 0.56521739130435, 1.1413043478261, 0.44444444444444
42880, 0.52173913043478, 1.1413043478261, 0.055555555555556
42881, 0.52173913043478, 1.1413043478261, 0.11111111111111
42882, 0.52173913043478, 1.1413043478261, 0.16666666666667
42883, 0.52173913043478, 1.1413043478261, 0.22222222222222
42884, 0.52173913043478, 1.1413043478261, 0.27777777777778
42885, 0.52173913043478, 1.1413043478261, 0.33333333333333
42886, 0.52173913043478, 1.1413043478261, 0.38888888888889
42887, 0.52173913043478, 1.1413043478261, 0.44444444444444
42888, 0.47826086956522, 1.1413043478261, 0.055555555555556
42889, 0.47826086956522, 1.1413043478261, 0.11111111111111
42890, 0.47826086956522, 1.1413043478261, 0.16666666666667
42891, 0.47826086956522, 1.1413043478261, 0.22222222222222
42892, 0.47826086956522, 1.1413043478261, 0.27777777777778
42893, 0.47826086956522, 1.1413043478261, 0.33333333333333
42894, 0.47826086956522, 1.1413043478261, 0.38888888888889
42895, 0.47826086956522, 1.1413043478261, 0.44444444444444
42896, 0.43478260869565, 1.1413043478261, 0.055555555555556
42897, 0.43478260869565, 1.1413043478261, 0.11111111111111
42898, 0.43478260869565, 1.1413043478261, 0.16666666666667
42899, 0.43478260869565, 1.1413043478261, 0.22222222222222
42900, 0.43478260869565, 1.1413043478261, 0.27777777777778
42901, 0.43478260869565, 1.1413043478261, 0.33333333333333
42902, 0.43478260869565, 1.1413043478261, 0.38888888888889
42903, 0.43478260869565, 1.1413043478261, 0.44444444444444
42904, 0.39130434782609, 1.1413043478261, 0.055555555555556
42905, 0.39130434782609, 1.1413043478261, 0.11111111111111
42906, 0.39130434782609, 1.1413043478261, 0.16666666666667
42907, 0.39130434782609, 1.1413043478261, 0.22222222222222
42908, 0.39130434782609, 1.1413043478261, 0.27777777777778
42909, 0.39130434782609, 1.1413043478261, 0.33333333333333
42910, 0.39130434782609, 1.1413043478261, 0.38888888888889
42911, 0.39130434782609, 1.1413043478261, 0.44444444444444
42912, 0.34782608695652, 1.1413043478261, 0.055555555555556
42913, 0.34782608695652, 1.1413043478261, 0.11111111111111
42914, 0.34782608695652, 1.1413043478261, 0.16666666666667
42915, 0.34782608695652, 1.1413043478261, 0.22222222222222
42916, 0.34782608695652, 1.1413043478261, 0.27777777777778
42917, 0.34782608695652, 1.1413043478261, 0.33333333333333
42918, 0.34782608695652, 1.1413043478261, 0.38888888888889
42919, 0.34782608695652, 1.1413043478261, 0.44444444444444
42920, 0.30434782608696, 1.1413043478261, 0.055555555555556
42921, 0.30434782608696, 1.1413043478261, 0.11111111111111
42922, 0.30434782608696, 1.1413043478261, 0.16666666666667
42923, 0.30434782608696, 1.1413043478261, 0.22222222222222
42924, 0.30434782608696, 1.1413043478261, 0.27777777777778
42925, 0.30434782608696, 1.1413043478261, 0.33333333333333
42926, 0.30434782608696, 1.1413043478261, 0.38888888888889
42927, 0.30434782608696, 1.1413043478261, 0.44444444444444
42928, 0.26086956521739, 1.1413043478261, 0.055555555555556
42929, 0.26086956521739, 1.1413043478261, 0.11111111111111
42930, 0.26086956521739, 1.1413043478261, 0.16666666666667
42931, 0.26086956521739, 1.1413043478261, 0.22222222222222
42932, 0.26086956521739, 1.1413043478261, 0.27777777777778
42933, 0.26086956521739, 1.1413043478261, 0.33333333333333
42934, 0.26086956521739, 1.1413043478261, 0.38888888888889
42935, 0.26086956521739, 1.1413043478261, 0.44444444444444
42936, 0.21739130434783, 1.1413043478261, 0.055555555555556
42937, 0.21739130434783, 1.1413043478261, 0.11111111111111
42938, 0.21739130434783, 1.1413043478261, 0.16666666666667
42939, 0.21739130434783, 1.1413043478261, 0.22222222222222
42940, 0.21739130434783, 1.1413043478261, 0.27777777777778
42941, 0.21739130434783, 1.1413043478261, 0.33333333333333
42942, 0.21739130434783, 1.1413043478261, 0.38888888888889
42943, 0.21739130434783, 1.1413043478261, 0.44444444444444
42944, 0.17391304347826, 1.1413043478261, 0.055555555555556
42945, 0.17391304347826, 1.1413043478261, 0.11111111111111
42946, 0.17391304347826, 1.1413043478261, 0.16666666666667
42947, 0.17391304347826, 1.1413043478261, 0.22222222222222
42948, 0.17391304347826, 1.1413043478261, 0.27777777777778
42949, 0.17391304347826, 1.1413043478261, 0.33333333333333
42950, 0.17391304347826, 1.1413043478261, 0.38888888888889
42951, 0.17391304347826, 1.1413043478261, 0.44444444444444
42952, 0.1304347826087, 1.1413043478261, 0.055555555555556
42953, 0.1304347826087, 1.1413043478261, 0.11111111111111
42954, 0.1304347826087, 1.1413043478261, 0.16666666666667
42955, 0.1304347826087, 1.1413043478261, 0.22222222222222
42956, 0.1304347826087, 1.1413043478261, 0.27777777777778
42957, 0.1304347826087, 1.1413043478261, 0.33333333333333
42958, 0.1304347826087, 1.1413043478261, 0.38888888888889
42959, 0.1304347826087, 1.1413043478261, 0.44444444444444
42960, 0.08695652173913, 1.1413043478261, 0.055555555555556
42961, 0.08695652173913, 1.1413043478261, 0.11111111111111
42962, 0.08695652173913, 1.1413043478261, 0.16666666666667
42963, 0.08695652173913, 1.1413043478261, 0.22222222222222
42964, 0.08695652173913, 1.1413043478261, 0.27777777777778
42965, 0.08695652173913, 1.1413043478261, 0.33333333333333
42966, 0.08695652173913, 1.1413043478261, 0.38888888888889
42967, 0.08695652173913, 1.1413043478261, 0.44444444444444
42968, 0.043478260869565, 1.1413043478261, 0.055555555555556
42969, 0.043478260869565, 1.1413043478261, 0.11111111111111
42970, 0.043478260869565, 1.1413043478261, 0.16666666666667
42971, 0.043478260869565, 1.1413043478261, 0.22222222222222
42972, 0.043478260869565, 1.1413043478261, 0.27777777777778
42973, 0.043478260869565, 1.1413043478261, 0.33333333333333
42974, 0.043478260869565, 1.1413043478261, 0.38888888888889
42975, 0.043478260869565, 1.1413043478261, 0.44444444444444
42976, 0.95652173913043, 1.1934782608696, 0.055555555555556
42977, 0.95652173913043, 1.1934782608696, 0.11111111111111
42978, 0.95652173913044, 1.1934782608696, 0.16666666666667
42979, 0.95652173913044, 1.1934782608696, 0.22222222222222
42980, 0.95652173913044, 1.1934782608696, 0.27777777777778
42981, 0.95652173913044, 1.1934782608696, 0.33333333333333
42982, 0.95652173913044, 1.1934782608696, 0.38888888888889
42983, 0.95652173913044, 1.1934782608696, 0.44444444444444
42984, 0.91304347826087, 1.1934782608696, 0.055555555555556
42985, 0.91304347826087, 1.1934782608696, 0.11111111111111
42986, 0.91304347826087, 1.1934782608696, 0.16666666666667
42987, 0.91304347826087, 1.1934782608696, 0.22222222222222
42988, 0.91304347826087, 1.1934782608696, 0.27777777777778
42989, 0.91304347826087, 1.1934782608696, 0.33333333333333
42990, 0.91304347826087, 1.1934782608696, 0.38888888888889
42991, 0.91304347826087, 1.1934782608696, 0.44444444444444
42992, 0.8695652173913, 1.1934782608696, 0.055555555555556
42993, 0.8695652173913, 1.1934782608696, 0.11111111111111
42994, 0.8695652173913, 1.1934782608696, 0.16666666666667
42995, 0.8695652173913, 1.1934782608696, 0.22222222222222
42996, 0.8695652173913, 1.1934782608696, 0.27777777777778
42997, 0.8695652173913, 1.1934782608696, 0.33333333333333
42998, 0.8695652173913, 1.1934782608696, 0.38888888888889
42999, 0.8695652173913, 1.1934782608696, 0.44444444444444
43000, 0.82608695652174, 1.1934782608696, 0.055555555555556
43001, 0.82608695652174, 1.1934782608696, 0.11111111111111
43002, 0.82608695652174, 1.1934782608696, 0.16666666666667
43003, 0.82608695652174, 1.1934782608696, 0.22222222222222
43004, 0.82608695652174, 1.1934782608696, 0.27777777777778
43005, 0.82608695652174, 1.1934782608696, 0.33333333333333
43006, 0.82608695652174, 1.1934782608696, 0.38888888888889
43007, 0.82608695652174, 1.1934782608696, 0.44444444444444
43008, 0.78260869565217, 1.1934782608696, 0.055555555555556
43009, 0.78260869565217, 1.1934782608696, 0.11111111111111
43010, 0.78260869565217, 1.1934782608696, 0.16666666666667
43011, 0.78260869565217, 1.1934782608696, 0.22222222222222
43012, 0.78260869565217, 1.1934782608696, 0.27777777777778
43013, 0.78260869565217, 1.1934782608696, 0.33333333333333
43014, 0.78260869565217, 1.1934782608696, 0.38888888888889
43015, 0.78260869565217, 1.1934782608696, 0.44444444444444
43016, 0.73913043478261, 1.1934782608696, 0.055555555555556
43017, 0.73913043478261, 1.1934782608696, 0.11111111111111
43018, 0.73913043478261, 1.1934782608696, 0.16666666666667
43019, 0.73913043478261, 1.1934782608696, 0.22222222222222
43020, 0.73913043478261, 1.1934782608696, 0.27777777777778
43021, 0.73913043478261, 1.1934782608696, 0.33333333333333
43022, 0.73913043478261, 1.1934782608696, 0.38888888888889
43023, 0.73913043478261, 1.1934782608696, 0.44444444444444
43024, 0.69565217391304, 1.1934782608696, 0.055555555555556
43025, 0.69565217391304, 1.1934782608696, 0.11111111111111
43026, 0.69565217391304, 1.1934782608696, 0.16666666666667
43027, 0.69565217391304, 1.1934782608696, 0.22222222222222
43028, 0.69565217391304, 1.1934782608696, 0.27777777777778
43029, 0.69565217391304, 1.1934782608696, 0.33333333333333
43030, 0.69565217391304, 1.1934782608696, 0.38888888888889
43031, 0.69565217391304, 1.1934782608696, 0.44444444444444
43032, 0.65217391304348, 1.1934782608696, 0.055555555555556
43033, 0.65217391304348, 1.1934782608696, 0.11111111111111
43034, 0.65217391304348, 1.1934782608696, 0.16666666666667
43035, 0.65217391304348, 1.1934782608696, 0.22222222222222
43036, 0.65217391304348, 1.1934782608696, 0.27777777777778
43037, 0.65217391304348, 1.1934782608696, 0.33333333333333
43038, 0.65217391304348, 1.1934782608696, 0.38888888888889
43039, 0.65217391304348, 1.1934782608696, 0.44444444444444
43040, 0.60869565217391, 1.1934782608696, 0.055555555555556
43041, 0.60869565217391, 1.1934782608696, 0.11111111111111
43042, 0.60869565217391, 1.1934782608696, 0.16666666666667
43043, 0.60869565217391, 1.1934782608696, 0.22222222222222
43044, 0.60869565217391, 1.1934782608696, 0.27777777777778
43045, 0.60869565217391, 1.1934782608696, 0.33333333333333
43046, 0.60869565217391, 1.1934782608696, 0.38888888888889
43047, 0.60869565217391, 1.1934782608696, 0.44444444444444
43048, 0.56521739130435, 1.1934782608696, 0.055555555555556
43049, 0.56521739130435, 1.1934782608696, 0.11111111111111
43050, 0.56521739130435, 1.1934782608696, 0.16666666666667
43051, 0.56521739130435, 1.1934782608696, 0.22222222222222
43052, 0.56521739130435, 1.1934782608696, 0.27777777777778
43053, 0.56521739130435, 1.1934782608696, 0.33333333333333
43054, 0.56521739130435, 1.1934782608696, 0.38888888888889
43055, 0.56521739130435, 1.1934782608696, 0.44444444444444
43056, 0.52173913043478, 1.1934782608696, 0.055555555555556
43057, 0.52173913043478, 1.1934782608696, 0.11111111111111
43058, 0.52173913043478, 1.1934782608696, 0.16666666666667
43059, 0.52173913043478, 1.1934782608696, 0.22222222222222
43060, 0.52173913043478, 1.1934782608696, 0.27777777777778
43061, 0.52173913043478, 1.1934782608696, 0.33333333333333
43062, 0.52173913043478, 1.1934782608696, 0.38888888888889
43063, 0.52173913043478, 1.1934782608696, 0.44444444444444
43064, 0.47826086956522, 1.1934782608696, 0.055555555555556
43065, 0.47826086956522, 1.1934782608696, 0.11111111111111
43066, 0.47826086956522, 1.1934782608696, 0.16666666666667
43067, 0.47826086956522, 1.1934782608696, 0.22222222222222
43068, 0.47826086956522, 1.1934782608696, 0.27777777777778
43069, 0.47826086956522, 1.1934782608696, 0.33333333333333
43070, 0.47826086956522, 1.1934782608696, 0.38888888888889
43071, 0.47826086956522, 1.1934782608696, 0.44444444444444
43072, 0.43478260869565, 1.1934782608696, 0.055555555555556
43073, 0.43478260869565, 1.1934782608696, 0.11111111111111
43074, 0.43478260869565, 1.1934782608696, 0.16666666666667
43075, 0.43478260869565, 1.1934782608696, 0.22222222222222
43076, 0.43478260869565, 1.1934782608696, 0.27777777777778
43077, 0.43478260869565, 1.1934782608696, 0.33333333333333
43078, 0.43478260869565, 1.1934782608696, 0.38888888888889
43079, 0.43478260869565, 1.1934782608696, 0.44444444444444
43080, 0.39130434782609, 1.1934782608696, 0.055555555555556
43081, 0.39130434782609, 1.1934782608696, 0.11111111111111
43082, 0.39130434782609, 1.1934782608696, 0.16666666666667
43083, 0.39130434782609, 1.1934782608696, 0.22222222222222
43084, 0.39130434782609, 1.1934782608696, 0.27777777777778
43085, 0.39130434782609, 1.1934782608696, 0.33333333333333
43086, 0.39130434782609, 1.1934782608696, 0.38888888888889
43087, 0.39130434782609, 1.1934782608696, 0.44444444444444
43088, 0.34782608695652, 1.1934782608696, 0.055555555555556
43089, 0.34782608695652, 1.1934782608696, 0.11111111111111
43090, 0.34782608695652, 1.1934782608696, 0.16666666666667
43091, 0.34782608695652, 1.1934782608696, 0.22222222222222
43092, 0.34782608695652, 1.1934782608696, 0.27777777777778
43093, 0.34782608695652, 1.1934782608696, 0.33333333333333
43094, 0.34782608695652, 1.1934782608696, 0.38888888888889
43095, 0.34782608695652, 1.1934782608696, 0.44444444444444
43096, 0.30434782608696, 1.1934782608696, 0.055555555555556
43097, 0.30434782608696, 1.1934782608696, 0.11111111111111
43098, 0.30434782608696, 1.1934782608696, 0.16666666666667
43099, 0.30434782608696, 1.1934782608696, 0.22222222222222
43100, 0.30434782608696, 1.1934782608696, 0.27777777777778
43101, 0.30434782608696, 1.1934782608696, 0.33333333333333
43102, 0.30434782608696, 1.1934782608696, 0.38888888888889
43103, 0.30434782608696, 1.1934782608696, 0.44444444444444
43104, 0.26086956521739, 1.1934782608696, 0.055555555555556
43105, 0.26086956521739, 1.1934782608696, 0.11111111111111
43106, 0.26086956521739, 1.1934782608696, 0.16666666666667
43107, 0.26086956521739, 1.1934782608696, 0.22222222222222
43108, 0.26086956521739, 1.1934782608696, 0.27777777777778
43109, 0.26086956521739, 1.1934782608696, 0.33333333333333
43110, 0.26086956521739, 1.1934782608696, 0.38888888888889
43111, 0.26086956521739, 1.1934782608696, 0.44444444444444
43112, 0.21739130434783, 1.1934782608696, 0.055555555555556
43113, 0.21739130434783, 1.1934782608696, 0.11111111111111
43114, 0.21739130434783, 1.1934782608696, 0.16666666666667
43115, 0.21739130434783, 1.1934782608696, 0.22222222222222
43116, 0.21739130434783, 1.1934782608696, 0.27777777777778
43117, 0.21739130434783, 1.1934782608696, 0.33333333333333
43118, 0.21739130434783, 1.1934782608696, 0.38888888888889
43119, 0.21739130434783, 1.1934782608696, 0.44444444444444
43120, 0.17391304347826, 1.1934782608696, 0.055555555555556
43121, 0.17391304347826, 1.1934782608696, 0.11111111111111
43122, 0.17391304347826, 1.1934782608696, 0.16666666666667
43123, 0.17391304347826, 1.1934782608696, 0.22222222222222
43124, 0.17391304347826, 1.1934782608696, 0.27777777777778
43125, 0.17391304347826, 1.1934782608696, 0.33333333333333
43126, 0.17391304347826, 1.1934782608696, 0.38888888888889
43127, 0.17391304347826, 1.1934782608696, 0.44444444444444
43128, 0.1304347826087, 1.1934782608696, 0.055555555555556
43129, 0.1304347826087, 1.1934782608696, 0.11111111111111
43130, 0.1304347826087, 1.1934782608696, 0.16666666666667
43131, 0.1304347826087, 1.1934782608696, 0.22222222222222
43132, 0.1304347826087, 1.1934782608696, 0.27777777777778
43133, 0.1304347826087, 1.1934782608696, 0.33333333333333
43134, 0.1304347826087, 1.1934782608696, 0.38888888888889
43135, 0.1304347826087, 1.1934782608696, 0.44444444444444
43136, 0.08695652173913, 1.1934782608696, 0.055555555555556
43137, 0.08695652173913, 1.1934782608696, 0.11111111111111
43138, 0.08695652173913, 1.1934782608696, 0.16666666666667
43139, 0.08695652173913, 1.1934782608696, 0.22222222222222
43140, 0.08695652173913, 1.1934782608696, 0.27777777777778
43141, 0.08695652173913, 1.1934782608696, 0.33333333333333
43142, 0.08695652173913, 1.1934782608696, 0.38888888888889
43143, 0.08695652173913, 1.1934782608696, 0.44444444444444
43144, 0.043478260869565, 1.1934782608696, 0.055555555555556
43145, 0.043478260869565, 1.1934782608696, 0.11111111111111
43146, 0.043478260869565, 1.1934782608696, 0.16666666666667
43147, 0.043478260869565, 1.1934782608696, 0.22222222222222
43148, 0.043478260869565, 1.1934782608696, 0.27777777777778
43149, 0.043478260869565, 1.1934782608696, 0.33333333333333
43150, 0.043478260869565, 1.1934782608696, 0.38888888888889
43151, 0.043478260869565, 1.1934782608696, 0.44444444444444
43152, 0.95652173913043, 1.245652173913, 0.055555555555556
43153, 0.95652173913044, 1.245652173913, 0.11111111111111
43154, 0.95652173913044, 1.245652173913, 0.16666666666667
43155, 0.95652173913043, 1.245652173913, 0.22222222222222
43156, 0.95652173913044, 1.245652173913, 0.27777777777778
43157, 0.95652173913044, 1.245652173913, 0.33333333333333
43158, 0.95652173913044, 1.245652173913, 0.38888888888889
43159, 0.95652173913044, 1.245652173913, 0.44444444444444
43160, 0.91304347826087, 1.245652173913, 0.055555555555556
43161, 0.91304347826087, 1.245652173913, 0.11111111111111
43162, 0.91304347826087, 1.245652173913, 0.16666666666667
43163, 0.91304347826087, 1.245652173913, 0.22222222222222
43164, 0.91304347826087, 1.245652173913, 0.27777777777778
43165, 0.91304347826087, 1.245652173913, 0.33333333333333
43166, 0.91304347826087, 1.245652173913, 0.38888888888889
43167, 0.91304347826087, 1.245652173913, 0.44444444444444
43168, 0.8695652173913, 1.245652173913, 0.055555555555556
43169, 0.8695652173913, 1.245652173913, 0.11111111111111
43170, 0.8695652173913, 1.245652173913, 0.16666666666667
43171, 0.8695652173913, 1.245652173913, 0.22222222222222
43172, 0.8695652173913, 1.245652173913, 0.27777777777778
43173, 0.8695652173913, 1.245652173913, 0.33333333333333
43174, 0.8695652173913, 1.245652173913, 0.38888888888889
43175, 0.8695652173913, 1.245652173913, 0.44444444444444
43176, 0.82608695652174, 1.245652173913, 0.055555555555556
43177, 0.82608695652174, 1.245652173913, 0.11111111111111
43178, 0.82608695652174, 1.245652173913, 0.16666666666667
43179, 0.82608695652174, 1.245652173913, 0.22222222222222
43180, 0.82608695652174, 1.245652173913, 0.27777777777778
43181, 0.82608695652174, 1.245652173913, 0.33333333333333
43182, 0.82608695652174, 1.245652173913, 0.38888888888889
43183, 0.82608695652174, 1.245652173913, 0.44444444444444
43184, 0.78260869565217, 1.245652173913, 0.055555555555556
43185, 0.78260869565217, 1.245652173913, 0.11111111111111
43186, 0.78260869565217, 1.245652173913, 0.16666666666667
43187, 0.78260869565217, 1.245652173913, 0.22222222222222
43188, 0.78260869565217, 1.245652173913, 0.27777777777778
43189, 0.78260869565217, 1.245652173913, 0.33333333333333
43190, 0.78260869565217, 1.245652173913, 0.38888888888889
43191, 0.78260869565217, 1.245652173913, 0.44444444444444
43192, 0.73913043478261, 1.245652173913, 0.055555555555556
43193, 0.73913043478261, 1.245652173913, 0.11111111111111
43194, 0.73913043478261, 1.245652173913, 0.16666666666667
43195, 0.73913043478261, 1.245652173913, 0.22222222222222
43196, 0.73913043478261, 1.245652173913, 0.27777777777778
43197, 0.73913043478261, 1.245652173913, 0.33333333333333
43198, 0.73913043478261, 1.245652173913, 0.38888888888889
43199, 0.73913043478261, 1.245652173913, 0.44444444444444
43200, 0.69565217391304, 1.245652173913, 0.055555555555556
43201, 0.69565217391304, 1.245652173913, 0.11111111111111
43202, 0.69565217391304, 1.245652173913, 0.16666666666667
43203, 0.69565217391304, 1.245652173913, 0.22222222222222
43204, 0.69565217391304, 1.245652173913, 0.27777777777778
43205, 0.69565217391304, 1.245652173913, 0.33333333333333
43206, 0.69565217391304, 1.245652173913, 0.38888888888889
43207, 0.69565217391304, 1.245652173913, 0.44444444444444
43208, 0.65217391304348, 1.245652173913, 0.055555555555556
43209, 0.65217391304348, 1.245652173913, 0.11111111111111
43210, 0.65217391304348, 1.245652173913, 0.16666666666667
43211, 0.65217391304348, 1.245652173913, 0.22222222222222
43212, 0.65217391304348, 1.245652173913, 0.27777777777778
43213, 0.65217391304348, 1.245652173913, 0.33333333333333
43214, 0.65217391304348, 1.245652173913, 0.38888888888889
43215, 0.65217391304348, 1.245652173913, 0.44444444444444
43216, 0.60869565217391, 1.245652173913, 0.055555555555556
43217, 0.60869565217391, 1.245652173913, 0.11111111111111
43218, 0.60869565217391, 1.245652173913, 0.16666666666667
43219, 0.60869565217391, 1.245652173913, 0.22222222222222
43220, 0.60869565217391, 1.245652173913, 0.27777777777778
43221, 0.60869565217391, 1.245652173913, 0.33333333333333
43222, 0.60869565217391, 1.245652173913, 0.38888888888889
43223, 0.60869565217391, 1.245652173913, 0.44444444444444
43224, 0.56521739130435, 1.245652173913, 0.055555555555556
43225, 0.56521739130435, 1.245652173913, 0.11111111111111
43226, 0.56521739130435, 1.245652173913, 0.16666666666667
43227, 0.56521739130435, 1.245652173913, 0.22222222222222
43228, 0.56521739130435, 1.245652173913, 0.27777777777778
43229, 0.56521739130435, 1.245652173913, 0.33333333333333
43230, 0.56521739130435, 1.245652173913, 0.38888888888889
43231, 0.56521739130435, 1.245652173913, 0.44444444444444
43232, 0.52173913043478, 1.245652173913, 0.055555555555556
43233, 0.52173913043478, 1.245652173913, 0.11111111111111
43234, 0.52173913043478, 1.245652173913, 0.16666666666667
43235, 0.52173913043478, 1.245652173913, 0.22222222222222
43236, 0.52173913043478, 1.245652173913, 0.27777777777778
43237, 0.52173913043478, 1.245652173913, 0.33333333333333
43238, 0.52173913043478, 1.245652173913, 0.38888888888889
43239, 0.52173913043478, 1.245652173913, 0.44444444444444
43240, 0.47826086956522, 1.245652173913, 0.055555555555556
43241, 0.47826086956522, 1.245652173913, 0.11111111111111
43242, 0.47826086956522, 1.245652173913, 0.16666666666667
43243, 0.47826086956522, 1.245652173913, 0.22222222222222
43244, 0.47826086956522, 1.245652173913, 0.27777777777778
43245, 0.47826086956522, 1.245652173913, 0.33333333333333
43246, 0.47826086956522, 1.245652173913, 0.38888888888889
43247, 0.47826086956522, 1.245652173913, 0.44444444444444
43248, 0.43478260869565, 1.245652173913, 0.055555555555556
43249, 0.43478260869565, 1.245652173913, 0.11111111111111
43250, 0.43478260869565, 1.245652173913, 0.16666666666667
43251, 0.43478260869565, 1.245652173913, 0.22222222222222
43252, 0.43478260869565, 1.245652173913, 0.27777777777778
43253, 0.43478260869565, 1.245652173913, 0.33333333333333
43254, 0.43478260869565, 1.245652173913, 0.38888888888889
43255, 0.43478260869565, 1.245652173913, 0.44444444444444
43256, 0.39130434782609, 1.245652173913, 0.055555555555556
43257, 0.39130434782609, 1.245652173913, 0.11111111111111
43258, 0.39130434782609, 1.245652173913, 0.16666666666667
43259, 0.39130434782609, 1.245652173913, 0.22222222222222
43260, 0.39130434782609, 1.245652173913, 0.27777777777778
43261, 0.39130434782609, 1.245652173913, 0.33333333333333
43262, 0.39130434782609, 1.245652173913, 0.38888888888889
43263, 0.39130434782609, 1.245652173913, 0.44444444444444
43264, 0.34782608695652, 1.245652173913, 0.055555555555556
43265, 0.34782608695652, 1.245652173913, 0.11111111111111
43266, 0.34782608695652, 1.245652173913, 0.16666666666667
43267, 0.34782608695652, 1.245652173913, 0.22222222222222
43268, 0.34782608695652, 1.245652173913, 0.27777777777778
43269, 0.34782608695652, 1.245652173913, 0.33333333333333
43270, 0.34782608695652, 1.245652173913, 0.38888888888889
43271, 0.34782608695652, 1.245652173913, 0.44444444444444
43272, 0.30434782608696, 1.245652173913, 0.055555555555556
43273, 0.30434782608696, 1.245652173913, 0.11111111111111
43274, 0.30434782608696, 1.245652173913, 0.16666666666667
43275, 0.30434782608696, 1.245652173913, 0.22222222222222
43276, 0.30434782608696, 1.245652173913, 0.27777777777778
43277, 0.30434782608696, 1.245652173913, 0.33333333333333
43278, 0.30434782608696, 1.245652173913, 0.38888888888889
43279, 0.30434782608696, 1.245652173913, 0.44444444444444
43280, 0.26086956521739, 1.245652173913, 0.055555555555556
43281, 0.26086956521739, 1.245652173913, 0.11111111111111
43282, 0.26086956521739, 1.245652173913, 0.16666666666667
43283, 0.26086956521739, 1.245652173913, 0.22222222222222
43284, 0.26086956521739, 1.245652173913, 0.27777777777778
43285, 0.26086956521739, 1.245652173913, 0.33333333333333
43286, 0.26086956521739, 1.245652173913, 0.38888888888889
43287, 0.26086956521739, 1.245652173913, 0.44444444444444
43288, 0.21739130434783, 1.245652173913, 0.055555555555556
43289, 0.21739130434783, 1.245652173913, 0.11111111111111
43290, 0.21739130434783, 1.245652173913, 0.16666666666667
43291, 0.21739130434783, 1.245652173913, 0.22222222222222
43292, 0.21739130434783, 1.245652173913, 0.27777777777778
43293, 0.21739130434783, 1.245652173913, 0.33333333333333
43294, 0.21739130434783, 1.245652173913, 0.38888888888889
43295, 0.21739130434783, 1.245652173913, 0.44444444444444
43296, 0.17391304347826, 1.245652173913, 0.055555555555556
43297, 0.17391304347826, 1.245652173913, 0.11111111111111
43298, 0.17391304347826, 1.245652173913, 0.16666666666667
43299, 0.17391304347826, 1.245652173913, 0.22222222222222
43300, 0.17391304347826, 1.245652173913, 0.27777777777778
43301, 0.17391304347826, 1.245652173913, 0.33333333333333
43302, 0.17391304347826, 1.245652173913, 0.38888888888889
43303, 0.17391304347826, 1.245652173913, 0.44444444444444
43304, 0.1304347826087, 1.245652173913, 0.055555555555556
43305, 0.1304347826087, 1.245652173913, 0.11111111111111
43306, 0.1304347826087, 1.245652173913, 0.16666666666667
43307, 0.1304347826087, 1.245652173913, 0.22222222222222
43308, 0.1304347826087, 1.245652173913, 0.27777777777778
43309, 0.1304347826087, 1.245652173913, 0.33333333333333
43310, 0.1304347826087, 1.245652173913, 0.38888888888889
43311, 0.1304347826087, 1.245652173913, 0.44444444444444
43312, 0.08695652173913, 1.245652173913, 0.055555555555556
43313, 0.08695652173913, 1.245652173913, 0.11111111111111
43314, 0.08695652173913, 1.245652173913, 0.16666666666667
43315, 0.08695652173913, 1.245652173913, 0.22222222222222
43316, 0.08695652173913, 1.245652173913, 0.27777777777778
43317, 0.08695652173913, 1.245652173913, 0.33333333333333
43318, 0.08695652173913, 1.245652173913, 0.38888888888889
43319, 0.08695652173913, 1.245652173913, 0.44444444444444
43320, 0.043478260869565, 1.245652173913, 0.055555555555556
43321, 0.043478260869565, 1.245652173913, 0.11111111111111
43322, 0.043478260869565, 1.245652173913, 0.16666666666667
43323, 0.043478260869565, 1.245652173913, 0.22222222222222
43324, 0.043478260869565, 1.245652173913, 0.27777777777778
43325, 0.043478260869565, 1.245652173913, 0.33333333333333
43326, 0.043478260869565, 1.245652173913, 0.38888888888889
43327, 0.043478260869565, 1.245652173913, 0.44444444444444
43328, 0.95652173913043, 1.2978260869565, 0.055555555555556
43329, 0.95652173913044, 1.2978260869565, 0.11111111111111
43330, 0.95652173913044, 1.2978260869565, 0.16666666666667
43331, 0.95652173913044, 1.2978260869565, 0.22222222222222
43332, 0.95652173913044, 1.2978260869565, 0.27777777777778
43333, 0.95652173913044, 1.2978260869565, 0.33333333333333
43334, 0.95652173913044, 1.2978260869565, 0.38888888888889
43335, 0.95652173913044, 1.2978260869565, 0.44444444444444
43336, 0.91304347826087, 1.2978260869565, 0.055555555555556
43337, 0.91304347826087, 1.2978260869565, 0.11111111111111
43338, 0.91304347826087, 1.2978260869565, 0.16666666666667
43339, 0.91304347826087, 1.2978260869565, 0.22222222222222
43340, 0.91304347826087, 1.2978260869565, 0.27777777777778
43341, 0.91304347826087, 1.2978260869565, 0.33333333333333
43342, 0.91304347826087, 1.2978260869565, 0.38888888888889
43343, 0.91304347826087, 1.2978260869565, 0.44444444444444
43344, 0.8695652173913, 1.2978260869565, 0.055555555555556
43345, 0.8695652173913, 1.2978260869565, 0.11111111111111
43346, 0.8695652173913, 1.2978260869565, 0.16666666666667
43347, 0.8695652173913, 1.2978260869565, 0.22222222222222
43348, 0.8695652173913, 1.2978260869565, 0.27777777777778
43349, 0.8695652173913, 1.2978260869565, 0.33333333333333
43350, 0.8695652173913, 1.2978260869565, 0.38888888888889
43351, 0.8695652173913, 1.2978260869565, 0.44444444444444
43352, 0.82608695652174, 1.2978260869565, 0.055555555555556
43353, 0.82608695652174, 1.2978260869565, 0.11111111111111
43354, 0.82608695652174, 1.2978260869565, 0.16666666666667
43355, 0.82608695652174, 1.2978260869565, 0.22222222222222
43356, 0.82608695652174, 1.2978260869565, 0.27777777777778
43357, 0.82608695652174, 1.2978260869565, 0.33333333333333
43358, 0.82608695652174, 1.2978260869565, 0.38888888888889
43359, 0.82608695652174, 1.2978260869565, 0.44444444444444
43360, 0.78260869565217, 1.2978260869565, 0.055555555555556
43361, 0.78260869565217, 1.2978260869565, 0.11111111111111
43362, 0.78260869565217, 1.2978260869565, 0.16666666666667
43363, 0.78260869565217, 1.2978260869565, 0.22222222222222
43364, 0.78260869565217, 1.2978260869565, 0.27777777777778
43365, 0.78260869565217, 1.2978260869565, 0.33333333333333
43366, 0.78260869565217, 1.2978260869565, 0.38888888888889
43367, 0.78260869565217, 1.2978260869565, 0.44444444444444
43368, 0.73913043478261, 1.2978260869565, 0.055555555555556
43369, 0.73913043478261, 1.2978260869565, 0.11111111111111
43370, 0.73913043478261, 1.2978260869565, 0.16666666666667
43371, 0.73913043478261, 1.2978260869565, 0.22222222222222
43372, 0.73913043478261, 1.2978260869565, 0.27777777777778
43373, 0.73913043478261, 1.2978260869565, 0.33333333333333
43374, 0.73913043478261, 1.2978260869565, 0.38888888888889
43375, 0.73913043478261, 1.2978260869565, 0.44444444444444
43376, 0.69565217391304, 1.2978260869565, 0.055555555555556
43377, 0.69565217391304, 1.2978260869565, 0.11111111111111
43378, 0.69565217391304, 1.2978260869565, 0.16666666666667
43379, 0.69565217391304, 1.2978260869565, 0.22222222222222
43380, 0.69565217391304, 1.2978260869565, 0.27777777777778
43381, 0.69565217391304, 1.2978260869565, 0.33333333333333
43382, 0.69565217391304, 1.2978260869565, 0.38888888888889
43383, 0.69565217391304, 1.2978260869565, 0.44444444444444
43384, 0.65217391304348, 1.2978260869565, 0.055555555555556
43385, 0.65217391304348, 1.2978260869565, 0.11111111111111
43386, 0.65217391304348, 1.2978260869565, 0.16666666666667
43387, 0.65217391304348, 1.2978260869565, 0.22222222222222
43388, 0.65217391304348, 1.2978260869565, 0.27777777777778
43389, 0.65217391304348, 1.2978260869565, 0.33333333333333
43390, 0.65217391304348, 1.2978260869565, 0.38888888888889
43391, 0.65217391304348, 1.2978260869565, 0.44444444444444
43392, 0.60869565217391, 1.2978260869565, 0.055555555555556
43393, 0.60869565217391, 1.2978260869565, 0.11111111111111
43394, 0.60869565217391, 1.2978260869565, 0.16666666666667
43395, 0.60869565217391, 1.2978260869565, 0.22222222222222
43396, 0.60869565217391, 1.2978260869565, 0.27777777777778
43397, 0.60869565217391, 1.2978260869565, 0.33333333333333
43398, 0.60869565217391, 1.2978260869565, 0.38888888888889
43399, 0.60869565217391, 1.2978260869565, 0.44444444444444
43400, 0.56521739130435, 1.2978260869565, 0.055555555555556
43401, 0.56521739130435, 1.2978260869565, 0.11111111111111
43402, 0.56521739130435, 1.2978260869565, 0.16666666666667
43403, 0.56521739130435, 1.2978260869565, 0.22222222222222
43404, 0.56521739130435, 1.2978260869565, 0.27777777777778
43405, 0.56521739130435, 1.2978260869565, 0.33333333333333
43406, 0.56521739130435, 1.2978260869565, 0.38888888888889
43407, 0.56521739130435, 1.2978260869565, 0.44444444444444
43408, 0.52173913043478, 1.2978260869565, 0.055555555555556
43409, 0.52173913043478, 1.2978260869565, 0.11111111111111
43410, 0.52173913043478, 1.2978260869565, 0.16666666666667
43411, 0.52173913043478, 1.2978260869565, 0.22222222222222
43412, 0.52173913043478, 1.2978260869565, 0.27777777777778
43413, 0.52173913043478, 1.2978260869565, 0.33333333333333
43414, 0.52173913043478, 1.2978260869565, 0.38888888888889
43415, 0.52173913043478, 1.2978260869565, 0.44444444444444
43416, 0.47826086956522, 1.2978260869565, 0.055555555555556
43417, 0.47826086956522, 1.2978260869565, 0.11111111111111
43418, 0.47826086956522, 1.2978260869565, 0.16666666666667
43419, 0.47826086956522, 1.2978260869565, 0.22222222222222
43420, 0.47826086956522, 1.2978260869565, 0.27777777777778
43421, 0.47826086956522, 1.2978260869565, 0.33333333333333
43422, 0.47826086956522, 1.2978260869565, 0.38888888888889
43423, 0.47826086956522, 1.2978260869565, 0.44444444444444
43424, 0.43478260869565, 1.2978260869565, 0.055555555555556
43425, 0.43478260869565, 1.2978260869565, 0.11111111111111
43426, 0.43478260869565, 1.2978260869565, 0.16666666666667
43427, 0.43478260869565, 1.2978260869565, 0.22222222222222
43428, 0.43478260869565, 1.2978260869565, 0.27777777777778
43429, 0.43478260869565, 1.2978260869565, 0.33333333333333
43430, 0.43478260869565, 1.2978260869565, 0.38888888888889
43431, 0.43478260869565, 1.2978260869565, 0.44444444444444
43432, 0.39130434782609, 1.2978260869565, 0.055555555555556
43433, 0.39130434782609, 1.2978260869565, 0.11111111111111
43434, 0.39130434782609, 1.2978260869565, 0.16666666666667
43435, 0.39130434782609, 1.2978260869565, 0.22222222222222
43436, 0.39130434782609, 1.2978260869565, 0.27777777777778
43437, 0.39130434782609, 1.2978260869565, 0.33333333333333
43438, 0.39130434782609, 1.2978260869565, 0.38888888888889
43439, 0.39130434782609, 1.2978260869565, 0.44444444444444
43440, 0.34782608695652, 1.2978260869565, 0.055555555555556
43441, 0.34782608695652, 1.2978260869565, 0.11111111111111
43442, 0.34782608695652, 1.2978260869565, 0.16666666666667
43443, 0.34782608695652, 1.2978260869565, 0.22222222222222
43444, 0.34782608695652, 1.2978260869565, 0.27777777777778
43445, 0.34782608695652, 1.2978260869565, 0.33333333333333
43446, 0.34782608695652, 1.2978260869565, 0.38888888888889
43447, 0.34782608695652, 1.2978260869565, 0.44444444444444
43448, 0.30434782608696, 1.2978260869565, 0.055555555555556
43449, 0.30434782608696, 1.2978260869565, 0.11111111111111
43450, 0.30434782608696, 1.2978260869565, 0.16666666666667
43451, 0.30434782608696, 1.2978260869565, 0.22222222222222
43452, 0.30434782608696, 1.2978260869565, 0.27777777777778
43453, 0.30434782608696, 1.2978260869565, 0.33333333333333
43454, 0.30434782608696, 1.2978260869565, 0.38888888888889
43455, 0.30434782608696, 1.2978260869565, 0.44444444444444
43456, 0.26086956521739, 1.2978260869565, 0.055555555555556
43457, 0.26086956521739, 1.2978260869565, 0.11111111111111
43458, 0.26086956521739, 1.2978260869565, 0.16666666666667
43459, 0.26086956521739, 1.2978260869565, 0.22222222222222
43460, 0.26086956521739, 1.2978260869565, 0.27777777777778
43461, 0.26086956521739, 1.2978260869565, 0.33333333333333
43462, 0.26086956521739, 1.2978260869565, 0.38888888888889
43463, 0.26086956521739, 1.2978260869565, 0.44444444444444
43464, 0.21739130434783, 1.2978260869565, 0.055555555555556
43465, 0.21739130434783, 1.2978260869565, 0.11111111111111
43466, 0.21739130434783, 1.2978260869565, 0.16666666666667
43467, 0.21739130434783, 1.2978260869565, 0.22222222222222
43468, 0.21739130434783, 1.2978260869565, 0.27777777777778
43469, 0.21739130434783, 1.2978260869565, 0.33333333333333
43470, 0.21739130434783, 1.2978260869565, 0.38888888888889
43471, 0.21739130434783, 1.2978260869565, 0.44444444444444
43472, 0.17391304347826, 1.2978260869565, 0.055555555555556
43473, 0.17391304347826, 1.2978260869565, 0.11111111111111
43474, 0.17391304347826, 1.2978260869565, 0.16666666666667
43475, 0.17391304347826, 1.2978260869565, 0.22222222222222
43476, 0.17391304347826, 1.2978260869565, 0.27777777777778
43477, 0.17391304347826, 1.2978260869565, 0.33333333333333
43478, 0.17391304347826, 1.2978260869565, 0.38888888888889
43479, 0.17391304347826, 1.2978260869565, 0.44444444444444
43480, 0.1304347826087, 1.2978260869565, 0.055555555555556
43481, 0.1304347826087, 1.2978260869565, 0.11111111111111
43482, 0.1304347826087, 1.2978260869565, 0.16666666666667
43483, 0.1304347826087, 1.2978260869565, 0.22222222222222
43484, 0.1304347826087, 1.2978260869565, 0.27777777777778
43485, 0.1304347826087, 1.2978260869565, 0.33333333333333
43486, 0.1304347826087, 1.2978260869565, 0.38888888888889
43487, 0.1304347826087, 1.2978260869565, 0.44444444444444
43488, 0.08695652173913, 1.2978260869565, 0.055555555555556
43489, 0.08695652173913, 1.2978260869565, 0.11111111111111
43490, 0.08695652173913, 1.2978260869565, 0.16666666666667
43491, 0.08695652173913, 1.2978260869565, 0.22222222222222
43492, 0.08695652173913, 1.2978260869565, 0.27777777777778
43493, 0.08695652173913, 1.2978260869565, 0.33333333333333
43494, 0.08695652173913, 1.2978260869565, 0.38888888888889
43495, 0.08695652173913, 1.2978260869565, 0.44444444444444
43496, 0.043478260869565, 1.2978260869565, 0.055555555555556
43497, 0.043478260869565, 1.2978260869565, 0.11111111111111
43498, 0.043478260869565, 1.2978260869565, 0.16666666666667
43499, 0.043478260869565, 1.2978260869565, 0.22222222222222
43500, 0.043478260869565, 1.2978260869565, 0.27777777777778
43501, 0.043478260869565, 1.2978260869565, 0.33333333333333
43502, 0.043478260869565, 1.2978260869565, 0.38888888888889
43503, 0.043478260869565, 1.2978260869565, 0.44444444444444
43504, 0.95652173913043, 0.20217391304348, 0.027777777777778
43505, 0.97826086956522, 0.20217391304348, 0.055555555555556
43506, 0.95652173913043, 0.17608695652174, 0.055555555555556
43507, 0.95652173913043, 0.20217391304348, 0.083333333333333
43508, 0.97826086956522, 0.20217391304348, 0.11111111111111
43509, 0.95652173913043, 0.17608695652174, 0.11111111111111
43510, 0.95652173913044, 0.20217391304348, 0.13888888888889
43511, 0.97826086956522, 0.20217391304348, 0.16666666666667
43512, 0.95652173913043, 0.17608695652174, 0.16666666666667
43513, 0.95652173913044, 0.20217391304348, 0.19444444444444
43514, 0.97826086956522, 0.20217391304348, 0.22222222222222
43515, 0.95652173913044, 0.17608695652174, 0.22222222222222
43516, 0.95652173913044, 0.20217391304348, 0.25
43517, 0.97826086956522, 0.20217391304348, 0.27777777777778
43518, 0.95652173913043, 0.17608695652174, 0.27777777777778
43519, 0.95652173913044, 0.20217391304348, 0.30555555555556
43520, 0.97826086956522, 0.20217391304348, 0.33333333333333
43521, 0.95652173913043, 0.17608695652174, 0.33333333333333
43522, 0.95652173913044, 0.20217391304348, 0.36111111111111
43523, 0.97826086956522, 0.20217391304348, 0.38888888888889
43524, 0.95652173913043, 0.17608695652174, 0.38888888888889
43525, 0.95652173913044, 0.20217391304348, 0.41666666666667
43526, 0.97826086956522, 0.20217391304348, 0.44444444444444
43527, 0.95652173913043, 0.17608695652174, 0.44444444444444
43528, 0.95652173913043, 0.20217391304348, 0.47222222222222
43529, 0.91304347826087, 0.20217391304348, 0.027777777777778
43530, 0.93478260869565, 0.20217391304348, 0.055555555555556
43531, 0.91304347826087, 0.17608695652174, 0.055555555555556
43532, 0.91304347826087, 0.20217391304348, 0.083333333333333
43533, 0.93478260869565, 0.20217391304348, 0.11111111111111
43534, 0.91304347826087, 0.17608695652174, 0.11111111111111
43535, 0.91304347826087, 0.20217391304348, 0.13888888888889
43536, 0.93478260869565, 0.20217391304348, 0.16666666666667
43537, 0.91304347826087, 0.17608695652174, 0.16666666666667
43538, 0.91304347826087, 0.20217391304348, 0.19444444444444
43539, 0.93478260869565, 0.20217391304348, 0.22222222222222
43540, 0.91304347826087, 0.17608695652174, 0.22222222222222
43541, 0.91304347826087, 0.20217391304348, 0.25
43542, 0.93478260869565, 0.20217391304348, 0.27777777777778
43543, 0.91304347826087, 0.17608695652174, 0.27777777777778
43544, 0.91304347826087, 0.20217391304348, 0.30555555555556
43545, 0.93478260869565, 0.20217391304348, 0.33333333333333
43546, 0.91304347826087, 0.17608695652174, 0.33333333333333
43547, 0.91304347826087, 0.20217391304348, 0.36111111111111
43548, 0.93478260869565, 0.20217391304348, 0.38888888888889
43549, 0.91304347826087, 0.17608695652174, 0.38888888888889
43550, 0.91304347826087, 0.20217391304348, 0.41666666666667
43551, 0.93478260869565, 0.20217391304348, 0.44444444444444
43552, 0.91304347826087, 0.17608695652174, 0.44444444444444
43553, 0.91304347826087, 0.20217391304348, 0.47222222222222
43554, 0.8695652173913, 0.20217391304348, 0.027777777777778
43555, 0.89130434782609, 0.20217391304348, 0.055555555555556
43556, 0.8695652173913, 0.17608695652174, 0.055555555555556
43557, 0.8695652173913, 0.20217391304348, 0.083333333333333
43558, 0.89130434782609, 0.20217391304348, 0.11111111111111
43559, 0.8695652173913, 0.17608695652174, 0.11111111111111
43560, 0.8695652173913, 0.20217391304348, 0.13888888888889
43561, 0.89130434782609, 0.20217391304348, 0.16666666666667
43562, 0.8695652173913, 0.17608695652174, 0.16666666666667
43563, 0.8695652173913, 0.20217391304348, 0.19444444444444
43564, 0.89130434782609, 0.20217391304348, 0.22222222222222
43565, 0.8695652173913, 0.17608695652174, 0.22222222222222
43566, 0.8695652173913, 0.20217391304348, 0.25
43567, 0.89130434782609, 0.20217391304348, 0.27777777777778
43568, 0.8695652173913, 0.17608695652174, 0.27777777777778
43569, 0.8695652173913, 0.20217391304348, 0.30555555555556
43570, 0.89130434782609, 0.20217391304348, 0.33333333333333
43571, 0.8695652173913, 0.17608695652174, 0.33333333333333
43572, 0.8695652173913, 0.20217391304348, 0.36111111111111
43573, 0.89130434782609, 0.20217391304348, 0.38888888888889
43574, 0.8695652173913, 0.17608695652174, 0.38888888888889
43575, 0.8695652173913, 0.20217391304348, 0.41666666666667
43576, 0.89130434782609, 0.20217391304348, 0.44444444444444
43577, 0.8695652173913, 0.17608695652174, 0.44444444444444
43578, 0.8695652173913, 0.20217391304348, 0.47222222222222
43579, 0.82608695652174, 0.20217391304348, 0.027777777777778
43580, 0.84782608695652, 0.20217391304348, 0.055555555555556
43581, 0.82608695652174, 0.17608695652174, 0.055555555555556
43582, 0.82608695652174, 0.20217391304348, 0.083333333333333
43583, 0.84782608695652, 0.20217391304348, 0.11111111111111
43584, 0.82608695652174, 0.17608695652174, 0.11111111111111
43585, 0.82608695652174, 0.20217391304348, 0.13888888888889
43586, 0.84782608695652, 0.20217391304348, 0.16666666666667
43587, 0.82608695652174, 0.17608695652174, 0.16666666666667
43588, 0.82608695652174, 0.20217391304348, 0.19444444444444
43589, 0.84782608695652, 0.20217391304348, 0.22222222222222
43590, 0.82608695652174, 0.17608695652174, 0.22222222222222
43591, 0.82608695652174, 0.20217391304348, 0.25
43592, 0.84782608695652, 0.20217391304348, 0.27777777777778
43593, 0.82608695652174, 0.17608695652174, 0.27777777777778
43594, 0.82608695652174, 0.20217391304348, 0.30555555555556
43595, 0.84782608695652, 0.20217391304348, 0.33333333333333
43596, 0.82608695652174, 0.17608695652174, 0.33333333333333
43597, 0.82608695652174, 0.20217391304348, 0.36111111111111
43598, 0.84782608695652, 0.20217391304348, 0.38888888888889
43599, 0.82608695652174, 0.17608695652174, 0.38888888888889
43600, 0.82608695652174, 0.20217391304348, 0.41666666666667
43601, 0.84782608695652, 0.20217391304348, 0.44444444444444
43602, 0.82608695652174, 0.17608695652174, 0.44444444444444
43603, 0.82608695652174, 0.20217391304348, 0.47222222222222
43604, 0.78260869565217, 0.20217391304348, 0.027777777777778
43605, 0.80434782608696, 0.20217391304348, 0.055555555555556
43606, 0.78260869565217, 0.17608695652174, 0.055555555555556
43607, 0.78260869565217, 0.20217391304348, 0.083333333333333
43608, 0.80434782608696, 0.20217391304348, 0.11111111111111
43609, 0.78260869565217, 0.17608695652174, 0.11111111111111
43610, 0.78260869565217, 0.20217391304348, 0.13888888888889
43611, 0.80434782608696, 0.20217391304348, 0.16666666666667
43612, 0.78260869565217, 0.17608695652174, 0.16666666666667
43613, 0.78260869565217, 0.20217391304348, 0.19444444444444
43614, 0.80434782608696, 0.20217391304348, 0.22222222222222
43615, 0.78260869565217, 0.17608695652174, 0.22222222222222
43616, 0.78260869565217, 0.20217391304348, 0.25
43617, 0.80434782608696, 0.20217391304348, 0.27777777777778
43618, 0.78260869565217, 0.17608695652174, 0.27777777777778
43619, 0.78260869565217, 0.20217391304348, 0.30555555555556
43620, 0.80434782608696, 0.20217391304348, 0.33333333333333
43621, 0.78260869565217, 0.17608695652174, 0.33333333333333
43622, 0.78260869565217, 0.20217391304348, 0.36111111111111
43623, 0.80434782608696, 0.20217391304348, 0.38888888888889
43624, 0.78260869565217, 0.17608695652174, 0.38888888888889
43625, 0.78260869565217, 0.20217391304348, 0.41666666666667
43626, 0.80434782608696, 0.20217391304348, 0.44444444444444
43627, 0.78260869565217, 0.17608695652174, 0.44444444444444
43628, 0.78260869565217, 0.20217391304348, 0.47222222222222
43629, 0.73913043478261, 0.20217391304348, 0.027777777777778
43630, 0.76086956521739, 0.20217391304348, 0.055555555555556
43631, 0.73913043478261, 0.17608695652174, 0.055555555555556
43632, 0.73913043478261, 0.20217391304348, 0.083333333333333
43633, 0.76086956521739, 0.20217391304348, 0.11111111111111
43634, 0.73913043478261, 0.17608695652174, 0.11111111111111
43635, 0.73913043478261, 0.20217391304348, 0.13888888888889
43636, 0.76086956521739, 0.20217391304348, 0.16666666666667
43637, 0.73913043478261, 0.17608695652174, 0.16666666666667
43638, 0.73913043478261, 0.20217391304348, 0.19444444444444
43639, 0.76086956521739, 0.20217391304348, 0.22222222222222
43640, 0.73913043478261, 0.17608695652174, 0.22222222222222
43641, 0.73913043478261, 0.20217391304348, 0.25
43642, 0.76086956521739, 0.20217391304348, 0.27777777777778
43643, 0.73913043478261, 0.17608695652174, 0.27777777777778
43644, 0.73913043478261, 0.20217391304348, 0.30555555555556
43645, 0.76086956521739, 0.20217391304348, 0.33333333333333
43646, 0.73913043478261, 0.17608695652174, 0.33333333333333
43647, 0.73913043478261, 0.20217391304348, 0.36111111111111
43648, 0.76086956521739, 0.20217391304348, 0.38888888888889
43649, 0.73913043478261, 0.17608695652174, 0.38888888888889
43650, 0.73913043478261, 0.20217391304348, 0.41666666666667
43651, 0.76086956521739, 0.20217391304348, 0.44444444444444
43652, 0.73913043478261, 0.17608695652174, 0.44444444444444
43653, 0.73913043478261, 0.20217391304348, 0.47222222222222
43654, 0.69565217391304, 0.20217391304348, 0.027777777777778
43655, 0.71739130434783, 0.20217391304348, 0.055555555555556
43656, 0.69565217391304, 0.17608695652174, 0.055555555555556
43657, 0.69565217391304, 0.20217391304348, 0.083333333333333
43658, 0.71739130434783, 0.20217391304348, 0.11111111111111
43659, 0.69565217391304, 0.17608695652174, 0.11111111111111
43660, 0.69565217391304, 0.20217391304348, 0.13888888888889
43661, 0.71739130434783, 0.20217391304348, 0.16666666666667
43662, 0.69565217391304, 0.17608695652174, 0.16666666666667
43663, 0.69565217391304, 0.20217391304348, 0.19444444444444
43664, 0.71739130434783, 0.20217391304348, 0.22222222222222
43665, 0.69565217391304, 0.17608695652174, 0.22222222222222
43666, 0.69565217391304, 0.20217391304348, 0.25
43667, 0.71739130434783, 0.20217391304348, 0.27777777777778
43668, 0.69565217391304, 0.17608695652174, 0.27777777777778
43669, 0.69565217391304, 0.20217391304348, 0.30555555555556
43670, 0.71739130434783, 0.20217391304348, 0.33333333333333
43671, 0.69565217391304, 0.17608695652174, 0.33333333333333
43672, 0.69565217391304, 0.20217391304348, 0.36111111111111
43673, 0.71739130434783, 0.20217391304348, 0.38888888888889
43674, 0.69565217391304, 0.17608695652174, 0.38888888888889
43675, 0.69565217391304, 0.20217391304348, 0.41666666666667
43676, 0.71739130434783, 0.20217391304348, 0.44444444444444
43677, 0.69565217391304, 0.17608695652174, 0.44444444444444
43678, 0.69565217391304, 0.20217391304348, 0.47222222222222
43679, 0.65217391304348, 0.20217391304348, 0.027777777777778
43680, 0.67391304347826, 0.20217391304348, 0.055555555555556
43681, 0.65217391304348, 0.17608695652174, 0.055555555555556
43682, 0.65217391304348, 0.20217391304348, 0.083333333333333
43683, 0.67391304347826, 0.20217391304348, 0.11111111111111
43684, 0.65217391304348, 0.17608695652174, 0.11111111111111
43685, 0.65217391304348, 0.20217391304348, 0.13888888888889
43686, 0.67391304347826, 0.20217391304348, 0.16666666666667
43687, 0.65217391304348, 0.17608695652174, 0.16666666666667
43688, 0.65217391304348, 0.20217391304348, 0.19444444444444
43689, 0.67391304347826, 0.20217391304348, 0.22222222222222
43690, 0.65217391304348, 0.17608695652174, 0.22222222222222
43691, 0.65217391304348, 0.20217391304348, 0.25
43692, 0.67391304347826, 0.20217391304348, 0.27777777777778
43693, 0.65217391304348, 0.17608695652174, 0.27777777777778
43694, 0.65217391304348, 0.20217391304348, 0.30555555555556
43695, 0.67391304347826, 0.20217391304348, 0.33333333333333
43696, 0.65217391304348, 0.17608695652174, 0.33333333333333
43697, 0.65217391304348, 0.20217391304348, 0.36111111111111
43698, 0.67391304347826, 0.20217391304348, 0.38888888888889
43699, 0.65217391304348, 0.17608695652174, 0.38888888888889
43700, 0.65217391304348, 0.20217391304348, 0.41666666666667
43701, 0.67391304347826, 0.20217391304348, 0.44444444444444
43702, 0.65217391304348, 0.17608695652174, 0.44444444444444
43703, 0.65217391304348, 0.20217391304348, 0.47222222222222
43704, 0.60869565217391, 0.20217391304348, 0.027777777777778
43705, 0.6304347826087, 0.20217391304348, 0.055555555555556
43706, 0.60869565217391, 0.17608695652174, 0.055555555555556
43707, 0.60869565217391, 0.20217391304348, 0.083333333333333
43708, 0.6304347826087, 0.20217391304348, 0.11111111111111
43709, 0.60869565217391, 0.17608695652174, 0.11111111111111
43710, 0.60869565217391, 0.20217391304348, 0.13888888888889
43711, 0.6304347826087, 0.20217391304348, 0.16666666666667
43712, 0.60869565217391, 0.17608695652174, 0.16666666666667
43713, 0.60869565217391, 0.20217391304348, 0.19444444444444
43714, 0.6304347826087, 0.20217391304348, 0.22222222222222
43715, 0.60869565217391, 0.17608695652174, 0.22222222222222
43716, 0.60869565217391, 0.20217391304348, 0.25
43717, 0.6304347826087, 0.20217391304348, 0.27777777777778
43718, 0.60869565217391, 0.17608695652174, 0.27777777777778
43719, 0.60869565217391, 0.20217391304348, 0.30555555555556
43720, 0.6304347826087, 0.20217391304348, 0.33333333333333
43721, 0.60869565217391, 0.17608695652174, 0.33333333333333
43722, 0.60869565217391, 0.20217391304348, 0.36111111111111
43723, 0.6304347826087, 0.20217391304348, 0.38888888888889
43724, 0.60869565217391, 0.17608695652174, 0.38888888888889
43725, 0.60869565217391, 0.20217391304348, 0.41666666666667
43726, 0.6304347826087, 0.20217391304348, 0.44444444444444
43727, 0.60869565217391, 0.17608695652174, 0.44444444444444
43728, 0.60869565217391, 0.20217391304348, 0.47222222222222
43729, 0.56521739130435, 0.20217391304348, 0.027777777777778
43730, 0.58695652173913, 0.20217391304348, 0.055555555555556
43731, 0.56521739130435, 0.17608695652174, 0.055555555555556
43732, 0.56521739130435, 0.20217391304348, 0.083333333333333
43733, 0.58695652173913, 0.20217391304348, 0.11111111111111
43734, 0.56521739130435, 0.17608695652174, 0.11111111111111
43735, 0.56521739130435, 0.20217391304348, 0.13888888888889
43736, 0.58695652173913, 0.20217391304348, 0.16666666666667
43737, 0.56521739130435, 0.17608695652174, 0.16666666666667
43738, 0.56521739130435, 0.20217391304348, 0.19444444444444
43739, 0.58695652173913, 0.20217391304348, 0.22222222222222
43740, 0.56521739130435, 0.17608695652174, 0.22222222222222
43741, 0.56521739130435, 0.20217391304348, 0.25
43742, 0.58695652173913, 0.20217391304348, 0.27777777777778
43743, 0.56521739130435, 0.17608695652174, 0.27777777777778
43744, 0.56521739130435, 0.20217391304348, 0.30555555555556
43745, 0.58695652173913, 0.20217391304348, 0.33333333333333
43746, 0.56521739130435, 0.17608695652174, 0.33333333333333
43747, 0.56521739130435, 0.20217391304348, 0.36111111111111
43748, 0.58695652173913, 0.20217391304348, 0.38888888888889
43749, 0.56521739130435, 0.17608695652174, 0.38888888888889
43750, 0.56521739130435, 0.20217391304348, 0.41666666666667
43751, 0.58695652173913, 0.20217391304348, 0.44444444444444
43752, 0.56521739130435, 0.17608695652174, 0.44444444444444
43753, 0.56521739130435, 0.20217391304348, 0.47222222222222
43754, 0.52173913043478, 0.20217391304348, 0.027777777777778
43755, 0.54347826086957, 0.20217391304348, 0.055555555555556
43756, 0.52173913043478, 0.17608695652174, 0.055555555555556
43757, 0.52173913043478, 0.20217391304348, 0.083333333333333
43758, 0.54347826086956, 0.20217391304348, 0.11111111111111
43759, 0.52173913043478, 0.17608695652174, 0.11111111111111
43760, 0.52173913043478, 0.20217391304348, 0.13888888888889
43761, 0.54347826086957, 0.20217391304348, 0.16666666666667
43762, 0.52173913043478, 0.17608695652174, 0.16666666666667
43763, 0.52173913043478, 0.20217391304348, 0.19444444444444
43764, 0.54347826086957, 0.20217391304348, 0.22222222222222
43765, 0.52173913043478, 0.17608695652174, 0.22222222222222
43766, 0.52173913043478, 0.20217391304348, 0.25
43767, 0.54347826086957, 0.20217391304348, 0.27777777777778
43768, 0.52173913043478, 0.17608695652174, 0.27777777777778
43769, 0.52173913043478, 0.20217391304348, 0.30555555555556
43770, 0.54347826086956, 0.20217391304348, 0.33333333333333
43771, 0.52173913043478, 0.17608695652174, 0.33333333333333
43772, 0.52173913043478, 0.20217391304348, 0.36111111111111
43773, 0.54347826086957, 0.20217391304348, 0.38888888888889
43774, 0.52173913043478, 0.17608695652174, 0.38888888888889
43775, 0.52173913043478, 0.20217391304348, 0.41666666666667
43776, 0.54347826086956, 0.20217391304348, 0.44444444444444
43777, 0.52173913043478, 0.17608695652174, 0.44444444444444
43778, 0.52173913043478, 0.20217391304348, 0.47222222222222
43779, 0.47826086956522, 0.20217391304348, 0.027777777777778
43780, 0.5, 0.20217391304348, 0.055555555555556
43781, 0.47826086956522, 0.17608695652174, 0.055555555555556
43782, 0.47826086956522, 0.20217391304348, 0.083333333333333
43783, 0.5, 0.20217391304348, 0.11111111111111
43784, 0.47826086956522, 0.17608695652174, 0.11111111111111
43785, 0.47826086956522, 0.20217391304348, 0.13888888888889
43786, 0.5, 0.20217391304348, 0.16666666666667
43787, 0.47826086956522, 0.17608695652174, 0.16666666666667
43788, 0.47826086956522, 0.20217391304348, 0.19444444444444
43789, 0.5, 0.20217391304348, 0.22222222222222
43790, 0.47826086956522, 0.17608695652174, 0.22222222222222
43791, 0.47826086956522, 0.20217391304348, 0.25
43792, 0.5, 0.20217391304348, 0.27777777777778
43793, 0.47826086956522, 0.17608695652174, 0.27777777777778
43794, 0.47826086956522, 0.20217391304348, 0.30555555555556
43795, 0.5, 0.20217391304348, 0.33333333333333
43796, 0.47826086956522, 0.17608695652174, 0.33333333333333
43797, 0.47826086956522, 0.20217391304348, 0.36111111111111
43798, 0.5, 0.20217391304348, 0.38888888888889
43799, 0.47826086956522, 0.17608695652174, 0.38888888888889
43800, 0.47826086956522, 0.20217391304348, 0.41666666666667
43801, 0.5, 0.20217391304348, 0.44444444444444
43802, 0.47826086956522, 0.17608695652174, 0.44444444444444
43803, 0.47826086956522, 0.20217391304348, 0.47222222222222
43804, 0.43478260869565, 0.20217391304348, 0.027777777777778
43805, 0.45652173913043, 0.20217391304348, 0.055555555555556
43806, 0.43478260869565, 0.17608695652174, 0.055555555555556
43807, 0.43478260869565, 0.20217391304348, 0.083333333333333
43808, 0.45652173913043, 0.20217391304348, 0.11111111111111
43809, 0.43478260869565, 0.17608695652174, 0.11111111111111
43810, 0.43478260869565, 0.20217391304348, 0.13888888888889
43811, 0.45652173913043, 0.20217391304348, 0.16666666666667
43812, 0.43478260869565, 0.17608695652174, 0.16666666666667
43813, 0.43478260869565, 0.20217391304348, 0.19444444444444
43814, 0.45652173913043, 0.20217391304348, 0.22222222222222
43815, 0.43478260869565, 0.17608695652174, 0.22222222222222
43816, 0.43478260869565, 0.20217391304348, 0.25
43817, 0.45652173913043, 0.20217391304348, 0.27777777777778
43818, 0.43478260869565, 0.17608695652174, 0.27777777777778
43819, 0.43478260869565, 0.20217391304348, 0.30555555555556
43820, 0.45652173913043, 0.20217391304348, 0.33333333333333
43821, 0.43478260869565, 0.17608695652174, 0.33333333333333
43822, 0.43478260869565, 0.20217391304348, 0.36111111111111
43823, 0.45652173913043, 0.20217391304348, 0.38888888888889
43824, 0.43478260869565, 0.17608695652174, 0.38888888888889
43825, 0.43478260869565, 0.20217391304348, 0.41666666666667
43826, 0.45652173913043, 0.20217391304348, 0.44444444444444
43827, 0.43478260869565, 0.17608695652174, 0.44444444444444
43828, 0.43478260869565, 0.20217391304348, 0.47222222222222
43829, 0.39130434782609, 0.20217391304348, 0.027777777777778
43830, 0.41304347826087, 0.20217391304348, 0.055555555555556
43831, 0.39130434782609, 0.17608695652174, 0.055555555555556
43832, 0.39130434782609, 0.20217391304348, 0.083333333333333
43833, 0.41304347826087, 0.20217391304348, 0.11111111111111
43834, 0.39130434782609, 0.17608695652174, 0.11111111111111
43835, 0.39130434782609, 0.20217391304348, 0.13888888888889
43836, 0.41304347826087, 0.20217391304348, 0.16666666666667
43837, 0.39130434782609, 0.17608695652174, 0.16666666666667
43838, 0.39130434782609, 0.20217391304348, 0.19444444444444
43839, 0.41304347826087, 0.20217391304348, 0.22222222222222
43840, 0.39130434782609, 0.17608695652174, 0.22222222222222
43841, 0.39130434782609, 0.20217391304348, 0.25
43842, 0.41304347826087, 0.20217391304348, 0.27777777777778
43843, 0.39130434782609, 0.17608695652174, 0.27777777777778
43844, 0.39130434782609, 0.20217391304348, 0.30555555555556
43845, 0.41304347826087, 0.20217391304348, 0.33333333333333
43846, 0.39130434782609, 0.17608695652174, 0.33333333333333
43847, 0.39130434782609, 0.20217391304348, 0.36111111111111
43848, 0.41304347826087, 0.20217391304348, 0.38888888888889
43849, 0.39130434782609, 0.17608695652174, 0.38888888888889
43850, 0.39130434782609, 0.20217391304348, 0.41666666666667
43851, 0.41304347826087, 0.20217391304348, 0.44444444444444
43852, 0.39130434782609, 0.17608695652174, 0.44444444444444
43853, 0.39130434782609, 0.20217391304348, 0.47222222222222
43854, 0.34782608695652, 0.20217391304348, 0.027777777777778
43855, 0.3695652173913, 0.20217391304348, 0.055555555555556
43856, 0.34782608695652, 0.17608695652174, 0.055555555555556
43857, 0.34782608695652, 0.20217391304348, 0.083333333333333
43858, 0.3695652173913, 0.20217391304348, 0.11111111111111
43859, 0.34782608695652, 0.17608695652174, 0.11111111111111
43860, 0.34782608695652, 0.20217391304348, 0.13888888888889
43861, 0.3695652173913, 0.20217391304348, 0.16666666666667
43862, 0.34782608695652, 0.17608695652174, 0.16666666666667
43863, 0.34782608695652, 0.20217391304348, 0.19444444444444
43864, 0.3695652173913, 0.20217391304348, 0.22222222222222
43865, 0.34782608695652, 0.17608695652174, 0.22222222222222
43866, 0.34782608695652, 0.20217391304348, 0.25
43867, 0.3695652173913, 0.20217391304348, 0.27777777777778
43868, 0.34782608695652, 0.17608695652174, 0.27777777777778
43869, 0.34782608695652, 0.20217391304348, 0.30555555555556
43870, 0.3695652173913, 0.20217391304348, 0.33333333333333
43871, 0.34782608695652, 0.17608695652174, 0.33333333333333
43872, 0.34782608695652, 0.20217391304348, 0.36111111111111
43873, 0.3695652173913, 0.20217391304348, 0.38888888888889
43874, 0.34782608695652, 0.17608695652174, 0.38888888888889
43875, 0.34782608695652, 0.20217391304348, 0.41666666666667
43876, 0.3695652173913, 0.20217391304348, 0.44444444444444
43877, 0.34782608695652, 0.17608695652174, 0.44444444444444
43878, 0.34782608695652, 0.20217391304348, 0.47222222222222
43879, 0.30434782608696, 0.20217391304348, 0.027777777777778
43880, 0.32608695652174, 0.20217391304348, 0.055555555555556
43881, 0.30434782608696, 0.17608695652174, 0.055555555555556
43882, 0.30434782608696, 0.20217391304348, 0.083333333333333
43883, 0.32608695652174, 0.20217391304348, 0.11111111111111
43884, 0.30434782608696, 0.17608695652174, 0.11111111111111
43885, 0.30434782608696, 0.20217391304348, 0.13888888888889
43886, 0.32608695652174, 0.20217391304348, 0.16666666666667
43887, 0.30434782608696, 0.17608695652174, 0.16666666666667
43888, 0.30434782608696, 0.20217391304348, 0.19444444444444
43889, 0.32608695652174, 0.20217391304348, 0.22222222222222
43890, 0.30434782608696, 0.17608695652174, 0.22222222222222
43891, 0.30434782608696, 0.20217391304348, 0.25
43892, 0.32608695652174, 0.20217391304348, 0.27777777777778
43893, 0.30434782608696, 0.17608695652174, 0.27777777777778
43894, 0.30434782608696, 0.20217391304348, 0.30555555555556
43895, 0.32608695652174, 0.20217391304348, 0.33333333333333
43896, 0.30434782608696, 0.17608695652174, 0.33333333333333
43897, 0.30434782608696, 0.20217391304348, 0.36111111111111
43898, 0.32608695652174, 0.20217391304348, 0.38888888888889
43899, 0.30434782608696, 0.17608695652174, 0.38888888888889
43900, 0.30434782608696, 0.20217391304348, 0.41666666666667
43901, 0.32608695652174, 0.20217391304348, 0.44444444444444
43902, 0.30434782608696, 0.17608695652174, 0.44444444444444
43903, 0.30434782608696, 0.20217391304348, 0.47222222222222
43904, 0.26086956521739, 0.20217391304348, 0.027777777777778
43905, 0.28260869565217, 0.20217391304348, 0.055555555555556
43906, 0.26086956521739, 0.17608695652174, 0.055555555555556
43907, 0.26086956521739, 0.20217391304348, 0.083333333333333
43908, 0.28260869565217, 0.20217391304348, 0.11111111111111
43909, 0.26086956521739, 0.17608695652174, 0.11111111111111
43910, 0.26086956521739, 0.20217391304348, 0.13888888888889
43911, 0.28260869565217, 0.20217391304348, 0.16666666666667
43912, 0.26086956521739, 0.17608695652174, 0.16666666666667
43913, 0.26086956521739, 0.20217391304348, 0.19444444444444
43914, 0.28260869565217, 0.20217391304348, 0.22222222222222
43915, 0.26086956521739, 0.17608695652174, 0.22222222222222
43916, 0.26086956521739, 0.20217391304348, 0.25
43917, 0.28260869565217, 0.20217391304348, 0.27777777777778
43918, 0.26086956521739, 0.17608695652174, 0.27777777777778
43919, 0.26086956521739, 0.20217391304348, 0.30555555555556
43920, 0.28260869565217, 0.20217391304348, 0.33333333333333
43921, 0.26086956521739, 0.17608695652174, 0.33333333333333
43922, 0.26086956521739, 0.20217391304348, 0.36111111111111
43923, 0.28260869565217, 0.20217391304348, 0.38888888888889
43924, 0.26086956521739, 0.17608695652174, 0.38888888888889
43925, 0.26086956521739, 0.20217391304348, 0.41666666666667
43926, 0.28260869565217, 0.20217391304348, 0.44444444444444
43927, 0.26086956521739, 0.17608695652174, 0.44444444444444
43928, 0.26086956521739, 0.20217391304348, 0.47222222222222
43929, 0.21739130434783, 0.20217391304348, 0.027777777777778
43930, 0.23913043478261, 0.20217391304348, 0.055555555555556
43931, 0.21739130434783, 0.17608695652174, 0.055555555555556
43932, 0.21739130434783, 0.20217391304348, 0.083333333333333
43933, 0.23913043478261, 0.20217391304348, 0.11111111111111
43934, 0.21739130434783, 0.17608695652174, 0.11111111111111
43935, 0.21739130434783, 0.20217391304348, 0.13888888888889
43936, 0.23913043478261, 0.20217391304348, 0.16666666666667
43937, 0.21739130434783, 0.17608695652174, 0.16666666666667
43938, 0.21739130434783, 0.20217391304348, 0.19444444444444
43939, 0.23913043478261, 0.20217391304348, 0.22222222222222
43940, 0.21739130434783, 0.17608695652174, 0.22222222222222
43941, 0.21739130434783, 0.20217391304348, 0.25
43942, 0.23913043478261, 0.20217391304348, 0.27777777777778
43943, 0.21739130434783, 0.17608695652174, 0.27777777777778
43944, 0.21739130434783, 0.20217391304348, 0.30555555555556
43945, 0.23913043478261, 0.20217391304348, 0.33333333333333
43946, 0.21739130434783, 0.17608695652174, 0.33333333333333
43947, 0.21739130434783, 0.20217391304348, 0.36111111111111
43948, 0.23913043478261, 0.20217391304348, 0.38888888888889
43949, 0.21739130434783, 0.17608695652174, 0.38888888888889
43950, 0.21739130434783, 0.20217391304348, 0.41666666666667
43951, 0.23913043478261, 0.20217391304348, 0.44444444444444
43952, 0.21739130434783, 0.17608695652174, 0.44444444444444
43953, 0.21739130434783, 0.20217391304348, 0.47222222222222
43954, 0.17391304347826, 0.20217391304348, 0.027777777777778
43955, 0.19565217391304, 0.20217391304348, 0.055555555555556
43956, 0.17391304347826, 0.17608695652174, 0.055555555555556
43957, 0.17391304347826, 0.20217391304348, 0.083333333333333
43958, 0.19565217391304, 0.20217391304348, 0.11111111111111
43959, 0.17391304347826, 0.17608695652174, 0.11111111111111
43960, 0.17391304347826, 0.20217391304348, 0.13888888888889
43961, 0.19565217391304, 0.20217391304348, 0.16666666666667
43962, 0.17391304347826, 0.17608695652174, 0.16666666666667
43963, 0.17391304347826, 0.20217391304348, 0.19444444444444
43964, 0.19565217391304, 0.20217391304348, 0.22222222222222
43965, 0.17391304347826, 0.17608695652174, 0.22222222222222
43966, 0.17391304347826, 0.20217391304348, 0.25
43967, 0.19565217391304, 0.20217391304348, 0.27777777777778
43968, 0.17391304347826, 0.17608695652174, 0.27777777777778
43969, 0.17391304347826, 0.20217391304348, 0.30555555555556
43970, 0.19565217391304, 0.20217391304348, 0.33333333333333
43971, 0.17391304347826, 0.17608695652174, 0.33333333333333
43972, 0.17391304347826, 0.20217391304348, 0.36111111111111
43973, 0.19565217391304, 0.20217391304348, 0.38888888888889
43974, 0.17391304347826, 0.17608695652174, 0.38888888888889
43975, 0.17391304347826, 0.20217391304348, 0.41666666666667
43976, 0.19565217391304, 0.20217391304348, 0.44444444444444
43977, 0.17391304347826, 0.17608695652174, 0.44444444444444
43978, 0.17391304347826, 0.20217391304348, 0.47222222222222
43979, 0.1304347826087, 0.20217391304348, 0.027777777777778
43980, 0.15217391304348, 0.20217391304348, 0.055555555555556
43981, 0.1304347826087, 0.17608695652174, 0.055555555555556
43982, 0.1304347826087, 0.20217391304348, 0.083333333333333
43983, 0.15217391304348, 0.20217391304348, 0.11111111111111
43984, 0.1304347826087, 0.17608695652174, 0.11111111111111
43985, 0.1304347826087, 0.20217391304348, 0.13888888888889
43986, 0.15217391304348, 0.20217391304348, 0.16666666666667
43987, 0.1304347826087, 0.17608695652174, 0.16666666666667
43988, 0.1304347826087, 0.20217391304348, 0.19444444444444
43989, 0.15217391304348, 0.20217391304348, 0.22222222222222
43990, 0.1304347826087, 0.17608695652174, 0.22222222222222
43991, 0.1304347826087, 0.20217391304348, 0.25
43992, 0.15217391304348, 0.20217391304348, 0.27777777777778
43993, 0.1304347826087, 0.17608695652174, 0.27777777777778
43994, 0.1304347826087, 0.20217391304348, 0.30555555555556
43995, 0.15217391304348, 0.20217391304348, 0.33333333333333
43996, 0.1304347826087, 0.17608695652174, 0.33333333333333
43997, 0.1304347826087, 0.20217391304348, 0.36111111111111
43998, 0.15217391304348, 0.20217391304348, 0.38888888888889
43999, 0.1304347826087, 0.17608695652174, 0.38888888888889
44000, 0.1304347826087, 0.20217391304348, 0.41666666666667
44001, 0.15217391304348, 0.20217391304348, 0.44444444444444
44002, 0.1304347826087, 0.17608695652174, 0.44444444444444
44003, 0.1304347826087, 0.20217391304348, 0.47222222222222
44004, 0.08695652173913, 0.20217391304348, 0.027777777777778
44005, 0.10869565217391, 0.20217391304348, 0.055555555555556
44006, 0.08695652173913, 0.17608695652174, 0.055555555555556
44007, 0.08695652173913, 0.20217391304348, 0.083333333333333
44008, 0.10869565217391, 0.20217391304348, 0.11111111111111
44009, 0.08695652173913, 0.17608695652174, 0.11111111111111
44010, 0.08695652173913, 0.20217391304348, 0.13888888888889
44011, 0.10869565217391, 0.20217391304348, 0.16666666666667
44012, 0.08695652173913, 0.17608695652174, 0.16666666666667
44013, 0.08695652173913, 0.20217391304348, 0.19444444444444
44014, 0.10869565217391, 0.20217391304348, 0.22222222222222
44015, 0.08695652173913, 0.17608695652174, 0.22222222222222
44016, 0.08695652173913, 0.20217391304348, 0.25
44017, 0.10869565217391, 0.20217391304348, 0.27777777777778
44018, 0.08695652173913, 0.17608695652174, 0.27777777777778
44019, 0.08695652173913, 0.20217391304348, 0.30555555555556
44020, 0.10869565217391, 0.20217391304348, 0.33333333333333
44021, 0.08695652173913, 0.17608695652174, 0.33333333333333
44022, 0.08695652173913, 0.20217391304348, 0.36111111111111
44023, 0.10869565217391, 0.20217391304348, 0.38888888888889
44024, 0.08695652173913, 0.17608695652174, 0.38888888888889
44025, 0.08695652173913, 0.20217391304348, 0.41666666666667
44026, 0.10869565217391, 0.20217391304348, 0.44444444444444
44027, 0.08695652173913, 0.17608695652174, 0.44444444444444
44028, 0.08695652173913, 0.20217391304348, 0.47222222222222
44029, 0.043478260869565, 0.20217391304348, 0.027777777777778
44030, 0.065217391304348, 0.20217391304348, 0.055555555555556
44031, 0.043478260869565, 0.17608695652174, 0.055555555555556
44032, 0.043478260869565, 0.20217391304348, 0.083333333333333
44033, 0.065217391304348, 0.20217391304348, 0.11111111111111
44034, 0.043478260869565, 0.17608695652174, 0.11111111111111
44035, 0.043478260869565, 0.20217391304348, 0.13888888888889
44036, 0.065217391304348, 0.20217391304348, 0.16666666666667
44037, 0.043478260869565, 0.17608695652174, 0.16666666666667
44038, 0.043478260869565, 0.20217391304348, 0.19444444444444
44039, 0.065217391304348, 0.20217391304348, 0.22222222222222
44040, 0.043478260869565, 0.17608695652174, 0.22222222222222
44041, 0.043478260869565, 0.20217391304348, 0.25
44042, 0.065217391304348, 0.20217391304348, 0.27777777777778
44043, 0.043478260869565, 0.17608695652174, 0.27777777777778
44044, 0.043478260869565, 0.20217391304348, 0.30555555555556
44045, 0.065217391304348, 0.20217391304348, 0.33333333333333
44046, 0.043478260869565, 0.17608695652174, 0.33333333333333
44047, 0.043478260869565, 0.20217391304348, 0.36111111111111
44048, 0.065217391304348, 0.20217391304348, 0.38888888888889
44049, 0.043478260869565, 0.17608695652174, 0.38888888888889
44050, 0.043478260869565, 0.20217391304348, 0.41666666666667
44051, 0.065217391304348, 0.20217391304348, 0.44444444444444
44052, 0.043478260869565, 0.17608695652174, 0.44444444444444
44053, 0.043478260869565, 0.20217391304348, 0.47222222222222
44054, 0.021739130434783, 0.20217391304348, 0.055555555555556
44055, 0.021739130434783, 0.20217391304348, 0.11111111111111
44056, 0.021739130434783, 0.20217391304348, 0.16666666666667
44057, 0.021739130434783, 0.20217391304348, 0.22222222222222
44058, 0.021739130434783, 0.20217391304348, 0.27777777777778
44059, 0.021739130434783, 0.20217391304348, 0.33333333333333
44060, 0.021739130434783, 0.20217391304348, 0.38888888888889
44061, 0.021739130434783, 0.20217391304348, 0.44444444444444
44062, 0.95652173913043, 0.25434782608696, 0.027777777777778
44063, 0.97826086956522, 0.25434782608696, 0.055555555555556
44064, 0.95652173913043, 0.22826086956522, 0.055555555555556
44065, 0.95652173913043, 0.25434782608696, 0.083333333333333
44066, 0.97826086956522, 0.25434782608696, 0.11111111111111
44067, 0.95652173913044, 0.22826086956522, 0.11111111111111
44068, 0.95652173913044, 0.25434782608696, 0.13888888888889
44069, 0.97826086956522, 0.25434782608696, 0.16666666666667
44070, 0.95652173913044, 0.22826086956522, 0.16666666666667
44071, 0.95652173913043, 0.25434782608696, 0.19444444444444
44072, 0.97826086956522, 0.25434782608696, 0.22222222222222
44073, 0.95652173913044, 0.22826086956522, 0.22222222222222
44074, 0.95652173913043, 0.25434782608696, 0.25
44075, 0.97826086956522, 0.25434782608696, 0.27777777777778
44076, 0.95652173913043, 0.22826086956522, 0.27777777777778
44077, 0.95652173913043, 0.25434782608696, 0.30555555555556
44078, 0.97826086956522, 0.25434782608696, 0.33333333333333
44079, 0.95652173913044, 0.22826086956522, 0.33333333333333
44080, 0.95652173913043, 0.25434782608696, 0.36111111111111
44081, 0.97826086956522, 0.25434782608696, 0.38888888888889
44082, 0.95652173913043, 0.22826086956522, 0.38888888888889
44083, 0.95652173913043, 0.25434782608696, 0.41666666666667
44084, 0.97826086956522, 0.25434782608696, 0.44444444444444
44085, 0.95652173913043, 0.22826086956522, 0.44444444444444
44086, 0.95652173913043, 0.25434782608696, 0.47222222222222
44087, 0.91304347826087, 0.25434782608696, 0.027777777777778
44088, 0.93478260869565, 0.25434782608696, 0.055555555555556
44089, 0.91304347826087, 0.22826086956522, 0.055555555555556
44090, 0.91304347826087, 0.25434782608696, 0.083333333333333
44091, 0.93478260869565, 0.25434782608696, 0.11111111111111
44092, 0.91304347826087, 0.22826086956522, 0.11111111111111
44093, 0.91304347826087, 0.25434782608696, 0.13888888888889
44094, 0.93478260869565, 0.25434782608696, 0.16666666666667
44095, 0.91304347826087, 0.22826086956522, 0.16666666666667
44096, 0.91304347826087, 0.25434782608696, 0.19444444444444
44097, 0.93478260869565, 0.25434782608696, 0.22222222222222
44098, 0.91304347826087, 0.22826086956522, 0.22222222222222
44099, 0.91304347826087, 0.25434782608696, 0.25
44100, 0.93478260869565, 0.25434782608696, 0.27777777777778
44101, 0.91304347826087, 0.22826086956522, 0.27777777777778
44102, 0.91304347826087, 0.25434782608696, 0.30555555555556
44103, 0.93478260869565, 0.25434782608696, 0.33333333333333
44104, 0.91304347826087, 0.22826086956522, 0.33333333333333
44105, 0.91304347826087, 0.25434782608696, 0.36111111111111
44106, 0.93478260869565, 0.25434782608696, 0.38888888888889
44107, 0.91304347826087, 0.22826086956522, 0.38888888888889
44108, 0.91304347826087, 0.25434782608696, 0.41666666666667
44109, 0.93478260869565, 0.25434782608696, 0.44444444444444
44110, 0.91304347826087, 0.22826086956522, 0.44444444444444
44111, 0.91304347826087, 0.25434782608696, 0.47222222222222
44112, 0.8695652173913, 0.25434782608696, 0.027777777777778
44113, 0.89130434782609, 0.25434782608696, 0.055555555555556
44114, 0.8695652173913, 0.22826086956522, 0.055555555555556
44115, 0.8695652173913, 0.25434782608696, 0.083333333333333
44116, 0.89130434782609, 0.25434782608696, 0.11111111111111
44117, 0.8695652173913, 0.22826086956522, 0.11111111111111
44118, 0.8695652173913, 0.25434782608696, 0.13888888888889
44119, 0.89130434782609, 0.25434782608696, 0.16666666666667
44120, 0.8695652173913, 0.22826086956522, 0.16666666666667
44121, 0.8695652173913, 0.25434782608696, 0.19444444444444
44122, 0.89130434782609, 0.25434782608696, 0.22222222222222
44123, 0.8695652173913, 0.22826086956522, 0.22222222222222
44124, 0.8695652173913, 0.25434782608696, 0.25
44125, 0.89130434782609, 0.25434782608696, 0.27777777777778
44126, 0.8695652173913, 0.22826086956522, 0.27777777777778
44127, 0.8695652173913, 0.25434782608696, 0.30555555555556
44128, 0.89130434782609, 0.25434782608696, 0.33333333333333
44129, 0.8695652173913, 0.22826086956522, 0.33333333333333
44130, 0.8695652173913, 0.25434782608696, 0.36111111111111
44131, 0.89130434782609, 0.25434782608696, 0.38888888888889
44132, 0.8695652173913, 0.22826086956522, 0.38888888888889
44133, 0.8695652173913, 0.25434782608696, 0.41666666666667
44134, 0.89130434782609, 0.25434782608696, 0.44444444444444
44135, 0.8695652173913, 0.22826086956522, 0.44444444444444
44136, 0.8695652173913, 0.25434782608696, 0.47222222222222
44137, 0.82608695652174, 0.25434782608696, 0.027777777777778
44138, 0.84782608695652, 0.25434782608696, 0.055555555555556
44139, 0.82608695652174, 0.22826086956522, 0.055555555555556
44140, 0.82608695652174, 0.25434782608696, 0.083333333333333
44141, 0.84782608695652, 0.25434782608696, 0.11111111111111
44142, 0.82608695652174, 0.22826086956522, 0.11111111111111
44143, 0.82608695652174, 0.25434782608696, 0.13888888888889
44144, 0.84782608695652, 0.25434782608696, 0.16666666666667
44145, 0.82608695652174, 0.22826086956522, 0.16666666666667
44146, 0.82608695652174, 0.25434782608696, 0.19444444444444
44147, 0.84782608695652, 0.25434782608696, 0.22222222222222
44148, 0.82608695652174, 0.22826086956522, 0.22222222222222
44149, 0.82608695652174, 0.25434782608696, 0.25
44150, 0.84782608695652, 0.25434782608696, 0.27777777777778
44151, 0.82608695652174, 0.22826086956522, 0.27777777777778
44152, 0.82608695652174, 0.25434782608696, 0.30555555555556
44153, 0.84782608695652, 0.25434782608696, 0.33333333333333
44154, 0.82608695652174, 0.22826086956522, 0.33333333333333
44155, 0.82608695652174, 0.25434782608696, 0.36111111111111
44156, 0.84782608695652, 0.25434782608696, 0.38888888888889
44157, 0.82608695652174, 0.22826086956522, 0.38888888888889
44158, 0.82608695652174, 0.25434782608696, 0.41666666666667
44159, 0.84782608695652, 0.25434782608696, 0.44444444444444
44160, 0.82608695652174, 0.22826086956522, 0.44444444444444
44161, 0.82608695652174, 0.25434782608696, 0.47222222222222
44162, 0.78260869565217, 0.25434782608696, 0.027777777777778
44163, 0.80434782608696, 0.25434782608696, 0.055555555555556
44164, 0.78260869565217, 0.22826086956522, 0.055555555555556
44165, 0.78260869565217, 0.25434782608696, 0.083333333333333
44166, 0.80434782608696, 0.25434782608696, 0.11111111111111
44167, 0.78260869565217, 0.22826086956522, 0.11111111111111
44168, 0.78260869565217, 0.25434782608696, 0.13888888888889
44169, 0.80434782608696, 0.25434782608696, 0.16666666666667
44170, 0.78260869565217, 0.22826086956522, 0.16666666666667
44171, 0.78260869565217, 0.25434782608696, 0.19444444444444
44172, 0.80434782608696, 0.25434782608696, 0.22222222222222
44173, 0.78260869565217, 0.22826086956522, 0.22222222222222
44174, 0.78260869565217, 0.25434782608696, 0.25
44175, 0.80434782608696, 0.25434782608696, 0.27777777777778
44176, 0.78260869565217, 0.22826086956522, 0.27777777777778
44177, 0.78260869565217, 0.25434782608696, 0.30555555555556
44178, 0.80434782608696, 0.25434782608696, 0.33333333333333
44179, 0.78260869565217, 0.22826086956522, 0.33333333333333
44180, 0.78260869565217, 0.25434782608696, 0.36111111111111
44181, 0.80434782608696, 0.25434782608696, 0.38888888888889
44182, 0.78260869565217, 0.22826086956522, 0.38888888888889
44183, 0.78260869565217, 0.25434782608696, 0.41666666666667
44184, 0.80434782608696, 0.25434782608696, 0.44444444444444
44185, 0.78260869565217, 0.22826086956522, 0.44444444444444
44186, 0.78260869565217, 0.25434782608696, 0.47222222222222
44187, 0.73913043478261, 0.25434782608696, 0.027777777777778
44188, 0.76086956521739, 0.25434782608696, 0.055555555555556
44189, 0.73913043478261, 0.22826086956522, 0.055555555555556
44190, 0.73913043478261, 0.25434782608696, 0.083333333333333
44191, 0.76086956521739, 0.25434782608696, 0.11111111111111
44192, 0.73913043478261, 0.22826086956522, 0.11111111111111
44193, 0.73913043478261, 0.25434782608696, 0.13888888888889
44194, 0.76086956521739, 0.25434782608696, 0.16666666666667
44195, 0.73913043478261, 0.22826086956522, 0.16666666666667
44196, 0.73913043478261, 0.25434782608696, 0.19444444444444
44197, 0.76086956521739, 0.25434782608696, 0.22222222222222
44198, 0.73913043478261, 0.22826086956522, 0.22222222222222
44199, 0.73913043478261, 0.25434782608696, 0.25
44200, 0.76086956521739, 0.25434782608696, 0.27777777777778
44201, 0.73913043478261, 0.22826086956522, 0.27777777777778
44202, 0.73913043478261, 0.25434782608696, 0.30555555555556
44203, 0.76086956521739, 0.25434782608696, 0.33333333333333
44204, 0.73913043478261, 0.22826086956522, 0.33333333333333
44205, 0.73913043478261, 0.25434782608696, 0.36111111111111
44206, 0.76086956521739, 0.25434782608696, 0.38888888888889
44207, 0.73913043478261, 0.22826086956522, 0.38888888888889
44208, 0.73913043478261, 0.25434782608696, 0.41666666666667
44209, 0.76086956521739, 0.25434782608696, 0.44444444444444
44210, 0.73913043478261, 0.22826086956522, 0.44444444444444
44211, 0.73913043478261, 0.25434782608696, 0.47222222222222
44212, 0.69565217391304, 0.25434782608696, 0.027777777777778
44213, 0.71739130434783, 0.25434782608696, 0.055555555555556
44214, 0.69565217391304, 0.22826086956522, 0.055555555555556
44215, 0.69565217391304, 0.25434782608696, 0.083333333333333
44216, 0.71739130434783, 0.25434782608696, 0.11111111111111
44217, 0.69565217391304, 0.22826086956522, 0.11111111111111
44218, 0.69565217391304, 0.25434782608696, 0.13888888888889
44219, 0.71739130434783, 0.25434782608696, 0.16666666666667
44220, 0.69565217391304, 0.22826086956522, 0.16666666666667
44221, 0.69565217391304, 0.25434782608696, 0.19444444444444
44222, 0.71739130434783, 0.25434782608696, 0.22222222222222
44223, 0.69565217391304, 0.22826086956522, 0.22222222222222
44224, 0.69565217391304, 0.25434782608696, 0.25
44225, 0.71739130434783, 0.25434782608696, 0.27777777777778
44226, 0.69565217391304, 0.22826086956522, 0.27777777777778
44227, 0.69565217391304, 0.25434782608696, 0.30555555555556
44228, 0.71739130434783, 0.25434782608696, 0.33333333333333
44229, 0.69565217391304, 0.22826086956522, 0.33333333333333
44230, 0.69565217391304, 0.25434782608696, 0.36111111111111
44231, 0.71739130434783, 0.25434782608696, 0.38888888888889
44232, 0.69565217391304, 0.22826086956522, 0.38888888888889
44233, 0.69565217391304, 0.25434782608696, 0.41666666666667
44234, 0.71739130434783, 0.25434782608696, 0.44444444444444
44235, 0.69565217391304, 0.22826086956522, 0.44444444444444
44236, 0.69565217391304, 0.25434782608696, 0.47222222222222
44237, 0.65217391304348, 0.25434782608696, 0.027777777777778
44238, 0.67391304347826, 0.25434782608696, 0.055555555555556
44239, 0.65217391304348, 0.22826086956522, 0.055555555555556
44240, 0.65217391304348, 0.25434782608696, 0.083333333333333
44241, 0.67391304347826, 0.25434782608696, 0.11111111111111
44242, 0.65217391304348, 0.22826086956522, 0.11111111111111
44243, 0.65217391304348, 0.25434782608696, 0.13888888888889
44244, 0.67391304347826, 0.25434782608696, 0.16666666666667
44245, 0.65217391304348, 0.22826086956522, 0.16666666666667
44246, 0.65217391304348, 0.25434782608696, 0.19444444444444
44247, 0.67391304347826, 0.25434782608696, 0.22222222222222
44248, 0.65217391304348, 0.22826086956522, 0.22222222222222
44249, 0.65217391304348, 0.25434782608696, 0.25
44250, 0.67391304347826, 0.25434782608696, 0.27777777777778
44251, 0.65217391304348, 0.22826086956522, 0.27777777777778
44252, 0.65217391304348, 0.25434782608696, 0.30555555555556
44253, 0.67391304347826, 0.25434782608696, 0.33333333333333
44254, 0.65217391304348, 0.22826086956522, 0.33333333333333
44255, 0.65217391304348, 0.25434782608696, 0.36111111111111
44256, 0.67391304347826, 0.25434782608696, 0.38888888888889
44257, 0.65217391304348, 0.22826086956522, 0.38888888888889
44258, 0.65217391304348, 0.25434782608696, 0.41666666666667
44259, 0.67391304347826, 0.25434782608696, 0.44444444444444
44260, 0.65217391304348, 0.22826086956522, 0.44444444444444
44261, 0.65217391304348, 0.25434782608696, 0.47222222222222
44262, 0.60869565217391, 0.25434782608696, 0.027777777777778
44263, 0.6304347826087, 0.25434782608696, 0.055555555555556
44264, 0.60869565217391, 0.22826086956522, 0.055555555555556
44265, 0.60869565217391, 0.25434782608696, 0.083333333333333
44266, 0.6304347826087, 0.25434782608696, 0.11111111111111
44267, 0.60869565217391, 0.22826086956522, 0.11111111111111
44268, 0.60869565217391, 0.25434782608696, 0.13888888888889
44269, 0.6304347826087, 0.25434782608696, 0.16666666666667
44270, 0.60869565217391, 0.22826086956522, 0.16666666666667
44271, 0.60869565217391, 0.25434782608696, 0.19444444444444
44272, 0.6304347826087, 0.25434782608696, 0.22222222222222
44273, 0.60869565217391, 0.22826086956522, 0.22222222222222
44274, 0.60869565217391, 0.25434782608696, 0.25
44275, 0.6304347826087, 0.25434782608696, 0.27777777777778
44276, 0.60869565217391, 0.22826086956522, 0.27777777777778
44277, 0.60869565217391, 0.25434782608696, 0.30555555555556
44278, 0.6304347826087, 0.25434782608696, 0.33333333333333
44279, 0.60869565217391, 0.22826086956522, 0.33333333333333
44280, 0.60869565217391, 0.25434782608696, 0.36111111111111
44281, 0.6304347826087, 0.25434782608696, 0.38888888888889
44282, 0.60869565217391, 0.22826086956522, 0.38888888888889
44283, 0.60869565217391, 0.25434782608696, 0.41666666666667
44284, 0.6304347826087, 0.25434782608696, 0.44444444444444
44285, 0.60869565217391, 0.22826086956522, 0.44444444444444
44286, 0.60869565217391, 0.25434782608696, 0.47222222222222
44287, 0.56521739130435, 0.25434782608696, 0.027777777777778
44288, 0.58695652173913, 0.25434782608696, 0.055555555555556
44289, 0.56521739130435, 0.22826086956522, 0.055555555555556
44290, 0.56521739130435, 0.25434782608696, 0.083333333333333
44291, 0.58695652173913, 0.25434782608696, 0.11111111111111
44292, 0.56521739130435, 0.22826086956522, 0.11111111111111
44293, 0.56521739130435, 0.25434782608696, 0.13888888888889
44294, 0.58695652173913, 0.25434782608696, 0.16666666666667
44295, 0.56521739130435, 0.22826086956522, 0.16666666666667
44296, 0.56521739130435, 0.25434782608696, 0.19444444444444
44297, 0.58695652173913, 0.25434782608696, 0.22222222222222
44298, 0.56521739130435, 0.22826086956522, 0.22222222222222
44299, 0.56521739130435, 0.25434782608696, 0.25
44300, 0.58695652173913, 0.25434782608696, 0.27777777777778
44301, 0.56521739130435, 0.22826086956522, 0.27777777777778
44302, 0.56521739130435, 0.25434782608696, 0.30555555555556
44303, 0.58695652173913, 0.25434782608696, 0.33333333333333
44304, 0.56521739130435, 0.22826086956522, 0.33333333333333
44305, 0.56521739130435, 0.25434782608696, 0.36111111111111
44306, 0.58695652173913, 0.25434782608696, 0.38888888888889
44307, 0.56521739130435, 0.22826086956522, 0.38888888888889
44308, 0.56521739130435, 0.25434782608696, 0.41666666666667
44309, 0.58695652173913, 0.25434782608696, 0.44444444444444
44310, 0.56521739130435, 0.22826086956522, 0.44444444444444
44311, 0.56521739130435, 0.25434782608696, 0.47222222222222
44312, 0.52173913043478, 0.25434782608696, 0.027777777777778
44313, 0.54347826086957, 0.25434782608696, 0.055555555555556
44314, 0.52173913043478, 0.22826086956522, 0.055555555555556
44315, 0.52173913043478, 0.25434782608696, 0.083333333333333
44316, 0.54347826086957, 0.25434782608696, 0.11111111111111
44317, 0.52173913043478, 0.22826086956522, 0.11111111111111
44318, 0.52173913043478, 0.25434782608696, 0.13888888888889
44319, 0.54347826086957, 0.25434782608696, 0.16666666666667
44320, 0.52173913043478, 0.22826086956522, 0.16666666666667
44321, 0.52173913043478, 0.25434782608696, 0.19444444444444
44322, 0.54347826086956, 0.25434782608696, 0.22222222222222
44323, 0.52173913043478, 0.22826086956522, 0.22222222222222
44324, 0.52173913043478, 0.25434782608696, 0.25
44325, 0.54347826086956, 0.25434782608696, 0.27777777777778
44326, 0.52173913043478, 0.22826086956522, 0.27777777777778
44327, 0.52173913043478, 0.25434782608696, 0.30555555555556
44328, 0.54347826086956, 0.25434782608696, 0.33333333333333
44329, 0.52173913043478, 0.22826086956522, 0.33333333333333
44330, 0.52173913043478, 0.25434782608696, 0.36111111111111
44331, 0.54347826086956, 0.25434782608696, 0.38888888888889
44332, 0.52173913043478, 0.22826086956522, 0.38888888888889
44333, 0.52173913043478, 0.25434782608696, 0.41666666666667
44334, 0.54347826086956, 0.25434782608696, 0.44444444444444
44335, 0.52173913043478, 0.22826086956522, 0.44444444444444
44336, 0.52173913043478, 0.25434782608696, 0.47222222222222
44337, 0.47826086956522, 0.25434782608696, 0.027777777777778
44338, 0.5, 0.25434782608696, 0.055555555555556
44339, 0.47826086956522, 0.22826086956522, 0.055555555555556
44340, 0.47826086956522, 0.25434782608696, 0.083333333333333
44341, 0.5, 0.25434782608696, 0.11111111111111
44342, 0.47826086956522, 0.22826086956522, 0.11111111111111
44343, 0.47826086956522, 0.25434782608696, 0.13888888888889
44344, 0.5, 0.25434782608696, 0.16666666666667
44345, 0.47826086956522, 0.22826086956522, 0.16666666666667
44346, 0.47826086956522, 0.25434782608696, 0.19444444444444
44347, 0.5, 0.25434782608696, 0.22222222222222
44348, 0.47826086956522, 0.22826086956522, 0.22222222222222
44349, 0.47826086956522, 0.25434782608696, 0.25
44350, 0.5, 0.25434782608696, 0.27777777777778
44351, 0.47826086956522, 0.22826086956522, 0.27777777777778
44352, 0.47826086956522, 0.25434782608696, 0.30555555555556
44353, 0.5, 0.25434782608696, 0.33333333333333
44354, 0.47826086956522, 0.22826086956522, 0.33333333333333
44355, 0.47826086956522, 0.25434782608696, 0.36111111111111
44356, 0.5, 0.25434782608696, 0.38888888888889
44357, 0.47826086956522, 0.22826086956522, 0.38888888888889
44358, 0.47826086956522, 0.25434782608696, 0.41666666666667
44359, 0.5, 0.25434782608696, 0.44444444444444
44360, 0.47826086956522, 0.22826086956522, 0.44444444444444
44361, 0.47826086956522, 0.25434782608696, 0.47222222222222
44362, 0.43478260869565, 0.25434782608696, 0.027777777777778
44363, 0.45652173913043, 0.25434782608696, 0.055555555555556
44364, 0.43478260869565, 0.22826086956522, 0.055555555555556
44365, 0.43478260869565, 0.25434782608696, 0.083333333333333
44366, 0.45652173913044, 0.25434782608696, 0.11111111111111
44367, 0.43478260869565, 0.22826086956522, 0.11111111111111
44368, 0.43478260869565, 0.25434782608696, 0.13888888888889
44369, 0.45652173913043, 0.25434782608696, 0.16666666666667
44370, 0.43478260869565, 0.22826086956522, 0.16666666666667
44371, 0.43478260869565, 0.25434782608696, 0.19444444444444
44372, 0.45652173913043, 0.25434782608696, 0.22222222222222
44373, 0.43478260869565, 0.22826086956522, 0.22222222222222
44374, 0.43478260869565, 0.25434782608696, 0.25
44375, 0.45652173913043, 0.25434782608696, 0.27777777777778
44376, 0.43478260869565, 0.22826086956522, 0.27777777777778
44377, 0.43478260869565, 0.25434782608696, 0.30555555555556
44378, 0.45652173913043, 0.25434782608696, 0.33333333333333
44379, 0.43478260869565, 0.22826086956522, 0.33333333333333
44380, 0.43478260869565, 0.25434782608696, 0.36111111111111
44381, 0.45652173913044, 0.25434782608696, 0.38888888888889
44382, 0.43478260869565, 0.22826086956522, 0.38888888888889
44383, 0.43478260869565, 0.25434782608696, 0.41666666666667
44384, 0.45652173913043, 0.25434782608696, 0.44444444444444
44385, 0.43478260869565, 0.22826086956522, 0.44444444444444
44386, 0.43478260869565, 0.25434782608696, 0.47222222222222
44387, 0.39130434782609, 0.25434782608696, 0.027777777777778
44388, 0.41304347826087, 0.25434782608696, 0.055555555555556
44389, 0.39130434782609, 0.22826086956522, 0.055555555555556
44390, 0.39130434782609, 0.25434782608696, 0.083333333333333
44391, 0.41304347826087, 0.25434782608696, 0.11111111111111
44392, 0.39130434782609, 0.22826086956522, 0.11111111111111
44393, 0.39130434782609, 0.25434782608696, 0.13888888888889
44394, 0.41304347826087, 0.25434782608696, 0.16666666666667
44395, 0.39130434782609, 0.22826086956522, 0.16666666666667
44396, 0.39130434782609, 0.25434782608696, 0.19444444444444
44397, 0.41304347826087, 0.25434782608696, 0.22222222222222
44398, 0.39130434782609, 0.22826086956522, 0.22222222222222
44399, 0.39130434782609, 0.25434782608696, 0.25
44400, 0.41304347826087, 0.25434782608696, 0.27777777777778
44401, 0.39130434782609, 0.22826086956522, 0.27777777777778
44402, 0.39130434782609, 0.25434782608696, 0.30555555555556
44403, 0.41304347826087, 0.25434782608696, 0.33333333333333
44404, 0.39130434782609, 0.22826086956522, 0.33333333333333
44405, 0.39130434782609, 0.25434782608696, 0.36111111111111
44406, 0.41304347826087, 0.25434782608696, 0.38888888888889
44407, 0.39130434782609, 0.22826086956522, 0.38888888888889
44408, 0.39130434782609, 0.25434782608696, 0.41666666666667
44409, 0.41304347826087, 0.25434782608696, 0.44444444444444
44410, 0.39130434782609, 0.22826086956522, 0.44444444444444
44411, 0.39130434782609, 0.25434782608696, 0.47222222222222
44412, 0.34782608695652, 0.25434782608696, 0.027777777777778
44413, 0.3695652173913, 0.25434782608696, 0.055555555555556
44414, 0.34782608695652, 0.22826086956522, 0.055555555555556
44415, 0.34782608695652, 0.25434782608696, 0.083333333333333
44416, 0.3695652173913, 0.25434782608696, 0.11111111111111
44417, 0.34782608695652, 0.22826086956522, 0.11111111111111
44418, 0.34782608695652, 0.25434782608696, 0.13888888888889
44419, 0.3695652173913, 0.25434782608696, 0.16666666666667
44420, 0.34782608695652, 0.22826086956522, 0.16666666666667
44421, 0.34782608695652, 0.25434782608696, 0.19444444444444
44422, 0.3695652173913, 0.25434782608696, 0.22222222222222
44423, 0.34782608695652, 0.22826086956522, 0.22222222222222
44424, 0.34782608695652, 0.25434782608696, 0.25
44425, 0.3695652173913, 0.25434782608696, 0.27777777777778
44426, 0.34782608695652, 0.22826086956522, 0.27777777777778
44427, 0.34782608695652, 0.25434782608696, 0.30555555555556
44428, 0.3695652173913, 0.25434782608696, 0.33333333333333
44429, 0.34782608695652, 0.22826086956522, 0.33333333333333
44430, 0.34782608695652, 0.25434782608696, 0.36111111111111
44431, 0.3695652173913, 0.25434782608696, 0.38888888888889
44432, 0.34782608695652, 0.22826086956522, 0.38888888888889
44433, 0.34782608695652, 0.25434782608696, 0.41666666666667
44434, 0.3695652173913, 0.25434782608696, 0.44444444444444
44435, 0.34782608695652, 0.22826086956522, 0.44444444444444
44436, 0.34782608695652, 0.25434782608696, 0.47222222222222
44437, 0.30434782608696, 0.25434782608696, 0.027777777777778
44438, 0.32608695652174, 0.25434782608696, 0.055555555555556
44439, 0.30434782608696, 0.22826086956522, 0.055555555555556
44440, 0.30434782608696, 0.25434782608696, 0.083333333333333
44441, 0.32608695652174, 0.25434782608696, 0.11111111111111
44442, 0.30434782608696, 0.22826086956522, 0.11111111111111
44443, 0.30434782608696, 0.25434782608696, 0.13888888888889
44444, 0.32608695652174, 0.25434782608696, 0.16666666666667
44445, 0.30434782608696, 0.22826086956522, 0.16666666666667
44446, 0.30434782608696, 0.25434782608696, 0.19444444444444
44447, 0.32608695652174, 0.25434782608696, 0.22222222222222
44448, 0.30434782608696, 0.22826086956522, 0.22222222222222
44449, 0.30434782608696, 0.25434782608696, 0.25
44450, 0.32608695652174, 0.25434782608696, 0.27777777777778
44451, 0.30434782608696, 0.22826086956522, 0.27777777777778
44452, 0.30434782608696, 0.25434782608696, 0.30555555555556
44453, 0.32608695652174, 0.25434782608696, 0.33333333333333
44454, 0.30434782608696, 0.22826086956522, 0.33333333333333
44455, 0.30434782608696, 0.25434782608696, 0.36111111111111
44456, 0.32608695652174, 0.25434782608696, 0.38888888888889
44457, 0.30434782608696, 0.22826086956522, 0.38888888888889
44458, 0.30434782608696, 0.25434782608696, 0.41666666666667
44459, 0.32608695652174, 0.25434782608696, 0.44444444444444
44460, 0.30434782608696, 0.22826086956522, 0.44444444444444
44461, 0.30434782608696, 0.25434782608696, 0.47222222222222
44462, 0.26086956521739, 0.25434782608696, 0.027777777777778
44463, 0.28260869565217, 0.25434782608696, 0.055555555555556
44464, 0.26086956521739, 0.22826086956522, 0.055555555555556
44465, 0.26086956521739, 0.25434782608696, 0.083333333333333
44466, 0.28260869565217, 0.25434782608696, 0.11111111111111
44467, 0.26086956521739, 0.22826086956522, 0.11111111111111
44468, 0.26086956521739, 0.25434782608696, 0.13888888888889
44469, 0.28260869565217, 0.25434782608696, 0.16666666666667
44470, 0.26086956521739, 0.22826086956522, 0.16666666666667
44471, 0.26086956521739, 0.25434782608696, 0.19444444444444
44472, 0.28260869565217, 0.25434782608696, 0.22222222222222
44473, 0.26086956521739, 0.22826086956522, 0.22222222222222
44474, 0.26086956521739, 0.25434782608696, 0.25
44475, 0.28260869565217, 0.25434782608696, 0.27777777777778
44476, 0.26086956521739, 0.22826086956522, 0.27777777777778
44477, 0.26086956521739, 0.25434782608696, 0.30555555555556
44478, 0.28260869565217, 0.25434782608696, 0.33333333333333
44479, 0.26086956521739, 0.22826086956522, 0.33333333333333
44480, 0.26086956521739, 0.25434782608696, 0.36111111111111
44481, 0.28260869565217, 0.25434782608696, 0.38888888888889
44482, 0.26086956521739, 0.22826086956522, 0.38888888888889
44483, 0.26086956521739, 0.25434782608696, 0.41666666666667
44484, 0.28260869565217, 0.25434782608696, 0.44444444444444
44485, 0.26086956521739, 0.22826086956522, 0.44444444444444
44486, 0.26086956521739, 0.25434782608696, 0.47222222222222
44487, 0.21739130434783, 0.25434782608696, 0.027777777777778
44488, 0.23913043478261, 0.25434782608696, 0.055555555555556
44489, 0.21739130434783, 0.22826086956522, 0.055555555555556
44490, 0.21739130434783, 0.25434782608696, 0.083333333333333
44491, 0.23913043478261, 0.25434782608696, 0.11111111111111
44492, 0.21739130434783, 0.22826086956522, 0.11111111111111
44493, 0.21739130434783, 0.25434782608696, 0.13888888888889
44494, 0.23913043478261, 0.25434782608696, 0.16666666666667
44495, 0.21739130434783, 0.22826086956522, 0.16666666666667
44496, 0.21739130434783, 0.25434782608696, 0.19444444444444
44497, 0.23913043478261, 0.25434782608696, 0.22222222222222
44498, 0.21739130434783, 0.22826086956522, 0.22222222222222
44499, 0.21739130434783, 0.25434782608696, 0.25
44500, 0.23913043478261, 0.25434782608696, 0.27777777777778
44501, 0.21739130434783, 0.22826086956522, 0.27777777777778
44502, 0.21739130434783, 0.25434782608696, 0.30555555555556
44503, 0.23913043478261, 0.25434782608696, 0.33333333333333
44504, 0.21739130434783, 0.22826086956522, 0.33333333333333
44505, 0.21739130434783, 0.25434782608696, 0.36111111111111
44506, 0.23913043478261, 0.25434782608696, 0.38888888888889
44507, 0.21739130434783, 0.22826086956522, 0.38888888888889
44508, 0.21739130434783, 0.25434782608696, 0.41666666666667
44509, 0.23913043478261, 0.25434782608696, 0.44444444444444
44510, 0.21739130434783, 0.22826086956522, 0.44444444444444
44511, 0.21739130434783, 0.25434782608696, 0.47222222222222
44512, 0.17391304347826, 0.25434782608696, 0.027777777777778
44513, 0.19565217391304, 0.25434782608696, 0.055555555555556
44514, 0.17391304347826, 0.22826086956522, 0.055555555555556
44515, 0.17391304347826, 0.25434782608696, 0.083333333333333
44516, 0.19565217391304, 0.25434782608696, 0.11111111111111
