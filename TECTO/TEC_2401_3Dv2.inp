*ELEMENT, type=T3D3, ELSET=Line315
794, 32, 1394, 1393
795, 1393, 1395, 43
*ELEMENT, type=T3D3, ELSET=Line316
796, 42, 1399, 1396
797, 1396, 1400, 1397
798, 1397, 1401, 1398
799, 1398, 1402, 44
*ELEMENT, type=T3D3, ELSET=Line317
800, 34, 1404, 1403
801, 1403, 1405, 44
*ELEMENT, type=T3D3, ELSET=Line318
802, 44, 1414, 1406
803, 1406, 1415, 1407
804, 1407, 1416, 1408
805, 1408, 1417, 1409
806, 1409, 1418, 1410
807, 1410, 1419, 1411
808, 1411, 1420, 1412
809, 1412, 1421, 1413
810, 1413, 1422, 43
*ELEMENT, type=T3D3, ELSET=Line319
811, 45, 1425, 1423
812, 1423, 1426, 1424
813, 1424, 1427, 46
*ELEMENT, type=T3D3, ELSET=Line320
814, 47, 1430, 1428
815, 1428, 1431, 1429
816, 1429, 1432, 48
*ELEMENT, type=T3D3, ELSET=Line321
817, 47, 1455, 1433
818, 1433, 1456, 1434
819, 1434, 1457, 1435
820, 1435, 1458, 1436
821, 1436, 1459, 1437
822, 1437, 1460, 1438
823, 1438, 1461, 1439
824, 1439, 1462, 1440
825, 1440, 1463, 1441
826, 1441, 1464, 1442
827, 1442, 1465, 1443
828, 1443, 1466, 1444
829, 1444, 1467, 1445
830, 1445, 1468, 1446
831, 1446, 1469, 1447
832, 1447, 1470, 1448
833, 1448, 1471, 1449
834, 1449, 1472, 1450
835, 1450, 1473, 1451
836, 1451, 1474, 1452
837, 1452, 1475, 1453
838, 1453, 1476, 1454
839, 1454, 1477, 45
*ELEMENT, type=T3D3, ELSET=Line322
840, 48, 1500, 1478
841, 1478, 1501, 1479
842, 1479, 1502, 1480
843, 1480, 1503, 1481
844, 1481, 1504, 1482
845, 1482, 1505, 1483
846, 1483, 1506, 1484
847, 1484, 1507, 1485
848, 1485, 1508, 1486
849, 1486, 1509, 1487
850, 1487, 1510, 1488
851, 1488, 1511, 1489
852, 1489, 1512, 1490
853, 1490, 1513, 1491
854, 1491, 1514, 1492
855, 1492, 1515, 1493
856, 1493, 1516, 1494
857, 1494, 1517, 1495
858, 1495, 1518, 1496
859, 1496, 1519, 1497
860, 1497, 1520, 1498
861, 1498, 1521, 1499
862, 1499, 1522, 46
*ELEMENT, type=T3D3, ELSET=Line323
863, 49, 1525, 1523
864, 1523, 1526, 1524
865, 1524, 1527, 50
*ELEMENT, type=T3D3, ELSET=Line324
866, 45, 1536, 1528
867, 1528, 1537, 1529
868, 1529, 1538, 1530
869, 1530, 1539, 1531
870, 1531, 1540, 1532
871, 1532, 1541, 1533
872, 1533, 1542, 1534
873, 1534, 1543, 1535
874, 1535, 1544, 49
*ELEMENT, type=T3D3, ELSET=Line325
875, 46, 1553, 1545
876, 1545, 1554, 1546
877, 1546, 1555, 1547
878, 1547, 1556, 1548
879, 1548, 1557, 1549
880, 1549, 1558, 1550
881, 1550, 1559, 1551
882, 1551, 1560, 1552
883, 1552, 1561, 50
*ELEMENT, type=T3D3, ELSET=Line326
884, 51, 1564, 1562
885, 1562, 1565, 1563
886, 1563, 1566, 52
*ELEMENT, type=T3D3, ELSET=Line327
887, 51, 1589, 1567
888, 1567, 1590, 1568
889, 1568, 1591, 1569
890, 1569, 1592, 1570
891, 1570, 1593, 1571
892, 1571, 1594, 1572
893, 1572, 1595, 1573
894, 1573, 1596, 1574
895, 1574, 1597, 1575
896, 1575, 1598, 1576
897, 1576, 1599, 1577
898, 1577, 1600, 1578
899, 1578, 1601, 1579
900, 1579, 1602, 1580
901, 1580, 1603, 1581
902, 1581, 1604, 1582
903, 1582, 1605, 1583
904, 1583, 1606, 1584
905, 1584, 1607, 1585
906, 1585, 1608, 1586
907, 1586, 1609, 1587
908, 1587, 1610, 1588
909, 1588, 1611, 49
*ELEMENT, type=T3D3, ELSET=Line328
910, 52, 1634, 1612
911, 1612, 1635, 1613
912, 1613, 1636, 1614
913, 1614, 1637, 1615
914, 1615, 1638, 1616
915, 1616, 1639, 1617
916, 1617, 1640, 1618
917, 1618, 1641, 1619
918, 1619, 1642, 1620
919, 1620, 1643, 1621
920, 1621, 1644, 1622
921, 1622, 1645, 1623
922, 1623, 1646, 1624
923, 1624, 1647, 1625
924, 1625, 1648, 1626
925, 1626, 1649, 1627
926, 1627, 1650, 1628
927, 1628, 1651, 1629
928, 1629, 1652, 1630
929, 1630, 1653, 1631
930, 1631, 1654, 1632
931, 1632, 1655, 1633
932, 1633, 1656, 50
*ELEMENT, type=T3D3, ELSET=Line329
933, 47, 1665, 1657
934, 1657, 1666, 1658
935, 1658, 1667, 1659
936, 1659, 1668, 1660
937, 1660, 1669, 1661
938, 1661, 1670, 1662
939, 1662, 1671, 1663
940, 1663, 1672, 1664
941, 1664, 1673, 51
*ELEMENT, type=T3D3, ELSET=Line330
942, 48, 1682, 1674
943, 1674, 1683, 1675
944, 1675, 1684, 1676
945, 1676, 1685, 1677
946, 1677, 1686, 1678
947, 1678, 1687, 1679
948, 1679, 1688, 1680
949, 1680, 1689, 1681
950, 1681, 1690, 52
*ELEMENT, type=T3D3, ELSET=Line331
951, 49, 1694, 1691
952, 1691, 1695, 1692
953, 1692, 1696, 1693
954, 1693, 1697, 53
*ELEMENT, type=T3D3, ELSET=Line332
955, 50, 1701, 1698
956, 1698, 1702, 1699
957, 1699, 1703, 1700
958, 1700, 1704, 54
*ELEMENT, type=T3D3, ELSET=Line333
959, 53, 1707, 1705
960, 1705, 1708, 1706
961, 1706, 1709, 54
*ELEMENT, type=T3D3, ELSET=Line334
962, 45, 1713, 1710
963, 1710, 1714, 1711
964, 1711, 1715, 1712
965, 1712, 1716, 55
*ELEMENT, type=T3D3, ELSET=Line335
966, 46, 1720, 1717
967, 1717, 1721, 1718
968, 1718, 1722, 1719
969, 1719, 1723, 56
*ELEMENT, type=T3D3, ELSET=Line336
970, 55, 1726, 1724
971, 1724, 1727, 1725
972, 1725, 1728, 56
*ELEMENT, type=T3D3, ELSET=Line337
973, 55, 1737, 1729
974, 1729, 1738, 1730
975, 1730, 1739, 1731
976, 1731, 1740, 1732
977, 1732, 1741, 1733
978, 1733, 1742, 1734
979, 1734, 1743, 1735
980, 1735, 1744, 1736
981, 1736, 1745, 53
*ELEMENT, type=T3D3, ELSET=Line338
982, 56, 1754, 1746
983, 1746, 1755, 1747
984, 1747, 1756, 1748
985, 1748, 1757, 1749
986, 1749, 1758, 1750
987, 1750, 1759, 1751
988, 1751, 1760, 1752
989, 1752, 1761, 1753
990, 1753, 1762, 54
*ELEMENT, type=T3D3, ELSET=Line339
991, 50, 1766, 1763
992, 1763, 1767, 1764
993, 1764, 1768, 1765
994, 1765, 1769, 57
*ELEMENT, type=T3D3, ELSET=Line340
995, 54, 1773, 1770
996, 1770, 1774, 1771
997, 1771, 1775, 1772
998, 1772, 1776, 58
*ELEMENT, type=T3D3, ELSET=Line341
999, 57, 1780, 1777
1000, 1777, 1781, 1778
1001, 1778, 1782, 1779
1002, 1779, 1783, 58
*ELEMENT, type=T3D3, ELSET=Line342
1003, 46, 1787, 1784
1004, 1784, 1788, 1785
1005, 1785, 1789, 1786
1006, 1786, 1790, 59
*ELEMENT, type=T3D3, ELSET=Line343
1007, 56, 1794, 1791
1008, 1791, 1795, 1792
1009, 1792, 1796, 1793
1010, 1793, 1797, 60
*ELEMENT, type=T3D3, ELSET=Line344
1011, 59, 1801, 1798
1012, 1798, 1802, 1799
1013, 1799, 1803, 1800
1014, 1800, 1804, 60
*ELEMENT, type=T3D3, ELSET=Line345
1015, 59, 1813, 1805
1016, 1805, 1814, 1806
1017, 1806, 1815, 1807
1018, 1807, 1816, 1808
1019, 1808, 1817, 1809
1020, 1809, 1818, 1810
1021, 1810, 1819, 1811
1022, 1811, 1820, 1812
1023, 1812, 1821, 57
*ELEMENT, type=T3D3, ELSET=Line346
1024, 60, 1830, 1822
1025, 1822, 1831, 1823
1026, 1823, 1832, 1824
1027, 1824, 1833, 1825
1028, 1825, 1834, 1826
1029, 1826, 1835, 1827
1030, 1827, 1836, 1828
1031, 1828, 1837, 1829
1032, 1829, 1838, 58
*ELEMENT, type=T3D3, ELSET=Line347
1033, 48, 1842, 1839
1034, 1839, 1843, 1840
1035, 1840, 1844, 1841
1036, 1841, 1845, 61
*ELEMENT, type=T3D3, ELSET=Line348
1037, 61, 1868, 1846
1038, 1846, 1869, 1847
1039, 1847, 1870, 1848
1040, 1848, 1871, 1849
1041, 1849, 1872, 1850
1042, 1850, 1873, 1851
1043, 1851, 1874, 1852
1044, 1852, 1875, 1853
1045, 1853, 1876, 1854
1046, 1854, 1877, 1855
1047, 1855, 1878, 1856
1048, 1856, 1879, 1857
1049, 1857, 1880, 1858
1050, 1858, 1881, 1859
1051, 1859, 1882, 1860
1052, 1860, 1883, 1861
1053, 1861, 1884, 1862
1054, 1862, 1885, 1863
1055, 1863, 1886, 1864
1056, 1864, 1887, 1865
1057, 1865, 1888, 1866
1058, 1866, 1889, 1867
1059, 1867, 1890, 59
*ELEMENT, type=T3D3, ELSET=Line349
1060, 52, 1894, 1891
1061, 1891, 1895, 1892
1062, 1892, 1896, 1893
1063, 1893, 1897, 62
*ELEMENT, type=T3D3, ELSET=Line350
1064, 62, 1920, 1898
1065, 1898, 1921, 1899
1066, 1899, 1922, 1900
1067, 1900, 1923, 1901
1068, 1901, 1924, 1902
1069, 1902, 1925, 1903
1070, 1903, 1926, 1904
1071, 1904, 1927, 1905
1072, 1905, 1928, 1906
1073, 1906, 1929, 1907
1074, 1907, 1930, 1908
1075, 1908, 1931, 1909
1076, 1909, 1932, 1910
1077, 1910, 1933, 1911
1078, 1911, 1934, 1912
1079, 1912, 1935, 1913
1080, 1913, 1936, 1914
1081, 1914, 1937, 1915
1082, 1915, 1938, 1916
1083, 1916, 1939, 1917
1084, 1917, 1940, 1918
1085, 1918, 1941, 1919
1086, 1919, 1942, 57
*ELEMENT, type=T3D3, ELSET=Line351
1087, 61, 1951, 1943
1088, 1943, 1952, 1944
1089, 1944, 1953, 1945
1090, 1945, 1954, 1946
1091, 1946, 1955, 1947
1092, 1947, 1956, 1948
1093, 1948, 1957, 1949
1094, 1949, 1958, 1950
1095, 1950, 1959, 62
*ELEMENT, type=T3D3, ELSET=Line352
1096, 52, 1961, 1960
1097, 1960, 1962, 63
*ELEMENT, type=T3D3, ELSET=Line353
1098, 62, 1964, 1963
1099, 1963, 1965, 64
*ELEMENT, type=T3D3, ELSET=Line354
1100, 63, 1969, 1966
1101, 1966, 1970, 1967
1102, 1967, 1971, 1968
1103, 1968, 1972, 64
*ELEMENT, type=T3D3, ELSET=Line355
1104, 48, 1974, 1973
1105, 1973, 1975, 65
*ELEMENT, type=T3D3, ELSET=Line356
1106, 61, 1977, 1976
1107, 1976, 1978, 66
*ELEMENT, type=T3D3, ELSET=Line357
1108, 65, 1982, 1979
1109, 1979, 1983, 1980
1110, 1980, 1984, 1981
1111, 1981, 1985, 66
*ELEMENT, type=T3D3, ELSET=Line358
1112, 65, 1994, 1986
1113, 1986, 1995, 1987
1114, 1987, 1996, 1988
1115, 1988, 1997, 1989
1116, 1989, 1998, 1990
1117, 1990, 1999, 1991
1118, 1991, 2000, 1992
1119, 1992, 2001, 1993
1120, 1993, 2002, 63
*ELEMENT, type=T3D3, ELSET=Line359
1121, 66, 2011, 2003
1122, 2003, 2012, 2004
1123, 2004, 2013, 2005
1124, 2005, 2014, 2006
1125, 2006, 2015, 2007
1126, 2007, 2016, 2008
1127, 2008, 2017, 2009
1128, 2009, 2018, 2010
1129, 2010, 2019, 64
*ELEMENT, type=T3D3, ELSET=Line360
1130, 67, 2021, 2020
1131, 2020, 2022, 45
*ELEMENT, type=T3D3, ELSET=Line361
1132, 68, 2024, 2023
1133, 2023, 2025, 47
*ELEMENT, type=T3D3, ELSET=Line362
1134, 68, 2048, 2026
1135, 2026, 2049, 2027
1136, 2027, 2050, 2028
1137, 2028, 2051, 2029
1138, 2029, 2052, 2030
1139, 2030, 2053, 2031
1140, 2031, 2054, 2032
1141, 2032, 2055, 2033
1142, 2033, 2056, 2034
1143, 2034, 2057, 2035
1144, 2035, 2058, 2036
1145, 2036, 2059, 2037
1146, 2037, 2060, 2038
1147, 2038, 2061, 2039
1148, 2039, 2062, 2040
1149, 2040, 2063, 2041
1150, 2041, 2064, 2042
1151, 2042, 2065, 2043
1152, 2043, 2066, 2044
1153, 2044, 2067, 2045
1154, 2045, 2068, 2046
1155, 2046, 2069, 2047
1156, 2047, 2070, 67
*ELEMENT, type=T3D3, ELSET=Line363
1157, 69, 2072, 2071
1158, 2071, 2073, 49
*ELEMENT, type=T3D3, ELSET=Line364
1159, 67, 2082, 2074
1160, 2074, 2083, 2075
1161, 2075, 2084, 2076
1162, 2076, 2085, 2077
1163, 2077, 2086, 2078
1164, 2078, 2087, 2079
1165, 2079, 2088, 2080
1166, 2080, 2089, 2081
1167, 2081, 2090, 69
*ELEMENT, type=T3D3, ELSET=Line365
1168, 70, 2092, 2091
1169, 2091, 2093, 51
*ELEMENT, type=T3D3, ELSET=Line366
1170, 70, 2116, 2094
1171, 2094, 2117, 2095
1172, 2095, 2118, 2096
1173, 2096, 2119, 2097
1174, 2097, 2120, 2098
1175, 2098, 2121, 2099
1176, 2099, 2122, 2100
1177, 2100, 2123, 2101
1178, 2101, 2124, 2102
1179, 2102, 2125, 2103
1180, 2103, 2126, 2104
1181, 2104, 2127, 2105
1182, 2105, 2128, 2106
1183, 2106, 2129, 2107
1184, 2107, 2130, 2108
1185, 2108, 2131, 2109
1186, 2109, 2132, 2110
1187, 2110, 2133, 2111
1188, 2111, 2134, 2112
1189, 2112, 2135, 2113
1190, 2113, 2136, 2114
1191, 2114, 2137, 2115
1192, 2115, 2138, 69
*ELEMENT, type=T3D3, ELSET=Line367
1193, 68, 2147, 2139
1194, 2139, 2148, 2140
1195, 2140, 2149, 2141
1196, 2141, 2150, 2142
1197, 2142, 2151, 2143
1198, 2143, 2152, 2144
1199, 2144, 2153, 2145
1200, 2145, 2154, 2146
1201, 2146, 2155, 70
*ELEMENT, type=T3D3, ELSET=Line368
1202, 53, 2157, 2156
1203, 2156, 2158, 71
*ELEMENT, type=T3D3, ELSET=Line369
1204, 72, 2160, 2159
1205, 2159, 2161, 73
*ELEMENT, type=T3D3, ELSET=Line370
1206, 53, 2184, 2162
1207, 2162, 2185, 2163
1208, 2163, 2186, 2164
1209, 2164, 2187, 2165
1210, 2165, 2188, 2166
1211, 2166, 2189, 2167
1212, 2167, 2190, 2168
1213, 2168, 2191, 2169
1214, 2169, 2192, 2170
1215, 2170, 2193, 2171
1216, 2171, 2194, 2172
1217, 2172, 2195, 2173
1218, 2173, 2196, 2174
1219, 2174, 2197, 2175
1220, 2175, 2198, 2176
1221, 2176, 2199, 2177
1222, 2177, 2200, 2178
1223, 2178, 2201, 2179
1224, 2179, 2202, 2180
1225, 2180, 2203, 2181
1226, 2181, 2204, 2182
1227, 2182, 2205, 2183
1228, 2183, 2206, 72
*ELEMENT, type=T3D3, ELSET=Line371
1229, 71, 2229, 2207
1230, 2207, 2230, 2208
1231, 2208, 2231, 2209
1232, 2209, 2232, 2210
1233, 2210, 2233, 2211
1234, 2211, 2234, 2212
1235, 2212, 2235, 2213
1236, 2213, 2236, 2214
1237, 2214, 2237, 2215
1238, 2215, 2238, 2216
1239, 2216, 2239, 2217
1240, 2217, 2240, 2218
1241, 2218, 2241, 2219
1242, 2219, 2242, 2220
1243, 2220, 2243, 2221
1244, 2221, 2244, 2222
1245, 2222, 2245, 2223
1246, 2223, 2246, 2224
1247, 2224, 2247, 2225
1248, 2225, 2248, 2226
1249, 2226, 2249, 2227
1250, 2227, 2250, 2228
1251, 2228, 2251, 73
*ELEMENT, type=T3D3, ELSET=Line372
1252, 55, 2253, 2252
1253, 2252, 2254, 74
*ELEMENT, type=T3D3, ELSET=Line373
1254, 75, 2256, 2255
1255, 2255, 2257, 76
*ELEMENT, type=T3D3, ELSET=Line374
1256, 55, 2280, 2258
1257, 2258, 2281, 2259
1258, 2259, 2282, 2260
1259, 2260, 2283, 2261
1260, 2261, 2284, 2262
1261, 2262, 2285, 2263
1262, 2263, 2286, 2264
1263, 2264, 2287, 2265
1264, 2265, 2288, 2266
1265, 2266, 2289, 2267
1266, 2267, 2290, 2268
1267, 2268, 2291, 2269
1268, 2269, 2292, 2270
1269, 2270, 2293, 2271
1270, 2271, 2294, 2272
1271, 2272, 2295, 2273
1272, 2273, 2296, 2274
1273, 2274, 2297, 2275
1274, 2275, 2298, 2276
1275, 2276, 2299, 2277
1276, 2277, 2300, 2278
1277, 2278, 2301, 2279
1278, 2279, 2302, 75
*ELEMENT, type=T3D3, ELSET=Line375
1279, 74, 2325, 2303
1280, 2303, 2326, 2304
1281, 2304, 2327, 2305
1282, 2305, 2328, 2306
1283, 2306, 2329, 2307
1284, 2307, 2330, 2308
1285, 2308, 2331, 2309
1286, 2309, 2332, 2310
1287, 2310, 2333, 2311
1288, 2311, 2334, 2312
1289, 2312, 2335, 2313
1290, 2313, 2336, 2314
1291, 2314, 2337, 2315
1292, 2315, 2338, 2316
1293, 2316, 2339, 2317
1294, 2317, 2340, 2318
1295, 2318, 2341, 2319
1296, 2319, 2342, 2320
1297, 2320, 2343, 2321
1298, 2321, 2344, 2322
1299, 2322, 2345, 2323
1300, 2323, 2346, 2324
1301, 2324, 2347, 76
*ELEMENT, type=T3D3, ELSET=Line376
1302, 74, 2356, 2348
1303, 2348, 2357, 2349
1304, 2349, 2358, 2350
1305, 2350, 2359, 2351
1306, 2351, 2360, 2352
1307, 2352, 2361, 2353
1308, 2353, 2362, 2354
1309, 2354, 2363, 2355
1310, 2355, 2364, 71
*ELEMENT, type=T3D3, ELSET=Line377
1311, 75, 2373, 2365
1312, 2365, 2374, 2366
1313, 2366, 2375, 2367
1314, 2367, 2376, 2368
1315, 2368, 2377, 2369
1316, 2369, 2378, 2370
1317, 2370, 2379, 2371
1318, 2371, 2380, 2372
1319, 2372, 2381, 72
*ELEMENT, type=T3D3, ELSET=Line378
1320, 76, 2390, 2382
1321, 2382, 2391, 2383
1322, 2383, 2392, 2384
1323, 2384, 2393, 2385
1324, 2385, 2394, 2386
1325, 2386, 2395, 2387
1326, 2387, 2396, 2388
1327, 2388, 2397, 2389
1328, 2389, 2398, 73
*ELEMENT, type=T3D3, ELSET=Line379
1329, 54, 2421, 2399
1330, 2399, 2422, 2400
1331, 2400, 2423, 2401
1332, 2401, 2424, 2402
1333, 2402, 2425, 2403
1334, 2403, 2426, 2404
1335, 2404, 2427, 2405
1336, 2405, 2428, 2406
1337, 2406, 2429, 2407
1338, 2407, 2430, 2408
1339, 2408, 2431, 2409
1340, 2409, 2432, 2410
1341, 2410, 2433, 2411
1342, 2411, 2434, 2412
1343, 2412, 2435, 2413
1344, 2413, 2436, 2414
1345, 2414, 2437, 2415
1346, 2415, 2438, 2416
1347, 2416, 2439, 2417
1348, 2417, 2440, 2418
1349, 2418, 2441, 2419
1350, 2419, 2442, 2420
1351, 2420, 2443, 77
*ELEMENT, type=T3D3, ELSET=Line380
1352, 72, 2446, 2444
1353, 2444, 2447, 2445
1354, 2445, 2448, 77
*ELEMENT, type=T3D3, ELSET=Line381
1355, 56, 2471, 2449
1356, 2449, 2472, 2450
1357, 2450, 2473, 2451
1358, 2451, 2474, 2452
1359, 2452, 2475, 2453
1360, 2453, 2476, 2454
1361, 2454, 2477, 2455
1362, 2455, 2478, 2456
1363, 2456, 2479, 2457
1364, 2457, 2480, 2458
1365, 2458, 2481, 2459
1366, 2459, 2482, 2460
1367, 2460, 2483, 2461
1368, 2461, 2484, 2462
1369, 2462, 2485, 2463
1370, 2463, 2486, 2464
1371, 2464, 2487, 2465
1372, 2465, 2488, 2466
1373, 2466, 2489, 2467
1374, 2467, 2490, 2468
1375, 2468, 2491, 2469
1376, 2469, 2492, 2470
1377, 2470, 2493, 78
*ELEMENT, type=T3D3, ELSET=Line382
1378, 75, 2496, 2494
1379, 2494, 2497, 2495
1380, 2495, 2498, 78
*ELEMENT, type=T3D3, ELSET=Line383
1381, 78, 2507, 2499
1382, 2499, 2508, 2500
1383, 2500, 2509, 2501
1384, 2501, 2510, 2502
1385, 2502, 2511, 2503
1386, 2503, 2512, 2504
1387, 2504, 2513, 2505
1388, 2505, 2514, 2506
1389, 2506, 2515, 77
*ELEMENT, type=T3D3, ELSET=Line384
1390, 77, 2519, 2516
1391, 2516, 2520, 2517
1392, 2517, 2521, 2518
1393, 2518, 2522, 79
*ELEMENT, type=T3D3, ELSET=Line385
1394, 58, 2545, 2523
1395, 2523, 2546, 2524
1396, 2524, 2547, 2525
1397, 2525, 2548, 2526
1398, 2526, 2549, 2527
1399, 2527, 2550, 2528
1400, 2528, 2551, 2529
1401, 2529, 2552, 2530
1402, 2530, 2553, 2531
1403, 2531, 2554, 2532
1404, 2532, 2555, 2533
1405, 2533, 2556, 2534
1406, 2534, 2557, 2535
1407, 2535, 2558, 2536
1408, 2536, 2559, 2537
1409, 2537, 2560, 2538
1410, 2538, 2561, 2539
1411, 2539, 2562, 2540
1412, 2540, 2563, 2541
1413, 2541, 2564, 2542
1414, 2542, 2565, 2543
1415, 2543, 2566, 2544
1416, 2544, 2567, 79
*ELEMENT, type=T3D3, ELSET=Line386
1417, 78, 2571, 2568
1418, 2568, 2572, 2569
1419, 2569, 2573, 2570
1420, 2570, 2574, 80
*ELEMENT, type=T3D3, ELSET=Line387
1421, 60, 2597, 2575
1422, 2575, 2598, 2576
1423, 2576, 2599, 2577
1424, 2577, 2600, 2578
1425, 2578, 2601, 2579
1426, 2579, 2602, 2580
1427, 2580, 2603, 2581
1428, 2581, 2604, 2582
1429, 2582, 2605, 2583
1430, 2583, 2606, 2584
1431, 2584, 2607, 2585
1432, 2585, 2608, 2586
1433, 2586, 2609, 2587
1434, 2587, 2610, 2588
1435, 2588, 2611, 2589
1436, 2589, 2612, 2590
1437, 2590, 2613, 2591
1438, 2591, 2614, 2592
1439, 2592, 2615, 2593
1440, 2593, 2616, 2594
1441, 2594, 2617, 2595
1442, 2595, 2618, 2596
1443, 2596, 2619, 80
*ELEMENT, type=T3D3, ELSET=Line388
1444, 80, 2628, 2620
1445, 2620, 2629, 2621
1446, 2621, 2630, 2622
1447, 2622, 2631, 2623
1448, 2623, 2632, 2624
1449, 2624, 2633, 2625
1450, 2625, 2634, 2626
1451, 2626, 2635, 2627
1452, 2627, 2636, 79
*ELEMENT, type=T3D3, ELSET=Line389
1453, 77, 2638, 2637
1454, 2637, 2639, 81
*ELEMENT, type=T3D3, ELSET=Line390
1455, 79, 2641, 2640
1456, 2640, 2642, 82
*ELEMENT, type=T3D3, ELSET=Line391
1457, 81, 2646, 2643
1458, 2643, 2647, 2644
1459, 2644, 2648, 2645
1460, 2645, 2649, 82
*ELEMENT, type=T3D3, ELSET=Line392
1461, 78, 2651, 2650
1462, 2650, 2652, 83
*ELEMENT, type=T3D3, ELSET=Line393
1463, 80, 2654, 2653
1464, 2653, 2655, 84
*ELEMENT, type=T3D3, ELSET=Line394
1465, 83, 2659, 2656
1466, 2656, 2660, 2657
1467, 2657, 2661, 2658
1468, 2658, 2662, 84
*ELEMENT, type=T3D3, ELSET=Line395
1469, 83, 2671, 2663
1470, 2663, 2672, 2664
1471, 2664, 2673, 2665
1472, 2665, 2674, 2666
1473, 2666, 2675, 2667
1474, 2667, 2676, 2668
1475, 2668, 2677, 2669
1476, 2669, 2678, 2670
1477, 2670, 2679, 81
*ELEMENT, type=T3D3, ELSET=Line396
1478, 84, 2688, 2680
1479, 2680, 2689, 2681
1480, 2681, 2690, 2682
1481, 2682, 2691, 2683
1482, 2683, 2692, 2684
1483, 2684, 2693, 2685
1484, 2685, 2694, 2686
1485, 2686, 2695, 2687
1486, 2687, 2696, 82
*ELEMENT, type=T3D3, ELSET=Line397
1487, 85, 2698, 2697
1488, 2697, 2699, 1
*ELEMENT, type=T3D3, ELSET=Line398
1489, 86, 2701, 2700
1490, 2700, 2702, 2
*ELEMENT, type=T3D3, ELSET=Line399
1491, 86, 2725, 2703
1492, 2703, 2726, 2704
1493, 2704, 2727, 2705
1494, 2705, 2728, 2706
1495, 2706, 2729, 2707
1496, 2707, 2730, 2708
1497, 2708, 2731, 2709
1498, 2709, 2732, 2710
1499, 2710, 2733, 2711
1500, 2711, 2734, 2712
1501, 2712, 2735, 2713
1502, 2713, 2736, 2714
1503, 2714, 2737, 2715
1504, 2715, 2738, 2716
1505, 2716, 2739, 2717
1506, 2717, 2740, 2718
1507, 2718, 2741, 2719
1508, 2719, 2742, 2720
1509, 2720, 2743, 2721
1510, 2721, 2744, 2722
1511, 2722, 2745, 2723
1512, 2723, 2746, 2724
1513, 2724, 2747, 85
*ELEMENT, type=T3D3, ELSET=Line400
1514, 87, 2749, 2748
1515, 2748, 2750, 3
*ELEMENT, type=T3D3, ELSET=Line401
1516, 85, 2759, 2751
1517, 2751, 2760, 2752
1518, 2752, 2761, 2753
1519, 2753, 2762, 2754
1520, 2754, 2763, 2755
1521, 2755, 2764, 2756
1522, 2756, 2765, 2757
1523, 2757, 2766, 2758
1524, 2758, 2767, 87
*ELEMENT, type=T3D3, ELSET=Line402
1525, 88, 2769, 2768
1526, 2768, 2770, 4
*ELEMENT, type=T3D3, ELSET=Line403
1527, 88, 2793, 2771
1528, 2771, 2794, 2772
1529, 2772, 2795, 2773
1530, 2773, 2796, 2774
1531, 2774, 2797, 2775
1532, 2775, 2798, 2776
1533, 2776, 2799, 2777
1534, 2777, 2800, 2778
1535, 2778, 2801, 2779
1536, 2779, 2802, 2780
1537, 2780, 2803, 2781
1538, 2781, 2804, 2782
1539, 2782, 2805, 2783
1540, 2783, 2806, 2784
1541, 2784, 2807, 2785
1542, 2785, 2808, 2786
1543, 2786, 2809, 2787
1544, 2787, 2810, 2788
1545, 2788, 2811, 2789
1546, 2789, 2812, 2790
1547, 2790, 2813, 2791
1548, 2791, 2814, 2792
1549, 2792, 2815, 87
*ELEMENT, type=T3D3, ELSET=Line404
1550, 86, 2824, 2816
1551, 2816, 2825, 2817
1552, 2817, 2826, 2818
1553, 2818, 2827, 2819
1554, 2819, 2828, 2820
1555, 2820, 2829, 2821
1556, 2821, 2830, 2822
1557, 2822, 2831, 2823
1558, 2823, 2832, 88
*ELEMENT, type=T3D3, ELSET=Line405
1559, 1, 2855, 2833
1560, 2833, 2856, 2834
1561, 2834, 2857, 2835
1562, 2835, 2858, 2836
1563, 2836, 2859, 2837
1564, 2837, 2860, 2838
1565, 2838, 2861, 2839
1566, 2839, 2862, 2840
1567, 2840, 2863, 2841
1568, 2841, 2864, 2842
1569, 2842, 2865, 2843
1570, 2843, 2866, 2844
1571, 2844, 2867, 2845
1572, 2845, 2868, 2846
1573, 2846, 2869, 2847
1574, 2847, 2870, 2848
1575, 2848, 2871, 2849
1576, 2849, 2872, 2850
1577, 2850, 2873, 2851
1578, 2851, 2874, 2852
1579, 2852, 2875, 2853
1580, 2853, 2876, 2854
1581, 2854, 2877, 89
*ELEMENT, type=T3D3, ELSET=Line406
1582, 2, 2900, 2878
1583, 2878, 2901, 2879
1584, 2879, 2902, 2880
1585, 2880, 2903, 2881
1586, 2881, 2904, 2882
1587, 2882, 2905, 2883
1588, 2883, 2906, 2884
1589, 2884, 2907, 2885
1590, 2885, 2908, 2886
1591, 2886, 2909, 2887
1592, 2887, 2910, 2888
1593, 2888, 2911, 2889
1594, 2889, 2912, 2890
1595, 2890, 2913, 2891
1596, 2891, 2914, 2892
1597, 2892, 2915, 2893
1598, 2893, 2916, 2894
1599, 2894, 2917, 2895
1600, 2895, 2918, 2896
1601, 2896, 2919, 2897
1602, 2897, 2920, 2898
1603, 2898, 2921, 2899
1604, 2899, 2922, 90
*ELEMENT, type=T3D3, ELSET=Line407
1605, 90, 2945, 2923
1606, 2923, 2946, 2924
1607, 2924, 2947, 2925
1608, 2925, 2948, 2926
1609, 2926, 2949, 2927
1610, 2927, 2950, 2928
1611, 2928, 2951, 2929
1612, 2929, 2952, 2930
1613, 2930, 2953, 2931
1614, 2931, 2954, 2932
1615, 2932, 2955, 2933
1616, 2933, 2956, 2934
1617, 2934, 2957, 2935
1618, 2935, 2958, 2936
1619, 2936, 2959, 2937
1620, 2937, 2960, 2938
1621, 2938, 2961, 2939
1622, 2939, 2962, 2940
1623, 2940, 2963, 2941
1624, 2941, 2964, 2942
1625, 2942, 2965, 2943
1626, 2943, 2966, 2944
1627, 2944, 2967, 89
*ELEMENT, type=T3D3, ELSET=Line408
1628, 3, 2990, 2968
1629, 2968, 2991, 2969
1630, 2969, 2992, 2970
1631, 2970, 2993, 2971
1632, 2971, 2994, 2972
1633, 2972, 2995, 2973
1634, 2973, 2996, 2974
1635, 2974, 2997, 2975
1636, 2975, 2998, 2976
1637, 2976, 2999, 2977
1638, 2977, 3000, 2978
1639, 2978, 3001, 2979
1640, 2979, 3002, 2980
1641, 2980, 3003, 2981
1642, 2981, 3004, 2982
1643, 2982, 3005, 2983
1644, 2983, 3006, 2984
1645, 2984, 3007, 2985
1646, 2985, 3008, 2986
1647, 2986, 3009, 2987
1648, 2987, 3010, 2988
1649, 2988, 3011, 2989
1650, 2989, 3012, 91
*ELEMENT, type=T3D3, ELSET=Line409
1651, 89, 3021, 3013
1652, 3013, 3022, 3014
1653, 3014, 3023, 3015
1654, 3015, 3024, 3016
1655, 3016, 3025, 3017
1656, 3017, 3026, 3018
1657, 3018, 3027, 3019
1658, 3019, 3028, 3020
1659, 3020, 3029, 91
*ELEMENT, type=T3D3, ELSET=Line410
1660, 4, 3052, 3030
1661, 3030, 3053, 3031
1662, 3031, 3054, 3032
1663, 3032, 3055, 3033
1664, 3033, 3056, 3034
1665, 3034, 3057, 3035
1666, 3035, 3058, 3036
1667, 3036, 3059, 3037
1668, 3037, 3060, 3038
1669, 3038, 3061, 3039
1670, 3039, 3062, 3040
1671, 3040, 3063, 3041
1672, 3041, 3064, 3042
1673, 3042, 3065, 3043
1674, 3043, 3066, 3044
1675, 3044, 3067, 3045
1676, 3045, 3068, 3046
1677, 3046, 3069, 3047
1678, 3047, 3070, 3048
1679, 3048, 3071, 3049
1680, 3049, 3072, 3050
1681, 3050, 3073, 3051
1682, 3051, 3074, 92
*ELEMENT, type=T3D3, ELSET=Line411
1683, 92, 3097, 3075
1684, 3075, 3098, 3076
1685, 3076, 3099, 3077
1686, 3077, 3100, 3078
1687, 3078, 3101, 3079
1688, 3079, 3102, 3080
1689, 3080, 3103, 3081
1690, 3081, 3104, 3082
1691, 3082, 3105, 3083
1692, 3083, 3106, 3084
1693, 3084, 3107, 3085
1694, 3085, 3108, 3086
1695, 3086, 3109, 3087
1696, 3087, 3110, 3088
1697, 3088, 3111, 3089
1698, 3089, 3112, 3090
1699, 3090, 3113, 3091
1700, 3091, 3114, 3092
1701, 3092, 3115, 3093
1702, 3093, 3116, 3094
1703, 3094, 3117, 3095
1704, 3095, 3118, 3096
1705, 3096, 3119, 91
*ELEMENT, type=T3D3, ELSET=Line412
1706, 90, 3128, 3120
1707, 3120, 3129, 3121
1708, 3121, 3130, 3122
1709, 3122, 3131, 3123
1710, 3123, 3132, 3124
1711, 3124, 3133, 3125
1712, 3125, 3134, 3126
1713, 3126, 3135, 3127
1714, 3127, 3136, 92
*ELEMENT, type=T3D3, ELSET=Line413
1715, 93, 3159, 3137
1716, 3137, 3160, 3138
1717, 3138, 3161, 3139
1718, 3139, 3162, 3140
1719, 3140, 3163, 3141
1720, 3141, 3164, 3142
1721, 3142, 3165, 3143
1722, 3143, 3166, 3144
1723, 3144, 3167, 3145
1724, 3145, 3168, 3146
1725, 3146, 3169, 3147
1726, 3147, 3170, 3148
1727, 3148, 3171, 3149
1728, 3149, 3172, 3150
1729, 3150, 3173, 3151
1730, 3151, 3174, 3152
1731, 3152, 3175, 3153
1732, 3153, 3176, 3154
1733, 3154, 3177, 3155
1734, 3155, 3178, 3156
1735, 3156, 3179, 3157
1736, 3157, 3180, 3158
1737, 3158, 3181, 5
*ELEMENT, type=T3D3, ELSET=Line414
1738, 94, 3204, 3182
1739, 3182, 3205, 3183
1740, 3183, 3206, 3184
1741, 3184, 3207, 3185
1742, 3185, 3208, 3186
1743, 3186, 3209, 3187
1744, 3187, 3210, 3188
1745, 3188, 3211, 3189
1746, 3189, 3212, 3190
1747, 3190, 3213, 3191
1748, 3191, 3214, 3192
1749, 3192, 3215, 3193
1750, 3193, 3216, 3194
1751, 3194, 3217, 3195
1752, 3195, 3218, 3196
1753, 3196, 3219, 3197
1754, 3197, 3220, 3198
1755, 3198, 3221, 3199
1756, 3199, 3222, 3200
1757, 3200, 3223, 3201
1758, 3201, 3224, 3202
1759, 3202, 3225, 3203
1760, 3203, 3226, 6
*ELEMENT, type=T3D3, ELSET=Line415
1761, 93, 3249, 3227
1762, 3227, 3250, 3228
1763, 3228, 3251, 3229
1764, 3229, 3252, 3230
1765, 3230, 3253, 3231
1766, 3231, 3254, 3232
1767, 3232, 3255, 3233
1768, 3233, 3256, 3234
1769, 3234, 3257, 3235
1770, 3235, 3258, 3236
1771, 3236, 3259, 3237
1772, 3237, 3260, 3238
1773, 3238, 3261, 3239
1774, 3239, 3262, 3240
1775, 3240, 3263, 3241
1776, 3241, 3264, 3242
1777, 3242, 3265, 3243
1778, 3243, 3266, 3244
1779, 3244, 3267, 3245
1780, 3245, 3268, 3246
1781, 3246, 3269, 3247
1782, 3247, 3270, 3248
1783, 3248, 3271, 94
*ELEMENT, type=T3D3, ELSET=Line416
1784, 95, 3294, 3272
1785, 3272, 3295, 3273
1786, 3273, 3296, 3274
1787, 3274, 3297, 3275
1788, 3275, 3298, 3276
1789, 3276, 3299, 3277
1790, 3277, 3300, 3278
1791, 3278, 3301, 3279
1792, 3279, 3302, 3280
1793, 3280, 3303, 3281
1794, 3281, 3304, 3282
1795, 3282, 3305, 3283
1796, 3283, 3306, 3284
1797, 3284, 3307, 3285
1798, 3285, 3308, 3286
1799, 3286, 3309, 3287
1800, 3287, 3310, 3288
1801, 3288, 3311, 3289
1802, 3289, 3312, 3290
1803, 3290, 3313, 3291
1804, 3291, 3314, 3292
1805, 3292, 3315, 3293
1806, 3293, 3316, 7
*ELEMENT, type=T3D3, ELSET=Line417
1807, 96, 3339, 3317
1808, 3317, 3340, 3318
1809, 3318, 3341, 3319
1810, 3319, 3342, 3320
1811, 3320, 3343, 3321
1812, 3321, 3344, 3322
1813, 3322, 3345, 3323
1814, 3323, 3346, 3324
1815, 3324, 3347, 3325
1816, 3325, 3348, 3326
1817, 3326, 3349, 3327
1818, 3327, 3350, 3328
1819, 3328, 3351, 3329
1820, 3329, 3352, 3330
1821, 3330, 3353, 3331
1822, 3331, 3354, 3332
1823, 3332, 3355, 3333
1824, 3333, 3356, 3334
1825, 3334, 3357, 3335
1826, 3335, 3358, 3336
1827, 3336, 3359, 3337
1828, 3337, 3360, 3338
1829, 3338, 3361, 8
*ELEMENT, type=T3D3, ELSET=Line418
1830, 95, 3384, 3362
1831, 3362, 3385, 3363
1832, 3363, 3386, 3364
1833, 3364, 3387, 3365
1834, 3365, 3388, 3366
1835, 3366, 3389, 3367
1836, 3367, 3390, 3368
1837, 3368, 3391, 3369
1838, 3369, 3392, 3370
1839, 3370, 3393, 3371
1840, 3371, 3394, 3372
1841, 3372, 3395, 3373
1842, 3373, 3396, 3374
1843, 3374, 3397, 3375
1844, 3375, 3398, 3376
1845, 3376, 3399, 3377
1846, 3377, 3400, 3378
1847, 3378, 3401, 3379
1848, 3379, 3402, 3380
1849, 3380, 3403, 3381
1850, 3381, 3404, 3382
1851, 3382, 3405, 3383
1852, 3383, 3406, 96
*ELEMENT, type=T3D3, ELSET=Line419
1853, 95, 3415, 3407
1854, 3407, 3416, 3408
1855, 3408, 3417, 3409
1856, 3409, 3418, 3410
1857, 3410, 3419, 3411
1858, 3411, 3420, 3412
1859, 3412, 3421, 3413
1860, 3413, 3422, 3414
1861, 3414, 3423, 93
*ELEMENT, type=T3D3, ELSET=Line420
1862, 96, 3432, 3424
1863, 3424, 3433, 3425
1864, 3425, 3434, 3426
1865, 3426, 3435, 3427
1866, 3427, 3436, 3428
1867, 3428, 3437, 3429
1868, 3429, 3438, 3430
1869, 3430, 3439, 3431
1870, 3431, 3440, 94
*ELEMENT, type=T3D3, ELSET=Line421
1871, 5, 3442, 3441
1872, 3441, 3443, 97
*ELEMENT, type=T3D3, ELSET=Line422
1873, 6, 3445, 3444
1874, 3444, 3446, 98
*ELEMENT, type=T3D3, ELSET=Line423
1875, 97, 3469, 3447
1876, 3447, 3470, 3448
1877, 3448, 3471, 3449
1878, 3449, 3472, 3450
1879, 3450, 3473, 3451
1880, 3451, 3474, 3452
1881, 3452, 3475, 3453
1882, 3453, 3476, 3454
1883, 3454, 3477, 3455
1884, 3455, 3478, 3456
1885, 3456, 3479, 3457
1886, 3457, 3480, 3458
1887, 3458, 3481, 3459
1888, 3459, 3482, 3460
1889, 3460, 3483, 3461
1890, 3461, 3484, 3462
1891, 3462, 3485, 3463
1892, 3463, 3486, 3464
1893, 3464, 3487, 3465
1894, 3465, 3488, 3466
1895, 3466, 3489, 3467
1896, 3467, 3490, 3468
1897, 3468, 3491, 98
*ELEMENT, type=T3D3, ELSET=Line424
1898, 7, 3493, 3492
1899, 3492, 3494, 99
*ELEMENT, type=T3D3, ELSET=Line425
1900, 8, 3496, 3495
1901, 3495, 3497, 100
*ELEMENT, type=T3D3, ELSET=Line426
1902, 99, 3520, 3498
1903, 3498, 3521, 3499
1904, 3499, 3522, 3500
1905, 3500, 3523, 3501
1906, 3501, 3524, 3502
1907, 3502, 3525, 3503
1908, 3503, 3526, 3504
1909, 3504, 3527, 3505
1910, 3505, 3528, 3506
1911, 3506, 3529, 3507
1912, 3507, 3530, 3508
1913, 3508, 3531, 3509
1914, 3509, 3532, 3510
1915, 3510, 3533, 3511
1916, 3511, 3534, 3512
1917, 3512, 3535, 3513
1918, 3513, 3536, 3514
1919, 3514, 3537, 3515
1920, 3515, 3538, 3516
1921, 3516, 3539, 3517
1922, 3517, 3540, 3518
1923, 3518, 3541, 3519
1924, 3519, 3542, 100
*ELEMENT, type=T3D3, ELSET=Line427
1925, 99, 3551, 3543
1926, 3543, 3552, 3544
1927, 3544, 3553, 3545
1928, 3545, 3554, 3546
1929, 3546, 3555, 3547
1930, 3547, 3556, 3548
1931, 3548, 3557, 3549
1932, 3549, 3558, 3550
1933, 3550, 3559, 97
*ELEMENT, type=T3D3, ELSET=Line428
1934, 100, 3568, 3560
1935, 3560, 3569, 3561
1936, 3561, 3570, 3562
1937, 3562, 3571, 3563
1938, 3563, 3572, 3564
1939, 3564, 3573, 3565
1940, 3565, 3574, 3566
1941, 3566, 3575, 3567
1942, 3567, 3576, 98
*ELEMENT, type=T3D3, ELSET=Line429
1943, 35, 3578, 3577
1944, 3577, 3579, 97
*ELEMENT, type=T3D3, ELSET=Line430
1945, 36, 3581, 3580
1946, 3580, 3582, 98
*ELEMENT, type=T3D3, ELSET=Line431
1947, 37, 3584, 3583
1948, 3583, 3585, 99
*ELEMENT, type=T3D3, ELSET=Line432
1949, 38, 3587, 3586
1950, 3586, 3588, 100
*ELEMENT, type=T3D3, ELSET=Line433
1951, 24, 3590, 3589
1952, 3589, 3591, 85
*ELEMENT, type=T3D3, ELSET=Line434
1953, 15, 3593, 3592
1954, 3592, 3594, 86
*ELEMENT, type=T3D3, ELSET=Line435
1955, 23, 3596, 3595
1956, 3595, 3597, 87
*ELEMENT, type=T3D3, ELSET=Line436
1957, 9, 3599, 3598
1958, 3598, 3600, 88
*ELEMENT, type=T3D3, ELSET=Line437
1959, 3, 3602, 3601
1960, 3601, 3603, 101
*ELEMENT, type=T3D3, ELSET=Line438
1961, 91, 3605, 3604
1962, 3604, 3606, 102
*ELEMENT, type=T3D3, ELSET=Line439
1963, 101, 3629, 3607
1964, 3607, 3630, 3608
1965, 3608, 3631, 3609
1966, 3609, 3632, 3610
1967, 3610, 3633, 3611
1968, 3611, 3634, 3612
1969, 3612, 3635, 3613
1970, 3613, 3636, 3614
1971, 3614, 3637, 3615
1972, 3615, 3638, 3616
1973, 3616, 3639, 3617
1974, 3617, 3640, 3618
1975, 3618, 3641, 3619
1976, 3619, 3642, 3620
1977, 3620, 3643, 3621
1978, 3621, 3644, 3622
1979, 3622, 3645, 3623
1980, 3623, 3646, 3624
1981, 3624, 3647, 3625
1982, 3625, 3648, 3626
1983, 3626, 3649, 3627
1984, 3627, 3650, 3628
1985, 3628, 3651, 102
*ELEMENT, type=T3D3, ELSET=Line440
1986, 1, 3653, 3652
1987, 3652, 3654, 103
*ELEMENT, type=T3D3, ELSET=Line441
1988, 89, 3656, 3655
1989, 3655, 3657, 104
*ELEMENT, type=T3D3, ELSET=Line442
1990, 103, 3680, 3658
1991, 3658, 3681, 3659
1992, 3659, 3682, 3660
1993, 3660, 3683, 3661
1994, 3661, 3684, 3662
1995, 3662, 3685, 3663
1996, 3663, 3686, 3664
1997, 3664, 3687, 3665
1998, 3665, 3688, 3666
1999, 3666, 3689, 3667
2000, 3667, 3690, 3668
2001, 3668, 3691, 3669
2002, 3669, 3692, 3670
2003, 3670, 3693, 3671
2004, 3671, 3694, 3672
2005, 3672, 3695, 3673
2006, 3673, 3696, 3674
2007, 3674, 3697, 3675
2008, 3675, 3698, 3676
2009, 3676, 3699, 3677
2010, 3677, 3700, 3678
2011, 3678, 3701, 3679
2012, 3679, 3702, 104
*ELEMENT, type=T3D3, ELSET=Line443
2013, 103, 3711, 3703
2014, 3703, 3712, 3704
2015, 3704, 3713, 3705
2016, 3705, 3714, 3706
2017, 3706, 3715, 3707
2018, 3707, 3716, 3708
2019, 3708, 3717, 3709
2020, 3709, 3718, 3710
2021, 3710, 3719, 101
*ELEMENT, type=T3D3, ELSET=Line444
2022, 104, 3728, 3720
2023, 3720, 3729, 3721
2024, 3721, 3730, 3722
2025, 3722, 3731, 3723
2026, 3723, 3732, 3724
2027, 3724, 3733, 3725
2028, 3725, 3734, 3726
2029, 3726, 3735, 3727
2030, 3727, 3736, 102
*ELEMENT, type=T3D3, ELSET=Line445
2031, 93, 3738, 3737
2032, 3737, 3739, 105
*ELEMENT, type=T3D3, ELSET=Line446
2033, 5, 3741, 3740
2034, 3740, 3742, 106
*ELEMENT, type=T3D3, ELSET=Line447
2035, 105, 3765, 3743
2036, 3743, 3766, 3744
2037, 3744, 3767, 3745
2038, 3745, 3768, 3746
2039, 3746, 3769, 3747
2040, 3747, 3770, 3748
2041, 3748, 3771, 3749
2042, 3749, 3772, 3750
2043, 3750, 3773, 3751
2044, 3751, 3774, 3752
2045, 3752, 3775, 3753
2046, 3753, 3776, 3754
2047, 3754, 3777, 3755
2048, 3755, 3778, 3756
2049, 3756, 3779, 3757
2050, 3757, 3780, 3758
2051, 3758, 3781, 3759
2052, 3759, 3782, 3760
2053, 3760, 3783, 3761
2054, 3761, 3784, 3762
2055, 3762, 3785, 3763
2056, 3763, 3786, 3764
2057, 3764, 3787, 106
*ELEMENT, type=T3D3, ELSET=Line448
2058, 95, 3789, 3788
2059, 3788, 3790, 107
*ELEMENT, type=T3D3, ELSET=Line449
2060, 7, 3792, 3791
2061, 3791, 3793, 108
*ELEMENT, type=T3D3, ELSET=Line450
2062, 107, 3816, 3794
2063, 3794, 3817, 3795
2064, 3795, 3818, 3796
2065, 3796, 3819, 3797
2066, 3797, 3820, 3798
2067, 3798, 3821, 3799
2068, 3799, 3822, 3800
2069, 3800, 3823, 3801
2070, 3801, 3824, 3802
2071, 3802, 3825, 3803
2072, 3803, 3826, 3804
2073, 3804, 3827, 3805
2074, 3805, 3828, 3806
2075, 3806, 3829, 3807
2076, 3807, 3830, 3808
2077, 3808, 3831, 3809
2078, 3809, 3832, 3810
2079, 3810, 3833, 3811
2080, 3811, 3834, 3812
2081, 3812, 3835, 3813
2082, 3813, 3836, 3814
2083, 3814, 3837, 3815
2084, 3815, 3838, 108
*ELEMENT, type=T3D3, ELSET=Line451
2085, 107, 3847, 3839
2086, 3839, 3848, 3840
2087, 3840, 3849, 3841
2088, 3841, 3850, 3842
2089, 3842, 3851, 3843
2090, 3843, 3852, 3844
2091, 3844, 3853, 3845
2092, 3845, 3854, 3846
2093, 3846, 3855, 105
*ELEMENT, type=T3D3, ELSET=Line452
2094, 108, 3864, 3856
2095, 3856, 3865, 3857
2096, 3857, 3866, 3858
2097, 3858, 3867, 3859
2098, 3859, 3868, 3860
2099, 3860, 3869, 3861
2100, 3861, 3870, 3862
2101, 3862, 3871, 3863
2102, 3863, 3872, 106
*ELEMENT, type=T3D3, ELSET=Line453
2103, 67, 3874, 3873
2104, 3873, 3875, 89
*ELEMENT, type=T3D3, ELSET=Line454
2105, 68, 3877, 3876
2106, 3876, 3878, 90
*ELEMENT, type=T3D3, ELSET=Line455
2107, 69, 3880, 3879
2108, 3879, 3881, 91
*ELEMENT, type=T3D3, ELSET=Line456
2109, 70, 3883, 3882
2110, 3882, 3884, 92
*ELEMENT, type=T3D3, ELSET=Line457
2111, 71, 3886, 3885
2112, 3885, 3887, 93
*ELEMENT, type=T3D3, ELSET=Line458
2113, 73, 3889, 3888
2114, 3888, 3890, 94
*ELEMENT, type=T3D3, ELSET=Line459
2115, 74, 3892, 3891
2116, 3891, 3893, 95
*ELEMENT, type=T3D3, ELSET=Line460
2117, 76, 3895, 3894
2118, 3894, 3896, 96
*ELEMENT, type=T3D3, ELSET=Line461
2119, 1, 3898, 3897
2120, 3897, 3899, 109
*ELEMENT, type=T3D3, ELSET=Line462
2121, 89, 3901, 3900
2122, 3900, 3902, 110
*ELEMENT, type=T3D3, ELSET=Line463
2123, 109, 3925, 3903
2124, 3903, 3926, 3904
2125, 3904, 3927, 3905
2126, 3905, 3928, 3906
2127, 3906, 3929, 3907
2128, 3907, 3930, 3908
2129, 3908, 3931, 3909
2130, 3909, 3932, 3910
2131, 3910, 3933, 3911
2132, 3911, 3934, 3912
2133, 3912, 3935, 3913
2134, 3913, 3936, 3914
2135, 3914, 3937, 3915
2136, 3915, 3938, 3916
2137, 3916, 3939, 3917
2138, 3917, 3940, 3918
2139, 3918, 3941, 3919
2140, 3919, 3942, 3920
2141, 3920, 3943, 3921
2142, 3921, 3944, 3922
2143, 3922, 3945, 3923
2144, 3923, 3946, 3924
2145, 3924, 3947, 110
*ELEMENT, type=T3D3, ELSET=Line464
2146, 2, 3949, 3948
2147, 3948, 3950, 111
*ELEMENT, type=T3D3, ELSET=Line465
2148, 90, 3952, 3951
2149, 3951, 3953, 112
*ELEMENT, type=T3D3, ELSET=Line466
2150, 111, 3976, 3954
2151, 3954, 3977, 3955
2152, 3955, 3978, 3956
2153, 3956, 3979, 3957
2154, 3957, 3980, 3958
2155, 3958, 3981, 3959
2156, 3959, 3982, 3960
2157, 3960, 3983, 3961
2158, 3961, 3984, 3962
2159, 3962, 3985, 3963
2160, 3963, 3986, 3964
2161, 3964, 3987, 3965
2162, 3965, 3988, 3966
2163, 3966, 3989, 3967
2164, 3967, 3990, 3968
2165, 3968, 3991, 3969
2166, 3969, 3992, 3970
2167, 3970, 3993, 3971
2168, 3971, 3994, 3972
2169, 3972, 3995, 3973
2170, 3973, 3996, 3974
2171, 3974, 3997, 3975
2172, 3975, 3998, 112
*ELEMENT, type=T3D3, ELSET=Line467
2173, 111, 4021, 3999
2174, 3999, 4022, 4000
2175, 4000, 4023, 4001
2176, 4001, 4024, 4002
2177, 4002, 4025, 4003
2178, 4003, 4026, 4004
2179, 4004, 4027, 4005
2180, 4005, 4028, 4006
2181, 4006, 4029, 4007
2182, 4007, 4030, 4008
2183, 4008, 4031, 4009
2184, 4009, 4032, 4010
2185, 4010, 4033, 4011
2186, 4011, 4034, 4012
2187, 4012, 4035, 4013
2188, 4013, 4036, 4014
2189, 4014, 4037, 4015
2190, 4015, 4038, 4016
2191, 4016, 4039, 4017
2192, 4017, 4040, 4018
2193, 4018, 4041, 4019
2194, 4019, 4042, 4020
2195, 4020, 4043, 109
*ELEMENT, type=T3D3, ELSET=Line468
2196, 112, 4066, 4044
2197, 4044, 4067, 4045
2198, 4045, 4068, 4046
2199, 4046, 4069, 4047
2200, 4047, 4070, 4048
2201, 4048, 4071, 4049
2202, 4049, 4072, 4050
2203, 4050, 4073, 4051
2204, 4051, 4074, 4052
2205, 4052, 4075, 4053
2206, 4053, 4076, 4054
2207, 4054, 4077, 4055
2208, 4055, 4078, 4056
2209, 4056, 4079, 4057
2210, 4057, 4080, 4058
2211, 4058, 4081, 4059
2212, 4059, 4082, 4060
2213, 4060, 4083, 4061
2214, 4061, 4084, 4062
2215, 4062, 4085, 4063
2216, 4063, 4086, 4064
2217, 4064, 4087, 4065
2218, 4065, 4088, 110
*ELEMENT, type=T3D3, ELSET=Line469
2219, 103, 4090, 4089
2220, 4089, 4091, 113
*ELEMENT, type=T3D3, ELSET=Line470
2221, 109, 4093, 4092
2222, 4092, 4094, 113
*ELEMENT, type=T3D3, ELSET=Line471
2223, 104, 4096, 4095
2224, 4095, 4097, 114
*ELEMENT, type=T3D3, ELSET=Line472
2225, 110, 4099, 4098
2226, 4098, 4100, 114
*ELEMENT, type=T3D3, ELSET=Line473
2227, 113, 4123, 4101
2228, 4101, 4124, 4102
2229, 4102, 4125, 4103
2230, 4103, 4126, 4104
2231, 4104, 4127, 4105
2232, 4105, 4128, 4106
2233, 4106, 4129, 4107
2234, 4107, 4130, 4108
2235, 4108, 4131, 4109
2236, 4109, 4132, 4110
2237, 4110, 4133, 4111
2238, 4111, 4134, 4112
2239, 4112, 4135, 4113
2240, 4113, 4136, 4114
2241, 4114, 4137, 4115
2242, 4115, 4138, 4116
2243, 4116, 4139, 4117
2244, 4117, 4140, 4118
2245, 4118, 4141, 4119
2246, 4119, 4142, 4120
2247, 4120, 4143, 4121
2248, 4121, 4144, 4122
2249, 4122, 4145, 114
*ELEMENT, type=T3D3, ELSET=Line474
2250, 95, 4147, 4146
2251, 4146, 4148, 115
*ELEMENT, type=T3D3, ELSET=Line475
2252, 107, 4150, 4149
2253, 4149, 4151, 116
*ELEMENT, type=T3D3, ELSET=Line476
2254, 115, 4153, 4152
2255, 4152, 4154, 116
*ELEMENT, type=T3D3, ELSET=Line477
2256, 7, 4156, 4155
2257, 4155, 4157, 117
*ELEMENT, type=T3D3, ELSET=Line478
2258, 108, 4159, 4158
2259, 4158, 4160, 118
*ELEMENT, type=T3D3, ELSET=Line479
2260, 117, 4162, 4161
2261, 4161, 4163, 118
*ELEMENT, type=T3D3, ELSET=Line480
2262, 115, 4186, 4164
2263, 4164, 4187, 4165
2264, 4165, 4188, 4166
2265, 4166, 4189, 4167
2266, 4167, 4190, 4168
2267, 4168, 4191, 4169
2268, 4169, 4192, 4170
2269, 4170, 4193, 4171
2270, 4171, 4194, 4172
2271, 4172, 4195, 4173
2272, 4173, 4196, 4174
2273, 4174, 4197, 4175
2274, 4175, 4198, 4176
2275, 4176, 4199, 4177
2276, 4177, 4200, 4178
2277, 4178, 4201, 4179
2278, 4179, 4202, 4180
2279, 4180, 4203, 4181
2280, 4181, 4204, 4182
2281, 4182, 4205, 4183
2282, 4183, 4206, 4184
2283, 4184, 4207, 4185
2284, 4185, 4208, 117
*ELEMENT, type=T3D3, ELSET=Line481
2285, 116, 4231, 4209
2286, 4209, 4232, 4210
2287, 4210, 4233, 4211
2288, 4211, 4234, 4212
2289, 4212, 4235, 4213
2290, 4213, 4236, 4214
2291, 4214, 4237, 4215
2292, 4215, 4238, 4216
2293, 4216, 4239, 4217
2294, 4217, 4240, 4218
2295, 4218, 4241, 4219
2296, 4219, 4242, 4220
2297, 4220, 4243, 4221
2298, 4221, 4244, 4222
2299, 4222, 4245, 4223
2300, 4223, 4246, 4224
2301, 4224, 4247, 4225
2302, 4225, 4248, 4226
2303, 4226, 4249, 4227
2304, 4227, 4250, 4228
2305, 4228, 4251, 4229
2306, 4229, 4252, 4230
2307, 4230, 4253, 118
*ELEMENT, type=T3D3, ELSET=Line482
2308, 96, 4255, 4254
2309, 4254, 4256, 119
*ELEMENT, type=T3D3, ELSET=Line483
2310, 8, 4258, 4257
2311, 4257, 4259, 120
*ELEMENT, type=T3D3, ELSET=Line484
2312, 119, 4282, 4260
2313, 4260, 4283, 4261
2314, 4261, 4284, 4262
2315, 4262, 4285, 4263
2316, 4263, 4286, 4264
2317, 4264, 4287, 4265
2318, 4265, 4288, 4266
2319, 4266, 4289, 4267
2320, 4267, 4290, 4268
2321, 4268, 4291, 4269
2322, 4269, 4292, 4270
2323, 4270, 4293, 4271
2324, 4271, 4294, 4272
2325, 4272, 4295, 4273
2326, 4273, 4296, 4274
2327, 4274, 4297, 4275
2328, 4275, 4298, 4276
2329, 4276, 4299, 4277
2330, 4277, 4300, 4278
2331, 4278, 4301, 4279
2332, 4279, 4302, 4280
2333, 4280, 4303, 4281
2334, 4281, 4304, 120
*ELEMENT, type=T3D3, ELSET=Line485
2335, 115, 4327, 4305
2336, 4305, 4328, 4306
2337, 4306, 4329, 4307
2338, 4307, 4330, 4308
2339, 4308, 4331, 4309
2340, 4309, 4332, 4310
2341, 4310, 4333, 4311
2342, 4311, 4334, 4312
2343, 4312, 4335, 4313
2344, 4313, 4336, 4314
2345, 4314, 4337, 4315
2346, 4315, 4338, 4316
2347, 4316, 4339, 4317
2348, 4317, 4340, 4318
2349, 4318, 4341, 4319
2350, 4319, 4342, 4320
2351, 4320, 4343, 4321
2352, 4321, 4344, 4322
2353, 4322, 4345, 4323
2354, 4323, 4346, 4324
2355, 4324, 4347, 4325
2356, 4325, 4348, 4326
2357, 4326, 4349, 119
*ELEMENT, type=T3D3, ELSET=Line486
2358, 117, 4372, 4350
2359, 4350, 4373, 4351
2360, 4351, 4374, 4352
2361, 4352, 4375, 4353
2362, 4353, 4376, 4354
2363, 4354, 4377, 4355
2364, 4355, 4378, 4356
2365, 4356, 4379, 4357
2366, 4357, 4380, 4358
2367, 4358, 4381, 4359
2368, 4359, 4382, 4360
2369, 4360, 4383, 4361
2370, 4361, 4384, 4362
2371, 4362, 4385, 4363
2372, 4363, 4386, 4364
2373, 4364, 4387, 4365
2374, 4365, 4388, 4366
2375, 4366, 4389, 4367
2376, 4367, 4390, 4368
2377, 4368, 4391, 4369
2378, 4369, 4392, 4370
2379, 4370, 4393, 4371
2380, 4371, 4394, 120
*ELEMENT, type=CPS8, ELSET=Surface11
2381, 2, 228, 4395, 121, 236, 4571, 4572, 143
2382, 228, 229, 4396, 4395, 237, 4573, 4574, 4571
2383, 229, 230, 4397, 4396, 238, 4575, 4576, 4573
2384, 230, 231, 4398, 4397, 239, 4577, 4578, 4575
2385, 231, 232, 4399, 4398, 240, 4579, 4580, 4577
2386, 232, 233, 4400, 4399, 241, 4581, 4582, 4579
2387, 233, 234, 4401, 4400, 242, 4583, 4584, 4581
2388, 234, 235, 4402, 4401, 243, 4585, 4586, 4583
2389, 235, 4, 183, 4402, 244, 205, 4587, 4585
2390, 121, 4395, 4403, 122, 4572, 4588, 4589, 144
2391, 4395, 4396, 4404, 4403, 4574, 4590, 4591, 4588
2392, 4396, 4397, 4405, 4404, 4576, 4592, 4593, 4590
2393, 4397, 4398, 4406, 4405, 4578, 4594, 4595, 4592
2394, 4398, 4399, 4407, 4406, 4580, 4596, 4597, 4594
2395, 4399, 4400, 4408, 4407, 4582, 4598, 4599, 4596
2396, 4400, 4401, 4409, 4408, 4584, 4600, 4601, 4598
2397, 4401, 4402, 4410, 4409, 4586, 4602, 4603, 4600
2398, 4402, 183, 184, 4410, 4587, 206, 4604, 4602
2399, 122, 4403, 4411, 123, 4589, 4605, 4606, 145
2400, 4403, 4404, 4412, 4411, 4591, 4607, 4608, 4605
2401, 4404, 4405, 4413, 4412, 4593, 4609, 4610, 4607
2402, 4405, 4406, 4414, 4413, 4595, 4611, 4612, 4609
2403, 4406, 4407, 4415, 4414, 4597, 4613, 4614, 4611
2404, 4407, 4408, 4416, 4415, 4599, 4615, 4616, 4613
2405, 4408, 4409, 4417, 4416, 4601, 4617, 4618, 4615
2406, 4409, 4410, 4418, 4417, 4603, 4619, 4620, 4617
2407, 4410, 184, 185, 4418, 4604, 207, 4621, 4619
2408, 123, 4411, 4419, 124, 4606, 4622, 4623, 146
2409, 4411, 4412, 4420, 4419, 4608, 4624, 4625, 4622
2410, 4412, 4413, 4421, 4420, 4610, 4626, 4627, 4624
2411, 4413, 4414, 4422, 4421, 4612, 4628, 4629, 4626
2412, 4414, 4415, 4423, 4422, 4614, 4630, 4631, 4628
2413, 4415, 4416, 4424, 4423, 4616, 4632, 4633, 4630
2414, 4416, 4417, 4425, 4424, 4618, 4634, 4635, 4632
2415, 4417, 4418, 4426, 4425, 4620, 4636, 4637, 4634
2416, 4418, 185, 186, 4426, 4621, 208, 4638, 4636
2417, 124, 4419, 4427, 125, 4623, 4639, 4640, 147
2418, 4419, 4420, 4428, 4427, 4625, 4641, 4642, 4639
2419, 4420, 4421, 4429, 4428, 4627, 4643, 4644, 4641
2420, 4421, 4422, 4430, 4429, 4629, 4645, 4646, 4643
2421, 4422, 4423, 4431, 4430, 4631, 4647, 4648, 4645
2422, 4423, 4424, 4432, 4431, 4633, 4649, 4650, 4647
2423, 4424, 4425, 4433, 4432, 4635, 4651, 4652, 4649
2424, 4425, 4426, 4434, 4433, 4637, 4653, 4654, 4651
2425, 4426, 186, 187, 4434, 4638, 209, 4655, 4653
2426, 125, 4427, 4435, 126, 4640, 4656, 4657, 148
2427, 4427, 4428, 4436, 4435, 4642, 4658, 4659, 4656
2428, 4428, 4429, 4437, 4436, 4644, 4660, 4661, 4658
2429, 4429, 4430, 4438, 4437, 4646, 4662, 4663, 4660
2430, 4430, 4431, 4439, 4438, 4648, 4664, 4665, 4662
2431, 4431, 4432, 4440, 4439, 4650, 4666, 4667, 4664
2432, 4432, 4433, 4441, 4440, 4652, 4668, 4669, 4666
2433, 4433, 4434, 4442, 4441, 4654, 4670, 4671, 4668
2434, 4434, 187, 188, 4442, 4655, 210, 4672, 4670
2435, 126, 4435, 4443, 127, 4657, 4673, 4674, 149
2436, 4435, 4436, 4444, 4443, 4659, 4675, 4676, 4673
2437, 4436, 4437, 4445, 4444, 4661, 4677, 4678, 4675
2438, 4437, 4438, 4446, 4445, 4663, 4679, 4680, 4677
2439, 4438, 4439, 4447, 4446, 4665, 4681, 4682, 4679
2440, 4439, 4440, 4448, 4447, 4667, 4683, 4684, 4681
2441, 4440, 4441, 4449, 4448, 4669, 4685, 4686, 4683
2442, 4441, 4442, 4450, 4449, 4671, 4687, 4688, 4685
2443, 4442, 188, 189, 4450, 4672, 211, 4689, 4687
2444, 127, 4443, 4451, 128, 4674, 4690, 4691, 150
2445, 4443, 4444, 4452, 4451, 4676, 4692, 4693, 4690
2446, 4444, 4445, 4453, 4452, 4678, 4694, 4695, 4692
2447, 4445, 4446, 4454, 4453, 4680, 4696, 4697, 4694
2448, 4446, 4447, 4455, 4454, 4682, 4698, 4699, 4696
2449, 4447, 4448, 4456, 4455, 4684, 4700, 4701, 4698
2450, 4448, 4449, 4457, 4456, 4686, 4702, 4703, 4700
2451, 4449, 4450, 4458, 4457, 4688, 4704, 4705, 4702
2452, 4450, 189, 190, 4458, 4689, 212, 4706, 4704
2453, 128, 4451, 4459, 129, 4691, 4707, 4708, 151
2454, 4451, 4452, 4460, 4459, 4693, 4709, 4710, 4707
2455, 4452, 4453, 4461, 4460, 4695, 4711, 4712, 4709
2456, 4453, 4454, 4462, 4461, 4697, 4713, 4714, 4711
2457, 4454, 4455, 4463, 4462, 4699, 4715, 4716, 4713
2458, 4455, 4456, 4464, 4463, 4701, 4717, 4718, 4715
2459, 4456, 4457, 4465, 4464, 4703, 4719, 4720, 4717
2460, 4457, 4458, 4466, 4465, 4705, 4721, 4722, 4719
2461, 4458, 190, 191, 4466, 4706, 213, 4723, 4721
2462, 129, 4459, 4467, 130, 4708, 4724, 4725, 152
2463, 4459, 4460, 4468, 4467, 4710, 4726, 4727, 4724
2464, 4460, 4461, 4469, 4468, 4712, 4728, 4729, 4726
2465, 4461, 4462, 4470, 4469, 4714, 4730, 4731, 4728
2466, 4462, 4463, 4471, 4470, 4716, 4732, 4733, 4730
2467, 4463, 4464, 4472, 4471, 4718, 4734, 4735, 4732
2468, 4464, 4465, 4473, 4472, 4720, 4736, 4737, 4734
2469, 4465, 4466, 4474, 4473, 4722, 4738, 4739, 4736
2470, 4466, 191, 192, 4474, 4723, 214, 4740, 4738
2471, 130, 4467, 4475, 131, 4725, 4741, 4742, 153
2472, 4467, 4468, 4476, 4475, 4727, 4743, 4744, 4741
2473, 4468, 4469, 4477, 4476, 4729, 4745, 4746, 4743
2474, 4469, 4470, 4478, 4477, 4731, 4747, 4748, 4745
2475, 4470, 4471, 4479, 4478, 4733, 4749, 4750, 4747
2476, 4471, 4472, 4480, 4479, 4735, 4751, 4752, 4749
2477, 4472, 4473, 4481, 4480, 4737, 4753, 4754, 4751
2478, 4473, 4474, 4482, 4481, 4739, 4755, 4756, 4753
2479, 4474, 192, 193, 4482, 4740, 215, 4757, 4755
2480, 131, 4475, 4483, 132, 4742, 4758, 4759, 154
2481, 4475, 4476, 4484, 4483, 4744, 4760, 4761, 4758
2482, 4476, 4477, 4485, 4484, 4746, 4762, 4763, 4760
2483, 4477, 4478, 4486, 4485, 4748, 4764, 4765, 4762
2484, 4478, 4479, 4487, 4486, 4750, 4766, 4767, 4764
2485, 4479, 4480, 4488, 4487, 4752, 4768, 4769, 4766
2486, 4480, 4481, 4489, 4488, 4754, 4770, 4771, 4768
2487, 4481, 4482, 4490, 4489, 4756, 4772, 4773, 4770
2488, 4482, 193, 194, 4490, 4757, 216, 4774, 4772
2489, 132, 4483, 4491, 133, 4759, 4775, 4776, 155
2490, 4483, 4484, 4492, 4491, 4761, 4777, 4778, 4775
2491, 4484, 4485, 4493, 4492, 4763, 4779, 4780, 4777
2492, 4485, 4486, 4494, 4493, 4765, 4781, 4782, 4779
2493, 4486, 4487, 4495, 4494, 4767, 4783, 4784, 4781
2494, 4487, 4488, 4496, 4495, 4769, 4785, 4786, 4783
2495, 4488, 4489, 4497, 4496, 4771, 4787, 4788, 4785
2496, 4489, 4490, 4498, 4497, 4773, 4789, 4790, 4787
2497, 4490, 194, 195, 4498, 4774, 217, 4791, 4789
2498, 133, 4491, 4499, 134, 4776, 4792, 4793, 156
2499, 4491, 4492, 4500, 4499, 4778, 4794, 4795, 4792
2500, 4492, 4493, 4501, 4500, 4780, 4796, 4797, 4794
2501, 4493, 4494, 4502, 4501, 4782, 4798, 4799, 4796
2502, 4494, 4495, 4503, 4502, 4784, 4800, 4801, 4798
2503, 4495, 4496, 4504, 4503, 4786, 4802, 4803, 4800
2504, 4496, 4497, 4505, 4504, 4788, 4804, 4805, 4802
2505, 4497, 4498, 4506, 4505, 4790, 4806, 4807, 4804
2506, 4498, 195, 196, 4506, 4791, 218, 4808, 4806
2507, 134, 4499, 4507, 135, 4793, 4809, 4810, 157
2508, 4499, 4500, 4508, 4507, 4795, 4811, 4812, 4809
2509, 4500, 4501, 4509, 4508, 4797, 4813, 4814, 4811
2510, 4501, 4502, 4510, 4509, 4799, 4815, 4816, 4813
2511, 4502, 4503, 4511, 4510, 4801, 4817, 4818, 4815
2512, 4503, 4504, 4512, 4511, 4803, 4819, 4820, 4817
2513, 4504, 4505, 4513, 4512, 4805, 4821, 4822, 4819
2514, 4505, 4506, 4514, 4513, 4807, 4823, 4824, 4821
2515, 4506, 196, 197, 4514, 4808, 219, 4825, 4823
2516, 135, 4507, 4515, 136, 4810, 4826, 4827, 158
2517, 4507, 4508, 4516, 4515, 4812, 4828, 4829, 4826
2518, 4508, 4509, 4517, 4516, 4814, 4830, 4831, 4828
2519, 4509, 4510, 4518, 4517, 4816, 4832, 4833, 4830
2520, 4510, 4511, 4519, 4518, 4818, 4834, 4835, 4832
2521, 4511, 4512, 4520, 4519, 4820, 4836, 4837, 4834
2522, 4512, 4513, 4521, 4520, 4822, 4838, 4839, 4836
2523, 4513, 4514, 4522, 4521, 4824, 4840, 4841, 4838
2524, 4514, 197, 198, 4522, 4825, 220, 4842, 4840
2525, 136, 4515, 4523, 137, 4827, 4843, 4844, 159
2526, 4515, 4516, 4524, 4523, 4829, 4845, 4846, 4843
2527, 4516, 4517, 4525, 4524, 4831, 4847, 4848, 4845
2528, 4517, 4518, 4526, 4525, 4833, 4849, 4850, 4847
2529, 4518, 4519, 4527, 4526, 4835, 4851, 4852, 4849
2530, 4519, 4520, 4528, 4527, 4837, 4853, 4854, 4851
2531, 4520, 4521, 4529, 4528, 4839, 4855, 4856, 4853
2532, 4521, 4522, 4530, 4529, 4841, 4857, 4858, 4855
2533, 4522, 198, 199, 4530, 4842, 221, 4859, 4857
2534, 137, 4523, 4531, 138, 4844, 4860, 4861, 160
2535, 4523, 4524, 4532, 4531, 4846, 4862, 4863, 4860
2536, 4524, 4525, 4533, 4532, 4848, 4864, 4865, 4862
2537, 4525, 4526, 4534, 4533, 4850, 4866, 4867, 4864
2538, 4526, 4527, 4535, 4534, 4852, 4868, 4869, 4866
2539, 4527, 4528, 4536, 4535, 4854, 4870, 4871, 4868
2540, 4528, 4529, 4537, 4536, 4856, 4872, 4873, 4870
2541, 4529, 4530, 4538, 4537, 4858, 4874, 4875, 4872
2542, 4530, 199, 200, 4538, 4859, 222, 4876, 4874
2543, 138, 4531, 4539, 139, 4861, 4877, 4878, 161
2544, 4531, 4532, 4540, 4539, 4863, 4879, 4880, 4877
2545, 4532, 4533, 4541, 4540, 4865, 4881, 4882, 4879
2546, 4533, 4534, 4542, 4541, 4867, 4883, 4884, 4881
2547, 4534, 4535, 4543, 4542, 4869, 4885, 4886, 4883
2548, 4535, 4536, 4544, 4543, 4871, 4887, 4888, 4885
2549, 4536, 4537, 4545, 4544, 4873, 4889, 4890, 4887
2550, 4537, 4538, 4546, 4545, 4875, 4891, 4892, 4889
2551, 4538, 200, 201, 4546, 4876, 223, 4893, 4891
2552, 139, 4539, 4547, 140, 4878, 4894, 4895, 162
2553, 4539, 4540, 4548, 4547, 4880, 4896, 4897, 4894
2554, 4540, 4541, 4549, 4548, 4882, 4898, 4899, 4896
2555, 4541, 4542, 4550, 4549, 4884, 4900, 4901, 4898
2556, 4542, 4543, 4551, 4550, 4886, 4902, 4903, 4900
2557, 4543, 4544, 4552, 4551, 4888, 4904, 4905, 4902
2558, 4544, 4545, 4553, 4552, 4890, 4906, 4907, 4904
2559, 4545, 4546, 4554, 4553, 4892, 4908, 4909, 4906
2560, 4546, 201, 202, 4554, 4893, 224, 4910, 4908
2561, 140, 4547, 4555, 141, 4895, 4911, 4912, 163
2562, 4547, 4548, 4556, 4555, 4897, 4913, 4914, 4911
2563, 4548, 4549, 4557, 4556, 4899, 4915, 4916, 4913
2564, 4549, 4550, 4558, 4557, 4901, 4917, 4918, 4915
2565, 4550, 4551, 4559, 4558, 4903, 4919, 4920, 4917
2566, 4551, 4552, 4560, 4559, 4905, 4921, 4922, 4919
2567, 4552, 4553, 4561, 4560, 4907, 4923, 4924, 4921
2568, 4553, 4554, 4562, 4561, 4909, 4925, 4926, 4923
2569, 4554, 202, 203, 4562, 4910, 225, 4927, 4925
2570, 141, 4555, 4563, 142, 4912, 4928, 4929, 164
2571, 4555, 4556, 4564, 4563, 4914, 4930, 4931, 4928
2572, 4556, 4557, 4565, 4564, 4916, 4932, 4933, 4930
2573, 4557, 4558, 4566, 4565, 4918, 4934, 4935, 4932
2574, 4558, 4559, 4567, 4566, 4920, 4936, 4937, 4934
2575, 4559, 4560, 4568, 4567, 4922, 4938, 4939, 4936
2576, 4560, 4561, 4569, 4568, 4924, 4940, 4941, 4938
2577, 4561, 4562, 4570, 4569, 4926, 4942, 4943, 4940
2578, 4562, 203, 204, 4570, 4927, 226, 4944, 4942
2579, 142, 4563, 166, 1, 4929, 4945, 174, 165
2580, 4563, 4564, 167, 166, 4931, 4946, 175, 4945
2581, 4564, 4565, 168, 167, 4933, 4947, 176, 4946
2582, 4565, 4566, 169, 168, 4935, 4948, 177, 4947
2583, 4566, 4567, 170, 169, 4937, 4949, 178, 4948
2584, 4567, 4568, 171, 170, 4939, 4950, 179, 4949
2585, 4568, 4569, 172, 171, 4941, 4951, 180, 4950
2586, 4569, 4570, 173, 172, 4943, 4952, 181, 4951
2587, 4570, 204, 3, 173, 4944, 227, 182, 4952
*ELEMENT, type=CPS8, ELSET=Surface46
2588, 5, 342, 4953, 245, 351, 5129, 5130, 267
2589, 342, 341, 4954, 4953, 350, 5131, 5132, 5129
2590, 341, 340, 4955, 4954, 349, 5133, 5134, 5131
2591, 340, 339, 4956, 4955, 348, 5135, 5136, 5133
2592, 339, 338, 4957, 4956, 347, 5137, 5138, 5135
2593, 338, 337, 4958, 4957, 346, 5139, 5140, 5137
2594, 337, 336, 4959, 4958, 345, 5141, 5142, 5139
2595, 336, 335, 4960, 4959, 344, 5143, 5144, 5141
2596, 335, 7, 290, 4960, 343, 312, 5145, 5143
2597, 245, 4953, 4961, 246, 5130, 5146, 5147, 268
2598, 4953, 4954, 4962, 4961, 5132, 5148, 5149, 5146
2599, 4954, 4955, 4963, 4962, 5134, 5150, 5151, 5148
2600, 4955, 4956, 4964, 4963, 5136, 5152, 5153, 5150
2601, 4956, 4957, 4965, 4964, 5138, 5154, 5155, 5152
2602, 4957, 4958, 4966, 4965, 5140, 5156, 5157, 5154
2603, 4958, 4959, 4967, 4966, 5142, 5158, 5159, 5156
2604, 4959, 4960, 4968, 4967, 5144, 5160, 5161, 5158
2605, 4960, 290, 291, 4968, 5145, 313, 5162, 5160
2606, 246, 4961, 4969, 247, 5147, 5163, 5164, 269
2607, 4961, 4962, 4970, 4969, 5149, 5165, 5166, 5163
2608, 4962, 4963, 4971, 4970, 5151, 5167, 5168, 5165
2609, 4963, 4964, 4972, 4971, 5153, 5169, 5170, 5167
2610, 4964, 4965, 4973, 4972, 5155, 5171, 5172, 5169
2611, 4965, 4966, 4974, 4973, 5157, 5173, 5174, 5171
2612, 4966, 4967, 4975, 4974, 5159, 5175, 5176, 5173
2613, 4967, 4968, 4976, 4975, 5161, 5177, 5178, 5175
2614, 4968, 291, 292, 4976, 5162, 314, 5179, 5177
2615, 247, 4969, 4977, 248, 5164, 5180, 5181, 270
2616, 4969, 4970, 4978, 4977, 5166, 5182, 5183, 5180
2617, 4970, 4971, 4979, 4978, 5168, 5184, 5185, 5182
2618, 4971, 4972, 4980, 4979, 5170, 5186, 5187, 5184
2619, 4972, 4973, 4981, 4980, 5172, 5188, 5189, 5186
2620, 4973, 4974, 4982, 4981, 5174, 5190, 5191, 5188
2621, 4974, 4975, 4983, 4982, 5176, 5192, 5193, 5190
2622, 4975, 4976, 4984, 4983, 5178, 5194, 5195, 5192
2623, 4976, 292, 293, 4984, 5179, 315, 5196, 5194
2624, 248, 4977, 4985, 249, 5181, 5197, 5198, 271
2625, 4977, 4978, 4986, 4985, 5183, 5199, 5200, 5197
2626, 4978, 4979, 4987, 4986, 5185, 5201, 5202, 5199
2627, 4979, 4980, 4988, 4987, 5187, 5203, 5204, 5201
2628, 4980, 4981, 4989, 4988, 5189, 5205, 5206, 5203
2629, 4981, 4982, 4990, 4989, 5191, 5207, 5208, 5205
2630, 4982, 4983, 4991, 4990, 5193, 5209, 5210, 5207
2631, 4983, 4984, 4992, 4991, 5195, 5211, 5212, 5209
2632, 4984, 293, 294, 4992, 5196, 316, 5213, 5211
2633, 249, 4985, 4993, 250, 5198, 5214, 5215, 272
2634, 4985, 4986, 4994, 4993, 5200, 5216, 5217, 5214
2635, 4986, 4987, 4995, 4994, 5202, 5218, 5219, 5216
2636, 4987, 4988, 4996, 4995, 5204, 5220, 5221, 5218
2637, 4988, 4989, 4997, 4996, 5206, 5222, 5223, 5220
2638, 4989, 4990, 4998, 4997, 5208, 5224, 5225, 5222
2639, 4990, 4991, 4999, 4998, 5210, 5226, 5227, 5224
2640, 4991, 4992, 5000, 4999, 5212, 5228, 5229, 5226
2641, 4992, 294, 295, 5000, 5213, 317, 5230, 5228
2642, 250, 4993, 5001, 251, 5215, 5231, 5232, 273
2643, 4993, 4994, 5002, 5001, 5217, 5233, 5234, 5231
2644, 4994, 4995, 5003, 5002, 5219, 5235, 5236, 5233
2645, 4995, 4996, 5004, 5003, 5221, 5237, 5238, 5235
2646, 4996, 4997, 5005, 5004, 5223, 5239, 5240, 5237
2647, 4997, 4998, 5006, 5005, 5225, 5241, 5242, 5239
2648, 4998, 4999, 5007, 5006, 5227, 5243, 5244, 5241
2649, 4999, 5000, 5008, 5007, 5229, 5245, 5246, 5243
2650, 5000, 295, 296, 5008, 5230, 318, 5247, 5245
2651, 251, 5001, 5009, 252, 5232, 5248, 5249, 274
2652, 5001, 5002, 5010, 5009, 5234, 5250, 5251, 5248
2653, 5002, 5003, 5011, 5010, 5236, 5252, 5253, 5250
2654, 5003, 5004, 5012, 5011, 5238, 5254, 5255, 5252
2655, 5004, 5005, 5013, 5012, 5240, 5256, 5257, 5254
2656, 5005, 5006, 5014, 5013, 5242, 5258, 5259, 5256
2657, 5006, 5007, 5015, 5014, 5244, 5260, 5261, 5258
2658, 5007, 5008, 5016, 5015, 5246, 5262, 5263, 5260
2659, 5008, 296, 297, 5016, 5247, 319, 5264, 5262
2660, 252, 5009, 5017, 253, 5249, 5265, 5266, 275
2661, 5009, 5010, 5018, 5017, 5251, 5267, 5268, 5265
2662, 5010, 5011, 5019, 5018, 5253, 5269, 5270, 5267
2663, 5011, 5012, 5020, 5019, 5255, 5271, 5272, 5269
2664, 5012, 5013, 5021, 5020, 5257, 5273, 5274, 5271
2665, 5013, 5014, 5022, 5021, 5259, 5275, 5276, 5273
2666, 5014, 5015, 5023, 5022, 5261, 5277, 5278, 5275
2667, 5015, 5016, 5024, 5023, 5263, 5279, 5280, 5277
2668, 5016, 297, 298, 5024, 5264, 320, 5281, 5279
2669, 253, 5017, 5025, 254, 5266, 5282, 5283, 276
2670, 5017, 5018, 5026, 5025, 5268, 5284, 5285, 5282
2671, 5018, 5019, 5027, 5026, 5270, 5286, 5287, 5284
2672, 5019, 5020, 5028, 5027, 5272, 5288, 5289, 5286
2673, 5020, 5021, 5029, 5028, 5274, 5290, 5291, 5288
2674, 5021, 5022, 5030, 5029, 5276, 5292, 5293, 5290
2675, 5022, 5023, 5031, 5030, 5278, 5294, 5295, 5292
2676, 5023, 5024, 5032, 5031, 5280, 5296, 5297, 5294
2677, 5024, 298, 299, 5032, 5281, 321, 5298, 5296
2678, 254, 5025, 5033, 255, 5283, 5299, 5300, 277
2679, 5025, 5026, 5034, 5033, 5285, 5301, 5302, 5299
2680, 5026, 5027, 5035, 5034, 5287, 5303, 5304, 5301
2681, 5027, 5028, 5036, 5035, 5289, 5305, 5306, 5303
2682, 5028, 5029, 5037, 5036, 5291, 5307, 5308, 5305
2683, 5029, 5030, 5038, 5037, 5293, 5309, 5310, 5307
2684, 5030, 5031, 5039, 5038, 5295, 5311, 5312, 5309
2685, 5031, 5032, 5040, 5039, 5297, 5313, 5314, 5311
2686, 5032, 299, 300, 5040, 5298, 322, 5315, 5313
2687, 255, 5033, 5041, 256, 5300, 5316, 5317, 278
2688, 5033, 5034, 5042, 5041, 5302, 5318, 5319, 5316
2689, 5034, 5035, 5043, 5042, 5304, 5320, 5321, 5318
2690, 5035, 5036, 5044, 5043, 5306, 5322, 5323, 5320
2691, 5036, 5037, 5045, 5044, 5308, 5324, 5325, 5322
2692, 5037, 5038, 5046, 5045, 5310, 5326, 5327, 5324
2693, 5038, 5039, 5047, 5046, 5312, 5328, 5329, 5326
2694, 5039, 5040, 5048, 5047, 5314, 5330, 5331, 5328
2695, 5040, 300, 301, 5048, 5315, 323, 5332, 5330
2696, 256, 5041, 5049, 257, 5317, 5333, 5334, 279
2697, 5041, 5042, 5050, 5049, 5319, 5335, 5336, 5333
2698, 5042, 5043, 5051, 5050, 5321, 5337, 5338, 5335
2699, 5043, 5044, 5052, 5051, 5323, 5339, 5340, 5337
2700, 5044, 5045, 5053, 5052, 5325, 5341, 5342, 5339
2701, 5045, 5046, 5054, 5053, 5327, 5343, 5344, 5341
2702, 5046, 5047, 5055, 5054, 5329, 5345, 5346, 5343
2703, 5047, 5048, 5056, 5055, 5331, 5347, 5348, 5345
2704, 5048, 301, 302, 5056, 5332, 324, 5349, 5347
2705, 257, 5049, 5057, 258, 5334, 5350, 5351, 280
2706, 5049, 5050, 5058, 5057, 5336, 5352, 5353, 5350
2707, 5050, 5051, 5059, 5058, 5338, 5354, 5355, 5352
2708, 5051, 5052, 5060, 5059, 5340, 5356, 5357, 5354
2709, 5052, 5053, 5061, 5060, 5342, 5358, 5359, 5356
2710, 5053, 5054, 5062, 5061, 5344, 5360, 5361, 5358
2711, 5054, 5055, 5063, 5062, 5346, 5362, 5363, 5360
2712, 5055, 5056, 5064, 5063, 5348, 5364, 5365, 5362
2713, 5056, 302, 303, 5064, 5349, 325, 5366, 5364
2714, 258, 5057, 5065, 259, 5351, 5367, 5368, 281
2715, 5057, 5058, 5066, 5065, 5353, 5369, 5370, 5367
2716, 5058, 5059, 5067, 5066, 5355, 5371, 5372, 5369
2717, 5059, 5060, 5068, 5067, 5357, 5373, 5374, 5371
2718, 5060, 5061, 5069, 5068, 5359, 5375, 5376, 5373
2719, 5061, 5062, 5070, 5069, 5361, 5377, 5378, 5375
2720, 5062, 5063, 5071, 5070, 5363, 5379, 5380, 5377
2721, 5063, 5064, 5072, 5071, 5365, 5381, 5382, 5379
2722, 5064, 303, 304, 5072, 5366, 326, 5383, 5381
2723, 259, 5065, 5073, 260, 5368, 5384, 5385, 282
2724, 5065, 5066, 5074, 5073, 5370, 5386, 5387, 5384
2725, 5066, 5067, 5075, 5074, 5372, 5388, 5389, 5386
2726, 5067, 5068, 5076, 5075, 5374, 5390, 5391, 5388
2727, 5068, 5069, 5077, 5076, 5376, 5392, 5393, 5390
2728, 5069, 5070, 5078, 5077, 5378, 5394, 5395, 5392
2729, 5070, 5071, 5079, 5078, 5380, 5396, 5397, 5394
2730, 5071, 5072, 5080, 5079, 5382, 5398, 5399, 5396
2731, 5072, 304, 305, 5080, 5383, 327, 5400, 5398
2732, 260, 5073, 5081, 261, 5385, 5401, 5402, 283
2733, 5073, 5074, 5082, 5081, 5387, 5403, 5404, 5401
2734, 5074, 5075, 5083, 5082, 5389, 5405, 5406, 5403
2735, 5075, 5076, 5084, 5083, 5391, 5407, 5408, 5405
2736, 5076, 5077, 5085, 5084, 5393, 5409, 5410, 5407
2737, 5077, 5078, 5086, 5085, 5395, 5411, 5412, 5409
2738, 5078, 5079, 5087, 5086, 5397, 5413, 5414, 5411
2739, 5079, 5080, 5088, 5087, 5399, 5415, 5416, 5413
2740, 5080, 305, 306, 5088, 5400, 328, 5417, 5415
2741, 261, 5081, 5089, 262, 5402, 5418, 5419, 284
2742, 5081, 5082, 5090, 5089, 5404, 5420, 5421, 5418
2743, 5082, 5083, 5091, 5090, 5406, 5422, 5423, 5420
2744, 5083, 5084, 5092, 5091, 5408, 5424, 5425, 5422
2745, 5084, 5085, 5093, 5092, 5410, 5426, 5427, 5424
2746, 5085, 5086, 5094, 5093, 5412, 5428, 5429, 5426
2747, 5086, 5087, 5095, 5094, 5414, 5430, 5431, 5428
2748, 5087, 5088, 5096, 5095, 5416, 5432, 5433, 5430
2749, 5088, 306, 307, 5096, 5417, 329, 5434, 5432
2750, 262, 5089, 5097, 263, 5419, 5435, 5436, 285
2751, 5089, 5090, 5098, 5097, 5421, 5437, 5438, 5435
2752, 5090, 5091, 5099, 5098, 5423, 5439, 5440, 5437
2753, 5091, 5092, 5100, 5099, 5425, 5441, 5442, 5439
2754, 5092, 5093, 5101, 5100, 5427, 5443, 5444, 5441
2755, 5093, 5094, 5102, 5101, 5429, 5445, 5446, 5443
2756, 5094, 5095, 5103, 5102, 5431, 5447, 5448, 5445
2757, 5095, 5096, 5104, 5103, 5433, 5449, 5450, 5447
2758, 5096, 307, 308, 5104, 5434, 330, 5451, 5449
2759, 263, 5097, 5105, 264, 5436, 5452, 5453, 286
2760, 5097, 5098, 5106, 5105, 5438, 5454, 5455, 5452
2761, 5098, 5099, 5107, 5106, 5440, 5456, 5457, 5454
2762, 5099, 5100, 5108, 5107, 5442, 5458, 5459, 5456
2763, 5100, 5101, 5109, 5108, 5444, 5460, 5461, 5458
2764, 5101, 5102, 5110, 5109, 5446, 5462, 5463, 5460
2765, 5102, 5103, 5111, 5110, 5448, 5464, 5465, 5462
2766, 5103, 5104, 5112, 5111, 5450, 5466, 5467, 5464
2767, 5104, 308, 309, 5112, 5451, 331, 5468, 5466
2768, 264, 5105, 5113, 265, 5453, 5469, 5470, 287
2769, 5105, 5106, 5114, 5113, 5455, 5471, 5472, 5469
2770, 5106, 5107, 5115, 5114, 5457, 5473, 5474, 5471
2771, 5107, 5108, 5116, 5115, 5459, 5475, 5476, 5473
2772, 5108, 5109, 5117, 5116, 5461, 5477, 5478, 5475
2773, 5109, 5110, 5118, 5117, 5463, 5479, 5480, 5477
2774, 5110, 5111, 5119, 5118, 5465, 5481, 5482, 5479
2775, 5111, 5112, 5120, 5119, 5467, 5483, 5484, 5481
2776, 5112, 309, 310, 5120, 5468, 332, 5485, 5483
2777, 265, 5113, 5121, 266, 5470, 5486, 5487, 288
2778, 5113, 5114, 5122, 5121, 5472, 5488, 5489, 5486
2779, 5114, 5115, 5123, 5122, 5474, 5490, 5491, 5488
2780, 5115, 5116, 5124, 5123, 5476, 5492, 5493, 5490
2781, 5116, 5117, 5125, 5124, 5478, 5494, 5495, 5492
2782, 5117, 5118, 5126, 5125, 5480, 5496, 5497, 5494
2783, 5118, 5119, 5127, 5126, 5482, 5498, 5499, 5496
2784, 5119, 5120, 5128, 5127, 5484, 5500, 5501, 5498
2785, 5120, 310, 311, 5128, 5485, 333, 5502, 5500
2786, 266, 5121, 359, 6, 5487, 5503, 368, 289
2787, 5121, 5122, 358, 359, 5489, 5504, 367, 5503
2788, 5122, 5123, 357, 358, 5491, 5505, 366, 5504
2789, 5123, 5124, 356, 357, 5493, 5506, 365, 5505
2790, 5124, 5125, 355, 356, 5495, 5507, 364, 5506
2791, 5125, 5126, 354, 355, 5497, 5508, 363, 5507
2792, 5126, 5127, 353, 354, 5499, 5509, 362, 5508
2793, 5127, 5128, 352, 353, 5501, 5510, 361, 5509
2794, 5128, 311, 8, 352, 5502, 334, 360, 5510
*ELEMENT, type=CPS8, ELSET=Surface63
2795, 9, 369, 5511, 376, 370, 5513, 5514, 379
2796, 376, 5511, 5512, 375, 5514, 5515, 5516, 378
2797, 375, 5512, 372, 11, 5516, 5517, 373, 377
2798, 369, 10, 381, 5511, 371, 384, 5518, 5513
2799, 5511, 381, 380, 5512, 5518, 383, 5519, 5515
2800, 5512, 380, 12, 372, 5519, 382, 374, 5517
*ELEMENT, type=CPS8, ELSET=Surface163
2801, 11, 372, 5520, 395, 373, 5528, 5529, 404
2802, 395, 5520, 5521, 394, 5529, 5530, 5531, 403
2803, 394, 5521, 5522, 393, 5531, 5532, 5533, 402
2804, 393, 5522, 5523, 392, 5533, 5534, 5535, 401
2805, 392, 5523, 5524, 391, 5535, 5536, 5537, 400
2806, 391, 5524, 5525, 390, 5537, 5538, 5539, 399
2807, 390, 5525, 5526, 389, 5539, 5540, 5541, 398
2808, 389, 5526, 5527, 388, 5541, 5542, 5543, 397
2809, 388, 5527, 385, 13, 5543, 5544, 386, 396
2810, 372, 12, 412, 5520, 374, 421, 5545, 5528
2811, 5520, 412, 411, 5521, 5545, 420, 5546, 5530
2812, 5521, 411, 410, 5522, 5546, 419, 5547, 5532
2813, 5522, 410, 409, 5523, 5547, 418, 5548, 5534
2814, 5523, 409, 408, 5524, 5548, 417, 5549, 5536
2815, 5524, 408, 407, 5525, 5549, 416, 5550, 5538
2816, 5525, 407, 406, 5526, 5550, 415, 5551, 5540
2817, 5526, 406, 405, 5527, 5551, 414, 5552, 5542
2818, 5527, 405, 14, 385, 5552, 413, 387, 5544
*ELEMENT, type=CPS8, ELSET=Surface164
2819, 9, 432, 5553, 369, 441, 5561, 5562, 370
2820, 432, 431, 5554, 5553, 440, 5563, 5564, 5561
2821, 431, 430, 5555, 5554, 439, 5565, 5566, 5563
2822, 430, 429, 5556, 5555, 438, 5567, 5568, 5565
2823, 429, 428, 5557, 5556, 437, 5569, 5570, 5567
2824, 428, 427, 5558, 5557, 436, 5571, 5572, 5569
2825, 427, 426, 5559, 5558, 435, 5573, 5574, 5571
2826, 426, 425, 5560, 5559, 434, 5575, 5576, 5573
2827, 425, 15, 422, 5560, 433, 423, 5577, 5575
2828, 369, 5553, 449, 10, 5562, 5578, 458, 371
2829, 5553, 5554, 448, 449, 5564, 5579, 457, 5578
2830, 5554, 5555, 447, 448, 5566, 5580, 456, 5579
2831, 5555, 5556, 446, 447, 5568, 5581, 455, 5580
2832, 5556, 5557, 445, 446, 5570, 5582, 454, 5581
2833, 5557, 5558, 444, 445, 5572, 5583, 453, 5582
2834, 5558, 5559, 443, 444, 5574, 5584, 452, 5583
2835, 5559, 5560, 442, 443, 5576, 5585, 451, 5584
2836, 5560, 422, 16, 442, 5577, 424, 450, 5585
*ELEMENT, type=CPS8, ELSET=Surface165
2837, 15, 460, 5586, 422, 463, 5588, 5589, 423
2838, 460, 459, 5587, 5586, 462, 5590, 5591, 5588
2839, 459, 13, 385, 5587, 461, 386, 5592, 5590
2840, 422, 5586, 465, 16, 5589, 5593, 468, 424
2841, 5586, 5587, 464, 465, 5591, 5594, 467, 5593
2842, 5587, 385, 14, 464, 5592, 387, 466, 5594
*ELEMENT, type=CPS8, ELSET=Surface166
2843, 13, 459, 5595, 388, 461, 5611, 5612, 396
2844, 459, 460, 5596, 5595, 462, 5613, 5614, 5611
2845, 460, 15, 425, 5596, 463, 433, 5615, 5613
2846, 388, 5595, 5597, 389, 5612, 5616, 5617, 397
2847, 5595, 5596, 5598, 5597, 5614, 5618, 5619, 5616
2848, 5596, 425, 426, 5598, 5615, 434, 5620, 5618
2849, 389, 5597, 5599, 390, 5617, 5621, 5622, 398
2850, 5597, 5598, 5600, 5599, 5619, 5623, 5624, 5621
2851, 5598, 426, 427, 5600, 5620, 435, 5625, 5623
2852, 390, 5599, 5601, 391, 5622, 5626, 5627, 399
2853, 5599, 5600, 5602, 5601, 5624, 5628, 5629, 5626
2854, 5600, 427, 428, 5602, 5625, 436, 5630, 5628
2855, 391, 5601, 5603, 392, 5627, 5631, 5632, 400
2856, 5601, 5602, 5604, 5603, 5629, 5633, 5634, 5631
2857, 5602, 428, 429, 5604, 5630, 437, 5635, 5633
2858, 392, 5603, 5605, 393, 5632, 5636, 5637, 401
2859, 5603, 5604, 5606, 5605, 5634, 5638, 5639, 5636
2860, 5604, 429, 430, 5606, 5635, 438, 5640, 5638
2861, 393, 5605, 5607, 394, 5637, 5641, 5642, 402
2862, 5605, 5606, 5608, 5607, 5639, 5643, 5644, 5641
2863, 5606, 430, 431, 5608, 5640, 439, 5645, 5643
2864, 394, 5607, 5609, 395, 5642, 5646, 5647, 403
2865, 5607, 5608, 5610, 5609, 5644, 5648, 5649, 5646
2866, 5608, 431, 432, 5610, 5645, 440, 5650, 5648
2867, 395, 5609, 375, 11, 5647, 5651, 377, 404
2868, 5609, 5610, 376, 375, 5649, 5652, 378, 5651
2869, 5610, 432, 9, 376, 5650, 441, 379, 5652
*ELEMENT, type=CPS8, ELSET=Surface167
2870, 14, 405, 5653, 464, 413, 5669, 5670, 466
2871, 464, 5653, 5654, 465, 5670, 5671, 5672, 467
2872, 465, 5654, 442, 16, 5672, 5673, 450, 468
2873, 405, 406, 5655, 5653, 414, 5674, 5675, 5669
2874, 5653, 5655, 5656, 5654, 5675, 5676, 5677, 5671
2875, 5654, 5656, 443, 442, 5677, 5678, 451, 5673
2876, 406, 407, 5657, 5655, 415, 5679, 5680, 5674
2877, 5655, 5657, 5658, 5656, 5680, 5681, 5682, 5676
2878, 5656, 5658, 444, 443, 5682, 5683, 452, 5678
2879, 407, 408, 5659, 5657, 416, 5684, 5685, 5679
2880, 5657, 5659, 5660, 5658, 5685, 5686, 5687, 5681
2881, 5658, 5660, 445, 444, 5687, 5688, 453, 5683
2882, 408, 409, 5661, 5659, 417, 5689, 5690, 5684
2883, 5659, 5661, 5662, 5660, 5690, 5691, 5692, 5686
2884, 5660, 5662, 446, 445, 5692, 5693, 454, 5688
2885, 409, 410, 5663, 5661, 418, 5694, 5695, 5689
2886, 5661, 5663, 5664, 5662, 5695, 5696, 5697, 5691
2887, 5662, 5664, 447, 446, 5697, 5698, 455, 5693
2888, 410, 411, 5665, 5663, 419, 5699, 5700, 5694
2889, 5663, 5665, 5666, 5664, 5700, 5701, 5702, 5696
2890, 5664, 5666, 448, 447, 5702, 5703, 456, 5698
2891, 411, 412, 5667, 5665, 420, 5704, 5705, 5699
2892, 5665, 5667, 5668, 5666, 5705, 5706, 5707, 5701
2893, 5666, 5668, 449, 448, 5707, 5708, 457, 5703
2894, 412, 12, 380, 5667, 421, 382, 5709, 5704
2895, 5667, 380, 381, 5668, 5709, 383, 5710, 5706
2896, 5668, 381, 10, 449, 5710, 384, 458, 5708
*ELEMENT, type=CPS8, ELSET=Surface168
2897, 11, 372, 5711, 469, 373, 5714, 5715, 472
2898, 372, 12, 476, 5711, 374, 479, 5716, 5714
2899, 469, 5711, 5712, 470, 5715, 5717, 5718, 473
2900, 5711, 476, 477, 5712, 5716, 480, 5719, 5717
2901, 470, 5712, 5713, 471, 5718, 5720, 5721, 474
2902, 5712, 477, 478, 5713, 5719, 481, 5722, 5720
2903, 471, 5713, 483, 17, 5721, 5723, 484, 475
2904, 5713, 478, 18, 483, 5722, 482, 485, 5723
*ELEMENT, type=CPS8, ELSET=Surface169
2905, 13, 486, 5724, 385, 489, 5727, 5728, 386
2906, 385, 5724, 493, 14, 5728, 5729, 496, 387
2907, 486, 487, 5725, 5724, 490, 5730, 5731, 5727
2908, 5724, 5725, 494, 493, 5731, 5732, 497, 5729
2909, 487, 488, 5726, 5725, 491, 5733, 5734, 5730
2910, 5725, 5726, 495, 494, 5734, 5735, 498, 5732
2911, 488, 19, 500, 5726, 492, 501, 5736, 5733
2912, 5726, 500, 20, 495, 5736, 502, 499, 5735
*ELEMENT, type=CPS8, ELSET=Surface170
2913, 11, 469, 5737, 395, 472, 5761, 5762, 404
2914, 395, 5737, 5738, 394, 5762, 5763, 5764, 403
2915, 394, 5738, 5739, 393, 5764, 5765, 5766, 402
2916, 393, 5739, 5740, 392, 5766, 5767, 5768, 401
2917, 392, 5740, 5741, 391, 5768, 5769, 5770, 400
2918, 391, 5741, 5742, 390, 5770, 5771, 5772, 399
2919, 390, 5742, 5743, 389, 5772, 5773, 5774, 398
2920, 389, 5743, 5744, 388, 5774, 5775, 5776, 397
2921, 388, 5744, 486, 13, 5776, 5777, 489, 396
2922, 469, 470, 5745, 5737, 473, 5778, 5779, 5761
2923, 5737, 5745, 5746, 5738, 5779, 5780, 5781, 5763
2924, 5738, 5746, 5747, 5739, 5781, 5782, 5783, 5765
2925, 5739, 5747, 5748, 5740, 5783, 5784, 5785, 5767
2926, 5740, 5748, 5749, 5741, 5785, 5786, 5787, 5769
2927, 5741, 5749, 5750, 5742, 5787, 5788, 5789, 5771
2928, 5742, 5750, 5751, 5743, 5789, 5790, 5791, 5773
2929, 5743, 5751, 5752, 5744, 5791, 5792, 5793, 5775
2930, 5744, 5752, 487, 486, 5793, 5794, 490, 5777
2931, 470, 471, 5753, 5745, 474, 5795, 5796, 5778
2932, 5745, 5753, 5754, 5746, 5796, 5797, 5798, 5780
2933, 5746, 5754, 5755, 5747, 5798, 5799, 5800, 5782
2934, 5747, 5755, 5756, 5748, 5800, 5801, 5802, 5784
2935, 5748, 5756, 5757, 5749, 5802, 5803, 5804, 5786
2936, 5749, 5757, 5758, 5750, 5804, 5805, 5806, 5788
2937, 5750, 5758, 5759, 5751, 5806, 5807, 5808, 5790
2938, 5751, 5759, 5760, 5752, 5808, 5809, 5810, 5792
2939, 5752, 5760, 488, 487, 5810, 5811, 491, 5794
2940, 471, 17, 510, 5753, 475, 519, 5812, 5795
2941, 5753, 510, 509, 5754, 5812, 518, 5813, 5797
2942, 5754, 509, 508, 5755, 5813, 517, 5814, 5799
2943, 5755, 508, 507, 5756, 5814, 516, 5815, 5801
2944, 5756, 507, 506, 5757, 5815, 515, 5816, 5803
2945, 5757, 506, 505, 5758, 5816, 514, 5817, 5805
2946, 5758, 505, 504, 5759, 5817, 513, 5818, 5807
2947, 5759, 504, 503, 5760, 5818, 512, 5819, 5809
2948, 5760, 503, 19, 488, 5819, 511, 492, 5811
*ELEMENT, type=CPS8, ELSET=Surface171
2949, 12, 412, 5820, 476, 421, 5844, 5845, 479
2950, 412, 411, 5821, 5820, 420, 5846, 5847, 5844
2951, 411, 410, 5822, 5821, 419, 5848, 5849, 5846
2952, 410, 409, 5823, 5822, 418, 5850, 5851, 5848
2953, 409, 408, 5824, 5823, 417, 5852, 5853, 5850
2954, 408, 407, 5825, 5824, 416, 5854, 5855, 5852
2955, 407, 406, 5826, 5825, 415, 5856, 5857, 5854
2956, 406, 405, 5827, 5826, 414, 5858, 5859, 5856
2957, 405, 14, 493, 5827, 413, 496, 5860, 5858
2958, 476, 5820, 5828, 477, 5845, 5861, 5862, 480
2959, 5820, 5821, 5829, 5828, 5847, 5863, 5864, 5861
2960, 5821, 5822, 5830, 5829, 5849, 5865, 5866, 5863
2961, 5822, 5823, 5831, 5830, 5851, 5867, 5868, 5865
2962, 5823, 5824, 5832, 5831, 5853, 5869, 5870, 5867
2963, 5824, 5825, 5833, 5832, 5855, 5871, 5872, 5869
2964, 5825, 5826, 5834, 5833, 5857, 5873, 5874, 5871
2965, 5826, 5827, 5835, 5834, 5859, 5875, 5876, 5873
2966, 5827, 493, 494, 5835, 5860, 497, 5877, 5875
2967, 477, 5828, 5836, 478, 5862, 5878, 5879, 481
2968, 5828, 5829, 5837, 5836, 5864, 5880, 5881, 5878
2969, 5829, 5830, 5838, 5837, 5866, 5882, 5883, 5880
2970, 5830, 5831, 5839, 5838, 5868, 5884, 5885, 5882
2971, 5831, 5832, 5840, 5839, 5870, 5886, 5887, 5884
2972, 5832, 5833, 5841, 5840, 5872, 5888, 5889, 5886
2973, 5833, 5834, 5842, 5841, 5874, 5890, 5891, 5888
2974, 5834, 5835, 5843, 5842, 5876, 5892, 5893, 5890
2975, 5835, 494, 495, 5843, 5877, 498, 5894, 5892
2976, 478, 5836, 527, 18, 5879, 5895, 536, 482
2977, 5836, 5837, 526, 527, 5881, 5896, 535, 5895
2978, 5837, 5838, 525, 526, 5883, 5897, 534, 5896
2979, 5838, 5839, 524, 525, 5885, 5898, 533, 5897
2980, 5839, 5840, 523, 524, 5887, 5899, 532, 5898
2981, 5840, 5841, 522, 523, 5889, 5900, 531, 5899
2982, 5841, 5842, 521, 522, 5891, 5901, 530, 5900
2983, 5842, 5843, 520, 521, 5893, 5902, 529, 5901
2984, 5843, 495, 20, 520, 5894, 499, 528, 5902
*ELEMENT, type=CPS8, ELSET=Surface172
2985, 17, 483, 5903, 510, 484, 5911, 5912, 519
2986, 510, 5903, 5904, 509, 5912, 5913, 5914, 518
2987, 509, 5904, 5905, 508, 5914, 5915, 5916, 517
2988, 508, 5905, 5906, 507, 5916, 5917, 5918, 516
2989, 507, 5906, 5907, 506, 5918, 5919, 5920, 515
2990, 506, 5907, 5908, 505, 5920, 5921, 5922, 514
2991, 505, 5908, 5909, 504, 5922, 5923, 5924, 513
2992, 504, 5909, 5910, 503, 5924, 5925, 5926, 512
2993, 503, 5910, 500, 19, 5926, 5927, 501, 511
2994, 483, 18, 527, 5903, 485, 536, 5928, 5911
2995, 5903, 527, 526, 5904, 5928, 535, 5929, 5913
2996, 5904, 526, 525, 5905, 5929, 534, 5930, 5915
2997, 5905, 525, 524, 5906, 5930, 533, 5931, 5917
2998, 5906, 524, 523, 5907, 5931, 532, 5932, 5919
2999, 5907, 523, 522, 5908, 5932, 531, 5933, 5921
3000, 5908, 522, 521, 5909, 5933, 530, 5934, 5923
3001, 5909, 521, 520, 5910, 5934, 529, 5935, 5925
3002, 5910, 520, 20, 500, 5935, 528, 502, 5927
*ELEMENT, type=CPS8, ELSET=Surface173
3003, 22, 576, 5936, 537, 578, 5952, 5953, 545
3004, 576, 577, 5937, 5936, 579, 5954, 5955, 5952
3005, 577, 24, 559, 5937, 580, 567, 5956, 5954
3006, 537, 5936, 5938, 538, 5953, 5957, 5958, 546
3007, 5936, 5937, 5939, 5938, 5955, 5959, 5960, 5957
3008, 5937, 559, 560, 5939, 5956, 568, 5961, 5959
3009, 538, 5938, 5940, 539, 5958, 5962, 5963, 547
3010, 5938, 5939, 5941, 5940, 5960, 5964, 5965, 5962
3011, 5939, 560, 561, 5941, 5961, 569, 5966, 5964
3012, 539, 5940, 5942, 540, 5963, 5967, 5968, 548
3013, 5940, 5941, 5943, 5942, 5965, 5969, 5970, 5967
3014, 5941, 561, 562, 5943, 5966, 570, 5971, 5969
3015, 540, 5942, 5944, 541, 5968, 5972, 5973, 549
3016, 5942, 5943, 5945, 5944, 5970, 5974, 5975, 5972
3017, 5943, 562, 563, 5945, 5971, 571, 5976, 5974
3018, 541, 5944, 5946, 542, 5973, 5977, 5978, 550
3019, 5944, 5945, 5947, 5946, 5975, 5979, 5980, 5977
3020, 5945, 563, 564, 5947, 5976, 572, 5981, 5979
3021, 542, 5946, 5948, 543, 5978, 5982, 5983, 551
3022, 5946, 5947, 5949, 5948, 5980, 5984, 5985, 5982
3023, 5947, 564, 565, 5949, 5981, 573, 5986, 5984
3024, 543, 5948, 5950, 544, 5983, 5987, 5988, 552
3025, 5948, 5949, 5951, 5950, 5985, 5989, 5990, 5987
3026, 5949, 565, 566, 5951, 5986, 574, 5991, 5989
3027, 544, 5950, 554, 21, 5988, 5992, 556, 553
3028, 5950, 5951, 555, 554, 5990, 5993, 557, 5992
3029, 5951, 566, 23, 555, 5991, 575, 558, 5993
*ELEMENT, type=CPS8, ELSET=Surface174
3030, 13, 581, 5994, 388, 603, 6170, 6171, 396
3031, 388, 5994, 5995, 389, 6171, 6172, 6173, 397
3032, 389, 5995, 5996, 390, 6173, 6174, 6175, 398
3033, 390, 5996, 5997, 391, 6175, 6176, 6177, 399
3034, 391, 5997, 5998, 392, 6177, 6178, 6179, 400
3035, 392, 5998, 5999, 393, 6179, 6180, 6181, 401
3036, 393, 5999, 6000, 394, 6181, 6182, 6183, 402
3037, 394, 6000, 6001, 395, 6183, 6184, 6185, 403
3038, 395, 6001, 626, 11, 6185, 6186, 648, 404
3039, 581, 582, 6002, 5994, 604, 6187, 6188, 6170
3040, 5994, 6002, 6003, 5995, 6188, 6189, 6190, 6172
3041, 5995, 6003, 6004, 5996, 6190, 6191, 6192, 6174
3042, 5996, 6004, 6005, 5997, 6192, 6193, 6194, 6176
3043, 5997, 6005, 6006, 5998, 6194, 6195, 6196, 6178
3044, 5998, 6006, 6007, 5999, 6196, 6197, 6198, 6180
3045, 5999, 6007, 6008, 6000, 6198, 6199, 6200, 6182
3046, 6000, 6008, 6009, 6001, 6200, 6201, 6202, 6184
3047, 6001, 6009, 627, 626, 6202, 6203, 649, 6186
3048, 582, 583, 6010, 6002, 605, 6204, 6205, 6187
3049, 6002, 6010, 6011, 6003, 6205, 6206, 6207, 6189
3050, 6003, 6011, 6012, 6004, 6207, 6208, 6209, 6191
3051, 6004, 6012, 6013, 6005, 6209, 6210, 6211, 6193
3052, 6005, 6013, 6014, 6006, 6211, 6212, 6213, 6195
3053, 6006, 6014, 6015, 6007, 6213, 6214, 6215, 6197
3054, 6007, 6015, 6016, 6008, 6215, 6216, 6217, 6199
3055, 6008, 6016, 6017, 6009, 6217, 6218, 6219, 6201
3056, 6009, 6017, 628, 627, 6219, 6220, 650, 6203
3057, 583, 584, 6018, 6010, 606, 6221, 6222, 6204
3058, 6010, 6018, 6019, 6011, 6222, 6223, 6224, 6206
3059, 6011, 6019, 6020, 6012, 6224, 6225, 6226, 6208
3060, 6012, 6020, 6021, 6013, 6226, 6227, 6228, 6210
3061, 6013, 6021, 6022, 6014, 6228, 6229, 6230, 6212
3062, 6014, 6022, 6023, 6015, 6230, 6231, 6232, 6214
3063, 6015, 6023, 6024, 6016, 6232, 6233, 6234, 6216
3064, 6016, 6024, 6025, 6017, 6234, 6235, 6236, 6218
3065, 6017, 6025, 629, 628, 6236, 6237, 651, 6220
3066, 584, 585, 6026, 6018, 607, 6238, 6239, 6221
3067, 6018, 6026, 6027, 6019, 6239, 6240, 6241, 6223
3068, 6019, 6027, 6028, 6020, 6241, 6242, 6243, 6225
3069, 6020, 6028, 6029, 6021, 6243, 6244, 6245, 6227
3070, 6021, 6029, 6030, 6022, 6245, 6246, 6247, 6229
3071, 6022, 6030, 6031, 6023, 6247, 6248, 6249, 6231
3072, 6023, 6031, 6032, 6024, 6249, 6250, 6251, 6233
3073, 6024, 6032, 6033, 6025, 6251, 6252, 6253, 6235
3074, 6025, 6033, 630, 629, 6253, 6254, 652, 6237
3075, 585, 586, 6034, 6026, 608, 6255, 6256, 6238
3076, 6026, 6034, 6035, 6027, 6256, 6257, 6258, 6240
3077, 6027, 6035, 6036, 6028, 6258, 6259, 6260, 6242
3078, 6028, 6036, 6037, 6029, 6260, 6261, 6262, 6244
3079, 6029, 6037, 6038, 6030, 6262, 6263, 6264, 6246
3080, 6030, 6038, 6039, 6031, 6264, 6265, 6266, 6248
3081, 6031, 6039, 6040, 6032, 6266, 6267, 6268, 6250
3082, 6032, 6040, 6041, 6033, 6268, 6269, 6270, 6252
3083, 6033, 6041, 631, 630, 6270, 6271, 653, 6254
3084, 586, 587, 6042, 6034, 609, 6272, 6273, 6255
3085, 6034, 6042, 6043, 6035, 6273, 6274, 6275, 6257
3086, 6035, 6043, 6044, 6036, 6275, 6276, 6277, 6259
3087, 6036, 6044, 6045, 6037, 6277, 6278, 6279, 6261
3088, 6037, 6045, 6046, 6038, 6279, 6280, 6281, 6263
3089, 6038, 6046, 6047, 6039, 6281, 6282, 6283, 6265
3090, 6039, 6047, 6048, 6040, 6283, 6284, 6285, 6267
3091, 6040, 6048, 6049, 6041, 6285, 6286, 6287, 6269
3092, 6041, 6049, 632, 631, 6287, 6288, 654, 6271
3093, 587, 588, 6050, 6042, 610, 6289, 6290, 6272
3094, 6042, 6050, 6051, 6043, 6290, 6291, 6292, 6274
3095, 6043, 6051, 6052, 6044, 6292, 6293, 6294, 6276
3096, 6044, 6052, 6053, 6045, 6294, 6295, 6296, 6278
3097, 6045, 6053, 6054, 6046, 6296, 6297, 6298, 6280
3098, 6046, 6054, 6055, 6047, 6298, 6299, 6300, 6282
3099, 6047, 6055, 6056, 6048, 6300, 6301, 6302, 6284
3100, 6048, 6056, 6057, 6049, 6302, 6303, 6304, 6286
3101, 6049, 6057, 633, 632, 6304, 6305, 655, 6288
3102, 588, 589, 6058, 6050, 611, 6306, 6307, 6289
3103, 6050, 6058, 6059, 6051, 6307, 6308, 6309, 6291
3104, 6051, 6059, 6060, 6052, 6309, 6310, 6311, 6293
3105, 6052, 6060, 6061, 6053, 6311, 6312, 6313, 6295
3106, 6053, 6061, 6062, 6054, 6313, 6314, 6315, 6297
3107, 6054, 6062, 6063, 6055, 6315, 6316, 6317, 6299
3108, 6055, 6063, 6064, 6056, 6317, 6318, 6319, 6301
3109, 6056, 6064, 6065, 6057, 6319, 6320, 6321, 6303
3110, 6057, 6065, 634, 633, 6321, 6322, 656, 6305
3111, 589, 590, 6066, 6058, 612, 6323, 6324, 6306
3112, 6058, 6066, 6067, 6059, 6324, 6325, 6326, 6308
3113, 6059, 6067, 6068, 6060, 6326, 6327, 6328, 6310
3114, 6060, 6068, 6069, 6061, 6328, 6329, 6330, 6312
3115, 6061, 6069, 6070, 6062, 6330, 6331, 6332, 6314
3116, 6062, 6070, 6071, 6063, 6332, 6333, 6334, 6316
3117, 6063, 6071, 6072, 6064, 6334, 6335, 6336, 6318
3118, 6064, 6072, 6073, 6065, 6336, 6337, 6338, 6320
3119, 6065, 6073, 635, 634, 6338, 6339, 657, 6322
3120, 590, 591, 6074, 6066, 613, 6340, 6341, 6323
3121, 6066, 6074, 6075, 6067, 6341, 6342, 6343, 6325
3122, 6067, 6075, 6076, 6068, 6343, 6344, 6345, 6327
3123, 6068, 6076, 6077, 6069, 6345, 6346, 6347, 6329
3124, 6069, 6077, 6078, 6070, 6347, 6348, 6349, 6331
3125, 6070, 6078, 6079, 6071, 6349, 6350, 6351, 6333
3126, 6071, 6079, 6080, 6072, 6351, 6352, 6353, 6335
3127, 6072, 6080, 6081, 6073, 6353, 6354, 6355, 6337
3128, 6073, 6081, 636, 635, 6355, 6356, 658, 6339
3129, 591, 592, 6082, 6074, 614, 6357, 6358, 6340
3130, 6074, 6082, 6083, 6075, 6358, 6359, 6360, 6342
3131, 6075, 6083, 6084, 6076, 6360, 6361, 6362, 6344
3132, 6076, 6084, 6085, 6077, 6362, 6363, 6364, 6346
3133, 6077, 6085, 6086, 6078, 6364, 6365, 6366, 6348
3134, 6078, 6086, 6087, 6079, 6366, 6367, 6368, 6350
3135, 6079, 6087, 6088, 6080, 6368, 6369, 6370, 6352
3136, 6080, 6088, 6089, 6081, 6370, 6371, 6372, 6354
3137, 6081, 6089, 637, 636, 6372, 6373, 659, 6356
3138, 592, 593, 6090, 6082, 615, 6374, 6375, 6357
3139, 6082, 6090, 6091, 6083, 6375, 6376, 6377, 6359
3140, 6083, 6091, 6092, 6084, 6377, 6378, 6379, 6361
3141, 6084, 6092, 6093, 6085, 6379, 6380, 6381, 6363
3142, 6085, 6093, 6094, 6086, 6381, 6382, 6383, 6365
3143, 6086, 6094, 6095, 6087, 6383, 6384, 6385, 6367
3144, 6087, 6095, 6096, 6088, 6385, 6386, 6387, 6369
3145, 6088, 6096, 6097, 6089, 6387, 6388, 6389, 6371
3146, 6089, 6097, 638, 637, 6389, 6390, 660, 6373
3147, 593, 594, 6098, 6090, 616, 6391, 6392, 6374
3148, 6090, 6098, 6099, 6091, 6392, 6393, 6394, 6376
3149, 6091, 6099, 6100, 6092, 6394, 6395, 6396, 6378
3150, 6092, 6100, 6101, 6093, 6396, 6397, 6398, 6380
3151, 6093, 6101, 6102, 6094, 6398, 6399, 6400, 6382
3152, 6094, 6102, 6103, 6095, 6400, 6401, 6402, 6384
3153, 6095, 6103, 6104, 6096, 6402, 6403, 6404, 6386
3154, 6096, 6104, 6105, 6097, 6404, 6405, 6406, 6388
3155, 6097, 6105, 639, 638, 6406, 6407, 661, 6390
3156, 594, 595, 6106, 6098, 617, 6408, 6409, 6391
3157, 6098, 6106, 6107, 6099, 6409, 6410, 6411, 6393
3158, 6099, 6107, 6108, 6100, 6411, 6412, 6413, 6395
3159, 6100, 6108, 6109, 6101, 6413, 6414, 6415, 6397
3160, 6101, 6109, 6110, 6102, 6415, 6416, 6417, 6399
3161, 6102, 6110, 6111, 6103, 6417, 6418, 6419, 6401
3162, 6103, 6111, 6112, 6104, 6419, 6420, 6421, 6403
3163, 6104, 6112, 6113, 6105, 6421, 6422, 6423, 6405
3164, 6105, 6113, 640, 639, 6423, 6424, 662, 6407
3165, 595, 596, 6114, 6106, 618, 6425, 6426, 6408
3166, 6106, 6114, 6115, 6107, 6426, 6427, 6428, 6410
3167, 6107, 6115, 6116, 6108, 6428, 6429, 6430, 6412
3168, 6108, 6116, 6117, 6109, 6430, 6431, 6432, 6414
3169, 6109, 6117, 6118, 6110, 6432, 6433, 6434, 6416
3170, 6110, 6118, 6119, 6111, 6434, 6435, 6436, 6418
3171, 6111, 6119, 6120, 6112, 6436, 6437, 6438, 6420
3172, 6112, 6120, 6121, 6113, 6438, 6439, 6440, 6422
3173, 6113, 6121, 641, 640, 6440, 6441, 663, 6424
3174, 596, 597, 6122, 6114, 619, 6442, 6443, 6425
3175, 6114, 6122, 6123, 6115, 6443, 6444, 6445, 6427
3176, 6115, 6123, 6124, 6116, 6445, 6446, 6447, 6429
3177, 6116, 6124, 6125, 6117, 6447, 6448, 6449, 6431
3178, 6117, 6125, 6126, 6118, 6449, 6450, 6451, 6433
3179, 6118, 6126, 6127, 6119, 6451, 6452, 6453, 6435
3180, 6119, 6127, 6128, 6120, 6453, 6454, 6455, 6437
3181, 6120, 6128, 6129, 6121, 6455, 6456, 6457, 6439
3182, 6121, 6129, 642, 641, 6457, 6458, 664, 6441
3183, 597, 598, 6130, 6122, 620, 6459, 6460, 6442
3184, 6122, 6130, 6131, 6123, 6460, 6461, 6462, 6444
3185, 6123, 6131, 6132, 6124, 6462, 6463, 6464, 6446
3186, 6124, 6132, 6133, 6125, 6464, 6465, 6466, 6448
3187, 6125, 6133, 6134, 6126, 6466, 6467, 6468, 6450
3188, 6126, 6134, 6135, 6127, 6468, 6469, 6470, 6452
3189, 6127, 6135, 6136, 6128, 6470, 6471, 6472, 6454
3190, 6128, 6136, 6137, 6129, 6472, 6473, 6474, 6456
3191, 6129, 6137, 643, 642, 6474, 6475, 665, 6458
3192, 598, 599, 6138, 6130, 621, 6476, 6477, 6459
3193, 6130, 6138, 6139, 6131, 6477, 6478, 6479, 6461
3194, 6131, 6139, 6140, 6132, 6479, 6480, 6481, 6463
3195, 6132, 6140, 6141, 6133, 6481, 6482, 6483, 6465
3196, 6133, 6141, 6142, 6134, 6483, 6484, 6485, 6467
3197, 6134, 6142, 6143, 6135, 6485, 6486, 6487, 6469
3198, 6135, 6143, 6144, 6136, 6487, 6488, 6489, 6471
3199, 6136, 6144, 6145, 6137, 6489, 6490, 6491, 6473
3200, 6137, 6145, 644, 643, 6491, 6492, 666, 6475
3201, 599, 600, 6146, 6138, 622, 6493, 6494, 6476
3202, 6138, 6146, 6147, 6139, 6494, 6495, 6496, 6478
3203, 6139, 6147, 6148, 6140, 6496, 6497, 6498, 6480
3204, 6140, 6148, 6149, 6141, 6498, 6499, 6500, 6482
3205, 6141, 6149, 6150, 6142, 6500, 6501, 6502, 6484
3206, 6142, 6150, 6151, 6143, 6502, 6503, 6504, 6486
3207, 6143, 6151, 6152, 6144, 6504, 6505, 6506, 6488
3208, 6144, 6152, 6153, 6145, 6506, 6507, 6508, 6490
3209, 6145, 6153, 645, 644, 6508, 6509, 667, 6492
3210, 600, 601, 6154, 6146, 623, 6510, 6511, 6493
3211, 6146, 6154, 6155, 6147, 6511, 6512, 6513, 6495
3212, 6147, 6155, 6156, 6148, 6513, 6514, 6515, 6497
3213, 6148, 6156, 6157, 6149, 6515, 6516, 6517, 6499
3214, 6149, 6157, 6158, 6150, 6517, 6518, 6519, 6501
3215, 6150, 6158, 6159, 6151, 6519, 6520, 6521, 6503
3216, 6151, 6159, 6160, 6152, 6521, 6522, 6523, 6505
3217, 6152, 6160, 6161, 6153, 6523, 6524, 6525, 6507
3218, 6153, 6161, 646, 645, 6525, 6526, 668, 6509
3219, 601, 602, 6162, 6154, 624, 6527, 6528, 6510
3220, 6154, 6162, 6163, 6155, 6528, 6529, 6530, 6512
3221, 6155, 6163, 6164, 6156, 6530, 6531, 6532, 6514
3222, 6156, 6164, 6165, 6157, 6532, 6533, 6534, 6516
3223, 6157, 6165, 6166, 6158, 6534, 6535, 6536, 6518
3224, 6158, 6166, 6167, 6159, 6536, 6537, 6538, 6520
3225, 6159, 6167, 6168, 6160, 6538, 6539, 6540, 6522
3226, 6160, 6168, 6169, 6161, 6540, 6541, 6542, 6524
3227, 6161, 6169, 647, 646, 6542, 6543, 669, 6526
3228, 602, 22, 537, 6162, 625, 545, 6544, 6527
3229, 6162, 537, 538, 6163, 6544, 546, 6545, 6529
3230, 6163, 538, 539, 6164, 6545, 547, 6546, 6531
3231, 6164, 539, 540, 6165, 6546, 548, 6547, 6533
3232, 6165, 540, 541, 6166, 6547, 549, 6548, 6535
3233, 6166, 541, 542, 6167, 6548, 550, 6549, 6537
3234, 6167, 542, 543, 6168, 6549, 551, 6550, 6539
3235, 6168, 543, 544, 6169, 6550, 552, 6551, 6541
3236, 6169, 544, 21, 647, 6551, 553, 670, 6543
*ELEMENT, type=CPS8, ELSET=Surface175
3237, 15, 425, 6552, 671, 433, 6728, 6729, 693
3238, 425, 426, 6553, 6552, 434, 6730, 6731, 6728
3239, 426, 427, 6554, 6553, 435, 6732, 6733, 6730
3240, 427, 428, 6555, 6554, 436, 6734, 6735, 6732
3241, 428, 429, 6556, 6555, 437, 6736, 6737, 6734
3242, 429, 430, 6557, 6556, 438, 6738, 6739, 6736
3243, 430, 431, 6558, 6557, 439, 6740, 6741, 6738
3244, 431, 432, 6559, 6558, 440, 6742, 6743, 6740
3245, 432, 9, 716, 6559, 441, 738, 6744, 6742
3246, 671, 6552, 6560, 672, 6729, 6745, 6746, 694
3247, 6552, 6553, 6561, 6560, 6731, 6747, 6748, 6745
3248, 6553, 6554, 6562, 6561, 6733, 6749, 6750, 6747
3249, 6554, 6555, 6563, 6562, 6735, 6751, 6752, 6749
3250, 6555, 6556, 6564, 6563, 6737, 6753, 6754, 6751
3251, 6556, 6557, 6565, 6564, 6739, 6755, 6756, 6753
3252, 6557, 6558, 6566, 6565, 6741, 6757, 6758, 6755
3253, 6558, 6559, 6567, 6566, 6743, 6759, 6760, 6757
3254, 6559, 716, 717, 6567, 6744, 739, 6761, 6759
3255, 672, 6560, 6568, 673, 6746, 6762, 6763, 695
3256, 6560, 6561, 6569, 6568, 6748, 6764, 6765, 6762
3257, 6561, 6562, 6570, 6569, 6750, 6766, 6767, 6764
3258, 6562, 6563, 6571, 6570, 6752, 6768, 6769, 6766
3259, 6563, 6564, 6572, 6571, 6754, 6770, 6771, 6768
3260, 6564, 6565, 6573, 6572, 6756, 6772, 6773, 6770
3261, 6565, 6566, 6574, 6573, 6758, 6774, 6775, 6772
3262, 6566, 6567, 6575, 6574, 6760, 6776, 6777, 6774
3263, 6567, 717, 718, 6575, 6761, 740, 6778, 6776
3264, 673, 6568, 6576, 674, 6763, 6779, 6780, 696
3265, 6568, 6569, 6577, 6576, 6765, 6781, 6782, 6779
3266, 6569, 6570, 6578, 6577, 6767, 6783, 6784, 6781
3267, 6570, 6571, 6579, 6578, 6769, 6785, 6786, 6783
3268, 6571, 6572, 6580, 6579, 6771, 6787, 6788, 6785
3269, 6572, 6573, 6581, 6580, 6773, 6789, 6790, 6787
3270, 6573, 6574, 6582, 6581, 6775, 6791, 6792, 6789
3271, 6574, 6575, 6583, 6582, 6777, 6793, 6794, 6791
3272, 6575, 718, 719, 6583, 6778, 741, 6795, 6793
3273, 674, 6576, 6584, 675, 6780, 6796, 6797, 697
3274, 6576, 6577, 6585, 6584, 6782, 6798, 6799, 6796
3275, 6577, 6578, 6586, 6585, 6784, 6800, 6801, 6798
3276, 6578, 6579, 6587, 6586, 6786, 6802, 6803, 6800
3277, 6579, 6580, 6588, 6587, 6788, 6804, 6805, 6802
3278, 6580, 6581, 6589, 6588, 6790, 6806, 6807, 6804
3279, 6581, 6582, 6590, 6589, 6792, 6808, 6809, 6806
3280, 6582, 6583, 6591, 6590, 6794, 6810, 6811, 6808
3281, 6583, 719, 720, 6591, 6795, 742, 6812, 6810
3282, 675, 6584, 6592, 676, 6797, 6813, 6814, 698
3283, 6584, 6585, 6593, 6592, 6799, 6815, 6816, 6813
3284, 6585, 6586, 6594, 6593, 6801, 6817, 6818, 6815
3285, 6586, 6587, 6595, 6594, 6803, 6819, 6820, 6817
3286, 6587, 6588, 6596, 6595, 6805, 6821, 6822, 6819
3287, 6588, 6589, 6597, 6596, 6807, 6823, 6824, 6821
3288, 6589, 6590, 6598, 6597, 6809, 6825, 6826, 6823
3289, 6590, 6591, 6599, 6598, 6811, 6827, 6828, 6825
3290, 6591, 720, 721, 6599, 6812, 743, 6829, 6827
3291, 676, 6592, 6600, 677, 6814, 6830, 6831, 699
3292, 6592, 6593, 6601, 6600, 6816, 6832, 6833, 6830
3293, 6593, 6594, 6602, 6601, 6818, 6834, 6835, 6832
3294, 6594, 6595, 6603, 6602, 6820, 6836, 6837, 6834
3295, 6595, 6596, 6604, 6603, 6822, 6838, 6839, 6836
3296, 6596, 6597, 6605, 6604, 6824, 6840, 6841, 6838
3297, 6597, 6598, 6606, 6605, 6826, 6842, 6843, 6840
3298, 6598, 6599, 6607, 6606, 6828, 6844, 6845, 6842
3299, 6599, 721, 722, 6607, 6829, 744, 6846, 6844
3300, 677, 6600, 6608, 678, 6831, 6847, 6848, 700
3301, 6600, 6601, 6609, 6608, 6833, 6849, 6850, 6847
3302, 6601, 6602, 6610, 6609, 6835, 6851, 6852, 6849
3303, 6602, 6603, 6611, 6610, 6837, 6853, 6854, 6851
3304, 6603, 6604, 6612, 6611, 6839, 6855, 6856, 6853
3305, 6604, 6605, 6613, 6612, 6841, 6857, 6858, 6855
3306, 6605, 6606, 6614, 6613, 6843, 6859, 6860, 6857
3307, 6606, 6607, 6615, 6614, 6845, 6861, 6862, 6859
3308, 6607, 722, 723, 6615, 6846, 745, 6863, 6861
3309, 678, 6608, 6616, 679, 6848, 6864, 6865, 701
3310, 6608, 6609, 6617, 6616, 6850, 6866, 6867, 6864
3311, 6609, 6610, 6618, 6617, 6852, 6868, 6869, 6866
3312, 6610, 6611, 6619, 6618, 6854, 6870, 6871, 6868
3313, 6611, 6612, 6620, 6619, 6856, 6872, 6873, 6870
3314, 6612, 6613, 6621, 6620, 6858, 6874, 6875, 6872
3315, 6613, 6614, 6622, 6621, 6860, 6876, 6877, 6874
3316, 6614, 6615, 6623, 6622, 6862, 6878, 6879, 6876
3317, 6615, 723, 724, 6623, 6863, 746, 6880, 6878
3318, 679, 6616, 6624, 680, 6865, 6881, 6882, 702
3319, 6616, 6617, 6625, 6624, 6867, 6883, 6884, 6881
3320, 6617, 6618, 6626, 6625, 6869, 6885, 6886, 6883
3321, 6618, 6619, 6627, 6626, 6871, 6887, 6888, 6885
3322, 6619, 6620, 6628, 6627, 6873, 6889, 6890, 6887
3323, 6620, 6621, 6629, 6628, 6875, 6891, 6892, 6889
3324, 6621, 6622, 6630, 6629, 6877, 6893, 6894, 6891
3325, 6622, 6623, 6631, 6630, 6879, 6895, 6896, 6893
3326, 6623, 724, 725, 6631, 6880, 747, 6897, 6895
3327, 680, 6624, 6632, 681, 6882, 6898, 6899, 703
3328, 6624, 6625, 6633, 6632, 6884, 6900, 6901, 6898
3329, 6625, 6626, 6634, 6633, 6886, 6902, 6903, 6900
3330, 6626, 6627, 6635, 6634, 6888, 6904, 6905, 6902
3331, 6627, 6628, 6636, 6635, 6890, 6906, 6907, 6904
3332, 6628, 6629, 6637, 6636, 6892, 6908, 6909, 6906
3333, 6629, 6630, 6638, 6637, 6894, 6910, 6911, 6908
3334, 6630, 6631, 6639, 6638, 6896, 6912, 6913, 6910
3335, 6631, 725, 726, 6639, 6897, 748, 6914, 6912
3336, 681, 6632, 6640, 682, 6899, 6915, 6916, 704
3337, 6632, 6633, 6641, 6640, 6901, 6917, 6918, 6915
3338, 6633, 6634, 6642, 6641, 6903, 6919, 6920, 6917
3339, 6634, 6635, 6643, 6642, 6905, 6921, 6922, 6919
3340, 6635, 6636, 6644, 6643, 6907, 6923, 6924, 6921
3341, 6636, 6637, 6645, 6644, 6909, 6925, 6926, 6923
3342, 6637, 6638, 6646, 6645, 6911, 6927, 6928, 6925
3343, 6638, 6639, 6647, 6646, 6913, 6929, 6930, 6927
3344, 6639, 726, 727, 6647, 6914, 749, 6931, 6929
3345, 682, 6640, 6648, 683, 6916, 6932, 6933, 705
3346, 6640, 6641, 6649, 6648, 6918, 6934, 6935, 6932
3347, 6641, 6642, 6650, 6649, 6920, 6936, 6937, 6934
3348, 6642, 6643, 6651, 6650, 6922, 6938, 6939, 6936
3349, 6643, 6644, 6652, 6651, 6924, 6940, 6941, 6938
3350, 6644, 6645, 6653, 6652, 6926, 6942, 6943, 6940
3351, 6645, 6646, 6654, 6653, 6928, 6944, 6945, 6942
3352, 6646, 6647, 6655, 6654, 6930, 6946, 6947, 6944
3353, 6647, 727, 728, 6655, 6931, 750, 6948, 6946
3354, 683, 6648, 6656, 684, 6933, 6949, 6950, 706
3355, 6648, 6649, 6657, 6656, 6935, 6951, 6952, 6949
3356, 6649, 6650, 6658, 6657, 6937, 6953, 6954, 6951
3357, 6650, 6651, 6659, 6658, 6939, 6955, 6956, 6953
3358, 6651, 6652, 6660, 6659, 6941, 6957, 6958, 6955
3359, 6652, 6653, 6661, 6660, 6943, 6959, 6960, 6957
3360, 6653, 6654, 6662, 6661, 6945, 6961, 6962, 6959
3361, 6654, 6655, 6663, 6662, 6947, 6963, 6964, 6961
3362, 6655, 728, 729, 6663, 6948, 751, 6965, 6963
3363, 684, 6656, 6664, 685, 6950, 6966, 6967, 707
3364, 6656, 6657, 6665, 6664, 6952, 6968, 6969, 6966
3365, 6657, 6658, 6666, 6665, 6954, 6970, 6971, 6968
3366, 6658, 6659, 6667, 6666, 6956, 6972, 6973, 6970
3367, 6659, 6660, 6668, 6667, 6958, 6974, 6975, 6972
3368, 6660, 6661, 6669, 6668, 6960, 6976, 6977, 6974
3369, 6661, 6662, 6670, 6669, 6962, 6978, 6979, 6976
3370, 6662, 6663, 6671, 6670, 6964, 6980, 6981, 6978
3371, 6663, 729, 730, 6671, 6965, 752, 6982, 6980
3372, 685, 6664, 6672, 686, 6967, 6983, 6984, 708
3373, 6664, 6665, 6673, 6672, 6969, 6985, 6986, 6983
3374, 6665, 6666, 6674, 6673, 6971, 6987, 6988, 6985
3375, 6666, 6667, 6675, 6674, 6973, 6989, 6990, 6987
3376, 6667, 6668, 6676, 6675, 6975, 6991, 6992, 6989
3377, 6668, 6669, 6677, 6676, 6977, 6993, 6994, 6991
3378, 6669, 6670, 6678, 6677, 6979, 6995, 6996, 6993
3379, 6670, 6671, 6679, 6678, 6981, 6997, 6998, 6995
3380, 6671, 730, 731, 6679, 6982, 753, 6999, 6997
3381, 686, 6672, 6680, 687, 6984, 7000, 7001, 709
3382, 6672, 6673, 6681, 6680, 6986, 7002, 7003, 7000
3383, 6673, 6674, 6682, 6681, 6988, 7004, 7005, 7002
3384, 6674, 6675, 6683, 6682, 6990, 7006, 7007, 7004
3385, 6675, 6676, 6684, 6683, 6992, 7008, 7009, 7006
3386, 6676, 6677, 6685, 6684, 6994, 7010, 7011, 7008
3387, 6677, 6678, 6686, 6685, 6996, 7012, 7013, 7010
3388, 6678, 6679, 6687, 6686, 6998, 7014, 7015, 7012
3389, 6679, 731, 732, 6687, 6999, 754, 7016, 7014
3390, 687, 6680, 6688, 688, 7001, 7017, 7018, 710
3391, 6680, 6681, 6689, 6688, 7003, 7019, 7020, 7017
3392, 6681, 6682, 6690, 6689, 7005, 7021, 7022, 7019
3393, 6682, 6683, 6691, 6690, 7007, 7023, 7024, 7021
3394, 6683, 6684, 6692, 6691, 7009, 7025, 7026, 7023
3395, 6684, 6685, 6693, 6692, 7011, 7027, 7028, 7025
3396, 6685, 6686, 6694, 6693, 7013, 7029, 7030, 7027
3397, 6686, 6687, 6695, 6694, 7015, 7031, 7032, 7029
3398, 6687, 732, 733, 6695, 7016, 755, 7033, 7031
3399, 688, 6688, 6696, 689, 7018, 7034, 7035, 711
3400, 6688, 6689, 6697, 6696, 7020, 7036, 7037, 7034
3401, 6689, 6690, 6698, 6697, 7022, 7038, 7039, 7036
3402, 6690, 6691, 6699, 6698, 7024, 7040, 7041, 7038
3403, 6691, 6692, 6700, 6699, 7026, 7042, 7043, 7040
3404, 6692, 6693, 6701, 6700, 7028, 7044, 7045, 7042
3405, 6693, 6694, 6702, 6701, 7030, 7046, 7047, 7044
3406, 6694, 6695, 6703, 6702, 7032, 7048, 7049, 7046
3407, 6695, 733, 734, 6703, 7033, 756, 7050, 7048
3408, 689, 6696, 6704, 690, 7035, 7051, 7052, 712
3409, 6696, 6697, 6705, 6704, 7037, 7053, 7054, 7051
3410, 6697, 6698, 6706, 6705, 7039, 7055, 7056, 7053
3411, 6698, 6699, 6707, 6706, 7041, 7057, 7058, 7055
3412, 6699, 6700, 6708, 6707, 7043, 7059, 7060, 7057
3413, 6700, 6701, 6709, 6708, 7045, 7061, 7062, 7059
3414, 6701, 6702, 6710, 6709, 7047, 7063, 7064, 7061
3415, 6702, 6703, 6711, 6710, 7049, 7065, 7066, 7063
3416, 6703, 734, 735, 6711, 7050, 757, 7067, 7065
3417, 690, 6704, 6712, 691, 7052, 7068, 7069, 713
3418, 6704, 6705, 6713, 6712, 7054, 7070, 7071, 7068
3419, 6705, 6706, 6714, 6713, 7056, 7072, 7073, 7070
3420, 6706, 6707, 6715, 6714, 7058, 7074, 7075, 7072
3421, 6707, 6708, 6716, 6715, 7060, 7076, 7077, 7074
3422, 6708, 6709, 6717, 6716, 7062, 7078, 7079, 7076
3423, 6709, 6710, 6718, 6717, 7064, 7080, 7081, 7078
3424, 6710, 6711, 6719, 6718, 7066, 7082, 7083, 7080
3425, 6711, 735, 736, 6719, 7067, 758, 7084, 7082
3426, 691, 6712, 6720, 692, 7069, 7085, 7086, 714
3427, 6712, 6713, 6721, 6720, 7071, 7087, 7088, 7085
3428, 6713, 6714, 6722, 6721, 7073, 7089, 7090, 7087
3429, 6714, 6715, 6723, 6722, 7075, 7091, 7092, 7089
3430, 6715, 6716, 6724, 6723, 7077, 7093, 7094, 7091
3431, 6716, 6717, 6725, 6724, 7079, 7095, 7096, 7093
3432, 6717, 6718, 6726, 6725, 7081, 7097, 7098, 7095
3433, 6718, 6719, 6727, 6726, 7083, 7099, 7100, 7097
3434, 6719, 736, 737, 6727, 7084, 759, 7101, 7099
3435, 692, 6720, 559, 24, 7086, 7102, 567, 715
3436, 6720, 6721, 560, 559, 7088, 7103, 568, 7102
3437, 6721, 6722, 561, 560, 7090, 7104, 569, 7103
3438, 6722, 6723, 562, 561, 7092, 7105, 570, 7104
3439, 6723, 6724, 563, 562, 7094, 7106, 571, 7105
3440, 6724, 6725, 564, 563, 7096, 7107, 572, 7106
3441, 6725, 6726, 565, 564, 7098, 7108, 573, 7107
3442, 6726, 6727, 566, 565, 7100, 7109, 574, 7108
3443, 6727, 737, 23, 566, 7101, 760, 575, 7109
*ELEMENT, type=CPS8, ELSET=Surface176
3444, 13, 459, 7110, 581, 461, 7154, 7155, 603
3445, 581, 7110, 7111, 582, 7155, 7156, 7157, 604
3446, 582, 7111, 7112, 583, 7157, 7158, 7159, 605
3447, 583, 7112, 7113, 584, 7159, 7160, 7161, 606
3448, 584, 7113, 7114, 585, 7161, 7162, 7163, 607
3449, 585, 7114, 7115, 586, 7163, 7164, 7165, 608
3450, 586, 7115, 7116, 587, 7165, 7166, 7167, 609
3451, 587, 7116, 7117, 588, 7167, 7168, 7169, 610
3452, 588, 7117, 7118, 589, 7169, 7170, 7171, 611
3453, 589, 7118, 7119, 590, 7171, 7172, 7173, 612
3454, 590, 7119, 7120, 591, 7173, 7174, 7175, 613
3455, 591, 7120, 7121, 592, 7175, 7176, 7177, 614
3456, 592, 7121, 7122, 593, 7177, 7178, 7179, 615
3457, 593, 7122, 7123, 594, 7179, 7180, 7181, 616
3458, 594, 7123, 7124, 595, 7181, 7182, 7183, 617
3459, 595, 7124, 7125, 596, 7183, 7184, 7185, 618
3460, 596, 7125, 7126, 597, 7185, 7186, 7187, 619
3461, 597, 7126, 7127, 598, 7187, 7188, 7189, 620
3462, 598, 7127, 7128, 599, 7189, 7190, 7191, 621
3463, 599, 7128, 7129, 600, 7191, 7192, 7193, 622
3464, 600, 7129, 7130, 601, 7193, 7194, 7195, 623
3465, 601, 7130, 7131, 602, 7195, 7196, 7197, 624
3466, 602, 7131, 576, 22, 7197, 7198, 578, 625
3467, 459, 460, 7132, 7110, 462, 7199, 7200, 7154
3468, 7110, 7132, 7133, 7111, 7200, 7201, 7202, 7156
3469, 7111, 7133, 7134, 7112, 7202, 7203, 7204, 7158
3470, 7112, 7134, 7135, 7113, 7204, 7205, 7206, 7160
3471, 7113, 7135, 7136, 7114, 7206, 7207, 7208, 7162
3472, 7114, 7136, 7137, 7115, 7208, 7209, 7210, 7164
3473, 7115, 7137, 7138, 7116, 7210, 7211, 7212, 7166
3474, 7116, 7138, 7139, 7117, 7212, 7213, 7214, 7168
3475, 7117, 7139, 7140, 7118, 7214, 7215, 7216, 7170
3476, 7118, 7140, 7141, 7119, 7216, 7217, 7218, 7172
3477, 7119, 7141, 7142, 7120, 7218, 7219, 7220, 7174
3478, 7120, 7142, 7143, 7121, 7220, 7221, 7222, 7176
3479, 7121, 7143, 7144, 7122, 7222, 7223, 7224, 7178
3480, 7122, 7144, 7145, 7123, 7224, 7225, 7226, 7180
3481, 7123, 7145, 7146, 7124, 7226, 7227, 7228, 7182
3482, 7124, 7146, 7147, 7125, 7228, 7229, 7230, 7184
3483, 7125, 7147, 7148, 7126, 7230, 7231, 7232, 7186
3484, 7126, 7148, 7149, 7127, 7232, 7233, 7234, 7188
3485, 7127, 7149, 7150, 7128, 7234, 7235, 7236, 7190
3486, 7128, 7150, 7151, 7129, 7236, 7237, 7238, 7192
3487, 7129, 7151, 7152, 7130, 7238, 7239, 7240, 7194
3488, 7130, 7152, 7153, 7131, 7240, 7241, 7242, 7196
3489, 7131, 7153, 577, 576, 7242, 7243, 579, 7198
3490, 460, 15, 671, 7132, 463, 693, 7244, 7199
3491, 7132, 671, 672, 7133, 7244, 694, 7245, 7201
3492, 7133, 672, 673, 7134, 7245, 695, 7246, 7203
3493, 7134, 673, 674, 7135, 7246, 696, 7247, 7205
3494, 7135, 674, 675, 7136, 7247, 697, 7248, 7207
3495, 7136, 675, 676, 7137, 7248, 698, 7249, 7209
3496, 7137, 676, 677, 7138, 7249, 699, 7250, 7211
3497, 7138, 677, 678, 7139, 7250, 700, 7251, 7213
3498, 7139, 678, 679, 7140, 7251, 701, 7252, 7215
