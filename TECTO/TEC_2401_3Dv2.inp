68878, 1.8521739130435, 0.98478260869565, 0.36111111111111
68879, 1.8304347826087, 0.98478260869565, 0.33333333333333
68880, 1.8521739130435, 1.0108695652174, 0.33333333333333
68881, 1.8521739130435, 0.98478260869565, 0.30555555555556
68882, 1.8304347826087, 0.98478260869565, 0.27777777777778
68883, 1.8521739130435, 1.0108695652174, 0.27777777777778
68884, 1.8521739130435, 0.98478260869565, 0.25
68885, 1.8304347826087, 0.98478260869565, 0.22222222222222
68886, 1.8521739130435, 1.0108695652174, 0.22222222222222
68887, 1.8521739130435, 0.98478260869565, 0.19444444444444
68888, 1.8304347826087, 0.98478260869565, 0.16666666666667
68889, 1.8521739130435, 1.0108695652174, 0.16666666666667
68890, 1.8521739130435, 0.98478260869565, 0.13888888888889
68891, 1.8304347826087, 0.98478260869565, 0.11111111111111
68892, 1.8521739130435, 1.0108695652174, 0.11111111111111
68893, 1.8521739130435, 0.98478260869565, 0.083333333333333
68894, 1.8304347826087, 0.98478260869565, 0.055555555555556
68895, 1.8521739130435, 1.0108695652174, 0.055555555555556
68896, 1.8521739130435, 0.98478260869565, 0.027777777777778
68897, 1.895652173913, 0.98478260869565, 0.47222222222222
68898, 1.8739130434783, 0.98478260869565, 0.44444444444444
68899, 1.895652173913, 1.0108695652174, 0.44444444444444
68900, 1.895652173913, 0.98478260869565, 0.41666666666667
68901, 1.8739130434783, 0.98478260869565, 0.38888888888889
68902, 1.895652173913, 1.0108695652174, 0.38888888888889
68903, 1.895652173913, 0.98478260869565, 0.36111111111111
68904, 1.8739130434783, 0.98478260869565, 0.33333333333333
68905, 1.895652173913, 1.0108695652174, 0.33333333333333
68906, 1.895652173913, 0.98478260869565, 0.30555555555556
68907, 1.8739130434783, 0.98478260869565, 0.27777777777778
68908, 1.895652173913, 1.0108695652174, 0.27777777777778
68909, 1.895652173913, 0.98478260869565, 0.25
68910, 1.8739130434783, 0.98478260869565, 0.22222222222222
68911, 1.895652173913, 1.0108695652174, 0.22222222222222
68912, 1.895652173913, 0.98478260869565, 0.19444444444444
68913, 1.8739130434783, 0.98478260869565, 0.16666666666667
68914, 1.895652173913, 1.0108695652174, 0.16666666666667
68915, 1.895652173913, 0.98478260869565, 0.13888888888889
68916, 1.8739130434783, 0.98478260869565, 0.11111111111111
68917, 1.895652173913, 1.0108695652174, 0.11111111111111
68918, 1.895652173913, 0.98478260869565, 0.083333333333333
68919, 1.8739130434783, 0.98478260869565, 0.055555555555556
68920, 1.895652173913, 1.0108695652174, 0.055555555555556
68921, 1.895652173913, 0.98478260869565, 0.027777777777778
68922, 1.9391304347826, 0.98478260869565, 0.47222222222222
68923, 1.9173913043478, 0.98478260869565, 0.44444444444444
68924, 1.9391304347826, 1.0108695652174, 0.44444444444444
68925, 1.9391304347826, 0.98478260869565, 0.41666666666667
68926, 1.9173913043478, 0.98478260869565, 0.38888888888889
68927, 1.9391304347826, 1.0108695652174, 0.38888888888889
68928, 1.9391304347826, 0.98478260869565, 0.36111111111111
68929, 1.9173913043478, 0.98478260869565, 0.33333333333333
68930, 1.9391304347826, 1.0108695652174, 0.33333333333333
68931, 1.9391304347826, 0.98478260869565, 0.30555555555556
68932, 1.9173913043478, 0.98478260869565, 0.27777777777778
68933, 1.9391304347826, 1.0108695652174, 0.27777777777778
68934, 1.9391304347826, 0.98478260869565, 0.25
68935, 1.9173913043478, 0.98478260869565, 0.22222222222222
68936, 1.9391304347826, 1.0108695652174, 0.22222222222222
68937, 1.9391304347826, 0.98478260869565, 0.19444444444444
68938, 1.9173913043478, 0.98478260869565, 0.16666666666667
68939, 1.9391304347826, 1.0108695652174, 0.16666666666667
68940, 1.9391304347826, 0.98478260869565, 0.13888888888889
68941, 1.9173913043478, 0.98478260869565, 0.11111111111111
68942, 1.9391304347826, 1.0108695652174, 0.11111111111111
68943, 1.9391304347826, 0.98478260869565, 0.083333333333333
68944, 1.9173913043478, 0.98478260869565, 0.055555555555556
68945, 1.9391304347826, 1.0108695652174, 0.055555555555556
68946, 1.9391304347826, 0.98478260869565, 0.027777777777778
68947, 1.9826086956522, 0.98478260869565, 0.47222222222222
68948, 1.9608695652174, 0.98478260869565, 0.44444444444444
68949, 1.9826086956522, 1.0108695652174, 0.44444444444444
68950, 1.9826086956522, 0.98478260869565, 0.41666666666667
68951, 1.9608695652174, 0.98478260869565, 0.38888888888889
68952, 1.9826086956522, 1.0108695652174, 0.38888888888889
68953, 1.9826086956522, 0.98478260869565, 0.36111111111111
68954, 1.9608695652174, 0.98478260869565, 0.33333333333333
68955, 1.9826086956522, 1.0108695652174, 0.33333333333333
68956, 1.9826086956522, 0.98478260869565, 0.30555555555556
68957, 1.9608695652174, 0.98478260869565, 0.27777777777778
68958, 1.9826086956522, 1.0108695652174, 0.27777777777778
68959, 1.9826086956522, 0.98478260869565, 0.25
68960, 1.9608695652174, 0.98478260869565, 0.22222222222222
68961, 1.9826086956522, 1.0108695652174, 0.22222222222222
68962, 1.9826086956522, 0.98478260869565, 0.19444444444444
68963, 1.9608695652174, 0.98478260869565, 0.16666666666667
68964, 1.9826086956522, 1.0108695652174, 0.16666666666667
68965, 1.9826086956522, 0.98478260869565, 0.13888888888889
68966, 1.9608695652174, 0.98478260869565, 0.11111111111111
68967, 1.9826086956522, 1.0108695652174, 0.11111111111111
68968, 1.9826086956522, 0.98478260869565, 0.083333333333333
68969, 1.9608695652174, 0.98478260869565, 0.055555555555556
68970, 1.9826086956522, 1.0108695652174, 0.055555555555556
68971, 1.9826086956522, 0.98478260869565, 0.027777777777778
68972, 2.0260869565217, 0.98478260869565, 0.47222222222222
68973, 2.004347826087, 0.98478260869565, 0.44444444444444
68974, 2.0260869565217, 1.0108695652174, 0.44444444444444
68975, 2.0260869565217, 0.98478260869565, 0.41666666666667
68976, 2.004347826087, 0.98478260869565, 0.38888888888889
68977, 2.0260869565217, 1.0108695652174, 0.38888888888889
68978, 2.0260869565217, 0.98478260869565, 0.36111111111111
68979, 2.004347826087, 0.98478260869565, 0.33333333333333
68980, 2.0260869565217, 1.0108695652174, 0.33333333333333
68981, 2.0260869565217, 0.98478260869565, 0.30555555555556
68982, 2.004347826087, 0.98478260869565, 0.27777777777778
68983, 2.0260869565217, 1.0108695652174, 0.27777777777778
68984, 2.0260869565217, 0.98478260869565, 0.25
68985, 2.004347826087, 0.98478260869565, 0.22222222222222
68986, 2.0260869565217, 1.0108695652174, 0.22222222222222
68987, 2.0260869565217, 0.98478260869565, 0.19444444444444
68988, 2.004347826087, 0.98478260869565, 0.16666666666667
68989, 2.0260869565217, 1.0108695652174, 0.16666666666667
68990, 2.0260869565217, 0.98478260869565, 0.13888888888889
68991, 2.004347826087, 0.98478260869565, 0.11111111111111
68992, 2.0260869565217, 1.0108695652174, 0.11111111111111
68993, 2.0260869565217, 0.98478260869565, 0.083333333333333
68994, 2.004347826087, 0.98478260869565, 0.055555555555556
68995, 2.0260869565217, 1.0108695652174, 0.055555555555556
68996, 2.0260869565217, 0.98478260869565, 0.027777777777778
68997, 2.0695652173913, 0.98478260869565, 0.47222222222222
68998, 2.0478260869565, 0.98478260869565, 0.44444444444444
68999, 2.0695652173913, 1.0108695652174, 0.44444444444444
69000, 2.0695652173913, 0.98478260869565, 0.41666666666667
69001, 2.0478260869565, 0.98478260869565, 0.38888888888889
69002, 2.0695652173913, 1.0108695652174, 0.38888888888889
69003, 2.0695652173913, 0.98478260869565, 0.36111111111111
69004, 2.0478260869565, 0.98478260869565, 0.33333333333333
69005, 2.0695652173913, 1.0108695652174, 0.33333333333333
69006, 2.0695652173913, 0.98478260869565, 0.30555555555556
69007, 2.0478260869565, 0.98478260869565, 0.27777777777778
69008, 2.0695652173913, 1.0108695652174, 0.27777777777778
69009, 2.0695652173913, 0.98478260869565, 0.25
69010, 2.0478260869565, 0.98478260869565, 0.22222222222222
69011, 2.0695652173913, 1.0108695652174, 0.22222222222222
69012, 2.0695652173913, 0.98478260869565, 0.19444444444444
69013, 2.0478260869565, 0.98478260869565, 0.16666666666667
69014, 2.0695652173913, 1.0108695652174, 0.16666666666667
69015, 2.0695652173913, 0.98478260869565, 0.13888888888889
69016, 2.0478260869565, 0.98478260869565, 0.11111111111111
69017, 2.0695652173913, 1.0108695652174, 0.11111111111111
69018, 2.0695652173913, 0.98478260869565, 0.083333333333333
69019, 2.0478260869565, 0.98478260869565, 0.055555555555556
69020, 2.0695652173913, 1.0108695652174, 0.055555555555556
69021, 2.0695652173913, 0.98478260869565, 0.027777777777778
69022, 2.1130434782609, 0.98478260869565, 0.47222222222222
69023, 2.0913043478261, 0.98478260869565, 0.44444444444444
69024, 2.1130434782609, 1.0108695652174, 0.44444444444444
69025, 2.1130434782609, 0.98478260869565, 0.41666666666667
69026, 2.0913043478261, 0.98478260869565, 0.38888888888889
69027, 2.1130434782609, 1.0108695652174, 0.38888888888889
69028, 2.1130434782609, 0.98478260869565, 0.36111111111111
69029, 2.0913043478261, 0.98478260869565, 0.33333333333333
69030, 2.1130434782609, 1.0108695652174, 0.33333333333333
69031, 2.1130434782609, 0.98478260869565, 0.30555555555556
69032, 2.0913043478261, 0.98478260869565, 0.27777777777778
69033, 2.1130434782609, 1.0108695652174, 0.27777777777778
69034, 2.1130434782609, 0.98478260869565, 0.25
69035, 2.0913043478261, 0.98478260869565, 0.22222222222222
69036, 2.1130434782609, 1.0108695652174, 0.22222222222222
69037, 2.1130434782609, 0.98478260869565, 0.19444444444444
69038, 2.0913043478261, 0.98478260869565, 0.16666666666667
69039, 2.1130434782609, 1.0108695652174, 0.16666666666667
69040, 2.1130434782609, 0.98478260869565, 0.13888888888889
69041, 2.0913043478261, 0.98478260869565, 0.11111111111111
69042, 2.1130434782609, 1.0108695652174, 0.11111111111111
69043, 2.1130434782609, 0.98478260869565, 0.083333333333333
69044, 2.0913043478261, 0.98478260869565, 0.055555555555556
69045, 2.1130434782609, 1.0108695652174, 0.055555555555556
69046, 2.1130434782609, 0.98478260869565, 0.027777777777778
69047, 2.1565217391304, 0.98478260869565, 0.47222222222222
69048, 2.1347826086957, 0.98478260869565, 0.44444444444444
69049, 2.1565217391304, 1.0108695652174, 0.44444444444444
69050, 2.1565217391304, 0.98478260869565, 0.41666666666667
69051, 2.1347826086957, 0.98478260869565, 0.38888888888889
69052, 2.1565217391304, 1.0108695652174, 0.38888888888889
69053, 2.1565217391304, 0.98478260869565, 0.36111111111111
69054, 2.1347826086957, 0.98478260869565, 0.33333333333333
69055, 2.1565217391304, 1.0108695652174, 0.33333333333333
69056, 2.1565217391304, 0.98478260869565, 0.30555555555556
69057, 2.1347826086957, 0.98478260869565, 0.27777777777778
69058, 2.1565217391304, 1.0108695652174, 0.27777777777778
69059, 2.1565217391304, 0.98478260869565, 0.25
69060, 2.1347826086957, 0.98478260869565, 0.22222222222222
69061, 2.1565217391304, 1.0108695652174, 0.22222222222222
69062, 2.1565217391304, 0.98478260869565, 0.19444444444444
69063, 2.1347826086957, 0.98478260869565, 0.16666666666667
69064, 2.1565217391304, 1.0108695652174, 0.16666666666667
69065, 2.1565217391304, 0.98478260869565, 0.13888888888889
69066, 2.1347826086957, 0.98478260869565, 0.11111111111111
69067, 2.1565217391304, 1.0108695652174, 0.11111111111111
69068, 2.1565217391304, 0.98478260869565, 0.083333333333333
69069, 2.1347826086957, 0.98478260869565, 0.055555555555556
69070, 2.1565217391304, 1.0108695652174, 0.055555555555556
69071, 2.1565217391304, 0.98478260869565, 0.027777777777778
69072, 2.1782608695652, 0.98478260869565, 0.44444444444444
69073, 2.1782608695652, 0.98478260869565, 0.38888888888889
69074, 2.1782608695652, 0.98478260869565, 0.33333333333333
69075, 2.1782608695652, 0.98478260869565, 0.27777777777778
69076, 2.1782608695652, 0.98478260869565, 0.22222222222222
69077, 2.1782608695652, 0.98478260869565, 0.16666666666667
69078, 2.1782608695652, 0.98478260869565, 0.11111111111111
69079, 2.1782608695652, 0.98478260869565, 0.055555555555556
69080, 1.2434782608696, 0.93260869565217, 0.47222222222222
69081, 1.2217391304348, 0.93260869565217, 0.44444444444444
69082, 1.2434782608696, 0.95869565217391, 0.44444444444444
69083, 1.2434782608696, 0.93260869565217, 0.41666666666667
69084, 1.2217391304348, 0.93260869565217, 0.38888888888889
69085, 1.2434782608696, 0.95869565217391, 0.38888888888889
69086, 1.2434782608696, 0.93260869565217, 0.36111111111111
69087, 1.2217391304348, 0.93260869565217, 0.33333333333333
69088, 1.2434782608696, 0.95869565217391, 0.33333333333333
69089, 1.2434782608696, 0.93260869565217, 0.30555555555556
69090, 1.2217391304348, 0.93260869565217, 0.27777777777778
69091, 1.2434782608696, 0.95869565217391, 0.27777777777778
69092, 1.2434782608696, 0.93260869565217, 0.25
69093, 1.2217391304348, 0.93260869565217, 0.22222222222222
69094, 1.2434782608696, 0.95869565217391, 0.22222222222222
69095, 1.2434782608696, 0.93260869565217, 0.19444444444444
69096, 1.2217391304348, 0.93260869565217, 0.16666666666667
69097, 1.2434782608696, 0.95869565217391, 0.16666666666667
69098, 1.2434782608696, 0.93260869565217, 0.13888888888889
69099, 1.2217391304348, 0.93260869565217, 0.11111111111111
69100, 1.2434782608696, 0.95869565217391, 0.11111111111111
69101, 1.2434782608696, 0.93260869565217, 0.083333333333333
69102, 1.2217391304348, 0.93260869565217, 0.055555555555556
69103, 1.2434782608696, 0.95869565217391, 0.055555555555556
69104, 1.2434782608696, 0.93260869565217, 0.027777777777778
69105, 1.2869565217391, 0.93260869565217, 0.47222222222222
69106, 1.2652173913043, 0.93260869565218, 0.44444444444444
69107, 1.2869565217391, 0.95869565217391, 0.44444444444444
69108, 1.2869565217391, 0.93260869565217, 0.41666666666667
69109, 1.2652173913043, 0.93260869565217, 0.38888888888889
69110, 1.2869565217391, 0.95869565217391, 0.38888888888889
69111, 1.2869565217391, 0.93260869565217, 0.36111111111111
69112, 1.2652173913043, 0.93260869565217, 0.33333333333333
69113, 1.2869565217391, 0.95869565217391, 0.33333333333333
69114, 1.2869565217391, 0.93260869565217, 0.30555555555556
69115, 1.2652173913043, 0.93260869565218, 0.27777777777778
69116, 1.2869565217391, 0.95869565217391, 0.27777777777778
69117, 1.2869565217391, 0.93260869565217, 0.25
69118, 1.2652173913043, 0.93260869565217, 0.22222222222222
69119, 1.2869565217391, 0.95869565217391, 0.22222222222222
69120, 1.2869565217391, 0.93260869565217, 0.19444444444444
69121, 1.2652173913043, 0.93260869565217, 0.16666666666667
69122, 1.2869565217391, 0.95869565217391, 0.16666666666667
69123, 1.2869565217391, 0.93260869565217, 0.13888888888889
69124, 1.2652173913043, 0.93260869565217, 0.11111111111111
69125, 1.2869565217391, 0.95869565217391, 0.11111111111111
69126, 1.2869565217391, 0.93260869565217, 0.083333333333333
69127, 1.2652173913043, 0.93260869565217, 0.055555555555556
69128, 1.2869565217391, 0.95869565217391, 0.055555555555556
69129, 1.2869565217391, 0.93260869565217, 0.027777777777778
69130, 1.3304347826087, 0.93260869565217, 0.47222222222222
69131, 1.3086956521739, 0.93260869565218, 0.44444444444444
69132, 1.3304347826087, 0.95869565217391, 0.44444444444444
69133, 1.3304347826087, 0.93260869565217, 0.41666666666667
69134, 1.3086956521739, 0.93260869565217, 0.38888888888889
69135, 1.3304347826087, 0.95869565217391, 0.38888888888889
69136, 1.3304347826087, 0.93260869565217, 0.36111111111111
69137, 1.3086956521739, 0.93260869565217, 0.33333333333333
69138, 1.3304347826087, 0.95869565217391, 0.33333333333333
69139, 1.3304347826087, 0.93260869565217, 0.30555555555556
69140, 1.3086956521739, 0.93260869565218, 0.27777777777778
69141, 1.3304347826087, 0.95869565217391, 0.27777777777778
69142, 1.3304347826087, 0.93260869565217, 0.25
69143, 1.3086956521739, 0.93260869565217, 0.22222222222222
69144, 1.3304347826087, 0.95869565217391, 0.22222222222222
69145, 1.3304347826087, 0.93260869565217, 0.19444444444444
69146, 1.3086956521739, 0.93260869565217, 0.16666666666667
69147, 1.3304347826087, 0.95869565217391, 0.16666666666667
69148, 1.3304347826087, 0.93260869565217, 0.13888888888889
69149, 1.3086956521739, 0.93260869565217, 0.11111111111111
69150, 1.3304347826087, 0.95869565217391, 0.11111111111111
69151, 1.3304347826087, 0.93260869565218, 0.083333333333333
69152, 1.3086956521739, 0.93260869565217, 0.055555555555556
69153, 1.3304347826087, 0.95869565217391, 0.055555555555556
69154, 1.3304347826087, 0.93260869565217, 0.027777777777778
69155, 1.3739130434783, 0.93260869565217, 0.47222222222222
69156, 1.3521739130435, 0.93260869565218, 0.44444444444444
69157, 1.3739130434783, 0.95869565217391, 0.44444444444444
69158, 1.3739130434783, 0.93260869565217, 0.41666666666667
69159, 1.3521739130435, 0.93260869565217, 0.38888888888889
69160, 1.3739130434783, 0.95869565217391, 0.38888888888889
69161, 1.3739130434783, 0.93260869565217, 0.36111111111111
69162, 1.3521739130435, 0.93260869565217, 0.33333333333333
69163, 1.3739130434783, 0.95869565217391, 0.33333333333333
69164, 1.3739130434783, 0.93260869565217, 0.30555555555556
69165, 1.3521739130435, 0.93260869565218, 0.27777777777778
69166, 1.3739130434783, 0.95869565217391, 0.27777777777778
69167, 1.3739130434783, 0.93260869565217, 0.25
69168, 1.3521739130435, 0.93260869565217, 0.22222222222222
69169, 1.3739130434783, 0.95869565217391, 0.22222222222222
69170, 1.3739130434783, 0.93260869565217, 0.19444444444444
69171, 1.3521739130435, 0.93260869565217, 0.16666666666667
69172, 1.3739130434783, 0.95869565217391, 0.16666666666667
69173, 1.3739130434783, 0.93260869565217, 0.13888888888889
69174, 1.3521739130435, 0.93260869565217, 0.11111111111111
69175, 1.3739130434783, 0.95869565217391, 0.11111111111111
69176, 1.3739130434783, 0.93260869565217, 0.083333333333333
69177, 1.3521739130435, 0.93260869565217, 0.055555555555556
69178, 1.3739130434783, 0.95869565217391, 0.055555555555556
69179, 1.3739130434783, 0.93260869565217, 0.027777777777778
69180, 1.4173913043478, 0.93260869565217, 0.47222222222222
69181, 1.395652173913, 0.93260869565218, 0.44444444444444
69182, 1.4173913043478, 0.95869565217391, 0.44444444444444
69183, 1.4173913043478, 0.93260869565217, 0.41666666666667
69184, 1.395652173913, 0.93260869565217, 0.38888888888889
69185, 1.4173913043478, 0.95869565217391, 0.38888888888889
69186, 1.4173913043478, 0.93260869565217, 0.36111111111111
69187, 1.395652173913, 0.93260869565217, 0.33333333333333
69188, 1.4173913043478, 0.95869565217391, 0.33333333333333
69189, 1.4173913043478, 0.93260869565217, 0.30555555555556
69190, 1.395652173913, 0.93260869565218, 0.27777777777778
69191, 1.4173913043478, 0.95869565217391, 0.27777777777778
69192, 1.4173913043478, 0.93260869565217, 0.25
69193, 1.395652173913, 0.93260869565217, 0.22222222222222
69194, 1.4173913043478, 0.95869565217391, 0.22222222222222
69195, 1.4173913043478, 0.93260869565217, 0.19444444444444
69196, 1.395652173913, 0.93260869565217, 0.16666666666667
69197, 1.4173913043478, 0.95869565217391, 0.16666666666667
69198, 1.4173913043478, 0.93260869565217, 0.13888888888889
69199, 1.395652173913, 0.93260869565217, 0.11111111111111
69200, 1.4173913043478, 0.95869565217391, 0.11111111111111
69201, 1.4173913043478, 0.93260869565217, 0.083333333333333
69202, 1.395652173913, 0.93260869565217, 0.055555555555556
69203, 1.4173913043478, 0.95869565217391, 0.055555555555556
69204, 1.4173913043478, 0.93260869565217, 0.027777777777778
69205, 1.4608695652174, 0.93260869565217, 0.47222222222222
69206, 1.4391304347826, 0.93260869565218, 0.44444444444444
69207, 1.4608695652174, 0.95869565217391, 0.44444444444444
69208, 1.4608695652174, 0.93260869565217, 0.41666666666667
69209, 1.4391304347826, 0.93260869565217, 0.38888888888889
69210, 1.4608695652174, 0.95869565217391, 0.38888888888889
69211, 1.4608695652174, 0.93260869565217, 0.36111111111111
69212, 1.4391304347826, 0.93260869565217, 0.33333333333333
69213, 1.4608695652174, 0.95869565217391, 0.33333333333333
69214, 1.4608695652174, 0.93260869565217, 0.30555555555556
69215, 1.4391304347826, 0.93260869565218, 0.27777777777778
69216, 1.4608695652174, 0.95869565217391, 0.27777777777778
69217, 1.4608695652174, 0.93260869565217, 0.25
69218, 1.4391304347826, 0.93260869565217, 0.22222222222222
69219, 1.4608695652174, 0.95869565217391, 0.22222222222222
69220, 1.4608695652174, 0.93260869565217, 0.19444444444444
69221, 1.4391304347826, 0.93260869565217, 0.16666666666667
69222, 1.4608695652174, 0.95869565217391, 0.16666666666667
69223, 1.4608695652174, 0.93260869565217, 0.13888888888889
69224, 1.4391304347826, 0.93260869565217, 0.11111111111111
69225, 1.4608695652174, 0.95869565217391, 0.11111111111111
69226, 1.4608695652174, 0.93260869565217, 0.083333333333333
69227, 1.4391304347826, 0.93260869565217, 0.055555555555556
69228, 1.4608695652174, 0.95869565217391, 0.055555555555556
69229, 1.4608695652174, 0.93260869565217, 0.027777777777778
69230, 1.504347826087, 0.93260869565217, 0.47222222222222
69231, 1.4826086956522, 0.93260869565217, 0.44444444444444
69232, 1.504347826087, 0.95869565217391, 0.44444444444444
69233, 1.504347826087, 0.93260869565217, 0.41666666666667
69234, 1.4826086956522, 0.93260869565217, 0.38888888888889
69235, 1.504347826087, 0.95869565217391, 0.38888888888889
69236, 1.504347826087, 0.93260869565217, 0.36111111111111
69237, 1.4826086956522, 0.93260869565217, 0.33333333333333
69238, 1.504347826087, 0.95869565217391, 0.33333333333333
69239, 1.504347826087, 0.93260869565217, 0.30555555555556
69240, 1.4826086956522, 0.93260869565217, 0.27777777777778
69241, 1.504347826087, 0.95869565217391, 0.27777777777778
69242, 1.504347826087, 0.93260869565217, 0.25
69243, 1.4826086956522, 0.93260869565217, 0.22222222222222
69244, 1.504347826087, 0.95869565217391, 0.22222222222222
69245, 1.504347826087, 0.93260869565217, 0.19444444444444
69246, 1.4826086956522, 0.93260869565217, 0.16666666666667
69247, 1.504347826087, 0.95869565217391, 0.16666666666667
69248, 1.504347826087, 0.93260869565217, 0.13888888888889
69249, 1.4826086956522, 0.93260869565217, 0.11111111111111
69250, 1.504347826087, 0.95869565217391, 0.11111111111111
69251, 1.504347826087, 0.93260869565217, 0.083333333333333
69252, 1.4826086956522, 0.93260869565217, 0.055555555555556
69253, 1.504347826087, 0.95869565217391, 0.055555555555556
69254, 1.504347826087, 0.93260869565217, 0.027777777777778
69255, 1.5478260869565, 0.93260869565217, 0.47222222222222
69256, 1.5260869565217, 0.93260869565217, 0.44444444444444
69257, 1.5478260869565, 0.95869565217391, 0.44444444444444
69258, 1.5478260869565, 0.93260869565217, 0.41666666666667
69259, 1.5260869565217, 0.93260869565217, 0.38888888888889
69260, 1.5478260869565, 0.95869565217391, 0.38888888888889
69261, 1.5478260869565, 0.93260869565217, 0.36111111111111
69262, 1.5260869565217, 0.93260869565217, 0.33333333333333
69263, 1.5478260869565, 0.95869565217391, 0.33333333333333
69264, 1.5478260869565, 0.93260869565217, 0.30555555555556
69265, 1.5260869565217, 0.93260869565217, 0.27777777777778
69266, 1.5478260869565, 0.95869565217391, 0.27777777777778
69267, 1.5478260869565, 0.93260869565217, 0.25
69268, 1.5260869565217, 0.93260869565217, 0.22222222222222
69269, 1.5478260869565, 0.95869565217391, 0.22222222222222
69270, 1.5478260869565, 0.93260869565217, 0.19444444444444
69271, 1.5260869565217, 0.93260869565217, 0.16666666666667
69272, 1.5478260869565, 0.95869565217391, 0.16666666666667
69273, 1.5478260869565, 0.93260869565218, 0.13888888888889
69274, 1.5260869565217, 0.93260869565217, 0.11111111111111
69275, 1.5478260869565, 0.95869565217391, 0.11111111111111
69276, 1.5478260869565, 0.93260869565217, 0.083333333333333
69277, 1.5260869565217, 0.93260869565217, 0.055555555555556
69278, 1.5478260869565, 0.95869565217391, 0.055555555555556
69279, 1.5478260869565, 0.93260869565217, 0.027777777777778
69280, 1.5913043478261, 0.93260869565217, 0.47222222222222
69281, 1.5695652173913, 0.93260869565218, 0.44444444444444
69282, 1.5913043478261, 0.95869565217391, 0.44444444444444
69283, 1.5913043478261, 0.93260869565217, 0.41666666666667
69284, 1.5695652173913, 0.93260869565217, 0.38888888888889
69285, 1.5913043478261, 0.95869565217391, 0.38888888888889
69286, 1.5913043478261, 0.93260869565217, 0.36111111111111
69287, 1.5695652173913, 0.93260869565217, 0.33333333333333
69288, 1.5913043478261, 0.95869565217391, 0.33333333333333
69289, 1.5913043478261, 0.93260869565218, 0.30555555555556
69290, 1.5695652173913, 0.93260869565218, 0.27777777777778
69291, 1.5913043478261, 0.95869565217391, 0.27777777777778
69292, 1.5913043478261, 0.93260869565218, 0.25
69293, 1.5695652173913, 0.93260869565217, 0.22222222222222
69294, 1.5913043478261, 0.95869565217391, 0.22222222222222
69295, 1.5913043478261, 0.93260869565218, 0.19444444444444
69296, 1.5695652173913, 0.93260869565218, 0.16666666666667
69297, 1.5913043478261, 0.95869565217391, 0.16666666666667
69298, 1.5913043478261, 0.93260869565218, 0.13888888888889
69299, 1.5695652173913, 0.93260869565218, 0.11111111111111
69300, 1.5913043478261, 0.95869565217391, 0.11111111111111
69301, 1.5913043478261, 0.93260869565217, 0.083333333333333
69302, 1.5695652173913, 0.93260869565217, 0.055555555555556
69303, 1.5913043478261, 0.95869565217391, 0.055555555555556
69304, 1.5913043478261, 0.93260869565217, 0.027777777777778
69305, 1.6347826086957, 0.93260869565217, 0.47222222222222
69306, 1.6130434782609, 0.93260869565218, 0.44444444444444
69307, 1.6347826086957, 0.95869565217391, 0.44444444444444
69308, 1.6347826086957, 0.93260869565217, 0.41666666666667
69309, 1.6130434782609, 0.93260869565217, 0.38888888888889
69310, 1.6347826086957, 0.95869565217391, 0.38888888888889
69311, 1.6347826086957, 0.93260869565217, 0.36111111111111
69312, 1.6130434782609, 0.93260869565217, 0.33333333333333
69313, 1.6347826086957, 0.95869565217391, 0.33333333333333
69314, 1.6347826086957, 0.93260869565217, 0.30555555555556
69315, 1.6130434782609, 0.93260869565218, 0.27777777777778
69316, 1.6347826086957, 0.95869565217391, 0.27777777777778
69317, 1.6347826086957, 0.93260869565217, 0.25
69318, 1.6130434782609, 0.93260869565217, 0.22222222222222
69319, 1.6347826086957, 0.95869565217391, 0.22222222222222
69320, 1.6347826086957, 0.93260869565217, 0.19444444444444
69321, 1.6130434782609, 0.93260869565217, 0.16666666666667
69322, 1.6347826086957, 0.95869565217391, 0.16666666666667
69323, 1.6347826086957, 0.93260869565217, 0.13888888888889
69324, 1.6130434782609, 0.93260869565218, 0.11111111111111
69325, 1.6347826086957, 0.95869565217391, 0.11111111111111
69326, 1.6347826086957, 0.93260869565218, 0.083333333333333
69327, 1.6130434782609, 0.93260869565218, 0.055555555555556
69328, 1.6347826086957, 0.95869565217391, 0.055555555555556
69329, 1.6347826086957, 0.93260869565217, 0.027777777777778
69330, 1.6782608695652, 0.93260869565217, 0.47222222222222
69331, 1.6565217391304, 0.93260869565218, 0.44444444444444
69332, 1.6782608695652, 0.95869565217391, 0.44444444444444
69333, 1.6782608695652, 0.93260869565217, 0.41666666666667
69334, 1.6565217391304, 0.93260869565217, 0.38888888888889
69335, 1.6782608695652, 0.95869565217391, 0.38888888888889
69336, 1.6782608695652, 0.93260869565217, 0.36111111111111
69337, 1.6565217391304, 0.93260869565217, 0.33333333333333
69338, 1.6782608695652, 0.95869565217391, 0.33333333333333
69339, 1.6782608695652, 0.93260869565217, 0.30555555555556
69340, 1.6565217391304, 0.93260869565218, 0.27777777777778
69341, 1.6782608695652, 0.95869565217391, 0.27777777777778
69342, 1.6782608695652, 0.93260869565217, 0.25
69343, 1.6565217391304, 0.93260869565217, 0.22222222222222
69344, 1.6782608695652, 0.95869565217391, 0.22222222222222
69345, 1.6782608695652, 0.93260869565217, 0.19444444444444
69346, 1.6565217391304, 0.93260869565217, 0.16666666666667
69347, 1.6782608695652, 0.95869565217391, 0.16666666666667
69348, 1.6782608695652, 0.93260869565217, 0.13888888888889
69349, 1.6565217391304, 0.93260869565217, 0.11111111111111
69350, 1.6782608695652, 0.95869565217391, 0.11111111111111
69351, 1.6782608695652, 0.93260869565217, 0.083333333333333
69352, 1.6565217391304, 0.93260869565218, 0.055555555555556
69353, 1.6782608695652, 0.95869565217391, 0.055555555555556
69354, 1.6782608695652, 0.93260869565217, 0.027777777777778
69355, 1.7217391304348, 0.93260869565217, 0.47222222222222
69356, 1.7, 0.93260869565218, 0.44444444444444
69357, 1.7217391304348, 0.95869565217391, 0.44444444444444
69358, 1.7217391304348, 0.93260869565217, 0.41666666666667
69359, 1.7, 0.93260869565217, 0.38888888888889
69360, 1.7217391304348, 0.95869565217391, 0.38888888888889
69361, 1.7217391304348, 0.93260869565217, 0.36111111111111
69362, 1.7, 0.93260869565217, 0.33333333333333
69363, 1.7217391304348, 0.95869565217391, 0.33333333333333
69364, 1.7217391304348, 0.93260869565217, 0.30555555555556
69365, 1.7, 0.93260869565218, 0.27777777777778
69366, 1.7217391304348, 0.95869565217391, 0.27777777777778
69367, 1.7217391304348, 0.93260869565217, 0.25
69368, 1.7, 0.93260869565217, 0.22222222222222
69369, 1.7217391304348, 0.95869565217391, 0.22222222222222
69370, 1.7217391304348, 0.93260869565217, 0.19444444444444
69371, 1.7, 0.93260869565217, 0.16666666666667
69372, 1.7217391304348, 0.95869565217391, 0.16666666666667
69373, 1.7217391304348, 0.93260869565217, 0.13888888888889
69374, 1.7, 0.93260869565217, 0.11111111111111
69375, 1.7217391304348, 0.95869565217391, 0.11111111111111
69376, 1.7217391304348, 0.93260869565217, 0.083333333333333
69377, 1.7, 0.93260869565217, 0.055555555555556
69378, 1.7217391304348, 0.95869565217391, 0.055555555555556
69379, 1.7217391304348, 0.93260869565217, 0.027777777777778
69380, 1.7652173913043, 0.93260869565217, 0.47222222222222
69381, 1.7434782608696, 0.93260869565218, 0.44444444444444
69382, 1.7652173913043, 0.95869565217391, 0.44444444444444
69383, 1.7652173913043, 0.93260869565217, 0.41666666666667
69384, 1.7434782608696, 0.93260869565217, 0.38888888888889
69385, 1.7652173913043, 0.95869565217391, 0.38888888888889
69386, 1.7652173913043, 0.93260869565217, 0.36111111111111
69387, 1.7434782608696, 0.93260869565217, 0.33333333333333
69388, 1.7652173913043, 0.95869565217391, 0.33333333333333
69389, 1.7652173913043, 0.93260869565217, 0.30555555555556
69390, 1.7434782608696, 0.93260869565218, 0.27777777777778
69391, 1.7652173913043, 0.95869565217391, 0.27777777777778
69392, 1.7652173913043, 0.93260869565217, 0.25
69393, 1.7434782608696, 0.93260869565217, 0.22222222222222
69394, 1.7652173913043, 0.95869565217391, 0.22222222222222
69395, 1.7652173913043, 0.93260869565217, 0.19444444444444
69396, 1.7434782608696, 0.93260869565217, 0.16666666666667
69397, 1.7652173913043, 0.95869565217391, 0.16666666666667
69398, 1.7652173913043, 0.93260869565217, 0.13888888888889
69399, 1.7434782608696, 0.93260869565217, 0.11111111111111
69400, 1.7652173913043, 0.95869565217391, 0.11111111111111
69401, 1.7652173913043, 0.93260869565217, 0.083333333333333
69402, 1.7434782608696, 0.93260869565217, 0.055555555555556
69403, 1.7652173913043, 0.95869565217391, 0.055555555555556
69404, 1.7652173913043, 0.93260869565217, 0.027777777777778
69405, 1.8086956521739, 0.93260869565217, 0.47222222222222
69406, 1.7869565217391, 0.93260869565218, 0.44444444444444
69407, 1.8086956521739, 0.95869565217391, 0.44444444444444
69408, 1.8086956521739, 0.93260869565217, 0.41666666666667
69409, 1.7869565217391, 0.93260869565217, 0.38888888888889
69410, 1.8086956521739, 0.95869565217391, 0.38888888888889
69411, 1.8086956521739, 0.93260869565217, 0.36111111111111
69412, 1.7869565217391, 0.93260869565217, 0.33333333333333
69413, 1.8086956521739, 0.95869565217391, 0.33333333333333
69414, 1.8086956521739, 0.93260869565217, 0.30555555555556
69415, 1.7869565217391, 0.93260869565218, 0.27777777777778
69416, 1.8086956521739, 0.95869565217391, 0.27777777777778
69417, 1.8086956521739, 0.93260869565217, 0.25
69418, 1.7869565217391, 0.93260869565217, 0.22222222222222
69419, 1.8086956521739, 0.95869565217391, 0.22222222222222
69420, 1.8086956521739, 0.93260869565217, 0.19444444444444
69421, 1.7869565217391, 0.93260869565217, 0.16666666666667
69422, 1.8086956521739, 0.95869565217391, 0.16666666666667
69423, 1.8086956521739, 0.93260869565218, 0.13888888888889
69424, 1.7869565217391, 0.93260869565217, 0.11111111111111
69425, 1.8086956521739, 0.95869565217391, 0.11111111111111
69426, 1.8086956521739, 0.93260869565217, 0.083333333333333
69427, 1.7869565217391, 0.93260869565217, 0.055555555555556
69428, 1.8086956521739, 0.95869565217391, 0.055555555555556
69429, 1.8086956521739, 0.93260869565217, 0.027777777777778
69430, 1.8521739130435, 0.93260869565217, 0.47222222222222
69431, 1.8304347826087, 0.93260869565217, 0.44444444444444
69432, 1.8521739130435, 0.95869565217391, 0.44444444444444
69433, 1.8521739130435, 0.93260869565217, 0.41666666666667
69434, 1.8304347826087, 0.93260869565217, 0.38888888888889
69435, 1.8521739130435, 0.95869565217391, 0.38888888888889
69436, 1.8521739130435, 0.93260869565217, 0.36111111111111
69437, 1.8304347826087, 0.93260869565217, 0.33333333333333
69438, 1.8521739130435, 0.95869565217391, 0.33333333333333
69439, 1.8521739130435, 0.93260869565217, 0.30555555555556
69440, 1.8304347826087, 0.93260869565218, 0.27777777777778
69441, 1.8521739130435, 0.95869565217391, 0.27777777777778
69442, 1.8521739130435, 0.93260869565217, 0.25
69443, 1.8304347826087, 0.93260869565217, 0.22222222222222
69444, 1.8521739130435, 0.95869565217391, 0.22222222222222
69445, 1.8521739130435, 0.93260869565217, 0.19444444444444
69446, 1.8304347826087, 0.93260869565218, 0.16666666666667
69447, 1.8521739130435, 0.95869565217391, 0.16666666666667
69448, 1.8521739130435, 0.93260869565218, 0.13888888888889
69449, 1.8304347826087, 0.93260869565218, 0.11111111111111
69450, 1.8521739130435, 0.95869565217391, 0.11111111111111
69451, 1.8521739130435, 0.93260869565217, 0.083333333333333
69452, 1.8304347826087, 0.93260869565217, 0.055555555555556
69453, 1.8521739130435, 0.95869565217391, 0.055555555555556
69454, 1.8521739130435, 0.93260869565217, 0.027777777777778
69455, 1.895652173913, 0.93260869565217, 0.47222222222222
69456, 1.8739130434783, 0.93260869565218, 0.44444444444444
69457, 1.895652173913, 0.95869565217391, 0.44444444444444
69458, 1.895652173913, 0.93260869565217, 0.41666666666667
69459, 1.8739130434783, 0.93260869565217, 0.38888888888889
69460, 1.895652173913, 0.95869565217391, 0.38888888888889
69461, 1.895652173913, 0.93260869565217, 0.36111111111111
69462, 1.8739130434783, 0.93260869565217, 0.33333333333333
69463, 1.895652173913, 0.95869565217391, 0.33333333333333
69464, 1.895652173913, 0.93260869565217, 0.30555555555556
69465, 1.8739130434783, 0.93260869565218, 0.27777777777778
69466, 1.895652173913, 0.95869565217391, 0.27777777777778
69467, 1.895652173913, 0.93260869565217, 0.25
69468, 1.8739130434783, 0.93260869565217, 0.22222222222222
69469, 1.895652173913, 0.95869565217391, 0.22222222222222
69470, 1.895652173913, 0.93260869565217, 0.19444444444444
69471, 1.8739130434783, 0.93260869565217, 0.16666666666667
69472, 1.895652173913, 0.95869565217391, 0.16666666666667
69473, 1.895652173913, 0.93260869565217, 0.13888888888889
69474, 1.8739130434783, 0.93260869565217, 0.11111111111111
69475, 1.895652173913, 0.95869565217391, 0.11111111111111
69476, 1.895652173913, 0.93260869565217, 0.083333333333333
69477, 1.8739130434783, 0.93260869565217, 0.055555555555556
69478, 1.895652173913, 0.95869565217391, 0.055555555555556
69479, 1.895652173913, 0.93260869565217, 0.027777777777778
69480, 1.9391304347826, 0.93260869565217, 0.47222222222222
69481, 1.9173913043478, 0.93260869565218, 0.44444444444444
69482, 1.9391304347826, 0.95869565217391, 0.44444444444444
69483, 1.9391304347826, 0.93260869565217, 0.41666666666667
69484, 1.9173913043478, 0.93260869565217, 0.38888888888889
69485, 1.9391304347826, 0.95869565217391, 0.38888888888889
69486, 1.9391304347826, 0.93260869565217, 0.36111111111111
69487, 1.9173913043478, 0.93260869565217, 0.33333333333333
69488, 1.9391304347826, 0.95869565217391, 0.33333333333333
69489, 1.9391304347826, 0.93260869565218, 0.30555555555556
69490, 1.9173913043478, 0.93260869565218, 0.27777777777778
69491, 1.9391304347826, 0.95869565217391, 0.27777777777778
69492, 1.9391304347826, 0.93260869565217, 0.25
69493, 1.9173913043478, 0.93260869565217, 0.22222222222222
69494, 1.9391304347826, 0.95869565217391, 0.22222222222222
69495, 1.9391304347826, 0.93260869565217, 0.19444444444444
69496, 1.9173913043478, 0.93260869565217, 0.16666666666667
69497, 1.9391304347826, 0.95869565217391, 0.16666666666667
69498, 1.9391304347826, 0.93260869565217, 0.13888888888889
69499, 1.9173913043478, 0.93260869565217, 0.11111111111111
69500, 1.9391304347826, 0.95869565217391, 0.11111111111111
69501, 1.9391304347826, 0.93260869565217, 0.083333333333333
69502, 1.9173913043478, 0.93260869565217, 0.055555555555556
69503, 1.9391304347826, 0.95869565217391, 0.055555555555556
69504, 1.9391304347826, 0.93260869565217, 0.027777777777778
69505, 1.9826086956522, 0.93260869565217, 0.47222222222222
69506, 1.9608695652174, 0.93260869565218, 0.44444444444444
69507, 1.9826086956522, 0.95869565217391, 0.44444444444444
69508, 1.9826086956522, 0.93260869565217, 0.41666666666667
69509, 1.9608695652174, 0.93260869565217, 0.38888888888889
69510, 1.9826086956522, 0.95869565217391, 0.38888888888889
69511, 1.9826086956522, 0.93260869565217, 0.36111111111111
69512, 1.9608695652174, 0.93260869565217, 0.33333333333333
69513, 1.9826086956522, 0.95869565217391, 0.33333333333333
69514, 1.9826086956522, 0.93260869565217, 0.30555555555556
69515, 1.9608695652174, 0.93260869565218, 0.27777777777778
69516, 1.9826086956522, 0.95869565217391, 0.27777777777778
69517, 1.9826086956522, 0.93260869565217, 0.25
69518, 1.9608695652174, 0.93260869565217, 0.22222222222222
69519, 1.9826086956522, 0.95869565217391, 0.22222222222222
69520, 1.9826086956522, 0.93260869565217, 0.19444444444444
69521, 1.9608695652174, 0.93260869565217, 0.16666666666667
69522, 1.9826086956522, 0.95869565217391, 0.16666666666667
69523, 1.9826086956522, 0.93260869565217, 0.13888888888889
69524, 1.9608695652174, 0.93260869565217, 0.11111111111111
69525, 1.9826086956522, 0.95869565217391, 0.11111111111111
69526, 1.9826086956522, 0.93260869565217, 0.083333333333333
69527, 1.9608695652174, 0.93260869565217, 0.055555555555556
69528, 1.9826086956522, 0.95869565217391, 0.055555555555556
69529, 1.9826086956522, 0.93260869565217, 0.027777777777778
69530, 2.0260869565217, 0.93260869565217, 0.47222222222222
69531, 2.004347826087, 0.93260869565218, 0.44444444444444
69532, 2.0260869565217, 0.95869565217391, 0.44444444444444
69533, 2.0260869565217, 0.93260869565217, 0.41666666666667
69534, 2.004347826087, 0.93260869565217, 0.38888888888889
69535, 2.0260869565217, 0.95869565217391, 0.38888888888889
69536, 2.0260869565217, 0.93260869565217, 0.36111111111111
69537, 2.004347826087, 0.93260869565217, 0.33333333333333
69538, 2.0260869565217, 0.95869565217391, 0.33333333333333
69539, 2.0260869565217, 0.93260869565217, 0.30555555555556
69540, 2.004347826087, 0.93260869565218, 0.27777777777778
69541, 2.0260869565217, 0.95869565217391, 0.27777777777778
69542, 2.0260869565217, 0.93260869565217, 0.25
69543, 2.004347826087, 0.93260869565217, 0.22222222222222
69544, 2.0260869565217, 0.95869565217391, 0.22222222222222
69545, 2.0260869565217, 0.93260869565217, 0.19444444444444
69546, 2.004347826087, 0.93260869565217, 0.16666666666667
69547, 2.0260869565217, 0.95869565217391, 0.16666666666667
69548, 2.0260869565217, 0.93260869565217, 0.13888888888889
69549, 2.004347826087, 0.93260869565217, 0.11111111111111
69550, 2.0260869565217, 0.95869565217391, 0.11111111111111
69551, 2.0260869565217, 0.93260869565217, 0.083333333333333
69552, 2.004347826087, 0.93260869565217, 0.055555555555556
69553, 2.0260869565217, 0.95869565217391, 0.055555555555556
69554, 2.0260869565217, 0.93260869565217, 0.027777777777778
69555, 2.0695652173913, 0.93260869565217, 0.47222222222222
69556, 2.0478260869565, 0.93260869565218, 0.44444444444444
69557, 2.0695652173913, 0.95869565217391, 0.44444444444444
69558, 2.0695652173913, 0.93260869565217, 0.41666666666667
69559, 2.0478260869565, 0.93260869565217, 0.38888888888889
69560, 2.0695652173913, 0.95869565217391, 0.38888888888889
69561, 2.0695652173913, 0.93260869565217, 0.36111111111111
69562, 2.0478260869565, 0.93260869565217, 0.33333333333333
69563, 2.0695652173913, 0.95869565217391, 0.33333333333333
69564, 2.0695652173913, 0.93260869565217, 0.30555555555556
69565, 2.0478260869565, 0.93260869565218, 0.27777777777778
69566, 2.0695652173913, 0.95869565217391, 0.27777777777778
69567, 2.0695652173913, 0.93260869565217, 0.25
69568, 2.0478260869565, 0.93260869565217, 0.22222222222222
69569, 2.0695652173913, 0.95869565217391, 0.22222222222222
69570, 2.0695652173913, 0.93260869565217, 0.19444444444444
69571, 2.0478260869565, 0.93260869565217, 0.16666666666667
69572, 2.0695652173913, 0.95869565217391, 0.16666666666667
69573, 2.0695652173913, 0.93260869565218, 0.13888888888889
69574, 2.0478260869565, 0.93260869565217, 0.11111111111111
69575, 2.0695652173913, 0.95869565217391, 0.11111111111111
69576, 2.0695652173913, 0.93260869565217, 0.083333333333333
69577, 2.0478260869565, 0.93260869565217, 0.055555555555556
69578, 2.0695652173913, 0.95869565217391, 0.055555555555556
69579, 2.0695652173913, 0.93260869565217, 0.027777777777778
69580, 2.1130434782609, 0.93260869565217, 0.47222222222222
69581, 2.0913043478261, 0.93260869565218, 0.44444444444444
69582, 2.1130434782609, 0.95869565217391, 0.44444444444444
69583, 2.1130434782609, 0.93260869565217, 0.41666666666667
69584, 2.0913043478261, 0.93260869565217, 0.38888888888889
69585, 2.1130434782609, 0.95869565217391, 0.38888888888889
69586, 2.1130434782609, 0.93260869565217, 0.36111111111111
69587, 2.0913043478261, 0.93260869565217, 0.33333333333333
69588, 2.1130434782609, 0.95869565217391, 0.33333333333333
69589, 2.1130434782609, 0.93260869565217, 0.30555555555556
69590, 2.0913043478261, 0.93260869565218, 0.27777777777778
69591, 2.1130434782609, 0.95869565217391, 0.27777777777778
69592, 2.1130434782609, 0.93260869565217, 0.25
69593, 2.0913043478261, 0.93260869565217, 0.22222222222222
69594, 2.1130434782609, 0.95869565217391, 0.22222222222222
69595, 2.1130434782609, 0.93260869565217, 0.19444444444444
69596, 2.0913043478261, 0.93260869565217, 0.16666666666667
69597, 2.1130434782609, 0.95869565217391, 0.16666666666667
69598, 2.1130434782609, 0.93260869565217, 0.13888888888889
69599, 2.0913043478261, 0.93260869565217, 0.11111111111111
69600, 2.1130434782609, 0.95869565217391, 0.11111111111111
69601, 2.1130434782609, 0.93260869565217, 0.083333333333333
69602, 2.0913043478261, 0.93260869565217, 0.055555555555556
69603, 2.1130434782609, 0.95869565217391, 0.055555555555556
69604, 2.1130434782609, 0.93260869565217, 0.027777777777778
69605, 2.1565217391304, 0.93260869565217, 0.47222222222222
69606, 2.1347826086957, 0.93260869565218, 0.44444444444444
69607, 2.1565217391304, 0.95869565217391, 0.44444444444444
69608, 2.1565217391304, 0.93260869565217, 0.41666666666667
69609, 2.1347826086957, 0.93260869565217, 0.38888888888889
69610, 2.1565217391304, 0.95869565217391, 0.38888888888889
69611, 2.1565217391304, 0.93260869565217, 0.36111111111111
69612, 2.1347826086957, 0.93260869565217, 0.33333333333333
69613, 2.1565217391304, 0.95869565217391, 0.33333333333333
69614, 2.1565217391304, 0.93260869565217, 0.30555555555556
69615, 2.1347826086957, 0.93260869565218, 0.27777777777778
69616, 2.1565217391304, 0.95869565217391, 0.27777777777778
69617, 2.1565217391304, 0.93260869565217, 0.25
69618, 2.1347826086957, 0.93260869565217, 0.22222222222222
69619, 2.1565217391304, 0.95869565217391, 0.22222222222222
69620, 2.1565217391304, 0.93260869565217, 0.19444444444444
69621, 2.1347826086957, 0.93260869565217, 0.16666666666667
69622, 2.1565217391304, 0.95869565217391, 0.16666666666667
69623, 2.1565217391304, 0.93260869565217, 0.13888888888889
69624, 2.1347826086957, 0.93260869565217, 0.11111111111111
69625, 2.1565217391304, 0.95869565217391, 0.11111111111111
69626, 2.1565217391304, 0.93260869565217, 0.083333333333333
69627, 2.1347826086957, 0.93260869565217, 0.055555555555556
69628, 2.1565217391304, 0.95869565217391, 0.055555555555556
69629, 2.1565217391304, 0.93260869565217, 0.027777777777778
69630, 2.1782608695652, 0.93260869565217, 0.44444444444444
69631, 2.1782608695652, 0.93260869565217, 0.38888888888889
69632, 2.1782608695652, 0.93260869565217, 0.33333333333333
69633, 2.1782608695652, 0.93260869565217, 0.27777777777778
69634, 2.1782608695652, 0.93260869565217, 0.22222222222222
69635, 2.1782608695652, 0.93260869565217, 0.16666666666667
69636, 2.1782608695652, 0.93260869565217, 0.11111111111111
69637, 2.1782608695652, 0.93260869565217, 0.055555555555556
69638, 1.2434782608696, 0.8804347826087, 0.47222222222222
69639, 1.2217391304348, 0.8804347826087, 0.44444444444444
69640, 1.2434782608696, 0.90652173913044, 0.44444444444444
69641, 1.2434782608696, 0.8804347826087, 0.41666666666667
69642, 1.2217391304348, 0.8804347826087, 0.38888888888889
69643, 1.2434782608696, 0.90652173913044, 0.38888888888889
69644, 1.2434782608696, 0.8804347826087, 0.36111111111111
69645, 1.2217391304348, 0.8804347826087, 0.33333333333333
69646, 1.2434782608696, 0.90652173913044, 0.33333333333333
69647, 1.2434782608696, 0.8804347826087, 0.30555555555556
69648, 1.2217391304348, 0.8804347826087, 0.27777777777778
69649, 1.2434782608696, 0.90652173913044, 0.27777777777778
69650, 1.2434782608696, 0.8804347826087, 0.25
69651, 1.2217391304348, 0.8804347826087, 0.22222222222222
69652, 1.2434782608696, 0.90652173913044, 0.22222222222222
69653, 1.2434782608696, 0.8804347826087, 0.19444444444444
69654, 1.2217391304348, 0.8804347826087, 0.16666666666667
69655, 1.2434782608696, 0.90652173913044, 0.16666666666667
69656, 1.2434782608696, 0.8804347826087, 0.13888888888889
69657, 1.2217391304348, 0.8804347826087, 0.11111111111111
69658, 1.2434782608696, 0.90652173913044, 0.11111111111111
69659, 1.2434782608696, 0.8804347826087, 0.083333333333333
69660, 1.2217391304348, 0.8804347826087, 0.055555555555556
69661, 1.2434782608696, 0.90652173913044, 0.055555555555556
69662, 1.2434782608696, 0.8804347826087, 0.027777777777778
69663, 1.2869565217391, 0.8804347826087, 0.47222222222222
69664, 1.2652173913043, 0.8804347826087, 0.44444444444444
69665, 1.2869565217391, 0.90652173913044, 0.44444444444444
69666, 1.2869565217391, 0.8804347826087, 0.41666666666667
69667, 1.2652173913043, 0.8804347826087, 0.38888888888889
69668, 1.2869565217391, 0.90652173913044, 0.38888888888889
69669, 1.2869565217391, 0.8804347826087, 0.36111111111111
69670, 1.2652173913043, 0.8804347826087, 0.33333333333333
69671, 1.2869565217391, 0.90652173913044, 0.33333333333333
69672, 1.2869565217391, 0.8804347826087, 0.30555555555556
69673, 1.2652173913043, 0.8804347826087, 0.27777777777778
69674, 1.2869565217391, 0.90652173913044, 0.27777777777778
69675, 1.2869565217391, 0.8804347826087, 0.25
69676, 1.2652173913043, 0.8804347826087, 0.22222222222222
69677, 1.2869565217391, 0.90652173913044, 0.22222222222222
69678, 1.2869565217391, 0.8804347826087, 0.19444444444444
69679, 1.2652173913043, 0.8804347826087, 0.16666666666667
69680, 1.2869565217391, 0.90652173913044, 0.16666666666667
69681, 1.2869565217391, 0.8804347826087, 0.13888888888889
69682, 1.2652173913043, 0.8804347826087, 0.11111111111111
69683, 1.2869565217391, 0.90652173913044, 0.11111111111111
69684, 1.2869565217391, 0.8804347826087, 0.083333333333333
69685, 1.2652173913043, 0.8804347826087, 0.055555555555556
69686, 1.2869565217391, 0.90652173913044, 0.055555555555556
69687, 1.2869565217391, 0.8804347826087, 0.027777777777778
69688, 1.3304347826087, 0.8804347826087, 0.47222222222222
69689, 1.3086956521739, 0.8804347826087, 0.44444444444444
69690, 1.3304347826087, 0.90652173913044, 0.44444444444444
69691, 1.3304347826087, 0.8804347826087, 0.41666666666667
69692, 1.3086956521739, 0.8804347826087, 0.38888888888889
69693, 1.3304347826087, 0.90652173913044, 0.38888888888889
69694, 1.3304347826087, 0.8804347826087, 0.36111111111111
69695, 1.3086956521739, 0.8804347826087, 0.33333333333333
69696, 1.3304347826087, 0.90652173913044, 0.33333333333333
69697, 1.3304347826087, 0.8804347826087, 0.30555555555556
69698, 1.3086956521739, 0.8804347826087, 0.27777777777778
69699, 1.3304347826087, 0.90652173913044, 0.27777777777778
69700, 1.3304347826087, 0.8804347826087, 0.25
69701, 1.3086956521739, 0.8804347826087, 0.22222222222222
69702, 1.3304347826087, 0.90652173913044, 0.22222222222222
69703, 1.3304347826087, 0.8804347826087, 0.19444444444444
69704, 1.3086956521739, 0.8804347826087, 0.16666666666667
69705, 1.3304347826087, 0.90652173913044, 0.16666666666667
69706, 1.3304347826087, 0.8804347826087, 0.13888888888889
69707, 1.3086956521739, 0.8804347826087, 0.11111111111111
69708, 1.3304347826087, 0.90652173913044, 0.11111111111111
69709, 1.3304347826087, 0.8804347826087, 0.083333333333333
69710, 1.3086956521739, 0.8804347826087, 0.055555555555556
69711, 1.3304347826087, 0.90652173913044, 0.055555555555556
69712, 1.3304347826087, 0.8804347826087, 0.027777777777778
69713, 1.3739130434783, 0.8804347826087, 0.47222222222222
69714, 1.3521739130435, 0.8804347826087, 0.44444444444444
69715, 1.3739130434783, 0.90652173913044, 0.44444444444444
69716, 1.3739130434783, 0.8804347826087, 0.41666666666667
69717, 1.3521739130435, 0.8804347826087, 0.38888888888889
69718, 1.3739130434783, 0.90652173913044, 0.38888888888889
69719, 1.3739130434783, 0.8804347826087, 0.36111111111111
69720, 1.3521739130435, 0.8804347826087, 0.33333333333333
69721, 1.3739130434783, 0.90652173913044, 0.33333333333333
69722, 1.3739130434783, 0.8804347826087, 0.30555555555556
69723, 1.3521739130435, 0.8804347826087, 0.27777777777778
69724, 1.3739130434783, 0.90652173913044, 0.27777777777778
69725, 1.3739130434783, 0.8804347826087, 0.25
69726, 1.3521739130435, 0.8804347826087, 0.22222222222222
69727, 1.3739130434783, 0.90652173913044, 0.22222222222222
69728, 1.3739130434783, 0.8804347826087, 0.19444444444444
69729, 1.3521739130435, 0.8804347826087, 0.16666666666667
69730, 1.3739130434783, 0.90652173913044, 0.16666666666667
69731, 1.3739130434783, 0.8804347826087, 0.13888888888889
69732, 1.3521739130435, 0.8804347826087, 0.11111111111111
69733, 1.3739130434783, 0.90652173913044, 0.11111111111111
69734, 1.3739130434783, 0.8804347826087, 0.083333333333333
69735, 1.3521739130435, 0.8804347826087, 0.055555555555556
69736, 1.3739130434783, 0.90652173913044, 0.055555555555556
69737, 1.3739130434783, 0.8804347826087, 0.027777777777778
69738, 1.4173913043478, 0.8804347826087, 0.47222222222222
69739, 1.395652173913, 0.8804347826087, 0.44444444444444
69740, 1.4173913043478, 0.90652173913044, 0.44444444444444
69741, 1.4173913043478, 0.8804347826087, 0.41666666666667
69742, 1.395652173913, 0.8804347826087, 0.38888888888889
69743, 1.4173913043478, 0.90652173913044, 0.38888888888889
69744, 1.4173913043478, 0.8804347826087, 0.36111111111111
69745, 1.395652173913, 0.8804347826087, 0.33333333333333
69746, 1.4173913043478, 0.90652173913044, 0.33333333333333
69747, 1.4173913043478, 0.8804347826087, 0.30555555555556
69748, 1.395652173913, 0.8804347826087, 0.27777777777778
69749, 1.4173913043478, 0.90652173913044, 0.27777777777778
69750, 1.4173913043478, 0.8804347826087, 0.25
69751, 1.395652173913, 0.8804347826087, 0.22222222222222
69752, 1.4173913043478, 0.90652173913044, 0.22222222222222
69753, 1.4173913043478, 0.8804347826087, 0.19444444444444
69754, 1.395652173913, 0.8804347826087, 0.16666666666667
69755, 1.4173913043478, 0.90652173913044, 0.16666666666667
69756, 1.4173913043478, 0.8804347826087, 0.13888888888889
69757, 1.395652173913, 0.8804347826087, 0.11111111111111
69758, 1.4173913043478, 0.90652173913044, 0.11111111111111
69759, 1.4173913043478, 0.8804347826087, 0.083333333333333
69760, 1.395652173913, 0.8804347826087, 0.055555555555556
69761, 1.4173913043478, 0.90652173913044, 0.055555555555556
69762, 1.4173913043478, 0.8804347826087, 0.027777777777778
69763, 1.4608695652174, 0.8804347826087, 0.47222222222222
69764, 1.4391304347826, 0.8804347826087, 0.44444444444444
69765, 1.4608695652174, 0.90652173913044, 0.44444444444444
69766, 1.4608695652174, 0.8804347826087, 0.41666666666667
69767, 1.4391304347826, 0.8804347826087, 0.38888888888889
69768, 1.4608695652174, 0.90652173913044, 0.38888888888889
69769, 1.4608695652174, 0.8804347826087, 0.36111111111111
69770, 1.4391304347826, 0.8804347826087, 0.33333333333333
69771, 1.4608695652174, 0.90652173913044, 0.33333333333333
69772, 1.4608695652174, 0.8804347826087, 0.30555555555556
69773, 1.4391304347826, 0.8804347826087, 0.27777777777778
69774, 1.4608695652174, 0.90652173913044, 0.27777777777778
69775, 1.4608695652174, 0.8804347826087, 0.25
69776, 1.4391304347826, 0.8804347826087, 0.22222222222222
69777, 1.4608695652174, 0.90652173913044, 0.22222222222222
69778, 1.4608695652174, 0.8804347826087, 0.19444444444444
69779, 1.4391304347826, 0.8804347826087, 0.16666666666667
69780, 1.4608695652174, 0.90652173913044, 0.16666666666667
69781, 1.4608695652174, 0.8804347826087, 0.13888888888889
69782, 1.4391304347826, 0.8804347826087, 0.11111111111111
69783, 1.4608695652174, 0.90652173913044, 0.11111111111111
69784, 1.4608695652174, 0.8804347826087, 0.083333333333333
69785, 1.4391304347826, 0.8804347826087, 0.055555555555556
69786, 1.4608695652174, 0.90652173913044, 0.055555555555556
69787, 1.4608695652174, 0.8804347826087, 0.027777777777778
69788, 1.504347826087, 0.8804347826087, 0.47222222222222
69789, 1.4826086956522, 0.8804347826087, 0.44444444444444
69790, 1.504347826087, 0.90652173913044, 0.44444444444444
69791, 1.504347826087, 0.8804347826087, 0.41666666666667
69792, 1.4826086956522, 0.8804347826087, 0.38888888888889
69793, 1.504347826087, 0.90652173913044, 0.38888888888889
69794, 1.504347826087, 0.8804347826087, 0.36111111111111
69795, 1.4826086956522, 0.8804347826087, 0.33333333333333
69796, 1.504347826087, 0.90652173913044, 0.33333333333333
69797, 1.504347826087, 0.8804347826087, 0.30555555555556
69798, 1.4826086956522, 0.8804347826087, 0.27777777777778
69799, 1.504347826087, 0.90652173913044, 0.27777777777778
69800, 1.504347826087, 0.8804347826087, 0.25
69801, 1.4826086956522, 0.8804347826087, 0.22222222222222
69802, 1.504347826087, 0.90652173913044, 0.22222222222222
69803, 1.504347826087, 0.8804347826087, 0.19444444444444
69804, 1.4826086956522, 0.8804347826087, 0.16666666666667
69805, 1.504347826087, 0.90652173913044, 0.16666666666667
69806, 1.504347826087, 0.8804347826087, 0.13888888888889
69807, 1.4826086956522, 0.8804347826087, 0.11111111111111
69808, 1.504347826087, 0.90652173913044, 0.11111111111111
69809, 1.504347826087, 0.8804347826087, 0.083333333333333
69810, 1.4826086956522, 0.8804347826087, 0.055555555555556
69811, 1.504347826087, 0.90652173913044, 0.055555555555556
69812, 1.504347826087, 0.8804347826087, 0.027777777777778
69813, 1.5478260869565, 0.8804347826087, 0.47222222222222
69814, 1.5260869565217, 0.8804347826087, 0.44444444444444
69815, 1.5478260869565, 0.90652173913044, 0.44444444444444
69816, 1.5478260869565, 0.8804347826087, 0.41666666666667
69817, 1.5260869565217, 0.8804347826087, 0.38888888888889
69818, 1.5478260869565, 0.90652173913044, 0.38888888888889
69819, 1.5478260869565, 0.8804347826087, 0.36111111111111
69820, 1.5260869565217, 0.8804347826087, 0.33333333333333
69821, 1.5478260869565, 0.90652173913044, 0.33333333333333
69822, 1.5478260869565, 0.8804347826087, 0.30555555555556
69823, 1.5260869565217, 0.8804347826087, 0.27777777777778
69824, 1.5478260869565, 0.90652173913044, 0.27777777777778
69825, 1.5478260869565, 0.8804347826087, 0.25
69826, 1.5260869565217, 0.8804347826087, 0.22222222222222
69827, 1.5478260869565, 0.90652173913044, 0.22222222222222
69828, 1.5478260869565, 0.8804347826087, 0.19444444444444
69829, 1.5260869565217, 0.8804347826087, 0.16666666666667
69830, 1.5478260869565, 0.90652173913044, 0.16666666666667
69831, 1.5478260869565, 0.8804347826087, 0.13888888888889
69832, 1.5260869565217, 0.8804347826087, 0.11111111111111
69833, 1.5478260869565, 0.90652173913044, 0.11111111111111
69834, 1.5478260869565, 0.8804347826087, 0.083333333333333
69835, 1.5260869565217, 0.8804347826087, 0.055555555555556
69836, 1.5478260869565, 0.90652173913044, 0.055555555555556
69837, 1.5478260869565, 0.8804347826087, 0.027777777777778
69838, 1.5913043478261, 0.8804347826087, 0.47222222222222
69839, 1.5695652173913, 0.8804347826087, 0.44444444444444
69840, 1.5913043478261, 0.90652173913044, 0.44444444444444
69841, 1.5913043478261, 0.8804347826087, 0.41666666666667
69842, 1.5695652173913, 0.8804347826087, 0.38888888888889
69843, 1.5913043478261, 0.90652173913044, 0.38888888888889
69844, 1.5913043478261, 0.8804347826087, 0.36111111111111
69845, 1.5695652173913, 0.8804347826087, 0.33333333333333
69846, 1.5913043478261, 0.90652173913044, 0.33333333333333
69847, 1.5913043478261, 0.8804347826087, 0.30555555555556
69848, 1.5695652173913, 0.8804347826087, 0.27777777777778
69849, 1.5913043478261, 0.90652173913044, 0.27777777777778
69850, 1.5913043478261, 0.8804347826087, 0.25
69851, 1.5695652173913, 0.8804347826087, 0.22222222222222
69852, 1.5913043478261, 0.90652173913044, 0.22222222222222
69853, 1.5913043478261, 0.8804347826087, 0.19444444444444
69854, 1.5695652173913, 0.8804347826087, 0.16666666666667
69855, 1.5913043478261, 0.90652173913044, 0.16666666666667
69856, 1.5913043478261, 0.8804347826087, 0.13888888888889
69857, 1.5695652173913, 0.8804347826087, 0.11111111111111
69858, 1.5913043478261, 0.90652173913044, 0.11111111111111
69859, 1.5913043478261, 0.8804347826087, 0.083333333333333
69860, 1.5695652173913, 0.8804347826087, 0.055555555555556
69861, 1.5913043478261, 0.90652173913044, 0.055555555555556
69862, 1.5913043478261, 0.8804347826087, 0.027777777777778
69863, 1.6347826086957, 0.8804347826087, 0.47222222222222
69864, 1.6130434782609, 0.8804347826087, 0.44444444444444
69865, 1.6347826086957, 0.90652173913044, 0.44444444444444
69866, 1.6347826086957, 0.8804347826087, 0.41666666666667
69867, 1.6130434782609, 0.8804347826087, 0.38888888888889
69868, 1.6347826086957, 0.90652173913044, 0.38888888888889
69869, 1.6347826086957, 0.8804347826087, 0.36111111111111
69870, 1.6130434782609, 0.8804347826087, 0.33333333333333
69871, 1.6347826086957, 0.90652173913044, 0.33333333333333
69872, 1.6347826086957, 0.8804347826087, 0.30555555555556
69873, 1.6130434782609, 0.8804347826087, 0.27777777777778
69874, 1.6347826086957, 0.90652173913044, 0.27777777777778
69875, 1.6347826086957, 0.8804347826087, 0.25
69876, 1.6130434782609, 0.8804347826087, 0.22222222222222
69877, 1.6347826086957, 0.90652173913044, 0.22222222222222
69878, 1.6347826086957, 0.8804347826087, 0.19444444444444
69879, 1.6130434782609, 0.8804347826087, 0.16666666666667
69880, 1.6347826086957, 0.90652173913044, 0.16666666666667
69881, 1.6347826086957, 0.8804347826087, 0.13888888888889
69882, 1.6130434782609, 0.8804347826087, 0.11111111111111
69883, 1.6347826086957, 0.90652173913044, 0.11111111111111
69884, 1.6347826086957, 0.8804347826087, 0.083333333333333
69885, 1.6130434782609, 0.8804347826087, 0.055555555555556
69886, 1.6347826086957, 0.90652173913044, 0.055555555555556
69887, 1.6347826086957, 0.8804347826087, 0.027777777777778
69888, 1.6782608695652, 0.8804347826087, 0.47222222222222
69889, 1.6565217391304, 0.8804347826087, 0.44444444444444
69890, 1.6782608695652, 0.90652173913044, 0.44444444444444
69891, 1.6782608695652, 0.8804347826087, 0.41666666666667
69892, 1.6565217391304, 0.8804347826087, 0.38888888888889
69893, 1.6782608695652, 0.90652173913044, 0.38888888888889
69894, 1.6782608695652, 0.8804347826087, 0.36111111111111
69895, 1.6565217391304, 0.8804347826087, 0.33333333333333
69896, 1.6782608695652, 0.90652173913044, 0.33333333333333
69897, 1.6782608695652, 0.8804347826087, 0.30555555555556
69898, 1.6565217391304, 0.8804347826087, 0.27777777777778
69899, 1.6782608695652, 0.90652173913044, 0.27777777777778
69900, 1.6782608695652, 0.8804347826087, 0.25
69901, 1.6565217391304, 0.8804347826087, 0.22222222222222
69902, 1.6782608695652, 0.90652173913044, 0.22222222222222
69903, 1.6782608695652, 0.8804347826087, 0.19444444444444
69904, 1.6565217391304, 0.8804347826087, 0.16666666666667
69905, 1.6782608695652, 0.90652173913044, 0.16666666666667
69906, 1.6782608695652, 0.8804347826087, 0.13888888888889
69907, 1.6565217391304, 0.8804347826087, 0.11111111111111
69908, 1.6782608695652, 0.90652173913044, 0.11111111111111
69909, 1.6782608695652, 0.8804347826087, 0.083333333333333
69910, 1.6565217391304, 0.8804347826087, 0.055555555555556
69911, 1.6782608695652, 0.90652173913044, 0.055555555555556
69912, 1.6782608695652, 0.8804347826087, 0.027777777777778
69913, 1.7217391304348, 0.8804347826087, 0.47222222222222
69914, 1.7, 0.8804347826087, 0.44444444444444
69915, 1.7217391304348, 0.90652173913044, 0.44444444444444
69916, 1.7217391304348, 0.8804347826087, 0.41666666666667
69917, 1.7, 0.8804347826087, 0.38888888888889
69918, 1.7217391304348, 0.90652173913044, 0.38888888888889
69919, 1.7217391304348, 0.8804347826087, 0.36111111111111
69920, 1.7, 0.8804347826087, 0.33333333333333
69921, 1.7217391304348, 0.90652173913044, 0.33333333333333
69922, 1.7217391304348, 0.8804347826087, 0.30555555555556
69923, 1.7, 0.8804347826087, 0.27777777777778
69924, 1.7217391304348, 0.90652173913044, 0.27777777777778
69925, 1.7217391304348, 0.8804347826087, 0.25
69926, 1.7, 0.8804347826087, 0.22222222222222
69927, 1.7217391304348, 0.90652173913044, 0.22222222222222
69928, 1.7217391304348, 0.8804347826087, 0.19444444444444
69929, 1.7, 0.8804347826087, 0.16666666666667
69930, 1.7217391304348, 0.90652173913044, 0.16666666666667
69931, 1.7217391304348, 0.8804347826087, 0.13888888888889
69932, 1.7, 0.8804347826087, 0.11111111111111
69933, 1.7217391304348, 0.90652173913044, 0.11111111111111
69934, 1.7217391304348, 0.8804347826087, 0.083333333333333
69935, 1.7, 0.8804347826087, 0.055555555555556
69936, 1.7217391304348, 0.90652173913044, 0.055555555555556
69937, 1.7217391304348, 0.8804347826087, 0.027777777777778
69938, 1.7652173913043, 0.8804347826087, 0.47222222222222
69939, 1.7434782608696, 0.8804347826087, 0.44444444444444
69940, 1.7652173913043, 0.90652173913044, 0.44444444444444
69941, 1.7652173913043, 0.8804347826087, 0.41666666666667
69942, 1.7434782608696, 0.8804347826087, 0.38888888888889
69943, 1.7652173913043, 0.90652173913044, 0.38888888888889
69944, 1.7652173913043, 0.8804347826087, 0.36111111111111
69945, 1.7434782608696, 0.8804347826087, 0.33333333333333
69946, 1.7652173913043, 0.90652173913044, 0.33333333333333
69947, 1.7652173913043, 0.8804347826087, 0.30555555555556
69948, 1.7434782608696, 0.8804347826087, 0.27777777777778
69949, 1.7652173913043, 0.90652173913044, 0.27777777777778
69950, 1.7652173913043, 0.8804347826087, 0.25
69951, 1.7434782608696, 0.8804347826087, 0.22222222222222
69952, 1.7652173913043, 0.90652173913044, 0.22222222222222
69953, 1.7652173913043, 0.8804347826087, 0.19444444444444
69954, 1.7434782608696, 0.8804347826087, 0.16666666666667
69955, 1.7652173913043, 0.90652173913044, 0.16666666666667
69956, 1.7652173913043, 0.8804347826087, 0.13888888888889
69957, 1.7434782608696, 0.8804347826087, 0.11111111111111
69958, 1.7652173913043, 0.90652173913044, 0.11111111111111
69959, 1.7652173913043, 0.8804347826087, 0.083333333333333
69960, 1.7434782608696, 0.8804347826087, 0.055555555555556
69961, 1.7652173913043, 0.90652173913044, 0.055555555555556
69962, 1.7652173913043, 0.8804347826087, 0.027777777777778
69963, 1.8086956521739, 0.8804347826087, 0.47222222222222
69964, 1.7869565217391, 0.8804347826087, 0.44444444444444
69965, 1.8086956521739, 0.90652173913044, 0.44444444444444
69966, 1.8086956521739, 0.8804347826087, 0.41666666666667
69967, 1.7869565217391, 0.8804347826087, 0.38888888888889
69968, 1.8086956521739, 0.90652173913044, 0.38888888888889
69969, 1.8086956521739, 0.8804347826087, 0.36111111111111
69970, 1.7869565217391, 0.8804347826087, 0.33333333333333
69971, 1.8086956521739, 0.90652173913044, 0.33333333333333
69972, 1.8086956521739, 0.8804347826087, 0.30555555555556
69973, 1.7869565217391, 0.8804347826087, 0.27777777777778
69974, 1.8086956521739, 0.90652173913044, 0.27777777777778
69975, 1.8086956521739, 0.8804347826087, 0.25
69976, 1.7869565217391, 0.8804347826087, 0.22222222222222
69977, 1.8086956521739, 0.90652173913044, 0.22222222222222
69978, 1.8086956521739, 0.8804347826087, 0.19444444444444
69979, 1.7869565217391, 0.8804347826087, 0.16666666666667
69980, 1.8086956521739, 0.90652173913044, 0.16666666666667
69981, 1.8086956521739, 0.8804347826087, 0.13888888888889
69982, 1.7869565217391, 0.8804347826087, 0.11111111111111
69983, 1.8086956521739, 0.90652173913044, 0.11111111111111
69984, 1.8086956521739, 0.8804347826087, 0.083333333333333
69985, 1.7869565217391, 0.8804347826087, 0.055555555555556
69986, 1.8086956521739, 0.90652173913044, 0.055555555555556
69987, 1.8086956521739, 0.8804347826087, 0.027777777777778
69988, 1.8521739130435, 0.8804347826087, 0.47222222222222
69989, 1.8304347826087, 0.8804347826087, 0.44444444444444
69990, 1.8521739130435, 0.90652173913044, 0.44444444444444
69991, 1.8521739130435, 0.8804347826087, 0.41666666666667
69992, 1.8304347826087, 0.8804347826087, 0.38888888888889
69993, 1.8521739130435, 0.90652173913044, 0.38888888888889
69994, 1.8521739130435, 0.8804347826087, 0.36111111111111
69995, 1.8304347826087, 0.8804347826087, 0.33333333333333
69996, 1.8521739130435, 0.90652173913044, 0.33333333333333
69997, 1.8521739130435, 0.8804347826087, 0.30555555555556
69998, 1.8304347826087, 0.8804347826087, 0.27777777777778
69999, 1.8521739130435, 0.90652173913044, 0.27777777777778
70000, 1.8521739130435, 0.8804347826087, 0.25
70001, 1.8304347826087, 0.8804347826087, 0.22222222222222
70002, 1.8521739130435, 0.90652173913044, 0.22222222222222
70003, 1.8521739130435, 0.8804347826087, 0.19444444444444
70004, 1.8304347826087, 0.8804347826087, 0.16666666666667
70005, 1.8521739130435, 0.90652173913044, 0.16666666666667
70006, 1.8521739130435, 0.8804347826087, 0.13888888888889
70007, 1.8304347826087, 0.8804347826087, 0.11111111111111
70008, 1.8521739130435, 0.90652173913044, 0.11111111111111
70009, 1.8521739130435, 0.8804347826087, 0.083333333333333
70010, 1.8304347826087, 0.8804347826087, 0.055555555555556
70011, 1.8521739130435, 0.90652173913044, 0.055555555555556
70012, 1.8521739130435, 0.8804347826087, 0.027777777777778
70013, 1.895652173913, 0.8804347826087, 0.47222222222222
70014, 1.8739130434783, 0.8804347826087, 0.44444444444444
70015, 1.895652173913, 0.90652173913044, 0.44444444444444
70016, 1.895652173913, 0.8804347826087, 0.41666666666667
70017, 1.8739130434783, 0.8804347826087, 0.38888888888889
70018, 1.895652173913, 0.90652173913044, 0.38888888888889
70019, 1.895652173913, 0.8804347826087, 0.36111111111111
70020, 1.8739130434783, 0.8804347826087, 0.33333333333333
70021, 1.895652173913, 0.90652173913044, 0.33333333333333
70022, 1.895652173913, 0.8804347826087, 0.30555555555556
70023, 1.8739130434783, 0.8804347826087, 0.27777777777778
70024, 1.895652173913, 0.90652173913044, 0.27777777777778
70025, 1.895652173913, 0.8804347826087, 0.25
70026, 1.8739130434783, 0.8804347826087, 0.22222222222222
70027, 1.895652173913, 0.90652173913044, 0.22222222222222
70028, 1.895652173913, 0.8804347826087, 0.19444444444444
70029, 1.8739130434783, 0.8804347826087, 0.16666666666667
70030, 1.895652173913, 0.90652173913044, 0.16666666666667
70031, 1.895652173913, 0.8804347826087, 0.13888888888889
70032, 1.8739130434783, 0.8804347826087, 0.11111111111111
70033, 1.895652173913, 0.90652173913044, 0.11111111111111
70034, 1.895652173913, 0.8804347826087, 0.083333333333333
70035, 1.8739130434783, 0.8804347826087, 0.055555555555556
70036, 1.895652173913, 0.90652173913044, 0.055555555555556
70037, 1.895652173913, 0.8804347826087, 0.027777777777778
70038, 1.9391304347826, 0.8804347826087, 0.47222222222222
70039, 1.9173913043478, 0.8804347826087, 0.44444444444444
70040, 1.9391304347826, 0.90652173913044, 0.44444444444444
70041, 1.9391304347826, 0.8804347826087, 0.41666666666667
70042, 1.9173913043478, 0.8804347826087, 0.38888888888889
70043, 1.9391304347826, 0.90652173913044, 0.38888888888889
70044, 1.9391304347826, 0.8804347826087, 0.36111111111111
70045, 1.9173913043478, 0.8804347826087, 0.33333333333333
70046, 1.9391304347826, 0.90652173913044, 0.33333333333333
70047, 1.9391304347826, 0.8804347826087, 0.30555555555556
70048, 1.9173913043478, 0.8804347826087, 0.27777777777778
70049, 1.9391304347826, 0.90652173913044, 0.27777777777778
70050, 1.9391304347826, 0.8804347826087, 0.25
70051, 1.9173913043478, 0.8804347826087, 0.22222222222222
70052, 1.9391304347826, 0.90652173913044, 0.22222222222222
70053, 1.9391304347826, 0.8804347826087, 0.19444444444444
70054, 1.9173913043478, 0.8804347826087, 0.16666666666667
70055, 1.9391304347826, 0.90652173913044, 0.16666666666667
70056, 1.9391304347826, 0.8804347826087, 0.13888888888889
70057, 1.9173913043478, 0.8804347826087, 0.11111111111111
70058, 1.9391304347826, 0.90652173913044, 0.11111111111111
70059, 1.9391304347826, 0.8804347826087, 0.083333333333333
70060, 1.9173913043478, 0.8804347826087, 0.055555555555556
70061, 1.9391304347826, 0.90652173913044, 0.055555555555556
70062, 1.9391304347826, 0.8804347826087, 0.027777777777778
70063, 1.9826086956522, 0.8804347826087, 0.47222222222222
70064, 1.9608695652174, 0.8804347826087, 0.44444444444444
70065, 1.9826086956522, 0.90652173913044, 0.44444444444444
70066, 1.9826086956522, 0.8804347826087, 0.41666666666667
70067, 1.9608695652174, 0.8804347826087, 0.38888888888889
70068, 1.9826086956522, 0.90652173913044, 0.38888888888889
70069, 1.9826086956522, 0.8804347826087, 0.36111111111111
70070, 1.9608695652174, 0.8804347826087, 0.33333333333333
70071, 1.9826086956522, 0.90652173913044, 0.33333333333333
70072, 1.9826086956522, 0.8804347826087, 0.30555555555556
70073, 1.9608695652174, 0.8804347826087, 0.27777777777778
70074, 1.9826086956522, 0.90652173913044, 0.27777777777778
70075, 1.9826086956522, 0.8804347826087, 0.25
70076, 1.9608695652174, 0.8804347826087, 0.22222222222222
70077, 1.9826086956522, 0.90652173913044, 0.22222222222222
70078, 1.9826086956522, 0.8804347826087, 0.19444444444444
70079, 1.9608695652174, 0.8804347826087, 0.16666666666667
70080, 1.9826086956522, 0.90652173913044, 0.16666666666667
70081, 1.9826086956522, 0.8804347826087, 0.13888888888889
70082, 1.9608695652174, 0.8804347826087, 0.11111111111111
70083, 1.9826086956522, 0.90652173913044, 0.11111111111111
70084, 1.9826086956522, 0.8804347826087, 0.083333333333333
70085, 1.9608695652174, 0.8804347826087, 0.055555555555556
70086, 1.9826086956522, 0.90652173913044, 0.055555555555556
70087, 1.9826086956522, 0.8804347826087, 0.027777777777778
70088, 2.0260869565217, 0.8804347826087, 0.47222222222222
70089, 2.004347826087, 0.8804347826087, 0.44444444444444
70090, 2.0260869565217, 0.90652173913044, 0.44444444444444
70091, 2.0260869565217, 0.8804347826087, 0.41666666666667
70092, 2.004347826087, 0.8804347826087, 0.38888888888889
70093, 2.0260869565217, 0.90652173913044, 0.38888888888889
70094, 2.0260869565217, 0.8804347826087, 0.36111111111111
70095, 2.004347826087, 0.8804347826087, 0.33333333333333
70096, 2.0260869565217, 0.90652173913044, 0.33333333333333
70097, 2.0260869565217, 0.8804347826087, 0.30555555555556
70098, 2.004347826087, 0.8804347826087, 0.27777777777778
70099, 2.0260869565217, 0.90652173913044, 0.27777777777778
70100, 2.0260869565217, 0.8804347826087, 0.25
70101, 2.004347826087, 0.8804347826087, 0.22222222222222
70102, 2.0260869565217, 0.90652173913044, 0.22222222222222
70103, 2.0260869565217, 0.8804347826087, 0.19444444444444
70104, 2.004347826087, 0.8804347826087, 0.16666666666667
70105, 2.0260869565217, 0.90652173913044, 0.16666666666667
70106, 2.0260869565217, 0.8804347826087, 0.13888888888889
70107, 2.004347826087, 0.8804347826087, 0.11111111111111
70108, 2.0260869565217, 0.90652173913044, 0.11111111111111
70109, 2.0260869565217, 0.8804347826087, 0.083333333333333
70110, 2.004347826087, 0.8804347826087, 0.055555555555556
70111, 2.0260869565217, 0.90652173913044, 0.055555555555556
70112, 2.0260869565217, 0.8804347826087, 0.027777777777778
70113, 2.0695652173913, 0.8804347826087, 0.47222222222222
70114, 2.0478260869565, 0.8804347826087, 0.44444444444444
70115, 2.0695652173913, 0.90652173913044, 0.44444444444444
70116, 2.0695652173913, 0.8804347826087, 0.41666666666667
70117, 2.0478260869565, 0.8804347826087, 0.38888888888889
70118, 2.0695652173913, 0.90652173913044, 0.38888888888889
70119, 2.0695652173913, 0.8804347826087, 0.36111111111111
70120, 2.0478260869565, 0.8804347826087, 0.33333333333333
70121, 2.0695652173913, 0.90652173913044, 0.33333333333333
70122, 2.0695652173913, 0.8804347826087, 0.30555555555556
70123, 2.0478260869565, 0.8804347826087, 0.27777777777778
70124, 2.0695652173913, 0.90652173913044, 0.27777777777778
70125, 2.0695652173913, 0.8804347826087, 0.25
70126, 2.0478260869565, 0.8804347826087, 0.22222222222222
70127, 2.0695652173913, 0.90652173913044, 0.22222222222222
70128, 2.0695652173913, 0.8804347826087, 0.19444444444444
70129, 2.0478260869565, 0.8804347826087, 0.16666666666667
70130, 2.0695652173913, 0.90652173913044, 0.16666666666667
70131, 2.0695652173913, 0.8804347826087, 0.13888888888889
70132, 2.0478260869565, 0.8804347826087, 0.11111111111111
70133, 2.0695652173913, 0.90652173913044, 0.11111111111111
70134, 2.0695652173913, 0.8804347826087, 0.083333333333333
70135, 2.0478260869565, 0.8804347826087, 0.055555555555556
70136, 2.0695652173913, 0.90652173913044, 0.055555555555556
70137, 2.0695652173913, 0.8804347826087, 0.027777777777778
70138, 2.1130434782609, 0.8804347826087, 0.47222222222222
70139, 2.0913043478261, 0.8804347826087, 0.44444444444444
70140, 2.1130434782609, 0.90652173913044, 0.44444444444444
70141, 2.1130434782609, 0.8804347826087, 0.41666666666667
70142, 2.0913043478261, 0.8804347826087, 0.38888888888889
70143, 2.1130434782609, 0.90652173913044, 0.38888888888889
70144, 2.1130434782609, 0.8804347826087, 0.36111111111111
70145, 2.0913043478261, 0.8804347826087, 0.33333333333333
70146, 2.1130434782609, 0.90652173913044, 0.33333333333333
70147, 2.1130434782609, 0.8804347826087, 0.30555555555556
70148, 2.0913043478261, 0.8804347826087, 0.27777777777778
70149, 2.1130434782609, 0.90652173913044, 0.27777777777778
70150, 2.1130434782609, 0.8804347826087, 0.25
70151, 2.0913043478261, 0.8804347826087, 0.22222222222222
70152, 2.1130434782609, 0.90652173913044, 0.22222222222222
70153, 2.1130434782609, 0.8804347826087, 0.19444444444444
70154, 2.0913043478261, 0.8804347826087, 0.16666666666667
70155, 2.1130434782609, 0.90652173913044, 0.16666666666667
70156, 2.1130434782609, 0.8804347826087, 0.13888888888889
70157, 2.0913043478261, 0.8804347826087, 0.11111111111111
70158, 2.1130434782609, 0.90652173913044, 0.11111111111111
70159, 2.1130434782609, 0.8804347826087, 0.083333333333333
70160, 2.0913043478261, 0.8804347826087, 0.055555555555556
70161, 2.1130434782609, 0.90652173913044, 0.055555555555556
70162, 2.1130434782609, 0.8804347826087, 0.027777777777778
70163, 2.1565217391304, 0.8804347826087, 0.47222222222222
70164, 2.1347826086957, 0.8804347826087, 0.44444444444444
70165, 2.1565217391304, 0.90652173913044, 0.44444444444444
70166, 2.1565217391304, 0.8804347826087, 0.41666666666667
70167, 2.1347826086957, 0.8804347826087, 0.38888888888889
70168, 2.1565217391304, 0.90652173913044, 0.38888888888889
70169, 2.1565217391304, 0.8804347826087, 0.36111111111111
70170, 2.1347826086957, 0.8804347826087, 0.33333333333333
70171, 2.1565217391304, 0.90652173913044, 0.33333333333333
70172, 2.1565217391304, 0.8804347826087, 0.30555555555556
70173, 2.1347826086957, 0.8804347826087, 0.27777777777778
70174, 2.1565217391304, 0.90652173913044, 0.27777777777778
70175, 2.1565217391304, 0.8804347826087, 0.25
70176, 2.1347826086957, 0.8804347826087, 0.22222222222222
70177, 2.1565217391304, 0.90652173913044, 0.22222222222222
70178, 2.1565217391304, 0.8804347826087, 0.19444444444444
70179, 2.1347826086957, 0.8804347826087, 0.16666666666667
70180, 2.1565217391304, 0.90652173913044, 0.16666666666667
70181, 2.1565217391304, 0.8804347826087, 0.13888888888889
70182, 2.1347826086957, 0.8804347826087, 0.11111111111111
70183, 2.1565217391304, 0.90652173913044, 0.11111111111111
70184, 2.1565217391304, 0.8804347826087, 0.083333333333333
70185, 2.1347826086957, 0.8804347826087, 0.055555555555556
70186, 2.1565217391304, 0.90652173913044, 0.055555555555556
70187, 2.1565217391304, 0.8804347826087, 0.027777777777778
70188, 2.1782608695652, 0.8804347826087, 0.44444444444444
70189, 2.1782608695652, 0.8804347826087, 0.38888888888889
70190, 2.1782608695652, 0.8804347826087, 0.33333333333333
70191, 2.1782608695652, 0.8804347826087, 0.27777777777778
70192, 2.1782608695652, 0.8804347826087, 0.22222222222222
70193, 2.1782608695652, 0.8804347826087, 0.16666666666667
70194, 2.1782608695652, 0.8804347826087, 0.11111111111111
70195, 2.1782608695652, 0.8804347826087, 0.055555555555556
70196, 1.2434782608696, 0.82826086956522, 0.47222222222222
70197, 1.2217391304348, 0.82826086956522, 0.44444444444444
70198, 1.2434782608696, 0.85434782608696, 0.44444444444444
70199, 1.2434782608696, 0.82826086956522, 0.41666666666667
70200, 1.2217391304348, 0.82826086956522, 0.38888888888889
70201, 1.2434782608696, 0.85434782608696, 0.38888888888889
70202, 1.2434782608696, 0.82826086956522, 0.36111111111111
70203, 1.2217391304348, 0.82826086956522, 0.33333333333333
70204, 1.2434782608696, 0.85434782608696, 0.33333333333333
70205, 1.2434782608696, 0.82826086956522, 0.30555555555556
70206, 1.2217391304348, 0.82826086956522, 0.27777777777778
70207, 1.2434782608696, 0.85434782608696, 0.27777777777778
70208, 1.2434782608696, 0.82826086956522, 0.25
70209, 1.2217391304348, 0.82826086956522, 0.22222222222222
70210, 1.2434782608696, 0.85434782608696, 0.22222222222222
70211, 1.2434782608696, 0.82826086956522, 0.19444444444444
70212, 1.2217391304348, 0.82826086956522, 0.16666666666667
70213, 1.2434782608696, 0.85434782608696, 0.16666666666667
70214, 1.2434782608696, 0.82826086956522, 0.13888888888889
70215, 1.2217391304348, 0.82826086956522, 0.11111111111111
70216, 1.2434782608696, 0.85434782608696, 0.11111111111111
70217, 1.2434782608696, 0.82826086956522, 0.083333333333333
70218, 1.2217391304348, 0.82826086956522, 0.055555555555556
70219, 1.2434782608696, 0.85434782608696, 0.055555555555556
70220, 1.2434782608696, 0.82826086956522, 0.027777777777778
70221, 1.2869565217391, 0.82826086956522, 0.47222222222222
70222, 1.2652173913043, 0.82826086956522, 0.44444444444444
70223, 1.2869565217391, 0.85434782608696, 0.44444444444444
70224, 1.2869565217391, 0.82826086956522, 0.41666666666667
70225, 1.2652173913043, 0.82826086956522, 0.38888888888889
70226, 1.2869565217391, 0.85434782608696, 0.38888888888889
70227, 1.2869565217391, 0.82826086956522, 0.36111111111111
70228, 1.2652173913043, 0.82826086956522, 0.33333333333333
70229, 1.2869565217391, 0.85434782608696, 0.33333333333333
70230, 1.2869565217391, 0.82826086956522, 0.30555555555556
70231, 1.2652173913043, 0.82826086956522, 0.27777777777778
70232, 1.2869565217391, 0.85434782608696, 0.27777777777778
70233, 1.2869565217391, 0.82826086956522, 0.25
70234, 1.2652173913043, 0.82826086956522, 0.22222222222222
70235, 1.2869565217391, 0.85434782608696, 0.22222222222222
70236, 1.2869565217391, 0.82826086956522, 0.19444444444444
70237, 1.2652173913043, 0.82826086956522, 0.16666666666667
70238, 1.2869565217391, 0.85434782608696, 0.16666666666667
70239, 1.2869565217391, 0.82826086956522, 0.13888888888889
70240, 1.2652173913043, 0.82826086956522, 0.11111111111111
70241, 1.2869565217391, 0.85434782608696, 0.11111111111111
70242, 1.2869565217391, 0.82826086956522, 0.083333333333333
70243, 1.2652173913043, 0.82826086956522, 0.055555555555556
70244, 1.2869565217391, 0.85434782608696, 0.055555555555556
70245, 1.2869565217391, 0.82826086956522, 0.027777777777778
70246, 1.3304347826087, 0.82826086956522, 0.47222222222222
70247, 1.3086956521739, 0.82826086956522, 0.44444444444444
70248, 1.3304347826087, 0.85434782608696, 0.44444444444444
70249, 1.3304347826087, 0.82826086956522, 0.41666666666667
70250, 1.3086956521739, 0.82826086956522, 0.38888888888889
70251, 1.3304347826087, 0.85434782608696, 0.38888888888889
70252, 1.3304347826087, 0.82826086956522, 0.36111111111111
70253, 1.3086956521739, 0.82826086956522, 0.33333333333333
70254, 1.3304347826087, 0.85434782608696, 0.33333333333333
70255, 1.3304347826087, 0.82826086956522, 0.30555555555556
70256, 1.3086956521739, 0.82826086956522, 0.27777777777778
70257, 1.3304347826087, 0.85434782608696, 0.27777777777778
70258, 1.3304347826087, 0.82826086956522, 0.25
70259, 1.3086956521739, 0.82826086956522, 0.22222222222222
70260, 1.3304347826087, 0.85434782608696, 0.22222222222222
70261, 1.3304347826087, 0.82826086956522, 0.19444444444444
70262, 1.3086956521739, 0.82826086956522, 0.16666666666667
70263, 1.3304347826087, 0.85434782608696, 0.16666666666667
70264, 1.3304347826087, 0.82826086956522, 0.13888888888889
70265, 1.3086956521739, 0.82826086956522, 0.11111111111111
70266, 1.3304347826087, 0.85434782608696, 0.11111111111111
70267, 1.3304347826087, 0.82826086956522, 0.083333333333333
70268, 1.3086956521739, 0.82826086956522, 0.055555555555556
70269, 1.3304347826087, 0.85434782608696, 0.055555555555556
70270, 1.3304347826087, 0.82826086956522, 0.027777777777778
70271, 1.3739130434783, 0.82826086956522, 0.47222222222222
70272, 1.3521739130435, 0.82826086956522, 0.44444444444444
70273, 1.3739130434783, 0.85434782608696, 0.44444444444444
70274, 1.3739130434783, 0.82826086956522, 0.41666666666667
70275, 1.3521739130435, 0.82826086956522, 0.38888888888889
70276, 1.3739130434783, 0.85434782608696, 0.38888888888889
70277, 1.3739130434783, 0.82826086956522, 0.36111111111111
70278, 1.3521739130435, 0.82826086956522, 0.33333333333333
70279, 1.3739130434783, 0.85434782608696, 0.33333333333333
70280, 1.3739130434783, 0.82826086956522, 0.30555555555556
70281, 1.3521739130435, 0.82826086956522, 0.27777777777778
70282, 1.3739130434783, 0.85434782608696, 0.27777777777778
70283, 1.3739130434783, 0.82826086956522, 0.25
70284, 1.3521739130435, 0.82826086956522, 0.22222222222222
70285, 1.3739130434783, 0.85434782608696, 0.22222222222222
70286, 1.3739130434783, 0.82826086956522, 0.19444444444444
70287, 1.3521739130435, 0.82826086956522, 0.16666666666667
70288, 1.3739130434783, 0.85434782608696, 0.16666666666667
70289, 1.3739130434783, 0.82826086956522, 0.13888888888889
70290, 1.3521739130435, 0.82826086956522, 0.11111111111111
70291, 1.3739130434783, 0.85434782608696, 0.11111111111111
70292, 1.3739130434783, 0.82826086956522, 0.083333333333333
70293, 1.3521739130435, 0.82826086956522, 0.055555555555556
70294, 1.3739130434783, 0.85434782608696, 0.055555555555556
70295, 1.3739130434783, 0.82826086956522, 0.027777777777778
70296, 1.4173913043478, 0.82826086956522, 0.47222222222222
70297, 1.395652173913, 0.82826086956522, 0.44444444444444
70298, 1.4173913043478, 0.85434782608696, 0.44444444444444
70299, 1.4173913043478, 0.82826086956522, 0.41666666666667
70300, 1.395652173913, 0.82826086956522, 0.38888888888889
70301, 1.4173913043478, 0.85434782608696, 0.38888888888889
70302, 1.4173913043478, 0.82826086956522, 0.36111111111111
70303, 1.395652173913, 0.82826086956522, 0.33333333333333
70304, 1.4173913043478, 0.85434782608696, 0.33333333333333
70305, 1.4173913043478, 0.82826086956522, 0.30555555555556
70306, 1.395652173913, 0.82826086956522, 0.27777777777778
70307, 1.4173913043478, 0.85434782608696, 0.27777777777778
70308, 1.4173913043478, 0.82826086956522, 0.25
70309, 1.395652173913, 0.82826086956522, 0.22222222222222
70310, 1.4173913043478, 0.85434782608696, 0.22222222222222
70311, 1.4173913043478, 0.82826086956522, 0.19444444444444
70312, 1.395652173913, 0.82826086956522, 0.16666666666667
70313, 1.4173913043478, 0.85434782608696, 0.16666666666667
70314, 1.4173913043478, 0.82826086956522, 0.13888888888889
70315, 1.395652173913, 0.82826086956522, 0.11111111111111
70316, 1.4173913043478, 0.85434782608696, 0.11111111111111
70317, 1.4173913043478, 0.82826086956522, 0.083333333333333
70318, 1.395652173913, 0.82826086956522, 0.055555555555556
70319, 1.4173913043478, 0.85434782608696, 0.055555555555556
70320, 1.4173913043478, 0.82826086956522, 0.027777777777778
70321, 1.4608695652174, 0.82826086956522, 0.47222222222222
70322, 1.4391304347826, 0.82826086956522, 0.44444444444444
70323, 1.4608695652174, 0.85434782608696, 0.44444444444444
70324, 1.4608695652174, 0.82826086956522, 0.41666666666667
70325, 1.4391304347826, 0.82826086956522, 0.38888888888889
70326, 1.4608695652174, 0.85434782608696, 0.38888888888889
70327, 1.4608695652174, 0.82826086956522, 0.36111111111111
70328, 1.4391304347826, 0.82826086956522, 0.33333333333333
70329, 1.4608695652174, 0.85434782608696, 0.33333333333333
70330, 1.4608695652174, 0.82826086956522, 0.30555555555556
70331, 1.4391304347826, 0.82826086956522, 0.27777777777778
70332, 1.4608695652174, 0.85434782608696, 0.27777777777778
70333, 1.4608695652174, 0.82826086956522, 0.25
70334, 1.4391304347826, 0.82826086956522, 0.22222222222222
70335, 1.4608695652174, 0.85434782608696, 0.22222222222222
70336, 1.4608695652174, 0.82826086956522, 0.19444444444444
70337, 1.4391304347826, 0.82826086956522, 0.16666666666667
70338, 1.4608695652174, 0.85434782608696, 0.16666666666667
70339, 1.4608695652174, 0.82826086956522, 0.13888888888889
70340, 1.4391304347826, 0.82826086956522, 0.11111111111111
70341, 1.4608695652174, 0.85434782608696, 0.11111111111111
70342, 1.4608695652174, 0.82826086956522, 0.083333333333333
70343, 1.4391304347826, 0.82826086956522, 0.055555555555556
70344, 1.4608695652174, 0.85434782608696, 0.055555555555556
70345, 1.4608695652174, 0.82826086956522, 0.027777777777778
70346, 1.504347826087, 0.82826086956522, 0.47222222222222
70347, 1.4826086956522, 0.82826086956522, 0.44444444444444
70348, 1.504347826087, 0.85434782608696, 0.44444444444444
70349, 1.504347826087, 0.82826086956522, 0.41666666666667
70350, 1.4826086956522, 0.82826086956522, 0.38888888888889
70351, 1.504347826087, 0.85434782608696, 0.38888888888889
70352, 1.504347826087, 0.82826086956522, 0.36111111111111
70353, 1.4826086956522, 0.82826086956522, 0.33333333333333
70354, 1.504347826087, 0.85434782608696, 0.33333333333333
70355, 1.504347826087, 0.82826086956522, 0.30555555555556
70356, 1.4826086956522, 0.82826086956522, 0.27777777777778
70357, 1.504347826087, 0.85434782608696, 0.27777777777778
70358, 1.504347826087, 0.82826086956522, 0.25
70359, 1.4826086956522, 0.82826086956522, 0.22222222222222
70360, 1.504347826087, 0.85434782608696, 0.22222222222222
70361, 1.504347826087, 0.82826086956522, 0.19444444444444
70362, 1.4826086956522, 0.82826086956522, 0.16666666666667
70363, 1.504347826087, 0.85434782608696, 0.16666666666667
70364, 1.504347826087, 0.82826086956522, 0.13888888888889
70365, 1.4826086956522, 0.82826086956522, 0.11111111111111
70366, 1.504347826087, 0.85434782608696, 0.11111111111111
70367, 1.504347826087, 0.82826086956522, 0.083333333333333
70368, 1.4826086956522, 0.82826086956522, 0.055555555555556
70369, 1.504347826087, 0.85434782608696, 0.055555555555556
70370, 1.504347826087, 0.82826086956522, 0.027777777777778
70371, 1.5478260869565, 0.82826086956522, 0.47222222222222
70372, 1.5260869565217, 0.82826086956522, 0.44444444444444
70373, 1.5478260869565, 0.85434782608696, 0.44444444444444
70374, 1.5478260869565, 0.82826086956522, 0.41666666666667
70375, 1.5260869565217, 0.82826086956522, 0.38888888888889
70376, 1.5478260869565, 0.85434782608696, 0.38888888888889
70377, 1.5478260869565, 0.82826086956522, 0.36111111111111
70378, 1.5260869565217, 0.82826086956522, 0.33333333333333
70379, 1.5478260869565, 0.85434782608696, 0.33333333333333
70380, 1.5478260869565, 0.82826086956522, 0.30555555555556
70381, 1.5260869565217, 0.82826086956522, 0.27777777777778
70382, 1.5478260869565, 0.85434782608696, 0.27777777777778
70383, 1.5478260869565, 0.82826086956522, 0.25
70384, 1.5260869565217, 0.82826086956522, 0.22222222222222
70385, 1.5478260869565, 0.85434782608696, 0.22222222222222
70386, 1.5478260869565, 0.82826086956522, 0.19444444444444
70387, 1.5260869565217, 0.82826086956522, 0.16666666666667
70388, 1.5478260869565, 0.85434782608696, 0.16666666666667
70389, 1.5478260869565, 0.82826086956522, 0.13888888888889
70390, 1.5260869565217, 0.82826086956522, 0.11111111111111
70391, 1.5478260869565, 0.85434782608696, 0.11111111111111
70392, 1.5478260869565, 0.82826086956522, 0.083333333333333
70393, 1.5260869565217, 0.82826086956522, 0.055555555555556
70394, 1.5478260869565, 0.85434782608696, 0.055555555555556
70395, 1.5478260869565, 0.82826086956522, 0.027777777777778
70396, 1.5913043478261, 0.82826086956522, 0.47222222222222
70397, 1.5695652173913, 0.82826086956522, 0.44444444444444
70398, 1.5913043478261, 0.85434782608696, 0.44444444444444
70399, 1.5913043478261, 0.82826086956522, 0.41666666666667
70400, 1.5695652173913, 0.82826086956522, 0.38888888888889
70401, 1.5913043478261, 0.85434782608696, 0.38888888888889
70402, 1.5913043478261, 0.82826086956522, 0.36111111111111
70403, 1.5695652173913, 0.82826086956522, 0.33333333333333
70404, 1.5913043478261, 0.85434782608696, 0.33333333333333
70405, 1.5913043478261, 0.82826086956522, 0.30555555555556
70406, 1.5695652173913, 0.82826086956522, 0.27777777777778
70407, 1.5913043478261, 0.85434782608696, 0.27777777777778
70408, 1.5913043478261, 0.82826086956522, 0.25
70409, 1.5695652173913, 0.82826086956522, 0.22222222222222
70410, 1.5913043478261, 0.85434782608696, 0.22222222222222
70411, 1.5913043478261, 0.82826086956522, 0.19444444444444
70412, 1.5695652173913, 0.82826086956522, 0.16666666666667
70413, 1.5913043478261, 0.85434782608696, 0.16666666666667
70414, 1.5913043478261, 0.82826086956522, 0.13888888888889
70415, 1.5695652173913, 0.82826086956522, 0.11111111111111
70416, 1.5913043478261, 0.85434782608696, 0.11111111111111
70417, 1.5913043478261, 0.82826086956522, 0.083333333333333
70418, 1.5695652173913, 0.82826086956522, 0.055555555555556
70419, 1.5913043478261, 0.85434782608696, 0.055555555555556
70420, 1.5913043478261, 0.82826086956522, 0.027777777777778
70421, 1.6347826086957, 0.82826086956522, 0.47222222222222
70422, 1.6130434782609, 0.82826086956522, 0.44444444444444
70423, 1.6347826086957, 0.85434782608696, 0.44444444444444
70424, 1.6347826086957, 0.82826086956522, 0.41666666666667
70425, 1.6130434782609, 0.82826086956522, 0.38888888888889
70426, 1.6347826086957, 0.85434782608696, 0.38888888888889
70427, 1.6347826086957, 0.82826086956522, 0.36111111111111
70428, 1.6130434782609, 0.82826086956522, 0.33333333333333
70429, 1.6347826086957, 0.85434782608696, 0.33333333333333
70430, 1.6347826086957, 0.82826086956522, 0.30555555555556
70431, 1.6130434782609, 0.82826086956522, 0.27777777777778
70432, 1.6347826086957, 0.85434782608696, 0.27777777777778
70433, 1.6347826086957, 0.82826086956522, 0.25
70434, 1.6130434782609, 0.82826086956522, 0.22222222222222
70435, 1.6347826086957, 0.85434782608696, 0.22222222222222
70436, 1.6347826086957, 0.82826086956522, 0.19444444444444
70437, 1.6130434782609, 0.82826086956522, 0.16666666666667
70438, 1.6347826086957, 0.85434782608696, 0.16666666666667
70439, 1.6347826086957, 0.82826086956522, 0.13888888888889
70440, 1.6130434782609, 0.82826086956522, 0.11111111111111
70441, 1.6347826086957, 0.85434782608696, 0.11111111111111
70442, 1.6347826086957, 0.82826086956522, 0.083333333333333
70443, 1.6130434782609, 0.82826086956522, 0.055555555555556
70444, 1.6347826086957, 0.85434782608696, 0.055555555555556
70445, 1.6347826086957, 0.82826086956522, 0.027777777777778
70446, 1.6782608695652, 0.82826086956522, 0.47222222222222
70447, 1.6565217391304, 0.82826086956522, 0.44444444444444
70448, 1.6782608695652, 0.85434782608696, 0.44444444444444
70449, 1.6782608695652, 0.82826086956522, 0.41666666666667
70450, 1.6565217391304, 0.82826086956522, 0.38888888888889
70451, 1.6782608695652, 0.85434782608696, 0.38888888888889
70452, 1.6782608695652, 0.82826086956522, 0.36111111111111
70453, 1.6565217391304, 0.82826086956522, 0.33333333333333
70454, 1.6782608695652, 0.85434782608696, 0.33333333333333
70455, 1.6782608695652, 0.82826086956522, 0.30555555555556
70456, 1.6565217391304, 0.82826086956522, 0.27777777777778
70457, 1.6782608695652, 0.85434782608696, 0.27777777777778
70458, 1.6782608695652, 0.82826086956522, 0.25
70459, 1.6565217391304, 0.82826086956522, 0.22222222222222
70460, 1.6782608695652, 0.85434782608696, 0.22222222222222
70461, 1.6782608695652, 0.82826086956522, 0.19444444444444
70462, 1.6565217391304, 0.82826086956522, 0.16666666666667
70463, 1.6782608695652, 0.85434782608696, 0.16666666666667
70464, 1.6782608695652, 0.82826086956522, 0.13888888888889
70465, 1.6565217391304, 0.82826086956522, 0.11111111111111
70466, 1.6782608695652, 0.85434782608696, 0.11111111111111
70467, 1.6782608695652, 0.82826086956522, 0.083333333333333
70468, 1.6565217391304, 0.82826086956522, 0.055555555555556
70469, 1.6782608695652, 0.85434782608696, 0.055555555555556
70470, 1.6782608695652, 0.82826086956522, 0.027777777777778
70471, 1.7217391304348, 0.82826086956522, 0.47222222222222
70472, 1.7, 0.82826086956522, 0.44444444444444
70473, 1.7217391304348, 0.85434782608696, 0.44444444444444
70474, 1.7217391304348, 0.82826086956522, 0.41666666666667
70475, 1.7, 0.82826086956522, 0.38888888888889
70476, 1.7217391304348, 0.85434782608696, 0.38888888888889
70477, 1.7217391304348, 0.82826086956522, 0.36111111111111
70478, 1.7, 0.82826086956522, 0.33333333333333
70479, 1.7217391304348, 0.85434782608696, 0.33333333333333
70480, 1.7217391304348, 0.82826086956522, 0.30555555555556
70481, 1.7, 0.82826086956522, 0.27777777777778
70482, 1.7217391304348, 0.85434782608696, 0.27777777777778
70483, 1.7217391304348, 0.82826086956522, 0.25
70484, 1.7, 0.82826086956522, 0.22222222222222
70485, 1.7217391304348, 0.85434782608696, 0.22222222222222
70486, 1.7217391304348, 0.82826086956522, 0.19444444444444
70487, 1.7, 0.82826086956522, 0.16666666666667
70488, 1.7217391304348, 0.85434782608696, 0.16666666666667
70489, 1.7217391304348, 0.82826086956522, 0.13888888888889
70490, 1.7, 0.82826086956522, 0.11111111111111
70491, 1.7217391304348, 0.85434782608696, 0.11111111111111
70492, 1.7217391304348, 0.82826086956522, 0.083333333333333
70493, 1.7, 0.82826086956522, 0.055555555555556
70494, 1.7217391304348, 0.85434782608696, 0.055555555555556
70495, 1.7217391304348, 0.82826086956522, 0.027777777777778
70496, 1.7652173913043, 0.82826086956522, 0.47222222222222
70497, 1.7434782608696, 0.82826086956522, 0.44444444444444
70498, 1.7652173913043, 0.85434782608696, 0.44444444444444
70499, 1.7652173913043, 0.82826086956522, 0.41666666666667
70500, 1.7434782608696, 0.82826086956522, 0.38888888888889
70501, 1.7652173913043, 0.85434782608696, 0.38888888888889
70502, 1.7652173913043, 0.82826086956522, 0.36111111111111
70503, 1.7434782608696, 0.82826086956522, 0.33333333333333
70504, 1.7652173913043, 0.85434782608696, 0.33333333333333
70505, 1.7652173913043, 0.82826086956522, 0.30555555555556
70506, 1.7434782608696, 0.82826086956522, 0.27777777777778
70507, 1.7652173913043, 0.85434782608696, 0.27777777777778
70508, 1.7652173913043, 0.82826086956522, 0.25
70509, 1.7434782608696, 0.82826086956522, 0.22222222222222
70510, 1.7652173913043, 0.85434782608696, 0.22222222222222
70511, 1.7652173913043, 0.82826086956522, 0.19444444444444
70512, 1.7434782608696, 0.82826086956522, 0.16666666666667
70513, 1.7652173913043, 0.85434782608696, 0.16666666666667
70514, 1.7652173913043, 0.82826086956522, 0.13888888888889
70515, 1.7434782608696, 0.82826086956522, 0.11111111111111
70516, 1.7652173913043, 0.85434782608696, 0.11111111111111
70517, 1.7652173913043, 0.82826086956522, 0.083333333333333
70518, 1.7434782608696, 0.82826086956522, 0.055555555555556
70519, 1.7652173913043, 0.85434782608696, 0.055555555555556
70520, 1.7652173913043, 0.82826086956522, 0.027777777777778
70521, 1.8086956521739, 0.82826086956522, 0.47222222222222
70522, 1.7869565217391, 0.82826086956522, 0.44444444444444
70523, 1.8086956521739, 0.85434782608696, 0.44444444444444
70524, 1.8086956521739, 0.82826086956522, 0.41666666666667
70525, 1.7869565217391, 0.82826086956522, 0.38888888888889
70526, 1.8086956521739, 0.85434782608696, 0.38888888888889
70527, 1.8086956521739, 0.82826086956522, 0.36111111111111
70528, 1.7869565217391, 0.82826086956522, 0.33333333333333
70529, 1.8086956521739, 0.85434782608696, 0.33333333333333
70530, 1.8086956521739, 0.82826086956522, 0.30555555555556
70531, 1.7869565217391, 0.82826086956522, 0.27777777777778
70532, 1.8086956521739, 0.85434782608696, 0.27777777777778
70533, 1.8086956521739, 0.82826086956522, 0.25
70534, 1.7869565217391, 0.82826086956522, 0.22222222222222
70535, 1.8086956521739, 0.85434782608696, 0.22222222222222
70536, 1.8086956521739, 0.82826086956522, 0.19444444444444
70537, 1.7869565217391, 0.82826086956522, 0.16666666666667
70538, 1.8086956521739, 0.85434782608696, 0.16666666666667
70539, 1.8086956521739, 0.82826086956522, 0.13888888888889
70540, 1.7869565217391, 0.82826086956522, 0.11111111111111
70541, 1.8086956521739, 0.85434782608696, 0.11111111111111
70542, 1.8086956521739, 0.82826086956522, 0.083333333333333
70543, 1.7869565217391, 0.82826086956522, 0.055555555555556
70544, 1.8086956521739, 0.85434782608696, 0.055555555555556
70545, 1.8086956521739, 0.82826086956522, 0.027777777777778
70546, 1.8521739130435, 0.82826086956522, 0.47222222222222
70547, 1.8304347826087, 0.82826086956522, 0.44444444444444
70548, 1.8521739130435, 0.85434782608696, 0.44444444444444
70549, 1.8521739130435, 0.82826086956522, 0.41666666666667
70550, 1.8304347826087, 0.82826086956522, 0.38888888888889
70551, 1.8521739130435, 0.85434782608696, 0.38888888888889
70552, 1.8521739130435, 0.82826086956522, 0.36111111111111
70553, 1.8304347826087, 0.82826086956522, 0.33333333333333
70554, 1.8521739130435, 0.85434782608696, 0.33333333333333
70555, 1.8521739130435, 0.82826086956522, 0.30555555555556
70556, 1.8304347826087, 0.82826086956522, 0.27777777777778
70557, 1.8521739130435, 0.85434782608696, 0.27777777777778
70558, 1.8521739130435, 0.82826086956522, 0.25
70559, 1.8304347826087, 0.82826086956522, 0.22222222222222
70560, 1.8521739130435, 0.85434782608696, 0.22222222222222
70561, 1.8521739130435, 0.82826086956522, 0.19444444444444
70562, 1.8304347826087, 0.82826086956522, 0.16666666666667
70563, 1.8521739130435, 0.85434782608696, 0.16666666666667
70564, 1.8521739130435, 0.82826086956522, 0.13888888888889
70565, 1.8304347826087, 0.82826086956522, 0.11111111111111
70566, 1.8521739130435, 0.85434782608696, 0.11111111111111
70567, 1.8521739130435, 0.82826086956522, 0.083333333333333
70568, 1.8304347826087, 0.82826086956522, 0.055555555555556
70569, 1.8521739130435, 0.85434782608696, 0.055555555555556
70570, 1.8521739130435, 0.82826086956522, 0.027777777777778
70571, 1.895652173913, 0.82826086956522, 0.47222222222222
70572, 1.8739130434783, 0.82826086956522, 0.44444444444444
70573, 1.895652173913, 0.85434782608696, 0.44444444444444
70574, 1.895652173913, 0.82826086956522, 0.41666666666667
70575, 1.8739130434783, 0.82826086956522, 0.38888888888889
70576, 1.895652173913, 0.85434782608696, 0.38888888888889
70577, 1.895652173913, 0.82826086956522, 0.36111111111111
70578, 1.8739130434783, 0.82826086956522, 0.33333333333333
70579, 1.895652173913, 0.85434782608696, 0.33333333333333
70580, 1.895652173913, 0.82826086956522, 0.30555555555556
70581, 1.8739130434783, 0.82826086956522, 0.27777777777778
70582, 1.895652173913, 0.85434782608696, 0.27777777777778
70583, 1.895652173913, 0.82826086956522, 0.25
70584, 1.8739130434783, 0.82826086956522, 0.22222222222222
70585, 1.895652173913, 0.85434782608696, 0.22222222222222
70586, 1.895652173913, 0.82826086956522, 0.19444444444444
70587, 1.8739130434783, 0.82826086956522, 0.16666666666667
70588, 1.895652173913, 0.85434782608696, 0.16666666666667
70589, 1.895652173913, 0.82826086956522, 0.13888888888889
70590, 1.8739130434783, 0.82826086956522, 0.11111111111111
70591, 1.895652173913, 0.85434782608696, 0.11111111111111
70592, 1.895652173913, 0.82826086956522, 0.083333333333333
70593, 1.8739130434783, 0.82826086956522, 0.055555555555556
70594, 1.895652173913, 0.85434782608696, 0.055555555555556
70595, 1.895652173913, 0.82826086956522, 0.027777777777778
70596, 1.9391304347826, 0.82826086956522, 0.47222222222222
