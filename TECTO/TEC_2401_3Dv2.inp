44517, 0.17391304347826, 0.22826086956522, 0.11111111111111
44518, 0.17391304347826, 0.25434782608696, 0.13888888888889
44519, 0.19565217391304, 0.25434782608696, 0.16666666666667
44520, 0.17391304347826, 0.22826086956522, 0.16666666666667
44521, 0.17391304347826, 0.25434782608696, 0.19444444444444
44522, 0.19565217391304, 0.25434782608696, 0.22222222222222
44523, 0.17391304347826, 0.22826086956522, 0.22222222222222
44524, 0.17391304347826, 0.25434782608696, 0.25
44525, 0.19565217391304, 0.25434782608696, 0.27777777777778
44526, 0.17391304347826, 0.22826086956522, 0.27777777777778
44527, 0.17391304347826, 0.25434782608696, 0.30555555555556
44528, 0.19565217391304, 0.25434782608696, 0.33333333333333
44529, 0.17391304347826, 0.22826086956522, 0.33333333333333
44530, 0.17391304347826, 0.25434782608696, 0.36111111111111
44531, 0.19565217391304, 0.25434782608696, 0.38888888888889
44532, 0.17391304347826, 0.22826086956522, 0.38888888888889
44533, 0.17391304347826, 0.25434782608696, 0.41666666666667
44534, 0.19565217391304, 0.25434782608696, 0.44444444444444
44535, 0.17391304347826, 0.22826086956522, 0.44444444444444
44536, 0.17391304347826, 0.25434782608696, 0.47222222222222
44537, 0.1304347826087, 0.25434782608696, 0.027777777777778
44538, 0.15217391304348, 0.25434782608696, 0.055555555555556
44539, 0.1304347826087, 0.22826086956522, 0.055555555555556
44540, 0.1304347826087, 0.25434782608696, 0.083333333333333
44541, 0.15217391304348, 0.25434782608696, 0.11111111111111
44542, 0.1304347826087, 0.22826086956522, 0.11111111111111
44543, 0.1304347826087, 0.25434782608696, 0.13888888888889
44544, 0.15217391304348, 0.25434782608696, 0.16666666666667
44545, 0.1304347826087, 0.22826086956522, 0.16666666666667
44546, 0.1304347826087, 0.25434782608696, 0.19444444444444
44547, 0.15217391304348, 0.25434782608696, 0.22222222222222
44548, 0.1304347826087, 0.22826086956522, 0.22222222222222
44549, 0.1304347826087, 0.25434782608696, 0.25
44550, 0.15217391304348, 0.25434782608696, 0.27777777777778
44551, 0.1304347826087, 0.22826086956522, 0.27777777777778
44552, 0.1304347826087, 0.25434782608696, 0.30555555555556
44553, 0.15217391304348, 0.25434782608696, 0.33333333333333
44554, 0.1304347826087, 0.22826086956522, 0.33333333333333
44555, 0.1304347826087, 0.25434782608696, 0.36111111111111
44556, 0.15217391304348, 0.25434782608696, 0.38888888888889
44557, 0.1304347826087, 0.22826086956522, 0.38888888888889
44558, 0.1304347826087, 0.25434782608696, 0.41666666666667
44559, 0.15217391304348, 0.25434782608696, 0.44444444444444
44560, 0.1304347826087, 0.22826086956522, 0.44444444444444
44561, 0.1304347826087, 0.25434782608696, 0.47222222222222
44562, 0.08695652173913, 0.25434782608696, 0.027777777777778
44563, 0.10869565217391, 0.25434782608696, 0.055555555555556
44564, 0.08695652173913, 0.22826086956522, 0.055555555555556
44565, 0.08695652173913, 0.25434782608696, 0.083333333333333
44566, 0.10869565217391, 0.25434782608696, 0.11111111111111
44567, 0.08695652173913, 0.22826086956522, 0.11111111111111
44568, 0.08695652173913, 0.25434782608696, 0.13888888888889
44569, 0.10869565217391, 0.25434782608696, 0.16666666666667
44570, 0.08695652173913, 0.22826086956522, 0.16666666666667
44571, 0.08695652173913, 0.25434782608696, 0.19444444444444
44572, 0.10869565217391, 0.25434782608696, 0.22222222222222
44573, 0.08695652173913, 0.22826086956522, 0.22222222222222
44574, 0.08695652173913, 0.25434782608696, 0.25
44575, 0.10869565217391, 0.25434782608696, 0.27777777777778
44576, 0.08695652173913, 0.22826086956522, 0.27777777777778
44577, 0.08695652173913, 0.25434782608696, 0.30555555555556
44578, 0.10869565217391, 0.25434782608696, 0.33333333333333
44579, 0.08695652173913, 0.22826086956522, 0.33333333333333
44580, 0.08695652173913, 0.25434782608696, 0.36111111111111
44581, 0.10869565217391, 0.25434782608696, 0.38888888888889
44582, 0.08695652173913, 0.22826086956522, 0.38888888888889
44583, 0.08695652173913, 0.25434782608696, 0.41666666666667
44584, 0.10869565217391, 0.25434782608696, 0.44444444444444
44585, 0.08695652173913, 0.22826086956522, 0.44444444444444
44586, 0.08695652173913, 0.25434782608696, 0.47222222222222
44587, 0.043478260869565, 0.25434782608696, 0.027777777777778
44588, 0.065217391304348, 0.25434782608696, 0.055555555555556
44589, 0.043478260869565, 0.22826086956522, 0.055555555555556
44590, 0.043478260869565, 0.25434782608696, 0.083333333333333
44591, 0.065217391304348, 0.25434782608696, 0.11111111111111
44592, 0.043478260869565, 0.22826086956522, 0.11111111111111
44593, 0.043478260869565, 0.25434782608696, 0.13888888888889
44594, 0.065217391304348, 0.25434782608696, 0.16666666666667
44595, 0.043478260869565, 0.22826086956522, 0.16666666666667
44596, 0.043478260869565, 0.25434782608696, 0.19444444444444
44597, 0.065217391304348, 0.25434782608696, 0.22222222222222
44598, 0.043478260869565, 0.22826086956522, 0.22222222222222
44599, 0.043478260869565, 0.25434782608696, 0.25
44600, 0.065217391304348, 0.25434782608696, 0.27777777777778
44601, 0.043478260869565, 0.22826086956522, 0.27777777777778
44602, 0.043478260869565, 0.25434782608696, 0.30555555555556
44603, 0.065217391304348, 0.25434782608696, 0.33333333333333
44604, 0.043478260869565, 0.22826086956522, 0.33333333333333
44605, 0.043478260869565, 0.25434782608696, 0.36111111111111
44606, 0.065217391304348, 0.25434782608696, 0.38888888888889
44607, 0.043478260869565, 0.22826086956522, 0.38888888888889
44608, 0.043478260869565, 0.25434782608696, 0.41666666666667
44609, 0.065217391304348, 0.25434782608696, 0.44444444444444
44610, 0.043478260869565, 0.22826086956522, 0.44444444444444
44611, 0.043478260869565, 0.25434782608696, 0.47222222222222
44612, 0.021739130434783, 0.25434782608696, 0.055555555555556
44613, 0.021739130434783, 0.25434782608696, 0.11111111111111
44614, 0.021739130434783, 0.25434782608696, 0.16666666666667
44615, 0.021739130434783, 0.25434782608696, 0.22222222222222
44616, 0.021739130434783, 0.25434782608696, 0.27777777777778
44617, 0.021739130434783, 0.25434782608696, 0.33333333333333
44618, 0.021739130434783, 0.25434782608696, 0.38888888888889
44619, 0.021739130434783, 0.25434782608696, 0.44444444444444
44620, 0.95652173913044, 0.30652173913043, 0.027777777777778
44621, 0.97826086956522, 0.30652173913043, 0.055555555555556
44622, 0.95652173913043, 0.2804347826087, 0.055555555555556
44623, 0.95652173913044, 0.30652173913043, 0.083333333333333
44624, 0.97826086956522, 0.30652173913043, 0.11111111111111
44625, 0.95652173913044, 0.2804347826087, 0.11111111111111
44626, 0.95652173913044, 0.30652173913043, 0.13888888888889
44627, 0.97826086956522, 0.30652173913043, 0.16666666666667
44628, 0.95652173913044, 0.2804347826087, 0.16666666666667
44629, 0.95652173913044, 0.30652173913043, 0.19444444444444
44630, 0.97826086956522, 0.30652173913043, 0.22222222222222
44631, 0.95652173913044, 0.2804347826087, 0.22222222222222
44632, 0.95652173913044, 0.30652173913043, 0.25
44633, 0.97826086956522, 0.30652173913043, 0.27777777777778
44634, 0.95652173913044, 0.2804347826087, 0.27777777777778
44635, 0.95652173913044, 0.30652173913043, 0.30555555555556
44636, 0.97826086956522, 0.30652173913043, 0.33333333333333
44637, 0.95652173913044, 0.2804347826087, 0.33333333333333
44638, 0.95652173913044, 0.30652173913043, 0.36111111111111
44639, 0.97826086956522, 0.30652173913043, 0.38888888888889
44640, 0.95652173913043, 0.2804347826087, 0.38888888888889
44641, 0.95652173913044, 0.30652173913043, 0.41666666666667
44642, 0.97826086956522, 0.30652173913043, 0.44444444444444
44643, 0.95652173913043, 0.2804347826087, 0.44444444444444
44644, 0.95652173913044, 0.30652173913043, 0.47222222222222
44645, 0.91304347826087, 0.30652173913043, 0.027777777777778
44646, 0.93478260869565, 0.30652173913043, 0.055555555555556
44647, 0.91304347826087, 0.2804347826087, 0.055555555555556
44648, 0.91304347826087, 0.30652173913043, 0.083333333333333
44649, 0.93478260869565, 0.30652173913043, 0.11111111111111
44650, 0.91304347826087, 0.2804347826087, 0.11111111111111
44651, 0.91304347826087, 0.30652173913043, 0.13888888888889
44652, 0.93478260869565, 0.30652173913043, 0.16666666666667
44653, 0.91304347826087, 0.2804347826087, 0.16666666666667
44654, 0.91304347826087, 0.30652173913043, 0.19444444444444
44655, 0.93478260869565, 0.30652173913043, 0.22222222222222
44656, 0.91304347826087, 0.2804347826087, 0.22222222222222
44657, 0.91304347826087, 0.30652173913043, 0.25
44658, 0.93478260869565, 0.30652173913043, 0.27777777777778
44659, 0.91304347826087, 0.2804347826087, 0.27777777777778
44660, 0.91304347826087, 0.30652173913043, 0.30555555555556
44661, 0.93478260869565, 0.30652173913043, 0.33333333333333
44662, 0.91304347826087, 0.2804347826087, 0.33333333333333
44663, 0.91304347826087, 0.30652173913043, 0.36111111111111
44664, 0.93478260869565, 0.30652173913043, 0.38888888888889
44665, 0.91304347826087, 0.2804347826087, 0.38888888888889
44666, 0.91304347826087, 0.30652173913043, 0.41666666666667
44667, 0.93478260869565, 0.30652173913043, 0.44444444444444
44668, 0.91304347826087, 0.2804347826087, 0.44444444444444
44669, 0.91304347826087, 0.30652173913043, 0.47222222222222
44670, 0.8695652173913, 0.30652173913043, 0.027777777777778
44671, 0.89130434782609, 0.30652173913043, 0.055555555555556
44672, 0.8695652173913, 0.2804347826087, 0.055555555555556
44673, 0.8695652173913, 0.30652173913043, 0.083333333333333
44674, 0.89130434782609, 0.30652173913043, 0.11111111111111
44675, 0.8695652173913, 0.2804347826087, 0.11111111111111
44676, 0.8695652173913, 0.30652173913043, 0.13888888888889
44677, 0.89130434782609, 0.30652173913043, 0.16666666666667
44678, 0.8695652173913, 0.2804347826087, 0.16666666666667
44679, 0.8695652173913, 0.30652173913043, 0.19444444444444
44680, 0.89130434782609, 0.30652173913043, 0.22222222222222
44681, 0.8695652173913, 0.2804347826087, 0.22222222222222
44682, 0.8695652173913, 0.30652173913043, 0.25
44683, 0.89130434782609, 0.30652173913043, 0.27777777777778
44684, 0.8695652173913, 0.2804347826087, 0.27777777777778
44685, 0.8695652173913, 0.30652173913043, 0.30555555555556
44686, 0.89130434782609, 0.30652173913043, 0.33333333333333
44687, 0.8695652173913, 0.2804347826087, 0.33333333333333
44688, 0.8695652173913, 0.30652173913043, 0.36111111111111
44689, 0.89130434782609, 0.30652173913043, 0.38888888888889
44690, 0.8695652173913, 0.2804347826087, 0.38888888888889
44691, 0.8695652173913, 0.30652173913043, 0.41666666666667
44692, 0.89130434782609, 0.30652173913043, 0.44444444444444
44693, 0.8695652173913, 0.2804347826087, 0.44444444444444
44694, 0.8695652173913, 0.30652173913043, 0.47222222222222
44695, 0.82608695652174, 0.30652173913043, 0.027777777777778
44696, 0.84782608695652, 0.30652173913043, 0.055555555555556
44697, 0.82608695652174, 0.2804347826087, 0.055555555555556
44698, 0.82608695652174, 0.30652173913043, 0.083333333333333
44699, 0.84782608695652, 0.30652173913043, 0.11111111111111
44700, 0.82608695652174, 0.2804347826087, 0.11111111111111
44701, 0.82608695652174, 0.30652173913043, 0.13888888888889
44702, 0.84782608695652, 0.30652173913043, 0.16666666666667
44703, 0.82608695652174, 0.2804347826087, 0.16666666666667
44704, 0.82608695652174, 0.30652173913043, 0.19444444444444
44705, 0.84782608695652, 0.30652173913043, 0.22222222222222
44706, 0.82608695652174, 0.2804347826087, 0.22222222222222
44707, 0.82608695652174, 0.30652173913043, 0.25
44708, 0.84782608695652, 0.30652173913043, 0.27777777777778
44709, 0.82608695652174, 0.2804347826087, 0.27777777777778
44710, 0.82608695652174, 0.30652173913043, 0.30555555555556
44711, 0.84782608695652, 0.30652173913043, 0.33333333333333
44712, 0.82608695652174, 0.2804347826087, 0.33333333333333
44713, 0.82608695652174, 0.30652173913043, 0.36111111111111
44714, 0.84782608695652, 0.30652173913043, 0.38888888888889
44715, 0.82608695652174, 0.2804347826087, 0.38888888888889
44716, 0.82608695652174, 0.30652173913043, 0.41666666666667
44717, 0.84782608695652, 0.30652173913043, 0.44444444444444
44718, 0.82608695652174, 0.2804347826087, 0.44444444444444
44719, 0.82608695652174, 0.30652173913043, 0.47222222222222
44720, 0.78260869565217, 0.30652173913043, 0.027777777777778
44721, 0.80434782608696, 0.30652173913043, 0.055555555555556
44722, 0.78260869565217, 0.2804347826087, 0.055555555555556
44723, 0.78260869565217, 0.30652173913043, 0.083333333333333
44724, 0.80434782608696, 0.30652173913043, 0.11111111111111
44725, 0.78260869565217, 0.2804347826087, 0.11111111111111
44726, 0.78260869565217, 0.30652173913043, 0.13888888888889
44727, 0.80434782608696, 0.30652173913043, 0.16666666666667
44728, 0.78260869565217, 0.2804347826087, 0.16666666666667
44729, 0.78260869565217, 0.30652173913043, 0.19444444444444
44730, 0.80434782608696, 0.30652173913043, 0.22222222222222
44731, 0.78260869565217, 0.2804347826087, 0.22222222222222
44732, 0.78260869565217, 0.30652173913043, 0.25
44733, 0.80434782608696, 0.30652173913043, 0.27777777777778
44734, 0.78260869565217, 0.2804347826087, 0.27777777777778
44735, 0.78260869565217, 0.30652173913043, 0.30555555555556
44736, 0.80434782608696, 0.30652173913043, 0.33333333333333
44737, 0.78260869565217, 0.2804347826087, 0.33333333333333
44738, 0.78260869565217, 0.30652173913043, 0.36111111111111
44739, 0.80434782608696, 0.30652173913043, 0.38888888888889
44740, 0.78260869565217, 0.2804347826087, 0.38888888888889
44741, 0.78260869565217, 0.30652173913043, 0.41666666666667
44742, 0.80434782608696, 0.30652173913043, 0.44444444444444
44743, 0.78260869565217, 0.2804347826087, 0.44444444444444
44744, 0.78260869565217, 0.30652173913043, 0.47222222222222
44745, 0.73913043478261, 0.30652173913043, 0.027777777777778
44746, 0.76086956521739, 0.30652173913043, 0.055555555555556
44747, 0.73913043478261, 0.2804347826087, 0.055555555555556
44748, 0.73913043478261, 0.30652173913043, 0.083333333333333
44749, 0.76086956521739, 0.30652173913043, 0.11111111111111
44750, 0.73913043478261, 0.2804347826087, 0.11111111111111
44751, 0.73913043478261, 0.30652173913043, 0.13888888888889
44752, 0.76086956521739, 0.30652173913043, 0.16666666666667
44753, 0.73913043478261, 0.2804347826087, 0.16666666666667
44754, 0.73913043478261, 0.30652173913043, 0.19444444444444
44755, 0.76086956521739, 0.30652173913043, 0.22222222222222
44756, 0.73913043478261, 0.2804347826087, 0.22222222222222
44757, 0.73913043478261, 0.30652173913043, 0.25
44758, 0.76086956521739, 0.30652173913043, 0.27777777777778
44759, 0.73913043478261, 0.2804347826087, 0.27777777777778
44760, 0.73913043478261, 0.30652173913043, 0.30555555555556
44761, 0.76086956521739, 0.30652173913043, 0.33333333333333
44762, 0.73913043478261, 0.2804347826087, 0.33333333333333
44763, 0.73913043478261, 0.30652173913043, 0.36111111111111
44764, 0.76086956521739, 0.30652173913043, 0.38888888888889
44765, 0.73913043478261, 0.2804347826087, 0.38888888888889
44766, 0.73913043478261, 0.30652173913043, 0.41666666666667
44767, 0.76086956521739, 0.30652173913043, 0.44444444444444
44768, 0.73913043478261, 0.2804347826087, 0.44444444444444
44769, 0.73913043478261, 0.30652173913043, 0.47222222222222
44770, 0.69565217391304, 0.30652173913043, 0.027777777777778
44771, 0.71739130434783, 0.30652173913043, 0.055555555555556
44772, 0.69565217391304, 0.2804347826087, 0.055555555555556
44773, 0.69565217391304, 0.30652173913043, 0.083333333333333
44774, 0.71739130434783, 0.30652173913043, 0.11111111111111
44775, 0.69565217391304, 0.2804347826087, 0.11111111111111
44776, 0.69565217391304, 0.30652173913043, 0.13888888888889
44777, 0.71739130434783, 0.30652173913043, 0.16666666666667
44778, 0.69565217391304, 0.2804347826087, 0.16666666666667
44779, 0.69565217391304, 0.30652173913043, 0.19444444444444
44780, 0.71739130434783, 0.30652173913043, 0.22222222222222
44781, 0.69565217391304, 0.2804347826087, 0.22222222222222
44782, 0.69565217391304, 0.30652173913043, 0.25
44783, 0.71739130434783, 0.30652173913043, 0.27777777777778
44784, 0.69565217391304, 0.2804347826087, 0.27777777777778
44785, 0.69565217391304, 0.30652173913043, 0.30555555555556
44786, 0.71739130434783, 0.30652173913043, 0.33333333333333
44787, 0.69565217391304, 0.2804347826087, 0.33333333333333
44788, 0.69565217391304, 0.30652173913043, 0.36111111111111
44789, 0.71739130434783, 0.30652173913043, 0.38888888888889
44790, 0.69565217391304, 0.2804347826087, 0.38888888888889
44791, 0.69565217391304, 0.30652173913043, 0.41666666666667
44792, 0.71739130434783, 0.30652173913043, 0.44444444444444
44793, 0.69565217391304, 0.2804347826087, 0.44444444444444
44794, 0.69565217391304, 0.30652173913043, 0.47222222222222
44795, 0.65217391304348, 0.30652173913043, 0.027777777777778
44796, 0.67391304347826, 0.30652173913043, 0.055555555555556
44797, 0.65217391304348, 0.2804347826087, 0.055555555555556
44798, 0.65217391304348, 0.30652173913043, 0.083333333333333
44799, 0.67391304347826, 0.30652173913043, 0.11111111111111
44800, 0.65217391304348, 0.2804347826087, 0.11111111111111
44801, 0.65217391304348, 0.30652173913043, 0.13888888888889
44802, 0.67391304347826, 0.30652173913043, 0.16666666666667
44803, 0.65217391304348, 0.2804347826087, 0.16666666666667
44804, 0.65217391304348, 0.30652173913043, 0.19444444444444
44805, 0.67391304347826, 0.30652173913043, 0.22222222222222
44806, 0.65217391304348, 0.2804347826087, 0.22222222222222
44807, 0.65217391304348, 0.30652173913043, 0.25
44808, 0.67391304347826, 0.30652173913043, 0.27777777777778
44809, 0.65217391304348, 0.2804347826087, 0.27777777777778
44810, 0.65217391304348, 0.30652173913043, 0.30555555555556
44811, 0.67391304347826, 0.30652173913043, 0.33333333333333
44812, 0.65217391304348, 0.2804347826087, 0.33333333333333
44813, 0.65217391304348, 0.30652173913043, 0.36111111111111
44814, 0.67391304347826, 0.30652173913043, 0.38888888888889
44815, 0.65217391304348, 0.2804347826087, 0.38888888888889
44816, 0.65217391304348, 0.30652173913043, 0.41666666666667
44817, 0.67391304347826, 0.30652173913043, 0.44444444444444
44818, 0.65217391304348, 0.2804347826087, 0.44444444444444
44819, 0.65217391304348, 0.30652173913043, 0.47222222222222
44820, 0.60869565217391, 0.30652173913043, 0.027777777777778
44821, 0.6304347826087, 0.30652173913043, 0.055555555555556
44822, 0.60869565217391, 0.2804347826087, 0.055555555555556
44823, 0.60869565217391, 0.30652173913043, 0.083333333333333
44824, 0.6304347826087, 0.30652173913043, 0.11111111111111
44825, 0.60869565217391, 0.2804347826087, 0.11111111111111
44826, 0.60869565217391, 0.30652173913043, 0.13888888888889
44827, 0.6304347826087, 0.30652173913043, 0.16666666666667
44828, 0.60869565217391, 0.2804347826087, 0.16666666666667
44829, 0.60869565217391, 0.30652173913043, 0.19444444444444
44830, 0.6304347826087, 0.30652173913043, 0.22222222222222
44831, 0.60869565217391, 0.2804347826087, 0.22222222222222
44832, 0.60869565217391, 0.30652173913043, 0.25
44833, 0.6304347826087, 0.30652173913043, 0.27777777777778
44834, 0.60869565217391, 0.2804347826087, 0.27777777777778
44835, 0.60869565217391, 0.30652173913043, 0.30555555555556
44836, 0.6304347826087, 0.30652173913043, 0.33333333333333
44837, 0.60869565217391, 0.2804347826087, 0.33333333333333
44838, 0.60869565217391, 0.30652173913043, 0.36111111111111
44839, 0.6304347826087, 0.30652173913043, 0.38888888888889
44840, 0.60869565217391, 0.2804347826087, 0.38888888888889
44841, 0.60869565217391, 0.30652173913043, 0.41666666666667
44842, 0.6304347826087, 0.30652173913043, 0.44444444444444
44843, 0.60869565217391, 0.2804347826087, 0.44444444444444
44844, 0.60869565217391, 0.30652173913043, 0.47222222222222
44845, 0.56521739130435, 0.30652173913043, 0.027777777777778
44846, 0.58695652173913, 0.30652173913043, 0.055555555555556
44847, 0.56521739130435, 0.2804347826087, 0.055555555555556
44848, 0.56521739130435, 0.30652173913043, 0.083333333333333
44849, 0.58695652173913, 0.30652173913043, 0.11111111111111
44850, 0.56521739130435, 0.2804347826087, 0.11111111111111
44851, 0.56521739130435, 0.30652173913043, 0.13888888888889
44852, 0.58695652173913, 0.30652173913043, 0.16666666666667
44853, 0.56521739130435, 0.2804347826087, 0.16666666666667
44854, 0.56521739130435, 0.30652173913043, 0.19444444444444
44855, 0.58695652173913, 0.30652173913043, 0.22222222222222
44856, 0.56521739130435, 0.2804347826087, 0.22222222222222
44857, 0.56521739130435, 0.30652173913043, 0.25
44858, 0.58695652173913, 0.30652173913043, 0.27777777777778
44859, 0.56521739130435, 0.2804347826087, 0.27777777777778
44860, 0.56521739130435, 0.30652173913043, 0.30555555555556
44861, 0.58695652173913, 0.30652173913043, 0.33333333333333
44862, 0.56521739130435, 0.2804347826087, 0.33333333333333
44863, 0.56521739130435, 0.30652173913043, 0.36111111111111
44864, 0.58695652173913, 0.30652173913043, 0.38888888888889
44865, 0.56521739130435, 0.2804347826087, 0.38888888888889
44866, 0.56521739130435, 0.30652173913043, 0.41666666666667
44867, 0.58695652173913, 0.30652173913043, 0.44444444444444
44868, 0.56521739130435, 0.2804347826087, 0.44444444444444
44869, 0.56521739130435, 0.30652173913043, 0.47222222222222
44870, 0.52173913043478, 0.30652173913043, 0.027777777777778
44871, 0.54347826086957, 0.30652173913043, 0.055555555555556
44872, 0.52173913043478, 0.2804347826087, 0.055555555555556
44873, 0.52173913043478, 0.30652173913043, 0.083333333333333
44874, 0.54347826086957, 0.30652173913043, 0.11111111111111
44875, 0.52173913043478, 0.2804347826087, 0.11111111111111
44876, 0.52173913043478, 0.30652173913043, 0.13888888888889
44877, 0.54347826086957, 0.30652173913043, 0.16666666666667
44878, 0.52173913043478, 0.2804347826087, 0.16666666666667
44879, 0.52173913043478, 0.30652173913043, 0.19444444444444
44880, 0.54347826086956, 0.30652173913043, 0.22222222222222
44881, 0.52173913043478, 0.2804347826087, 0.22222222222222
44882, 0.52173913043478, 0.30652173913043, 0.25
44883, 0.54347826086956, 0.30652173913043, 0.27777777777778
44884, 0.52173913043478, 0.2804347826087, 0.27777777777778
44885, 0.52173913043478, 0.30652173913043, 0.30555555555556
44886, 0.54347826086956, 0.30652173913043, 0.33333333333333
44887, 0.52173913043478, 0.2804347826087, 0.33333333333333
44888, 0.52173913043478, 0.30652173913043, 0.36111111111111
44889, 0.54347826086956, 0.30652173913043, 0.38888888888889
44890, 0.52173913043478, 0.2804347826087, 0.38888888888889
44891, 0.52173913043478, 0.30652173913043, 0.41666666666667
44892, 0.54347826086956, 0.30652173913043, 0.44444444444444
44893, 0.52173913043478, 0.2804347826087, 0.44444444444444
44894, 0.52173913043478, 0.30652173913043, 0.47222222222222
44895, 0.47826086956522, 0.30652173913043, 0.027777777777778
44896, 0.5, 0.30652173913043, 0.055555555555556
44897, 0.47826086956522, 0.2804347826087, 0.055555555555556
44898, 0.47826086956522, 0.30652173913043, 0.083333333333333
44899, 0.5, 0.30652173913043, 0.11111111111111
44900, 0.47826086956522, 0.2804347826087, 0.11111111111111
44901, 0.47826086956522, 0.30652173913043, 0.13888888888889
44902, 0.5, 0.30652173913043, 0.16666666666667
44903, 0.47826086956522, 0.2804347826087, 0.16666666666667
44904, 0.47826086956522, 0.30652173913043, 0.19444444444444
44905, 0.5, 0.30652173913043, 0.22222222222222
44906, 0.47826086956522, 0.2804347826087, 0.22222222222222
44907, 0.47826086956522, 0.30652173913043, 0.25
44908, 0.5, 0.30652173913043, 0.27777777777778
44909, 0.47826086956522, 0.2804347826087, 0.27777777777778
44910, 0.47826086956522, 0.30652173913043, 0.30555555555556
44911, 0.5, 0.30652173913043, 0.33333333333333
44912, 0.47826086956522, 0.2804347826087, 0.33333333333333
44913, 0.47826086956522, 0.30652173913043, 0.36111111111111
44914, 0.5, 0.30652173913043, 0.38888888888889
44915, 0.47826086956522, 0.2804347826087, 0.38888888888889
44916, 0.47826086956522, 0.30652173913043, 0.41666666666667
44917, 0.5, 0.30652173913043, 0.44444444444444
44918, 0.47826086956522, 0.2804347826087, 0.44444444444444
44919, 0.47826086956522, 0.30652173913043, 0.47222222222222
44920, 0.43478260869565, 0.30652173913043, 0.027777777777778
44921, 0.45652173913043, 0.30652173913043, 0.055555555555556
44922, 0.43478260869565, 0.2804347826087, 0.055555555555556
44923, 0.43478260869565, 0.30652173913043, 0.083333333333333
44924, 0.45652173913043, 0.30652173913043, 0.11111111111111
44925, 0.43478260869565, 0.2804347826087, 0.11111111111111
44926, 0.43478260869565, 0.30652173913043, 0.13888888888889
44927, 0.45652173913043, 0.30652173913043, 0.16666666666667
44928, 0.43478260869565, 0.2804347826087, 0.16666666666667
44929, 0.43478260869565, 0.30652173913043, 0.19444444444444
44930, 0.45652173913043, 0.30652173913043, 0.22222222222222
44931, 0.43478260869565, 0.2804347826087, 0.22222222222222
44932, 0.43478260869565, 0.30652173913043, 0.25
44933, 0.45652173913043, 0.30652173913043, 0.27777777777778
44934, 0.43478260869565, 0.2804347826087, 0.27777777777778
44935, 0.43478260869565, 0.30652173913043, 0.30555555555556
44936, 0.45652173913043, 0.30652173913043, 0.33333333333333
44937, 0.43478260869565, 0.2804347826087, 0.33333333333333
44938, 0.43478260869565, 0.30652173913043, 0.36111111111111
44939, 0.45652173913043, 0.30652173913043, 0.38888888888889
44940, 0.43478260869565, 0.2804347826087, 0.38888888888889
44941, 0.43478260869565, 0.30652173913043, 0.41666666666667
44942, 0.45652173913043, 0.30652173913043, 0.44444444444444
44943, 0.43478260869565, 0.2804347826087, 0.44444444444444
44944, 0.43478260869565, 0.30652173913043, 0.47222222222222
44945, 0.39130434782609, 0.30652173913043, 0.027777777777778
44946, 0.41304347826087, 0.30652173913043, 0.055555555555556
44947, 0.39130434782609, 0.2804347826087, 0.055555555555556
44948, 0.39130434782609, 0.30652173913043, 0.083333333333333
44949, 0.41304347826087, 0.30652173913043, 0.11111111111111
44950, 0.39130434782609, 0.2804347826087, 0.11111111111111
44951, 0.39130434782609, 0.30652173913043, 0.13888888888889
44952, 0.41304347826087, 0.30652173913043, 0.16666666666667
44953, 0.39130434782609, 0.2804347826087, 0.16666666666667
44954, 0.39130434782609, 0.30652173913043, 0.19444444444444
44955, 0.41304347826087, 0.30652173913043, 0.22222222222222
44956, 0.39130434782609, 0.2804347826087, 0.22222222222222
44957, 0.39130434782609, 0.30652173913043, 0.25
44958, 0.41304347826087, 0.30652173913043, 0.27777777777778
44959, 0.39130434782609, 0.2804347826087, 0.27777777777778
44960, 0.39130434782609, 0.30652173913043, 0.30555555555556
44961, 0.41304347826087, 0.30652173913043, 0.33333333333333
44962, 0.39130434782609, 0.2804347826087, 0.33333333333333
44963, 0.39130434782609, 0.30652173913043, 0.36111111111111
44964, 0.41304347826087, 0.30652173913043, 0.38888888888889
44965, 0.39130434782609, 0.2804347826087, 0.38888888888889
44966, 0.39130434782609, 0.30652173913043, 0.41666666666667
44967, 0.41304347826087, 0.30652173913043, 0.44444444444444
44968, 0.39130434782609, 0.2804347826087, 0.44444444444444
44969, 0.39130434782609, 0.30652173913043, 0.47222222222222
44970, 0.34782608695652, 0.30652173913043, 0.027777777777778
44971, 0.3695652173913, 0.30652173913043, 0.055555555555556
44972, 0.34782608695652, 0.2804347826087, 0.055555555555556
44973, 0.34782608695652, 0.30652173913043, 0.083333333333333
44974, 0.3695652173913, 0.30652173913043, 0.11111111111111
44975, 0.34782608695652, 0.2804347826087, 0.11111111111111
44976, 0.34782608695652, 0.30652173913043, 0.13888888888889
44977, 0.3695652173913, 0.30652173913043, 0.16666666666667
44978, 0.34782608695652, 0.2804347826087, 0.16666666666667
44979, 0.34782608695652, 0.30652173913043, 0.19444444444444
44980, 0.3695652173913, 0.30652173913043, 0.22222222222222
44981, 0.34782608695652, 0.2804347826087, 0.22222222222222
44982, 0.34782608695652, 0.30652173913043, 0.25
44983, 0.3695652173913, 0.30652173913043, 0.27777777777778
44984, 0.34782608695652, 0.2804347826087, 0.27777777777778
44985, 0.34782608695652, 0.30652173913043, 0.30555555555556
44986, 0.3695652173913, 0.30652173913043, 0.33333333333333
44987, 0.34782608695652, 0.2804347826087, 0.33333333333333
44988, 0.34782608695652, 0.30652173913043, 0.36111111111111
44989, 0.3695652173913, 0.30652173913043, 0.38888888888889
44990, 0.34782608695652, 0.2804347826087, 0.38888888888889
44991, 0.34782608695652, 0.30652173913043, 0.41666666666667
44992, 0.3695652173913, 0.30652173913043, 0.44444444444444
44993, 0.34782608695652, 0.2804347826087, 0.44444444444444
44994, 0.34782608695652, 0.30652173913043, 0.47222222222222
44995, 0.30434782608696, 0.30652173913043, 0.027777777777778
44996, 0.32608695652174, 0.30652173913043, 0.055555555555556
44997, 0.30434782608696, 0.2804347826087, 0.055555555555556
44998, 0.30434782608696, 0.30652173913043, 0.083333333333333
44999, 0.32608695652174, 0.30652173913043, 0.11111111111111
45000, 0.30434782608696, 0.2804347826087, 0.11111111111111
45001, 0.30434782608696, 0.30652173913043, 0.13888888888889
45002, 0.32608695652174, 0.30652173913043, 0.16666666666667
45003, 0.30434782608696, 0.2804347826087, 0.16666666666667
45004, 0.30434782608696, 0.30652173913043, 0.19444444444444
45005, 0.32608695652174, 0.30652173913043, 0.22222222222222
45006, 0.30434782608696, 0.2804347826087, 0.22222222222222
45007, 0.30434782608696, 0.30652173913043, 0.25
45008, 0.32608695652174, 0.30652173913043, 0.27777777777778
45009, 0.30434782608696, 0.2804347826087, 0.27777777777778
45010, 0.30434782608696, 0.30652173913043, 0.30555555555556
45011, 0.32608695652174, 0.30652173913043, 0.33333333333333
45012, 0.30434782608696, 0.2804347826087, 0.33333333333333
45013, 0.30434782608696, 0.30652173913043, 0.36111111111111
45014, 0.32608695652174, 0.30652173913043, 0.38888888888889
45015, 0.30434782608696, 0.2804347826087, 0.38888888888889
45016, 0.30434782608696, 0.30652173913043, 0.41666666666667
45017, 0.32608695652174, 0.30652173913043, 0.44444444444444
45018, 0.30434782608696, 0.2804347826087, 0.44444444444444
45019, 0.30434782608696, 0.30652173913043, 0.47222222222222
45020, 0.26086956521739, 0.30652173913043, 0.027777777777778
45021, 0.28260869565217, 0.30652173913043, 0.055555555555556
45022, 0.26086956521739, 0.2804347826087, 0.055555555555556
45023, 0.26086956521739, 0.30652173913043, 0.083333333333333
45024, 0.28260869565217, 0.30652173913043, 0.11111111111111
45025, 0.26086956521739, 0.2804347826087, 0.11111111111111
45026, 0.26086956521739, 0.30652173913043, 0.13888888888889
45027, 0.28260869565217, 0.30652173913043, 0.16666666666667
45028, 0.26086956521739, 0.2804347826087, 0.16666666666667
45029, 0.26086956521739, 0.30652173913043, 0.19444444444444
45030, 0.28260869565217, 0.30652173913043, 0.22222222222222
45031, 0.26086956521739, 0.2804347826087, 0.22222222222222
45032, 0.26086956521739, 0.30652173913043, 0.25
45033, 0.28260869565217, 0.30652173913043, 0.27777777777778
45034, 0.26086956521739, 0.2804347826087, 0.27777777777778
45035, 0.26086956521739, 0.30652173913043, 0.30555555555556
45036, 0.28260869565217, 0.30652173913043, 0.33333333333333
45037, 0.26086956521739, 0.2804347826087, 0.33333333333333
45038, 0.26086956521739, 0.30652173913043, 0.36111111111111
45039, 0.28260869565217, 0.30652173913043, 0.38888888888889
45040, 0.26086956521739, 0.2804347826087, 0.38888888888889
45041, 0.26086956521739, 0.30652173913043, 0.41666666666667
45042, 0.28260869565217, 0.30652173913043, 0.44444444444444
45043, 0.26086956521739, 0.2804347826087, 0.44444444444444
45044, 0.26086956521739, 0.30652173913043, 0.47222222222222
45045, 0.21739130434783, 0.30652173913043, 0.027777777777778
45046, 0.23913043478261, 0.30652173913043, 0.055555555555556
45047, 0.21739130434783, 0.2804347826087, 0.055555555555556
45048, 0.21739130434783, 0.30652173913043, 0.083333333333333
45049, 0.23913043478261, 0.30652173913043, 0.11111111111111
45050, 0.21739130434783, 0.2804347826087, 0.11111111111111
45051, 0.21739130434783, 0.30652173913043, 0.13888888888889
45052, 0.23913043478261, 0.30652173913043, 0.16666666666667
45053, 0.21739130434783, 0.2804347826087, 0.16666666666667
45054, 0.21739130434783, 0.30652173913043, 0.19444444444444
45055, 0.23913043478261, 0.30652173913043, 0.22222222222222
45056, 0.21739130434783, 0.2804347826087, 0.22222222222222
45057, 0.21739130434783, 0.30652173913043, 0.25
45058, 0.23913043478261, 0.30652173913043, 0.27777777777778
45059, 0.21739130434783, 0.2804347826087, 0.27777777777778
45060, 0.21739130434783, 0.30652173913043, 0.30555555555556
45061, 0.23913043478261, 0.30652173913043, 0.33333333333333
45062, 0.21739130434783, 0.2804347826087, 0.33333333333333
45063, 0.21739130434783, 0.30652173913043, 0.36111111111111
45064, 0.23913043478261, 0.30652173913043, 0.38888888888889
45065, 0.21739130434783, 0.2804347826087, 0.38888888888889
45066, 0.21739130434783, 0.30652173913043, 0.41666666666667
45067, 0.23913043478261, 0.30652173913043, 0.44444444444444
45068, 0.21739130434783, 0.2804347826087, 0.44444444444444
45069, 0.21739130434783, 0.30652173913043, 0.47222222222222
45070, 0.17391304347826, 0.30652173913043, 0.027777777777778
45071, 0.19565217391304, 0.30652173913043, 0.055555555555556
45072, 0.17391304347826, 0.2804347826087, 0.055555555555556
45073, 0.17391304347826, 0.30652173913043, 0.083333333333333
45074, 0.19565217391304, 0.30652173913043, 0.11111111111111
45075, 0.17391304347826, 0.2804347826087, 0.11111111111111
45076, 0.17391304347826, 0.30652173913043, 0.13888888888889
45077, 0.19565217391304, 0.30652173913043, 0.16666666666667
45078, 0.17391304347826, 0.2804347826087, 0.16666666666667
45079, 0.17391304347826, 0.30652173913043, 0.19444444444444
45080, 0.19565217391304, 0.30652173913043, 0.22222222222222
45081, 0.17391304347826, 0.2804347826087, 0.22222222222222
45082, 0.17391304347826, 0.30652173913043, 0.25
45083, 0.19565217391304, 0.30652173913043, 0.27777777777778
45084, 0.17391304347826, 0.2804347826087, 0.27777777777778
45085, 0.17391304347826, 0.30652173913043, 0.30555555555556
45086, 0.19565217391304, 0.30652173913043, 0.33333333333333
45087, 0.17391304347826, 0.2804347826087, 0.33333333333333
45088, 0.17391304347826, 0.30652173913043, 0.36111111111111
45089, 0.19565217391304, 0.30652173913043, 0.38888888888889
45090, 0.17391304347826, 0.2804347826087, 0.38888888888889
45091, 0.17391304347826, 0.30652173913043, 0.41666666666667
45092, 0.19565217391304, 0.30652173913043, 0.44444444444444
45093, 0.17391304347826, 0.2804347826087, 0.44444444444444
45094, 0.17391304347826, 0.30652173913043, 0.47222222222222
45095, 0.1304347826087, 0.30652173913043, 0.027777777777778
45096, 0.15217391304348, 0.30652173913043, 0.055555555555556
45097, 0.1304347826087, 0.2804347826087, 0.055555555555556
45098, 0.1304347826087, 0.30652173913043, 0.083333333333333
45099, 0.15217391304348, 0.30652173913043, 0.11111111111111
45100, 0.1304347826087, 0.2804347826087, 0.11111111111111
45101, 0.1304347826087, 0.30652173913043, 0.13888888888889
45102, 0.15217391304348, 0.30652173913043, 0.16666666666667
45103, 0.1304347826087, 0.2804347826087, 0.16666666666667
45104, 0.1304347826087, 0.30652173913043, 0.19444444444444
45105, 0.15217391304348, 0.30652173913043, 0.22222222222222
45106, 0.1304347826087, 0.2804347826087, 0.22222222222222
45107, 0.1304347826087, 0.30652173913043, 0.25
45108, 0.15217391304348, 0.30652173913043, 0.27777777777778
45109, 0.1304347826087, 0.2804347826087, 0.27777777777778
45110, 0.1304347826087, 0.30652173913043, 0.30555555555556
45111, 0.15217391304348, 0.30652173913043, 0.33333333333333
45112, 0.1304347826087, 0.2804347826087, 0.33333333333333
45113, 0.1304347826087, 0.30652173913043, 0.36111111111111
45114, 0.15217391304348, 0.30652173913043, 0.38888888888889
45115, 0.1304347826087, 0.2804347826087, 0.38888888888889
45116, 0.1304347826087, 0.30652173913043, 0.41666666666667
45117, 0.15217391304348, 0.30652173913043, 0.44444444444444
45118, 0.1304347826087, 0.2804347826087, 0.44444444444444
45119, 0.1304347826087, 0.30652173913043, 0.47222222222222
45120, 0.08695652173913, 0.30652173913043, 0.027777777777778
45121, 0.10869565217391, 0.30652173913043, 0.055555555555556
45122, 0.08695652173913, 0.2804347826087, 0.055555555555556
45123, 0.08695652173913, 0.30652173913043, 0.083333333333333
45124, 0.10869565217391, 0.30652173913043, 0.11111111111111
45125, 0.08695652173913, 0.2804347826087, 0.11111111111111
45126, 0.08695652173913, 0.30652173913043, 0.13888888888889
45127, 0.10869565217391, 0.30652173913043, 0.16666666666667
45128, 0.08695652173913, 0.2804347826087, 0.16666666666667
45129, 0.08695652173913, 0.30652173913043, 0.19444444444444
45130, 0.10869565217391, 0.30652173913043, 0.22222222222222
45131, 0.08695652173913, 0.2804347826087, 0.22222222222222
45132, 0.08695652173913, 0.30652173913043, 0.25
45133, 0.10869565217391, 0.30652173913043, 0.27777777777778
45134, 0.08695652173913, 0.2804347826087, 0.27777777777778
45135, 0.08695652173913, 0.30652173913043, 0.30555555555556
45136, 0.10869565217391, 0.30652173913043, 0.33333333333333
45137, 0.08695652173913, 0.2804347826087, 0.33333333333333
45138, 0.08695652173913, 0.30652173913043, 0.36111111111111
45139, 0.10869565217391, 0.30652173913043, 0.38888888888889
45140, 0.08695652173913, 0.2804347826087, 0.38888888888889
45141, 0.08695652173913, 0.30652173913043, 0.41666666666667
45142, 0.10869565217391, 0.30652173913043, 0.44444444444444
45143, 0.08695652173913, 0.2804347826087, 0.44444444444444
45144, 0.08695652173913, 0.30652173913043, 0.47222222222222
45145, 0.043478260869565, 0.30652173913043, 0.027777777777778
45146, 0.065217391304348, 0.30652173913043, 0.055555555555556
45147, 0.043478260869565, 0.2804347826087, 0.055555555555556
45148, 0.043478260869565, 0.30652173913043, 0.083333333333333
45149, 0.065217391304348, 0.30652173913043, 0.11111111111111
45150, 0.043478260869565, 0.2804347826087, 0.11111111111111
45151, 0.043478260869565, 0.30652173913043, 0.13888888888889
45152, 0.065217391304348, 0.30652173913043, 0.16666666666667
45153, 0.043478260869565, 0.2804347826087, 0.16666666666667
45154, 0.043478260869565, 0.30652173913043, 0.19444444444444
45155, 0.065217391304348, 0.30652173913043, 0.22222222222222
45156, 0.043478260869565, 0.2804347826087, 0.22222222222222
45157, 0.043478260869565, 0.30652173913043, 0.25
45158, 0.065217391304348, 0.30652173913043, 0.27777777777778
45159, 0.043478260869565, 0.2804347826087, 0.27777777777778
45160, 0.043478260869565, 0.30652173913043, 0.30555555555556
45161, 0.065217391304348, 0.30652173913043, 0.33333333333333
45162, 0.043478260869565, 0.2804347826087, 0.33333333333333
45163, 0.043478260869565, 0.30652173913043, 0.36111111111111
45164, 0.065217391304348, 0.30652173913043, 0.38888888888889
45165, 0.043478260869565, 0.2804347826087, 0.38888888888889
45166, 0.043478260869565, 0.30652173913043, 0.41666666666667
45167, 0.065217391304348, 0.30652173913043, 0.44444444444444
45168, 0.043478260869565, 0.2804347826087, 0.44444444444444
45169, 0.043478260869565, 0.30652173913043, 0.47222222222222
45170, 0.021739130434783, 0.30652173913043, 0.055555555555556
45171, 0.021739130434783, 0.30652173913043, 0.11111111111111
45172, 0.021739130434783, 0.30652173913043, 0.16666666666667
45173, 0.021739130434783, 0.30652173913043, 0.22222222222222
45174, 0.021739130434783, 0.30652173913043, 0.27777777777778
45175, 0.021739130434783, 0.30652173913043, 0.33333333333333
45176, 0.021739130434783, 0.30652173913043, 0.38888888888889
45177, 0.021739130434783, 0.30652173913043, 0.44444444444444
45178, 0.95652173913043, 0.35869565217391, 0.027777777777778
45179, 0.97826086956522, 0.35869565217391, 0.055555555555556
45180, 0.95652173913044, 0.33260869565217, 0.055555555555556
45181, 0.95652173913043, 0.35869565217391, 0.083333333333333
45182, 0.97826086956522, 0.35869565217391, 0.11111111111111
45183, 0.95652173913044, 0.33260869565217, 0.11111111111111
45184, 0.95652173913044, 0.35869565217391, 0.13888888888889
45185, 0.97826086956522, 0.35869565217391, 0.16666666666667
45186, 0.95652173913044, 0.33260869565217, 0.16666666666667
45187, 0.95652173913044, 0.35869565217391, 0.19444444444444
45188, 0.97826086956522, 0.35869565217391, 0.22222222222222
45189, 0.95652173913044, 0.33260869565217, 0.22222222222222
45190, 0.95652173913044, 0.35869565217391, 0.25
45191, 0.97826086956522, 0.35869565217391, 0.27777777777778
45192, 0.95652173913044, 0.33260869565217, 0.27777777777778
45193, 0.95652173913044, 0.35869565217391, 0.30555555555556
45194, 0.97826086956522, 0.35869565217391, 0.33333333333333
45195, 0.95652173913044, 0.33260869565217, 0.33333333333333
45196, 0.95652173913043, 0.35869565217391, 0.36111111111111
45197, 0.97826086956522, 0.35869565217391, 0.38888888888889
45198, 0.95652173913044, 0.33260869565217, 0.38888888888889
45199, 0.95652173913043, 0.35869565217391, 0.41666666666667
45200, 0.97826086956522, 0.35869565217391, 0.44444444444444
45201, 0.95652173913044, 0.33260869565217, 0.44444444444444
45202, 0.95652173913043, 0.35869565217391, 0.47222222222222
45203, 0.91304347826087, 0.35869565217391, 0.027777777777778
45204, 0.93478260869565, 0.35869565217391, 0.055555555555556
45205, 0.91304347826087, 0.33260869565217, 0.055555555555556
45206, 0.91304347826087, 0.35869565217391, 0.083333333333333
45207, 0.93478260869565, 0.35869565217391, 0.11111111111111
45208, 0.91304347826087, 0.33260869565217, 0.11111111111111
45209, 0.91304347826087, 0.35869565217391, 0.13888888888889
45210, 0.93478260869565, 0.35869565217391, 0.16666666666667
45211, 0.91304347826087, 0.33260869565217, 0.16666666666667
45212, 0.91304347826087, 0.35869565217391, 0.19444444444444
45213, 0.93478260869565, 0.35869565217391, 0.22222222222222
45214, 0.91304347826087, 0.33260869565217, 0.22222222222222
45215, 0.91304347826087, 0.35869565217391, 0.25
45216, 0.93478260869565, 0.35869565217391, 0.27777777777778
45217, 0.91304347826087, 0.33260869565217, 0.27777777777778
45218, 0.91304347826087, 0.35869565217391, 0.30555555555556
45219, 0.93478260869565, 0.35869565217391, 0.33333333333333
45220, 0.91304347826087, 0.33260869565217, 0.33333333333333
45221, 0.91304347826087, 0.35869565217391, 0.36111111111111
45222, 0.93478260869565, 0.35869565217391, 0.38888888888889
45223, 0.91304347826087, 0.33260869565217, 0.38888888888889
45224, 0.91304347826087, 0.35869565217391, 0.41666666666667
45225, 0.93478260869565, 0.35869565217391, 0.44444444444444
45226, 0.91304347826087, 0.33260869565217, 0.44444444444444
45227, 0.91304347826087, 0.35869565217391, 0.47222222222222
45228, 0.8695652173913, 0.35869565217391, 0.027777777777778
45229, 0.89130434782609, 0.35869565217391, 0.055555555555556
45230, 0.8695652173913, 0.33260869565217, 0.055555555555556
45231, 0.8695652173913, 0.35869565217391, 0.083333333333333
45232, 0.89130434782609, 0.35869565217391, 0.11111111111111
45233, 0.8695652173913, 0.33260869565217, 0.11111111111111
45234, 0.8695652173913, 0.35869565217391, 0.13888888888889
45235, 0.89130434782609, 0.35869565217391, 0.16666666666667
45236, 0.8695652173913, 0.33260869565217, 0.16666666666667
45237, 0.8695652173913, 0.35869565217391, 0.19444444444444
45238, 0.89130434782609, 0.35869565217391, 0.22222222222222
45239, 0.8695652173913, 0.33260869565217, 0.22222222222222
45240, 0.8695652173913, 0.35869565217391, 0.25
45241, 0.89130434782609, 0.35869565217391, 0.27777777777778
45242, 0.8695652173913, 0.33260869565217, 0.27777777777778
45243, 0.8695652173913, 0.35869565217391, 0.30555555555556
45244, 0.89130434782609, 0.35869565217391, 0.33333333333333
45245, 0.8695652173913, 0.33260869565217, 0.33333333333333
45246, 0.8695652173913, 0.35869565217391, 0.36111111111111
45247, 0.89130434782609, 0.35869565217391, 0.38888888888889
45248, 0.8695652173913, 0.33260869565217, 0.38888888888889
45249, 0.8695652173913, 0.35869565217391, 0.41666666666667
45250, 0.89130434782609, 0.35869565217391, 0.44444444444444
45251, 0.8695652173913, 0.33260869565217, 0.44444444444444
45252, 0.8695652173913, 0.35869565217391, 0.47222222222222
45253, 0.82608695652174, 0.35869565217391, 0.027777777777778
45254, 0.84782608695652, 0.35869565217391, 0.055555555555556
45255, 0.82608695652174, 0.33260869565217, 0.055555555555556
45256, 0.82608695652174, 0.35869565217391, 0.083333333333333
45257, 0.84782608695652, 0.35869565217391, 0.11111111111111
45258, 0.82608695652174, 0.33260869565217, 0.11111111111111
45259, 0.82608695652174, 0.35869565217391, 0.13888888888889
45260, 0.84782608695652, 0.35869565217391, 0.16666666666667
45261, 0.82608695652174, 0.33260869565217, 0.16666666666667
45262, 0.82608695652174, 0.35869565217391, 0.19444444444444
45263, 0.84782608695652, 0.35869565217391, 0.22222222222222
45264, 0.82608695652174, 0.33260869565217, 0.22222222222222
45265, 0.82608695652174, 0.35869565217391, 0.25
45266, 0.84782608695652, 0.35869565217391, 0.27777777777778
45267, 0.82608695652174, 0.33260869565217, 0.27777777777778
45268, 0.82608695652174, 0.35869565217391, 0.30555555555556
45269, 0.84782608695652, 0.35869565217391, 0.33333333333333
45270, 0.82608695652174, 0.33260869565217, 0.33333333333333
45271, 0.82608695652174, 0.35869565217391, 0.36111111111111
45272, 0.84782608695652, 0.35869565217391, 0.38888888888889
45273, 0.82608695652174, 0.33260869565217, 0.38888888888889
45274, 0.82608695652174, 0.35869565217391, 0.41666666666667
45275, 0.84782608695652, 0.35869565217391, 0.44444444444444
45276, 0.82608695652174, 0.33260869565217, 0.44444444444444
45277, 0.82608695652174, 0.35869565217391, 0.47222222222222
45278, 0.78260869565217, 0.35869565217391, 0.027777777777778
45279, 0.80434782608696, 0.35869565217391, 0.055555555555556
45280, 0.78260869565217, 0.33260869565217, 0.055555555555556
45281, 0.78260869565217, 0.35869565217391, 0.083333333333333
45282, 0.80434782608696, 0.35869565217391, 0.11111111111111
45283, 0.78260869565217, 0.33260869565217, 0.11111111111111
45284, 0.78260869565217, 0.35869565217391, 0.13888888888889
45285, 0.80434782608696, 0.35869565217391, 0.16666666666667
45286, 0.78260869565217, 0.33260869565217, 0.16666666666667
45287, 0.78260869565217, 0.35869565217391, 0.19444444444444
45288, 0.80434782608696, 0.35869565217391, 0.22222222222222
45289, 0.78260869565217, 0.33260869565217, 0.22222222222222
45290, 0.78260869565217, 0.35869565217391, 0.25
45291, 0.80434782608696, 0.35869565217391, 0.27777777777778
45292, 0.78260869565217, 0.33260869565217, 0.27777777777778
45293, 0.78260869565217, 0.35869565217391, 0.30555555555556
45294, 0.80434782608696, 0.35869565217391, 0.33333333333333
45295, 0.78260869565217, 0.33260869565217, 0.33333333333333
45296, 0.78260869565217, 0.35869565217391, 0.36111111111111
45297, 0.80434782608696, 0.35869565217391, 0.38888888888889
45298, 0.78260869565217, 0.33260869565217, 0.38888888888889
45299, 0.78260869565217, 0.35869565217391, 0.41666666666667
45300, 0.80434782608696, 0.35869565217391, 0.44444444444444
45301, 0.78260869565217, 0.33260869565217, 0.44444444444444
45302, 0.78260869565217, 0.35869565217391, 0.47222222222222
45303, 0.73913043478261, 0.35869565217391, 0.027777777777778
45304, 0.76086956521739, 0.35869565217391, 0.055555555555556
45305, 0.73913043478261, 0.33260869565217, 0.055555555555556
45306, 0.73913043478261, 0.35869565217391, 0.083333333333333
45307, 0.76086956521739, 0.35869565217391, 0.11111111111111
45308, 0.73913043478261, 0.33260869565217, 0.11111111111111
45309, 0.73913043478261, 0.35869565217391, 0.13888888888889
45310, 0.76086956521739, 0.35869565217391, 0.16666666666667
45311, 0.73913043478261, 0.33260869565217, 0.16666666666667
45312, 0.73913043478261, 0.35869565217391, 0.19444444444444
45313, 0.76086956521739, 0.35869565217391, 0.22222222222222
45314, 0.73913043478261, 0.33260869565217, 0.22222222222222
45315, 0.73913043478261, 0.35869565217391, 0.25
45316, 0.76086956521739, 0.35869565217391, 0.27777777777778
45317, 0.73913043478261, 0.33260869565217, 0.27777777777778
45318, 0.73913043478261, 0.35869565217391, 0.30555555555556
45319, 0.76086956521739, 0.35869565217391, 0.33333333333333
45320, 0.73913043478261, 0.33260869565217, 0.33333333333333
45321, 0.73913043478261, 0.35869565217391, 0.36111111111111
45322, 0.76086956521739, 0.35869565217391, 0.38888888888889
45323, 0.73913043478261, 0.33260869565217, 0.38888888888889
45324, 0.73913043478261, 0.35869565217391, 0.41666666666667
45325, 0.76086956521739, 0.35869565217391, 0.44444444444444
45326, 0.73913043478261, 0.33260869565217, 0.44444444444444
45327, 0.73913043478261, 0.35869565217391, 0.47222222222222
45328, 0.69565217391304, 0.35869565217391, 0.027777777777778
45329, 0.71739130434783, 0.35869565217391, 0.055555555555556
45330, 0.69565217391304, 0.33260869565217, 0.055555555555556
45331, 0.69565217391304, 0.35869565217391, 0.083333333333333
45332, 0.71739130434783, 0.35869565217391, 0.11111111111111
45333, 0.69565217391304, 0.33260869565217, 0.11111111111111
45334, 0.69565217391304, 0.35869565217391, 0.13888888888889
45335, 0.71739130434783, 0.35869565217391, 0.16666666666667
45336, 0.69565217391304, 0.33260869565217, 0.16666666666667
45337, 0.69565217391304, 0.35869565217391, 0.19444444444444
45338, 0.71739130434783, 0.35869565217391, 0.22222222222222
45339, 0.69565217391304, 0.33260869565217, 0.22222222222222
45340, 0.69565217391304, 0.35869565217391, 0.25
45341, 0.71739130434783, 0.35869565217391, 0.27777777777778
45342, 0.69565217391304, 0.33260869565217, 0.27777777777778
45343, 0.69565217391304, 0.35869565217391, 0.30555555555556
45344, 0.71739130434783, 0.35869565217391, 0.33333333333333
45345, 0.69565217391304, 0.33260869565217, 0.33333333333333
45346, 0.69565217391304, 0.35869565217391, 0.36111111111111
45347, 0.71739130434783, 0.35869565217391, 0.38888888888889
45348, 0.69565217391304, 0.33260869565217, 0.38888888888889
45349, 0.69565217391304, 0.35869565217391, 0.41666666666667
45350, 0.71739130434783, 0.35869565217391, 0.44444444444444
45351, 0.69565217391304, 0.33260869565217, 0.44444444444444
45352, 0.69565217391304, 0.35869565217391, 0.47222222222222
45353, 0.65217391304348, 0.35869565217391, 0.027777777777778
45354, 0.67391304347826, 0.35869565217391, 0.055555555555556
45355, 0.65217391304348, 0.33260869565217, 0.055555555555556
45356, 0.65217391304348, 0.35869565217391, 0.083333333333333
45357, 0.67391304347826, 0.35869565217391, 0.11111111111111
45358, 0.65217391304348, 0.33260869565217, 0.11111111111111
45359, 0.65217391304348, 0.35869565217391, 0.13888888888889
45360, 0.67391304347826, 0.35869565217391, 0.16666666666667
45361, 0.65217391304348, 0.33260869565217, 0.16666666666667
45362, 0.65217391304348, 0.35869565217391, 0.19444444444444
45363, 0.67391304347826, 0.35869565217391, 0.22222222222222
45364, 0.65217391304348, 0.33260869565217, 0.22222222222222
45365, 0.65217391304348, 0.35869565217391, 0.25
45366, 0.67391304347826, 0.35869565217391, 0.27777777777778
45367, 0.65217391304348, 0.33260869565217, 0.27777777777778
45368, 0.65217391304348, 0.35869565217391, 0.30555555555556
45369, 0.67391304347826, 0.35869565217391, 0.33333333333333
45370, 0.65217391304348, 0.33260869565217, 0.33333333333333
45371, 0.65217391304348, 0.35869565217391, 0.36111111111111
45372, 0.67391304347826, 0.35869565217391, 0.38888888888889
45373, 0.65217391304348, 0.33260869565217, 0.38888888888889
45374, 0.65217391304348, 0.35869565217391, 0.41666666666667
45375, 0.67391304347826, 0.35869565217391, 0.44444444444444
45376, 0.65217391304348, 0.33260869565217, 0.44444444444444
45377, 0.65217391304348, 0.35869565217391, 0.47222222222222
45378, 0.60869565217391, 0.35869565217391, 0.027777777777778
45379, 0.6304347826087, 0.35869565217391, 0.055555555555556
45380, 0.60869565217391, 0.33260869565217, 0.055555555555556
45381, 0.60869565217391, 0.35869565217391, 0.083333333333333
45382, 0.6304347826087, 0.35869565217391, 0.11111111111111
45383, 0.60869565217391, 0.33260869565217, 0.11111111111111
45384, 0.60869565217391, 0.35869565217391, 0.13888888888889
45385, 0.6304347826087, 0.35869565217391, 0.16666666666667
45386, 0.60869565217391, 0.33260869565217, 0.16666666666667
45387, 0.60869565217391, 0.35869565217391, 0.19444444444444
45388, 0.6304347826087, 0.35869565217391, 0.22222222222222
45389, 0.60869565217391, 0.33260869565217, 0.22222222222222
45390, 0.60869565217391, 0.35869565217391, 0.25
45391, 0.6304347826087, 0.35869565217391, 0.27777777777778
45392, 0.60869565217391, 0.33260869565217, 0.27777777777778
45393, 0.60869565217391, 0.35869565217391, 0.30555555555556
45394, 0.6304347826087, 0.35869565217391, 0.33333333333333
45395, 0.60869565217391, 0.33260869565217, 0.33333333333333
45396, 0.60869565217391, 0.35869565217391, 0.36111111111111
45397, 0.6304347826087, 0.35869565217391, 0.38888888888889
45398, 0.60869565217391, 0.33260869565217, 0.38888888888889
45399, 0.60869565217391, 0.35869565217391, 0.41666666666667
45400, 0.6304347826087, 0.35869565217391, 0.44444444444444
45401, 0.60869565217391, 0.33260869565217, 0.44444444444444
45402, 0.60869565217391, 0.35869565217391, 0.47222222222222
45403, 0.56521739130435, 0.35869565217391, 0.027777777777778
45404, 0.58695652173913, 0.35869565217391, 0.055555555555556
45405, 0.56521739130435, 0.33260869565217, 0.055555555555556
45406, 0.56521739130435, 0.35869565217391, 0.083333333333333
45407, 0.58695652173913, 0.35869565217391, 0.11111111111111
45408, 0.56521739130435, 0.33260869565217, 0.11111111111111
45409, 0.56521739130435, 0.35869565217391, 0.13888888888889
45410, 0.58695652173913, 0.35869565217391, 0.16666666666667
45411, 0.56521739130435, 0.33260869565217, 0.16666666666667
45412, 0.56521739130435, 0.35869565217391, 0.19444444444444
45413, 0.58695652173913, 0.35869565217391, 0.22222222222222
45414, 0.56521739130435, 0.33260869565217, 0.22222222222222
45415, 0.56521739130435, 0.35869565217391, 0.25
45416, 0.58695652173913, 0.35869565217391, 0.27777777777778
45417, 0.56521739130435, 0.33260869565217, 0.27777777777778
45418, 0.56521739130435, 0.35869565217391, 0.30555555555556
45419, 0.58695652173913, 0.35869565217391, 0.33333333333333
45420, 0.56521739130435, 0.33260869565217, 0.33333333333333
45421, 0.56521739130435, 0.35869565217391, 0.36111111111111
45422, 0.58695652173913, 0.35869565217391, 0.38888888888889
45423, 0.56521739130435, 0.33260869565217, 0.38888888888889
45424, 0.56521739130435, 0.35869565217391, 0.41666666666667
45425, 0.58695652173913, 0.35869565217391, 0.44444444444444
45426, 0.56521739130435, 0.33260869565217, 0.44444444444444
45427, 0.56521739130435, 0.35869565217391, 0.47222222222222
45428, 0.52173913043478, 0.35869565217391, 0.027777777777778
45429, 0.54347826086957, 0.35869565217391, 0.055555555555556
45430, 0.52173913043478, 0.33260869565217, 0.055555555555556
45431, 0.52173913043478, 0.35869565217391, 0.083333333333333
45432, 0.54347826086957, 0.35869565217391, 0.11111111111111
45433, 0.52173913043478, 0.33260869565217, 0.11111111111111
45434, 0.52173913043478, 0.35869565217391, 0.13888888888889
45435, 0.54347826086956, 0.35869565217391, 0.16666666666667
45436, 0.52173913043478, 0.33260869565217, 0.16666666666667
45437, 0.52173913043478, 0.35869565217391, 0.19444444444444
45438, 0.54347826086956, 0.35869565217391, 0.22222222222222
45439, 0.52173913043478, 0.33260869565217, 0.22222222222222
45440, 0.52173913043478, 0.35869565217391, 0.25
45441, 0.54347826086956, 0.35869565217391, 0.27777777777778
45442, 0.52173913043478, 0.33260869565217, 0.27777777777778
45443, 0.52173913043478, 0.35869565217391, 0.30555555555556
45444, 0.54347826086956, 0.35869565217391, 0.33333333333333
45445, 0.52173913043478, 0.33260869565217, 0.33333333333333
45446, 0.52173913043478, 0.35869565217391, 0.36111111111111
45447, 0.54347826086956, 0.35869565217391, 0.38888888888889
45448, 0.52173913043478, 0.33260869565217, 0.38888888888889
45449, 0.52173913043478, 0.35869565217391, 0.41666666666667
45450, 0.54347826086956, 0.35869565217391, 0.44444444444444
45451, 0.52173913043478, 0.33260869565217, 0.44444444444444
45452, 0.52173913043478, 0.35869565217391, 0.47222222222222
45453, 0.47826086956522, 0.35869565217391, 0.027777777777778
45454, 0.5, 0.35869565217391, 0.055555555555556
45455, 0.47826086956522, 0.33260869565217, 0.055555555555556
45456, 0.47826086956522, 0.35869565217391, 0.083333333333333
45457, 0.5, 0.35869565217391, 0.11111111111111
45458, 0.47826086956522, 0.33260869565217, 0.11111111111111
45459, 0.47826086956522, 0.35869565217391, 0.13888888888889
45460, 0.5, 0.35869565217391, 0.16666666666667
45461, 0.47826086956522, 0.33260869565217, 0.16666666666667
45462, 0.47826086956522, 0.35869565217391, 0.19444444444444
45463, 0.5, 0.35869565217391, 0.22222222222222
45464, 0.47826086956522, 0.33260869565217, 0.22222222222222
45465, 0.47826086956522, 0.35869565217391, 0.25
45466, 0.5, 0.35869565217391, 0.27777777777778
45467, 0.47826086956522, 0.33260869565217, 0.27777777777778
45468, 0.47826086956522, 0.35869565217391, 0.30555555555556
45469, 0.5, 0.35869565217391, 0.33333333333333
45470, 0.47826086956522, 0.33260869565217, 0.33333333333333
45471, 0.47826086956522, 0.35869565217391, 0.36111111111111
45472, 0.5, 0.35869565217391, 0.38888888888889
45473, 0.47826086956522, 0.33260869565217, 0.38888888888889
45474, 0.47826086956522, 0.35869565217391, 0.41666666666667
45475, 0.5, 0.35869565217391, 0.44444444444444
45476, 0.47826086956522, 0.33260869565217, 0.44444444444444
45477, 0.47826086956522, 0.35869565217391, 0.47222222222222
45478, 0.43478260869565, 0.35869565217391, 0.027777777777778
45479, 0.45652173913043, 0.35869565217391, 0.055555555555556
45480, 0.43478260869565, 0.33260869565217, 0.055555555555556
45481, 0.43478260869565, 0.35869565217391, 0.083333333333333
45482, 0.45652173913043, 0.35869565217391, 0.11111111111111
45483, 0.43478260869565, 0.33260869565217, 0.11111111111111
45484, 0.43478260869565, 0.35869565217391, 0.13888888888889
45485, 0.45652173913043, 0.35869565217391, 0.16666666666667
45486, 0.43478260869565, 0.33260869565217, 0.16666666666667
45487, 0.43478260869565, 0.35869565217391, 0.19444444444444
45488, 0.45652173913043, 0.35869565217391, 0.22222222222222
45489, 0.43478260869565, 0.33260869565217, 0.22222222222222
45490, 0.43478260869565, 0.35869565217391, 0.25
45491, 0.45652173913043, 0.35869565217391, 0.27777777777778
45492, 0.43478260869565, 0.33260869565217, 0.27777777777778
45493, 0.43478260869565, 0.35869565217391, 0.30555555555556
45494, 0.45652173913043, 0.35869565217391, 0.33333333333333
45495, 0.43478260869565, 0.33260869565217, 0.33333333333333
45496, 0.43478260869565, 0.35869565217391, 0.36111111111111
45497, 0.45652173913043, 0.35869565217391, 0.38888888888889
45498, 0.43478260869565, 0.33260869565217, 0.38888888888889
45499, 0.43478260869565, 0.35869565217391, 0.41666666666667
45500, 0.45652173913043, 0.35869565217391, 0.44444444444444
45501, 0.43478260869565, 0.33260869565217, 0.44444444444444
45502, 0.43478260869565, 0.35869565217391, 0.47222222222222
45503, 0.39130434782609, 0.35869565217391, 0.027777777777778
45504, 0.41304347826087, 0.35869565217391, 0.055555555555556
45505, 0.39130434782609, 0.33260869565217, 0.055555555555556
45506, 0.39130434782609, 0.35869565217391, 0.083333333333333
45507, 0.41304347826087, 0.35869565217391, 0.11111111111111
45508, 0.39130434782609, 0.33260869565217, 0.11111111111111
45509, 0.39130434782609, 0.35869565217391, 0.13888888888889
45510, 0.41304347826087, 0.35869565217391, 0.16666666666667
45511, 0.39130434782609, 0.33260869565217, 0.16666666666667
45512, 0.39130434782609, 0.35869565217391, 0.19444444444444
45513, 0.41304347826087, 0.35869565217391, 0.22222222222222
45514, 0.39130434782609, 0.33260869565217, 0.22222222222222
45515, 0.39130434782609, 0.35869565217391, 0.25
45516, 0.41304347826087, 0.35869565217391, 0.27777777777778
45517, 0.39130434782609, 0.33260869565217, 0.27777777777778
45518, 0.39130434782609, 0.35869565217391, 0.30555555555556
45519, 0.41304347826087, 0.35869565217391, 0.33333333333333
45520, 0.39130434782609, 0.33260869565217, 0.33333333333333
45521, 0.39130434782609, 0.35869565217391, 0.36111111111111
45522, 0.41304347826087, 0.35869565217391, 0.38888888888889
45523, 0.39130434782609, 0.33260869565217, 0.38888888888889
45524, 0.39130434782609, 0.35869565217391, 0.41666666666667
45525, 0.41304347826087, 0.35869565217391, 0.44444444444444
45526, 0.39130434782609, 0.33260869565217, 0.44444444444444
45527, 0.39130434782609, 0.35869565217391, 0.47222222222222
45528, 0.34782608695652, 0.35869565217391, 0.027777777777778
45529, 0.3695652173913, 0.35869565217391, 0.055555555555556
45530, 0.34782608695652, 0.33260869565217, 0.055555555555556
45531, 0.34782608695652, 0.35869565217391, 0.083333333333333
45532, 0.3695652173913, 0.35869565217391, 0.11111111111111
45533, 0.34782608695652, 0.33260869565217, 0.11111111111111
45534, 0.34782608695652, 0.35869565217391, 0.13888888888889
45535, 0.3695652173913, 0.35869565217391, 0.16666666666667
45536, 0.34782608695652, 0.33260869565217, 0.16666666666667
45537, 0.34782608695652, 0.35869565217391, 0.19444444444444
45538, 0.3695652173913, 0.35869565217391, 0.22222222222222
45539, 0.34782608695652, 0.33260869565217, 0.22222222222222
45540, 0.34782608695652, 0.35869565217391, 0.25
45541, 0.3695652173913, 0.35869565217391, 0.27777777777778
45542, 0.34782608695652, 0.33260869565217, 0.27777777777778
45543, 0.34782608695652, 0.35869565217391, 0.30555555555556
45544, 0.3695652173913, 0.35869565217391, 0.33333333333333
45545, 0.34782608695652, 0.33260869565217, 0.33333333333333
45546, 0.34782608695652, 0.35869565217391, 0.36111111111111
45547, 0.3695652173913, 0.35869565217391, 0.38888888888889
45548, 0.34782608695652, 0.33260869565217, 0.38888888888889
45549, 0.34782608695652, 0.35869565217391, 0.41666666666667
45550, 0.3695652173913, 0.35869565217391, 0.44444444444444
45551, 0.34782608695652, 0.33260869565217, 0.44444444444444
45552, 0.34782608695652, 0.35869565217391, 0.47222222222222
45553, 0.30434782608696, 0.35869565217391, 0.027777777777778
45554, 0.32608695652174, 0.35869565217391, 0.055555555555556
45555, 0.30434782608696, 0.33260869565217, 0.055555555555556
45556, 0.30434782608696, 0.35869565217391, 0.083333333333333
45557, 0.32608695652174, 0.35869565217391, 0.11111111111111
45558, 0.30434782608696, 0.33260869565217, 0.11111111111111
45559, 0.30434782608696, 0.35869565217391, 0.13888888888889
45560, 0.32608695652174, 0.35869565217391, 0.16666666666667
45561, 0.30434782608696, 0.33260869565217, 0.16666666666667
45562, 0.30434782608696, 0.35869565217391, 0.19444444444444
45563, 0.32608695652174, 0.35869565217391, 0.22222222222222
45564, 0.30434782608696, 0.33260869565217, 0.22222222222222
45565, 0.30434782608696, 0.35869565217391, 0.25
45566, 0.32608695652174, 0.35869565217391, 0.27777777777778
45567, 0.30434782608696, 0.33260869565217, 0.27777777777778
45568, 0.30434782608696, 0.35869565217391, 0.30555555555556
45569, 0.32608695652174, 0.35869565217391, 0.33333333333333
45570, 0.30434782608696, 0.33260869565217, 0.33333333333333
45571, 0.30434782608696, 0.35869565217391, 0.36111111111111
45572, 0.32608695652174, 0.35869565217391, 0.38888888888889
45573, 0.30434782608696, 0.33260869565217, 0.38888888888889
45574, 0.30434782608696, 0.35869565217391, 0.41666666666667
45575, 0.32608695652174, 0.35869565217391, 0.44444444444444
45576, 0.30434782608696, 0.33260869565217, 0.44444444444444
45577, 0.30434782608696, 0.35869565217391, 0.47222222222222
45578, 0.26086956521739, 0.35869565217391, 0.027777777777778
45579, 0.28260869565217, 0.35869565217391, 0.055555555555556
45580, 0.26086956521739, 0.33260869565217, 0.055555555555556
45581, 0.26086956521739, 0.35869565217391, 0.083333333333333
45582, 0.28260869565217, 0.35869565217391, 0.11111111111111
45583, 0.26086956521739, 0.33260869565217, 0.11111111111111
45584, 0.26086956521739, 0.35869565217391, 0.13888888888889
45585, 0.28260869565217, 0.35869565217391, 0.16666666666667
45586, 0.26086956521739, 0.33260869565217, 0.16666666666667
45587, 0.26086956521739, 0.35869565217391, 0.19444444444444
45588, 0.28260869565217, 0.35869565217391, 0.22222222222222
45589, 0.26086956521739, 0.33260869565217, 0.22222222222222
45590, 0.26086956521739, 0.35869565217391, 0.25
45591, 0.28260869565217, 0.35869565217391, 0.27777777777778
45592, 0.26086956521739, 0.33260869565217, 0.27777777777778
45593, 0.26086956521739, 0.35869565217391, 0.30555555555556
45594, 0.28260869565217, 0.35869565217391, 0.33333333333333
45595, 0.26086956521739, 0.33260869565217, 0.33333333333333
45596, 0.26086956521739, 0.35869565217391, 0.36111111111111
45597, 0.28260869565217, 0.35869565217391, 0.38888888888889
45598, 0.26086956521739, 0.33260869565217, 0.38888888888889
45599, 0.26086956521739, 0.35869565217391, 0.41666666666667
45600, 0.28260869565217, 0.35869565217391, 0.44444444444444
45601, 0.26086956521739, 0.33260869565217, 0.44444444444444
45602, 0.26086956521739, 0.35869565217391, 0.47222222222222
45603, 0.21739130434783, 0.35869565217391, 0.027777777777778
45604, 0.23913043478261, 0.35869565217391, 0.055555555555556
45605, 0.21739130434783, 0.33260869565217, 0.055555555555556
45606, 0.21739130434783, 0.35869565217391, 0.083333333333333
45607, 0.23913043478261, 0.35869565217391, 0.11111111111111
45608, 0.21739130434783, 0.33260869565217, 0.11111111111111
45609, 0.21739130434783, 0.35869565217391, 0.13888888888889
45610, 0.23913043478261, 0.35869565217391, 0.16666666666667
45611, 0.21739130434783, 0.33260869565217, 0.16666666666667
45612, 0.21739130434783, 0.35869565217391, 0.19444444444444
45613, 0.23913043478261, 0.35869565217391, 0.22222222222222
45614, 0.21739130434783, 0.33260869565217, 0.22222222222222
45615, 0.21739130434783, 0.35869565217391, 0.25
45616, 0.23913043478261, 0.35869565217391, 0.27777777777778
45617, 0.21739130434783, 0.33260869565217, 0.27777777777778
45618, 0.21739130434783, 0.35869565217391, 0.30555555555556
45619, 0.23913043478261, 0.35869565217391, 0.33333333333333
45620, 0.21739130434783, 0.33260869565217, 0.33333333333333
45621, 0.21739130434783, 0.35869565217391, 0.36111111111111
45622, 0.23913043478261, 0.35869565217391, 0.38888888888889
45623, 0.21739130434783, 0.33260869565217, 0.38888888888889
45624, 0.21739130434783, 0.35869565217391, 0.41666666666667
45625, 0.23913043478261, 0.35869565217391, 0.44444444444444
45626, 0.21739130434783, 0.33260869565217, 0.44444444444444
45627, 0.21739130434783, 0.35869565217391, 0.47222222222222
45628, 0.17391304347826, 0.35869565217391, 0.027777777777778
45629, 0.19565217391304, 0.35869565217391, 0.055555555555556
45630, 0.17391304347826, 0.33260869565217, 0.055555555555556
45631, 0.17391304347826, 0.35869565217391, 0.083333333333333
45632, 0.19565217391304, 0.35869565217391, 0.11111111111111
45633, 0.17391304347826, 0.33260869565217, 0.11111111111111
45634, 0.17391304347826, 0.35869565217391, 0.13888888888889
45635, 0.19565217391304, 0.35869565217391, 0.16666666666667
45636, 0.17391304347826, 0.33260869565217, 0.16666666666667
45637, 0.17391304347826, 0.35869565217391, 0.19444444444444
45638, 0.19565217391304, 0.35869565217391, 0.22222222222222
45639, 0.17391304347826, 0.33260869565217, 0.22222222222222
45640, 0.17391304347826, 0.35869565217391, 0.25
45641, 0.19565217391304, 0.35869565217391, 0.27777777777778
45642, 0.17391304347826, 0.33260869565217, 0.27777777777778
45643, 0.17391304347826, 0.35869565217391, 0.30555555555556
45644, 0.19565217391304, 0.35869565217391, 0.33333333333333
45645, 0.17391304347826, 0.33260869565217, 0.33333333333333
45646, 0.17391304347826, 0.35869565217391, 0.36111111111111
45647, 0.19565217391304, 0.35869565217391, 0.38888888888889
45648, 0.17391304347826, 0.33260869565217, 0.38888888888889
45649, 0.17391304347826, 0.35869565217391, 0.41666666666667
45650, 0.19565217391304, 0.35869565217391, 0.44444444444444
45651, 0.17391304347826, 0.33260869565217, 0.44444444444444
45652, 0.17391304347826, 0.35869565217391, 0.47222222222222
45653, 0.1304347826087, 0.35869565217391, 0.027777777777778
45654, 0.15217391304348, 0.35869565217391, 0.055555555555556
45655, 0.1304347826087, 0.33260869565217, 0.055555555555556
45656, 0.1304347826087, 0.35869565217391, 0.083333333333333
45657, 0.15217391304348, 0.35869565217391, 0.11111111111111
45658, 0.1304347826087, 0.33260869565217, 0.11111111111111
45659, 0.1304347826087, 0.35869565217391, 0.13888888888889
45660, 0.15217391304348, 0.35869565217391, 0.16666666666667
45661, 0.1304347826087, 0.33260869565217, 0.16666666666667
45662, 0.1304347826087, 0.35869565217391, 0.19444444444444
45663, 0.15217391304348, 0.35869565217391, 0.22222222222222
45664, 0.1304347826087, 0.33260869565217, 0.22222222222222
45665, 0.1304347826087, 0.35869565217391, 0.25
45666, 0.15217391304348, 0.35869565217391, 0.27777777777778
45667, 0.1304347826087, 0.33260869565217, 0.27777777777778
45668, 0.1304347826087, 0.35869565217391, 0.30555555555556
45669, 0.15217391304348, 0.35869565217391, 0.33333333333333
45670, 0.1304347826087, 0.33260869565217, 0.33333333333333
45671, 0.1304347826087, 0.35869565217391, 0.36111111111111
45672, 0.15217391304348, 0.35869565217391, 0.38888888888889
45673, 0.1304347826087, 0.33260869565217, 0.38888888888889
45674, 0.1304347826087, 0.35869565217391, 0.41666666666667
45675, 0.15217391304348, 0.35869565217391, 0.44444444444444
45676, 0.1304347826087, 0.33260869565217, 0.44444444444444
45677, 0.1304347826087, 0.35869565217391, 0.47222222222222
45678, 0.08695652173913, 0.35869565217391, 0.027777777777778
45679, 0.10869565217391, 0.35869565217391, 0.055555555555556
45680, 0.08695652173913, 0.33260869565217, 0.055555555555556
45681, 0.08695652173913, 0.35869565217391, 0.083333333333333
45682, 0.10869565217391, 0.35869565217391, 0.11111111111111
45683, 0.08695652173913, 0.33260869565217, 0.11111111111111
45684, 0.08695652173913, 0.35869565217391, 0.13888888888889
45685, 0.10869565217391, 0.35869565217391, 0.16666666666667
45686, 0.08695652173913, 0.33260869565217, 0.16666666666667
45687, 0.08695652173913, 0.35869565217391, 0.19444444444444
45688, 0.10869565217391, 0.35869565217391, 0.22222222222222
45689, 0.08695652173913, 0.33260869565217, 0.22222222222222
45690, 0.08695652173913, 0.35869565217391, 0.25
45691, 0.10869565217391, 0.35869565217391, 0.27777777777778
45692, 0.08695652173913, 0.33260869565217, 0.27777777777778
45693, 0.08695652173913, 0.35869565217391, 0.30555555555556
45694, 0.10869565217391, 0.35869565217391, 0.33333333333333
45695, 0.08695652173913, 0.33260869565217, 0.33333333333333
45696, 0.08695652173913, 0.35869565217391, 0.36111111111111
45697, 0.10869565217391, 0.35869565217391, 0.38888888888889
45698, 0.08695652173913, 0.33260869565217, 0.38888888888889
45699, 0.08695652173913, 0.35869565217391, 0.41666666666667
45700, 0.10869565217391, 0.35869565217391, 0.44444444444444
45701, 0.08695652173913, 0.33260869565217, 0.44444444444444
45702, 0.08695652173913, 0.35869565217391, 0.47222222222222
45703, 0.043478260869565, 0.35869565217391, 0.027777777777778
45704, 0.065217391304348, 0.35869565217391, 0.055555555555556
45705, 0.043478260869565, 0.33260869565217, 0.055555555555556
45706, 0.043478260869565, 0.35869565217391, 0.083333333333333
45707, 0.065217391304348, 0.35869565217391, 0.11111111111111
45708, 0.043478260869565, 0.33260869565217, 0.11111111111111
45709, 0.043478260869565, 0.35869565217391, 0.13888888888889
45710, 0.065217391304348, 0.35869565217391, 0.16666666666667
45711, 0.043478260869565, 0.33260869565217, 0.16666666666667
45712, 0.043478260869565, 0.35869565217391, 0.19444444444444
45713, 0.065217391304348, 0.35869565217391, 0.22222222222222
45714, 0.043478260869565, 0.33260869565217, 0.22222222222222
45715, 0.043478260869565, 0.35869565217391, 0.25
45716, 0.065217391304348, 0.35869565217391, 0.27777777777778
45717, 0.043478260869565, 0.33260869565217, 0.27777777777778
45718, 0.043478260869565, 0.35869565217391, 0.30555555555556
45719, 0.065217391304348, 0.35869565217391, 0.33333333333333
45720, 0.043478260869565, 0.33260869565217, 0.33333333333333
45721, 0.043478260869565, 0.35869565217391, 0.36111111111111
45722, 0.065217391304348, 0.35869565217391, 0.38888888888889
45723, 0.043478260869565, 0.33260869565217, 0.38888888888889
45724, 0.043478260869565, 0.35869565217391, 0.41666666666667
45725, 0.065217391304348, 0.35869565217391, 0.44444444444444
45726, 0.043478260869565, 0.33260869565217, 0.44444444444444
45727, 0.043478260869565, 0.35869565217391, 0.47222222222222
45728, 0.021739130434783, 0.35869565217391, 0.055555555555556
45729, 0.021739130434783, 0.35869565217391, 0.11111111111111
45730, 0.021739130434783, 0.35869565217391, 0.16666666666667
45731, 0.021739130434783, 0.35869565217391, 0.22222222222222
45732, 0.021739130434783, 0.35869565217391, 0.27777777777778
45733, 0.021739130434783, 0.35869565217391, 0.33333333333333
45734, 0.021739130434783, 0.35869565217391, 0.38888888888889
45735, 0.021739130434783, 0.35869565217391, 0.44444444444444
45736, 0.95652173913043, 0.41086956521739, 0.027777777777778
45737, 0.97826086956522, 0.41086956521739, 0.055555555555556
45738, 0.95652173913043, 0.38478260869565, 0.055555555555556
45739, 0.95652173913043, 0.41086956521739, 0.083333333333333
45740, 0.97826086956522, 0.41086956521739, 0.11111111111111
45741, 0.95652173913044, 0.38478260869565, 0.11111111111111
45742, 0.95652173913044, 0.41086956521739, 0.13888888888889
45743, 0.97826086956522, 0.41086956521739, 0.16666666666667
45744, 0.95652173913044, 0.38478260869565, 0.16666666666667
45745, 0.95652173913044, 0.41086956521739, 0.19444444444444
45746, 0.97826086956522, 0.41086956521739, 0.22222222222222
45747, 0.95652173913044, 0.38478260869565, 0.22222222222222
45748, 0.95652173913044, 0.41086956521739, 0.25
45749, 0.97826086956522, 0.41086956521739, 0.27777777777778
45750, 0.95652173913044, 0.38478260869565, 0.27777777777778
45751, 0.95652173913044, 0.41086956521739, 0.30555555555556
45752, 0.97826086956522, 0.41086956521739, 0.33333333333333
45753, 0.95652173913044, 0.38478260869565, 0.33333333333333
45754, 0.95652173913044, 0.41086956521739, 0.36111111111111
45755, 0.97826086956522, 0.41086956521739, 0.38888888888889
45756, 0.95652173913043, 0.38478260869565, 0.38888888888889
45757, 0.95652173913044, 0.41086956521739, 0.41666666666667
45758, 0.97826086956522, 0.41086956521739, 0.44444444444444
45759, 0.95652173913044, 0.38478260869565, 0.44444444444444
45760, 0.95652173913043, 0.41086956521739, 0.47222222222222
45761, 0.91304347826087, 0.41086956521739, 0.027777777777778
45762, 0.93478260869565, 0.41086956521739, 0.055555555555556
45763, 0.91304347826087, 0.38478260869565, 0.055555555555556
45764, 0.91304347826087, 0.41086956521739, 0.083333333333333
45765, 0.93478260869565, 0.41086956521739, 0.11111111111111
45766, 0.91304347826087, 0.38478260869565, 0.11111111111111
45767, 0.91304347826087, 0.41086956521739, 0.13888888888889
45768, 0.93478260869565, 0.41086956521739, 0.16666666666667
45769, 0.91304347826087, 0.38478260869565, 0.16666666666667
45770, 0.91304347826087, 0.41086956521739, 0.19444444444444
45771, 0.93478260869565, 0.41086956521739, 0.22222222222222
45772, 0.91304347826087, 0.38478260869565, 0.22222222222222
45773, 0.91304347826087, 0.41086956521739, 0.25
45774, 0.93478260869565, 0.41086956521739, 0.27777777777778
45775, 0.91304347826087, 0.38478260869565, 0.27777777777778
45776, 0.91304347826087, 0.41086956521739, 0.30555555555556
45777, 0.93478260869565, 0.41086956521739, 0.33333333333333
45778, 0.91304347826087, 0.38478260869565, 0.33333333333333
45779, 0.91304347826087, 0.41086956521739, 0.36111111111111
45780, 0.93478260869565, 0.41086956521739, 0.38888888888889
45781, 0.91304347826087, 0.38478260869565, 0.38888888888889
45782, 0.91304347826087, 0.41086956521739, 0.41666666666667
45783, 0.93478260869565, 0.41086956521739, 0.44444444444444
45784, 0.91304347826087, 0.38478260869565, 0.44444444444444
45785, 0.91304347826087, 0.41086956521739, 0.47222222222222
45786, 0.8695652173913, 0.41086956521739, 0.027777777777778
45787, 0.89130434782609, 0.41086956521739, 0.055555555555556
45788, 0.8695652173913, 0.38478260869565, 0.055555555555556
45789, 0.8695652173913, 0.41086956521739, 0.083333333333333
45790, 0.89130434782609, 0.41086956521739, 0.11111111111111
45791, 0.8695652173913, 0.38478260869565, 0.11111111111111
45792, 0.8695652173913, 0.41086956521739, 0.13888888888889
45793, 0.89130434782609, 0.41086956521739, 0.16666666666667
45794, 0.8695652173913, 0.38478260869565, 0.16666666666667
45795, 0.8695652173913, 0.41086956521739, 0.19444444444444
45796, 0.89130434782609, 0.41086956521739, 0.22222222222222
45797, 0.8695652173913, 0.38478260869565, 0.22222222222222
45798, 0.8695652173913, 0.41086956521739, 0.25
45799, 0.89130434782609, 0.41086956521739, 0.27777777777778
45800, 0.8695652173913, 0.38478260869565, 0.27777777777778
45801, 0.8695652173913, 0.41086956521739, 0.30555555555556
45802, 0.89130434782609, 0.41086956521739, 0.33333333333333
45803, 0.8695652173913, 0.38478260869565, 0.33333333333333
45804, 0.8695652173913, 0.41086956521739, 0.36111111111111
45805, 0.89130434782609, 0.41086956521739, 0.38888888888889
45806, 0.8695652173913, 0.38478260869565, 0.38888888888889
45807, 0.8695652173913, 0.41086956521739, 0.41666666666667
45808, 0.89130434782609, 0.41086956521739, 0.44444444444444
45809, 0.8695652173913, 0.38478260869565, 0.44444444444444
45810, 0.8695652173913, 0.41086956521739, 0.47222222222222
45811, 0.82608695652174, 0.41086956521739, 0.027777777777778
45812, 0.84782608695652, 0.41086956521739, 0.055555555555556
45813, 0.82608695652174, 0.38478260869565, 0.055555555555556
45814, 0.82608695652174, 0.41086956521739, 0.083333333333333
45815, 0.84782608695652, 0.41086956521739, 0.11111111111111
45816, 0.82608695652174, 0.38478260869565, 0.11111111111111
45817, 0.82608695652174, 0.41086956521739, 0.13888888888889
45818, 0.84782608695652, 0.41086956521739, 0.16666666666667
45819, 0.82608695652174, 0.38478260869565, 0.16666666666667
45820, 0.82608695652174, 0.41086956521739, 0.19444444444444
45821, 0.84782608695652, 0.41086956521739, 0.22222222222222
45822, 0.82608695652174, 0.38478260869565, 0.22222222222222
45823, 0.82608695652174, 0.41086956521739, 0.25
45824, 0.84782608695652, 0.41086956521739, 0.27777777777778
45825, 0.82608695652174, 0.38478260869565, 0.27777777777778
45826, 0.82608695652174, 0.41086956521739, 0.30555555555556
45827, 0.84782608695652, 0.41086956521739, 0.33333333333333
45828, 0.82608695652174, 0.38478260869565, 0.33333333333333
45829, 0.82608695652174, 0.41086956521739, 0.36111111111111
45830, 0.84782608695652, 0.41086956521739, 0.38888888888889
45831, 0.82608695652174, 0.38478260869565, 0.38888888888889
45832, 0.82608695652174, 0.41086956521739, 0.41666666666667
45833, 0.84782608695652, 0.41086956521739, 0.44444444444444
45834, 0.82608695652174, 0.38478260869565, 0.44444444444444
45835, 0.82608695652174, 0.41086956521739, 0.47222222222222
45836, 0.78260869565217, 0.41086956521739, 0.027777777777778
45837, 0.80434782608696, 0.41086956521739, 0.055555555555556
45838, 0.78260869565217, 0.38478260869565, 0.055555555555556
45839, 0.78260869565217, 0.41086956521739, 0.083333333333333
45840, 0.80434782608696, 0.41086956521739, 0.11111111111111
45841, 0.78260869565217, 0.38478260869565, 0.11111111111111
45842, 0.78260869565217, 0.41086956521739, 0.13888888888889
45843, 0.80434782608696, 0.41086956521739, 0.16666666666667
45844, 0.78260869565217, 0.38478260869565, 0.16666666666667
45845, 0.78260869565217, 0.41086956521739, 0.19444444444444
45846, 0.80434782608696, 0.41086956521739, 0.22222222222222
45847, 0.78260869565217, 0.38478260869565, 0.22222222222222
45848, 0.78260869565217, 0.41086956521739, 0.25
45849, 0.80434782608696, 0.41086956521739, 0.27777777777778
45850, 0.78260869565217, 0.38478260869565, 0.27777777777778
45851, 0.78260869565217, 0.41086956521739, 0.30555555555556
45852, 0.80434782608696, 0.41086956521739, 0.33333333333333
45853, 0.78260869565217, 0.38478260869565, 0.33333333333333
45854, 0.78260869565217, 0.41086956521739, 0.36111111111111
45855, 0.80434782608696, 0.41086956521739, 0.38888888888889
45856, 0.78260869565217, 0.38478260869565, 0.38888888888889
45857, 0.78260869565217, 0.41086956521739, 0.41666666666667
45858, 0.80434782608696, 0.41086956521739, 0.44444444444444
45859, 0.78260869565217, 0.38478260869565, 0.44444444444444
45860, 0.78260869565217, 0.41086956521739, 0.47222222222222
45861, 0.73913043478261, 0.41086956521739, 0.027777777777778
45862, 0.76086956521739, 0.41086956521739, 0.055555555555556
45863, 0.73913043478261, 0.38478260869565, 0.055555555555556
45864, 0.73913043478261, 0.41086956521739, 0.083333333333333
45865, 0.76086956521739, 0.41086956521739, 0.11111111111111
45866, 0.73913043478261, 0.38478260869565, 0.11111111111111
45867, 0.73913043478261, 0.41086956521739, 0.13888888888889
45868, 0.76086956521739, 0.41086956521739, 0.16666666666667
45869, 0.73913043478261, 0.38478260869565, 0.16666666666667
45870, 0.73913043478261, 0.41086956521739, 0.19444444444444
45871, 0.76086956521739, 0.41086956521739, 0.22222222222222
45872, 0.73913043478261, 0.38478260869565, 0.22222222222222
45873, 0.73913043478261, 0.41086956521739, 0.25
45874, 0.76086956521739, 0.41086956521739, 0.27777777777778
45875, 0.73913043478261, 0.38478260869565, 0.27777777777778
45876, 0.73913043478261, 0.41086956521739, 0.30555555555556
45877, 0.76086956521739, 0.41086956521739, 0.33333333333333
45878, 0.73913043478261, 0.38478260869565, 0.33333333333333
45879, 0.73913043478261, 0.41086956521739, 0.36111111111111
45880, 0.76086956521739, 0.41086956521739, 0.38888888888889
45881, 0.73913043478261, 0.38478260869565, 0.38888888888889
45882, 0.73913043478261, 0.41086956521739, 0.41666666666667
45883, 0.76086956521739, 0.41086956521739, 0.44444444444444
45884, 0.73913043478261, 0.38478260869565, 0.44444444444444
45885, 0.73913043478261, 0.41086956521739, 0.47222222222222
45886, 0.69565217391304, 0.41086956521739, 0.027777777777778
45887, 0.71739130434783, 0.41086956521739, 0.055555555555556
45888, 0.69565217391304, 0.38478260869565, 0.055555555555556
45889, 0.69565217391304, 0.41086956521739, 0.083333333333333
45890, 0.71739130434783, 0.41086956521739, 0.11111111111111
45891, 0.69565217391304, 0.38478260869565, 0.11111111111111
45892, 0.69565217391304, 0.41086956521739, 0.13888888888889
45893, 0.71739130434783, 0.41086956521739, 0.16666666666667
45894, 0.69565217391304, 0.38478260869565, 0.16666666666667
45895, 0.69565217391304, 0.41086956521739, 0.19444444444444
45896, 0.71739130434783, 0.41086956521739, 0.22222222222222
45897, 0.69565217391304, 0.38478260869565, 0.22222222222222
45898, 0.69565217391304, 0.41086956521739, 0.25
45899, 0.71739130434783, 0.41086956521739, 0.27777777777778
45900, 0.69565217391304, 0.38478260869565, 0.27777777777778
45901, 0.69565217391304, 0.41086956521739, 0.30555555555556
45902, 0.71739130434783, 0.41086956521739, 0.33333333333333
45903, 0.69565217391304, 0.38478260869565, 0.33333333333333
45904, 0.69565217391304, 0.41086956521739, 0.36111111111111
45905, 0.71739130434783, 0.41086956521739, 0.38888888888889
45906, 0.69565217391304, 0.38478260869565, 0.38888888888889
45907, 0.69565217391304, 0.41086956521739, 0.41666666666667
45908, 0.71739130434783, 0.41086956521739, 0.44444444444444
45909, 0.69565217391304, 0.38478260869565, 0.44444444444444
45910, 0.69565217391304, 0.41086956521739, 0.47222222222222
45911, 0.65217391304348, 0.41086956521739, 0.027777777777778
45912, 0.67391304347826, 0.41086956521739, 0.055555555555556
45913, 0.65217391304348, 0.38478260869565, 0.055555555555556
45914, 0.65217391304348, 0.41086956521739, 0.083333333333333
45915, 0.67391304347826, 0.41086956521739, 0.11111111111111
45916, 0.65217391304348, 0.38478260869565, 0.11111111111111
45917, 0.65217391304348, 0.41086956521739, 0.13888888888889
45918, 0.67391304347826, 0.41086956521739, 0.16666666666667
45919, 0.65217391304348, 0.38478260869565, 0.16666666666667
45920, 0.65217391304348, 0.41086956521739, 0.19444444444444
45921, 0.67391304347826, 0.41086956521739, 0.22222222222222
45922, 0.65217391304348, 0.38478260869565, 0.22222222222222
45923, 0.65217391304348, 0.41086956521739, 0.25
45924, 0.67391304347826, 0.41086956521739, 0.27777777777778
45925, 0.65217391304348, 0.38478260869565, 0.27777777777778
45926, 0.65217391304348, 0.41086956521739, 0.30555555555556
45927, 0.67391304347826, 0.41086956521739, 0.33333333333333
45928, 0.65217391304348, 0.38478260869565, 0.33333333333333
45929, 0.65217391304348, 0.41086956521739, 0.36111111111111
45930, 0.67391304347826, 0.41086956521739, 0.38888888888889
45931, 0.65217391304348, 0.38478260869565, 0.38888888888889
45932, 0.65217391304348, 0.41086956521739, 0.41666666666667
45933, 0.67391304347826, 0.41086956521739, 0.44444444444444
45934, 0.65217391304348, 0.38478260869565, 0.44444444444444
45935, 0.65217391304348, 0.41086956521739, 0.47222222222222
45936, 0.60869565217391, 0.41086956521739, 0.027777777777778
45937, 0.6304347826087, 0.41086956521739, 0.055555555555556
45938, 0.60869565217391, 0.38478260869565, 0.055555555555556
45939, 0.60869565217391, 0.41086956521739, 0.083333333333333
45940, 0.6304347826087, 0.41086956521739, 0.11111111111111
45941, 0.60869565217391, 0.38478260869565, 0.11111111111111
45942, 0.60869565217391, 0.41086956521739, 0.13888888888889
45943, 0.6304347826087, 0.41086956521739, 0.16666666666667
45944, 0.60869565217391, 0.38478260869565, 0.16666666666667
45945, 0.60869565217391, 0.41086956521739, 0.19444444444444
45946, 0.6304347826087, 0.41086956521739, 0.22222222222222
45947, 0.60869565217391, 0.38478260869565, 0.22222222222222
45948, 0.60869565217391, 0.41086956521739, 0.25
45949, 0.6304347826087, 0.41086956521739, 0.27777777777778
45950, 0.60869565217391, 0.38478260869565, 0.27777777777778
45951, 0.60869565217391, 0.41086956521739, 0.30555555555556
45952, 0.6304347826087, 0.41086956521739, 0.33333333333333
45953, 0.60869565217391, 0.38478260869565, 0.33333333333333
45954, 0.60869565217391, 0.41086956521739, 0.36111111111111
45955, 0.6304347826087, 0.41086956521739, 0.38888888888889
45956, 0.60869565217391, 0.38478260869565, 0.38888888888889
45957, 0.60869565217391, 0.41086956521739, 0.41666666666667
45958, 0.6304347826087, 0.41086956521739, 0.44444444444444
45959, 0.60869565217391, 0.38478260869565, 0.44444444444444
45960, 0.60869565217391, 0.41086956521739, 0.47222222222222
45961, 0.56521739130435, 0.41086956521739, 0.027777777777778
45962, 0.58695652173913, 0.41086956521739, 0.055555555555556
45963, 0.56521739130435, 0.38478260869565, 0.055555555555556
45964, 0.56521739130435, 0.41086956521739, 0.083333333333333
45965, 0.58695652173913, 0.41086956521739, 0.11111111111111
45966, 0.56521739130435, 0.38478260869565, 0.11111111111111
45967, 0.56521739130435, 0.41086956521739, 0.13888888888889
45968, 0.58695652173913, 0.41086956521739, 0.16666666666667
45969, 0.56521739130435, 0.38478260869565, 0.16666666666667
45970, 0.56521739130435, 0.41086956521739, 0.19444444444444
45971, 0.58695652173913, 0.41086956521739, 0.22222222222222
45972, 0.56521739130435, 0.38478260869565, 0.22222222222222
45973, 0.56521739130435, 0.41086956521739, 0.25
45974, 0.58695652173913, 0.41086956521739, 0.27777777777778
45975, 0.56521739130435, 0.38478260869565, 0.27777777777778
45976, 0.56521739130435, 0.41086956521739, 0.30555555555556
45977, 0.58695652173913, 0.41086956521739, 0.33333333333333
45978, 0.56521739130435, 0.38478260869565, 0.33333333333333
45979, 0.56521739130435, 0.41086956521739, 0.36111111111111
45980, 0.58695652173913, 0.41086956521739, 0.38888888888889
45981, 0.56521739130435, 0.38478260869565, 0.38888888888889
45982, 0.56521739130435, 0.41086956521739, 0.41666666666667
45983, 0.58695652173913, 0.41086956521739, 0.44444444444444
45984, 0.56521739130435, 0.38478260869565, 0.44444444444444
45985, 0.56521739130435, 0.41086956521739, 0.47222222222222
45986, 0.52173913043478, 0.41086956521739, 0.027777777777778
45987, 0.54347826086957, 0.41086956521739, 0.055555555555556
45988, 0.52173913043478, 0.38478260869565, 0.055555555555556
45989, 0.52173913043478, 0.41086956521739, 0.083333333333333
45990, 0.54347826086957, 0.41086956521739, 0.11111111111111
45991, 0.52173913043478, 0.38478260869565, 0.11111111111111
45992, 0.52173913043478, 0.41086956521739, 0.13888888888889
45993, 0.54347826086957, 0.41086956521739, 0.16666666666667
45994, 0.52173913043478, 0.38478260869565, 0.16666666666667
45995, 0.52173913043478, 0.41086956521739, 0.19444444444444
45996, 0.54347826086956, 0.41086956521739, 0.22222222222222
45997, 0.52173913043478, 0.38478260869565, 0.22222222222222
45998, 0.52173913043478, 0.41086956521739, 0.25
45999, 0.54347826086956, 0.41086956521739, 0.27777777777778
46000, 0.52173913043478, 0.38478260869565, 0.27777777777778
46001, 0.52173913043478, 0.41086956521739, 0.30555555555556
46002, 0.54347826086956, 0.41086956521739, 0.33333333333333
46003, 0.52173913043478, 0.38478260869565, 0.33333333333333
46004, 0.52173913043478, 0.41086956521739, 0.36111111111111
46005, 0.54347826086956, 0.41086956521739, 0.38888888888889
46006, 0.52173913043478, 0.38478260869565, 0.38888888888889
46007, 0.52173913043478, 0.41086956521739, 0.41666666666667
46008, 0.54347826086956, 0.41086956521739, 0.44444444444444
46009, 0.52173913043478, 0.38478260869565, 0.44444444444444
46010, 0.52173913043478, 0.41086956521739, 0.47222222222222
46011, 0.47826086956522, 0.41086956521739, 0.027777777777778
46012, 0.5, 0.41086956521739, 0.055555555555556
46013, 0.47826086956522, 0.38478260869565, 0.055555555555556
46014, 0.47826086956522, 0.41086956521739, 0.083333333333333
46015, 0.5, 0.41086956521739, 0.11111111111111
46016, 0.47826086956522, 0.38478260869565, 0.11111111111111
46017, 0.47826086956522, 0.41086956521739, 0.13888888888889
46018, 0.5, 0.41086956521739, 0.16666666666667
46019, 0.47826086956522, 0.38478260869565, 0.16666666666667
46020, 0.47826086956522, 0.41086956521739, 0.19444444444444
46021, 0.5, 0.41086956521739, 0.22222222222222
46022, 0.47826086956522, 0.38478260869565, 0.22222222222222
46023, 0.47826086956522, 0.41086956521739, 0.25
46024, 0.5, 0.41086956521739, 0.27777777777778
46025, 0.47826086956522, 0.38478260869565, 0.27777777777778
46026, 0.47826086956522, 0.41086956521739, 0.30555555555556
46027, 0.5, 0.41086956521739, 0.33333333333333
46028, 0.47826086956522, 0.38478260869565, 0.33333333333333
46029, 0.47826086956522, 0.41086956521739, 0.36111111111111
46030, 0.5, 0.41086956521739, 0.38888888888889
46031, 0.47826086956522, 0.38478260869565, 0.38888888888889
46032, 0.47826086956522, 0.41086956521739, 0.41666666666667
46033, 0.5, 0.41086956521739, 0.44444444444444
46034, 0.47826086956522, 0.38478260869565, 0.44444444444444
46035, 0.47826086956522, 0.41086956521739, 0.47222222222222
46036, 0.43478260869565, 0.41086956521739, 0.027777777777778
46037, 0.45652173913043, 0.41086956521739, 0.055555555555556
46038, 0.43478260869565, 0.38478260869565, 0.055555555555556
46039, 0.43478260869565, 0.41086956521739, 0.083333333333333
46040, 0.45652173913043, 0.41086956521739, 0.11111111111111
46041, 0.43478260869565, 0.38478260869565, 0.11111111111111
46042, 0.43478260869565, 0.41086956521739, 0.13888888888889
46043, 0.45652173913043, 0.41086956521739, 0.16666666666667
46044, 0.43478260869565, 0.38478260869565, 0.16666666666667
46045, 0.43478260869565, 0.41086956521739, 0.19444444444444
46046, 0.45652173913043, 0.41086956521739, 0.22222222222222
46047, 0.43478260869565, 0.38478260869565, 0.22222222222222
46048, 0.43478260869565, 0.41086956521739, 0.25
46049, 0.45652173913043, 0.41086956521739, 0.27777777777778
46050, 0.43478260869565, 0.38478260869565, 0.27777777777778
46051, 0.43478260869565, 0.41086956521739, 0.30555555555556
46052, 0.45652173913043, 0.41086956521739, 0.33333333333333
46053, 0.43478260869565, 0.38478260869565, 0.33333333333333
46054, 0.43478260869565, 0.41086956521739, 0.36111111111111
46055, 0.45652173913044, 0.41086956521739, 0.38888888888889
46056, 0.43478260869565, 0.38478260869565, 0.38888888888889
46057, 0.43478260869565, 0.41086956521739, 0.41666666666667
46058, 0.45652173913043, 0.41086956521739, 0.44444444444444
46059, 0.43478260869565, 0.38478260869565, 0.44444444444444
46060, 0.43478260869565, 0.41086956521739, 0.47222222222222
46061, 0.39130434782609, 0.41086956521739, 0.027777777777778
46062, 0.41304347826087, 0.41086956521739, 0.055555555555556
46063, 0.39130434782609, 0.38478260869565, 0.055555555555556
46064, 0.39130434782609, 0.41086956521739, 0.083333333333333
46065, 0.41304347826087, 0.41086956521739, 0.11111111111111
46066, 0.39130434782609, 0.38478260869565, 0.11111111111111
46067, 0.39130434782609, 0.41086956521739, 0.13888888888889
46068, 0.41304347826087, 0.41086956521739, 0.16666666666667
46069, 0.39130434782609, 0.38478260869565, 0.16666666666667
46070, 0.39130434782609, 0.41086956521739, 0.19444444444444
46071, 0.41304347826087, 0.41086956521739, 0.22222222222222
46072, 0.39130434782609, 0.38478260869565, 0.22222222222222
46073, 0.39130434782609, 0.41086956521739, 0.25
46074, 0.41304347826087, 0.41086956521739, 0.27777777777778
46075, 0.39130434782609, 0.38478260869565, 0.27777777777778
46076, 0.39130434782609, 0.41086956521739, 0.30555555555556
46077, 0.41304347826087, 0.41086956521739, 0.33333333333333
46078, 0.39130434782609, 0.38478260869565, 0.33333333333333
46079, 0.39130434782609, 0.41086956521739, 0.36111111111111
46080, 0.41304347826087, 0.41086956521739, 0.38888888888889
46081, 0.39130434782609, 0.38478260869565, 0.38888888888889
46082, 0.39130434782609, 0.41086956521739, 0.41666666666667
46083, 0.41304347826087, 0.41086956521739, 0.44444444444444
46084, 0.39130434782609, 0.38478260869565, 0.44444444444444
46085, 0.39130434782609, 0.41086956521739, 0.47222222222222
46086, 0.34782608695652, 0.41086956521739, 0.027777777777778
46087, 0.3695652173913, 0.41086956521739, 0.055555555555556
46088, 0.34782608695652, 0.38478260869565, 0.055555555555556
46089, 0.34782608695652, 0.41086956521739, 0.083333333333333
46090, 0.3695652173913, 0.41086956521739, 0.11111111111111
46091, 0.34782608695652, 0.38478260869565, 0.11111111111111
46092, 0.34782608695652, 0.41086956521739, 0.13888888888889
46093, 0.3695652173913, 0.41086956521739, 0.16666666666667
46094, 0.34782608695652, 0.38478260869565, 0.16666666666667
46095, 0.34782608695652, 0.41086956521739, 0.19444444444444
46096, 0.3695652173913, 0.41086956521739, 0.22222222222222
46097, 0.34782608695652, 0.38478260869565, 0.22222222222222
46098, 0.34782608695652, 0.41086956521739, 0.25
46099, 0.3695652173913, 0.41086956521739, 0.27777777777778
46100, 0.34782608695652, 0.38478260869565, 0.27777777777778
46101, 0.34782608695652, 0.41086956521739, 0.30555555555556
46102, 0.3695652173913, 0.41086956521739, 0.33333333333333
46103, 0.34782608695652, 0.38478260869565, 0.33333333333333
46104, 0.34782608695652, 0.41086956521739, 0.36111111111111
46105, 0.3695652173913, 0.41086956521739, 0.38888888888889
46106, 0.34782608695652, 0.38478260869565, 0.38888888888889
46107, 0.34782608695652, 0.41086956521739, 0.41666666666667
46108, 0.3695652173913, 0.41086956521739, 0.44444444444444
46109, 0.34782608695652, 0.38478260869565, 0.44444444444444
46110, 0.34782608695652, 0.41086956521739, 0.47222222222222
46111, 0.30434782608696, 0.41086956521739, 0.027777777777778
46112, 0.32608695652174, 0.41086956521739, 0.055555555555556
46113, 0.30434782608696, 0.38478260869565, 0.055555555555556
46114, 0.30434782608696, 0.41086956521739, 0.083333333333333
46115, 0.32608695652174, 0.41086956521739, 0.11111111111111
46116, 0.30434782608696, 0.38478260869565, 0.11111111111111
46117, 0.30434782608696, 0.41086956521739, 0.13888888888889
46118, 0.32608695652174, 0.41086956521739, 0.16666666666667
46119, 0.30434782608696, 0.38478260869565, 0.16666666666667
46120, 0.30434782608696, 0.41086956521739, 0.19444444444444
46121, 0.32608695652174, 0.41086956521739, 0.22222222222222
46122, 0.30434782608696, 0.38478260869565, 0.22222222222222
46123, 0.30434782608696, 0.41086956521739, 0.25
46124, 0.32608695652174, 0.41086956521739, 0.27777777777778
46125, 0.30434782608696, 0.38478260869565, 0.27777777777778
46126, 0.30434782608696, 0.41086956521739, 0.30555555555556
46127, 0.32608695652174, 0.41086956521739, 0.33333333333333
46128, 0.30434782608696, 0.38478260869565, 0.33333333333333
46129, 0.30434782608696, 0.41086956521739, 0.36111111111111
46130, 0.32608695652174, 0.41086956521739, 0.38888888888889
46131, 0.30434782608696, 0.38478260869565, 0.38888888888889
46132, 0.30434782608696, 0.41086956521739, 0.41666666666667
46133, 0.32608695652174, 0.41086956521739, 0.44444444444444
46134, 0.30434782608696, 0.38478260869565, 0.44444444444444
46135, 0.30434782608696, 0.41086956521739, 0.47222222222222
46136, 0.26086956521739, 0.41086956521739, 0.027777777777778
46137, 0.28260869565217, 0.41086956521739, 0.055555555555556
46138, 0.26086956521739, 0.38478260869565, 0.055555555555556
46139, 0.26086956521739, 0.41086956521739, 0.083333333333333
46140, 0.28260869565217, 0.41086956521739, 0.11111111111111
46141, 0.26086956521739, 0.38478260869565, 0.11111111111111
46142, 0.26086956521739, 0.41086956521739, 0.13888888888889
46143, 0.28260869565217, 0.41086956521739, 0.16666666666667
46144, 0.26086956521739, 0.38478260869565, 0.16666666666667
46145, 0.26086956521739, 0.41086956521739, 0.19444444444444
46146, 0.28260869565217, 0.41086956521739, 0.22222222222222
46147, 0.26086956521739, 0.38478260869565, 0.22222222222222
46148, 0.26086956521739, 0.41086956521739, 0.25
46149, 0.28260869565217, 0.41086956521739, 0.27777777777778
46150, 0.26086956521739, 0.38478260869565, 0.27777777777778
46151, 0.26086956521739, 0.41086956521739, 0.30555555555556
46152, 0.28260869565217, 0.41086956521739, 0.33333333333333
46153, 0.26086956521739, 0.38478260869565, 0.33333333333333
46154, 0.26086956521739, 0.41086956521739, 0.36111111111111
46155, 0.28260869565217, 0.41086956521739, 0.38888888888889
46156, 0.26086956521739, 0.38478260869565, 0.38888888888889
46157, 0.26086956521739, 0.41086956521739, 0.41666666666667
46158, 0.28260869565217, 0.41086956521739, 0.44444444444444
46159, 0.26086956521739, 0.38478260869565, 0.44444444444444
46160, 0.26086956521739, 0.41086956521739, 0.47222222222222
46161, 0.21739130434783, 0.41086956521739, 0.027777777777778
46162, 0.23913043478261, 0.41086956521739, 0.055555555555556
46163, 0.21739130434783, 0.38478260869565, 0.055555555555556
46164, 0.21739130434783, 0.41086956521739, 0.083333333333333
46165, 0.23913043478261, 0.41086956521739, 0.11111111111111
46166, 0.21739130434783, 0.38478260869565, 0.11111111111111
46167, 0.21739130434783, 0.41086956521739, 0.13888888888889
46168, 0.23913043478261, 0.41086956521739, 0.16666666666667
46169, 0.21739130434783, 0.38478260869565, 0.16666666666667
46170, 0.21739130434783, 0.41086956521739, 0.19444444444444
46171, 0.23913043478261, 0.41086956521739, 0.22222222222222
46172, 0.21739130434783, 0.38478260869565, 0.22222222222222
46173, 0.21739130434783, 0.41086956521739, 0.25
46174, 0.23913043478261, 0.41086956521739, 0.27777777777778
46175, 0.21739130434783, 0.38478260869565, 0.27777777777778
46176, 0.21739130434783, 0.41086956521739, 0.30555555555556
46177, 0.23913043478261, 0.41086956521739, 0.33333333333333
46178, 0.21739130434783, 0.38478260869565, 0.33333333333333
46179, 0.21739130434783, 0.41086956521739, 0.36111111111111
46180, 0.23913043478261, 0.41086956521739, 0.38888888888889
46181, 0.21739130434783, 0.38478260869565, 0.38888888888889
46182, 0.21739130434783, 0.41086956521739, 0.41666666666667
46183, 0.23913043478261, 0.41086956521739, 0.44444444444444
46184, 0.21739130434783, 0.38478260869565, 0.44444444444444
46185, 0.21739130434783, 0.41086956521739, 0.47222222222222
46186, 0.17391304347826, 0.41086956521739, 0.027777777777778
46187, 0.19565217391304, 0.41086956521739, 0.055555555555556
46188, 0.17391304347826, 0.38478260869565, 0.055555555555556
46189, 0.17391304347826, 0.41086956521739, 0.083333333333333
46190, 0.19565217391304, 0.41086956521739, 0.11111111111111
46191, 0.17391304347826, 0.38478260869565, 0.11111111111111
46192, 0.17391304347826, 0.41086956521739, 0.13888888888889
46193, 0.19565217391304, 0.41086956521739, 0.16666666666667
46194, 0.17391304347826, 0.38478260869565, 0.16666666666667
46195, 0.17391304347826, 0.41086956521739, 0.19444444444444
46196, 0.19565217391304, 0.41086956521739, 0.22222222222222
46197, 0.17391304347826, 0.38478260869565, 0.22222222222222
46198, 0.17391304347826, 0.41086956521739, 0.25
46199, 0.19565217391304, 0.41086956521739, 0.27777777777778
46200, 0.17391304347826, 0.38478260869565, 0.27777777777778
