58289, 0.10869565217391, 1.5166666666667, 0.27777777777778
58290, 0.08695652173913, 1.5, 0.27777777777778
58291, 0.08695652173913, 1.5166666666667, 0.30555555555556
58292, 0.10869565217391, 1.5166666666667, 0.33333333333333
58293, 0.08695652173913, 1.5, 0.33333333333333
58294, 0.08695652173913, 1.5166666666667, 0.36111111111111
58295, 0.10869565217391, 1.5166666666667, 0.38888888888889
58296, 0.08695652173913, 1.5, 0.38888888888889
58297, 0.08695652173913, 1.5166666666667, 0.41666666666667
58298, 0.10869565217391, 1.5166666666667, 0.44444444444444
58299, 0.08695652173913, 1.5, 0.44444444444444
58300, 0.08695652173913, 1.5166666666667, 0.47222222222222
58301, 0.043478260869565, 1.5166666666667, 0.027777777777778
58302, 0.065217391304348, 1.5166666666667, 0.055555555555556
58303, 0.043478260869565, 1.5, 0.055555555555556
58304, 0.043478260869565, 1.5166666666667, 0.083333333333333
58305, 0.065217391304348, 1.5166666666667, 0.11111111111111
58306, 0.043478260869565, 1.5, 0.11111111111111
58307, 0.043478260869565, 1.5166666666667, 0.13888888888889
58308, 0.065217391304348, 1.5166666666667, 0.16666666666667
58309, 0.043478260869565, 1.5, 0.16666666666667
58310, 0.043478260869565, 1.5166666666667, 0.19444444444444
58311, 0.065217391304348, 1.5166666666667, 0.22222222222222
58312, 0.043478260869565, 1.5, 0.22222222222222
58313, 0.043478260869565, 1.5166666666667, 0.25
58314, 0.065217391304348, 1.5166666666667, 0.27777777777778
58315, 0.043478260869565, 1.5, 0.27777777777778
58316, 0.043478260869565, 1.5166666666667, 0.30555555555556
58317, 0.065217391304348, 1.5166666666667, 0.33333333333333
58318, 0.043478260869565, 1.5, 0.33333333333333
58319, 0.043478260869565, 1.5166666666667, 0.36111111111111
58320, 0.065217391304348, 1.5166666666667, 0.38888888888889
58321, 0.043478260869565, 1.5, 0.38888888888889
58322, 0.043478260869565, 1.5166666666667, 0.41666666666667
58323, 0.065217391304348, 1.5166666666667, 0.44444444444444
58324, 0.043478260869565, 1.5, 0.44444444444444
58325, 0.043478260869565, 1.5166666666667, 0.47222222222222
58326, 0.021739130434783, 1.5166666666667, 0.055555555555556
58327, 0.021739130434783, 1.5166666666667, 0.11111111111111
58328, 0.021739130434783, 1.5166666666667, 0.16666666666667
58329, 0.021739130434783, 1.5166666666667, 0.22222222222222
58330, 0.021739130434783, 1.5166666666667, 0.27777777777778
58331, 0.021739130434783, 1.5166666666667, 0.33333333333333
58332, 0.021739130434783, 1.5166666666667, 0.38888888888889
58333, 0.021739130434783, 1.5166666666667, 0.44444444444444
58334, 0.95652173913043, 1.5333333333333, 0.055555555555556
58335, 0.95652173913043, 1.5333333333333, 0.11111111111111
58336, 0.95652173913044, 1.5333333333333, 0.16666666666667
58337, 0.95652173913043, 1.5333333333333, 0.22222222222222
58338, 0.95652173913043, 1.5333333333333, 0.27777777777778
58339, 0.95652173913043, 1.5333333333333, 0.33333333333333
58340, 0.95652173913043, 1.5333333333333, 0.38888888888889
58341, 0.95652173913043, 1.5333333333333, 0.44444444444444
58342, 0.91304347826087, 1.5333333333333, 0.055555555555556
58343, 0.91304347826087, 1.5333333333333, 0.11111111111111
58344, 0.91304347826087, 1.5333333333333, 0.16666666666667
58345, 0.91304347826087, 1.5333333333333, 0.22222222222222
58346, 0.91304347826087, 1.5333333333333, 0.27777777777778
58347, 0.91304347826087, 1.5333333333333, 0.33333333333333
58348, 0.91304347826087, 1.5333333333333, 0.38888888888889
58349, 0.91304347826087, 1.5333333333333, 0.44444444444444
58350, 0.8695652173913, 1.5333333333333, 0.055555555555556
58351, 0.8695652173913, 1.5333333333333, 0.11111111111111
58352, 0.8695652173913, 1.5333333333333, 0.16666666666667
58353, 0.8695652173913, 1.5333333333333, 0.22222222222222
58354, 0.8695652173913, 1.5333333333333, 0.27777777777778
58355, 0.8695652173913, 1.5333333333333, 0.33333333333333
58356, 0.8695652173913, 1.5333333333333, 0.38888888888889
58357, 0.8695652173913, 1.5333333333333, 0.44444444444444
58358, 0.82608695652174, 1.5333333333333, 0.055555555555556
58359, 0.82608695652174, 1.5333333333333, 0.11111111111111
58360, 0.82608695652174, 1.5333333333333, 0.16666666666667
58361, 0.82608695652174, 1.5333333333333, 0.22222222222222
58362, 0.82608695652174, 1.5333333333333, 0.27777777777778
58363, 0.82608695652174, 1.5333333333333, 0.33333333333333
58364, 0.82608695652174, 1.5333333333333, 0.38888888888889
58365, 0.82608695652174, 1.5333333333333, 0.44444444444444
58366, 0.78260869565217, 1.5333333333333, 0.055555555555556
58367, 0.78260869565217, 1.5333333333333, 0.11111111111111
58368, 0.78260869565217, 1.5333333333333, 0.16666666666667
58369, 0.78260869565217, 1.5333333333333, 0.22222222222222
58370, 0.78260869565217, 1.5333333333333, 0.27777777777778
58371, 0.78260869565217, 1.5333333333333, 0.33333333333333
58372, 0.78260869565217, 1.5333333333333, 0.38888888888889
58373, 0.78260869565217, 1.5333333333333, 0.44444444444444
58374, 0.73913043478261, 1.5333333333333, 0.055555555555556
58375, 0.73913043478261, 1.5333333333333, 0.11111111111111
58376, 0.73913043478261, 1.5333333333333, 0.16666666666667
58377, 0.73913043478261, 1.5333333333333, 0.22222222222222
58378, 0.73913043478261, 1.5333333333333, 0.27777777777778
58379, 0.73913043478261, 1.5333333333333, 0.33333333333333
58380, 0.73913043478261, 1.5333333333333, 0.38888888888889
58381, 0.73913043478261, 1.5333333333333, 0.44444444444444
58382, 0.69565217391304, 1.5333333333333, 0.055555555555556
58383, 0.69565217391304, 1.5333333333333, 0.11111111111111
58384, 0.69565217391304, 1.5333333333333, 0.16666666666667
58385, 0.69565217391304, 1.5333333333333, 0.22222222222222
58386, 0.69565217391304, 1.5333333333333, 0.27777777777778
58387, 0.69565217391304, 1.5333333333333, 0.33333333333333
58388, 0.69565217391304, 1.5333333333333, 0.38888888888889
58389, 0.69565217391304, 1.5333333333333, 0.44444444444444
58390, 0.65217391304348, 1.5333333333333, 0.055555555555556
58391, 0.65217391304348, 1.5333333333333, 0.11111111111111
58392, 0.65217391304348, 1.5333333333333, 0.16666666666667
58393, 0.65217391304348, 1.5333333333333, 0.22222222222222
58394, 0.65217391304348, 1.5333333333333, 0.27777777777778
58395, 0.65217391304348, 1.5333333333333, 0.33333333333333
58396, 0.65217391304348, 1.5333333333333, 0.38888888888889
58397, 0.65217391304348, 1.5333333333333, 0.44444444444444
58398, 0.60869565217391, 1.5333333333333, 0.055555555555556
58399, 0.60869565217391, 1.5333333333333, 0.11111111111111
58400, 0.60869565217391, 1.5333333333333, 0.16666666666667
58401, 0.60869565217391, 1.5333333333333, 0.22222222222222
58402, 0.60869565217391, 1.5333333333333, 0.27777777777778
58403, 0.60869565217391, 1.5333333333333, 0.33333333333333
58404, 0.60869565217391, 1.5333333333333, 0.38888888888889
58405, 0.60869565217391, 1.5333333333333, 0.44444444444444
58406, 0.56521739130435, 1.5333333333333, 0.055555555555556
58407, 0.56521739130435, 1.5333333333333, 0.11111111111111
58408, 0.56521739130435, 1.5333333333333, 0.16666666666667
58409, 0.56521739130435, 1.5333333333333, 0.22222222222222
58410, 0.56521739130435, 1.5333333333333, 0.27777777777778
58411, 0.56521739130435, 1.5333333333333, 0.33333333333333
58412, 0.56521739130435, 1.5333333333333, 0.38888888888889
58413, 0.56521739130435, 1.5333333333333, 0.44444444444444
58414, 0.52173913043478, 1.5333333333333, 0.055555555555556
58415, 0.52173913043478, 1.5333333333333, 0.11111111111111
58416, 0.52173913043478, 1.5333333333333, 0.16666666666667
58417, 0.52173913043478, 1.5333333333333, 0.22222222222222
58418, 0.52173913043478, 1.5333333333333, 0.27777777777778
58419, 0.52173913043478, 1.5333333333333, 0.33333333333333
58420, 0.52173913043478, 1.5333333333333, 0.38888888888889
58421, 0.52173913043478, 1.5333333333333, 0.44444444444444
58422, 0.47826086956522, 1.5333333333333, 0.055555555555556
58423, 0.47826086956522, 1.5333333333333, 0.11111111111111
58424, 0.47826086956522, 1.5333333333333, 0.16666666666667
58425, 0.47826086956522, 1.5333333333333, 0.22222222222222
58426, 0.47826086956522, 1.5333333333333, 0.27777777777778
58427, 0.47826086956522, 1.5333333333333, 0.33333333333333
58428, 0.47826086956522, 1.5333333333333, 0.38888888888889
58429, 0.47826086956522, 1.5333333333333, 0.44444444444444
58430, 0.43478260869565, 1.5333333333333, 0.055555555555556
58431, 0.43478260869565, 1.5333333333333, 0.11111111111111
58432, 0.43478260869565, 1.5333333333333, 0.16666666666667
58433, 0.43478260869565, 1.5333333333333, 0.22222222222222
58434, 0.43478260869565, 1.5333333333333, 0.27777777777778
58435, 0.43478260869565, 1.5333333333333, 0.33333333333333
58436, 0.43478260869565, 1.5333333333333, 0.38888888888889
58437, 0.43478260869565, 1.5333333333333, 0.44444444444444
58438, 0.39130434782609, 1.5333333333333, 0.055555555555556
58439, 0.39130434782609, 1.5333333333333, 0.11111111111111
58440, 0.39130434782609, 1.5333333333333, 0.16666666666667
58441, 0.39130434782609, 1.5333333333333, 0.22222222222222
58442, 0.39130434782609, 1.5333333333333, 0.27777777777778
58443, 0.39130434782609, 1.5333333333333, 0.33333333333333
58444, 0.39130434782609, 1.5333333333333, 0.38888888888889
58445, 0.39130434782609, 1.5333333333333, 0.44444444444444
58446, 0.34782608695652, 1.5333333333333, 0.055555555555556
58447, 0.34782608695652, 1.5333333333333, 0.11111111111111
58448, 0.34782608695652, 1.5333333333333, 0.16666666666667
58449, 0.34782608695652, 1.5333333333333, 0.22222222222222
58450, 0.34782608695652, 1.5333333333333, 0.27777777777778
58451, 0.34782608695652, 1.5333333333333, 0.33333333333333
58452, 0.34782608695652, 1.5333333333333, 0.38888888888889
58453, 0.34782608695652, 1.5333333333333, 0.44444444444444
58454, 0.30434782608696, 1.5333333333333, 0.055555555555556
58455, 0.30434782608696, 1.5333333333333, 0.11111111111111
58456, 0.30434782608696, 1.5333333333333, 0.16666666666667
58457, 0.30434782608696, 1.5333333333333, 0.22222222222222
58458, 0.30434782608696, 1.5333333333333, 0.27777777777778
58459, 0.30434782608696, 1.5333333333333, 0.33333333333333
58460, 0.30434782608696, 1.5333333333333, 0.38888888888889
58461, 0.30434782608696, 1.5333333333333, 0.44444444444444
58462, 0.26086956521739, 1.5333333333333, 0.055555555555556
58463, 0.26086956521739, 1.5333333333333, 0.11111111111111
58464, 0.26086956521739, 1.5333333333333, 0.16666666666667
58465, 0.26086956521739, 1.5333333333333, 0.22222222222222
58466, 0.26086956521739, 1.5333333333333, 0.27777777777778
58467, 0.26086956521739, 1.5333333333333, 0.33333333333333
58468, 0.26086956521739, 1.5333333333333, 0.38888888888889
58469, 0.26086956521739, 1.5333333333333, 0.44444444444444
58470, 0.21739130434783, 1.5333333333333, 0.055555555555556
58471, 0.21739130434783, 1.5333333333333, 0.11111111111111
58472, 0.21739130434783, 1.5333333333333, 0.16666666666667
58473, 0.21739130434783, 1.5333333333333, 0.22222222222222
58474, 0.21739130434783, 1.5333333333333, 0.27777777777778
58475, 0.21739130434783, 1.5333333333333, 0.33333333333333
58476, 0.21739130434783, 1.5333333333333, 0.38888888888889
58477, 0.21739130434783, 1.5333333333333, 0.44444444444444
58478, 0.17391304347826, 1.5333333333333, 0.055555555555556
58479, 0.17391304347826, 1.5333333333333, 0.11111111111111
58480, 0.17391304347826, 1.5333333333333, 0.16666666666667
58481, 0.17391304347826, 1.5333333333333, 0.22222222222222
58482, 0.17391304347826, 1.5333333333333, 0.27777777777778
58483, 0.17391304347826, 1.5333333333333, 0.33333333333333
58484, 0.17391304347826, 1.5333333333333, 0.38888888888889
58485, 0.17391304347826, 1.5333333333333, 0.44444444444444
58486, 0.1304347826087, 1.5333333333333, 0.055555555555556
58487, 0.1304347826087, 1.5333333333333, 0.11111111111111
58488, 0.1304347826087, 1.5333333333333, 0.16666666666667
58489, 0.1304347826087, 1.5333333333333, 0.22222222222222
58490, 0.1304347826087, 1.5333333333333, 0.27777777777778
58491, 0.1304347826087, 1.5333333333333, 0.33333333333333
58492, 0.1304347826087, 1.5333333333333, 0.38888888888889
58493, 0.1304347826087, 1.5333333333333, 0.44444444444444
58494, 0.08695652173913, 1.5333333333333, 0.055555555555556
58495, 0.08695652173913, 1.5333333333333, 0.11111111111111
58496, 0.08695652173913, 1.5333333333333, 0.16666666666667
58497, 0.08695652173913, 1.5333333333333, 0.22222222222222
58498, 0.08695652173913, 1.5333333333333, 0.27777777777778
58499, 0.08695652173913, 1.5333333333333, 0.33333333333333
58500, 0.08695652173913, 1.5333333333333, 0.38888888888889
58501, 0.08695652173913, 1.5333333333333, 0.44444444444444
58502, 0.043478260869565, 1.5333333333333, 0.055555555555556
58503, 0.043478260869565, 1.5333333333333, 0.11111111111111
58504, 0.043478260869565, 1.5333333333333, 0.16666666666667
58505, 0.043478260869565, 1.5333333333333, 0.22222222222222
58506, 0.043478260869565, 1.5333333333333, 0.27777777777778
58507, 0.043478260869565, 1.5333333333333, 0.33333333333333
58508, 0.043478260869565, 1.5333333333333, 0.38888888888889
58509, 0.043478260869565, 1.5333333333333, 0.44444444444444
58510, 1.05, 1.4833333333333, 0.44444444444444
58511, 1.05, 1.4833333333333, 0.38888888888889
58512, 1.05, 1.4833333333333, 0.33333333333333
58513, 1.05, 1.4833333333333, 0.27777777777778
58514, 1.05, 1.4833333333333, 0.22222222222222
58515, 1.05, 1.4833333333333, 0.16666666666667
58516, 1.05, 1.4833333333333, 0.11111111111111
58517, 1.05, 1.4833333333333, 0.055555555555556
58518, 1.05, 1.5166666666667, 0.44444444444444
58519, 1.05, 1.5166666666667, 0.38888888888889
58520, 1.05, 1.5166666666667, 0.33333333333333
58521, 1.05, 1.5166666666667, 0.27777777777778
58522, 1.05, 1.5166666666667, 0.22222222222222
58523, 1.05, 1.5166666666667, 0.16666666666667
58524, 1.05, 1.5166666666667, 0.11111111111111
58525, 1.05, 1.5166666666667, 0.055555555555556
58526, 1.1, 1.4833333333333, 0.44444444444444
58527, 1.1, 1.4833333333333, 0.38888888888889
58528, 1.1, 1.4833333333333, 0.33333333333333
58529, 1.1, 1.4833333333333, 0.27777777777778
58530, 1.1, 1.4833333333333, 0.22222222222222
58531, 1.1, 1.4833333333333, 0.16666666666667
58532, 1.1, 1.4833333333333, 0.11111111111111
58533, 1.1, 1.4833333333333, 0.055555555555556
58534, 1.1, 1.5166666666667, 0.44444444444444
58535, 1.1, 1.5166666666667, 0.38888888888889
58536, 1.1, 1.5166666666667, 0.33333333333333
58537, 1.1, 1.5166666666667, 0.27777777777778
58538, 1.1, 1.5166666666667, 0.22222222222222
58539, 1.1, 1.5166666666667, 0.16666666666667
58540, 1.1, 1.5166666666667, 0.11111111111111
58541, 1.1, 1.5166666666667, 0.055555555555556
58542, 1.15, 1.4833333333333, 0.44444444444444
58543, 1.15, 1.4833333333333, 0.38888888888889
58544, 1.15, 1.4833333333333, 0.33333333333333
58545, 1.15, 1.4833333333333, 0.27777777777778
58546, 1.15, 1.4833333333333, 0.22222222222222
58547, 1.15, 1.4833333333333, 0.16666666666667
58548, 1.15, 1.4833333333333, 0.11111111111111
58549, 1.15, 1.4833333333333, 0.055555555555556
58550, 1.15, 1.5166666666667, 0.44444444444444
58551, 1.15, 1.5166666666667, 0.38888888888889
58552, 1.15, 1.5166666666667, 0.33333333333333
58553, 1.15, 1.5166666666667, 0.27777777777778
58554, 1.15, 1.5166666666667, 0.22222222222222
58555, 1.15, 1.5166666666667, 0.16666666666667
58556, 1.15, 1.5166666666667, 0.11111111111111
58557, 1.15, 1.5166666666667, 0.055555555555556
58558, 1.05, 1.4833333333333, 0.47222222222222
58559, 1.05, 1.4666666666667, 0.44444444444444
58560, 1.025, 1.4833333333333, 0.44444444444444
58561, 1.05, 1.4833333333333, 0.41666666666667
58562, 1.05, 1.4666666666667, 0.38888888888889
58563, 1.025, 1.4833333333333, 0.38888888888889
58564, 1.05, 1.4833333333333, 0.36111111111111
58565, 1.05, 1.4666666666667, 0.33333333333333
58566, 1.025, 1.4833333333333, 0.33333333333333
58567, 1.05, 1.4833333333333, 0.30555555555556
58568, 1.05, 1.4666666666667, 0.27777777777778
58569, 1.025, 1.4833333333333, 0.27777777777778
58570, 1.05, 1.4833333333333, 0.25
58571, 1.05, 1.4666666666667, 0.22222222222222
58572, 1.025, 1.4833333333333, 0.22222222222222
58573, 1.05, 1.4833333333333, 0.19444444444444
58574, 1.05, 1.4666666666667, 0.16666666666667
58575, 1.025, 1.4833333333333, 0.16666666666667
58576, 1.05, 1.4833333333333, 0.13888888888889
58577, 1.05, 1.4666666666667, 0.11111111111111
58578, 1.025, 1.4833333333333, 0.11111111111111
58579, 1.05, 1.4833333333333, 0.083333333333333
58580, 1.05, 1.4666666666667, 0.055555555555556
58581, 1.025, 1.4833333333333, 0.055555555555556
58582, 1.05, 1.4833333333333, 0.027777777777778
58583, 1.05, 1.5166666666667, 0.47222222222222
58584, 1.05, 1.5, 0.44444444444444
58585, 1.025, 1.5166666666667, 0.44444444444444
58586, 1.05, 1.5166666666667, 0.41666666666667
58587, 1.05, 1.5, 0.38888888888889
58588, 1.025, 1.5166666666667, 0.38888888888889
58589, 1.05, 1.5166666666667, 0.36111111111111
58590, 1.05, 1.5, 0.33333333333333
58591, 1.025, 1.5166666666667, 0.33333333333333
58592, 1.05, 1.5166666666667, 0.30555555555556
58593, 1.05, 1.5, 0.27777777777778
58594, 1.025, 1.5166666666667, 0.27777777777778
58595, 1.05, 1.5166666666667, 0.25
58596, 1.05, 1.5, 0.22222222222222
58597, 1.025, 1.5166666666667, 0.22222222222222
58598, 1.05, 1.5166666666667, 0.19444444444444
58599, 1.05, 1.5, 0.16666666666667
58600, 1.025, 1.5166666666667, 0.16666666666667
58601, 1.05, 1.5166666666667, 0.13888888888889
58602, 1.05, 1.5, 0.11111111111111
58603, 1.025, 1.5166666666667, 0.11111111111111
58604, 1.05, 1.5166666666667, 0.083333333333333
58605, 1.05, 1.5, 0.055555555555556
58606, 1.025, 1.5166666666667, 0.055555555555556
58607, 1.05, 1.5166666666667, 0.027777777777778
58608, 1.05, 1.5333333333333, 0.44444444444444
58609, 1.05, 1.5333333333333, 0.38888888888889
58610, 1.05, 1.5333333333333, 0.33333333333333
58611, 1.05, 1.5333333333333, 0.27777777777778
58612, 1.05, 1.5333333333333, 0.22222222222222
58613, 1.05, 1.5333333333333, 0.16666666666667
58614, 1.05, 1.5333333333333, 0.11111111111111
58615, 1.05, 1.5333333333333, 0.055555555555556
58616, 1.1, 1.4833333333333, 0.47222222222222
58617, 1.1, 1.4666666666667, 0.44444444444444
58618, 1.075, 1.4833333333333, 0.44444444444444
58619, 1.1, 1.4833333333333, 0.41666666666667
58620, 1.1, 1.4666666666667, 0.38888888888889
58621, 1.075, 1.4833333333333, 0.38888888888889
58622, 1.1, 1.4833333333333, 0.36111111111111
58623, 1.1, 1.4666666666667, 0.33333333333333
58624, 1.075, 1.4833333333333, 0.33333333333333
58625, 1.1, 1.4833333333333, 0.30555555555556
58626, 1.1, 1.4666666666667, 0.27777777777778
58627, 1.075, 1.4833333333333, 0.27777777777778
58628, 1.1, 1.4833333333333, 0.25
58629, 1.1, 1.4666666666667, 0.22222222222222
58630, 1.075, 1.4833333333333, 0.22222222222222
58631, 1.1, 1.4833333333333, 0.19444444444444
58632, 1.1, 1.4666666666667, 0.16666666666667
58633, 1.075, 1.4833333333333, 0.16666666666667
58634, 1.1, 1.4833333333333, 0.13888888888889
58635, 1.1, 1.4666666666667, 0.11111111111111
58636, 1.075, 1.4833333333333, 0.11111111111111
58637, 1.1, 1.4833333333333, 0.083333333333333
58638, 1.1, 1.4666666666667, 0.055555555555556
58639, 1.075, 1.4833333333333, 0.055555555555556
58640, 1.1, 1.4833333333333, 0.027777777777778
58641, 1.1, 1.5166666666667, 0.47222222222222
58642, 1.1, 1.5, 0.44444444444444
58643, 1.075, 1.5166666666667, 0.44444444444444
58644, 1.1, 1.5166666666667, 0.41666666666667
58645, 1.1, 1.5, 0.38888888888889
58646, 1.075, 1.5166666666667, 0.38888888888889
58647, 1.1, 1.5166666666667, 0.36111111111111
58648, 1.1, 1.5, 0.33333333333333
58649, 1.075, 1.5166666666667, 0.33333333333333
58650, 1.1, 1.5166666666667, 0.30555555555556
58651, 1.1, 1.5, 0.27777777777778
58652, 1.075, 1.5166666666667, 0.27777777777778
58653, 1.1, 1.5166666666667, 0.25
58654, 1.1, 1.5, 0.22222222222222
58655, 1.075, 1.5166666666667, 0.22222222222222
58656, 1.1, 1.5166666666667, 0.19444444444444
58657, 1.1, 1.5, 0.16666666666667
58658, 1.075, 1.5166666666667, 0.16666666666667
58659, 1.1, 1.5166666666667, 0.13888888888889
58660, 1.1, 1.5, 0.11111111111111
58661, 1.075, 1.5166666666667, 0.11111111111111
58662, 1.1, 1.5166666666667, 0.083333333333333
58663, 1.1, 1.5, 0.055555555555556
58664, 1.075, 1.5166666666667, 0.055555555555556
58665, 1.1, 1.5166666666667, 0.027777777777778
58666, 1.1, 1.5333333333333, 0.44444444444444
58667, 1.1, 1.5333333333333, 0.38888888888889
58668, 1.1, 1.5333333333333, 0.33333333333333
58669, 1.1, 1.5333333333333, 0.27777777777778
58670, 1.1, 1.5333333333333, 0.22222222222222
58671, 1.1, 1.5333333333333, 0.16666666666667
58672, 1.1, 1.5333333333333, 0.11111111111111
58673, 1.1, 1.5333333333333, 0.055555555555556
58674, 1.15, 1.4833333333333, 0.47222222222222
58675, 1.15, 1.4666666666667, 0.44444444444444
58676, 1.125, 1.4833333333333, 0.44444444444444
58677, 1.15, 1.4833333333333, 0.41666666666667
58678, 1.15, 1.4666666666667, 0.38888888888889
58679, 1.125, 1.4833333333333, 0.38888888888889
58680, 1.15, 1.4833333333333, 0.36111111111111
58681, 1.15, 1.4666666666667, 0.33333333333333
58682, 1.125, 1.4833333333333, 0.33333333333333
58683, 1.15, 1.4833333333333, 0.30555555555556
58684, 1.15, 1.4666666666667, 0.27777777777778
58685, 1.125, 1.4833333333333, 0.27777777777778
58686, 1.15, 1.4833333333333, 0.25
58687, 1.15, 1.4666666666667, 0.22222222222222
58688, 1.125, 1.4833333333333, 0.22222222222222
58689, 1.15, 1.4833333333333, 0.19444444444444
58690, 1.15, 1.4666666666667, 0.16666666666667
58691, 1.125, 1.4833333333333, 0.16666666666667
58692, 1.15, 1.4833333333333, 0.13888888888889
58693, 1.15, 1.4666666666667, 0.11111111111111
58694, 1.125, 1.4833333333333, 0.11111111111111
58695, 1.15, 1.4833333333333, 0.083333333333333
58696, 1.15, 1.4666666666667, 0.055555555555556
58697, 1.125, 1.4833333333333, 0.055555555555556
58698, 1.15, 1.4833333333333, 0.027777777777778
58699, 1.15, 1.5166666666667, 0.47222222222222
58700, 1.15, 1.5, 0.44444444444444
58701, 1.125, 1.5166666666667, 0.44444444444444
58702, 1.15, 1.5166666666667, 0.41666666666667
58703, 1.15, 1.5, 0.38888888888889
58704, 1.125, 1.5166666666667, 0.38888888888889
58705, 1.15, 1.5166666666667, 0.36111111111111
58706, 1.15, 1.5, 0.33333333333333
58707, 1.125, 1.5166666666667, 0.33333333333333
58708, 1.15, 1.5166666666667, 0.30555555555556
58709, 1.15, 1.5, 0.27777777777778
58710, 1.125, 1.5166666666667, 0.27777777777778
58711, 1.15, 1.5166666666667, 0.25
58712, 1.15, 1.5, 0.22222222222222
58713, 1.125, 1.5166666666667, 0.22222222222222
58714, 1.15, 1.5166666666667, 0.19444444444444
58715, 1.15, 1.5, 0.16666666666667
58716, 1.125, 1.5166666666667, 0.16666666666667
58717, 1.15, 1.5166666666667, 0.13888888888889
58718, 1.15, 1.5, 0.11111111111111
58719, 1.125, 1.5166666666667, 0.11111111111111
58720, 1.15, 1.5166666666667, 0.083333333333333
58721, 1.15, 1.5, 0.055555555555556
58722, 1.125, 1.5166666666667, 0.055555555555556
58723, 1.15, 1.5166666666667, 0.027777777777778
58724, 1.15, 1.5333333333333, 0.44444444444444
58725, 1.15, 1.5333333333333, 0.38888888888889
58726, 1.15, 1.5333333333333, 0.33333333333333
58727, 1.15, 1.5333333333333, 0.27777777777778
58728, 1.15, 1.5333333333333, 0.22222222222222
58729, 1.15, 1.5333333333333, 0.16666666666667
58730, 1.15, 1.5333333333333, 0.11111111111111
58731, 1.15, 1.5333333333333, 0.055555555555556
58732, 1.175, 1.4833333333333, 0.44444444444444
58733, 1.175, 1.4833333333333, 0.38888888888889
58734, 1.175, 1.4833333333333, 0.33333333333333
58735, 1.175, 1.4833333333333, 0.27777777777778
58736, 1.175, 1.4833333333333, 0.22222222222222
58737, 1.175, 1.4833333333333, 0.16666666666667
58738, 1.175, 1.4833333333333, 0.11111111111111
58739, 1.175, 1.4833333333333, 0.055555555555556
58740, 1.175, 1.5166666666667, 0.44444444444444
58741, 1.175, 1.5166666666667, 0.38888888888889
58742, 1.175, 1.5166666666667, 0.33333333333333
58743, 1.175, 1.5166666666667, 0.27777777777778
58744, 1.175, 1.5166666666667, 0.22222222222222
58745, 1.175, 1.5166666666667, 0.16666666666667
58746, 1.175, 1.5166666666667, 0.11111111111111
58747, 1.175, 1.5166666666667, 0.055555555555556
58748, 1.2434782608696, 1.4833333333333, 0.44444444444444
58749, 1.2434782608696, 1.4833333333333, 0.38888888888889
58750, 1.2434782608696, 1.4833333333333, 0.33333333333333
58751, 1.2434782608696, 1.4833333333333, 0.27777777777778
58752, 1.2434782608696, 1.4833333333333, 0.22222222222222
58753, 1.2434782608696, 1.4833333333333, 0.16666666666667
58754, 1.2434782608696, 1.4833333333333, 0.11111111111111
58755, 1.2434782608696, 1.4833333333333, 0.055555555555556
58756, 1.2434782608696, 1.5166666666667, 0.44444444444444
58757, 1.2434782608696, 1.5166666666667, 0.38888888888889
58758, 1.2434782608696, 1.5166666666667, 0.33333333333333
58759, 1.2434782608696, 1.5166666666667, 0.27777777777778
58760, 1.2434782608696, 1.5166666666667, 0.22222222222222
58761, 1.2434782608696, 1.5166666666667, 0.16666666666667
58762, 1.2434782608696, 1.5166666666667, 0.11111111111111
58763, 1.2434782608696, 1.5166666666667, 0.055555555555556
58764, 1.2869565217391, 1.4833333333333, 0.44444444444444
58765, 1.2869565217391, 1.4833333333333, 0.38888888888889
58766, 1.2869565217391, 1.4833333333333, 0.33333333333333
58767, 1.2869565217391, 1.4833333333333, 0.27777777777778
58768, 1.2869565217391, 1.4833333333333, 0.22222222222222
58769, 1.2869565217391, 1.4833333333333, 0.16666666666667
58770, 1.2869565217391, 1.4833333333333, 0.11111111111111
58771, 1.2869565217391, 1.4833333333333, 0.055555555555556
58772, 1.2869565217391, 1.5166666666667, 0.44444444444444
58773, 1.2869565217391, 1.5166666666667, 0.38888888888889
58774, 1.2869565217391, 1.5166666666667, 0.33333333333333
58775, 1.2869565217391, 1.5166666666667, 0.27777777777778
58776, 1.2869565217391, 1.5166666666667, 0.22222222222222
58777, 1.2869565217391, 1.5166666666667, 0.16666666666667
58778, 1.2869565217391, 1.5166666666667, 0.11111111111111
58779, 1.2869565217391, 1.5166666666667, 0.055555555555556
58780, 1.3304347826087, 1.4833333333333, 0.44444444444444
58781, 1.3304347826087, 1.4833333333333, 0.38888888888889
58782, 1.3304347826087, 1.4833333333333, 0.33333333333333
58783, 1.3304347826087, 1.4833333333333, 0.27777777777778
58784, 1.3304347826087, 1.4833333333333, 0.22222222222222
58785, 1.3304347826087, 1.4833333333333, 0.16666666666667
58786, 1.3304347826087, 1.4833333333333, 0.11111111111111
58787, 1.3304347826087, 1.4833333333333, 0.055555555555556
58788, 1.3304347826087, 1.5166666666667, 0.44444444444444
58789, 1.3304347826087, 1.5166666666667, 0.38888888888889
58790, 1.3304347826087, 1.5166666666667, 0.33333333333333
58791, 1.3304347826087, 1.5166666666667, 0.27777777777778
58792, 1.3304347826087, 1.5166666666667, 0.22222222222222
58793, 1.3304347826087, 1.5166666666667, 0.16666666666667
58794, 1.3304347826087, 1.5166666666667, 0.11111111111111
58795, 1.3304347826087, 1.5166666666667, 0.055555555555556
58796, 1.3739130434783, 1.4833333333333, 0.44444444444444
58797, 1.3739130434783, 1.4833333333333, 0.38888888888889
58798, 1.3739130434783, 1.4833333333333, 0.33333333333333
58799, 1.3739130434783, 1.4833333333333, 0.27777777777778
58800, 1.3739130434783, 1.4833333333333, 0.22222222222222
58801, 1.3739130434783, 1.4833333333333, 0.16666666666667
58802, 1.3739130434783, 1.4833333333333, 0.11111111111111
58803, 1.3739130434783, 1.4833333333333, 0.055555555555556
58804, 1.3739130434783, 1.5166666666667, 0.44444444444444
58805, 1.3739130434783, 1.5166666666667, 0.38888888888889
58806, 1.3739130434783, 1.5166666666667, 0.33333333333333
58807, 1.3739130434783, 1.5166666666667, 0.27777777777778
58808, 1.3739130434783, 1.5166666666667, 0.22222222222222
58809, 1.3739130434783, 1.5166666666667, 0.16666666666667
58810, 1.3739130434783, 1.5166666666667, 0.11111111111111
58811, 1.3739130434783, 1.5166666666667, 0.055555555555556
58812, 1.4173913043478, 1.4833333333333, 0.44444444444444
58813, 1.4173913043478, 1.4833333333333, 0.38888888888889
58814, 1.4173913043478, 1.4833333333333, 0.33333333333333
58815, 1.4173913043478, 1.4833333333333, 0.27777777777778
58816, 1.4173913043478, 1.4833333333333, 0.22222222222222
58817, 1.4173913043478, 1.4833333333333, 0.16666666666667
58818, 1.4173913043478, 1.4833333333333, 0.11111111111111
58819, 1.4173913043478, 1.4833333333333, 0.055555555555556
58820, 1.4173913043478, 1.5166666666667, 0.44444444444444
58821, 1.4173913043478, 1.5166666666667, 0.38888888888889
58822, 1.4173913043478, 1.5166666666667, 0.33333333333333
58823, 1.4173913043478, 1.5166666666667, 0.27777777777778
58824, 1.4173913043478, 1.5166666666667, 0.22222222222222
58825, 1.4173913043478, 1.5166666666667, 0.16666666666667
58826, 1.4173913043478, 1.5166666666667, 0.11111111111111
58827, 1.4173913043478, 1.5166666666667, 0.055555555555556
58828, 1.4608695652174, 1.4833333333333, 0.44444444444444
58829, 1.4608695652174, 1.4833333333333, 0.38888888888889
58830, 1.4608695652174, 1.4833333333333, 0.33333333333333
58831, 1.4608695652174, 1.4833333333333, 0.27777777777778
58832, 1.4608695652174, 1.4833333333333, 0.22222222222222
58833, 1.4608695652174, 1.4833333333333, 0.16666666666667
58834, 1.4608695652174, 1.4833333333333, 0.11111111111111
58835, 1.4608695652174, 1.4833333333333, 0.055555555555556
58836, 1.4608695652174, 1.5166666666667, 0.44444444444444
58837, 1.4608695652174, 1.5166666666667, 0.38888888888889
58838, 1.4608695652174, 1.5166666666667, 0.33333333333333
58839, 1.4608695652174, 1.5166666666667, 0.27777777777778
58840, 1.4608695652174, 1.5166666666667, 0.22222222222222
58841, 1.4608695652174, 1.5166666666667, 0.16666666666667
58842, 1.4608695652174, 1.5166666666667, 0.11111111111111
58843, 1.4608695652174, 1.5166666666667, 0.055555555555556
58844, 1.504347826087, 1.4833333333333, 0.44444444444444
58845, 1.504347826087, 1.4833333333333, 0.38888888888889
58846, 1.504347826087, 1.4833333333333, 0.33333333333333
58847, 1.504347826087, 1.4833333333333, 0.27777777777778
58848, 1.504347826087, 1.4833333333333, 0.22222222222222
58849, 1.504347826087, 1.4833333333333, 0.16666666666667
58850, 1.504347826087, 1.4833333333333, 0.11111111111111
58851, 1.504347826087, 1.4833333333333, 0.055555555555556
58852, 1.504347826087, 1.5166666666667, 0.44444444444444
58853, 1.504347826087, 1.5166666666667, 0.38888888888889
58854, 1.504347826087, 1.5166666666667, 0.33333333333333
58855, 1.504347826087, 1.5166666666667, 0.27777777777778
58856, 1.504347826087, 1.5166666666667, 0.22222222222222
58857, 1.504347826087, 1.5166666666667, 0.16666666666667
58858, 1.504347826087, 1.5166666666667, 0.11111111111111
58859, 1.504347826087, 1.5166666666667, 0.055555555555556
58860, 1.5478260869565, 1.4833333333333, 0.44444444444444
58861, 1.5478260869565, 1.4833333333333, 0.38888888888889
58862, 1.5478260869565, 1.4833333333333, 0.33333333333333
58863, 1.5478260869565, 1.4833333333333, 0.27777777777778
58864, 1.5478260869565, 1.4833333333333, 0.22222222222222
58865, 1.5478260869565, 1.4833333333333, 0.16666666666667
58866, 1.5478260869565, 1.4833333333333, 0.11111111111111
58867, 1.5478260869565, 1.4833333333333, 0.055555555555556
58868, 1.5478260869565, 1.5166666666667, 0.44444444444444
58869, 1.5478260869565, 1.5166666666667, 0.38888888888889
58870, 1.5478260869565, 1.5166666666667, 0.33333333333333
58871, 1.5478260869565, 1.5166666666667, 0.27777777777778
58872, 1.5478260869565, 1.5166666666667, 0.22222222222222
58873, 1.5478260869565, 1.5166666666667, 0.16666666666667
58874, 1.5478260869565, 1.5166666666667, 0.11111111111111
58875, 1.5478260869565, 1.5166666666667, 0.055555555555556
58876, 1.5913043478261, 1.4833333333333, 0.44444444444444
58877, 1.5913043478261, 1.4833333333333, 0.38888888888889
58878, 1.5913043478261, 1.4833333333333, 0.33333333333333
58879, 1.5913043478261, 1.4833333333333, 0.27777777777778
58880, 1.5913043478261, 1.4833333333333, 0.22222222222222
58881, 1.5913043478261, 1.4833333333333, 0.16666666666667
58882, 1.5913043478261, 1.4833333333333, 0.11111111111111
58883, 1.5913043478261, 1.4833333333333, 0.055555555555556
58884, 1.5913043478261, 1.5166666666667, 0.44444444444444
58885, 1.5913043478261, 1.5166666666667, 0.38888888888889
58886, 1.5913043478261, 1.5166666666667, 0.33333333333333
58887, 1.5913043478261, 1.5166666666667, 0.27777777777778
58888, 1.5913043478261, 1.5166666666667, 0.22222222222222
58889, 1.5913043478261, 1.5166666666667, 0.16666666666667
58890, 1.5913043478261, 1.5166666666667, 0.11111111111111
58891, 1.5913043478261, 1.5166666666667, 0.055555555555556
58892, 1.6347826086957, 1.4833333333333, 0.44444444444444
58893, 1.6347826086957, 1.4833333333333, 0.38888888888889
58894, 1.6347826086957, 1.4833333333333, 0.33333333333333
58895, 1.6347826086957, 1.4833333333333, 0.27777777777778
58896, 1.6347826086957, 1.4833333333333, 0.22222222222222
58897, 1.6347826086957, 1.4833333333333, 0.16666666666667
58898, 1.6347826086957, 1.4833333333333, 0.11111111111111
58899, 1.6347826086957, 1.4833333333333, 0.055555555555556
58900, 1.6347826086957, 1.5166666666667, 0.44444444444444
58901, 1.6347826086957, 1.5166666666667, 0.38888888888889
58902, 1.6347826086957, 1.5166666666667, 0.33333333333333
58903, 1.6347826086957, 1.5166666666667, 0.27777777777778
58904, 1.6347826086957, 1.5166666666667, 0.22222222222222
58905, 1.6347826086957, 1.5166666666667, 0.16666666666667
58906, 1.6347826086957, 1.5166666666667, 0.11111111111111
58907, 1.6347826086957, 1.5166666666667, 0.055555555555556
58908, 1.6782608695652, 1.4833333333333, 0.44444444444444
58909, 1.6782608695652, 1.4833333333333, 0.38888888888889
58910, 1.6782608695652, 1.4833333333333, 0.33333333333333
58911, 1.6782608695652, 1.4833333333333, 0.27777777777778
58912, 1.6782608695652, 1.4833333333333, 0.22222222222222
58913, 1.6782608695652, 1.4833333333333, 0.16666666666667
58914, 1.6782608695652, 1.4833333333333, 0.11111111111111
58915, 1.6782608695652, 1.4833333333333, 0.055555555555556
58916, 1.6782608695652, 1.5166666666667, 0.44444444444444
58917, 1.6782608695652, 1.5166666666667, 0.38888888888889
58918, 1.6782608695652, 1.5166666666667, 0.33333333333333
58919, 1.6782608695652, 1.5166666666667, 0.27777777777778
58920, 1.6782608695652, 1.5166666666667, 0.22222222222222
58921, 1.6782608695652, 1.5166666666667, 0.16666666666667
58922, 1.6782608695652, 1.5166666666667, 0.11111111111111
58923, 1.6782608695652, 1.5166666666667, 0.055555555555556
58924, 1.7217391304348, 1.4833333333333, 0.44444444444444
58925, 1.7217391304348, 1.4833333333333, 0.38888888888889
58926, 1.7217391304348, 1.4833333333333, 0.33333333333333
58927, 1.7217391304348, 1.4833333333333, 0.27777777777778
58928, 1.7217391304348, 1.4833333333333, 0.22222222222222
58929, 1.7217391304348, 1.4833333333333, 0.16666666666667
58930, 1.7217391304348, 1.4833333333333, 0.11111111111111
58931, 1.7217391304348, 1.4833333333333, 0.055555555555556
58932, 1.7217391304348, 1.5166666666667, 0.44444444444444
58933, 1.7217391304348, 1.5166666666667, 0.38888888888889
58934, 1.7217391304348, 1.5166666666667, 0.33333333333333
58935, 1.7217391304348, 1.5166666666667, 0.27777777777778
58936, 1.7217391304348, 1.5166666666667, 0.22222222222222
58937, 1.7217391304348, 1.5166666666667, 0.16666666666667
58938, 1.7217391304348, 1.5166666666667, 0.11111111111111
58939, 1.7217391304348, 1.5166666666667, 0.055555555555556
58940, 1.7652173913043, 1.4833333333333, 0.44444444444444
58941, 1.7652173913043, 1.4833333333333, 0.38888888888889
58942, 1.7652173913043, 1.4833333333333, 0.33333333333333
58943, 1.7652173913043, 1.4833333333333, 0.27777777777778
58944, 1.7652173913043, 1.4833333333333, 0.22222222222222
58945, 1.7652173913043, 1.4833333333333, 0.16666666666667
58946, 1.7652173913043, 1.4833333333333, 0.11111111111111
58947, 1.7652173913043, 1.4833333333333, 0.055555555555556
58948, 1.7652173913043, 1.5166666666667, 0.44444444444444
58949, 1.7652173913043, 1.5166666666667, 0.38888888888889
58950, 1.7652173913043, 1.5166666666667, 0.33333333333333
58951, 1.7652173913043, 1.5166666666667, 0.27777777777778
58952, 1.7652173913043, 1.5166666666667, 0.22222222222222
58953, 1.7652173913043, 1.5166666666667, 0.16666666666667
58954, 1.7652173913043, 1.5166666666667, 0.11111111111111
58955, 1.7652173913043, 1.5166666666667, 0.055555555555556
58956, 1.8086956521739, 1.4833333333333, 0.44444444444444
58957, 1.8086956521739, 1.4833333333333, 0.38888888888889
58958, 1.8086956521739, 1.4833333333333, 0.33333333333333
58959, 1.8086956521739, 1.4833333333333, 0.27777777777778
58960, 1.8086956521739, 1.4833333333333, 0.22222222222222
58961, 1.8086956521739, 1.4833333333333, 0.16666666666667
58962, 1.8086956521739, 1.4833333333333, 0.11111111111111
58963, 1.8086956521739, 1.4833333333333, 0.055555555555556
58964, 1.8086956521739, 1.5166666666667, 0.44444444444444
58965, 1.8086956521739, 1.5166666666667, 0.38888888888889
58966, 1.8086956521739, 1.5166666666667, 0.33333333333333
58967, 1.8086956521739, 1.5166666666667, 0.27777777777778
58968, 1.8086956521739, 1.5166666666667, 0.22222222222222
58969, 1.8086956521739, 1.5166666666667, 0.16666666666667
58970, 1.8086956521739, 1.5166666666667, 0.11111111111111
58971, 1.8086956521739, 1.5166666666667, 0.055555555555556
58972, 1.8521739130435, 1.4833333333333, 0.44444444444444
58973, 1.8521739130435, 1.4833333333333, 0.38888888888889
58974, 1.8521739130435, 1.4833333333333, 0.33333333333333
58975, 1.8521739130435, 1.4833333333333, 0.27777777777778
58976, 1.8521739130435, 1.4833333333333, 0.22222222222222
58977, 1.8521739130435, 1.4833333333333, 0.16666666666667
58978, 1.8521739130435, 1.4833333333333, 0.11111111111111
58979, 1.8521739130435, 1.4833333333333, 0.055555555555556
58980, 1.8521739130435, 1.5166666666667, 0.44444444444444
58981, 1.8521739130435, 1.5166666666667, 0.38888888888889
58982, 1.8521739130435, 1.5166666666667, 0.33333333333333
58983, 1.8521739130435, 1.5166666666667, 0.27777777777778
58984, 1.8521739130435, 1.5166666666667, 0.22222222222222
58985, 1.8521739130435, 1.5166666666667, 0.16666666666667
58986, 1.8521739130435, 1.5166666666667, 0.11111111111111
58987, 1.8521739130435, 1.5166666666667, 0.055555555555556
58988, 1.895652173913, 1.4833333333333, 0.44444444444444
58989, 1.895652173913, 1.4833333333333, 0.38888888888889
58990, 1.895652173913, 1.4833333333333, 0.33333333333333
58991, 1.895652173913, 1.4833333333333, 0.27777777777778
58992, 1.895652173913, 1.4833333333333, 0.22222222222222
58993, 1.895652173913, 1.4833333333333, 0.16666666666667
58994, 1.895652173913, 1.4833333333333, 0.11111111111111
58995, 1.895652173913, 1.4833333333333, 0.055555555555556
58996, 1.895652173913, 1.5166666666667, 0.44444444444444
58997, 1.895652173913, 1.5166666666667, 0.38888888888889
58998, 1.895652173913, 1.5166666666667, 0.33333333333333
58999, 1.895652173913, 1.5166666666667, 0.27777777777778
59000, 1.895652173913, 1.5166666666667, 0.22222222222222
59001, 1.895652173913, 1.5166666666667, 0.16666666666667
59002, 1.895652173913, 1.5166666666667, 0.11111111111111
59003, 1.895652173913, 1.5166666666667, 0.055555555555556
59004, 1.9391304347826, 1.4833333333333, 0.44444444444444
59005, 1.9391304347826, 1.4833333333333, 0.38888888888889
59006, 1.9391304347826, 1.4833333333333, 0.33333333333333
59007, 1.9391304347826, 1.4833333333333, 0.27777777777778
59008, 1.9391304347826, 1.4833333333333, 0.22222222222222
59009, 1.9391304347826, 1.4833333333333, 0.16666666666667
59010, 1.9391304347826, 1.4833333333333, 0.11111111111111
59011, 1.9391304347826, 1.4833333333333, 0.055555555555556
59012, 1.9391304347826, 1.5166666666667, 0.44444444444444
59013, 1.9391304347826, 1.5166666666667, 0.38888888888889
59014, 1.9391304347826, 1.5166666666667, 0.33333333333333
59015, 1.9391304347826, 1.5166666666667, 0.27777777777778
59016, 1.9391304347826, 1.5166666666667, 0.22222222222222
59017, 1.9391304347826, 1.5166666666667, 0.16666666666667
59018, 1.9391304347826, 1.5166666666667, 0.11111111111111
59019, 1.9391304347826, 1.5166666666667, 0.055555555555556
59020, 1.9826086956522, 1.4833333333333, 0.44444444444444
59021, 1.9826086956522, 1.4833333333333, 0.38888888888889
59022, 1.9826086956522, 1.4833333333333, 0.33333333333333
59023, 1.9826086956522, 1.4833333333333, 0.27777777777778
59024, 1.9826086956522, 1.4833333333333, 0.22222222222222
59025, 1.9826086956522, 1.4833333333333, 0.16666666666667
59026, 1.9826086956522, 1.4833333333333, 0.11111111111111
59027, 1.9826086956522, 1.4833333333333, 0.055555555555556
59028, 1.9826086956522, 1.5166666666667, 0.44444444444444
59029, 1.9826086956522, 1.5166666666667, 0.38888888888889
59030, 1.9826086956522, 1.5166666666667, 0.33333333333333
59031, 1.9826086956522, 1.5166666666667, 0.27777777777778
59032, 1.9826086956522, 1.5166666666667, 0.22222222222222
59033, 1.9826086956522, 1.5166666666667, 0.16666666666667
59034, 1.9826086956522, 1.5166666666667, 0.11111111111111
59035, 1.9826086956522, 1.5166666666667, 0.055555555555556
59036, 2.0260869565217, 1.4833333333333, 0.44444444444444
59037, 2.0260869565217, 1.4833333333333, 0.38888888888889
59038, 2.0260869565217, 1.4833333333333, 0.33333333333333
59039, 2.0260869565217, 1.4833333333333, 0.27777777777778
59040, 2.0260869565217, 1.4833333333333, 0.22222222222222
59041, 2.0260869565217, 1.4833333333333, 0.16666666666667
59042, 2.0260869565217, 1.4833333333333, 0.11111111111111
59043, 2.0260869565217, 1.4833333333333, 0.055555555555556
59044, 2.0260869565217, 1.5166666666667, 0.44444444444444
59045, 2.0260869565217, 1.5166666666667, 0.38888888888889
59046, 2.0260869565217, 1.5166666666667, 0.33333333333333
59047, 2.0260869565217, 1.5166666666667, 0.27777777777778
59048, 2.0260869565217, 1.5166666666667, 0.22222222222222
59049, 2.0260869565217, 1.5166666666667, 0.16666666666667
59050, 2.0260869565217, 1.5166666666667, 0.11111111111111
59051, 2.0260869565217, 1.5166666666667, 0.055555555555556
59052, 2.0695652173913, 1.4833333333333, 0.44444444444444
59053, 2.0695652173913, 1.4833333333333, 0.38888888888889
59054, 2.0695652173913, 1.4833333333333, 0.33333333333333
59055, 2.0695652173913, 1.4833333333333, 0.27777777777778
59056, 2.0695652173913, 1.4833333333333, 0.22222222222222
59057, 2.0695652173913, 1.4833333333333, 0.16666666666667
59058, 2.0695652173913, 1.4833333333333, 0.11111111111111
59059, 2.0695652173913, 1.4833333333333, 0.055555555555556
59060, 2.0695652173913, 1.5166666666667, 0.44444444444444
59061, 2.0695652173913, 1.5166666666667, 0.38888888888889
59062, 2.0695652173913, 1.5166666666667, 0.33333333333333
59063, 2.0695652173913, 1.5166666666667, 0.27777777777778
59064, 2.0695652173913, 1.5166666666667, 0.22222222222222
59065, 2.0695652173913, 1.5166666666667, 0.16666666666667
59066, 2.0695652173913, 1.5166666666667, 0.11111111111111
59067, 2.0695652173913, 1.5166666666667, 0.055555555555556
59068, 2.1130434782609, 1.4833333333333, 0.44444444444444
59069, 2.1130434782609, 1.4833333333333, 0.38888888888889
59070, 2.1130434782609, 1.4833333333333, 0.33333333333333
59071, 2.1130434782609, 1.4833333333333, 0.27777777777778
59072, 2.1130434782609, 1.4833333333333, 0.22222222222222
59073, 2.1130434782609, 1.4833333333333, 0.16666666666667
59074, 2.1130434782609, 1.4833333333333, 0.11111111111111
59075, 2.1130434782609, 1.4833333333333, 0.055555555555556
59076, 2.1130434782609, 1.5166666666667, 0.44444444444444
59077, 2.1130434782609, 1.5166666666667, 0.38888888888889
59078, 2.1130434782609, 1.5166666666667, 0.33333333333333
59079, 2.1130434782609, 1.5166666666667, 0.27777777777778
59080, 2.1130434782609, 1.5166666666667, 0.22222222222222
59081, 2.1130434782609, 1.5166666666667, 0.16666666666667
59082, 2.1130434782609, 1.5166666666667, 0.11111111111111
59083, 2.1130434782609, 1.5166666666667, 0.055555555555556
59084, 2.1565217391304, 1.4833333333333, 0.44444444444444
59085, 2.1565217391304, 1.4833333333333, 0.38888888888889
59086, 2.1565217391304, 1.4833333333333, 0.33333333333333
59087, 2.1565217391304, 1.4833333333333, 0.27777777777778
59088, 2.1565217391304, 1.4833333333333, 0.22222222222222
59089, 2.1565217391304, 1.4833333333333, 0.16666666666667
59090, 2.1565217391304, 1.4833333333333, 0.11111111111111
59091, 2.1565217391304, 1.4833333333333, 0.055555555555556
59092, 2.1565217391304, 1.5166666666667, 0.44444444444444
59093, 2.1565217391304, 1.5166666666667, 0.38888888888889
59094, 2.1565217391304, 1.5166666666667, 0.33333333333333
59095, 2.1565217391304, 1.5166666666667, 0.27777777777778
59096, 2.1565217391304, 1.5166666666667, 0.22222222222222
59097, 2.1565217391304, 1.5166666666667, 0.16666666666667
59098, 2.1565217391304, 1.5166666666667, 0.11111111111111
59099, 2.1565217391304, 1.5166666666667, 0.055555555555556
59100, 1.2434782608696, 1.4833333333333, 0.47222222222222
59101, 1.2434782608696, 1.4666666666667, 0.44444444444444
59102, 1.2217391304348, 1.4833333333333, 0.44444444444444
59103, 1.2434782608696, 1.4833333333333, 0.41666666666667
59104, 1.2434782608696, 1.4666666666667, 0.38888888888889
59105, 1.2217391304348, 1.4833333333333, 0.38888888888889
59106, 1.2434782608696, 1.4833333333333, 0.36111111111111
59107, 1.2434782608696, 1.4666666666667, 0.33333333333333
59108, 1.2217391304348, 1.4833333333333, 0.33333333333333
59109, 1.2434782608696, 1.4833333333333, 0.30555555555556
59110, 1.2434782608696, 1.4666666666667, 0.27777777777778
59111, 1.2217391304348, 1.4833333333333, 0.27777777777778
59112, 1.2434782608696, 1.4833333333333, 0.25
59113, 1.2434782608696, 1.4666666666667, 0.22222222222222
59114, 1.2217391304348, 1.4833333333333, 0.22222222222222
59115, 1.2434782608696, 1.4833333333333, 0.19444444444444
59116, 1.2434782608696, 1.4666666666667, 0.16666666666667
59117, 1.2217391304348, 1.4833333333333, 0.16666666666667
59118, 1.2434782608696, 1.4833333333333, 0.13888888888889
59119, 1.2434782608696, 1.4666666666667, 0.11111111111111
59120, 1.2217391304348, 1.4833333333333, 0.11111111111111
59121, 1.2434782608696, 1.4833333333333, 0.083333333333333
59122, 1.2434782608696, 1.4666666666667, 0.055555555555556
59123, 1.2217391304348, 1.4833333333333, 0.055555555555556
59124, 1.2434782608696, 1.4833333333333, 0.027777777777778
59125, 1.2434782608696, 1.5166666666667, 0.47222222222222
59126, 1.2434782608696, 1.5, 0.44444444444444
59127, 1.2217391304348, 1.5166666666667, 0.44444444444444
59128, 1.2434782608696, 1.5166666666667, 0.41666666666667
59129, 1.2434782608696, 1.5, 0.38888888888889
59130, 1.2217391304348, 1.5166666666667, 0.38888888888889
59131, 1.2434782608696, 1.5166666666667, 0.36111111111111
59132, 1.2434782608696, 1.5, 0.33333333333333
59133, 1.2217391304348, 1.5166666666667, 0.33333333333333
59134, 1.2434782608696, 1.5166666666667, 0.30555555555556
59135, 1.2434782608696, 1.5, 0.27777777777778
59136, 1.2217391304348, 1.5166666666667, 0.27777777777778
59137, 1.2434782608696, 1.5166666666667, 0.25
59138, 1.2434782608696, 1.5, 0.22222222222222
59139, 1.2217391304348, 1.5166666666667, 0.22222222222222
59140, 1.2434782608696, 1.5166666666667, 0.19444444444444
59141, 1.2434782608696, 1.5, 0.16666666666667
59142, 1.2217391304348, 1.5166666666667, 0.16666666666667
59143, 1.2434782608696, 1.5166666666667, 0.13888888888889
59144, 1.2434782608696, 1.5, 0.11111111111111
59145, 1.2217391304348, 1.5166666666667, 0.11111111111111
59146, 1.2434782608696, 1.5166666666667, 0.083333333333333
59147, 1.2434782608696, 1.5, 0.055555555555556
59148, 1.2217391304348, 1.5166666666667, 0.055555555555556
59149, 1.2434782608696, 1.5166666666667, 0.027777777777778
59150, 1.2434782608696, 1.5333333333333, 0.44444444444444
59151, 1.2434782608696, 1.5333333333333, 0.38888888888889
59152, 1.2434782608696, 1.5333333333333, 0.33333333333333
59153, 1.2434782608696, 1.5333333333333, 0.27777777777778
59154, 1.2434782608696, 1.5333333333333, 0.22222222222222
59155, 1.2434782608696, 1.5333333333333, 0.16666666666667
59156, 1.2434782608696, 1.5333333333333, 0.11111111111111
59157, 1.2434782608696, 1.5333333333333, 0.055555555555556
59158, 1.2869565217391, 1.4833333333333, 0.47222222222222
59159, 1.2869565217391, 1.4666666666667, 0.44444444444444
59160, 1.2652173913043, 1.4833333333333, 0.44444444444444
59161, 1.2869565217391, 1.4833333333333, 0.41666666666667
59162, 1.2869565217391, 1.4666666666667, 0.38888888888889
59163, 1.2652173913043, 1.4833333333333, 0.38888888888889
59164, 1.2869565217391, 1.4833333333333, 0.36111111111111
59165, 1.2869565217391, 1.4666666666667, 0.33333333333333
59166, 1.2652173913043, 1.4833333333333, 0.33333333333333
59167, 1.2869565217391, 1.4833333333333, 0.30555555555556
59168, 1.2869565217391, 1.4666666666667, 0.27777777777778
59169, 1.2652173913043, 1.4833333333333, 0.27777777777778
59170, 1.2869565217391, 1.4833333333333, 0.25
59171, 1.2869565217391, 1.4666666666667, 0.22222222222222
59172, 1.2652173913043, 1.4833333333333, 0.22222222222222
59173, 1.2869565217391, 1.4833333333333, 0.19444444444444
59174, 1.2869565217391, 1.4666666666667, 0.16666666666667
59175, 1.2652173913043, 1.4833333333333, 0.16666666666667
59176, 1.2869565217391, 1.4833333333333, 0.13888888888889
59177, 1.2869565217391, 1.4666666666667, 0.11111111111111
59178, 1.2652173913043, 1.4833333333333, 0.11111111111111
59179, 1.2869565217391, 1.4833333333333, 0.083333333333333
59180, 1.2869565217391, 1.4666666666667, 0.055555555555556
59181, 1.2652173913043, 1.4833333333333, 0.055555555555556
59182, 1.2869565217391, 1.4833333333333, 0.027777777777778
59183, 1.2869565217391, 1.5166666666667, 0.47222222222222
59184, 1.2869565217391, 1.5, 0.44444444444444
59185, 1.2652173913043, 1.5166666666667, 0.44444444444444
59186, 1.2869565217391, 1.5166666666667, 0.41666666666667
59187, 1.2869565217391, 1.5, 0.38888888888889
59188, 1.2652173913043, 1.5166666666667, 0.38888888888889
59189, 1.2869565217391, 1.5166666666667, 0.36111111111111
59190, 1.2869565217391, 1.5, 0.33333333333333
59191, 1.2652173913043, 1.5166666666667, 0.33333333333333
59192, 1.2869565217391, 1.5166666666667, 0.30555555555556
59193, 1.2869565217391, 1.5, 0.27777777777778
59194, 1.2652173913043, 1.5166666666667, 0.27777777777778
59195, 1.2869565217391, 1.5166666666667, 0.25
59196, 1.2869565217391, 1.5, 0.22222222222222
59197, 1.2652173913043, 1.5166666666667, 0.22222222222222
59198, 1.2869565217391, 1.5166666666667, 0.19444444444444
59199, 1.2869565217391, 1.5, 0.16666666666667
59200, 1.2652173913043, 1.5166666666667, 0.16666666666667
59201, 1.2869565217391, 1.5166666666667, 0.13888888888889
59202, 1.2869565217391, 1.5, 0.11111111111111
59203, 1.2652173913043, 1.5166666666667, 0.11111111111111
59204, 1.2869565217391, 1.5166666666667, 0.083333333333333
59205, 1.2869565217391, 1.5, 0.055555555555556
59206, 1.2652173913043, 1.5166666666667, 0.055555555555556
59207, 1.2869565217391, 1.5166666666667, 0.027777777777778
59208, 1.2869565217391, 1.5333333333333, 0.44444444444444
59209, 1.2869565217391, 1.5333333333333, 0.38888888888889
59210, 1.2869565217391, 1.5333333333333, 0.33333333333333
59211, 1.2869565217391, 1.5333333333333, 0.27777777777778
59212, 1.2869565217391, 1.5333333333333, 0.22222222222222
59213, 1.2869565217391, 1.5333333333333, 0.16666666666667
59214, 1.2869565217391, 1.5333333333333, 0.11111111111111
59215, 1.2869565217391, 1.5333333333333, 0.055555555555556
59216, 1.3304347826087, 1.4833333333333, 0.47222222222222
59217, 1.3304347826087, 1.4666666666667, 0.44444444444444
59218, 1.3086956521739, 1.4833333333333, 0.44444444444444
59219, 1.3304347826087, 1.4833333333333, 0.41666666666667
59220, 1.3304347826087, 1.4666666666667, 0.38888888888889
59221, 1.3086956521739, 1.4833333333333, 0.38888888888889
59222, 1.3304347826087, 1.4833333333333, 0.36111111111111
59223, 1.3304347826087, 1.4666666666667, 0.33333333333333
59224, 1.3086956521739, 1.4833333333333, 0.33333333333333
59225, 1.3304347826087, 1.4833333333333, 0.30555555555556
59226, 1.3304347826087, 1.4666666666667, 0.27777777777778
59227, 1.3086956521739, 1.4833333333333, 0.27777777777778
59228, 1.3304347826087, 1.4833333333333, 0.25
59229, 1.3304347826087, 1.4666666666667, 0.22222222222222
59230, 1.3086956521739, 1.4833333333333, 0.22222222222222
59231, 1.3304347826087, 1.4833333333333, 0.19444444444444
59232, 1.3304347826087, 1.4666666666667, 0.16666666666667
59233, 1.3086956521739, 1.4833333333333, 0.16666666666667
59234, 1.3304347826087, 1.4833333333333, 0.13888888888889
59235, 1.3304347826087, 1.4666666666667, 0.11111111111111
59236, 1.3086956521739, 1.4833333333333, 0.11111111111111
59237, 1.3304347826087, 1.4833333333333, 0.083333333333333
59238, 1.3304347826087, 1.4666666666667, 0.055555555555556
59239, 1.3086956521739, 1.4833333333333, 0.055555555555556
59240, 1.3304347826087, 1.4833333333333, 0.027777777777778
59241, 1.3304347826087, 1.5166666666667, 0.47222222222222
59242, 1.3304347826087, 1.5, 0.44444444444444
59243, 1.3086956521739, 1.5166666666667, 0.44444444444444
59244, 1.3304347826087, 1.5166666666667, 0.41666666666667
59245, 1.3304347826087, 1.5, 0.38888888888889
59246, 1.3086956521739, 1.5166666666667, 0.38888888888889
59247, 1.3304347826087, 1.5166666666667, 0.36111111111111
59248, 1.3304347826087, 1.5, 0.33333333333333
59249, 1.3086956521739, 1.5166666666667, 0.33333333333333
59250, 1.3304347826087, 1.5166666666667, 0.30555555555556
59251, 1.3304347826087, 1.5, 0.27777777777778
59252, 1.3086956521739, 1.5166666666667, 0.27777777777778
59253, 1.3304347826087, 1.5166666666667, 0.25
59254, 1.3304347826087, 1.5, 0.22222222222222
59255, 1.3086956521739, 1.5166666666667, 0.22222222222222
59256, 1.3304347826087, 1.5166666666667, 0.19444444444444
59257, 1.3304347826087, 1.5, 0.16666666666667
59258, 1.3086956521739, 1.5166666666667, 0.16666666666667
59259, 1.3304347826087, 1.5166666666667, 0.13888888888889
59260, 1.3304347826087, 1.5, 0.11111111111111
59261, 1.3086956521739, 1.5166666666667, 0.11111111111111
59262, 1.3304347826087, 1.5166666666667, 0.083333333333333
59263, 1.3304347826087, 1.5, 0.055555555555556
59264, 1.3086956521739, 1.5166666666667, 0.055555555555556
59265, 1.3304347826087, 1.5166666666667, 0.027777777777778
59266, 1.3304347826087, 1.5333333333333, 0.44444444444444
59267, 1.3304347826087, 1.5333333333333, 0.38888888888889
59268, 1.3304347826087, 1.5333333333333, 0.33333333333333
59269, 1.3304347826087, 1.5333333333333, 0.27777777777778
59270, 1.3304347826087, 1.5333333333333, 0.22222222222222
59271, 1.3304347826087, 1.5333333333333, 0.16666666666667
59272, 1.3304347826087, 1.5333333333333, 0.11111111111111
59273, 1.3304347826087, 1.5333333333333, 0.055555555555556
59274, 1.3739130434783, 1.4833333333333, 0.47222222222222
59275, 1.3739130434783, 1.4666666666667, 0.44444444444444
59276, 1.3521739130435, 1.4833333333333, 0.44444444444444
59277, 1.3739130434783, 1.4833333333333, 0.41666666666667
59278, 1.3739130434783, 1.4666666666667, 0.38888888888889
59279, 1.3521739130435, 1.4833333333333, 0.38888888888889
59280, 1.3739130434783, 1.4833333333333, 0.36111111111111
59281, 1.3739130434783, 1.4666666666667, 0.33333333333333
59282, 1.3521739130435, 1.4833333333333, 0.33333333333333
59283, 1.3739130434783, 1.4833333333333, 0.30555555555556
59284, 1.3739130434783, 1.4666666666667, 0.27777777777778
59285, 1.3521739130435, 1.4833333333333, 0.27777777777778
59286, 1.3739130434783, 1.4833333333333, 0.25
59287, 1.3739130434783, 1.4666666666667, 0.22222222222222
59288, 1.3521739130435, 1.4833333333333, 0.22222222222222
59289, 1.3739130434783, 1.4833333333333, 0.19444444444444
59290, 1.3739130434783, 1.4666666666667, 0.16666666666667
59291, 1.3521739130435, 1.4833333333333, 0.16666666666667
59292, 1.3739130434783, 1.4833333333333, 0.13888888888889
59293, 1.3739130434783, 1.4666666666667, 0.11111111111111
59294, 1.3521739130435, 1.4833333333333, 0.11111111111111
59295, 1.3739130434783, 1.4833333333333, 0.083333333333333
59296, 1.3739130434783, 1.4666666666667, 0.055555555555556
59297, 1.3521739130435, 1.4833333333333, 0.055555555555556
59298, 1.3739130434783, 1.4833333333333, 0.027777777777778
59299, 1.3739130434783, 1.5166666666667, 0.47222222222222
59300, 1.3739130434783, 1.5, 0.44444444444444
59301, 1.3521739130435, 1.5166666666667, 0.44444444444444
59302, 1.3739130434783, 1.5166666666667, 0.41666666666667
59303, 1.3739130434783, 1.5, 0.38888888888889
59304, 1.3521739130435, 1.5166666666667, 0.38888888888889
59305, 1.3739130434783, 1.5166666666667, 0.36111111111111
59306, 1.3739130434783, 1.5, 0.33333333333333
59307, 1.3521739130435, 1.5166666666667, 0.33333333333333
59308, 1.3739130434783, 1.5166666666667, 0.30555555555556
59309, 1.3739130434783, 1.5, 0.27777777777778
59310, 1.3521739130435, 1.5166666666667, 0.27777777777778
59311, 1.3739130434783, 1.5166666666667, 0.25
59312, 1.3739130434783, 1.5, 0.22222222222222
59313, 1.3521739130435, 1.5166666666667, 0.22222222222222
59314, 1.3739130434783, 1.5166666666667, 0.19444444444444
59315, 1.3739130434783, 1.5, 0.16666666666667
59316, 1.3521739130435, 1.5166666666667, 0.16666666666667
59317, 1.3739130434783, 1.5166666666667, 0.13888888888889
59318, 1.3739130434783, 1.5, 0.11111111111111
59319, 1.3521739130435, 1.5166666666667, 0.11111111111111
59320, 1.3739130434783, 1.5166666666667, 0.083333333333333
59321, 1.3739130434783, 1.5, 0.055555555555556
59322, 1.3521739130435, 1.5166666666667, 0.055555555555556
59323, 1.3739130434783, 1.5166666666667, 0.027777777777778
59324, 1.3739130434783, 1.5333333333333, 0.44444444444444
59325, 1.3739130434783, 1.5333333333333, 0.38888888888889
59326, 1.3739130434783, 1.5333333333333, 0.33333333333333
59327, 1.3739130434783, 1.5333333333333, 0.27777777777778
59328, 1.3739130434783, 1.5333333333333, 0.22222222222222
59329, 1.3739130434783, 1.5333333333333, 0.16666666666667
59330, 1.3739130434783, 1.5333333333333, 0.11111111111111
59331, 1.3739130434783, 1.5333333333333, 0.055555555555556
59332, 1.4173913043478, 1.4833333333333, 0.47222222222222
59333, 1.4173913043478, 1.4666666666667, 0.44444444444444
59334, 1.395652173913, 1.4833333333333, 0.44444444444444
59335, 1.4173913043478, 1.4833333333333, 0.41666666666667
59336, 1.4173913043478, 1.4666666666667, 0.38888888888889
59337, 1.395652173913, 1.4833333333333, 0.38888888888889
59338, 1.4173913043478, 1.4833333333333, 0.36111111111111
59339, 1.4173913043478, 1.4666666666667, 0.33333333333333
59340, 1.395652173913, 1.4833333333333, 0.33333333333333
59341, 1.4173913043478, 1.4833333333333, 0.30555555555556
59342, 1.4173913043478, 1.4666666666667, 0.27777777777778
59343, 1.395652173913, 1.4833333333333, 0.27777777777778
59344, 1.4173913043478, 1.4833333333333, 0.25
59345, 1.4173913043478, 1.4666666666667, 0.22222222222222
59346, 1.395652173913, 1.4833333333333, 0.22222222222222
59347, 1.4173913043478, 1.4833333333333, 0.19444444444444
59348, 1.4173913043478, 1.4666666666667, 0.16666666666667
59349, 1.395652173913, 1.4833333333333, 0.16666666666667
59350, 1.4173913043478, 1.4833333333333, 0.13888888888889
59351, 1.4173913043478, 1.4666666666667, 0.11111111111111
59352, 1.395652173913, 1.4833333333333, 0.11111111111111
59353, 1.4173913043478, 1.4833333333333, 0.083333333333333
59354, 1.4173913043478, 1.4666666666667, 0.055555555555556
59355, 1.395652173913, 1.4833333333333, 0.055555555555556
59356, 1.4173913043478, 1.4833333333333, 0.027777777777778
59357, 1.4173913043478, 1.5166666666667, 0.47222222222222
59358, 1.4173913043478, 1.5, 0.44444444444444
59359, 1.395652173913, 1.5166666666667, 0.44444444444444
59360, 1.4173913043478, 1.5166666666667, 0.41666666666667
59361, 1.4173913043478, 1.5, 0.38888888888889
59362, 1.395652173913, 1.5166666666667, 0.38888888888889
59363, 1.4173913043478, 1.5166666666667, 0.36111111111111
59364, 1.4173913043478, 1.5, 0.33333333333333
59365, 1.395652173913, 1.5166666666667, 0.33333333333333
59366, 1.4173913043478, 1.5166666666667, 0.30555555555556
59367, 1.4173913043478, 1.5, 0.27777777777778
59368, 1.395652173913, 1.5166666666667, 0.27777777777778
59369, 1.4173913043478, 1.5166666666667, 0.25
59370, 1.4173913043478, 1.5, 0.22222222222222
59371, 1.395652173913, 1.5166666666667, 0.22222222222222
59372, 1.4173913043478, 1.5166666666667, 0.19444444444444
59373, 1.4173913043478, 1.5, 0.16666666666667
59374, 1.395652173913, 1.5166666666667, 0.16666666666667
59375, 1.4173913043478, 1.5166666666667, 0.13888888888889
59376, 1.4173913043478, 1.5, 0.11111111111111
59377, 1.395652173913, 1.5166666666667, 0.11111111111111
59378, 1.4173913043478, 1.5166666666667, 0.083333333333333
59379, 1.4173913043478, 1.5, 0.055555555555556
59380, 1.395652173913, 1.5166666666667, 0.055555555555556
59381, 1.4173913043478, 1.5166666666667, 0.027777777777778
59382, 1.4173913043478, 1.5333333333333, 0.44444444444444
59383, 1.4173913043478, 1.5333333333333, 0.38888888888889
59384, 1.4173913043478, 1.5333333333333, 0.33333333333333
59385, 1.4173913043478, 1.5333333333333, 0.27777777777778
59386, 1.4173913043478, 1.5333333333333, 0.22222222222222
59387, 1.4173913043478, 1.5333333333333, 0.16666666666667
59388, 1.4173913043478, 1.5333333333333, 0.11111111111111
59389, 1.4173913043478, 1.5333333333333, 0.055555555555556
59390, 1.4608695652174, 1.4833333333333, 0.47222222222222
59391, 1.4608695652174, 1.4666666666667, 0.44444444444444
59392, 1.4391304347826, 1.4833333333333, 0.44444444444444
59393, 1.4608695652174, 1.4833333333333, 0.41666666666667
59394, 1.4608695652174, 1.4666666666667, 0.38888888888889
59395, 1.4391304347826, 1.4833333333333, 0.38888888888889
59396, 1.4608695652174, 1.4833333333333, 0.36111111111111
59397, 1.4608695652174, 1.4666666666667, 0.33333333333333
59398, 1.4391304347826, 1.4833333333333, 0.33333333333333
59399, 1.4608695652174, 1.4833333333333, 0.30555555555556
59400, 1.4608695652174, 1.4666666666667, 0.27777777777778
59401, 1.4391304347826, 1.4833333333333, 0.27777777777778
59402, 1.4608695652174, 1.4833333333333, 0.25
59403, 1.4608695652174, 1.4666666666667, 0.22222222222222
59404, 1.4391304347826, 1.4833333333333, 0.22222222222222
59405, 1.4608695652174, 1.4833333333333, 0.19444444444444
59406, 1.4608695652174, 1.4666666666667, 0.16666666666667
59407, 1.4391304347826, 1.4833333333333, 0.16666666666667
59408, 1.4608695652174, 1.4833333333333, 0.13888888888889
59409, 1.4608695652174, 1.4666666666667, 0.11111111111111
59410, 1.4391304347826, 1.4833333333333, 0.11111111111111
59411, 1.4608695652174, 1.4833333333333, 0.083333333333333
59412, 1.4608695652174, 1.4666666666667, 0.055555555555556
59413, 1.4391304347826, 1.4833333333333, 0.055555555555556
59414, 1.4608695652174, 1.4833333333333, 0.027777777777778
59415, 1.4608695652174, 1.5166666666667, 0.47222222222222
59416, 1.4608695652174, 1.5, 0.44444444444444
59417, 1.4391304347826, 1.5166666666667, 0.44444444444444
59418, 1.4608695652174, 1.5166666666667, 0.41666666666667
59419, 1.4608695652174, 1.5, 0.38888888888889
59420, 1.4391304347826, 1.5166666666667, 0.38888888888889
59421, 1.4608695652174, 1.5166666666667, 0.36111111111111
59422, 1.4608695652174, 1.5, 0.33333333333333
59423, 1.4391304347826, 1.5166666666667, 0.33333333333333
59424, 1.4608695652174, 1.5166666666667, 0.30555555555556
59425, 1.4608695652174, 1.5, 0.27777777777778
59426, 1.4391304347826, 1.5166666666667, 0.27777777777778
59427, 1.4608695652174, 1.5166666666667, 0.25
59428, 1.4608695652174, 1.5, 0.22222222222222
59429, 1.4391304347826, 1.5166666666667, 0.22222222222222
59430, 1.4608695652174, 1.5166666666667, 0.19444444444444
59431, 1.4608695652174, 1.5, 0.16666666666667
59432, 1.4391304347826, 1.5166666666667, 0.16666666666667
59433, 1.4608695652174, 1.5166666666667, 0.13888888888889
59434, 1.4608695652174, 1.5, 0.11111111111111
59435, 1.4391304347826, 1.5166666666667, 0.11111111111111
59436, 1.4608695652174, 1.5166666666667, 0.083333333333333
59437, 1.4608695652174, 1.5, 0.055555555555556
59438, 1.4391304347826, 1.5166666666667, 0.055555555555556
59439, 1.4608695652174, 1.5166666666667, 0.027777777777778
59440, 1.4608695652174, 1.5333333333333, 0.44444444444444
59441, 1.4608695652174, 1.5333333333333, 0.38888888888889
59442, 1.4608695652174, 1.5333333333333, 0.33333333333333
59443, 1.4608695652174, 1.5333333333333, 0.27777777777778
59444, 1.4608695652174, 1.5333333333333, 0.22222222222222
59445, 1.4608695652174, 1.5333333333333, 0.16666666666667
59446, 1.4608695652174, 1.5333333333333, 0.11111111111111
59447, 1.4608695652174, 1.5333333333333, 0.055555555555556
59448, 1.504347826087, 1.4833333333333, 0.47222222222222
59449, 1.504347826087, 1.4666666666667, 0.44444444444444
59450, 1.4826086956522, 1.4833333333333, 0.44444444444444
59451, 1.504347826087, 1.4833333333333, 0.41666666666667
59452, 1.504347826087, 1.4666666666667, 0.38888888888889
59453, 1.4826086956522, 1.4833333333333, 0.38888888888889
59454, 1.504347826087, 1.4833333333333, 0.36111111111111
59455, 1.504347826087, 1.4666666666667, 0.33333333333333
59456, 1.4826086956522, 1.4833333333333, 0.33333333333333
59457, 1.504347826087, 1.4833333333333, 0.30555555555556
59458, 1.504347826087, 1.4666666666667, 0.27777777777778
59459, 1.4826086956522, 1.4833333333333, 0.27777777777778
59460, 1.504347826087, 1.4833333333333, 0.25
59461, 1.504347826087, 1.4666666666667, 0.22222222222222
59462, 1.4826086956522, 1.4833333333333, 0.22222222222222
59463, 1.504347826087, 1.4833333333333, 0.19444444444444
59464, 1.504347826087, 1.4666666666667, 0.16666666666667
59465, 1.4826086956522, 1.4833333333333, 0.16666666666667
59466, 1.504347826087, 1.4833333333333, 0.13888888888889
59467, 1.504347826087, 1.4666666666667, 0.11111111111111
59468, 1.4826086956522, 1.4833333333333, 0.11111111111111
59469, 1.504347826087, 1.4833333333333, 0.083333333333333
59470, 1.504347826087, 1.4666666666667, 0.055555555555556
59471, 1.4826086956522, 1.4833333333333, 0.055555555555556
59472, 1.504347826087, 1.4833333333333, 0.027777777777778
59473, 1.504347826087, 1.5166666666667, 0.47222222222222
59474, 1.504347826087, 1.5, 0.44444444444444
59475, 1.4826086956522, 1.5166666666667, 0.44444444444444
59476, 1.504347826087, 1.5166666666667, 0.41666666666667
59477, 1.504347826087, 1.5, 0.38888888888889
59478, 1.4826086956522, 1.5166666666667, 0.38888888888889
59479, 1.504347826087, 1.5166666666667, 0.36111111111111
59480, 1.504347826087, 1.5, 0.33333333333333
59481, 1.4826086956522, 1.5166666666667, 0.33333333333333
59482, 1.504347826087, 1.5166666666667, 0.30555555555556
59483, 1.504347826087, 1.5, 0.27777777777778
59484, 1.4826086956522, 1.5166666666667, 0.27777777777778
59485, 1.504347826087, 1.5166666666667, 0.25
59486, 1.504347826087, 1.5, 0.22222222222222
59487, 1.4826086956522, 1.5166666666667, 0.22222222222222
59488, 1.504347826087, 1.5166666666667, 0.19444444444444
59489, 1.504347826087, 1.5, 0.16666666666667
59490, 1.4826086956522, 1.5166666666667, 0.16666666666667
59491, 1.504347826087, 1.5166666666667, 0.13888888888889
59492, 1.504347826087, 1.5, 0.11111111111111
59493, 1.4826086956522, 1.5166666666667, 0.11111111111111
59494, 1.504347826087, 1.5166666666667, 0.083333333333333
59495, 1.504347826087, 1.5, 0.055555555555556
59496, 1.4826086956522, 1.5166666666667, 0.055555555555556
59497, 1.504347826087, 1.5166666666667, 0.027777777777778
59498, 1.504347826087, 1.5333333333333, 0.44444444444444
59499, 1.504347826087, 1.5333333333333, 0.38888888888889
59500, 1.504347826087, 1.5333333333333, 0.33333333333333
59501, 1.504347826087, 1.5333333333333, 0.27777777777778
59502, 1.504347826087, 1.5333333333333, 0.22222222222222
59503, 1.504347826087, 1.5333333333333, 0.16666666666667
59504, 1.504347826087, 1.5333333333333, 0.11111111111111
59505, 1.504347826087, 1.5333333333333, 0.055555555555556
59506, 1.5478260869565, 1.4833333333333, 0.47222222222222
59507, 1.5478260869565, 1.4666666666667, 0.44444444444444
59508, 1.5260869565217, 1.4833333333333, 0.44444444444444
59509, 1.5478260869565, 1.4833333333333, 0.41666666666667
59510, 1.5478260869565, 1.4666666666667, 0.38888888888889
59511, 1.5260869565217, 1.4833333333333, 0.38888888888889
59512, 1.5478260869565, 1.4833333333333, 0.36111111111111
59513, 1.5478260869565, 1.4666666666667, 0.33333333333333
59514, 1.5260869565217, 1.4833333333333, 0.33333333333333
59515, 1.5478260869565, 1.4833333333333, 0.30555555555556
59516, 1.5478260869565, 1.4666666666667, 0.27777777777778
59517, 1.5260869565217, 1.4833333333333, 0.27777777777778
59518, 1.5478260869565, 1.4833333333333, 0.25
59519, 1.5478260869565, 1.4666666666667, 0.22222222222222
59520, 1.5260869565217, 1.4833333333333, 0.22222222222222
59521, 1.5478260869565, 1.4833333333333, 0.19444444444444
59522, 1.5478260869565, 1.4666666666667, 0.16666666666667
59523, 1.5260869565217, 1.4833333333333, 0.16666666666667
59524, 1.5478260869565, 1.4833333333333, 0.13888888888889
59525, 1.5478260869565, 1.4666666666667, 0.11111111111111
59526, 1.5260869565217, 1.4833333333333, 0.11111111111111
59527, 1.5478260869565, 1.4833333333333, 0.083333333333333
59528, 1.5478260869565, 1.4666666666667, 0.055555555555556
59529, 1.5260869565217, 1.4833333333333, 0.055555555555556
59530, 1.5478260869565, 1.4833333333333, 0.027777777777778
59531, 1.5478260869565, 1.5166666666667, 0.47222222222222
59532, 1.5478260869565, 1.5, 0.44444444444444
59533, 1.5260869565217, 1.5166666666667, 0.44444444444444
59534, 1.5478260869565, 1.5166666666667, 0.41666666666667
59535, 1.5478260869565, 1.5, 0.38888888888889
59536, 1.5260869565217, 1.5166666666667, 0.38888888888889
59537, 1.5478260869565, 1.5166666666667, 0.36111111111111
59538, 1.5478260869565, 1.5, 0.33333333333333
59539, 1.5260869565217, 1.5166666666667, 0.33333333333333
59540, 1.5478260869565, 1.5166666666667, 0.30555555555556
59541, 1.5478260869565, 1.5, 0.27777777777778
59542, 1.5260869565217, 1.5166666666667, 0.27777777777778
59543, 1.5478260869565, 1.5166666666667, 0.25
59544, 1.5478260869565, 1.5, 0.22222222222222
59545, 1.5260869565217, 1.5166666666667, 0.22222222222222
59546, 1.5478260869565, 1.5166666666667, 0.19444444444444
59547, 1.5478260869565, 1.5, 0.16666666666667
59548, 1.5260869565217, 1.5166666666667, 0.16666666666667
59549, 1.5478260869565, 1.5166666666667, 0.13888888888889
59550, 1.5478260869565, 1.5, 0.11111111111111
59551, 1.5260869565217, 1.5166666666667, 0.11111111111111
59552, 1.5478260869565, 1.5166666666667, 0.083333333333333
59553, 1.5478260869565, 1.5, 0.055555555555556
59554, 1.5260869565217, 1.5166666666667, 0.055555555555556
59555, 1.5478260869565, 1.5166666666667, 0.027777777777778
59556, 1.5478260869565, 1.5333333333333, 0.44444444444444
59557, 1.5478260869565, 1.5333333333333, 0.38888888888889
59558, 1.5478260869565, 1.5333333333333, 0.33333333333333
59559, 1.5478260869565, 1.5333333333333, 0.27777777777778
59560, 1.5478260869565, 1.5333333333333, 0.22222222222222
59561, 1.5478260869565, 1.5333333333333, 0.16666666666667
59562, 1.5478260869565, 1.5333333333333, 0.11111111111111
59563, 1.5478260869565, 1.5333333333333, 0.055555555555556
59564, 1.5913043478261, 1.4833333333333, 0.47222222222222
59565, 1.5913043478261, 1.4666666666667, 0.44444444444444
59566, 1.5695652173913, 1.4833333333333, 0.44444444444444
59567, 1.5913043478261, 1.4833333333333, 0.41666666666667
59568, 1.5913043478261, 1.4666666666667, 0.38888888888889
59569, 1.5695652173913, 1.4833333333333, 0.38888888888889
59570, 1.5913043478261, 1.4833333333333, 0.36111111111111
59571, 1.5913043478261, 1.4666666666667, 0.33333333333333
59572, 1.5695652173913, 1.4833333333333, 0.33333333333333
59573, 1.5913043478261, 1.4833333333333, 0.30555555555556
59574, 1.5913043478261, 1.4666666666667, 0.27777777777778
59575, 1.5695652173913, 1.4833333333333, 0.27777777777778
59576, 1.5913043478261, 1.4833333333333, 0.25
59577, 1.5913043478261, 1.4666666666667, 0.22222222222222
59578, 1.5695652173913, 1.4833333333333, 0.22222222222222
59579, 1.5913043478261, 1.4833333333333, 0.19444444444444
59580, 1.5913043478261, 1.4666666666667, 0.16666666666667
59581, 1.5695652173913, 1.4833333333333, 0.16666666666667
59582, 1.5913043478261, 1.4833333333333, 0.13888888888889
59583, 1.5913043478261, 1.4666666666667, 0.11111111111111
59584, 1.5695652173913, 1.4833333333333, 0.11111111111111
59585, 1.5913043478261, 1.4833333333333, 0.083333333333333
59586, 1.5913043478261, 1.4666666666667, 0.055555555555556
59587, 1.5695652173913, 1.4833333333333, 0.055555555555556
59588, 1.5913043478261, 1.4833333333333, 0.027777777777778
59589, 1.5913043478261, 1.5166666666667, 0.47222222222222
59590, 1.5913043478261, 1.5, 0.44444444444444
59591, 1.5695652173913, 1.5166666666667, 0.44444444444444
59592, 1.5913043478261, 1.5166666666667, 0.41666666666667
59593, 1.5913043478261, 1.5, 0.38888888888889
59594, 1.5695652173913, 1.5166666666667, 0.38888888888889
59595, 1.5913043478261, 1.5166666666667, 0.36111111111111
59596, 1.5913043478261, 1.5, 0.33333333333333
59597, 1.5695652173913, 1.5166666666667, 0.33333333333333
59598, 1.5913043478261, 1.5166666666667, 0.30555555555556
59599, 1.5913043478261, 1.5, 0.27777777777778
59600, 1.5695652173913, 1.5166666666667, 0.27777777777778
59601, 1.5913043478261, 1.5166666666667, 0.25
59602, 1.5913043478261, 1.5, 0.22222222222222
59603, 1.5695652173913, 1.5166666666667, 0.22222222222222
59604, 1.5913043478261, 1.5166666666667, 0.19444444444444
59605, 1.5913043478261, 1.5, 0.16666666666667
59606, 1.5695652173913, 1.5166666666667, 0.16666666666667
59607, 1.5913043478261, 1.5166666666667, 0.13888888888889
59608, 1.5913043478261, 1.5, 0.11111111111111
59609, 1.5695652173913, 1.5166666666667, 0.11111111111111
59610, 1.5913043478261, 1.5166666666667, 0.083333333333333
59611, 1.5913043478261, 1.5, 0.055555555555556
59612, 1.5695652173913, 1.5166666666667, 0.055555555555556
59613, 1.5913043478261, 1.5166666666667, 0.027777777777778
59614, 1.5913043478261, 1.5333333333333, 0.44444444444444
59615, 1.5913043478261, 1.5333333333333, 0.38888888888889
59616, 1.5913043478261, 1.5333333333333, 0.33333333333333
59617, 1.5913043478261, 1.5333333333333, 0.27777777777778
59618, 1.5913043478261, 1.5333333333333, 0.22222222222222
59619, 1.5913043478261, 1.5333333333333, 0.16666666666667
59620, 1.5913043478261, 1.5333333333333, 0.11111111111111
59621, 1.5913043478261, 1.5333333333333, 0.055555555555556
59622, 1.6347826086957, 1.4833333333333, 0.47222222222222
59623, 1.6347826086957, 1.4666666666667, 0.44444444444444
59624, 1.6130434782609, 1.4833333333333, 0.44444444444444
59625, 1.6347826086957, 1.4833333333333, 0.41666666666667
59626, 1.6347826086957, 1.4666666666667, 0.38888888888889
59627, 1.6130434782609, 1.4833333333333, 0.38888888888889
59628, 1.6347826086957, 1.4833333333333, 0.36111111111111
59629, 1.6347826086957, 1.4666666666667, 0.33333333333333
59630, 1.6130434782609, 1.4833333333333, 0.33333333333333
59631, 1.6347826086957, 1.4833333333333, 0.30555555555556
59632, 1.6347826086957, 1.4666666666667, 0.27777777777778
59633, 1.6130434782609, 1.4833333333333, 0.27777777777778
59634, 1.6347826086957, 1.4833333333333, 0.25
59635, 1.6347826086957, 1.4666666666667, 0.22222222222222
59636, 1.6130434782609, 1.4833333333333, 0.22222222222222
59637, 1.6347826086957, 1.4833333333333, 0.19444444444444
59638, 1.6347826086957, 1.4666666666667, 0.16666666666667
59639, 1.6130434782609, 1.4833333333333, 0.16666666666667
59640, 1.6347826086957, 1.4833333333333, 0.13888888888889
59641, 1.6347826086957, 1.4666666666667, 0.11111111111111
59642, 1.6130434782609, 1.4833333333333, 0.11111111111111
59643, 1.6347826086957, 1.4833333333333, 0.083333333333333
59644, 1.6347826086957, 1.4666666666667, 0.055555555555556
59645, 1.6130434782609, 1.4833333333333, 0.055555555555556
59646, 1.6347826086957, 1.4833333333333, 0.027777777777778
59647, 1.6347826086957, 1.5166666666667, 0.47222222222222
59648, 1.6347826086957, 1.5, 0.44444444444444
59649, 1.6130434782609, 1.5166666666667, 0.44444444444444
59650, 1.6347826086957, 1.5166666666667, 0.41666666666667
59651, 1.6347826086957, 1.5, 0.38888888888889
59652, 1.6130434782609, 1.5166666666667, 0.38888888888889
59653, 1.6347826086957, 1.5166666666667, 0.36111111111111
59654, 1.6347826086957, 1.5, 0.33333333333333
59655, 1.6130434782609, 1.5166666666667, 0.33333333333333
59656, 1.6347826086957, 1.5166666666667, 0.30555555555556
59657, 1.6347826086957, 1.5, 0.27777777777778
59658, 1.6130434782609, 1.5166666666667, 0.27777777777778
59659, 1.6347826086957, 1.5166666666667, 0.25
59660, 1.6347826086957, 1.5, 0.22222222222222
59661, 1.6130434782609, 1.5166666666667, 0.22222222222222
59662, 1.6347826086957, 1.5166666666667, 0.19444444444444
59663, 1.6347826086957, 1.5, 0.16666666666667
59664, 1.6130434782609, 1.5166666666667, 0.16666666666667
59665, 1.6347826086957, 1.5166666666667, 0.13888888888889
59666, 1.6347826086957, 1.5, 0.11111111111111
59667, 1.6130434782609, 1.5166666666667, 0.11111111111111
59668, 1.6347826086957, 1.5166666666667, 0.083333333333333
59669, 1.6347826086957, 1.5, 0.055555555555556
59670, 1.6130434782609, 1.5166666666667, 0.055555555555556
59671, 1.6347826086957, 1.5166666666667, 0.027777777777778
59672, 1.6347826086957, 1.5333333333333, 0.44444444444444
59673, 1.6347826086957, 1.5333333333333, 0.38888888888889
59674, 1.6347826086957, 1.5333333333333, 0.33333333333333
59675, 1.6347826086957, 1.5333333333333, 0.27777777777778
59676, 1.6347826086957, 1.5333333333333, 0.22222222222222
59677, 1.6347826086957, 1.5333333333333, 0.16666666666667
59678, 1.6347826086957, 1.5333333333333, 0.11111111111111
59679, 1.6347826086957, 1.5333333333333, 0.055555555555556
59680, 1.6782608695652, 1.4833333333333, 0.47222222222222
59681, 1.6782608695652, 1.4666666666667, 0.44444444444444
59682, 1.6565217391304, 1.4833333333333, 0.44444444444444
59683, 1.6782608695652, 1.4833333333333, 0.41666666666667
59684, 1.6782608695652, 1.4666666666667, 0.38888888888889
59685, 1.6565217391304, 1.4833333333333, 0.38888888888889
59686, 1.6782608695652, 1.4833333333333, 0.36111111111111
59687, 1.6782608695652, 1.4666666666667, 0.33333333333333
59688, 1.6565217391304, 1.4833333333333, 0.33333333333333
59689, 1.6782608695652, 1.4833333333333, 0.30555555555556
59690, 1.6782608695652, 1.4666666666667, 0.27777777777778
59691, 1.6565217391304, 1.4833333333333, 0.27777777777778
59692, 1.6782608695652, 1.4833333333333, 0.25
59693, 1.6782608695652, 1.4666666666667, 0.22222222222222
59694, 1.6565217391304, 1.4833333333333, 0.22222222222222
59695, 1.6782608695652, 1.4833333333333, 0.19444444444444
59696, 1.6782608695652, 1.4666666666667, 0.16666666666667
59697, 1.6565217391304, 1.4833333333333, 0.16666666666667
59698, 1.6782608695652, 1.4833333333333, 0.13888888888889
59699, 1.6782608695652, 1.4666666666667, 0.11111111111111
59700, 1.6565217391304, 1.4833333333333, 0.11111111111111
59701, 1.6782608695652, 1.4833333333333, 0.083333333333333
59702, 1.6782608695652, 1.4666666666667, 0.055555555555556
59703, 1.6565217391304, 1.4833333333333, 0.055555555555556
59704, 1.6782608695652, 1.4833333333333, 0.027777777777778
59705, 1.6782608695652, 1.5166666666667, 0.47222222222222
59706, 1.6782608695652, 1.5, 0.44444444444444
59707, 1.6565217391304, 1.5166666666667, 0.44444444444444
59708, 1.6782608695652, 1.5166666666667, 0.41666666666667
59709, 1.6782608695652, 1.5, 0.38888888888889
59710, 1.6565217391304, 1.5166666666667, 0.38888888888889
59711, 1.6782608695652, 1.5166666666667, 0.36111111111111
59712, 1.6782608695652, 1.5, 0.33333333333333
59713, 1.6565217391304, 1.5166666666667, 0.33333333333333
59714, 1.6782608695652, 1.5166666666667, 0.30555555555556
59715, 1.6782608695652, 1.5, 0.27777777777778
59716, 1.6565217391304, 1.5166666666667, 0.27777777777778
59717, 1.6782608695652, 1.5166666666667, 0.25
59718, 1.6782608695652, 1.5, 0.22222222222222
59719, 1.6565217391304, 1.5166666666667, 0.22222222222222
59720, 1.6782608695652, 1.5166666666667, 0.19444444444444
59721, 1.6782608695652, 1.5, 0.16666666666667
59722, 1.6565217391304, 1.5166666666667, 0.16666666666667
59723, 1.6782608695652, 1.5166666666667, 0.13888888888889
59724, 1.6782608695652, 1.5, 0.11111111111111
59725, 1.6565217391304, 1.5166666666667, 0.11111111111111
59726, 1.6782608695652, 1.5166666666667, 0.083333333333333
59727, 1.6782608695652, 1.5, 0.055555555555556
59728, 1.6565217391304, 1.5166666666667, 0.055555555555556
59729, 1.6782608695652, 1.5166666666667, 0.027777777777778
59730, 1.6782608695652, 1.5333333333333, 0.44444444444444
59731, 1.6782608695652, 1.5333333333333, 0.38888888888889
59732, 1.6782608695652, 1.5333333333333, 0.33333333333333
59733, 1.6782608695652, 1.5333333333333, 0.27777777777778
59734, 1.6782608695652, 1.5333333333333, 0.22222222222222
59735, 1.6782608695652, 1.5333333333333, 0.16666666666667
59736, 1.6782608695652, 1.5333333333333, 0.11111111111111
59737, 1.6782608695652, 1.5333333333333, 0.055555555555556
59738, 1.7217391304348, 1.4833333333333, 0.47222222222222
59739, 1.7217391304348, 1.4666666666667, 0.44444444444444
59740, 1.7, 1.4833333333333, 0.44444444444444
59741, 1.7217391304348, 1.4833333333333, 0.41666666666667
59742, 1.7217391304348, 1.4666666666667, 0.38888888888889
59743, 1.7, 1.4833333333333, 0.38888888888889
59744, 1.7217391304348, 1.4833333333333, 0.36111111111111
59745, 1.7217391304348, 1.4666666666667, 0.33333333333333
59746, 1.7, 1.4833333333333, 0.33333333333333
59747, 1.7217391304348, 1.4833333333333, 0.30555555555556
59748, 1.7217391304348, 1.4666666666667, 0.27777777777778
59749, 1.7, 1.4833333333333, 0.27777777777778
59750, 1.7217391304348, 1.4833333333333, 0.25
59751, 1.7217391304348, 1.4666666666667, 0.22222222222222
59752, 1.7, 1.4833333333333, 0.22222222222222
59753, 1.7217391304348, 1.4833333333333, 0.19444444444444
59754, 1.7217391304348, 1.4666666666667, 0.16666666666667
59755, 1.7, 1.4833333333333, 0.16666666666667
59756, 1.7217391304348, 1.4833333333333, 0.13888888888889
59757, 1.7217391304348, 1.4666666666667, 0.11111111111111
59758, 1.7, 1.4833333333333, 0.11111111111111
59759, 1.7217391304348, 1.4833333333333, 0.083333333333333
59760, 1.7217391304348, 1.4666666666667, 0.055555555555556
59761, 1.7, 1.4833333333333, 0.055555555555556
59762, 1.7217391304348, 1.4833333333333, 0.027777777777778
59763, 1.7217391304348, 1.5166666666667, 0.47222222222222
59764, 1.7217391304348, 1.5, 0.44444444444444
59765, 1.7, 1.5166666666667, 0.44444444444444
59766, 1.7217391304348, 1.5166666666667, 0.41666666666667
59767, 1.7217391304348, 1.5, 0.38888888888889
59768, 1.7, 1.5166666666667, 0.38888888888889
59769, 1.7217391304348, 1.5166666666667, 0.36111111111111
59770, 1.7217391304348, 1.5, 0.33333333333333
59771, 1.7, 1.5166666666667, 0.33333333333333
59772, 1.7217391304348, 1.5166666666667, 0.30555555555556
59773, 1.7217391304348, 1.5, 0.27777777777778
59774, 1.7, 1.5166666666667, 0.27777777777778
59775, 1.7217391304348, 1.5166666666667, 0.25
59776, 1.7217391304348, 1.5, 0.22222222222222
59777, 1.7, 1.5166666666667, 0.22222222222222
59778, 1.7217391304348, 1.5166666666667, 0.19444444444444
59779, 1.7217391304348, 1.5, 0.16666666666667
59780, 1.7, 1.5166666666667, 0.16666666666667
59781, 1.7217391304348, 1.5166666666667, 0.13888888888889
59782, 1.7217391304348, 1.5, 0.11111111111111
59783, 1.7, 1.5166666666667, 0.11111111111111
59784, 1.7217391304348, 1.5166666666667, 0.083333333333333
59785, 1.7217391304348, 1.5, 0.055555555555556
59786, 1.7, 1.5166666666667, 0.055555555555556
59787, 1.7217391304348, 1.5166666666667, 0.027777777777778
59788, 1.7217391304348, 1.5333333333333, 0.44444444444444
59789, 1.7217391304348, 1.5333333333333, 0.38888888888889
59790, 1.7217391304348, 1.5333333333333, 0.33333333333333
59791, 1.7217391304348, 1.5333333333333, 0.27777777777778
59792, 1.7217391304348, 1.5333333333333, 0.22222222222222
59793, 1.7217391304348, 1.5333333333333, 0.16666666666667
59794, 1.7217391304348, 1.5333333333333, 0.11111111111111
59795, 1.7217391304348, 1.5333333333333, 0.055555555555556
59796, 1.7652173913043, 1.4833333333333, 0.47222222222222
59797, 1.7652173913043, 1.4666666666667, 0.44444444444444
59798, 1.7434782608696, 1.4833333333333, 0.44444444444444
59799, 1.7652173913043, 1.4833333333333, 0.41666666666667
59800, 1.7652173913043, 1.4666666666667, 0.38888888888889
59801, 1.7434782608696, 1.4833333333333, 0.38888888888889
59802, 1.7652173913043, 1.4833333333333, 0.36111111111111
59803, 1.7652173913043, 1.4666666666667, 0.33333333333333
59804, 1.7434782608696, 1.4833333333333, 0.33333333333333
59805, 1.7652173913043, 1.4833333333333, 0.30555555555556
59806, 1.7652173913043, 1.4666666666667, 0.27777777777778
59807, 1.7434782608696, 1.4833333333333, 0.27777777777778
59808, 1.7652173913043, 1.4833333333333, 0.25
59809, 1.7652173913043, 1.4666666666667, 0.22222222222222
59810, 1.7434782608696, 1.4833333333333, 0.22222222222222
59811, 1.7652173913043, 1.4833333333333, 0.19444444444444
59812, 1.7652173913043, 1.4666666666667, 0.16666666666667
59813, 1.7434782608696, 1.4833333333333, 0.16666666666667
59814, 1.7652173913043, 1.4833333333333, 0.13888888888889
59815, 1.7652173913043, 1.4666666666667, 0.11111111111111
59816, 1.7434782608696, 1.4833333333333, 0.11111111111111
59817, 1.7652173913043, 1.4833333333333, 0.083333333333333
59818, 1.7652173913043, 1.4666666666667, 0.055555555555556
59819, 1.7434782608696, 1.4833333333333, 0.055555555555556
59820, 1.7652173913043, 1.4833333333333, 0.027777777777778
59821, 1.7652173913043, 1.5166666666667, 0.47222222222222
59822, 1.7652173913043, 1.5, 0.44444444444444
59823, 1.7434782608696, 1.5166666666667, 0.44444444444444
59824, 1.7652173913043, 1.5166666666667, 0.41666666666667
59825, 1.7652173913043, 1.5, 0.38888888888889
59826, 1.7434782608696, 1.5166666666667, 0.38888888888889
59827, 1.7652173913043, 1.5166666666667, 0.36111111111111
59828, 1.7652173913043, 1.5, 0.33333333333333
59829, 1.7434782608696, 1.5166666666667, 0.33333333333333
59830, 1.7652173913043, 1.5166666666667, 0.30555555555556
59831, 1.7652173913043, 1.5, 0.27777777777778
59832, 1.7434782608696, 1.5166666666667, 0.27777777777778
59833, 1.7652173913043, 1.5166666666667, 0.25
59834, 1.7652173913043, 1.5, 0.22222222222222
59835, 1.7434782608696, 1.5166666666667, 0.22222222222222
59836, 1.7652173913043, 1.5166666666667, 0.19444444444444
59837, 1.7652173913043, 1.5, 0.16666666666667
59838, 1.7434782608696, 1.5166666666667, 0.16666666666667
59839, 1.7652173913043, 1.5166666666667, 0.13888888888889
59840, 1.7652173913043, 1.5, 0.11111111111111
59841, 1.7434782608696, 1.5166666666667, 0.11111111111111
59842, 1.7652173913043, 1.5166666666667, 0.083333333333333
59843, 1.7652173913043, 1.5, 0.055555555555556
59844, 1.7434782608696, 1.5166666666667, 0.055555555555556
59845, 1.7652173913043, 1.5166666666667, 0.027777777777778
59846, 1.7652173913043, 1.5333333333333, 0.44444444444444
59847, 1.7652173913043, 1.5333333333333, 0.38888888888889
59848, 1.7652173913043, 1.5333333333333, 0.33333333333333
59849, 1.7652173913043, 1.5333333333333, 0.27777777777778
59850, 1.7652173913043, 1.5333333333333, 0.22222222222222
59851, 1.7652173913043, 1.5333333333333, 0.16666666666667
59852, 1.7652173913043, 1.5333333333333, 0.11111111111111
59853, 1.7652173913043, 1.5333333333333, 0.055555555555556
59854, 1.8086956521739, 1.4833333333333, 0.47222222222222
59855, 1.8086956521739, 1.4666666666667, 0.44444444444444
59856, 1.7869565217391, 1.4833333333333, 0.44444444444444
59857, 1.8086956521739, 1.4833333333333, 0.41666666666667
59858, 1.8086956521739, 1.4666666666667, 0.38888888888889
59859, 1.7869565217391, 1.4833333333333, 0.38888888888889
59860, 1.8086956521739, 1.4833333333333, 0.36111111111111
59861, 1.8086956521739, 1.4666666666667, 0.33333333333333
59862, 1.7869565217391, 1.4833333333333, 0.33333333333333
59863, 1.8086956521739, 1.4833333333333, 0.30555555555556
59864, 1.8086956521739, 1.4666666666667, 0.27777777777778
59865, 1.7869565217391, 1.4833333333333, 0.27777777777778
59866, 1.8086956521739, 1.4833333333333, 0.25
59867, 1.8086956521739, 1.4666666666667, 0.22222222222222
59868, 1.7869565217391, 1.4833333333333, 0.22222222222222
59869, 1.8086956521739, 1.4833333333333, 0.19444444444444
59870, 1.8086956521739, 1.4666666666667, 0.16666666666667
59871, 1.7869565217391, 1.4833333333333, 0.16666666666667
59872, 1.8086956521739, 1.4833333333333, 0.13888888888889
59873, 1.8086956521739, 1.4666666666667, 0.11111111111111
59874, 1.7869565217391, 1.4833333333333, 0.11111111111111
59875, 1.8086956521739, 1.4833333333333, 0.083333333333333
59876, 1.8086956521739, 1.4666666666667, 0.055555555555556
59877, 1.7869565217391, 1.4833333333333, 0.055555555555556
59878, 1.8086956521739, 1.4833333333333, 0.027777777777778
59879, 1.8086956521739, 1.5166666666667, 0.47222222222222
59880, 1.8086956521739, 1.5, 0.44444444444444
59881, 1.7869565217391, 1.5166666666667, 0.44444444444444
59882, 1.8086956521739, 1.5166666666667, 0.41666666666667
59883, 1.8086956521739, 1.5, 0.38888888888889
59884, 1.7869565217391, 1.5166666666667, 0.38888888888889
59885, 1.8086956521739, 1.5166666666667, 0.36111111111111
59886, 1.8086956521739, 1.5, 0.33333333333333
59887, 1.7869565217391, 1.5166666666667, 0.33333333333333
59888, 1.8086956521739, 1.5166666666667, 0.30555555555556
59889, 1.8086956521739, 1.5, 0.27777777777778
59890, 1.7869565217391, 1.5166666666667, 0.27777777777778
59891, 1.8086956521739, 1.5166666666667, 0.25
59892, 1.8086956521739, 1.5, 0.22222222222222
59893, 1.7869565217391, 1.5166666666667, 0.22222222222222
59894, 1.8086956521739, 1.5166666666667, 0.19444444444444
59895, 1.8086956521739, 1.5, 0.16666666666667
59896, 1.7869565217391, 1.5166666666667, 0.16666666666667
59897, 1.8086956521739, 1.5166666666667, 0.13888888888889
59898, 1.8086956521739, 1.5, 0.11111111111111
59899, 1.7869565217391, 1.5166666666667, 0.11111111111111
59900, 1.8086956521739, 1.5166666666667, 0.083333333333333
59901, 1.8086956521739, 1.5, 0.055555555555556
59902, 1.7869565217391, 1.5166666666667, 0.055555555555556
59903, 1.8086956521739, 1.5166666666667, 0.027777777777778
59904, 1.8086956521739, 1.5333333333333, 0.44444444444444
59905, 1.8086956521739, 1.5333333333333, 0.38888888888889
59906, 1.8086956521739, 1.5333333333333, 0.33333333333333
59907, 1.8086956521739, 1.5333333333333, 0.27777777777778
59908, 1.8086956521739, 1.5333333333333, 0.22222222222222
59909, 1.8086956521739, 1.5333333333333, 0.16666666666667
59910, 1.8086956521739, 1.5333333333333, 0.11111111111111
59911, 1.8086956521739, 1.5333333333333, 0.055555555555556
59912, 1.8521739130435, 1.4833333333333, 0.47222222222222
59913, 1.8521739130435, 1.4666666666667, 0.44444444444444
59914, 1.8304347826087, 1.4833333333333, 0.44444444444444
59915, 1.8521739130435, 1.4833333333333, 0.41666666666667
59916, 1.8521739130435, 1.4666666666667, 0.38888888888889
59917, 1.8304347826087, 1.4833333333333, 0.38888888888889
59918, 1.8521739130435, 1.4833333333333, 0.36111111111111
59919, 1.8521739130435, 1.4666666666667, 0.33333333333333
59920, 1.8304347826087, 1.4833333333333, 0.33333333333333
59921, 1.8521739130435, 1.4833333333333, 0.30555555555556
59922, 1.8521739130435, 1.4666666666667, 0.27777777777778
59923, 1.8304347826087, 1.4833333333333, 0.27777777777778
59924, 1.8521739130435, 1.4833333333333, 0.25
59925, 1.8521739130435, 1.4666666666667, 0.22222222222222
59926, 1.8304347826087, 1.4833333333333, 0.22222222222222
59927, 1.8521739130435, 1.4833333333333, 0.19444444444444
59928, 1.8521739130435, 1.4666666666667, 0.16666666666667
59929, 1.8304347826087, 1.4833333333333, 0.16666666666667
59930, 1.8521739130435, 1.4833333333333, 0.13888888888889
59931, 1.8521739130435, 1.4666666666667, 0.11111111111111
59932, 1.8304347826087, 1.4833333333333, 0.11111111111111
59933, 1.8521739130435, 1.4833333333333, 0.083333333333333
59934, 1.8521739130435, 1.4666666666667, 0.055555555555556
59935, 1.8304347826087, 1.4833333333333, 0.055555555555556
59936, 1.8521739130435, 1.4833333333333, 0.027777777777778
59937, 1.8521739130435, 1.5166666666667, 0.47222222222222
59938, 1.8521739130435, 1.5, 0.44444444444444
59939, 1.8304347826087, 1.5166666666667, 0.44444444444444
59940, 1.8521739130435, 1.5166666666667, 0.41666666666667
59941, 1.8521739130435, 1.5, 0.38888888888889
59942, 1.8304347826087, 1.5166666666667, 0.38888888888889
59943, 1.8521739130435, 1.5166666666667, 0.36111111111111
59944, 1.8521739130435, 1.5, 0.33333333333333
59945, 1.8304347826087, 1.5166666666667, 0.33333333333333
59946, 1.8521739130435, 1.5166666666667, 0.30555555555556
59947, 1.8521739130435, 1.5, 0.27777777777778
59948, 1.8304347826087, 1.5166666666667, 0.27777777777778
59949, 1.8521739130435, 1.5166666666667, 0.25
59950, 1.8521739130435, 1.5, 0.22222222222222
59951, 1.8304347826087, 1.5166666666667, 0.22222222222222
59952, 1.8521739130435, 1.5166666666667, 0.19444444444444
59953, 1.8521739130435, 1.5, 0.16666666666667
59954, 1.8304347826087, 1.5166666666667, 0.16666666666667
59955, 1.8521739130435, 1.5166666666667, 0.13888888888889
59956, 1.8521739130435, 1.5, 0.11111111111111
59957, 1.8304347826087, 1.5166666666667, 0.11111111111111
59958, 1.8521739130435, 1.5166666666667, 0.083333333333333
59959, 1.8521739130435, 1.5, 0.055555555555556
59960, 1.8304347826087, 1.5166666666667, 0.055555555555556
59961, 1.8521739130435, 1.5166666666667, 0.027777777777778
59962, 1.8521739130435, 1.5333333333333, 0.44444444444444
59963, 1.8521739130435, 1.5333333333333, 0.38888888888889
59964, 1.8521739130435, 1.5333333333333, 0.33333333333333
59965, 1.8521739130435, 1.5333333333333, 0.27777777777778
59966, 1.8521739130435, 1.5333333333333, 0.22222222222222
59967, 1.8521739130435, 1.5333333333333, 0.16666666666667
59968, 1.8521739130435, 1.5333333333333, 0.11111111111111
59969, 1.8521739130435, 1.5333333333333, 0.055555555555556
59970, 1.895652173913, 1.4833333333333, 0.47222222222222
59971, 1.895652173913, 1.4666666666667, 0.44444444444444
59972, 1.8739130434783, 1.4833333333333, 0.44444444444444
59973, 1.895652173913, 1.4833333333333, 0.41666666666667
59974, 1.895652173913, 1.4666666666667, 0.38888888888889
59975, 1.8739130434783, 1.4833333333333, 0.38888888888889
59976, 1.895652173913, 1.4833333333333, 0.36111111111111
59977, 1.895652173913, 1.4666666666667, 0.33333333333333
59978, 1.8739130434783, 1.4833333333333, 0.33333333333333
59979, 1.895652173913, 1.4833333333333, 0.30555555555556
59980, 1.895652173913, 1.4666666666667, 0.27777777777778
59981, 1.8739130434783, 1.4833333333333, 0.27777777777778
59982, 1.895652173913, 1.4833333333333, 0.25
59983, 1.895652173913, 1.4666666666667, 0.22222222222222
59984, 1.8739130434783, 1.4833333333333, 0.22222222222222
59985, 1.895652173913, 1.4833333333333, 0.19444444444444
59986, 1.895652173913, 1.4666666666667, 0.16666666666667
59987, 1.8739130434783, 1.4833333333333, 0.16666666666667
59988, 1.895652173913, 1.4833333333333, 0.13888888888889
59989, 1.895652173913, 1.4666666666667, 0.11111111111111
59990, 1.8739130434783, 1.4833333333333, 0.11111111111111
59991, 1.895652173913, 1.4833333333333, 0.083333333333333
59992, 1.895652173913, 1.4666666666667, 0.055555555555556
59993, 1.8739130434783, 1.4833333333333, 0.055555555555556
59994, 1.895652173913, 1.4833333333333, 0.027777777777778
59995, 1.895652173913, 1.5166666666667, 0.47222222222222
59996, 1.895652173913, 1.5, 0.44444444444444
59997, 1.8739130434783, 1.5166666666667, 0.44444444444444
59998, 1.895652173913, 1.5166666666667, 0.41666666666667
59999, 1.895652173913, 1.5, 0.38888888888889
60000, 1.8739130434783, 1.5166666666667, 0.38888888888889
60001, 1.895652173913, 1.5166666666667, 0.36111111111111
60002, 1.895652173913, 1.5, 0.33333333333333
60003, 1.8739130434783, 1.5166666666667, 0.33333333333333
60004, 1.895652173913, 1.5166666666667, 0.30555555555556
60005, 1.895652173913, 1.5, 0.27777777777778
60006, 1.8739130434783, 1.5166666666667, 0.27777777777778
60007, 1.895652173913, 1.5166666666667, 0.25
60008, 1.895652173913, 1.5, 0.22222222222222
60009, 1.8739130434783, 1.5166666666667, 0.22222222222222
60010, 1.895652173913, 1.5166666666667, 0.19444444444444
60011, 1.895652173913, 1.5, 0.16666666666667
60012, 1.8739130434783, 1.5166666666667, 0.16666666666667
60013, 1.895652173913, 1.5166666666667, 0.13888888888889
60014, 1.895652173913, 1.5, 0.11111111111111
60015, 1.8739130434783, 1.5166666666667, 0.11111111111111
60016, 1.895652173913, 1.5166666666667, 0.083333333333333
60017, 1.895652173913, 1.5, 0.055555555555556
60018, 1.8739130434783, 1.5166666666667, 0.055555555555556
60019, 1.895652173913, 1.5166666666667, 0.027777777777778
60020, 1.895652173913, 1.5333333333333, 0.44444444444444
60021, 1.895652173913, 1.5333333333333, 0.38888888888889
60022, 1.895652173913, 1.5333333333333, 0.33333333333333
60023, 1.895652173913, 1.5333333333333, 0.27777777777778
60024, 1.895652173913, 1.5333333333333, 0.22222222222222
60025, 1.895652173913, 1.5333333333333, 0.16666666666667
60026, 1.895652173913, 1.5333333333333, 0.11111111111111
60027, 1.895652173913, 1.5333333333333, 0.055555555555556
60028, 1.9391304347826, 1.4833333333333, 0.47222222222222
60029, 1.9391304347826, 1.4666666666667, 0.44444444444444
60030, 1.9173913043478, 1.4833333333333, 0.44444444444444
60031, 1.9391304347826, 1.4833333333333, 0.41666666666667
60032, 1.9391304347826, 1.4666666666667, 0.38888888888889
60033, 1.9173913043478, 1.4833333333333, 0.38888888888889
60034, 1.9391304347826, 1.4833333333333, 0.36111111111111
60035, 1.9391304347826, 1.4666666666667, 0.33333333333333
60036, 1.9173913043478, 1.4833333333333, 0.33333333333333
60037, 1.9391304347826, 1.4833333333333, 0.30555555555556
60038, 1.9391304347826, 1.4666666666667, 0.27777777777778
60039, 1.9173913043478, 1.4833333333333, 0.27777777777778
60040, 1.9391304347826, 1.4833333333333, 0.25
60041, 1.9391304347826, 1.4666666666667, 0.22222222222222
60042, 1.9173913043478, 1.4833333333333, 0.22222222222222
60043, 1.9391304347826, 1.4833333333333, 0.19444444444444
60044, 1.9391304347826, 1.4666666666667, 0.16666666666667
60045, 1.9173913043478, 1.4833333333333, 0.16666666666667
60046, 1.9391304347826, 1.4833333333333, 0.13888888888889
60047, 1.9391304347826, 1.4666666666667, 0.11111111111111
60048, 1.9173913043478, 1.4833333333333, 0.11111111111111
60049, 1.9391304347826, 1.4833333333333, 0.083333333333333
60050, 1.9391304347826, 1.4666666666667, 0.055555555555556
60051, 1.9173913043478, 1.4833333333333, 0.055555555555556
60052, 1.9391304347826, 1.4833333333333, 0.027777777777778
60053, 1.9391304347826, 1.5166666666667, 0.47222222222222
60054, 1.9391304347826, 1.5, 0.44444444444444
60055, 1.9173913043478, 1.5166666666667, 0.44444444444444
60056, 1.9391304347826, 1.5166666666667, 0.41666666666667
60057, 1.9391304347826, 1.5, 0.38888888888889
60058, 1.9173913043478, 1.5166666666667, 0.38888888888889
60059, 1.9391304347826, 1.5166666666667, 0.36111111111111
60060, 1.9391304347826, 1.5, 0.33333333333333
60061, 1.9173913043478, 1.5166666666667, 0.33333333333333
60062, 1.9391304347826, 1.5166666666667, 0.30555555555556
60063, 1.9391304347826, 1.5, 0.27777777777778
60064, 1.9173913043478, 1.5166666666667, 0.27777777777778
60065, 1.9391304347826, 1.5166666666667, 0.25
60066, 1.9391304347826, 1.5, 0.22222222222222
60067, 1.9173913043478, 1.5166666666667, 0.22222222222222
60068, 1.9391304347826, 1.5166666666667, 0.19444444444444
60069, 1.9391304347826, 1.5, 0.16666666666667
60070, 1.9173913043478, 1.5166666666667, 0.16666666666667
60071, 1.9391304347826, 1.5166666666667, 0.13888888888889
60072, 1.9391304347826, 1.5, 0.11111111111111
60073, 1.9173913043478, 1.5166666666667, 0.11111111111111
60074, 1.9391304347826, 1.5166666666667, 0.083333333333333
60075, 1.9391304347826, 1.5, 0.055555555555556
60076, 1.9173913043478, 1.5166666666667, 0.055555555555556
60077, 1.9391304347826, 1.5166666666667, 0.027777777777778
60078, 1.9391304347826, 1.5333333333333, 0.44444444444444
60079, 1.9391304347826, 1.5333333333333, 0.38888888888889
60080, 1.9391304347826, 1.5333333333333, 0.33333333333333
60081, 1.9391304347826, 1.5333333333333, 0.27777777777778
60082, 1.9391304347826, 1.5333333333333, 0.22222222222222
60083, 1.9391304347826, 1.5333333333333, 0.16666666666667
60084, 1.9391304347826, 1.5333333333333, 0.11111111111111
60085, 1.9391304347826, 1.5333333333333, 0.055555555555556
60086, 1.9826086956522, 1.4833333333333, 0.47222222222222
60087, 1.9826086956522, 1.4666666666667, 0.44444444444444
60088, 1.9608695652174, 1.4833333333333, 0.44444444444444
60089, 1.9826086956522, 1.4833333333333, 0.41666666666667
60090, 1.9826086956522, 1.4666666666667, 0.38888888888889
60091, 1.9608695652174, 1.4833333333333, 0.38888888888889
60092, 1.9826086956522, 1.4833333333333, 0.36111111111111
60093, 1.9826086956522, 1.4666666666667, 0.33333333333333
60094, 1.9608695652174, 1.4833333333333, 0.33333333333333
60095, 1.9826086956522, 1.4833333333333, 0.30555555555556
60096, 1.9826086956522, 1.4666666666667, 0.27777777777778
60097, 1.9608695652174, 1.4833333333333, 0.27777777777778
60098, 1.9826086956522, 1.4833333333333, 0.25
