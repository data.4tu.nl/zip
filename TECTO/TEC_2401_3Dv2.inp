30367, 17779, 83258, 18673, 2499, 2470, 18464, 2568, 78, 84159, 84168, 18704, 18161, 18552, 18553, 2571, 
2493, 18153, 84160, 18706, 2507
30368, 1770, 1771, 18242, 18220, 13702, 13710, 83259, 83083, 1774, 18332, 18331, 18287, 13743, 84170, 84171, 
83612, 13727, 13744, 84169, 83611
30369, 13702, 13710, 83259, 83083, 13703, 13711, 83260, 83084, 13743, 84170, 84171, 83612, 13745, 84173, 84174, 
83615, 13729, 13746, 84172, 83614
30370, 13703, 13711, 83260, 83084, 13704, 13712, 83261, 83085, 13745, 84173, 84174, 83615, 13747, 84176, 84177, 
83618, 13731, 13748, 84175, 83617
30371, 13704, 13712, 83261, 83085, 13705, 13713, 83262, 83086, 13747, 84176, 84177, 83618, 13749, 84179, 84180, 
83621, 13733, 13750, 84178, 83620
30372, 13705, 13713, 83262, 83086, 13706, 13714, 83263, 83087, 13749, 84179, 84180, 83621, 13751, 84182, 84183, 
83624, 13735, 13752, 84181, 83623
30373, 13706, 13714, 83263, 83087, 13707, 13715, 83264, 83088, 13751, 84182, 84183, 83624, 13753, 84185, 84186, 
83627, 13737, 13754, 84184, 83626
30374, 13707, 13715, 83264, 83088, 13708, 13716, 83265, 83089, 13753, 84185, 84186, 83627, 13755, 84188, 84189, 
83630, 13739, 13756, 84187, 83629
30375, 13708, 13716, 83265, 83089, 13709, 13717, 83266, 83090, 13755, 84188, 84189, 83630, 13757, 84191, 84192, 
83633, 13741, 13758, 84190, 83632
30376, 13709, 13717, 83266, 83090, 1791, 1792, 18465, 18443, 13757, 84191, 84192, 83633, 1795, 18554, 18555, 
18509, 13742, 13759, 84193, 83635
30377, 18220, 18242, 18243, 18221, 83083, 83259, 83267, 83091, 18331, 18334, 18333, 18289, 84171, 84195, 84196, 
83637, 83611, 84169, 84194, 83636
30378, 83083, 83259, 83267, 83091, 83084, 83260, 83268, 83092, 84171, 84195, 84196, 83637, 84174, 84198, 84199, 
83640, 83614, 84172, 84197, 83639
30379, 83084, 83260, 83268, 83092, 83085, 83261, 83269, 83093, 84174, 84198, 84199, 83640, 84177, 84201, 84202, 
83643, 83617, 84175, 84200, 83642
30380, 83085, 83261, 83269, 83093, 83086, 83262, 83270, 83094, 84177, 84201, 84202, 83643, 84180, 84204, 84205, 
83646, 83620, 84178, 84203, 83645
30381, 83086, 83262, 83270, 83094, 83087, 83263, 83271, 83095, 84180, 84204, 84205, 83646, 84183, 84207, 84208, 
83649, 83623, 84181, 84206, 83648
30382, 83087, 83263, 83271, 83095, 83088, 83264, 83272, 83096, 84183, 84207, 84208, 83649, 84186, 84210, 84211, 
83652, 83626, 84184, 84209, 83651
30383, 83088, 83264, 83272, 83096, 83089, 83265, 83273, 83097, 84186, 84210, 84211, 83652, 84189, 84213, 84214, 
83655, 83629, 84187, 84212, 83654
30384, 83089, 83265, 83273, 83097, 83090, 83266, 83274, 83098, 84189, 84213, 84214, 83655, 84192, 84216, 84217, 
83658, 83632, 84190, 84215, 83657
30385, 83090, 83266, 83274, 83098, 18443, 18465, 18466, 18444, 84192, 84216, 84217, 83658, 18555, 18556, 18557, 
18511, 83635, 84193, 84218, 83660
30386, 18221, 18243, 18244, 18222, 83091, 83267, 83275, 83099, 18333, 18336, 18335, 18291, 84196, 84220, 84221, 
83662, 83636, 84194, 84219, 83661
30387, 83091, 83267, 83275, 83099, 83092, 83268, 83276, 83100, 84196, 84220, 84221, 83662, 84199, 84223, 84224, 
83665, 83639, 84197, 84222, 83664
30388, 83092, 83268, 83276, 83100, 83093, 83269, 83277, 83101, 84199, 84223, 84224, 83665, 84202, 84226, 84227, 
83668, 83642, 84200, 84225, 83667
30389, 83093, 83269, 83277, 83101, 83094, 83270, 83278, 83102, 84202, 84226, 84227, 83668, 84205, 84229, 84230, 
83671, 83645, 84203, 84228, 83670
30390, 83094, 83270, 83278, 83102, 83095, 83271, 83279, 83103, 84205, 84229, 84230, 83671, 84208, 84232, 84233, 
83674, 83648, 84206, 84231, 83673
30391, 83095, 83271, 83279, 83103, 83096, 83272, 83280, 83104, 84208, 84232, 84233, 83674, 84211, 84235, 84236, 
83677, 83651, 84209, 84234, 83676
30392, 83096, 83272, 83280, 83104, 83097, 83273, 83281, 83105, 84211, 84235, 84236, 83677, 84214, 84238, 84239, 
83680, 83654, 84212, 84237, 83679
30393, 83097, 83273, 83281, 83105, 83098, 83274, 83282, 83106, 84214, 84238, 84239, 83680, 84217, 84241, 84242, 
83683, 83657, 84215, 84240, 83682
30394, 83098, 83274, 83282, 83106, 18444, 18466, 18467, 18445, 84217, 84241, 84242, 83683, 18557, 18558, 18559, 
18513, 83660, 84218, 84243, 83685
30395, 18222, 18244, 18245, 18223, 83099, 83275, 83283, 83107, 18335, 18338, 18337, 18293, 84221, 84245, 84246, 
83687, 83661, 84219, 84244, 83686
30396, 83099, 83275, 83283, 83107, 83100, 83276, 83284, 83108, 84221, 84245, 84246, 83687, 84224, 84248, 84249, 
83690, 83664, 84222, 84247, 83689
30397, 83100, 83276, 83284, 83108, 83101, 83277, 83285, 83109, 84224, 84248, 84249, 83690, 84227, 84251, 84252, 
83693, 83667, 84225, 84250, 83692
30398, 83101, 83277, 83285, 83109, 83102, 83278, 83286, 83110, 84227, 84251, 84252, 83693, 84230, 84254, 84255, 
83696, 83670, 84228, 84253, 83695
30399, 83102, 83278, 83286, 83110, 83103, 83279, 83287, 83111, 84230, 84254, 84255, 83696, 84233, 84257, 84258, 
83699, 83673, 84231, 84256, 83698
30400, 83103, 83279, 83287, 83111, 83104, 83280, 83288, 83112, 84233, 84257, 84258, 83699, 84236, 84260, 84261, 
83702, 83676, 84234, 84259, 83701
30401, 83104, 83280, 83288, 83112, 83105, 83281, 83289, 83113, 84236, 84260, 84261, 83702, 84239, 84263, 84264, 
83705, 83679, 84237, 84262, 83704
30402, 83105, 83281, 83289, 83113, 83106, 83282, 83290, 83114, 84239, 84263, 84264, 83705, 84242, 84266, 84267, 
83708, 83682, 84240, 84265, 83707
30403, 83106, 83282, 83290, 83114, 18445, 18467, 18468, 18446, 84242, 84266, 84267, 83708, 18559, 18560, 18561, 
18515, 83685, 84243, 84268, 83710
30404, 18223, 18245, 18246, 18224, 83107, 83283, 83291, 83115, 18337, 18340, 18339, 18295, 84246, 84270, 84271, 
83712, 83686, 84244, 84269, 83711
30405, 83107, 83283, 83291, 83115, 83108, 83284, 83292, 83116, 84246, 84270, 84271, 83712, 84249, 84273, 84274, 
83715, 83689, 84247, 84272, 83714
30406, 83108, 83284, 83292, 83116, 83109, 83285, 83293, 83117, 84249, 84273, 84274, 83715, 84252, 84276, 84277, 
83718, 83692, 84250, 84275, 83717
30407, 83109, 83285, 83293, 83117, 83110, 83286, 83294, 83118, 84252, 84276, 84277, 83718, 84255, 84279, 84280, 
83721, 83695, 84253, 84278, 83720
30408, 83110, 83286, 83294, 83118, 83111, 83287, 83295, 83119, 84255, 84279, 84280, 83721, 84258, 84282, 84283, 
83724, 83698, 84256, 84281, 83723
30409, 83111, 83287, 83295, 83119, 83112, 83288, 83296, 83120, 84258, 84282, 84283, 83724, 84261, 84285, 84286, 
83727, 83701, 84259, 84284, 83726
30410, 83112, 83288, 83296, 83120, 83113, 83289, 83297, 83121, 84261, 84285, 84286, 83727, 84264, 84288, 84289, 
83730, 83704, 84262, 84287, 83729
30411, 83113, 83289, 83297, 83121, 83114, 83290, 83298, 83122, 84264, 84288, 84289, 83730, 84267, 84291, 84292, 
83733, 83707, 84265, 84290, 83732
30412, 83114, 83290, 83298, 83122, 18446, 18468, 18469, 18447, 84267, 84291, 84292, 83733, 18561, 18562, 18563, 
18517, 83710, 84268, 84293, 83735
30413, 18224, 18246, 18247, 18225, 83115, 83291, 83299, 83123, 18339, 18342, 18341, 18297, 84271, 84295, 84296, 
83737, 83711, 84269, 84294, 83736
30414, 83115, 83291, 83299, 83123, 83116, 83292, 83300, 83124, 84271, 84295, 84296, 83737, 84274, 84298, 84299, 
83740, 83714, 84272, 84297, 83739
30415, 83116, 83292, 83300, 83124, 83117, 83293, 83301, 83125, 84274, 84298, 84299, 83740, 84277, 84301, 84302, 
83743, 83717, 84275, 84300, 83742
30416, 83117, 83293, 83301, 83125, 83118, 83294, 83302, 83126, 84277, 84301, 84302, 83743, 84280, 84304, 84305, 
83746, 83720, 84278, 84303, 83745
30417, 83118, 83294, 83302, 83126, 83119, 83295, 83303, 83127, 84280, 84304, 84305, 83746, 84283, 84307, 84308, 
83749, 83723, 84281, 84306, 83748
30418, 83119, 83295, 83303, 83127, 83120, 83296, 83304, 83128, 84283, 84307, 84308, 83749, 84286, 84310, 84311, 
83752, 83726, 84284, 84309, 83751
30419, 83120, 83296, 83304, 83128, 83121, 83297, 83305, 83129, 84286, 84310, 84311, 83752, 84289, 84313, 84314, 
83755, 83729, 84287, 84312, 83754
30420, 83121, 83297, 83305, 83129, 83122, 83298, 83306, 83130, 84289, 84313, 84314, 83755, 84292, 84316, 84317, 
83758, 83732, 84290, 84315, 83757
30421, 83122, 83298, 83306, 83130, 18447, 18469, 18470, 18448, 84292, 84316, 84317, 83758, 18563, 18564, 18565, 
18519, 83735, 84293, 84318, 83760
30422, 18225, 18247, 18248, 18226, 83123, 83299, 83307, 83131, 18341, 18344, 18343, 18299, 84296, 84320, 84321, 
83762, 83736, 84294, 84319, 83761
30423, 83123, 83299, 83307, 83131, 83124, 83300, 83308, 83132, 84296, 84320, 84321, 83762, 84299, 84323, 84324, 
83765, 83739, 84297, 84322, 83764
30424, 83124, 83300, 83308, 83132, 83125, 83301, 83309, 83133, 84299, 84323, 84324, 83765, 84302, 84326, 84327, 
83768, 83742, 84300, 84325, 83767
30425, 83125, 83301, 83309, 83133, 83126, 83302, 83310, 83134, 84302, 84326, 84327, 83768, 84305, 84329, 84330, 
83771, 83745, 84303, 84328, 83770
30426, 83126, 83302, 83310, 83134, 83127, 83303, 83311, 83135, 84305, 84329, 84330, 83771, 84308, 84332, 84333, 
83774, 83748, 84306, 84331, 83773
30427, 83127, 83303, 83311, 83135, 83128, 83304, 83312, 83136, 84308, 84332, 84333, 83774, 84311, 84335, 84336, 
83777, 83751, 84309, 84334, 83776
30428, 83128, 83304, 83312, 83136, 83129, 83305, 83313, 83137, 84311, 84335, 84336, 83777, 84314, 84338, 84339, 
83780, 83754, 84312, 84337, 83779
30429, 83129, 83305, 83313, 83137, 83130, 83306, 83314, 83138, 84314, 84338, 84339, 83780, 84317, 84341, 84342, 
83783, 83757, 84315, 84340, 83782
30430, 83130, 83306, 83314, 83138, 18448, 18470, 18471, 18449, 84317, 84341, 84342, 83783, 18565, 18566, 18567, 
18521, 83760, 84318, 84343, 83785
30431, 18226, 18248, 18249, 18227, 83131, 83307, 83315, 83139, 18343, 18346, 18345, 18301, 84321, 84345, 84346, 
83787, 83761, 84319, 84344, 83786
30432, 83131, 83307, 83315, 83139, 83132, 83308, 83316, 83140, 84321, 84345, 84346, 83787, 84324, 84348, 84349, 
83790, 83764, 84322, 84347, 83789
30433, 83132, 83308, 83316, 83140, 83133, 83309, 83317, 83141, 84324, 84348, 84349, 83790, 84327, 84351, 84352, 
83793, 83767, 84325, 84350, 83792
30434, 83133, 83309, 83317, 83141, 83134, 83310, 83318, 83142, 84327, 84351, 84352, 83793, 84330, 84354, 84355, 
83796, 83770, 84328, 84353, 83795
30435, 83134, 83310, 83318, 83142, 83135, 83311, 83319, 83143, 84330, 84354, 84355, 83796, 84333, 84357, 84358, 
83799, 83773, 84331, 84356, 83798
30436, 83135, 83311, 83319, 83143, 83136, 83312, 83320, 83144, 84333, 84357, 84358, 83799, 84336, 84360, 84361, 
83802, 83776, 84334, 84359, 83801
30437, 83136, 83312, 83320, 83144, 83137, 83313, 83321, 83145, 84336, 84360, 84361, 83802, 84339, 84363, 84364, 
83805, 83779, 84337, 84362, 83804
30438, 83137, 83313, 83321, 83145, 83138, 83314, 83322, 83146, 84339, 84363, 84364, 83805, 84342, 84366, 84367, 
83808, 83782, 84340, 84365, 83807
30439, 83138, 83314, 83322, 83146, 18449, 18471, 18472, 18450, 84342, 84366, 84367, 83808, 18567, 18568, 18569, 
18523, 83785, 84343, 84368, 83810
30440, 18227, 18249, 18250, 18228, 83139, 83315, 83323, 83147, 18345, 18348, 18347, 18303, 84346, 84370, 84371, 
83812, 83786, 84344, 84369, 83811
30441, 83139, 83315, 83323, 83147, 83140, 83316, 83324, 83148, 84346, 84370, 84371, 83812, 84349, 84373, 84374, 
83815, 83789, 84347, 84372, 83814
30442, 83140, 83316, 83324, 83148, 83141, 83317, 83325, 83149, 84349, 84373, 84374, 83815, 84352, 84376, 84377, 
83818, 83792, 84350, 84375, 83817
30443, 83141, 83317, 83325, 83149, 83142, 83318, 83326, 83150, 84352, 84376, 84377, 83818, 84355, 84379, 84380, 
83821, 83795, 84353, 84378, 83820
30444, 83142, 83318, 83326, 83150, 83143, 83319, 83327, 83151, 84355, 84379, 84380, 83821, 84358, 84382, 84383, 
83824, 83798, 84356, 84381, 83823
30445, 83143, 83319, 83327, 83151, 83144, 83320, 83328, 83152, 84358, 84382, 84383, 83824, 84361, 84385, 84386, 
83827, 83801, 84359, 84384, 83826
30446, 83144, 83320, 83328, 83152, 83145, 83321, 83329, 83153, 84361, 84385, 84386, 83827, 84364, 84388, 84389, 
83830, 83804, 84362, 84387, 83829
30447, 83145, 83321, 83329, 83153, 83146, 83322, 83330, 83154, 84364, 84388, 84389, 83830, 84367, 84391, 84392, 
83833, 83807, 84365, 84390, 83832
30448, 83146, 83322, 83330, 83154, 18450, 18472, 18473, 18451, 84367, 84391, 84392, 83833, 18569, 18570, 18571, 
18525, 83810, 84368, 84393, 83835
30449, 18228, 18250, 18251, 18229, 83147, 83323, 83331, 83155, 18347, 18350, 18349, 18305, 84371, 84395, 84396, 
83837, 83811, 84369, 84394, 83836
30450, 83147, 83323, 83331, 83155, 83148, 83324, 83332, 83156, 84371, 84395, 84396, 83837, 84374, 84398, 84399, 
83840, 83814, 84372, 84397, 83839
30451, 83148, 83324, 83332, 83156, 83149, 83325, 83333, 83157, 84374, 84398, 84399, 83840, 84377, 84401, 84402, 
83843, 83817, 84375, 84400, 83842
30452, 83149, 83325, 83333, 83157, 83150, 83326, 83334, 83158, 84377, 84401, 84402, 83843, 84380, 84404, 84405, 
83846, 83820, 84378, 84403, 83845
30453, 83150, 83326, 83334, 83158, 83151, 83327, 83335, 83159, 84380, 84404, 84405, 83846, 84383, 84407, 84408, 
83849, 83823, 84381, 84406, 83848
30454, 83151, 83327, 83335, 83159, 83152, 83328, 83336, 83160, 84383, 84407, 84408, 83849, 84386, 84410, 84411, 
83852, 83826, 84384, 84409, 83851
30455, 83152, 83328, 83336, 83160, 83153, 83329, 83337, 83161, 84386, 84410, 84411, 83852, 84389, 84413, 84414, 
83855, 83829, 84387, 84412, 83854
30456, 83153, 83329, 83337, 83161, 83154, 83330, 83338, 83162, 84389, 84413, 84414, 83855, 84392, 84416, 84417, 
83858, 83832, 84390, 84415, 83857
30457, 83154, 83330, 83338, 83162, 18451, 18473, 18474, 18452, 84392, 84416, 84417, 83858, 18571, 18572, 18573, 
18527, 83835, 84393, 84418, 83860
30458, 18229, 18251, 18252, 18230, 83155, 83331, 83339, 83163, 18349, 18352, 18351, 18307, 84396, 84420, 84421, 
83862, 83836, 84394, 84419, 83861
30459, 83155, 83331, 83339, 83163, 83156, 83332, 83340, 83164, 84396, 84420, 84421, 83862, 84399, 84423, 84424, 
83865, 83839, 84397, 84422, 83864
30460, 83156, 83332, 83340, 83164, 83157, 83333, 83341, 83165, 84399, 84423, 84424, 83865, 84402, 84426, 84427, 
83868, 83842, 84400, 84425, 83867
30461, 83157, 83333, 83341, 83165, 83158, 83334, 83342, 83166, 84402, 84426, 84427, 83868, 84405, 84429, 84430, 
83871, 83845, 84403, 84428, 83870
30462, 83158, 83334, 83342, 83166, 83159, 83335, 83343, 83167, 84405, 84429, 84430, 83871, 84408, 84432, 84433, 
83874, 83848, 84406, 84431, 83873
30463, 83159, 83335, 83343, 83167, 83160, 83336, 83344, 83168, 84408, 84432, 84433, 83874, 84411, 84435, 84436, 
83877, 83851, 84409, 84434, 83876
30464, 83160, 83336, 83344, 83168, 83161, 83337, 83345, 83169, 84411, 84435, 84436, 83877, 84414, 84438, 84439, 
83880, 83854, 84412, 84437, 83879
30465, 83161, 83337, 83345, 83169, 83162, 83338, 83346, 83170, 84414, 84438, 84439, 83880, 84417, 84441, 84442, 
83883, 83857, 84415, 84440, 83882
30466, 83162, 83338, 83346, 83170, 18452, 18474, 18475, 18453, 84417, 84441, 84442, 83883, 18573, 18574, 18575, 
18529, 83860, 84418, 84443, 83885
30467, 18230, 18252, 18253, 18231, 83163, 83339, 83347, 83171, 18351, 18354, 18353, 18309, 84421, 84445, 84446, 
83887, 83861, 84419, 84444, 83886
30468, 83163, 83339, 83347, 83171, 83164, 83340, 83348, 83172, 84421, 84445, 84446, 83887, 84424, 84448, 84449, 
83890, 83864, 84422, 84447, 83889
30469, 83164, 83340, 83348, 83172, 83165, 83341, 83349, 83173, 84424, 84448, 84449, 83890, 84427, 84451, 84452, 
83893, 83867, 84425, 84450, 83892
30470, 83165, 83341, 83349, 83173, 83166, 83342, 83350, 83174, 84427, 84451, 84452, 83893, 84430, 84454, 84455, 
83896, 83870, 84428, 84453, 83895
30471, 83166, 83342, 83350, 83174, 83167, 83343, 83351, 83175, 84430, 84454, 84455, 83896, 84433, 84457, 84458, 
83899, 83873, 84431, 84456, 83898
30472, 83167, 83343, 83351, 83175, 83168, 83344, 83352, 83176, 84433, 84457, 84458, 83899, 84436, 84460, 84461, 
83902, 83876, 84434, 84459, 83901
30473, 83168, 83344, 83352, 83176, 83169, 83345, 83353, 83177, 84436, 84460, 84461, 83902, 84439, 84463, 84464, 
83905, 83879, 84437, 84462, 83904
30474, 83169, 83345, 83353, 83177, 83170, 83346, 83354, 83178, 84439, 84463, 84464, 83905, 84442, 84466, 84467, 
83908, 83882, 84440, 84465, 83907
30475, 83170, 83346, 83354, 83178, 18453, 18475, 18476, 18454, 84442, 84466, 84467, 83908, 18575, 18576, 18577, 
18531, 83885, 84443, 84468, 83910
30476, 18231, 18253, 18254, 18232, 83171, 83347, 83355, 83179, 18353, 18356, 18355, 18311, 84446, 84470, 84471, 
83912, 83886, 84444, 84469, 83911
30477, 83171, 83347, 83355, 83179, 83172, 83348, 83356, 83180, 84446, 84470, 84471, 83912, 84449, 84473, 84474, 
83915, 83889, 84447, 84472, 83914
30478, 83172, 83348, 83356, 83180, 83173, 83349, 83357, 83181, 84449, 84473, 84474, 83915, 84452, 84476, 84477, 
83918, 83892, 84450, 84475, 83917
30479, 83173, 83349, 83357, 83181, 83174, 83350, 83358, 83182, 84452, 84476, 84477, 83918, 84455, 84479, 84480, 
83921, 83895, 84453, 84478, 83920
30480, 83174, 83350, 83358, 83182, 83175, 83351, 83359, 83183, 84455, 84479, 84480, 83921, 84458, 84482, 84483, 
83924, 83898, 84456, 84481, 83923
30481, 83175, 83351, 83359, 83183, 83176, 83352, 83360, 83184, 84458, 84482, 84483, 83924, 84461, 84485, 84486, 
83927, 83901, 84459, 84484, 83926
30482, 83176, 83352, 83360, 83184, 83177, 83353, 83361, 83185, 84461, 84485, 84486, 83927, 84464, 84488, 84489, 
83930, 83904, 84462, 84487, 83929
30483, 83177, 83353, 83361, 83185, 83178, 83354, 83362, 83186, 84464, 84488, 84489, 83930, 84467, 84491, 84492, 
83933, 83907, 84465, 84490, 83932
30484, 83178, 83354, 83362, 83186, 18454, 18476, 18477, 18455, 84467, 84491, 84492, 83933, 18577, 18578, 18579, 
18533, 83910, 84468, 84493, 83935
30485, 18232, 18254, 18255, 18233, 83179, 83355, 83363, 83187, 18355, 18358, 18357, 18313, 84471, 84495, 84496, 
83937, 83911, 84469, 84494, 83936
30486, 83179, 83355, 83363, 83187, 83180, 83356, 83364, 83188, 84471, 84495, 84496, 83937, 84474, 84498, 84499, 
83940, 83914, 84472, 84497, 83939
30487, 83180, 83356, 83364, 83188, 83181, 83357, 83365, 83189, 84474, 84498, 84499, 83940, 84477, 84501, 84502, 
83943, 83917, 84475, 84500, 83942
30488, 83181, 83357, 83365, 83189, 83182, 83358, 83366, 83190, 84477, 84501, 84502, 83943, 84480, 84504, 84505, 
83946, 83920, 84478, 84503, 83945
30489, 83182, 83358, 83366, 83190, 83183, 83359, 83367, 83191, 84480, 84504, 84505, 83946, 84483, 84507, 84508, 
83949, 83923, 84481, 84506, 83948
30490, 83183, 83359, 83367, 83191, 83184, 83360, 83368, 83192, 84483, 84507, 84508, 83949, 84486, 84510, 84511, 
83952, 83926, 84484, 84509, 83951
30491, 83184, 83360, 83368, 83192, 83185, 83361, 83369, 83193, 84486, 84510, 84511, 83952, 84489, 84513, 84514, 
83955, 83929, 84487, 84512, 83954
30492, 83185, 83361, 83369, 83193, 83186, 83362, 83370, 83194, 84489, 84513, 84514, 83955, 84492, 84516, 84517, 
83958, 83932, 84490, 84515, 83957
30493, 83186, 83362, 83370, 83194, 18455, 18477, 18478, 18456, 84492, 84516, 84517, 83958, 18579, 18580, 18581, 
18535, 83935, 84493, 84518, 83960
30494, 18233, 18255, 18256, 18234, 83187, 83363, 83371, 83195, 18357, 18360, 18359, 18315, 84496, 84520, 84521, 
83962, 83936, 84494, 84519, 83961
30495, 83187, 83363, 83371, 83195, 83188, 83364, 83372, 83196, 84496, 84520, 84521, 83962, 84499, 84523, 84524, 
83965, 83939, 84497, 84522, 83964
30496, 83188, 83364, 83372, 83196, 83189, 83365, 83373, 83197, 84499, 84523, 84524, 83965, 84502, 84526, 84527, 
83968, 83942, 84500, 84525, 83967
30497, 83189, 83365, 83373, 83197, 83190, 83366, 83374, 83198, 84502, 84526, 84527, 83968, 84505, 84529, 84530, 
83971, 83945, 84503, 84528, 83970
30498, 83190, 83366, 83374, 83198, 83191, 83367, 83375, 83199, 84505, 84529, 84530, 83971, 84508, 84532, 84533, 
83974, 83948, 84506, 84531, 83973
30499, 83191, 83367, 83375, 83199, 83192, 83368, 83376, 83200, 84508, 84532, 84533, 83974, 84511, 84535, 84536, 
83977, 83951, 84509, 84534, 83976
30500, 83192, 83368, 83376, 83200, 83193, 83369, 83377, 83201, 84511, 84535, 84536, 83977, 84514, 84538, 84539, 
83980, 83954, 84512, 84537, 83979
30501, 83193, 83369, 83377, 83201, 83194, 83370, 83378, 83202, 84514, 84538, 84539, 83980, 84517, 84541, 84542, 
83983, 83957, 84515, 84540, 83982
30502, 83194, 83370, 83378, 83202, 18456, 18478, 18479, 18457, 84517, 84541, 84542, 83983, 18581, 18582, 18583, 
18537, 83960, 84518, 84543, 83985
30503, 18234, 18256, 18257, 18235, 83195, 83371, 83379, 83203, 18359, 18362, 18361, 18317, 84521, 84545, 84546, 
83987, 83961, 84519, 84544, 83986
30504, 83195, 83371, 83379, 83203, 83196, 83372, 83380, 83204, 84521, 84545, 84546, 83987, 84524, 84548, 84549, 
83990, 83964, 84522, 84547, 83989
30505, 83196, 83372, 83380, 83204, 83197, 83373, 83381, 83205, 84524, 84548, 84549, 83990, 84527, 84551, 84552, 
83993, 83967, 84525, 84550, 83992
30506, 83197, 83373, 83381, 83205, 83198, 83374, 83382, 83206, 84527, 84551, 84552, 83993, 84530, 84554, 84555, 
83996, 83970, 84528, 84553, 83995
30507, 83198, 83374, 83382, 83206, 83199, 83375, 83383, 83207, 84530, 84554, 84555, 83996, 84533, 84557, 84558, 
83999, 83973, 84531, 84556, 83998
30508, 83199, 83375, 83383, 83207, 83200, 83376, 83384, 83208, 84533, 84557, 84558, 83999, 84536, 84560, 84561, 
84002, 83976, 84534, 84559, 84001
30509, 83200, 83376, 83384, 83208, 83201, 83377, 83385, 83209, 84536, 84560, 84561, 84002, 84539, 84563, 84564, 
84005, 83979, 84537, 84562, 84004
30510, 83201, 83377, 83385, 83209, 83202, 83378, 83386, 83210, 84539, 84563, 84564, 84005, 84542, 84566, 84567, 
84008, 83982, 84540, 84565, 84007
30511, 83202, 83378, 83386, 83210, 18457, 18479, 18480, 18458, 84542, 84566, 84567, 84008, 18583, 18584, 18585, 
18539, 83985, 84543, 84568, 84010
30512, 18235, 18257, 18258, 18236, 83203, 83379, 83387, 83211, 18361, 18364, 18363, 18319, 84546, 84570, 84571, 
84012, 83986, 84544, 84569, 84011
30513, 83203, 83379, 83387, 83211, 83204, 83380, 83388, 83212, 84546, 84570, 84571, 84012, 84549, 84573, 84574, 
84015, 83989, 84547, 84572, 84014
30514, 83204, 83380, 83388, 83212, 83205, 83381, 83389, 83213, 84549, 84573, 84574, 84015, 84552, 84576, 84577, 
84018, 83992, 84550, 84575, 84017
30515, 83205, 83381, 83389, 83213, 83206, 83382, 83390, 83214, 84552, 84576, 84577, 84018, 84555, 84579, 84580, 
84021, 83995, 84553, 84578, 84020
30516, 83206, 83382, 83390, 83214, 83207, 83383, 83391, 83215, 84555, 84579, 84580, 84021, 84558, 84582, 84583, 
84024, 83998, 84556, 84581, 84023
30517, 83207, 83383, 83391, 83215, 83208, 83384, 83392, 83216, 84558, 84582, 84583, 84024, 84561, 84585, 84586, 
84027, 84001, 84559, 84584, 84026
30518, 83208, 83384, 83392, 83216, 83209, 83385, 83393, 83217, 84561, 84585, 84586, 84027, 84564, 84588, 84589, 
84030, 84004, 84562, 84587, 84029
30519, 83209, 83385, 83393, 83217, 83210, 83386, 83394, 83218, 84564, 84588, 84589, 84030, 84567, 84591, 84592, 
84033, 84007, 84565, 84590, 84032
30520, 83210, 83386, 83394, 83218, 18458, 18480, 18481, 18459, 84567, 84591, 84592, 84033, 18585, 18586, 18587, 
18541, 84010, 84568, 84593, 84035
30521, 18236, 18258, 18259, 18237, 83211, 83387, 83395, 83219, 18363, 18366, 18365, 18321, 84571, 84595, 84596, 
84037, 84011, 84569, 84594, 84036
30522, 83211, 83387, 83395, 83219, 83212, 83388, 83396, 83220, 84571, 84595, 84596, 84037, 84574, 84598, 84599, 
84040, 84014, 84572, 84597, 84039
30523, 83212, 83388, 83396, 83220, 83213, 83389, 83397, 83221, 84574, 84598, 84599, 84040, 84577, 84601, 84602, 
84043, 84017, 84575, 84600, 84042
30524, 83213, 83389, 83397, 83221, 83214, 83390, 83398, 83222, 84577, 84601, 84602, 84043, 84580, 84604, 84605, 
84046, 84020, 84578, 84603, 84045
30525, 83214, 83390, 83398, 83222, 83215, 83391, 83399, 83223, 84580, 84604, 84605, 84046, 84583, 84607, 84608, 
84049, 84023, 84581, 84606, 84048
30526, 83215, 83391, 83399, 83223, 83216, 83392, 83400, 83224, 84583, 84607, 84608, 84049, 84586, 84610, 84611, 
84052, 84026, 84584, 84609, 84051
30527, 83216, 83392, 83400, 83224, 83217, 83393, 83401, 83225, 84586, 84610, 84611, 84052, 84589, 84613, 84614, 
84055, 84029, 84587, 84612, 84054
30528, 83217, 83393, 83401, 83225, 83218, 83394, 83402, 83226, 84589, 84613, 84614, 84055, 84592, 84616, 84617, 
84058, 84032, 84590, 84615, 84057
30529, 83218, 83394, 83402, 83226, 18459, 18481, 18482, 18460, 84592, 84616, 84617, 84058, 18587, 18588, 18589, 
18543, 84035, 84593, 84618, 84060
30530, 18237, 18259, 18260, 18238, 83219, 83395, 83403, 83227, 18365, 18368, 18367, 18323, 84596, 84620, 84621, 
84062, 84036, 84594, 84619, 84061
30531, 83219, 83395, 83403, 83227, 83220, 83396, 83404, 83228, 84596, 84620, 84621, 84062, 84599, 84623, 84624, 
84065, 84039, 84597, 84622, 84064
30532, 83220, 83396, 83404, 83228, 83221, 83397, 83405, 83229, 84599, 84623, 84624, 84065, 84602, 84626, 84627, 
84068, 84042, 84600, 84625, 84067
30533, 83221, 83397, 83405, 83229, 83222, 83398, 83406, 83230, 84602, 84626, 84627, 84068, 84605, 84629, 84630, 
84071, 84045, 84603, 84628, 84070
30534, 83222, 83398, 83406, 83230, 83223, 83399, 83407, 83231, 84605, 84629, 84630, 84071, 84608, 84632, 84633, 
84074, 84048, 84606, 84631, 84073
30535, 83223, 83399, 83407, 83231, 83224, 83400, 83408, 83232, 84608, 84632, 84633, 84074, 84611, 84635, 84636, 
84077, 84051, 84609, 84634, 84076
30536, 83224, 83400, 83408, 83232, 83225, 83401, 83409, 83233, 84611, 84635, 84636, 84077, 84614, 84638, 84639, 
84080, 84054, 84612, 84637, 84079
30537, 83225, 83401, 83409, 83233, 83226, 83402, 83410, 83234, 84614, 84638, 84639, 84080, 84617, 84641, 84642, 
84083, 84057, 84615, 84640, 84082
30538, 83226, 83402, 83410, 83234, 18460, 18482, 18483, 18461, 84617, 84641, 84642, 84083, 18589, 18590, 18591, 
18545, 84060, 84618, 84643, 84085
30539, 18238, 18260, 18261, 18239, 83227, 83403, 83411, 83235, 18367, 18370, 18369, 18325, 84621, 84645, 84646, 
84087, 84061, 84619, 84644, 84086
30540, 83227, 83403, 83411, 83235, 83228, 83404, 83412, 83236, 84621, 84645, 84646, 84087, 84624, 84648, 84649, 
84090, 84064, 84622, 84647, 84089
30541, 83228, 83404, 83412, 83236, 83229, 83405, 83413, 83237, 84624, 84648, 84649, 84090, 84627, 84651, 84652, 
84093, 84067, 84625, 84650, 84092
30542, 83229, 83405, 83413, 83237, 83230, 83406, 83414, 83238, 84627, 84651, 84652, 84093, 84630, 84654, 84655, 
84096, 84070, 84628, 84653, 84095
30543, 83230, 83406, 83414, 83238, 83231, 83407, 83415, 83239, 84630, 84654, 84655, 84096, 84633, 84657, 84658, 
84099, 84073, 84631, 84656, 84098
30544, 83231, 83407, 83415, 83239, 83232, 83408, 83416, 83240, 84633, 84657, 84658, 84099, 84636, 84660, 84661, 
84102, 84076, 84634, 84659, 84101
30545, 83232, 83408, 83416, 83240, 83233, 83409, 83417, 83241, 84636, 84660, 84661, 84102, 84639, 84663, 84664, 
84105, 84079, 84637, 84662, 84104
30546, 83233, 83409, 83417, 83241, 83234, 83410, 83418, 83242, 84639, 84663, 84664, 84105, 84642, 84666, 84667, 
84108, 84082, 84640, 84665, 84107
30547, 83234, 83410, 83418, 83242, 18461, 18483, 18484, 18462, 84642, 84666, 84667, 84108, 18591, 18592, 18593, 
18547, 84085, 84643, 84668, 84110
30548, 18239, 18261, 18262, 18240, 83235, 83411, 83419, 83243, 18369, 18372, 18371, 18327, 84646, 84670, 84671, 
84112, 84086, 84644, 84669, 84111
30549, 83235, 83411, 83419, 83243, 83236, 83412, 83420, 83244, 84646, 84670, 84671, 84112, 84649, 84673, 84674, 
84115, 84089, 84647, 84672, 84114
30550, 83236, 83412, 83420, 83244, 83237, 83413, 83421, 83245, 84649, 84673, 84674, 84115, 84652, 84676, 84677, 
84118, 84092, 84650, 84675, 84117
30551, 83237, 83413, 83421, 83245, 83238, 83414, 83422, 83246, 84652, 84676, 84677, 84118, 84655, 84679, 84680, 
84121, 84095, 84653, 84678, 84120
30552, 83238, 83414, 83422, 83246, 83239, 83415, 83423, 83247, 84655, 84679, 84680, 84121, 84658, 84682, 84683, 
84124, 84098, 84656, 84681, 84123
30553, 83239, 83415, 83423, 83247, 83240, 83416, 83424, 83248, 84658, 84682, 84683, 84124, 84661, 84685, 84686, 
84127, 84101, 84659, 84684, 84126
30554, 83240, 83416, 83424, 83248, 83241, 83417, 83425, 83249, 84661, 84685, 84686, 84127, 84664, 84688, 84689, 
84130, 84104, 84662, 84687, 84129
30555, 83241, 83417, 83425, 83249, 83242, 83418, 83426, 83250, 84664, 84688, 84689, 84130, 84667, 84691, 84692, 
84133, 84107, 84665, 84690, 84132
30556, 83242, 83418, 83426, 83250, 18462, 18484, 18485, 18463, 84667, 84691, 84692, 84133, 18593, 18594, 18595, 
18549, 84110, 84668, 84693, 84135
30557, 18240, 18262, 18263, 18241, 83243, 83419, 83427, 83251, 18371, 18374, 18373, 18329, 84671, 84695, 84696, 
84137, 84111, 84669, 84694, 84136
30558, 83243, 83419, 83427, 83251, 83244, 83420, 83428, 83252, 84671, 84695, 84696, 84137, 84674, 84698, 84699, 
84140, 84114, 84672, 84697, 84139
30559, 83244, 83420, 83428, 83252, 83245, 83421, 83429, 83253, 84674, 84698, 84699, 84140, 84677, 84701, 84702, 
84143, 84117, 84675, 84700, 84142
30560, 83245, 83421, 83429, 83253, 83246, 83422, 83430, 83254, 84677, 84701, 84702, 84143, 84680, 84704, 84705, 
84146, 84120, 84678, 84703, 84145
30561, 83246, 83422, 83430, 83254, 83247, 83423, 83431, 83255, 84680, 84704, 84705, 84146, 84683, 84707, 84708, 
84149, 84123, 84681, 84706, 84148
30562, 83247, 83423, 83431, 83255, 83248, 83424, 83432, 83256, 84683, 84707, 84708, 84149, 84686, 84710, 84711, 
84152, 84126, 84684, 84709, 84151
30563, 83248, 83424, 83432, 83256, 83249, 83425, 83433, 83257, 84686, 84710, 84711, 84152, 84689, 84713, 84714, 
84155, 84129, 84687, 84712, 84154
30564, 83249, 83425, 83433, 83257, 83250, 83426, 83434, 83258, 84689, 84713, 84714, 84155, 84692, 84716, 84717, 
84158, 84132, 84690, 84715, 84157
30565, 83250, 83426, 83434, 83258, 18463, 18485, 18486, 18464, 84692, 84716, 84717, 84158, 18595, 18596, 18597, 
18551, 84135, 84693, 84718, 84160
30566, 18241, 18263, 2517, 2516, 83251, 83427, 18674, 18666, 18373, 18375, 2520, 18330, 84696, 84719, 18707, 
84161, 84136, 84694, 18708, 18691
30567, 83251, 83427, 18674, 18666, 83252, 83428, 18675, 18667, 84696, 84719, 18707, 84161, 84699, 84720, 18709, 
84162, 84139, 84697, 18710, 18693
30568, 83252, 83428, 18675, 18667, 83253, 83429, 18676, 18668, 84699, 84720, 18709, 84162, 84702, 84721, 18711, 
84163, 84142, 84700, 18712, 18695
30569, 83253, 83429, 18676, 18668, 83254, 83430, 18677, 18669, 84702, 84721, 18711, 84163, 84705, 84722, 18713, 
84164, 84145, 84703, 18714, 18697
30570, 83254, 83430, 18677, 18669, 83255, 83431, 18678, 18670, 84705, 84722, 18713, 84164, 84708, 84723, 18715, 
84165, 84148, 84706, 18716, 18699
30571, 83255, 83431, 18678, 18670, 83256, 83432, 18679, 18671, 84708, 84723, 18715, 84165, 84711, 84724, 18717, 
84166, 84151, 84709, 18718, 18701
30572, 83256, 83432, 18679, 18671, 83257, 83433, 18680, 18672, 84711, 84724, 18717, 84166, 84714, 84725, 18719, 
84167, 84154, 84712, 18720, 18703
30573, 83257, 83433, 18680, 18672, 83258, 83434, 18681, 18673, 84714, 84725, 18719, 84167, 84717, 84726, 18721, 
84168, 84157, 84715, 18722, 18705
30574, 83258, 83434, 18681, 18673, 18464, 18486, 2569, 2568, 84717, 84726, 18721, 84168, 18597, 18598, 2572, 
18553, 84160, 84718, 18723, 18706
30575, 1771, 1772, 18264, 18242, 13710, 13718, 83435, 83259, 1775, 18377, 18376, 18332, 13760, 84728, 84729, 
84170, 13744, 13761, 84727, 84169
30576, 13710, 13718, 83435, 83259, 13711, 13719, 83436, 83260, 13760, 84728, 84729, 84170, 13762, 84731, 84732, 
84173, 13746, 13763, 84730, 84172
30577, 13711, 13719, 83436, 83260, 13712, 13720, 83437, 83261, 13762, 84731, 84732, 84173, 13764, 84734, 84735, 
84176, 13748, 13765, 84733, 84175
30578, 13712, 13720, 83437, 83261, 13713, 13721, 83438, 83262, 13764, 84734, 84735, 84176, 13766, 84737, 84738, 
84179, 13750, 13767, 84736, 84178
30579, 13713, 13721, 83438, 83262, 13714, 13722, 83439, 83263, 13766, 84737, 84738, 84179, 13768, 84740, 84741, 
84182, 13752, 13769, 84739, 84181
30580, 13714, 13722, 83439, 83263, 13715, 13723, 83440, 83264, 13768, 84740, 84741, 84182, 13770, 84743, 84744, 
84185, 13754, 13771, 84742, 84184
30581, 13715, 13723, 83440, 83264, 13716, 13724, 83441, 83265, 13770, 84743, 84744, 84185, 13772, 84746, 84747, 
84188, 13756, 13773, 84745, 84187
30582, 13716, 13724, 83441, 83265, 13717, 13725, 83442, 83266, 13772, 84746, 84747, 84188, 13774, 84749, 84750, 
84191, 13758, 13775, 84748, 84190
30583, 13717, 13725, 83442, 83266, 1792, 1793, 18487, 18465, 13774, 84749, 84750, 84191, 1796, 18599, 18600, 
18554, 13759, 13776, 84751, 84193
30584, 18242, 18264, 18265, 18243, 83259, 83435, 83443, 83267, 18376, 18379, 18378, 18334, 84729, 84753, 84754, 
84195, 84169, 84727, 84752, 84194
30585, 83259, 83435, 83443, 83267, 83260, 83436, 83444, 83268, 84729, 84753, 84754, 84195, 84732, 84756, 84757, 
84198, 84172, 84730, 84755, 84197
30586, 83260, 83436, 83444, 83268, 83261, 83437, 83445, 83269, 84732, 84756, 84757, 84198, 84735, 84759, 84760, 
84201, 84175, 84733, 84758, 84200
30587, 83261, 83437, 83445, 83269, 83262, 83438, 83446, 83270, 84735, 84759, 84760, 84201, 84738, 84762, 84763, 
84204, 84178, 84736, 84761, 84203
30588, 83262, 83438, 83446, 83270, 83263, 83439, 83447, 83271, 84738, 84762, 84763, 84204, 84741, 84765, 84766, 
84207, 84181, 84739, 84764, 84206
30589, 83263, 83439, 83447, 83271, 83264, 83440, 83448, 83272, 84741, 84765, 84766, 84207, 84744, 84768, 84769, 
84210, 84184, 84742, 84767, 84209
30590, 83264, 83440, 83448, 83272, 83265, 83441, 83449, 83273, 84744, 84768, 84769, 84210, 84747, 84771, 84772, 
84213, 84187, 84745, 84770, 84212
30591, 83265, 83441, 83449, 83273, 83266, 83442, 83450, 83274, 84747, 84771, 84772, 84213, 84750, 84774, 84775, 
84216, 84190, 84748, 84773, 84215
30592, 83266, 83442, 83450, 83274, 18465, 18487, 18488, 18466, 84750, 84774, 84775, 84216, 18600, 18601, 18602, 
18556, 84193, 84751, 84776, 84218
30593, 18243, 18265, 18266, 18244, 83267, 83443, 83451, 83275, 18378, 18381, 18380, 18336, 84754, 84778, 84779, 
84220, 84194, 84752, 84777, 84219
30594, 83267, 83443, 83451, 83275, 83268, 83444, 83452, 83276, 84754, 84778, 84779, 84220, 84757, 84781, 84782, 
84223, 84197, 84755, 84780, 84222
30595, 83268, 83444, 83452, 83276, 83269, 83445, 83453, 83277, 84757, 84781, 84782, 84223, 84760, 84784, 84785, 
84226, 84200, 84758, 84783, 84225
30596, 83269, 83445, 83453, 83277, 83270, 83446, 83454, 83278, 84760, 84784, 84785, 84226, 84763, 84787, 84788, 
84229, 84203, 84761, 84786, 84228
30597, 83270, 83446, 83454, 83278, 83271, 83447, 83455, 83279, 84763, 84787, 84788, 84229, 84766, 84790, 84791, 
84232, 84206, 84764, 84789, 84231
30598, 83271, 83447, 83455, 83279, 83272, 83448, 83456, 83280, 84766, 84790, 84791, 84232, 84769, 84793, 84794, 
84235, 84209, 84767, 84792, 84234
30599, 83272, 83448, 83456, 83280, 83273, 83449, 83457, 83281, 84769, 84793, 84794, 84235, 84772, 84796, 84797, 
84238, 84212, 84770, 84795, 84237
30600, 83273, 83449, 83457, 83281, 83274, 83450, 83458, 83282, 84772, 84796, 84797, 84238, 84775, 84799, 84800, 
84241, 84215, 84773, 84798, 84240
30601, 83274, 83450, 83458, 83282, 18466, 18488, 18489, 18467, 84775, 84799, 84800, 84241, 18602, 18603, 18604, 
18558, 84218, 84776, 84801, 84243
30602, 18244, 18266, 18267, 18245, 83275, 83451, 83459, 83283, 18380, 18383, 18382, 18338, 84779, 84803, 84804, 
84245, 84219, 84777, 84802, 84244
30603, 83275, 83451, 83459, 83283, 83276, 83452, 83460, 83284, 84779, 84803, 84804, 84245, 84782, 84806, 84807, 
84248, 84222, 84780, 84805, 84247
30604, 83276, 83452, 83460, 83284, 83277, 83453, 83461, 83285, 84782, 84806, 84807, 84248, 84785, 84809, 84810, 
84251, 84225, 84783, 84808, 84250
30605, 83277, 83453, 83461, 83285, 83278, 83454, 83462, 83286, 84785, 84809, 84810, 84251, 84788, 84812, 84813, 
84254, 84228, 84786, 84811, 84253
30606, 83278, 83454, 83462, 83286, 83279, 83455, 83463, 83287, 84788, 84812, 84813, 84254, 84791, 84815, 84816, 
84257, 84231, 84789, 84814, 84256
30607, 83279, 83455, 83463, 83287, 83280, 83456, 83464, 83288, 84791, 84815, 84816, 84257, 84794, 84818, 84819, 
84260, 84234, 84792, 84817, 84259
30608, 83280, 83456, 83464, 83288, 83281, 83457, 83465, 83289, 84794, 84818, 84819, 84260, 84797, 84821, 84822, 
84263, 84237, 84795, 84820, 84262
30609, 83281, 83457, 83465, 83289, 83282, 83458, 83466, 83290, 84797, 84821, 84822, 84263, 84800, 84824, 84825, 
84266, 84240, 84798, 84823, 84265
30610, 83282, 83458, 83466, 83290, 18467, 18489, 18490, 18468, 84800, 84824, 84825, 84266, 18604, 18605, 18606, 
18560, 84243, 84801, 84826, 84268
30611, 18245, 18267, 18268, 18246, 83283, 83459, 83467, 83291, 18382, 18385, 18384, 18340, 84804, 84828, 84829, 
84270, 84244, 84802, 84827, 84269
30612, 83283, 83459, 83467, 83291, 83284, 83460, 83468, 83292, 84804, 84828, 84829, 84270, 84807, 84831, 84832, 
84273, 84247, 84805, 84830, 84272
30613, 83284, 83460, 83468, 83292, 83285, 83461, 83469, 83293, 84807, 84831, 84832, 84273, 84810, 84834, 84835, 
84276, 84250, 84808, 84833, 84275
30614, 83285, 83461, 83469, 83293, 83286, 83462, 83470, 83294, 84810, 84834, 84835, 84276, 84813, 84837, 84838, 
84279, 84253, 84811, 84836, 84278
30615, 83286, 83462, 83470, 83294, 83287, 83463, 83471, 83295, 84813, 84837, 84838, 84279, 84816, 84840, 84841, 
84282, 84256, 84814, 84839, 84281
30616, 83287, 83463, 83471, 83295, 83288, 83464, 83472, 83296, 84816, 84840, 84841, 84282, 84819, 84843, 84844, 
84285, 84259, 84817, 84842, 84284
30617, 83288, 83464, 83472, 83296, 83289, 83465, 83473, 83297, 84819, 84843, 84844, 84285, 84822, 84846, 84847, 
84288, 84262, 84820, 84845, 84287
30618, 83289, 83465, 83473, 83297, 83290, 83466, 83474, 83298, 84822, 84846, 84847, 84288, 84825, 84849, 84850, 
84291, 84265, 84823, 84848, 84290
30619, 83290, 83466, 83474, 83298, 18468, 18490, 18491, 18469, 84825, 84849, 84850, 84291, 18606, 18607, 18608, 
18562, 84268, 84826, 84851, 84293
30620, 18246, 18268, 18269, 18247, 83291, 83467, 83475, 83299, 18384, 18387, 18386, 18342, 84829, 84853, 84854, 
84295, 84269, 84827, 84852, 84294
30621, 83291, 83467, 83475, 83299, 83292, 83468, 83476, 83300, 84829, 84853, 84854, 84295, 84832, 84856, 84857, 
84298, 84272, 84830, 84855, 84297
30622, 83292, 83468, 83476, 83300, 83293, 83469, 83477, 83301, 84832, 84856, 84857, 84298, 84835, 84859, 84860, 
84301, 84275, 84833, 84858, 84300
30623, 83293, 83469, 83477, 83301, 83294, 83470, 83478, 83302, 84835, 84859, 84860, 84301, 84838, 84862, 84863, 
84304, 84278, 84836, 84861, 84303
30624, 83294, 83470, 83478, 83302, 83295, 83471, 83479, 83303, 84838, 84862, 84863, 84304, 84841, 84865, 84866, 
84307, 84281, 84839, 84864, 84306
30625, 83295, 83471, 83479, 83303, 83296, 83472, 83480, 83304, 84841, 84865, 84866, 84307, 84844, 84868, 84869, 
84310, 84284, 84842, 84867, 84309
30626, 83296, 83472, 83480, 83304, 83297, 83473, 83481, 83305, 84844, 84868, 84869, 84310, 84847, 84871, 84872, 
84313, 84287, 84845, 84870, 84312
30627, 83297, 83473, 83481, 83305, 83298, 83474, 83482, 83306, 84847, 84871, 84872, 84313, 84850, 84874, 84875, 
84316, 84290, 84848, 84873, 84315
30628, 83298, 83474, 83482, 83306, 18469, 18491, 18492, 18470, 84850, 84874, 84875, 84316, 18608, 18609, 18610, 
18564, 84293, 84851, 84876, 84318
30629, 18247, 18269, 18270, 18248, 83299, 83475, 83483, 83307, 18386, 18389, 18388, 18344, 84854, 84878, 84879, 
84320, 84294, 84852, 84877, 84319
30630, 83299, 83475, 83483, 83307, 83300, 83476, 83484, 83308, 84854, 84878, 84879, 84320, 84857, 84881, 84882, 
84323, 84297, 84855, 84880, 84322
30631, 83300, 83476, 83484, 83308, 83301, 83477, 83485, 83309, 84857, 84881, 84882, 84323, 84860, 84884, 84885, 
84326, 84300, 84858, 84883, 84325
30632, 83301, 83477, 83485, 83309, 83302, 83478, 83486, 83310, 84860, 84884, 84885, 84326, 84863, 84887, 84888, 
84329, 84303, 84861, 84886, 84328
30633, 83302, 83478, 83486, 83310, 83303, 83479, 83487, 83311, 84863, 84887, 84888, 84329, 84866, 84890, 84891, 
84332, 84306, 84864, 84889, 84331
30634, 83303, 83479, 83487, 83311, 83304, 83480, 83488, 83312, 84866, 84890, 84891, 84332, 84869, 84893, 84894, 
84335, 84309, 84867, 84892, 84334
30635, 83304, 83480, 83488, 83312, 83305, 83481, 83489, 83313, 84869, 84893, 84894, 84335, 84872, 84896, 84897, 
84338, 84312, 84870, 84895, 84337
30636, 83305, 83481, 83489, 83313, 83306, 83482, 83490, 83314, 84872, 84896, 84897, 84338, 84875, 84899, 84900, 
84341, 84315, 84873, 84898, 84340
30637, 83306, 83482, 83490, 83314, 18470, 18492, 18493, 18471, 84875, 84899, 84900, 84341, 18610, 18611, 18612, 
18566, 84318, 84876, 84901, 84343
30638, 18248, 18270, 18271, 18249, 83307, 83483, 83491, 83315, 18388, 18391, 18390, 18346, 84879, 84903, 84904, 
84345, 84319, 84877, 84902, 84344
30639, 83307, 83483, 83491, 83315, 83308, 83484, 83492, 83316, 84879, 84903, 84904, 84345, 84882, 84906, 84907, 
84348, 84322, 84880, 84905, 84347
30640, 83308, 83484, 83492, 83316, 83309, 83485, 83493, 83317, 84882, 84906, 84907, 84348, 84885, 84909, 84910, 
84351, 84325, 84883, 84908, 84350
30641, 83309, 83485, 83493, 83317, 83310, 83486, 83494, 83318, 84885, 84909, 84910, 84351, 84888, 84912, 84913, 
84354, 84328, 84886, 84911, 84353
30642, 83310, 83486, 83494, 83318, 83311, 83487, 83495, 83319, 84888, 84912, 84913, 84354, 84891, 84915, 84916, 
84357, 84331, 84889, 84914, 84356
30643, 83311, 83487, 83495, 83319, 83312, 83488, 83496, 83320, 84891, 84915, 84916, 84357, 84894, 84918, 84919, 
84360, 84334, 84892, 84917, 84359
30644, 83312, 83488, 83496, 83320, 83313, 83489, 83497, 83321, 84894, 84918, 84919, 84360, 84897, 84921, 84922, 
84363, 84337, 84895, 84920, 84362
30645, 83313, 83489, 83497, 83321, 83314, 83490, 83498, 83322, 84897, 84921, 84922, 84363, 84900, 84924, 84925, 
84366, 84340, 84898, 84923, 84365
30646, 83314, 83490, 83498, 83322, 18471, 18493, 18494, 18472, 84900, 84924, 84925, 84366, 18612, 18613, 18614, 
18568, 84343, 84901, 84926, 84368
30647, 18249, 18271, 18272, 18250, 83315, 83491, 83499, 83323, 18390, 18393, 18392, 18348, 84904, 84928, 84929, 
84370, 84344, 84902, 84927, 84369
30648, 83315, 83491, 83499, 83323, 83316, 83492, 83500, 83324, 84904, 84928, 84929, 84370, 84907, 84931, 84932, 
84373, 84347, 84905, 84930, 84372
30649, 83316, 83492, 83500, 83324, 83317, 83493, 83501, 83325, 84907, 84931, 84932, 84373, 84910, 84934, 84935, 
84376, 84350, 84908, 84933, 84375
30650, 83317, 83493, 83501, 83325, 83318, 83494, 83502, 83326, 84910, 84934, 84935, 84376, 84913, 84937, 84938, 
84379, 84353, 84911, 84936, 84378
30651, 83318, 83494, 83502, 83326, 83319, 83495, 83503, 83327, 84913, 84937, 84938, 84379, 84916, 84940, 84941, 
84382, 84356, 84914, 84939, 84381
30652, 83319, 83495, 83503, 83327, 83320, 83496, 83504, 83328, 84916, 84940, 84941, 84382, 84919, 84943, 84944, 
84385, 84359, 84917, 84942, 84384
30653, 83320, 83496, 83504, 83328, 83321, 83497, 83505, 83329, 84919, 84943, 84944, 84385, 84922, 84946, 84947, 
84388, 84362, 84920, 84945, 84387
30654, 83321, 83497, 83505, 83329, 83322, 83498, 83506, 83330, 84922, 84946, 84947, 84388, 84925, 84949, 84950, 
84391, 84365, 84923, 84948, 84390
30655, 83322, 83498, 83506, 83330, 18472, 18494, 18495, 18473, 84925, 84949, 84950, 84391, 18614, 18615, 18616, 
18570, 84368, 84926, 84951, 84393
30656, 18250, 18272, 18273, 18251, 83323, 83499, 83507, 83331, 18392, 18395, 18394, 18350, 84929, 84953, 84954, 
84395, 84369, 84927, 84952, 84394
30657, 83323, 83499, 83507, 83331, 83324, 83500, 83508, 83332, 84929, 84953, 84954, 84395, 84932, 84956, 84957, 
84398, 84372, 84930, 84955, 84397
30658, 83324, 83500, 83508, 83332, 83325, 83501, 83509, 83333, 84932, 84956, 84957, 84398, 84935, 84959, 84960, 
84401, 84375, 84933, 84958, 84400
30659, 83325, 83501, 83509, 83333, 83326, 83502, 83510, 83334, 84935, 84959, 84960, 84401, 84938, 84962, 84963, 
84404, 84378, 84936, 84961, 84403
30660, 83326, 83502, 83510, 83334, 83327, 83503, 83511, 83335, 84938, 84962, 84963, 84404, 84941, 84965, 84966, 
84407, 84381, 84939, 84964, 84406
30661, 83327, 83503, 83511, 83335, 83328, 83504, 83512, 83336, 84941, 84965, 84966, 84407, 84944, 84968, 84969, 
84410, 84384, 84942, 84967, 84409
30662, 83328, 83504, 83512, 83336, 83329, 83505, 83513, 83337, 84944, 84968, 84969, 84410, 84947, 84971, 84972, 
84413, 84387, 84945, 84970, 84412
30663, 83329, 83505, 83513, 83337, 83330, 83506, 83514, 83338, 84947, 84971, 84972, 84413, 84950, 84974, 84975, 
84416, 84390, 84948, 84973, 84415
30664, 83330, 83506, 83514, 83338, 18473, 18495, 18496, 18474, 84950, 84974, 84975, 84416, 18616, 18617, 18618, 
18572, 84393, 84951, 84976, 84418
30665, 18251, 18273, 18274, 18252, 83331, 83507, 83515, 83339, 18394, 18397, 18396, 18352, 84954, 84978, 84979, 
84420, 84394, 84952, 84977, 84419
30666, 83331, 83507, 83515, 83339, 83332, 83508, 83516, 83340, 84954, 84978, 84979, 84420, 84957, 84981, 84982, 
84423, 84397, 84955, 84980, 84422
30667, 83332, 83508, 83516, 83340, 83333, 83509, 83517, 83341, 84957, 84981, 84982, 84423, 84960, 84984, 84985, 
84426, 84400, 84958, 84983, 84425
30668, 83333, 83509, 83517, 83341, 83334, 83510, 83518, 83342, 84960, 84984, 84985, 84426, 84963, 84987, 84988, 
84429, 84403, 84961, 84986, 84428
30669, 83334, 83510, 83518, 83342, 83335, 83511, 83519, 83343, 84963, 84987, 84988, 84429, 84966, 84990, 84991, 
84432, 84406, 84964, 84989, 84431
30670, 83335, 83511, 83519, 83343, 83336, 83512, 83520, 83344, 84966, 84990, 84991, 84432, 84969, 84993, 84994, 
84435, 84409, 84967, 84992, 84434
30671, 83336, 83512, 83520, 83344, 83337, 83513, 83521, 83345, 84969, 84993, 84994, 84435, 84972, 84996, 84997, 
84438, 84412, 84970, 84995, 84437
30672, 83337, 83513, 83521, 83345, 83338, 83514, 83522, 83346, 84972, 84996, 84997, 84438, 84975, 84999, 85000, 
84441, 84415, 84973, 84998, 84440
30673, 83338, 83514, 83522, 83346, 18474, 18496, 18497, 18475, 84975, 84999, 85000, 84441, 18618, 18619, 18620, 
18574, 84418, 84976, 85001, 84443
30674, 18252, 18274, 18275, 18253, 83339, 83515, 83523, 83347, 18396, 18399, 18398, 18354, 84979, 85003, 85004, 
84445, 84419, 84977, 85002, 84444
30675, 83339, 83515, 83523, 83347, 83340, 83516, 83524, 83348, 84979, 85003, 85004, 84445, 84982, 85006, 85007, 
84448, 84422, 84980, 85005, 84447
30676, 83340, 83516, 83524, 83348, 83341, 83517, 83525, 83349, 84982, 85006, 85007, 84448, 84985, 85009, 85010, 
84451, 84425, 84983, 85008, 84450
30677, 83341, 83517, 83525, 83349, 83342, 83518, 83526, 83350, 84985, 85009, 85010, 84451, 84988, 85012, 85013, 
84454, 84428, 84986, 85011, 84453
30678, 83342, 83518, 83526, 83350, 83343, 83519, 83527, 83351, 84988, 85012, 85013, 84454, 84991, 85015, 85016, 
84457, 84431, 84989, 85014, 84456
30679, 83343, 83519, 83527, 83351, 83344, 83520, 83528, 83352, 84991, 85015, 85016, 84457, 84994, 85018, 85019, 
84460, 84434, 84992, 85017, 84459
30680, 83344, 83520, 83528, 83352, 83345, 83521, 83529, 83353, 84994, 85018, 85019, 84460, 84997, 85021, 85022, 
84463, 84437, 84995, 85020, 84462
30681, 83345, 83521, 83529, 83353, 83346, 83522, 83530, 83354, 84997, 85021, 85022, 84463, 85000, 85024, 85025, 
84466, 84440, 84998, 85023, 84465
30682, 83346, 83522, 83530, 83354, 18475, 18497, 18498, 18476, 85000, 85024, 85025, 84466, 18620, 18621, 18622, 
18576, 84443, 85001, 85026, 84468
30683, 18253, 18275, 18276, 18254, 83347, 83523, 83531, 83355, 18398, 18401, 18400, 18356, 85004, 85028, 85029, 
84470, 84444, 85002, 85027, 84469
30684, 83347, 83523, 83531, 83355, 83348, 83524, 83532, 83356, 85004, 85028, 85029, 84470, 85007, 85031, 85032, 
84473, 84447, 85005, 85030, 84472
30685, 83348, 83524, 83532, 83356, 83349, 83525, 83533, 83357, 85007, 85031, 85032, 84473, 85010, 85034, 85035, 
84476, 84450, 85008, 85033, 84475
30686, 83349, 83525, 83533, 83357, 83350, 83526, 83534, 83358, 85010, 85034, 85035, 84476, 85013, 85037, 85038, 
84479, 84453, 85011, 85036, 84478
30687, 83350, 83526, 83534, 83358, 83351, 83527, 83535, 83359, 85013, 85037, 85038, 84479, 85016, 85040, 85041, 
84482, 84456, 85014, 85039, 84481
30688, 83351, 83527, 83535, 83359, 83352, 83528, 83536, 83360, 85016, 85040, 85041, 84482, 85019, 85043, 85044, 
84485, 84459, 85017, 85042, 84484
30689, 83352, 83528, 83536, 83360, 83353, 83529, 83537, 83361, 85019, 85043, 85044, 84485, 85022, 85046, 85047, 
84488, 84462, 85020, 85045, 84487
30690, 83353, 83529, 83537, 83361, 83354, 83530, 83538, 83362, 85022, 85046, 85047, 84488, 85025, 85049, 85050, 
84491, 84465, 85023, 85048, 84490
30691, 83354, 83530, 83538, 83362, 18476, 18498, 18499, 18477, 85025, 85049, 85050, 84491, 18622, 18623, 18624, 
18578, 84468, 85026, 85051, 84493
30692, 18254, 18276, 18277, 18255, 83355, 83531, 83539, 83363, 18400, 18403, 18402, 18358, 85029, 85053, 85054, 
84495, 84469, 85027, 85052, 84494
30693, 83355, 83531, 83539, 83363, 83356, 83532, 83540, 83364, 85029, 85053, 85054, 84495, 85032, 85056, 85057, 
84498, 84472, 85030, 85055, 84497
30694, 83356, 83532, 83540, 83364, 83357, 83533, 83541, 83365, 85032, 85056, 85057, 84498, 85035, 85059, 85060, 
84501, 84475, 85033, 85058, 84500
30695, 83357, 83533, 83541, 83365, 83358, 83534, 83542, 83366, 85035, 85059, 85060, 84501, 85038, 85062, 85063, 
84504, 84478, 85036, 85061, 84503
30696, 83358, 83534, 83542, 83366, 83359, 83535, 83543, 83367, 85038, 85062, 85063, 84504, 85041, 85065, 85066, 
84507, 84481, 85039, 85064, 84506
30697, 83359, 83535, 83543, 83367, 83360, 83536, 83544, 83368, 85041, 85065, 85066, 84507, 85044, 85068, 85069, 
84510, 84484, 85042, 85067, 84509
30698, 83360, 83536, 83544, 83368, 83361, 83537, 83545, 83369, 85044, 85068, 85069, 84510, 85047, 85071, 85072, 
84513, 84487, 85045, 85070, 84512
30699, 83361, 83537, 83545, 83369, 83362, 83538, 83546, 83370, 85047, 85071, 85072, 84513, 85050, 85074, 85075, 
84516, 84490, 85048, 85073, 84515
30700, 83362, 83538, 83546, 83370, 18477, 18499, 18500, 18478, 85050, 85074, 85075, 84516, 18624, 18625, 18626, 
18580, 84493, 85051, 85076, 84518
30701, 18255, 18277, 18278, 18256, 83363, 83539, 83547, 83371, 18402, 18405, 18404, 18360, 85054, 85078, 85079, 
84520, 84494, 85052, 85077, 84519
30702, 83363, 83539, 83547, 83371, 83364, 83540, 83548, 83372, 85054, 85078, 85079, 84520, 85057, 85081, 85082, 
84523, 84497, 85055, 85080, 84522
30703, 83364, 83540, 83548, 83372, 83365, 83541, 83549, 83373, 85057, 85081, 85082, 84523, 85060, 85084, 85085, 
84526, 84500, 85058, 85083, 84525
30704, 83365, 83541, 83549, 83373, 83366, 83542, 83550, 83374, 85060, 85084, 85085, 84526, 85063, 85087, 85088, 
84529, 84503, 85061, 85086, 84528
30705, 83366, 83542, 83550, 83374, 83367, 83543, 83551, 83375, 85063, 85087, 85088, 84529, 85066, 85090, 85091, 
84532, 84506, 85064, 85089, 84531
30706, 83367, 83543, 83551, 83375, 83368, 83544, 83552, 83376, 85066, 85090, 85091, 84532, 85069, 85093, 85094, 
84535, 84509, 85067, 85092, 84534
30707, 83368, 83544, 83552, 83376, 83369, 83545, 83553, 83377, 85069, 85093, 85094, 84535, 85072, 85096, 85097, 
84538, 84512, 85070, 85095, 84537
30708, 83369, 83545, 83553, 83377, 83370, 83546, 83554, 83378, 85072, 85096, 85097, 84538, 85075, 85099, 85100, 
84541, 84515, 85073, 85098, 84540
30709, 83370, 83546, 83554, 83378, 18478, 18500, 18501, 18479, 85075, 85099, 85100, 84541, 18626, 18627, 18628, 
18582, 84518, 85076, 85101, 84543
30710, 18256, 18278, 18279, 18257, 83371, 83547, 83555, 83379, 18404, 18407, 18406, 18362, 85079, 85103, 85104, 
84545, 84519, 85077, 85102, 84544
30711, 83371, 83547, 83555, 83379, 83372, 83548, 83556, 83380, 85079, 85103, 85104, 84545, 85082, 85106, 85107, 
84548, 84522, 85080, 85105, 84547
30712, 83372, 83548, 83556, 83380, 83373, 83549, 83557, 83381, 85082, 85106, 85107, 84548, 85085, 85109, 85110, 
84551, 84525, 85083, 85108, 84550
30713, 83373, 83549, 83557, 83381, 83374, 83550, 83558, 83382, 85085, 85109, 85110, 84551, 85088, 85112, 85113, 
84554, 84528, 85086, 85111, 84553
30714, 83374, 83550, 83558, 83382, 83375, 83551, 83559, 83383, 85088, 85112, 85113, 84554, 85091, 85115, 85116, 
84557, 84531, 85089, 85114, 84556
30715, 83375, 83551, 83559, 83383, 83376, 83552, 83560, 83384, 85091, 85115, 85116, 84557, 85094, 85118, 85119, 
84560, 84534, 85092, 85117, 84559
30716, 83376, 83552, 83560, 83384, 83377, 83553, 83561, 83385, 85094, 85118, 85119, 84560, 85097, 85121, 85122, 
84563, 84537, 85095, 85120, 84562
30717, 83377, 83553, 83561, 83385, 83378, 83554, 83562, 83386, 85097, 85121, 85122, 84563, 85100, 85124, 85125, 
84566, 84540, 85098, 85123, 84565
30718, 83378, 83554, 83562, 83386, 18479, 18501, 18502, 18480, 85100, 85124, 85125, 84566, 18628, 18629, 18630, 
18584, 84543, 85101, 85126, 84568
30719, 18257, 18279, 18280, 18258, 83379, 83555, 83563, 83387, 18406, 18409, 18408, 18364, 85104, 85128, 85129, 
84570, 84544, 85102, 85127, 84569
30720, 83379, 83555, 83563, 83387, 83380, 83556, 83564, 83388, 85104, 85128, 85129, 84570, 85107, 85131, 85132, 
84573, 84547, 85105, 85130, 84572
30721, 83380, 83556, 83564, 83388, 83381, 83557, 83565, 83389, 85107, 85131, 85132, 84573, 85110, 85134, 85135, 
84576, 84550, 85108, 85133, 84575
30722, 83381, 83557, 83565, 83389, 83382, 83558, 83566, 83390, 85110, 85134, 85135, 84576, 85113, 85137, 85138, 
84579, 84553, 85111, 85136, 84578
30723, 83382, 83558, 83566, 83390, 83383, 83559, 83567, 83391, 85113, 85137, 85138, 84579, 85116, 85140, 85141, 
84582, 84556, 85114, 85139, 84581
30724, 83383, 83559, 83567, 83391, 83384, 83560, 83568, 83392, 85116, 85140, 85141, 84582, 85119, 85143, 85144, 
84585, 84559, 85117, 85142, 84584
30725, 83384, 83560, 83568, 83392, 83385, 83561, 83569, 83393, 85119, 85143, 85144, 84585, 85122, 85146, 85147, 
84588, 84562, 85120, 85145, 84587
30726, 83385, 83561, 83569, 83393, 83386, 83562, 83570, 83394, 85122, 85146, 85147, 84588, 85125, 85149, 85150, 
84591, 84565, 85123, 85148, 84590
30727, 83386, 83562, 83570, 83394, 18480, 18502, 18503, 18481, 85125, 85149, 85150, 84591, 18630, 18631, 18632, 
18586, 84568, 85126, 85151, 84593
30728, 18258, 18280, 18281, 18259, 83387, 83563, 83571, 83395, 18408, 18411, 18410, 18366, 85129, 85153, 85154, 
84595, 84569, 85127, 85152, 84594
30729, 83387, 83563, 83571, 83395, 83388, 83564, 83572, 83396, 85129, 85153, 85154, 84595, 85132, 85156, 85157, 
84598, 84572, 85130, 85155, 84597
30730, 83388, 83564, 83572, 83396, 83389, 83565, 83573, 83397, 85132, 85156, 85157, 84598, 85135, 85159, 85160, 
84601, 84575, 85133, 85158, 84600
30731, 83389, 83565, 83573, 83397, 83390, 83566, 83574, 83398, 85135, 85159, 85160, 84601, 85138, 85162, 85163, 
84604, 84578, 85136, 85161, 84603
30732, 83390, 83566, 83574, 83398, 83391, 83567, 83575, 83399, 85138, 85162, 85163, 84604, 85141, 85165, 85166, 
84607, 84581, 85139, 85164, 84606
30733, 83391, 83567, 83575, 83399, 83392, 83568, 83576, 83400, 85141, 85165, 85166, 84607, 85144, 85168, 85169, 
84610, 84584, 85142, 85167, 84609
30734, 83392, 83568, 83576, 83400, 83393, 83569, 83577, 83401, 85144, 85168, 85169, 84610, 85147, 85171, 85172, 
84613, 84587, 85145, 85170, 84612
30735, 83393, 83569, 83577, 83401, 83394, 83570, 83578, 83402, 85147, 85171, 85172, 84613, 85150, 85174, 85175, 
84616, 84590, 85148, 85173, 84615
30736, 83394, 83570, 83578, 83402, 18481, 18503, 18504, 18482, 85150, 85174, 85175, 84616, 18632, 18633, 18634, 
18588, 84593, 85151, 85176, 84618
30737, 18259, 18281, 18282, 18260, 83395, 83571, 83579, 83403, 18410, 18413, 18412, 18368, 85154, 85178, 85179, 
84620, 84594, 85152, 85177, 84619
30738, 83395, 83571, 83579, 83403, 83396, 83572, 83580, 83404, 85154, 85178, 85179, 84620, 85157, 85181, 85182, 
84623, 84597, 85155, 85180, 84622
30739, 83396, 83572, 83580, 83404, 83397, 83573, 83581, 83405, 85157, 85181, 85182, 84623, 85160, 85184, 85185, 
84626, 84600, 85158, 85183, 84625
30740, 83397, 83573, 83581, 83405, 83398, 83574, 83582, 83406, 85160, 85184, 85185, 84626, 85163, 85187, 85188, 
84629, 84603, 85161, 85186, 84628
30741, 83398, 83574, 83582, 83406, 83399, 83575, 83583, 83407, 85163, 85187, 85188, 84629, 85166, 85190, 85191, 
84632, 84606, 85164, 85189, 84631
30742, 83399, 83575, 83583, 83407, 83400, 83576, 83584, 83408, 85166, 85190, 85191, 84632, 85169, 85193, 85194, 
84635, 84609, 85167, 85192, 84634
30743, 83400, 83576, 83584, 83408, 83401, 83577, 83585, 83409, 85169, 85193, 85194, 84635, 85172, 85196, 85197, 
84638, 84612, 85170, 85195, 84637
30744, 83401, 83577, 83585, 83409, 83402, 83578, 83586, 83410, 85172, 85196, 85197, 84638, 85175, 85199, 85200, 
84641, 84615, 85173, 85198, 84640
30745, 83402, 83578, 83586, 83410, 18482, 18504, 18505, 18483, 85175, 85199, 85200, 84641, 18634, 18635, 18636, 
18590, 84618, 85176, 85201, 84643
30746, 18260, 18282, 18283, 18261, 83403, 83579, 83587, 83411, 18412, 18415, 18414, 18370, 85179, 85203, 85204, 
84645, 84619, 85177, 85202, 84644
30747, 83403, 83579, 83587, 83411, 83404, 83580, 83588, 83412, 85179, 85203, 85204, 84645, 85182, 85206, 85207, 
84648, 84622, 85180, 85205, 84647
30748, 83404, 83580, 83588, 83412, 83405, 83581, 83589, 83413, 85182, 85206, 85207, 84648, 85185, 85209, 85210, 
84651, 84625, 85183, 85208, 84650
30749, 83405, 83581, 83589, 83413, 83406, 83582, 83590, 83414, 85185, 85209, 85210, 84651, 85188, 85212, 85213, 
84654, 84628, 85186, 85211, 84653
30750, 83406, 83582, 83590, 83414, 83407, 83583, 83591, 83415, 85188, 85212, 85213, 84654, 85191, 85215, 85216, 
84657, 84631, 85189, 85214, 84656
30751, 83407, 83583, 83591, 83415, 83408, 83584, 83592, 83416, 85191, 85215, 85216, 84657, 85194, 85218, 85219, 
84660, 84634, 85192, 85217, 84659
30752, 83408, 83584, 83592, 83416, 83409, 83585, 83593, 83417, 85194, 85218, 85219, 84660, 85197, 85221, 85222, 
84663, 84637, 85195, 85220, 84662
30753, 83409, 83585, 83593, 83417, 83410, 83586, 83594, 83418, 85197, 85221, 85222, 84663, 85200, 85224, 85225, 
84666, 84640, 85198, 85223, 84665
30754, 83410, 83586, 83594, 83418, 18483, 18505, 18506, 18484, 85200, 85224, 85225, 84666, 18636, 18637, 18638, 
18592, 84643, 85201, 85226, 84668
30755, 18261, 18283, 18284, 18262, 83411, 83587, 83595, 83419, 18414, 18417, 18416, 18372, 85204, 85228, 85229, 
84670, 84644, 85202, 85227, 84669
30756, 83411, 83587, 83595, 83419, 83412, 83588, 83596, 83420, 85204, 85228, 85229, 84670, 85207, 85231, 85232, 
84673, 84647, 85205, 85230, 84672
30757, 83412, 83588, 83596, 83420, 83413, 83589, 83597, 83421, 85207, 85231, 85232, 84673, 85210, 85234, 85235, 
84676, 84650, 85208, 85233, 84675
30758, 83413, 83589, 83597, 83421, 83414, 83590, 83598, 83422, 85210, 85234, 85235, 84676, 85213, 85237, 85238, 
84679, 84653, 85211, 85236, 84678
30759, 83414, 83590, 83598, 83422, 83415, 83591, 83599, 83423, 85213, 85237, 85238, 84679, 85216, 85240, 85241, 
84682, 84656, 85214, 85239, 84681
30760, 83415, 83591, 83599, 83423, 83416, 83592, 83600, 83424, 85216, 85240, 85241, 84682, 85219, 85243, 85244, 
84685, 84659, 85217, 85242, 84684
30761, 83416, 83592, 83600, 83424, 83417, 83593, 83601, 83425, 85219, 85243, 85244, 84685, 85222, 85246, 85247, 
84688, 84662, 85220, 85245, 84687
30762, 83417, 83593, 83601, 83425, 83418, 83594, 83602, 83426, 85222, 85246, 85247, 84688, 85225, 85249, 85250, 
84691, 84665, 85223, 85248, 84690
30763, 83418, 83594, 83602, 83426, 18484, 18506, 18507, 18485, 85225, 85249, 85250, 84691, 18638, 18639, 18640, 
18594, 84668, 85226, 85251, 84693
30764, 18262, 18284, 18285, 18263, 83419, 83595, 83603, 83427, 18416, 18419, 18418, 18374, 85229, 85253, 85254, 
84695, 84669, 85227, 85252, 84694
30765, 83419, 83595, 83603, 83427, 83420, 83596, 83604, 83428, 85229, 85253, 85254, 84695, 85232, 85256, 85257, 
84698, 84672, 85230, 85255, 84697
30766, 83420, 83596, 83604, 83428, 83421, 83597, 83605, 83429, 85232, 85256, 85257, 84698, 85235, 85259, 85260, 
84701, 84675, 85233, 85258, 84700
30767, 83421, 83597, 83605, 83429, 83422, 83598, 83606, 83430, 85235, 85259, 85260, 84701, 85238, 85262, 85263, 
84704, 84678, 85236, 85261, 84703
30768, 83422, 83598, 83606, 83430, 83423, 83599, 83607, 83431, 85238, 85262, 85263, 84704, 85241, 85265, 85266, 
84707, 84681, 85239, 85264, 84706
30769, 83423, 83599, 83607, 83431, 83424, 83600, 83608, 83432, 85241, 85265, 85266, 84707, 85244, 85268, 85269, 
84710, 84684, 85242, 85267, 84709
30770, 83424, 83600, 83608, 83432, 83425, 83601, 83609, 83433, 85244, 85268, 85269, 84710, 85247, 85271, 85272, 
84713, 84687, 85245, 85270, 84712
30771, 83425, 83601, 83609, 83433, 83426, 83602, 83610, 83434, 85247, 85271, 85272, 84713, 85250, 85274, 85275, 
84716, 84690, 85248, 85273, 84715
30772, 83426, 83602, 83610, 83434, 18485, 18507, 18508, 18486, 85250, 85274, 85275, 84716, 18640, 18641, 18642, 
18596, 84693, 85251, 85276, 84718
30773, 18263, 18285, 2518, 2517, 83427, 83603, 18682, 18674, 18418, 18420, 2521, 18375, 85254, 85277, 18724, 
84719, 84694, 85252, 18725, 18708
30774, 83427, 83603, 18682, 18674, 83428, 83604, 18683, 18675, 85254, 85277, 18724, 84719, 85257, 85278, 18726, 
84720, 84697, 85255, 18727, 18710
30775, 83428, 83604, 18683, 18675, 83429, 83605, 18684, 18676, 85257, 85278, 18726, 84720, 85260, 85279, 18728, 
84721, 84700, 85258, 18729, 18712
30776, 83429, 83605, 18684, 18676, 83430, 83606, 18685, 18677, 85260, 85279, 18728, 84721, 85263, 85280, 18730, 
84722, 84703, 85261, 18731, 18714
30777, 83430, 83606, 18685, 18677, 83431, 83607, 18686, 18678, 85263, 85280, 18730, 84722, 85266, 85281, 18732, 
84723, 84706, 85264, 18733, 18716
30778, 83431, 83607, 18686, 18678, 83432, 83608, 18687, 18679, 85266, 85281, 18732, 84723, 85269, 85282, 18734, 
84724, 84709, 85267, 18735, 18718
30779, 83432, 83608, 18687, 18679, 83433, 83609, 18688, 18680, 85269, 85282, 18734, 84724, 85272, 85283, 18736, 
84725, 84712, 85270, 18737, 18720
30780, 83433, 83609, 18688, 18680, 83434, 83610, 18689, 18681, 85272, 85283, 18736, 84725, 85275, 85284, 18738, 
84726, 84715, 85273, 18739, 18722
30781, 83434, 83610, 18689, 18681, 18486, 18508, 2570, 2569, 85275, 85284, 18738, 84726, 18642, 18643, 2573, 
18598, 84718, 85276, 18740, 18723
30782, 1772, 58, 2523, 18264, 13718, 1829, 18749, 83435, 1776, 2545, 18421, 18377, 13777, 18926, 85285, 
84728, 13761, 1838, 18925, 84727
30783, 13718, 1829, 18749, 83435, 13719, 1828, 18750, 83436, 13777, 18926, 85285, 84728, 13778, 18928, 85286, 
84731, 13763, 1837, 18927, 84730
30784, 13719, 1828, 18750, 83436, 13720, 1827, 18751, 83437, 13778, 18928, 85286, 84731, 13779, 18930, 85287, 
84734, 13765, 1836, 18929, 84733
30785, 13720, 1827, 18751, 83437, 13721, 1826, 18752, 83438, 13779, 18930, 85287, 84734, 13780, 18932, 85288, 
84737, 13767, 1835, 18931, 84736
30786, 13721, 1826, 18752, 83438, 13722, 1825, 18753, 83439, 13780, 18932, 85288, 84737, 13781, 18934, 85289, 
84740, 13769, 1834, 18933, 84739
30787, 13722, 1825, 18753, 83439, 13723, 1824, 18754, 83440, 13781, 18934, 85289, 84740, 13782, 18936, 85290, 
84743, 13771, 1833, 18935, 84742
30788, 13723, 1824, 18754, 83440, 13724, 1823, 18755, 83441, 13782, 18936, 85290, 84743, 13783, 18938, 85291, 
84746, 13773, 1832, 18937, 84745
30789, 13724, 1823, 18755, 83441, 13725, 1822, 18756, 83442, 13783, 18938, 85291, 84746, 13784, 18940, 85292, 
84749, 13775, 1831, 18939, 84748
30790, 13725, 1822, 18756, 83442, 1793, 60, 2575, 18487, 13784, 18940, 85292, 84749, 1797, 2597, 18644, 
18599, 13776, 1830, 18941, 84751
30791, 18264, 2523, 2524, 18265, 83435, 18749, 18757, 83443, 18421, 2546, 18422, 18379, 85285, 18943, 85293, 
84753, 84727, 18925, 18942, 84752
30792, 83435, 18749, 18757, 83443, 83436, 18750, 18758, 83444, 85285, 18943, 85293, 84753, 85286, 18945, 85294, 
84756, 84730, 18927, 18944, 84755
30793, 83436, 18750, 18758, 83444, 83437, 18751, 18759, 83445, 85286, 18945, 85294, 84756, 85287, 18947, 85295, 
84759, 84733, 18929, 18946, 84758
30794, 83437, 18751, 18759, 83445, 83438, 18752, 18760, 83446, 85287, 18947, 85295, 84759, 85288, 18949, 85296, 
84762, 84736, 18931, 18948, 84761
30795, 83438, 18752, 18760, 83446, 83439, 18753, 18761, 83447, 85288, 18949, 85296, 84762, 85289, 18951, 85297, 
84765, 84739, 18933, 18950, 84764
30796, 83439, 18753, 18761, 83447, 83440, 18754, 18762, 83448, 85289, 18951, 85297, 84765, 85290, 18953, 85298, 
84768, 84742, 18935, 18952, 84767
30797, 83440, 18754, 18762, 83448, 83441, 18755, 18763, 83449, 85290, 18953, 85298, 84768, 85291, 18955, 85299, 
84771, 84745, 18937, 18954, 84770
30798, 83441, 18755, 18763, 83449, 83442, 18756, 18764, 83450, 85291, 18955, 85299, 84771, 85292, 18957, 85300, 
84774, 84748, 18939, 18956, 84773
30799, 83442, 18756, 18764, 83450, 18487, 2575, 2576, 18488, 85292, 18957, 85300, 84774, 18644, 2598, 18645, 
18601, 84751, 18941, 18958, 84776
30800, 18265, 2524, 2525, 18266, 83443, 18757, 18765, 83451, 18422, 2547, 18423, 18381, 85293, 18960, 85301, 
84778, 84752, 18942, 18959, 84777
30801, 83443, 18757, 18765, 83451, 83444, 18758, 18766, 83452, 85293, 18960, 85301, 84778, 85294, 18962, 85302, 
84781, 84755, 18944, 18961, 84780
30802, 83444, 18758, 18766, 83452, 83445, 18759, 18767, 83453, 85294, 18962, 85302, 84781, 85295, 18964, 85303, 
84784, 84758, 18946, 18963, 84783
30803, 83445, 18759, 18767, 83453, 83446, 18760, 18768, 83454, 85295, 18964, 85303, 84784, 85296, 18966, 85304, 
84787, 84761, 18948, 18965, 84786
30804, 83446, 18760, 18768, 83454, 83447, 18761, 18769, 83455, 85296, 18966, 85304, 84787, 85297, 18968, 85305, 
84790, 84764, 18950, 18967, 84789
30805, 83447, 18761, 18769, 83455, 83448, 18762, 18770, 83456, 85297, 18968, 85305, 84790, 85298, 18970, 85306, 
84793, 84767, 18952, 18969, 84792
30806, 83448, 18762, 18770, 83456, 83449, 18763, 18771, 83457, 85298, 18970, 85306, 84793, 85299, 18972, 85307, 
84796, 84770, 18954, 18971, 84795
30807, 83449, 18763, 18771, 83457, 83450, 18764, 18772, 83458, 85299, 18972, 85307, 84796, 85300, 18974, 85308, 
84799, 84773, 18956, 18973, 84798
30808, 83450, 18764, 18772, 83458, 18488, 2576, 2577, 18489, 85300, 18974, 85308, 84799, 18645, 2599, 18646, 
18603, 84776, 18958, 18975, 84801
30809, 18266, 2525, 2526, 18267, 83451, 18765, 18773, 83459, 18423, 2548, 18424, 18383, 85301, 18977, 85309, 
84803, 84777, 18959, 18976, 84802
30810, 83451, 18765, 18773, 83459, 83452, 18766, 18774, 83460, 85301, 18977, 85309, 84803, 85302, 18979, 85310, 
84806, 84780, 18961, 18978, 84805
30811, 83452, 18766, 18774, 83460, 83453, 18767, 18775, 83461, 85302, 18979, 85310, 84806, 85303, 18981, 85311, 
84809, 84783, 18963, 18980, 84808
30812, 83453, 18767, 18775, 83461, 83454, 18768, 18776, 83462, 85303, 18981, 85311, 84809, 85304, 18983, 85312, 
84812, 84786, 18965, 18982, 84811
30813, 83454, 18768, 18776, 83462, 83455, 18769, 18777, 83463, 85304, 18983, 85312, 84812, 85305, 18985, 85313, 
84815, 84789, 18967, 18984, 84814
30814, 83455, 18769, 18777, 83463, 83456, 18770, 18778, 83464, 85305, 18985, 85313, 84815, 85306, 18987, 85314, 
84818, 84792, 18969, 18986, 84817
30815, 83456, 18770, 18778, 83464, 83457, 18771, 18779, 83465, 85306, 18987, 85314, 84818, 85307, 18989, 85315, 
84821, 84795, 18971, 18988, 84820
30816, 83457, 18771, 18779, 83465, 83458, 18772, 18780, 83466, 85307, 18989, 85315, 84821, 85308, 18991, 85316, 
84824, 84798, 18973, 18990, 84823
30817, 83458, 18772, 18780, 83466, 18489, 2577, 2578, 18490, 85308, 18991, 85316, 84824, 18646, 2600, 18647, 
18605, 84801, 18975, 18992, 84826
30818, 18267, 2526, 2527, 18268, 83459, 18773, 18781, 83467, 18424, 2549, 18425, 18385, 85309, 18994, 85317, 
84828, 84802, 18976, 18993, 84827
30819, 83459, 18773, 18781, 83467, 83460, 18774, 18782, 83468, 85309, 18994, 85317, 84828, 85310, 18996, 85318, 
84831, 84805, 18978, 18995, 84830
30820, 83460, 18774, 18782, 83468, 83461, 18775, 18783, 83469, 85310, 18996, 85318, 84831, 85311, 18998, 85319, 
84834, 84808, 18980, 18997, 84833
30821, 83461, 18775, 18783, 83469, 83462, 18776, 18784, 83470, 85311, 18998, 85319, 84834, 85312, 19000, 85320, 
84837, 84811, 18982, 18999, 84836
30822, 83462, 18776, 18784, 83470, 83463, 18777, 18785, 83471, 85312, 19000, 85320, 84837, 85313, 19002, 85321, 
84840, 84814, 18984, 19001, 84839
30823, 83463, 18777, 18785, 83471, 83464, 18778, 18786, 83472, 85313, 19002, 85321, 84840, 85314, 19004, 85322, 
84843, 84817, 18986, 19003, 84842
30824, 83464, 18778, 18786, 83472, 83465, 18779, 18787, 83473, 85314, 19004, 85322, 84843, 85315, 19006, 85323, 
84846, 84820, 18988, 19005, 84845
30825, 83465, 18779, 18787, 83473, 83466, 18780, 18788, 83474, 85315, 19006, 85323, 84846, 85316, 19008, 85324, 
84849, 84823, 18990, 19007, 84848
30826, 83466, 18780, 18788, 83474, 18490, 2578, 2579, 18491, 85316, 19008, 85324, 84849, 18647, 2601, 18648, 
18607, 84826, 18992, 19009, 84851
30827, 18268, 2527, 2528, 18269, 83467, 18781, 18789, 83475, 18425, 2550, 18426, 18387, 85317, 19011, 85325, 
84853, 84827, 18993, 19010, 84852
30828, 83467, 18781, 18789, 83475, 83468, 18782, 18790, 83476, 85317, 19011, 85325, 84853, 85318, 19013, 85326, 
84856, 84830, 18995, 19012, 84855
30829, 83468, 18782, 18790, 83476, 83469, 18783, 18791, 83477, 85318, 19013, 85326, 84856, 85319, 19015, 85327, 
84859, 84833, 18997, 19014, 84858
30830, 83469, 18783, 18791, 83477, 83470, 18784, 18792, 83478, 85319, 19015, 85327, 84859, 85320, 19017, 85328, 
84862, 84836, 18999, 19016, 84861
30831, 83470, 18784, 18792, 83478, 83471, 18785, 18793, 83479, 85320, 19017, 85328, 84862, 85321, 19019, 85329, 
84865, 84839, 19001, 19018, 84864
30832, 83471, 18785, 18793, 83479, 83472, 18786, 18794, 83480, 85321, 19019, 85329, 84865, 85322, 19021, 85330, 
84868, 84842, 19003, 19020, 84867
30833, 83472, 18786, 18794, 83480, 83473, 18787, 18795, 83481, 85322, 19021, 85330, 84868, 85323, 19023, 85331, 
84871, 84845, 19005, 19022, 84870
30834, 83473, 18787, 18795, 83481, 83474, 18788, 18796, 83482, 85323, 19023, 85331, 84871, 85324, 19025, 85332, 
84874, 84848, 19007, 19024, 84873
30835, 83474, 18788, 18796, 83482, 18491, 2579, 2580, 18492, 85324, 19025, 85332, 84874, 18648, 2602, 18649, 
18609, 84851, 19009, 19026, 84876
30836, 18269, 2528, 2529, 18270, 83475, 18789, 18797, 83483, 18426, 2551, 18427, 18389, 85325, 19028, 85333, 
84878, 84852, 19010, 19027, 84877
30837, 83475, 18789, 18797, 83483, 83476, 18790, 18798, 83484, 85325, 19028, 85333, 84878, 85326, 19030, 85334, 
84881, 84855, 19012, 19029, 84880
30838, 83476, 18790, 18798, 83484, 83477, 18791, 18799, 83485, 85326, 19030, 85334, 84881, 85327, 19032, 85335, 
84884, 84858, 19014, 19031, 84883
30839, 83477, 18791, 18799, 83485, 83478, 18792, 18800, 83486, 85327, 19032, 85335, 84884, 85328, 19034, 85336, 
84887, 84861, 19016, 19033, 84886
30840, 83478, 18792, 18800, 83486, 83479, 18793, 18801, 83487, 85328, 19034, 85336, 84887, 85329, 19036, 85337, 
84890, 84864, 19018, 19035, 84889
30841, 83479, 18793, 18801, 83487, 83480, 18794, 18802, 83488, 85329, 19036, 85337, 84890, 85330, 19038, 85338, 
84893, 84867, 19020, 19037, 84892
30842, 83480, 18794, 18802, 83488, 83481, 18795, 18803, 83489, 85330, 19038, 85338, 84893, 85331, 19040, 85339, 
84896, 84870, 19022, 19039, 84895
30843, 83481, 18795, 18803, 83489, 83482, 18796, 18804, 83490, 85331, 19040, 85339, 84896, 85332, 19042, 85340, 
84899, 84873, 19024, 19041, 84898
30844, 83482, 18796, 18804, 83490, 18492, 2580, 2581, 18493, 85332, 19042, 85340, 84899, 18649, 2603, 18650, 
18611, 84876, 19026, 19043, 84901
30845, 18270, 2529, 2530, 18271, 83483, 18797, 18805, 83491, 18427, 2552, 18428, 18391, 85333, 19045, 85341, 
84903, 84877, 19027, 19044, 84902
30846, 83483, 18797, 18805, 83491, 83484, 18798, 18806, 83492, 85333, 19045, 85341, 84903, 85334, 19047, 85342, 
84906, 84880, 19029, 19046, 84905
30847, 83484, 18798, 18806, 83492, 83485, 18799, 18807, 83493, 85334, 19047, 85342, 84906, 85335, 19049, 85343, 
84909, 84883, 19031, 19048, 84908
30848, 83485, 18799, 18807, 83493, 83486, 18800, 18808, 83494, 85335, 19049, 85343, 84909, 85336, 19051, 85344, 
84912, 84886, 19033, 19050, 84911
30849, 83486, 18800, 18808, 83494, 83487, 18801, 18809, 83495, 85336, 19051, 85344, 84912, 85337, 19053, 85345, 
84915, 84889, 19035, 19052, 84914
30850, 83487, 18801, 18809, 83495, 83488, 18802, 18810, 83496, 85337, 19053, 85345, 84915, 85338, 19055, 85346, 
84918, 84892, 19037, 19054, 84917
30851, 83488, 18802, 18810, 83496, 83489, 18803, 18811, 83497, 85338, 19055, 85346, 84918, 85339, 19057, 85347, 
84921, 84895, 19039, 19056, 84920
30852, 83489, 18803, 18811, 83497, 83490, 18804, 18812, 83498, 85339, 19057, 85347, 84921, 85340, 19059, 85348, 
84924, 84898, 19041, 19058, 84923
30853, 83490, 18804, 18812, 83498, 18493, 2581, 2582, 18494, 85340, 19059, 85348, 84924, 18650, 2604, 18651, 
18613, 84901, 19043, 19060, 84926
30854, 18271, 2530, 2531, 18272, 83491, 18805, 18813, 83499, 18428, 2553, 18429, 18393, 85341, 19062, 85349, 
84928, 84902, 19044, 19061, 84927
30855, 83491, 18805, 18813, 83499, 83492, 18806, 18814, 83500, 85341, 19062, 85349, 84928, 85342, 19064, 85350, 
84931, 84905, 19046, 19063, 84930
30856, 83492, 18806, 18814, 83500, 83493, 18807, 18815, 83501, 85342, 19064, 85350, 84931, 85343, 19066, 85351, 
84934, 84908, 19048, 19065, 84933
30857, 83493, 18807, 18815, 83501, 83494, 18808, 18816, 83502, 85343, 19066, 85351, 84934, 85344, 19068, 85352, 
84937, 84911, 19050, 19067, 84936
30858, 83494, 18808, 18816, 83502, 83495, 18809, 18817, 83503, 85344, 19068, 85352, 84937, 85345, 19070, 85353, 
84940, 84914, 19052, 19069, 84939
30859, 83495, 18809, 18817, 83503, 83496, 18810, 18818, 83504, 85345, 19070, 85353, 84940, 85346, 19072, 85354, 
84943, 84917, 19054, 19071, 84942
30860, 83496, 18810, 18818, 83504, 83497, 18811, 18819, 83505, 85346, 19072, 85354, 84943, 85347, 19074, 85355, 
84946, 84920, 19056, 19073, 84945
30861, 83497, 18811, 18819, 83505, 83498, 18812, 18820, 83506, 85347, 19074, 85355, 84946, 85348, 19076, 85356, 
84949, 84923, 19058, 19075, 84948
30862, 83498, 18812, 18820, 83506, 18494, 2582, 2583, 18495, 85348, 19076, 85356, 84949, 18651, 2605, 18652, 
18615, 84926, 19060, 19077, 84951
30863, 18272, 2531, 2532, 18273, 83499, 18813, 18821, 83507, 18429, 2554, 18430, 18395, 85349, 19079, 85357, 
84953, 84927, 19061, 19078, 84952
30864, 83499, 18813, 18821, 83507, 83500, 18814, 18822, 83508, 85349, 19079, 85357, 84953, 85350, 19081, 85358, 
84956, 84930, 19063, 19080, 84955
30865, 83500, 18814, 18822, 83508, 83501, 18815, 18823, 83509, 85350, 19081, 85358, 84956, 85351, 19083, 85359, 
84959, 84933, 19065, 19082, 84958
30866, 83501, 18815, 18823, 83509, 83502, 18816, 18824, 83510, 85351, 19083, 85359, 84959, 85352, 19085, 85360, 
84962, 84936, 19067, 19084, 84961
30867, 83502, 18816, 18824, 83510, 83503, 18817, 18825, 83511, 85352, 19085, 85360, 84962, 85353, 19087, 85361, 
84965, 84939, 19069, 19086, 84964
30868, 83503, 18817, 18825, 83511, 83504, 18818, 18826, 83512, 85353, 19087, 85361, 84965, 85354, 19089, 85362, 
84968, 84942, 19071, 19088, 84967
30869, 83504, 18818, 18826, 83512, 83505, 18819, 18827, 83513, 85354, 19089, 85362, 84968, 85355, 19091, 85363, 
84971, 84945, 19073, 19090, 84970
30870, 83505, 18819, 18827, 83513, 83506, 18820, 18828, 83514, 85355, 19091, 85363, 84971, 85356, 19093, 85364, 
84974, 84948, 19075, 19092, 84973
30871, 83506, 18820, 18828, 83514, 18495, 2583, 2584, 18496, 85356, 19093, 85364, 84974, 18652, 2606, 18653, 
18617, 84951, 19077, 19094, 84976
30872, 18273, 2532, 2533, 18274, 83507, 18821, 18829, 83515, 18430, 2555, 18431, 18397, 85357, 19096, 85365, 
84978, 84952, 19078, 19095, 84977
30873, 83507, 18821, 18829, 83515, 83508, 18822, 18830, 83516, 85357, 19096, 85365, 84978, 85358, 19098, 85366, 
84981, 84955, 19080, 19097, 84980
30874, 83508, 18822, 18830, 83516, 83509, 18823, 18831, 83517, 85358, 19098, 85366, 84981, 85359, 19100, 85367, 
84984, 84958, 19082, 19099, 84983
30875, 83509, 18823, 18831, 83517, 83510, 18824, 18832, 83518, 85359, 19100, 85367, 84984, 85360, 19102, 85368, 
84987, 84961, 19084, 19101, 84986
30876, 83510, 18824, 18832, 83518, 83511, 18825, 18833, 83519, 85360, 19102, 85368, 84987, 85361, 19104, 85369, 
84990, 84964, 19086, 19103, 84989
30877, 83511, 18825, 18833, 83519, 83512, 18826, 18834, 83520, 85361, 19104, 85369, 84990, 85362, 19106, 85370, 
84993, 84967, 19088, 19105, 84992
30878, 83512, 18826, 18834, 83520, 83513, 18827, 18835, 83521, 85362, 19106, 85370, 84993, 85363, 19108, 85371, 
84996, 84970, 19090, 19107, 84995
30879, 83513, 18827, 18835, 83521, 83514, 18828, 18836, 83522, 85363, 19108, 85371, 84996, 85364, 19110, 85372, 
84999, 84973, 19092, 19109, 84998
30880, 83514, 18828, 18836, 83522, 18496, 2584, 2585, 18497, 85364, 19110, 85372, 84999, 18653, 2607, 18654, 
18619, 84976, 19094, 19111, 85001
30881, 18274, 2533, 2534, 18275, 83515, 18829, 18837, 83523, 18431, 2556, 18432, 18399, 85365, 19113, 85373, 
85003, 84977, 19095, 19112, 85002
30882, 83515, 18829, 18837, 83523, 83516, 18830, 18838, 83524, 85365, 19113, 85373, 85003, 85366, 19115, 85374, 
85006, 84980, 19097, 19114, 85005
30883, 83516, 18830, 18838, 83524, 83517, 18831, 18839, 83525, 85366, 19115, 85374, 85006, 85367, 19117, 85375, 
85009, 84983, 19099, 19116, 85008
30884, 83517, 18831, 18839, 83525, 83518, 18832, 18840, 83526, 85367, 19117, 85375, 85009, 85368, 19119, 85376, 
85012, 84986, 19101, 19118, 85011
30885, 83518, 18832, 18840, 83526, 83519, 18833, 18841, 83527, 85368, 19119, 85376, 85012, 85369, 19121, 85377, 
85015, 84989, 19103, 19120, 85014
30886, 83519, 18833, 18841, 83527, 83520, 18834, 18842, 83528, 85369, 19121, 85377, 85015, 85370, 19123, 85378, 
85018, 84992, 19105, 19122, 85017
30887, 83520, 18834, 18842, 83528, 83521, 18835, 18843, 83529, 85370, 19123, 85378, 85018, 85371, 19125, 85379, 
85021, 84995, 19107, 19124, 85020
30888, 83521, 18835, 18843, 83529, 83522, 18836, 18844, 83530, 85371, 19125, 85379, 85021, 85372, 19127, 85380, 
85024, 84998, 19109, 19126, 85023
30889, 83522, 18836, 18844, 83530, 18497, 2585, 2586, 18498, 85372, 19127, 85380, 85024, 18654, 2608, 18655, 
18621, 85001, 19111, 19128, 85026
30890, 18275, 2534, 2535, 18276, 83523, 18837, 18845, 83531, 18432, 2557, 18433, 18401, 85373, 19130, 85381, 
85028, 85002, 19112, 19129, 85027
30891, 83523, 18837, 18845, 83531, 83524, 18838, 18846, 83532, 85373, 19130, 85381, 85028, 85374, 19132, 85382, 
85031, 85005, 19114, 19131, 85030
30892, 83524, 18838, 18846, 83532, 83525, 18839, 18847, 83533, 85374, 19132, 85382, 85031, 85375, 19134, 85383, 
85034, 85008, 19116, 19133, 85033
30893, 83525, 18839, 18847, 83533, 83526, 18840, 18848, 83534, 85375, 19134, 85383, 85034, 85376, 19136, 85384, 
85037, 85011, 19118, 19135, 85036
30894, 83526, 18840, 18848, 83534, 83527, 18841, 18849, 83535, 85376, 19136, 85384, 85037, 85377, 19138, 85385, 
85040, 85014, 19120, 19137, 85039
30895, 83527, 18841, 18849, 83535, 83528, 18842, 18850, 83536, 85377, 19138, 85385, 85040, 85378, 19140, 85386, 
85043, 85017, 19122, 19139, 85042
30896, 83528, 18842, 18850, 83536, 83529, 18843, 18851, 83537, 85378, 19140, 85386, 85043, 85379, 19142, 85387, 
85046, 85020, 19124, 19141, 85045
30897, 83529, 18843, 18851, 83537, 83530, 18844, 18852, 83538, 85379, 19142, 85387, 85046, 85380, 19144, 85388, 
85049, 85023, 19126, 19143, 85048
30898, 83530, 18844, 18852, 83538, 18498, 2586, 2587, 18499, 85380, 19144, 85388, 85049, 18655, 2609, 18656, 
18623, 85026, 19128, 19145, 85051
30899, 18276, 2535, 2536, 18277, 83531, 18845, 18853, 83539, 18433, 2558, 18434, 18403, 85381, 19147, 85389, 
85053, 85027, 19129, 19146, 85052
30900, 83531, 18845, 18853, 83539, 83532, 18846, 18854, 83540, 85381, 19147, 85389, 85053, 85382, 19149, 85390, 
85056, 85030, 19131, 19148, 85055
30901, 83532, 18846, 18854, 83540, 83533, 18847, 18855, 83541, 85382, 19149, 85390, 85056, 85383, 19151, 85391, 
85059, 85033, 19133, 19150, 85058
30902, 83533, 18847, 18855, 83541, 83534, 18848, 18856, 83542, 85383, 19151, 85391, 85059, 85384, 19153, 85392, 
85062, 85036, 19135, 19152, 85061
30903, 83534, 18848, 18856, 83542, 83535, 18849, 18857, 83543, 85384, 19153, 85392, 85062, 85385, 19155, 85393, 
85065, 85039, 19137, 19154, 85064
30904, 83535, 18849, 18857, 83543, 83536, 18850, 18858, 83544, 85385, 19155, 85393, 85065, 85386, 19157, 85394, 
85068, 85042, 19139, 19156, 85067
30905, 83536, 18850, 18858, 83544, 83537, 18851, 18859, 83545, 85386, 19157, 85394, 85068, 85387, 19159, 85395, 
85071, 85045, 19141, 19158, 85070
30906, 83537, 18851, 18859, 83545, 83538, 18852, 18860, 83546, 85387, 19159, 85395, 85071, 85388, 19161, 85396, 
85074, 85048, 19143, 19160, 85073
30907, 83538, 18852, 18860, 83546, 18499, 2587, 2588, 18500, 85388, 19161, 85396, 85074, 18656, 2610, 18657, 
18625, 85051, 19145, 19162, 85076
30908, 18277, 2536, 2537, 18278, 83539, 18853, 18861, 83547, 18434, 2559, 18435, 18405, 85389, 19164, 85397, 
85078, 85052, 19146, 19163, 85077
30909, 83539, 18853, 18861, 83547, 83540, 18854, 18862, 83548, 85389, 19164, 85397, 85078, 85390, 19166, 85398, 
85081, 85055, 19148, 19165, 85080
30910, 83540, 18854, 18862, 83548, 83541, 18855, 18863, 83549, 85390, 19166, 85398, 85081, 85391, 19168, 85399, 
85084, 85058, 19150, 19167, 85083
30911, 83541, 18855, 18863, 83549, 83542, 18856, 18864, 83550, 85391, 19168, 85399, 85084, 85392, 19170, 85400, 
85087, 85061, 19152, 19169, 85086
30912, 83542, 18856, 18864, 83550, 83543, 18857, 18865, 83551, 85392, 19170, 85400, 85087, 85393, 19172, 85401, 
85090, 85064, 19154, 19171, 85089
30913, 83543, 18857, 18865, 83551, 83544, 18858, 18866, 83552, 85393, 19172, 85401, 85090, 85394, 19174, 85402, 
85093, 85067, 19156, 19173, 85092
30914, 83544, 18858, 18866, 83552, 83545, 18859, 18867, 83553, 85394, 19174, 85402, 85093, 85395, 19176, 85403, 
85096, 85070, 19158, 19175, 85095
30915, 83545, 18859, 18867, 83553, 83546, 18860, 18868, 83554, 85395, 19176, 85403, 85096, 85396, 19178, 85404, 
85099, 85073, 19160, 19177, 85098
30916, 83546, 18860, 18868, 83554, 18500, 2588, 2589, 18501, 85396, 19178, 85404, 85099, 18657, 2611, 18658, 
18627, 85076, 19162, 19179, 85101
30917, 18278, 2537, 2538, 18279, 83547, 18861, 18869, 83555, 18435, 2560, 18436, 18407, 85397, 19181, 85405, 
85103, 85077, 19163, 19180, 85102
30918, 83547, 18861, 18869, 83555, 83548, 18862, 18870, 83556, 85397, 19181, 85405, 85103, 85398, 19183, 85406, 
85106, 85080, 19165, 19182, 85105
30919, 83548, 18862, 18870, 83556, 83549, 18863, 18871, 83557, 85398, 19183, 85406, 85106, 85399, 19185, 85407, 
85109, 85083, 19167, 19184, 85108
30920, 83549, 18863, 18871, 83557, 83550, 18864, 18872, 83558, 85399, 19185, 85407, 85109, 85400, 19187, 85408, 
85112, 85086, 19169, 19186, 85111
30921, 83550, 18864, 18872, 83558, 83551, 18865, 18873, 83559, 85400, 19187, 85408, 85112, 85401, 19189, 85409, 
85115, 85089, 19171, 19188, 85114
30922, 83551, 18865, 18873, 83559, 83552, 18866, 18874, 83560, 85401, 19189, 85409, 85115, 85402, 19191, 85410, 
85118, 85092, 19173, 19190, 85117
30923, 83552, 18866, 18874, 83560, 83553, 18867, 18875, 83561, 85402, 19191, 85410, 85118, 85403, 19193, 85411, 
85121, 85095, 19175, 19192, 85120
30924, 83553, 18867, 18875, 83561, 83554, 18868, 18876, 83562, 85403, 19193, 85411, 85121, 85404, 19195, 85412, 
85124, 85098, 19177, 19194, 85123
30925, 83554, 18868, 18876, 83562, 18501, 2589, 2590, 18502, 85404, 19195, 85412, 85124, 18658, 2612, 18659, 
18629, 85101, 19179, 19196, 85126
30926, 18279, 2538, 2539, 18280, 83555, 18869, 18877, 83563, 18436, 2561, 18437, 18409, 85405, 19198, 85413, 
85128, 85102, 19180, 19197, 85127
30927, 83555, 18869, 18877, 83563, 83556, 18870, 18878, 83564, 85405, 19198, 85413, 85128, 85406, 19200, 85414, 
85131, 85105, 19182, 19199, 85130
30928, 83556, 18870, 18878, 83564, 83557, 18871, 18879, 83565, 85406, 19200, 85414, 85131, 85407, 19202, 85415, 
85134, 85108, 19184, 19201, 85133
30929, 83557, 18871, 18879, 83565, 83558, 18872, 18880, 83566, 85407, 19202, 85415, 85134, 85408, 19204, 85416, 
85137, 85111, 19186, 19203, 85136
30930, 83558, 18872, 18880, 83566, 83559, 18873, 18881, 83567, 85408, 19204, 85416, 85137, 85409, 19206, 85417, 
85140, 85114, 19188, 19205, 85139
30931, 83559, 18873, 18881, 83567, 83560, 18874, 18882, 83568, 85409, 19206, 85417, 85140, 85410, 19208, 85418, 
85143, 85117, 19190, 19207, 85142
30932, 83560, 18874, 18882, 83568, 83561, 18875, 18883, 83569, 85410, 19208, 85418, 85143, 85411, 19210, 85419, 
85146, 85120, 19192, 19209, 85145
30933, 83561, 18875, 18883, 83569, 83562, 18876, 18884, 83570, 85411, 19210, 85419, 85146, 85412, 19212, 85420, 
85149, 85123, 19194, 19211, 85148
30934, 83562, 18876, 18884, 83570, 18502, 2590, 2591, 18503, 85412, 19212, 85420, 85149, 18659, 2613, 18660, 
18631, 85126, 19196, 19213, 85151
30935, 18280, 2539, 2540, 18281, 83563, 18877, 18885, 83571, 18437, 2562, 18438, 18411, 85413, 19215, 85421, 
85153, 85127, 19197, 19214, 85152
30936, 83563, 18877, 18885, 83571, 83564, 18878, 18886, 83572, 85413, 19215, 85421, 85153, 85414, 19217, 85422, 
85156, 85130, 19199, 19216, 85155
30937, 83564, 18878, 18886, 83572, 83565, 18879, 18887, 83573, 85414, 19217, 85422, 85156, 85415, 19219, 85423, 
85159, 85133, 19201, 19218, 85158
30938, 83565, 18879, 18887, 83573, 83566, 18880, 18888, 83574, 85415, 19219, 85423, 85159, 85416, 19221, 85424, 
85162, 85136, 19203, 19220, 85161
30939, 83566, 18880, 18888, 83574, 83567, 18881, 18889, 83575, 85416, 19221, 85424, 85162, 85417, 19223, 85425, 
85165, 85139, 19205, 19222, 85164
30940, 83567, 18881, 18889, 83575, 83568, 18882, 18890, 83576, 85417, 19223, 85425, 85165, 85418, 19225, 85426, 
85168, 85142, 19207, 19224, 85167
30941, 83568, 18882, 18890, 83576, 83569, 18883, 18891, 83577, 85418, 19225, 85426, 85168, 85419, 19227, 85427, 
85171, 85145, 19209, 19226, 85170
30942, 83569, 18883, 18891, 83577, 83570, 18884, 18892, 83578, 85419, 19227, 85427, 85171, 85420, 19229, 85428, 
85174, 85148, 19211, 19228, 85173
30943, 83570, 18884, 18892, 83578, 18503, 2591, 2592, 18504, 85420, 19229, 85428, 85174, 18660, 2614, 18661, 
18633, 85151, 19213, 19230, 85176
30944, 18281, 2540, 2541, 18282, 83571, 18885, 18893, 83579, 18438, 2563, 18439, 18413, 85421, 19232, 85429, 
85178, 85152, 19214, 19231, 85177
30945, 83571, 18885, 18893, 83579, 83572, 18886, 18894, 83580, 85421, 19232, 85429, 85178, 85422, 19234, 85430, 
85181, 85155, 19216, 19233, 85180
30946, 83572, 18886, 18894, 83580, 83573, 18887, 18895, 83581, 85422, 19234, 85430, 85181, 85423, 19236, 85431, 
85184, 85158, 19218, 19235, 85183
30947, 83573, 18887, 18895, 83581, 83574, 18888, 18896, 83582, 85423, 19236, 85431, 85184, 85424, 19238, 85432, 
85187, 85161, 19220, 19237, 85186
30948, 83574, 18888, 18896, 83582, 83575, 18889, 18897, 83583, 85424, 19238, 85432, 85187, 85425, 19240, 85433, 
85190, 85164, 19222, 19239, 85189
30949, 83575, 18889, 18897, 83583, 83576, 18890, 18898, 83584, 85425, 19240, 85433, 85190, 85426, 19242, 85434, 
85193, 85167, 19224, 19241, 85192
30950, 83576, 18890, 18898, 83584, 83577, 18891, 18899, 83585, 85426, 19242, 85434, 85193, 85427, 19244, 85435, 
85196, 85170, 19226, 19243, 85195
30951, 83577, 18891, 18899, 83585, 83578, 18892, 18900, 83586, 85427, 19244, 85435, 85196, 85428, 19246, 85436, 
85199, 85173, 19228, 19245, 85198
30952, 83578, 18892, 18900, 83586, 18504, 2592, 2593, 18505, 85428, 19246, 85436, 85199, 18661, 2615, 18662, 
18635, 85176, 19230, 19247, 85201
30953, 18282, 2541, 2542, 18283, 83579, 18893, 18901, 83587, 18439, 2564, 18440, 18415, 85429, 19249, 85437, 
85203, 85177, 19231, 19248, 85202
30954, 83579, 18893, 18901, 83587, 83580, 18894, 18902, 83588, 85429, 19249, 85437, 85203, 85430, 19251, 85438, 
85206, 85180, 19233, 19250, 85205
30955, 83580, 18894, 18902, 83588, 83581, 18895, 18903, 83589, 85430, 19251, 85438, 85206, 85431, 19253, 85439, 
85209, 85183, 19235, 19252, 85208
30956, 83581, 18895, 18903, 83589, 83582, 18896, 18904, 83590, 85431, 19253, 85439, 85209, 85432, 19255, 85440, 
85212, 85186, 19237, 19254, 85211
30957, 83582, 18896, 18904, 83590, 83583, 18897, 18905, 83591, 85432, 19255, 85440, 85212, 85433, 19257, 85441, 
85215, 85189, 19239, 19256, 85214
30958, 83583, 18897, 18905, 83591, 83584, 18898, 18906, 83592, 85433, 19257, 85441, 85215, 85434, 19259, 85442, 
85218, 85192, 19241, 19258, 85217
30959, 83584, 18898, 18906, 83592, 83585, 18899, 18907, 83593, 85434, 19259, 85442, 85218, 85435, 19261, 85443, 
85221, 85195, 19243, 19260, 85220
30960, 83585, 18899, 18907, 83593, 83586, 18900, 18908, 83594, 85435, 19261, 85443, 85221, 85436, 19263, 85444, 
85224, 85198, 19245, 19262, 85223
30961, 83586, 18900, 18908, 83594, 18505, 2593, 2594, 18506, 85436, 19263, 85444, 85224, 18662, 2616, 18663, 
18637, 85201, 19247, 19264, 85226
30962, 18283, 2542, 2543, 18284, 83587, 18901, 18909, 83595, 18440, 2565, 18441, 18417, 85437, 19266, 85445, 
85228, 85202, 19248, 19265, 85227
30963, 83587, 18901, 18909, 83595, 83588, 18902, 18910, 83596, 85437, 19266, 85445, 85228, 85438, 19268, 85446, 
85231, 85205, 19250, 19267, 85230
30964, 83588, 18902, 18910, 83596, 83589, 18903, 18911, 83597, 85438, 19268, 85446, 85231, 85439, 19270, 85447, 
85234, 85208, 19252, 19269, 85233
30965, 83589, 18903, 18911, 83597, 83590, 18904, 18912, 83598, 85439, 19270, 85447, 85234, 85440, 19272, 85448, 
85237, 85211, 19254, 19271, 85236
30966, 83590, 18904, 18912, 83598, 83591, 18905, 18913, 83599, 85440, 19272, 85448, 85237, 85441, 19274, 85449, 
85240, 85214, 19256, 19273, 85239
30967, 83591, 18905, 18913, 83599, 83592, 18906, 18914, 83600, 85441, 19274, 85449, 85240, 85442, 19276, 85450, 
85243, 85217, 19258, 19275, 85242
30968, 83592, 18906, 18914, 83600, 83593, 18907, 18915, 83601, 85442, 19276, 85450, 85243, 85443, 19278, 85451, 
85246, 85220, 19260, 19277, 85245
30969, 83593, 18907, 18915, 83601, 83594, 18908, 18916, 83602, 85443, 19278, 85451, 85246, 85444, 19280, 85452, 
85249, 85223, 19262, 19279, 85248
30970, 83594, 18908, 18916, 83602, 18506, 2594, 2595, 18507, 85444, 19280, 85452, 85249, 18663, 2617, 18664, 
18639, 85226, 19264, 19281, 85251
30971, 18284, 2543, 2544, 18285, 83595, 18909, 18917, 83603, 18441, 2566, 18442, 18419, 85445, 19283, 85453, 
85253, 85227, 19265, 19282, 85252
30972, 83595, 18909, 18917, 83603, 83596, 18910, 18918, 83604, 85445, 19283, 85453, 85253, 85446, 19285, 85454, 
85256, 85230, 19267, 19284, 85255
30973, 83596, 18910, 18918, 83604, 83597, 18911, 18919, 83605, 85446, 19285, 85454, 85256, 85447, 19287, 85455, 
85259, 85233, 19269, 19286, 85258
30974, 83597, 18911, 18919, 83605, 83598, 18912, 18920, 83606, 85447, 19287, 85455, 85259, 85448, 19289, 85456, 
85262, 85236, 19271, 19288, 85261
30975, 83598, 18912, 18920, 83606, 83599, 18913, 18921, 83607, 85448, 19289, 85456, 85262, 85449, 19291, 85457, 
85265, 85239, 19273, 19290, 85264
30976, 83599, 18913, 18921, 83607, 83600, 18914, 18922, 83608, 85449, 19291, 85457, 85265, 85450, 19293, 85458, 
85268, 85242, 19275, 19292, 85267
30977, 83600, 18914, 18922, 83608, 83601, 18915, 18923, 83609, 85450, 19293, 85458, 85268, 85451, 19295, 85459, 
85271, 85245, 19277, 19294, 85270
30978, 83601, 18915, 18923, 83609, 83602, 18916, 18924, 83610, 85451, 19295, 85459, 85271, 85452, 19297, 85460, 
85274, 85248, 19279, 19296, 85273
30979, 83602, 18916, 18924, 83610, 18507, 2595, 2596, 18508, 85452, 19297, 85460, 85274, 18664, 2618, 18665, 
18641, 85251, 19281, 19298, 85276
30980, 18285, 2544, 79, 2518, 83603, 18917, 2627, 18682, 18442, 2567, 2522, 18420, 85453, 19299, 18741, 
85277, 85252, 19282, 2636, 18725
30981, 83603, 18917, 2627, 18682, 83604, 18918, 2626, 18683, 85453, 19299, 18741, 85277, 85454, 19300, 18742, 
85278, 85255, 19284, 2635, 18727
30982, 83604, 18918, 2626, 18683, 83605, 18919, 2625, 18684, 85454, 19300, 18742, 85278, 85455, 19301, 18743, 
85279, 85258, 19286, 2634, 18729
30983, 83605, 18919, 2625, 18684, 83606, 18920, 2624, 18685, 85455, 19301, 18743, 85279, 85456, 19302, 18744, 
85280, 85261, 19288, 2633, 18731
30984, 83606, 18920, 2624, 18685, 83607, 18921, 2623, 18686, 85456, 19302, 18744, 85280, 85457, 19303, 18745, 
85281, 85264, 19290, 2632, 18733
30985, 83607, 18921, 2623, 18686, 83608, 18922, 2622, 18687, 85457, 19303, 18745, 85281, 85458, 19304, 18746, 
85282, 85267, 19292, 2631, 18735
30986, 83608, 18922, 2622, 18687, 83609, 18923, 2621, 18688, 85458, 19304, 18746, 85282, 85459, 19305, 18747, 
85283, 85270, 19294, 2630, 18737
30987, 83609, 18923, 2621, 18688, 83610, 18924, 2620, 18689, 85459, 19305, 18747, 85283, 85460, 19306, 18748, 
85284, 85273, 19296, 2629, 18739
30988, 83610, 18924, 2620, 18689, 18508, 2596, 80, 2570, 85460, 19306, 18748, 85284, 18665, 2619, 2574, 
18643, 85276, 19298, 2628, 18740
*ELEMENT, type=C3D20, ELSET=Volume23
30989, 7422, 761, 22, 602, 85461, 7652, 537, 6162, 7488, 764, 625, 7489, 85990, 7684, 6544, 
85991, 85989, 7685, 545, 6527
30990, 85461, 7652, 537, 6162, 85462, 7651, 538, 6163, 85990, 7684, 6544, 85991, 85993, 7682, 6545, 
85994, 85992, 7683, 546, 6529
30991, 85462, 7651, 538, 6163, 85463, 7650, 539, 6164, 85993, 7682, 6545, 85994, 85996, 7680, 6546, 
85997, 85995, 7681, 547, 6531
30992, 85463, 7650, 539, 6164, 85464, 7649, 540, 6165, 85996, 7680, 6546, 85997, 85999, 7678, 6547, 
86000, 85998, 7679, 548, 6533
30993, 85464, 7649, 540, 6165, 85465, 7648, 541, 6166, 85999, 7678, 6547, 86000, 86002, 7676, 6548, 
86003, 86001, 7677, 549, 6535
30994, 85465, 7648, 541, 6166, 85466, 7647, 542, 6167, 86002, 7676, 6548, 86003, 86005, 7674, 6549, 
86006, 86004, 7675, 550, 6537
30995, 85466, 7647, 542, 6167, 85467, 7646, 543, 6168, 86005, 7674, 6549, 86006, 86008, 7672, 6550, 
86009, 86007, 7673, 551, 6539
30996, 85467, 7646, 543, 6168, 85468, 7645, 544, 6169, 86008, 7672, 6550, 86009, 86011, 7670, 6551, 
86012, 86010, 7671, 552, 6541
30997, 85468, 7645, 544, 6169, 7728, 813, 21, 647, 86011, 7670, 6551, 86012, 7795, 816, 670, 
7794, 86013, 7669, 553, 6543
30998, 7423, 7422, 602, 601, 85469, 85461, 6162, 6154, 7490, 7489, 624, 7491, 86015, 85991, 6528, 
86016, 86014, 85989, 6527, 6510
30999, 85469, 85461, 6162, 6154, 85470, 85462, 6163, 6155, 86015, 85991, 6528, 86016, 86018, 85994, 6530, 
86019, 86017, 85992, 6529, 6512
31000, 85470, 85462, 6163, 6155, 85471, 85463, 6164, 6156, 86018, 85994, 6530, 86019, 86021, 85997, 6532, 
86022, 86020, 85995, 6531, 6514
31001, 85471, 85463, 6164, 6156, 85472, 85464, 6165, 6157, 86021, 85997, 6532, 86022, 86024, 86000, 6534, 
86025, 86023, 85998, 6533, 6516
31002, 85472, 85464, 6165, 6157, 85473, 85465, 6166, 6158, 86024, 86000, 6534, 86025, 86027, 86003, 6536, 
86028, 86026, 86001, 6535, 6518
31003, 85473, 85465, 6166, 6158, 85474, 85466, 6167, 6159, 86027, 86003, 6536, 86028, 86030, 86006, 6538, 
86031, 86029, 86004, 6537, 6520
31004, 85474, 85466, 6167, 6159, 85475, 85467, 6168, 6160, 86030, 86006, 6538, 86031, 86033, 86009, 6540, 
86034, 86032, 86007, 6539, 6522
31005, 85475, 85467, 6168, 6160, 85476, 85468, 6169, 6161, 86033, 86009, 6540, 86034, 86036, 86012, 6542, 
86037, 86035, 86010, 6541, 6524
31006, 85476, 85468, 6169, 6161, 7729, 7728, 647, 646, 86036, 86012, 6542, 86037, 7797, 7794, 669, 
7796, 86038, 86013, 6543, 6526
31007, 7424, 7423, 601, 600, 85477, 85469, 6154, 6146, 7492, 7491, 623, 7493, 86040, 86016, 6511, 
86041, 86039, 86014, 6510, 6493
31008, 85477, 85469, 6154, 6146, 85478, 85470, 6155, 6147, 86040, 86016, 6511, 86041, 86043, 86019, 6513, 
86044, 86042, 86017, 6512, 6495
31009, 85478, 85470, 6155, 6147, 85479, 85471, 6156, 6148, 86043, 86019, 6513, 86044, 86046, 86022, 6515, 
86047, 86045, 86020, 6514, 6497
31010, 85479, 85471, 6156, 6148, 85480, 85472, 6157, 6149, 86046, 86022, 6515, 86047, 86049, 86025, 6517, 
86050, 86048, 86023, 6516, 6499
31011, 85480, 85472, 6157, 6149, 85481, 85473, 6158, 6150, 86049, 86025, 6517, 86050, 86052, 86028, 6519, 
86053, 86051, 86026, 6518, 6501
31012, 85481, 85473, 6158, 6150, 85482, 85474, 6159, 6151, 86052, 86028, 6519, 86053, 86055, 86031, 6521, 
86056, 86054, 86029, 6520, 6503
31013, 85482, 85474, 6159, 6151, 85483, 85475, 6160, 6152, 86055, 86031, 6521, 86056, 86058, 86034, 6523, 
86059, 86057, 86032, 6522, 6505
31014, 85483, 85475, 6160, 6152, 85484, 85476, 6161, 6153, 86058, 86034, 6523, 86059, 86061, 86037, 6525, 
86062, 86060, 86035, 6524, 6507
31015, 85484, 85476, 6161, 6153, 7730, 7729, 646, 645, 86061, 86037, 6525, 86062, 7799, 7796, 668, 
7798, 86063, 86038, 6526, 6509
31016, 7425, 7424, 600, 599, 85485, 85477, 6146, 6138, 7494, 7493, 622, 7495, 86065, 86041, 6494, 
86066, 86064, 86039, 6493, 6476
31017, 85485, 85477, 6146, 6138, 85486, 85478, 6147, 6139, 86065, 86041, 6494, 86066, 86068, 86044, 6496, 
86069, 86067, 86042, 6495, 6478
31018, 85486, 85478, 6147, 6139, 85487, 85479, 6148, 6140, 86068, 86044, 6496, 86069, 86071, 86047, 6498, 
86072, 86070, 86045, 6497, 6480
31019, 85487, 85479, 6148, 6140, 85488, 85480, 6149, 6141, 86071, 86047, 6498, 86072, 86074, 86050, 6500, 
86075, 86073, 86048, 6499, 6482
31020, 85488, 85480, 6149, 6141, 85489, 85481, 6150, 6142, 86074, 86050, 6500, 86075, 86077, 86053, 6502, 
86078, 86076, 86051, 6501, 6484
31021, 85489, 85481, 6150, 6142, 85490, 85482, 6151, 6143, 86077, 86053, 6502, 86078, 86080, 86056, 6504, 
86081, 86079, 86054, 6503, 6486
31022, 85490, 85482, 6151, 6143, 85491, 85483, 6152, 6144, 86080, 86056, 6504, 86081, 86083, 86059, 6506, 
86084, 86082, 86057, 6505, 6488
31023, 85491, 85483, 6152, 6144, 85492, 85484, 6153, 6145, 86083, 86059, 6506, 86084, 86086, 86062, 6508, 
86087, 86085, 86060, 6507, 6490
31024, 85492, 85484, 6153, 6145, 7731, 7730, 645, 644, 86086, 86062, 6508, 86087, 7801, 7798, 667, 
7800, 86088, 86063, 6509, 6492
31025, 7426, 7425, 599, 598, 85493, 85485, 6138, 6130, 7496, 7495, 621, 7497, 86090, 86066, 6477, 
86091, 86089, 86064, 6476, 6459
31026, 85493, 85485, 6138, 6130, 85494, 85486, 6139, 6131, 86090, 86066, 6477, 86091, 86093, 86069, 6479, 
86094, 86092, 86067, 6478, 6461
31027, 85494, 85486, 6139, 6131, 85495, 85487, 6140, 6132, 86093, 86069, 6479, 86094, 86096, 86072, 6481, 
86097, 86095, 86070, 6480, 6463
31028, 85495, 85487, 6140, 6132, 85496, 85488, 6141, 6133, 86096, 86072, 6481, 86097, 86099, 86075, 6483, 
86100, 86098, 86073, 6482, 6465
31029, 85496, 85488, 6141, 6133, 85497, 85489, 6142, 6134, 86099, 86075, 6483, 86100, 86102, 86078, 6485, 
86103, 86101, 86076, 6484, 6467
31030, 85497, 85489, 6142, 6134, 85498, 85490, 6143, 6135, 86102, 86078, 6485, 86103, 86105, 86081, 6487, 
86106, 86104, 86079, 6486, 6469
31031, 85498, 85490, 6143, 6135, 85499, 85491, 6144, 6136, 86105, 86081, 6487, 86106, 86108, 86084, 6489, 
86109, 86107, 86082, 6488, 6471
31032, 85499, 85491, 6144, 6136, 85500, 85492, 6145, 6137, 86108, 86084, 6489, 86109, 86111, 86087, 6491, 
86112, 86110, 86085, 6490, 6473
31033, 85500, 85492, 6145, 6137, 7732, 7731, 644, 643, 86111, 86087, 6491, 86112, 7803, 7800, 666, 
7802, 86113, 86088, 6492, 6475
31034, 7427, 7426, 598, 597, 85501, 85493, 6130, 6122, 7498, 7497, 620, 7499, 86115, 86091, 6460, 
86116, 86114, 86089, 6459, 6442
31035, 85501, 85493, 6130, 6122, 85502, 85494, 6131, 6123, 86115, 86091, 6460, 86116, 86118, 86094, 6462, 
86119, 86117, 86092, 6461, 6444
31036, 85502, 85494, 6131, 6123, 85503, 85495, 6132, 6124, 86118, 86094, 6462, 86119, 86121, 86097, 6464, 
86122, 86120, 86095, 6463, 6446
31037, 85503, 85495, 6132, 6124, 85504, 85496, 6133, 6125, 86121, 86097, 6464, 86122, 86124, 86100, 6466, 
86125, 86123, 86098, 6465, 6448
31038, 85504, 85496, 6133, 6125, 85505, 85497, 6134, 6126, 86124, 86100, 6466, 86125, 86127, 86103, 6468, 
86128, 86126, 86101, 6467, 6450
31039, 85505, 85497, 6134, 6126, 85506, 85498, 6135, 6127, 86127, 86103, 6468, 86128, 86130, 86106, 6470, 
86131, 86129, 86104, 6469, 6452
31040, 85506, 85498, 6135, 6127, 85507, 85499, 6136, 6128, 86130, 86106, 6470, 86131, 86133, 86109, 6472, 
86134, 86132, 86107, 6471, 6454
31041, 85507, 85499, 6136, 6128, 85508, 85500, 6137, 6129, 86133, 86109, 6472, 86134, 86136, 86112, 6474, 
86137, 86135, 86110, 6473, 6456
31042, 85508, 85500, 6137, 6129, 7733, 7732, 643, 642, 86136, 86112, 6474, 86137, 7805, 7802, 665, 
7804, 86138, 86113, 6475, 6458
31043, 7428, 7427, 597, 596, 85509, 85501, 6122, 6114, 7500, 7499, 619, 7501, 86140, 86116, 6443, 
86141, 86139, 86114, 6442, 6425
31044, 85509, 85501, 6122, 6114, 85510, 85502, 6123, 6115, 86140, 86116, 6443, 86141, 86143, 86119, 6445, 
86144, 86142, 86117, 6444, 6427
31045, 85510, 85502, 6123, 6115, 85511, 85503, 6124, 6116, 86143, 86119, 6445, 86144, 86146, 86122, 6447, 
86147, 86145, 86120, 6446, 6429
31046, 85511, 85503, 6124, 6116, 85512, 85504, 6125, 6117, 86146, 86122, 6447, 86147, 86149, 86125, 6449, 
86150, 86148, 86123, 6448, 6431
31047, 85512, 85504, 6125, 6117, 85513, 85505, 6126, 6118, 86149, 86125, 6449, 86150, 86152, 86128, 6451, 
86153, 86151, 86126, 6450, 6433
31048, 85513, 85505, 6126, 6118, 85514, 85506, 6127, 6119, 86152, 86128, 6451, 86153, 86155, 86131, 6453, 
86156, 86154, 86129, 6452, 6435
31049, 85514, 85506, 6127, 6119, 85515, 85507, 6128, 6120, 86155, 86131, 6453, 86156, 86158, 86134, 6455, 
86159, 86157, 86132, 6454, 6437
31050, 85515, 85507, 6128, 6120, 85516, 85508, 6129, 6121, 86158, 86134, 6455, 86159, 86161, 86137, 6457, 
86162, 86160, 86135, 6456, 6439
31051, 85516, 85508, 6129, 6121, 7734, 7733, 642, 641, 86161, 86137, 6457, 86162, 7807, 7804, 664, 
7806, 86163, 86138, 6458, 6441
31052, 7429, 7428, 596, 595, 85517, 85509, 6114, 6106, 7502, 7501, 618, 7503, 86165, 86141, 6426, 
86166, 86164, 86139, 6425, 6408
