26591, 1.8086956521739, 0.98478260869565, 0
26592, 1.8521739130435, 0.98478260869565, 0
26593, 1.895652173913, 0.98478260869565, 0
26594, 1.9391304347826, 0.98478260869565, 0
26595, 1.9826086956522, 0.98478260869565, 0
26596, 2.0260869565217, 0.98478260869565, 0
26597, 2.0695652173913, 0.98478260869565, 0
26598, 2.1130434782609, 0.98478260869565, 0
26599, 2.1565217391304, 0.98478260869565, 0
26600, 1.2434782608696, 0.93260869565217, 0
26601, 1.2869565217391, 0.93260869565217, 0
26602, 1.3304347826087, 0.93260869565217, 0
26603, 1.3739130434783, 0.93260869565217, 0
26604, 1.4173913043478, 0.93260869565217, 0
26605, 1.4608695652174, 0.93260869565217, 0
26606, 1.504347826087, 0.93260869565217, 0
26607, 1.5478260869565, 0.93260869565217, 0
26608, 1.5913043478261, 0.93260869565217, 0
26609, 1.6347826086957, 0.93260869565217, 0
26610, 1.6782608695652, 0.93260869565217, 0
26611, 1.7217391304348, 0.93260869565217, 0
26612, 1.7652173913043, 0.93260869565217, 0
26613, 1.8086956521739, 0.93260869565217, 0
26614, 1.8521739130435, 0.93260869565217, 0
26615, 1.895652173913, 0.93260869565217, 0
26616, 1.9391304347826, 0.93260869565217, 0
26617, 1.9826086956522, 0.93260869565217, 0
26618, 2.0260869565217, 0.93260869565217, 0
26619, 2.0695652173913, 0.93260869565217, 0
26620, 2.1130434782609, 0.93260869565217, 0
26621, 2.1565217391304, 0.93260869565217, 0
26622, 1.2434782608696, 0.8804347826087, 0
26623, 1.2869565217391, 0.8804347826087, 0
26624, 1.3304347826087, 0.8804347826087, 0
26625, 1.3739130434783, 0.8804347826087, 0
26626, 1.4173913043478, 0.8804347826087, 0
26627, 1.4608695652174, 0.8804347826087, 0
26628, 1.504347826087, 0.8804347826087, 0
26629, 1.5478260869565, 0.8804347826087, 0
26630, 1.5913043478261, 0.8804347826087, 0
26631, 1.6347826086957, 0.8804347826087, 0
26632, 1.6782608695652, 0.8804347826087, 0
26633, 1.7217391304348, 0.8804347826087, 0
26634, 1.7652173913043, 0.8804347826087, 0
26635, 1.8086956521739, 0.8804347826087, 0
26636, 1.8521739130435, 0.8804347826087, 0
26637, 1.895652173913, 0.8804347826087, 0
26638, 1.9391304347826, 0.8804347826087, 0
26639, 1.9826086956522, 0.8804347826087, 0
26640, 2.0260869565217, 0.8804347826087, 0
26641, 2.0695652173913, 0.8804347826087, 0
26642, 2.1130434782609, 0.8804347826087, 0
26643, 2.1565217391304, 0.8804347826087, 0
26644, 1.2434782608696, 0.82826086956522, 0
26645, 1.2869565217391, 0.82826086956522, 0
26646, 1.3304347826087, 0.82826086956522, 0
26647, 1.3739130434783, 0.82826086956522, 0
26648, 1.4173913043478, 0.82826086956522, 0
26649, 1.4608695652174, 0.82826086956522, 0
26650, 1.504347826087, 0.82826086956522, 0
26651, 1.5478260869565, 0.82826086956522, 0
26652, 1.5913043478261, 0.82826086956522, 0
26653, 1.6347826086957, 0.82826086956522, 0
26654, 1.6782608695652, 0.82826086956522, 0
26655, 1.7217391304348, 0.82826086956522, 0
26656, 1.7652173913043, 0.82826086956522, 0
26657, 1.8086956521739, 0.82826086956522, 0
26658, 1.8521739130435, 0.82826086956522, 0
26659, 1.895652173913, 0.82826086956522, 0
26660, 1.9391304347826, 0.82826086956522, 0
26661, 1.9826086956522, 0.82826086956522, 0
26662, 2.0260869565217, 0.82826086956522, 0
26663, 2.0695652173913, 0.82826086956522, 0
26664, 2.1130434782609, 0.82826086956522, 0
26665, 2.1565217391304, 0.82826086956522, 0
26666, 1.2434782608696, 0.77608695652174, 0
26667, 1.2869565217391, 0.77608695652174, 0
26668, 1.3304347826087, 0.77608695652174, 0
26669, 1.3739130434783, 0.77608695652174, 0
26670, 1.4173913043478, 0.77608695652174, 0
26671, 1.4608695652174, 0.77608695652174, 0
26672, 1.504347826087, 0.77608695652174, 0
26673, 1.5478260869565, 0.77608695652174, 0
26674, 1.5913043478261, 0.77608695652174, 0
26675, 1.6347826086957, 0.77608695652174, 0
26676, 1.6782608695652, 0.77608695652174, 0
26677, 1.7217391304348, 0.77608695652174, 0
26678, 1.7652173913043, 0.77608695652174, 0
26679, 1.8086956521739, 0.77608695652174, 0
26680, 1.8521739130435, 0.77608695652174, 0
26681, 1.895652173913, 0.77608695652174, 0
26682, 1.9391304347826, 0.77608695652174, 0
26683, 1.9826086956522, 0.77608695652174, 0
26684, 2.0260869565217, 0.77608695652174, 0
26685, 2.0695652173913, 0.77608695652174, 0
26686, 2.1130434782609, 0.77608695652174, 0
26687, 2.1565217391304, 0.77608695652174, 0
26688, 1.2434782608696, 0.72391304347826, 0
26689, 1.2869565217391, 0.72391304347826, 0
26690, 1.3304347826087, 0.72391304347826, 0
26691, 1.3739130434783, 0.72391304347826, 0
26692, 1.4173913043478, 0.72391304347826, 0
26693, 1.4608695652174, 0.72391304347826, 0
26694, 1.504347826087, 0.72391304347826, 0
26695, 1.5478260869565, 0.72391304347826, 0
26696, 1.5913043478261, 0.72391304347826, 0
26697, 1.6347826086957, 0.72391304347826, 0
26698, 1.6782608695652, 0.72391304347826, 0
26699, 1.7217391304348, 0.72391304347826, 0
26700, 1.7652173913043, 0.72391304347826, 0
26701, 1.8086956521739, 0.72391304347826, 0
26702, 1.8521739130435, 0.72391304347826, 0
26703, 1.895652173913, 0.72391304347826, 0
26704, 1.9391304347826, 0.72391304347826, 0
26705, 1.9826086956522, 0.72391304347826, 0
26706, 2.0260869565217, 0.72391304347826, 0
26707, 2.0695652173913, 0.72391304347826, 0
26708, 2.1130434782609, 0.72391304347826, 0
26709, 2.1565217391304, 0.72391304347826, 0
26710, 1.2434782608696, 0.67173913043478, 0
26711, 1.2869565217391, 0.67173913043478, 0
26712, 1.3304347826087, 0.67173913043478, 0
26713, 1.3739130434783, 0.67173913043478, 0
26714, 1.4173913043478, 0.67173913043478, 0
26715, 1.4608695652174, 0.67173913043478, 0
26716, 1.504347826087, 0.67173913043478, 0
26717, 1.5478260869565, 0.67173913043478, 0
26718, 1.5913043478261, 0.67173913043478, 0
26719, 1.6347826086957, 0.67173913043478, 0
26720, 1.6782608695652, 0.67173913043478, 0
26721, 1.7217391304348, 0.67173913043478, 0
26722, 1.7652173913043, 0.67173913043478, 0
26723, 1.8086956521739, 0.67173913043478, 0
26724, 1.8521739130435, 0.67173913043478, 0
26725, 1.895652173913, 0.67173913043478, 0
26726, 1.9391304347826, 0.67173913043478, 0
26727, 1.9826086956522, 0.67173913043478, 0
26728, 2.0260869565217, 0.67173913043478, 0
26729, 2.0695652173913, 0.67173913043478, 0
26730, 2.1130434782609, 0.67173913043478, 0
26731, 2.1565217391304, 0.67173913043478, 0
26732, 1.2434782608696, 0.61956521739131, 0
26733, 1.2869565217391, 0.61956521739131, 0
26734, 1.3304347826087, 0.61956521739131, 0
26735, 1.3739130434783, 0.61956521739131, 0
26736, 1.4173913043478, 0.61956521739131, 0
26737, 1.4608695652174, 0.61956521739131, 0
26738, 1.504347826087, 0.6195652173913, 0
26739, 1.5478260869565, 0.61956521739131, 0
26740, 1.5913043478261, 0.61956521739131, 0
26741, 1.6347826086957, 0.61956521739131, 0
26742, 1.6782608695652, 0.61956521739131, 0
26743, 1.7217391304348, 0.61956521739131, 0
26744, 1.7652173913043, 0.61956521739131, 0
26745, 1.8086956521739, 0.61956521739131, 0
26746, 1.8521739130435, 0.61956521739131, 0
26747, 1.895652173913, 0.61956521739131, 0
26748, 1.9391304347826, 0.61956521739131, 0
26749, 1.9826086956522, 0.61956521739131, 0
26750, 2.0260869565217, 0.61956521739131, 0
26751, 2.0695652173913, 0.61956521739131, 0
26752, 2.1130434782609, 0.61956521739131, 0
26753, 2.1565217391304, 0.61956521739131, 0
26754, 1.2434782608696, 0.56739130434783, 0
26755, 1.2869565217391, 0.56739130434783, 0
26756, 1.3304347826087, 0.56739130434783, 0
26757, 1.3739130434783, 0.56739130434783, 0
26758, 1.4173913043478, 0.56739130434783, 0
26759, 1.4608695652174, 0.56739130434783, 0
26760, 1.504347826087, 0.56739130434783, 0
26761, 1.5478260869565, 0.56739130434783, 0
26762, 1.5913043478261, 0.56739130434783, 0
26763, 1.6347826086957, 0.56739130434783, 0
26764, 1.6782608695652, 0.56739130434783, 0
26765, 1.7217391304348, 0.56739130434783, 0
26766, 1.7652173913043, 0.56739130434783, 0
26767, 1.8086956521739, 0.56739130434783, 0
26768, 1.8521739130435, 0.56739130434783, 0
26769, 1.895652173913, 0.56739130434783, 0
26770, 1.9391304347826, 0.56739130434783, 0
26771, 1.9826086956522, 0.56739130434783, 0
26772, 2.0260869565217, 0.56739130434783, 0
26773, 2.0695652173913, 0.56739130434783, 0
26774, 2.1130434782609, 0.56739130434783, 0
26775, 2.1565217391304, 0.56739130434783, 0
26776, 1.2434782608696, 0.51521739130435, 0
26777, 1.2869565217391, 0.51521739130435, 0
26778, 1.3304347826087, 0.51521739130435, 0
26779, 1.3739130434783, 0.51521739130435, 0
26780, 1.4173913043478, 0.51521739130435, 0
26781, 1.4608695652174, 0.51521739130435, 0
26782, 1.504347826087, 0.51521739130435, 0
26783, 1.5478260869565, 0.51521739130435, 0
26784, 1.5913043478261, 0.51521739130435, 0
26785, 1.6347826086957, 0.51521739130435, 0
26786, 1.6782608695652, 0.51521739130435, 0
26787, 1.7217391304348, 0.51521739130435, 0
26788, 1.7652173913043, 0.51521739130435, 0
26789, 1.8086956521739, 0.51521739130435, 0
26790, 1.8521739130435, 0.51521739130435, 0
26791, 1.895652173913, 0.51521739130435, 0
26792, 1.9391304347826, 0.51521739130435, 0
26793, 1.9826086956522, 0.51521739130435, 0
26794, 2.0260869565217, 0.51521739130435, 0
26795, 2.0695652173913, 0.51521739130435, 0
26796, 2.1130434782609, 0.51521739130435, 0
26797, 2.1565217391304, 0.51521739130435, 0
26798, 1.2434782608696, 0.46304347826087, 0
26799, 1.2869565217391, 0.46304347826087, 0
26800, 1.3304347826087, 0.46304347826087, 0
26801, 1.3739130434783, 0.46304347826087, 0
26802, 1.4173913043478, 0.46304347826087, 0
26803, 1.4608695652174, 0.46304347826087, 0
26804, 1.504347826087, 0.46304347826087, 0
26805, 1.5478260869565, 0.46304347826087, 0
26806, 1.5913043478261, 0.46304347826087, 0
26807, 1.6347826086957, 0.46304347826087, 0
26808, 1.6782608695652, 0.46304347826087, 0
26809, 1.7217391304348, 0.46304347826087, 0
26810, 1.7652173913043, 0.46304347826087, 0
26811, 1.8086956521739, 0.46304347826087, 0
26812, 1.8521739130435, 0.46304347826087, 0
26813, 1.895652173913, 0.46304347826087, 0
26814, 1.9391304347826, 0.46304347826087, 0
26815, 1.9826086956522, 0.46304347826087, 0
26816, 2.0260869565217, 0.46304347826087, 0
26817, 2.0695652173913, 0.46304347826087, 0
26818, 2.1130434782609, 0.46304347826087, 0
26819, 2.1565217391304, 0.46304347826087, 0
26820, 1.2434782608696, 0.41086956521739, 0
26821, 1.2869565217391, 0.41086956521739, 0
26822, 1.3304347826087, 0.41086956521739, 0
26823, 1.3739130434783, 0.41086956521739, 0
26824, 1.4173913043478, 0.41086956521739, 0
26825, 1.4608695652174, 0.41086956521739, 0
26826, 1.504347826087, 0.41086956521739, 0
26827, 1.5478260869565, 0.41086956521739, 0
26828, 1.5913043478261, 0.41086956521739, 0
26829, 1.6347826086957, 0.41086956521739, 0
26830, 1.6782608695652, 0.41086956521739, 0
26831, 1.7217391304348, 0.41086956521739, 0
26832, 1.7652173913043, 0.41086956521739, 0
26833, 1.8086956521739, 0.41086956521739, 0
26834, 1.8521739130435, 0.41086956521739, 0
26835, 1.895652173913, 0.41086956521739, 0
26836, 1.9391304347826, 0.41086956521739, 0
26837, 1.9826086956522, 0.41086956521739, 0
26838, 2.0260869565217, 0.41086956521739, 0
26839, 2.0695652173913, 0.41086956521739, 0
26840, 2.1130434782609, 0.41086956521739, 0
26841, 2.1565217391304, 0.41086956521739, 0
26842, 1.2434782608696, 0.35869565217391, 0
26843, 1.2869565217391, 0.35869565217391, 0
26844, 1.3304347826087, 0.35869565217391, 0
26845, 1.3739130434783, 0.35869565217391, 0
26846, 1.4173913043478, 0.35869565217391, 0
26847, 1.4608695652174, 0.35869565217391, 0
26848, 1.504347826087, 0.35869565217391, 0
26849, 1.5478260869565, 0.35869565217391, 0
26850, 1.5913043478261, 0.35869565217391, 0
26851, 1.6347826086957, 0.35869565217391, 0
26852, 1.6782608695652, 0.35869565217391, 0
26853, 1.7217391304348, 0.35869565217391, 0
26854, 1.7652173913043, 0.35869565217391, 0
26855, 1.8086956521739, 0.35869565217391, 0
26856, 1.8521739130435, 0.35869565217391, 0
26857, 1.895652173913, 0.35869565217391, 0
26858, 1.9391304347826, 0.35869565217391, 0
26859, 1.9826086956522, 0.35869565217391, 0
26860, 2.0260869565217, 0.35869565217391, 0
26861, 2.0695652173913, 0.35869565217391, 0
26862, 2.1130434782609, 0.35869565217391, 0
26863, 2.1565217391304, 0.35869565217391, 0
26864, 1.2434782608696, 0.30652173913044, 0
26865, 1.2869565217391, 0.30652173913043, 0
26866, 1.3304347826087, 0.30652173913043, 0
26867, 1.3739130434783, 0.30652173913044, 0
26868, 1.4173913043478, 0.30652173913044, 0
26869, 1.4608695652174, 0.30652173913043, 0
26870, 1.504347826087, 0.30652173913044, 0
26871, 1.5478260869565, 0.30652173913044, 0
26872, 1.5913043478261, 0.30652173913044, 0
26873, 1.6347826086957, 0.30652173913043, 0
26874, 1.6782608695652, 0.30652173913043, 0
26875, 1.7217391304348, 0.30652173913043, 0
26876, 1.7652173913043, 0.30652173913043, 0
26877, 1.8086956521739, 0.30652173913044, 0
26878, 1.8521739130435, 0.30652173913043, 0
26879, 1.895652173913, 0.30652173913044, 0
26880, 1.9391304347826, 0.30652173913043, 0
26881, 1.9826086956522, 0.30652173913044, 0
26882, 2.0260869565217, 0.30652173913044, 0
26883, 2.0695652173913, 0.30652173913043, 0
26884, 2.1130434782609, 0.30652173913043, 0
26885, 2.1565217391304, 0.30652173913043, 0
26886, 1.2434782608696, 0.25434782608696, 0
26887, 1.2869565217391, 0.25434782608696, 0
26888, 1.3304347826087, 0.25434782608696, 0
26889, 1.3739130434783, 0.25434782608696, 0
26890, 1.4173913043478, 0.25434782608696, 0
26891, 1.4608695652174, 0.25434782608696, 0
26892, 1.504347826087, 0.25434782608696, 0
26893, 1.5478260869565, 0.25434782608696, 0
26894, 1.5913043478261, 0.25434782608696, 0
26895, 1.6347826086957, 0.25434782608696, 0
26896, 1.6782608695652, 0.25434782608696, 0
26897, 1.7217391304348, 0.25434782608696, 0
26898, 1.7652173913043, 0.25434782608696, 0
26899, 1.8086956521739, 0.25434782608696, 0
26900, 1.8521739130435, 0.25434782608696, 0
26901, 1.895652173913, 0.25434782608696, 0
26902, 1.9391304347826, 0.25434782608696, 0
26903, 1.9826086956522, 0.25434782608696, 0
26904, 2.0260869565217, 0.25434782608696, 0
26905, 2.0695652173913, 0.25434782608696, 0
26906, 2.1130434782609, 0.25434782608696, 0
26907, 2.1565217391304, 0.25434782608696, 0
26908, 1.2434782608696, 0.20217391304348, 0
26909, 1.2869565217391, 0.20217391304348, 0
26910, 1.3304347826087, 0.20217391304348, 0
26911, 1.3739130434783, 0.20217391304348, 0
26912, 1.4173913043478, 0.20217391304348, 0
26913, 1.4608695652174, 0.20217391304348, 0
26914, 1.504347826087, 0.20217391304348, 0
26915, 1.5478260869565, 0.20217391304348, 0
26916, 1.5913043478261, 0.20217391304348, 0
26917, 1.6347826086957, 0.20217391304348, 0
26918, 1.6782608695652, 0.20217391304348, 0
26919, 1.7217391304348, 0.20217391304348, 0
26920, 1.7652173913043, 0.20217391304348, 0
26921, 1.8086956521739, 0.20217391304348, 0
26922, 1.8521739130435, 0.20217391304348, 0
26923, 1.895652173913, 0.20217391304348, 0
26924, 1.9391304347826, 0.20217391304348, 0
26925, 1.9826086956522, 0.20217391304348, 0
26926, 2.0260869565217, 0.20217391304348, 0
26927, 2.0695652173913, 0.20217391304348, 0
26928, 2.1130434782609, 0.20217391304348, 0
26929, 2.1565217391304, 0.20217391304348, 0
26930, 1.2434782608696, 1.3239130434783, 0
26931, 1.2217391304348, 1.2978260869565, 0
26932, 1.2869565217391, 1.3239130434783, 0
26933, 1.2652173913043, 1.2978260869565, 0
26934, 1.3304347826087, 1.3239130434783, 0
26935, 1.3086956521739, 1.2978260869565, 0
26936, 1.3739130434783, 1.3239130434783, 0
26937, 1.3521739130435, 1.2978260869565, 0
26938, 1.4173913043478, 1.3239130434783, 0
26939, 1.395652173913, 1.2978260869565, 0
26940, 1.4608695652174, 1.3239130434783, 0
26941, 1.4391304347826, 1.2978260869565, 0
26942, 1.504347826087, 1.3239130434783, 0
26943, 1.4826086956522, 1.2978260869565, 0
26944, 1.5478260869565, 1.3239130434783, 0
26945, 1.5260869565217, 1.2978260869565, 0
26946, 1.5913043478261, 1.3239130434783, 0
26947, 1.5695652173913, 1.2978260869565, 0
26948, 1.6347826086957, 1.3239130434783, 0
26949, 1.6130434782609, 1.2978260869565, 0
26950, 1.6782608695652, 1.3239130434783, 0
26951, 1.6565217391304, 1.2978260869565, 0
26952, 1.7217391304348, 1.3239130434783, 0
26953, 1.7, 1.2978260869565, 0
26954, 1.7652173913043, 1.3239130434783, 0
26955, 1.7434782608696, 1.2978260869565, 0
26956, 1.8086956521739, 1.3239130434783, 0
26957, 1.7869565217391, 1.2978260869565, 0
26958, 1.8521739130435, 1.3239130434783, 0
26959, 1.8304347826087, 1.2978260869565, 0
26960, 1.895652173913, 1.3239130434783, 0
26961, 1.8739130434783, 1.2978260869565, 0
26962, 1.9391304347826, 1.3239130434783, 0
26963, 1.9173913043478, 1.2978260869565, 0
26964, 1.9826086956522, 1.3239130434783, 0
26965, 1.9608695652174, 1.2978260869565, 0
26966, 2.0260869565217, 1.3239130434783, 0
26967, 2.004347826087, 1.2978260869565, 0
26968, 2.0695652173913, 1.3239130434783, 0
26969, 2.0478260869565, 1.2978260869565, 0
26970, 2.1130434782609, 1.3239130434783, 0
26971, 2.0913043478261, 1.2978260869565, 0
26972, 2.1565217391304, 1.3239130434783, 0
26973, 2.1347826086957, 1.2978260869565, 0
26974, 2.1782608695652, 1.2978260869565, 0
26975, 1.2434782608696, 1.2717391304348, 0
26976, 1.2217391304348, 1.245652173913, 0
26977, 1.2869565217391, 1.2717391304348, 0
26978, 1.2652173913043, 1.245652173913, 0
26979, 1.3304347826087, 1.2717391304348, 0
26980, 1.3086956521739, 1.245652173913, 0
26981, 1.3739130434783, 1.2717391304348, 0
26982, 1.3521739130435, 1.245652173913, 0
26983, 1.4173913043478, 1.2717391304348, 0
26984, 1.395652173913, 1.245652173913, 0
26985, 1.4608695652174, 1.2717391304348, 0
26986, 1.4391304347826, 1.245652173913, 0
26987, 1.504347826087, 1.2717391304348, 0
26988, 1.4826086956522, 1.245652173913, 0
26989, 1.5478260869565, 1.2717391304348, 0
26990, 1.5260869565217, 1.245652173913, 0
26991, 1.5913043478261, 1.2717391304348, 0
26992, 1.5695652173913, 1.245652173913, 0
26993, 1.6347826086957, 1.2717391304348, 0
26994, 1.6130434782609, 1.245652173913, 0
26995, 1.6782608695652, 1.2717391304348, 0
26996, 1.6565217391304, 1.245652173913, 0
26997, 1.7217391304348, 1.2717391304348, 0
26998, 1.7, 1.245652173913, 0
26999, 1.7652173913043, 1.2717391304348, 0
27000, 1.7434782608696, 1.245652173913, 0
27001, 1.8086956521739, 1.2717391304348, 0
27002, 1.7869565217391, 1.245652173913, 0
27003, 1.8521739130435, 1.2717391304348, 0
27004, 1.8304347826087, 1.245652173913, 0
27005, 1.895652173913, 1.2717391304348, 0
27006, 1.8739130434783, 1.245652173913, 0
27007, 1.9391304347826, 1.2717391304348, 0
27008, 1.9173913043478, 1.245652173913, 0
27009, 1.9826086956522, 1.2717391304348, 0
27010, 1.9608695652174, 1.245652173913, 0
27011, 2.0260869565217, 1.2717391304348, 0
27012, 2.004347826087, 1.245652173913, 0
27013, 2.0695652173913, 1.2717391304348, 0
27014, 2.0478260869565, 1.245652173913, 0
27015, 2.1130434782609, 1.2717391304348, 0
27016, 2.0913043478261, 1.245652173913, 0
27017, 2.1565217391304, 1.2717391304348, 0
27018, 2.1347826086957, 1.245652173913, 0
27019, 2.1782608695652, 1.245652173913, 0
27020, 1.2434782608696, 1.2195652173913, 0
27021, 1.2217391304348, 1.1934782608696, 0
27022, 1.2869565217391, 1.2195652173913, 0
27023, 1.2652173913043, 1.1934782608696, 0
27024, 1.3304347826087, 1.2195652173913, 0
27025, 1.3086956521739, 1.1934782608696, 0
27026, 1.3739130434783, 1.2195652173913, 0
27027, 1.3521739130435, 1.1934782608696, 0
27028, 1.4173913043478, 1.2195652173913, 0
27029, 1.395652173913, 1.1934782608696, 0
27030, 1.4608695652174, 1.2195652173913, 0
27031, 1.4391304347826, 1.1934782608696, 0
27032, 1.504347826087, 1.2195652173913, 0
27033, 1.4826086956522, 1.1934782608696, 0
27034, 1.5478260869565, 1.2195652173913, 0
27035, 1.5260869565217, 1.1934782608696, 0
27036, 1.5913043478261, 1.2195652173913, 0
27037, 1.5695652173913, 1.1934782608696, 0
27038, 1.6347826086957, 1.2195652173913, 0
27039, 1.6130434782609, 1.1934782608696, 0
27040, 1.6782608695652, 1.2195652173913, 0
27041, 1.6565217391304, 1.1934782608696, 0
27042, 1.7217391304348, 1.2195652173913, 0
27043, 1.7, 1.1934782608696, 0
27044, 1.7652173913043, 1.2195652173913, 0
27045, 1.7434782608696, 1.1934782608696, 0
27046, 1.8086956521739, 1.2195652173913, 0
27047, 1.7869565217391, 1.1934782608696, 0
27048, 1.8521739130435, 1.2195652173913, 0
27049, 1.8304347826087, 1.1934782608696, 0
27050, 1.895652173913, 1.2195652173913, 0
27051, 1.8739130434783, 1.1934782608696, 0
27052, 1.9391304347826, 1.2195652173913, 0
27053, 1.9173913043478, 1.1934782608696, 0
27054, 1.9826086956522, 1.2195652173913, 0
27055, 1.9608695652174, 1.1934782608696, 0
27056, 2.0260869565217, 1.2195652173913, 0
27057, 2.004347826087, 1.1934782608696, 0
27058, 2.0695652173913, 1.2195652173913, 0
27059, 2.0478260869565, 1.1934782608696, 0
27060, 2.1130434782609, 1.2195652173913, 0
27061, 2.0913043478261, 1.1934782608696, 0
27062, 2.1565217391304, 1.2195652173913, 0
27063, 2.1347826086957, 1.1934782608696, 0
27064, 2.1782608695652, 1.1934782608696, 0
27065, 1.2434782608696, 1.1673913043478, 0
27066, 1.2217391304348, 1.1413043478261, 0
27067, 1.2869565217391, 1.1673913043478, 0
27068, 1.2652173913043, 1.1413043478261, 0
27069, 1.3304347826087, 1.1673913043478, 0
27070, 1.3086956521739, 1.1413043478261, 0
27071, 1.3739130434783, 1.1673913043478, 0
27072, 1.3521739130435, 1.1413043478261, 0
27073, 1.4173913043478, 1.1673913043478, 0
27074, 1.395652173913, 1.1413043478261, 0
27075, 1.4608695652174, 1.1673913043478, 0
27076, 1.4391304347826, 1.1413043478261, 0
27077, 1.504347826087, 1.1673913043478, 0
27078, 1.4826086956522, 1.1413043478261, 0
27079, 1.5478260869565, 1.1673913043478, 0
27080, 1.5260869565217, 1.1413043478261, 0
27081, 1.5913043478261, 1.1673913043478, 0
27082, 1.5695652173913, 1.1413043478261, 0
27083, 1.6347826086957, 1.1673913043478, 0
27084, 1.6130434782609, 1.1413043478261, 0
27085, 1.6782608695652, 1.1673913043478, 0
27086, 1.6565217391304, 1.1413043478261, 0
27087, 1.7217391304348, 1.1673913043478, 0
27088, 1.7, 1.1413043478261, 0
27089, 1.7652173913043, 1.1673913043478, 0
27090, 1.7434782608696, 1.1413043478261, 0
27091, 1.8086956521739, 1.1673913043478, 0
27092, 1.7869565217391, 1.1413043478261, 0
27093, 1.8521739130435, 1.1673913043478, 0
27094, 1.8304347826087, 1.1413043478261, 0
27095, 1.895652173913, 1.1673913043478, 0
27096, 1.8739130434783, 1.1413043478261, 0
27097, 1.9391304347826, 1.1673913043478, 0
27098, 1.9173913043478, 1.1413043478261, 0
27099, 1.9826086956522, 1.1673913043478, 0
27100, 1.9608695652174, 1.1413043478261, 0
27101, 2.0260869565217, 1.1673913043478, 0
27102, 2.004347826087, 1.1413043478261, 0
27103, 2.0695652173913, 1.1673913043478, 0
27104, 2.0478260869565, 1.1413043478261, 0
27105, 2.1130434782609, 1.1673913043478, 0
27106, 2.0913043478261, 1.1413043478261, 0
27107, 2.1565217391304, 1.1673913043478, 0
27108, 2.1347826086957, 1.1413043478261, 0
27109, 2.1782608695652, 1.1413043478261, 0
27110, 1.2434782608696, 1.1152173913043, 0
27111, 1.2217391304348, 1.0891304347826, 0
27112, 1.2869565217391, 1.1152173913043, 0
27113, 1.2652173913043, 1.0891304347826, 0
27114, 1.3304347826087, 1.1152173913043, 0
27115, 1.3086956521739, 1.0891304347826, 0
27116, 1.3739130434783, 1.1152173913043, 0
27117, 1.3521739130435, 1.0891304347826, 0
27118, 1.4173913043478, 1.1152173913043, 0
27119, 1.395652173913, 1.0891304347826, 0
27120, 1.4608695652174, 1.1152173913043, 0
27121, 1.4391304347826, 1.0891304347826, 0
27122, 1.504347826087, 1.1152173913043, 0
27123, 1.4826086956522, 1.0891304347826, 0
27124, 1.5478260869565, 1.1152173913043, 0
27125, 1.5260869565217, 1.0891304347826, 0
27126, 1.5913043478261, 1.1152173913043, 0
27127, 1.5695652173913, 1.0891304347826, 0
27128, 1.6347826086957, 1.1152173913043, 0
27129, 1.6130434782609, 1.0891304347826, 0
27130, 1.6782608695652, 1.1152173913043, 0
27131, 1.6565217391304, 1.0891304347826, 0
27132, 1.7217391304348, 1.1152173913043, 0
27133, 1.7, 1.0891304347826, 0
27134, 1.7652173913043, 1.1152173913043, 0
27135, 1.7434782608696, 1.0891304347826, 0
27136, 1.8086956521739, 1.1152173913043, 0
27137, 1.7869565217391, 1.0891304347826, 0
27138, 1.8521739130435, 1.1152173913043, 0
27139, 1.8304347826087, 1.0891304347826, 0
27140, 1.895652173913, 1.1152173913043, 0
27141, 1.8739130434783, 1.0891304347826, 0
27142, 1.9391304347826, 1.1152173913043, 0
27143, 1.9173913043478, 1.0891304347826, 0
27144, 1.9826086956522, 1.1152173913043, 0
27145, 1.9608695652174, 1.0891304347826, 0
27146, 2.0260869565217, 1.1152173913043, 0
27147, 2.004347826087, 1.0891304347826, 0
27148, 2.0695652173913, 1.1152173913043, 0
27149, 2.0478260869565, 1.0891304347826, 0
27150, 2.1130434782609, 1.1152173913043, 0
27151, 2.0913043478261, 1.0891304347826, 0
27152, 2.1565217391304, 1.1152173913043, 0
27153, 2.1347826086957, 1.0891304347826, 0
27154, 2.1782608695652, 1.0891304347826, 0
27155, 1.2434782608696, 1.0630434782609, 0
27156, 1.2217391304348, 1.0369565217391, 0
27157, 1.2869565217391, 1.0630434782609, 0
27158, 1.2652173913043, 1.0369565217391, 0
27159, 1.3304347826087, 1.0630434782609, 0
27160, 1.3086956521739, 1.0369565217391, 0
27161, 1.3739130434783, 1.0630434782609, 0
27162, 1.3521739130435, 1.0369565217391, 0
27163, 1.4173913043478, 1.0630434782609, 0
27164, 1.395652173913, 1.0369565217391, 0
27165, 1.4608695652174, 1.0630434782609, 0
27166, 1.4391304347826, 1.0369565217391, 0
27167, 1.504347826087, 1.0630434782609, 0
27168, 1.4826086956522, 1.0369565217391, 0
27169, 1.5478260869565, 1.0630434782609, 0
27170, 1.5260869565217, 1.0369565217391, 0
27171, 1.5913043478261, 1.0630434782609, 0
27172, 1.5695652173913, 1.0369565217391, 0
27173, 1.6347826086957, 1.0630434782609, 0
27174, 1.6130434782609, 1.0369565217391, 0
27175, 1.6782608695652, 1.0630434782609, 0
27176, 1.6565217391304, 1.0369565217391, 0
27177, 1.7217391304348, 1.0630434782609, 0
27178, 1.7, 1.0369565217391, 0
27179, 1.7652173913043, 1.0630434782609, 0
27180, 1.7434782608696, 1.0369565217391, 0
27181, 1.8086956521739, 1.0630434782609, 0
27182, 1.7869565217391, 1.0369565217391, 0
27183, 1.8521739130435, 1.0630434782609, 0
27184, 1.8304347826087, 1.0369565217391, 0
27185, 1.895652173913, 1.0630434782609, 0
27186, 1.8739130434783, 1.0369565217391, 0
27187, 1.9391304347826, 1.0630434782609, 0
27188, 1.9173913043478, 1.0369565217391, 0
27189, 1.9826086956522, 1.0630434782609, 0
27190, 1.9608695652174, 1.0369565217391, 0
27191, 2.0260869565217, 1.0630434782609, 0
27192, 2.004347826087, 1.0369565217391, 0
27193, 2.0695652173913, 1.0630434782609, 0
27194, 2.0478260869565, 1.0369565217391, 0
27195, 2.1130434782609, 1.0630434782609, 0
27196, 2.0913043478261, 1.0369565217391, 0
27197, 2.1565217391304, 1.0630434782609, 0
27198, 2.1347826086957, 1.0369565217391, 0
27199, 2.1782608695652, 1.0369565217391, 0
27200, 1.2434782608696, 1.0108695652174, 0
27201, 1.2217391304348, 0.98478260869565, 0
27202, 1.2869565217391, 1.0108695652174, 0
27203, 1.2652173913043, 0.98478260869565, 0
27204, 1.3304347826087, 1.0108695652174, 0
27205, 1.3086956521739, 0.98478260869565, 0
27206, 1.3739130434783, 1.0108695652174, 0
27207, 1.3521739130435, 0.98478260869565, 0
27208, 1.4173913043478, 1.0108695652174, 0
27209, 1.395652173913, 0.98478260869565, 0
27210, 1.4608695652174, 1.0108695652174, 0
27211, 1.4391304347826, 0.98478260869565, 0
27212, 1.504347826087, 1.0108695652174, 0
27213, 1.4826086956522, 0.98478260869565, 0
27214, 1.5478260869565, 1.0108695652174, 0
27215, 1.5260869565217, 0.98478260869565, 0
27216, 1.5913043478261, 1.0108695652174, 0
27217, 1.5695652173913, 0.98478260869565, 0
27218, 1.6347826086957, 1.0108695652174, 0
27219, 1.6130434782609, 0.98478260869565, 0
27220, 1.6782608695652, 1.0108695652174, 0
27221, 1.6565217391304, 0.98478260869565, 0
27222, 1.7217391304348, 1.0108695652174, 0
27223, 1.7, 0.98478260869565, 0
27224, 1.7652173913043, 1.0108695652174, 0
27225, 1.7434782608696, 0.98478260869565, 0
27226, 1.8086956521739, 1.0108695652174, 0
27227, 1.7869565217391, 0.98478260869565, 0
27228, 1.8521739130435, 1.0108695652174, 0
27229, 1.8304347826087, 0.98478260869565, 0
27230, 1.895652173913, 1.0108695652174, 0
27231, 1.8739130434783, 0.98478260869565, 0
27232, 1.9391304347826, 1.0108695652174, 0
27233, 1.9173913043478, 0.98478260869565, 0
27234, 1.9826086956522, 1.0108695652174, 0
27235, 1.9608695652174, 0.98478260869565, 0
27236, 2.0260869565217, 1.0108695652174, 0
27237, 2.004347826087, 0.98478260869565, 0
27238, 2.0695652173913, 1.0108695652174, 0
27239, 2.0478260869565, 0.98478260869565, 0
27240, 2.1130434782609, 1.0108695652174, 0
27241, 2.0913043478261, 0.98478260869565, 0
27242, 2.1565217391304, 1.0108695652174, 0
27243, 2.1347826086957, 0.98478260869565, 0
27244, 2.1782608695652, 0.98478260869565, 0
27245, 1.2434782608696, 0.95869565217391, 0
27246, 1.2217391304348, 0.93260869565217, 0
27247, 1.2869565217391, 0.95869565217391, 0
27248, 1.2652173913043, 0.93260869565217, 0
27249, 1.3304347826087, 0.95869565217391, 0
27250, 1.3086956521739, 0.93260869565217, 0
27251, 1.3739130434783, 0.95869565217391, 0
27252, 1.3521739130435, 0.93260869565217, 0
27253, 1.4173913043478, 0.95869565217391, 0
27254, 1.395652173913, 0.93260869565217, 0
27255, 1.4608695652174, 0.95869565217391, 0
27256, 1.4391304347826, 0.93260869565217, 0
27257, 1.504347826087, 0.95869565217391, 0
27258, 1.4826086956522, 0.93260869565217, 0
27259, 1.5478260869565, 0.95869565217391, 0
27260, 1.5260869565217, 0.93260869565217, 0
27261, 1.5913043478261, 0.95869565217391, 0
27262, 1.5695652173913, 0.93260869565217, 0
27263, 1.6347826086957, 0.95869565217391, 0
27264, 1.6130434782609, 0.93260869565217, 0
27265, 1.6782608695652, 0.95869565217391, 0
27266, 1.6565217391304, 0.93260869565217, 0
27267, 1.7217391304348, 0.95869565217391, 0
27268, 1.7, 0.93260869565217, 0
27269, 1.7652173913043, 0.95869565217391, 0
27270, 1.7434782608696, 0.93260869565217, 0
27271, 1.8086956521739, 0.95869565217391, 0
27272, 1.7869565217391, 0.93260869565217, 0
27273, 1.8521739130435, 0.95869565217391, 0
27274, 1.8304347826087, 0.93260869565217, 0
27275, 1.895652173913, 0.95869565217391, 0
27276, 1.8739130434783, 0.93260869565217, 0
27277, 1.9391304347826, 0.95869565217391, 0
27278, 1.9173913043478, 0.93260869565217, 0
27279, 1.9826086956522, 0.95869565217391, 0
27280, 1.9608695652174, 0.93260869565217, 0
27281, 2.0260869565217, 0.95869565217391, 0
27282, 2.004347826087, 0.93260869565217, 0
27283, 2.0695652173913, 0.95869565217391, 0
27284, 2.0478260869565, 0.93260869565217, 0
27285, 2.1130434782609, 0.95869565217391, 0
27286, 2.0913043478261, 0.93260869565217, 0
27287, 2.1565217391304, 0.95869565217391, 0
27288, 2.1347826086957, 0.93260869565217, 0
27289, 2.1782608695652, 0.93260869565217, 0
27290, 1.2434782608696, 0.90652173913044, 0
27291, 1.2217391304348, 0.8804347826087, 0
27292, 1.2869565217391, 0.90652173913044, 0
27293, 1.2652173913043, 0.8804347826087, 0
27294, 1.3304347826087, 0.90652173913044, 0
27295, 1.3086956521739, 0.8804347826087, 0
27296, 1.3739130434783, 0.90652173913044, 0
27297, 1.3521739130435, 0.8804347826087, 0
27298, 1.4173913043478, 0.90652173913044, 0
27299, 1.395652173913, 0.8804347826087, 0
27300, 1.4608695652174, 0.90652173913044, 0
27301, 1.4391304347826, 0.8804347826087, 0
27302, 1.504347826087, 0.90652173913044, 0
27303, 1.4826086956522, 0.8804347826087, 0
27304, 1.5478260869565, 0.90652173913044, 0
27305, 1.5260869565217, 0.8804347826087, 0
27306, 1.5913043478261, 0.90652173913044, 0
27307, 1.5695652173913, 0.8804347826087, 0
27308, 1.6347826086957, 0.90652173913044, 0
27309, 1.6130434782609, 0.8804347826087, 0
27310, 1.6782608695652, 0.90652173913044, 0
27311, 1.6565217391304, 0.8804347826087, 0
27312, 1.7217391304348, 0.90652173913044, 0
27313, 1.7, 0.8804347826087, 0
27314, 1.7652173913043, 0.90652173913044, 0
27315, 1.7434782608696, 0.8804347826087, 0
27316, 1.8086956521739, 0.90652173913044, 0
27317, 1.7869565217391, 0.8804347826087, 0
27318, 1.8521739130435, 0.90652173913044, 0
27319, 1.8304347826087, 0.8804347826087, 0
27320, 1.895652173913, 0.90652173913044, 0
27321, 1.8739130434783, 0.8804347826087, 0
27322, 1.9391304347826, 0.90652173913044, 0
27323, 1.9173913043478, 0.8804347826087, 0
27324, 1.9826086956522, 0.90652173913044, 0
27325, 1.9608695652174, 0.8804347826087, 0
27326, 2.0260869565217, 0.90652173913044, 0
27327, 2.004347826087, 0.8804347826087, 0
27328, 2.0695652173913, 0.90652173913044, 0
27329, 2.0478260869565, 0.8804347826087, 0
27330, 2.1130434782609, 0.90652173913044, 0
27331, 2.0913043478261, 0.8804347826087, 0
27332, 2.1565217391304, 0.90652173913044, 0
27333, 2.1347826086957, 0.8804347826087, 0
27334, 2.1782608695652, 0.8804347826087, 0
27335, 1.2434782608696, 0.85434782608696, 0
27336, 1.2217391304348, 0.82826086956522, 0
27337, 1.2869565217391, 0.85434782608696, 0
27338, 1.2652173913043, 0.82826086956522, 0
27339, 1.3304347826087, 0.85434782608696, 0
27340, 1.3086956521739, 0.82826086956522, 0
27341, 1.3739130434783, 0.85434782608696, 0
27342, 1.3521739130435, 0.82826086956522, 0
27343, 1.4173913043478, 0.85434782608696, 0
27344, 1.395652173913, 0.82826086956522, 0
27345, 1.4608695652174, 0.85434782608696, 0
27346, 1.4391304347826, 0.82826086956522, 0
27347, 1.504347826087, 0.85434782608696, 0
27348, 1.4826086956522, 0.82826086956522, 0
27349, 1.5478260869565, 0.85434782608696, 0
27350, 1.5260869565217, 0.82826086956522, 0
27351, 1.5913043478261, 0.85434782608696, 0
27352, 1.5695652173913, 0.82826086956522, 0
27353, 1.6347826086957, 0.85434782608696, 0
27354, 1.6130434782609, 0.82826086956522, 0
27355, 1.6782608695652, 0.85434782608696, 0
27356, 1.6565217391304, 0.82826086956522, 0
27357, 1.7217391304348, 0.85434782608696, 0
27358, 1.7, 0.82826086956522, 0
27359, 1.7652173913043, 0.85434782608696, 0
27360, 1.7434782608696, 0.82826086956522, 0
27361, 1.8086956521739, 0.85434782608696, 0
27362, 1.7869565217391, 0.82826086956522, 0
27363, 1.8521739130435, 0.85434782608696, 0
27364, 1.8304347826087, 0.82826086956522, 0
27365, 1.895652173913, 0.85434782608696, 0
27366, 1.8739130434783, 0.82826086956522, 0
27367, 1.9391304347826, 0.85434782608696, 0
27368, 1.9173913043478, 0.82826086956522, 0
27369, 1.9826086956522, 0.85434782608696, 0
27370, 1.9608695652174, 0.82826086956522, 0
27371, 2.0260869565217, 0.85434782608696, 0
27372, 2.004347826087, 0.82826086956522, 0
27373, 2.0695652173913, 0.85434782608696, 0
27374, 2.0478260869565, 0.82826086956522, 0
27375, 2.1130434782609, 0.85434782608696, 0
27376, 2.0913043478261, 0.82826086956522, 0
27377, 2.1565217391304, 0.85434782608696, 0
27378, 2.1347826086957, 0.82826086956522, 0
27379, 2.1782608695652, 0.82826086956522, 0
27380, 1.2434782608696, 0.80217391304348, 0
27381, 1.2217391304348, 0.77608695652174, 0
27382, 1.2869565217391, 0.80217391304348, 0
27383, 1.2652173913043, 0.77608695652174, 0
27384, 1.3304347826087, 0.80217391304348, 0
27385, 1.3086956521739, 0.77608695652174, 0
27386, 1.3739130434783, 0.80217391304348, 0
27387, 1.3521739130435, 0.77608695652174, 0
27388, 1.4173913043478, 0.80217391304348, 0
27389, 1.395652173913, 0.77608695652174, 0
27390, 1.4608695652174, 0.80217391304348, 0
27391, 1.4391304347826, 0.77608695652174, 0
27392, 1.504347826087, 0.80217391304348, 0
27393, 1.4826086956522, 0.77608695652174, 0
27394, 1.5478260869565, 0.80217391304348, 0
27395, 1.5260869565217, 0.77608695652174, 0
27396, 1.5913043478261, 0.80217391304348, 0
27397, 1.5695652173913, 0.77608695652174, 0
27398, 1.6347826086957, 0.80217391304348, 0
27399, 1.6130434782609, 0.77608695652174, 0
27400, 1.6782608695652, 0.80217391304348, 0
27401, 1.6565217391304, 0.77608695652174, 0
27402, 1.7217391304348, 0.80217391304348, 0
27403, 1.7, 0.77608695652174, 0
27404, 1.7652173913043, 0.80217391304348, 0
27405, 1.7434782608696, 0.77608695652174, 0
27406, 1.8086956521739, 0.80217391304348, 0
27407, 1.7869565217391, 0.77608695652174, 0
27408, 1.8521739130435, 0.80217391304348, 0
27409, 1.8304347826087, 0.77608695652174, 0
27410, 1.895652173913, 0.80217391304348, 0
27411, 1.8739130434783, 0.77608695652174, 0
27412, 1.9391304347826, 0.80217391304348, 0
27413, 1.9173913043478, 0.77608695652174, 0
27414, 1.9826086956522, 0.80217391304348, 0
27415, 1.9608695652174, 0.77608695652174, 0
27416, 2.0260869565217, 0.80217391304348, 0
27417, 2.004347826087, 0.77608695652174, 0
27418, 2.0695652173913, 0.80217391304348, 0
27419, 2.0478260869565, 0.77608695652174, 0
27420, 2.1130434782609, 0.80217391304348, 0
27421, 2.0913043478261, 0.77608695652174, 0
27422, 2.1565217391304, 0.80217391304348, 0
27423, 2.1347826086957, 0.77608695652174, 0
27424, 2.1782608695652, 0.77608695652174, 0
27425, 1.2434782608696, 0.75, 0
27426, 1.2217391304348, 0.72391304347826, 0
27427, 1.2869565217391, 0.75, 0
27428, 1.2652173913043, 0.72391304347826, 0
27429, 1.3304347826087, 0.75, 0
27430, 1.3086956521739, 0.72391304347826, 0
27431, 1.3739130434783, 0.75, 0
27432, 1.3521739130435, 0.72391304347826, 0
27433, 1.4173913043478, 0.75, 0
27434, 1.395652173913, 0.72391304347826, 0
27435, 1.4608695652174, 0.75, 0
27436, 1.4391304347826, 0.72391304347826, 0
27437, 1.504347826087, 0.75, 0
27438, 1.4826086956522, 0.72391304347826, 0
27439, 1.5478260869565, 0.75, 0
27440, 1.5260869565217, 0.72391304347826, 0
27441, 1.5913043478261, 0.75, 0
27442, 1.5695652173913, 0.72391304347826, 0
27443, 1.6347826086957, 0.75, 0
27444, 1.6130434782609, 0.72391304347826, 0
27445, 1.6782608695652, 0.75, 0
27446, 1.6565217391304, 0.72391304347826, 0
27447, 1.7217391304348, 0.75, 0
27448, 1.7, 0.72391304347826, 0
27449, 1.7652173913043, 0.75, 0
27450, 1.7434782608696, 0.72391304347826, 0
27451, 1.8086956521739, 0.75, 0
27452, 1.7869565217391, 0.72391304347826, 0
27453, 1.8521739130435, 0.75, 0
27454, 1.8304347826087, 0.72391304347826, 0
27455, 1.895652173913, 0.75, 0
27456, 1.8739130434783, 0.72391304347826, 0
27457, 1.9391304347826, 0.75, 0
27458, 1.9173913043478, 0.72391304347826, 0
27459, 1.9826086956522, 0.75, 0
27460, 1.9608695652174, 0.72391304347826, 0
27461, 2.0260869565217, 0.75, 0
27462, 2.004347826087, 0.72391304347826, 0
27463, 2.0695652173913, 0.75, 0
27464, 2.0478260869565, 0.72391304347826, 0
27465, 2.1130434782609, 0.75, 0
27466, 2.0913043478261, 0.72391304347826, 0
27467, 2.1565217391304, 0.75, 0
27468, 2.1347826086957, 0.72391304347826, 0
27469, 2.1782608695652, 0.72391304347826, 0
27470, 1.2434782608696, 0.69782608695652, 0
27471, 1.2217391304348, 0.67173913043478, 0
27472, 1.2869565217391, 0.69782608695652, 0
27473, 1.2652173913043, 0.67173913043478, 0
27474, 1.3304347826087, 0.69782608695652, 0
27475, 1.3086956521739, 0.67173913043478, 0
27476, 1.3739130434783, 0.69782608695652, 0
27477, 1.3521739130435, 0.67173913043478, 0
27478, 1.4173913043478, 0.69782608695652, 0
27479, 1.395652173913, 0.67173913043478, 0
27480, 1.4608695652174, 0.69782608695652, 0
27481, 1.4391304347826, 0.67173913043478, 0
27482, 1.504347826087, 0.69782608695652, 0
27483, 1.4826086956522, 0.67173913043478, 0
27484, 1.5478260869565, 0.69782608695652, 0
27485, 1.5260869565217, 0.67173913043478, 0
27486, 1.5913043478261, 0.69782608695652, 0
27487, 1.5695652173913, 0.67173913043478, 0
27488, 1.6347826086957, 0.69782608695652, 0
27489, 1.6130434782609, 0.67173913043478, 0
27490, 1.6782608695652, 0.69782608695652, 0
27491, 1.6565217391304, 0.67173913043478, 0
27492, 1.7217391304348, 0.69782608695652, 0
27493, 1.7, 0.67173913043478, 0
27494, 1.7652173913043, 0.69782608695652, 0
27495, 1.7434782608696, 0.67173913043478, 0
27496, 1.8086956521739, 0.69782608695652, 0
27497, 1.7869565217391, 0.67173913043478, 0
27498, 1.8521739130435, 0.69782608695652, 0
27499, 1.8304347826087, 0.67173913043478, 0
27500, 1.895652173913, 0.69782608695652, 0
27501, 1.8739130434783, 0.67173913043478, 0
27502, 1.9391304347826, 0.69782608695652, 0
27503, 1.9173913043478, 0.67173913043478, 0
27504, 1.9826086956522, 0.69782608695652, 0
27505, 1.9608695652174, 0.67173913043478, 0
27506, 2.0260869565217, 0.69782608695652, 0
27507, 2.004347826087, 0.67173913043478, 0
27508, 2.0695652173913, 0.69782608695652, 0
27509, 2.0478260869565, 0.67173913043478, 0
27510, 2.1130434782609, 0.69782608695652, 0
27511, 2.0913043478261, 0.67173913043478, 0
27512, 2.1565217391304, 0.69782608695652, 0
27513, 2.1347826086957, 0.67173913043478, 0
27514, 2.1782608695652, 0.67173913043478, 0
27515, 1.2434782608696, 0.64565217391304, 0
27516, 1.2217391304348, 0.61956521739131, 0
27517, 1.2869565217391, 0.64565217391304, 0
27518, 1.2652173913043, 0.61956521739131, 0
27519, 1.3304347826087, 0.64565217391304, 0
27520, 1.3086956521739, 0.61956521739131, 0
27521, 1.3739130434783, 0.64565217391304, 0
27522, 1.3521739130435, 0.61956521739131, 0
27523, 1.4173913043478, 0.64565217391304, 0
27524, 1.395652173913, 0.61956521739131, 0
27525, 1.4608695652174, 0.64565217391304, 0
27526, 1.4391304347826, 0.61956521739131, 0
27527, 1.504347826087, 0.64565217391304, 0
27528, 1.4826086956522, 0.61956521739131, 0
27529, 1.5478260869565, 0.64565217391304, 0
27530, 1.5260869565217, 0.61956521739131, 0
27531, 1.5913043478261, 0.64565217391304, 0
27532, 1.5695652173913, 0.61956521739131, 0
27533, 1.6347826086957, 0.64565217391304, 0
27534, 1.6130434782609, 0.61956521739131, 0
27535, 1.6782608695652, 0.64565217391304, 0
27536, 1.6565217391304, 0.61956521739131, 0
27537, 1.7217391304348, 0.64565217391304, 0
27538, 1.7, 0.61956521739131, 0
27539, 1.7652173913043, 0.64565217391304, 0
27540, 1.7434782608696, 0.61956521739131, 0
27541, 1.8086956521739, 0.64565217391304, 0
27542, 1.7869565217391, 0.61956521739131, 0
27543, 1.8521739130435, 0.64565217391304, 0
27544, 1.8304347826087, 0.61956521739131, 0
27545, 1.895652173913, 0.64565217391304, 0
27546, 1.8739130434783, 0.61956521739131, 0
27547, 1.9391304347826, 0.64565217391304, 0
27548, 1.9173913043478, 0.61956521739131, 0
27549, 1.9826086956522, 0.64565217391304, 0
27550, 1.9608695652174, 0.61956521739131, 0
27551, 2.0260869565217, 0.64565217391304, 0
27552, 2.004347826087, 0.61956521739131, 0
27553, 2.0695652173913, 0.64565217391304, 0
27554, 2.0478260869565, 0.61956521739131, 0
27555, 2.1130434782609, 0.64565217391304, 0
27556, 2.0913043478261, 0.61956521739131, 0
27557, 2.1565217391304, 0.64565217391304, 0
27558, 2.1347826086957, 0.61956521739131, 0
27559, 2.1782608695652, 0.61956521739131, 0
27560, 1.2434782608696, 0.59347826086957, 0
27561, 1.2217391304348, 0.56739130434783, 0
27562, 1.2869565217391, 0.59347826086957, 0
27563, 1.2652173913043, 0.56739130434783, 0
27564, 1.3304347826087, 0.59347826086957, 0
27565, 1.3086956521739, 0.56739130434783, 0
27566, 1.3739130434783, 0.59347826086957, 0
27567, 1.3521739130435, 0.56739130434783, 0
27568, 1.4173913043478, 0.59347826086957, 0
27569, 1.395652173913, 0.56739130434783, 0
27570, 1.4608695652174, 0.59347826086957, 0
27571, 1.4391304347826, 0.56739130434783, 0
27572, 1.504347826087, 0.59347826086957, 0
27573, 1.4826086956522, 0.56739130434783, 0
27574, 1.5478260869565, 0.59347826086957, 0
27575, 1.5260869565217, 0.56739130434783, 0
27576, 1.5913043478261, 0.59347826086957, 0
27577, 1.5695652173913, 0.56739130434783, 0
27578, 1.6347826086957, 0.59347826086957, 0
27579, 1.6130434782609, 0.56739130434783, 0
27580, 1.6782608695652, 0.59347826086957, 0
27581, 1.6565217391304, 0.56739130434783, 0
27582, 1.7217391304348, 0.59347826086957, 0
27583, 1.7, 0.56739130434783, 0
27584, 1.7652173913043, 0.59347826086957, 0
27585, 1.7434782608696, 0.56739130434783, 0
27586, 1.8086956521739, 0.59347826086957, 0
27587, 1.7869565217391, 0.56739130434783, 0
27588, 1.8521739130435, 0.59347826086957, 0
27589, 1.8304347826087, 0.56739130434783, 0
27590, 1.895652173913, 0.59347826086957, 0
27591, 1.8739130434783, 0.56739130434783, 0
27592, 1.9391304347826, 0.59347826086957, 0
27593, 1.9173913043478, 0.56739130434783, 0
27594, 1.9826086956522, 0.59347826086957, 0
27595, 1.9608695652174, 0.56739130434783, 0
27596, 2.0260869565217, 0.59347826086957, 0
27597, 2.004347826087, 0.56739130434783, 0
27598, 2.0695652173913, 0.59347826086957, 0
27599, 2.0478260869565, 0.56739130434783, 0
27600, 2.1130434782609, 0.59347826086957, 0
27601, 2.0913043478261, 0.56739130434783, 0
27602, 2.1565217391304, 0.59347826086957, 0
27603, 2.1347826086957, 0.56739130434783, 0
27604, 2.1782608695652, 0.56739130434783, 0
27605, 1.2434782608696, 0.54130434782609, 0
27606, 1.2217391304348, 0.51521739130435, 0
27607, 1.2869565217391, 0.54130434782609, 0
27608, 1.2652173913043, 0.51521739130435, 0
27609, 1.3304347826087, 0.54130434782609, 0
27610, 1.3086956521739, 0.51521739130435, 0
27611, 1.3739130434783, 0.54130434782609, 0
27612, 1.3521739130435, 0.51521739130435, 0
27613, 1.4173913043478, 0.54130434782609, 0
27614, 1.395652173913, 0.51521739130435, 0
27615, 1.4608695652174, 0.54130434782609, 0
27616, 1.4391304347826, 0.51521739130435, 0
27617, 1.504347826087, 0.54130434782609, 0
27618, 1.4826086956522, 0.51521739130435, 0
27619, 1.5478260869565, 0.54130434782609, 0
27620, 1.5260869565217, 0.51521739130435, 0
27621, 1.5913043478261, 0.54130434782609, 0
27622, 1.5695652173913, 0.51521739130435, 0
27623, 1.6347826086957, 0.54130434782609, 0
27624, 1.6130434782609, 0.51521739130435, 0
27625, 1.6782608695652, 0.54130434782609, 0
27626, 1.6565217391304, 0.51521739130435, 0
27627, 1.7217391304348, 0.54130434782609, 0
27628, 1.7, 0.51521739130435, 0
27629, 1.7652173913043, 0.54130434782609, 0
27630, 1.7434782608696, 0.51521739130435, 0
27631, 1.8086956521739, 0.54130434782609, 0
27632, 1.7869565217391, 0.51521739130435, 0
27633, 1.8521739130435, 0.54130434782609, 0
27634, 1.8304347826087, 0.51521739130435, 0
27635, 1.895652173913, 0.54130434782609, 0
27636, 1.8739130434783, 0.51521739130435, 0
27637, 1.9391304347826, 0.54130434782609, 0
27638, 1.9173913043478, 0.51521739130435, 0
27639, 1.9826086956522, 0.54130434782609, 0
27640, 1.9608695652174, 0.51521739130435, 0
27641, 2.0260869565217, 0.54130434782609, 0
27642, 2.004347826087, 0.51521739130435, 0
27643, 2.0695652173913, 0.54130434782609, 0
27644, 2.0478260869565, 0.51521739130435, 0
27645, 2.1130434782609, 0.54130434782609, 0
27646, 2.0913043478261, 0.51521739130435, 0
27647, 2.1565217391304, 0.54130434782609, 0
27648, 2.1347826086957, 0.51521739130435, 0
27649, 2.1782608695652, 0.51521739130435, 0
27650, 1.2434782608696, 0.48913043478261, 0
27651, 1.2217391304348, 0.46304347826087, 0
27652, 1.2869565217391, 0.48913043478261, 0
27653, 1.2652173913043, 0.46304347826087, 0
27654, 1.3304347826087, 0.48913043478261, 0
27655, 1.3086956521739, 0.46304347826087, 0
27656, 1.3739130434783, 0.48913043478261, 0
27657, 1.3521739130435, 0.46304347826087, 0
27658, 1.4173913043478, 0.48913043478261, 0
27659, 1.395652173913, 0.46304347826087, 0
27660, 1.4608695652174, 0.48913043478261, 0
27661, 1.4391304347826, 0.46304347826087, 0
27662, 1.504347826087, 0.48913043478261, 0
27663, 1.4826086956522, 0.46304347826087, 0
27664, 1.5478260869565, 0.48913043478261, 0
27665, 1.5260869565217, 0.46304347826087, 0
27666, 1.5913043478261, 0.48913043478261, 0
27667, 1.5695652173913, 0.46304347826087, 0
27668, 1.6347826086957, 0.48913043478261, 0
27669, 1.6130434782609, 0.46304347826087, 0
27670, 1.6782608695652, 0.48913043478261, 0
27671, 1.6565217391304, 0.46304347826087, 0
27672, 1.7217391304348, 0.48913043478261, 0
27673, 1.7, 0.46304347826087, 0
27674, 1.7652173913043, 0.48913043478261, 0
27675, 1.7434782608696, 0.46304347826087, 0
27676, 1.8086956521739, 0.48913043478261, 0
27677, 1.7869565217391, 0.46304347826087, 0
27678, 1.8521739130435, 0.48913043478261, 0
27679, 1.8304347826087, 0.46304347826087, 0
27680, 1.895652173913, 0.48913043478261, 0
27681, 1.8739130434783, 0.46304347826087, 0
27682, 1.9391304347826, 0.48913043478261, 0
27683, 1.9173913043478, 0.46304347826087, 0
27684, 1.9826086956522, 0.48913043478261, 0
27685, 1.9608695652174, 0.46304347826087, 0
27686, 2.0260869565217, 0.48913043478261, 0
27687, 2.004347826087, 0.46304347826087, 0
27688, 2.0695652173913, 0.48913043478261, 0
27689, 2.0478260869565, 0.46304347826087, 0
27690, 2.1130434782609, 0.48913043478261, 0
27691, 2.0913043478261, 0.46304347826087, 0
27692, 2.1565217391304, 0.48913043478261, 0
27693, 2.1347826086957, 0.46304347826087, 0
27694, 2.1782608695652, 0.46304347826087, 0
27695, 1.2434782608696, 0.43695652173913, 0
27696, 1.2217391304348, 0.41086956521739, 0
27697, 1.2869565217391, 0.43695652173913, 0
27698, 1.2652173913043, 0.41086956521739, 0
27699, 1.3304347826087, 0.43695652173913, 0
27700, 1.3086956521739, 0.41086956521739, 0
27701, 1.3739130434783, 0.43695652173913, 0
27702, 1.3521739130435, 0.41086956521739, 0
27703, 1.4173913043478, 0.43695652173913, 0
27704, 1.395652173913, 0.41086956521739, 0
27705, 1.4608695652174, 0.43695652173913, 0
27706, 1.4391304347826, 0.41086956521739, 0
27707, 1.504347826087, 0.43695652173913, 0
27708, 1.4826086956522, 0.41086956521739, 0
27709, 1.5478260869565, 0.43695652173913, 0
27710, 1.5260869565217, 0.41086956521739, 0
27711, 1.5913043478261, 0.43695652173913, 0
27712, 1.5695652173913, 0.41086956521739, 0
27713, 1.6347826086957, 0.43695652173913, 0
27714, 1.6130434782609, 0.41086956521739, 0
27715, 1.6782608695652, 0.43695652173913, 0
27716, 1.6565217391304, 0.41086956521739, 0
27717, 1.7217391304348, 0.43695652173913, 0
27718, 1.7, 0.41086956521739, 0
27719, 1.7652173913043, 0.43695652173913, 0
27720, 1.7434782608696, 0.41086956521739, 0
27721, 1.8086956521739, 0.43695652173913, 0
27722, 1.7869565217391, 0.41086956521739, 0
27723, 1.8521739130435, 0.43695652173913, 0
27724, 1.8304347826087, 0.41086956521739, 0
27725, 1.895652173913, 0.43695652173913, 0
27726, 1.8739130434783, 0.41086956521739, 0
27727, 1.9391304347826, 0.43695652173913, 0
27728, 1.9173913043478, 0.41086956521739, 0
27729, 1.9826086956522, 0.43695652173913, 0
27730, 1.9608695652174, 0.41086956521739, 0
27731, 2.0260869565217, 0.43695652173913, 0
27732, 2.004347826087, 0.41086956521739, 0
27733, 2.0695652173913, 0.43695652173913, 0
27734, 2.0478260869565, 0.41086956521739, 0
27735, 2.1130434782609, 0.43695652173913, 0
27736, 2.0913043478261, 0.41086956521739, 0
27737, 2.1565217391304, 0.43695652173913, 0
27738, 2.1347826086957, 0.41086956521739, 0
27739, 2.1782608695652, 0.41086956521739, 0
27740, 1.2434782608696, 0.38478260869565, 0
27741, 1.2217391304348, 0.35869565217391, 0
27742, 1.2869565217391, 0.38478260869565, 0
27743, 1.2652173913043, 0.35869565217391, 0
27744, 1.3304347826087, 0.38478260869565, 0
27745, 1.3086956521739, 0.35869565217391, 0
27746, 1.3739130434783, 0.38478260869565, 0
27747, 1.3521739130435, 0.35869565217391, 0
27748, 1.4173913043478, 0.38478260869565, 0
27749, 1.395652173913, 0.35869565217391, 0
27750, 1.4608695652174, 0.38478260869565, 0
27751, 1.4391304347826, 0.35869565217391, 0
27752, 1.504347826087, 0.38478260869565, 0
27753, 1.4826086956522, 0.35869565217391, 0
27754, 1.5478260869565, 0.38478260869565, 0
27755, 1.5260869565217, 0.35869565217391, 0
27756, 1.5913043478261, 0.38478260869565, 0
27757, 1.5695652173913, 0.35869565217391, 0
27758, 1.6347826086957, 0.38478260869565, 0
27759, 1.6130434782609, 0.35869565217391, 0
27760, 1.6782608695652, 0.38478260869565, 0
27761, 1.6565217391304, 0.35869565217391, 0
27762, 1.7217391304348, 0.38478260869565, 0
27763, 1.7, 0.35869565217391, 0
27764, 1.7652173913043, 0.38478260869565, 0
27765, 1.7434782608696, 0.35869565217391, 0
27766, 1.8086956521739, 0.38478260869565, 0
27767, 1.7869565217391, 0.35869565217391, 0
27768, 1.8521739130435, 0.38478260869565, 0
27769, 1.8304347826087, 0.35869565217391, 0
27770, 1.895652173913, 0.38478260869565, 0
27771, 1.8739130434783, 0.35869565217391, 0
27772, 1.9391304347826, 0.38478260869565, 0
27773, 1.9173913043478, 0.35869565217391, 0
27774, 1.9826086956522, 0.38478260869565, 0
27775, 1.9608695652174, 0.35869565217391, 0
27776, 2.0260869565217, 0.38478260869565, 0
27777, 2.004347826087, 0.35869565217391, 0
27778, 2.0695652173913, 0.38478260869565, 0
27779, 2.0478260869565, 0.35869565217391, 0
27780, 2.1130434782609, 0.38478260869565, 0
27781, 2.0913043478261, 0.35869565217391, 0
27782, 2.1565217391304, 0.38478260869565, 0
27783, 2.1347826086957, 0.35869565217391, 0
27784, 2.1782608695652, 0.35869565217391, 0
27785, 1.2434782608696, 0.33260869565217, 0
27786, 1.2217391304348, 0.30652173913044, 0
27787, 1.2869565217391, 0.33260869565217, 0
27788, 1.2652173913043, 0.30652173913044, 0
27789, 1.3304347826087, 0.33260869565217, 0
27790, 1.3086956521739, 0.30652173913043, 0
27791, 1.3739130434783, 0.33260869565217, 0
27792, 1.3521739130435, 0.30652173913044, 0
27793, 1.4173913043478, 0.33260869565217, 0
27794, 1.395652173913, 0.30652173913044, 0
27795, 1.4608695652174, 0.33260869565217, 0
27796, 1.4391304347826, 0.30652173913044, 0
27797, 1.504347826087, 0.33260869565217, 0
27798, 1.4826086956522, 0.30652173913044, 0
27799, 1.5478260869565, 0.33260869565217, 0
27800, 1.5260869565217, 0.30652173913044, 0
27801, 1.5913043478261, 0.33260869565217, 0
27802, 1.5695652173913, 0.30652173913044, 0
27803, 1.6347826086957, 0.33260869565217, 0
27804, 1.6130434782609, 0.30652173913044, 0
27805, 1.6782608695652, 0.33260869565217, 0
27806, 1.6565217391304, 0.30652173913043, 0
27807, 1.7217391304348, 0.33260869565217, 0
27808, 1.7, 0.30652173913043, 0
27809, 1.7652173913043, 0.33260869565217, 0
27810, 1.7434782608696, 0.30652173913043, 0
27811, 1.8086956521739, 0.33260869565217, 0
27812, 1.7869565217391, 0.30652173913044, 0
27813, 1.8521739130435, 0.33260869565217, 0
27814, 1.8304347826087, 0.30652173913044, 0
27815, 1.895652173913, 0.33260869565217, 0
27816, 1.8739130434783, 0.30652173913043, 0
27817, 1.9391304347826, 0.33260869565217, 0
27818, 1.9173913043478, 0.30652173913044, 0
27819, 1.9826086956522, 0.33260869565217, 0
27820, 1.9608695652174, 0.30652173913044, 0
27821, 2.0260869565217, 0.33260869565217, 0
27822, 2.004347826087, 0.30652173913044, 0
27823, 2.0695652173913, 0.33260869565217, 0
27824, 2.0478260869565, 0.30652173913044, 0
27825, 2.1130434782609, 0.33260869565217, 0
27826, 2.0913043478261, 0.30652173913043, 0
27827, 2.1565217391304, 0.33260869565217, 0
27828, 2.1347826086957, 0.30652173913043, 0
27829, 2.1782608695652, 0.30652173913044, 0
27830, 1.2434782608696, 0.2804347826087, 0
27831, 1.2217391304348, 0.25434782608696, 0
27832, 1.2869565217391, 0.2804347826087, 0
27833, 1.2652173913043, 0.25434782608696, 0
27834, 1.3304347826087, 0.2804347826087, 0
27835, 1.3086956521739, 0.25434782608696, 0
27836, 1.3739130434783, 0.2804347826087, 0
27837, 1.3521739130435, 0.25434782608696, 0
27838, 1.4173913043478, 0.2804347826087, 0
27839, 1.395652173913, 0.25434782608696, 0
27840, 1.4608695652174, 0.2804347826087, 0
27841, 1.4391304347826, 0.25434782608696, 0
27842, 1.504347826087, 0.2804347826087, 0
27843, 1.4826086956522, 0.25434782608696, 0
27844, 1.5478260869565, 0.2804347826087, 0
27845, 1.5260869565217, 0.25434782608696, 0
27846, 1.5913043478261, 0.2804347826087, 0
27847, 1.5695652173913, 0.25434782608696, 0
27848, 1.6347826086957, 0.2804347826087, 0
27849, 1.6130434782609, 0.25434782608696, 0
27850, 1.6782608695652, 0.2804347826087, 0
27851, 1.6565217391304, 0.25434782608696, 0
27852, 1.7217391304348, 0.2804347826087, 0
27853, 1.7, 0.25434782608696, 0
27854, 1.7652173913043, 0.2804347826087, 0
27855, 1.7434782608696, 0.25434782608696, 0
27856, 1.8086956521739, 0.2804347826087, 0
27857, 1.7869565217391, 0.25434782608696, 0
27858, 1.8521739130435, 0.2804347826087, 0
27859, 1.8304347826087, 0.25434782608696, 0
27860, 1.895652173913, 0.2804347826087, 0
27861, 1.8739130434783, 0.25434782608696, 0
27862, 1.9391304347826, 0.2804347826087, 0
27863, 1.9173913043478, 0.25434782608696, 0
27864, 1.9826086956522, 0.2804347826087, 0
27865, 1.9608695652174, 0.25434782608696, 0
27866, 2.0260869565217, 0.2804347826087, 0
27867, 2.004347826087, 0.25434782608696, 0
27868, 2.0695652173913, 0.2804347826087, 0
27869, 2.0478260869565, 0.25434782608696, 0
27870, 2.1130434782609, 0.2804347826087, 0
27871, 2.0913043478261, 0.25434782608696, 0
27872, 2.1565217391304, 0.2804347826087, 0
27873, 2.1347826086957, 0.25434782608696, 0
27874, 2.1782608695652, 0.25434782608696, 0
27875, 1.2434782608696, 0.22826086956522, 0
27876, 1.2217391304348, 0.20217391304348, 0
27877, 1.2869565217391, 0.22826086956522, 0
27878, 1.2652173913043, 0.20217391304348, 0
27879, 1.3304347826087, 0.22826086956522, 0
27880, 1.3086956521739, 0.20217391304348, 0
27881, 1.3739130434783, 0.22826086956522, 0
27882, 1.3521739130435, 0.20217391304348, 0
27883, 1.4173913043478, 0.22826086956522, 0
27884, 1.395652173913, 0.20217391304348, 0
27885, 1.4608695652174, 0.22826086956522, 0
27886, 1.4391304347826, 0.20217391304348, 0
27887, 1.504347826087, 0.22826086956522, 0
27888, 1.4826086956522, 0.20217391304348, 0
27889, 1.5478260869565, 0.22826086956522, 0
27890, 1.5260869565217, 0.20217391304348, 0
27891, 1.5913043478261, 0.22826086956522, 0
27892, 1.5695652173913, 0.20217391304348, 0
27893, 1.6347826086957, 0.22826086956522, 0
27894, 1.6130434782609, 0.20217391304348, 0
27895, 1.6782608695652, 0.22826086956522, 0
27896, 1.6565217391304, 0.20217391304348, 0
27897, 1.7217391304348, 0.22826086956522, 0
27898, 1.7, 0.20217391304348, 0
27899, 1.7652173913043, 0.22826086956522, 0
27900, 1.7434782608696, 0.20217391304348, 0
27901, 1.8086956521739, 0.22826086956522, 0
27902, 1.7869565217391, 0.20217391304348, 0
27903, 1.8521739130435, 0.22826086956522, 0
27904, 1.8304347826087, 0.20217391304348, 0
27905, 1.895652173913, 0.22826086956522, 0
27906, 1.8739130434783, 0.20217391304348, 0
27907, 1.9391304347826, 0.22826086956522, 0
27908, 1.9173913043478, 0.20217391304348, 0
27909, 1.9826086956522, 0.22826086956522, 0
27910, 1.9608695652174, 0.20217391304348, 0
27911, 2.0260869565217, 0.22826086956522, 0
27912, 2.004347826087, 0.20217391304348, 0
27913, 2.0695652173913, 0.22826086956522, 0
27914, 2.0478260869565, 0.20217391304348, 0
27915, 2.1130434782609, 0.22826086956522, 0
27916, 2.0913043478261, 0.20217391304348, 0
27917, 2.1565217391304, 0.22826086956522, 0
27918, 2.1347826086957, 0.20217391304348, 0
27919, 2.1782608695652, 0.20217391304348, 0
27920, 1.2434782608696, 0.17608695652174, 0
27921, 1.2869565217391, 0.17608695652174, 0
27922, 1.3304347826087, 0.17608695652174, 0
27923, 1.3739130434783, 0.17608695652174, 0
27924, 1.4173913043478, 0.17608695652174, 0
27925, 1.4608695652174, 0.17608695652174, 0
27926, 1.504347826087, 0.17608695652174, 0
27927, 1.5478260869565, 0.17608695652174, 0
27928, 1.5913043478261, 0.17608695652174, 0
27929, 1.6347826086957, 0.17608695652174, 0
27930, 1.6782608695652, 0.17608695652174, 0
27931, 1.7217391304348, 0.17608695652174, 0
27932, 1.7652173913043, 0.17608695652174, 0
27933, 1.8086956521739, 0.17608695652174, 0
27934, 1.8521739130435, 0.17608695652174, 0
27935, 1.895652173913, 0.17608695652174, 0
27936, 1.9391304347826, 0.17608695652174, 0
27937, 1.9826086956522, 0.17608695652174, 0
27938, 2.0260869565217, 0.17608695652174, 0
27939, 2.0695652173913, 0.17608695652174, 0
27940, 2.1130434782609, 0.17608695652174, 0
27941, 2.1565217391304, 0.17608695652174, 0
27942, 1.2, 1.2978260869565, 0.44444444444444
27943, 1.2, 1.2978260869565, 0.38888888888889
27944, 1.2, 1.2978260869565, 0.33333333333333
27945, 1.2, 1.2978260869565, 0.27777777777778
27946, 1.2, 1.2978260869565, 0.22222222222222
27947, 1.2, 1.2978260869565, 0.16666666666667
27948, 1.2, 1.2978260869565, 0.11111111111111
27949, 1.2, 1.2978260869565, 0.055555555555556
27950, 1.2, 1.245652173913, 0.44444444444444
27951, 1.2, 1.245652173913, 0.38888888888889
27952, 1.2, 1.245652173913, 0.33333333333333
27953, 1.2, 1.245652173913, 0.27777777777778
27954, 1.2, 1.245652173913, 0.22222222222222
27955, 1.2, 1.245652173913, 0.16666666666667
27956, 1.2, 1.245652173913, 0.11111111111111
27957, 1.2, 1.245652173913, 0.055555555555556
27958, 1.2, 1.1934782608696, 0.44444444444444
27959, 1.2, 1.1934782608696, 0.38888888888889
27960, 1.2, 1.1934782608696, 0.33333333333333
27961, 1.2, 1.1934782608696, 0.27777777777778
27962, 1.2, 1.1934782608696, 0.22222222222222
27963, 1.2, 1.1934782608696, 0.16666666666667
27964, 1.2, 1.1934782608696, 0.11111111111111
27965, 1.2, 1.1934782608696, 0.055555555555556
27966, 1.2, 1.1413043478261, 0.44444444444444
27967, 1.2, 1.1413043478261, 0.38888888888889
27968, 1.2, 1.1413043478261, 0.33333333333333
27969, 1.2, 1.1413043478261, 0.27777777777778
27970, 1.2, 1.1413043478261, 0.22222222222222
27971, 1.2, 1.1413043478261, 0.16666666666667
27972, 1.2, 1.1413043478261, 0.11111111111111
27973, 1.2, 1.1413043478261, 0.055555555555556
27974, 1.2, 1.0891304347826, 0.44444444444444
27975, 1.2, 1.0891304347826, 0.38888888888889
27976, 1.2, 1.0891304347826, 0.33333333333333
27977, 1.2, 1.0891304347826, 0.27777777777778
27978, 1.2, 1.0891304347826, 0.22222222222222
27979, 1.2, 1.0891304347826, 0.16666666666667
27980, 1.2, 1.0891304347826, 0.11111111111111
27981, 1.2, 1.0891304347826, 0.055555555555556
27982, 1.2, 1.0369565217391, 0.44444444444444
27983, 1.2, 1.0369565217391, 0.38888888888889
27984, 1.2, 1.0369565217391, 0.33333333333333
27985, 1.2, 1.0369565217391, 0.27777777777778
27986, 1.2, 1.0369565217391, 0.22222222222222
27987, 1.2, 1.0369565217391, 0.16666666666667
27988, 1.2, 1.0369565217391, 0.11111111111111
27989, 1.2, 1.0369565217391, 0.055555555555556
27990, 1.2, 0.98478260869565, 0.44444444444444
27991, 1.2, 0.98478260869565, 0.38888888888889
27992, 1.2, 0.98478260869565, 0.33333333333333
27993, 1.2, 0.98478260869565, 0.27777777777778
27994, 1.2, 0.98478260869565, 0.22222222222222
27995, 1.2, 0.98478260869565, 0.16666666666667
27996, 1.2, 0.98478260869565, 0.11111111111111
27997, 1.2, 0.98478260869565, 0.055555555555556
27998, 1.2, 0.93260869565217, 0.44444444444444
27999, 1.2, 0.93260869565217, 0.38888888888889
28000, 1.2, 0.93260869565217, 0.33333333333333
28001, 1.2, 0.93260869565217, 0.27777777777778
28002, 1.2, 0.93260869565217, 0.22222222222222
28003, 1.2, 0.93260869565217, 0.16666666666667
28004, 1.2, 0.93260869565217, 0.11111111111111
28005, 1.2, 0.93260869565217, 0.055555555555556
28006, 1.2, 0.8804347826087, 0.44444444444444
28007, 1.2, 0.8804347826087, 0.38888888888889
28008, 1.2, 0.8804347826087, 0.33333333333333
28009, 1.2, 0.8804347826087, 0.27777777777778
28010, 1.2, 0.8804347826087, 0.22222222222222
28011, 1.2, 0.8804347826087, 0.16666666666667
28012, 1.2, 0.8804347826087, 0.11111111111111
28013, 1.2, 0.8804347826087, 0.055555555555556
28014, 1.2, 0.82826086956522, 0.44444444444444
28015, 1.2, 0.82826086956522, 0.38888888888889
28016, 1.2, 0.82826086956522, 0.33333333333333
28017, 1.2, 0.82826086956522, 0.27777777777778
28018, 1.2, 0.82826086956522, 0.22222222222222
28019, 1.2, 0.82826086956522, 0.16666666666667
28020, 1.2, 0.82826086956522, 0.11111111111111
28021, 1.2, 0.82826086956522, 0.055555555555556
28022, 1.2, 0.77608695652174, 0.44444444444444
28023, 1.2, 0.77608695652174, 0.38888888888889
28024, 1.2, 0.77608695652174, 0.33333333333333
28025, 1.2, 0.77608695652174, 0.27777777777778
28026, 1.2, 0.77608695652174, 0.22222222222222
28027, 1.2, 0.77608695652174, 0.16666666666667
28028, 1.2, 0.77608695652174, 0.11111111111111
28029, 1.2, 0.77608695652174, 0.055555555555556
28030, 1.2, 0.72391304347826, 0.44444444444444
28031, 1.2, 0.72391304347826, 0.38888888888889
28032, 1.2, 0.72391304347826, 0.33333333333333
28033, 1.2, 0.72391304347826, 0.27777777777778
28034, 1.2, 0.72391304347826, 0.22222222222222
28035, 1.2, 0.72391304347826, 0.16666666666667
28036, 1.2, 0.72391304347826, 0.11111111111111
28037, 1.2, 0.72391304347826, 0.055555555555556
28038, 1.2, 0.67173913043478, 0.44444444444444
28039, 1.2, 0.67173913043478, 0.38888888888889
28040, 1.2, 0.67173913043478, 0.33333333333333
28041, 1.2, 0.67173913043478, 0.27777777777778
28042, 1.2, 0.67173913043478, 0.22222222222222
28043, 1.2, 0.67173913043478, 0.16666666666667
28044, 1.2, 0.67173913043478, 0.11111111111111
28045, 1.2, 0.67173913043478, 0.055555555555556
28046, 1.2, 0.61956521739131, 0.44444444444444
28047, 1.2, 0.61956521739131, 0.38888888888889
28048, 1.2, 0.61956521739131, 0.33333333333333
28049, 1.2, 0.61956521739131, 0.27777777777778
28050, 1.2, 0.61956521739131, 0.22222222222222
28051, 1.2, 0.61956521739131, 0.16666666666667
28052, 1.2, 0.61956521739131, 0.11111111111111
28053, 1.2, 0.61956521739131, 0.055555555555556
28054, 1.2, 0.56739130434783, 0.44444444444444
28055, 1.2, 0.56739130434783, 0.38888888888889
28056, 1.2, 0.56739130434783, 0.33333333333333
28057, 1.2, 0.56739130434783, 0.27777777777778
28058, 1.2, 0.56739130434783, 0.22222222222222
28059, 1.2, 0.56739130434783, 0.16666666666667
28060, 1.2, 0.56739130434783, 0.11111111111111
28061, 1.2, 0.56739130434783, 0.055555555555556
28062, 1.2, 0.51521739130435, 0.44444444444444
28063, 1.2, 0.51521739130435, 0.38888888888889
28064, 1.2, 0.51521739130435, 0.33333333333333
28065, 1.2, 0.51521739130435, 0.27777777777778
28066, 1.2, 0.51521739130435, 0.22222222222222
28067, 1.2, 0.51521739130435, 0.16666666666667
28068, 1.2, 0.51521739130435, 0.11111111111111
28069, 1.2, 0.51521739130435, 0.055555555555556
28070, 1.2, 0.46304347826087, 0.44444444444444
28071, 1.2, 0.46304347826087, 0.38888888888889
28072, 1.2, 0.46304347826087, 0.33333333333333
28073, 1.2, 0.46304347826087, 0.27777777777778
28074, 1.2, 0.46304347826087, 0.22222222222222
28075, 1.2, 0.46304347826087, 0.16666666666667
28076, 1.2, 0.46304347826087, 0.11111111111111
28077, 1.2, 0.46304347826087, 0.055555555555556
28078, 1.2, 0.41086956521739, 0.44444444444444
28079, 1.2, 0.41086956521739, 0.38888888888889
28080, 1.2, 0.41086956521739, 0.33333333333333
28081, 1.2, 0.41086956521739, 0.27777777777778
28082, 1.2, 0.41086956521739, 0.22222222222222
28083, 1.2, 0.41086956521739, 0.16666666666667
28084, 1.2, 0.41086956521739, 0.11111111111111
28085, 1.2, 0.41086956521739, 0.055555555555556
28086, 1.2, 0.35869565217391, 0.44444444444444
28087, 1.2, 0.35869565217391, 0.38888888888889
28088, 1.2, 0.35869565217391, 0.33333333333333
28089, 1.2, 0.35869565217391, 0.27777777777778
28090, 1.2, 0.35869565217391, 0.22222222222222
28091, 1.2, 0.35869565217391, 0.16666666666667
28092, 1.2, 0.35869565217391, 0.11111111111111
28093, 1.2, 0.35869565217391, 0.055555555555556
28094, 1.2, 0.30652173913044, 0.44444444444444
28095, 1.2, 0.30652173913044, 0.38888888888889
28096, 1.2, 0.30652173913044, 0.33333333333333
28097, 1.2, 0.30652173913044, 0.27777777777778
28098, 1.2, 0.30652173913044, 0.22222222222222
28099, 1.2, 0.30652173913044, 0.16666666666667
28100, 1.2, 0.30652173913044, 0.11111111111111
28101, 1.2, 0.30652173913044, 0.055555555555556
28102, 1.2, 0.25434782608696, 0.44444444444444
28103, 1.2, 0.25434782608696, 0.38888888888889
28104, 1.2, 0.25434782608696, 0.33333333333333
28105, 1.2, 0.25434782608696, 0.27777777777778
28106, 1.2, 0.25434782608696, 0.22222222222222
28107, 1.2, 0.25434782608696, 0.16666666666667
28108, 1.2, 0.25434782608696, 0.11111111111111
28109, 1.2, 0.25434782608696, 0.055555555555556
28110, 1.2, 0.20217391304348, 0.44444444444444
28111, 1.2, 0.20217391304348, 0.38888888888889
28112, 1.2, 0.20217391304348, 0.33333333333333
28113, 1.2, 0.20217391304348, 0.27777777777778
28114, 1.2, 0.20217391304348, 0.22222222222222
28115, 1.2, 0.20217391304348, 0.16666666666667
28116, 1.2, 0.20217391304348, 0.11111111111111
28117, 1.2, 0.20217391304348, 0.055555555555556
28118, 1.2, 1.3239130434783, 0.44444444444444
28119, 1.2, 1.2978260869565, 0.47222222222222
28120, 1.2, 1.3239130434783, 0.38888888888889
28121, 1.2, 1.2978260869565, 0.41666666666667
28122, 1.2, 1.3239130434783, 0.33333333333333
28123, 1.2, 1.2978260869565, 0.36111111111111
28124, 1.2, 1.3239130434783, 0.27777777777778
28125, 1.2, 1.2978260869565, 0.30555555555556
28126, 1.2, 1.3239130434783, 0.22222222222222
28127, 1.2, 1.2978260869565, 0.25
28128, 1.2, 1.3239130434783, 0.16666666666667
28129, 1.2, 1.2978260869565, 0.19444444444444
28130, 1.2, 1.3239130434783, 0.11111111111111
28131, 1.2, 1.2978260869565, 0.13888888888889
28132, 1.2, 1.3239130434783, 0.055555555555556
28133, 1.2, 1.2978260869565, 0.083333333333333
28134, 1.2, 1.2978260869565, 0.027777777777778
28135, 1.2, 1.2717391304348, 0.44444444444444
28136, 1.2, 1.245652173913, 0.47222222222222
28137, 1.2, 1.2717391304348, 0.38888888888889
28138, 1.2, 1.245652173913, 0.41666666666667
28139, 1.2, 1.2717391304348, 0.33333333333333
28140, 1.2, 1.245652173913, 0.36111111111111
28141, 1.2, 1.2717391304348, 0.27777777777778
28142, 1.2, 1.245652173913, 0.30555555555556
28143, 1.2, 1.2717391304348, 0.22222222222222
28144, 1.2, 1.245652173913, 0.25
28145, 1.2, 1.2717391304348, 0.16666666666667
28146, 1.2, 1.245652173913, 0.19444444444444
28147, 1.2, 1.2717391304348, 0.11111111111111
28148, 1.2, 1.245652173913, 0.13888888888889
28149, 1.2, 1.2717391304348, 0.055555555555556
28150, 1.2, 1.245652173913, 0.083333333333333
28151, 1.2, 1.245652173913, 0.027777777777778
28152, 1.2, 1.2195652173913, 0.44444444444444
28153, 1.2, 1.1934782608696, 0.47222222222222
28154, 1.2, 1.2195652173913, 0.38888888888889
28155, 1.2, 1.1934782608696, 0.41666666666667
28156, 1.2, 1.2195652173913, 0.33333333333333
28157, 1.2, 1.1934782608696, 0.36111111111111
28158, 1.2, 1.2195652173913, 0.27777777777778
28159, 1.2, 1.1934782608696, 0.30555555555556
28160, 1.2, 1.2195652173913, 0.22222222222222
28161, 1.2, 1.1934782608696, 0.25
28162, 1.2, 1.2195652173913, 0.16666666666667
28163, 1.2, 1.1934782608696, 0.19444444444444
28164, 1.2, 1.2195652173913, 0.11111111111111
28165, 1.2, 1.1934782608696, 0.13888888888889
28166, 1.2, 1.2195652173913, 0.055555555555556
28167, 1.2, 1.1934782608696, 0.083333333333333
28168, 1.2, 1.1934782608696, 0.027777777777778
28169, 1.2, 1.1673913043478, 0.44444444444444
28170, 1.2, 1.1413043478261, 0.47222222222222
28171, 1.2, 1.1673913043478, 0.38888888888889
28172, 1.2, 1.1413043478261, 0.41666666666667
28173, 1.2, 1.1673913043478, 0.33333333333333
28174, 1.2, 1.1413043478261, 0.36111111111111
28175, 1.2, 1.1673913043478, 0.27777777777778
28176, 1.2, 1.1413043478261, 0.30555555555556
28177, 1.2, 1.1673913043478, 0.22222222222222
28178, 1.2, 1.1413043478261, 0.25
28179, 1.2, 1.1673913043478, 0.16666666666667
28180, 1.2, 1.1413043478261, 0.19444444444444
28181, 1.2, 1.1673913043478, 0.11111111111111
28182, 1.2, 1.1413043478261, 0.13888888888889
28183, 1.2, 1.1673913043478, 0.055555555555556
28184, 1.2, 1.1413043478261, 0.083333333333333
28185, 1.2, 1.1413043478261, 0.027777777777778
28186, 1.2, 1.1152173913043, 0.44444444444444
28187, 1.2, 1.0891304347826, 0.47222222222222
28188, 1.2, 1.1152173913043, 0.38888888888889
28189, 1.2, 1.0891304347826, 0.41666666666667
28190, 1.2, 1.1152173913043, 0.33333333333333
28191, 1.2, 1.0891304347826, 0.36111111111111
28192, 1.2, 1.1152173913043, 0.27777777777778
28193, 1.2, 1.0891304347826, 0.30555555555556
28194, 1.2, 1.1152173913043, 0.22222222222222
28195, 1.2, 1.0891304347826, 0.25
28196, 1.2, 1.1152173913043, 0.16666666666667
28197, 1.2, 1.0891304347826, 0.19444444444444
28198, 1.2, 1.1152173913043, 0.11111111111111
28199, 1.2, 1.0891304347826, 0.13888888888889
28200, 1.2, 1.1152173913043, 0.055555555555556
28201, 1.2, 1.0891304347826, 0.083333333333333
28202, 1.2, 1.0891304347826, 0.027777777777778
28203, 1.2, 1.0630434782609, 0.44444444444444
28204, 1.2, 1.0369565217391, 0.47222222222222
28205, 1.2, 1.0630434782609, 0.38888888888889
28206, 1.2, 1.0369565217391, 0.41666666666667
28207, 1.2, 1.0630434782609, 0.33333333333333
28208, 1.2, 1.0369565217391, 0.36111111111111
28209, 1.2, 1.0630434782609, 0.27777777777778
28210, 1.2, 1.0369565217391, 0.30555555555556
28211, 1.2, 1.0630434782609, 0.22222222222222
28212, 1.2, 1.0369565217391, 0.25
28213, 1.2, 1.0630434782609, 0.16666666666667
28214, 1.2, 1.0369565217391, 0.19444444444444
28215, 1.2, 1.0630434782609, 0.11111111111111
28216, 1.2, 1.0369565217391, 0.13888888888889
28217, 1.2, 1.0630434782609, 0.055555555555556
28218, 1.2, 1.0369565217391, 0.083333333333333
28219, 1.2, 1.0369565217391, 0.027777777777778
28220, 1.2, 1.0108695652174, 0.44444444444444
28221, 1.2, 0.98478260869565, 0.47222222222222
28222, 1.2, 1.0108695652174, 0.38888888888889
28223, 1.2, 0.98478260869565, 0.41666666666667
28224, 1.2, 1.0108695652174, 0.33333333333333
28225, 1.2, 0.98478260869565, 0.36111111111111
28226, 1.2, 1.0108695652174, 0.27777777777778
28227, 1.2, 0.98478260869565, 0.30555555555556
28228, 1.2, 1.0108695652174, 0.22222222222222
28229, 1.2, 0.98478260869565, 0.25
28230, 1.2, 1.0108695652174, 0.16666666666667
28231, 1.2, 0.98478260869565, 0.19444444444444
28232, 1.2, 1.0108695652174, 0.11111111111111
28233, 1.2, 0.98478260869565, 0.13888888888889
28234, 1.2, 1.0108695652174, 0.055555555555556
28235, 1.2, 0.98478260869565, 0.083333333333333
28236, 1.2, 0.98478260869565, 0.027777777777778
28237, 1.2, 0.95869565217391, 0.44444444444444
28238, 1.2, 0.93260869565217, 0.47222222222222
28239, 1.2, 0.95869565217391, 0.38888888888889
28240, 1.2, 0.93260869565217, 0.41666666666667
28241, 1.2, 0.95869565217391, 0.33333333333333
28242, 1.2, 0.93260869565217, 0.36111111111111
28243, 1.2, 0.95869565217391, 0.27777777777778
28244, 1.2, 0.93260869565217, 0.30555555555556
28245, 1.2, 0.95869565217391, 0.22222222222222
28246, 1.2, 0.93260869565217, 0.25
28247, 1.2, 0.95869565217391, 0.16666666666667
28248, 1.2, 0.93260869565217, 0.19444444444444
28249, 1.2, 0.95869565217391, 0.11111111111111
28250, 1.2, 0.93260869565217, 0.13888888888889
28251, 1.2, 0.95869565217391, 0.055555555555556
28252, 1.2, 0.93260869565217, 0.083333333333333
28253, 1.2, 0.93260869565217, 0.027777777777778
28254, 1.2, 0.90652173913044, 0.44444444444444
28255, 1.2, 0.8804347826087, 0.47222222222222
28256, 1.2, 0.90652173913044, 0.38888888888889
28257, 1.2, 0.8804347826087, 0.41666666666667
28258, 1.2, 0.90652173913044, 0.33333333333333
28259, 1.2, 0.8804347826087, 0.36111111111111
28260, 1.2, 0.90652173913044, 0.27777777777778
28261, 1.2, 0.8804347826087, 0.30555555555556
28262, 1.2, 0.90652173913044, 0.22222222222222
28263, 1.2, 0.8804347826087, 0.25
28264, 1.2, 0.90652173913044, 0.16666666666667
28265, 1.2, 0.8804347826087, 0.19444444444444
28266, 1.2, 0.90652173913044, 0.11111111111111
28267, 1.2, 0.8804347826087, 0.13888888888889
28268, 1.2, 0.90652173913044, 0.055555555555556
28269, 1.2, 0.8804347826087, 0.083333333333333
28270, 1.2, 0.8804347826087, 0.027777777777778
28271, 1.2, 0.85434782608696, 0.44444444444444
28272, 1.2, 0.82826086956522, 0.47222222222222
28273, 1.2, 0.85434782608696, 0.38888888888889
28274, 1.2, 0.82826086956522, 0.41666666666667
28275, 1.2, 0.85434782608696, 0.33333333333333
28276, 1.2, 0.82826086956522, 0.36111111111111
28277, 1.2, 0.85434782608696, 0.27777777777778
28278, 1.2, 0.82826086956522, 0.30555555555556
28279, 1.2, 0.85434782608696, 0.22222222222222
28280, 1.2, 0.82826086956522, 0.25
28281, 1.2, 0.85434782608696, 0.16666666666667
28282, 1.2, 0.82826086956522, 0.19444444444444
28283, 1.2, 0.85434782608696, 0.11111111111111
28284, 1.2, 0.82826086956522, 0.13888888888889
28285, 1.2, 0.85434782608696, 0.055555555555556
28286, 1.2, 0.82826086956522, 0.083333333333333
28287, 1.2, 0.82826086956522, 0.027777777777778
28288, 1.2, 0.80217391304348, 0.44444444444444
28289, 1.2, 0.77608695652174, 0.47222222222222
28290, 1.2, 0.80217391304348, 0.38888888888889
28291, 1.2, 0.77608695652174, 0.41666666666667
28292, 1.2, 0.80217391304348, 0.33333333333333
28293, 1.2, 0.77608695652174, 0.36111111111111
28294, 1.2, 0.80217391304348, 0.27777777777778
28295, 1.2, 0.77608695652174, 0.30555555555556
28296, 1.2, 0.80217391304348, 0.22222222222222
28297, 1.2, 0.77608695652174, 0.25
28298, 1.2, 0.80217391304348, 0.16666666666667
28299, 1.2, 0.77608695652174, 0.19444444444444
28300, 1.2, 0.80217391304348, 0.11111111111111
28301, 1.2, 0.77608695652174, 0.13888888888889
28302, 1.2, 0.80217391304348, 0.055555555555556
28303, 1.2, 0.77608695652174, 0.083333333333333
28304, 1.2, 0.77608695652174, 0.027777777777778
28305, 1.2, 0.75, 0.44444444444444
28306, 1.2, 0.72391304347826, 0.47222222222222
28307, 1.2, 0.75, 0.38888888888889
28308, 1.2, 0.72391304347826, 0.41666666666667
28309, 1.2, 0.75, 0.33333333333333
28310, 1.2, 0.72391304347826, 0.36111111111111
28311, 1.2, 0.75, 0.27777777777778
28312, 1.2, 0.72391304347826, 0.30555555555556
28313, 1.2, 0.75, 0.22222222222222
28314, 1.2, 0.72391304347826, 0.25
28315, 1.2, 0.75, 0.16666666666667
28316, 1.2, 0.72391304347826, 0.19444444444444
28317, 1.2, 0.75, 0.11111111111111
28318, 1.2, 0.72391304347826, 0.13888888888889
28319, 1.2, 0.75, 0.055555555555556
28320, 1.2, 0.72391304347826, 0.083333333333333
28321, 1.2, 0.72391304347826, 0.027777777777778
28322, 1.2, 0.69782608695652, 0.44444444444444
28323, 1.2, 0.67173913043478, 0.47222222222222
28324, 1.2, 0.69782608695652, 0.38888888888889
28325, 1.2, 0.67173913043478, 0.41666666666667
28326, 1.2, 0.69782608695652, 0.33333333333333
28327, 1.2, 0.67173913043478, 0.36111111111111
28328, 1.2, 0.69782608695652, 0.27777777777778
28329, 1.2, 0.67173913043478, 0.30555555555556
28330, 1.2, 0.69782608695652, 0.22222222222222
28331, 1.2, 0.67173913043478, 0.25
28332, 1.2, 0.69782608695652, 0.16666666666667
28333, 1.2, 0.67173913043478, 0.19444444444444
28334, 1.2, 0.69782608695652, 0.11111111111111
28335, 1.2, 0.67173913043478, 0.13888888888889
28336, 1.2, 0.69782608695652, 0.055555555555556
28337, 1.2, 0.67173913043478, 0.083333333333333
28338, 1.2, 0.67173913043478, 0.027777777777778
28339, 1.2, 0.64565217391304, 0.44444444444444
28340, 1.2, 0.61956521739131, 0.47222222222222
28341, 1.2, 0.64565217391304, 0.38888888888889
28342, 1.2, 0.61956521739131, 0.41666666666667
28343, 1.2, 0.64565217391304, 0.33333333333333
28344, 1.2, 0.61956521739131, 0.36111111111111
28345, 1.2, 0.64565217391304, 0.27777777777778
28346, 1.2, 0.61956521739131, 0.30555555555556
28347, 1.2, 0.64565217391304, 0.22222222222222
28348, 1.2, 0.61956521739131, 0.25
28349, 1.2, 0.64565217391304, 0.16666666666667
28350, 1.2, 0.61956521739131, 0.19444444444444
28351, 1.2, 0.64565217391304, 0.11111111111111
28352, 1.2, 0.61956521739131, 0.13888888888889
28353, 1.2, 0.64565217391304, 0.055555555555556
28354, 1.2, 0.61956521739131, 0.083333333333333
28355, 1.2, 0.61956521739131, 0.027777777777778
28356, 1.2, 0.59347826086957, 0.44444444444444
28357, 1.2, 0.56739130434783, 0.47222222222222
28358, 1.2, 0.59347826086957, 0.38888888888889
28359, 1.2, 0.56739130434783, 0.41666666666667
28360, 1.2, 0.59347826086957, 0.33333333333333
28361, 1.2, 0.56739130434783, 0.36111111111111
28362, 1.2, 0.59347826086957, 0.27777777777778
28363, 1.2, 0.56739130434783, 0.30555555555556
28364, 1.2, 0.59347826086957, 0.22222222222222
28365, 1.2, 0.56739130434783, 0.25
28366, 1.2, 0.59347826086957, 0.16666666666667
28367, 1.2, 0.56739130434783, 0.19444444444444
28368, 1.2, 0.59347826086957, 0.11111111111111
28369, 1.2, 0.56739130434783, 0.13888888888889
28370, 1.2, 0.59347826086957, 0.055555555555556
28371, 1.2, 0.56739130434783, 0.083333333333333
28372, 1.2, 0.56739130434783, 0.027777777777778
28373, 1.2, 0.54130434782609, 0.44444444444444
28374, 1.2, 0.51521739130435, 0.47222222222222
28375, 1.2, 0.54130434782609, 0.38888888888889
28376, 1.2, 0.51521739130435, 0.41666666666667
28377, 1.2, 0.54130434782609, 0.33333333333333
28378, 1.2, 0.51521739130435, 0.36111111111111
28379, 1.2, 0.54130434782609, 0.27777777777778
28380, 1.2, 0.51521739130435, 0.30555555555556
28381, 1.2, 0.54130434782609, 0.22222222222222
28382, 1.2, 0.51521739130435, 0.25
28383, 1.2, 0.54130434782609, 0.16666666666667
28384, 1.2, 0.51521739130435, 0.19444444444444
28385, 1.2, 0.54130434782609, 0.11111111111111
28386, 1.2, 0.51521739130435, 0.13888888888889
28387, 1.2, 0.54130434782609, 0.055555555555556
28388, 1.2, 0.51521739130435, 0.083333333333333
28389, 1.2, 0.51521739130435, 0.027777777777778
28390, 1.2, 0.48913043478261, 0.44444444444444
28391, 1.2, 0.46304347826087, 0.47222222222222
28392, 1.2, 0.48913043478261, 0.38888888888889
28393, 1.2, 0.46304347826087, 0.41666666666667
28394, 1.2, 0.48913043478261, 0.33333333333333
28395, 1.2, 0.46304347826087, 0.36111111111111
28396, 1.2, 0.48913043478261, 0.27777777777778
28397, 1.2, 0.46304347826087, 0.30555555555556
28398, 1.2, 0.48913043478261, 0.22222222222222
28399, 1.2, 0.46304347826087, 0.25
28400, 1.2, 0.48913043478261, 0.16666666666667
28401, 1.2, 0.46304347826087, 0.19444444444444
28402, 1.2, 0.48913043478261, 0.11111111111111
28403, 1.2, 0.46304347826087, 0.13888888888889
28404, 1.2, 0.48913043478261, 0.055555555555556
28405, 1.2, 0.46304347826087, 0.083333333333333
28406, 1.2, 0.46304347826087, 0.027777777777778
28407, 1.2, 0.43695652173913, 0.44444444444444
28408, 1.2, 0.41086956521739, 0.47222222222222
28409, 1.2, 0.43695652173913, 0.38888888888889
28410, 1.2, 0.41086956521739, 0.41666666666667
28411, 1.2, 0.43695652173913, 0.33333333333333
28412, 1.2, 0.41086956521739, 0.36111111111111
28413, 1.2, 0.43695652173913, 0.27777777777778
28414, 1.2, 0.41086956521739, 0.30555555555556
28415, 1.2, 0.43695652173913, 0.22222222222222
28416, 1.2, 0.41086956521739, 0.25
28417, 1.2, 0.43695652173913, 0.16666666666667
28418, 1.2, 0.41086956521739, 0.19444444444444
28419, 1.2, 0.43695652173913, 0.11111111111111
28420, 1.2, 0.41086956521739, 0.13888888888889
28421, 1.2, 0.43695652173913, 0.055555555555556
28422, 1.2, 0.41086956521739, 0.083333333333333
28423, 1.2, 0.41086956521739, 0.027777777777778
28424, 1.2, 0.38478260869565, 0.44444444444444
28425, 1.2, 0.35869565217391, 0.47222222222222
28426, 1.2, 0.38478260869565, 0.38888888888889
28427, 1.2, 0.35869565217391, 0.41666666666667
28428, 1.2, 0.38478260869565, 0.33333333333333
28429, 1.2, 0.35869565217391, 0.36111111111111
28430, 1.2, 0.38478260869565, 0.27777777777778
28431, 1.2, 0.35869565217391, 0.30555555555556
28432, 1.2, 0.38478260869565, 0.22222222222222
28433, 1.2, 0.35869565217391, 0.25
28434, 1.2, 0.38478260869565, 0.16666666666667
28435, 1.2, 0.35869565217391, 0.19444444444444
28436, 1.2, 0.38478260869565, 0.11111111111111
28437, 1.2, 0.35869565217391, 0.13888888888889
28438, 1.2, 0.38478260869565, 0.055555555555556
28439, 1.2, 0.35869565217391, 0.083333333333333
28440, 1.2, 0.35869565217391, 0.027777777777778
28441, 1.2, 0.33260869565217, 0.44444444444444
28442, 1.2, 0.30652173913044, 0.47222222222222
28443, 1.2, 0.33260869565217, 0.38888888888889
28444, 1.2, 0.30652173913044, 0.41666666666667
28445, 1.2, 0.33260869565217, 0.33333333333333
28446, 1.2, 0.30652173913044, 0.36111111111111
28447, 1.2, 0.33260869565217, 0.27777777777778
28448, 1.2, 0.30652173913044, 0.30555555555556
28449, 1.2, 0.33260869565217, 0.22222222222222
28450, 1.2, 0.30652173913044, 0.25
28451, 1.2, 0.33260869565217, 0.16666666666667
28452, 1.2, 0.30652173913044, 0.19444444444444
28453, 1.2, 0.33260869565217, 0.11111111111111
28454, 1.2, 0.30652173913044, 0.13888888888889
28455, 1.2, 0.33260869565217, 0.055555555555556
28456, 1.2, 0.30652173913044, 0.083333333333333
28457, 1.2, 0.30652173913044, 0.027777777777778
28458, 1.2, 0.2804347826087, 0.44444444444444
28459, 1.2, 0.25434782608696, 0.47222222222222
28460, 1.2, 0.2804347826087, 0.38888888888889
28461, 1.2, 0.25434782608696, 0.41666666666667
28462, 1.2, 0.2804347826087, 0.33333333333333
28463, 1.2, 0.25434782608696, 0.36111111111111
28464, 1.2, 0.2804347826087, 0.27777777777778
28465, 1.2, 0.25434782608696, 0.30555555555556
28466, 1.2, 0.2804347826087, 0.22222222222222
28467, 1.2, 0.25434782608696, 0.25
28468, 1.2, 0.2804347826087, 0.16666666666667
28469, 1.2, 0.25434782608696, 0.19444444444444
28470, 1.2, 0.2804347826087, 0.11111111111111
28471, 1.2, 0.25434782608696, 0.13888888888889
28472, 1.2, 0.2804347826087, 0.055555555555556
28473, 1.2, 0.25434782608696, 0.083333333333333
28474, 1.2, 0.25434782608696, 0.027777777777778
28475, 1.2, 0.22826086956522, 0.44444444444444
28476, 1.2, 0.20217391304348, 0.47222222222222
28477, 1.2, 0.22826086956522, 0.38888888888889
28478, 1.2, 0.20217391304348, 0.41666666666667
28479, 1.2, 0.22826086956522, 0.33333333333333
28480, 1.2, 0.20217391304348, 0.36111111111111
28481, 1.2, 0.22826086956522, 0.27777777777778
28482, 1.2, 0.20217391304348, 0.30555555555556
28483, 1.2, 0.22826086956522, 0.22222222222222
28484, 1.2, 0.20217391304348, 0.25
28485, 1.2, 0.22826086956522, 0.16666666666667
28486, 1.2, 0.20217391304348, 0.19444444444444
28487, 1.2, 0.22826086956522, 0.11111111111111
28488, 1.2, 0.20217391304348, 0.13888888888889
28489, 1.2, 0.22826086956522, 0.055555555555556
28490, 1.2, 0.20217391304348, 0.083333333333333
28491, 1.2, 0.20217391304348, 0.027777777777778
28492, 1.2, 0.17608695652174, 0.44444444444444
28493, 1.2, 0.17608695652174, 0.38888888888889
28494, 1.2, 0.17608695652174, 0.33333333333333
28495, 1.2, 0.17608695652174, 0.27777777777778
28496, 1.2, 0.17608695652174, 0.22222222222222
28497, 1.2, 0.17608695652174, 0.16666666666667
28498, 1.2, 0.17608695652174, 0.11111111111111
28499, 1.2, 0.17608695652174, 0.055555555555556
28500, 2.2, 1.2978260869565, 0.44444444444444
28501, 2.2, 1.2978260869565, 0.38888888888889
28502, 2.2, 1.2978260869565, 0.33333333333333
28503, 2.2, 1.2978260869565, 0.27777777777778
28504, 2.2, 1.2978260869565, 0.22222222222222
28505, 2.2, 1.2978260869565, 0.16666666666667
28506, 2.2, 1.2978260869565, 0.11111111111111
28507, 2.2, 1.2978260869565, 0.055555555555556
28508, 2.2, 1.245652173913, 0.44444444444444
28509, 2.2, 1.245652173913, 0.38888888888889
28510, 2.2, 1.245652173913, 0.33333333333333
28511, 2.2, 1.245652173913, 0.27777777777778
28512, 2.2, 1.245652173913, 0.22222222222222
28513, 2.2, 1.245652173913, 0.16666666666667
28514, 2.2, 1.245652173913, 0.11111111111111
28515, 2.2, 1.245652173913, 0.055555555555556
28516, 2.2, 1.1934782608696, 0.44444444444444
28517, 2.2, 1.1934782608696, 0.38888888888889
28518, 2.2, 1.1934782608696, 0.33333333333333
28519, 2.2, 1.1934782608696, 0.27777777777778
28520, 2.2, 1.1934782608696, 0.22222222222222
28521, 2.2, 1.1934782608696, 0.16666666666667
28522, 2.2, 1.1934782608696, 0.11111111111111
28523, 2.2, 1.1934782608696, 0.055555555555556
28524, 2.2, 1.1413043478261, 0.44444444444444
28525, 2.2, 1.1413043478261, 0.38888888888889
28526, 2.2, 1.1413043478261, 0.33333333333333
28527, 2.2, 1.1413043478261, 0.27777777777778
28528, 2.2, 1.1413043478261, 0.22222222222222
28529, 2.2, 1.1413043478261, 0.16666666666667
28530, 2.2, 1.1413043478261, 0.11111111111111
28531, 2.2, 1.1413043478261, 0.055555555555556
28532, 2.2, 1.0891304347826, 0.44444444444444
28533, 2.2, 1.0891304347826, 0.38888888888889
28534, 2.2, 1.0891304347826, 0.33333333333333
28535, 2.2, 1.0891304347826, 0.27777777777778
28536, 2.2, 1.0891304347826, 0.22222222222222
28537, 2.2, 1.0891304347826, 0.16666666666667
28538, 2.2, 1.0891304347826, 0.11111111111111
28539, 2.2, 1.0891304347826, 0.055555555555556
28540, 2.2, 1.0369565217391, 0.44444444444444
28541, 2.2, 1.0369565217391, 0.38888888888889
28542, 2.2, 1.0369565217391, 0.33333333333333
28543, 2.2, 1.0369565217391, 0.27777777777778
28544, 2.2, 1.0369565217391, 0.22222222222222
28545, 2.2, 1.0369565217391, 0.16666666666667
28546, 2.2, 1.0369565217391, 0.11111111111111
28547, 2.2, 1.0369565217391, 0.055555555555556
28548, 2.2, 0.98478260869565, 0.44444444444444
28549, 2.2, 0.98478260869565, 0.38888888888889
28550, 2.2, 0.98478260869565, 0.33333333333333
28551, 2.2, 0.98478260869565, 0.27777777777778
28552, 2.2, 0.98478260869565, 0.22222222222222
28553, 2.2, 0.98478260869565, 0.16666666666667
28554, 2.2, 0.98478260869565, 0.11111111111111
28555, 2.2, 0.98478260869565, 0.055555555555556
28556, 2.2, 0.93260869565217, 0.44444444444444
28557, 2.2, 0.93260869565217, 0.38888888888889
28558, 2.2, 0.93260869565217, 0.33333333333333
28559, 2.2, 0.93260869565217, 0.27777777777778
28560, 2.2, 0.93260869565217, 0.22222222222222
28561, 2.2, 0.93260869565217, 0.16666666666667
28562, 2.2, 0.93260869565217, 0.11111111111111
28563, 2.2, 0.93260869565217, 0.055555555555556
28564, 2.2, 0.8804347826087, 0.44444444444444
28565, 2.2, 0.8804347826087, 0.38888888888889
28566, 2.2, 0.8804347826087, 0.33333333333333
28567, 2.2, 0.8804347826087, 0.27777777777778
28568, 2.2, 0.8804347826087, 0.22222222222222
28569, 2.2, 0.8804347826087, 0.16666666666667
28570, 2.2, 0.8804347826087, 0.11111111111111
28571, 2.2, 0.8804347826087, 0.055555555555556
28572, 2.2, 0.82826086956522, 0.44444444444444
28573, 2.2, 0.82826086956522, 0.38888888888889
28574, 2.2, 0.82826086956522, 0.33333333333333
28575, 2.2, 0.82826086956522, 0.27777777777778
28576, 2.2, 0.82826086956522, 0.22222222222222
28577, 2.2, 0.82826086956522, 0.16666666666667
28578, 2.2, 0.82826086956522, 0.11111111111111
28579, 2.2, 0.82826086956522, 0.055555555555556
28580, 2.2, 0.77608695652174, 0.44444444444444
28581, 2.2, 0.77608695652174, 0.38888888888889
28582, 2.2, 0.77608695652174, 0.33333333333333
28583, 2.2, 0.77608695652174, 0.27777777777778
28584, 2.2, 0.77608695652174, 0.22222222222222
28585, 2.2, 0.77608695652174, 0.16666666666667
28586, 2.2, 0.77608695652174, 0.11111111111111
28587, 2.2, 0.77608695652174, 0.055555555555556
28588, 2.2, 0.72391304347826, 0.44444444444444
28589, 2.2, 0.72391304347826, 0.38888888888889
28590, 2.2, 0.72391304347826, 0.33333333333333
28591, 2.2, 0.72391304347826, 0.27777777777778
28592, 2.2, 0.72391304347826, 0.22222222222222
28593, 2.2, 0.72391304347826, 0.16666666666667
28594, 2.2, 0.72391304347826, 0.11111111111111
28595, 2.2, 0.72391304347826, 0.055555555555556
28596, 2.2, 0.67173913043478, 0.44444444444444
28597, 2.2, 0.67173913043478, 0.38888888888889
28598, 2.2, 0.67173913043478, 0.33333333333333
28599, 2.2, 0.67173913043478, 0.27777777777778
28600, 2.2, 0.67173913043478, 0.22222222222222
28601, 2.2, 0.67173913043478, 0.16666666666667
28602, 2.2, 0.67173913043478, 0.11111111111111
28603, 2.2, 0.67173913043478, 0.055555555555556
28604, 2.2, 0.61956521739131, 0.44444444444444
28605, 2.2, 0.61956521739131, 0.38888888888889
28606, 2.2, 0.61956521739131, 0.33333333333333
28607, 2.2, 0.61956521739131, 0.27777777777778
28608, 2.2, 0.61956521739131, 0.22222222222222
28609, 2.2, 0.61956521739131, 0.16666666666667
28610, 2.2, 0.61956521739131, 0.11111111111111
28611, 2.2, 0.61956521739131, 0.055555555555556
28612, 2.2, 0.56739130434783, 0.44444444444444
28613, 2.2, 0.56739130434783, 0.38888888888889
28614, 2.2, 0.56739130434783, 0.33333333333333
28615, 2.2, 0.56739130434783, 0.27777777777778
28616, 2.2, 0.56739130434783, 0.22222222222222
28617, 2.2, 0.56739130434783, 0.16666666666667
28618, 2.2, 0.56739130434783, 0.11111111111111
28619, 2.2, 0.56739130434783, 0.055555555555556
28620, 2.2, 0.51521739130435, 0.44444444444444
28621, 2.2, 0.51521739130435, 0.38888888888889
28622, 2.2, 0.51521739130435, 0.33333333333333
28623, 2.2, 0.51521739130435, 0.27777777777778
28624, 2.2, 0.51521739130435, 0.22222222222222
28625, 2.2, 0.51521739130435, 0.16666666666667
28626, 2.2, 0.51521739130435, 0.11111111111111
28627, 2.2, 0.51521739130435, 0.055555555555556
28628, 2.2, 0.46304347826087, 0.44444444444444
28629, 2.2, 0.46304347826087, 0.38888888888889
28630, 2.2, 0.46304347826087, 0.33333333333333
28631, 2.2, 0.46304347826087, 0.27777777777778
28632, 2.2, 0.46304347826087, 0.22222222222222
28633, 2.2, 0.46304347826087, 0.16666666666667
28634, 2.2, 0.46304347826087, 0.11111111111111
28635, 2.2, 0.46304347826087, 0.055555555555556
28636, 2.2, 0.41086956521739, 0.44444444444444
28637, 2.2, 0.41086956521739, 0.38888888888889
28638, 2.2, 0.41086956521739, 0.33333333333333
28639, 2.2, 0.41086956521739, 0.27777777777778
28640, 2.2, 0.41086956521739, 0.22222222222222
28641, 2.2, 0.41086956521739, 0.16666666666667
28642, 2.2, 0.41086956521739, 0.11111111111111
28643, 2.2, 0.41086956521739, 0.055555555555556
28644, 2.2, 0.35869565217391, 0.44444444444444
28645, 2.2, 0.35869565217391, 0.38888888888889
28646, 2.2, 0.35869565217391, 0.33333333333333
28647, 2.2, 0.35869565217391, 0.27777777777778
28648, 2.2, 0.35869565217391, 0.22222222222222
28649, 2.2, 0.35869565217391, 0.16666666666667
28650, 2.2, 0.35869565217391, 0.11111111111111
28651, 2.2, 0.35869565217391, 0.055555555555556
28652, 2.2, 0.30652173913044, 0.44444444444444
28653, 2.2, 0.30652173913044, 0.38888888888889
28654, 2.2, 0.30652173913044, 0.33333333333333
28655, 2.2, 0.30652173913044, 0.27777777777778
28656, 2.2, 0.30652173913044, 0.22222222222222
28657, 2.2, 0.30652173913044, 0.16666666666667
28658, 2.2, 0.30652173913044, 0.11111111111111
28659, 2.2, 0.30652173913044, 0.055555555555556
28660, 2.2, 0.25434782608696, 0.44444444444444
28661, 2.2, 0.25434782608696, 0.38888888888889
28662, 2.2, 0.25434782608696, 0.33333333333333
28663, 2.2, 0.25434782608696, 0.27777777777778
28664, 2.2, 0.25434782608696, 0.22222222222222
28665, 2.2, 0.25434782608696, 0.16666666666667
28666, 2.2, 0.25434782608696, 0.11111111111111
28667, 2.2, 0.25434782608696, 0.055555555555556
28668, 2.2, 0.20217391304348, 0.44444444444444
28669, 2.2, 0.20217391304348, 0.38888888888889
28670, 2.2, 0.20217391304348, 0.33333333333333
28671, 2.2, 0.20217391304348, 0.27777777777778
28672, 2.2, 0.20217391304348, 0.22222222222222
28673, 2.2, 0.20217391304348, 0.16666666666667
28674, 2.2, 0.20217391304348, 0.11111111111111
28675, 2.2, 0.20217391304348, 0.055555555555556
28676, 2.2, 1.2978260869565, 0.47222222222222
28677, 2.2, 1.3239130434783, 0.44444444444444
28678, 2.2, 1.2978260869565, 0.41666666666667
28679, 2.2, 1.3239130434783, 0.38888888888889
28680, 2.2, 1.2978260869565, 0.36111111111111
28681, 2.2, 1.3239130434783, 0.33333333333333
28682, 2.2, 1.2978260869565, 0.30555555555556
28683, 2.2, 1.3239130434783, 0.27777777777778
28684, 2.2, 1.2978260869565, 0.25
28685, 2.2, 1.3239130434783, 0.22222222222222
28686, 2.2, 1.2978260869565, 0.19444444444444
28687, 2.2, 1.3239130434783, 0.16666666666667
28688, 2.2, 1.2978260869565, 0.13888888888889
28689, 2.2, 1.3239130434783, 0.11111111111111
28690, 2.2, 1.2978260869565, 0.083333333333333
28691, 2.2, 1.3239130434783, 0.055555555555556
28692, 2.2, 1.2978260869565, 0.027777777777778
28693, 2.2, 1.245652173913, 0.47222222222222
28694, 2.2, 1.2717391304348, 0.44444444444444
28695, 2.2, 1.245652173913, 0.41666666666667
28696, 2.2, 1.2717391304348, 0.38888888888889
28697, 2.2, 1.245652173913, 0.36111111111111
28698, 2.2, 1.2717391304348, 0.33333333333333
28699, 2.2, 1.245652173913, 0.30555555555556
28700, 2.2, 1.2717391304348, 0.27777777777778
28701, 2.2, 1.245652173913, 0.25
28702, 2.2, 1.2717391304348, 0.22222222222222
28703, 2.2, 1.245652173913, 0.19444444444444
28704, 2.2, 1.2717391304348, 0.16666666666667
28705, 2.2, 1.245652173913, 0.13888888888889
28706, 2.2, 1.2717391304348, 0.11111111111111
28707, 2.2, 1.245652173913, 0.083333333333333
28708, 2.2, 1.2717391304348, 0.055555555555556
28709, 2.2, 1.245652173913, 0.027777777777778
28710, 2.2, 1.1934782608696, 0.47222222222222
28711, 2.2, 1.2195652173913, 0.44444444444444
28712, 2.2, 1.1934782608696, 0.41666666666667
28713, 2.2, 1.2195652173913, 0.38888888888889
28714, 2.2, 1.1934782608696, 0.36111111111111
28715, 2.2, 1.2195652173913, 0.33333333333333
28716, 2.2, 1.1934782608696, 0.30555555555556
28717, 2.2, 1.2195652173913, 0.27777777777778
28718, 2.2, 1.1934782608696, 0.25
28719, 2.2, 1.2195652173913, 0.22222222222222
28720, 2.2, 1.1934782608696, 0.19444444444444
28721, 2.2, 1.2195652173913, 0.16666666666667
28722, 2.2, 1.1934782608696, 0.13888888888889
28723, 2.2, 1.2195652173913, 0.11111111111111
28724, 2.2, 1.1934782608696, 0.083333333333333
28725, 2.2, 1.2195652173913, 0.055555555555556
28726, 2.2, 1.1934782608696, 0.027777777777778
28727, 2.2, 1.1413043478261, 0.47222222222222
28728, 2.2, 1.1673913043478, 0.44444444444444
28729, 2.2, 1.1413043478261, 0.41666666666667
28730, 2.2, 1.1673913043478, 0.38888888888889
28731, 2.2, 1.1413043478261, 0.36111111111111
28732, 2.2, 1.1673913043478, 0.33333333333333
28733, 2.2, 1.1413043478261, 0.30555555555556
28734, 2.2, 1.1673913043478, 0.27777777777778
28735, 2.2, 1.1413043478261, 0.25
28736, 2.2, 1.1673913043478, 0.22222222222222
28737, 2.2, 1.1413043478261, 0.19444444444444
28738, 2.2, 1.1673913043478, 0.16666666666667
28739, 2.2, 1.1413043478261, 0.13888888888889
28740, 2.2, 1.1673913043478, 0.11111111111111
28741, 2.2, 1.1413043478261, 0.083333333333333
28742, 2.2, 1.1673913043478, 0.055555555555556
28743, 2.2, 1.1413043478261, 0.027777777777778
28744, 2.2, 1.0891304347826, 0.47222222222222
28745, 2.2, 1.1152173913043, 0.44444444444444
28746, 2.2, 1.0891304347826, 0.41666666666667
28747, 2.2, 1.1152173913043, 0.38888888888889
28748, 2.2, 1.0891304347826, 0.36111111111111
28749, 2.2, 1.1152173913043, 0.33333333333333
28750, 2.2, 1.0891304347826, 0.30555555555556
28751, 2.2, 1.1152173913043, 0.27777777777778
28752, 2.2, 1.0891304347826, 0.25
28753, 2.2, 1.1152173913043, 0.22222222222222
28754, 2.2, 1.0891304347826, 0.19444444444444
28755, 2.2, 1.1152173913043, 0.16666666666667
28756, 2.2, 1.0891304347826, 0.13888888888889
28757, 2.2, 1.1152173913043, 0.11111111111111
28758, 2.2, 1.0891304347826, 0.083333333333333
28759, 2.2, 1.1152173913043, 0.055555555555556
28760, 2.2, 1.0891304347826, 0.027777777777778
28761, 2.2, 1.0369565217391, 0.47222222222222
28762, 2.2, 1.0630434782609, 0.44444444444444
28763, 2.2, 1.0369565217391, 0.41666666666667
28764, 2.2, 1.0630434782609, 0.38888888888889
28765, 2.2, 1.0369565217391, 0.36111111111111
28766, 2.2, 1.0630434782609, 0.33333333333333
28767, 2.2, 1.0369565217391, 0.30555555555556
28768, 2.2, 1.0630434782609, 0.27777777777778
28769, 2.2, 1.0369565217391, 0.25
28770, 2.2, 1.0630434782609, 0.22222222222222
28771, 2.2, 1.0369565217391, 0.19444444444444
28772, 2.2, 1.0630434782609, 0.16666666666667
28773, 2.2, 1.0369565217391, 0.13888888888889
28774, 2.2, 1.0630434782609, 0.11111111111111
28775, 2.2, 1.0369565217391, 0.083333333333333
28776, 2.2, 1.0630434782609, 0.055555555555556
28777, 2.2, 1.0369565217391, 0.027777777777778
28778, 2.2, 0.98478260869565, 0.47222222222222
28779, 2.2, 1.0108695652174, 0.44444444444444
28780, 2.2, 0.98478260869565, 0.41666666666667
28781, 2.2, 1.0108695652174, 0.38888888888889
28782, 2.2, 0.98478260869565, 0.36111111111111
28783, 2.2, 1.0108695652174, 0.33333333333333
28784, 2.2, 0.98478260869565, 0.30555555555556
28785, 2.2, 1.0108695652174, 0.27777777777778
28786, 2.2, 0.98478260869565, 0.25
28787, 2.2, 1.0108695652174, 0.22222222222222
28788, 2.2, 0.98478260869565, 0.19444444444444
28789, 2.2, 1.0108695652174, 0.16666666666667
28790, 2.2, 0.98478260869565, 0.13888888888889
28791, 2.2, 1.0108695652174, 0.11111111111111
28792, 2.2, 0.98478260869565, 0.083333333333333
28793, 2.2, 1.0108695652174, 0.055555555555556
28794, 2.2, 0.98478260869565, 0.027777777777778
28795, 2.2, 0.93260869565217, 0.47222222222222
28796, 2.2, 0.95869565217391, 0.44444444444444
28797, 2.2, 0.93260869565217, 0.41666666666667
28798, 2.2, 0.95869565217391, 0.38888888888889
28799, 2.2, 0.93260869565217, 0.36111111111111
28800, 2.2, 0.95869565217391, 0.33333333333333
28801, 2.2, 0.93260869565217, 0.30555555555556
28802, 2.2, 0.95869565217391, 0.27777777777778
28803, 2.2, 0.93260869565217, 0.25
28804, 2.2, 0.95869565217391, 0.22222222222222
28805, 2.2, 0.93260869565217, 0.19444444444444
28806, 2.2, 0.95869565217391, 0.16666666666667
28807, 2.2, 0.93260869565217, 0.13888888888889
28808, 2.2, 0.95869565217391, 0.11111111111111
28809, 2.2, 0.93260869565217, 0.083333333333333
28810, 2.2, 0.95869565217391, 0.055555555555556
28811, 2.2, 0.93260869565217, 0.027777777777778
28812, 2.2, 0.8804347826087, 0.47222222222222
28813, 2.2, 0.90652173913044, 0.44444444444444
28814, 2.2, 0.8804347826087, 0.41666666666667
28815, 2.2, 0.90652173913044, 0.38888888888889
28816, 2.2, 0.8804347826087, 0.36111111111111
28817, 2.2, 0.90652173913044, 0.33333333333333
28818, 2.2, 0.8804347826087, 0.30555555555556
28819, 2.2, 0.90652173913044, 0.27777777777778
28820, 2.2, 0.8804347826087, 0.25
28821, 2.2, 0.90652173913044, 0.22222222222222
28822, 2.2, 0.8804347826087, 0.19444444444444
28823, 2.2, 0.90652173913044, 0.16666666666667
28824, 2.2, 0.8804347826087, 0.13888888888889
28825, 2.2, 0.90652173913044, 0.11111111111111
28826, 2.2, 0.8804347826087, 0.083333333333333
28827, 2.2, 0.90652173913044, 0.055555555555556
28828, 2.2, 0.8804347826087, 0.027777777777778
28829, 2.2, 0.82826086956522, 0.47222222222222
28830, 2.2, 0.85434782608696, 0.44444444444444
28831, 2.2, 0.82826086956522, 0.41666666666667
28832, 2.2, 0.85434782608696, 0.38888888888889
28833, 2.2, 0.82826086956522, 0.36111111111111
28834, 2.2, 0.85434782608696, 0.33333333333333
28835, 2.2, 0.82826086956522, 0.30555555555556
28836, 2.2, 0.85434782608696, 0.27777777777778
28837, 2.2, 0.82826086956522, 0.25
28838, 2.2, 0.85434782608696, 0.22222222222222
28839, 2.2, 0.82826086956522, 0.19444444444444
28840, 2.2, 0.85434782608696, 0.16666666666667
28841, 2.2, 0.82826086956522, 0.13888888888889
