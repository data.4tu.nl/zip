75767, 2.1565217391304, 0.35869565217391, 0.027777777777778
75768, 2.1782608695652, 0.35869565217391, 0.44444444444444
75769, 2.1782608695652, 0.35869565217391, 0.38888888888889
75770, 2.1782608695652, 0.35869565217391, 0.33333333333333
75771, 2.1782608695652, 0.35869565217391, 0.27777777777778
75772, 2.1782608695652, 0.35869565217391, 0.22222222222222
75773, 2.1782608695652, 0.35869565217391, 0.16666666666667
75774, 2.1782608695652, 0.35869565217391, 0.11111111111111
75775, 2.1782608695652, 0.35869565217391, 0.055555555555556
75776, 1.2434782608696, 0.30652173913044, 0.47222222222222
75777, 1.2217391304348, 0.30652173913044, 0.44444444444444
75778, 1.2434782608696, 0.33260869565217, 0.44444444444444
75779, 1.2434782608696, 0.30652173913044, 0.41666666666667
75780, 1.2217391304348, 0.30652173913044, 0.38888888888889
75781, 1.2434782608696, 0.33260869565217, 0.38888888888889
75782, 1.2434782608696, 0.30652173913044, 0.36111111111111
75783, 1.2217391304348, 0.30652173913044, 0.33333333333333
75784, 1.2434782608696, 0.33260869565217, 0.33333333333333
75785, 1.2434782608696, 0.30652173913044, 0.30555555555556
75786, 1.2217391304348, 0.30652173913044, 0.27777777777778
75787, 1.2434782608696, 0.33260869565217, 0.27777777777778
75788, 1.2434782608696, 0.30652173913044, 0.25
75789, 1.2217391304348, 0.30652173913044, 0.22222222222222
75790, 1.2434782608696, 0.33260869565217, 0.22222222222222
75791, 1.2434782608696, 0.30652173913044, 0.19444444444444
75792, 1.2217391304348, 0.30652173913044, 0.16666666666667
75793, 1.2434782608696, 0.33260869565217, 0.16666666666667
75794, 1.2434782608696, 0.30652173913044, 0.13888888888889
75795, 1.2217391304348, 0.30652173913044, 0.11111111111111
75796, 1.2434782608696, 0.33260869565217, 0.11111111111111
75797, 1.2434782608696, 0.30652173913044, 0.083333333333333
75798, 1.2217391304348, 0.30652173913044, 0.055555555555556
75799, 1.2434782608696, 0.33260869565217, 0.055555555555556
75800, 1.2434782608696, 0.30652173913044, 0.027777777777778
75801, 1.2869565217391, 0.30652173913043, 0.47222222222222
75802, 1.2652173913043, 0.30652173913044, 0.44444444444444
75803, 1.2869565217391, 0.33260869565217, 0.44444444444444
75804, 1.2869565217391, 0.30652173913043, 0.41666666666667
75805, 1.2652173913043, 0.30652173913044, 0.38888888888889
75806, 1.2869565217391, 0.33260869565217, 0.38888888888889
75807, 1.2869565217391, 0.30652173913043, 0.36111111111111
75808, 1.2652173913043, 0.30652173913044, 0.33333333333333
75809, 1.2869565217391, 0.33260869565217, 0.33333333333333
75810, 1.2869565217391, 0.30652173913043, 0.30555555555556
75811, 1.2652173913043, 0.30652173913044, 0.27777777777778
75812, 1.2869565217391, 0.33260869565217, 0.27777777777778
75813, 1.2869565217391, 0.30652173913043, 0.25
75814, 1.2652173913043, 0.30652173913044, 0.22222222222222
75815, 1.2869565217391, 0.33260869565217, 0.22222222222222
75816, 1.2869565217391, 0.30652173913043, 0.19444444444444
75817, 1.2652173913043, 0.30652173913044, 0.16666666666667
75818, 1.2869565217391, 0.33260869565217, 0.16666666666667
75819, 1.2869565217391, 0.30652173913043, 0.13888888888889
75820, 1.2652173913043, 0.30652173913044, 0.11111111111111
75821, 1.2869565217391, 0.33260869565217, 0.11111111111111
75822, 1.2869565217391, 0.30652173913043, 0.083333333333333
75823, 1.2652173913043, 0.30652173913044, 0.055555555555556
75824, 1.2869565217391, 0.33260869565217, 0.055555555555556
75825, 1.2869565217391, 0.30652173913043, 0.027777777777778
75826, 1.3304347826087, 0.30652173913043, 0.47222222222222
75827, 1.3086956521739, 0.30652173913043, 0.44444444444444
75828, 1.3304347826087, 0.33260869565217, 0.44444444444444
75829, 1.3304347826087, 0.30652173913043, 0.41666666666667
75830, 1.3086956521739, 0.30652173913043, 0.38888888888889
75831, 1.3304347826087, 0.33260869565217, 0.38888888888889
75832, 1.3304347826087, 0.30652173913043, 0.36111111111111
75833, 1.3086956521739, 0.30652173913043, 0.33333333333333
75834, 1.3304347826087, 0.33260869565217, 0.33333333333333
75835, 1.3304347826087, 0.30652173913043, 0.30555555555556
75836, 1.3086956521739, 0.30652173913043, 0.27777777777778
75837, 1.3304347826087, 0.33260869565217, 0.27777777777778
75838, 1.3304347826087, 0.30652173913043, 0.25
75839, 1.3086956521739, 0.30652173913043, 0.22222222222222
75840, 1.3304347826087, 0.33260869565217, 0.22222222222222
75841, 1.3304347826087, 0.30652173913043, 0.19444444444444
75842, 1.3086956521739, 0.30652173913043, 0.16666666666667
75843, 1.3304347826087, 0.33260869565217, 0.16666666666667
75844, 1.3304347826087, 0.30652173913043, 0.13888888888889
75845, 1.3086956521739, 0.30652173913043, 0.11111111111111
75846, 1.3304347826087, 0.33260869565217, 0.11111111111111
75847, 1.3304347826087, 0.30652173913043, 0.083333333333333
75848, 1.3086956521739, 0.30652173913043, 0.055555555555556
75849, 1.3304347826087, 0.33260869565217, 0.055555555555556
75850, 1.3304347826087, 0.30652173913043, 0.027777777777778
75851, 1.3739130434783, 0.30652173913044, 0.47222222222222
75852, 1.3521739130435, 0.30652173913044, 0.44444444444444
75853, 1.3739130434783, 0.33260869565217, 0.44444444444444
75854, 1.3739130434783, 0.30652173913044, 0.41666666666667
75855, 1.3521739130435, 0.30652173913044, 0.38888888888889
75856, 1.3739130434783, 0.33260869565217, 0.38888888888889
75857, 1.3739130434783, 0.30652173913044, 0.36111111111111
75858, 1.3521739130435, 0.30652173913044, 0.33333333333333
75859, 1.3739130434783, 0.33260869565217, 0.33333333333333
75860, 1.3739130434783, 0.30652173913044, 0.30555555555556
75861, 1.3521739130435, 0.30652173913044, 0.27777777777778
75862, 1.3739130434783, 0.33260869565217, 0.27777777777778
75863, 1.3739130434783, 0.30652173913044, 0.25
75864, 1.3521739130435, 0.30652173913044, 0.22222222222222
75865, 1.3739130434783, 0.33260869565217, 0.22222222222222
75866, 1.3739130434783, 0.30652173913044, 0.19444444444444
75867, 1.3521739130435, 0.30652173913044, 0.16666666666667
75868, 1.3739130434783, 0.33260869565217, 0.16666666666667
75869, 1.3739130434783, 0.30652173913044, 0.13888888888889
75870, 1.3521739130435, 0.30652173913044, 0.11111111111111
75871, 1.3739130434783, 0.33260869565217, 0.11111111111111
75872, 1.3739130434783, 0.30652173913044, 0.083333333333333
75873, 1.3521739130435, 0.30652173913044, 0.055555555555556
75874, 1.3739130434783, 0.33260869565217, 0.055555555555556
75875, 1.3739130434783, 0.30652173913044, 0.027777777777778
75876, 1.4173913043478, 0.30652173913044, 0.47222222222222
75877, 1.395652173913, 0.30652173913044, 0.44444444444444
75878, 1.4173913043478, 0.33260869565217, 0.44444444444444
75879, 1.4173913043478, 0.30652173913044, 0.41666666666667
75880, 1.395652173913, 0.30652173913044, 0.38888888888889
75881, 1.4173913043478, 0.33260869565217, 0.38888888888889
75882, 1.4173913043478, 0.30652173913044, 0.36111111111111
75883, 1.395652173913, 0.30652173913044, 0.33333333333333
75884, 1.4173913043478, 0.33260869565217, 0.33333333333333
75885, 1.4173913043478, 0.30652173913044, 0.30555555555556
75886, 1.395652173913, 0.30652173913044, 0.27777777777778
75887, 1.4173913043478, 0.33260869565217, 0.27777777777778
75888, 1.4173913043478, 0.30652173913044, 0.25
75889, 1.395652173913, 0.30652173913044, 0.22222222222222
75890, 1.4173913043478, 0.33260869565217, 0.22222222222222
75891, 1.4173913043478, 0.30652173913044, 0.19444444444444
75892, 1.395652173913, 0.30652173913044, 0.16666666666667
75893, 1.4173913043478, 0.33260869565217, 0.16666666666667
75894, 1.4173913043478, 0.30652173913044, 0.13888888888889
75895, 1.395652173913, 0.30652173913044, 0.11111111111111
75896, 1.4173913043478, 0.33260869565217, 0.11111111111111
75897, 1.4173913043478, 0.30652173913044, 0.083333333333333
75898, 1.395652173913, 0.30652173913044, 0.055555555555556
75899, 1.4173913043478, 0.33260869565217, 0.055555555555556
75900, 1.4173913043478, 0.30652173913044, 0.027777777777778
75901, 1.4608695652174, 0.30652173913043, 0.47222222222222
75902, 1.4391304347826, 0.30652173913044, 0.44444444444444
75903, 1.4608695652174, 0.33260869565217, 0.44444444444444
75904, 1.4608695652174, 0.30652173913043, 0.41666666666667
75905, 1.4391304347826, 0.30652173913043, 0.38888888888889
75906, 1.4608695652174, 0.33260869565217, 0.38888888888889
75907, 1.4608695652174, 0.30652173913043, 0.36111111111111
75908, 1.4391304347826, 0.30652173913044, 0.33333333333333
75909, 1.4608695652174, 0.33260869565217, 0.33333333333333
75910, 1.4608695652174, 0.30652173913043, 0.30555555555556
75911, 1.4391304347826, 0.30652173913044, 0.27777777777778
75912, 1.4608695652174, 0.33260869565217, 0.27777777777778
75913, 1.4608695652174, 0.30652173913043, 0.25
75914, 1.4391304347826, 0.30652173913044, 0.22222222222222
75915, 1.4608695652174, 0.33260869565217, 0.22222222222222
75916, 1.4608695652174, 0.30652173913043, 0.19444444444444
75917, 1.4391304347826, 0.30652173913044, 0.16666666666667
75918, 1.4608695652174, 0.33260869565217, 0.16666666666667
75919, 1.4608695652174, 0.30652173913043, 0.13888888888889
75920, 1.4391304347826, 0.30652173913044, 0.11111111111111
75921, 1.4608695652174, 0.33260869565217, 0.11111111111111
75922, 1.4608695652174, 0.30652173913043, 0.083333333333333
75923, 1.4391304347826, 0.30652173913044, 0.055555555555556
75924, 1.4608695652174, 0.33260869565217, 0.055555555555556
75925, 1.4608695652174, 0.30652173913043, 0.027777777777778
75926, 1.504347826087, 0.30652173913044, 0.47222222222222
75927, 1.4826086956522, 0.30652173913044, 0.44444444444444
75928, 1.504347826087, 0.33260869565217, 0.44444444444444
75929, 1.504347826087, 0.30652173913044, 0.41666666666667
75930, 1.4826086956522, 0.30652173913044, 0.38888888888889
75931, 1.504347826087, 0.33260869565217, 0.38888888888889
75932, 1.504347826087, 0.30652173913044, 0.36111111111111
75933, 1.4826086956522, 0.30652173913044, 0.33333333333333
75934, 1.504347826087, 0.33260869565217, 0.33333333333333
75935, 1.504347826087, 0.30652173913044, 0.30555555555556
75936, 1.4826086956522, 0.30652173913044, 0.27777777777778
75937, 1.504347826087, 0.33260869565217, 0.27777777777778
75938, 1.504347826087, 0.30652173913044, 0.25
75939, 1.4826086956522, 0.30652173913044, 0.22222222222222
75940, 1.504347826087, 0.33260869565217, 0.22222222222222
75941, 1.504347826087, 0.30652173913044, 0.19444444444444
75942, 1.4826086956522, 0.30652173913044, 0.16666666666667
75943, 1.504347826087, 0.33260869565217, 0.16666666666667
75944, 1.504347826087, 0.30652173913044, 0.13888888888889
75945, 1.4826086956522, 0.30652173913044, 0.11111111111111
75946, 1.504347826087, 0.33260869565217, 0.11111111111111
75947, 1.504347826087, 0.30652173913044, 0.083333333333333
75948, 1.4826086956522, 0.30652173913044, 0.055555555555556
75949, 1.504347826087, 0.33260869565217, 0.055555555555556
75950, 1.504347826087, 0.30652173913044, 0.027777777777778
75951, 1.5478260869565, 0.30652173913044, 0.47222222222222
75952, 1.5260869565217, 0.30652173913044, 0.44444444444444
75953, 1.5478260869565, 0.33260869565217, 0.44444444444444
75954, 1.5478260869565, 0.30652173913044, 0.41666666666667
75955, 1.5260869565217, 0.30652173913044, 0.38888888888889
75956, 1.5478260869565, 0.33260869565217, 0.38888888888889
75957, 1.5478260869565, 0.30652173913044, 0.36111111111111
75958, 1.5260869565217, 0.30652173913044, 0.33333333333333
75959, 1.5478260869565, 0.33260869565217, 0.33333333333333
75960, 1.5478260869565, 0.30652173913044, 0.30555555555556
75961, 1.5260869565217, 0.30652173913044, 0.27777777777778
75962, 1.5478260869565, 0.33260869565217, 0.27777777777778
75963, 1.5478260869565, 0.30652173913044, 0.25
75964, 1.5260869565217, 0.30652173913044, 0.22222222222222
75965, 1.5478260869565, 0.33260869565217, 0.22222222222222
75966, 1.5478260869565, 0.30652173913044, 0.19444444444444
75967, 1.5260869565217, 0.30652173913044, 0.16666666666667
75968, 1.5478260869565, 0.33260869565217, 0.16666666666667
75969, 1.5478260869565, 0.30652173913044, 0.13888888888889
75970, 1.5260869565217, 0.30652173913044, 0.11111111111111
75971, 1.5478260869565, 0.33260869565217, 0.11111111111111
75972, 1.5478260869565, 0.30652173913044, 0.083333333333333
75973, 1.5260869565217, 0.30652173913044, 0.055555555555556
75974, 1.5478260869565, 0.33260869565217, 0.055555555555556
75975, 1.5478260869565, 0.30652173913044, 0.027777777777778
75976, 1.5913043478261, 0.30652173913044, 0.47222222222222
75977, 1.5695652173913, 0.30652173913044, 0.44444444444444
75978, 1.5913043478261, 0.33260869565217, 0.44444444444444
75979, 1.5913043478261, 0.30652173913044, 0.41666666666667
75980, 1.5695652173913, 0.30652173913044, 0.38888888888889
75981, 1.5913043478261, 0.33260869565217, 0.38888888888889
75982, 1.5913043478261, 0.30652173913044, 0.36111111111111
75983, 1.5695652173913, 0.30652173913044, 0.33333333333333
75984, 1.5913043478261, 0.33260869565217, 0.33333333333333
75985, 1.5913043478261, 0.30652173913044, 0.30555555555556
75986, 1.5695652173913, 0.30652173913044, 0.27777777777778
75987, 1.5913043478261, 0.33260869565217, 0.27777777777778
75988, 1.5913043478261, 0.30652173913044, 0.25
75989, 1.5695652173913, 0.30652173913044, 0.22222222222222
75990, 1.5913043478261, 0.33260869565217, 0.22222222222222
75991, 1.5913043478261, 0.30652173913044, 0.19444444444444
75992, 1.5695652173913, 0.30652173913044, 0.16666666666667
75993, 1.5913043478261, 0.33260869565217, 0.16666666666667
75994, 1.5913043478261, 0.30652173913044, 0.13888888888889
75995, 1.5695652173913, 0.30652173913044, 0.11111111111111
75996, 1.5913043478261, 0.33260869565217, 0.11111111111111
75997, 1.5913043478261, 0.30652173913044, 0.083333333333333
75998, 1.5695652173913, 0.30652173913044, 0.055555555555556
75999, 1.5913043478261, 0.33260869565217, 0.055555555555556
76000, 1.5913043478261, 0.30652173913044, 0.027777777777778
76001, 1.6347826086957, 0.30652173913043, 0.47222222222222
76002, 1.6130434782609, 0.30652173913044, 0.44444444444444
76003, 1.6347826086957, 0.33260869565217, 0.44444444444444
76004, 1.6347826086957, 0.30652173913043, 0.41666666666667
76005, 1.6130434782609, 0.30652173913043, 0.38888888888889
76006, 1.6347826086957, 0.33260869565217, 0.38888888888889
76007, 1.6347826086957, 0.30652173913043, 0.36111111111111
76008, 1.6130434782609, 0.30652173913044, 0.33333333333333
76009, 1.6347826086957, 0.33260869565217, 0.33333333333333
76010, 1.6347826086957, 0.30652173913044, 0.30555555555556
76011, 1.6130434782609, 0.30652173913044, 0.27777777777778
76012, 1.6347826086957, 0.33260869565217, 0.27777777777778
76013, 1.6347826086957, 0.30652173913043, 0.25
76014, 1.6130434782609, 0.30652173913043, 0.22222222222222
76015, 1.6347826086957, 0.33260869565217, 0.22222222222222
76016, 1.6347826086957, 0.30652173913043, 0.19444444444444
76017, 1.6130434782609, 0.30652173913043, 0.16666666666667
76018, 1.6347826086957, 0.33260869565217, 0.16666666666667
76019, 1.6347826086957, 0.30652173913043, 0.13888888888889
76020, 1.6130434782609, 0.30652173913043, 0.11111111111111
76021, 1.6347826086957, 0.33260869565217, 0.11111111111111
76022, 1.6347826086957, 0.30652173913043, 0.083333333333333
76023, 1.6130434782609, 0.30652173913043, 0.055555555555556
76024, 1.6347826086957, 0.33260869565217, 0.055555555555556
76025, 1.6347826086957, 0.30652173913043, 0.027777777777778
76026, 1.6782608695652, 0.30652173913043, 0.47222222222222
76027, 1.6565217391304, 0.30652173913043, 0.44444444444444
76028, 1.6782608695652, 0.33260869565217, 0.44444444444444
76029, 1.6782608695652, 0.30652173913043, 0.41666666666667
76030, 1.6565217391304, 0.30652173913043, 0.38888888888889
76031, 1.6782608695652, 0.33260869565217, 0.38888888888889
76032, 1.6782608695652, 0.30652173913043, 0.36111111111111
76033, 1.6565217391304, 0.30652173913044, 0.33333333333333
76034, 1.6782608695652, 0.33260869565217, 0.33333333333333
76035, 1.6782608695652, 0.30652173913043, 0.30555555555556
76036, 1.6565217391304, 0.30652173913043, 0.27777777777778
76037, 1.6782608695652, 0.33260869565217, 0.27777777777778
76038, 1.6782608695652, 0.30652173913043, 0.25
76039, 1.6565217391304, 0.30652173913043, 0.22222222222222
76040, 1.6782608695652, 0.33260869565217, 0.22222222222222
76041, 1.6782608695652, 0.30652173913043, 0.19444444444444
76042, 1.6565217391304, 0.30652173913043, 0.16666666666667
76043, 1.6782608695652, 0.33260869565217, 0.16666666666667
76044, 1.6782608695652, 0.30652173913043, 0.13888888888889
76045, 1.6565217391304, 0.30652173913043, 0.11111111111111
76046, 1.6782608695652, 0.33260869565217, 0.11111111111111
76047, 1.6782608695652, 0.30652173913043, 0.083333333333333
76048, 1.6565217391304, 0.30652173913043, 0.055555555555556
76049, 1.6782608695652, 0.33260869565217, 0.055555555555556
76050, 1.6782608695652, 0.30652173913043, 0.027777777777778
76051, 1.7217391304348, 0.30652173913043, 0.47222222222222
76052, 1.7, 0.30652173913043, 0.44444444444444
76053, 1.7217391304348, 0.33260869565217, 0.44444444444444
76054, 1.7217391304348, 0.30652173913043, 0.41666666666667
76055, 1.7, 0.30652173913043, 0.38888888888889
76056, 1.7217391304348, 0.33260869565217, 0.38888888888889
76057, 1.7217391304348, 0.30652173913043, 0.36111111111111
76058, 1.7, 0.30652173913044, 0.33333333333333
76059, 1.7217391304348, 0.33260869565217, 0.33333333333333
76060, 1.7217391304348, 0.30652173913044, 0.30555555555556
76061, 1.7, 0.30652173913043, 0.27777777777778
76062, 1.7217391304348, 0.33260869565217, 0.27777777777778
76063, 1.7217391304348, 0.30652173913043, 0.25
76064, 1.7, 0.30652173913043, 0.22222222222222
76065, 1.7217391304348, 0.33260869565217, 0.22222222222222
76066, 1.7217391304348, 0.30652173913043, 0.19444444444444
76067, 1.7, 0.30652173913043, 0.16666666666667
76068, 1.7217391304348, 0.33260869565217, 0.16666666666667
76069, 1.7217391304348, 0.30652173913043, 0.13888888888889
76070, 1.7, 0.30652173913043, 0.11111111111111
76071, 1.7217391304348, 0.33260869565217, 0.11111111111111
76072, 1.7217391304348, 0.30652173913043, 0.083333333333333
76073, 1.7, 0.30652173913043, 0.055555555555556
76074, 1.7217391304348, 0.33260869565217, 0.055555555555556
76075, 1.7217391304348, 0.30652173913043, 0.027777777777778
76076, 1.7652173913043, 0.30652173913043, 0.47222222222222
76077, 1.7434782608696, 0.30652173913043, 0.44444444444444
76078, 1.7652173913043, 0.33260869565217, 0.44444444444444
76079, 1.7652173913043, 0.30652173913043, 0.41666666666667
76080, 1.7434782608696, 0.30652173913043, 0.38888888888889
76081, 1.7652173913043, 0.33260869565217, 0.38888888888889
76082, 1.7652173913043, 0.30652173913043, 0.36111111111111
76083, 1.7434782608696, 0.30652173913044, 0.33333333333333
76084, 1.7652173913043, 0.33260869565217, 0.33333333333333
76085, 1.7652173913043, 0.30652173913043, 0.30555555555556
76086, 1.7434782608696, 0.30652173913043, 0.27777777777778
76087, 1.7652173913043, 0.33260869565217, 0.27777777777778
76088, 1.7652173913043, 0.30652173913043, 0.25
76089, 1.7434782608696, 0.30652173913043, 0.22222222222222
76090, 1.7652173913043, 0.33260869565217, 0.22222222222222
76091, 1.7652173913043, 0.30652173913043, 0.19444444444444
76092, 1.7434782608696, 0.30652173913043, 0.16666666666667
76093, 1.7652173913043, 0.33260869565217, 0.16666666666667
76094, 1.7652173913043, 0.30652173913043, 0.13888888888889
76095, 1.7434782608696, 0.30652173913043, 0.11111111111111
76096, 1.7652173913043, 0.33260869565217, 0.11111111111111
76097, 1.7652173913043, 0.30652173913043, 0.083333333333333
76098, 1.7434782608696, 0.30652173913043, 0.055555555555556
76099, 1.7652173913043, 0.33260869565217, 0.055555555555556
76100, 1.7652173913043, 0.30652173913043, 0.027777777777778
76101, 1.8086956521739, 0.30652173913044, 0.47222222222222
76102, 1.7869565217391, 0.30652173913044, 0.44444444444444
76103, 1.8086956521739, 0.33260869565217, 0.44444444444444
76104, 1.8086956521739, 0.30652173913044, 0.41666666666667
76105, 1.7869565217391, 0.30652173913044, 0.38888888888889
76106, 1.8086956521739, 0.33260869565217, 0.38888888888889
76107, 1.8086956521739, 0.30652173913044, 0.36111111111111
76108, 1.7869565217391, 0.30652173913044, 0.33333333333333
76109, 1.8086956521739, 0.33260869565217, 0.33333333333333
76110, 1.8086956521739, 0.30652173913044, 0.30555555555556
76111, 1.7869565217391, 0.30652173913044, 0.27777777777778
76112, 1.8086956521739, 0.33260869565217, 0.27777777777778
76113, 1.8086956521739, 0.30652173913044, 0.25
76114, 1.7869565217391, 0.30652173913044, 0.22222222222222
76115, 1.8086956521739, 0.33260869565217, 0.22222222222222
76116, 1.8086956521739, 0.30652173913044, 0.19444444444444
76117, 1.7869565217391, 0.30652173913044, 0.16666666666667
76118, 1.8086956521739, 0.33260869565217, 0.16666666666667
76119, 1.8086956521739, 0.30652173913044, 0.13888888888889
76120, 1.7869565217391, 0.30652173913044, 0.11111111111111
76121, 1.8086956521739, 0.33260869565217, 0.11111111111111
76122, 1.8086956521739, 0.30652173913044, 0.083333333333333
76123, 1.7869565217391, 0.30652173913044, 0.055555555555556
76124, 1.8086956521739, 0.33260869565217, 0.055555555555556
76125, 1.8086956521739, 0.30652173913044, 0.027777777777778
76126, 1.8521739130435, 0.30652173913043, 0.47222222222222
76127, 1.8304347826087, 0.30652173913043, 0.44444444444444
76128, 1.8521739130435, 0.33260869565217, 0.44444444444444
76129, 1.8521739130435, 0.30652173913043, 0.41666666666667
76130, 1.8304347826087, 0.30652173913044, 0.38888888888889
76131, 1.8521739130435, 0.33260869565217, 0.38888888888889
76132, 1.8521739130435, 0.30652173913043, 0.36111111111111
76133, 1.8304347826087, 0.30652173913044, 0.33333333333333
76134, 1.8521739130435, 0.33260869565217, 0.33333333333333
76135, 1.8521739130435, 0.30652173913043, 0.30555555555556
76136, 1.8304347826087, 0.30652173913044, 0.27777777777778
76137, 1.8521739130435, 0.33260869565217, 0.27777777777778
76138, 1.8521739130435, 0.30652173913043, 0.25
76139, 1.8304347826087, 0.30652173913044, 0.22222222222222
76140, 1.8521739130435, 0.33260869565217, 0.22222222222222
76141, 1.8521739130435, 0.30652173913043, 0.19444444444444
76142, 1.8304347826087, 0.30652173913044, 0.16666666666667
76143, 1.8521739130435, 0.33260869565217, 0.16666666666667
76144, 1.8521739130435, 0.30652173913043, 0.13888888888889
76145, 1.8304347826087, 0.30652173913044, 0.11111111111111
76146, 1.8521739130435, 0.33260869565217, 0.11111111111111
76147, 1.8521739130435, 0.30652173913043, 0.083333333333333
76148, 1.8304347826087, 0.30652173913044, 0.055555555555556
76149, 1.8521739130435, 0.33260869565217, 0.055555555555556
76150, 1.8521739130435, 0.30652173913043, 0.027777777777778
76151, 1.895652173913, 0.30652173913044, 0.47222222222222
76152, 1.8739130434783, 0.30652173913043, 0.44444444444444
76153, 1.895652173913, 0.33260869565217, 0.44444444444444
76154, 1.895652173913, 0.30652173913044, 0.41666666666667
76155, 1.8739130434783, 0.30652173913043, 0.38888888888889
76156, 1.895652173913, 0.33260869565217, 0.38888888888889
76157, 1.895652173913, 0.30652173913044, 0.36111111111111
76158, 1.8739130434783, 0.30652173913043, 0.33333333333333
76159, 1.895652173913, 0.33260869565217, 0.33333333333333
76160, 1.895652173913, 0.30652173913044, 0.30555555555556
76161, 1.8739130434783, 0.30652173913043, 0.27777777777778
76162, 1.895652173913, 0.33260869565217, 0.27777777777778
76163, 1.895652173913, 0.30652173913044, 0.25
76164, 1.8739130434783, 0.30652173913043, 0.22222222222222
76165, 1.895652173913, 0.33260869565217, 0.22222222222222
76166, 1.895652173913, 0.30652173913044, 0.19444444444444
76167, 1.8739130434783, 0.30652173913043, 0.16666666666667
76168, 1.895652173913, 0.33260869565217, 0.16666666666667
76169, 1.895652173913, 0.30652173913044, 0.13888888888889
76170, 1.8739130434783, 0.30652173913043, 0.11111111111111
76171, 1.895652173913, 0.33260869565217, 0.11111111111111
76172, 1.895652173913, 0.30652173913044, 0.083333333333333
76173, 1.8739130434783, 0.30652173913043, 0.055555555555556
76174, 1.895652173913, 0.33260869565217, 0.055555555555556
76175, 1.895652173913, 0.30652173913044, 0.027777777777778
76176, 1.9391304347826, 0.30652173913043, 0.47222222222222
76177, 1.9173913043478, 0.30652173913044, 0.44444444444444
76178, 1.9391304347826, 0.33260869565217, 0.44444444444444
76179, 1.9391304347826, 0.30652173913043, 0.41666666666667
76180, 1.9173913043478, 0.30652173913044, 0.38888888888889
76181, 1.9391304347826, 0.33260869565217, 0.38888888888889
76182, 1.9391304347826, 0.30652173913043, 0.36111111111111
76183, 1.9173913043478, 0.30652173913044, 0.33333333333333
76184, 1.9391304347826, 0.33260869565217, 0.33333333333333
76185, 1.9391304347826, 0.30652173913044, 0.30555555555556
76186, 1.9173913043478, 0.30652173913044, 0.27777777777778
76187, 1.9391304347826, 0.33260869565217, 0.27777777777778
76188, 1.9391304347826, 0.30652173913043, 0.25
76189, 1.9173913043478, 0.30652173913044, 0.22222222222222
76190, 1.9391304347826, 0.33260869565217, 0.22222222222222
76191, 1.9391304347826, 0.30652173913043, 0.19444444444444
76192, 1.9173913043478, 0.30652173913044, 0.16666666666667
76193, 1.9391304347826, 0.33260869565217, 0.16666666666667
76194, 1.9391304347826, 0.30652173913043, 0.13888888888889
76195, 1.9173913043478, 0.30652173913044, 0.11111111111111
76196, 1.9391304347826, 0.33260869565217, 0.11111111111111
76197, 1.9391304347826, 0.30652173913043, 0.083333333333333
76198, 1.9173913043478, 0.30652173913044, 0.055555555555556
76199, 1.9391304347826, 0.33260869565217, 0.055555555555556
76200, 1.9391304347826, 0.30652173913043, 0.027777777777778
76201, 1.9826086956522, 0.30652173913044, 0.47222222222222
76202, 1.9608695652174, 0.30652173913044, 0.44444444444444
76203, 1.9826086956522, 0.33260869565217, 0.44444444444444
76204, 1.9826086956522, 0.30652173913044, 0.41666666666667
76205, 1.9608695652174, 0.30652173913044, 0.38888888888889
76206, 1.9826086956522, 0.33260869565217, 0.38888888888889
76207, 1.9826086956522, 0.30652173913044, 0.36111111111111
76208, 1.9608695652174, 0.30652173913044, 0.33333333333333
76209, 1.9826086956522, 0.33260869565217, 0.33333333333333
76210, 1.9826086956522, 0.30652173913044, 0.30555555555556
76211, 1.9608695652174, 0.30652173913044, 0.27777777777778
76212, 1.9826086956522, 0.33260869565217, 0.27777777777778
76213, 1.9826086956522, 0.30652173913044, 0.25
76214, 1.9608695652174, 0.30652173913044, 0.22222222222222
76215, 1.9826086956522, 0.33260869565217, 0.22222222222222
76216, 1.9826086956522, 0.30652173913044, 0.19444444444444
76217, 1.9608695652174, 0.30652173913044, 0.16666666666667
76218, 1.9826086956522, 0.33260869565217, 0.16666666666667
76219, 1.9826086956522, 0.30652173913044, 0.13888888888889
76220, 1.9608695652174, 0.30652173913044, 0.11111111111111
76221, 1.9826086956522, 0.33260869565217, 0.11111111111111
76222, 1.9826086956522, 0.30652173913044, 0.083333333333333
76223, 1.9608695652174, 0.30652173913044, 0.055555555555556
76224, 1.9826086956522, 0.33260869565217, 0.055555555555556
76225, 1.9826086956522, 0.30652173913044, 0.027777777777778
76226, 2.0260869565217, 0.30652173913044, 0.47222222222222
76227, 2.004347826087, 0.30652173913044, 0.44444444444444
76228, 2.0260869565217, 0.33260869565217, 0.44444444444444
76229, 2.0260869565217, 0.30652173913044, 0.41666666666667
76230, 2.004347826087, 0.30652173913044, 0.38888888888889
76231, 2.0260869565217, 0.33260869565217, 0.38888888888889
76232, 2.0260869565217, 0.30652173913044, 0.36111111111111
76233, 2.004347826087, 0.30652173913044, 0.33333333333333
76234, 2.0260869565217, 0.33260869565217, 0.33333333333333
76235, 2.0260869565217, 0.30652173913044, 0.30555555555556
76236, 2.004347826087, 0.30652173913044, 0.27777777777778
76237, 2.0260869565217, 0.33260869565217, 0.27777777777778
76238, 2.0260869565217, 0.30652173913044, 0.25
76239, 2.004347826087, 0.30652173913044, 0.22222222222222
76240, 2.0260869565217, 0.33260869565217, 0.22222222222222
76241, 2.0260869565217, 0.30652173913044, 0.19444444444444
76242, 2.004347826087, 0.30652173913044, 0.16666666666667
76243, 2.0260869565217, 0.33260869565217, 0.16666666666667
76244, 2.0260869565217, 0.30652173913044, 0.13888888888889
76245, 2.004347826087, 0.30652173913044, 0.11111111111111
76246, 2.0260869565217, 0.33260869565217, 0.11111111111111
76247, 2.0260869565217, 0.30652173913044, 0.083333333333333
76248, 2.004347826087, 0.30652173913044, 0.055555555555556
76249, 2.0260869565217, 0.33260869565217, 0.055555555555556
76250, 2.0260869565217, 0.30652173913044, 0.027777777777778
76251, 2.0695652173913, 0.30652173913043, 0.47222222222222
76252, 2.0478260869565, 0.30652173913044, 0.44444444444444
76253, 2.0695652173913, 0.33260869565217, 0.44444444444444
76254, 2.0695652173913, 0.30652173913043, 0.41666666666667
76255, 2.0478260869565, 0.30652173913044, 0.38888888888889
76256, 2.0695652173913, 0.33260869565217, 0.38888888888889
76257, 2.0695652173913, 0.30652173913043, 0.36111111111111
76258, 2.0478260869565, 0.30652173913044, 0.33333333333333
76259, 2.0695652173913, 0.33260869565217, 0.33333333333333
76260, 2.0695652173913, 0.30652173913044, 0.30555555555556
76261, 2.0478260869565, 0.30652173913044, 0.27777777777778
76262, 2.0695652173913, 0.33260869565217, 0.27777777777778
76263, 2.0695652173913, 0.30652173913043, 0.25
76264, 2.0478260869565, 0.30652173913044, 0.22222222222222
76265, 2.0695652173913, 0.33260869565217, 0.22222222222222
76266, 2.0695652173913, 0.30652173913043, 0.19444444444444
76267, 2.0478260869565, 0.30652173913044, 0.16666666666667
76268, 2.0695652173913, 0.33260869565217, 0.16666666666667
76269, 2.0695652173913, 0.30652173913043, 0.13888888888889
76270, 2.0478260869565, 0.30652173913044, 0.11111111111111
76271, 2.0695652173913, 0.33260869565217, 0.11111111111111
76272, 2.0695652173913, 0.30652173913043, 0.083333333333333
76273, 2.0478260869565, 0.30652173913044, 0.055555555555556
76274, 2.0695652173913, 0.33260869565217, 0.055555555555556
76275, 2.0695652173913, 0.30652173913043, 0.027777777777778
76276, 2.1130434782609, 0.30652173913043, 0.47222222222222
76277, 2.0913043478261, 0.30652173913043, 0.44444444444444
76278, 2.1130434782609, 0.33260869565217, 0.44444444444444
76279, 2.1130434782609, 0.30652173913043, 0.41666666666667
76280, 2.0913043478261, 0.30652173913043, 0.38888888888889
76281, 2.1130434782609, 0.33260869565217, 0.38888888888889
76282, 2.1130434782609, 0.30652173913043, 0.36111111111111
76283, 2.0913043478261, 0.30652173913044, 0.33333333333333
76284, 2.1130434782609, 0.33260869565217, 0.33333333333333
76285, 2.1130434782609, 0.30652173913044, 0.30555555555556
76286, 2.0913043478261, 0.30652173913043, 0.27777777777778
76287, 2.1130434782609, 0.33260869565217, 0.27777777777778
76288, 2.1130434782609, 0.30652173913043, 0.25
76289, 2.0913043478261, 0.30652173913043, 0.22222222222222
76290, 2.1130434782609, 0.33260869565217, 0.22222222222222
76291, 2.1130434782609, 0.30652173913043, 0.19444444444444
76292, 2.0913043478261, 0.30652173913043, 0.16666666666667
76293, 2.1130434782609, 0.33260869565217, 0.16666666666667
76294, 2.1130434782609, 0.30652173913043, 0.13888888888889
76295, 2.0913043478261, 0.30652173913043, 0.11111111111111
76296, 2.1130434782609, 0.33260869565217, 0.11111111111111
76297, 2.1130434782609, 0.30652173913043, 0.083333333333333
76298, 2.0913043478261, 0.30652173913043, 0.055555555555556
76299, 2.1130434782609, 0.33260869565217, 0.055555555555556
76300, 2.1130434782609, 0.30652173913043, 0.027777777777778
76301, 2.1565217391304, 0.30652173913043, 0.47222222222222
76302, 2.1347826086957, 0.30652173913044, 0.44444444444444
76303, 2.1565217391304, 0.33260869565217, 0.44444444444444
76304, 2.1565217391304, 0.30652173913043, 0.41666666666667
76305, 2.1347826086957, 0.30652173913043, 0.38888888888889
76306, 2.1565217391304, 0.33260869565217, 0.38888888888889
76307, 2.1565217391304, 0.30652173913043, 0.36111111111111
76308, 2.1347826086957, 0.30652173913044, 0.33333333333333
76309, 2.1565217391304, 0.33260869565217, 0.33333333333333
76310, 2.1565217391304, 0.30652173913044, 0.30555555555556
76311, 2.1347826086957, 0.30652173913043, 0.27777777777778
76312, 2.1565217391304, 0.33260869565217, 0.27777777777778
76313, 2.1565217391304, 0.30652173913043, 0.25
76314, 2.1347826086957, 0.30652173913043, 0.22222222222222
76315, 2.1565217391304, 0.33260869565217, 0.22222222222222
76316, 2.1565217391304, 0.30652173913043, 0.19444444444444
76317, 2.1347826086957, 0.30652173913043, 0.16666666666667
76318, 2.1565217391304, 0.33260869565217, 0.16666666666667
76319, 2.1565217391304, 0.30652173913043, 0.13888888888889
76320, 2.1347826086957, 0.30652173913043, 0.11111111111111
76321, 2.1565217391304, 0.33260869565217, 0.11111111111111
76322, 2.1565217391304, 0.30652173913043, 0.083333333333333
76323, 2.1347826086957, 0.30652173913043, 0.055555555555556
76324, 2.1565217391304, 0.33260869565217, 0.055555555555556
76325, 2.1565217391304, 0.30652173913043, 0.027777777777778
76326, 2.1782608695652, 0.30652173913044, 0.44444444444444
76327, 2.1782608695652, 0.30652173913043, 0.38888888888889
76328, 2.1782608695652, 0.30652173913044, 0.33333333333333
76329, 2.1782608695652, 0.30652173913044, 0.27777777777778
76330, 2.1782608695652, 0.30652173913044, 0.22222222222222
76331, 2.1782608695652, 0.30652173913044, 0.16666666666667
76332, 2.1782608695652, 0.30652173913044, 0.11111111111111
76333, 2.1782608695652, 0.30652173913044, 0.055555555555556
76334, 1.2434782608696, 0.25434782608696, 0.47222222222222
76335, 1.2217391304348, 0.25434782608696, 0.44444444444444
76336, 1.2434782608696, 0.2804347826087, 0.44444444444444
76337, 1.2434782608696, 0.25434782608696, 0.41666666666667
76338, 1.2217391304348, 0.25434782608696, 0.38888888888889
76339, 1.2434782608696, 0.2804347826087, 0.38888888888889
76340, 1.2434782608696, 0.25434782608696, 0.36111111111111
76341, 1.2217391304348, 0.25434782608696, 0.33333333333333
76342, 1.2434782608696, 0.2804347826087, 0.33333333333333
76343, 1.2434782608696, 0.25434782608696, 0.30555555555556
76344, 1.2217391304348, 0.25434782608696, 0.27777777777778
76345, 1.2434782608696, 0.2804347826087, 0.27777777777778
76346, 1.2434782608696, 0.25434782608696, 0.25
76347, 1.2217391304348, 0.25434782608696, 0.22222222222222
76348, 1.2434782608696, 0.2804347826087, 0.22222222222222
76349, 1.2434782608696, 0.25434782608696, 0.19444444444444
76350, 1.2217391304348, 0.25434782608696, 0.16666666666667
76351, 1.2434782608696, 0.2804347826087, 0.16666666666667
76352, 1.2434782608696, 0.25434782608696, 0.13888888888889
76353, 1.2217391304348, 0.25434782608696, 0.11111111111111
76354, 1.2434782608696, 0.2804347826087, 0.11111111111111
76355, 1.2434782608696, 0.25434782608696, 0.083333333333333
76356, 1.2217391304348, 0.25434782608696, 0.055555555555556
76357, 1.2434782608696, 0.2804347826087, 0.055555555555556
76358, 1.2434782608696, 0.25434782608696, 0.027777777777778
76359, 1.2869565217391, 0.25434782608696, 0.47222222222222
76360, 1.2652173913043, 0.25434782608696, 0.44444444444444
76361, 1.2869565217391, 0.2804347826087, 0.44444444444444
76362, 1.2869565217391, 0.25434782608696, 0.41666666666667
76363, 1.2652173913043, 0.25434782608696, 0.38888888888889
76364, 1.2869565217391, 0.2804347826087, 0.38888888888889
76365, 1.2869565217391, 0.25434782608696, 0.36111111111111
76366, 1.2652173913043, 0.25434782608696, 0.33333333333333
76367, 1.2869565217391, 0.2804347826087, 0.33333333333333
76368, 1.2869565217391, 0.25434782608696, 0.30555555555556
76369, 1.2652173913043, 0.25434782608696, 0.27777777777778
76370, 1.2869565217391, 0.2804347826087, 0.27777777777778
76371, 1.2869565217391, 0.25434782608696, 0.25
76372, 1.2652173913043, 0.25434782608696, 0.22222222222222
76373, 1.2869565217391, 0.2804347826087, 0.22222222222222
76374, 1.2869565217391, 0.25434782608696, 0.19444444444444
76375, 1.2652173913043, 0.25434782608696, 0.16666666666667
76376, 1.2869565217391, 0.2804347826087, 0.16666666666667
76377, 1.2869565217391, 0.25434782608696, 0.13888888888889
76378, 1.2652173913043, 0.25434782608696, 0.11111111111111
76379, 1.2869565217391, 0.2804347826087, 0.11111111111111
76380, 1.2869565217391, 0.25434782608696, 0.083333333333333
76381, 1.2652173913043, 0.25434782608696, 0.055555555555556
76382, 1.2869565217391, 0.2804347826087, 0.055555555555556
76383, 1.2869565217391, 0.25434782608696, 0.027777777777778
76384, 1.3304347826087, 0.25434782608696, 0.47222222222222
76385, 1.3086956521739, 0.25434782608696, 0.44444444444444
76386, 1.3304347826087, 0.2804347826087, 0.44444444444444
76387, 1.3304347826087, 0.25434782608696, 0.41666666666667
76388, 1.3086956521739, 0.25434782608696, 0.38888888888889
76389, 1.3304347826087, 0.2804347826087, 0.38888888888889
76390, 1.3304347826087, 0.25434782608696, 0.36111111111111
76391, 1.3086956521739, 0.25434782608696, 0.33333333333333
76392, 1.3304347826087, 0.2804347826087, 0.33333333333333
76393, 1.3304347826087, 0.25434782608696, 0.30555555555556
76394, 1.3086956521739, 0.25434782608696, 0.27777777777778
76395, 1.3304347826087, 0.2804347826087, 0.27777777777778
76396, 1.3304347826087, 0.25434782608696, 0.25
76397, 1.3086956521739, 0.25434782608696, 0.22222222222222
76398, 1.3304347826087, 0.2804347826087, 0.22222222222222
76399, 1.3304347826087, 0.25434782608696, 0.19444444444444
76400, 1.3086956521739, 0.25434782608696, 0.16666666666667
76401, 1.3304347826087, 0.2804347826087, 0.16666666666667
76402, 1.3304347826087, 0.25434782608696, 0.13888888888889
76403, 1.3086956521739, 0.25434782608696, 0.11111111111111
76404, 1.3304347826087, 0.2804347826087, 0.11111111111111
76405, 1.3304347826087, 0.25434782608696, 0.083333333333333
76406, 1.3086956521739, 0.25434782608696, 0.055555555555556
76407, 1.3304347826087, 0.2804347826087, 0.055555555555556
76408, 1.3304347826087, 0.25434782608696, 0.027777777777778
76409, 1.3739130434783, 0.25434782608696, 0.47222222222222
76410, 1.3521739130435, 0.25434782608696, 0.44444444444444
76411, 1.3739130434783, 0.2804347826087, 0.44444444444444
76412, 1.3739130434783, 0.25434782608696, 0.41666666666667
76413, 1.3521739130435, 0.25434782608696, 0.38888888888889
76414, 1.3739130434783, 0.2804347826087, 0.38888888888889
76415, 1.3739130434783, 0.25434782608696, 0.36111111111111
76416, 1.3521739130435, 0.25434782608696, 0.33333333333333
76417, 1.3739130434783, 0.2804347826087, 0.33333333333333
76418, 1.3739130434783, 0.25434782608696, 0.30555555555556
76419, 1.3521739130435, 0.25434782608696, 0.27777777777778
76420, 1.3739130434783, 0.2804347826087, 0.27777777777778
76421, 1.3739130434783, 0.25434782608696, 0.25
76422, 1.3521739130435, 0.25434782608696, 0.22222222222222
76423, 1.3739130434783, 0.2804347826087, 0.22222222222222
76424, 1.3739130434783, 0.25434782608696, 0.19444444444444
76425, 1.3521739130435, 0.25434782608696, 0.16666666666667
76426, 1.3739130434783, 0.2804347826087, 0.16666666666667
76427, 1.3739130434783, 0.25434782608696, 0.13888888888889
76428, 1.3521739130435, 0.25434782608696, 0.11111111111111
76429, 1.3739130434783, 0.2804347826087, 0.11111111111111
76430, 1.3739130434783, 0.25434782608696, 0.083333333333333
76431, 1.3521739130435, 0.25434782608696, 0.055555555555556
76432, 1.3739130434783, 0.2804347826087, 0.055555555555556
76433, 1.3739130434783, 0.25434782608696, 0.027777777777778
76434, 1.4173913043478, 0.25434782608696, 0.47222222222222
76435, 1.395652173913, 0.25434782608696, 0.44444444444444
76436, 1.4173913043478, 0.2804347826087, 0.44444444444444
76437, 1.4173913043478, 0.25434782608696, 0.41666666666667
76438, 1.395652173913, 0.25434782608696, 0.38888888888889
76439, 1.4173913043478, 0.2804347826087, 0.38888888888889
76440, 1.4173913043478, 0.25434782608696, 0.36111111111111
76441, 1.395652173913, 0.25434782608696, 0.33333333333333
76442, 1.4173913043478, 0.2804347826087, 0.33333333333333
76443, 1.4173913043478, 0.25434782608696, 0.30555555555556
76444, 1.395652173913, 0.25434782608696, 0.27777777777778
76445, 1.4173913043478, 0.2804347826087, 0.27777777777778
76446, 1.4173913043478, 0.25434782608696, 0.25
76447, 1.395652173913, 0.25434782608696, 0.22222222222222
76448, 1.4173913043478, 0.2804347826087, 0.22222222222222
76449, 1.4173913043478, 0.25434782608696, 0.19444444444444
76450, 1.395652173913, 0.25434782608696, 0.16666666666667
76451, 1.4173913043478, 0.2804347826087, 0.16666666666667
76452, 1.4173913043478, 0.25434782608696, 0.13888888888889
76453, 1.395652173913, 0.25434782608696, 0.11111111111111
76454, 1.4173913043478, 0.2804347826087, 0.11111111111111
76455, 1.4173913043478, 0.25434782608696, 0.083333333333333
76456, 1.395652173913, 0.25434782608696, 0.055555555555556
76457, 1.4173913043478, 0.2804347826087, 0.055555555555556
76458, 1.4173913043478, 0.25434782608696, 0.027777777777778
76459, 1.4608695652174, 0.25434782608696, 0.47222222222222
76460, 1.4391304347826, 0.25434782608696, 0.44444444444444
76461, 1.4608695652174, 0.2804347826087, 0.44444444444444
76462, 1.4608695652174, 0.25434782608696, 0.41666666666667
76463, 1.4391304347826, 0.25434782608696, 0.38888888888889
76464, 1.4608695652174, 0.2804347826087, 0.38888888888889
76465, 1.4608695652174, 0.25434782608696, 0.36111111111111
76466, 1.4391304347826, 0.25434782608696, 0.33333333333333
76467, 1.4608695652174, 0.2804347826087, 0.33333333333333
76468, 1.4608695652174, 0.25434782608696, 0.30555555555556
76469, 1.4391304347826, 0.25434782608696, 0.27777777777778
76470, 1.4608695652174, 0.2804347826087, 0.27777777777778
76471, 1.4608695652174, 0.25434782608696, 0.25
76472, 1.4391304347826, 0.25434782608696, 0.22222222222222
76473, 1.4608695652174, 0.2804347826087, 0.22222222222222
76474, 1.4608695652174, 0.25434782608696, 0.19444444444444
76475, 1.4391304347826, 0.25434782608696, 0.16666666666667
76476, 1.4608695652174, 0.2804347826087, 0.16666666666667
76477, 1.4608695652174, 0.25434782608696, 0.13888888888889
76478, 1.4391304347826, 0.25434782608696, 0.11111111111111
76479, 1.4608695652174, 0.2804347826087, 0.11111111111111
76480, 1.4608695652174, 0.25434782608696, 0.083333333333333
76481, 1.4391304347826, 0.25434782608696, 0.055555555555556
76482, 1.4608695652174, 0.2804347826087, 0.055555555555556
76483, 1.4608695652174, 0.25434782608696, 0.027777777777778
76484, 1.504347826087, 0.25434782608696, 0.47222222222222
76485, 1.4826086956522, 0.25434782608696, 0.44444444444444
76486, 1.504347826087, 0.2804347826087, 0.44444444444444
76487, 1.504347826087, 0.25434782608696, 0.41666666666667
76488, 1.4826086956522, 0.25434782608696, 0.38888888888889
76489, 1.504347826087, 0.2804347826087, 0.38888888888889
76490, 1.504347826087, 0.25434782608696, 0.36111111111111
76491, 1.4826086956522, 0.25434782608696, 0.33333333333333
76492, 1.504347826087, 0.2804347826087, 0.33333333333333
76493, 1.504347826087, 0.25434782608696, 0.30555555555556
76494, 1.4826086956522, 0.25434782608696, 0.27777777777778
76495, 1.504347826087, 0.2804347826087, 0.27777777777778
76496, 1.504347826087, 0.25434782608696, 0.25
76497, 1.4826086956522, 0.25434782608696, 0.22222222222222
76498, 1.504347826087, 0.2804347826087, 0.22222222222222
76499, 1.504347826087, 0.25434782608696, 0.19444444444444
76500, 1.4826086956522, 0.25434782608696, 0.16666666666667
76501, 1.504347826087, 0.2804347826087, 0.16666666666667
76502, 1.504347826087, 0.25434782608696, 0.13888888888889
76503, 1.4826086956522, 0.25434782608696, 0.11111111111111
76504, 1.504347826087, 0.2804347826087, 0.11111111111111
76505, 1.504347826087, 0.25434782608696, 0.083333333333333
76506, 1.4826086956522, 0.25434782608696, 0.055555555555556
76507, 1.504347826087, 0.2804347826087, 0.055555555555556
76508, 1.504347826087, 0.25434782608696, 0.027777777777778
76509, 1.5478260869565, 0.25434782608696, 0.47222222222222
76510, 1.5260869565217, 0.25434782608696, 0.44444444444444
76511, 1.5478260869565, 0.2804347826087, 0.44444444444444
76512, 1.5478260869565, 0.25434782608696, 0.41666666666667
76513, 1.5260869565217, 0.25434782608696, 0.38888888888889
76514, 1.5478260869565, 0.2804347826087, 0.38888888888889
76515, 1.5478260869565, 0.25434782608696, 0.36111111111111
76516, 1.5260869565217, 0.25434782608696, 0.33333333333333
76517, 1.5478260869565, 0.2804347826087, 0.33333333333333
76518, 1.5478260869565, 0.25434782608696, 0.30555555555556
76519, 1.5260869565217, 0.25434782608696, 0.27777777777778
76520, 1.5478260869565, 0.2804347826087, 0.27777777777778
76521, 1.5478260869565, 0.25434782608696, 0.25
76522, 1.5260869565217, 0.25434782608696, 0.22222222222222
76523, 1.5478260869565, 0.2804347826087, 0.22222222222222
76524, 1.5478260869565, 0.25434782608696, 0.19444444444444
76525, 1.5260869565217, 0.25434782608696, 0.16666666666667
76526, 1.5478260869565, 0.2804347826087, 0.16666666666667
76527, 1.5478260869565, 0.25434782608696, 0.13888888888889
76528, 1.5260869565217, 0.25434782608696, 0.11111111111111
76529, 1.5478260869565, 0.2804347826087, 0.11111111111111
76530, 1.5478260869565, 0.25434782608696, 0.083333333333333
76531, 1.5260869565217, 0.25434782608696, 0.055555555555556
76532, 1.5478260869565, 0.2804347826087, 0.055555555555556
76533, 1.5478260869565, 0.25434782608696, 0.027777777777778
76534, 1.5913043478261, 0.25434782608696, 0.47222222222222
76535, 1.5695652173913, 0.25434782608696, 0.44444444444444
76536, 1.5913043478261, 0.2804347826087, 0.44444444444444
76537, 1.5913043478261, 0.25434782608696, 0.41666666666667
76538, 1.5695652173913, 0.25434782608696, 0.38888888888889
76539, 1.5913043478261, 0.2804347826087, 0.38888888888889
76540, 1.5913043478261, 0.25434782608696, 0.36111111111111
76541, 1.5695652173913, 0.25434782608696, 0.33333333333333
76542, 1.5913043478261, 0.2804347826087, 0.33333333333333
76543, 1.5913043478261, 0.25434782608696, 0.30555555555556
76544, 1.5695652173913, 0.25434782608696, 0.27777777777778
76545, 1.5913043478261, 0.2804347826087, 0.27777777777778
76546, 1.5913043478261, 0.25434782608696, 0.25
76547, 1.5695652173913, 0.25434782608696, 0.22222222222222
76548, 1.5913043478261, 0.2804347826087, 0.22222222222222
76549, 1.5913043478261, 0.25434782608696, 0.19444444444444
76550, 1.5695652173913, 0.25434782608696, 0.16666666666667
76551, 1.5913043478261, 0.2804347826087, 0.16666666666667
76552, 1.5913043478261, 0.25434782608696, 0.13888888888889
76553, 1.5695652173913, 0.25434782608696, 0.11111111111111
76554, 1.5913043478261, 0.2804347826087, 0.11111111111111
76555, 1.5913043478261, 0.25434782608696, 0.083333333333333
76556, 1.5695652173913, 0.25434782608696, 0.055555555555556
76557, 1.5913043478261, 0.2804347826087, 0.055555555555556
76558, 1.5913043478261, 0.25434782608696, 0.027777777777778
76559, 1.6347826086957, 0.25434782608696, 0.47222222222222
76560, 1.6130434782609, 0.25434782608696, 0.44444444444444
76561, 1.6347826086957, 0.2804347826087, 0.44444444444444
76562, 1.6347826086957, 0.25434782608696, 0.41666666666667
76563, 1.6130434782609, 0.25434782608696, 0.38888888888889
76564, 1.6347826086957, 0.2804347826087, 0.38888888888889
76565, 1.6347826086957, 0.25434782608696, 0.36111111111111
76566, 1.6130434782609, 0.25434782608696, 0.33333333333333
76567, 1.6347826086957, 0.2804347826087, 0.33333333333333
76568, 1.6347826086957, 0.25434782608696, 0.30555555555556
76569, 1.6130434782609, 0.25434782608696, 0.27777777777778
76570, 1.6347826086957, 0.2804347826087, 0.27777777777778
76571, 1.6347826086957, 0.25434782608696, 0.25
76572, 1.6130434782609, 0.25434782608696, 0.22222222222222
76573, 1.6347826086957, 0.2804347826087, 0.22222222222222
76574, 1.6347826086957, 0.25434782608696, 0.19444444444444
76575, 1.6130434782609, 0.25434782608696, 0.16666666666667
76576, 1.6347826086957, 0.2804347826087, 0.16666666666667
76577, 1.6347826086957, 0.25434782608696, 0.13888888888889
76578, 1.6130434782609, 0.25434782608696, 0.11111111111111
76579, 1.6347826086957, 0.2804347826087, 0.11111111111111
76580, 1.6347826086957, 0.25434782608696, 0.083333333333333
76581, 1.6130434782609, 0.25434782608696, 0.055555555555556
76582, 1.6347826086957, 0.2804347826087, 0.055555555555556
76583, 1.6347826086957, 0.25434782608696, 0.027777777777778
76584, 1.6782608695652, 0.25434782608696, 0.47222222222222
76585, 1.6565217391304, 0.25434782608696, 0.44444444444444
76586, 1.6782608695652, 0.2804347826087, 0.44444444444444
76587, 1.6782608695652, 0.25434782608696, 0.41666666666667
76588, 1.6565217391304, 0.25434782608696, 0.38888888888889
76589, 1.6782608695652, 0.2804347826087, 0.38888888888889
76590, 1.6782608695652, 0.25434782608696, 0.36111111111111
76591, 1.6565217391304, 0.25434782608696, 0.33333333333333
76592, 1.6782608695652, 0.2804347826087, 0.33333333333333
76593, 1.6782608695652, 0.25434782608696, 0.30555555555556
76594, 1.6565217391304, 0.25434782608696, 0.27777777777778
76595, 1.6782608695652, 0.2804347826087, 0.27777777777778
76596, 1.6782608695652, 0.25434782608696, 0.25
76597, 1.6565217391304, 0.25434782608696, 0.22222222222222
76598, 1.6782608695652, 0.2804347826087, 0.22222222222222
76599, 1.6782608695652, 0.25434782608696, 0.19444444444444
76600, 1.6565217391304, 0.25434782608696, 0.16666666666667
76601, 1.6782608695652, 0.2804347826087, 0.16666666666667
76602, 1.6782608695652, 0.25434782608696, 0.13888888888889
76603, 1.6565217391304, 0.25434782608696, 0.11111111111111
76604, 1.6782608695652, 0.2804347826087, 0.11111111111111
76605, 1.6782608695652, 0.25434782608696, 0.083333333333333
76606, 1.6565217391304, 0.25434782608696, 0.055555555555556
76607, 1.6782608695652, 0.2804347826087, 0.055555555555556
76608, 1.6782608695652, 0.25434782608696, 0.027777777777778
76609, 1.7217391304348, 0.25434782608696, 0.47222222222222
76610, 1.7, 0.25434782608696, 0.44444444444444
76611, 1.7217391304348, 0.2804347826087, 0.44444444444444
76612, 1.7217391304348, 0.25434782608696, 0.41666666666667
76613, 1.7, 0.25434782608696, 0.38888888888889
76614, 1.7217391304348, 0.2804347826087, 0.38888888888889
76615, 1.7217391304348, 0.25434782608696, 0.36111111111111
76616, 1.7, 0.25434782608696, 0.33333333333333
76617, 1.7217391304348, 0.2804347826087, 0.33333333333333
76618, 1.7217391304348, 0.25434782608696, 0.30555555555556
76619, 1.7, 0.25434782608696, 0.27777777777778
76620, 1.7217391304348, 0.2804347826087, 0.27777777777778
76621, 1.7217391304348, 0.25434782608696, 0.25
76622, 1.7, 0.25434782608696, 0.22222222222222
76623, 1.7217391304348, 0.2804347826087, 0.22222222222222
76624, 1.7217391304348, 0.25434782608696, 0.19444444444444
76625, 1.7, 0.25434782608696, 0.16666666666667
76626, 1.7217391304348, 0.2804347826087, 0.16666666666667
76627, 1.7217391304348, 0.25434782608696, 0.13888888888889
76628, 1.7, 0.25434782608696, 0.11111111111111
76629, 1.7217391304348, 0.2804347826087, 0.11111111111111
76630, 1.7217391304348, 0.25434782608696, 0.083333333333333
76631, 1.7, 0.25434782608696, 0.055555555555556
76632, 1.7217391304348, 0.2804347826087, 0.055555555555556
76633, 1.7217391304348, 0.25434782608696, 0.027777777777778
76634, 1.7652173913043, 0.25434782608696, 0.47222222222222
76635, 1.7434782608696, 0.25434782608696, 0.44444444444444
76636, 1.7652173913043, 0.2804347826087, 0.44444444444444
76637, 1.7652173913043, 0.25434782608696, 0.41666666666667
76638, 1.7434782608696, 0.25434782608696, 0.38888888888889
76639, 1.7652173913043, 0.2804347826087, 0.38888888888889
76640, 1.7652173913043, 0.25434782608696, 0.36111111111111
76641, 1.7434782608696, 0.25434782608696, 0.33333333333333
76642, 1.7652173913043, 0.2804347826087, 0.33333333333333
76643, 1.7652173913043, 0.25434782608696, 0.30555555555556
76644, 1.7434782608696, 0.25434782608696, 0.27777777777778
76645, 1.7652173913043, 0.2804347826087, 0.27777777777778
76646, 1.7652173913043, 0.25434782608696, 0.25
76647, 1.7434782608696, 0.25434782608696, 0.22222222222222
76648, 1.7652173913043, 0.2804347826087, 0.22222222222222
76649, 1.7652173913043, 0.25434782608696, 0.19444444444444
76650, 1.7434782608696, 0.25434782608696, 0.16666666666667
76651, 1.7652173913043, 0.2804347826087, 0.16666666666667
76652, 1.7652173913043, 0.25434782608696, 0.13888888888889
76653, 1.7434782608696, 0.25434782608696, 0.11111111111111
76654, 1.7652173913043, 0.2804347826087, 0.11111111111111
76655, 1.7652173913043, 0.25434782608696, 0.083333333333333
76656, 1.7434782608696, 0.25434782608696, 0.055555555555556
76657, 1.7652173913043, 0.2804347826087, 0.055555555555556
76658, 1.7652173913043, 0.25434782608696, 0.027777777777778
76659, 1.8086956521739, 0.25434782608696, 0.47222222222222
76660, 1.7869565217391, 0.25434782608696, 0.44444444444444
76661, 1.8086956521739, 0.2804347826087, 0.44444444444444
76662, 1.8086956521739, 0.25434782608696, 0.41666666666667
76663, 1.7869565217391, 0.25434782608696, 0.38888888888889
76664, 1.8086956521739, 0.2804347826087, 0.38888888888889
76665, 1.8086956521739, 0.25434782608696, 0.36111111111111
76666, 1.7869565217391, 0.25434782608696, 0.33333333333333
76667, 1.8086956521739, 0.2804347826087, 0.33333333333333
76668, 1.8086956521739, 0.25434782608696, 0.30555555555556
76669, 1.7869565217391, 0.25434782608696, 0.27777777777778
76670, 1.8086956521739, 0.2804347826087, 0.27777777777778
76671, 1.8086956521739, 0.25434782608696, 0.25
76672, 1.7869565217391, 0.25434782608696, 0.22222222222222
76673, 1.8086956521739, 0.2804347826087, 0.22222222222222
76674, 1.8086956521739, 0.25434782608696, 0.19444444444444
76675, 1.7869565217391, 0.25434782608696, 0.16666666666667
76676, 1.8086956521739, 0.2804347826087, 0.16666666666667
76677, 1.8086956521739, 0.25434782608696, 0.13888888888889
76678, 1.7869565217391, 0.25434782608696, 0.11111111111111
76679, 1.8086956521739, 0.2804347826087, 0.11111111111111
76680, 1.8086956521739, 0.25434782608696, 0.083333333333333
76681, 1.7869565217391, 0.25434782608696, 0.055555555555556
76682, 1.8086956521739, 0.2804347826087, 0.055555555555556
76683, 1.8086956521739, 0.25434782608696, 0.027777777777778
76684, 1.8521739130435, 0.25434782608696, 0.47222222222222
76685, 1.8304347826087, 0.25434782608696, 0.44444444444444
76686, 1.8521739130435, 0.2804347826087, 0.44444444444444
76687, 1.8521739130435, 0.25434782608696, 0.41666666666667
76688, 1.8304347826087, 0.25434782608696, 0.38888888888889
76689, 1.8521739130435, 0.2804347826087, 0.38888888888889
76690, 1.8521739130435, 0.25434782608696, 0.36111111111111
76691, 1.8304347826087, 0.25434782608696, 0.33333333333333
76692, 1.8521739130435, 0.2804347826087, 0.33333333333333
76693, 1.8521739130435, 0.25434782608696, 0.30555555555556
76694, 1.8304347826087, 0.25434782608696, 0.27777777777778
76695, 1.8521739130435, 0.2804347826087, 0.27777777777778
76696, 1.8521739130435, 0.25434782608696, 0.25
76697, 1.8304347826087, 0.25434782608696, 0.22222222222222
76698, 1.8521739130435, 0.2804347826087, 0.22222222222222
76699, 1.8521739130435, 0.25434782608696, 0.19444444444444
76700, 1.8304347826087, 0.25434782608696, 0.16666666666667
76701, 1.8521739130435, 0.2804347826087, 0.16666666666667
76702, 1.8521739130435, 0.25434782608696, 0.13888888888889
76703, 1.8304347826087, 0.25434782608696, 0.11111111111111
76704, 1.8521739130435, 0.2804347826087, 0.11111111111111
76705, 1.8521739130435, 0.25434782608696, 0.083333333333333
76706, 1.8304347826087, 0.25434782608696, 0.055555555555556
76707, 1.8521739130435, 0.2804347826087, 0.055555555555556
76708, 1.8521739130435, 0.25434782608696, 0.027777777777778
76709, 1.895652173913, 0.25434782608696, 0.47222222222222
76710, 1.8739130434783, 0.25434782608696, 0.44444444444444
76711, 1.895652173913, 0.2804347826087, 0.44444444444444
76712, 1.895652173913, 0.25434782608696, 0.41666666666667
76713, 1.8739130434783, 0.25434782608696, 0.38888888888889
76714, 1.895652173913, 0.2804347826087, 0.38888888888889
76715, 1.895652173913, 0.25434782608696, 0.36111111111111
76716, 1.8739130434783, 0.25434782608696, 0.33333333333333
76717, 1.895652173913, 0.2804347826087, 0.33333333333333
76718, 1.895652173913, 0.25434782608696, 0.30555555555556
76719, 1.8739130434783, 0.25434782608696, 0.27777777777778
76720, 1.895652173913, 0.2804347826087, 0.27777777777778
76721, 1.895652173913, 0.25434782608696, 0.25
76722, 1.8739130434783, 0.25434782608696, 0.22222222222222
76723, 1.895652173913, 0.2804347826087, 0.22222222222222
76724, 1.895652173913, 0.25434782608696, 0.19444444444444
76725, 1.8739130434783, 0.25434782608696, 0.16666666666667
76726, 1.895652173913, 0.2804347826087, 0.16666666666667
76727, 1.895652173913, 0.25434782608696, 0.13888888888889
76728, 1.8739130434783, 0.25434782608696, 0.11111111111111
76729, 1.895652173913, 0.2804347826087, 0.11111111111111
76730, 1.895652173913, 0.25434782608696, 0.083333333333333
76731, 1.8739130434783, 0.25434782608696, 0.055555555555556
76732, 1.895652173913, 0.2804347826087, 0.055555555555556
76733, 1.895652173913, 0.25434782608696, 0.027777777777778
76734, 1.9391304347826, 0.25434782608696, 0.47222222222222
76735, 1.9173913043478, 0.25434782608696, 0.44444444444444
76736, 1.9391304347826, 0.2804347826087, 0.44444444444444
76737, 1.9391304347826, 0.25434782608696, 0.41666666666667
76738, 1.9173913043478, 0.25434782608696, 0.38888888888889
76739, 1.9391304347826, 0.2804347826087, 0.38888888888889
76740, 1.9391304347826, 0.25434782608696, 0.36111111111111
76741, 1.9173913043478, 0.25434782608696, 0.33333333333333
76742, 1.9391304347826, 0.2804347826087, 0.33333333333333
76743, 1.9391304347826, 0.25434782608696, 0.30555555555556
76744, 1.9173913043478, 0.25434782608696, 0.27777777777778
76745, 1.9391304347826, 0.2804347826087, 0.27777777777778
76746, 1.9391304347826, 0.25434782608696, 0.25
76747, 1.9173913043478, 0.25434782608696, 0.22222222222222
76748, 1.9391304347826, 0.2804347826087, 0.22222222222222
76749, 1.9391304347826, 0.25434782608696, 0.19444444444444
76750, 1.9173913043478, 0.25434782608696, 0.16666666666667
76751, 1.9391304347826, 0.2804347826087, 0.16666666666667
76752, 1.9391304347826, 0.25434782608696, 0.13888888888889
76753, 1.9173913043478, 0.25434782608696, 0.11111111111111
76754, 1.9391304347826, 0.2804347826087, 0.11111111111111
76755, 1.9391304347826, 0.25434782608696, 0.083333333333333
76756, 1.9173913043478, 0.25434782608696, 0.055555555555556
76757, 1.9391304347826, 0.2804347826087, 0.055555555555556
76758, 1.9391304347826, 0.25434782608696, 0.027777777777778
76759, 1.9826086956522, 0.25434782608696, 0.47222222222222
76760, 1.9608695652174, 0.25434782608696, 0.44444444444444
76761, 1.9826086956522, 0.2804347826087, 0.44444444444444
76762, 1.9826086956522, 0.25434782608696, 0.41666666666667
76763, 1.9608695652174, 0.25434782608696, 0.38888888888889
76764, 1.9826086956522, 0.2804347826087, 0.38888888888889
76765, 1.9826086956522, 0.25434782608696, 0.36111111111111
76766, 1.9608695652174, 0.25434782608696, 0.33333333333333
76767, 1.9826086956522, 0.2804347826087, 0.33333333333333
76768, 1.9826086956522, 0.25434782608696, 0.30555555555556
76769, 1.9608695652174, 0.25434782608696, 0.27777777777778
76770, 1.9826086956522, 0.2804347826087, 0.27777777777778
76771, 1.9826086956522, 0.25434782608696, 0.25
76772, 1.9608695652174, 0.25434782608696, 0.22222222222222
76773, 1.9826086956522, 0.2804347826087, 0.22222222222222
76774, 1.9826086956522, 0.25434782608696, 0.19444444444444
76775, 1.9608695652174, 0.25434782608696, 0.16666666666667
76776, 1.9826086956522, 0.2804347826087, 0.16666666666667
76777, 1.9826086956522, 0.25434782608696, 0.13888888888889
76778, 1.9608695652174, 0.25434782608696, 0.11111111111111
76779, 1.9826086956522, 0.2804347826087, 0.11111111111111
76780, 1.9826086956522, 0.25434782608696, 0.083333333333333
76781, 1.9608695652174, 0.25434782608696, 0.055555555555556
76782, 1.9826086956522, 0.2804347826087, 0.055555555555556
76783, 1.9826086956522, 0.25434782608696, 0.027777777777778
76784, 2.0260869565217, 0.25434782608696, 0.47222222222222
76785, 2.004347826087, 0.25434782608696, 0.44444444444444
76786, 2.0260869565217, 0.2804347826087, 0.44444444444444
76787, 2.0260869565217, 0.25434782608696, 0.41666666666667
76788, 2.004347826087, 0.25434782608696, 0.38888888888889
76789, 2.0260869565217, 0.2804347826087, 0.38888888888889
76790, 2.0260869565217, 0.25434782608696, 0.36111111111111
76791, 2.004347826087, 0.25434782608696, 0.33333333333333
76792, 2.0260869565217, 0.2804347826087, 0.33333333333333
76793, 2.0260869565217, 0.25434782608696, 0.30555555555556
76794, 2.004347826087, 0.25434782608696, 0.27777777777778
76795, 2.0260869565217, 0.2804347826087, 0.27777777777778
76796, 2.0260869565217, 0.25434782608696, 0.25
76797, 2.004347826087, 0.25434782608696, 0.22222222222222
76798, 2.0260869565217, 0.2804347826087, 0.22222222222222
76799, 2.0260869565217, 0.25434782608696, 0.19444444444444
76800, 2.004347826087, 0.25434782608696, 0.16666666666667
76801, 2.0260869565217, 0.2804347826087, 0.16666666666667
76802, 2.0260869565217, 0.25434782608696, 0.13888888888889
76803, 2.004347826087, 0.25434782608696, 0.11111111111111
76804, 2.0260869565217, 0.2804347826087, 0.11111111111111
76805, 2.0260869565217, 0.25434782608696, 0.083333333333333
76806, 2.004347826087, 0.25434782608696, 0.055555555555556
76807, 2.0260869565217, 0.2804347826087, 0.055555555555556
76808, 2.0260869565217, 0.25434782608696, 0.027777777777778
76809, 2.0695652173913, 0.25434782608696, 0.47222222222222
76810, 2.0478260869565, 0.25434782608696, 0.44444444444444
76811, 2.0695652173913, 0.2804347826087, 0.44444444444444
76812, 2.0695652173913, 0.25434782608696, 0.41666666666667
76813, 2.0478260869565, 0.25434782608696, 0.38888888888889
76814, 2.0695652173913, 0.2804347826087, 0.38888888888889
76815, 2.0695652173913, 0.25434782608696, 0.36111111111111
76816, 2.0478260869565, 0.25434782608696, 0.33333333333333
76817, 2.0695652173913, 0.2804347826087, 0.33333333333333
76818, 2.0695652173913, 0.25434782608696, 0.30555555555556
76819, 2.0478260869565, 0.25434782608696, 0.27777777777778
76820, 2.0695652173913, 0.2804347826087, 0.27777777777778
76821, 2.0695652173913, 0.25434782608696, 0.25
76822, 2.0478260869565, 0.25434782608696, 0.22222222222222
76823, 2.0695652173913, 0.2804347826087, 0.22222222222222
76824, 2.0695652173913, 0.25434782608696, 0.19444444444444
76825, 2.0478260869565, 0.25434782608696, 0.16666666666667
76826, 2.0695652173913, 0.2804347826087, 0.16666666666667
76827, 2.0695652173913, 0.25434782608696, 0.13888888888889
76828, 2.0478260869565, 0.25434782608696, 0.11111111111111
76829, 2.0695652173913, 0.2804347826087, 0.11111111111111
76830, 2.0695652173913, 0.25434782608696, 0.083333333333333
76831, 2.0478260869565, 0.25434782608696, 0.055555555555556
76832, 2.0695652173913, 0.2804347826087, 0.055555555555556
76833, 2.0695652173913, 0.25434782608696, 0.027777777777778
76834, 2.1130434782609, 0.25434782608696, 0.47222222222222
76835, 2.0913043478261, 0.25434782608696, 0.44444444444444
76836, 2.1130434782609, 0.2804347826087, 0.44444444444444
76837, 2.1130434782609, 0.25434782608696, 0.41666666666667
76838, 2.0913043478261, 0.25434782608696, 0.38888888888889
76839, 2.1130434782609, 0.2804347826087, 0.38888888888889
76840, 2.1130434782609, 0.25434782608696, 0.36111111111111
76841, 2.0913043478261, 0.25434782608696, 0.33333333333333
76842, 2.1130434782609, 0.2804347826087, 0.33333333333333
76843, 2.1130434782609, 0.25434782608696, 0.30555555555556
76844, 2.0913043478261, 0.25434782608696, 0.27777777777778
76845, 2.1130434782609, 0.2804347826087, 0.27777777777778
76846, 2.1130434782609, 0.25434782608696, 0.25
76847, 2.0913043478261, 0.25434782608696, 0.22222222222222
76848, 2.1130434782609, 0.2804347826087, 0.22222222222222
76849, 2.1130434782609, 0.25434782608696, 0.19444444444444
76850, 2.0913043478261, 0.25434782608696, 0.16666666666667
76851, 2.1130434782609, 0.2804347826087, 0.16666666666667
76852, 2.1130434782609, 0.25434782608696, 0.13888888888889
76853, 2.0913043478261, 0.25434782608696, 0.11111111111111
76854, 2.1130434782609, 0.2804347826087, 0.11111111111111
76855, 2.1130434782609, 0.25434782608696, 0.083333333333333
76856, 2.0913043478261, 0.25434782608696, 0.055555555555556
76857, 2.1130434782609, 0.2804347826087, 0.055555555555556
76858, 2.1130434782609, 0.25434782608696, 0.027777777777778
76859, 2.1565217391304, 0.25434782608696, 0.47222222222222
76860, 2.1347826086957, 0.25434782608696, 0.44444444444444
76861, 2.1565217391304, 0.2804347826087, 0.44444444444444
76862, 2.1565217391304, 0.25434782608696, 0.41666666666667
76863, 2.1347826086957, 0.25434782608696, 0.38888888888889
76864, 2.1565217391304, 0.2804347826087, 0.38888888888889
76865, 2.1565217391304, 0.25434782608696, 0.36111111111111
76866, 2.1347826086957, 0.25434782608696, 0.33333333333333
76867, 2.1565217391304, 0.2804347826087, 0.33333333333333
76868, 2.1565217391304, 0.25434782608696, 0.30555555555556
76869, 2.1347826086957, 0.25434782608696, 0.27777777777778
76870, 2.1565217391304, 0.2804347826087, 0.27777777777778
76871, 2.1565217391304, 0.25434782608696, 0.25
76872, 2.1347826086957, 0.25434782608696, 0.22222222222222
76873, 2.1565217391304, 0.2804347826087, 0.22222222222222
76874, 2.1565217391304, 0.25434782608696, 0.19444444444444
76875, 2.1347826086957, 0.25434782608696, 0.16666666666667
76876, 2.1565217391304, 0.2804347826087, 0.16666666666667
76877, 2.1565217391304, 0.25434782608696, 0.13888888888889
76878, 2.1347826086957, 0.25434782608696, 0.11111111111111
76879, 2.1565217391304, 0.2804347826087, 0.11111111111111
76880, 2.1565217391304, 0.25434782608696, 0.083333333333333
76881, 2.1347826086957, 0.25434782608696, 0.055555555555556
76882, 2.1565217391304, 0.2804347826087, 0.055555555555556
76883, 2.1565217391304, 0.25434782608696, 0.027777777777778
76884, 2.1782608695652, 0.25434782608696, 0.44444444444444
76885, 2.1782608695652, 0.25434782608696, 0.38888888888889
76886, 2.1782608695652, 0.25434782608696, 0.33333333333333
76887, 2.1782608695652, 0.25434782608696, 0.27777777777778
76888, 2.1782608695652, 0.25434782608696, 0.22222222222222
76889, 2.1782608695652, 0.25434782608696, 0.16666666666667
76890, 2.1782608695652, 0.25434782608696, 0.11111111111111
76891, 2.1782608695652, 0.25434782608696, 0.055555555555556
76892, 1.2434782608696, 0.20217391304348, 0.47222222222222
76893, 1.2217391304348, 0.20217391304348, 0.44444444444444
76894, 1.2434782608696, 0.22826086956522, 0.44444444444444
76895, 1.2434782608696, 0.20217391304348, 0.41666666666667
76896, 1.2217391304348, 0.20217391304348, 0.38888888888889
76897, 1.2434782608696, 0.22826086956522, 0.38888888888889
76898, 1.2434782608696, 0.20217391304348, 0.36111111111111
76899, 1.2217391304348, 0.20217391304348, 0.33333333333333
76900, 1.2434782608696, 0.22826086956522, 0.33333333333333
76901, 1.2434782608696, 0.20217391304348, 0.30555555555556
76902, 1.2217391304348, 0.20217391304348, 0.27777777777778
76903, 1.2434782608696, 0.22826086956522, 0.27777777777778
76904, 1.2434782608696, 0.20217391304348, 0.25
76905, 1.2217391304348, 0.20217391304348, 0.22222222222222
76906, 1.2434782608696, 0.22826086956522, 0.22222222222222
76907, 1.2434782608696, 0.20217391304348, 0.19444444444444
76908, 1.2217391304348, 0.20217391304348, 0.16666666666667
76909, 1.2434782608696, 0.22826086956522, 0.16666666666667
76910, 1.2434782608696, 0.20217391304348, 0.13888888888889
76911, 1.2217391304348, 0.20217391304348, 0.11111111111111
76912, 1.2434782608696, 0.22826086956522, 0.11111111111111
76913, 1.2434782608696, 0.20217391304348, 0.083333333333333
76914, 1.2217391304348, 0.20217391304348, 0.055555555555556
76915, 1.2434782608696, 0.22826086956522, 0.055555555555556
76916, 1.2434782608696, 0.20217391304348, 0.027777777777778
76917, 1.2869565217391, 0.20217391304348, 0.47222222222222
76918, 1.2652173913043, 0.20217391304348, 0.44444444444444
76919, 1.2869565217391, 0.22826086956522, 0.44444444444444
76920, 1.2869565217391, 0.20217391304348, 0.41666666666667
76921, 1.2652173913043, 0.20217391304348, 0.38888888888889
76922, 1.2869565217391, 0.22826086956522, 0.38888888888889
76923, 1.2869565217391, 0.20217391304348, 0.36111111111111
76924, 1.2652173913043, 0.20217391304348, 0.33333333333333
76925, 1.2869565217391, 0.22826086956522, 0.33333333333333
76926, 1.2869565217391, 0.20217391304348, 0.30555555555556
76927, 1.2652173913043, 0.20217391304348, 0.27777777777778
76928, 1.2869565217391, 0.22826086956522, 0.27777777777778
76929, 1.2869565217391, 0.20217391304348, 0.25
76930, 1.2652173913043, 0.20217391304348, 0.22222222222222
76931, 1.2869565217391, 0.22826086956522, 0.22222222222222
76932, 1.2869565217391, 0.20217391304348, 0.19444444444444
76933, 1.2652173913043, 0.20217391304348, 0.16666666666667
76934, 1.2869565217391, 0.22826086956522, 0.16666666666667
76935, 1.2869565217391, 0.20217391304348, 0.13888888888889
76936, 1.2652173913043, 0.20217391304348, 0.11111111111111
76937, 1.2869565217391, 0.22826086956522, 0.11111111111111
76938, 1.2869565217391, 0.20217391304348, 0.083333333333333
76939, 1.2652173913043, 0.20217391304348, 0.055555555555556
76940, 1.2869565217391, 0.22826086956522, 0.055555555555556
76941, 1.2869565217391, 0.20217391304348, 0.027777777777778
76942, 1.3304347826087, 0.20217391304348, 0.47222222222222
76943, 1.3086956521739, 0.20217391304348, 0.44444444444444
76944, 1.3304347826087, 0.22826086956522, 0.44444444444444
76945, 1.3304347826087, 0.20217391304348, 0.41666666666667
76946, 1.3086956521739, 0.20217391304348, 0.38888888888889
76947, 1.3304347826087, 0.22826086956522, 0.38888888888889
76948, 1.3304347826087, 0.20217391304348, 0.36111111111111
76949, 1.3086956521739, 0.20217391304348, 0.33333333333333
76950, 1.3304347826087, 0.22826086956522, 0.33333333333333
76951, 1.3304347826087, 0.20217391304348, 0.30555555555556
76952, 1.3086956521739, 0.20217391304348, 0.27777777777778
76953, 1.3304347826087, 0.22826086956522, 0.27777777777778
76954, 1.3304347826087, 0.20217391304348, 0.25
76955, 1.3086956521739, 0.20217391304348, 0.22222222222222
76956, 1.3304347826087, 0.22826086956522, 0.22222222222222
76957, 1.3304347826087, 0.20217391304348, 0.19444444444444
76958, 1.3086956521739, 0.20217391304348, 0.16666666666667
76959, 1.3304347826087, 0.22826086956522, 0.16666666666667
76960, 1.3304347826087, 0.20217391304348, 0.13888888888889
76961, 1.3086956521739, 0.20217391304348, 0.11111111111111
76962, 1.3304347826087, 0.22826086956522, 0.11111111111111
76963, 1.3304347826087, 0.20217391304348, 0.083333333333333
76964, 1.3086956521739, 0.20217391304348, 0.055555555555556
76965, 1.3304347826087, 0.22826086956522, 0.055555555555556
76966, 1.3304347826087, 0.20217391304348, 0.027777777777778
76967, 1.3739130434783, 0.20217391304348, 0.47222222222222
76968, 1.3521739130435, 0.20217391304348, 0.44444444444444
76969, 1.3739130434783, 0.22826086956522, 0.44444444444444
76970, 1.3739130434783, 0.20217391304348, 0.41666666666667
76971, 1.3521739130435, 0.20217391304348, 0.38888888888889
76972, 1.3739130434783, 0.22826086956522, 0.38888888888889
76973, 1.3739130434783, 0.20217391304348, 0.36111111111111
76974, 1.3521739130435, 0.20217391304348, 0.33333333333333
76975, 1.3739130434783, 0.22826086956522, 0.33333333333333
76976, 1.3739130434783, 0.20217391304348, 0.30555555555556
76977, 1.3521739130435, 0.20217391304348, 0.27777777777778
76978, 1.3739130434783, 0.22826086956522, 0.27777777777778
76979, 1.3739130434783, 0.20217391304348, 0.25
76980, 1.3521739130435, 0.20217391304348, 0.22222222222222
76981, 1.3739130434783, 0.22826086956522, 0.22222222222222
76982, 1.3739130434783, 0.20217391304348, 0.19444444444444
76983, 1.3521739130435, 0.20217391304348, 0.16666666666667
76984, 1.3739130434783, 0.22826086956522, 0.16666666666667
76985, 1.3739130434783, 0.20217391304348, 0.13888888888889
76986, 1.3521739130435, 0.20217391304348, 0.11111111111111
76987, 1.3739130434783, 0.22826086956522, 0.11111111111111
76988, 1.3739130434783, 0.20217391304348, 0.083333333333333
76989, 1.3521739130435, 0.20217391304348, 0.055555555555556
76990, 1.3739130434783, 0.22826086956522, 0.055555555555556
76991, 1.3739130434783, 0.20217391304348, 0.027777777777778
76992, 1.4173913043478, 0.20217391304348, 0.47222222222222
76993, 1.395652173913, 0.20217391304348, 0.44444444444444
76994, 1.4173913043478, 0.22826086956522, 0.44444444444444
76995, 1.4173913043478, 0.20217391304348, 0.41666666666667
76996, 1.395652173913, 0.20217391304348, 0.38888888888889
76997, 1.4173913043478, 0.22826086956522, 0.38888888888889
76998, 1.4173913043478, 0.20217391304348, 0.36111111111111
76999, 1.395652173913, 0.20217391304348, 0.33333333333333
77000, 1.4173913043478, 0.22826086956522, 0.33333333333333
77001, 1.4173913043478, 0.20217391304348, 0.30555555555556
77002, 1.395652173913, 0.20217391304348, 0.27777777777778
77003, 1.4173913043478, 0.22826086956522, 0.27777777777778
77004, 1.4173913043478, 0.20217391304348, 0.25
77005, 1.395652173913, 0.20217391304348, 0.22222222222222
77006, 1.4173913043478, 0.22826086956522, 0.22222222222222
77007, 1.4173913043478, 0.20217391304348, 0.19444444444444
77008, 1.395652173913, 0.20217391304348, 0.16666666666667
77009, 1.4173913043478, 0.22826086956522, 0.16666666666667
77010, 1.4173913043478, 0.20217391304348, 0.13888888888889
77011, 1.395652173913, 0.20217391304348, 0.11111111111111
77012, 1.4173913043478, 0.22826086956522, 0.11111111111111
77013, 1.4173913043478, 0.20217391304348, 0.083333333333333
77014, 1.395652173913, 0.20217391304348, 0.055555555555556
77015, 1.4173913043478, 0.22826086956522, 0.055555555555556
77016, 1.4173913043478, 0.20217391304348, 0.027777777777778
77017, 1.4608695652174, 0.20217391304348, 0.47222222222222
77018, 1.4391304347826, 0.20217391304348, 0.44444444444444
77019, 1.4608695652174, 0.22826086956522, 0.44444444444444
77020, 1.4608695652174, 0.20217391304348, 0.41666666666667
77021, 1.4391304347826, 0.20217391304348, 0.38888888888889
77022, 1.4608695652174, 0.22826086956522, 0.38888888888889
77023, 1.4608695652174, 0.20217391304348, 0.36111111111111
77024, 1.4391304347826, 0.20217391304348, 0.33333333333333
77025, 1.4608695652174, 0.22826086956522, 0.33333333333333
77026, 1.4608695652174, 0.20217391304348, 0.30555555555556
77027, 1.4391304347826, 0.20217391304348, 0.27777777777778
77028, 1.4608695652174, 0.22826086956522, 0.27777777777778
77029, 1.4608695652174, 0.20217391304348, 0.25
77030, 1.4391304347826, 0.20217391304348, 0.22222222222222
77031, 1.4608695652174, 0.22826086956522, 0.22222222222222
77032, 1.4608695652174, 0.20217391304348, 0.19444444444444
77033, 1.4391304347826, 0.20217391304348, 0.16666666666667
77034, 1.4608695652174, 0.22826086956522, 0.16666666666667
77035, 1.4608695652174, 0.20217391304348, 0.13888888888889
77036, 1.4391304347826, 0.20217391304348, 0.11111111111111
77037, 1.4608695652174, 0.22826086956522, 0.11111111111111
77038, 1.4608695652174, 0.20217391304348, 0.083333333333333
77039, 1.4391304347826, 0.20217391304348, 0.055555555555556
77040, 1.4608695652174, 0.22826086956522, 0.055555555555556
77041, 1.4608695652174, 0.20217391304348, 0.027777777777778
77042, 1.504347826087, 0.20217391304348, 0.47222222222222
77043, 1.4826086956522, 0.20217391304348, 0.44444444444444
77044, 1.504347826087, 0.22826086956522, 0.44444444444444
77045, 1.504347826087, 0.20217391304348, 0.41666666666667
77046, 1.4826086956522, 0.20217391304348, 0.38888888888889
77047, 1.504347826087, 0.22826086956522, 0.38888888888889
77048, 1.504347826087, 0.20217391304348, 0.36111111111111
77049, 1.4826086956522, 0.20217391304348, 0.33333333333333
77050, 1.504347826087, 0.22826086956522, 0.33333333333333
77051, 1.504347826087, 0.20217391304348, 0.30555555555556
77052, 1.4826086956522, 0.20217391304348, 0.27777777777778
77053, 1.504347826087, 0.22826086956522, 0.27777777777778
77054, 1.504347826087, 0.20217391304348, 0.25
77055, 1.4826086956522, 0.20217391304348, 0.22222222222222
77056, 1.504347826087, 0.22826086956522, 0.22222222222222
77057, 1.504347826087, 0.20217391304348, 0.19444444444444
77058, 1.4826086956522, 0.20217391304348, 0.16666666666667
77059, 1.504347826087, 0.22826086956522, 0.16666666666667
77060, 1.504347826087, 0.20217391304348, 0.13888888888889
77061, 1.4826086956522, 0.20217391304348, 0.11111111111111
77062, 1.504347826087, 0.22826086956522, 0.11111111111111
77063, 1.504347826087, 0.20217391304348, 0.083333333333333
77064, 1.4826086956522, 0.20217391304348, 0.055555555555556
77065, 1.504347826087, 0.22826086956522, 0.055555555555556
77066, 1.504347826087, 0.20217391304348, 0.027777777777778
77067, 1.5478260869565, 0.20217391304348, 0.47222222222222
77068, 1.5260869565217, 0.20217391304348, 0.44444444444444
77069, 1.5478260869565, 0.22826086956522, 0.44444444444444
77070, 1.5478260869565, 0.20217391304348, 0.41666666666667
77071, 1.5260869565217, 0.20217391304348, 0.38888888888889
77072, 1.5478260869565, 0.22826086956522, 0.38888888888889
77073, 1.5478260869565, 0.20217391304348, 0.36111111111111
77074, 1.5260869565217, 0.20217391304348, 0.33333333333333
77075, 1.5478260869565, 0.22826086956522, 0.33333333333333
77076, 1.5478260869565, 0.20217391304348, 0.30555555555556
77077, 1.5260869565217, 0.20217391304348, 0.27777777777778
77078, 1.5478260869565, 0.22826086956522, 0.27777777777778
77079, 1.5478260869565, 0.20217391304348, 0.25
77080, 1.5260869565217, 0.20217391304348, 0.22222222222222
77081, 1.5478260869565, 0.22826086956522, 0.22222222222222
77082, 1.5478260869565, 0.20217391304348, 0.19444444444444
77083, 1.5260869565217, 0.20217391304348, 0.16666666666667
77084, 1.5478260869565, 0.22826086956522, 0.16666666666667
77085, 1.5478260869565, 0.20217391304348, 0.13888888888889
77086, 1.5260869565217, 0.20217391304348, 0.11111111111111
77087, 1.5478260869565, 0.22826086956522, 0.11111111111111
77088, 1.5478260869565, 0.20217391304348, 0.083333333333333
77089, 1.5260869565217, 0.20217391304348, 0.055555555555556
77090, 1.5478260869565, 0.22826086956522, 0.055555555555556
77091, 1.5478260869565, 0.20217391304348, 0.027777777777778
77092, 1.5913043478261, 0.20217391304348, 0.47222222222222
77093, 1.5695652173913, 0.20217391304348, 0.44444444444444
77094, 1.5913043478261, 0.22826086956522, 0.44444444444444
77095, 1.5913043478261, 0.20217391304348, 0.41666666666667
77096, 1.5695652173913, 0.20217391304348, 0.38888888888889
77097, 1.5913043478261, 0.22826086956522, 0.38888888888889
77098, 1.5913043478261, 0.20217391304348, 0.36111111111111
77099, 1.5695652173913, 0.20217391304348, 0.33333333333333
77100, 1.5913043478261, 0.22826086956522, 0.33333333333333
77101, 1.5913043478261, 0.20217391304348, 0.30555555555556
77102, 1.5695652173913, 0.20217391304348, 0.27777777777778
77103, 1.5913043478261, 0.22826086956522, 0.27777777777778
77104, 1.5913043478261, 0.20217391304348, 0.25
77105, 1.5695652173913, 0.20217391304348, 0.22222222222222
77106, 1.5913043478261, 0.22826086956522, 0.22222222222222
77107, 1.5913043478261, 0.20217391304348, 0.19444444444444
77108, 1.5695652173913, 0.20217391304348, 0.16666666666667
77109, 1.5913043478261, 0.22826086956522, 0.16666666666667
77110, 1.5913043478261, 0.20217391304348, 0.13888888888889
77111, 1.5695652173913, 0.20217391304348, 0.11111111111111
77112, 1.5913043478261, 0.22826086956522, 0.11111111111111
77113, 1.5913043478261, 0.20217391304348, 0.083333333333333
77114, 1.5695652173913, 0.20217391304348, 0.055555555555556
77115, 1.5913043478261, 0.22826086956522, 0.055555555555556
77116, 1.5913043478261, 0.20217391304348, 0.027777777777778
77117, 1.6347826086957, 0.20217391304348, 0.47222222222222
77118, 1.6130434782609, 0.20217391304348, 0.44444444444444
77119, 1.6347826086957, 0.22826086956522, 0.44444444444444
77120, 1.6347826086957, 0.20217391304348, 0.41666666666667
77121, 1.6130434782609, 0.20217391304348, 0.38888888888889
77122, 1.6347826086957, 0.22826086956522, 0.38888888888889
77123, 1.6347826086957, 0.20217391304348, 0.36111111111111
77124, 1.6130434782609, 0.20217391304348, 0.33333333333333
77125, 1.6347826086957, 0.22826086956522, 0.33333333333333
77126, 1.6347826086957, 0.20217391304348, 0.30555555555556
77127, 1.6130434782609, 0.20217391304348, 0.27777777777778
77128, 1.6347826086957, 0.22826086956522, 0.27777777777778
77129, 1.6347826086957, 0.20217391304348, 0.25
77130, 1.6130434782609, 0.20217391304348, 0.22222222222222
77131, 1.6347826086957, 0.22826086956522, 0.22222222222222
77132, 1.6347826086957, 0.20217391304348, 0.19444444444444
77133, 1.6130434782609, 0.20217391304348, 0.16666666666667
77134, 1.6347826086957, 0.22826086956522, 0.16666666666667
77135, 1.6347826086957, 0.20217391304348, 0.13888888888889
77136, 1.6130434782609, 0.20217391304348, 0.11111111111111
77137, 1.6347826086957, 0.22826086956522, 0.11111111111111
77138, 1.6347826086957, 0.20217391304348, 0.083333333333333
77139, 1.6130434782609, 0.20217391304348, 0.055555555555556
77140, 1.6347826086957, 0.22826086956522, 0.055555555555556
77141, 1.6347826086957, 0.20217391304348, 0.027777777777778
77142, 1.6782608695652, 0.20217391304348, 0.47222222222222
77143, 1.6565217391304, 0.20217391304348, 0.44444444444444
77144, 1.6782608695652, 0.22826086956522, 0.44444444444444
77145, 1.6782608695652, 0.20217391304348, 0.41666666666667
77146, 1.6565217391304, 0.20217391304348, 0.38888888888889
77147, 1.6782608695652, 0.22826086956522, 0.38888888888889
77148, 1.6782608695652, 0.20217391304348, 0.36111111111111
77149, 1.6565217391304, 0.20217391304348, 0.33333333333333
77150, 1.6782608695652, 0.22826086956522, 0.33333333333333
77151, 1.6782608695652, 0.20217391304348, 0.30555555555556
77152, 1.6565217391304, 0.20217391304348, 0.27777777777778
77153, 1.6782608695652, 0.22826086956522, 0.27777777777778
77154, 1.6782608695652, 0.20217391304348, 0.25
77155, 1.6565217391304, 0.20217391304348, 0.22222222222222
77156, 1.6782608695652, 0.22826086956522, 0.22222222222222
77157, 1.6782608695652, 0.20217391304348, 0.19444444444444
77158, 1.6565217391304, 0.20217391304348, 0.16666666666667
77159, 1.6782608695652, 0.22826086956522, 0.16666666666667
77160, 1.6782608695652, 0.20217391304348, 0.13888888888889
77161, 1.6565217391304, 0.20217391304348, 0.11111111111111
77162, 1.6782608695652, 0.22826086956522, 0.11111111111111
77163, 1.6782608695652, 0.20217391304348, 0.083333333333333
77164, 1.6565217391304, 0.20217391304348, 0.055555555555556
77165, 1.6782608695652, 0.22826086956522, 0.055555555555556
77166, 1.6782608695652, 0.20217391304348, 0.027777777777778
77167, 1.7217391304348, 0.20217391304348, 0.47222222222222
77168, 1.7, 0.20217391304348, 0.44444444444444
77169, 1.7217391304348, 0.22826086956522, 0.44444444444444
77170, 1.7217391304348, 0.20217391304348, 0.41666666666667
77171, 1.7, 0.20217391304348, 0.38888888888889
77172, 1.7217391304348, 0.22826086956522, 0.38888888888889
77173, 1.7217391304348, 0.20217391304348, 0.36111111111111
77174, 1.7, 0.20217391304348, 0.33333333333333
77175, 1.7217391304348, 0.22826086956522, 0.33333333333333
77176, 1.7217391304348, 0.20217391304348, 0.30555555555556
77177, 1.7, 0.20217391304348, 0.27777777777778
77178, 1.7217391304348, 0.22826086956522, 0.27777777777778
77179, 1.7217391304348, 0.20217391304348, 0.25
77180, 1.7, 0.20217391304348, 0.22222222222222
77181, 1.7217391304348, 0.22826086956522, 0.22222222222222
77182, 1.7217391304348, 0.20217391304348, 0.19444444444444
77183, 1.7, 0.20217391304348, 0.16666666666667
77184, 1.7217391304348, 0.22826086956522, 0.16666666666667
77185, 1.7217391304348, 0.20217391304348, 0.13888888888889
77186, 1.7, 0.20217391304348, 0.11111111111111
77187, 1.7217391304348, 0.22826086956522, 0.11111111111111
77188, 1.7217391304348, 0.20217391304348, 0.083333333333333
77189, 1.7, 0.20217391304348, 0.055555555555556
77190, 1.7217391304348, 0.22826086956522, 0.055555555555556
77191, 1.7217391304348, 0.20217391304348, 0.027777777777778
77192, 1.7652173913043, 0.20217391304348, 0.47222222222222
77193, 1.7434782608696, 0.20217391304348, 0.44444444444444
77194, 1.7652173913043, 0.22826086956522, 0.44444444444444
77195, 1.7652173913043, 0.20217391304348, 0.41666666666667
77196, 1.7434782608696, 0.20217391304348, 0.38888888888889
77197, 1.7652173913043, 0.22826086956522, 0.38888888888889
77198, 1.7652173913043, 0.20217391304348, 0.36111111111111
77199, 1.7434782608696, 0.20217391304348, 0.33333333333333
77200, 1.7652173913043, 0.22826086956522, 0.33333333333333
77201, 1.7652173913043, 0.20217391304348, 0.30555555555556
77202, 1.7434782608696, 0.20217391304348, 0.27777777777778
77203, 1.7652173913043, 0.22826086956522, 0.27777777777778
77204, 1.7652173913043, 0.20217391304348, 0.25
77205, 1.7434782608696, 0.20217391304348, 0.22222222222222
77206, 1.7652173913043, 0.22826086956522, 0.22222222222222
77207, 1.7652173913043, 0.20217391304348, 0.19444444444444
77208, 1.7434782608696, 0.20217391304348, 0.16666666666667
77209, 1.7652173913043, 0.22826086956522, 0.16666666666667
77210, 1.7652173913043, 0.20217391304348, 0.13888888888889
77211, 1.7434782608696, 0.20217391304348, 0.11111111111111
77212, 1.7652173913043, 0.22826086956522, 0.11111111111111
77213, 1.7652173913043, 0.20217391304348, 0.083333333333333
77214, 1.7434782608696, 0.20217391304348, 0.055555555555556
77215, 1.7652173913043, 0.22826086956522, 0.055555555555556
77216, 1.7652173913043, 0.20217391304348, 0.027777777777778
77217, 1.8086956521739, 0.20217391304348, 0.47222222222222
77218, 1.7869565217391, 0.20217391304348, 0.44444444444444
77219, 1.8086956521739, 0.22826086956522, 0.44444444444444
77220, 1.8086956521739, 0.20217391304348, 0.41666666666667
77221, 1.7869565217391, 0.20217391304348, 0.38888888888889
77222, 1.8086956521739, 0.22826086956522, 0.38888888888889
77223, 1.8086956521739, 0.20217391304348, 0.36111111111111
77224, 1.7869565217391, 0.20217391304348, 0.33333333333333
77225, 1.8086956521739, 0.22826086956522, 0.33333333333333
77226, 1.8086956521739, 0.20217391304348, 0.30555555555556
77227, 1.7869565217391, 0.20217391304348, 0.27777777777778
77228, 1.8086956521739, 0.22826086956522, 0.27777777777778
77229, 1.8086956521739, 0.20217391304348, 0.25
77230, 1.7869565217391, 0.20217391304348, 0.22222222222222
77231, 1.8086956521739, 0.22826086956522, 0.22222222222222
77232, 1.8086956521739, 0.20217391304348, 0.19444444444444
77233, 1.7869565217391, 0.20217391304348, 0.16666666666667
77234, 1.8086956521739, 0.22826086956522, 0.16666666666667
77235, 1.8086956521739, 0.20217391304348, 0.13888888888889
77236, 1.7869565217391, 0.20217391304348, 0.11111111111111
77237, 1.8086956521739, 0.22826086956522, 0.11111111111111
77238, 1.8086956521739, 0.20217391304348, 0.083333333333333
77239, 1.7869565217391, 0.20217391304348, 0.055555555555556
77240, 1.8086956521739, 0.22826086956522, 0.055555555555556
77241, 1.8086956521739, 0.20217391304348, 0.027777777777778
77242, 1.8521739130435, 0.20217391304348, 0.47222222222222
77243, 1.8304347826087, 0.20217391304348, 0.44444444444444
77244, 1.8521739130435, 0.22826086956522, 0.44444444444444
77245, 1.8521739130435, 0.20217391304348, 0.41666666666667
77246, 1.8304347826087, 0.20217391304348, 0.38888888888889
77247, 1.8521739130435, 0.22826086956522, 0.38888888888889
77248, 1.8521739130435, 0.20217391304348, 0.36111111111111
77249, 1.8304347826087, 0.20217391304348, 0.33333333333333
77250, 1.8521739130435, 0.22826086956522, 0.33333333333333
77251, 1.8521739130435, 0.20217391304348, 0.30555555555556
77252, 1.8304347826087, 0.20217391304348, 0.27777777777778
77253, 1.8521739130435, 0.22826086956522, 0.27777777777778
77254, 1.8521739130435, 0.20217391304348, 0.25
77255, 1.8304347826087, 0.20217391304348, 0.22222222222222
77256, 1.8521739130435, 0.22826086956522, 0.22222222222222
77257, 1.8521739130435, 0.20217391304348, 0.19444444444444
77258, 1.8304347826087, 0.20217391304348, 0.16666666666667
77259, 1.8521739130435, 0.22826086956522, 0.16666666666667
77260, 1.8521739130435, 0.20217391304348, 0.13888888888889
77261, 1.8304347826087, 0.20217391304348, 0.11111111111111
77262, 1.8521739130435, 0.22826086956522, 0.11111111111111
77263, 1.8521739130435, 0.20217391304348, 0.083333333333333
77264, 1.8304347826087, 0.20217391304348, 0.055555555555556
77265, 1.8521739130435, 0.22826086956522, 0.055555555555556
77266, 1.8521739130435, 0.20217391304348, 0.027777777777778
77267, 1.895652173913, 0.20217391304348, 0.47222222222222
77268, 1.8739130434783, 0.20217391304348, 0.44444444444444
77269, 1.895652173913, 0.22826086956522, 0.44444444444444
77270, 1.895652173913, 0.20217391304348, 0.41666666666667
77271, 1.8739130434783, 0.20217391304348, 0.38888888888889
77272, 1.895652173913, 0.22826086956522, 0.38888888888889
77273, 1.895652173913, 0.20217391304348, 0.36111111111111
77274, 1.8739130434783, 0.20217391304348, 0.33333333333333
77275, 1.895652173913, 0.22826086956522, 0.33333333333333
77276, 1.895652173913, 0.20217391304348, 0.30555555555556
77277, 1.8739130434783, 0.20217391304348, 0.27777777777778
77278, 1.895652173913, 0.22826086956522, 0.27777777777778
77279, 1.895652173913, 0.20217391304348, 0.25
77280, 1.8739130434783, 0.20217391304348, 0.22222222222222
77281, 1.895652173913, 0.22826086956522, 0.22222222222222
77282, 1.895652173913, 0.20217391304348, 0.19444444444444
77283, 1.8739130434783, 0.20217391304348, 0.16666666666667
77284, 1.895652173913, 0.22826086956522, 0.16666666666667
77285, 1.895652173913, 0.20217391304348, 0.13888888888889
77286, 1.8739130434783, 0.20217391304348, 0.11111111111111
77287, 1.895652173913, 0.22826086956522, 0.11111111111111
77288, 1.895652173913, 0.20217391304348, 0.083333333333333
77289, 1.8739130434783, 0.20217391304348, 0.055555555555556
77290, 1.895652173913, 0.22826086956522, 0.055555555555556
77291, 1.895652173913, 0.20217391304348, 0.027777777777778
77292, 1.9391304347826, 0.20217391304348, 0.47222222222222
77293, 1.9173913043478, 0.20217391304348, 0.44444444444444
77294, 1.9391304347826, 0.22826086956522, 0.44444444444444
77295, 1.9391304347826, 0.20217391304348, 0.41666666666667
77296, 1.9173913043478, 0.20217391304348, 0.38888888888889
77297, 1.9391304347826, 0.22826086956522, 0.38888888888889
77298, 1.9391304347826, 0.20217391304348, 0.36111111111111
77299, 1.9173913043478, 0.20217391304348, 0.33333333333333
77300, 1.9391304347826, 0.22826086956522, 0.33333333333333
77301, 1.9391304347826, 0.20217391304348, 0.30555555555556
77302, 1.9173913043478, 0.20217391304348, 0.27777777777778
77303, 1.9391304347826, 0.22826086956522, 0.27777777777778
77304, 1.9391304347826, 0.20217391304348, 0.25
77305, 1.9173913043478, 0.20217391304348, 0.22222222222222
77306, 1.9391304347826, 0.22826086956522, 0.22222222222222
77307, 1.9391304347826, 0.20217391304348, 0.19444444444444
77308, 1.9173913043478, 0.20217391304348, 0.16666666666667
77309, 1.9391304347826, 0.22826086956522, 0.16666666666667
77310, 1.9391304347826, 0.20217391304348, 0.13888888888889
77311, 1.9173913043478, 0.20217391304348, 0.11111111111111
77312, 1.9391304347826, 0.22826086956522, 0.11111111111111
77313, 1.9391304347826, 0.20217391304348, 0.083333333333333
77314, 1.9173913043478, 0.20217391304348, 0.055555555555556
77315, 1.9391304347826, 0.22826086956522, 0.055555555555556
77316, 1.9391304347826, 0.20217391304348, 0.027777777777778
77317, 1.9826086956522, 0.20217391304348, 0.47222222222222
77318, 1.9608695652174, 0.20217391304348, 0.44444444444444
77319, 1.9826086956522, 0.22826086956522, 0.44444444444444
77320, 1.9826086956522, 0.20217391304348, 0.41666666666667
77321, 1.9608695652174, 0.20217391304348, 0.38888888888889
77322, 1.9826086956522, 0.22826086956522, 0.38888888888889
77323, 1.9826086956522, 0.20217391304348, 0.36111111111111
77324, 1.9608695652174, 0.20217391304348, 0.33333333333333
77325, 1.9826086956522, 0.22826086956522, 0.33333333333333
77326, 1.9826086956522, 0.20217391304348, 0.30555555555556
77327, 1.9608695652174, 0.20217391304348, 0.27777777777778
77328, 1.9826086956522, 0.22826086956522, 0.27777777777778
77329, 1.9826086956522, 0.20217391304348, 0.25
77330, 1.9608695652174, 0.20217391304348, 0.22222222222222
77331, 1.9826086956522, 0.22826086956522, 0.22222222222222
77332, 1.9826086956522, 0.20217391304348, 0.19444444444444
77333, 1.9608695652174, 0.20217391304348, 0.16666666666667
77334, 1.9826086956522, 0.22826086956522, 0.16666666666667
77335, 1.9826086956522, 0.20217391304348, 0.13888888888889
77336, 1.9608695652174, 0.20217391304348, 0.11111111111111
77337, 1.9826086956522, 0.22826086956522, 0.11111111111111
77338, 1.9826086956522, 0.20217391304348, 0.083333333333333
77339, 1.9608695652174, 0.20217391304348, 0.055555555555556
77340, 1.9826086956522, 0.22826086956522, 0.055555555555556
77341, 1.9826086956522, 0.20217391304348, 0.027777777777778
77342, 2.0260869565217, 0.20217391304348, 0.47222222222222
77343, 2.004347826087, 0.20217391304348, 0.44444444444444
77344, 2.0260869565217, 0.22826086956522, 0.44444444444444
77345, 2.0260869565217, 0.20217391304348, 0.41666666666667
77346, 2.004347826087, 0.20217391304348, 0.38888888888889
77347, 2.0260869565217, 0.22826086956522, 0.38888888888889
77348, 2.0260869565217, 0.20217391304348, 0.36111111111111
77349, 2.004347826087, 0.20217391304348, 0.33333333333333
77350, 2.0260869565217, 0.22826086956522, 0.33333333333333
77351, 2.0260869565217, 0.20217391304348, 0.30555555555556
77352, 2.004347826087, 0.20217391304348, 0.27777777777778
77353, 2.0260869565217, 0.22826086956522, 0.27777777777778
77354, 2.0260869565217, 0.20217391304348, 0.25
77355, 2.004347826087, 0.20217391304348, 0.22222222222222
77356, 2.0260869565217, 0.22826086956522, 0.22222222222222
77357, 2.0260869565217, 0.20217391304348, 0.19444444444444
77358, 2.004347826087, 0.20217391304348, 0.16666666666667
77359, 2.0260869565217, 0.22826086956522, 0.16666666666667
77360, 2.0260869565217, 0.20217391304348, 0.13888888888889
77361, 2.004347826087, 0.20217391304348, 0.11111111111111
77362, 2.0260869565217, 0.22826086956522, 0.11111111111111
77363, 2.0260869565217, 0.20217391304348, 0.083333333333333
77364, 2.004347826087, 0.20217391304348, 0.055555555555556
77365, 2.0260869565217, 0.22826086956522, 0.055555555555556
77366, 2.0260869565217, 0.20217391304348, 0.027777777777778
77367, 2.0695652173913, 0.20217391304348, 0.47222222222222
77368, 2.0478260869565, 0.20217391304348, 0.44444444444444
77369, 2.0695652173913, 0.22826086956522, 0.44444444444444
77370, 2.0695652173913, 0.20217391304348, 0.41666666666667
77371, 2.0478260869565, 0.20217391304348, 0.38888888888889
77372, 2.0695652173913, 0.22826086956522, 0.38888888888889
77373, 2.0695652173913, 0.20217391304348, 0.36111111111111
77374, 2.0478260869565, 0.20217391304348, 0.33333333333333
77375, 2.0695652173913, 0.22826086956522, 0.33333333333333
77376, 2.0695652173913, 0.20217391304348, 0.30555555555556
77377, 2.0478260869565, 0.20217391304348, 0.27777777777778
77378, 2.0695652173913, 0.22826086956522, 0.27777777777778
77379, 2.0695652173913, 0.20217391304348, 0.25
77380, 2.0478260869565, 0.20217391304348, 0.22222222222222
77381, 2.0695652173913, 0.22826086956522, 0.22222222222222
77382, 2.0695652173913, 0.20217391304348, 0.19444444444444
77383, 2.0478260869565, 0.20217391304348, 0.16666666666667
77384, 2.0695652173913, 0.22826086956522, 0.16666666666667
77385, 2.0695652173913, 0.20217391304348, 0.13888888888889
77386, 2.0478260869565, 0.20217391304348, 0.11111111111111
77387, 2.0695652173913, 0.22826086956522, 0.11111111111111
77388, 2.0695652173913, 0.20217391304348, 0.083333333333333
77389, 2.0478260869565, 0.20217391304348, 0.055555555555556
77390, 2.0695652173913, 0.22826086956522, 0.055555555555556
77391, 2.0695652173913, 0.20217391304348, 0.027777777777778
77392, 2.1130434782609, 0.20217391304348, 0.47222222222222
77393, 2.0913043478261, 0.20217391304348, 0.44444444444444
77394, 2.1130434782609, 0.22826086956522, 0.44444444444444
77395, 2.1130434782609, 0.20217391304348, 0.41666666666667
77396, 2.0913043478261, 0.20217391304348, 0.38888888888889
77397, 2.1130434782609, 0.22826086956522, 0.38888888888889
77398, 2.1130434782609, 0.20217391304348, 0.36111111111111
77399, 2.0913043478261, 0.20217391304348, 0.33333333333333
77400, 2.1130434782609, 0.22826086956522, 0.33333333333333
77401, 2.1130434782609, 0.20217391304348, 0.30555555555556
77402, 2.0913043478261, 0.20217391304348, 0.27777777777778
77403, 2.1130434782609, 0.22826086956522, 0.27777777777778
77404, 2.1130434782609, 0.20217391304348, 0.25
77405, 2.0913043478261, 0.20217391304348, 0.22222222222222
77406, 2.1130434782609, 0.22826086956522, 0.22222222222222
77407, 2.1130434782609, 0.20217391304348, 0.19444444444444
77408, 2.0913043478261, 0.20217391304348, 0.16666666666667
77409, 2.1130434782609, 0.22826086956522, 0.16666666666667
77410, 2.1130434782609, 0.20217391304348, 0.13888888888889
77411, 2.0913043478261, 0.20217391304348, 0.11111111111111
77412, 2.1130434782609, 0.22826086956522, 0.11111111111111
77413, 2.1130434782609, 0.20217391304348, 0.083333333333333
77414, 2.0913043478261, 0.20217391304348, 0.055555555555556
77415, 2.1130434782609, 0.22826086956522, 0.055555555555556
77416, 2.1130434782609, 0.20217391304348, 0.027777777777778
77417, 2.1565217391304, 0.20217391304348, 0.47222222222222
77418, 2.1347826086957, 0.20217391304348, 0.44444444444444
77419, 2.1565217391304, 0.22826086956522, 0.44444444444444
77420, 2.1565217391304, 0.20217391304348, 0.41666666666667
77421, 2.1347826086957, 0.20217391304348, 0.38888888888889
77422, 2.1565217391304, 0.22826086956522, 0.38888888888889
77423, 2.1565217391304, 0.20217391304348, 0.36111111111111
77424, 2.1347826086957, 0.20217391304348, 0.33333333333333
77425, 2.1565217391304, 0.22826086956522, 0.33333333333333
77426, 2.1565217391304, 0.20217391304348, 0.30555555555556
77427, 2.1347826086957, 0.20217391304348, 0.27777777777778
77428, 2.1565217391304, 0.22826086956522, 0.27777777777778
77429, 2.1565217391304, 0.20217391304348, 0.25
77430, 2.1347826086957, 0.20217391304348, 0.22222222222222
77431, 2.1565217391304, 0.22826086956522, 0.22222222222222
77432, 2.1565217391304, 0.20217391304348, 0.19444444444444
77433, 2.1347826086957, 0.20217391304348, 0.16666666666667
77434, 2.1565217391304, 0.22826086956522, 0.16666666666667
77435, 2.1565217391304, 0.20217391304348, 0.13888888888889
77436, 2.1347826086957, 0.20217391304348, 0.11111111111111
77437, 2.1565217391304, 0.22826086956522, 0.11111111111111
77438, 2.1565217391304, 0.20217391304348, 0.083333333333333
77439, 2.1347826086957, 0.20217391304348, 0.055555555555556
77440, 2.1565217391304, 0.22826086956522, 0.055555555555556
77441, 2.1565217391304, 0.20217391304348, 0.027777777777778
77442, 2.1782608695652, 0.20217391304348, 0.44444444444444
77443, 2.1782608695652, 0.20217391304348, 0.38888888888889
77444, 2.1782608695652, 0.20217391304348, 0.33333333333333
77445, 2.1782608695652, 0.20217391304348, 0.27777777777778
77446, 2.1782608695652, 0.20217391304348, 0.22222222222222
77447, 2.1782608695652, 0.20217391304348, 0.16666666666667
77448, 2.1782608695652, 0.20217391304348, 0.11111111111111
77449, 2.1782608695652, 0.20217391304348, 0.055555555555556
77450, 1.2434782608696, 0.17608695652174, 0.44444444444444
77451, 1.2434782608696, 0.17608695652174, 0.38888888888889
77452, 1.2434782608696, 0.17608695652174, 0.33333333333333
77453, 1.2434782608696, 0.17608695652174, 0.27777777777778
77454, 1.2434782608696, 0.17608695652174, 0.22222222222222
77455, 1.2434782608696, 0.17608695652174, 0.16666666666667
77456, 1.2434782608696, 0.17608695652174, 0.11111111111111
77457, 1.2434782608696, 0.17608695652174, 0.055555555555556
77458, 1.2869565217391, 0.17608695652174, 0.44444444444444
77459, 1.2869565217391, 0.17608695652174, 0.38888888888889
77460, 1.2869565217391, 0.17608695652174, 0.33333333333333
77461, 1.2869565217391, 0.17608695652174, 0.27777777777778
77462, 1.2869565217391, 0.17608695652174, 0.22222222222222
77463, 1.2869565217391, 0.17608695652174, 0.16666666666667
77464, 1.2869565217391, 0.17608695652174, 0.11111111111111
77465, 1.2869565217391, 0.17608695652174, 0.055555555555556
77466, 1.3304347826087, 0.17608695652174, 0.44444444444444
77467, 1.3304347826087, 0.17608695652174, 0.38888888888889
77468, 1.3304347826087, 0.17608695652174, 0.33333333333333
77469, 1.3304347826087, 0.17608695652174, 0.27777777777778
77470, 1.3304347826087, 0.17608695652174, 0.22222222222222
77471, 1.3304347826087, 0.17608695652174, 0.16666666666667
77472, 1.3304347826087, 0.17608695652174, 0.11111111111111
77473, 1.3304347826087, 0.17608695652174, 0.055555555555556
77474, 1.3739130434783, 0.17608695652174, 0.44444444444444
77475, 1.3739130434783, 0.17608695652174, 0.38888888888889
77476, 1.3739130434783, 0.17608695652174, 0.33333333333333
77477, 1.3739130434783, 0.17608695652174, 0.27777777777778
77478, 1.3739130434783, 0.17608695652174, 0.22222222222222
77479, 1.3739130434783, 0.17608695652174, 0.16666666666667
77480, 1.3739130434783, 0.17608695652174, 0.11111111111111
