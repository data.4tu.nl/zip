90081, 90079, 90054, 89496, 89521
32471, 88471, 88463, 88287, 88295, 88472, 88464, 88288, 88296, 90080, 90056, 89522, 90081, 90083, 90059, 89525, 
90084, 90082, 90057, 89499, 89524
32472, 88472, 88464, 88288, 88296, 88473, 88465, 88289, 88297, 90083, 90059, 89525, 90084, 90086, 90062, 89528, 
90087, 90085, 90060, 89502, 89527
32473, 88473, 88465, 88289, 88297, 9109, 9108, 9086, 9087, 90086, 90062, 89528, 90087, 9240, 9237, 9195, 
9239, 90088, 90063, 89505, 89530
32474, 8887, 8886, 8864, 8865, 88474, 88466, 88290, 88298, 9018, 9017, 8973, 9019, 90090, 90066, 89532, 
90091, 90089, 90064, 89506, 89531
32475, 88474, 88466, 88290, 88298, 88475, 88467, 88291, 88299, 90090, 90066, 89532, 90091, 90093, 90069, 89535, 
90094, 90092, 90067, 89509, 89534
32476, 88475, 88467, 88291, 88299, 88476, 88468, 88292, 88300, 90093, 90069, 89535, 90094, 90096, 90072, 89538, 
90097, 90095, 90070, 89512, 89537
32477, 88476, 88468, 88292, 88300, 88477, 88469, 88293, 88301, 90096, 90072, 89538, 90097, 90099, 90075, 89541, 
90100, 90098, 90073, 89515, 89540
32478, 88477, 88469, 88293, 88301, 88478, 88470, 88294, 88302, 90099, 90075, 89541, 90100, 90102, 90078, 89544, 
90103, 90101, 90076, 89518, 89543
32479, 88478, 88470, 88294, 88302, 88479, 88471, 88295, 88303, 90102, 90078, 89544, 90103, 90105, 90081, 89547, 
90106, 90104, 90079, 89521, 89546
32480, 88479, 88471, 88295, 88303, 88480, 88472, 88296, 88304, 90105, 90081, 89547, 90106, 90108, 90084, 89550, 
90109, 90107, 90082, 89524, 89549
32481, 88480, 88472, 88296, 88304, 88481, 88473, 88297, 88305, 90108, 90084, 89550, 90109, 90111, 90087, 89553, 
90112, 90110, 90085, 89527, 89552
32482, 88481, 88473, 88297, 88305, 9110, 9109, 9087, 9088, 90111, 90087, 89553, 90112, 9242, 9239, 9197, 
9241, 90113, 90088, 89530, 89555
32483, 8888, 8887, 8865, 8866, 88482, 88474, 88298, 88306, 9020, 9019, 8975, 9021, 90115, 90091, 89557, 
90116, 90114, 90089, 89531, 89556
32484, 88482, 88474, 88298, 88306, 88483, 88475, 88299, 88307, 90115, 90091, 89557, 90116, 90118, 90094, 89560, 
90119, 90117, 90092, 89534, 89559
32485, 88483, 88475, 88299, 88307, 88484, 88476, 88300, 88308, 90118, 90094, 89560, 90119, 90121, 90097, 89563, 
90122, 90120, 90095, 89537, 89562
32486, 88484, 88476, 88300, 88308, 88485, 88477, 88301, 88309, 90121, 90097, 89563, 90122, 90124, 90100, 89566, 
90125, 90123, 90098, 89540, 89565
32487, 88485, 88477, 88301, 88309, 88486, 88478, 88302, 88310, 90124, 90100, 89566, 90125, 90127, 90103, 89569, 
90128, 90126, 90101, 89543, 89568
32488, 88486, 88478, 88302, 88310, 88487, 88479, 88303, 88311, 90127, 90103, 89569, 90128, 90130, 90106, 89572, 
90131, 90129, 90104, 89546, 89571
32489, 88487, 88479, 88303, 88311, 88488, 88480, 88304, 88312, 90130, 90106, 89572, 90131, 90133, 90109, 89575, 
90134, 90132, 90107, 89549, 89574
32490, 88488, 88480, 88304, 88312, 88489, 88481, 88305, 88313, 90133, 90109, 89575, 90134, 90136, 90112, 89578, 
90137, 90135, 90110, 89552, 89577
32491, 88489, 88481, 88305, 88313, 9111, 9110, 9088, 9089, 90136, 90112, 89578, 90137, 9244, 9241, 9199, 
9243, 90138, 90113, 89555, 89580
32492, 8889, 8888, 8866, 8867, 88490, 88482, 88306, 88314, 9022, 9021, 8977, 9023, 90140, 90116, 89582, 
90141, 90139, 90114, 89556, 89581
32493, 88490, 88482, 88306, 88314, 88491, 88483, 88307, 88315, 90140, 90116, 89582, 90141, 90143, 90119, 89585, 
90144, 90142, 90117, 89559, 89584
32494, 88491, 88483, 88307, 88315, 88492, 88484, 88308, 88316, 90143, 90119, 89585, 90144, 90146, 90122, 89588, 
90147, 90145, 90120, 89562, 89587
32495, 88492, 88484, 88308, 88316, 88493, 88485, 88309, 88317, 90146, 90122, 89588, 90147, 90149, 90125, 89591, 
90150, 90148, 90123, 89565, 89590
32496, 88493, 88485, 88309, 88317, 88494, 88486, 88310, 88318, 90149, 90125, 89591, 90150, 90152, 90128, 89594, 
90153, 90151, 90126, 89568, 89593
32497, 88494, 88486, 88310, 88318, 88495, 88487, 88311, 88319, 90152, 90128, 89594, 90153, 90155, 90131, 89597, 
90156, 90154, 90129, 89571, 89596
32498, 88495, 88487, 88311, 88319, 88496, 88488, 88312, 88320, 90155, 90131, 89597, 90156, 90158, 90134, 89600, 
90159, 90157, 90132, 89574, 89599
32499, 88496, 88488, 88312, 88320, 88497, 88489, 88313, 88321, 90158, 90134, 89600, 90159, 90161, 90137, 89603, 
90162, 90160, 90135, 89577, 89602
32500, 88497, 88489, 88313, 88321, 9112, 9111, 9089, 9090, 90161, 90137, 89603, 90162, 9246, 9243, 9201, 
9245, 90163, 90138, 89580, 89605
32501, 960, 8889, 8867, 959, 9286, 88490, 88314, 9278, 9024, 9023, 8979, 963, 90164, 90141, 89606, 
9329, 9328, 90139, 89581, 9311
32502, 9286, 88490, 88314, 9278, 9287, 88491, 88315, 9279, 90164, 90141, 89606, 9329, 90165, 90144, 89607, 
9331, 9330, 90142, 89584, 9313
32503, 9287, 88491, 88315, 9279, 9288, 88492, 88316, 9280, 90165, 90144, 89607, 9331, 90166, 90147, 89608, 
9333, 9332, 90145, 89587, 9315
32504, 9288, 88492, 88316, 9280, 9289, 88493, 88317, 9281, 90166, 90147, 89608, 9333, 90167, 90150, 89609, 
9335, 9334, 90148, 89590, 9317
32505, 9289, 88493, 88317, 9281, 9290, 88494, 88318, 9282, 90167, 90150, 89609, 9335, 90168, 90153, 89610, 
9337, 9336, 90151, 89593, 9319
32506, 9290, 88494, 88318, 9282, 9291, 88495, 88319, 9283, 90168, 90153, 89610, 9337, 90169, 90156, 89611, 
9339, 9338, 90154, 89596, 9321
32507, 9291, 88495, 88319, 9283, 9292, 88496, 88320, 9284, 90169, 90156, 89611, 9339, 90170, 90159, 89612, 
9341, 9340, 90157, 89599, 9323
32508, 9292, 88496, 88320, 9284, 9293, 88497, 88321, 9285, 90170, 90159, 89612, 9341, 90171, 90162, 89613, 
9343, 9342, 90160, 89602, 9325
32509, 9293, 88497, 88321, 9285, 1057, 9112, 9090, 1056, 90171, 90162, 89613, 9343, 9247, 9245, 9202, 
1060, 9344, 90163, 89605, 9327
32510, 1010, 28, 898, 8868, 9911, 948, 8757, 88322, 1032, 902, 8980, 9025, 10087, 8816, 89615, 
90172, 10088, 957, 8799, 89614
32511, 9911, 948, 8757, 88322, 9912, 947, 8758, 88323, 10087, 8816, 89615, 90172, 10089, 8817, 89618, 
90173, 10090, 956, 8801, 89617
32512, 9912, 947, 8758, 88323, 9913, 946, 8759, 88324, 10089, 8817, 89618, 90173, 10091, 8818, 89621, 
90174, 10092, 955, 8803, 89620
32513, 9913, 946, 8759, 88324, 9914, 945, 8760, 88325, 10091, 8818, 89621, 90174, 10093, 8819, 89624, 
90175, 10094, 954, 8805, 89623
32514, 9914, 945, 8760, 88325, 9915, 944, 8761, 88326, 10093, 8819, 89624, 90175, 10095, 8820, 89627, 
90176, 10096, 953, 8807, 89626
32515, 9915, 944, 8761, 88326, 9916, 943, 8762, 88327, 10095, 8820, 89627, 90176, 10097, 8821, 89630, 
90177, 10098, 952, 8809, 89629
32516, 9916, 943, 8762, 88327, 9917, 942, 8763, 88328, 10097, 8821, 89630, 90177, 10099, 8822, 89633, 
90178, 10100, 951, 8811, 89632
32517, 9917, 942, 8763, 88328, 9918, 941, 8764, 88329, 10099, 8822, 89633, 90178, 10101, 8823, 89636, 
90179, 10102, 950, 8813, 89635
32518, 9918, 941, 8764, 88329, 1107, 30, 919, 9091, 10101, 8823, 89636, 90179, 1129, 923, 9204, 
9248, 10103, 949, 8815, 89638
32519, 1011, 1010, 8868, 8869, 9919, 9911, 88322, 88330, 1033, 9025, 8982, 9026, 10104, 90172, 89640, 
90180, 10105, 10088, 89614, 89639
32520, 9919, 9911, 88322, 88330, 9920, 9912, 88323, 88331, 10104, 90172, 89640, 90180, 10106, 90173, 89643, 
90181, 10107, 10090, 89617, 89642
32521, 9920, 9912, 88323, 88331, 9921, 9913, 88324, 88332, 10106, 90173, 89643, 90181, 10108, 90174, 89646, 
90182, 10109, 10092, 89620, 89645
32522, 9921, 9913, 88324, 88332, 9922, 9914, 88325, 88333, 10108, 90174, 89646, 90182, 10110, 90175, 89649, 
90183, 10111, 10094, 89623, 89648
32523, 9922, 9914, 88325, 88333, 9923, 9915, 88326, 88334, 10110, 90175, 89649, 90183, 10112, 90176, 89652, 
90184, 10113, 10096, 89626, 89651
32524, 9923, 9915, 88326, 88334, 9924, 9916, 88327, 88335, 10112, 90176, 89652, 90184, 10114, 90177, 89655, 
90185, 10115, 10098, 89629, 89654
32525, 9924, 9916, 88327, 88335, 9925, 9917, 88328, 88336, 10114, 90177, 89655, 90185, 10116, 90178, 89658, 
90186, 10117, 10100, 89632, 89657
32526, 9925, 9917, 88328, 88336, 9926, 9918, 88329, 88337, 10116, 90178, 89658, 90186, 10118, 90179, 89661, 
90187, 10119, 10102, 89635, 89660
32527, 9926, 9918, 88329, 88337, 1108, 1107, 9091, 9092, 10118, 90179, 89661, 90187, 1130, 9248, 9206, 
9249, 10120, 10103, 89638, 89663
32528, 1012, 1011, 8869, 8870, 9927, 9919, 88330, 88338, 1034, 9026, 8984, 9027, 10121, 90180, 89665, 
90188, 10122, 10105, 89639, 89664
32529, 9927, 9919, 88330, 88338, 9928, 9920, 88331, 88339, 10121, 90180, 89665, 90188, 10123, 90181, 89668, 
90189, 10124, 10107, 89642, 89667
32530, 9928, 9920, 88331, 88339, 9929, 9921, 88332, 88340, 10123, 90181, 89668, 90189, 10125, 90182, 89671, 
90190, 10126, 10109, 89645, 89670
32531, 9929, 9921, 88332, 88340, 9930, 9922, 88333, 88341, 10125, 90182, 89671, 90190, 10127, 90183, 89674, 
90191, 10128, 10111, 89648, 89673
32532, 9930, 9922, 88333, 88341, 9931, 9923, 88334, 88342, 10127, 90183, 89674, 90191, 10129, 90184, 89677, 
90192, 10130, 10113, 89651, 89676
32533, 9931, 9923, 88334, 88342, 9932, 9924, 88335, 88343, 10129, 90184, 89677, 90192, 10131, 90185, 89680, 
90193, 10132, 10115, 89654, 89679
32534, 9932, 9924, 88335, 88343, 9933, 9925, 88336, 88344, 10131, 90185, 89680, 90193, 10133, 90186, 89683, 
90194, 10134, 10117, 89657, 89682
32535, 9933, 9925, 88336, 88344, 9934, 9926, 88337, 88345, 10133, 90186, 89683, 90194, 10135, 90187, 89686, 
90195, 10136, 10119, 89660, 89685
32536, 9934, 9926, 88337, 88345, 1109, 1108, 9092, 9093, 10135, 90187, 89686, 90195, 1131, 9249, 9208, 
9250, 10137, 10120, 89663, 89688
32537, 1013, 1012, 8870, 8871, 9935, 9927, 88338, 88346, 1035, 9027, 8986, 9028, 10138, 90188, 89690, 
90196, 10139, 10122, 89664, 89689
32538, 9935, 9927, 88338, 88346, 9936, 9928, 88339, 88347, 10138, 90188, 89690, 90196, 10140, 90189, 89693, 
90197, 10141, 10124, 89667, 89692
32539, 9936, 9928, 88339, 88347, 9937, 9929, 88340, 88348, 10140, 90189, 89693, 90197, 10142, 90190, 89696, 
90198, 10143, 10126, 89670, 89695
32540, 9937, 9929, 88340, 88348, 9938, 9930, 88341, 88349, 10142, 90190, 89696, 90198, 10144, 90191, 89699, 
90199, 10145, 10128, 89673, 89698
32541, 9938, 9930, 88341, 88349, 9939, 9931, 88342, 88350, 10144, 90191, 89699, 90199, 10146, 90192, 89702, 
90200, 10147, 10130, 89676, 89701
32542, 9939, 9931, 88342, 88350, 9940, 9932, 88343, 88351, 10146, 90192, 89702, 90200, 10148, 90193, 89705, 
90201, 10149, 10132, 89679, 89704
32543, 9940, 9932, 88343, 88351, 9941, 9933, 88344, 88352, 10148, 90193, 89705, 90201, 10150, 90194, 89708, 
90202, 10151, 10134, 89682, 89707
32544, 9941, 9933, 88344, 88352, 9942, 9934, 88345, 88353, 10150, 90194, 89708, 90202, 10152, 90195, 89711, 
90203, 10153, 10136, 89685, 89710
32545, 9942, 9934, 88345, 88353, 1110, 1109, 9093, 9094, 10152, 90195, 89711, 90203, 1132, 9250, 9210, 
9251, 10154, 10137, 89688, 89713
32546, 1014, 1013, 8871, 8872, 9943, 9935, 88346, 88354, 1036, 9028, 8988, 9029, 10155, 90196, 89715, 
90204, 10156, 10139, 89689, 89714
32547, 9943, 9935, 88346, 88354, 9944, 9936, 88347, 88355, 10155, 90196, 89715, 90204, 10157, 90197, 89718, 
90205, 10158, 10141, 89692, 89717
32548, 9944, 9936, 88347, 88355, 9945, 9937, 88348, 88356, 10157, 90197, 89718, 90205, 10159, 90198, 89721, 
90206, 10160, 10143, 89695, 89720
32549, 9945, 9937, 88348, 88356, 9946, 9938, 88349, 88357, 10159, 90198, 89721, 90206, 10161, 90199, 89724, 
90207, 10162, 10145, 89698, 89723
32550, 9946, 9938, 88349, 88357, 9947, 9939, 88350, 88358, 10161, 90199, 89724, 90207, 10163, 90200, 89727, 
90208, 10164, 10147, 89701, 89726
32551, 9947, 9939, 88350, 88358, 9948, 9940, 88351, 88359, 10163, 90200, 89727, 90208, 10165, 90201, 89730, 
90209, 10166, 10149, 89704, 89729
32552, 9948, 9940, 88351, 88359, 9949, 9941, 88352, 88360, 10165, 90201, 89730, 90209, 10167, 90202, 89733, 
90210, 10168, 10151, 89707, 89732
32553, 9949, 9941, 88352, 88360, 9950, 9942, 88353, 88361, 10167, 90202, 89733, 90210, 10169, 90203, 89736, 
90211, 10170, 10153, 89710, 89735
32554, 9950, 9942, 88353, 88361, 1111, 1110, 9094, 9095, 10169, 90203, 89736, 90211, 1133, 9251, 9212, 
9252, 10171, 10154, 89713, 89738
32555, 1015, 1014, 8872, 8873, 9951, 9943, 88354, 88362, 1037, 9029, 8990, 9030, 10172, 90204, 89740, 
90212, 10173, 10156, 89714, 89739
32556, 9951, 9943, 88354, 88362, 9952, 9944, 88355, 88363, 10172, 90204, 89740, 90212, 10174, 90205, 89743, 
90213, 10175, 10158, 89717, 89742
32557, 9952, 9944, 88355, 88363, 9953, 9945, 88356, 88364, 10174, 90205, 89743, 90213, 10176, 90206, 89746, 
90214, 10177, 10160, 89720, 89745
32558, 9953, 9945, 88356, 88364, 9954, 9946, 88357, 88365, 10176, 90206, 89746, 90214, 10178, 90207, 89749, 
90215, 10179, 10162, 89723, 89748
32559, 9954, 9946, 88357, 88365, 9955, 9947, 88358, 88366, 10178, 90207, 89749, 90215, 10180, 90208, 89752, 
90216, 10181, 10164, 89726, 89751
32560, 9955, 9947, 88358, 88366, 9956, 9948, 88359, 88367, 10180, 90208, 89752, 90216, 10182, 90209, 89755, 
90217, 10183, 10166, 89729, 89754
32561, 9956, 9948, 88359, 88367, 9957, 9949, 88360, 88368, 10182, 90209, 89755, 90217, 10184, 90210, 89758, 
90218, 10185, 10168, 89732, 89757
32562, 9957, 9949, 88360, 88368, 9958, 9950, 88361, 88369, 10184, 90210, 89758, 90218, 10186, 90211, 89761, 
90219, 10187, 10170, 89735, 89760
32563, 9958, 9950, 88361, 88369, 1112, 1111, 9095, 9096, 10186, 90211, 89761, 90219, 1134, 9252, 9214, 
9253, 10188, 10171, 89738, 89763
32564, 1016, 1015, 8873, 8874, 9959, 9951, 88362, 88370, 1038, 9030, 8992, 9031, 10189, 90212, 89765, 
90220, 10190, 10173, 89739, 89764
32565, 9959, 9951, 88362, 88370, 9960, 9952, 88363, 88371, 10189, 90212, 89765, 90220, 10191, 90213, 89768, 
90221, 10192, 10175, 89742, 89767
32566, 9960, 9952, 88363, 88371, 9961, 9953, 88364, 88372, 10191, 90213, 89768, 90221, 10193, 90214, 89771, 
90222, 10194, 10177, 89745, 89770
32567, 9961, 9953, 88364, 88372, 9962, 9954, 88365, 88373, 10193, 90214, 89771, 90222, 10195, 90215, 89774, 
90223, 10196, 10179, 89748, 89773
32568, 9962, 9954, 88365, 88373, 9963, 9955, 88366, 88374, 10195, 90215, 89774, 90223, 10197, 90216, 89777, 
90224, 10198, 10181, 89751, 89776
32569, 9963, 9955, 88366, 88374, 9964, 9956, 88367, 88375, 10197, 90216, 89777, 90224, 10199, 90217, 89780, 
90225, 10200, 10183, 89754, 89779
32570, 9964, 9956, 88367, 88375, 9965, 9957, 88368, 88376, 10199, 90217, 89780, 90225, 10201, 90218, 89783, 
90226, 10202, 10185, 89757, 89782
32571, 9965, 9957, 88368, 88376, 9966, 9958, 88369, 88377, 10201, 90218, 89783, 90226, 10203, 90219, 89786, 
90227, 10204, 10187, 89760, 89785
32572, 9966, 9958, 88369, 88377, 1113, 1112, 9096, 9097, 10203, 90219, 89786, 90227, 1135, 9253, 9216, 
9254, 10205, 10188, 89763, 89788
32573, 1017, 1016, 8874, 8875, 9967, 9959, 88370, 88378, 1039, 9031, 8994, 9032, 10206, 90220, 89790, 
90228, 10207, 10190, 89764, 89789
32574, 9967, 9959, 88370, 88378, 9968, 9960, 88371, 88379, 10206, 90220, 89790, 90228, 10208, 90221, 89793, 
90229, 10209, 10192, 89767, 89792
32575, 9968, 9960, 88371, 88379, 9969, 9961, 88372, 88380, 10208, 90221, 89793, 90229, 10210, 90222, 89796, 
90230, 10211, 10194, 89770, 89795
32576, 9969, 9961, 88372, 88380, 9970, 9962, 88373, 88381, 10210, 90222, 89796, 90230, 10212, 90223, 89799, 
90231, 10213, 10196, 89773, 89798
32577, 9970, 9962, 88373, 88381, 9971, 9963, 88374, 88382, 10212, 90223, 89799, 90231, 10214, 90224, 89802, 
90232, 10215, 10198, 89776, 89801
32578, 9971, 9963, 88374, 88382, 9972, 9964, 88375, 88383, 10214, 90224, 89802, 90232, 10216, 90225, 89805, 
90233, 10217, 10200, 89779, 89804
32579, 9972, 9964, 88375, 88383, 9973, 9965, 88376, 88384, 10216, 90225, 89805, 90233, 10218, 90226, 89808, 
90234, 10219, 10202, 89782, 89807
32580, 9973, 9965, 88376, 88384, 9974, 9966, 88377, 88385, 10218, 90226, 89808, 90234, 10220, 90227, 89811, 
90235, 10221, 10204, 89785, 89810
32581, 9974, 9966, 88377, 88385, 1114, 1113, 9097, 9098, 10220, 90227, 89811, 90235, 1136, 9254, 9218, 
9255, 10222, 10205, 89788, 89813
32582, 1018, 1017, 8875, 8876, 9975, 9967, 88378, 88386, 1040, 9032, 8996, 9033, 10223, 90228, 89815, 
90236, 10224, 10207, 89789, 89814
32583, 9975, 9967, 88378, 88386, 9976, 9968, 88379, 88387, 10223, 90228, 89815, 90236, 10225, 90229, 89818, 
90237, 10226, 10209, 89792, 89817
32584, 9976, 9968, 88379, 88387, 9977, 9969, 88380, 88388, 10225, 90229, 89818, 90237, 10227, 90230, 89821, 
90238, 10228, 10211, 89795, 89820
32585, 9977, 9969, 88380, 88388, 9978, 9970, 88381, 88389, 10227, 90230, 89821, 90238, 10229, 90231, 89824, 
90239, 10230, 10213, 89798, 89823
32586, 9978, 9970, 88381, 88389, 9979, 9971, 88382, 88390, 10229, 90231, 89824, 90239, 10231, 90232, 89827, 
90240, 10232, 10215, 89801, 89826
32587, 9979, 9971, 88382, 88390, 9980, 9972, 88383, 88391, 10231, 90232, 89827, 90240, 10233, 90233, 89830, 
90241, 10234, 10217, 89804, 89829
32588, 9980, 9972, 88383, 88391, 9981, 9973, 88384, 88392, 10233, 90233, 89830, 90241, 10235, 90234, 89833, 
90242, 10236, 10219, 89807, 89832
32589, 9981, 9973, 88384, 88392, 9982, 9974, 88385, 88393, 10235, 90234, 89833, 90242, 10237, 90235, 89836, 
90243, 10238, 10221, 89810, 89835
32590, 9982, 9974, 88385, 88393, 1115, 1114, 9098, 9099, 10237, 90235, 89836, 90243, 1137, 9255, 9220, 
9256, 10239, 10222, 89813, 89838
32591, 1019, 1018, 8876, 8877, 9983, 9975, 88386, 88394, 1041, 9033, 8998, 9034, 10240, 90236, 89840, 
90244, 10241, 10224, 89814, 89839
32592, 9983, 9975, 88386, 88394, 9984, 9976, 88387, 88395, 10240, 90236, 89840, 90244, 10242, 90237, 89843, 
90245, 10243, 10226, 89817, 89842
32593, 9984, 9976, 88387, 88395, 9985, 9977, 88388, 88396, 10242, 90237, 89843, 90245, 10244, 90238, 89846, 
90246, 10245, 10228, 89820, 89845
32594, 9985, 9977, 88388, 88396, 9986, 9978, 88389, 88397, 10244, 90238, 89846, 90246, 10246, 90239, 89849, 
90247, 10247, 10230, 89823, 89848
32595, 9986, 9978, 88389, 88397, 9987, 9979, 88390, 88398, 10246, 90239, 89849, 90247, 10248, 90240, 89852, 
90248, 10249, 10232, 89826, 89851
32596, 9987, 9979, 88390, 88398, 9988, 9980, 88391, 88399, 10248, 90240, 89852, 90248, 10250, 90241, 89855, 
90249, 10251, 10234, 89829, 89854
32597, 9988, 9980, 88391, 88399, 9989, 9981, 88392, 88400, 10250, 90241, 89855, 90249, 10252, 90242, 89858, 
90250, 10253, 10236, 89832, 89857
32598, 9989, 9981, 88392, 88400, 9990, 9982, 88393, 88401, 10252, 90242, 89858, 90250, 10254, 90243, 89861, 
90251, 10255, 10238, 89835, 89860
32599, 9990, 9982, 88393, 88401, 1116, 1115, 9099, 9100, 10254, 90243, 89861, 90251, 1138, 9256, 9222, 
9257, 10256, 10239, 89838, 89863
32600, 1020, 1019, 8877, 8878, 9991, 9983, 88394, 88402, 1042, 9034, 9000, 9035, 10257, 90244, 89865, 
90252, 10258, 10241, 89839, 89864
32601, 9991, 9983, 88394, 88402, 9992, 9984, 88395, 88403, 10257, 90244, 89865, 90252, 10259, 90245, 89868, 
90253, 10260, 10243, 89842, 89867
32602, 9992, 9984, 88395, 88403, 9993, 9985, 88396, 88404, 10259, 90245, 89868, 90253, 10261, 90246, 89871, 
90254, 10262, 10245, 89845, 89870
32603, 9993, 9985, 88396, 88404, 9994, 9986, 88397, 88405, 10261, 90246, 89871, 90254, 10263, 90247, 89874, 
90255, 10264, 10247, 89848, 89873
32604, 9994, 9986, 88397, 88405, 9995, 9987, 88398, 88406, 10263, 90247, 89874, 90255, 10265, 90248, 89877, 
90256, 10266, 10249, 89851, 89876
32605, 9995, 9987, 88398, 88406, 9996, 9988, 88399, 88407, 10265, 90248, 89877, 90256, 10267, 90249, 89880, 
90257, 10268, 10251, 89854, 89879
32606, 9996, 9988, 88399, 88407, 9997, 9989, 88400, 88408, 10267, 90249, 89880, 90257, 10269, 90250, 89883, 
90258, 10270, 10253, 89857, 89882
32607, 9997, 9989, 88400, 88408, 9998, 9990, 88401, 88409, 10269, 90250, 89883, 90258, 10271, 90251, 89886, 
90259, 10272, 10255, 89860, 89885
32608, 9998, 9990, 88401, 88409, 1117, 1116, 9100, 9101, 10271, 90251, 89886, 90259, 1139, 9257, 9224, 
9258, 10273, 10256, 89863, 89888
32609, 1021, 1020, 8878, 8879, 9999, 9991, 88402, 88410, 1043, 9035, 9002, 9036, 10274, 90252, 89890, 
90260, 10275, 10258, 89864, 89889
32610, 9999, 9991, 88402, 88410, 10000, 9992, 88403, 88411, 10274, 90252, 89890, 90260, 10276, 90253, 89893, 
90261, 10277, 10260, 89867, 89892
32611, 10000, 9992, 88403, 88411, 10001, 9993, 88404, 88412, 10276, 90253, 89893, 90261, 10278, 90254, 89896, 
90262, 10279, 10262, 89870, 89895
32612, 10001, 9993, 88404, 88412, 10002, 9994, 88405, 88413, 10278, 90254, 89896, 90262, 10280, 90255, 89899, 
90263, 10281, 10264, 89873, 89898
32613, 10002, 9994, 88405, 88413, 10003, 9995, 88406, 88414, 10280, 90255, 89899, 90263, 10282, 90256, 89902, 
90264, 10283, 10266, 89876, 89901
32614, 10003, 9995, 88406, 88414, 10004, 9996, 88407, 88415, 10282, 90256, 89902, 90264, 10284, 90257, 89905, 
90265, 10285, 10268, 89879, 89904
32615, 10004, 9996, 88407, 88415, 10005, 9997, 88408, 88416, 10284, 90257, 89905, 90265, 10286, 90258, 89908, 
90266, 10287, 10270, 89882, 89907
32616, 10005, 9997, 88408, 88416, 10006, 9998, 88409, 88417, 10286, 90258, 89908, 90266, 10288, 90259, 89911, 
90267, 10289, 10272, 89885, 89910
32617, 10006, 9998, 88409, 88417, 1118, 1117, 9101, 9102, 10288, 90259, 89911, 90267, 1140, 9258, 9226, 
9259, 10290, 10273, 89888, 89913
32618, 1022, 1021, 8879, 8880, 10007, 9999, 88410, 88418, 1044, 9036, 9004, 9037, 10291, 90260, 89915, 
90268, 10292, 10275, 89889, 89914
32619, 10007, 9999, 88410, 88418, 10008, 10000, 88411, 88419, 10291, 90260, 89915, 90268, 10293, 90261, 89918, 
90269, 10294, 10277, 89892, 89917
32620, 10008, 10000, 88411, 88419, 10009, 10001, 88412, 88420, 10293, 90261, 89918, 90269, 10295, 90262, 89921, 
90270, 10296, 10279, 89895, 89920
32621, 10009, 10001, 88412, 88420, 10010, 10002, 88413, 88421, 10295, 90262, 89921, 90270, 10297, 90263, 89924, 
90271, 10298, 10281, 89898, 89923
32622, 10010, 10002, 88413, 88421, 10011, 10003, 88414, 88422, 10297, 90263, 89924, 90271, 10299, 90264, 89927, 
90272, 10300, 10283, 89901, 89926
32623, 10011, 10003, 88414, 88422, 10012, 10004, 88415, 88423, 10299, 90264, 89927, 90272, 10301, 90265, 89930, 
90273, 10302, 10285, 89904, 89929
32624, 10012, 10004, 88415, 88423, 10013, 10005, 88416, 88424, 10301, 90265, 89930, 90273, 10303, 90266, 89933, 
90274, 10304, 10287, 89907, 89932
32625, 10013, 10005, 88416, 88424, 10014, 10006, 88417, 88425, 10303, 90266, 89933, 90274, 10305, 90267, 89936, 
90275, 10306, 10289, 89910, 89935
32626, 10014, 10006, 88417, 88425, 1119, 1118, 9102, 9103, 10305, 90267, 89936, 90275, 1141, 9259, 9228, 
9260, 10307, 10290, 89913, 89938
32627, 1023, 1022, 8880, 8881, 10015, 10007, 88418, 88426, 1045, 9037, 9006, 9038, 10308, 90268, 89940, 
90276, 10309, 10292, 89914, 89939
32628, 10015, 10007, 88418, 88426, 10016, 10008, 88419, 88427, 10308, 90268, 89940, 90276, 10310, 90269, 89943, 
90277, 10311, 10294, 89917, 89942
32629, 10016, 10008, 88419, 88427, 10017, 10009, 88420, 88428, 10310, 90269, 89943, 90277, 10312, 90270, 89946, 
90278, 10313, 10296, 89920, 89945
32630, 10017, 10009, 88420, 88428, 10018, 10010, 88421, 88429, 10312, 90270, 89946, 90278, 10314, 90271, 89949, 
90279, 10315, 10298, 89923, 89948
32631, 10018, 10010, 88421, 88429, 10019, 10011, 88422, 88430, 10314, 90271, 89949, 90279, 10316, 90272, 89952, 
90280, 10317, 10300, 89926, 89951
32632, 10019, 10011, 88422, 88430, 10020, 10012, 88423, 88431, 10316, 90272, 89952, 90280, 10318, 90273, 89955, 
90281, 10319, 10302, 89929, 89954
32633, 10020, 10012, 88423, 88431, 10021, 10013, 88424, 88432, 10318, 90273, 89955, 90281, 10320, 90274, 89958, 
90282, 10321, 10304, 89932, 89957
32634, 10021, 10013, 88424, 88432, 10022, 10014, 88425, 88433, 10320, 90274, 89958, 90282, 10322, 90275, 89961, 
90283, 10323, 10306, 89935, 89960
32635, 10022, 10014, 88425, 88433, 1120, 1119, 9103, 9104, 10322, 90275, 89961, 90283, 1142, 9260, 9230, 
9261, 10324, 10307, 89938, 89963
32636, 1024, 1023, 8881, 8882, 10023, 10015, 88426, 88434, 1046, 9038, 9008, 9039, 10325, 90276, 89965, 
90284, 10326, 10309, 89939, 89964
32637, 10023, 10015, 88426, 88434, 10024, 10016, 88427, 88435, 10325, 90276, 89965, 90284, 10327, 90277, 89968, 
90285, 10328, 10311, 89942, 89967
32638, 10024, 10016, 88427, 88435, 10025, 10017, 88428, 88436, 10327, 90277, 89968, 90285, 10329, 90278, 89971, 
90286, 10330, 10313, 89945, 89970
32639, 10025, 10017, 88428, 88436, 10026, 10018, 88429, 88437, 10329, 90278, 89971, 90286, 10331, 90279, 89974, 
90287, 10332, 10315, 89948, 89973
32640, 10026, 10018, 88429, 88437, 10027, 10019, 88430, 88438, 10331, 90279, 89974, 90287, 10333, 90280, 89977, 
90288, 10334, 10317, 89951, 89976
32641, 10027, 10019, 88430, 88438, 10028, 10020, 88431, 88439, 10333, 90280, 89977, 90288, 10335, 90281, 89980, 
90289, 10336, 10319, 89954, 89979
32642, 10028, 10020, 88431, 88439, 10029, 10021, 88432, 88440, 10335, 90281, 89980, 90289, 10337, 90282, 89983, 
90290, 10338, 10321, 89957, 89982
32643, 10029, 10021, 88432, 88440, 10030, 10022, 88433, 88441, 10337, 90282, 89983, 90290, 10339, 90283, 89986, 
90291, 10340, 10323, 89960, 89985
32644, 10030, 10022, 88433, 88441, 1121, 1120, 9104, 9105, 10339, 90283, 89986, 90291, 1143, 9261, 9232, 
9262, 10341, 10324, 89963, 89988
32645, 1025, 1024, 8882, 8883, 10031, 10023, 88434, 88442, 1047, 9039, 9010, 9040, 10342, 90284, 89990, 
90292, 10343, 10326, 89964, 89989
32646, 10031, 10023, 88434, 88442, 10032, 10024, 88435, 88443, 10342, 90284, 89990, 90292, 10344, 90285, 89993, 
90293, 10345, 10328, 89967, 89992
32647, 10032, 10024, 88435, 88443, 10033, 10025, 88436, 88444, 10344, 90285, 89993, 90293, 10346, 90286, 89996, 
90294, 10347, 10330, 89970, 89995
32648, 10033, 10025, 88436, 88444, 10034, 10026, 88437, 88445, 10346, 90286, 89996, 90294, 10348, 90287, 89999, 
90295, 10349, 10332, 89973, 89998
32649, 10034, 10026, 88437, 88445, 10035, 10027, 88438, 88446, 10348, 90287, 89999, 90295, 10350, 90288, 90002, 
90296, 10351, 10334, 89976, 90001
32650, 10035, 10027, 88438, 88446, 10036, 10028, 88439, 88447, 10350, 90288, 90002, 90296, 10352, 90289, 90005, 
90297, 10353, 10336, 89979, 90004
32651, 10036, 10028, 88439, 88447, 10037, 10029, 88440, 88448, 10352, 90289, 90005, 90297, 10354, 90290, 90008, 
90298, 10355, 10338, 89982, 90007
32652, 10037, 10029, 88440, 88448, 10038, 10030, 88441, 88449, 10354, 90290, 90008, 90298, 10356, 90291, 90011, 
90299, 10357, 10340, 89985, 90010
32653, 10038, 10030, 88441, 88449, 1122, 1121, 9105, 9106, 10356, 90291, 90011, 90299, 1144, 9262, 9234, 
9263, 10358, 10341, 89988, 90013
32654, 1026, 1025, 8883, 8884, 10039, 10031, 88442, 88450, 1048, 9040, 9012, 9041, 10359, 90292, 90015, 
90300, 10360, 10343, 89989, 90014
32655, 10039, 10031, 88442, 88450, 10040, 10032, 88443, 88451, 10359, 90292, 90015, 90300, 10361, 90293, 90018, 
90301, 10362, 10345, 89992, 90017
32656, 10040, 10032, 88443, 88451, 10041, 10033, 88444, 88452, 10361, 90293, 90018, 90301, 10363, 90294, 90021, 
90302, 10364, 10347, 89995, 90020
32657, 10041, 10033, 88444, 88452, 10042, 10034, 88445, 88453, 10363, 90294, 90021, 90302, 10365, 90295, 90024, 
90303, 10366, 10349, 89998, 90023
32658, 10042, 10034, 88445, 88453, 10043, 10035, 88446, 88454, 10365, 90295, 90024, 90303, 10367, 90296, 90027, 
90304, 10368, 10351, 90001, 90026
32659, 10043, 10035, 88446, 88454, 10044, 10036, 88447, 88455, 10367, 90296, 90027, 90304, 10369, 90297, 90030, 
90305, 10370, 10353, 90004, 90029
32660, 10044, 10036, 88447, 88455, 10045, 10037, 88448, 88456, 10369, 90297, 90030, 90305, 10371, 90298, 90033, 
90306, 10372, 10355, 90007, 90032
32661, 10045, 10037, 88448, 88456, 10046, 10038, 88449, 88457, 10371, 90298, 90033, 90306, 10373, 90299, 90036, 
90307, 10374, 10357, 90010, 90035
32662, 10046, 10038, 88449, 88457, 1123, 1122, 9106, 9107, 10373, 90299, 90036, 90307, 1145, 9263, 9236, 
9264, 10375, 10358, 90013, 90038
32663, 1027, 1026, 8884, 8885, 10047, 10039, 88450, 88458, 1049, 9041, 9014, 9042, 10376, 90300, 90040, 
90308, 10377, 10360, 90014, 90039
32664, 10047, 10039, 88450, 88458, 10048, 10040, 88451, 88459, 10376, 90300, 90040, 90308, 10378, 90301, 90043, 
90309, 10379, 10362, 90017, 90042
32665, 10048, 10040, 88451, 88459, 10049, 10041, 88452, 88460, 10378, 90301, 90043, 90309, 10380, 90302, 90046, 
90310, 10381, 10364, 90020, 90045
32666, 10049, 10041, 88452, 88460, 10050, 10042, 88453, 88461, 10380, 90302, 90046, 90310, 10382, 90303, 90049, 
90311, 10383, 10366, 90023, 90048
32667, 10050, 10042, 88453, 88461, 10051, 10043, 88454, 88462, 10382, 90303, 90049, 90311, 10384, 90304, 90052, 
90312, 10385, 10368, 90026, 90051
32668, 10051, 10043, 88454, 88462, 10052, 10044, 88455, 88463, 10384, 90304, 90052, 90312, 10386, 90305, 90055, 
90313, 10387, 10370, 90029, 90054
32669, 10052, 10044, 88455, 88463, 10053, 10045, 88456, 88464, 10386, 90305, 90055, 90313, 10388, 90306, 90058, 
90314, 10389, 10372, 90032, 90057
32670, 10053, 10045, 88456, 88464, 10054, 10046, 88457, 88465, 10388, 90306, 90058, 90314, 10390, 90307, 90061, 
90315, 10391, 10374, 90035, 90060
32671, 10054, 10046, 88457, 88465, 1124, 1123, 9107, 9108, 10390, 90307, 90061, 90315, 1146, 9264, 9238, 
9265, 10392, 10375, 90038, 90063
32672, 1028, 1027, 8885, 8886, 10055, 10047, 88458, 88466, 1050, 9042, 9016, 9043, 10393, 90308, 90065, 
90316, 10394, 10377, 90039, 90064
32673, 10055, 10047, 88458, 88466, 10056, 10048, 88459, 88467, 10393, 90308, 90065, 90316, 10395, 90309, 90068, 
90317, 10396, 10379, 90042, 90067
32674, 10056, 10048, 88459, 88467, 10057, 10049, 88460, 88468, 10395, 90309, 90068, 90317, 10397, 90310, 90071, 
90318, 10398, 10381, 90045, 90070
32675, 10057, 10049, 88460, 88468, 10058, 10050, 88461, 88469, 10397, 90310, 90071, 90318, 10399, 90311, 90074, 
90319, 10400, 10383, 90048, 90073
32676, 10058, 10050, 88461, 88469, 10059, 10051, 88462, 88470, 10399, 90311, 90074, 90319, 10401, 90312, 90077, 
90320, 10402, 10385, 90051, 90076
32677, 10059, 10051, 88462, 88470, 10060, 10052, 88463, 88471, 10401, 90312, 90077, 90320, 10403, 90313, 90080, 
90321, 10404, 10387, 90054, 90079
32678, 10060, 10052, 88463, 88471, 10061, 10053, 88464, 88472, 10403, 90313, 90080, 90321, 10405, 90314, 90083, 
90322, 10406, 10389, 90057, 90082
32679, 10061, 10053, 88464, 88472, 10062, 10054, 88465, 88473, 10405, 90314, 90083, 90322, 10407, 90315, 90086, 
90323, 10408, 10391, 90060, 90085
32680, 10062, 10054, 88465, 88473, 1125, 1124, 9108, 9109, 10407, 90315, 90086, 90323, 1147, 9265, 9240, 
9266, 10409, 10392, 90063, 90088
32681, 1029, 1028, 8886, 8887, 10063, 10055, 88466, 88474, 1051, 9043, 9018, 9044, 10410, 90316, 90090, 
90324, 10411, 10394, 90064, 90089
32682, 10063, 10055, 88466, 88474, 10064, 10056, 88467, 88475, 10410, 90316, 90090, 90324, 10412, 90317, 90093, 
90325, 10413, 10396, 90067, 90092
32683, 10064, 10056, 88467, 88475, 10065, 10057, 88468, 88476, 10412, 90317, 90093, 90325, 10414, 90318, 90096, 
90326, 10415, 10398, 90070, 90095
32684, 10065, 10057, 88468, 88476, 10066, 10058, 88469, 88477, 10414, 90318, 90096, 90326, 10416, 90319, 90099, 
90327, 10417, 10400, 90073, 90098
32685, 10066, 10058, 88469, 88477, 10067, 10059, 88470, 88478, 10416, 90319, 90099, 90327, 10418, 90320, 90102, 
90328, 10419, 10402, 90076, 90101
32686, 10067, 10059, 88470, 88478, 10068, 10060, 88471, 88479, 10418, 90320, 90102, 90328, 10420, 90321, 90105, 
90329, 10421, 10404, 90079, 90104
32687, 10068, 10060, 88471, 88479, 10069, 10061, 88472, 88480, 10420, 90321, 90105, 90329, 10422, 90322, 90108, 
90330, 10423, 10406, 90082, 90107
32688, 10069, 10061, 88472, 88480, 10070, 10062, 88473, 88481, 10422, 90322, 90108, 90330, 10424, 90323, 90111, 
90331, 10425, 10408, 90085, 90110
32689, 10070, 10062, 88473, 88481, 1126, 1125, 9109, 9110, 10424, 90323, 90111, 90331, 1148, 9266, 9242, 
9267, 10426, 10409, 90088, 90113
32690, 1030, 1029, 8887, 8888, 10071, 10063, 88474, 88482, 1052, 9044, 9020, 9045, 10427, 90324, 90115, 
90332, 10428, 10411, 90089, 90114
32691, 10071, 10063, 88474, 88482, 10072, 10064, 88475, 88483, 10427, 90324, 90115, 90332, 10429, 90325, 90118, 
90333, 10430, 10413, 90092, 90117
32692, 10072, 10064, 88475, 88483, 10073, 10065, 88476, 88484, 10429, 90325, 90118, 90333, 10431, 90326, 90121, 
90334, 10432, 10415, 90095, 90120
32693, 10073, 10065, 88476, 88484, 10074, 10066, 88477, 88485, 10431, 90326, 90121, 90334, 10433, 90327, 90124, 
90335, 10434, 10417, 90098, 90123
32694, 10074, 10066, 88477, 88485, 10075, 10067, 88478, 88486, 10433, 90327, 90124, 90335, 10435, 90328, 90127, 
90336, 10436, 10419, 90101, 90126
32695, 10075, 10067, 88478, 88486, 10076, 10068, 88479, 88487, 10435, 90328, 90127, 90336, 10437, 90329, 90130, 
90337, 10438, 10421, 90104, 90129
32696, 10076, 10068, 88479, 88487, 10077, 10069, 88480, 88488, 10437, 90329, 90130, 90337, 10439, 90330, 90133, 
90338, 10440, 10423, 90107, 90132
32697, 10077, 10069, 88480, 88488, 10078, 10070, 88481, 88489, 10439, 90330, 90133, 90338, 10441, 90331, 90136, 
90339, 10442, 10425, 90110, 90135
32698, 10078, 10070, 88481, 88489, 1127, 1126, 9110, 9111, 10441, 90331, 90136, 90339, 1149, 9267, 9244, 
9268, 10443, 10426, 90113, 90138
32699, 1031, 1030, 8888, 8889, 10079, 10071, 88482, 88490, 1053, 9045, 9022, 9046, 10444, 90332, 90140, 
90340, 10445, 10428, 90114, 90139
32700, 10079, 10071, 88482, 88490, 10080, 10072, 88483, 88491, 10444, 90332, 90140, 90340, 10446, 90333, 90143, 
90341, 10447, 10430, 90117, 90142
32701, 10080, 10072, 88483, 88491, 10081, 10073, 88484, 88492, 10446, 90333, 90143, 90341, 10448, 90334, 90146, 
90342, 10449, 10432, 90120, 90145
32702, 10081, 10073, 88484, 88492, 10082, 10074, 88485, 88493, 10448, 90334, 90146, 90342, 10450, 90335, 90149, 
90343, 10451, 10434, 90123, 90148
32703, 10082, 10074, 88485, 88493, 10083, 10075, 88486, 88494, 10450, 90335, 90149, 90343, 10452, 90336, 90152, 
90344, 10453, 10436, 90126, 90151
32704, 10083, 10075, 88486, 88494, 10084, 10076, 88487, 88495, 10452, 90336, 90152, 90344, 10454, 90337, 90155, 
90345, 10455, 10438, 90129, 90154
32705, 10084, 10076, 88487, 88495, 10085, 10077, 88488, 88496, 10454, 90337, 90155, 90345, 10456, 90338, 90158, 
90346, 10457, 10440, 90132, 90157
32706, 10085, 10077, 88488, 88496, 10086, 10078, 88489, 88497, 10456, 90338, 90158, 90346, 10458, 90339, 90161, 
90347, 10459, 10442, 90135, 90160
32707, 10086, 10078, 88489, 88497, 1128, 1127, 9111, 9112, 10458, 90339, 90161, 90347, 1150, 9268, 9246, 
9269, 10460, 10443, 90138, 90163
32708, 32, 1031, 8889, 960, 1176, 10079, 88490, 9286, 1054, 9046, 9024, 964, 10461, 90340, 90164, 
9345, 1185, 10445, 90139, 9328
32709, 1176, 10079, 88490, 9286, 1175, 10080, 88491, 9287, 10461, 90340, 90164, 9345, 10462, 90341, 90165, 
9346, 1184, 10447, 90142, 9330
32710, 1175, 10080, 88491, 9287, 1174, 10081, 88492, 9288, 10462, 90341, 90165, 9346, 10463, 90342, 90166, 
9347, 1183, 10449, 90145, 9332
32711, 1174, 10081, 88492, 9288, 1173, 10082, 88493, 9289, 10463, 90342, 90166, 9347, 10464, 90343, 90167, 
9348, 1182, 10451, 90148, 9334
32712, 1173, 10082, 88493, 9289, 1172, 10083, 88494, 9290, 10464, 90343, 90167, 9348, 10465, 90344, 90168, 
9349, 1181, 10453, 90151, 9336
32713, 1172, 10083, 88494, 9290, 1171, 10084, 88495, 9291, 10465, 90344, 90168, 9349, 10466, 90345, 90169, 
9350, 1180, 10455, 90154, 9338
32714, 1171, 10084, 88495, 9291, 1170, 10085, 88496, 9292, 10466, 90345, 90169, 9350, 10467, 90346, 90170, 
9351, 1179, 10457, 90157, 9340
32715, 1170, 10085, 88496, 9292, 1169, 10086, 88497, 9293, 10467, 90346, 90170, 9351, 10468, 90347, 90171, 
9352, 1178, 10459, 90160, 9342
32716, 1169, 10086, 88497, 9293, 34, 1128, 9112, 1057, 10468, 90347, 90171, 9352, 1151, 9269, 9247, 
1061, 1177, 10460, 90163, 9344
*ELEMENT, type=C3D20, ELSET=Volume26
32717, 11597, 958, 31, 1333, 90348, 9270, 1159, 11506, 11600, 961, 1334, 11601, 90373, 9295, 11514, 
90374, 90372, 9294, 1168, 11515
32718, 90348, 9270, 1159, 11506, 90349, 9271, 1158, 11507, 90373, 9295, 11514, 90374, 90376, 9297, 11516, 
90377, 90375, 9296, 1167, 11517
32719, 90349, 9271, 1158, 11507, 90350, 9272, 1157, 11508, 90376, 9297, 11516, 90377, 90379, 9299, 11518, 
90380, 90378, 9298, 1166, 11519
32720, 90350, 9272, 1157, 11508, 90351, 9273, 1156, 11509, 90379, 9299, 11518, 90380, 90382, 9301, 11520, 
90383, 90381, 9300, 1165, 11521
32721, 90351, 9273, 1156, 11509, 90352, 9274, 1155, 11510, 90382, 9301, 11520, 90383, 90385, 9303, 11522, 
90386, 90384, 9302, 1164, 11523
32722, 90352, 9274, 1155, 11510, 90353, 9275, 1154, 11511, 90385, 9303, 11522, 90386, 90388, 9305, 11524, 
90389, 90387, 9304, 1163, 11525
32723, 90353, 9275, 1154, 11511, 90354, 9276, 1153, 11512, 90388, 9305, 11524, 90389, 90391, 9307, 11526, 
90392, 90390, 9306, 1162, 11527
32724, 90354, 9276, 1153, 11512, 90355, 9277, 1152, 11513, 90391, 9307, 11526, 90392, 90394, 9309, 11528, 
90395, 90393, 9308, 1161, 11529
32725, 90355, 9277, 1152, 11513, 11610, 1055, 33, 1344, 90394, 9309, 11528, 90395, 11614, 1058, 1345, 
11613, 90396, 9310, 1160, 11530
32726, 1386, 11597, 1333, 40, 11623, 90348, 11506, 1376, 11602, 11601, 1335, 1389, 90397, 90374, 11531, 
11648, 11647, 90372, 11515, 1385
32727, 11623, 90348, 11506, 1376, 11624, 90349, 11507, 1375, 90397, 90374, 11531, 11648, 90398, 90377, 11532, 
11650, 11649, 90375, 11517, 1384
32728, 11624, 90349, 11507, 1375, 11625, 90350, 11508, 1374, 90398, 90377, 11532, 11650, 90399, 90380, 11533, 
11652, 11651, 90378, 11519, 1383
32729, 11625, 90350, 11508, 1374, 11626, 90351, 11509, 1373, 90399, 90380, 11533, 11652, 90400, 90383, 11534, 
11654, 11653, 90381, 11521, 1382
32730, 11626, 90351, 11509, 1373, 11627, 90352, 11510, 1372, 90400, 90383, 11534, 11654, 90401, 90386, 11535, 
11656, 11655, 90384, 11523, 1381
32731, 11627, 90352, 11510, 1372, 11628, 90353, 11511, 1371, 90401, 90386, 11535, 11656, 90402, 90389, 11536, 
11658, 11657, 90387, 11525, 1380
32732, 11628, 90353, 11511, 1371, 11629, 90354, 11512, 1370, 90402, 90389, 11536, 11658, 90403, 90392, 11537, 
11660, 11659, 90390, 11527, 1379
32733, 11629, 90354, 11512, 1370, 11630, 90355, 11513, 1369, 90403, 90392, 11537, 11660, 90404, 90395, 11538, 
11662, 11661, 90393, 11529, 1378
32734, 11630, 90355, 11513, 1369, 1396, 11610, 1344, 42, 90404, 90395, 11538, 11662, 11615, 11613, 1346, 
1399, 11663, 90396, 11530, 1377
32735, 11598, 959, 958, 11597, 90356, 9278, 9270, 90348, 11603, 962, 11600, 11604, 90406, 9312, 90373, 
90407, 90405, 9311, 9294, 90372
32736, 90356, 9278, 9270, 90348, 90357, 9279, 9271, 90349, 90406, 9312, 90373, 90407, 90409, 9314, 90376, 
90410, 90408, 9313, 9296, 90375
32737, 90357, 9279, 9271, 90349, 90358, 9280, 9272, 90350, 90409, 9314, 90376, 90410, 90412, 9316, 90379, 
90413, 90411, 9315, 9298, 90378
32738, 90358, 9280, 9272, 90350, 90359, 9281, 9273, 90351, 90412, 9316, 90379, 90413, 90415, 9318, 90382, 
90416, 90414, 9317, 9300, 90381
32739, 90359, 9281, 9273, 90351, 90360, 9282, 9274, 90352, 90415, 9318, 90382, 90416, 90418, 9320, 90385, 
90419, 90417, 9319, 9302, 90384
32740, 90360, 9282, 9274, 90352, 90361, 9283, 9275, 90353, 90418, 9320, 90385, 90419, 90421, 9322, 90388, 
90422, 90420, 9321, 9304, 90387
32741, 90361, 9283, 9275, 90353, 90362, 9284, 9276, 90354, 90421, 9322, 90388, 90422, 90424, 9324, 90391, 
90425, 90423, 9323, 9306, 90390
32742, 90362, 9284, 9276, 90354, 90363, 9285, 9277, 90355, 90424, 9324, 90391, 90425, 90427, 9326, 90394, 
90428, 90426, 9325, 9308, 90393
32743, 90363, 9285, 9277, 90355, 11611, 1056, 1055, 11610, 90427, 9326, 90394, 90428, 11617, 1059, 11614, 
11616, 90429, 9327, 9310, 90396
32744, 1387, 11598, 11597, 1386, 11631, 90356, 90348, 11623, 11605, 11604, 11602, 1390, 90430, 90407, 90397, 
11665, 11664, 90405, 90372, 11647
32745, 11631, 90356, 90348, 11623, 11632, 90357, 90349, 11624, 90430, 90407, 90397, 11665, 90431, 90410, 90398, 
11667, 11666, 90408, 90375, 11649
32746, 11632, 90357, 90349, 11624, 11633, 90358, 90350, 11625, 90431, 90410, 90398, 11667, 90432, 90413, 90399, 
11669, 11668, 90411, 90378, 11651
32747, 11633, 90358, 90350, 11625, 11634, 90359, 90351, 11626, 90432, 90413, 90399, 11669, 90433, 90416, 90400, 
11671, 11670, 90414, 90381, 11653
32748, 11634, 90359, 90351, 11626, 11635, 90360, 90352, 11627, 90433, 90416, 90400, 11671, 90434, 90419, 90401, 
11673, 11672, 90417, 90384, 11655
32749, 11635, 90360, 90352, 11627, 11636, 90361, 90353, 11628, 90434, 90419, 90401, 11673, 90435, 90422, 90402, 
11675, 11674, 90420, 90387, 11657
32750, 11636, 90361, 90353, 11628, 11637, 90362, 90354, 11629, 90435, 90422, 90402, 11675, 90436, 90425, 90403, 
11677, 11676, 90423, 90390, 11659
32751, 11637, 90362, 90354, 11629, 11638, 90363, 90355, 11630, 90436, 90425, 90403, 11677, 90437, 90428, 90404, 
11679, 11678, 90426, 90393, 11661
32752, 11638, 90363, 90355, 11630, 1397, 11611, 11610, 1396, 90437, 90428, 90404, 11679, 11618, 11616, 11615, 
1400, 11680, 90429, 90396, 11663
32753, 11599, 960, 959, 11598, 90364, 9286, 9278, 90356, 11606, 963, 11603, 11607, 90439, 9329, 90406, 
90440, 90438, 9328, 9311, 90405
32754, 90364, 9286, 9278, 90356, 90365, 9287, 9279, 90357, 90439, 9329, 90406, 90440, 90442, 9331, 90409, 
90443, 90441, 9330, 9313, 90408
32755, 90365, 9287, 9279, 90357, 90366, 9288, 9280, 90358, 90442, 9331, 90409, 90443, 90445, 9333, 90412, 
90446, 90444, 9332, 9315, 90411
32756, 90366, 9288, 9280, 90358, 90367, 9289, 9281, 90359, 90445, 9333, 90412, 90446, 90448, 9335, 90415, 
90449, 90447, 9334, 9317, 90414
32757, 90367, 9289, 9281, 90359, 90368, 9290, 9282, 90360, 90448, 9335, 90415, 90449, 90451, 9337, 90418, 
90452, 90450, 9336, 9319, 90417
32758, 90368, 9290, 9282, 90360, 90369, 9291, 9283, 90361, 90451, 9337, 90418, 90452, 90454, 9339, 90421, 
90455, 90453, 9338, 9321, 90420
32759, 90369, 9291, 9283, 90361, 90370, 9292, 9284, 90362, 90454, 9339, 90421, 90455, 90457, 9341, 90424, 
90458, 90456, 9340, 9323, 90423
32760, 90370, 9292, 9284, 90362, 90371, 9293, 9285, 90363, 90457, 9341, 90424, 90458, 90460, 9343, 90427, 
90461, 90459, 9342, 9325, 90426
32761, 90371, 9293, 9285, 90363, 11612, 1057, 1056, 11611, 90460, 9343, 90427, 90461, 11620, 1060, 11617, 
11619, 90462, 9344, 9327, 90429
32762, 1388, 11599, 11598, 1387, 11639, 90364, 90356, 11631, 11608, 11607, 11605, 1391, 90463, 90440, 90430, 
11682, 11681, 90438, 90405, 11664
32763, 11639, 90364, 90356, 11631, 11640, 90365, 90357, 11632, 90463, 90440, 90430, 11682, 90464, 90443, 90431, 
11684, 11683, 90441, 90408, 11666
32764, 11640, 90365, 90357, 11632, 11641, 90366, 90358, 11633, 90464, 90443, 90431, 11684, 90465, 90446, 90432, 
11686, 11685, 90444, 90411, 11668
32765, 11641, 90366, 90358, 11633, 11642, 90367, 90359, 11634, 90465, 90446, 90432, 11686, 90466, 90449, 90433, 
11688, 11687, 90447, 90414, 11670
32766, 11642, 90367, 90359, 11634, 11643, 90368, 90360, 11635, 90466, 90449, 90433, 11688, 90467, 90452, 90434, 
11690, 11689, 90450, 90417, 11672
32767, 11643, 90368, 90360, 11635, 11644, 90369, 90361, 11636, 90467, 90452, 90434, 11690, 90468, 90455, 90435, 
11692, 11691, 90453, 90420, 11674
32768, 11644, 90369, 90361, 11636, 11645, 90370, 90362, 11637, 90468, 90455, 90435, 11692, 90469, 90458, 90436, 
11694, 11693, 90456, 90423, 11676
32769, 11645, 90370, 90362, 11637, 11646, 90371, 90363, 11638, 90469, 90458, 90436, 11694, 90470, 90461, 90437, 
11696, 11695, 90459, 90426, 11678
32770, 11646, 90371, 90363, 11638, 1398, 11612, 11611, 1397, 90470, 90461, 90437, 11696, 11621, 11619, 11618, 
1401, 11697, 90462, 90429, 11680
32771, 1393, 32, 960, 11599, 11706, 1176, 9286, 90364, 1394, 964, 11606, 11609, 11714, 9345, 90439, 
90471, 11715, 1185, 9328, 90438
32772, 11706, 1176, 9286, 90364, 11707, 1175, 9287, 90365, 11714, 9345, 90439, 90471, 11716, 9346, 90442, 
90472, 11717, 1184, 9330, 90441
32773, 11707, 1175, 9287, 90365, 11708, 1174, 9288, 90366, 11716, 9346, 90442, 90472, 11718, 9347, 90445, 
90473, 11719, 1183, 9332, 90444
32774, 11708, 1174, 9288, 90366, 11709, 1173, 9289, 90367, 11718, 9347, 90445, 90473, 11720, 9348, 90448, 
90474, 11721, 1182, 9334, 90447
32775, 11709, 1173, 9289, 90367, 11710, 1172, 9290, 90368, 11720, 9348, 90448, 90474, 11722, 9349, 90451, 
90475, 11723, 1181, 9336, 90450
32776, 11710, 1172, 9290, 90368, 11711, 1171, 9291, 90369, 11722, 9349, 90451, 90475, 11724, 9350, 90454, 
90476, 11725, 1180, 9338, 90453
32777, 11711, 1171, 9291, 90369, 11712, 1170, 9292, 90370, 11724, 9350, 90454, 90476, 11726, 9351, 90457, 
90477, 11727, 1179, 9340, 90456
32778, 11712, 1170, 9292, 90370, 11713, 1169, 9293, 90371, 11726, 9351, 90457, 90477, 11728, 9352, 90460, 
90478, 11729, 1178, 9342, 90459
32779, 11713, 1169, 9293, 90371, 1403, 34, 1057, 11612, 11728, 9352, 90460, 90478, 1404, 1061, 11620, 
11622, 11730, 1177, 9344, 90462
32780, 43, 1393, 11599, 1388, 1413, 11706, 90364, 11639, 1395, 11609, 11608, 1392, 11731, 90471, 90463, 
11698, 1422, 11715, 90438, 11681
32781, 1413, 11706, 90364, 11639, 1412, 11707, 90365, 11640, 11731, 90471, 90463, 11698, 11732, 90472, 90464, 
11699, 1421, 11717, 90441, 11683
32782, 1412, 11707, 90365, 11640, 1411, 11708, 90366, 11641, 11732, 90472, 90464, 11699, 11733, 90473, 90465, 
11700, 1420, 11719, 90444, 11685
32783, 1411, 11708, 90366, 11641, 1410, 11709, 90367, 11642, 11733, 90473, 90465, 11700, 11734, 90474, 90466, 
11701, 1419, 11721, 90447, 11687
32784, 1410, 11709, 90367, 11642, 1409, 11710, 90368, 11643, 11734, 90474, 90466, 11701, 11735, 90475, 90467, 
11702, 1418, 11723, 90450, 11689
32785, 1409, 11710, 90368, 11643, 1408, 11711, 90369, 11644, 11735, 90475, 90467, 11702, 11736, 90476, 90468, 
11703, 1417, 11725, 90453, 11691
32786, 1408, 11711, 90369, 11644, 1407, 11712, 90370, 11645, 11736, 90476, 90468, 11703, 11737, 90477, 90469, 
11704, 1416, 11727, 90456, 11693
32787, 1407, 11712, 90370, 11645, 1406, 11713, 90371, 11646, 11737, 90477, 90469, 11704, 11738, 90478, 90470, 
11705, 1415, 11729, 90459, 11695
32788, 1406, 11713, 90371, 11646, 44, 1403, 11612, 1398, 11738, 90478, 90470, 11705, 1405, 11622, 11621, 
1402, 1414, 11730, 90462, 11697
*ELEMENT, type=C3D20, ELSET=Volume27
32789, 21, 882, 8509, 813, 544, 8575, 90479, 7645, 885, 8519, 8518, 816, 8600, 90552, 90553, 
7670, 553, 8599, 90551, 7669
32790, 544, 8575, 90479, 7645, 543, 8576, 90480, 7646, 8600, 90552, 90553, 7670, 8602, 90555, 90556, 
7672, 552, 8601, 90554, 7671
32791, 543, 8576, 90480, 7646, 542, 8577, 90481, 7647, 8602, 90555, 90556, 7672, 8604, 90558, 90559, 
7674, 551, 8603, 90557, 7673
32792, 542, 8577, 90481, 7647, 541, 8578, 90482, 7648, 8604, 90558, 90559, 7674, 8606, 90561, 90562, 
7676, 550, 8605, 90560, 7675
32793, 541, 8578, 90482, 7648, 540, 8579, 90483, 7649, 8606, 90561, 90562, 7676, 8608, 90564, 90565, 
7678, 549, 8607, 90563, 7677
32794, 540, 8579, 90483, 7649, 539, 8580, 90484, 7650, 8608, 90564, 90565, 7678, 8610, 90567, 90568, 
7680, 548, 8609, 90566, 7679
32795, 539, 8580, 90484, 7650, 538, 8581, 90485, 7651, 8610, 90567, 90568, 7680, 8612, 90570, 90571, 
7682, 547, 8611, 90569, 7681
32796, 538, 8581, 90485, 7651, 537, 8582, 90486, 7652, 8612, 90570, 90571, 7682, 8614, 90573, 90574, 
7684, 546, 8613, 90572, 7683
32797, 537, 8582, 90486, 7652, 22, 903, 8542, 761, 8614, 90573, 90574, 7684, 906, 8551, 8552, 
764, 545, 8615, 90575, 7685
32798, 813, 8509, 8510, 814, 7645, 90479, 90487, 7653, 8518, 8521, 8520, 817, 90553, 90577, 90578, 
7687, 7669, 90551, 90576, 7686
32799, 7645, 90479, 90487, 7653, 7646, 90480, 90488, 7654, 90553, 90577, 90578, 7687, 90556, 90580, 90581, 
7689, 7671, 90554, 90579, 7688
32800, 7646, 90480, 90488, 7654, 7647, 90481, 90489, 7655, 90556, 90580, 90581, 7689, 90559, 90583, 90584, 
7691, 7673, 90557, 90582, 7690
32801, 7647, 90481, 90489, 7655, 7648, 90482, 90490, 7656, 90559, 90583, 90584, 7691, 90562, 90586, 90587, 
7693, 7675, 90560, 90585, 7692
32802, 7648, 90482, 90490, 7656, 7649, 90483, 90491, 7657, 90562, 90586, 90587, 7693, 90565, 90589, 90590, 
7695, 7677, 90563, 90588, 7694
32803, 7649, 90483, 90491, 7657, 7650, 90484, 90492, 7658, 90565, 90589, 90590, 7695, 90568, 90592, 90593, 
7697, 7679, 90566, 90591, 7696
32804, 7650, 90484, 90492, 7658, 7651, 90485, 90493, 7659, 90568, 90592, 90593, 7697, 90571, 90595, 90596, 
7699, 7681, 90569, 90594, 7698
32805, 7651, 90485, 90493, 7659, 7652, 90486, 90494, 7660, 90571, 90595, 90596, 7699, 90574, 90598, 90599, 
7701, 7683, 90572, 90597, 7700
32806, 7652, 90486, 90494, 7660, 761, 8542, 8543, 762, 90574, 90598, 90599, 7701, 8552, 8553, 8554, 
765, 7685, 90575, 90600, 7702
32807, 814, 8510, 8511, 815, 7653, 90487, 90495, 7661, 8520, 8523, 8522, 818, 90578, 90602, 90603, 
7704, 7686, 90576, 90601, 7703
32808, 7653, 90487, 90495, 7661, 7654, 90488, 90496, 7662, 90578, 90602, 90603, 7704, 90581, 90605, 90606, 
7706, 7688, 90579, 90604, 7705
32809, 7654, 90488, 90496, 7662, 7655, 90489, 90497, 7663, 90581, 90605, 90606, 7706, 90584, 90608, 90609, 
7708, 7690, 90582, 90607, 7707
32810, 7655, 90489, 90497, 7663, 7656, 90490, 90498, 7664, 90584, 90608, 90609, 7708, 90587, 90611, 90612, 
7710, 7692, 90585, 90610, 7709
32811, 7656, 90490, 90498, 7664, 7657, 90491, 90499, 7665, 90587, 90611, 90612, 7710, 90590, 90614, 90615, 
7712, 7694, 90588, 90613, 7711
32812, 7657, 90491, 90499, 7665, 7658, 90492, 90500, 7666, 90590, 90614, 90615, 7712, 90593, 90617, 90618, 
7714, 7696, 90591, 90616, 7713
32813, 7658, 90492, 90500, 7666, 7659, 90493, 90501, 7667, 90593, 90617, 90618, 7714, 90596, 90620, 90621, 
7716, 7698, 90594, 90619, 7715
32814, 7659, 90493, 90501, 7667, 7660, 90494, 90502, 7668, 90596, 90620, 90621, 7716, 90599, 90623, 90624, 
7718, 7700, 90597, 90622, 7717
32815, 7660, 90494, 90502, 7668, 762, 8543, 8544, 763, 90599, 90623, 90624, 7718, 8554, 8555, 8556, 
766, 7702, 90600, 90625, 7719
32816, 815, 8511, 889, 26, 7661, 90495, 8658, 827, 8522, 8524, 892, 819, 90603, 90626, 8682, 
7720, 7703, 90601, 8683, 836
32817, 7661, 90495, 8658, 827, 7662, 90496, 8659, 826, 90603, 90626, 8682, 7720, 90606, 90627, 8684, 
7721, 7705, 90604, 8685, 835
32818, 7662, 90496, 8659, 826, 7663, 90497, 8660, 825, 90606, 90627, 8684, 7721, 90609, 90628, 8686, 
7722, 7707, 90607, 8687, 834
32819, 7663, 90497, 8660, 825, 7664, 90498, 8661, 824, 90609, 90628, 8686, 7722, 90612, 90629, 8688, 
7723, 7709, 90610, 8689, 833
32820, 7664, 90498, 8661, 824, 7665, 90499, 8662, 823, 90612, 90629, 8688, 7723, 90615, 90630, 8690, 
7724, 7711, 90613, 8691, 832
32821, 7665, 90499, 8662, 823, 7666, 90500, 8663, 822, 90615, 90630, 8690, 7724, 90618, 90631, 8692, 
7725, 7713, 90616, 8693, 831
32822, 7666, 90500, 8663, 822, 7667, 90501, 8664, 821, 90618, 90631, 8692, 7725, 90621, 90632, 8694, 
7726, 7715, 90619, 8695, 830
32823, 7667, 90501, 8664, 821, 7668, 90502, 8665, 820, 90621, 90632, 8694, 7726, 90624, 90633, 8696, 
7727, 7717, 90622, 8697, 829
32824, 7668, 90502, 8665, 820, 763, 8544, 910, 25, 90624, 90633, 8696, 7727, 8556, 8557, 913, 
767, 7719, 90625, 8698, 828
32825, 882, 883, 8512, 8509, 8575, 8583, 90503, 90479, 886, 8526, 8525, 8519, 8617, 90635, 90636, 
90552, 8599, 8616, 90634, 90551
32826, 8575, 8583, 90503, 90479, 8576, 8584, 90504, 90480, 8617, 90635, 90636, 90552, 8619, 90638, 90639, 
90555, 8601, 8618, 90637, 90554
32827, 8576, 8584, 90504, 90480, 8577, 8585, 90505, 90481, 8619, 90638, 90639, 90555, 8621, 90641, 90642, 
90558, 8603, 8620, 90640, 90557
32828, 8577, 8585, 90505, 90481, 8578, 8586, 90506, 90482, 8621, 90641, 90642, 90558, 8623, 90644, 90645, 
90561, 8605, 8622, 90643, 90560
32829, 8578, 8586, 90506, 90482, 8579, 8587, 90507, 90483, 8623, 90644, 90645, 90561, 8625, 90647, 90648, 
90564, 8607, 8624, 90646, 90563
32830, 8579, 8587, 90507, 90483, 8580, 8588, 90508, 90484, 8625, 90647, 90648, 90564, 8627, 90650, 90651, 
90567, 8609, 8626, 90649, 90566
32831, 8580, 8588, 90508, 90484, 8581, 8589, 90509, 90485, 8627, 90650, 90651, 90567, 8629, 90653, 90654, 
90570, 8611, 8628, 90652, 90569
32832, 8581, 8589, 90509, 90485, 8582, 8590, 90510, 90486, 8629, 90653, 90654, 90570, 8631, 90656, 90657, 
90573, 8613, 8630, 90655, 90572
32833, 8582, 8590, 90510, 90486, 903, 904, 8545, 8542, 8631, 90656, 90657, 90573, 907, 8558, 8559, 
8551, 8615, 8632, 90658, 90575
32834, 8509, 8512, 8513, 8510, 90479, 90503, 90511, 90487, 8525, 8528, 8527, 8521, 90636, 90660, 90661, 
90577, 90551, 90634, 90659, 90576
32835, 90479, 90503, 90511, 90487, 90480, 90504, 90512, 90488, 90636, 90660, 90661, 90577, 90639, 90663, 90664, 
90580, 90554, 90637, 90662, 90579
32836, 90480, 90504, 90512, 90488, 90481, 90505, 90513, 90489, 90639, 90663, 90664, 90580, 90642, 90666, 90667, 
90583, 90557, 90640, 90665, 90582
32837, 90481, 90505, 90513, 90489, 90482, 90506, 90514, 90490, 90642, 90666, 90667, 90583, 90645, 90669, 90670, 
90586, 90560, 90643, 90668, 90585
32838, 90482, 90506, 90514, 90490, 90483, 90507, 90515, 90491, 90645, 90669, 90670, 90586, 90648, 90672, 90673, 
90589, 90563, 90646, 90671, 90588
32839, 90483, 90507, 90515, 90491, 90484, 90508, 90516, 90492, 90648, 90672, 90673, 90589, 90651, 90675, 90676, 
90592, 90566, 90649, 90674, 90591
32840, 90484, 90508, 90516, 90492, 90485, 90509, 90517, 90493, 90651, 90675, 90676, 90592, 90654, 90678, 90679, 
90595, 90569, 90652, 90677, 90594
32841, 90485, 90509, 90517, 90493, 90486, 90510, 90518, 90494, 90654, 90678, 90679, 90595, 90657, 90681, 90682, 
90598, 90572, 90655, 90680, 90597
32842, 90486, 90510, 90518, 90494, 8542, 8545, 8546, 8543, 90657, 90681, 90682, 90598, 8559, 8560, 8561, 
8553, 90575, 90658, 90683, 90600
32843, 8510, 8513, 8514, 8511, 90487, 90511, 90519, 90495, 8527, 8530, 8529, 8523, 90661, 90685, 90686, 
90602, 90576, 90659, 90684, 90601
32844, 90487, 90511, 90519, 90495, 90488, 90512, 90520, 90496, 90661, 90685, 90686, 90602, 90664, 90688, 90689, 
90605, 90579, 90662, 90687, 90604
32845, 90488, 90512, 90520, 90496, 90489, 90513, 90521, 90497, 90664, 90688, 90689, 90605, 90667, 90691, 90692, 
90608, 90582, 90665, 90690, 90607
32846, 90489, 90513, 90521, 90497, 90490, 90514, 90522, 90498, 90667, 90691, 90692, 90608, 90670, 90694, 90695, 
90611, 90585, 90668, 90693, 90610
32847, 90490, 90514, 90522, 90498, 90491, 90515, 90523, 90499, 90670, 90694, 90695, 90611, 90673, 90697, 90698, 
90614, 90588, 90671, 90696, 90613
32848, 90491, 90515, 90523, 90499, 90492, 90516, 90524, 90500, 90673, 90697, 90698, 90614, 90676, 90700, 90701, 
90617, 90591, 90674, 90699, 90616
32849, 90492, 90516, 90524, 90500, 90493, 90517, 90525, 90501, 90676, 90700, 90701, 90617, 90679, 90703, 90704, 
90620, 90594, 90677, 90702, 90619
32850, 90493, 90517, 90525, 90501, 90494, 90518, 90526, 90502, 90679, 90703, 90704, 90620, 90682, 90706, 90707, 
90623, 90597, 90680, 90705, 90622
32851, 90494, 90518, 90526, 90502, 8543, 8546, 8547, 8544, 90682, 90706, 90707, 90623, 8561, 8562, 8563, 
8555, 90600, 90683, 90708, 90625
32852, 8511, 8514, 890, 889, 90495, 90519, 8666, 8658, 8529, 8531, 893, 8524, 90686, 90709, 8699, 
90626, 90601, 90684, 8700, 8683
32853, 90495, 90519, 8666, 8658, 90496, 90520, 8667, 8659, 90686, 90709, 8699, 90626, 90689, 90710, 8701, 
90627, 90604, 90687, 8702, 8685
32854, 90496, 90520, 8667, 8659, 90497, 90521, 8668, 8660, 90689, 90710, 8701, 90627, 90692, 90711, 8703, 
90628, 90607, 90690, 8704, 8687
32855, 90497, 90521, 8668, 8660, 90498, 90522, 8669, 8661, 90692, 90711, 8703, 90628, 90695, 90712, 8705, 
90629, 90610, 90693, 8706, 8689
32856, 90498, 90522, 8669, 8661, 90499, 90523, 8670, 8662, 90695, 90712, 8705, 90629, 90698, 90713, 8707, 
90630, 90613, 90696, 8708, 8691
32857, 90499, 90523, 8670, 8662, 90500, 90524, 8671, 8663, 90698, 90713, 8707, 90630, 90701, 90714, 8709, 
90631, 90616, 90699, 8710, 8693
32858, 90500, 90524, 8671, 8663, 90501, 90525, 8672, 8664, 90701, 90714, 8709, 90631, 90704, 90715, 8711, 
90632, 90619, 90702, 8712, 8695
32859, 90501, 90525, 8672, 8664, 90502, 90526, 8673, 8665, 90704, 90715, 8711, 90632, 90707, 90716, 8713, 
90633, 90622, 90705, 8714, 8697
32860, 90502, 90526, 8673, 8665, 8544, 8547, 911, 910, 90707, 90716, 8713, 90633, 8563, 8564, 914, 
8557, 90625, 90708, 8715, 8698
32861, 883, 884, 8515, 8512, 8583, 8591, 90527, 90503, 887, 8533, 8532, 8526, 8634, 90718, 90719, 
90635, 8616, 8633, 90717, 90634
32862, 8583, 8591, 90527, 90503, 8584, 8592, 90528, 90504, 8634, 90718, 90719, 90635, 8636, 90721, 90722, 
90638, 8618, 8635, 90720, 90637
32863, 8584, 8592, 90528, 90504, 8585, 8593, 90529, 90505, 8636, 90721, 90722, 90638, 8638, 90724, 90725, 
90641, 8620, 8637, 90723, 90640
32864, 8585, 8593, 90529, 90505, 8586, 8594, 90530, 90506, 8638, 90724, 90725, 90641, 8640, 90727, 90728, 
90644, 8622, 8639, 90726, 90643
32865, 8586, 8594, 90530, 90506, 8587, 8595, 90531, 90507, 8640, 90727, 90728, 90644, 8642, 90730, 90731, 
90647, 8624, 8641, 90729, 90646
32866, 8587, 8595, 90531, 90507, 8588, 8596, 90532, 90508, 8642, 90730, 90731, 90647, 8644, 90733, 90734, 
90650, 8626, 8643, 90732, 90649
32867, 8588, 8596, 90532, 90508, 8589, 8597, 90533, 90509, 8644, 90733, 90734, 90650, 8646, 90736, 90737, 
90653, 8628, 8645, 90735, 90652
32868, 8589, 8597, 90533, 90509, 8590, 8598, 90534, 90510, 8646, 90736, 90737, 90653, 8648, 90739, 90740, 
90656, 8630, 8647, 90738, 90655
32869, 8590, 8598, 90534, 90510, 904, 905, 8548, 8545, 8648, 90739, 90740, 90656, 908, 8565, 8566, 
8558, 8632, 8649, 90741, 90658
32870, 8512, 8515, 8516, 8513, 90503, 90527, 90535, 90511, 8532, 8535, 8534, 8528, 90719, 90743, 90744, 
90660, 90634, 90717, 90742, 90659
32871, 90503, 90527, 90535, 90511, 90504, 90528, 90536, 90512, 90719, 90743, 90744, 90660, 90722, 90746, 90747, 
90663, 90637, 90720, 90745, 90662
32872, 90504, 90528, 90536, 90512, 90505, 90529, 90537, 90513, 90722, 90746, 90747, 90663, 90725, 90749, 90750, 
90666, 90640, 90723, 90748, 90665
32873, 90505, 90529, 90537, 90513, 90506, 90530, 90538, 90514, 90725, 90749, 90750, 90666, 90728, 90752, 90753, 
90669, 90643, 90726, 90751, 90668
32874, 90506, 90530, 90538, 90514, 90507, 90531, 90539, 90515, 90728, 90752, 90753, 90669, 90731, 90755, 90756, 
90672, 90646, 90729, 90754, 90671
32875, 90507, 90531, 90539, 90515, 90508, 90532, 90540, 90516, 90731, 90755, 90756, 90672, 90734, 90758, 90759, 
90675, 90649, 90732, 90757, 90674
32876, 90508, 90532, 90540, 90516, 90509, 90533, 90541, 90517, 90734, 90758, 90759, 90675, 90737, 90761, 90762, 
90678, 90652, 90735, 90760, 90677
32877, 90509, 90533, 90541, 90517, 90510, 90534, 90542, 90518, 90737, 90761, 90762, 90678, 90740, 90764, 90765, 
90681, 90655, 90738, 90763, 90680
32878, 90510, 90534, 90542, 90518, 8545, 8548, 8549, 8546, 90740, 90764, 90765, 90681, 8566, 8567, 8568, 
8560, 90658, 90741, 90766, 90683
32879, 8513, 8516, 8517, 8514, 90511, 90535, 90543, 90519, 8534, 8537, 8536, 8530, 90744, 90768, 90769, 
90685, 90659, 90742, 90767, 90684
32880, 90511, 90535, 90543, 90519, 90512, 90536, 90544, 90520, 90744, 90768, 90769, 90685, 90747, 90771, 90772, 
90688, 90662, 90745, 90770, 90687
32881, 90512, 90536, 90544, 90520, 90513, 90537, 90545, 90521, 90747, 90771, 90772, 90688, 90750, 90774, 90775, 
90691, 90665, 90748, 90773, 90690
32882, 90513, 90537, 90545, 90521, 90514, 90538, 90546, 90522, 90750, 90774, 90775, 90691, 90753, 90777, 90778, 
90694, 90668, 90751, 90776, 90693
32883, 90514, 90538, 90546, 90522, 90515, 90539, 90547, 90523, 90753, 90777, 90778, 90694, 90756, 90780, 90781, 
90697, 90671, 90754, 90779, 90696
32884, 90515, 90539, 90547, 90523, 90516, 90540, 90548, 90524, 90756, 90780, 90781, 90697, 90759, 90783, 90784, 
90700, 90674, 90757, 90782, 90699
32885, 90516, 90540, 90548, 90524, 90517, 90541, 90549, 90525, 90759, 90783, 90784, 90700, 90762, 90786, 90787, 
90703, 90677, 90760, 90785, 90702
32886, 90517, 90541, 90549, 90525, 90518, 90542, 90550, 90526, 90762, 90786, 90787, 90703, 90765, 90789, 90790, 
90706, 90680, 90763, 90788, 90705
32887, 90518, 90542, 90550, 90526, 8546, 8549, 8550, 8547, 90765, 90789, 90790, 90706, 8568, 8569, 8570, 
8562, 90683, 90766, 90791, 90708
32888, 8514, 8517, 891, 890, 90519, 90543, 8674, 8666, 8536, 8538, 894, 8531, 90769, 90792, 8716, 
90709, 90684, 90767, 8717, 8700
32889, 90519, 90543, 8674, 8666, 90520, 90544, 8675, 8667, 90769, 90792, 8716, 90709, 90772, 90793, 8718, 
90710, 90687, 90770, 8719, 8702
32890, 90520, 90544, 8675, 8667, 90521, 90545, 8676, 8668, 90772, 90793, 8718, 90710, 90775, 90794, 8720, 
90711, 90690, 90773, 8721, 8704
32891, 90521, 90545, 8676, 8668, 90522, 90546, 8677, 8669, 90775, 90794, 8720, 90711, 90778, 90795, 8722, 
90712, 90693, 90776, 8723, 8706
32892, 90522, 90546, 8677, 8669, 90523, 90547, 8678, 8670, 90778, 90795, 8722, 90712, 90781, 90796, 8724, 
90713, 90696, 90779, 8725, 8708
32893, 90523, 90547, 8678, 8670, 90524, 90548, 8679, 8671, 90781, 90796, 8724, 90713, 90784, 90797, 8726, 
90714, 90699, 90782, 8727, 8710
32894, 90524, 90548, 8679, 8671, 90525, 90549, 8680, 8672, 90784, 90797, 8726, 90714, 90787, 90798, 8728, 
90715, 90702, 90785, 8729, 8712
32895, 90525, 90549, 8680, 8672, 90526, 90550, 8681, 8673, 90787, 90798, 8728, 90715, 90790, 90799, 8730, 
90716, 90705, 90788, 8731, 8714
32896, 90526, 90550, 8681, 8673, 8547, 8550, 912, 911, 90790, 90799, 8730, 90716, 8570, 8571, 915, 
8564, 90708, 90791, 8732, 8715
32897, 884, 27, 896, 8515, 8591, 931, 8741, 90527, 888, 899, 8539, 8533, 8650, 8766, 90800, 
90718, 8633, 940, 8765, 90717
32898, 8591, 931, 8741, 90527, 8592, 930, 8742, 90528, 8650, 8766, 90800, 90718, 8651, 8768, 90801, 
90721, 8635, 939, 8767, 90720
32899, 8592, 930, 8742, 90528, 8593, 929, 8743, 90529, 8651, 8768, 90801, 90721, 8652, 8770, 90802, 
90724, 8637, 938, 8769, 90723
32900, 8593, 929, 8743, 90529, 8594, 928, 8744, 90530, 8652, 8770, 90802, 90724, 8653, 8772, 90803, 
90727, 8639, 937, 8771, 90726
32901, 8594, 928, 8744, 90530, 8595, 927, 8745, 90531, 8653, 8772, 90803, 90727, 8654, 8774, 90804, 
90730, 8641, 936, 8773, 90729
32902, 8595, 927, 8745, 90531, 8596, 926, 8746, 90532, 8654, 8774, 90804, 90730, 8655, 8776, 90805, 
90733, 8643, 935, 8775, 90732
32903, 8596, 926, 8746, 90532, 8597, 925, 8747, 90533, 8655, 8776, 90805, 90733, 8656, 8778, 90806, 
90736, 8645, 934, 8777, 90735
32904, 8597, 925, 8747, 90533, 8598, 924, 8748, 90534, 8656, 8778, 90806, 90736, 8657, 8780, 90807, 
90739, 8647, 933, 8779, 90738
32905, 8598, 924, 8748, 90534, 905, 29, 917, 8548, 8657, 8780, 90807, 90739, 909, 920, 8572, 
8565, 8649, 932, 8781, 90741
32906, 8515, 896, 897, 8516, 90527, 8741, 8749, 90535, 8539, 900, 8540, 8535, 90800, 8783, 90808, 
90743, 90717, 8765, 8782, 90742
32907, 90527, 8741, 8749, 90535, 90528, 8742, 8750, 90536, 90800, 8783, 90808, 90743, 90801, 8785, 90809, 
90746, 90720, 8767, 8784, 90745
32908, 90528, 8742, 8750, 90536, 90529, 8743, 8751, 90537, 90801, 8785, 90809, 90746, 90802, 8787, 90810, 
90749, 90723, 8769, 8786, 90748
32909, 90529, 8743, 8751, 90537, 90530, 8744, 8752, 90538, 90802, 8787, 90810, 90749, 90803, 8789, 90811, 
90752, 90726, 8771, 8788, 90751
32910, 90530, 8744, 8752, 90538, 90531, 8745, 8753, 90539, 90803, 8789, 90811, 90752, 90804, 8791, 90812, 
90755, 90729, 8773, 8790, 90754
32911, 90531, 8745, 8753, 90539, 90532, 8746, 8754, 90540, 90804, 8791, 90812, 90755, 90805, 8793, 90813, 
90758, 90732, 8775, 8792, 90757
32912, 90532, 8746, 8754, 90540, 90533, 8747, 8755, 90541, 90805, 8793, 90813, 90758, 90806, 8795, 90814, 
90761, 90735, 8777, 8794, 90760
32913, 90533, 8747, 8755, 90541, 90534, 8748, 8756, 90542, 90806, 8795, 90814, 90761, 90807, 8797, 90815, 
90764, 90738, 8779, 8796, 90763
32914, 90534, 8748, 8756, 90542, 8548, 917, 918, 8549, 90807, 8797, 90815, 90764, 8572, 921, 8573, 
8567, 90741, 8781, 8798, 90766
32915, 8516, 897, 898, 8517, 90535, 8749, 8757, 90543, 8540, 901, 8541, 8537, 90808, 8800, 90816, 
90768, 90742, 8782, 8799, 90767
32916, 90535, 8749, 8757, 90543, 90536, 8750, 8758, 90544, 90808, 8800, 90816, 90768, 90809, 8802, 90817, 
90771, 90745, 8784, 8801, 90770
32917, 90536, 8750, 8758, 90544, 90537, 8751, 8759, 90545, 90809, 8802, 90817, 90771, 90810, 8804, 90818, 
90774, 90748, 8786, 8803, 90773
32918, 90537, 8751, 8759, 90545, 90538, 8752, 8760, 90546, 90810, 8804, 90818, 90774, 90811, 8806, 90819, 
90777, 90751, 8788, 8805, 90776
32919, 90538, 8752, 8760, 90546, 90539, 8753, 8761, 90547, 90811, 8806, 90819, 90777, 90812, 8808, 90820, 
90780, 90754, 8790, 8807, 90779
32920, 90539, 8753, 8761, 90547, 90540, 8754, 8762, 90548, 90812, 8808, 90820, 90780, 90813, 8810, 90821, 
90783, 90757, 8792, 8809, 90782
32921, 90540, 8754, 8762, 90548, 90541, 8755, 8763, 90549, 90813, 8810, 90821, 90783, 90814, 8812, 90822, 
90786, 90760, 8794, 8811, 90785
32922, 90541, 8755, 8763, 90549, 90542, 8756, 8764, 90550, 90814, 8812, 90822, 90786, 90815, 8814, 90823, 
90789, 90763, 8796, 8813, 90788
32923, 90542, 8756, 8764, 90550, 8549, 918, 919, 8550, 90815, 8814, 90823, 90789, 8573, 922, 8574, 
8569, 90766, 8798, 8815, 90791
32924, 8517, 898, 28, 891, 90543, 8757, 948, 8674, 8541, 902, 895, 8538, 90816, 8816, 8733, 
90792, 90767, 8799, 957, 8717
32925, 90543, 8757, 948, 8674, 90544, 8758, 947, 8675, 90816, 8816, 8733, 90792, 90817, 8817, 8734, 
90793, 90770, 8801, 956, 8719
32926, 90544, 8758, 947, 8675, 90545, 8759, 946, 8676, 90817, 8817, 8734, 90793, 90818, 8818, 8735, 
90794, 90773, 8803, 955, 8721
32927, 90545, 8759, 946, 8676, 90546, 8760, 945, 8677, 90818, 8818, 8735, 90794, 90819, 8819, 8736, 
90795, 90776, 8805, 954, 8723
32928, 90546, 8760, 945, 8677, 90547, 8761, 944, 8678, 90819, 8819, 8736, 90795, 90820, 8820, 8737, 
90796, 90779, 8807, 953, 8725
32929, 90547, 8761, 944, 8678, 90548, 8762, 943, 8679, 90820, 8820, 8737, 90796, 90821, 8821, 8738, 
90797, 90782, 8809, 952, 8727
32930, 90548, 8762, 943, 8679, 90549, 8763, 942, 8680, 90821, 8821, 8738, 90797, 90822, 8822, 8739, 
90798, 90785, 8811, 951, 8729
32931, 90549, 8763, 942, 8680, 90550, 8764, 941, 8681, 90822, 8822, 8739, 90798, 90823, 8823, 8740, 
90799, 90788, 8813, 950, 8731
32932, 90550, 8764, 941, 8681, 8550, 919, 30, 912, 90823, 8823, 8740, 90799, 8574, 923, 916, 
8571, 90791, 8815, 949, 8732
*ELEMENT, type=C3D20, ELSET=Volume28
32933, 52, 1960, 14955, 1891, 1681, 14981, 90824, 14314, 1961, 14959, 14958, 1894, 14990, 90849, 90850, 
14339, 1690, 14989, 90848, 14338
32934, 1681, 14981, 90824, 14314, 1680, 14982, 90825, 14315, 14990, 90849, 90850, 14339, 14992, 90852, 90853, 
14341, 1689, 14991, 90851, 14340
32935, 1680, 14982, 90825, 14315, 1679, 14983, 90826, 14316, 14992, 90852, 90853, 14341, 14994, 90855, 90856, 
14343, 1688, 14993, 90854, 14342
32936, 1679, 14983, 90826, 14316, 1678, 14984, 90827, 14317, 14994, 90855, 90856, 14343, 14996, 90858, 90859, 
14345, 1687, 14995, 90857, 14344
32937, 1678, 14984, 90827, 14317, 1677, 14985, 90828, 14318, 14996, 90858, 90859, 14345, 14998, 90861, 90862, 
14347, 1686, 14997, 90860, 14346
32938, 1677, 14985, 90828, 14318, 1676, 14986, 90829, 14319, 14998, 90861, 90862, 14347, 15000, 90864, 90865, 
14349, 1685, 14999, 90863, 14348
32939, 1676, 14986, 90829, 14319, 1675, 14987, 90830, 14320, 15000, 90864, 90865, 14349, 15002, 90867, 90868, 
14351, 1684, 15001, 90866, 14350
32940, 1675, 14987, 90830, 14320, 1674, 14988, 90831, 14321, 15002, 90867, 90868, 14351, 15004, 90870, 90871, 
14353, 1683, 15003, 90869, 14352
32941, 1674, 14988, 90831, 14321, 48, 1973, 14968, 1839, 15004, 90870, 90871, 14353, 1974, 14971, 14972, 
1842, 1682, 15005, 90872, 14354
32942, 1891, 14955, 14956, 1892, 14314, 90824, 90832, 14322, 14958, 14961, 14960, 1895, 90850, 90874, 90875, 
14356, 14338, 90848, 90873, 14355
32943, 14314, 90824, 90832, 14322, 14315, 90825, 90833, 14323, 90850, 90874, 90875, 14356, 90853, 90877, 90878, 
14358, 14340, 90851, 90876, 14357
32944, 14315, 90825, 90833, 14323, 14316, 90826, 90834, 14324, 90853, 90877, 90878, 14358, 90856, 90880, 90881, 
14360, 14342, 90854, 90879, 14359
32945, 14316, 90826, 90834, 14324, 14317, 90827, 90835, 14325, 90856, 90880, 90881, 14360, 90859, 90883, 90884, 
14362, 14344, 90857, 90882, 14361
32946, 14317, 90827, 90835, 14325, 14318, 90828, 90836, 14326, 90859, 90883, 90884, 14362, 90862, 90886, 90887, 
14364, 14346, 90860, 90885, 14363
32947, 14318, 90828, 90836, 14326, 14319, 90829, 90837, 14327, 90862, 90886, 90887, 14364, 90865, 90889, 90890, 
14366, 14348, 90863, 90888, 14365
32948, 14319, 90829, 90837, 14327, 14320, 90830, 90838, 14328, 90865, 90889, 90890, 14366, 90868, 90892, 90893, 
14368, 14350, 90866, 90891, 14367
32949, 14320, 90830, 90838, 14328, 14321, 90831, 90839, 14329, 90868, 90892, 90893, 14368, 90871, 90895, 90896, 
14370, 14352, 90869, 90894, 14369
32950, 14321, 90831, 90839, 14329, 1839, 14968, 14969, 1840, 90871, 90895, 90896, 14370, 14972, 14973, 14974, 
1843, 14354, 90872, 90897, 14371
32951, 1892, 14956, 14957, 1893, 14322, 90832, 90840, 14330, 14960, 14963, 14962, 1896, 90875, 90899, 90900, 
14373, 14355, 90873, 90898, 14372
32952, 14322, 90832, 90840, 14330, 14323, 90833, 90841, 14331, 90875, 90899, 90900, 14373, 90878, 90902, 90903, 
14375, 14357, 90876, 90901, 14374
32953, 14323, 90833, 90841, 14331, 14324, 90834, 90842, 14332, 90878, 90902, 90903, 14375, 90881, 90905, 90906, 
14377, 14359, 90879, 90904, 14376
32954, 14324, 90834, 90842, 14332, 14325, 90835, 90843, 14333, 90881, 90905, 90906, 14377, 90884, 90908, 90909, 
14379, 14361, 90882, 90907, 14378
32955, 14325, 90835, 90843, 14333, 14326, 90836, 90844, 14334, 90884, 90908, 90909, 14379, 90887, 90911, 90912, 
14381, 14363, 90885, 90910, 14380
32956, 14326, 90836, 90844, 14334, 14327, 90837, 90845, 14335, 90887, 90911, 90912, 14381, 90890, 90914, 90915, 
14383, 14365, 90888, 90913, 14382
32957, 14327, 90837, 90845, 14335, 14328, 90838, 90846, 14336, 90890, 90914, 90915, 14383, 90893, 90917, 90918, 
14385, 14367, 90891, 90916, 14384
32958, 14328, 90838, 90846, 14336, 14329, 90839, 90847, 14337, 90893, 90917, 90918, 14385, 90896, 90920, 90921, 
14387, 14369, 90894, 90919, 14386
32959, 14329, 90839, 90847, 14337, 1840, 14969, 14970, 1841, 90896, 90920, 90921, 14387, 14974, 14975, 14976, 
1844, 14371, 90897, 90922, 14388
32960, 1893, 14957, 1963, 62, 14330, 90840, 15014, 1950, 14962, 14964, 1964, 1897, 90900, 90923, 15022, 
14389, 14372, 90898, 15023, 1959
32961, 14330, 90840, 15014, 1950, 14331, 90841, 15015, 1949, 90900, 90923, 15022, 14389, 90903, 90924, 15024, 
14390, 14374, 90901, 15025, 1958
32962, 14331, 90841, 15015, 1949, 14332, 90842, 15016, 1948, 90903, 90924, 15024, 14390, 90906, 90925, 15026, 
14391, 14376, 90904, 15027, 1957
32963, 14332, 90842, 15016, 1948, 14333, 90843, 15017, 1947, 90906, 90925, 15026, 14391, 90909, 90926, 15028, 
14392, 14378, 90907, 15029, 1956
32964, 14333, 90843, 15017, 1947, 14334, 90844, 15018, 1946, 90909, 90926, 15028, 14392, 90912, 90927, 15030, 
14393, 14380, 90910, 15031, 1955
32965, 14334, 90844, 15018, 1946, 14335, 90845, 15019, 1945, 90912, 90927, 15030, 14393, 90915, 90928, 15032, 
14394, 14382, 90913, 15033, 1954
32966, 14335, 90845, 15019, 1945, 14336, 90846, 15020, 1944, 90915, 90928, 15032, 14394, 90918, 90929, 15034, 
14395, 14384, 90916, 15035, 1953
32967, 14336, 90846, 15020, 1944, 14337, 90847, 15021, 1943, 90918, 90929, 15034, 14395, 90921, 90930, 15036, 
14396, 14386, 90919, 15037, 1952
32968, 14337, 90847, 15021, 1943, 1841, 14970, 1976, 61, 90921, 90930, 15036, 14396, 14976, 14977, 1977, 
1845, 14388, 90922, 15038, 1951
32969, 1960, 63, 1966, 14955, 14981, 1993, 15047, 90824, 1962, 1969, 14965, 14959, 15006, 15072, 90931, 
90849, 14989, 2002, 15071, 90848
32970, 14981, 1993, 15047, 90824, 14982, 1992, 15048, 90825, 15006, 15072, 90931, 90849, 15007, 15074, 90932, 
90852, 14991, 2001, 15073, 90851
32971, 14982, 1992, 15048, 90825, 14983, 1991, 15049, 90826, 15007, 15074, 90932, 90852, 15008, 15076, 90933, 
90855, 14993, 2000, 15075, 90854
32972, 14983, 1991, 15049, 90826, 14984, 1990, 15050, 90827, 15008, 15076, 90933, 90855, 15009, 15078, 90934, 
90858, 14995, 1999, 15077, 90857
32973, 14984, 1990, 15050, 90827, 14985, 1989, 15051, 90828, 15009, 15078, 90934, 90858, 15010, 15080, 90935, 
90861, 14997, 1998, 15079, 90860
32974, 14985, 1989, 15051, 90828, 14986, 1988, 15052, 90829, 15010, 15080, 90935, 90861, 15011, 15082, 90936, 
90864, 14999, 1997, 15081, 90863
32975, 14986, 1988, 15052, 90829, 14987, 1987, 15053, 90830, 15011, 15082, 90936, 90864, 15012, 15084, 90937, 
90867, 15001, 1996, 15083, 90866
32976, 14987, 1987, 15053, 90830, 14988, 1986, 15054, 90831, 15012, 15084, 90937, 90867, 15013, 15086, 90938, 
90870, 15003, 1995, 15085, 90869
32977, 14988, 1986, 15054, 90831, 1973, 65, 1979, 14968, 15013, 15086, 90938, 90870, 1975, 1982, 14978, 
14971, 15005, 1994, 15087, 90872
32978, 14955, 1966, 1967, 14956, 90824, 15047, 15055, 90832, 14965, 1970, 14966, 14961, 90931, 15089, 90939, 
90874, 90848, 15071, 15088, 90873
32979, 90824, 15047, 15055, 90832, 90825, 15048, 15056, 90833, 90931, 15089, 90939, 90874, 90932, 15091, 90940, 
90877, 90851, 15073, 15090, 90876
32980, 90825, 15048, 15056, 90833, 90826, 15049, 15057, 90834, 90932, 15091, 90940, 90877, 90933, 15093, 90941, 
90880, 90854, 15075, 15092, 90879
32981, 90826, 15049, 15057, 90834, 90827, 15050, 15058, 90835, 90933, 15093, 90941, 90880, 90934, 15095, 90942, 
90883, 90857, 15077, 15094, 90882
32982, 90827, 15050, 15058, 90835, 90828, 15051, 15059, 90836, 90934, 15095, 90942, 90883, 90935, 15097, 90943, 
90886, 90860, 15079, 15096, 90885
32983, 90828, 15051, 15059, 90836, 90829, 15052, 15060, 90837, 90935, 15097, 90943, 90886, 90936, 15099, 90944, 
90889, 90863, 15081, 15098, 90888
32984, 90829, 15052, 15060, 90837, 90830, 15053, 15061, 90838, 90936, 15099, 90944, 90889, 90937, 15101, 90945, 
90892, 90866, 15083, 15100, 90891
32985, 90830, 15053, 15061, 90838, 90831, 15054, 15062, 90839, 90937, 15101, 90945, 90892, 90938, 15103, 90946, 
90895, 90869, 15085, 15102, 90894
32986, 90831, 15054, 15062, 90839, 14968, 1979, 1980, 14969, 90938, 15103, 90946, 90895, 14978, 1983, 14979, 
14973, 90872, 15087, 15104, 90897
32987, 14956, 1967, 1968, 14957, 90832, 15055, 15063, 90840, 14966, 1971, 14967, 14963, 90939, 15106, 90947, 
90899, 90873, 15088, 15105, 90898
32988, 90832, 15055, 15063, 90840, 90833, 15056, 15064, 90841, 90939, 15106, 90947, 90899, 90940, 15108, 90948, 
90902, 90876, 15090, 15107, 90901
32989, 90833, 15056, 15064, 90841, 90834, 15057, 15065, 90842, 90940, 15108, 90948, 90902, 90941, 15110, 90949, 
90905, 90879, 15092, 15109, 90904
32990, 90834, 15057, 15065, 90842, 90835, 15058, 15066, 90843, 90941, 15110, 90949, 90905, 90942, 15112, 90950, 
90908, 90882, 15094, 15111, 90907
32991, 90835, 15058, 15066, 90843, 90836, 15059, 15067, 90844, 90942, 15112, 90950, 90908, 90943, 15114, 90951, 
90911, 90885, 15096, 15113, 90910
32992, 90836, 15059, 15067, 90844, 90837, 15060, 15068, 90845, 90943, 15114, 90951, 90911, 90944, 15116, 90952, 
90914, 90888, 15098, 15115, 90913
32993, 90837, 15060, 15068, 90845, 90838, 15061, 15069, 90846, 90944, 15116, 90952, 90914, 90945, 15118, 90953, 
90917, 90891, 15100, 15117, 90916
32994, 90838, 15061, 15069, 90846, 90839, 15062, 15070, 90847, 90945, 15118, 90953, 90917, 90946, 15120, 90954, 
90920, 90894, 15102, 15119, 90919
32995, 90839, 15062, 15070, 90847, 14969, 1980, 1981, 14970, 90946, 15120, 90954, 90920, 14979, 1984, 14980, 
14975, 90897, 15104, 15121, 90922
32996, 14957, 1968, 64, 1963, 90840, 15063, 2010, 15014, 14967, 1972, 1965, 14964, 90947, 15122, 15039, 
90923, 90898, 15105, 2019, 15023
32997, 90840, 15063, 2010, 15014, 90841, 15064, 2009, 15015, 90947, 15122, 15039, 90923, 90948, 15123, 15040, 
90924, 90901, 15107, 2018, 15025
32998, 90841, 15064, 2009, 15015, 90842, 15065, 2008, 15016, 90948, 15123, 15040, 90924, 90949, 15124, 15041, 
90925, 90904, 15109, 2017, 15027
32999, 90842, 15065, 2008, 15016, 90843, 15066, 2007, 15017, 90949, 15124, 15041, 90925, 90950, 15125, 15042, 
90926, 90907, 15111, 2016, 15029
33000, 90843, 15066, 2007, 15017, 90844, 15067, 2006, 15018, 90950, 15125, 15042, 90926, 90951, 15126, 15043, 
90927, 90910, 15113, 2015, 15031
33001, 90844, 15067, 2006, 15018, 90845, 15068, 2005, 15019, 90951, 15126, 15043, 90927, 90952, 15127, 15044, 
90928, 90913, 15115, 2014, 15033
33002, 90845, 15068, 2005, 15019, 90846, 15069, 2004, 15020, 90952, 15127, 15044, 90928, 90953, 15128, 15045, 
90929, 90916, 15117, 2013, 15035
33003, 90846, 15069, 2004, 15020, 90847, 15070, 2003, 15021, 90953, 15128, 15045, 90929, 90954, 15129, 15046, 
90930, 90919, 15119, 2012, 15037
33004, 90847, 15070, 2003, 15021, 14970, 1981, 66, 1976, 90954, 15129, 15046, 90930, 14980, 1985, 1978, 
14977, 90922, 15121, 2011, 15038
*ELEMENT, type=C3D20, ELSET=Volume29
33005, 19307, 2637, 77, 2516, 90955, 19333, 2506, 18666, 19310, 2638, 2519, 19311, 90980, 19341, 18690, 
90981, 90979, 19342, 2515, 18691
33006, 90955, 19333, 2506, 18666, 90956, 19334, 2505, 18667, 90980, 19341, 18690, 90981, 90983, 19343, 18692, 
90984, 90982, 19344, 2514, 18693
33007, 90956, 19334, 2505, 18667, 90957, 19335, 2504, 18668, 90983, 19343, 18692, 90984, 90986, 19345, 18694, 
90987, 90985, 19346, 2513, 18695
33008, 90957, 19335, 2504, 18668, 90958, 19336, 2503, 18669, 90986, 19345, 18694, 90987, 90989, 19347, 18696, 
90990, 90988, 19348, 2512, 18697
33009, 90958, 19336, 2503, 18669, 90959, 19337, 2502, 18670, 90989, 19347, 18696, 90990, 90992, 19349, 18698, 
90993, 90991, 19350, 2511, 18699
33010, 90959, 19337, 2502, 18670, 90960, 19338, 2501, 18671, 90992, 19349, 18698, 90993, 90995, 19351, 18700, 
90996, 90994, 19352, 2510, 18701
33011, 90960, 19338, 2501, 18671, 90961, 19339, 2500, 18672, 90995, 19351, 18700, 90996, 90998, 19353, 18702, 
90999, 90997, 19354, 2509, 18703
33012, 90961, 19339, 2500, 18672, 90962, 19340, 2499, 18673, 90998, 19353, 18702, 90999, 91001, 19355, 18704, 
91002, 91000, 19356, 2508, 18705
33013, 90962, 19340, 2499, 18673, 19320, 2650, 78, 2568, 91001, 19355, 18704, 91002, 19324, 2651, 2571, 
19323, 91003, 19357, 2507, 18706
33014, 19308, 19307, 2516, 2517, 90963, 90955, 18666, 18674, 19312, 19311, 2520, 19313, 91005, 90981, 18707, 
91006, 91004, 90979, 18691, 18708
33015, 90963, 90955, 18666, 18674, 90964, 90956, 18667, 18675, 91005, 90981, 18707, 91006, 91008, 90984, 18709, 
91009, 91007, 90982, 18693, 18710
33016, 90964, 90956, 18667, 18675, 90965, 90957, 18668, 18676, 91008, 90984, 18709, 91009, 91011, 90987, 18711, 
91012, 91010, 90985, 18695, 18712
33017, 90965, 90957, 18668, 18676, 90966, 90958, 18669, 18677, 91011, 90987, 18711, 91012, 91014, 90990, 18713, 
91015, 91013, 90988, 18697, 18714
33018, 90966, 90958, 18669, 18677, 90967, 90959, 18670, 18678, 91014, 90990, 18713, 91015, 91017, 90993, 18715, 
91018, 91016, 90991, 18699, 18716
33019, 90967, 90959, 18670, 18678, 90968, 90960, 18671, 18679, 91017, 90993, 18715, 91018, 91020, 90996, 18717, 
91021, 91019, 90994, 18701, 18718
33020, 90968, 90960, 18671, 18679, 90969, 90961, 18672, 18680, 91020, 90996, 18717, 91021, 91023, 90999, 18719, 
91024, 91022, 90997, 18703, 18720
33021, 90969, 90961, 18672, 18680, 90970, 90962, 18673, 18681, 91023, 90999, 18719, 91024, 91026, 91002, 18721, 
91027, 91025, 91000, 18705, 18722
33022, 90970, 90962, 18673, 18681, 19321, 19320, 2568, 2569, 91026, 91002, 18721, 91027, 19326, 19323, 2572, 
19325, 91028, 91003, 18706, 18723
33023, 19309, 19308, 2517, 2518, 90971, 90963, 18674, 18682, 19314, 19313, 2521, 19315, 91030, 91006, 18724, 
91031, 91029, 91004, 18708, 18725
33024, 90971, 90963, 18674, 18682, 90972, 90964, 18675, 18683, 91030, 91006, 18724, 91031, 91033, 91009, 18726, 
91034, 91032, 91007, 18710, 18727
33025, 90972, 90964, 18675, 18683, 90973, 90965, 18676, 18684, 91033, 91009, 18726, 91034, 91036, 91012, 18728, 
91037, 91035, 91010, 18712, 18729
33026, 90973, 90965, 18676, 18684, 90974, 90966, 18677, 18685, 91036, 91012, 18728, 91037, 91039, 91015, 18730, 
91040, 91038, 91013, 18714, 18731
33027, 90974, 90966, 18677, 18685, 90975, 90967, 18678, 18686, 91039, 91015, 18730, 91040, 91042, 91018, 18732, 
91043, 91041, 91016, 18716, 18733
33028, 90975, 90967, 18678, 18686, 90976, 90968, 18679, 18687, 91042, 91018, 18732, 91043, 91045, 91021, 18734, 
91046, 91044, 91019, 18718, 18735
33029, 90976, 90968, 18679, 18687, 90977, 90969, 18680, 18688, 91045, 91021, 18734, 91046, 91048, 91024, 18736, 
91049, 91047, 91022, 18720, 18737
33030, 90977, 90969, 18680, 18688, 90978, 90970, 18681, 18689, 91048, 91024, 18736, 91049, 91051, 91027, 18738, 
91052, 91050, 91025, 18722, 18739
33031, 90978, 90970, 18681, 18689, 19322, 19321, 2569, 2570, 91051, 91027, 18738, 91052, 19328, 19325, 2573, 
19327, 91053, 91028, 18723, 18740
33032, 2640, 19309, 2518, 79, 19366, 90971, 18682, 2627, 19316, 19315, 2522, 2641, 91054, 91031, 18741, 
19375, 19374, 91029, 18725, 2636
33033, 19366, 90971, 18682, 2627, 19367, 90972, 18683, 2626, 91054, 91031, 18741, 19375, 91055, 91034, 18742, 
19377, 19376, 91032, 18727, 2635
33034, 19367, 90972, 18683, 2626, 19368, 90973, 18684, 2625, 91055, 91034, 18742, 19377, 91056, 91037, 18743, 
19379, 19378, 91035, 18729, 2634
33035, 19368, 90973, 18684, 2625, 19369, 90974, 18685, 2624, 91056, 91037, 18743, 19379, 91057, 91040, 18744, 
19381, 19380, 91038, 18731, 2633
33036, 19369, 90974, 18685, 2624, 19370, 90975, 18686, 2623, 91057, 91040, 18744, 19381, 91058, 91043, 18745, 
19383, 19382, 91041, 18733, 2632
33037, 19370, 90975, 18686, 2623, 19371, 90976, 18687, 2622, 91058, 91043, 18745, 19383, 91059, 91046, 18746, 
19385, 19384, 91044, 18735, 2631
33038, 19371, 90976, 18687, 2622, 19372, 90977, 18688, 2621, 91059, 91046, 18746, 19385, 91060, 91049, 18747, 
19387, 19386, 91047, 18737, 2630
33039, 19372, 90977, 18688, 2621, 19373, 90978, 18689, 2620, 91060, 91049, 18747, 19387, 91061, 91052, 18748, 
19389, 19388, 91050, 18739, 2629
33040, 19373, 90978, 18689, 2620, 2653, 19322, 2570, 80, 91061, 91052, 18748, 19389, 19329, 19327, 2574, 
2654, 19390, 91053, 18740, 2628
33041, 2643, 81, 2637, 19307, 19399, 2670, 19333, 90955, 2646, 2639, 19310, 19317, 19423, 19358, 90980, 
91062, 19424, 2679, 19342, 90979
33042, 19399, 2670, 19333, 90955, 19400, 2669, 19334, 90956, 19423, 19358, 90980, 91062, 19425, 19359, 90983, 
91063, 19426, 2678, 19344, 90982
33043, 19400, 2669, 19334, 90956, 19401, 2668, 19335, 90957, 19425, 19359, 90983, 91063, 19427, 19360, 90986, 
91064, 19428, 2677, 19346, 90985
33044, 19401, 2668, 19335, 90957, 19402, 2667, 19336, 90958, 19427, 19360, 90986, 91064, 19429, 19361, 90989, 
91065, 19430, 2676, 19348, 90988
33045, 19402, 2667, 19336, 90958, 19403, 2666, 19337, 90959, 19429, 19361, 90989, 91065, 19431, 19362, 90992, 
91066, 19432, 2675, 19350, 90991
33046, 19403, 2666, 19337, 90959, 19404, 2665, 19338, 90960, 19431, 19362, 90992, 91066, 19433, 19363, 90995, 
91067, 19434, 2674, 19352, 90994
33047, 19404, 2665, 19338, 90960, 19405, 2664, 19339, 90961, 19433, 19363, 90995, 91067, 19435, 19364, 90998, 
91068, 19436, 2673, 19354, 90997
33048, 19405, 2664, 19339, 90961, 19406, 2663, 19340, 90962, 19435, 19364, 90998, 91068, 19437, 19365, 91001, 
91069, 19438, 2672, 19356, 91000
33049, 19406, 2663, 19340, 90962, 2656, 83, 2650, 19320, 19437, 19365, 91001, 91069, 2659, 2652, 19324, 
19330, 19439, 2671, 19357, 91003
33050, 2644, 2643, 19307, 19308, 19407, 19399, 90955, 90963, 2647, 19317, 19312, 19318, 19440, 91062, 91005, 
91070, 19441, 19424, 90979, 91004
33051, 19407, 19399, 90955, 90963, 19408, 19400, 90956, 90964, 19440, 91062, 91005, 91070, 19442, 91063, 91008, 
91071, 19443, 19426, 90982, 91007
33052, 19408, 19400, 90956, 90964, 19409, 19401, 90957, 90965, 19442, 91063, 91008, 91071, 19444, 91064, 91011, 
91072, 19445, 19428, 90985, 91010
33053, 19409, 19401, 90957, 90965, 19410, 19402, 90958, 90966, 19444, 91064, 91011, 91072, 19446, 91065, 91014, 
91073, 19447, 19430, 90988, 91013
33054, 19410, 19402, 90958, 90966, 19411, 19403, 90959, 90967, 19446, 91065, 91014, 91073, 19448, 91066, 91017, 
91074, 19449, 19432, 90991, 91016
33055, 19411, 19403, 90959, 90967, 19412, 19404, 90960, 90968, 19448, 91066, 91017, 91074, 19450, 91067, 91020, 
91075, 19451, 19434, 90994, 91019
33056, 19412, 19404, 90960, 90968, 19413, 19405, 90961, 90969, 19450, 91067, 91020, 91075, 19452, 91068, 91023, 
91076, 19453, 19436, 90997, 91022
33057, 19413, 19405, 90961, 90969, 19414, 19406, 90962, 90970, 19452, 91068, 91023, 91076, 19454, 91069, 91026, 
91077, 19455, 19438, 91000, 91025
33058, 19414, 19406, 90962, 90970, 2657, 2656, 19320, 19321, 19454, 91069, 91026, 91077, 2660, 19330, 19326, 
19331, 19456, 19439, 91003, 91028
33059, 2645, 2644, 19308, 19309, 19415, 19407, 90963, 90971, 2648, 19318, 19314, 19319, 19457, 91070, 91030, 
91078, 19458, 19441, 91004, 91029
33060, 19415, 19407, 90963, 90971, 19416, 19408, 90964, 90972, 19457, 91070, 91030, 91078, 19459, 91071, 91033, 
91079, 19460, 19443, 91007, 91032
33061, 19416, 19408, 90964, 90972, 19417, 19409, 90965, 90973, 19459, 91071, 91033, 91079, 19461, 91072, 91036, 
91080, 19462, 19445, 91010, 91035
33062, 19417, 19409, 90965, 90973, 19418, 19410, 90966, 90974, 19461, 91072, 91036, 91080, 19463, 91073, 91039, 
91081, 19464, 19447, 91013, 91038
33063, 19418, 19410, 90966, 90974, 19419, 19411, 90967, 90975, 19463, 91073, 91039, 91081, 19465, 91074, 91042, 
91082, 19466, 19449, 91016, 91041
33064, 19419, 19411, 90967, 90975, 19420, 19412, 90968, 90976, 19465, 91074, 91042, 91082, 19467, 91075, 91045, 
91083, 19468, 19451, 91019, 91044
33065, 19420, 19412, 90968, 90976, 19421, 19413, 90969, 90977, 19467, 91075, 91045, 91083, 19469, 91076, 91048, 
91084, 19470, 19453, 91022, 91047
33066, 19421, 19413, 90969, 90977, 19422, 19414, 90970, 90978, 19469, 91076, 91048, 91084, 19471, 91077, 91051, 
91085, 19472, 19455, 91025, 91050
33067, 19422, 19414, 90970, 90978, 2658, 2657, 19321, 19322, 19471, 91077, 91051, 91085, 2661, 19331, 19328, 
19332, 19473, 19456, 91028, 91053
33068, 82, 2645, 19309, 2640, 2687, 19415, 90971, 19366, 2649, 19319, 19316, 2642, 19474, 91078, 91054, 
19391, 2696, 19458, 91029, 19374
33069, 2687, 19415, 90971, 19366, 2686, 19416, 90972, 19367, 19474, 91078, 91054, 19391, 19475, 91079, 91055, 
19392, 2695, 19460, 91032, 19376
33070, 2686, 19416, 90972, 19367, 2685, 19417, 90973, 19368, 19475, 91079, 91055, 19392, 19476, 91080, 91056, 
19393, 2694, 19462, 91035, 19378
33071, 2685, 19417, 90973, 19368, 2684, 19418, 90974, 19369, 19476, 91080, 91056, 19393, 19477, 91081, 91057, 
19394, 2693, 19464, 91038, 19380
33072, 2684, 19418, 90974, 19369, 2683, 19419, 90975, 19370, 19477, 91081, 91057, 19394, 19478, 91082, 91058, 
19395, 2692, 19466, 91041, 19382
33073, 2683, 19419, 90975, 19370, 2682, 19420, 90976, 19371, 19478, 91082, 91058, 19395, 19479, 91083, 91059, 
19396, 2691, 19468, 91044, 19384
33074, 2682, 19420, 90976, 19371, 2681, 19421, 90977, 19372, 19479, 91083, 91059, 19396, 19480, 91084, 91060, 
19397, 2690, 19470, 91047, 19386
33075, 2681, 19421, 90977, 19372, 2680, 19422, 90978, 19373, 19480, 91084, 91060, 19397, 19481, 91085, 91061, 
19398, 2689, 19472, 91050, 19388
33076, 2680, 19422, 90978, 19373, 84, 2658, 19322, 2653, 19481, 91085, 91061, 19398, 2662, 19332, 19329, 
2655, 2688, 19473, 91053, 19390
*ELEMENT, type=C3D20, ELSET=Volume30
33077, 35, 3577, 30418, 1196, 1303, 30596, 91086, 10897, 3578, 30441, 30440, 1218, 30605, 91263, 91264, 
11074, 1312, 30604, 91262, 11073
33078, 1303, 30596, 91086, 10897, 1302, 30597, 91087, 10898, 30605, 91263, 91264, 11074, 30607, 91266, 91267, 
11076, 1311, 30606, 91265, 11075
33079, 1302, 30597, 91087, 10898, 1301, 30598, 91088, 10899, 30607, 91266, 91267, 11076, 30609, 91269, 91270, 
11078, 1310, 30608, 91268, 11077
33080, 1301, 30598, 91088, 10899, 1300, 30599, 91089, 10900, 30609, 91269, 91270, 11078, 30611, 91272, 91273, 
11080, 1309, 30610, 91271, 11079
33081, 1300, 30599, 91089, 10900, 1299, 30600, 91090, 10901, 30611, 91272, 91273, 11080, 30613, 91275, 91276, 
11082, 1308, 30612, 91274, 11081
33082, 1299, 30600, 91090, 10901, 1298, 30601, 91091, 10902, 30613, 91275, 91276, 11082, 30615, 91278, 91279, 
11084, 1307, 30614, 91277, 11083
33083, 1298, 30601, 91091, 10902, 1297, 30602, 91092, 10903, 30615, 91278, 91279, 11084, 30617, 91281, 91282, 
11086, 1306, 30616, 91280, 11085
33084, 1297, 30602, 91092, 10903, 1296, 30603, 91093, 10904, 30617, 91281, 91282, 11086, 30619, 91284, 91285, 
11088, 1305, 30618, 91283, 11087
33085, 1296, 30603, 91093, 10904, 37, 3583, 30507, 1251, 30619, 91284, 91285, 11088, 3584, 30529, 30530, 
1273, 1304, 30620, 91286, 11089
33086, 1196, 30418, 30419, 1197, 10897, 91086, 91094, 10905, 30440, 30443, 30442, 1219, 91264, 91288, 91289, 
11091, 11073, 91262, 91287, 11090
33087, 10897, 91086, 91094, 10905, 10898, 91087, 91095, 10906, 91264, 91288, 91289, 11091, 91267, 91291, 91292, 
11093, 11075, 91265, 91290, 11092
33088, 10898, 91087, 91095, 10906, 10899, 91088, 91096, 10907, 91267, 91291, 91292, 11093, 91270, 91294, 91295, 
11095, 11077, 91268, 91293, 11094
33089, 10899, 91088, 91096, 10907, 10900, 91089, 91097, 10908, 91270, 91294, 91295, 11095, 91273, 91297, 91298, 
11097, 11079, 91271, 91296, 11096
33090, 10900, 91089, 91097, 10908, 10901, 91090, 91098, 10909, 91273, 91297, 91298, 11097, 91276, 91300, 91301, 
11099, 11081, 91274, 91299, 11098
33091, 10901, 91090, 91098, 10909, 10902, 91091, 91099, 10910, 91276, 91300, 91301, 11099, 91279, 91303, 91304, 
11101, 11083, 91277, 91302, 11100
33092, 10902, 91091, 91099, 10910, 10903, 91092, 91100, 10911, 91279, 91303, 91304, 11101, 91282, 91306, 91307, 
11103, 11085, 91280, 91305, 11102
33093, 10903, 91092, 91100, 10911, 10904, 91093, 91101, 10912, 91282, 91306, 91307, 11103, 91285, 91309, 91310, 
11105, 11087, 91283, 91308, 11104
33094, 10904, 91093, 91101, 10912, 1251, 30507, 30508, 1252, 91285, 91309, 91310, 11105, 30530, 30531, 30532, 
1274, 11089, 91286, 91311, 11106
33095, 1197, 30419, 30420, 1198, 10905, 91094, 91102, 10913, 30442, 30445, 30444, 1220, 91289, 91313, 91314, 
11108, 11090, 91287, 91312, 11107
33096, 10905, 91094, 91102, 10913, 10906, 91095, 91103, 10914, 91289, 91313, 91314, 11108, 91292, 91316, 91317, 
11110, 11092, 91290, 91315, 11109
33097, 10906, 91095, 91103, 10914, 10907, 91096, 91104, 10915, 91292, 91316, 91317, 11110, 91295, 91319, 91320, 
11112, 11094, 91293, 91318, 11111
33098, 10907, 91096, 91104, 10915, 10908, 91097, 91105, 10916, 91295, 91319, 91320, 11112, 91298, 91322, 91323, 
11114, 11096, 91296, 91321, 11113
33099, 10908, 91097, 91105, 10916, 10909, 91098, 91106, 10917, 91298, 91322, 91323, 11114, 91301, 91325, 91326, 
11116, 11098, 91299, 91324, 11115
33100, 10909, 91098, 91106, 10917, 10910, 91099, 91107, 10918, 91301, 91325, 91326, 11116, 91304, 91328, 91329, 
11118, 11100, 91302, 91327, 11117
33101, 10910, 91099, 91107, 10918, 10911, 91100, 91108, 10919, 91304, 91328, 91329, 11118, 91307, 91331, 91332, 
11120, 11102, 91305, 91330, 11119
33102, 10911, 91100, 91108, 10919, 10912, 91101, 91109, 10920, 91307, 91331, 91332, 11120, 91310, 91334, 91335, 
11122, 11104, 91308, 91333, 11121
33103, 10912, 91101, 91109, 10920, 1252, 30508, 30509, 1253, 91310, 91334, 91335, 11122, 30532, 30533, 30534, 
1275, 11106, 91311, 91336, 11123
33104, 1198, 30420, 30421, 1199, 10913, 91102, 91110, 10921, 30444, 30447, 30446, 1221, 91314, 91338, 91339, 
11125, 11107, 91312, 91337, 11124
33105, 10913, 91102, 91110, 10921, 10914, 91103, 91111, 10922, 91314, 91338, 91339, 11125, 91317, 91341, 91342, 
11127, 11109, 91315, 91340, 11126
33106, 10914, 91103, 91111, 10922, 10915, 91104, 91112, 10923, 91317, 91341, 91342, 11127, 91320, 91344, 91345, 
11129, 11111, 91318, 91343, 11128
33107, 10915, 91104, 91112, 10923, 10916, 91105, 91113, 10924, 91320, 91344, 91345, 11129, 91323, 91347, 91348, 
11131, 11113, 91321, 91346, 11130
33108, 10916, 91105, 91113, 10924, 10917, 91106, 91114, 10925, 91323, 91347, 91348, 11131, 91326, 91350, 91351, 
11133, 11115, 91324, 91349, 11132
33109, 10917, 91106, 91114, 10925, 10918, 91107, 91115, 10926, 91326, 91350, 91351, 11133, 91329, 91353, 91354, 
11135, 11117, 91327, 91352, 11134
33110, 10918, 91107, 91115, 10926, 10919, 91108, 91116, 10927, 91329, 91353, 91354, 11135, 91332, 91356, 91357, 
11137, 11119, 91330, 91355, 11136
33111, 10919, 91108, 91116, 10927, 10920, 91109, 91117, 10928, 91332, 91356, 91357, 11137, 91335, 91359, 91360, 
11139, 11121, 91333, 91358, 11138
33112, 10920, 91109, 91117, 10928, 1253, 30509, 30510, 1254, 91335, 91359, 91360, 11139, 30534, 30535, 30536, 
1276, 11123, 91336, 91361, 11140
33113, 1199, 30421, 30422, 1200, 10921, 91110, 91118, 10929, 30446, 30449, 30448, 1222, 91339, 91363, 91364, 
11142, 11124, 91337, 91362, 11141
33114, 10921, 91110, 91118, 10929, 10922, 91111, 91119, 10930, 91339, 91363, 91364, 11142, 91342, 91366, 91367, 
11144, 11126, 91340, 91365, 11143
33115, 10922, 91111, 91119, 10930, 10923, 91112, 91120, 10931, 91342, 91366, 91367, 11144, 91345, 91369, 91370, 
11146, 11128, 91343, 91368, 11145
33116, 10923, 91112, 91120, 10931, 10924, 91113, 91121, 10932, 91345, 91369, 91370, 11146, 91348, 91372, 91373, 
11148, 11130, 91346, 91371, 11147
33117, 10924, 91113, 91121, 10932, 10925, 91114, 91122, 10933, 91348, 91372, 91373, 11148, 91351, 91375, 91376, 
11150, 11132, 91349, 91374, 11149
33118, 10925, 91114, 91122, 10933, 10926, 91115, 91123, 10934, 91351, 91375, 91376, 11150, 91354, 91378, 91379, 
11152, 11134, 91352, 91377, 11151
33119, 10926, 91115, 91123, 10934, 10927, 91116, 91124, 10935, 91354, 91378, 91379, 11152, 91357, 91381, 91382, 
11154, 11136, 91355, 91380, 11153
33120, 10927, 91116, 91124, 10935, 10928, 91117, 91125, 10936, 91357, 91381, 91382, 11154, 91360, 91384, 91385, 
11156, 11138, 91358, 91383, 11155
33121, 10928, 91117, 91125, 10936, 1254, 30510, 30511, 1255, 91360, 91384, 91385, 11156, 30536, 30537, 30538, 
1277, 11140, 91361, 91386, 11157
33122, 1200, 30422, 30423, 1201, 10929, 91118, 91126, 10937, 30448, 30451, 30450, 1223, 91364, 91388, 91389, 
11159, 11141, 91362, 91387, 11158
33123, 10929, 91118, 91126, 10937, 10930, 91119, 91127, 10938, 91364, 91388, 91389, 11159, 91367, 91391, 91392, 
11161, 11143, 91365, 91390, 11160
33124, 10930, 91119, 91127, 10938, 10931, 91120, 91128, 10939, 91367, 91391, 91392, 11161, 91370, 91394, 91395, 
11163, 11145, 91368, 91393, 11162
33125, 10931, 91120, 91128, 10939, 10932, 91121, 91129, 10940, 91370, 91394, 91395, 11163, 91373, 91397, 91398, 
11165, 11147, 91371, 91396, 11164
33126, 10932, 91121, 91129, 10940, 10933, 91122, 91130, 10941, 91373, 91397, 91398, 11165, 91376, 91400, 91401, 
11167, 11149, 91374, 91399, 11166
33127, 10933, 91122, 91130, 10941, 10934, 91123, 91131, 10942, 91376, 91400, 91401, 11167, 91379, 91403, 91404, 
11169, 11151, 91377, 91402, 11168
33128, 10934, 91123, 91131, 10942, 10935, 91124, 91132, 10943, 91379, 91403, 91404, 11169, 91382, 91406, 91407, 
11171, 11153, 91380, 91405, 11170
33129, 10935, 91124, 91132, 10943, 10936, 91125, 91133, 10944, 91382, 91406, 91407, 11171, 91385, 91409, 91410, 
11173, 11155, 91383, 91408, 11172
33130, 10936, 91125, 91133, 10944, 1255, 30511, 30512, 1256, 91385, 91409, 91410, 11173, 30538, 30539, 30540, 
1278, 11157, 91386, 91411, 11174
33131, 1201, 30423, 30424, 1202, 10937, 91126, 91134, 10945, 30450, 30453, 30452, 1224, 91389, 91413, 91414, 
11176, 11158, 91387, 91412, 11175
33132, 10937, 91126, 91134, 10945, 10938, 91127, 91135, 10946, 91389, 91413, 91414, 11176, 91392, 91416, 91417, 
11178, 11160, 91390, 91415, 11177
33133, 10938, 91127, 91135, 10946, 10939, 91128, 91136, 10947, 91392, 91416, 91417, 11178, 91395, 91419, 91420, 
11180, 11162, 91393, 91418, 11179
33134, 10939, 91128, 91136, 10947, 10940, 91129, 91137, 10948, 91395, 91419, 91420, 11180, 91398, 91422, 91423, 
11182, 11164, 91396, 91421, 11181
33135, 10940, 91129, 91137, 10948, 10941, 91130, 91138, 10949, 91398, 91422, 91423, 11182, 91401, 91425, 91426, 
11184, 11166, 91399, 91424, 11183
33136, 10941, 91130, 91138, 10949, 10942, 91131, 91139, 10950, 91401, 91425, 91426, 11184, 91404, 91428, 91429, 
11186, 11168, 91402, 91427, 11185
33137, 10942, 91131, 91139, 10950, 10943, 91132, 91140, 10951, 91404, 91428, 91429, 11186, 91407, 91431, 91432, 
11188, 11170, 91405, 91430, 11187
33138, 10943, 91132, 91140, 10951, 10944, 91133, 91141, 10952, 91407, 91431, 91432, 11188, 91410, 91434, 91435, 
11190, 11172, 91408, 91433, 11189
33139, 10944, 91133, 91141, 10952, 1256, 30512, 30513, 1257, 91410, 91434, 91435, 11190, 30540, 30541, 30542, 
1279, 11174, 91411, 91436, 11191
33140, 1202, 30424, 30425, 1203, 10945, 91134, 91142, 10953, 30452, 30455, 30454, 1225, 91414, 91438, 91439, 
11193, 11175, 91412, 91437, 11192
33141, 10945, 91134, 91142, 10953, 10946, 91135, 91143, 10954, 91414, 91438, 91439, 11193, 91417, 91441, 91442, 
11195, 11177, 91415, 91440, 11194
33142, 10946, 91135, 91143, 10954, 10947, 91136, 91144, 10955, 91417, 91441, 91442, 11195, 91420, 91444, 91445, 
11197, 11179, 91418, 91443, 11196
33143, 10947, 91136, 91144, 10955, 10948, 91137, 91145, 10956, 91420, 91444, 91445, 11197, 91423, 91447, 91448, 
11199, 11181, 91421, 91446, 11198
33144, 10948, 91137, 91145, 10956, 10949, 91138, 91146, 10957, 91423, 91447, 91448, 11199, 91426, 91450, 91451, 
11201, 11183, 91424, 91449, 11200
33145, 10949, 91138, 91146, 10957, 10950, 91139, 91147, 10958, 91426, 91450, 91451, 11201, 91429, 91453, 91454, 
11203, 11185, 91427, 91452, 11202
33146, 10950, 91139, 91147, 10958, 10951, 91140, 91148, 10959, 91429, 91453, 91454, 11203, 91432, 91456, 91457, 
11205, 11187, 91430, 91455, 11204
33147, 10951, 91140, 91148, 10959, 10952, 91141, 91149, 10960, 91432, 91456, 91457, 11205, 91435, 91459, 91460, 
11207, 11189, 91433, 91458, 11206
33148, 10952, 91141, 91149, 10960, 1257, 30513, 30514, 1258, 91435, 91459, 91460, 11207, 30542, 30543, 30544, 
1280, 11191, 91436, 91461, 11208
33149, 1203, 30425, 30426, 1204, 10953, 91142, 91150, 10961, 30454, 30457, 30456, 1226, 91439, 91463, 91464, 
11210, 11192, 91437, 91462, 11209
33150, 10953, 91142, 91150, 10961, 10954, 91143, 91151, 10962, 91439, 91463, 91464, 11210, 91442, 91466, 91467, 
11212, 11194, 91440, 91465, 11211
33151, 10954, 91143, 91151, 10962, 10955, 91144, 91152, 10963, 91442, 91466, 91467, 11212, 91445, 91469, 91470, 
11214, 11196, 91443, 91468, 11213
33152, 10955, 91144, 91152, 10963, 10956, 91145, 91153, 10964, 91445, 91469, 91470, 11214, 91448, 91472, 91473, 
11216, 11198, 91446, 91471, 11215
33153, 10956, 91145, 91153, 10964, 10957, 91146, 91154, 10965, 91448, 91472, 91473, 11216, 91451, 91475, 91476, 
11218, 11200, 91449, 91474, 11217
33154, 10957, 91146, 91154, 10965, 10958, 91147, 91155, 10966, 91451, 91475, 91476, 11218, 91454, 91478, 91479, 
11220, 11202, 91452, 91477, 11219
33155, 10958, 91147, 91155, 10966, 10959, 91148, 91156, 10967, 91454, 91478, 91479, 11220, 91457, 91481, 91482, 
11222, 11204, 91455, 91480, 11221
33156, 10959, 91148, 91156, 10967, 10960, 91149, 91157, 10968, 91457, 91481, 91482, 11222, 91460, 91484, 91485, 
11224, 11206, 91458, 91483, 11223
33157, 10960, 91149, 91157, 10968, 1258, 30514, 30515, 1259, 91460, 91484, 91485, 11224, 30544, 30545, 30546, 
1281, 11208, 91461, 91486, 11225
33158, 1204, 30426, 30427, 1205, 10961, 91150, 91158, 10969, 30456, 30459, 30458, 1227, 91464, 91488, 91489, 
11227, 11209, 91462, 91487, 11226
33159, 10961, 91150, 91158, 10969, 10962, 91151, 91159, 10970, 91464, 91488, 91489, 11227, 91467, 91491, 91492, 
11229, 11211, 91465, 91490, 11228
33160, 10962, 91151, 91159, 10970, 10963, 91152, 91160, 10971, 91467, 91491, 91492, 11229, 91470, 91494, 91495, 
11231, 11213, 91468, 91493, 11230
33161, 10963, 91152, 91160, 10971, 10964, 91153, 91161, 10972, 91470, 91494, 91495, 11231, 91473, 91497, 91498, 
11233, 11215, 91471, 91496, 11232
33162, 10964, 91153, 91161, 10972, 10965, 91154, 91162, 10973, 91473, 91497, 91498, 11233, 91476, 91500, 91501, 
11235, 11217, 91474, 91499, 11234
33163, 10965, 91154, 91162, 10973, 10966, 91155, 91163, 10974, 91476, 91500, 91501, 11235, 91479, 91503, 91504, 
11237, 11219, 91477, 91502, 11236
33164, 10966, 91155, 91163, 10974, 10967, 91156, 91164, 10975, 91479, 91503, 91504, 11237, 91482, 91506, 91507, 
11239, 11221, 91480, 91505, 11238
33165, 10967, 91156, 91164, 10975, 10968, 91157, 91165, 10976, 91482, 91506, 91507, 11239, 91485, 91509, 91510, 
11241, 11223, 91483, 91508, 11240
33166, 10968, 91157, 91165, 10976, 1259, 30515, 30516, 1260, 91485, 91509, 91510, 11241, 30546, 30547, 30548, 
1282, 11225, 91486, 91511, 11242
33167, 1205, 30427, 30428, 1206, 10969, 91158, 91166, 10977, 30458, 30461, 30460, 1228, 91489, 91513, 91514, 
11244, 11226, 91487, 91512, 11243
33168, 10969, 91158, 91166, 10977, 10970, 91159, 91167, 10978, 91489, 91513, 91514, 11244, 91492, 91516, 91517, 
11246, 11228, 91490, 91515, 11245
33169, 10970, 91159, 91167, 10978, 10971, 91160, 91168, 10979, 91492, 91516, 91517, 11246, 91495, 91519, 91520, 
11248, 11230, 91493, 91518, 11247
33170, 10971, 91160, 91168, 10979, 10972, 91161, 91169, 10980, 91495, 91519, 91520, 11248, 91498, 91522, 91523, 
11250, 11232, 91496, 91521, 11249
33171, 10972, 91161, 91169, 10980, 10973, 91162, 91170, 10981, 91498, 91522, 91523, 11250, 91501, 91525, 91526, 
11252, 11234, 91499, 91524, 11251
