33867, 92138, 19764, 19756, 92146, 92139, 19765, 19757, 92147, 92872, 19983, 92880, 92641, 92873, 19985, 92881, 
92644, 92618, 19984, 19967, 92643
33868, 92139, 19765, 19757, 92147, 30801, 2775, 2774, 30802, 92873, 19985, 92881, 92644, 30868, 2797, 30869, 
30842, 92621, 19986, 19969, 92646
33869, 30680, 2706, 2705, 30681, 92140, 19750, 19742, 92148, 30747, 2728, 30748, 30723, 92874, 19954, 92882, 
92648, 92622, 19953, 19936, 92647
33870, 92140, 19750, 19742, 92148, 92141, 19751, 19743, 92149, 92874, 19954, 92882, 92648, 92875, 19956, 92883, 
92651, 92625, 19955, 19938, 92650
33871, 92141, 19751, 19743, 92149, 92142, 19752, 19744, 92150, 92875, 19956, 92883, 92651, 92876, 19958, 92884, 
92654, 92628, 19957, 19940, 92653
33872, 92142, 19752, 19744, 92150, 92143, 19753, 19745, 92151, 92876, 19958, 92884, 92654, 92877, 19960, 92885, 
92657, 92631, 19959, 19942, 92656
33873, 92143, 19753, 19745, 92151, 92144, 19754, 19746, 92152, 92877, 19960, 92885, 92657, 92878, 19962, 92886, 
92660, 92634, 19961, 19944, 92659
33874, 92144, 19754, 19746, 92152, 92145, 19755, 19747, 92153, 92878, 19962, 92886, 92660, 92879, 19964, 92887, 
92663, 92637, 19963, 19946, 92662
33875, 92145, 19755, 19747, 92153, 92146, 19756, 19748, 92154, 92879, 19964, 92887, 92663, 92880, 19966, 92888, 
92666, 92640, 19965, 19948, 92665
33876, 92146, 19756, 19748, 92154, 92147, 19757, 19749, 92155, 92880, 19966, 92888, 92666, 92881, 19968, 92889, 
92669, 92643, 19967, 19950, 92668
33877, 92147, 19757, 19749, 92155, 30802, 2774, 2773, 30803, 92881, 19968, 92889, 92669, 30869, 2796, 30870, 
30844, 92646, 19969, 19952, 92671
33878, 30681, 2705, 2704, 30682, 92148, 19742, 19734, 92156, 30748, 2727, 30749, 30725, 92882, 19937, 92890, 
92673, 92647, 19936, 19919, 92672
33879, 92148, 19742, 19734, 92156, 92149, 19743, 19735, 92157, 92882, 19937, 92890, 92673, 92883, 19939, 92891, 
92676, 92650, 19938, 19921, 92675
33880, 92149, 19743, 19735, 92157, 92150, 19744, 19736, 92158, 92883, 19939, 92891, 92676, 92884, 19941, 92892, 
92679, 92653, 19940, 19923, 92678
33881, 92150, 19744, 19736, 92158, 92151, 19745, 19737, 92159, 92884, 19941, 92892, 92679, 92885, 19943, 92893, 
92682, 92656, 19942, 19925, 92681
33882, 92151, 19745, 19737, 92159, 92152, 19746, 19738, 92160, 92885, 19943, 92893, 92682, 92886, 19945, 92894, 
92685, 92659, 19944, 19927, 92684
33883, 92152, 19746, 19738, 92160, 92153, 19747, 19739, 92161, 92886, 19945, 92894, 92685, 92887, 19947, 92895, 
92688, 92662, 19946, 19929, 92687
33884, 92153, 19747, 19739, 92161, 92154, 19748, 19740, 92162, 92887, 19947, 92895, 92688, 92888, 19949, 92896, 
92691, 92665, 19948, 19931, 92690
33885, 92154, 19748, 19740, 92162, 92155, 19749, 19741, 92163, 92888, 19949, 92896, 92691, 92889, 19951, 92897, 
92694, 92668, 19950, 19933, 92693
33886, 92155, 19749, 19741, 92163, 30803, 2773, 2772, 30804, 92889, 19951, 92897, 92694, 30870, 2795, 30871, 
30846, 92671, 19952, 19935, 92696
33887, 30682, 2704, 2703, 30683, 92156, 19734, 19726, 92164, 30749, 2726, 30750, 30727, 92890, 19920, 92898, 
92698, 92672, 19919, 19902, 92697
33888, 92156, 19734, 19726, 92164, 92157, 19735, 19727, 92165, 92890, 19920, 92898, 92698, 92891, 19922, 92899, 
92701, 92675, 19921, 19904, 92700
33889, 92157, 19735, 19727, 92165, 92158, 19736, 19728, 92166, 92891, 19922, 92899, 92701, 92892, 19924, 92900, 
92704, 92678, 19923, 19906, 92703
33890, 92158, 19736, 19728, 92166, 92159, 19737, 19729, 92167, 92892, 19924, 92900, 92704, 92893, 19926, 92901, 
92707, 92681, 19925, 19908, 92706
33891, 92159, 19737, 19729, 92167, 92160, 19738, 19730, 92168, 92893, 19926, 92901, 92707, 92894, 19928, 92902, 
92710, 92684, 19927, 19910, 92709
33892, 92160, 19738, 19730, 92168, 92161, 19739, 19731, 92169, 92894, 19928, 92902, 92710, 92895, 19930, 92903, 
92713, 92687, 19929, 19912, 92712
33893, 92161, 19739, 19731, 92169, 92162, 19740, 19732, 92170, 92895, 19930, 92903, 92713, 92896, 19932, 92904, 
92716, 92690, 19931, 19914, 92715
33894, 92162, 19740, 19732, 92170, 92163, 19741, 19733, 92171, 92896, 19932, 92904, 92716, 92897, 19934, 92905, 
92719, 92693, 19933, 19916, 92718
33895, 92163, 19741, 19733, 92171, 30804, 2772, 2771, 30805, 92897, 19934, 92905, 92719, 30871, 2794, 30872, 
30848, 92696, 19935, 19918, 92721
33896, 30683, 2703, 86, 3592, 92164, 19726, 2816, 30880, 30750, 2725, 3594, 30728, 92898, 19903, 30905, 
92722, 92697, 19902, 2824, 30897
33897, 92164, 19726, 2816, 30880, 92165, 19727, 2817, 30879, 92898, 19903, 30905, 92722, 92899, 19905, 30904, 
92723, 92700, 19904, 2825, 30895
33898, 92165, 19727, 2817, 30879, 92166, 19728, 2818, 30878, 92899, 19905, 30904, 92723, 92900, 19907, 30903, 
92724, 92703, 19906, 2826, 30893
33899, 92166, 19728, 2818, 30878, 92167, 19729, 2819, 30877, 92900, 19907, 30903, 92724, 92901, 19909, 30902, 
92725, 92706, 19908, 2827, 30891
33900, 92167, 19729, 2819, 30877, 92168, 19730, 2820, 30876, 92901, 19909, 30902, 92725, 92902, 19911, 30901, 
92726, 92709, 19910, 2828, 30889
33901, 92168, 19730, 2820, 30876, 92169, 19731, 2821, 30875, 92902, 19911, 30901, 92726, 92903, 19913, 30900, 
92727, 92712, 19912, 2829, 30887
33902, 92169, 19731, 2821, 30875, 92170, 19732, 2822, 30874, 92903, 19913, 30900, 92727, 92904, 19915, 30899, 
92728, 92715, 19914, 2830, 30885
33903, 92170, 19732, 2822, 30874, 92171, 19733, 2823, 30873, 92904, 19915, 30899, 92728, 92905, 19917, 30898, 
92729, 92718, 19916, 2831, 30883
33904, 92171, 19733, 2823, 30873, 30805, 2771, 88, 3598, 92905, 19917, 30898, 92729, 30872, 2793, 3600, 
30850, 92721, 19918, 2832, 30881
*ELEMENT, type=C3D20, ELSET=Volume32
33905, 30906, 3601, 3, 2968, 92906, 31084, 173, 21780, 30928, 3602, 2990, 30929, 93083, 31092, 21956, 
93084, 93082, 31093, 182, 21957
33906, 92906, 31084, 173, 21780, 92907, 31085, 172, 21781, 93083, 31092, 21956, 93084, 93086, 31094, 21958, 
93087, 93085, 31095, 181, 21959
33907, 92907, 31085, 172, 21781, 92908, 31086, 171, 21782, 93086, 31094, 21958, 93087, 93089, 31096, 21960, 
93090, 93088, 31097, 180, 21961
33908, 92908, 31086, 171, 21782, 92909, 31087, 170, 21783, 93089, 31096, 21960, 93090, 93092, 31098, 21962, 
93093, 93091, 31099, 179, 21963
33909, 92909, 31087, 170, 21783, 92910, 31088, 169, 21784, 93092, 31098, 21962, 93093, 93095, 31100, 21964, 
93096, 93094, 31101, 178, 21965
33910, 92910, 31088, 169, 21784, 92911, 31089, 168, 21785, 93095, 31100, 21964, 93096, 93098, 31102, 21966, 
93099, 93097, 31103, 177, 21967
33911, 92911, 31089, 168, 21785, 92912, 31090, 167, 21786, 93098, 31102, 21966, 93099, 93101, 31104, 21968, 
93102, 93100, 31105, 176, 21969
33912, 92912, 31090, 167, 21786, 92913, 31091, 166, 21787, 93101, 31104, 21968, 93102, 93104, 31106, 21970, 
93105, 93103, 31107, 175, 21971
33913, 92913, 31091, 166, 21787, 30995, 3652, 1, 2833, 93104, 31106, 21970, 93105, 31018, 3653, 2855, 
31017, 93106, 31108, 174, 21972
33914, 30907, 30906, 2968, 2969, 92914, 92906, 21780, 21788, 30930, 30929, 2991, 30931, 93108, 93084, 21973, 
93109, 93107, 93082, 21957, 21974
33915, 92914, 92906, 21780, 21788, 92915, 92907, 21781, 21789, 93108, 93084, 21973, 93109, 93111, 93087, 21975, 
93112, 93110, 93085, 21959, 21976
33916, 92915, 92907, 21781, 21789, 92916, 92908, 21782, 21790, 93111, 93087, 21975, 93112, 93114, 93090, 21977, 
93115, 93113, 93088, 21961, 21978
33917, 92916, 92908, 21782, 21790, 92917, 92909, 21783, 21791, 93114, 93090, 21977, 93115, 93117, 93093, 21979, 
93118, 93116, 93091, 21963, 21980
33918, 92917, 92909, 21783, 21791, 92918, 92910, 21784, 21792, 93117, 93093, 21979, 93118, 93120, 93096, 21981, 
93121, 93119, 93094, 21965, 21982
33919, 92918, 92910, 21784, 21792, 92919, 92911, 21785, 21793, 93120, 93096, 21981, 93121, 93123, 93099, 21983, 
93124, 93122, 93097, 21967, 21984
33920, 92919, 92911, 21785, 21793, 92920, 92912, 21786, 21794, 93123, 93099, 21983, 93124, 93126, 93102, 21985, 
93127, 93125, 93100, 21969, 21986
33921, 92920, 92912, 21786, 21794, 92921, 92913, 21787, 21795, 93126, 93102, 21985, 93127, 93129, 93105, 21987, 
93130, 93128, 93103, 21971, 21988
33922, 92921, 92913, 21787, 21795, 30996, 30995, 2833, 2834, 93129, 93105, 21987, 93130, 31020, 31017, 2856, 
31019, 93131, 93106, 21972, 21989
33923, 30908, 30907, 2969, 2970, 92922, 92914, 21788, 21796, 30932, 30931, 2992, 30933, 93133, 93109, 21990, 
93134, 93132, 93107, 21974, 21991
33924, 92922, 92914, 21788, 21796, 92923, 92915, 21789, 21797, 93133, 93109, 21990, 93134, 93136, 93112, 21992, 
93137, 93135, 93110, 21976, 21993
33925, 92923, 92915, 21789, 21797, 92924, 92916, 21790, 21798, 93136, 93112, 21992, 93137, 93139, 93115, 21994, 
93140, 93138, 93113, 21978, 21995
33926, 92924, 92916, 21790, 21798, 92925, 92917, 21791, 21799, 93139, 93115, 21994, 93140, 93142, 93118, 21996, 
93143, 93141, 93116, 21980, 21997
33927, 92925, 92917, 21791, 21799, 92926, 92918, 21792, 21800, 93142, 93118, 21996, 93143, 93145, 93121, 21998, 
93146, 93144, 93119, 21982, 21999
33928, 92926, 92918, 21792, 21800, 92927, 92919, 21793, 21801, 93145, 93121, 21998, 93146, 93148, 93124, 22000, 
93149, 93147, 93122, 21984, 22001
33929, 92927, 92919, 21793, 21801, 92928, 92920, 21794, 21802, 93148, 93124, 22000, 93149, 93151, 93127, 22002, 
93152, 93150, 93125, 21986, 22003
33930, 92928, 92920, 21794, 21802, 92929, 92921, 21795, 21803, 93151, 93127, 22002, 93152, 93154, 93130, 22004, 
93155, 93153, 93128, 21988, 22005
33931, 92929, 92921, 21795, 21803, 30997, 30996, 2834, 2835, 93154, 93130, 22004, 93155, 31022, 31019, 2857, 
31021, 93156, 93131, 21989, 22006
33932, 30909, 30908, 2970, 2971, 92930, 92922, 21796, 21804, 30934, 30933, 2993, 30935, 93158, 93134, 22007, 
93159, 93157, 93132, 21991, 22008
33933, 92930, 92922, 21796, 21804, 92931, 92923, 21797, 21805, 93158, 93134, 22007, 93159, 93161, 93137, 22009, 
93162, 93160, 93135, 21993, 22010
33934, 92931, 92923, 21797, 21805, 92932, 92924, 21798, 21806, 93161, 93137, 22009, 93162, 93164, 93140, 22011, 
93165, 93163, 93138, 21995, 22012
33935, 92932, 92924, 21798, 21806, 92933, 92925, 21799, 21807, 93164, 93140, 22011, 93165, 93167, 93143, 22013, 
93168, 93166, 93141, 21997, 22014
33936, 92933, 92925, 21799, 21807, 92934, 92926, 21800, 21808, 93167, 93143, 22013, 93168, 93170, 93146, 22015, 
93171, 93169, 93144, 21999, 22016
33937, 92934, 92926, 21800, 21808, 92935, 92927, 21801, 21809, 93170, 93146, 22015, 93171, 93173, 93149, 22017, 
93174, 93172, 93147, 22001, 22018
33938, 92935, 92927, 21801, 21809, 92936, 92928, 21802, 21810, 93173, 93149, 22017, 93174, 93176, 93152, 22019, 
93177, 93175, 93150, 22003, 22020
33939, 92936, 92928, 21802, 21810, 92937, 92929, 21803, 21811, 93176, 93152, 22019, 93177, 93179, 93155, 22021, 
93180, 93178, 93153, 22005, 22022
33940, 92937, 92929, 21803, 21811, 30998, 30997, 2835, 2836, 93179, 93155, 22021, 93180, 31024, 31021, 2858, 
31023, 93181, 93156, 22006, 22023
33941, 30910, 30909, 2971, 2972, 92938, 92930, 21804, 21812, 30936, 30935, 2994, 30937, 93183, 93159, 22024, 
93184, 93182, 93157, 22008, 22025
33942, 92938, 92930, 21804, 21812, 92939, 92931, 21805, 21813, 93183, 93159, 22024, 93184, 93186, 93162, 22026, 
93187, 93185, 93160, 22010, 22027
33943, 92939, 92931, 21805, 21813, 92940, 92932, 21806, 21814, 93186, 93162, 22026, 93187, 93189, 93165, 22028, 
93190, 93188, 93163, 22012, 22029
33944, 92940, 92932, 21806, 21814, 92941, 92933, 21807, 21815, 93189, 93165, 22028, 93190, 93192, 93168, 22030, 
93193, 93191, 93166, 22014, 22031
33945, 92941, 92933, 21807, 21815, 92942, 92934, 21808, 21816, 93192, 93168, 22030, 93193, 93195, 93171, 22032, 
93196, 93194, 93169, 22016, 22033
33946, 92942, 92934, 21808, 21816, 92943, 92935, 21809, 21817, 93195, 93171, 22032, 93196, 93198, 93174, 22034, 
93199, 93197, 93172, 22018, 22035
33947, 92943, 92935, 21809, 21817, 92944, 92936, 21810, 21818, 93198, 93174, 22034, 93199, 93201, 93177, 22036, 
93202, 93200, 93175, 22020, 22037
33948, 92944, 92936, 21810, 21818, 92945, 92937, 21811, 21819, 93201, 93177, 22036, 93202, 93204, 93180, 22038, 
93205, 93203, 93178, 22022, 22039
33949, 92945, 92937, 21811, 21819, 30999, 30998, 2836, 2837, 93204, 93180, 22038, 93205, 31026, 31023, 2859, 
31025, 93206, 93181, 22023, 22040
33950, 30911, 30910, 2972, 2973, 92946, 92938, 21812, 21820, 30938, 30937, 2995, 30939, 93208, 93184, 22041, 
93209, 93207, 93182, 22025, 22042
33951, 92946, 92938, 21812, 21820, 92947, 92939, 21813, 21821, 93208, 93184, 22041, 93209, 93211, 93187, 22043, 
93212, 93210, 93185, 22027, 22044
33952, 92947, 92939, 21813, 21821, 92948, 92940, 21814, 21822, 93211, 93187, 22043, 93212, 93214, 93190, 22045, 
93215, 93213, 93188, 22029, 22046
33953, 92948, 92940, 21814, 21822, 92949, 92941, 21815, 21823, 93214, 93190, 22045, 93215, 93217, 93193, 22047, 
93218, 93216, 93191, 22031, 22048
33954, 92949, 92941, 21815, 21823, 92950, 92942, 21816, 21824, 93217, 93193, 22047, 93218, 93220, 93196, 22049, 
93221, 93219, 93194, 22033, 22050
33955, 92950, 92942, 21816, 21824, 92951, 92943, 21817, 21825, 93220, 93196, 22049, 93221, 93223, 93199, 22051, 
93224, 93222, 93197, 22035, 22052
33956, 92951, 92943, 21817, 21825, 92952, 92944, 21818, 21826, 93223, 93199, 22051, 93224, 93226, 93202, 22053, 
93227, 93225, 93200, 22037, 22054
33957, 92952, 92944, 21818, 21826, 92953, 92945, 21819, 21827, 93226, 93202, 22053, 93227, 93229, 93205, 22055, 
93230, 93228, 93203, 22039, 22056
33958, 92953, 92945, 21819, 21827, 31000, 30999, 2837, 2838, 93229, 93205, 22055, 93230, 31028, 31025, 2860, 
31027, 93231, 93206, 22040, 22057
33959, 30912, 30911, 2973, 2974, 92954, 92946, 21820, 21828, 30940, 30939, 2996, 30941, 93233, 93209, 22058, 
93234, 93232, 93207, 22042, 22059
33960, 92954, 92946, 21820, 21828, 92955, 92947, 21821, 21829, 93233, 93209, 22058, 93234, 93236, 93212, 22060, 
93237, 93235, 93210, 22044, 22061
33961, 92955, 92947, 21821, 21829, 92956, 92948, 21822, 21830, 93236, 93212, 22060, 93237, 93239, 93215, 22062, 
93240, 93238, 93213, 22046, 22063
33962, 92956, 92948, 21822, 21830, 92957, 92949, 21823, 21831, 93239, 93215, 22062, 93240, 93242, 93218, 22064, 
93243, 93241, 93216, 22048, 22065
33963, 92957, 92949, 21823, 21831, 92958, 92950, 21824, 21832, 93242, 93218, 22064, 93243, 93245, 93221, 22066, 
93246, 93244, 93219, 22050, 22067
33964, 92958, 92950, 21824, 21832, 92959, 92951, 21825, 21833, 93245, 93221, 22066, 93246, 93248, 93224, 22068, 
93249, 93247, 93222, 22052, 22069
33965, 92959, 92951, 21825, 21833, 92960, 92952, 21826, 21834, 93248, 93224, 22068, 93249, 93251, 93227, 22070, 
93252, 93250, 93225, 22054, 22071
33966, 92960, 92952, 21826, 21834, 92961, 92953, 21827, 21835, 93251, 93227, 22070, 93252, 93254, 93230, 22072, 
93255, 93253, 93228, 22056, 22073
33967, 92961, 92953, 21827, 21835, 31001, 31000, 2838, 2839, 93254, 93230, 22072, 93255, 31030, 31027, 2861, 
31029, 93256, 93231, 22057, 22074
33968, 30913, 30912, 2974, 2975, 92962, 92954, 21828, 21836, 30942, 30941, 2997, 30943, 93258, 93234, 22075, 
93259, 93257, 93232, 22059, 22076
33969, 92962, 92954, 21828, 21836, 92963, 92955, 21829, 21837, 93258, 93234, 22075, 93259, 93261, 93237, 22077, 
93262, 93260, 93235, 22061, 22078
33970, 92963, 92955, 21829, 21837, 92964, 92956, 21830, 21838, 93261, 93237, 22077, 93262, 93264, 93240, 22079, 
93265, 93263, 93238, 22063, 22080
33971, 92964, 92956, 21830, 21838, 92965, 92957, 21831, 21839, 93264, 93240, 22079, 93265, 93267, 93243, 22081, 
93268, 93266, 93241, 22065, 22082
33972, 92965, 92957, 21831, 21839, 92966, 92958, 21832, 21840, 93267, 93243, 22081, 93268, 93270, 93246, 22083, 
93271, 93269, 93244, 22067, 22084
33973, 92966, 92958, 21832, 21840, 92967, 92959, 21833, 21841, 93270, 93246, 22083, 93271, 93273, 93249, 22085, 
93274, 93272, 93247, 22069, 22086
33974, 92967, 92959, 21833, 21841, 92968, 92960, 21834, 21842, 93273, 93249, 22085, 93274, 93276, 93252, 22087, 
93277, 93275, 93250, 22071, 22088
33975, 92968, 92960, 21834, 21842, 92969, 92961, 21835, 21843, 93276, 93252, 22087, 93277, 93279, 93255, 22089, 
93280, 93278, 93253, 22073, 22090
33976, 92969, 92961, 21835, 21843, 31002, 31001, 2839, 2840, 93279, 93255, 22089, 93280, 31032, 31029, 2862, 
31031, 93281, 93256, 22074, 22091
33977, 30914, 30913, 2975, 2976, 92970, 92962, 21836, 21844, 30944, 30943, 2998, 30945, 93283, 93259, 22092, 
93284, 93282, 93257, 22076, 22093
33978, 92970, 92962, 21836, 21844, 92971, 92963, 21837, 21845, 93283, 93259, 22092, 93284, 93286, 93262, 22094, 
93287, 93285, 93260, 22078, 22095
33979, 92971, 92963, 21837, 21845, 92972, 92964, 21838, 21846, 93286, 93262, 22094, 93287, 93289, 93265, 22096, 
93290, 93288, 93263, 22080, 22097
33980, 92972, 92964, 21838, 21846, 92973, 92965, 21839, 21847, 93289, 93265, 22096, 93290, 93292, 93268, 22098, 
93293, 93291, 93266, 22082, 22099
33981, 92973, 92965, 21839, 21847, 92974, 92966, 21840, 21848, 93292, 93268, 22098, 93293, 93295, 93271, 22100, 
93296, 93294, 93269, 22084, 22101
33982, 92974, 92966, 21840, 21848, 92975, 92967, 21841, 21849, 93295, 93271, 22100, 93296, 93298, 93274, 22102, 
93299, 93297, 93272, 22086, 22103
33983, 92975, 92967, 21841, 21849, 92976, 92968, 21842, 21850, 93298, 93274, 22102, 93299, 93301, 93277, 22104, 
93302, 93300, 93275, 22088, 22105
33984, 92976, 92968, 21842, 21850, 92977, 92969, 21843, 21851, 93301, 93277, 22104, 93302, 93304, 93280, 22106, 
93305, 93303, 93278, 22090, 22107
33985, 92977, 92969, 21843, 21851, 31003, 31002, 2840, 2841, 93304, 93280, 22106, 93305, 31034, 31031, 2863, 
31033, 93306, 93281, 22091, 22108
33986, 30915, 30914, 2976, 2977, 92978, 92970, 21844, 21852, 30946, 30945, 2999, 30947, 93308, 93284, 22109, 
93309, 93307, 93282, 22093, 22110
33987, 92978, 92970, 21844, 21852, 92979, 92971, 21845, 21853, 93308, 93284, 22109, 93309, 93311, 93287, 22111, 
93312, 93310, 93285, 22095, 22112
33988, 92979, 92971, 21845, 21853, 92980, 92972, 21846, 21854, 93311, 93287, 22111, 93312, 93314, 93290, 22113, 
93315, 93313, 93288, 22097, 22114
33989, 92980, 92972, 21846, 21854, 92981, 92973, 21847, 21855, 93314, 93290, 22113, 93315, 93317, 93293, 22115, 
93318, 93316, 93291, 22099, 22116
33990, 92981, 92973, 21847, 21855, 92982, 92974, 21848, 21856, 93317, 93293, 22115, 93318, 93320, 93296, 22117, 
93321, 93319, 93294, 22101, 22118
33991, 92982, 92974, 21848, 21856, 92983, 92975, 21849, 21857, 93320, 93296, 22117, 93321, 93323, 93299, 22119, 
93324, 93322, 93297, 22103, 22120
33992, 92983, 92975, 21849, 21857, 92984, 92976, 21850, 21858, 93323, 93299, 22119, 93324, 93326, 93302, 22121, 
93327, 93325, 93300, 22105, 22122
33993, 92984, 92976, 21850, 21858, 92985, 92977, 21851, 21859, 93326, 93302, 22121, 93327, 93329, 93305, 22123, 
93330, 93328, 93303, 22107, 22124
33994, 92985, 92977, 21851, 21859, 31004, 31003, 2841, 2842, 93329, 93305, 22123, 93330, 31036, 31033, 2864, 
31035, 93331, 93306, 22108, 22125
33995, 30916, 30915, 2977, 2978, 92986, 92978, 21852, 21860, 30948, 30947, 3000, 30949, 93333, 93309, 22126, 
93334, 93332, 93307, 22110, 22127
33996, 92986, 92978, 21852, 21860, 92987, 92979, 21853, 21861, 93333, 93309, 22126, 93334, 93336, 93312, 22128, 
93337, 93335, 93310, 22112, 22129
33997, 92987, 92979, 21853, 21861, 92988, 92980, 21854, 21862, 93336, 93312, 22128, 93337, 93339, 93315, 22130, 
93340, 93338, 93313, 22114, 22131
33998, 92988, 92980, 21854, 21862, 92989, 92981, 21855, 21863, 93339, 93315, 22130, 93340, 93342, 93318, 22132, 
93343, 93341, 93316, 22116, 22133
33999, 92989, 92981, 21855, 21863, 92990, 92982, 21856, 21864, 93342, 93318, 22132, 93343, 93345, 93321, 22134, 
93346, 93344, 93319, 22118, 22135
34000, 92990, 92982, 21856, 21864, 92991, 92983, 21857, 21865, 93345, 93321, 22134, 93346, 93348, 93324, 22136, 
93349, 93347, 93322, 22120, 22137
34001, 92991, 92983, 21857, 21865, 92992, 92984, 21858, 21866, 93348, 93324, 22136, 93349, 93351, 93327, 22138, 
93352, 93350, 93325, 22122, 22139
34002, 92992, 92984, 21858, 21866, 92993, 92985, 21859, 21867, 93351, 93327, 22138, 93352, 93354, 93330, 22140, 
93355, 93353, 93328, 22124, 22141
34003, 92993, 92985, 21859, 21867, 31005, 31004, 2842, 2843, 93354, 93330, 22140, 93355, 31038, 31035, 2865, 
31037, 93356, 93331, 22125, 22142
34004, 30917, 30916, 2978, 2979, 92994, 92986, 21860, 21868, 30950, 30949, 3001, 30951, 93358, 93334, 22143, 
93359, 93357, 93332, 22127, 22144
34005, 92994, 92986, 21860, 21868, 92995, 92987, 21861, 21869, 93358, 93334, 22143, 93359, 93361, 93337, 22145, 
93362, 93360, 93335, 22129, 22146
34006, 92995, 92987, 21861, 21869, 92996, 92988, 21862, 21870, 93361, 93337, 22145, 93362, 93364, 93340, 22147, 
93365, 93363, 93338, 22131, 22148
34007, 92996, 92988, 21862, 21870, 92997, 92989, 21863, 21871, 93364, 93340, 22147, 93365, 93367, 93343, 22149, 
93368, 93366, 93341, 22133, 22150
34008, 92997, 92989, 21863, 21871, 92998, 92990, 21864, 21872, 93367, 93343, 22149, 93368, 93370, 93346, 22151, 
93371, 93369, 93344, 22135, 22152
34009, 92998, 92990, 21864, 21872, 92999, 92991, 21865, 21873, 93370, 93346, 22151, 93371, 93373, 93349, 22153, 
93374, 93372, 93347, 22137, 22154
34010, 92999, 92991, 21865, 21873, 93000, 92992, 21866, 21874, 93373, 93349, 22153, 93374, 93376, 93352, 22155, 
93377, 93375, 93350, 22139, 22156
34011, 93000, 92992, 21866, 21874, 93001, 92993, 21867, 21875, 93376, 93352, 22155, 93377, 93379, 93355, 22157, 
93380, 93378, 93353, 22141, 22158
34012, 93001, 92993, 21867, 21875, 31006, 31005, 2843, 2844, 93379, 93355, 22157, 93380, 31040, 31037, 2866, 
31039, 93381, 93356, 22142, 22159
34013, 30918, 30917, 2979, 2980, 93002, 92994, 21868, 21876, 30952, 30951, 3002, 30953, 93383, 93359, 22160, 
93384, 93382, 93357, 22144, 22161
34014, 93002, 92994, 21868, 21876, 93003, 92995, 21869, 21877, 93383, 93359, 22160, 93384, 93386, 93362, 22162, 
93387, 93385, 93360, 22146, 22163
34015, 93003, 92995, 21869, 21877, 93004, 92996, 21870, 21878, 93386, 93362, 22162, 93387, 93389, 93365, 22164, 
93390, 93388, 93363, 22148, 22165
34016, 93004, 92996, 21870, 21878, 93005, 92997, 21871, 21879, 93389, 93365, 22164, 93390, 93392, 93368, 22166, 
93393, 93391, 93366, 22150, 22167
34017, 93005, 92997, 21871, 21879, 93006, 92998, 21872, 21880, 93392, 93368, 22166, 93393, 93395, 93371, 22168, 
93396, 93394, 93369, 22152, 22169
34018, 93006, 92998, 21872, 21880, 93007, 92999, 21873, 21881, 93395, 93371, 22168, 93396, 93398, 93374, 22170, 
93399, 93397, 93372, 22154, 22171
34019, 93007, 92999, 21873, 21881, 93008, 93000, 21874, 21882, 93398, 93374, 22170, 93399, 93401, 93377, 22172, 
93402, 93400, 93375, 22156, 22173
34020, 93008, 93000, 21874, 21882, 93009, 93001, 21875, 21883, 93401, 93377, 22172, 93402, 93404, 93380, 22174, 
93405, 93403, 93378, 22158, 22175
34021, 93009, 93001, 21875, 21883, 31007, 31006, 2844, 2845, 93404, 93380, 22174, 93405, 31042, 31039, 2867, 
31041, 93406, 93381, 22159, 22176
34022, 30919, 30918, 2980, 2981, 93010, 93002, 21876, 21884, 30954, 30953, 3003, 30955, 93408, 93384, 22177, 
93409, 93407, 93382, 22161, 22178
34023, 93010, 93002, 21876, 21884, 93011, 93003, 21877, 21885, 93408, 93384, 22177, 93409, 93411, 93387, 22179, 
93412, 93410, 93385, 22163, 22180
34024, 93011, 93003, 21877, 21885, 93012, 93004, 21878, 21886, 93411, 93387, 22179, 93412, 93414, 93390, 22181, 
93415, 93413, 93388, 22165, 22182
34025, 93012, 93004, 21878, 21886, 93013, 93005, 21879, 21887, 93414, 93390, 22181, 93415, 93417, 93393, 22183, 
93418, 93416, 93391, 22167, 22184
34026, 93013, 93005, 21879, 21887, 93014, 93006, 21880, 21888, 93417, 93393, 22183, 93418, 93420, 93396, 22185, 
93421, 93419, 93394, 22169, 22186
34027, 93014, 93006, 21880, 21888, 93015, 93007, 21881, 21889, 93420, 93396, 22185, 93421, 93423, 93399, 22187, 
93424, 93422, 93397, 22171, 22188
34028, 93015, 93007, 21881, 21889, 93016, 93008, 21882, 21890, 93423, 93399, 22187, 93424, 93426, 93402, 22189, 
93427, 93425, 93400, 22173, 22190
34029, 93016, 93008, 21882, 21890, 93017, 93009, 21883, 21891, 93426, 93402, 22189, 93427, 93429, 93405, 22191, 
93430, 93428, 93403, 22175, 22192
34030, 93017, 93009, 21883, 21891, 31008, 31007, 2845, 2846, 93429, 93405, 22191, 93430, 31044, 31041, 2868, 
31043, 93431, 93406, 22176, 22193
34031, 30920, 30919, 2981, 2982, 93018, 93010, 21884, 21892, 30956, 30955, 3004, 30957, 93433, 93409, 22194, 
93434, 93432, 93407, 22178, 22195
34032, 93018, 93010, 21884, 21892, 93019, 93011, 21885, 21893, 93433, 93409, 22194, 93434, 93436, 93412, 22196, 
93437, 93435, 93410, 22180, 22197
34033, 93019, 93011, 21885, 21893, 93020, 93012, 21886, 21894, 93436, 93412, 22196, 93437, 93439, 93415, 22198, 
93440, 93438, 93413, 22182, 22199
34034, 93020, 93012, 21886, 21894, 93021, 93013, 21887, 21895, 93439, 93415, 22198, 93440, 93442, 93418, 22200, 
93443, 93441, 93416, 22184, 22201
34035, 93021, 93013, 21887, 21895, 93022, 93014, 21888, 21896, 93442, 93418, 22200, 93443, 93445, 93421, 22202, 
93446, 93444, 93419, 22186, 22203
34036, 93022, 93014, 21888, 21896, 93023, 93015, 21889, 21897, 93445, 93421, 22202, 93446, 93448, 93424, 22204, 
93449, 93447, 93422, 22188, 22205
34037, 93023, 93015, 21889, 21897, 93024, 93016, 21890, 21898, 93448, 93424, 22204, 93449, 93451, 93427, 22206, 
93452, 93450, 93425, 22190, 22207
34038, 93024, 93016, 21890, 21898, 93025, 93017, 21891, 21899, 93451, 93427, 22206, 93452, 93454, 93430, 22208, 
93455, 93453, 93428, 22192, 22209
34039, 93025, 93017, 21891, 21899, 31009, 31008, 2846, 2847, 93454, 93430, 22208, 93455, 31046, 31043, 2869, 
31045, 93456, 93431, 22193, 22210
34040, 30921, 30920, 2982, 2983, 93026, 93018, 21892, 21900, 30958, 30957, 3005, 30959, 93458, 93434, 22211, 
93459, 93457, 93432, 22195, 22212
34041, 93026, 93018, 21892, 21900, 93027, 93019, 21893, 21901, 93458, 93434, 22211, 93459, 93461, 93437, 22213, 
93462, 93460, 93435, 22197, 22214
34042, 93027, 93019, 21893, 21901, 93028, 93020, 21894, 21902, 93461, 93437, 22213, 93462, 93464, 93440, 22215, 
93465, 93463, 93438, 22199, 22216
34043, 93028, 93020, 21894, 21902, 93029, 93021, 21895, 21903, 93464, 93440, 22215, 93465, 93467, 93443, 22217, 
93468, 93466, 93441, 22201, 22218
34044, 93029, 93021, 21895, 21903, 93030, 93022, 21896, 21904, 93467, 93443, 22217, 93468, 93470, 93446, 22219, 
93471, 93469, 93444, 22203, 22220
34045, 93030, 93022, 21896, 21904, 93031, 93023, 21897, 21905, 93470, 93446, 22219, 93471, 93473, 93449, 22221, 
93474, 93472, 93447, 22205, 22222
34046, 93031, 93023, 21897, 21905, 93032, 93024, 21898, 21906, 93473, 93449, 22221, 93474, 93476, 93452, 22223, 
93477, 93475, 93450, 22207, 22224
34047, 93032, 93024, 21898, 21906, 93033, 93025, 21899, 21907, 93476, 93452, 22223, 93477, 93479, 93455, 22225, 
93480, 93478, 93453, 22209, 22226
34048, 93033, 93025, 21899, 21907, 31010, 31009, 2847, 2848, 93479, 93455, 22225, 93480, 31048, 31045, 2870, 
31047, 93481, 93456, 22210, 22227
34049, 30922, 30921, 2983, 2984, 93034, 93026, 21900, 21908, 30960, 30959, 3006, 30961, 93483, 93459, 22228, 
93484, 93482, 93457, 22212, 22229
34050, 93034, 93026, 21900, 21908, 93035, 93027, 21901, 21909, 93483, 93459, 22228, 93484, 93486, 93462, 22230, 
93487, 93485, 93460, 22214, 22231
34051, 93035, 93027, 21901, 21909, 93036, 93028, 21902, 21910, 93486, 93462, 22230, 93487, 93489, 93465, 22232, 
93490, 93488, 93463, 22216, 22233
34052, 93036, 93028, 21902, 21910, 93037, 93029, 21903, 21911, 93489, 93465, 22232, 93490, 93492, 93468, 22234, 
93493, 93491, 93466, 22218, 22235
34053, 93037, 93029, 21903, 21911, 93038, 93030, 21904, 21912, 93492, 93468, 22234, 93493, 93495, 93471, 22236, 
93496, 93494, 93469, 22220, 22237
34054, 93038, 93030, 21904, 21912, 93039, 93031, 21905, 21913, 93495, 93471, 22236, 93496, 93498, 93474, 22238, 
93499, 93497, 93472, 22222, 22239
34055, 93039, 93031, 21905, 21913, 93040, 93032, 21906, 21914, 93498, 93474, 22238, 93499, 93501, 93477, 22240, 
93502, 93500, 93475, 22224, 22241
34056, 93040, 93032, 21906, 21914, 93041, 93033, 21907, 21915, 93501, 93477, 22240, 93502, 93504, 93480, 22242, 
93505, 93503, 93478, 22226, 22243
34057, 93041, 93033, 21907, 21915, 31011, 31010, 2848, 2849, 93504, 93480, 22242, 93505, 31050, 31047, 2871, 
31049, 93506, 93481, 22227, 22244
34058, 30923, 30922, 2984, 2985, 93042, 93034, 21908, 21916, 30962, 30961, 3007, 30963, 93508, 93484, 22245, 
93509, 93507, 93482, 22229, 22246
34059, 93042, 93034, 21908, 21916, 93043, 93035, 21909, 21917, 93508, 93484, 22245, 93509, 93511, 93487, 22247, 
93512, 93510, 93485, 22231, 22248
34060, 93043, 93035, 21909, 21917, 93044, 93036, 21910, 21918, 93511, 93487, 22247, 93512, 93514, 93490, 22249, 
93515, 93513, 93488, 22233, 22250
34061, 93044, 93036, 21910, 21918, 93045, 93037, 21911, 21919, 93514, 93490, 22249, 93515, 93517, 93493, 22251, 
93518, 93516, 93491, 22235, 22252
34062, 93045, 93037, 21911, 21919, 93046, 93038, 21912, 21920, 93517, 93493, 22251, 93518, 93520, 93496, 22253, 
93521, 93519, 93494, 22237, 22254
34063, 93046, 93038, 21912, 21920, 93047, 93039, 21913, 21921, 93520, 93496, 22253, 93521, 93523, 93499, 22255, 
93524, 93522, 93497, 22239, 22256
34064, 93047, 93039, 21913, 21921, 93048, 93040, 21914, 21922, 93523, 93499, 22255, 93524, 93526, 93502, 22257, 
93527, 93525, 93500, 22241, 22258
34065, 93048, 93040, 21914, 21922, 93049, 93041, 21915, 21923, 93526, 93502, 22257, 93527, 93529, 93505, 22259, 
93530, 93528, 93503, 22243, 22260
34066, 93049, 93041, 21915, 21923, 31012, 31011, 2849, 2850, 93529, 93505, 22259, 93530, 31052, 31049, 2872, 
31051, 93531, 93506, 22244, 22261
34067, 30924, 30923, 2985, 2986, 93050, 93042, 21916, 21924, 30964, 30963, 3008, 30965, 93533, 93509, 22262, 
93534, 93532, 93507, 22246, 22263
34068, 93050, 93042, 21916, 21924, 93051, 93043, 21917, 21925, 93533, 93509, 22262, 93534, 93536, 93512, 22264, 
93537, 93535, 93510, 22248, 22265
34069, 93051, 93043, 21917, 21925, 93052, 93044, 21918, 21926, 93536, 93512, 22264, 93537, 93539, 93515, 22266, 
93540, 93538, 93513, 22250, 22267
34070, 93052, 93044, 21918, 21926, 93053, 93045, 21919, 21927, 93539, 93515, 22266, 93540, 93542, 93518, 22268, 
93543, 93541, 93516, 22252, 22269
34071, 93053, 93045, 21919, 21927, 93054, 93046, 21920, 21928, 93542, 93518, 22268, 93543, 93545, 93521, 22270, 
93546, 93544, 93519, 22254, 22271
34072, 93054, 93046, 21920, 21928, 93055, 93047, 21921, 21929, 93545, 93521, 22270, 93546, 93548, 93524, 22272, 
93549, 93547, 93522, 22256, 22273
34073, 93055, 93047, 21921, 21929, 93056, 93048, 21922, 21930, 93548, 93524, 22272, 93549, 93551, 93527, 22274, 
93552, 93550, 93525, 22258, 22275
34074, 93056, 93048, 21922, 21930, 93057, 93049, 21923, 21931, 93551, 93527, 22274, 93552, 93554, 93530, 22276, 
93555, 93553, 93528, 22260, 22277
34075, 93057, 93049, 21923, 21931, 31013, 31012, 2850, 2851, 93554, 93530, 22276, 93555, 31054, 31051, 2873, 
31053, 93556, 93531, 22261, 22278
34076, 30925, 30924, 2986, 2987, 93058, 93050, 21924, 21932, 30966, 30965, 3009, 30967, 93558, 93534, 22279, 
93559, 93557, 93532, 22263, 22280
34077, 93058, 93050, 21924, 21932, 93059, 93051, 21925, 21933, 93558, 93534, 22279, 93559, 93561, 93537, 22281, 
93562, 93560, 93535, 22265, 22282
34078, 93059, 93051, 21925, 21933, 93060, 93052, 21926, 21934, 93561, 93537, 22281, 93562, 93564, 93540, 22283, 
93565, 93563, 93538, 22267, 22284
34079, 93060, 93052, 21926, 21934, 93061, 93053, 21927, 21935, 93564, 93540, 22283, 93565, 93567, 93543, 22285, 
93568, 93566, 93541, 22269, 22286
34080, 93061, 93053, 21927, 21935, 93062, 93054, 21928, 21936, 93567, 93543, 22285, 93568, 93570, 93546, 22287, 
93571, 93569, 93544, 22271, 22288
34081, 93062, 93054, 21928, 21936, 93063, 93055, 21929, 21937, 93570, 93546, 22287, 93571, 93573, 93549, 22289, 
93574, 93572, 93547, 22273, 22290
34082, 93063, 93055, 21929, 21937, 93064, 93056, 21930, 21938, 93573, 93549, 22289, 93574, 93576, 93552, 22291, 
93577, 93575, 93550, 22275, 22292
34083, 93064, 93056, 21930, 21938, 93065, 93057, 21931, 21939, 93576, 93552, 22291, 93577, 93579, 93555, 22293, 
93580, 93578, 93553, 22277, 22294
34084, 93065, 93057, 21931, 21939, 31014, 31013, 2851, 2852, 93579, 93555, 22293, 93580, 31056, 31053, 2874, 
31055, 93581, 93556, 22278, 22295
34085, 30926, 30925, 2987, 2988, 93066, 93058, 21932, 21940, 30968, 30967, 3010, 30969, 93583, 93559, 22296, 
93584, 93582, 93557, 22280, 22297
34086, 93066, 93058, 21932, 21940, 93067, 93059, 21933, 21941, 93583, 93559, 22296, 93584, 93586, 93562, 22298, 
93587, 93585, 93560, 22282, 22299
34087, 93067, 93059, 21933, 21941, 93068, 93060, 21934, 21942, 93586, 93562, 22298, 93587, 93589, 93565, 22300, 
93590, 93588, 93563, 22284, 22301
34088, 93068, 93060, 21934, 21942, 93069, 93061, 21935, 21943, 93589, 93565, 22300, 93590, 93592, 93568, 22302, 
93593, 93591, 93566, 22286, 22303
34089, 93069, 93061, 21935, 21943, 93070, 93062, 21936, 21944, 93592, 93568, 22302, 93593, 93595, 93571, 22304, 
93596, 93594, 93569, 22288, 22305
34090, 93070, 93062, 21936, 21944, 93071, 93063, 21937, 21945, 93595, 93571, 22304, 93596, 93598, 93574, 22306, 
93599, 93597, 93572, 22290, 22307
34091, 93071, 93063, 21937, 21945, 93072, 93064, 21938, 21946, 93598, 93574, 22306, 93599, 93601, 93577, 22308, 
93602, 93600, 93575, 22292, 22309
34092, 93072, 93064, 21938, 21946, 93073, 93065, 21939, 21947, 93601, 93577, 22308, 93602, 93604, 93580, 22310, 
93605, 93603, 93578, 22294, 22311
34093, 93073, 93065, 21939, 21947, 31015, 31014, 2852, 2853, 93604, 93580, 22310, 93605, 31058, 31055, 2875, 
31057, 93606, 93581, 22295, 22312
34094, 30927, 30926, 2988, 2989, 93074, 93066, 21940, 21948, 30970, 30969, 3011, 30971, 93608, 93584, 22313, 
93609, 93607, 93582, 22297, 22314
34095, 93074, 93066, 21940, 21948, 93075, 93067, 21941, 21949, 93608, 93584, 22313, 93609, 93611, 93587, 22315, 
93612, 93610, 93585, 22299, 22316
34096, 93075, 93067, 21941, 21949, 93076, 93068, 21942, 21950, 93611, 93587, 22315, 93612, 93614, 93590, 22317, 
93615, 93613, 93588, 22301, 22318
34097, 93076, 93068, 21942, 21950, 93077, 93069, 21943, 21951, 93614, 93590, 22317, 93615, 93617, 93593, 22319, 
93618, 93616, 93591, 22303, 22320
34098, 93077, 93069, 21943, 21951, 93078, 93070, 21944, 21952, 93617, 93593, 22319, 93618, 93620, 93596, 22321, 
93621, 93619, 93594, 22305, 22322
34099, 93078, 93070, 21944, 21952, 93079, 93071, 21945, 21953, 93620, 93596, 22321, 93621, 93623, 93599, 22323, 
93624, 93622, 93597, 22307, 22324
34100, 93079, 93071, 21945, 21953, 93080, 93072, 21946, 21954, 93623, 93599, 22323, 93624, 93626, 93602, 22325, 
93627, 93625, 93600, 22309, 22326
34101, 93080, 93072, 21946, 21954, 93081, 93073, 21947, 21955, 93626, 93602, 22325, 93627, 93629, 93605, 22327, 
93630, 93628, 93603, 22311, 22328
34102, 93081, 93073, 21947, 21955, 31016, 31015, 2853, 2854, 93629, 93605, 22327, 93630, 31060, 31057, 2876, 
31059, 93631, 93606, 22312, 22329
34103, 3604, 30927, 2989, 91, 31117, 93074, 21948, 3020, 30972, 30971, 3012, 3605, 93632, 93609, 22330, 
31126, 31125, 93607, 22314, 3029
34104, 31117, 93074, 21948, 3020, 31118, 93075, 21949, 3019, 93632, 93609, 22330, 31126, 93633, 93612, 22331, 
31128, 31127, 93610, 22316, 3028
34105, 31118, 93075, 21949, 3019, 31119, 93076, 21950, 3018, 93633, 93612, 22331, 31128, 93634, 93615, 22332, 
31130, 31129, 93613, 22318, 3027
34106, 31119, 93076, 21950, 3018, 31120, 93077, 21951, 3017, 93634, 93615, 22332, 31130, 93635, 93618, 22333, 
31132, 31131, 93616, 22320, 3026
34107, 31120, 93077, 21951, 3017, 31121, 93078, 21952, 3016, 93635, 93618, 22333, 31132, 93636, 93621, 22334, 
31134, 31133, 93619, 22322, 3025
34108, 31121, 93078, 21952, 3016, 31122, 93079, 21953, 3015, 93636, 93621, 22334, 31134, 93637, 93624, 22335, 
31136, 31135, 93622, 22324, 3024
34109, 31122, 93079, 21953, 3015, 31123, 93080, 21954, 3014, 93637, 93624, 22335, 31136, 93638, 93627, 22336, 
31138, 31137, 93625, 22326, 3023
34110, 31123, 93080, 21954, 3014, 31124, 93081, 21955, 3013, 93638, 93627, 22336, 31138, 93639, 93630, 22337, 
31140, 31139, 93628, 22328, 3022
34111, 31124, 93081, 21955, 3013, 3655, 31016, 2854, 89, 93639, 93630, 22337, 31140, 31061, 31059, 2877, 
3656, 31141, 93631, 22329, 3021
34112, 3607, 101, 3601, 30906, 31150, 3710, 31084, 92906, 3629, 3603, 30928, 30973, 31326, 31109, 93083, 
93640, 31327, 3719, 31093, 93082
34113, 31150, 3710, 31084, 92906, 31151, 3709, 31085, 92907, 31326, 31109, 93083, 93640, 31328, 31110, 93086, 
93641, 31329, 3718, 31095, 93085
34114, 31151, 3709, 31085, 92907, 31152, 3708, 31086, 92908, 31328, 31110, 93086, 93641, 31330, 31111, 93089, 
93642, 31331, 3717, 31097, 93088
34115, 31152, 3708, 31086, 92908, 31153, 3707, 31087, 92909, 31330, 31111, 93089, 93642, 31332, 31112, 93092, 
93643, 31333, 3716, 31099, 93091
34116, 31153, 3707, 31087, 92909, 31154, 3706, 31088, 92910, 31332, 31112, 93092, 93643, 31334, 31113, 93095, 
93644, 31335, 3715, 31101, 93094
34117, 31154, 3706, 31088, 92910, 31155, 3705, 31089, 92911, 31334, 31113, 93095, 93644, 31336, 31114, 93098, 
93645, 31337, 3714, 31103, 93097
34118, 31155, 3705, 31089, 92911, 31156, 3704, 31090, 92912, 31336, 31114, 93098, 93645, 31338, 31115, 93101, 
93646, 31339, 3713, 31105, 93100
34119, 31156, 3704, 31090, 92912, 31157, 3703, 31091, 92913, 31338, 31115, 93101, 93646, 31340, 31116, 93104, 
93647, 31341, 3712, 31107, 93103
34120, 31157, 3703, 31091, 92913, 3658, 103, 3652, 30995, 31340, 31116, 93104, 93647, 3680, 3654, 31018, 
31062, 31342, 3711, 31108, 93106
34121, 3608, 3607, 30906, 30907, 31158, 31150, 92906, 92914, 3630, 30973, 30930, 30974, 31343, 93640, 93108, 
93648, 31344, 31327, 93082, 93107
34122, 31158, 31150, 92906, 92914, 31159, 31151, 92907, 92915, 31343, 93640, 93108, 93648, 31345, 93641, 93111, 
93649, 31346, 31329, 93085, 93110
34123, 31159, 31151, 92907, 92915, 31160, 31152, 92908, 92916, 31345, 93641, 93111, 93649, 31347, 93642, 93114, 
93650, 31348, 31331, 93088, 93113
34124, 31160, 31152, 92908, 92916, 31161, 31153, 92909, 92917, 31347, 93642, 93114, 93650, 31349, 93643, 93117, 
93651, 31350, 31333, 93091, 93116
34125, 31161, 31153, 92909, 92917, 31162, 31154, 92910, 92918, 31349, 93643, 93117, 93651, 31351, 93644, 93120, 
93652, 31352, 31335, 93094, 93119
34126, 31162, 31154, 92910, 92918, 31163, 31155, 92911, 92919, 31351, 93644, 93120, 93652, 31353, 93645, 93123, 
93653, 31354, 31337, 93097, 93122
34127, 31163, 31155, 92911, 92919, 31164, 31156, 92912, 92920, 31353, 93645, 93123, 93653, 31355, 93646, 93126, 
93654, 31356, 31339, 93100, 93125
34128, 31164, 31156, 92912, 92920, 31165, 31157, 92913, 92921, 31355, 93646, 93126, 93654, 31357, 93647, 93129, 
93655, 31358, 31341, 93103, 93128
34129, 31165, 31157, 92913, 92921, 3659, 3658, 30995, 30996, 31357, 93647, 93129, 93655, 3681, 31062, 31020, 
31063, 31359, 31342, 93106, 93131
34130, 3609, 3608, 30907, 30908, 31166, 31158, 92914, 92922, 3631, 30974, 30932, 30975, 31360, 93648, 93133, 
93656, 31361, 31344, 93107, 93132
34131, 31166, 31158, 92914, 92922, 31167, 31159, 92915, 92923, 31360, 93648, 93133, 93656, 31362, 93649, 93136, 
93657, 31363, 31346, 93110, 93135
34132, 31167, 31159, 92915, 92923, 31168, 31160, 92916, 92924, 31362, 93649, 93136, 93657, 31364, 93650, 93139, 
93658, 31365, 31348, 93113, 93138
34133, 31168, 31160, 92916, 92924, 31169, 31161, 92917, 92925, 31364, 93650, 93139, 93658, 31366, 93651, 93142, 
93659, 31367, 31350, 93116, 93141
34134, 31169, 31161, 92917, 92925, 31170, 31162, 92918, 92926, 31366, 93651, 93142, 93659, 31368, 93652, 93145, 
93660, 31369, 31352, 93119, 93144
34135, 31170, 31162, 92918, 92926, 31171, 31163, 92919, 92927, 31368, 93652, 93145, 93660, 31370, 93653, 93148, 
93661, 31371, 31354, 93122, 93147
34136, 31171, 31163, 92919, 92927, 31172, 31164, 92920, 92928, 31370, 93653, 93148, 93661, 31372, 93654, 93151, 
93662, 31373, 31356, 93125, 93150
34137, 31172, 31164, 92920, 92928, 31173, 31165, 92921, 92929, 31372, 93654, 93151, 93662, 31374, 93655, 93154, 
93663, 31375, 31358, 93128, 93153
34138, 31173, 31165, 92921, 92929, 3660, 3659, 30996, 30997, 31374, 93655, 93154, 93663, 3682, 31063, 31022, 
31064, 31376, 31359, 93131, 93156
34139, 3610, 3609, 30908, 30909, 31174, 31166, 92922, 92930, 3632, 30975, 30934, 30976, 31377, 93656, 93158, 
93664, 31378, 31361, 93132, 93157
34140, 31174, 31166, 92922, 92930, 31175, 31167, 92923, 92931, 31377, 93656, 93158, 93664, 31379, 93657, 93161, 
93665, 31380, 31363, 93135, 93160
34141, 31175, 31167, 92923, 92931, 31176, 31168, 92924, 92932, 31379, 93657, 93161, 93665, 31381, 93658, 93164, 
93666, 31382, 31365, 93138, 93163
34142, 31176, 31168, 92924, 92932, 31177, 31169, 92925, 92933, 31381, 93658, 93164, 93666, 31383, 93659, 93167, 
93667, 31384, 31367, 93141, 93166
34143, 31177, 31169, 92925, 92933, 31178, 31170, 92926, 92934, 31383, 93659, 93167, 93667, 31385, 93660, 93170, 
93668, 31386, 31369, 93144, 93169
34144, 31178, 31170, 92926, 92934, 31179, 31171, 92927, 92935, 31385, 93660, 93170, 93668, 31387, 93661, 93173, 
93669, 31388, 31371, 93147, 93172
34145, 31179, 31171, 92927, 92935, 31180, 31172, 92928, 92936, 31387, 93661, 93173, 93669, 31389, 93662, 93176, 
93670, 31390, 31373, 93150, 93175
34146, 31180, 31172, 92928, 92936, 31181, 31173, 92929, 92937, 31389, 93662, 93176, 93670, 31391, 93663, 93179, 
93671, 31392, 31375, 93153, 93178
34147, 31181, 31173, 92929, 92937, 3661, 3660, 30997, 30998, 31391, 93663, 93179, 93671, 3683, 31064, 31024, 
31065, 31393, 31376, 93156, 93181
34148, 3611, 3610, 30909, 30910, 31182, 31174, 92930, 92938, 3633, 30976, 30936, 30977, 31394, 93664, 93183, 
93672, 31395, 31378, 93157, 93182
34149, 31182, 31174, 92930, 92938, 31183, 31175, 92931, 92939, 31394, 93664, 93183, 93672, 31396, 93665, 93186, 
93673, 31397, 31380, 93160, 93185
34150, 31183, 31175, 92931, 92939, 31184, 31176, 92932, 92940, 31396, 93665, 93186, 93673, 31398, 93666, 93189, 
93674, 31399, 31382, 93163, 93188
34151, 31184, 31176, 92932, 92940, 31185, 31177, 92933, 92941, 31398, 93666, 93189, 93674, 31400, 93667, 93192, 
93675, 31401, 31384, 93166, 93191
34152, 31185, 31177, 92933, 92941, 31186, 31178, 92934, 92942, 31400, 93667, 93192, 93675, 31402, 93668, 93195, 
93676, 31403, 31386, 93169, 93194
34153, 31186, 31178, 92934, 92942, 31187, 31179, 92935, 92943, 31402, 93668, 93195, 93676, 31404, 93669, 93198, 
93677, 31405, 31388, 93172, 93197
34154, 31187, 31179, 92935, 92943, 31188, 31180, 92936, 92944, 31404, 93669, 93198, 93677, 31406, 93670, 93201, 
93678, 31407, 31390, 93175, 93200
34155, 31188, 31180, 92936, 92944, 31189, 31181, 92937, 92945, 31406, 93670, 93201, 93678, 31408, 93671, 93204, 
93679, 31409, 31392, 93178, 93203
34156, 31189, 31181, 92937, 92945, 3662, 3661, 30998, 30999, 31408, 93671, 93204, 93679, 3684, 31065, 31026, 
31066, 31410, 31393, 93181, 93206
34157, 3612, 3611, 30910, 30911, 31190, 31182, 92938, 92946, 3634, 30977, 30938, 30978, 31411, 93672, 93208, 
93680, 31412, 31395, 93182, 93207
34158, 31190, 31182, 92938, 92946, 31191, 31183, 92939, 92947, 31411, 93672, 93208, 93680, 31413, 93673, 93211, 
93681, 31414, 31397, 93185, 93210
34159, 31191, 31183, 92939, 92947, 31192, 31184, 92940, 92948, 31413, 93673, 93211, 93681, 31415, 93674, 93214, 
93682, 31416, 31399, 93188, 93213
34160, 31192, 31184, 92940, 92948, 31193, 31185, 92941, 92949, 31415, 93674, 93214, 93682, 31417, 93675, 93217, 
93683, 31418, 31401, 93191, 93216
34161, 31193, 31185, 92941, 92949, 31194, 31186, 92942, 92950, 31417, 93675, 93217, 93683, 31419, 93676, 93220, 
93684, 31420, 31403, 93194, 93219
34162, 31194, 31186, 92942, 92950, 31195, 31187, 92943, 92951, 31419, 93676, 93220, 93684, 31421, 93677, 93223, 
93685, 31422, 31405, 93197, 93222
34163, 31195, 31187, 92943, 92951, 31196, 31188, 92944, 92952, 31421, 93677, 93223, 93685, 31423, 93678, 93226, 
93686, 31424, 31407, 93200, 93225
34164, 31196, 31188, 92944, 92952, 31197, 31189, 92945, 92953, 31423, 93678, 93226, 93686, 31425, 93679, 93229, 
93687, 31426, 31409, 93203, 93228
34165, 31197, 31189, 92945, 92953, 3663, 3662, 30999, 31000, 31425, 93679, 93229, 93687, 3685, 31066, 31028, 
31067, 31427, 31410, 93206, 93231
34166, 3613, 3612, 30911, 30912, 31198, 31190, 92946, 92954, 3635, 30978, 30940, 30979, 31428, 93680, 93233, 
93688, 31429, 31412, 93207, 93232
34167, 31198, 31190, 92946, 92954, 31199, 31191, 92947, 92955, 31428, 93680, 93233, 93688, 31430, 93681, 93236, 
93689, 31431, 31414, 93210, 93235
34168, 31199, 31191, 92947, 92955, 31200, 31192, 92948, 92956, 31430, 93681, 93236, 93689, 31432, 93682, 93239, 
93690, 31433, 31416, 93213, 93238
34169, 31200, 31192, 92948, 92956, 31201, 31193, 92949, 92957, 31432, 93682, 93239, 93690, 31434, 93683, 93242, 
93691, 31435, 31418, 93216, 93241
34170, 31201, 31193, 92949, 92957, 31202, 31194, 92950, 92958, 31434, 93683, 93242, 93691, 31436, 93684, 93245, 
93692, 31437, 31420, 93219, 93244
34171, 31202, 31194, 92950, 92958, 31203, 31195, 92951, 92959, 31436, 93684, 93245, 93692, 31438, 93685, 93248, 
93693, 31439, 31422, 93222, 93247
34172, 31203, 31195, 92951, 92959, 31204, 31196, 92952, 92960, 31438, 93685, 93248, 93693, 31440, 93686, 93251, 
93694, 31441, 31424, 93225, 93250
34173, 31204, 31196, 92952, 92960, 31205, 31197, 92953, 92961, 31440, 93686, 93251, 93694, 31442, 93687, 93254, 
93695, 31443, 31426, 93228, 93253
34174, 31205, 31197, 92953, 92961, 3664, 3663, 31000, 31001, 31442, 93687, 93254, 93695, 3686, 31067, 31030, 
31068, 31444, 31427, 93231, 93256
34175, 3614, 3613, 30912, 30913, 31206, 31198, 92954, 92962, 3636, 30979, 30942, 30980, 31445, 93688, 93258, 
93696, 31446, 31429, 93232, 93257
34176, 31206, 31198, 92954, 92962, 31207, 31199, 92955, 92963, 31445, 93688, 93258, 93696, 31447, 93689, 93261, 
93697, 31448, 31431, 93235, 93260
34177, 31207, 31199, 92955, 92963, 31208, 31200, 92956, 92964, 31447, 93689, 93261, 93697, 31449, 93690, 93264, 
93698, 31450, 31433, 93238, 93263
34178, 31208, 31200, 92956, 92964, 31209, 31201, 92957, 92965, 31449, 93690, 93264, 93698, 31451, 93691, 93267, 
93699, 31452, 31435, 93241, 93266
34179, 31209, 31201, 92957, 92965, 31210, 31202, 92958, 92966, 31451, 93691, 93267, 93699, 31453, 93692, 93270, 
93700, 31454, 31437, 93244, 93269
34180, 31210, 31202, 92958, 92966, 31211, 31203, 92959, 92967, 31453, 93692, 93270, 93700, 31455, 93693, 93273, 
93701, 31456, 31439, 93247, 93272
34181, 31211, 31203, 92959, 92967, 31212, 31204, 92960, 92968, 31455, 93693, 93273, 93701, 31457, 93694, 93276, 
93702, 31458, 31441, 93250, 93275
34182, 31212, 31204, 92960, 92968, 31213, 31205, 92961, 92969, 31457, 93694, 93276, 93702, 31459, 93695, 93279, 
93703, 31460, 31443, 93253, 93278
34183, 31213, 31205, 92961, 92969, 3665, 3664, 31001, 31002, 31459, 93695, 93279, 93703, 3687, 31068, 31032, 
31069, 31461, 31444, 93256, 93281
34184, 3615, 3614, 30913, 30914, 31214, 31206, 92962, 92970, 3637, 30980, 30944, 30981, 31462, 93696, 93283, 
93704, 31463, 31446, 93257, 93282
34185, 31214, 31206, 92962, 92970, 31215, 31207, 92963, 92971, 31462, 93696, 93283, 93704, 31464, 93697, 93286, 
93705, 31465, 31448, 93260, 93285
34186, 31215, 31207, 92963, 92971, 31216, 31208, 92964, 92972, 31464, 93697, 93286, 93705, 31466, 93698, 93289, 
93706, 31467, 31450, 93263, 93288
34187, 31216, 31208, 92964, 92972, 31217, 31209, 92965, 92973, 31466, 93698, 93289, 93706, 31468, 93699, 93292, 
93707, 31469, 31452, 93266, 93291
34188, 31217, 31209, 92965, 92973, 31218, 31210, 92966, 92974, 31468, 93699, 93292, 93707, 31470, 93700, 93295, 
93708, 31471, 31454, 93269, 93294
34189, 31218, 31210, 92966, 92974, 31219, 31211, 92967, 92975, 31470, 93700, 93295, 93708, 31472, 93701, 93298, 
93709, 31473, 31456, 93272, 93297
34190, 31219, 31211, 92967, 92975, 31220, 31212, 92968, 92976, 31472, 93701, 93298, 93709, 31474, 93702, 93301, 
93710, 31475, 31458, 93275, 93300
34191, 31220, 31212, 92968, 92976, 31221, 31213, 92969, 92977, 31474, 93702, 93301, 93710, 31476, 93703, 93304, 
93711, 31477, 31460, 93278, 93303
34192, 31221, 31213, 92969, 92977, 3666, 3665, 31002, 31003, 31476, 93703, 93304, 93711, 3688, 31069, 31034, 
31070, 31478, 31461, 93281, 93306
34193, 3616, 3615, 30914, 30915, 31222, 31214, 92970, 92978, 3638, 30981, 30946, 30982, 31479, 93704, 93308, 
93712, 31480, 31463, 93282, 93307
34194, 31222, 31214, 92970, 92978, 31223, 31215, 92971, 92979, 31479, 93704, 93308, 93712, 31481, 93705, 93311, 
93713, 31482, 31465, 93285, 93310
34195, 31223, 31215, 92971, 92979, 31224, 31216, 92972, 92980, 31481, 93705, 93311, 93713, 31483, 93706, 93314, 
93714, 31484, 31467, 93288, 93313
34196, 31224, 31216, 92972, 92980, 31225, 31217, 92973, 92981, 31483, 93706, 93314, 93714, 31485, 93707, 93317, 
93715, 31486, 31469, 93291, 93316
34197, 31225, 31217, 92973, 92981, 31226, 31218, 92974, 92982, 31485, 93707, 93317, 93715, 31487, 93708, 93320, 
93716, 31488, 31471, 93294, 93319
34198, 31226, 31218, 92974, 92982, 31227, 31219, 92975, 92983, 31487, 93708, 93320, 93716, 31489, 93709, 93323, 
93717, 31490, 31473, 93297, 93322
34199, 31227, 31219, 92975, 92983, 31228, 31220, 92976, 92984, 31489, 93709, 93323, 93717, 31491, 93710, 93326, 
93718, 31492, 31475, 93300, 93325
34200, 31228, 31220, 92976, 92984, 31229, 31221, 92977, 92985, 31491, 93710, 93326, 93718, 31493, 93711, 93329, 
93719, 31494, 31477, 93303, 93328
34201, 31229, 31221, 92977, 92985, 3667, 3666, 31003, 31004, 31493, 93711, 93329, 93719, 3689, 31070, 31036, 
31071, 31495, 31478, 93306, 93331
34202, 3617, 3616, 30915, 30916, 31230, 31222, 92978, 92986, 3639, 30982, 30948, 30983, 31496, 93712, 93333, 
93720, 31497, 31480, 93307, 93332
34203, 31230, 31222, 92978, 92986, 31231, 31223, 92979, 92987, 31496, 93712, 93333, 93720, 31498, 93713, 93336, 
93721, 31499, 31482, 93310, 93335
34204, 31231, 31223, 92979, 92987, 31232, 31224, 92980, 92988, 31498, 93713, 93336, 93721, 31500, 93714, 93339, 
93722, 31501, 31484, 93313, 93338
34205, 31232, 31224, 92980, 92988, 31233, 31225, 92981, 92989, 31500, 93714, 93339, 93722, 31502, 93715, 93342, 
93723, 31503, 31486, 93316, 93341
34206, 31233, 31225, 92981, 92989, 31234, 31226, 92982, 92990, 31502, 93715, 93342, 93723, 31504, 93716, 93345, 
93724, 31505, 31488, 93319, 93344
34207, 31234, 31226, 92982, 92990, 31235, 31227, 92983, 92991, 31504, 93716, 93345, 93724, 31506, 93717, 93348, 
93725, 31507, 31490, 93322, 93347
34208, 31235, 31227, 92983, 92991, 31236, 31228, 92984, 92992, 31506, 93717, 93348, 93725, 31508, 93718, 93351, 
93726, 31509, 31492, 93325, 93350
34209, 31236, 31228, 92984, 92992, 31237, 31229, 92985, 92993, 31508, 93718, 93351, 93726, 31510, 93719, 93354, 
93727, 31511, 31494, 93328, 93353
34210, 31237, 31229, 92985, 92993, 3668, 3667, 31004, 31005, 31510, 93719, 93354, 93727, 3690, 31071, 31038, 
31072, 31512, 31495, 93331, 93356
34211, 3618, 3617, 30916, 30917, 31238, 31230, 92986, 92994, 3640, 30983, 30950, 30984, 31513, 93720, 93358, 
93728, 31514, 31497, 93332, 93357
34212, 31238, 31230, 92986, 92994, 31239, 31231, 92987, 92995, 31513, 93720, 93358, 93728, 31515, 93721, 93361, 
93729, 31516, 31499, 93335, 93360
34213, 31239, 31231, 92987, 92995, 31240, 31232, 92988, 92996, 31515, 93721, 93361, 93729, 31517, 93722, 93364, 
93730, 31518, 31501, 93338, 93363
34214, 31240, 31232, 92988, 92996, 31241, 31233, 92989, 92997, 31517, 93722, 93364, 93730, 31519, 93723, 93367, 
93731, 31520, 31503, 93341, 93366
34215, 31241, 31233, 92989, 92997, 31242, 31234, 92990, 92998, 31519, 93723, 93367, 93731, 31521, 93724, 93370, 
93732, 31522, 31505, 93344, 93369
34216, 31242, 31234, 92990, 92998, 31243, 31235, 92991, 92999, 31521, 93724, 93370, 93732, 31523, 93725, 93373, 
93733, 31524, 31507, 93347, 93372
34217, 31243, 31235, 92991, 92999, 31244, 31236, 92992, 93000, 31523, 93725, 93373, 93733, 31525, 93726, 93376, 
93734, 31526, 31509, 93350, 93375
34218, 31244, 31236, 92992, 93000, 31245, 31237, 92993, 93001, 31525, 93726, 93376, 93734, 31527, 93727, 93379, 
93735, 31528, 31511, 93353, 93378
34219, 31245, 31237, 92993, 93001, 3669, 3668, 31005, 31006, 31527, 93727, 93379, 93735, 3691, 31072, 31040, 
31073, 31529, 31512, 93356, 93381
34220, 3619, 3618, 30917, 30918, 31246, 31238, 92994, 93002, 3641, 30984, 30952, 30985, 31530, 93728, 93383, 
93736, 31531, 31514, 93357, 93382
34221, 31246, 31238, 92994, 93002, 31247, 31239, 92995, 93003, 31530, 93728, 93383, 93736, 31532, 93729, 93386, 
93737, 31533, 31516, 93360, 93385
34222, 31247, 31239, 92995, 93003, 31248, 31240, 92996, 93004, 31532, 93729, 93386, 93737, 31534, 93730, 93389, 
93738, 31535, 31518, 93363, 93388
34223, 31248, 31240, 92996, 93004, 31249, 31241, 92997, 93005, 31534, 93730, 93389, 93738, 31536, 93731, 93392, 
93739, 31537, 31520, 93366, 93391
34224, 31249, 31241, 92997, 93005, 31250, 31242, 92998, 93006, 31536, 93731, 93392, 93739, 31538, 93732, 93395, 
93740, 31539, 31522, 93369, 93394
34225, 31250, 31242, 92998, 93006, 31251, 31243, 92999, 93007, 31538, 93732, 93395, 93740, 31540, 93733, 93398, 
93741, 31541, 31524, 93372, 93397
34226, 31251, 31243, 92999, 93007, 31252, 31244, 93000, 93008, 31540, 93733, 93398, 93741, 31542, 93734, 93401, 
93742, 31543, 31526, 93375, 93400
34227, 31252, 31244, 93000, 93008, 31253, 31245, 93001, 93009, 31542, 93734, 93401, 93742, 31544, 93735, 93404, 
93743, 31545, 31528, 93378, 93403
34228, 31253, 31245, 93001, 93009, 3670, 3669, 31006, 31007, 31544, 93735, 93404, 93743, 3692, 31073, 31042, 
31074, 31546, 31529, 93381, 93406
34229, 3620, 3619, 30918, 30919, 31254, 31246, 93002, 93010, 3642, 30985, 30954, 30986, 31547, 93736, 93408, 
93744, 31548, 31531, 93382, 93407
34230, 31254, 31246, 93002, 93010, 31255, 31247, 93003, 93011, 31547, 93736, 93408, 93744, 31549, 93737, 93411, 
93745, 31550, 31533, 93385, 93410
34231, 31255, 31247, 93003, 93011, 31256, 31248, 93004, 93012, 31549, 93737, 93411, 93745, 31551, 93738, 93414, 
93746, 31552, 31535, 93388, 93413
34232, 31256, 31248, 93004, 93012, 31257, 31249, 93005, 93013, 31551, 93738, 93414, 93746, 31553, 93739, 93417, 
93747, 31554, 31537, 93391, 93416
34233, 31257, 31249, 93005, 93013, 31258, 31250, 93006, 93014, 31553, 93739, 93417, 93747, 31555, 93740, 93420, 
93748, 31556, 31539, 93394, 93419
34234, 31258, 31250, 93006, 93014, 31259, 31251, 93007, 93015, 31555, 93740, 93420, 93748, 31557, 93741, 93423, 
93749, 31558, 31541, 93397, 93422
34235, 31259, 31251, 93007, 93015, 31260, 31252, 93008, 93016, 31557, 93741, 93423, 93749, 31559, 93742, 93426, 
93750, 31560, 31543, 93400, 93425
34236, 31260, 31252, 93008, 93016, 31261, 31253, 93009, 93017, 31559, 93742, 93426, 93750, 31561, 93743, 93429, 
93751, 31562, 31545, 93403, 93428
34237, 31261, 31253, 93009, 93017, 3671, 3670, 31007, 31008, 31561, 93743, 93429, 93751, 3693, 31074, 31044, 
31075, 31563, 31546, 93406, 93431
34238, 3621, 3620, 30919, 30920, 31262, 31254, 93010, 93018, 3643, 30986, 30956, 30987, 31564, 93744, 93433, 
93752, 31565, 31548, 93407, 93432
34239, 31262, 31254, 93010, 93018, 31263, 31255, 93011, 93019, 31564, 93744, 93433, 93752, 31566, 93745, 93436, 
93753, 31567, 31550, 93410, 93435
34240, 31263, 31255, 93011, 93019, 31264, 31256, 93012, 93020, 31566, 93745, 93436, 93753, 31568, 93746, 93439, 
93754, 31569, 31552, 93413, 93438
34241, 31264, 31256, 93012, 93020, 31265, 31257, 93013, 93021, 31568, 93746, 93439, 93754, 31570, 93747, 93442, 
93755, 31571, 31554, 93416, 93441
34242, 31265, 31257, 93013, 93021, 31266, 31258, 93014, 93022, 31570, 93747, 93442, 93755, 31572, 93748, 93445, 
93756, 31573, 31556, 93419, 93444
34243, 31266, 31258, 93014, 93022, 31267, 31259, 93015, 93023, 31572, 93748, 93445, 93756, 31574, 93749, 93448, 
93757, 31575, 31558, 93422, 93447
34244, 31267, 31259, 93015, 93023, 31268, 31260, 93016, 93024, 31574, 93749, 93448, 93757, 31576, 93750, 93451, 
93758, 31577, 31560, 93425, 93450
34245, 31268, 31260, 93016, 93024, 31269, 31261, 93017, 93025, 31576, 93750, 93451, 93758, 31578, 93751, 93454, 
93759, 31579, 31562, 93428, 93453
34246, 31269, 31261, 93017, 93025, 3672, 3671, 31008, 31009, 31578, 93751, 93454, 93759, 3694, 31075, 31046, 
31076, 31580, 31563, 93431, 93456
34247, 3622, 3621, 30920, 30921, 31270, 31262, 93018, 93026, 3644, 30987, 30958, 30988, 31581, 93752, 93458, 
93760, 31582, 31565, 93432, 93457
34248, 31270, 31262, 93018, 93026, 31271, 31263, 93019, 93027, 31581, 93752, 93458, 93760, 31583, 93753, 93461, 
93761, 31584, 31567, 93435, 93460
34249, 31271, 31263, 93019, 93027, 31272, 31264, 93020, 93028, 31583, 93753, 93461, 93761, 31585, 93754, 93464, 
93762, 31586, 31569, 93438, 93463
34250, 31272, 31264, 93020, 93028, 31273, 31265, 93021, 93029, 31585, 93754, 93464, 93762, 31587, 93755, 93467, 
93763, 31588, 31571, 93441, 93466
34251, 31273, 31265, 93021, 93029, 31274, 31266, 93022, 93030, 31587, 93755, 93467, 93763, 31589, 93756, 93470, 
93764, 31590, 31573, 93444, 93469
34252, 31274, 31266, 93022, 93030, 31275, 31267, 93023, 93031, 31589, 93756, 93470, 93764, 31591, 93757, 93473, 
93765, 31592, 31575, 93447, 93472
34253, 31275, 31267, 93023, 93031, 31276, 31268, 93024, 93032, 31591, 93757, 93473, 93765, 31593, 93758, 93476, 
93766, 31594, 31577, 93450, 93475
34254, 31276, 31268, 93024, 93032, 31277, 31269, 93025, 93033, 31593, 93758, 93476, 93766, 31595, 93759, 93479, 
93767, 31596, 31579, 93453, 93478
34255, 31277, 31269, 93025, 93033, 3673, 3672, 31009, 31010, 31595, 93759, 93479, 93767, 3695, 31076, 31048, 
31077, 31597, 31580, 93456, 93481
34256, 3623, 3622, 30921, 30922, 31278, 31270, 93026, 93034, 3645, 30988, 30960, 30989, 31598, 93760, 93483, 
93768, 31599, 31582, 93457, 93482
34257, 31278, 31270, 93026, 93034, 31279, 31271, 93027, 93035, 31598, 93760, 93483, 93768, 31600, 93761, 93486, 
93769, 31601, 31584, 93460, 93485
34258, 31279, 31271, 93027, 93035, 31280, 31272, 93028, 93036, 31600, 93761, 93486, 93769, 31602, 93762, 93489, 
93770, 31603, 31586, 93463, 93488
34259, 31280, 31272, 93028, 93036, 31281, 31273, 93029, 93037, 31602, 93762, 93489, 93770, 31604, 93763, 93492, 
93771, 31605, 31588, 93466, 93491
34260, 31281, 31273, 93029, 93037, 31282, 31274, 93030, 93038, 31604, 93763, 93492, 93771, 31606, 93764, 93495, 
93772, 31607, 31590, 93469, 93494
34261, 31282, 31274, 93030, 93038, 31283, 31275, 93031, 93039, 31606, 93764, 93495, 93772, 31608, 93765, 93498, 
93773, 31609, 31592, 93472, 93497
34262, 31283, 31275, 93031, 93039, 31284, 31276, 93032, 93040, 31608, 93765, 93498, 93773, 31610, 93766, 93501, 
93774, 31611, 31594, 93475, 93500
34263, 31284, 31276, 93032, 93040, 31285, 31277, 93033, 93041, 31610, 93766, 93501, 93774, 31612, 93767, 93504, 
93775, 31613, 31596, 93478, 93503
34264, 31285, 31277, 93033, 93041, 3674, 3673, 31010, 31011, 31612, 93767, 93504, 93775, 3696, 31077, 31050, 
31078, 31614, 31597, 93481, 93506
34265, 3624, 3623, 30922, 30923, 31286, 31278, 93034, 93042, 3646, 30989, 30962, 30990, 31615, 93768, 93508, 
93776, 31616, 31599, 93482, 93507
34266, 31286, 31278, 93034, 93042, 31287, 31279, 93035, 93043, 31615, 93768, 93508, 93776, 31617, 93769, 93511, 
93777, 31618, 31601, 93485, 93510
34267, 31287, 31279, 93035, 93043, 31288, 31280, 93036, 93044, 31617, 93769, 93511, 93777, 31619, 93770, 93514, 
93778, 31620, 31603, 93488, 93513
34268, 31288, 31280, 93036, 93044, 31289, 31281, 93037, 93045, 31619, 93770, 93514, 93778, 31621, 93771, 93517, 
93779, 31622, 31605, 93491, 93516
34269, 31289, 31281, 93037, 93045, 31290, 31282, 93038, 93046, 31621, 93771, 93517, 93779, 31623, 93772, 93520, 
93780, 31624, 31607, 93494, 93519
34270, 31290, 31282, 93038, 93046, 31291, 31283, 93039, 93047, 31623, 93772, 93520, 93780, 31625, 93773, 93523, 
93781, 31626, 31609, 93497, 93522
34271, 31291, 31283, 93039, 93047, 31292, 31284, 93040, 93048, 31625, 93773, 93523, 93781, 31627, 93774, 93526, 
93782, 31628, 31611, 93500, 93525
34272, 31292, 31284, 93040, 93048, 31293, 31285, 93041, 93049, 31627, 93774, 93526, 93782, 31629, 93775, 93529, 
93783, 31630, 31613, 93503, 93528
34273, 31293, 31285, 93041, 93049, 3675, 3674, 31011, 31012, 31629, 93775, 93529, 93783, 3697, 31078, 31052, 
31079, 31631, 31614, 93506, 93531
34274, 3625, 3624, 30923, 30924, 31294, 31286, 93042, 93050, 3647, 30990, 30964, 30991, 31632, 93776, 93533, 
93784, 31633, 31616, 93507, 93532
34275, 31294, 31286, 93042, 93050, 31295, 31287, 93043, 93051, 31632, 93776, 93533, 93784, 31634, 93777, 93536, 
93785, 31635, 31618, 93510, 93535
34276, 31295, 31287, 93043, 93051, 31296, 31288, 93044, 93052, 31634, 93777, 93536, 93785, 31636, 93778, 93539, 
93786, 31637, 31620, 93513, 93538
34277, 31296, 31288, 93044, 93052, 31297, 31289, 93045, 93053, 31636, 93778, 93539, 93786, 31638, 93779, 93542, 
93787, 31639, 31622, 93516, 93541
34278, 31297, 31289, 93045, 93053, 31298, 31290, 93046, 93054, 31638, 93779, 93542, 93787, 31640, 93780, 93545, 
93788, 31641, 31624, 93519, 93544
34279, 31298, 31290, 93046, 93054, 31299, 31291, 93047, 93055, 31640, 93780, 93545, 93788, 31642, 93781, 93548, 
93789, 31643, 31626, 93522, 93547
34280, 31299, 31291, 93047, 93055, 31300, 31292, 93048, 93056, 31642, 93781, 93548, 93789, 31644, 93782, 93551, 
93790, 31645, 31628, 93525, 93550
34281, 31300, 31292, 93048, 93056, 31301, 31293, 93049, 93057, 31644, 93782, 93551, 93790, 31646, 93783, 93554, 
93791, 31647, 31630, 93528, 93553
34282, 31301, 31293, 93049, 93057, 3676, 3675, 31012, 31013, 31646, 93783, 93554, 93791, 3698, 31079, 31054, 
31080, 31648, 31631, 93531, 93556
34283, 3626, 3625, 30924, 30925, 31302, 31294, 93050, 93058, 3648, 30991, 30966, 30992, 31649, 93784, 93558, 
93792, 31650, 31633, 93532, 93557
34284, 31302, 31294, 93050, 93058, 31303, 31295, 93051, 93059, 31649, 93784, 93558, 93792, 31651, 93785, 93561, 
93793, 31652, 31635, 93535, 93560
34285, 31303, 31295, 93051, 93059, 31304, 31296, 93052, 93060, 31651, 93785, 93561, 93793, 31653, 93786, 93564, 
93794, 31654, 31637, 93538, 93563
34286, 31304, 31296, 93052, 93060, 31305, 31297, 93053, 93061, 31653, 93786, 93564, 93794, 31655, 93787, 93567, 
93795, 31656, 31639, 93541, 93566
34287, 31305, 31297, 93053, 93061, 31306, 31298, 93054, 93062, 31655, 93787, 93567, 93795, 31657, 93788, 93570, 
93796, 31658, 31641, 93544, 93569
34288, 31306, 31298, 93054, 93062, 31307, 31299, 93055, 93063, 31657, 93788, 93570, 93796, 31659, 93789, 93573, 
93797, 31660, 31643, 93547, 93572
34289, 31307, 31299, 93055, 93063, 31308, 31300, 93056, 93064, 31659, 93789, 93573, 93797, 31661, 93790, 93576, 
93798, 31662, 31645, 93550, 93575
34290, 31308, 31300, 93056, 93064, 31309, 31301, 93057, 93065, 31661, 93790, 93576, 93798, 31663, 93791, 93579, 
93799, 31664, 31647, 93553, 93578
34291, 31309, 31301, 93057, 93065, 3677, 3676, 31013, 31014, 31663, 93791, 93579, 93799, 3699, 31080, 31056, 
31081, 31665, 31648, 93556, 93581
34292, 3627, 3626, 30925, 30926, 31310, 31302, 93058, 93066, 3649, 30992, 30968, 30993, 31666, 93792, 93583, 
93800, 31667, 31650, 93557, 93582
34293, 31310, 31302, 93058, 93066, 31311, 31303, 93059, 93067, 31666, 93792, 93583, 93800, 31668, 93793, 93586, 
93801, 31669, 31652, 93560, 93585
34294, 31311, 31303, 93059, 93067, 31312, 31304, 93060, 93068, 31668, 93793, 93586, 93801, 31670, 93794, 93589, 
93802, 31671, 31654, 93563, 93588
34295, 31312, 31304, 93060, 93068, 31313, 31305, 93061, 93069, 31670, 93794, 93589, 93802, 31672, 93795, 93592, 
93803, 31673, 31656, 93566, 93591
34296, 31313, 31305, 93061, 93069, 31314, 31306, 93062, 93070, 31672, 93795, 93592, 93803, 31674, 93796, 93595, 
93804, 31675, 31658, 93569, 93594
34297, 31314, 31306, 93062, 93070, 31315, 31307, 93063, 93071, 31674, 93796, 93595, 93804, 31676, 93797, 93598, 
93805, 31677, 31660, 93572, 93597
34298, 31315, 31307, 93063, 93071, 31316, 31308, 93064, 93072, 31676, 93797, 93598, 93805, 31678, 93798, 93601, 
93806, 31679, 31662, 93575, 93600
34299, 31316, 31308, 93064, 93072, 31317, 31309, 93065, 93073, 31678, 93798, 93601, 93806, 31680, 93799, 93604, 
93807, 31681, 31664, 93578, 93603
34300, 31317, 31309, 93065, 93073, 3678, 3677, 31014, 31015, 31680, 93799, 93604, 93807, 3700, 31081, 31058, 
31082, 31682, 31665, 93581, 93606
34301, 3628, 3627, 30926, 30927, 31318, 31310, 93066, 93074, 3650, 30993, 30970, 30994, 31683, 93800, 93608, 
93808, 31684, 31667, 93582, 93607
34302, 31318, 31310, 93066, 93074, 31319, 31311, 93067, 93075, 31683, 93800, 93608, 93808, 31685, 93801, 93611, 
93809, 31686, 31669, 93585, 93610
34303, 31319, 31311, 93067, 93075, 31320, 31312, 93068, 93076, 31685, 93801, 93611, 93809, 31687, 93802, 93614, 
93810, 31688, 31671, 93588, 93613
34304, 31320, 31312, 93068, 93076, 31321, 31313, 93069, 93077, 31687, 93802, 93614, 93810, 31689, 93803, 93617, 
93811, 31690, 31673, 93591, 93616
34305, 31321, 31313, 93069, 93077, 31322, 31314, 93070, 93078, 31689, 93803, 93617, 93811, 31691, 93804, 93620, 
93812, 31692, 31675, 93594, 93619
34306, 31322, 31314, 93070, 93078, 31323, 31315, 93071, 93079, 31691, 93804, 93620, 93812, 31693, 93805, 93623, 
93813, 31694, 31677, 93597, 93622
34307, 31323, 31315, 93071, 93079, 31324, 31316, 93072, 93080, 31693, 93805, 93623, 93813, 31695, 93806, 93626, 
93814, 31696, 31679, 93600, 93625
34308, 31324, 31316, 93072, 93080, 31325, 31317, 93073, 93081, 31695, 93806, 93626, 93814, 31697, 93807, 93629, 
93815, 31698, 31681, 93603, 93628
34309, 31325, 31317, 93073, 93081, 3679, 3678, 31015, 31016, 31697, 93807, 93629, 93815, 3701, 31082, 31060, 
31083, 31699, 31682, 93606, 93631
34310, 102, 3628, 30927, 3604, 3727, 31318, 93074, 31117, 3651, 30994, 30972, 3606, 31700, 93808, 93632, 
31142, 3736, 31684, 93607, 31125
34311, 3727, 31318, 93074, 31117, 3726, 31319, 93075, 31118, 31700, 93808, 93632, 31142, 31701, 93809, 93633, 
31143, 3735, 31686, 93610, 31127
34312, 3726, 31319, 93075, 31118, 3725, 31320, 93076, 31119, 31701, 93809, 93633, 31143, 31702, 93810, 93634, 
31144, 3734, 31688, 93613, 31129
34313, 3725, 31320, 93076, 31119, 3724, 31321, 93077, 31120, 31702, 93810, 93634, 31144, 31703, 93811, 93635, 
31145, 3733, 31690, 93616, 31131
34314, 3724, 31321, 93077, 31120, 3723, 31322, 93078, 31121, 31703, 93811, 93635, 31145, 31704, 93812, 93636, 
31146, 3732, 31692, 93619, 31133
34315, 3723, 31322, 93078, 31121, 3722, 31323, 93079, 31122, 31704, 93812, 93636, 31146, 31705, 93813, 93637, 
31147, 3731, 31694, 93622, 31135
34316, 3722, 31323, 93079, 31122, 3721, 31324, 93080, 31123, 31705, 93813, 93637, 31147, 31706, 93814, 93638, 
31148, 3730, 31696, 93625, 31137
34317, 3721, 31324, 93080, 31123, 3720, 31325, 93081, 31124, 31706, 93814, 93638, 31148, 31707, 93815, 93639, 
31149, 3729, 31698, 93628, 31139
34318, 3720, 31325, 93081, 31124, 104, 3679, 31016, 3655, 31707, 93815, 93639, 31149, 3702, 31083, 31061, 
3657, 3728, 31699, 93631, 31141
*ELEMENT, type=C3D20, ELSET=Volume33
34319, 31708, 3737, 93, 3137, 93816, 31886, 3414, 27942, 31730, 3738, 3159, 31731, 93993, 31894, 28118, 
93994, 93992, 31895, 3423, 28119
34320, 93816, 31886, 3414, 27942, 93817, 31887, 3413, 27943, 93993, 31894, 28118, 93994, 93996, 31896, 28120, 
93997, 93995, 31897, 3422, 28121
34321, 93817, 31887, 3413, 27943, 93818, 31888, 3412, 27944, 93996, 31896, 28120, 93997, 93999, 31898, 28122, 
94000, 93998, 31899, 3421, 28123
34322, 93818, 31888, 3412, 27944, 93819, 31889, 3411, 27945, 93999, 31898, 28122, 94000, 94002, 31900, 28124, 
94003, 94001, 31901, 3420, 28125
34323, 93819, 31889, 3411, 27945, 93820, 31890, 3410, 27946, 94002, 31900, 28124, 94003, 94005, 31902, 28126, 
94006, 94004, 31903, 3419, 28127
34324, 93820, 31890, 3410, 27946, 93821, 31891, 3409, 27947, 94005, 31902, 28126, 94006, 94008, 31904, 28128, 
94009, 94007, 31905, 3418, 28129
34325, 93821, 31891, 3409, 27947, 93822, 31892, 3408, 27948, 94008, 31904, 28128, 94009, 94011, 31906, 28130, 
94012, 94010, 31907, 3417, 28131
34326, 93822, 31892, 3408, 27948, 93823, 31893, 3407, 27949, 94011, 31906, 28130, 94012, 94014, 31908, 28132, 
94015, 94013, 31909, 3416, 28133
34327, 93823, 31893, 3407, 27949, 31797, 3788, 95, 3272, 94014, 31908, 28132, 94015, 31820, 3789, 3294, 
31819, 94016, 31910, 3415, 28134
34328, 31709, 31708, 3137, 3138, 93824, 93816, 27942, 27950, 31732, 31731, 3160, 31733, 94018, 93994, 28135, 
94019, 94017, 93992, 28119, 28136
34329, 93824, 93816, 27942, 27950, 93825, 93817, 27943, 27951, 94018, 93994, 28135, 94019, 94021, 93997, 28137, 
94022, 94020, 93995, 28121, 28138
34330, 93825, 93817, 27943, 27951, 93826, 93818, 27944, 27952, 94021, 93997, 28137, 94022, 94024, 94000, 28139, 
94025, 94023, 93998, 28123, 28140
34331, 93826, 93818, 27944, 27952, 93827, 93819, 27945, 27953, 94024, 94000, 28139, 94025, 94027, 94003, 28141, 
94028, 94026, 94001, 28125, 28142
34332, 93827, 93819, 27945, 27953, 93828, 93820, 27946, 27954, 94027, 94003, 28141, 94028, 94030, 94006, 28143, 
94031, 94029, 94004, 28127, 28144
34333, 93828, 93820, 27946, 27954, 93829, 93821, 27947, 27955, 94030, 94006, 28143, 94031, 94033, 94009, 28145, 
94034, 94032, 94007, 28129, 28146
34334, 93829, 93821, 27947, 27955, 93830, 93822, 27948, 27956, 94033, 94009, 28145, 94034, 94036, 94012, 28147, 
94037, 94035, 94010, 28131, 28148
34335, 93830, 93822, 27948, 27956, 93831, 93823, 27949, 27957, 94036, 94012, 28147, 94037, 94039, 94015, 28149, 
94040, 94038, 94013, 28133, 28150
34336, 93831, 93823, 27949, 27957, 31798, 31797, 3272, 3273, 94039, 94015, 28149, 94040, 31822, 31819, 3295, 
31821, 94041, 94016, 28134, 28151
34337, 31710, 31709, 3138, 3139, 93832, 93824, 27950, 27958, 31734, 31733, 3161, 31735, 94043, 94019, 28152, 
94044, 94042, 94017, 28136, 28153
34338, 93832, 93824, 27950, 27958, 93833, 93825, 27951, 27959, 94043, 94019, 28152, 94044, 94046, 94022, 28154, 
94047, 94045, 94020, 28138, 28155
34339, 93833, 93825, 27951, 27959, 93834, 93826, 27952, 27960, 94046, 94022, 28154, 94047, 94049, 94025, 28156, 
94050, 94048, 94023, 28140, 28157
34340, 93834, 93826, 27952, 27960, 93835, 93827, 27953, 27961, 94049, 94025, 28156, 94050, 94052, 94028, 28158, 
94053, 94051, 94026, 28142, 28159
34341, 93835, 93827, 27953, 27961, 93836, 93828, 27954, 27962, 94052, 94028, 28158, 94053, 94055, 94031, 28160, 
94056, 94054, 94029, 28144, 28161
34342, 93836, 93828, 27954, 27962, 93837, 93829, 27955, 27963, 94055, 94031, 28160, 94056, 94058, 94034, 28162, 
94059, 94057, 94032, 28146, 28163
34343, 93837, 93829, 27955, 27963, 93838, 93830, 27956, 27964, 94058, 94034, 28162, 94059, 94061, 94037, 28164, 
94062, 94060, 94035, 28148, 28165
34344, 93838, 93830, 27956, 27964, 93839, 93831, 27957, 27965, 94061, 94037, 28164, 94062, 94064, 94040, 28166, 
94065, 94063, 94038, 28150, 28167
34345, 93839, 93831, 27957, 27965, 31799, 31798, 3273, 3274, 94064, 94040, 28166, 94065, 31824, 31821, 3296, 
31823, 94066, 94041, 28151, 28168
34346, 31711, 31710, 3139, 3140, 93840, 93832, 27958, 27966, 31736, 31735, 3162, 31737, 94068, 94044, 28169, 
94069, 94067, 94042, 28153, 28170
34347, 93840, 93832, 27958, 27966, 93841, 93833, 27959, 27967, 94068, 94044, 28169, 94069, 94071, 94047, 28171, 
94072, 94070, 94045, 28155, 28172
34348, 93841, 93833, 27959, 27967, 93842, 93834, 27960, 27968, 94071, 94047, 28171, 94072, 94074, 94050, 28173, 
94075, 94073, 94048, 28157, 28174
34349, 93842, 93834, 27960, 27968, 93843, 93835, 27961, 27969, 94074, 94050, 28173, 94075, 94077, 94053, 28175, 
94078, 94076, 94051, 28159, 28176
34350, 93843, 93835, 27961, 27969, 93844, 93836, 27962, 27970, 94077, 94053, 28175, 94078, 94080, 94056, 28177, 
94081, 94079, 94054, 28161, 28178
34351, 93844, 93836, 27962, 27970, 93845, 93837, 27963, 27971, 94080, 94056, 28177, 94081, 94083, 94059, 28179, 
94084, 94082, 94057, 28163, 28180
34352, 93845, 93837, 27963, 27971, 93846, 93838, 27964, 27972, 94083, 94059, 28179, 94084, 94086, 94062, 28181, 
94087, 94085, 94060, 28165, 28182
34353, 93846, 93838, 27964, 27972, 93847, 93839, 27965, 27973, 94086, 94062, 28181, 94087, 94089, 94065, 28183, 
94090, 94088, 94063, 28167, 28184
34354, 93847, 93839, 27965, 27973, 31800, 31799, 3274, 3275, 94089, 94065, 28183, 94090, 31826, 31823, 3297, 
31825, 94091, 94066, 28168, 28185
34355, 31712, 31711, 3140, 3141, 93848, 93840, 27966, 27974, 31738, 31737, 3163, 31739, 94093, 94069, 28186, 
94094, 94092, 94067, 28170, 28187
34356, 93848, 93840, 27966, 27974, 93849, 93841, 27967, 27975, 94093, 94069, 28186, 94094, 94096, 94072, 28188, 
94097, 94095, 94070, 28172, 28189
34357, 93849, 93841, 27967, 27975, 93850, 93842, 27968, 27976, 94096, 94072, 28188, 94097, 94099, 94075, 28190, 
94100, 94098, 94073, 28174, 28191
34358, 93850, 93842, 27968, 27976, 93851, 93843, 27969, 27977, 94099, 94075, 28190, 94100, 94102, 94078, 28192, 
94103, 94101, 94076, 28176, 28193
34359, 93851, 93843, 27969, 27977, 93852, 93844, 27970, 27978, 94102, 94078, 28192, 94103, 94105, 94081, 28194, 
94106, 94104, 94079, 28178, 28195
34360, 93852, 93844, 27970, 27978, 93853, 93845, 27971, 27979, 94105, 94081, 28194, 94106, 94108, 94084, 28196, 
94109, 94107, 94082, 28180, 28197
34361, 93853, 93845, 27971, 27979, 93854, 93846, 27972, 27980, 94108, 94084, 28196, 94109, 94111, 94087, 28198, 
94112, 94110, 94085, 28182, 28199
34362, 93854, 93846, 27972, 27980, 93855, 93847, 27973, 27981, 94111, 94087, 28198, 94112, 94114, 94090, 28200, 
94115, 94113, 94088, 28184, 28201
34363, 93855, 93847, 27973, 27981, 31801, 31800, 3275, 3276, 94114, 94090, 28200, 94115, 31828, 31825, 3298, 
31827, 94116, 94091, 28185, 28202
34364, 31713, 31712, 3141, 3142, 93856, 93848, 27974, 27982, 31740, 31739, 3164, 31741, 94118, 94094, 28203, 
94119, 94117, 94092, 28187, 28204
34365, 93856, 93848, 27974, 27982, 93857, 93849, 27975, 27983, 94118, 94094, 28203, 94119, 94121, 94097, 28205, 
94122, 94120, 94095, 28189, 28206
34366, 93857, 93849, 27975, 27983, 93858, 93850, 27976, 27984, 94121, 94097, 28205, 94122, 94124, 94100, 28207, 
94125, 94123, 94098, 28191, 28208
34367, 93858, 93850, 27976, 27984, 93859, 93851, 27977, 27985, 94124, 94100, 28207, 94125, 94127, 94103, 28209, 
94128, 94126, 94101, 28193, 28210
34368, 93859, 93851, 27977, 27985, 93860, 93852, 27978, 27986, 94127, 94103, 28209, 94128, 94130, 94106, 28211, 
94131, 94129, 94104, 28195, 28212
34369, 93860, 93852, 27978, 27986, 93861, 93853, 27979, 27987, 94130, 94106, 28211, 94131, 94133, 94109, 28213, 
94134, 94132, 94107, 28197, 28214
34370, 93861, 93853, 27979, 27987, 93862, 93854, 27980, 27988, 94133, 94109, 28213, 94134, 94136, 94112, 28215, 
94137, 94135, 94110, 28199, 28216
34371, 93862, 93854, 27980, 27988, 93863, 93855, 27981, 27989, 94136, 94112, 28215, 94137, 94139, 94115, 28217, 
94140, 94138, 94113, 28201, 28218
34372, 93863, 93855, 27981, 27989, 31802, 31801, 3276, 3277, 94139, 94115, 28217, 94140, 31830, 31827, 3299, 
31829, 94141, 94116, 28202, 28219
34373, 31714, 31713, 3142, 3143, 93864, 93856, 27982, 27990, 31742, 31741, 3165, 31743, 94143, 94119, 28220, 
94144, 94142, 94117, 28204, 28221
34374, 93864, 93856, 27982, 27990, 93865, 93857, 27983, 27991, 94143, 94119, 28220, 94144, 94146, 94122, 28222, 
94147, 94145, 94120, 28206, 28223
34375, 93865, 93857, 27983, 27991, 93866, 93858, 27984, 27992, 94146, 94122, 28222, 94147, 94149, 94125, 28224, 
94150, 94148, 94123, 28208, 28225
34376, 93866, 93858, 27984, 27992, 93867, 93859, 27985, 27993, 94149, 94125, 28224, 94150, 94152, 94128, 28226, 
94153, 94151, 94126, 28210, 28227
34377, 93867, 93859, 27985, 27993, 93868, 93860, 27986, 27994, 94152, 94128, 28226, 94153, 94155, 94131, 28228, 
94156, 94154, 94129, 28212, 28229
34378, 93868, 93860, 27986, 27994, 93869, 93861, 27987, 27995, 94155, 94131, 28228, 94156, 94158, 94134, 28230, 
94159, 94157, 94132, 28214, 28231
34379, 93869, 93861, 27987, 27995, 93870, 93862, 27988, 27996, 94158, 94134, 28230, 94159, 94161, 94137, 28232, 
94162, 94160, 94135, 28216, 28233
34380, 93870, 93862, 27988, 27996, 93871, 93863, 27989, 27997, 94161, 94137, 28232, 94162, 94164, 94140, 28234, 
94165, 94163, 94138, 28218, 28235
34381, 93871, 93863, 27989, 27997, 31803, 31802, 3277, 3278, 94164, 94140, 28234, 94165, 31832, 31829, 3300, 
31831, 94166, 94141, 28219, 28236
34382, 31715, 31714, 3143, 3144, 93872, 93864, 27990, 27998, 31744, 31743, 3166, 31745, 94168, 94144, 28237, 
94169, 94167, 94142, 28221, 28238
34383, 93872, 93864, 27990, 27998, 93873, 93865, 27991, 27999, 94168, 94144, 28237, 94169, 94171, 94147, 28239, 
94172, 94170, 94145, 28223, 28240
34384, 93873, 93865, 27991, 27999, 93874, 93866, 27992, 28000, 94171, 94147, 28239, 94172, 94174, 94150, 28241, 
94175, 94173, 94148, 28225, 28242
34385, 93874, 93866, 27992, 28000, 93875, 93867, 27993, 28001, 94174, 94150, 28241, 94175, 94177, 94153, 28243, 
94178, 94176, 94151, 28227, 28244
34386, 93875, 93867, 27993, 28001, 93876, 93868, 27994, 28002, 94177, 94153, 28243, 94178, 94180, 94156, 28245, 
94181, 94179, 94154, 28229, 28246
34387, 93876, 93868, 27994, 28002, 93877, 93869, 27995, 28003, 94180, 94156, 28245, 94181, 94183, 94159, 28247, 
94184, 94182, 94157, 28231, 28248
34388, 93877, 93869, 27995, 28003, 93878, 93870, 27996, 28004, 94183, 94159, 28247, 94184, 94186, 94162, 28249, 
94187, 94185, 94160, 28233, 28250
34389, 93878, 93870, 27996, 28004, 93879, 93871, 27997, 28005, 94186, 94162, 28249, 94187, 94189, 94165, 28251, 
94190, 94188, 94163, 28235, 28252
34390, 93879, 93871, 27997, 28005, 31804, 31803, 3278, 3279, 94189, 94165, 28251, 94190, 31834, 31831, 3301, 
31833, 94191, 94166, 28236, 28253
34391, 31716, 31715, 3144, 3145, 93880, 93872, 27998, 28006, 31746, 31745, 3167, 31747, 94193, 94169, 28254, 
94194, 94192, 94167, 28238, 28255
34392, 93880, 93872, 27998, 28006, 93881, 93873, 27999, 28007, 94193, 94169, 28254, 94194, 94196, 94172, 28256, 
94197, 94195, 94170, 28240, 28257
34393, 93881, 93873, 27999, 28007, 93882, 93874, 28000, 28008, 94196, 94172, 28256, 94197, 94199, 94175, 28258, 
94200, 94198, 94173, 28242, 28259
34394, 93882, 93874, 28000, 28008, 93883, 93875, 28001, 28009, 94199, 94175, 28258, 94200, 94202, 94178, 28260, 
94203, 94201, 94176, 28244, 28261
34395, 93883, 93875, 28001, 28009, 93884, 93876, 28002, 28010, 94202, 94178, 28260, 94203, 94205, 94181, 28262, 
94206, 94204, 94179, 28246, 28263
34396, 93884, 93876, 28002, 28010, 93885, 93877, 28003, 28011, 94205, 94181, 28262, 94206, 94208, 94184, 28264, 
94209, 94207, 94182, 28248, 28265
34397, 93885, 93877, 28003, 28011, 93886, 93878, 28004, 28012, 94208, 94184, 28264, 94209, 94211, 94187, 28266, 
94212, 94210, 94185, 28250, 28267
34398, 93886, 93878, 28004, 28012, 93887, 93879, 28005, 28013, 94211, 94187, 28266, 94212, 94214, 94190, 28268, 
94215, 94213, 94188, 28252, 28269
34399, 93887, 93879, 28005, 28013, 31805, 31804, 3279, 3280, 94214, 94190, 28268, 94215, 31836, 31833, 3302, 
31835, 94216, 94191, 28253, 28270
34400, 31717, 31716, 3145, 3146, 93888, 93880, 28006, 28014, 31748, 31747, 3168, 31749, 94218, 94194, 28271, 
94219, 94217, 94192, 28255, 28272
34401, 93888, 93880, 28006, 28014, 93889, 93881, 28007, 28015, 94218, 94194, 28271, 94219, 94221, 94197, 28273, 
94222, 94220, 94195, 28257, 28274
34402, 93889, 93881, 28007, 28015, 93890, 93882, 28008, 28016, 94221, 94197, 28273, 94222, 94224, 94200, 28275, 
94225, 94223, 94198, 28259, 28276
34403, 93890, 93882, 28008, 28016, 93891, 93883, 28009, 28017, 94224, 94200, 28275, 94225, 94227, 94203, 28277, 
94228, 94226, 94201, 28261, 28278
34404, 93891, 93883, 28009, 28017, 93892, 93884, 28010, 28018, 94227, 94203, 28277, 94228, 94230, 94206, 28279, 
94231, 94229, 94204, 28263, 28280
34405, 93892, 93884, 28010, 28018, 93893, 93885, 28011, 28019, 94230, 94206, 28279, 94231, 94233, 94209, 28281, 
94234, 94232, 94207, 28265, 28282
34406, 93893, 93885, 28011, 28019, 93894, 93886, 28012, 28020, 94233, 94209, 28281, 94234, 94236, 94212, 28283, 
94237, 94235, 94210, 28267, 28284
34407, 93894, 93886, 28012, 28020, 93895, 93887, 28013, 28021, 94236, 94212, 28283, 94237, 94239, 94215, 28285, 
94240, 94238, 94213, 28269, 28286
34408, 93895, 93887, 28013, 28021, 31806, 31805, 3280, 3281, 94239, 94215, 28285, 94240, 31838, 31835, 3303, 
31837, 94241, 94216, 28270, 28287
34409, 31718, 31717, 3146, 3147, 93896, 93888, 28014, 28022, 31750, 31749, 3169, 31751, 94243, 94219, 28288, 
94244, 94242, 94217, 28272, 28289
34410, 93896, 93888, 28014, 28022, 93897, 93889, 28015, 28023, 94243, 94219, 28288, 94244, 94246, 94222, 28290, 
94247, 94245, 94220, 28274, 28291
34411, 93897, 93889, 28015, 28023, 93898, 93890, 28016, 28024, 94246, 94222, 28290, 94247, 94249, 94225, 28292, 
94250, 94248, 94223, 28276, 28293
34412, 93898, 93890, 28016, 28024, 93899, 93891, 28017, 28025, 94249, 94225, 28292, 94250, 94252, 94228, 28294, 
94253, 94251, 94226, 28278, 28295
34413, 93899, 93891, 28017, 28025, 93900, 93892, 28018, 28026, 94252, 94228, 28294, 94253, 94255, 94231, 28296, 
94256, 94254, 94229, 28280, 28297
34414, 93900, 93892, 28018, 28026, 93901, 93893, 28019, 28027, 94255, 94231, 28296, 94256, 94258, 94234, 28298, 
94259, 94257, 94232, 28282, 28299
34415, 93901, 93893, 28019, 28027, 93902, 93894, 28020, 28028, 94258, 94234, 28298, 94259, 94261, 94237, 28300, 
94262, 94260, 94235, 28284, 28301
34416, 93902, 93894, 28020, 28028, 93903, 93895, 28021, 28029, 94261, 94237, 28300, 94262, 94264, 94240, 28302, 
94265, 94263, 94238, 28286, 28303
34417, 93903, 93895, 28021, 28029, 31807, 31806, 3281, 3282, 94264, 94240, 28302, 94265, 31840, 31837, 3304, 
31839, 94266, 94241, 28287, 28304
34418, 31719, 31718, 3147, 3148, 93904, 93896, 28022, 28030, 31752, 31751, 3170, 31753, 94268, 94244, 28305, 
94269, 94267, 94242, 28289, 28306
34419, 93904, 93896, 28022, 28030, 93905, 93897, 28023, 28031, 94268, 94244, 28305, 94269, 94271, 94247, 28307, 
94272, 94270, 94245, 28291, 28308
34420, 93905, 93897, 28023, 28031, 93906, 93898, 28024, 28032, 94271, 94247, 28307, 94272, 94274, 94250, 28309, 
94275, 94273, 94248, 28293, 28310
34421, 93906, 93898, 28024, 28032, 93907, 93899, 28025, 28033, 94274, 94250, 28309, 94275, 94277, 94253, 28311, 
94278, 94276, 94251, 28295, 28312
34422, 93907, 93899, 28025, 28033, 93908, 93900, 28026, 28034, 94277, 94253, 28311, 94278, 94280, 94256, 28313, 
94281, 94279, 94254, 28297, 28314
34423, 93908, 93900, 28026, 28034, 93909, 93901, 28027, 28035, 94280, 94256, 28313, 94281, 94283, 94259, 28315, 
94284, 94282, 94257, 28299, 28316
34424, 93909, 93901, 28027, 28035, 93910, 93902, 28028, 28036, 94283, 94259, 28315, 94284, 94286, 94262, 28317, 
94287, 94285, 94260, 28301, 28318
34425, 93910, 93902, 28028, 28036, 93911, 93903, 28029, 28037, 94286, 94262, 28317, 94287, 94289, 94265, 28319, 
94290, 94288, 94263, 28303, 28320
34426, 93911, 93903, 28029, 28037, 31808, 31807, 3282, 3283, 94289, 94265, 28319, 94290, 31842, 31839, 3305, 
31841, 94291, 94266, 28304, 28321
34427, 31720, 31719, 3148, 3149, 93912, 93904, 28030, 28038, 31754, 31753, 3171, 31755, 94293, 94269, 28322, 
94294, 94292, 94267, 28306, 28323
34428, 93912, 93904, 28030, 28038, 93913, 93905, 28031, 28039, 94293, 94269, 28322, 94294, 94296, 94272, 28324, 
94297, 94295, 94270, 28308, 28325
34429, 93913, 93905, 28031, 28039, 93914, 93906, 28032, 28040, 94296, 94272, 28324, 94297, 94299, 94275, 28326, 
94300, 94298, 94273, 28310, 28327
34430, 93914, 93906, 28032, 28040, 93915, 93907, 28033, 28041, 94299, 94275, 28326, 94300, 94302, 94278, 28328, 
94303, 94301, 94276, 28312, 28329
34431, 93915, 93907, 28033, 28041, 93916, 93908, 28034, 28042, 94302, 94278, 28328, 94303, 94305, 94281, 28330, 
94306, 94304, 94279, 28314, 28331
34432, 93916, 93908, 28034, 28042, 93917, 93909, 28035, 28043, 94305, 94281, 28330, 94306, 94308, 94284, 28332, 
94309, 94307, 94282, 28316, 28333
34433, 93917, 93909, 28035, 28043, 93918, 93910, 28036, 28044, 94308, 94284, 28332, 94309, 94311, 94287, 28334, 
94312, 94310, 94285, 28318, 28335
34434, 93918, 93910, 28036, 28044, 93919, 93911, 28037, 28045, 94311, 94287, 28334, 94312, 94314, 94290, 28336, 
94315, 94313, 94288, 28320, 28337
34435, 93919, 93911, 28037, 28045, 31809, 31808, 3283, 3284, 94314, 94290, 28336, 94315, 31844, 31841, 3306, 
31843, 94316, 94291, 28321, 28338
34436, 31721, 31720, 3149, 3150, 93920, 93912, 28038, 28046, 31756, 31755, 3172, 31757, 94318, 94294, 28339, 
94319, 94317, 94292, 28323, 28340
34437, 93920, 93912, 28038, 28046, 93921, 93913, 28039, 28047, 94318, 94294, 28339, 94319, 94321, 94297, 28341, 
94322, 94320, 94295, 28325, 28342
34438, 93921, 93913, 28039, 28047, 93922, 93914, 28040, 28048, 94321, 94297, 28341, 94322, 94324, 94300, 28343, 
94325, 94323, 94298, 28327, 28344
34439, 93922, 93914, 28040, 28048, 93923, 93915, 28041, 28049, 94324, 94300, 28343, 94325, 94327, 94303, 28345, 
94328, 94326, 94301, 28329, 28346
34440, 93923, 93915, 28041, 28049, 93924, 93916, 28042, 28050, 94327, 94303, 28345, 94328, 94330, 94306, 28347, 
94331, 94329, 94304, 28331, 28348
34441, 93924, 93916, 28042, 28050, 93925, 93917, 28043, 28051, 94330, 94306, 28347, 94331, 94333, 94309, 28349, 
94334, 94332, 94307, 28333, 28350
34442, 93925, 93917, 28043, 28051, 93926, 93918, 28044, 28052, 94333, 94309, 28349, 94334, 94336, 94312, 28351, 
94337, 94335, 94310, 28335, 28352
34443, 93926, 93918, 28044, 28052, 93927, 93919, 28045, 28053, 94336, 94312, 28351, 94337, 94339, 94315, 28353, 
94340, 94338, 94313, 28337, 28354
34444, 93927, 93919, 28045, 28053, 31810, 31809, 3284, 3285, 94339, 94315, 28353, 94340, 31846, 31843, 3307, 
31845, 94341, 94316, 28338, 28355
34445, 31722, 31721, 3150, 3151, 93928, 93920, 28046, 28054, 31758, 31757, 3173, 31759, 94343, 94319, 28356, 
94344, 94342, 94317, 28340, 28357
34446, 93928, 93920, 28046, 28054, 93929, 93921, 28047, 28055, 94343, 94319, 28356, 94344, 94346, 94322, 28358, 
94347, 94345, 94320, 28342, 28359
34447, 93929, 93921, 28047, 28055, 93930, 93922, 28048, 28056, 94346, 94322, 28358, 94347, 94349, 94325, 28360, 
94350, 94348, 94323, 28344, 28361
34448, 93930, 93922, 28048, 28056, 93931, 93923, 28049, 28057, 94349, 94325, 28360, 94350, 94352, 94328, 28362, 
94353, 94351, 94326, 28346, 28363
34449, 93931, 93923, 28049, 28057, 93932, 93924, 28050, 28058, 94352, 94328, 28362, 94353, 94355, 94331, 28364, 
94356, 94354, 94329, 28348, 28365
34450, 93932, 93924, 28050, 28058, 93933, 93925, 28051, 28059, 94355, 94331, 28364, 94356, 94358, 94334, 28366, 
94359, 94357, 94332, 28350, 28367
34451, 93933, 93925, 28051, 28059, 93934, 93926, 28052, 28060, 94358, 94334, 28366, 94359, 94361, 94337, 28368, 
94362, 94360, 94335, 28352, 28369
34452, 93934, 93926, 28052, 28060, 93935, 93927, 28053, 28061, 94361, 94337, 28368, 94362, 94364, 94340, 28370, 
94365, 94363, 94338, 28354, 28371
34453, 93935, 93927, 28053, 28061, 31811, 31810, 3285, 3286, 94364, 94340, 28370, 94365, 31848, 31845, 3308, 
31847, 94366, 94341, 28355, 28372
34454, 31723, 31722, 3151, 3152, 93936, 93928, 28054, 28062, 31760, 31759, 3174, 31761, 94368, 94344, 28373, 
94369, 94367, 94342, 28357, 28374
34455, 93936, 93928, 28054, 28062, 93937, 93929, 28055, 28063, 94368, 94344, 28373, 94369, 94371, 94347, 28375, 
94372, 94370, 94345, 28359, 28376
34456, 93937, 93929, 28055, 28063, 93938, 93930, 28056, 28064, 94371, 94347, 28375, 94372, 94374, 94350, 28377, 
94375, 94373, 94348, 28361, 28378
34457, 93938, 93930, 28056, 28064, 93939, 93931, 28057, 28065, 94374, 94350, 28377, 94375, 94377, 94353, 28379, 
94378, 94376, 94351, 28363, 28380
34458, 93939, 93931, 28057, 28065, 93940, 93932, 28058, 28066, 94377, 94353, 28379, 94378, 94380, 94356, 28381, 
94381, 94379, 94354, 28365, 28382
34459, 93940, 93932, 28058, 28066, 93941, 93933, 28059, 28067, 94380, 94356, 28381, 94381, 94383, 94359, 28383, 
94384, 94382, 94357, 28367, 28384
34460, 93941, 93933, 28059, 28067, 93942, 93934, 28060, 28068, 94383, 94359, 28383, 94384, 94386, 94362, 28385, 
94387, 94385, 94360, 28369, 28386
34461, 93942, 93934, 28060, 28068, 93943, 93935, 28061, 28069, 94386, 94362, 28385, 94387, 94389, 94365, 28387, 
94390, 94388, 94363, 28371, 28388
34462, 93943, 93935, 28061, 28069, 31812, 31811, 3286, 3287, 94389, 94365, 28387, 94390, 31850, 31847, 3309, 
31849, 94391, 94366, 28372, 28389
34463, 31724, 31723, 3152, 3153, 93944, 93936, 28062, 28070, 31762, 31761, 3175, 31763, 94393, 94369, 28390, 
94394, 94392, 94367, 28374, 28391
34464, 93944, 93936, 28062, 28070, 93945, 93937, 28063, 28071, 94393, 94369, 28390, 94394, 94396, 94372, 28392, 
94397, 94395, 94370, 28376, 28393
34465, 93945, 93937, 28063, 28071, 93946, 93938, 28064, 28072, 94396, 94372, 28392, 94397, 94399, 94375, 28394, 
94400, 94398, 94373, 28378, 28395
34466, 93946, 93938, 28064, 28072, 93947, 93939, 28065, 28073, 94399, 94375, 28394, 94400, 94402, 94378, 28396, 
94403, 94401, 94376, 28380, 28397
34467, 93947, 93939, 28065, 28073, 93948, 93940, 28066, 28074, 94402, 94378, 28396, 94403, 94405, 94381, 28398, 
94406, 94404, 94379, 28382, 28399
34468, 93948, 93940, 28066, 28074, 93949, 93941, 28067, 28075, 94405, 94381, 28398, 94406, 94408, 94384, 28400, 
94409, 94407, 94382, 28384, 28401
34469, 93949, 93941, 28067, 28075, 93950, 93942, 28068, 28076, 94408, 94384, 28400, 94409, 94411, 94387, 28402, 
94412, 94410, 94385, 28386, 28403
34470, 93950, 93942, 28068, 28076, 93951, 93943, 28069, 28077, 94411, 94387, 28402, 94412, 94414, 94390, 28404, 
94415, 94413, 94388, 28388, 28405
34471, 93951, 93943, 28069, 28077, 31813, 31812, 3287, 3288, 94414, 94390, 28404, 94415, 31852, 31849, 3310, 
31851, 94416, 94391, 28389, 28406
34472, 31725, 31724, 3153, 3154, 93952, 93944, 28070, 28078, 31764, 31763, 3176, 31765, 94418, 94394, 28407, 
94419, 94417, 94392, 28391, 28408
34473, 93952, 93944, 28070, 28078, 93953, 93945, 28071, 28079, 94418, 94394, 28407, 94419, 94421, 94397, 28409, 
94422, 94420, 94395, 28393, 28410
34474, 93953, 93945, 28071, 28079, 93954, 93946, 28072, 28080, 94421, 94397, 28409, 94422, 94424, 94400, 28411, 
94425, 94423, 94398, 28395, 28412
34475, 93954, 93946, 28072, 28080, 93955, 93947, 28073, 28081, 94424, 94400, 28411, 94425, 94427, 94403, 28413, 
94428, 94426, 94401, 28397, 28414
34476, 93955, 93947, 28073, 28081, 93956, 93948, 28074, 28082, 94427, 94403, 28413, 94428, 94430, 94406, 28415, 
94431, 94429, 94404, 28399, 28416
34477, 93956, 93948, 28074, 28082, 93957, 93949, 28075, 28083, 94430, 94406, 28415, 94431, 94433, 94409, 28417, 
94434, 94432, 94407, 28401, 28418
34478, 93957, 93949, 28075, 28083, 93958, 93950, 28076, 28084, 94433, 94409, 28417, 94434, 94436, 94412, 28419, 
94437, 94435, 94410, 28403, 28420
34479, 93958, 93950, 28076, 28084, 93959, 93951, 28077, 28085, 94436, 94412, 28419, 94437, 94439, 94415, 28421, 
94440, 94438, 94413, 28405, 28422
34480, 93959, 93951, 28077, 28085, 31814, 31813, 3288, 3289, 94439, 94415, 28421, 94440, 31854, 31851, 3311, 
31853, 94441, 94416, 28406, 28423
34481, 31726, 31725, 3154, 3155, 93960, 93952, 28078, 28086, 31766, 31765, 3177, 31767, 94443, 94419, 28424, 
94444, 94442, 94417, 28408, 28425
34482, 93960, 93952, 28078, 28086, 93961, 93953, 28079, 28087, 94443, 94419, 28424, 94444, 94446, 94422, 28426, 
94447, 94445, 94420, 28410, 28427
34483, 93961, 93953, 28079, 28087, 93962, 93954, 28080, 28088, 94446, 94422, 28426, 94447, 94449, 94425, 28428, 
94450, 94448, 94423, 28412, 28429
34484, 93962, 93954, 28080, 28088, 93963, 93955, 28081, 28089, 94449, 94425, 28428, 94450, 94452, 94428, 28430, 
94453, 94451, 94426, 28414, 28431
34485, 93963, 93955, 28081, 28089, 93964, 93956, 28082, 28090, 94452, 94428, 28430, 94453, 94455, 94431, 28432, 
94456, 94454, 94429, 28416, 28433
34486, 93964, 93956, 28082, 28090, 93965, 93957, 28083, 28091, 94455, 94431, 28432, 94456, 94458, 94434, 28434, 
94459, 94457, 94432, 28418, 28435
34487, 93965, 93957, 28083, 28091, 93966, 93958, 28084, 28092, 94458, 94434, 28434, 94459, 94461, 94437, 28436, 
94462, 94460, 94435, 28420, 28437
34488, 93966, 93958, 28084, 28092, 93967, 93959, 28085, 28093, 94461, 94437, 28436, 94462, 94464, 94440, 28438, 
94465, 94463, 94438, 28422, 28439
34489, 93967, 93959, 28085, 28093, 31815, 31814, 3289, 3290, 94464, 94440, 28438, 94465, 31856, 31853, 3312, 
31855, 94466, 94441, 28423, 28440
34490, 31727, 31726, 3155, 3156, 93968, 93960, 28086, 28094, 31768, 31767, 3178, 31769, 94468, 94444, 28441, 
94469, 94467, 94442, 28425, 28442
34491, 93968, 93960, 28086, 28094, 93969, 93961, 28087, 28095, 94468, 94444, 28441, 94469, 94471, 94447, 28443, 
94472, 94470, 94445, 28427, 28444
34492, 93969, 93961, 28087, 28095, 93970, 93962, 28088, 28096, 94471, 94447, 28443, 94472, 94474, 94450, 28445, 
94475, 94473, 94448, 28429, 28446
34493, 93970, 93962, 28088, 28096, 93971, 93963, 28089, 28097, 94474, 94450, 28445, 94475, 94477, 94453, 28447, 
94478, 94476, 94451, 28431, 28448
34494, 93971, 93963, 28089, 28097, 93972, 93964, 28090, 28098, 94477, 94453, 28447, 94478, 94480, 94456, 28449, 
94481, 94479, 94454, 28433, 28450
34495, 93972, 93964, 28090, 28098, 93973, 93965, 28091, 28099, 94480, 94456, 28449, 94481, 94483, 94459, 28451, 
94484, 94482, 94457, 28435, 28452
34496, 93973, 93965, 28091, 28099, 93974, 93966, 28092, 28100, 94483, 94459, 28451, 94484, 94486, 94462, 28453, 
94487, 94485, 94460, 28437, 28454
34497, 93974, 93966, 28092, 28100, 93975, 93967, 28093, 28101, 94486, 94462, 28453, 94487, 94489, 94465, 28455, 
94490, 94488, 94463, 28439, 28456
34498, 93975, 93967, 28093, 28101, 31816, 31815, 3290, 3291, 94489, 94465, 28455, 94490, 31858, 31855, 3313, 
31857, 94491, 94466, 28440, 28457
34499, 31728, 31727, 3156, 3157, 93976, 93968, 28094, 28102, 31770, 31769, 3179, 31771, 94493, 94469, 28458, 
94494, 94492, 94467, 28442, 28459
34500, 93976, 93968, 28094, 28102, 93977, 93969, 28095, 28103, 94493, 94469, 28458, 94494, 94496, 94472, 28460, 
94497, 94495, 94470, 28444, 28461
34501, 93977, 93969, 28095, 28103, 93978, 93970, 28096, 28104, 94496, 94472, 28460, 94497, 94499, 94475, 28462, 
94500, 94498, 94473, 28446, 28463
34502, 93978, 93970, 28096, 28104, 93979, 93971, 28097, 28105, 94499, 94475, 28462, 94500, 94502, 94478, 28464, 
94503, 94501, 94476, 28448, 28465
34503, 93979, 93971, 28097, 28105, 93980, 93972, 28098, 28106, 94502, 94478, 28464, 94503, 94505, 94481, 28466, 
94506, 94504, 94479, 28450, 28467
34504, 93980, 93972, 28098, 28106, 93981, 93973, 28099, 28107, 94505, 94481, 28466, 94506, 94508, 94484, 28468, 
94509, 94507, 94482, 28452, 28469
34505, 93981, 93973, 28099, 28107, 93982, 93974, 28100, 28108, 94508, 94484, 28468, 94509, 94511, 94487, 28470, 
94512, 94510, 94485, 28454, 28471
34506, 93982, 93974, 28100, 28108, 93983, 93975, 28101, 28109, 94511, 94487, 28470, 94512, 94514, 94490, 28472, 
94515, 94513, 94488, 28456, 28473
34507, 93983, 93975, 28101, 28109, 31817, 31816, 3291, 3292, 94514, 94490, 28472, 94515, 31860, 31857, 3314, 
31859, 94516, 94491, 28457, 28474
34508, 31729, 31728, 3157, 3158, 93984, 93976, 28102, 28110, 31772, 31771, 3180, 31773, 94518, 94494, 28475, 
94519, 94517, 94492, 28459, 28476
34509, 93984, 93976, 28102, 28110, 93985, 93977, 28103, 28111, 94518, 94494, 28475, 94519, 94521, 94497, 28477, 
94522, 94520, 94495, 28461, 28478
34510, 93985, 93977, 28103, 28111, 93986, 93978, 28104, 28112, 94521, 94497, 28477, 94522, 94524, 94500, 28479, 
94525, 94523, 94498, 28463, 28480
34511, 93986, 93978, 28104, 28112, 93987, 93979, 28105, 28113, 94524, 94500, 28479, 94525, 94527, 94503, 28481, 
94528, 94526, 94501, 28465, 28482
34512, 93987, 93979, 28105, 28113, 93988, 93980, 28106, 28114, 94527, 94503, 28481, 94528, 94530, 94506, 28483, 
94531, 94529, 94504, 28467, 28484
34513, 93988, 93980, 28106, 28114, 93989, 93981, 28107, 28115, 94530, 94506, 28483, 94531, 94533, 94509, 28485, 
94534, 94532, 94507, 28469, 28486
34514, 93989, 93981, 28107, 28115, 93990, 93982, 28108, 28116, 94533, 94509, 28485, 94534, 94536, 94512, 28487, 
94537, 94535, 94510, 28471, 28488
34515, 93990, 93982, 28108, 28116, 93991, 93983, 28109, 28117, 94536, 94512, 28487, 94537, 94539, 94515, 28489, 
94540, 94538, 94513, 28473, 28490
34516, 93991, 93983, 28109, 28117, 31818, 31817, 3292, 3293, 94539, 94515, 28489, 94540, 31862, 31859, 3315, 
31861, 94541, 94516, 28474, 28491
34517, 3740, 31729, 3158, 5, 31919, 93984, 28110, 342, 31774, 31773, 3181, 3741, 94542, 94519, 28492, 
31928, 31927, 94517, 28476, 351
34518, 31919, 93984, 28110, 342, 31920, 93985, 28111, 341, 94542, 94519, 28492, 31928, 94543, 94522, 28493, 
31930, 31929, 94520, 28478, 350
34519, 31920, 93985, 28111, 341, 31921, 93986, 28112, 340, 94543, 94522, 28493, 31930, 94544, 94525, 28494, 
31932, 31931, 94523, 28480, 349
34520, 31921, 93986, 28112, 340, 31922, 93987, 28113, 339, 94544, 94525, 28494, 31932, 94545, 94528, 28495, 
31934, 31933, 94526, 28482, 348
34521, 31922, 93987, 28113, 339, 31923, 93988, 28114, 338, 94545, 94528, 28495, 31934, 94546, 94531, 28496, 
31936, 31935, 94529, 28484, 347
34522, 31923, 93988, 28114, 338, 31924, 93989, 28115, 337, 94546, 94531, 28496, 31936, 94547, 94534, 28497, 
31938, 31937, 94532, 28486, 346
34523, 31924, 93989, 28115, 337, 31925, 93990, 28116, 336, 94547, 94534, 28497, 31938, 94548, 94537, 28498, 
31940, 31939, 94535, 28488, 345
34524, 31925, 93990, 28116, 336, 31926, 93991, 28117, 335, 94548, 94537, 28498, 31940, 94549, 94540, 28499, 
31942, 31941, 94538, 28490, 344
34525, 31926, 93991, 28117, 335, 3791, 31818, 3293, 7, 94549, 94540, 28499, 31942, 31863, 31861, 3316, 
3792, 31943, 94541, 28491, 343
34526, 3743, 105, 3737, 31708, 31952, 3846, 31886, 93816, 3765, 3739, 31730, 31775, 32128, 31911, 93993, 
94550, 32129, 3855, 31895, 93992
34527, 31952, 3846, 31886, 93816, 31953, 3845, 31887, 93817, 32128, 31911, 93993, 94550, 32130, 31912, 93996, 
94551, 32131, 3854, 31897, 93995
34528, 31953, 3845, 31887, 93817, 31954, 3844, 31888, 93818, 32130, 31912, 93996, 94551, 32132, 31913, 93999, 
94552, 32133, 3853, 31899, 93998
34529, 31954, 3844, 31888, 93818, 31955, 3843, 31889, 93819, 32132, 31913, 93999, 94552, 32134, 31914, 94002, 
94553, 32135, 3852, 31901, 94001
34530, 31955, 3843, 31889, 93819, 31956, 3842, 31890, 93820, 32134, 31914, 94002, 94553, 32136, 31915, 94005, 
94554, 32137, 3851, 31903, 94004
34531, 31956, 3842, 31890, 93820, 31957, 3841, 31891, 93821, 32136, 31915, 94005, 94554, 32138, 31916, 94008, 
94555, 32139, 3850, 31905, 94007
34532, 31957, 3841, 31891, 93821, 31958, 3840, 31892, 93822, 32138, 31916, 94008, 94555, 32140, 31917, 94011, 
94556, 32141, 3849, 31907, 94010
34533, 31958, 3840, 31892, 93822, 31959, 3839, 31893, 93823, 32140, 31917, 94011, 94556, 32142, 31918, 94014, 
94557, 32143, 3848, 31909, 94013
34534, 31959, 3839, 31893, 93823, 3794, 107, 3788, 31797, 32142, 31918, 94014, 94557, 3816, 3790, 31820, 
31864, 32144, 3847, 31910, 94016
34535, 3744, 3743, 31708, 31709, 31960, 31952, 93816, 93824, 3766, 31775, 31732, 31776, 32145, 94550, 94018, 
94558, 32146, 32129, 93992, 94017
34536, 31960, 31952, 93816, 93824, 31961, 31953, 93817, 93825, 32145, 94550, 94018, 94558, 32147, 94551, 94021, 
94559, 32148, 32131, 93995, 94020
34537, 31961, 31953, 93817, 93825, 31962, 31954, 93818, 93826, 32147, 94551, 94021, 94559, 32149, 94552, 94024, 
94560, 32150, 32133, 93998, 94023
34538, 31962, 31954, 93818, 93826, 31963, 31955, 93819, 93827, 32149, 94552, 94024, 94560, 32151, 94553, 94027, 
94561, 32152, 32135, 94001, 94026
34539, 31963, 31955, 93819, 93827, 31964, 31956, 93820, 93828, 32151, 94553, 94027, 94561, 32153, 94554, 94030, 
94562, 32154, 32137, 94004, 94029
34540, 31964, 31956, 93820, 93828, 31965, 31957, 93821, 93829, 32153, 94554, 94030, 94562, 32155, 94555, 94033, 
94563, 32156, 32139, 94007, 94032
34541, 31965, 31957, 93821, 93829, 31966, 31958, 93822, 93830, 32155, 94555, 94033, 94563, 32157, 94556, 94036, 
94564, 32158, 32141, 94010, 94035
34542, 31966, 31958, 93822, 93830, 31967, 31959, 93823, 93831, 32157, 94556, 94036, 94564, 32159, 94557, 94039, 
94565, 32160, 32143, 94013, 94038
34543, 31967, 31959, 93823, 93831, 3795, 3794, 31797, 31798, 32159, 94557, 94039, 94565, 3817, 31864, 31822, 
31865, 32161, 32144, 94016, 94041
34544, 3745, 3744, 31709, 31710, 31968, 31960, 93824, 93832, 3767, 31776, 31734, 31777, 32162, 94558, 94043, 
94566, 32163, 32146, 94017, 94042
34545, 31968, 31960, 93824, 93832, 31969, 31961, 93825, 93833, 32162, 94558, 94043, 94566, 32164, 94559, 94046, 
94567, 32165, 32148, 94020, 94045
34546, 31969, 31961, 93825, 93833, 31970, 31962, 93826, 93834, 32164, 94559, 94046, 94567, 32166, 94560, 94049, 
94568, 32167, 32150, 94023, 94048
34547, 31970, 31962, 93826, 93834, 31971, 31963, 93827, 93835, 32166, 94560, 94049, 94568, 32168, 94561, 94052, 
94569, 32169, 32152, 94026, 94051
34548, 31971, 31963, 93827, 93835, 31972, 31964, 93828, 93836, 32168, 94561, 94052, 94569, 32170, 94562, 94055, 
94570, 32171, 32154, 94029, 94054
34549, 31972, 31964, 93828, 93836, 31973, 31965, 93829, 93837, 32170, 94562, 94055, 94570, 32172, 94563, 94058, 
94571, 32173, 32156, 94032, 94057
34550, 31973, 31965, 93829, 93837, 31974, 31966, 93830, 93838, 32172, 94563, 94058, 94571, 32174, 94564, 94061, 
94572, 32175, 32158, 94035, 94060
34551, 31974, 31966, 93830, 93838, 31975, 31967, 93831, 93839, 32174, 94564, 94061, 94572, 32176, 94565, 94064, 
