98047, 0.80434782608696, 0.98478260869565, -0.0375
98048, 0.78260869565217, 0.95869565217391, -0.0375
98049, 0.78260869565217, 0.98478260869565, -0.01875
98050, 0.76086956521739, 0.98478260869565, -0.0375
98051, 0.73913043478261, 0.95869565217391, -0.0375
98052, 0.73913043478261, 0.98478260869565, -0.01875
98053, 0.71739130434783, 0.98478260869565, -0.0375
98054, 0.69565217391304, 0.95869565217391, -0.0375
98055, 0.69565217391304, 0.98478260869565, -0.01875
98056, 0.67391304347826, 0.98478260869565, -0.0375
98057, 0.65217391304348, 0.95869565217391, -0.0375
98058, 0.65217391304348, 0.98478260869565, -0.01875
98059, 0.6304347826087, 0.98478260869565, -0.0375
98060, 0.60869565217391, 0.95869565217391, -0.0375
98061, 0.60869565217391, 0.98478260869565, -0.01875
98062, 0.58695652173913, 0.98478260869565, -0.0375
98063, 0.56521739130435, 0.95869565217391, -0.0375
98064, 0.56521739130435, 0.98478260869565, -0.01875
98065, 0.54347826086956, 0.98478260869565, -0.0375
98066, 0.52173913043478, 0.95869565217391, -0.0375
98067, 0.52173913043478, 0.98478260869565, -0.01875
98068, 0.5, 0.98478260869565, -0.0375
98069, 0.47826086956522, 0.95869565217391, -0.0375
98070, 0.47826086956522, 0.98478260869565, -0.01875
98071, 0.45652173913043, 0.98478260869565, -0.0375
98072, 0.43478260869565, 0.95869565217391, -0.0375
98073, 0.43478260869565, 0.98478260869565, -0.01875
98074, 0.41304347826087, 0.98478260869565, -0.0375
98075, 0.39130434782609, 0.95869565217391, -0.0375
98076, 0.39130434782609, 0.98478260869565, -0.01875
98077, 0.3695652173913, 0.98478260869565, -0.0375
98078, 0.34782608695652, 0.95869565217391, -0.0375
98079, 0.34782608695652, 0.98478260869565, -0.01875
98080, 0.32608695652174, 0.98478260869565, -0.0375
98081, 0.30434782608696, 0.95869565217391, -0.0375
98082, 0.30434782608696, 0.98478260869565, -0.01875
98083, 0.28260869565217, 0.98478260869565, -0.0375
98084, 0.26086956521739, 0.95869565217391, -0.0375
98085, 0.26086956521739, 0.98478260869565, -0.01875
98086, 0.23913043478261, 0.98478260869565, -0.0375
98087, 0.21739130434783, 0.95869565217391, -0.0375
98088, 0.21739130434783, 0.98478260869565, -0.01875
98089, 0.19565217391304, 0.98478260869565, -0.0375
98090, 0.17391304347826, 0.95869565217391, -0.0375
98091, 0.17391304347826, 0.98478260869565, -0.01875
98092, 0.15217391304348, 0.98478260869565, -0.0375
98093, 0.1304347826087, 0.95869565217391, -0.0375
98094, 0.1304347826087, 0.98478260869565, -0.01875
98095, 0.10869565217391, 0.98478260869565, -0.0375
98096, 0.08695652173913, 0.95869565217391, -0.0375
98097, 0.08695652173913, 0.98478260869565, -0.01875
98098, 0.065217391304348, 0.98478260869565, -0.0375
98099, 0.043478260869565, 0.95869565217391, -0.0375
98100, 0.043478260869565, 0.98478260869565, -0.01875
98101, 0.021739130434783, 0.98478260869565, -0.0375
98102, 0.97826086956522, 1.0369565217391, -0.0375
98103, 0.95652173913043, 1.0108695652174, -0.0375
98104, 0.95652173913043, 1.0369565217391, -0.01875
98105, 0.93478260869565, 1.0369565217391, -0.0375
98106, 0.91304347826087, 1.0108695652174, -0.0375
98107, 0.91304347826087, 1.0369565217391, -0.01875
98108, 0.89130434782609, 1.0369565217391, -0.0375
98109, 0.8695652173913, 1.0108695652174, -0.0375
98110, 0.8695652173913, 1.0369565217391, -0.01875
98111, 0.84782608695652, 1.0369565217391, -0.0375
98112, 0.82608695652174, 1.0108695652174, -0.0375
98113, 0.82608695652174, 1.0369565217391, -0.01875
98114, 0.80434782608696, 1.0369565217391, -0.0375
98115, 0.78260869565217, 1.0108695652174, -0.0375
98116, 0.78260869565217, 1.0369565217391, -0.01875
98117, 0.76086956521739, 1.0369565217391, -0.0375
98118, 0.73913043478261, 1.0108695652174, -0.0375
98119, 0.73913043478261, 1.0369565217391, -0.01875
98120, 0.71739130434783, 1.0369565217391, -0.0375
98121, 0.69565217391304, 1.0108695652174, -0.0375
98122, 0.69565217391304, 1.0369565217391, -0.01875
98123, 0.67391304347826, 1.0369565217391, -0.0375
98124, 0.65217391304348, 1.0108695652174, -0.0375
98125, 0.65217391304348, 1.0369565217391, -0.01875
98126, 0.6304347826087, 1.0369565217391, -0.0375
98127, 0.60869565217391, 1.0108695652174, -0.0375
98128, 0.60869565217391, 1.0369565217391, -0.01875
98129, 0.58695652173913, 1.0369565217391, -0.0375
98130, 0.56521739130435, 1.0108695652174, -0.0375
98131, 0.56521739130435, 1.0369565217391, -0.01875
98132, 0.54347826086957, 1.0369565217391, -0.0375
98133, 0.52173913043478, 1.0108695652174, -0.0375
98134, 0.52173913043478, 1.0369565217391, -0.01875
98135, 0.5, 1.0369565217391, -0.0375
98136, 0.47826086956522, 1.0108695652174, -0.0375
98137, 0.47826086956522, 1.0369565217391, -0.01875
98138, 0.45652173913043, 1.0369565217391, -0.0375
98139, 0.43478260869565, 1.0108695652174, -0.0375
98140, 0.43478260869565, 1.0369565217391, -0.01875
98141, 0.41304347826087, 1.0369565217391, -0.0375
98142, 0.39130434782609, 1.0108695652174, -0.0375
98143, 0.39130434782609, 1.0369565217391, -0.01875
98144, 0.3695652173913, 1.0369565217391, -0.0375
98145, 0.34782608695652, 1.0108695652174, -0.0375
98146, 0.34782608695652, 1.0369565217391, -0.01875
98147, 0.32608695652174, 1.0369565217391, -0.0375
98148, 0.30434782608696, 1.0108695652174, -0.0375
98149, 0.30434782608696, 1.0369565217391, -0.01875
98150, 0.28260869565217, 1.0369565217391, -0.0375
98151, 0.26086956521739, 1.0108695652174, -0.0375
98152, 0.26086956521739, 1.0369565217391, -0.01875
98153, 0.23913043478261, 1.0369565217391, -0.0375
98154, 0.21739130434783, 1.0108695652174, -0.0375
98155, 0.21739130434783, 1.0369565217391, -0.01875
98156, 0.19565217391304, 1.0369565217391, -0.0375
98157, 0.17391304347826, 1.0108695652174, -0.0375
98158, 0.17391304347826, 1.0369565217391, -0.01875
98159, 0.15217391304348, 1.0369565217391, -0.0375
98160, 0.1304347826087, 1.0108695652174, -0.0375
98161, 0.1304347826087, 1.0369565217391, -0.01875
98162, 0.10869565217391, 1.0369565217391, -0.0375
98163, 0.08695652173913, 1.0108695652174, -0.0375
98164, 0.08695652173913, 1.0369565217391, -0.01875
98165, 0.065217391304348, 1.0369565217391, -0.0375
98166, 0.043478260869565, 1.0108695652174, -0.0375
98167, 0.043478260869565, 1.0369565217391, -0.01875
98168, 0.021739130434783, 1.0369565217391, -0.0375
98169, 0.97826086956522, 1.0891304347826, -0.0375
98170, 0.95652173913043, 1.0630434782609, -0.0375
98171, 0.95652173913043, 1.0891304347826, -0.01875
98172, 0.93478260869565, 1.0891304347826, -0.0375
98173, 0.91304347826087, 1.0630434782609, -0.0375
98174, 0.91304347826087, 1.0891304347826, -0.01875
98175, 0.89130434782609, 1.0891304347826, -0.0375
98176, 0.8695652173913, 1.0630434782609, -0.0375
98177, 0.8695652173913, 1.0891304347826, -0.01875
98178, 0.84782608695652, 1.0891304347826, -0.0375
98179, 0.82608695652174, 1.0630434782609, -0.0375
98180, 0.82608695652174, 1.0891304347826, -0.01875
98181, 0.80434782608696, 1.0891304347826, -0.0375
98182, 0.78260869565217, 1.0630434782609, -0.0375
98183, 0.78260869565217, 1.0891304347826, -0.01875
98184, 0.76086956521739, 1.0891304347826, -0.0375
98185, 0.73913043478261, 1.0630434782609, -0.0375
98186, 0.73913043478261, 1.0891304347826, -0.01875
98187, 0.71739130434783, 1.0891304347826, -0.0375
98188, 0.69565217391304, 1.0630434782609, -0.0375
98189, 0.69565217391304, 1.0891304347826, -0.01875
98190, 0.67391304347826, 1.0891304347826, -0.0375
98191, 0.65217391304348, 1.0630434782609, -0.0375
98192, 0.65217391304348, 1.0891304347826, -0.01875
98193, 0.6304347826087, 1.0891304347826, -0.0375
98194, 0.60869565217391, 1.0630434782609, -0.0375
98195, 0.60869565217391, 1.0891304347826, -0.01875
98196, 0.58695652173913, 1.0891304347826, -0.0375
98197, 0.56521739130435, 1.0630434782609, -0.0375
98198, 0.56521739130435, 1.0891304347826, -0.01875
98199, 0.54347826086956, 1.0891304347826, -0.0375
98200, 0.52173913043478, 1.0630434782609, -0.0375
98201, 0.52173913043478, 1.0891304347826, -0.01875
98202, 0.5, 1.0891304347826, -0.0375
98203, 0.47826086956522, 1.0630434782609, -0.0375
98204, 0.47826086956522, 1.0891304347826, -0.01875
98205, 0.45652173913043, 1.0891304347826, -0.0375
98206, 0.43478260869565, 1.0630434782609, -0.0375
98207, 0.43478260869565, 1.0891304347826, -0.01875
98208, 0.41304347826087, 1.0891304347826, -0.0375
98209, 0.39130434782609, 1.0630434782609, -0.0375
98210, 0.39130434782609, 1.0891304347826, -0.01875
98211, 0.3695652173913, 1.0891304347826, -0.0375
98212, 0.34782608695652, 1.0630434782609, -0.0375
98213, 0.34782608695652, 1.0891304347826, -0.01875
98214, 0.32608695652174, 1.0891304347826, -0.0375
98215, 0.30434782608696, 1.0630434782609, -0.0375
98216, 0.30434782608696, 1.0891304347826, -0.01875
98217, 0.28260869565217, 1.0891304347826, -0.0375
98218, 0.26086956521739, 1.0630434782609, -0.0375
98219, 0.26086956521739, 1.0891304347826, -0.01875
98220, 0.23913043478261, 1.0891304347826, -0.0375
98221, 0.21739130434783, 1.0630434782609, -0.0375
98222, 0.21739130434783, 1.0891304347826, -0.01875
98223, 0.19565217391304, 1.0891304347826, -0.0375
98224, 0.17391304347826, 1.0630434782609, -0.0375
98225, 0.17391304347826, 1.0891304347826, -0.01875
98226, 0.15217391304348, 1.0891304347826, -0.0375
98227, 0.1304347826087, 1.0630434782609, -0.0375
98228, 0.1304347826087, 1.0891304347826, -0.01875
98229, 0.10869565217391, 1.0891304347826, -0.0375
98230, 0.08695652173913, 1.0630434782609, -0.0375
98231, 0.08695652173913, 1.0891304347826, -0.01875
98232, 0.065217391304348, 1.0891304347826, -0.0375
98233, 0.043478260869565, 1.0630434782609, -0.0375
98234, 0.043478260869565, 1.0891304347826, -0.01875
98235, 0.021739130434783, 1.0891304347826, -0.0375
98236, 0.97826086956522, 1.1413043478261, -0.0375
98237, 0.95652173913044, 1.1152173913043, -0.0375
98238, 0.95652173913043, 1.1413043478261, -0.01875
98239, 0.93478260869565, 1.1413043478261, -0.0375
98240, 0.91304347826087, 1.1152173913043, -0.0375
98241, 0.91304347826087, 1.1413043478261, -0.01875
98242, 0.89130434782609, 1.1413043478261, -0.0375
98243, 0.8695652173913, 1.1152173913043, -0.0375
98244, 0.8695652173913, 1.1413043478261, -0.01875
98245, 0.84782608695652, 1.1413043478261, -0.0375
98246, 0.82608695652174, 1.1152173913043, -0.0375
98247, 0.82608695652174, 1.1413043478261, -0.01875
98248, 0.80434782608696, 1.1413043478261, -0.0375
98249, 0.78260869565217, 1.1152173913043, -0.0375
98250, 0.78260869565217, 1.1413043478261, -0.01875
98251, 0.76086956521739, 1.1413043478261, -0.0375
98252, 0.73913043478261, 1.1152173913043, -0.0375
98253, 0.73913043478261, 1.1413043478261, -0.01875
98254, 0.71739130434783, 1.1413043478261, -0.0375
98255, 0.69565217391304, 1.1152173913043, -0.0375
98256, 0.69565217391304, 1.1413043478261, -0.01875
98257, 0.67391304347826, 1.1413043478261, -0.0375
98258, 0.65217391304348, 1.1152173913043, -0.0375
98259, 0.65217391304348, 1.1413043478261, -0.01875
98260, 0.6304347826087, 1.1413043478261, -0.0375
98261, 0.60869565217391, 1.1152173913043, -0.0375
98262, 0.60869565217391, 1.1413043478261, -0.01875
98263, 0.58695652173913, 1.1413043478261, -0.0375
98264, 0.56521739130435, 1.1152173913043, -0.0375
98265, 0.56521739130435, 1.1413043478261, -0.01875
98266, 0.54347826086957, 1.1413043478261, -0.0375
98267, 0.52173913043478, 1.1152173913043, -0.0375
98268, 0.52173913043478, 1.1413043478261, -0.01875
98269, 0.5, 1.1413043478261, -0.0375
98270, 0.47826086956522, 1.1152173913043, -0.0375
98271, 0.47826086956522, 1.1413043478261, -0.01875
98272, 0.45652173913043, 1.1413043478261, -0.0375
98273, 0.43478260869565, 1.1152173913043, -0.0375
98274, 0.43478260869565, 1.1413043478261, -0.01875
98275, 0.41304347826087, 1.1413043478261, -0.0375
98276, 0.39130434782609, 1.1152173913043, -0.0375
98277, 0.39130434782609, 1.1413043478261, -0.01875
98278, 0.3695652173913, 1.1413043478261, -0.0375
98279, 0.34782608695652, 1.1152173913043, -0.0375
98280, 0.34782608695652, 1.1413043478261, -0.01875
98281, 0.32608695652174, 1.1413043478261, -0.0375
98282, 0.30434782608696, 1.1152173913043, -0.0375
98283, 0.30434782608696, 1.1413043478261, -0.01875
98284, 0.28260869565217, 1.1413043478261, -0.0375
98285, 0.26086956521739, 1.1152173913043, -0.0375
98286, 0.26086956521739, 1.1413043478261, -0.01875
98287, 0.23913043478261, 1.1413043478261, -0.0375
98288, 0.21739130434783, 1.1152173913043, -0.0375
98289, 0.21739130434783, 1.1413043478261, -0.01875
98290, 0.19565217391304, 1.1413043478261, -0.0375
98291, 0.17391304347826, 1.1152173913043, -0.0375
98292, 0.17391304347826, 1.1413043478261, -0.01875
98293, 0.15217391304348, 1.1413043478261, -0.0375
98294, 0.1304347826087, 1.1152173913043, -0.0375
98295, 0.1304347826087, 1.1413043478261, -0.01875
98296, 0.10869565217391, 1.1413043478261, -0.0375
98297, 0.08695652173913, 1.1152173913043, -0.0375
98298, 0.08695652173913, 1.1413043478261, -0.01875
98299, 0.065217391304348, 1.1413043478261, -0.0375
98300, 0.043478260869565, 1.1152173913043, -0.0375
98301, 0.043478260869565, 1.1413043478261, -0.01875
98302, 0.021739130434783, 1.1413043478261, -0.0375
98303, 0.97826086956522, 1.1934782608696, -0.0375
98304, 0.95652173913044, 1.1673913043478, -0.0375
98305, 0.95652173913043, 1.1934782608696, -0.01875
98306, 0.93478260869565, 1.1934782608696, -0.0375
98307, 0.91304347826087, 1.1673913043478, -0.0375
98308, 0.91304347826087, 1.1934782608696, -0.01875
98309, 0.89130434782609, 1.1934782608696, -0.0375
98310, 0.8695652173913, 1.1673913043478, -0.0375
98311, 0.8695652173913, 1.1934782608696, -0.01875
98312, 0.84782608695652, 1.1934782608696, -0.0375
98313, 0.82608695652174, 1.1673913043478, -0.0375
98314, 0.82608695652174, 1.1934782608696, -0.01875
98315, 0.80434782608696, 1.1934782608696, -0.0375
98316, 0.78260869565217, 1.1673913043478, -0.0375
98317, 0.78260869565217, 1.1934782608696, -0.01875
98318, 0.76086956521739, 1.1934782608696, -0.0375
98319, 0.73913043478261, 1.1673913043478, -0.0375
98320, 0.73913043478261, 1.1934782608696, -0.01875
98321, 0.71739130434783, 1.1934782608696, -0.0375
98322, 0.69565217391304, 1.1673913043478, -0.0375
98323, 0.69565217391304, 1.1934782608696, -0.01875
98324, 0.67391304347826, 1.1934782608696, -0.0375
98325, 0.65217391304348, 1.1673913043478, -0.0375
98326, 0.65217391304348, 1.1934782608696, -0.01875
98327, 0.6304347826087, 1.1934782608696, -0.0375
98328, 0.60869565217391, 1.1673913043478, -0.0375
98329, 0.60869565217391, 1.1934782608696, -0.01875
98330, 0.58695652173913, 1.1934782608696, -0.0375
98331, 0.56521739130435, 1.1673913043478, -0.0375
98332, 0.56521739130435, 1.1934782608696, -0.01875
98333, 0.54347826086957, 1.1934782608696, -0.0375
98334, 0.52173913043478, 1.1673913043478, -0.0375
98335, 0.52173913043478, 1.1934782608696, -0.01875
98336, 0.5, 1.1934782608696, -0.0375
98337, 0.47826086956522, 1.1673913043478, -0.0375
98338, 0.47826086956522, 1.1934782608696, -0.01875
98339, 0.45652173913043, 1.1934782608696, -0.0375
98340, 0.43478260869565, 1.1673913043478, -0.0375
98341, 0.43478260869565, 1.1934782608696, -0.01875
98342, 0.41304347826087, 1.1934782608696, -0.0375
98343, 0.39130434782609, 1.1673913043478, -0.0375
98344, 0.39130434782609, 1.1934782608696, -0.01875
98345, 0.3695652173913, 1.1934782608696, -0.0375
98346, 0.34782608695652, 1.1673913043478, -0.0375
98347, 0.34782608695652, 1.1934782608696, -0.01875
98348, 0.32608695652174, 1.1934782608696, -0.0375
98349, 0.30434782608696, 1.1673913043478, -0.0375
98350, 0.30434782608696, 1.1934782608696, -0.01875
98351, 0.28260869565217, 1.1934782608696, -0.0375
98352, 0.26086956521739, 1.1673913043478, -0.0375
98353, 0.26086956521739, 1.1934782608696, -0.01875
98354, 0.23913043478261, 1.1934782608696, -0.0375
98355, 0.21739130434783, 1.1673913043478, -0.0375
98356, 0.21739130434783, 1.1934782608696, -0.01875
98357, 0.19565217391304, 1.1934782608696, -0.0375
98358, 0.17391304347826, 1.1673913043478, -0.0375
98359, 0.17391304347826, 1.1934782608696, -0.01875
98360, 0.15217391304348, 1.1934782608696, -0.0375
98361, 0.1304347826087, 1.1673913043478, -0.0375
98362, 0.1304347826087, 1.1934782608696, -0.01875
98363, 0.10869565217391, 1.1934782608696, -0.0375
98364, 0.08695652173913, 1.1673913043478, -0.0375
98365, 0.08695652173913, 1.1934782608696, -0.01875
98366, 0.065217391304348, 1.1934782608696, -0.0375
98367, 0.043478260869565, 1.1673913043478, -0.0375
98368, 0.043478260869565, 1.1934782608696, -0.01875
98369, 0.021739130434783, 1.1934782608696, -0.0375
98370, 0.97826086956522, 1.245652173913, -0.0375
98371, 0.95652173913043, 1.2195652173913, -0.0375
98372, 0.95652173913043, 1.245652173913, -0.01875
98373, 0.93478260869565, 1.245652173913, -0.0375
98374, 0.91304347826087, 1.2195652173913, -0.0375
98375, 0.91304347826087, 1.245652173913, -0.01875
98376, 0.89130434782609, 1.245652173913, -0.0375
98377, 0.8695652173913, 1.2195652173913, -0.0375
98378, 0.8695652173913, 1.245652173913, -0.01875
98379, 0.84782608695652, 1.245652173913, -0.0375
98380, 0.82608695652174, 1.2195652173913, -0.0375
98381, 0.82608695652174, 1.245652173913, -0.01875
98382, 0.80434782608696, 1.245652173913, -0.0375
98383, 0.78260869565217, 1.2195652173913, -0.0375
98384, 0.78260869565217, 1.245652173913, -0.01875
98385, 0.76086956521739, 1.245652173913, -0.0375
98386, 0.73913043478261, 1.2195652173913, -0.0375
98387, 0.73913043478261, 1.245652173913, -0.01875
98388, 0.71739130434783, 1.245652173913, -0.0375
98389, 0.69565217391304, 1.2195652173913, -0.0375
98390, 0.69565217391304, 1.245652173913, -0.01875
98391, 0.67391304347826, 1.245652173913, -0.0375
98392, 0.65217391304348, 1.2195652173913, -0.0375
98393, 0.65217391304348, 1.245652173913, -0.01875
98394, 0.6304347826087, 1.245652173913, -0.0375
98395, 0.60869565217391, 1.2195652173913, -0.0375
98396, 0.60869565217391, 1.245652173913, -0.01875
98397, 0.58695652173913, 1.245652173913, -0.0375
98398, 0.56521739130435, 1.2195652173913, -0.0375
98399, 0.56521739130435, 1.245652173913, -0.01875
98400, 0.54347826086957, 1.245652173913, -0.0375
98401, 0.52173913043478, 1.2195652173913, -0.0375
98402, 0.52173913043478, 1.245652173913, -0.01875
98403, 0.5, 1.245652173913, -0.0375
98404, 0.47826086956522, 1.2195652173913, -0.0375
98405, 0.47826086956522, 1.245652173913, -0.01875
98406, 0.45652173913043, 1.245652173913, -0.0375
98407, 0.43478260869565, 1.2195652173913, -0.0375
98408, 0.43478260869565, 1.245652173913, -0.01875
98409, 0.41304347826087, 1.245652173913, -0.0375
98410, 0.39130434782609, 1.2195652173913, -0.0375
98411, 0.39130434782609, 1.245652173913, -0.01875
98412, 0.3695652173913, 1.245652173913, -0.0375
98413, 0.34782608695652, 1.2195652173913, -0.0375
98414, 0.34782608695652, 1.245652173913, -0.01875
98415, 0.32608695652174, 1.245652173913, -0.0375
98416, 0.30434782608696, 1.2195652173913, -0.0375
98417, 0.30434782608696, 1.245652173913, -0.01875
98418, 0.28260869565217, 1.245652173913, -0.0375
98419, 0.26086956521739, 1.2195652173913, -0.0375
98420, 0.26086956521739, 1.245652173913, -0.01875
98421, 0.23913043478261, 1.245652173913, -0.0375
98422, 0.21739130434783, 1.2195652173913, -0.0375
98423, 0.21739130434783, 1.245652173913, -0.01875
98424, 0.19565217391304, 1.245652173913, -0.0375
98425, 0.17391304347826, 1.2195652173913, -0.0375
98426, 0.17391304347826, 1.245652173913, -0.01875
98427, 0.15217391304348, 1.245652173913, -0.0375
98428, 0.1304347826087, 1.2195652173913, -0.0375
98429, 0.1304347826087, 1.245652173913, -0.01875
98430, 0.10869565217391, 1.245652173913, -0.0375
98431, 0.08695652173913, 1.2195652173913, -0.0375
98432, 0.08695652173913, 1.245652173913, -0.01875
98433, 0.065217391304348, 1.245652173913, -0.0375
98434, 0.043478260869565, 1.2195652173913, -0.0375
98435, 0.043478260869565, 1.245652173913, -0.01875
98436, 0.021739130434783, 1.245652173913, -0.0375
98437, 0.97826086956522, 1.2978260869565, -0.0375
98438, 0.95652173913043, 1.2717391304348, -0.0375
98439, 0.95652173913043, 1.2978260869565, -0.01875
98440, 0.93478260869565, 1.2978260869565, -0.0375
98441, 0.91304347826087, 1.2717391304348, -0.0375
98442, 0.91304347826087, 1.2978260869565, -0.01875
98443, 0.89130434782609, 1.2978260869565, -0.0375
98444, 0.8695652173913, 1.2717391304348, -0.0375
98445, 0.8695652173913, 1.2978260869565, -0.01875
98446, 0.84782608695652, 1.2978260869565, -0.0375
98447, 0.82608695652174, 1.2717391304348, -0.0375
98448, 0.82608695652174, 1.2978260869565, -0.01875
98449, 0.80434782608696, 1.2978260869565, -0.0375
98450, 0.78260869565217, 1.2717391304348, -0.0375
98451, 0.78260869565217, 1.2978260869565, -0.01875
98452, 0.76086956521739, 1.2978260869565, -0.0375
98453, 0.73913043478261, 1.2717391304348, -0.0375
98454, 0.73913043478261, 1.2978260869565, -0.01875
98455, 0.71739130434783, 1.2978260869565, -0.0375
98456, 0.69565217391304, 1.2717391304348, -0.0375
98457, 0.69565217391304, 1.2978260869565, -0.01875
98458, 0.67391304347826, 1.2978260869565, -0.0375
98459, 0.65217391304348, 1.2717391304348, -0.0375
98460, 0.65217391304348, 1.2978260869565, -0.01875
98461, 0.6304347826087, 1.2978260869565, -0.0375
98462, 0.60869565217391, 1.2717391304348, -0.0375
98463, 0.60869565217391, 1.2978260869565, -0.01875
98464, 0.58695652173913, 1.2978260869565, -0.0375
98465, 0.56521739130435, 1.2717391304348, -0.0375
98466, 0.56521739130435, 1.2978260869565, -0.01875
98467, 0.54347826086957, 1.2978260869565, -0.0375
98468, 0.52173913043478, 1.2717391304348, -0.0375
98469, 0.52173913043478, 1.2978260869565, -0.01875
98470, 0.5, 1.2978260869565, -0.0375
98471, 0.47826086956522, 1.2717391304348, -0.0375
98472, 0.47826086956522, 1.2978260869565, -0.01875
98473, 0.45652173913043, 1.2978260869565, -0.0375
98474, 0.43478260869565, 1.2717391304348, -0.0375
98475, 0.43478260869565, 1.2978260869565, -0.01875
98476, 0.41304347826087, 1.2978260869565, -0.0375
98477, 0.39130434782609, 1.2717391304348, -0.0375
98478, 0.39130434782609, 1.2978260869565, -0.01875
98479, 0.3695652173913, 1.2978260869565, -0.0375
98480, 0.34782608695652, 1.2717391304348, -0.0375
98481, 0.34782608695652, 1.2978260869565, -0.01875
98482, 0.32608695652174, 1.2978260869565, -0.0375
98483, 0.30434782608696, 1.2717391304348, -0.0375
98484, 0.30434782608696, 1.2978260869565, -0.01875
98485, 0.28260869565217, 1.2978260869565, -0.0375
98486, 0.26086956521739, 1.2717391304348, -0.0375
98487, 0.26086956521739, 1.2978260869565, -0.01875
98488, 0.23913043478261, 1.2978260869565, -0.0375
98489, 0.21739130434783, 1.2717391304348, -0.0375
98490, 0.21739130434783, 1.2978260869565, -0.01875
98491, 0.19565217391304, 1.2978260869565, -0.0375
98492, 0.17391304347826, 1.2717391304348, -0.0375
98493, 0.17391304347826, 1.2978260869565, -0.01875
98494, 0.15217391304348, 1.2978260869565, -0.0375
98495, 0.1304347826087, 1.2717391304348, -0.0375
98496, 0.1304347826087, 1.2978260869565, -0.01875
98497, 0.10869565217391, 1.2978260869565, -0.0375
98498, 0.08695652173913, 1.2717391304348, -0.0375
98499, 0.08695652173913, 1.2978260869565, -0.01875
98500, 0.065217391304348, 1.2978260869565, -0.0375
98501, 0.043478260869565, 1.2717391304348, -0.0375
98502, 0.043478260869565, 1.2978260869565, -0.01875
98503, 0.021739130434783, 1.2978260869565, -0.0375
98504, 0.95652173913043, 1.3239130434783, -0.0375
98505, 0.91304347826087, 1.3239130434783, -0.0375
98506, 0.8695652173913, 1.3239130434783, -0.0375
98507, 0.82608695652174, 1.3239130434783, -0.0375
98508, 0.78260869565217, 1.3239130434783, -0.0375
98509, 0.73913043478261, 1.3239130434783, -0.0375
98510, 0.69565217391304, 1.3239130434783, -0.0375
98511, 0.65217391304348, 1.3239130434783, -0.0375
98512, 0.60869565217391, 1.3239130434783, -0.0375
98513, 0.56521739130435, 1.3239130434783, -0.0375
98514, 0.52173913043478, 1.3239130434783, -0.0375
98515, 0.47826086956522, 1.3239130434783, -0.0375
98516, 0.43478260869565, 1.3239130434783, -0.0375
98517, 0.39130434782609, 1.3239130434783, -0.0375
98518, 0.34782608695652, 1.3239130434783, -0.0375
98519, 0.30434782608696, 1.3239130434783, -0.0375
98520, 0.26086956521739, 1.3239130434783, -0.0375
98521, 0.21739130434783, 1.3239130434783, -0.0375
98522, 0.17391304347826, 1.3239130434783, -0.0375
98523, 0.1304347826087, 1.3239130434783, -0.0375
98524, 0.08695652173913, 1.3239130434783, -0.0375
98525, 0.043478260869565, 1.3239130434783, -0.0375
98526, 0.95652173913043, 0.20217391304348, -0.05625
98527, 0.91304347826087, 0.20217391304348, -0.05625
98528, 0.8695652173913, 0.20217391304348, -0.05625
98529, 0.82608695652174, 0.20217391304348, -0.05625
98530, 0.78260869565217, 0.20217391304348, -0.05625
98531, 0.73913043478261, 0.20217391304348, -0.05625
98532, 0.69565217391304, 0.20217391304348, -0.05625
98533, 0.65217391304348, 0.20217391304348, -0.05625
98534, 0.60869565217391, 0.20217391304348, -0.05625
98535, 0.56521739130435, 0.20217391304348, -0.05625
98536, 0.52173913043478, 0.20217391304348, -0.05625
98537, 0.47826086956522, 0.20217391304348, -0.05625
98538, 0.43478260869565, 0.20217391304348, -0.05625
98539, 0.39130434782609, 0.20217391304348, -0.05625
98540, 0.34782608695652, 0.20217391304348, -0.05625
98541, 0.30434782608696, 0.20217391304348, -0.05625
98542, 0.26086956521739, 0.20217391304348, -0.05625
98543, 0.21739130434783, 0.20217391304348, -0.05625
98544, 0.17391304347826, 0.20217391304348, -0.05625
98545, 0.1304347826087, 0.20217391304348, -0.05625
98546, 0.08695652173913, 0.20217391304348, -0.05625
98547, 0.043478260869565, 0.20217391304348, -0.05625
98548, 0.95652173913043, 0.25434782608696, -0.05625
98549, 0.91304347826087, 0.25434782608696, -0.05625
98550, 0.8695652173913, 0.25434782608696, -0.05625
98551, 0.82608695652174, 0.25434782608696, -0.05625
98552, 0.78260869565217, 0.25434782608696, -0.05625
98553, 0.73913043478261, 0.25434782608696, -0.05625
98554, 0.69565217391304, 0.25434782608696, -0.05625
98555, 0.65217391304348, 0.25434782608696, -0.05625
98556, 0.60869565217391, 0.25434782608696, -0.05625
98557, 0.56521739130435, 0.25434782608696, -0.05625
98558, 0.52173913043478, 0.25434782608696, -0.05625
98559, 0.47826086956522, 0.25434782608696, -0.05625
98560, 0.43478260869565, 0.25434782608696, -0.05625
98561, 0.39130434782609, 0.25434782608696, -0.05625
98562, 0.34782608695652, 0.25434782608696, -0.05625
98563, 0.30434782608696, 0.25434782608696, -0.05625
98564, 0.26086956521739, 0.25434782608696, -0.05625
98565, 0.21739130434783, 0.25434782608696, -0.05625
98566, 0.17391304347826, 0.25434782608696, -0.05625
98567, 0.1304347826087, 0.25434782608696, -0.05625
98568, 0.08695652173913, 0.25434782608696, -0.05625
98569, 0.043478260869565, 0.25434782608696, -0.05625
98570, 0.95652173913044, 0.30652173913043, -0.05625
98571, 0.91304347826087, 0.30652173913043, -0.05625
98572, 0.8695652173913, 0.30652173913043, -0.05625
98573, 0.82608695652174, 0.30652173913043, -0.05625
98574, 0.78260869565217, 0.30652173913043, -0.05625
98575, 0.73913043478261, 0.30652173913043, -0.05625
98576, 0.69565217391304, 0.30652173913043, -0.05625
98577, 0.65217391304348, 0.30652173913043, -0.05625
98578, 0.60869565217391, 0.30652173913043, -0.05625
98579, 0.56521739130435, 0.30652173913043, -0.05625
98580, 0.52173913043478, 0.30652173913043, -0.05625
98581, 0.47826086956522, 0.30652173913043, -0.05625
98582, 0.43478260869565, 0.30652173913043, -0.05625
98583, 0.39130434782609, 0.30652173913043, -0.05625
98584, 0.34782608695652, 0.30652173913043, -0.05625
98585, 0.30434782608696, 0.30652173913043, -0.05625
98586, 0.26086956521739, 0.30652173913043, -0.05625
98587, 0.21739130434783, 0.30652173913043, -0.05625
98588, 0.17391304347826, 0.30652173913043, -0.05625
98589, 0.1304347826087, 0.30652173913043, -0.05625
98590, 0.08695652173913, 0.30652173913043, -0.05625
98591, 0.043478260869565, 0.30652173913043, -0.05625
98592, 0.95652173913043, 0.35869565217391, -0.05625
98593, 0.91304347826087, 0.35869565217391, -0.05625
98594, 0.8695652173913, 0.35869565217391, -0.05625
98595, 0.82608695652174, 0.35869565217391, -0.05625
98596, 0.78260869565217, 0.35869565217391, -0.05625
98597, 0.73913043478261, 0.35869565217391, -0.05625
98598, 0.69565217391304, 0.35869565217391, -0.05625
98599, 0.65217391304348, 0.35869565217391, -0.05625
98600, 0.60869565217391, 0.35869565217391, -0.05625
98601, 0.56521739130435, 0.35869565217391, -0.05625
98602, 0.52173913043478, 0.35869565217391, -0.05625
98603, 0.47826086956522, 0.35869565217391, -0.05625
98604, 0.43478260869565, 0.35869565217391, -0.05625
98605, 0.39130434782609, 0.35869565217391, -0.05625
98606, 0.34782608695652, 0.35869565217391, -0.05625
98607, 0.30434782608696, 0.35869565217391, -0.05625
98608, 0.26086956521739, 0.35869565217391, -0.05625
98609, 0.21739130434783, 0.35869565217391, -0.05625
98610, 0.17391304347826, 0.35869565217391, -0.05625
98611, 0.1304347826087, 0.35869565217391, -0.05625
98612, 0.08695652173913, 0.35869565217391, -0.05625
98613, 0.043478260869565, 0.35869565217391, -0.05625
98614, 0.95652173913043, 0.41086956521739, -0.05625
98615, 0.91304347826087, 0.41086956521739, -0.05625
98616, 0.8695652173913, 0.41086956521739, -0.05625
98617, 0.82608695652174, 0.41086956521739, -0.05625
98618, 0.78260869565217, 0.41086956521739, -0.05625
98619, 0.73913043478261, 0.41086956521739, -0.05625
98620, 0.69565217391304, 0.41086956521739, -0.05625
98621, 0.65217391304348, 0.41086956521739, -0.05625
98622, 0.60869565217391, 0.41086956521739, -0.05625
98623, 0.56521739130435, 0.41086956521739, -0.05625
98624, 0.52173913043478, 0.41086956521739, -0.05625
98625, 0.47826086956522, 0.41086956521739, -0.05625
98626, 0.43478260869565, 0.41086956521739, -0.05625
98627, 0.39130434782609, 0.41086956521739, -0.05625
98628, 0.34782608695652, 0.41086956521739, -0.05625
98629, 0.30434782608696, 0.41086956521739, -0.05625
98630, 0.26086956521739, 0.41086956521739, -0.05625
98631, 0.21739130434783, 0.41086956521739, -0.05625
98632, 0.17391304347826, 0.41086956521739, -0.05625
98633, 0.1304347826087, 0.41086956521739, -0.05625
98634, 0.08695652173913, 0.41086956521739, -0.05625
98635, 0.043478260869565, 0.41086956521739, -0.05625
98636, 0.95652173913043, 0.46304347826087, -0.05625
98637, 0.91304347826087, 0.46304347826087, -0.05625
98638, 0.8695652173913, 0.46304347826087, -0.05625
98639, 0.82608695652174, 0.46304347826087, -0.05625
98640, 0.78260869565217, 0.46304347826087, -0.05625
98641, 0.73913043478261, 0.46304347826087, -0.05625
98642, 0.69565217391304, 0.46304347826087, -0.05625
98643, 0.65217391304348, 0.46304347826087, -0.05625
98644, 0.60869565217391, 0.46304347826087, -0.05625
98645, 0.56521739130435, 0.46304347826087, -0.05625
98646, 0.52173913043478, 0.46304347826087, -0.05625
98647, 0.47826086956522, 0.46304347826087, -0.05625
98648, 0.43478260869565, 0.46304347826087, -0.05625
98649, 0.39130434782609, 0.46304347826087, -0.05625
98650, 0.34782608695652, 0.46304347826087, -0.05625
98651, 0.30434782608696, 0.46304347826087, -0.05625
98652, 0.26086956521739, 0.46304347826087, -0.05625
98653, 0.21739130434783, 0.46304347826087, -0.05625
98654, 0.17391304347826, 0.46304347826087, -0.05625
98655, 0.1304347826087, 0.46304347826087, -0.05625
98656, 0.08695652173913, 0.46304347826087, -0.05625
98657, 0.043478260869565, 0.46304347826087, -0.05625
98658, 0.95652173913043, 0.51521739130435, -0.05625
98659, 0.91304347826087, 0.51521739130435, -0.05625
98660, 0.8695652173913, 0.51521739130435, -0.05625
98661, 0.82608695652174, 0.51521739130435, -0.05625
98662, 0.78260869565217, 0.51521739130435, -0.05625
98663, 0.73913043478261, 0.51521739130435, -0.05625
98664, 0.69565217391304, 0.51521739130435, -0.05625
98665, 0.65217391304348, 0.51521739130435, -0.05625
98666, 0.60869565217391, 0.51521739130435, -0.05625
98667, 0.56521739130435, 0.51521739130435, -0.05625
98668, 0.52173913043478, 0.51521739130435, -0.05625
98669, 0.47826086956522, 0.51521739130435, -0.05625
98670, 0.43478260869565, 0.51521739130435, -0.05625
98671, 0.39130434782609, 0.51521739130435, -0.05625
98672, 0.34782608695652, 0.51521739130435, -0.05625
98673, 0.30434782608696, 0.51521739130435, -0.05625
98674, 0.26086956521739, 0.51521739130435, -0.05625
98675, 0.21739130434783, 0.51521739130435, -0.05625
98676, 0.17391304347826, 0.51521739130435, -0.05625
98677, 0.1304347826087, 0.51521739130435, -0.05625
98678, 0.08695652173913, 0.51521739130435, -0.05625
98679, 0.043478260869565, 0.51521739130435, -0.05625
98680, 0.95652173913043, 0.56739130434783, -0.05625
98681, 0.91304347826087, 0.56739130434783, -0.05625
98682, 0.8695652173913, 0.56739130434783, -0.05625
98683, 0.82608695652174, 0.56739130434783, -0.05625
98684, 0.78260869565217, 0.56739130434783, -0.05625
98685, 0.73913043478261, 0.56739130434783, -0.05625
98686, 0.69565217391304, 0.56739130434783, -0.05625
98687, 0.65217391304348, 0.56739130434783, -0.05625
98688, 0.60869565217391, 0.56739130434783, -0.05625
98689, 0.56521739130435, 0.56739130434783, -0.05625
98690, 0.52173913043478, 0.56739130434783, -0.05625
98691, 0.47826086956522, 0.56739130434783, -0.05625
98692, 0.43478260869565, 0.56739130434783, -0.05625
98693, 0.39130434782609, 0.56739130434783, -0.05625
98694, 0.34782608695652, 0.56739130434783, -0.05625
98695, 0.30434782608696, 0.56739130434783, -0.05625
98696, 0.26086956521739, 0.56739130434783, -0.05625
98697, 0.21739130434783, 0.56739130434783, -0.05625
98698, 0.17391304347826, 0.56739130434783, -0.05625
98699, 0.1304347826087, 0.56739130434783, -0.05625
98700, 0.08695652173913, 0.56739130434783, -0.05625
98701, 0.043478260869565, 0.56739130434783, -0.05625
98702, 0.95652173913043, 0.6195652173913, -0.05625
98703, 0.91304347826087, 0.6195652173913, -0.05625
98704, 0.8695652173913, 0.6195652173913, -0.05625
98705, 0.82608695652174, 0.6195652173913, -0.05625
98706, 0.78260869565217, 0.6195652173913, -0.05625
98707, 0.73913043478261, 0.6195652173913, -0.05625
98708, 0.69565217391304, 0.6195652173913, -0.05625
98709, 0.65217391304348, 0.6195652173913, -0.05625
98710, 0.60869565217391, 0.6195652173913, -0.05625
98711, 0.56521739130435, 0.6195652173913, -0.05625
98712, 0.52173913043478, 0.6195652173913, -0.05625
98713, 0.47826086956522, 0.6195652173913, -0.05625
98714, 0.43478260869565, 0.6195652173913, -0.05625
98715, 0.39130434782609, 0.6195652173913, -0.05625
98716, 0.34782608695652, 0.6195652173913, -0.05625
98717, 0.30434782608696, 0.6195652173913, -0.05625
98718, 0.26086956521739, 0.6195652173913, -0.05625
98719, 0.21739130434783, 0.6195652173913, -0.05625
98720, 0.17391304347826, 0.6195652173913, -0.05625
98721, 0.1304347826087, 0.6195652173913, -0.05625
98722, 0.08695652173913, 0.6195652173913, -0.05625
98723, 0.043478260869565, 0.6195652173913, -0.05625
98724, 0.95652173913043, 0.67173913043478, -0.05625
98725, 0.91304347826087, 0.67173913043478, -0.05625
98726, 0.8695652173913, 0.67173913043478, -0.05625
98727, 0.82608695652174, 0.67173913043478, -0.05625
98728, 0.78260869565217, 0.67173913043478, -0.05625
98729, 0.73913043478261, 0.67173913043478, -0.05625
98730, 0.69565217391304, 0.67173913043478, -0.05625
98731, 0.65217391304348, 0.67173913043478, -0.05625
98732, 0.60869565217391, 0.67173913043478, -0.05625
98733, 0.56521739130435, 0.67173913043478, -0.05625
98734, 0.52173913043478, 0.67173913043478, -0.05625
98735, 0.47826086956522, 0.67173913043478, -0.05625
98736, 0.43478260869565, 0.67173913043478, -0.05625
98737, 0.39130434782609, 0.67173913043478, -0.05625
98738, 0.34782608695652, 0.67173913043478, -0.05625
98739, 0.30434782608696, 0.67173913043478, -0.05625
98740, 0.26086956521739, 0.67173913043478, -0.05625
98741, 0.21739130434783, 0.67173913043478, -0.05625
98742, 0.17391304347826, 0.67173913043478, -0.05625
98743, 0.1304347826087, 0.67173913043478, -0.05625
98744, 0.08695652173913, 0.67173913043478, -0.05625
98745, 0.043478260869565, 0.67173913043478, -0.05625
98746, 0.95652173913043, 0.72391304347826, -0.05625
98747, 0.91304347826087, 0.72391304347826, -0.05625
98748, 0.8695652173913, 0.72391304347826, -0.05625
98749, 0.82608695652174, 0.72391304347826, -0.05625
98750, 0.78260869565217, 0.72391304347826, -0.05625
98751, 0.73913043478261, 0.72391304347826, -0.05625
98752, 0.69565217391304, 0.72391304347826, -0.05625
98753, 0.65217391304348, 0.72391304347826, -0.05625
98754, 0.60869565217391, 0.72391304347826, -0.05625
98755, 0.56521739130435, 0.72391304347826, -0.05625
98756, 0.52173913043478, 0.72391304347826, -0.05625
98757, 0.47826086956522, 0.72391304347826, -0.05625
98758, 0.43478260869565, 0.72391304347826, -0.05625
98759, 0.39130434782609, 0.72391304347826, -0.05625
98760, 0.34782608695652, 0.72391304347826, -0.05625
98761, 0.30434782608696, 0.72391304347826, -0.05625
98762, 0.26086956521739, 0.72391304347826, -0.05625
98763, 0.21739130434783, 0.72391304347826, -0.05625
98764, 0.17391304347826, 0.72391304347826, -0.05625
98765, 0.1304347826087, 0.72391304347826, -0.05625
98766, 0.08695652173913, 0.72391304347826, -0.05625
98767, 0.043478260869565, 0.72391304347826, -0.05625
98768, 0.95652173913043, 0.77608695652174, -0.05625
98769, 0.91304347826087, 0.77608695652174, -0.05625
98770, 0.8695652173913, 0.77608695652174, -0.05625
98771, 0.82608695652174, 0.77608695652174, -0.05625
98772, 0.78260869565217, 0.77608695652174, -0.05625
98773, 0.73913043478261, 0.77608695652174, -0.05625
98774, 0.69565217391304, 0.77608695652174, -0.05625
98775, 0.65217391304348, 0.77608695652174, -0.05625
98776, 0.60869565217391, 0.77608695652174, -0.05625
98777, 0.56521739130435, 0.77608695652174, -0.05625
98778, 0.52173913043478, 0.77608695652174, -0.05625
98779, 0.47826086956522, 0.77608695652174, -0.05625
98780, 0.43478260869565, 0.77608695652174, -0.05625
98781, 0.39130434782609, 0.77608695652174, -0.05625
98782, 0.34782608695652, 0.77608695652174, -0.05625
98783, 0.30434782608696, 0.77608695652174, -0.05625
98784, 0.26086956521739, 0.77608695652174, -0.05625
98785, 0.21739130434783, 0.77608695652174, -0.05625
98786, 0.17391304347826, 0.77608695652174, -0.05625
98787, 0.1304347826087, 0.77608695652174, -0.05625
98788, 0.08695652173913, 0.77608695652174, -0.05625
98789, 0.043478260869565, 0.77608695652174, -0.05625
98790, 0.95652173913043, 0.82826086956522, -0.05625
98791, 0.91304347826087, 0.82826086956522, -0.05625
98792, 0.8695652173913, 0.82826086956522, -0.05625
98793, 0.82608695652174, 0.82826086956522, -0.05625
98794, 0.78260869565217, 0.82826086956522, -0.05625
98795, 0.73913043478261, 0.82826086956522, -0.05625
98796, 0.69565217391304, 0.82826086956522, -0.05625
98797, 0.65217391304348, 0.82826086956522, -0.05625
98798, 0.60869565217391, 0.82826086956522, -0.05625
98799, 0.56521739130435, 0.82826086956522, -0.05625
98800, 0.52173913043478, 0.82826086956522, -0.05625
98801, 0.47826086956522, 0.82826086956522, -0.05625
98802, 0.43478260869565, 0.82826086956522, -0.05625
98803, 0.39130434782609, 0.82826086956522, -0.05625
98804, 0.34782608695652, 0.82826086956522, -0.05625
98805, 0.30434782608696, 0.82826086956522, -0.05625
98806, 0.26086956521739, 0.82826086956522, -0.05625
98807, 0.21739130434783, 0.82826086956522, -0.05625
98808, 0.17391304347826, 0.82826086956522, -0.05625
98809, 0.1304347826087, 0.82826086956522, -0.05625
98810, 0.08695652173913, 0.82826086956522, -0.05625
98811, 0.043478260869565, 0.82826086956522, -0.05625
98812, 0.95652173913043, 0.88043478260869, -0.05625
98813, 0.91304347826087, 0.8804347826087, -0.05625
98814, 0.8695652173913, 0.8804347826087, -0.05625
98815, 0.82608695652174, 0.8804347826087, -0.05625
98816, 0.78260869565217, 0.8804347826087, -0.05625
98817, 0.73913043478261, 0.88043478260869, -0.05625
98818, 0.69565217391304, 0.8804347826087, -0.05625
98819, 0.65217391304348, 0.8804347826087, -0.05625
98820, 0.60869565217391, 0.8804347826087, -0.05625
98821, 0.56521739130435, 0.88043478260869, -0.05625
98822, 0.52173913043478, 0.8804347826087, -0.05625
98823, 0.47826086956522, 0.88043478260869, -0.05625
98824, 0.43478260869565, 0.8804347826087, -0.05625
98825, 0.39130434782609, 0.8804347826087, -0.05625
98826, 0.34782608695652, 0.8804347826087, -0.05625
98827, 0.30434782608696, 0.88043478260869, -0.05625
98828, 0.26086956521739, 0.8804347826087, -0.05625
98829, 0.21739130434783, 0.8804347826087, -0.05625
98830, 0.17391304347826, 0.8804347826087, -0.05625
98831, 0.1304347826087, 0.8804347826087, -0.05625
98832, 0.08695652173913, 0.8804347826087, -0.05625
98833, 0.043478260869565, 0.8804347826087, -0.05625
98834, 0.95652173913043, 0.93260869565217, -0.05625
98835, 0.91304347826087, 0.93260869565217, -0.05625
98836, 0.8695652173913, 0.93260869565217, -0.05625
98837, 0.82608695652174, 0.93260869565217, -0.05625
98838, 0.78260869565217, 0.93260869565217, -0.05625
98839, 0.73913043478261, 0.93260869565217, -0.05625
98840, 0.69565217391304, 0.93260869565217, -0.05625
98841, 0.65217391304348, 0.93260869565217, -0.05625
98842, 0.60869565217391, 0.93260869565217, -0.05625
98843, 0.56521739130435, 0.93260869565217, -0.05625
98844, 0.52173913043478, 0.93260869565217, -0.05625
98845, 0.47826086956522, 0.93260869565217, -0.05625
98846, 0.43478260869565, 0.93260869565217, -0.05625
98847, 0.39130434782609, 0.93260869565217, -0.05625
98848, 0.34782608695652, 0.93260869565217, -0.05625
98849, 0.30434782608696, 0.93260869565217, -0.05625
98850, 0.26086956521739, 0.93260869565217, -0.05625
98851, 0.21739130434783, 0.93260869565217, -0.05625
98852, 0.17391304347826, 0.93260869565217, -0.05625
98853, 0.1304347826087, 0.93260869565217, -0.05625
98854, 0.08695652173913, 0.93260869565217, -0.05625
98855, 0.043478260869565, 0.93260869565217, -0.05625
98856, 0.95652173913043, 0.98478260869565, -0.05625
98857, 0.91304347826087, 0.98478260869565, -0.05625
98858, 0.8695652173913, 0.98478260869565, -0.05625
98859, 0.82608695652174, 0.98478260869565, -0.05625
98860, 0.78260869565217, 0.98478260869565, -0.05625
98861, 0.73913043478261, 0.98478260869565, -0.05625
98862, 0.69565217391304, 0.98478260869565, -0.05625
98863, 0.65217391304348, 0.98478260869565, -0.05625
98864, 0.60869565217391, 0.98478260869565, -0.05625
98865, 0.56521739130435, 0.98478260869565, -0.05625
98866, 0.52173913043478, 0.98478260869565, -0.05625
98867, 0.47826086956522, 0.98478260869565, -0.05625
98868, 0.43478260869565, 0.98478260869565, -0.05625
98869, 0.39130434782609, 0.98478260869565, -0.05625
98870, 0.34782608695652, 0.98478260869565, -0.05625
98871, 0.30434782608696, 0.98478260869565, -0.05625
98872, 0.26086956521739, 0.98478260869565, -0.05625
98873, 0.21739130434783, 0.98478260869565, -0.05625
98874, 0.17391304347826, 0.98478260869565, -0.05625
98875, 0.1304347826087, 0.98478260869565, -0.05625
98876, 0.08695652173913, 0.98478260869565, -0.05625
98877, 0.043478260869565, 0.98478260869565, -0.05625
98878, 0.95652173913043, 1.0369565217391, -0.05625
98879, 0.91304347826087, 1.0369565217391, -0.05625
98880, 0.8695652173913, 1.0369565217391, -0.05625
98881, 0.82608695652174, 1.0369565217391, -0.05625
98882, 0.78260869565217, 1.0369565217391, -0.05625
98883, 0.73913043478261, 1.0369565217391, -0.05625
98884, 0.69565217391304, 1.0369565217391, -0.05625
98885, 0.65217391304348, 1.0369565217391, -0.05625
98886, 0.60869565217391, 1.0369565217391, -0.05625
98887, 0.56521739130435, 1.0369565217391, -0.05625
98888, 0.52173913043478, 1.0369565217391, -0.05625
98889, 0.47826086956522, 1.0369565217391, -0.05625
98890, 0.43478260869565, 1.0369565217391, -0.05625
98891, 0.39130434782609, 1.0369565217391, -0.05625
98892, 0.34782608695652, 1.0369565217391, -0.05625
98893, 0.30434782608696, 1.0369565217391, -0.05625
98894, 0.26086956521739, 1.0369565217391, -0.05625
98895, 0.21739130434783, 1.0369565217391, -0.05625
98896, 0.17391304347826, 1.0369565217391, -0.05625
98897, 0.1304347826087, 1.0369565217391, -0.05625
98898, 0.08695652173913, 1.0369565217391, -0.05625
98899, 0.043478260869565, 1.0369565217391, -0.05625
98900, 0.95652173913043, 1.0891304347826, -0.05625
98901, 0.91304347826087, 1.0891304347826, -0.05625
98902, 0.8695652173913, 1.0891304347826, -0.05625
98903, 0.82608695652174, 1.0891304347826, -0.05625
98904, 0.78260869565217, 1.0891304347826, -0.05625
98905, 0.73913043478261, 1.0891304347826, -0.05625
98906, 0.69565217391304, 1.0891304347826, -0.05625
98907, 0.65217391304348, 1.0891304347826, -0.05625
98908, 0.60869565217391, 1.0891304347826, -0.05625
98909, 0.56521739130435, 1.0891304347826, -0.05625
98910, 0.52173913043478, 1.0891304347826, -0.05625
98911, 0.47826086956522, 1.0891304347826, -0.05625
98912, 0.43478260869565, 1.0891304347826, -0.05625
98913, 0.39130434782609, 1.0891304347826, -0.05625
98914, 0.34782608695652, 1.0891304347826, -0.05625
98915, 0.30434782608696, 1.0891304347826, -0.05625
98916, 0.26086956521739, 1.0891304347826, -0.05625
98917, 0.21739130434783, 1.0891304347826, -0.05625
98918, 0.17391304347826, 1.0891304347826, -0.05625
98919, 0.1304347826087, 1.0891304347826, -0.05625
98920, 0.08695652173913, 1.0891304347826, -0.05625
98921, 0.043478260869565, 1.0891304347826, -0.05625
98922, 0.95652173913043, 1.1413043478261, -0.05625
98923, 0.91304347826087, 1.1413043478261, -0.05625
98924, 0.8695652173913, 1.1413043478261, -0.05625
98925, 0.82608695652174, 1.1413043478261, -0.05625
98926, 0.78260869565217, 1.1413043478261, -0.05625
98927, 0.73913043478261, 1.1413043478261, -0.05625
98928, 0.69565217391304, 1.1413043478261, -0.05625
98929, 0.65217391304348, 1.1413043478261, -0.05625
98930, 0.60869565217391, 1.1413043478261, -0.05625
98931, 0.56521739130435, 1.1413043478261, -0.05625
98932, 0.52173913043478, 1.1413043478261, -0.05625
98933, 0.47826086956522, 1.1413043478261, -0.05625
98934, 0.43478260869565, 1.1413043478261, -0.05625
98935, 0.39130434782609, 1.1413043478261, -0.05625
98936, 0.34782608695652, 1.1413043478261, -0.05625
98937, 0.30434782608696, 1.1413043478261, -0.05625
98938, 0.26086956521739, 1.1413043478261, -0.05625
98939, 0.21739130434783, 1.1413043478261, -0.05625
98940, 0.17391304347826, 1.1413043478261, -0.05625
98941, 0.1304347826087, 1.1413043478261, -0.05625
98942, 0.08695652173913, 1.1413043478261, -0.05625
98943, 0.043478260869565, 1.1413043478261, -0.05625
98944, 0.95652173913043, 1.1934782608696, -0.05625
98945, 0.91304347826087, 1.1934782608696, -0.05625
98946, 0.8695652173913, 1.1934782608696, -0.05625
98947, 0.82608695652174, 1.1934782608696, -0.05625
98948, 0.78260869565217, 1.1934782608696, -0.05625
98949, 0.73913043478261, 1.1934782608696, -0.05625
98950, 0.69565217391304, 1.1934782608696, -0.05625
98951, 0.65217391304348, 1.1934782608696, -0.05625
98952, 0.60869565217391, 1.1934782608696, -0.05625
98953, 0.56521739130435, 1.1934782608696, -0.05625
98954, 0.52173913043478, 1.1934782608696, -0.05625
98955, 0.47826086956522, 1.1934782608696, -0.05625
98956, 0.43478260869565, 1.1934782608696, -0.05625
98957, 0.39130434782609, 1.1934782608696, -0.05625
98958, 0.34782608695652, 1.1934782608696, -0.05625
98959, 0.30434782608696, 1.1934782608696, -0.05625
98960, 0.26086956521739, 1.1934782608696, -0.05625
98961, 0.21739130434783, 1.1934782608696, -0.05625
98962, 0.17391304347826, 1.1934782608696, -0.05625
98963, 0.1304347826087, 1.1934782608696, -0.05625
98964, 0.08695652173913, 1.1934782608696, -0.05625
98965, 0.043478260869565, 1.1934782608696, -0.05625
98966, 0.95652173913043, 1.245652173913, -0.05625
98967, 0.91304347826087, 1.245652173913, -0.05625
98968, 0.8695652173913, 1.245652173913, -0.05625
98969, 0.82608695652174, 1.245652173913, -0.05625
98970, 0.78260869565217, 1.245652173913, -0.05625
98971, 0.73913043478261, 1.245652173913, -0.05625
98972, 0.69565217391304, 1.245652173913, -0.05625
98973, 0.65217391304348, 1.245652173913, -0.05625
98974, 0.60869565217391, 1.245652173913, -0.05625
98975, 0.56521739130435, 1.245652173913, -0.05625
98976, 0.52173913043478, 1.245652173913, -0.05625
98977, 0.47826086956522, 1.245652173913, -0.05625
98978, 0.43478260869565, 1.245652173913, -0.05625
98979, 0.39130434782609, 1.245652173913, -0.05625
98980, 0.34782608695652, 1.245652173913, -0.05625
98981, 0.30434782608696, 1.245652173913, -0.05625
98982, 0.26086956521739, 1.245652173913, -0.05625
98983, 0.21739130434783, 1.245652173913, -0.05625
98984, 0.17391304347826, 1.245652173913, -0.05625
98985, 0.1304347826087, 1.245652173913, -0.05625
98986, 0.08695652173913, 1.245652173913, -0.05625
98987, 0.043478260869565, 1.245652173913, -0.05625
98988, 0.95652173913043, 1.2978260869565, -0.05625
98989, 0.91304347826087, 1.2978260869565, -0.05625
98990, 0.8695652173913, 1.2978260869565, -0.05625
98991, 0.82608695652174, 1.2978260869565, -0.05625
98992, 0.78260869565217, 1.2978260869565, -0.05625
98993, 0.73913043478261, 1.2978260869565, -0.05625
98994, 0.69565217391304, 1.2978260869565, -0.05625
98995, 0.65217391304348, 1.2978260869565, -0.05625
98996, 0.60869565217391, 1.2978260869565, -0.05625
98997, 0.56521739130435, 1.2978260869565, -0.05625
98998, 0.52173913043478, 1.2978260869565, -0.05625
98999, 0.47826086956522, 1.2978260869565, -0.05625
99000, 0.43478260869565, 1.2978260869565, -0.05625
99001, 0.39130434782609, 1.2978260869565, -0.05625
99002, 0.34782608695652, 1.2978260869565, -0.05625
99003, 0.30434782608696, 1.2978260869565, -0.05625
99004, 0.26086956521739, 1.2978260869565, -0.05625
99005, 0.21739130434783, 1.2978260869565, -0.05625
99006, 0.17391304347826, 1.2978260869565, -0.05625
99007, 0.1304347826087, 1.2978260869565, -0.05625
99008, 0.08695652173913, 1.2978260869565, -0.05625
99009, 0.043478260869565, 1.2978260869565, -0.05625
99010, 1.0375, 0.20217391304348, -0.0375
99011, 1.0375, 0.25434782608696, -0.0375
99012, 1.0375, 0.30652173913043, -0.0375
99013, 1.0375, 0.35869565217391, -0.0375
99014, 1.0375, 0.41086956521739, -0.0375
99015, 1.0375, 0.46304347826087, -0.0375
99016, 1.0375, 0.51521739130435, -0.0375
99017, 1.0375, 0.56739130434783, -0.0375
99018, 1.0375, 0.6195652173913, -0.0375
99019, 1.0375, 0.67173913043478, -0.0375
99020, 1.0375, 0.72391304347826, -0.0375
99021, 1.0375, 0.77608695652174, -0.0375
99022, 1.0375, 0.82826086956522, -0.0375
99023, 1.0375, 0.8804347826087, -0.0375
99024, 1.0375, 0.93260869565217, -0.0375
99025, 1.0375, 0.98478260869565, -0.0375
99026, 1.0375, 1.0369565217391, -0.0375
99027, 1.0375, 1.0891304347826, -0.0375
99028, 1.0375, 1.1413043478261, -0.0375
99029, 1.0375, 1.1934782608696, -0.0375
99030, 1.0375, 1.245652173913, -0.0375
99031, 1.0375, 1.2978260869565, -0.0375
99032, 1.0375, 0.17608695652174, -0.0375
99033, 1.01875, 0.20217391304348, -0.0375
99034, 1.0375, 0.20217391304348, -0.01875
99035, 1.0375, 0.22826086956522, -0.0375
99036, 1.01875, 0.25434782608696, -0.0375
99037, 1.0375, 0.25434782608696, -0.01875
99038, 1.0375, 0.2804347826087, -0.0375
99039, 1.01875, 0.30652173913043, -0.0375
99040, 1.0375, 0.30652173913043, -0.01875
99041, 1.0375, 0.33260869565217, -0.0375
99042, 1.01875, 0.35869565217391, -0.0375
99043, 1.0375, 0.35869565217391, -0.01875
99044, 1.0375, 0.38478260869565, -0.0375
99045, 1.01875, 0.41086956521739, -0.0375
99046, 1.0375, 0.41086956521739, -0.01875
99047, 1.0375, 0.43695652173913, -0.0375
99048, 1.01875, 0.46304347826087, -0.0375
99049, 1.0375, 0.46304347826087, -0.01875
99050, 1.0375, 0.48913043478261, -0.0375
99051, 1.01875, 0.51521739130435, -0.0375
99052, 1.0375, 0.51521739130435, -0.01875
99053, 1.0375, 0.54130434782609, -0.0375
99054, 1.01875, 0.56739130434783, -0.0375
99055, 1.0375, 0.56739130434783, -0.01875
99056, 1.0375, 0.59347826086956, -0.0375
99057, 1.01875, 0.6195652173913, -0.0375
99058, 1.0375, 0.6195652173913, -0.01875
99059, 1.0375, 0.64565217391304, -0.0375
99060, 1.01875, 0.67173913043478, -0.0375
99061, 1.0375, 0.67173913043478, -0.01875
99062, 1.0375, 0.69782608695652, -0.0375
99063, 1.01875, 0.72391304347826, -0.0375
99064, 1.0375, 0.72391304347826, -0.01875
99065, 1.0375, 0.75, -0.0375
99066, 1.01875, 0.77608695652174, -0.0375
99067, 1.0375, 0.77608695652174, -0.01875
99068, 1.0375, 0.80217391304348, -0.0375
99069, 1.01875, 0.82826086956522, -0.0375
99070, 1.0375, 0.82826086956522, -0.01875
99071, 1.0375, 0.85434782608696, -0.0375
99072, 1.01875, 0.8804347826087, -0.0375
99073, 1.0375, 0.8804347826087, -0.01875
99074, 1.0375, 0.90652173913043, -0.0375
99075, 1.01875, 0.93260869565217, -0.0375
99076, 1.0375, 0.93260869565217, -0.01875
99077, 1.0375, 0.95869565217391, -0.0375
99078, 1.01875, 0.98478260869565, -0.0375
99079, 1.0375, 0.98478260869565, -0.01875
99080, 1.0375, 1.0108695652174, -0.0375
99081, 1.01875, 1.0369565217391, -0.0375
99082, 1.0375, 1.0369565217391, -0.01875
99083, 1.0375, 1.0630434782609, -0.0375
99084, 1.01875, 1.0891304347826, -0.0375
99085, 1.0375, 1.0891304347826, -0.01875
99086, 1.0375, 1.1152173913043, -0.0375
99087, 1.01875, 1.1413043478261, -0.0375
99088, 1.0375, 1.1413043478261, -0.01875
99089, 1.0375, 1.1673913043478, -0.0375
99090, 1.01875, 1.1934782608696, -0.0375
99091, 1.0375, 1.1934782608696, -0.01875
99092, 1.0375, 1.2195652173913, -0.0375
99093, 1.01875, 1.245652173913, -0.0375
99094, 1.0375, 1.245652173913, -0.01875
99095, 1.0375, 1.2717391304348, -0.0375
99096, 1.01875, 1.2978260869565, -0.0375
99097, 1.0375, 1.2978260869565, -0.01875
99098, 1.0375, 1.3239130434783, -0.0375
99099, 1.05625, 0.20217391304348, -0.0375
99100, 1.05625, 0.25434782608696, -0.0375
99101, 1.05625, 0.30652173913043, -0.0375
99102, 1.05625, 0.35869565217391, -0.0375
99103, 1.05625, 0.41086956521739, -0.0375
99104, 1.05625, 0.46304347826087, -0.0375
99105, 1.05625, 0.51521739130435, -0.0375
99106, 1.05625, 0.56739130434783, -0.0375
99107, 1.05625, 0.6195652173913, -0.0375
99108, 1.05625, 0.67173913043478, -0.0375
99109, 1.05625, 0.72391304347826, -0.0375
99110, 1.05625, 0.77608695652174, -0.0375
99111, 1.05625, 0.82826086956522, -0.0375
99112, 1.05625, 0.8804347826087, -0.0375
99113, 1.05625, 0.93260869565217, -0.0375
99114, 1.05625, 0.98478260869565, -0.0375
99115, 1.05625, 1.0369565217391, -0.0375
99116, 1.05625, 1.0891304347826, -0.0375
99117, 1.05625, 1.1413043478261, -0.0375
99118, 1.05625, 1.1934782608696, -0.0375
99119, 1.05625, 1.245652173913, -0.0375
99120, 1.05625, 1.2978260869565, -0.0375
99121, 1.0375, 0.20217391304348, -0.05625
99122, 1.0375, 0.25434782608696, -0.05625
99123, 1.0375, 0.30652173913043, -0.05625
99124, 1.0375, 0.35869565217391, -0.05625
99125, 1.0375, 0.41086956521739, -0.05625
99126, 1.0375, 0.46304347826087, -0.05625
99127, 1.0375, 0.51521739130435, -0.05625
99128, 1.0375, 0.56739130434783, -0.05625
99129, 1.0375, 0.6195652173913, -0.05625
99130, 1.0375, 0.67173913043478, -0.05625
99131, 1.0375, 0.72391304347826, -0.05625
99132, 1.0375, 0.77608695652174, -0.05625
99133, 1.0375, 0.82826086956522, -0.05625
99134, 1.0375, 0.8804347826087, -0.05625
99135, 1.0375, 0.93260869565217, -0.05625
99136, 1.0375, 0.98478260869565, -0.05625
99137, 1.0375, 1.0369565217391, -0.05625
99138, 1.0375, 1.0891304347826, -0.05625
99139, 1.0375, 1.1413043478261, -0.05625
99140, 1.0375, 1.1934782608696, -0.05625
99141, 1.0375, 1.245652173913, -0.05625
99142, 1.0375, 1.2978260869565, -0.05625
99143, 1.1625, 1.2978260869565, -0.0375
99144, 1.1625, 1.245652173913, -0.0375
99145, 1.1625, 1.1934782608696, -0.0375
99146, 1.1625, 1.1413043478261, -0.0375
99147, 1.1625, 1.0891304347826, -0.0375
99148, 1.1625, 1.0369565217391, -0.0375
99149, 1.1625, 0.98478260869565, -0.0375
99150, 1.1625, 0.93260869565218, -0.0375
99151, 1.1625, 0.8804347826087, -0.0375
99152, 1.1625, 0.82826086956522, -0.0375
99153, 1.1625, 0.77608695652174, -0.0375
99154, 1.1625, 0.72391304347826, -0.0375
99155, 1.1625, 0.67173913043478, -0.0375
99156, 1.1625, 0.6195652173913, -0.0375
99157, 1.1625, 0.56739130434783, -0.0375
99158, 1.1625, 0.51521739130435, -0.0375
99159, 1.1625, 0.46304347826087, -0.0375
99160, 1.1625, 0.41086956521739, -0.0375
99161, 1.1625, 0.35869565217391, -0.0375
99162, 1.1625, 0.30652173913043, -0.0375
99163, 1.1625, 0.25434782608696, -0.0375
99164, 1.1625, 0.20217391304348, -0.0375
99165, 1.1625, 1.3239130434783, -0.0375
99166, 1.18125, 1.2978260869565, -0.0375
99167, 1.1625, 1.2978260869565, -0.01875
99168, 1.1625, 1.2717391304348, -0.0375
99169, 1.18125, 1.245652173913, -0.0375
99170, 1.1625, 1.245652173913, -0.01875
99171, 1.1625, 1.2195652173913, -0.0375
99172, 1.18125, 1.1934782608696, -0.0375
99173, 1.1625, 1.1934782608696, -0.01875
99174, 1.1625, 1.1673913043478, -0.0375
99175, 1.18125, 1.1413043478261, -0.0375
99176, 1.1625, 1.1413043478261, -0.01875
99177, 1.1625, 1.1152173913043, -0.0375
99178, 1.18125, 1.0891304347826, -0.0375
99179, 1.1625, 1.0891304347826, -0.01875
99180, 1.1625, 1.0630434782609, -0.0375
99181, 1.18125, 1.0369565217391, -0.0375
99182, 1.1625, 1.0369565217391, -0.01875
99183, 1.1625, 1.0108695652174, -0.0375
99184, 1.18125, 0.98478260869565, -0.0375
99185, 1.1625, 0.98478260869565, -0.01875
99186, 1.1625, 0.95869565217391, -0.0375
99187, 1.18125, 0.93260869565217, -0.0375
99188, 1.1625, 0.93260869565217, -0.01875
99189, 1.1625, 0.90652173913044, -0.0375
99190, 1.18125, 0.8804347826087, -0.0375
99191, 1.1625, 0.8804347826087, -0.01875
99192, 1.1625, 0.85434782608696, -0.0375
99193, 1.18125, 0.82826086956522, -0.0375
99194, 1.1625, 0.82826086956522, -0.01875
99195, 1.1625, 0.80217391304348, -0.0375
99196, 1.18125, 0.77608695652174, -0.0375
99197, 1.1625, 0.77608695652174, -0.01875
99198, 1.1625, 0.75, -0.0375
99199, 1.18125, 0.72391304347826, -0.0375
99200, 1.1625, 0.72391304347826, -0.01875
99201, 1.1625, 0.69782608695652, -0.0375
99202, 1.18125, 0.67173913043478, -0.0375
99203, 1.1625, 0.67173913043478, -0.01875
99204, 1.1625, 0.64565217391304, -0.0375
99205, 1.18125, 0.6195652173913, -0.0375
99206, 1.1625, 0.61956521739131, -0.01875
99207, 1.1625, 0.59347826086957, -0.0375
99208, 1.18125, 0.56739130434783, -0.0375
99209, 1.1625, 0.56739130434783, -0.01875
99210, 1.1625, 0.54130434782609, -0.0375
99211, 1.18125, 0.51521739130435, -0.0375
99212, 1.1625, 0.51521739130435, -0.01875
99213, 1.1625, 0.48913043478261, -0.0375
99214, 1.18125, 0.46304347826087, -0.0375
99215, 1.1625, 0.46304347826087, -0.01875
99216, 1.1625, 0.43695652173913, -0.0375
99217, 1.18125, 0.41086956521739, -0.0375
99218, 1.1625, 0.41086956521739, -0.01875
99219, 1.1625, 0.38478260869565, -0.0375
99220, 1.18125, 0.35869565217391, -0.0375
99221, 1.1625, 0.35869565217391, -0.01875
99222, 1.1625, 0.33260869565217, -0.0375
99223, 1.18125, 0.30652173913044, -0.0375
99224, 1.1625, 0.30652173913044, -0.01875
99225, 1.1625, 0.2804347826087, -0.0375
99226, 1.18125, 0.25434782608696, -0.0375
99227, 1.1625, 0.25434782608696, -0.01875
99228, 1.1625, 0.22826086956522, -0.0375
99229, 1.18125, 0.20217391304348, -0.0375
99230, 1.1625, 0.20217391304348, -0.01875
99231, 1.1625, 0.17608695652174, -0.0375
99232, 1.14375, 1.2978260869565, -0.0375
99233, 1.14375, 1.245652173913, -0.0375
99234, 1.14375, 1.1934782608696, -0.0375
99235, 1.14375, 1.1413043478261, -0.0375
99236, 1.14375, 1.0891304347826, -0.0375
99237, 1.14375, 1.0369565217391, -0.0375
99238, 1.14375, 0.98478260869565, -0.0375
99239, 1.14375, 0.93260869565217, -0.0375
99240, 1.14375, 0.8804347826087, -0.0375
99241, 1.14375, 0.82826086956522, -0.0375
99242, 1.14375, 0.77608695652174, -0.0375
99243, 1.14375, 0.72391304347826, -0.0375
99244, 1.14375, 0.67173913043478, -0.0375
99245, 1.14375, 0.6195652173913, -0.0375
99246, 1.14375, 0.56739130434783, -0.0375
99247, 1.14375, 0.51521739130435, -0.0375
99248, 1.14375, 0.46304347826087, -0.0375
99249, 1.14375, 0.41086956521739, -0.0375
99250, 1.14375, 0.35869565217391, -0.0375
99251, 1.14375, 0.30652173913044, -0.0375
99252, 1.14375, 0.25434782608696, -0.0375
99253, 1.14375, 0.20217391304348, -0.0375
99254, 1.1625, 1.2978260869565, -0.05625
99255, 1.1625, 1.245652173913, -0.05625
99256, 1.1625, 1.1934782608696, -0.05625
99257, 1.1625, 1.1413043478261, -0.05625
99258, 1.1625, 1.0891304347826, -0.05625
99259, 1.1625, 1.0369565217391, -0.05625
99260, 1.1625, 0.98478260869565, -0.05625
99261, 1.1625, 0.93260869565217, -0.05625
99262, 1.1625, 0.8804347826087, -0.05625
99263, 1.1625, 0.82826086956522, -0.05625
99264, 1.1625, 0.77608695652174, -0.05625
99265, 1.1625, 0.72391304347826, -0.05625
99266, 1.1625, 0.67173913043478, -0.05625
99267, 1.1625, 0.61956521739131, -0.05625
99268, 1.1625, 0.56739130434783, -0.05625
99269, 1.1625, 0.51521739130435, -0.05625
99270, 1.1625, 0.46304347826087, -0.05625
99271, 1.1625, 0.41086956521739, -0.05625
99272, 1.1625, 0.35869565217391, -0.05625
99273, 1.1625, 0.30652173913044, -0.05625
99274, 1.1625, 0.25434782608696, -0.05625
99275, 1.1625, 0.20217391304348, -0.05625
99276, 1.2434782608696, 1.2978260869565, -0.0375
99277, 1.2869565217391, 1.2978260869565, -0.0375
99278, 1.3304347826087, 1.2978260869565, -0.0375
99279, 1.3739130434783, 1.2978260869565, -0.0375
99280, 1.4173913043478, 1.2978260869565, -0.0375
99281, 1.4608695652174, 1.2978260869565, -0.0375
99282, 1.504347826087, 1.2978260869565, -0.0375
99283, 1.5478260869565, 1.2978260869565, -0.0375
99284, 1.5913043478261, 1.2978260869565, -0.0375
99285, 1.6347826086957, 1.2978260869565, -0.0375
99286, 1.6782608695652, 1.2978260869565, -0.0375
99287, 1.7217391304348, 1.2978260869565, -0.0375
99288, 1.7652173913043, 1.2978260869565, -0.0375
99289, 1.8086956521739, 1.2978260869565, -0.0375
99290, 1.8521739130435, 1.2978260869565, -0.0375
99291, 1.895652173913, 1.2978260869565, -0.0375
99292, 1.9391304347826, 1.2978260869565, -0.0375
99293, 1.9826086956522, 1.2978260869565, -0.0375
99294, 2.0260869565217, 1.2978260869565, -0.0375
99295, 2.0695652173913, 1.2978260869565, -0.0375
99296, 2.1130434782609, 1.2978260869565, -0.0375
99297, 2.1565217391304, 1.2978260869565, -0.0375
99298, 1.2434782608696, 1.245652173913, -0.0375
99299, 1.2869565217391, 1.245652173913, -0.0375
99300, 1.3304347826087, 1.245652173913, -0.0375
99301, 1.3739130434783, 1.245652173913, -0.0375
99302, 1.4173913043478, 1.245652173913, -0.0375
99303, 1.4608695652174, 1.245652173913, -0.0375
99304, 1.504347826087, 1.245652173913, -0.0375
99305, 1.5478260869565, 1.245652173913, -0.0375
99306, 1.5913043478261, 1.245652173913, -0.0375
99307, 1.6347826086957, 1.245652173913, -0.0375
99308, 1.6782608695652, 1.245652173913, -0.0375
99309, 1.7217391304348, 1.245652173913, -0.0375
99310, 1.7652173913043, 1.245652173913, -0.0375
99311, 1.8086956521739, 1.245652173913, -0.0375
99312, 1.8521739130435, 1.245652173913, -0.0375
99313, 1.895652173913, 1.245652173913, -0.0375
99314, 1.9391304347826, 1.245652173913, -0.0375
99315, 1.9826086956522, 1.245652173913, -0.0375
99316, 2.0260869565217, 1.245652173913, -0.0375
99317, 2.0695652173913, 1.245652173913, -0.0375
99318, 2.1130434782609, 1.245652173913, -0.0375
99319, 2.1565217391304, 1.245652173913, -0.0375
99320, 1.2434782608696, 1.1934782608696, -0.0375
99321, 1.2869565217391, 1.1934782608696, -0.0375
99322, 1.3304347826087, 1.1934782608696, -0.0375
99323, 1.3739130434783, 1.1934782608696, -0.0375
99324, 1.4173913043478, 1.1934782608696, -0.0375
99325, 1.4608695652174, 1.1934782608696, -0.0375
99326, 1.504347826087, 1.1934782608696, -0.0375
99327, 1.5478260869565, 1.1934782608696, -0.0375
99328, 1.5913043478261, 1.1934782608696, -0.0375
99329, 1.6347826086957, 1.1934782608696, -0.0375
99330, 1.6782608695652, 1.1934782608696, -0.0375
99331, 1.7217391304348, 1.1934782608696, -0.0375
99332, 1.7652173913043, 1.1934782608696, -0.0375
99333, 1.8086956521739, 1.1934782608696, -0.0375
99334, 1.8521739130435, 1.1934782608696, -0.0375
99335, 1.895652173913, 1.1934782608696, -0.0375
99336, 1.9391304347826, 1.1934782608696, -0.0375
99337, 1.9826086956522, 1.1934782608696, -0.0375
99338, 2.0260869565217, 1.1934782608696, -0.0375
99339, 2.0695652173913, 1.1934782608696, -0.0375
99340, 2.1130434782609, 1.1934782608696, -0.0375
99341, 2.1565217391304, 1.1934782608696, -0.0375
99342, 1.2434782608696, 1.1413043478261, -0.0375
99343, 1.2869565217391, 1.1413043478261, -0.0375
99344, 1.3304347826087, 1.1413043478261, -0.0375
99345, 1.3739130434783, 1.1413043478261, -0.0375
99346, 1.4173913043478, 1.1413043478261, -0.0375
99347, 1.4608695652174, 1.1413043478261, -0.0375
99348, 1.504347826087, 1.1413043478261, -0.0375
99349, 1.5478260869565, 1.1413043478261, -0.0375
99350, 1.5913043478261, 1.1413043478261, -0.0375
99351, 1.6347826086957, 1.1413043478261, -0.0375
99352, 1.6782608695652, 1.1413043478261, -0.0375
99353, 1.7217391304348, 1.1413043478261, -0.0375
99354, 1.7652173913043, 1.1413043478261, -0.0375
99355, 1.8086956521739, 1.1413043478261, -0.0375
99356, 1.8521739130435, 1.1413043478261, -0.0375
99357, 1.895652173913, 1.1413043478261, -0.0375
99358, 1.9391304347826, 1.1413043478261, -0.0375
99359, 1.9826086956522, 1.1413043478261, -0.0375
99360, 2.0260869565217, 1.1413043478261, -0.0375
99361, 2.0695652173913, 1.1413043478261, -0.0375
99362, 2.1130434782609, 1.1413043478261, -0.0375
99363, 2.1565217391304, 1.1413043478261, -0.0375
99364, 1.2434782608696, 1.0891304347826, -0.0375
99365, 1.2869565217391, 1.0891304347826, -0.0375
99366, 1.3304347826087, 1.0891304347826, -0.0375
99367, 1.3739130434783, 1.0891304347826, -0.0375
99368, 1.4173913043478, 1.0891304347826, -0.0375
99369, 1.4608695652174, 1.0891304347826, -0.0375
99370, 1.504347826087, 1.0891304347826, -0.0375
99371, 1.5478260869565, 1.0891304347826, -0.0375
99372, 1.5913043478261, 1.0891304347826, -0.0375
99373, 1.6347826086957, 1.0891304347826, -0.0375
99374, 1.6782608695652, 1.0891304347826, -0.0375
99375, 1.7217391304348, 1.0891304347826, -0.0375
99376, 1.7652173913043, 1.0891304347826, -0.0375
99377, 1.8086956521739, 1.0891304347826, -0.0375
99378, 1.8521739130435, 1.0891304347826, -0.0375
99379, 1.895652173913, 1.0891304347826, -0.0375
99380, 1.9391304347826, 1.0891304347826, -0.0375
99381, 1.9826086956522, 1.0891304347826, -0.0375
99382, 2.0260869565217, 1.0891304347826, -0.0375
99383, 2.0695652173913, 1.0891304347826, -0.0375
99384, 2.1130434782609, 1.0891304347826, -0.0375
99385, 2.1565217391304, 1.0891304347826, -0.0375
99386, 1.2434782608696, 1.0369565217391, -0.0375
99387, 1.2869565217391, 1.0369565217391, -0.0375
99388, 1.3304347826087, 1.0369565217391, -0.0375
99389, 1.3739130434783, 1.0369565217391, -0.0375
99390, 1.4173913043478, 1.0369565217391, -0.0375
99391, 1.4608695652174, 1.0369565217391, -0.0375
99392, 1.504347826087, 1.0369565217391, -0.0375
99393, 1.5478260869565, 1.0369565217391, -0.0375
99394, 1.5913043478261, 1.0369565217391, -0.0375
99395, 1.6347826086957, 1.0369565217391, -0.0375
99396, 1.6782608695652, 1.0369565217391, -0.0375
99397, 1.7217391304348, 1.0369565217391, -0.0375
99398, 1.7652173913043, 1.0369565217391, -0.0375
99399, 1.8086956521739, 1.0369565217391, -0.0375
99400, 1.8521739130435, 1.0369565217391, -0.0375
99401, 1.895652173913, 1.0369565217391, -0.0375
99402, 1.9391304347826, 1.0369565217391, -0.0375
99403, 1.9826086956522, 1.0369565217391, -0.0375
99404, 2.0260869565217, 1.0369565217391, -0.0375
99405, 2.0695652173913, 1.0369565217391, -0.0375
99406, 2.1130434782609, 1.0369565217391, -0.0375
99407, 2.1565217391304, 1.0369565217391, -0.0375
99408, 1.2434782608696, 0.98478260869565, -0.0375
99409, 1.2869565217391, 0.98478260869565, -0.0375
99410, 1.3304347826087, 0.98478260869565, -0.0375
99411, 1.3739130434783, 0.98478260869565, -0.0375
99412, 1.4173913043478, 0.98478260869565, -0.0375
99413, 1.4608695652174, 0.98478260869565, -0.0375
99414, 1.504347826087, 0.98478260869565, -0.0375
99415, 1.5478260869565, 0.98478260869565, -0.0375
99416, 1.5913043478261, 0.98478260869565, -0.0375
99417, 1.6347826086957, 0.98478260869565, -0.0375
99418, 1.6782608695652, 0.98478260869565, -0.0375
99419, 1.7217391304348, 0.98478260869565, -0.0375
99420, 1.7652173913043, 0.98478260869565, -0.0375
99421, 1.8086956521739, 0.98478260869565, -0.0375
99422, 1.8521739130435, 0.98478260869565, -0.0375
99423, 1.895652173913, 0.98478260869565, -0.0375
99424, 1.9391304347826, 0.98478260869565, -0.0375
99425, 1.9826086956522, 0.98478260869565, -0.0375
99426, 2.0260869565217, 0.98478260869565, -0.0375
99427, 2.0695652173913, 0.98478260869565, -0.0375
99428, 2.1130434782609, 0.98478260869565, -0.0375
99429, 2.1565217391304, 0.98478260869565, -0.0375
99430, 1.2434782608696, 0.93260869565217, -0.0375
99431, 1.2869565217391, 0.93260869565217, -0.0375
99432, 1.3304347826087, 0.93260869565217, -0.0375
99433, 1.3739130434783, 0.93260869565217, -0.0375
99434, 1.4173913043478, 0.93260869565217, -0.0375
99435, 1.4608695652174, 0.93260869565217, -0.0375
99436, 1.504347826087, 0.93260869565217, -0.0375
99437, 1.5478260869565, 0.93260869565217, -0.0375
99438, 1.5913043478261, 0.93260869565217, -0.0375
99439, 1.6347826086957, 0.93260869565217, -0.0375
99440, 1.6782608695652, 0.93260869565217, -0.0375
99441, 1.7217391304348, 0.93260869565217, -0.0375
99442, 1.7652173913043, 0.93260869565217, -0.0375
99443, 1.8086956521739, 0.93260869565217, -0.0375
99444, 1.8521739130435, 0.93260869565218, -0.0375
99445, 1.895652173913, 0.93260869565217, -0.0375
99446, 1.9391304347826, 0.93260869565218, -0.0375
99447, 1.9826086956522, 0.93260869565217, -0.0375
99448, 2.0260869565217, 0.93260869565217, -0.0375
99449, 2.0695652173913, 0.93260869565217, -0.0375
99450, 2.1130434782609, 0.93260869565217, -0.0375
99451, 2.1565217391304, 0.93260869565217, -0.0375
99452, 1.2434782608696, 0.8804347826087, -0.0375
99453, 1.2869565217391, 0.8804347826087, -0.0375
99454, 1.3304347826087, 0.8804347826087, -0.0375
99455, 1.3739130434783, 0.8804347826087, -0.0375
99456, 1.4173913043478, 0.8804347826087, -0.0375
99457, 1.4608695652174, 0.8804347826087, -0.0375
99458, 1.504347826087, 0.8804347826087, -0.0375
99459, 1.5478260869565, 0.8804347826087, -0.0375
99460, 1.5913043478261, 0.8804347826087, -0.0375
99461, 1.6347826086957, 0.8804347826087, -0.0375
99462, 1.6782608695652, 0.8804347826087, -0.0375
99463, 1.7217391304348, 0.8804347826087, -0.0375
99464, 1.7652173913043, 0.8804347826087, -0.0375
99465, 1.8086956521739, 0.8804347826087, -0.0375
99466, 1.8521739130435, 0.8804347826087, -0.0375
99467, 1.895652173913, 0.8804347826087, -0.0375
99468, 1.9391304347826, 0.8804347826087, -0.0375
99469, 1.9826086956522, 0.8804347826087, -0.0375
99470, 2.0260869565217, 0.8804347826087, -0.0375
99471, 2.0695652173913, 0.8804347826087, -0.0375
99472, 2.1130434782609, 0.8804347826087, -0.0375
99473, 2.1565217391304, 0.8804347826087, -0.0375
99474, 1.2434782608696, 0.82826086956522, -0.0375
99475, 1.2869565217391, 0.82826086956522, -0.0375
99476, 1.3304347826087, 0.82826086956522, -0.0375
99477, 1.3739130434783, 0.82826086956522, -0.0375
99478, 1.4173913043478, 0.82826086956522, -0.0375
99479, 1.4608695652174, 0.82826086956522, -0.0375
99480, 1.504347826087, 0.82826086956522, -0.0375
99481, 1.5478260869565, 0.82826086956522, -0.0375
99482, 1.5913043478261, 0.82826086956522, -0.0375
99483, 1.6347826086957, 0.82826086956522, -0.0375
99484, 1.6782608695652, 0.82826086956522, -0.0375
99485, 1.7217391304348, 0.82826086956522, -0.0375
99486, 1.7652173913043, 0.82826086956522, -0.0375
99487, 1.8086956521739, 0.82826086956522, -0.0375
99488, 1.8521739130435, 0.82826086956522, -0.0375
99489, 1.895652173913, 0.82826086956522, -0.0375
99490, 1.9391304347826, 0.82826086956522, -0.0375
99491, 1.9826086956522, 0.82826086956522, -0.0375
99492, 2.0260869565217, 0.82826086956522, -0.0375
99493, 2.0695652173913, 0.82826086956522, -0.0375
99494, 2.1130434782609, 0.82826086956522, -0.0375
99495, 2.1565217391304, 0.82826086956522, -0.0375
99496, 1.2434782608696, 0.77608695652174, -0.0375
99497, 1.2869565217391, 0.77608695652174, -0.0375
99498, 1.3304347826087, 0.77608695652174, -0.0375
99499, 1.3739130434783, 0.77608695652174, -0.0375
99500, 1.4173913043478, 0.77608695652174, -0.0375
99501, 1.4608695652174, 0.77608695652174, -0.0375
99502, 1.504347826087, 0.77608695652174, -0.0375
99503, 1.5478260869565, 0.77608695652174, -0.0375
99504, 1.5913043478261, 0.77608695652174, -0.0375
99505, 1.6347826086957, 0.77608695652174, -0.0375
99506, 1.6782608695652, 0.77608695652174, -0.0375
99507, 1.7217391304348, 0.77608695652174, -0.0375
99508, 1.7652173913043, 0.77608695652174, -0.0375
99509, 1.8086956521739, 0.77608695652174, -0.0375
99510, 1.8521739130435, 0.77608695652174, -0.0375
99511, 1.895652173913, 0.77608695652174, -0.0375
99512, 1.9391304347826, 0.77608695652174, -0.0375
99513, 1.9826086956522, 0.77608695652174, -0.0375
99514, 2.0260869565217, 0.77608695652174, -0.0375
99515, 2.0695652173913, 0.77608695652174, -0.0375
99516, 2.1130434782609, 0.77608695652174, -0.0375
99517, 2.1565217391304, 0.77608695652174, -0.0375
99518, 1.2434782608696, 0.72391304347826, -0.0375
99519, 1.2869565217391, 0.72391304347826, -0.0375
99520, 1.3304347826087, 0.72391304347826, -0.0375
99521, 1.3739130434783, 0.72391304347826, -0.0375
99522, 1.4173913043478, 0.72391304347826, -0.0375
99523, 1.4608695652174, 0.72391304347826, -0.0375
99524, 1.504347826087, 0.72391304347826, -0.0375
99525, 1.5478260869565, 0.72391304347826, -0.0375
99526, 1.5913043478261, 0.72391304347826, -0.0375
99527, 1.6347826086957, 0.72391304347826, -0.0375
99528, 1.6782608695652, 0.72391304347826, -0.0375
99529, 1.7217391304348, 0.72391304347826, -0.0375
99530, 1.7652173913043, 0.72391304347826, -0.0375
99531, 1.8086956521739, 0.72391304347826, -0.0375
99532, 1.8521739130435, 0.72391304347826, -0.0375
99533, 1.895652173913, 0.72391304347826, -0.0375
99534, 1.9391304347826, 0.72391304347826, -0.0375
99535, 1.9826086956522, 0.72391304347826, -0.0375
99536, 2.0260869565217, 0.72391304347826, -0.0375
99537, 2.0695652173913, 0.72391304347826, -0.0375
99538, 2.1130434782609, 0.72391304347826, -0.0375
99539, 2.1565217391304, 0.72391304347826, -0.0375
99540, 1.2434782608696, 0.67173913043478, -0.0375
99541, 1.2869565217391, 0.67173913043478, -0.0375
99542, 1.3304347826087, 0.67173913043478, -0.0375
99543, 1.3739130434783, 0.67173913043478, -0.0375
99544, 1.4173913043478, 0.67173913043478, -0.0375
99545, 1.4608695652174, 0.67173913043478, -0.0375
99546, 1.504347826087, 0.67173913043478, -0.0375
99547, 1.5478260869565, 0.67173913043478, -0.0375
99548, 1.5913043478261, 0.67173913043478, -0.0375
99549, 1.6347826086957, 0.67173913043478, -0.0375
99550, 1.6782608695652, 0.67173913043478, -0.0375
99551, 1.7217391304348, 0.67173913043478, -0.0375
99552, 1.7652173913043, 0.67173913043478, -0.0375
99553, 1.8086956521739, 0.67173913043478, -0.0375
99554, 1.8521739130435, 0.67173913043478, -0.0375
99555, 1.895652173913, 0.67173913043478, -0.0375
99556, 1.9391304347826, 0.67173913043478, -0.0375
99557, 1.9826086956522, 0.67173913043478, -0.0375
99558, 2.0260869565217, 0.67173913043478, -0.0375
99559, 2.0695652173913, 0.67173913043478, -0.0375
99560, 2.1130434782609, 0.67173913043478, -0.0375
99561, 2.1565217391304, 0.67173913043478, -0.0375
99562, 1.2434782608696, 0.6195652173913, -0.0375
99563, 1.2869565217391, 0.61956521739131, -0.0375
99564, 1.3304347826087, 0.6195652173913, -0.0375
99565, 1.3739130434783, 0.61956521739131, -0.0375
99566, 1.4173913043478, 0.6195652173913, -0.0375
99567, 1.4608695652174, 0.6195652173913, -0.0375
99568, 1.504347826087, 0.6195652173913, -0.0375
99569, 1.5478260869565, 0.6195652173913, -0.0375
99570, 1.5913043478261, 0.6195652173913, -0.0375
99571, 1.6347826086957, 0.6195652173913, -0.0375
99572, 1.6782608695652, 0.6195652173913, -0.0375
99573, 1.7217391304348, 0.61956521739131, -0.0375
99574, 1.7652173913043, 0.6195652173913, -0.0375
99575, 1.8086956521739, 0.6195652173913, -0.0375
99576, 1.8521739130435, 0.6195652173913, -0.0375
99577, 1.895652173913, 0.6195652173913, -0.0375
99578, 1.9391304347826, 0.6195652173913, -0.0375
99579, 1.9826086956522, 0.6195652173913, -0.0375
99580, 2.0260869565217, 0.6195652173913, -0.0375
99581, 2.0695652173913, 0.6195652173913, -0.0375
99582, 2.1130434782609, 0.6195652173913, -0.0375
99583, 2.1565217391304, 0.6195652173913, -0.0375
99584, 1.2434782608696, 0.56739130434783, -0.0375
99585, 1.2869565217391, 0.56739130434783, -0.0375
99586, 1.3304347826087, 0.56739130434783, -0.0375
99587, 1.3739130434783, 0.56739130434783, -0.0375
99588, 1.4173913043478, 0.56739130434783, -0.0375
99589, 1.4608695652174, 0.56739130434783, -0.0375
99590, 1.504347826087, 0.56739130434783, -0.0375
99591, 1.5478260869565, 0.56739130434783, -0.0375
99592, 1.5913043478261, 0.56739130434783, -0.0375
99593, 1.6347826086957, 0.56739130434783, -0.0375
99594, 1.6782608695652, 0.56739130434783, -0.0375
99595, 1.7217391304348, 0.56739130434783, -0.0375
99596, 1.7652173913043, 0.56739130434783, -0.0375
99597, 1.8086956521739, 0.56739130434783, -0.0375
99598, 1.8521739130435, 0.56739130434783, -0.0375
99599, 1.895652173913, 0.56739130434783, -0.0375
99600, 1.9391304347826, 0.56739130434783, -0.0375
99601, 1.9826086956522, 0.56739130434783, -0.0375
99602, 2.0260869565217, 0.56739130434783, -0.0375
99603, 2.0695652173913, 0.56739130434783, -0.0375
99604, 2.1130434782609, 0.56739130434783, -0.0375
99605, 2.1565217391304, 0.56739130434783, -0.0375
99606, 1.2434782608696, 0.51521739130435, -0.0375
99607, 1.2869565217391, 0.51521739130435, -0.0375
99608, 1.3304347826087, 0.51521739130435, -0.0375
99609, 1.3739130434783, 0.51521739130435, -0.0375
99610, 1.4173913043478, 0.51521739130435, -0.0375
99611, 1.4608695652174, 0.51521739130435, -0.0375
99612, 1.504347826087, 0.51521739130435, -0.0375
99613, 1.5478260869565, 0.51521739130435, -0.0375
99614, 1.5913043478261, 0.51521739130435, -0.0375
99615, 1.6347826086957, 0.51521739130435, -0.0375
99616, 1.6782608695652, 0.51521739130435, -0.0375
99617, 1.7217391304348, 0.51521739130435, -0.0375
99618, 1.7652173913043, 0.51521739130435, -0.0375
99619, 1.8086956521739, 0.51521739130435, -0.0375
99620, 1.8521739130435, 0.51521739130435, -0.0375
99621, 1.895652173913, 0.51521739130435, -0.0375
99622, 1.9391304347826, 0.51521739130435, -0.0375
99623, 1.9826086956522, 0.51521739130435, -0.0375
99624, 2.0260869565217, 0.51521739130435, -0.0375
99625, 2.0695652173913, 0.51521739130435, -0.0375
99626, 2.1130434782609, 0.51521739130435, -0.0375
99627, 2.1565217391304, 0.51521739130435, -0.0375
99628, 1.2434782608696, 0.46304347826087, -0.0375
99629, 1.2869565217391, 0.46304347826087, -0.0375
99630, 1.3304347826087, 0.46304347826087, -0.0375
99631, 1.3739130434783, 0.46304347826087, -0.0375
99632, 1.4173913043478, 0.46304347826087, -0.0375
99633, 1.4608695652174, 0.46304347826087, -0.0375
99634, 1.504347826087, 0.46304347826087, -0.0375
99635, 1.5478260869565, 0.46304347826087, -0.0375
99636, 1.5913043478261, 0.46304347826087, -0.0375
99637, 1.6347826086957, 0.46304347826087, -0.0375
99638, 1.6782608695652, 0.46304347826087, -0.0375
99639, 1.7217391304348, 0.46304347826087, -0.0375
99640, 1.7652173913043, 0.46304347826087, -0.0375
99641, 1.8086956521739, 0.46304347826087, -0.0375
99642, 1.8521739130435, 0.46304347826087, -0.0375
99643, 1.895652173913, 0.46304347826087, -0.0375
99644, 1.9391304347826, 0.46304347826087, -0.0375
99645, 1.9826086956522, 0.46304347826087, -0.0375
99646, 2.0260869565217, 0.46304347826087, -0.0375
99647, 2.0695652173913, 0.46304347826087, -0.0375
99648, 2.1130434782609, 0.46304347826087, -0.0375
99649, 2.1565217391304, 0.46304347826087, -0.0375
99650, 1.2434782608696, 0.41086956521739, -0.0375
99651, 1.2869565217391, 0.41086956521739, -0.0375
99652, 1.3304347826087, 0.41086956521739, -0.0375
99653, 1.3739130434783, 0.41086956521739, -0.0375
99654, 1.4173913043478, 0.41086956521739, -0.0375
99655, 1.4608695652174, 0.41086956521739, -0.0375
99656, 1.504347826087, 0.41086956521739, -0.0375
99657, 1.5478260869565, 0.41086956521739, -0.0375
99658, 1.5913043478261, 0.41086956521739, -0.0375
99659, 1.6347826086957, 0.41086956521739, -0.0375
99660, 1.6782608695652, 0.41086956521739, -0.0375
99661, 1.7217391304348, 0.41086956521739, -0.0375
99662, 1.7652173913043, 0.41086956521739, -0.0375
99663, 1.8086956521739, 0.41086956521739, -0.0375
99664, 1.8521739130435, 0.41086956521739, -0.0375
99665, 1.895652173913, 0.41086956521739, -0.0375
99666, 1.9391304347826, 0.41086956521739, -0.0375
99667, 1.9826086956522, 0.41086956521739, -0.0375
99668, 2.0260869565217, 0.41086956521739, -0.0375
99669, 2.0695652173913, 0.41086956521739, -0.0375
99670, 2.1130434782609, 0.41086956521739, -0.0375
99671, 2.1565217391304, 0.41086956521739, -0.0375
99672, 1.2434782608696, 0.35869565217391, -0.0375
99673, 1.2869565217391, 0.35869565217391, -0.0375
99674, 1.3304347826087, 0.35869565217391, -0.0375
99675, 1.3739130434783, 0.35869565217391, -0.0375
99676, 1.4173913043478, 0.35869565217391, -0.0375
99677, 1.4608695652174, 0.35869565217391, -0.0375
99678, 1.504347826087, 0.35869565217391, -0.0375
99679, 1.5478260869565, 0.35869565217391, -0.0375
99680, 1.5913043478261, 0.35869565217391, -0.0375
99681, 1.6347826086957, 0.35869565217391, -0.0375
99682, 1.6782608695652, 0.35869565217391, -0.0375
99683, 1.7217391304348, 0.35869565217391, -0.0375
99684, 1.7652173913043, 0.35869565217391, -0.0375
99685, 1.8086956521739, 0.35869565217391, -0.0375
99686, 1.8521739130435, 0.35869565217391, -0.0375
99687, 1.895652173913, 0.35869565217391, -0.0375
99688, 1.9391304347826, 0.35869565217391, -0.0375
99689, 1.9826086956522, 0.35869565217391, -0.0375
99690, 2.0260869565217, 0.35869565217391, -0.0375
99691, 2.0695652173913, 0.35869565217391, -0.0375
99692, 2.1130434782609, 0.35869565217391, -0.0375
99693, 2.1565217391304, 0.35869565217391, -0.0375
99694, 1.2434782608696, 0.30652173913044, -0.0375
99695, 1.2869565217391, 0.30652173913043, -0.0375
99696, 1.3304347826087, 0.30652173913043, -0.0375
99697, 1.3739130434783, 0.30652173913044, -0.0375
99698, 1.4173913043478, 0.30652173913044, -0.0375
99699, 1.4608695652174, 0.30652173913043, -0.0375
99700, 1.504347826087, 0.30652173913044, -0.0375
99701, 1.5478260869565, 0.30652173913044, -0.0375
99702, 1.5913043478261, 0.30652173913044, -0.0375
99703, 1.6347826086957, 0.30652173913043, -0.0375
99704, 1.6782608695652, 0.30652173913043, -0.0375
99705, 1.7217391304348, 0.30652173913043, -0.0375
99706, 1.7652173913043, 0.30652173913043, -0.0375
99707, 1.8086956521739, 0.30652173913044, -0.0375
99708, 1.8521739130435, 0.30652173913043, -0.0375
99709, 1.895652173913, 0.30652173913044, -0.0375
99710, 1.9391304347826, 0.30652173913043, -0.0375
99711, 1.9826086956522, 0.30652173913044, -0.0375
99712, 2.0260869565217, 0.30652173913044, -0.0375
99713, 2.0695652173913, 0.30652173913043, -0.0375
99714, 2.1130434782609, 0.30652173913043, -0.0375
99715, 2.1565217391304, 0.30652173913043, -0.0375
99716, 1.2434782608696, 0.25434782608696, -0.0375
99717, 1.2869565217391, 0.25434782608696, -0.0375
99718, 1.3304347826087, 0.25434782608696, -0.0375
99719, 1.3739130434783, 0.25434782608696, -0.0375
99720, 1.4173913043478, 0.25434782608696, -0.0375
99721, 1.4608695652174, 0.25434782608696, -0.0375
99722, 1.504347826087, 0.25434782608696, -0.0375
99723, 1.5478260869565, 0.25434782608696, -0.0375
99724, 1.5913043478261, 0.25434782608696, -0.0375
99725, 1.6347826086957, 0.25434782608696, -0.0375
99726, 1.6782608695652, 0.25434782608696, -0.0375
99727, 1.7217391304348, 0.25434782608696, -0.0375
99728, 1.7652173913043, 0.25434782608696, -0.0375
99729, 1.8086956521739, 0.25434782608696, -0.0375
99730, 1.8521739130435, 0.25434782608696, -0.0375
99731, 1.895652173913, 0.25434782608696, -0.0375
99732, 1.9391304347826, 0.25434782608696, -0.0375
99733, 1.9826086956522, 0.25434782608696, -0.0375
99734, 2.0260869565217, 0.25434782608696, -0.0375
99735, 2.0695652173913, 0.25434782608696, -0.0375
99736, 2.1130434782609, 0.25434782608696, -0.0375
99737, 2.1565217391304, 0.25434782608696, -0.0375
99738, 1.2434782608696, 0.20217391304348, -0.0375
99739, 1.2869565217391, 0.20217391304348, -0.0375
99740, 1.3304347826087, 0.20217391304348, -0.0375
99741, 1.3739130434783, 0.20217391304348, -0.0375
99742, 1.4173913043478, 0.20217391304348, -0.0375
99743, 1.4608695652174, 0.20217391304348, -0.0375
99744, 1.504347826087, 0.20217391304348, -0.0375
99745, 1.5478260869565, 0.20217391304348, -0.0375
99746, 1.5913043478261, 0.20217391304348, -0.0375
99747, 1.6347826086957, 0.20217391304348, -0.0375
99748, 1.6782608695652, 0.20217391304348, -0.0375
99749, 1.7217391304348, 0.20217391304348, -0.0375
99750, 1.7652173913043, 0.20217391304348, -0.0375
99751, 1.8086956521739, 0.20217391304348, -0.0375
99752, 1.8521739130435, 0.20217391304348, -0.0375
99753, 1.895652173913, 0.20217391304348, -0.0375
99754, 1.9391304347826, 0.20217391304348, -0.0375
99755, 1.9826086956522, 0.20217391304348, -0.0375
99756, 2.0260869565217, 0.20217391304348, -0.0375
99757, 2.0695652173913, 0.20217391304348, -0.0375
99758, 2.1130434782609, 0.20217391304348, -0.0375
99759, 2.1565217391304, 0.20217391304348, -0.0375
99760, 1.2217391304348, 1.2978260869565, -0.0375
99761, 1.2434782608696, 1.3239130434783, -0.0375
99762, 1.2434782608696, 1.2978260869565, -0.01875
99763, 1.2652173913043, 1.2978260869565, -0.0375
99764, 1.2869565217391, 1.3239130434783, -0.0375
99765, 1.2869565217391, 1.2978260869565, -0.01875
99766, 1.3086956521739, 1.2978260869565, -0.0375
99767, 1.3304347826087, 1.3239130434783, -0.0375
99768, 1.3304347826087, 1.2978260869565, -0.01875
99769, 1.3521739130435, 1.2978260869565, -0.0375
99770, 1.3739130434783, 1.3239130434783, -0.0375
99771, 1.3739130434783, 1.2978260869565, -0.01875
99772, 1.395652173913, 1.2978260869565, -0.0375
99773, 1.4173913043478, 1.3239130434783, -0.0375
99774, 1.4173913043478, 1.2978260869565, -0.01875
99775, 1.4391304347826, 1.2978260869565, -0.0375
99776, 1.4608695652174, 1.3239130434783, -0.0375
99777, 1.4608695652174, 1.2978260869565, -0.01875
99778, 1.4826086956522, 1.2978260869565, -0.0375
99779, 1.504347826087, 1.3239130434783, -0.0375
99780, 1.504347826087, 1.2978260869565, -0.01875
99781, 1.5260869565217, 1.2978260869565, -0.0375
99782, 1.5478260869565, 1.3239130434783, -0.0375
99783, 1.5478260869565, 1.2978260869565, -0.01875
99784, 1.5695652173913, 1.2978260869565, -0.0375
99785, 1.5913043478261, 1.3239130434783, -0.0375
99786, 1.5913043478261, 1.2978260869565, -0.01875
99787, 1.6130434782609, 1.2978260869565, -0.0375
99788, 1.6347826086957, 1.3239130434783, -0.0375
99789, 1.6347826086957, 1.2978260869565, -0.01875
99790, 1.6565217391304, 1.2978260869565, -0.0375
99791, 1.6782608695652, 1.3239130434783, -0.0375
99792, 1.6782608695652, 1.2978260869565, -0.01875
99793, 1.7, 1.2978260869565, -0.0375
99794, 1.7217391304348, 1.3239130434783, -0.0375
99795, 1.7217391304348, 1.2978260869565, -0.01875
99796, 1.7434782608696, 1.2978260869565, -0.0375
99797, 1.7652173913043, 1.3239130434783, -0.0375
99798, 1.7652173913043, 1.2978260869565, -0.01875
99799, 1.7869565217391, 1.2978260869565, -0.0375
99800, 1.8086956521739, 1.3239130434783, -0.0375
99801, 1.8086956521739, 1.2978260869565, -0.01875
99802, 1.8304347826087, 1.2978260869565, -0.0375
99803, 1.8521739130435, 1.3239130434783, -0.0375
99804, 1.8521739130435, 1.2978260869565, -0.01875
99805, 1.8739130434783, 1.2978260869565, -0.0375
99806, 1.895652173913, 1.3239130434783, -0.0375
99807, 1.895652173913, 1.2978260869565, -0.01875
99808, 1.9173913043478, 1.2978260869565, -0.0375
99809, 1.9391304347826, 1.3239130434783, -0.0375
99810, 1.9391304347826, 1.2978260869565, -0.01875
99811, 1.9608695652174, 1.2978260869565, -0.0375
99812, 1.9826086956522, 1.3239130434783, -0.0375
99813, 1.9826086956522, 1.2978260869565, -0.01875
99814, 2.004347826087, 1.2978260869565, -0.0375
99815, 2.0260869565217, 1.3239130434783, -0.0375
99816, 2.0260869565217, 1.2978260869565, -0.01875
99817, 2.0478260869565, 1.2978260869565, -0.0375
99818, 2.0695652173913, 1.3239130434783, -0.0375
99819, 2.0695652173913, 1.2978260869565, -0.01875
99820, 2.0913043478261, 1.2978260869565, -0.0375
99821, 2.1130434782609, 1.3239130434783, -0.0375
99822, 2.1130434782609, 1.2978260869565, -0.01875
99823, 2.1347826086957, 1.2978260869565, -0.0375
99824, 2.1565217391304, 1.3239130434783, -0.0375
99825, 2.1565217391304, 1.2978260869565, -0.01875
99826, 2.1782608695652, 1.2978260869565, -0.0375
99827, 1.2217391304348, 1.245652173913, -0.0375
99828, 1.2434782608696, 1.2717391304348, -0.0375
99829, 1.2434782608696, 1.245652173913, -0.01875
99830, 1.2652173913043, 1.245652173913, -0.0375
99831, 1.2869565217391, 1.2717391304348, -0.0375
99832, 1.2869565217391, 1.245652173913, -0.01875
99833, 1.3086956521739, 1.245652173913, -0.0375
99834, 1.3304347826087, 1.2717391304348, -0.0375
99835, 1.3304347826087, 1.245652173913, -0.01875
99836, 1.3521739130435, 1.245652173913, -0.0375
99837, 1.3739130434783, 1.2717391304348, -0.0375
99838, 1.3739130434783, 1.245652173913, -0.01875
99839, 1.395652173913, 1.245652173913, -0.0375
99840, 1.4173913043478, 1.2717391304348, -0.0375
99841, 1.4173913043478, 1.245652173913, -0.01875
99842, 1.4391304347826, 1.245652173913, -0.0375
99843, 1.4608695652174, 1.2717391304348, -0.0375
99844, 1.4608695652174, 1.245652173913, -0.01875
99845, 1.4826086956522, 1.245652173913, -0.0375
99846, 1.504347826087, 1.2717391304348, -0.0375
99847, 1.504347826087, 1.245652173913, -0.01875
99848, 1.5260869565217, 1.245652173913, -0.0375
99849, 1.5478260869565, 1.2717391304348, -0.0375
99850, 1.5478260869565, 1.245652173913, -0.01875
99851, 1.5695652173913, 1.245652173913, -0.0375
99852, 1.5913043478261, 1.2717391304348, -0.0375
99853, 1.5913043478261, 1.245652173913, -0.01875
99854, 1.6130434782609, 1.245652173913, -0.0375
99855, 1.6347826086957, 1.2717391304348, -0.0375
99856, 1.6347826086957, 1.245652173913, -0.01875
99857, 1.6565217391304, 1.245652173913, -0.0375
99858, 1.6782608695652, 1.2717391304348, -0.0375
99859, 1.6782608695652, 1.245652173913, -0.01875
99860, 1.7, 1.245652173913, -0.0375
99861, 1.7217391304348, 1.2717391304348, -0.0375
99862, 1.7217391304348, 1.245652173913, -0.01875
99863, 1.7434782608696, 1.245652173913, -0.0375
99864, 1.7652173913043, 1.2717391304348, -0.0375
99865, 1.7652173913043, 1.245652173913, -0.01875
99866, 1.7869565217391, 1.245652173913, -0.0375
99867, 1.8086956521739, 1.2717391304348, -0.0375
99868, 1.8086956521739, 1.245652173913, -0.01875
99869, 1.8304347826087, 1.245652173913, -0.0375
99870, 1.8521739130435, 1.2717391304348, -0.0375
99871, 1.8521739130435, 1.245652173913, -0.01875
99872, 1.8739130434783, 1.245652173913, -0.0375
99873, 1.895652173913, 1.2717391304348, -0.0375
99874, 1.895652173913, 1.245652173913, -0.01875
99875, 1.9173913043478, 1.245652173913, -0.0375
99876, 1.9391304347826, 1.2717391304348, -0.0375
99877, 1.9391304347826, 1.245652173913, -0.01875
99878, 1.9608695652174, 1.245652173913, -0.0375
99879, 1.9826086956522, 1.2717391304348, -0.0375
99880, 1.9826086956522, 1.245652173913, -0.01875
99881, 2.004347826087, 1.245652173913, -0.0375
99882, 2.0260869565217, 1.2717391304348, -0.0375
99883, 2.0260869565217, 1.245652173913, -0.01875
99884, 2.0478260869565, 1.245652173913, -0.0375
99885, 2.0695652173913, 1.2717391304348, -0.0375
99886, 2.0695652173913, 1.245652173913, -0.01875
99887, 2.0913043478261, 1.245652173913, -0.0375
99888, 2.1130434782609, 1.2717391304348, -0.0375
99889, 2.1130434782609, 1.245652173913, -0.01875
99890, 2.1347826086957, 1.245652173913, -0.0375
99891, 2.1565217391304, 1.2717391304348, -0.0375
99892, 2.1565217391304, 1.245652173913, -0.01875
99893, 2.1782608695652, 1.245652173913, -0.0375
99894, 1.2217391304348, 1.1934782608696, -0.0375
99895, 1.2434782608696, 1.2195652173913, -0.0375
99896, 1.2434782608696, 1.1934782608696, -0.01875
99897, 1.2652173913043, 1.1934782608696, -0.0375
99898, 1.2869565217391, 1.2195652173913, -0.0375
99899, 1.2869565217391, 1.1934782608696, -0.01875
99900, 1.3086956521739, 1.1934782608696, -0.0375
99901, 1.3304347826087, 1.2195652173913, -0.0375
99902, 1.3304347826087, 1.1934782608696, -0.01875
99903, 1.3521739130435, 1.1934782608696, -0.0375
99904, 1.3739130434783, 1.2195652173913, -0.0375
99905, 1.3739130434783, 1.1934782608696, -0.01875
99906, 1.395652173913, 1.1934782608696, -0.0375
99907, 1.4173913043478, 1.2195652173913, -0.0375
99908, 1.4173913043478, 1.1934782608696, -0.01875
99909, 1.4391304347826, 1.1934782608696, -0.0375
99910, 1.4608695652174, 1.2195652173913, -0.0375
99911, 1.4608695652174, 1.1934782608696, -0.01875
99912, 1.4826086956522, 1.1934782608696, -0.0375
99913, 1.504347826087, 1.2195652173913, -0.0375
99914, 1.504347826087, 1.1934782608696, -0.01875
99915, 1.5260869565217, 1.1934782608696, -0.0375
99916, 1.5478260869565, 1.2195652173913, -0.0375
99917, 1.5478260869565, 1.1934782608696, -0.01875
99918, 1.5695652173913, 1.1934782608696, -0.0375
99919, 1.5913043478261, 1.2195652173913, -0.0375
99920, 1.5913043478261, 1.1934782608696, -0.01875
99921, 1.6130434782609, 1.1934782608696, -0.0375
99922, 1.6347826086957, 1.2195652173913, -0.0375
99923, 1.6347826086957, 1.1934782608696, -0.01875
99924, 1.6565217391304, 1.1934782608696, -0.0375
99925, 1.6782608695652, 1.2195652173913, -0.0375
99926, 1.6782608695652, 1.1934782608696, -0.01875
99927, 1.7, 1.1934782608696, -0.0375
99928, 1.7217391304348, 1.2195652173913, -0.0375
99929, 1.7217391304348, 1.1934782608696, -0.01875
99930, 1.7434782608696, 1.1934782608696, -0.0375
99931, 1.7652173913043, 1.2195652173913, -0.0375
99932, 1.7652173913043, 1.1934782608696, -0.01875
99933, 1.7869565217391, 1.1934782608696, -0.0375
99934, 1.8086956521739, 1.2195652173913, -0.0375
99935, 1.8086956521739, 1.1934782608696, -0.01875
99936, 1.8304347826087, 1.1934782608696, -0.0375
99937, 1.8521739130435, 1.2195652173913, -0.0375
99938, 1.8521739130435, 1.1934782608696, -0.01875
99939, 1.8739130434783, 1.1934782608696, -0.0375
99940, 1.895652173913, 1.2195652173913, -0.0375
99941, 1.895652173913, 1.1934782608696, -0.01875
99942, 1.9173913043478, 1.1934782608696, -0.0375
99943, 1.9391304347826, 1.2195652173913, -0.0375
99944, 1.9391304347826, 1.1934782608696, -0.01875
99945, 1.9608695652174, 1.1934782608696, -0.0375
99946, 1.9826086956522, 1.2195652173913, -0.0375
99947, 1.9826086956522, 1.1934782608696, -0.01875
99948, 2.004347826087, 1.1934782608696, -0.0375
99949, 2.0260869565217, 1.2195652173913, -0.0375
99950, 2.0260869565217, 1.1934782608696, -0.01875
99951, 2.0478260869565, 1.1934782608696, -0.0375
99952, 2.0695652173913, 1.2195652173913, -0.0375
99953, 2.0695652173913, 1.1934782608696, -0.01875
99954, 2.0913043478261, 1.1934782608696, -0.0375
99955, 2.1130434782609, 1.2195652173913, -0.0375
99956, 2.1130434782609, 1.1934782608696, -0.01875
99957, 2.1347826086957, 1.1934782608696, -0.0375
99958, 2.1565217391304, 1.2195652173913, -0.0375
99959, 2.1565217391304, 1.1934782608696, -0.01875
99960, 2.1782608695652, 1.1934782608696, -0.0375
99961, 1.2217391304348, 1.1413043478261, -0.0375
99962, 1.2434782608696, 1.1673913043478, -0.0375
99963, 1.2434782608696, 1.1413043478261, -0.01875
99964, 1.2652173913043, 1.1413043478261, -0.0375
99965, 1.2869565217391, 1.1673913043478, -0.0375
99966, 1.2869565217391, 1.1413043478261, -0.01875
99967, 1.3086956521739, 1.1413043478261, -0.0375
99968, 1.3304347826087, 1.1673913043478, -0.0375
99969, 1.3304347826087, 1.1413043478261, -0.01875
99970, 1.3521739130435, 1.1413043478261, -0.0375
99971, 1.3739130434783, 1.1673913043478, -0.0375
99972, 1.3739130434783, 1.1413043478261, -0.01875
99973, 1.395652173913, 1.1413043478261, -0.0375
99974, 1.4173913043478, 1.1673913043478, -0.0375
99975, 1.4173913043478, 1.1413043478261, -0.01875
99976, 1.4391304347826, 1.1413043478261, -0.0375
99977, 1.4608695652174, 1.1673913043478, -0.0375
99978, 1.4608695652174, 1.1413043478261, -0.01875
99979, 1.4826086956522, 1.1413043478261, -0.0375
99980, 1.504347826087, 1.1673913043478, -0.0375
99981, 1.504347826087, 1.1413043478261, -0.01875
99982, 1.5260869565217, 1.1413043478261, -0.0375
99983, 1.5478260869565, 1.1673913043478, -0.0375
99984, 1.5478260869565, 1.1413043478261, -0.01875
99985, 1.5695652173913, 1.1413043478261, -0.0375
99986, 1.5913043478261, 1.1673913043478, -0.0375
99987, 1.5913043478261, 1.1413043478261, -0.01875
99988, 1.6130434782609, 1.1413043478261, -0.0375
99989, 1.6347826086957, 1.1673913043478, -0.0375
99990, 1.6347826086957, 1.1413043478261, -0.01875
99991, 1.6565217391304, 1.1413043478261, -0.0375
99992, 1.6782608695652, 1.1673913043478, -0.0375
99993, 1.6782608695652, 1.1413043478261, -0.01875
99994, 1.7, 1.1413043478261, -0.0375
99995, 1.7217391304348, 1.1673913043478, -0.0375
99996, 1.7217391304348, 1.1413043478261, -0.01875
99997, 1.7434782608696, 1.1413043478261, -0.0375
99998, 1.7652173913043, 1.1673913043478, -0.0375
99999, 1.7652173913043, 1.1413043478261, -0.01875
100000, 1.7869565217391, 1.1413043478261, -0.0375
100001, 1.8086956521739, 1.1673913043478, -0.0375
100002, 1.8086956521739, 1.1413043478261, -0.01875
100003, 1.8304347826087, 1.1413043478261, -0.0375
100004, 1.8521739130435, 1.1673913043478, -0.0375
100005, 1.8521739130435, 1.1413043478261, -0.01875
100006, 1.8739130434783, 1.1413043478261, -0.0375
100007, 1.895652173913, 1.1673913043478, -0.0375
100008, 1.895652173913, 1.1413043478261, -0.01875
100009, 1.9173913043478, 1.1413043478261, -0.0375
100010, 1.9391304347826, 1.1673913043478, -0.0375
100011, 1.9391304347826, 1.1413043478261, -0.01875
100012, 1.9608695652174, 1.1413043478261, -0.0375
100013, 1.9826086956522, 1.1673913043478, -0.0375
100014, 1.9826086956522, 1.1413043478261, -0.01875
100015, 2.004347826087, 1.1413043478261, -0.0375
100016, 2.0260869565217, 1.1673913043478, -0.0375
100017, 2.0260869565217, 1.1413043478261, -0.01875
100018, 2.0478260869565, 1.1413043478261, -0.0375
100019, 2.0695652173913, 1.1673913043478, -0.0375
100020, 2.0695652173913, 1.1413043478261, -0.01875
100021, 2.0913043478261, 1.1413043478261, -0.0375
100022, 2.1130434782609, 1.1673913043478, -0.0375
100023, 2.1130434782609, 1.1413043478261, -0.01875
100024, 2.1347826086957, 1.1413043478261, -0.0375
100025, 2.1565217391304, 1.1673913043478, -0.0375
100026, 2.1565217391304, 1.1413043478261, -0.01875
100027, 2.1782608695652, 1.1413043478261, -0.0375
100028, 1.2217391304348, 1.0891304347826, -0.0375
100029, 1.2434782608696, 1.1152173913043, -0.0375
100030, 1.2434782608696, 1.0891304347826, -0.01875
100031, 1.2652173913043, 1.0891304347826, -0.0375
100032, 1.2869565217391, 1.1152173913043, -0.0375
100033, 1.2869565217391, 1.0891304347826, -0.01875
100034, 1.3086956521739, 1.0891304347826, -0.0375
100035, 1.3304347826087, 1.1152173913043, -0.0375
100036, 1.3304347826087, 1.0891304347826, -0.01875
100037, 1.3521739130435, 1.0891304347826, -0.0375
100038, 1.3739130434783, 1.1152173913043, -0.0375
100039, 1.3739130434783, 1.0891304347826, -0.01875
100040, 1.395652173913, 1.0891304347826, -0.0375
100041, 1.4173913043478, 1.1152173913043, -0.0375
100042, 1.4173913043478, 1.0891304347826, -0.01875
100043, 1.4391304347826, 1.0891304347826, -0.0375
100044, 1.4608695652174, 1.1152173913043, -0.0375
100045, 1.4608695652174, 1.0891304347826, -0.01875
100046, 1.4826086956522, 1.0891304347826, -0.0375
100047, 1.504347826087, 1.1152173913043, -0.0375
100048, 1.504347826087, 1.0891304347826, -0.01875
100049, 1.5260869565217, 1.0891304347826, -0.0375
100050, 1.5478260869565, 1.1152173913043, -0.0375
100051, 1.5478260869565, 1.0891304347826, -0.01875
100052, 1.5695652173913, 1.0891304347826, -0.0375
100053, 1.5913043478261, 1.1152173913043, -0.0375
100054, 1.5913043478261, 1.0891304347826, -0.01875
100055, 1.6130434782609, 1.0891304347826, -0.0375
100056, 1.6347826086957, 1.1152173913043, -0.0375
100057, 1.6347826086957, 1.0891304347826, -0.01875
100058, 1.6565217391304, 1.0891304347826, -0.0375
100059, 1.6782608695652, 1.1152173913043, -0.0375
100060, 1.6782608695652, 1.0891304347826, -0.01875
100061, 1.7, 1.0891304347826, -0.0375
100062, 1.7217391304348, 1.1152173913043, -0.0375
100063, 1.7217391304348, 1.0891304347826, -0.01875
100064, 1.7434782608696, 1.0891304347826, -0.0375
100065, 1.7652173913043, 1.1152173913043, -0.0375
100066, 1.7652173913043, 1.0891304347826, -0.01875
100067, 1.7869565217391, 1.0891304347826, -0.0375
100068, 1.8086956521739, 1.1152173913043, -0.0375
100069, 1.8086956521739, 1.0891304347826, -0.01875
100070, 1.8304347826087, 1.0891304347826, -0.0375
100071, 1.8521739130435, 1.1152173913043, -0.0375
100072, 1.8521739130435, 1.0891304347826, -0.01875
100073, 1.8739130434783, 1.0891304347826, -0.0375
100074, 1.895652173913, 1.1152173913043, -0.0375
100075, 1.895652173913, 1.0891304347826, -0.01875
100076, 1.9173913043478, 1.0891304347826, -0.0375
100077, 1.9391304347826, 1.1152173913043, -0.0375
100078, 1.9391304347826, 1.0891304347826, -0.01875
100079, 1.9608695652174, 1.0891304347826, -0.0375
100080, 1.9826086956522, 1.1152173913043, -0.0375
100081, 1.9826086956522, 1.0891304347826, -0.01875
100082, 2.004347826087, 1.0891304347826, -0.0375
100083, 2.0260869565217, 1.1152173913043, -0.0375
100084, 2.0260869565217, 1.0891304347826, -0.01875
100085, 2.0478260869565, 1.0891304347826, -0.0375
100086, 2.0695652173913, 1.1152173913043, -0.0375
