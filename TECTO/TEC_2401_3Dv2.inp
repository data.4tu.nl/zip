3299, 1.2, 1.0630434782609, 0
3300, 1.2, 1.0108695652174, 0
3301, 1.2, 0.95869565217391, 0
3302, 1.2, 0.90652173913044, 0
3303, 1.2, 0.85434782608696, 0
3304, 1.2, 0.80217391304348, 0
3305, 1.2, 0.75, 0
3306, 1.2, 0.69782608695652, 0
3307, 1.2, 0.64565217391304, 0
3308, 1.2, 0.59347826086957, 0
3309, 1.2, 0.54130434782609, 0
3310, 1.2, 0.48913043478261, 0
3311, 1.2, 0.43695652173913, 0
3312, 1.2, 0.38478260869565, 0
3313, 1.2, 0.33260869565217, 0
3314, 1.2, 0.2804347826087, 0
3315, 1.2, 0.22826086956522, 0
3316, 1.2, 0.17608695652174, 0
3317, 2.2, 1.2978260869565, 0
3318, 2.2, 1.245652173913, 0
3319, 2.2, 1.1934782608696, 0
3320, 2.2, 1.1413043478261, 0
3321, 2.2, 1.0891304347826, 0
3322, 2.2, 1.0369565217391, 0
3323, 2.2, 0.98478260869565, 0
3324, 2.2, 0.93260869565217, 0
3325, 2.2, 0.8804347826087, 0
3326, 2.2, 0.82826086956522, 0
3327, 2.2, 0.77608695652174, 0
3328, 2.2, 0.72391304347826, 0
3329, 2.2, 0.67173913043478, 0
3330, 2.2, 0.61956521739131, 0
3331, 2.2, 0.56739130434783, 0
3332, 2.2, 0.51521739130435, 0
3333, 2.2, 0.46304347826087, 0
3334, 2.2, 0.41086956521739, 0
3335, 2.2, 0.35869565217391, 0
3336, 2.2, 0.30652173913044, 0
3337, 2.2, 0.25434782608696, 0
3338, 2.2, 0.20217391304348, 0
3339, 2.2, 1.3239130434783, 0
3340, 2.2, 1.2717391304348, 0
3341, 2.2, 1.2195652173913, 0
3342, 2.2, 1.1673913043478, 0
3343, 2.2, 1.1152173913043, 0
3344, 2.2, 1.0630434782609, 0
3345, 2.2, 1.0108695652174, 0
3346, 2.2, 0.95869565217391, 0
3347, 2.2, 0.90652173913044, 0
3348, 2.2, 0.85434782608696, 0
3349, 2.2, 0.80217391304348, 0
3350, 2.2, 0.75, 0
3351, 2.2, 0.69782608695652, 0
3352, 2.2, 0.64565217391304, 0
3353, 2.2, 0.59347826086957, 0
3354, 2.2, 0.54130434782609, 0
3355, 2.2, 0.48913043478261, 0
3356, 2.2, 0.43695652173913, 0
3357, 2.2, 0.38478260869565, 0
3358, 2.2, 0.33260869565217, 0
3359, 2.2, 0.2804347826087, 0
3360, 2.2, 0.22826086956522, 0
3361, 2.2, 0.17608695652174, 0
3362, 1.2434782608696, 1.35, 0
3363, 1.2869565217391, 1.35, 0
3364, 1.3304347826087, 1.35, 0
3365, 1.3739130434783, 1.35, 0
3366, 1.4173913043478, 1.35, 0
3367, 1.4608695652174, 1.35, 0
3368, 1.504347826087, 1.35, 0
3369, 1.5478260869565, 1.35, 0
3370, 1.5913043478261, 1.35, 0
3371, 1.6347826086957, 1.35, 0
3372, 1.6782608695652, 1.35, 0
3373, 1.7217391304348, 1.35, 0
3374, 1.7652173913043, 1.35, 0
3375, 1.8086956521739, 1.35, 0
3376, 1.8521739130435, 1.35, 0
3377, 1.895652173913, 1.35, 0
3378, 1.9391304347826, 1.35, 0
3379, 1.9826086956522, 1.35, 0
3380, 2.0260869565217, 1.35, 0
3381, 2.0695652173913, 1.35, 0
3382, 2.1130434782609, 1.35, 0
3383, 2.1565217391304, 1.35, 0
3384, 1.2217391304348, 1.35, 0
3385, 1.2652173913043, 1.35, 0
3386, 1.3086956521739, 1.35, 0
3387, 1.3521739130435, 1.35, 0
3388, 1.395652173913, 1.35, 0
3389, 1.4391304347826, 1.35, 0
3390, 1.4826086956522, 1.35, 0
3391, 1.5260869565217, 1.35, 0
3392, 1.5695652173913, 1.35, 0
3393, 1.6130434782609, 1.35, 0
3394, 1.6565217391304, 1.35, 0
3395, 1.7, 1.35, 0
3396, 1.7434782608696, 1.35, 0
3397, 1.7869565217391, 1.35, 0
3398, 1.8304347826087, 1.35, 0
3399, 1.8739130434783, 1.35, 0
3400, 1.9173913043478, 1.35, 0
3401, 1.9608695652174, 1.35, 0
3402, 2.004347826087, 1.35, 0
3403, 2.0478260869565, 1.35, 0
3404, 2.0913043478261, 1.35, 0
3405, 2.1347826086957, 1.35, 0
3406, 2.1782608695652, 1.35, 0
3407, 1.2, 1.35, 0.055555555555556
3408, 1.2, 1.35, 0.11111111111111
3409, 1.2, 1.35, 0.16666666666667
3410, 1.2, 1.35, 0.22222222222222
3411, 1.2, 1.35, 0.27777777777778
3412, 1.2, 1.35, 0.33333333333333
3413, 1.2, 1.35, 0.38888888888889
3414, 1.2, 1.35, 0.44444444444444
3415, 1.2, 1.35, 0.027777777777778
3416, 1.2, 1.35, 0.083333333333333
3417, 1.2, 1.35, 0.13888888888889
3418, 1.2, 1.35, 0.19444444444444
3419, 1.2, 1.35, 0.25
3420, 1.2, 1.35, 0.30555555555556
3421, 1.2, 1.35, 0.36111111111111
3422, 1.2, 1.35, 0.41666666666667
3423, 1.2, 1.35, 0.47222222222222
3424, 2.2, 1.35, 0.055555555555556
3425, 2.2, 1.35, 0.11111111111111
3426, 2.2, 1.35, 0.16666666666667
3427, 2.2, 1.35, 0.22222222222222
3428, 2.2, 1.35, 0.27777777777778
3429, 2.2, 1.35, 0.33333333333333
3430, 2.2, 1.35, 0.38888888888889
3431, 2.2, 1.35, 0.44444444444444
3432, 2.2, 1.35, 0.027777777777778
3433, 2.2, 1.35, 0.083333333333333
3434, 2.2, 1.35, 0.13888888888889
3435, 2.2, 1.35, 0.19444444444444
3436, 2.2, 1.35, 0.25
3437, 2.2, 1.35, 0.30555555555556
3438, 2.2, 1.35, 0.36111111111111
3439, 2.2, 1.35, 0.41666666666667
3440, 2.2, 1.35, 0.47222222222222
3441, 1.2, 0.125, 0.5
3442, 1.2, 0.1375, 0.5
3443, 1.2, 0.1125, 0.5
3444, 2.2, 0.125, 0.5
3445, 2.2, 0.1375, 0.5
3446, 2.2, 0.1125, 0.5
3447, 1.2434782608696, 0.1, 0.5
3448, 1.2869565217391, 0.1, 0.5
3449, 1.3304347826087, 0.1, 0.5
3450, 1.3739130434783, 0.1, 0.5
3451, 1.4173913043478, 0.1, 0.5
3452, 1.4608695652174, 0.1, 0.5
3453, 1.504347826087, 0.1, 0.5
3454, 1.5478260869565, 0.1, 0.5
3455, 1.5913043478261, 0.1, 0.5
3456, 1.6347826086957, 0.1, 0.5
3457, 1.6782608695652, 0.1, 0.5
3458, 1.7217391304348, 0.1, 0.5
3459, 1.7652173913043, 0.1, 0.5
3460, 1.8086956521739, 0.1, 0.5
3461, 1.8521739130435, 0.1, 0.5
3462, 1.895652173913, 0.1, 0.5
3463, 1.9391304347826, 0.1, 0.5
3464, 1.9826086956522, 0.1, 0.5
3465, 2.0260869565217, 0.1, 0.5
3466, 2.0695652173913, 0.1, 0.5
3467, 2.1130434782609, 0.1, 0.5
3468, 2.1565217391304, 0.1, 0.5
3469, 1.2217391304348, 0.1, 0.5
3470, 1.2652173913043, 0.1, 0.5
3471, 1.3086956521739, 0.1, 0.5
3472, 1.3521739130435, 0.1, 0.5
3473, 1.395652173913, 0.1, 0.5
3474, 1.4391304347826, 0.1, 0.5
3475, 1.4826086956522, 0.1, 0.5
3476, 1.5260869565217, 0.1, 0.5
3477, 1.5695652173913, 0.1, 0.5
3478, 1.6130434782609, 0.1, 0.5
3479, 1.6565217391304, 0.1, 0.5
3480, 1.7, 0.1, 0.5
3481, 1.7434782608696, 0.1, 0.5
3482, 1.7869565217391, 0.1, 0.5
3483, 1.8304347826087, 0.1, 0.5
3484, 1.8739130434783, 0.1, 0.5
3485, 1.9173913043478, 0.1, 0.5
3486, 1.9608695652174, 0.1, 0.5
3487, 2.004347826087, 0.1, 0.5
3488, 2.0478260869565, 0.1, 0.5
3489, 2.0913043478261, 0.1, 0.5
3490, 2.1347826086957, 0.1, 0.5
3491, 2.1782608695652, 0.1, 0.5
3492, 1.2, 0.125, 0
3493, 1.2, 0.1375, 0
3494, 1.2, 0.1125, 0
3495, 2.2, 0.125, 0
3496, 2.2, 0.1375, 0
3497, 2.2, 0.1125, 0
3498, 1.2434782608696, 0.1, 0
3499, 1.2869565217391, 0.1, 0
3500, 1.3304347826087, 0.1, 0
3501, 1.3739130434783, 0.1, 0
3502, 1.4173913043478, 0.1, 0
3503, 1.4608695652174, 0.1, 0
3504, 1.504347826087, 0.1, 0
3505, 1.5478260869565, 0.1, 0
3506, 1.5913043478261, 0.1, 0
3507, 1.6347826086957, 0.1, 0
3508, 1.6782608695652, 0.1, 0
3509, 1.7217391304348, 0.1, 0
3510, 1.7652173913043, 0.1, 0
3511, 1.8086956521739, 0.1, 0
3512, 1.8521739130435, 0.1, 0
3513, 1.895652173913, 0.1, 0
3514, 1.9391304347826, 0.1, 0
3515, 1.9826086956522, 0.1, 0
3516, 2.0260869565217, 0.1, 0
3517, 2.0695652173913, 0.1, 0
3518, 2.1130434782609, 0.1, 0
3519, 2.1565217391304, 0.1, 0
3520, 1.2217391304348, 0.1, 0
3521, 1.2652173913043, 0.1, 0
3522, 1.3086956521739, 0.1, 0
3523, 1.3521739130435, 0.1, 0
3524, 1.395652173913, 0.1, 0
3525, 1.4391304347826, 0.1, 0
3526, 1.4826086956522, 0.1, 0
3527, 1.5260869565217, 0.1, 0
3528, 1.5695652173913, 0.1, 0
3529, 1.6130434782609, 0.1, 0
3530, 1.6565217391304, 0.1, 0
3531, 1.7, 0.1, 0
3532, 1.7434782608696, 0.1, 0
3533, 1.7869565217391, 0.1, 0
3534, 1.8304347826087, 0.1, 0
3535, 1.8739130434783, 0.1, 0
3536, 1.9173913043478, 0.1, 0
3537, 1.9608695652174, 0.1, 0
3538, 2.004347826087, 0.1, 0
3539, 2.0478260869565, 0.1, 0
3540, 2.0913043478261, 0.1, 0
3541, 2.1347826086957, 0.1, 0
3542, 2.1782608695652, 0.1, 0
3543, 1.2, 0.1, 0.055555555555556
3544, 1.2, 0.1, 0.11111111111111
3545, 1.2, 0.1, 0.16666666666667
3546, 1.2, 0.1, 0.22222222222222
3547, 1.2, 0.1, 0.27777777777778
3548, 1.2, 0.1, 0.33333333333333
3549, 1.2, 0.1, 0.38888888888889
3550, 1.2, 0.1, 0.44444444444444
3551, 1.2, 0.1, 0.027777777777778
3552, 1.2, 0.1, 0.083333333333333
3553, 1.2, 0.1, 0.13888888888889
3554, 1.2, 0.1, 0.19444444444444
3555, 1.2, 0.1, 0.25
3556, 1.2, 0.1, 0.30555555555556
3557, 1.2, 0.1, 0.36111111111111
3558, 1.2, 0.1, 0.41666666666667
3559, 1.2, 0.1, 0.47222222222222
3560, 2.2, 0.1, 0.055555555555556
3561, 2.2, 0.1, 0.11111111111111
3562, 2.2, 0.1, 0.16666666666667
3563, 2.2, 0.1, 0.22222222222222
3564, 2.2, 0.1, 0.27777777777778
3565, 2.2, 0.1, 0.33333333333333
3566, 2.2, 0.1, 0.38888888888889
3567, 2.2, 0.1, 0.44444444444444
3568, 2.2, 0.1, 0.027777777777778
3569, 2.2, 0.1, 0.083333333333333
3570, 2.2, 0.1, 0.13888888888889
3571, 2.2, 0.1, 0.19444444444444
3572, 2.2, 0.1, 0.25
3573, 2.2, 0.1, 0.30555555555556
3574, 2.2, 0.1, 0.36111111111111
3575, 2.2, 0.1, 0.41666666666667
3576, 2.2, 0.1, 0.47222222222222
3577, 1.2, 0.075, 0.5
3578, 1.2, 0.0625, 0.5
3579, 1.2, 0.0875, 0.5
3580, 2.2, 0.075, 0.5
3581, 2.2, 0.0625, 0.5
3582, 2.2, 0.0875, 0.5
3583, 1.2, 0.075, 0
3584, 1.2, 0.0625, 0
3585, 1.2, 0.0875, 0
3586, 2.2, 0.075, 0
3587, 2.2, 0.0625, 0
3588, 2.2, 0.0875, 0
3589, 1, 0.075, 0
3590, 1, 0.0625, 0
3591, 1, 0.0875, 0
3592, 0, 0.075, 0
3593, 0, 0.0625, 0
3594, 0, 0.0875, 0
3595, 1, 0.075, 0.5
3596, 1, 0.0625, 0.5
3597, 1, 0.0875, 0.5
3598, 0, 0.075, 0.5
3599, 0, 0.0625, 0.5
3600, 0, 0.0875, 0.5
3601, 1.0375, 0.15, 0.5
3602, 1.01875, 0.15, 0.5
3603, 1.05625, 0.15, 0.5
3604, 1.0375, 1.35, 0.5
3605, 1.01875, 1.35, 0.5
3606, 1.05625, 1.35, 0.5
3607, 1.075, 0.20217391304348, 0.5
3608, 1.075, 0.25434782608696, 0.5
3609, 1.075, 0.30652173913043, 0.5
3610, 1.075, 0.35869565217391, 0.5
3611, 1.075, 0.41086956521739, 0.5
3612, 1.075, 0.46304347826087, 0.5
3613, 1.075, 0.51521739130435, 0.5
3614, 1.075, 0.56739130434783, 0.5
3615, 1.075, 0.6195652173913, 0.5
3616, 1.075, 0.67173913043478, 0.5
3617, 1.075, 0.72391304347826, 0.5
3618, 1.075, 0.77608695652174, 0.5
3619, 1.075, 0.82826086956522, 0.5
3620, 1.075, 0.88043478260869, 0.5
3621, 1.075, 0.93260869565217, 0.5
3622, 1.075, 0.98478260869565, 0.5
3623, 1.075, 1.0369565217391, 0.5
3624, 1.075, 1.0891304347826, 0.5
3625, 1.075, 1.1413043478261, 0.5
3626, 1.075, 1.1934782608696, 0.5
3627, 1.075, 1.245652173913, 0.5
3628, 1.075, 1.2978260869565, 0.5
3629, 1.075, 0.17608695652174, 0.5
3630, 1.075, 0.22826086956522, 0.5
3631, 1.075, 0.2804347826087, 0.5
3632, 1.075, 0.33260869565217, 0.5
3633, 1.075, 0.38478260869565, 0.5
3634, 1.075, 0.43695652173913, 0.5
3635, 1.075, 0.48913043478261, 0.5
3636, 1.075, 0.54130434782609, 0.5
3637, 1.075, 0.59347826086956, 0.5
3638, 1.075, 0.64565217391304, 0.5
3639, 1.075, 0.69782608695652, 0.5
3640, 1.075, 0.75, 0.5
3641, 1.075, 0.80217391304348, 0.5
3642, 1.075, 0.85434782608696, 0.5
3643, 1.075, 0.90652173913043, 0.5
3644, 1.075, 0.95869565217391, 0.5
3645, 1.075, 1.0108695652174, 0.5
3646, 1.075, 1.0630434782609, 0.5
3647, 1.075, 1.1152173913043, 0.5
3648, 1.075, 1.1673913043478, 0.5
3649, 1.075, 1.2195652173913, 0.5
3650, 1.075, 1.2717391304348, 0.5
3651, 1.075, 1.3239130434783, 0.5
3652, 1.0375, 0.15, 0
3653, 1.01875, 0.15, 0
3654, 1.05625, 0.15, 0
3655, 1.0375, 1.35, 0
3656, 1.01875, 1.35, 0
3657, 1.05625, 1.35, 0
3658, 1.075, 0.20217391304348, 0
3659, 1.075, 0.25434782608696, 0
3660, 1.075, 0.30652173913043, 0
3661, 1.075, 0.35869565217391, 0
3662, 1.075, 0.41086956521739, 0
3663, 1.075, 0.46304347826087, 0
3664, 1.075, 0.51521739130435, 0
3665, 1.075, 0.56739130434783, 0
3666, 1.075, 0.6195652173913, 0
3667, 1.075, 0.67173913043478, 0
3668, 1.075, 0.72391304347826, 0
3669, 1.075, 0.77608695652174, 0
3670, 1.075, 0.82826086956522, 0
3671, 1.075, 0.88043478260869, 0
3672, 1.075, 0.93260869565217, 0
3673, 1.075, 0.98478260869565, 0
3674, 1.075, 1.0369565217391, 0
3675, 1.075, 1.0891304347826, 0
3676, 1.075, 1.1413043478261, 0
3677, 1.075, 1.1934782608696, 0
3678, 1.075, 1.245652173913, 0
3679, 1.075, 1.2978260869565, 0
3680, 1.075, 0.17608695652174, 0
3681, 1.075, 0.22826086956522, 0
3682, 1.075, 0.2804347826087, 0
3683, 1.075, 0.33260869565217, 0
3684, 1.075, 0.38478260869565, 0
3685, 1.075, 0.43695652173913, 0
3686, 1.075, 0.48913043478261, 0
3687, 1.075, 0.54130434782609, 0
3688, 1.075, 0.59347826086956, 0
3689, 1.075, 0.64565217391304, 0
3690, 1.075, 0.69782608695652, 0
3691, 1.075, 0.75, 0
3692, 1.075, 0.80217391304348, 0
3693, 1.075, 0.85434782608696, 0
3694, 1.075, 0.90652173913043, 0
3695, 1.075, 0.95869565217391, 0
3696, 1.075, 1.0108695652174, 0
3697, 1.075, 1.0630434782609, 0
3698, 1.075, 1.1152173913043, 0
3699, 1.075, 1.1673913043478, 0
3700, 1.075, 1.2195652173913, 0
3701, 1.075, 1.2717391304348, 0
3702, 1.075, 1.3239130434783, 0
3703, 1.075, 0.15, 0.055555555555556
3704, 1.075, 0.15, 0.11111111111111
3705, 1.075, 0.15, 0.16666666666667
3706, 1.075, 0.15, 0.22222222222222
3707, 1.075, 0.15, 0.27777777777778
3708, 1.075, 0.15, 0.33333333333333
3709, 1.075, 0.15, 0.38888888888889
3710, 1.075, 0.15, 0.44444444444444
3711, 1.075, 0.15, 0.027777777777778
3712, 1.075, 0.15, 0.083333333333333
3713, 1.075, 0.15, 0.13888888888889
3714, 1.075, 0.15, 0.19444444444444
3715, 1.075, 0.15, 0.25
3716, 1.075, 0.15, 0.30555555555556
3717, 1.075, 0.15, 0.36111111111111
3718, 1.075, 0.15, 0.41666666666667
3719, 1.075, 0.15, 0.47222222222222
3720, 1.075, 1.35, 0.055555555555556
3721, 1.075, 1.35, 0.11111111111111
3722, 1.075, 1.35, 0.16666666666667
3723, 1.075, 1.35, 0.22222222222222
3724, 1.075, 1.35, 0.27777777777778
3725, 1.075, 1.35, 0.33333333333333
3726, 1.075, 1.35, 0.38888888888889
3727, 1.075, 1.35, 0.44444444444444
3728, 1.075, 1.35, 0.027777777777778
3729, 1.075, 1.35, 0.083333333333333
3730, 1.075, 1.35, 0.13888888888889
3731, 1.075, 1.35, 0.19444444444444
3732, 1.075, 1.35, 0.25
3733, 1.075, 1.35, 0.30555555555556
3734, 1.075, 1.35, 0.36111111111111
3735, 1.075, 1.35, 0.41666666666667
3736, 1.075, 1.35, 0.47222222222222
3737, 1.1625, 1.35, 0.5
3738, 1.18125, 1.35, 0.5
3739, 1.14375, 1.35, 0.5
3740, 1.1625, 0.15, 0.5
3741, 1.18125, 0.15, 0.5
3742, 1.14375, 0.15, 0.5
3743, 1.125, 1.2978260869565, 0.5
3744, 1.125, 1.245652173913, 0.5
3745, 1.125, 1.1934782608696, 0.5
3746, 1.125, 1.1413043478261, 0.5
3747, 1.125, 1.0891304347826, 0.5
3748, 1.125, 1.0369565217391, 0.5
3749, 1.125, 0.98478260869565, 0.5
3750, 1.125, 0.93260869565217, 0.5
3751, 1.125, 0.8804347826087, 0.5
3752, 1.125, 0.82826086956522, 0.5
3753, 1.125, 0.77608695652174, 0.5
3754, 1.125, 0.72391304347826, 0.5
3755, 1.125, 0.67173913043478, 0.5
3756, 1.125, 0.61956521739131, 0.5
3757, 1.125, 0.56739130434783, 0.5
3758, 1.125, 0.51521739130435, 0.5
3759, 1.125, 0.46304347826087, 0.5
3760, 1.125, 0.41086956521739, 0.5
3761, 1.125, 0.35869565217391, 0.5
3762, 1.125, 0.30652173913044, 0.5
3763, 1.125, 0.25434782608696, 0.5
3764, 1.125, 0.20217391304348, 0.5
3765, 1.125, 1.3239130434783, 0.5
3766, 1.125, 1.2717391304348, 0.5
3767, 1.125, 1.2195652173913, 0.5
3768, 1.125, 1.1673913043478, 0.5
3769, 1.125, 1.1152173913043, 0.5
3770, 1.125, 1.0630434782609, 0.5
3771, 1.125, 1.0108695652174, 0.5
3772, 1.125, 0.95869565217391, 0.5
3773, 1.125, 0.90652173913044, 0.5
3774, 1.125, 0.85434782608696, 0.5
3775, 1.125, 0.80217391304348, 0.5
3776, 1.125, 0.75, 0.5
3777, 1.125, 0.69782608695652, 0.5
3778, 1.125, 0.64565217391304, 0.5
3779, 1.125, 0.59347826086957, 0.5
3780, 1.125, 0.54130434782609, 0.5
3781, 1.125, 0.48913043478261, 0.5
3782, 1.125, 0.43695652173913, 0.5
3783, 1.125, 0.38478260869565, 0.5
3784, 1.125, 0.33260869565217, 0.5
3785, 1.125, 0.2804347826087, 0.5
3786, 1.125, 0.22826086956522, 0.5
3787, 1.125, 0.17608695652174, 0.5
3788, 1.1625, 1.35, 0
3789, 1.18125, 1.35, 0
3790, 1.14375, 1.35, 0
3791, 1.1625, 0.15, 0
3792, 1.18125, 0.15, 0
3793, 1.14375, 0.15, 0
3794, 1.125, 1.2978260869565, 0
3795, 1.125, 1.245652173913, 0
3796, 1.125, 1.1934782608696, 0
3797, 1.125, 1.1413043478261, 0
3798, 1.125, 1.0891304347826, 0
3799, 1.125, 1.0369565217391, 0
3800, 1.125, 0.98478260869565, 0
3801, 1.125, 0.93260869565217, 0
3802, 1.125, 0.8804347826087, 0
3803, 1.125, 0.82826086956522, 0
3804, 1.125, 0.77608695652174, 0
3805, 1.125, 0.72391304347826, 0
3806, 1.125, 0.67173913043478, 0
3807, 1.125, 0.61956521739131, 0
3808, 1.125, 0.56739130434783, 0
3809, 1.125, 0.51521739130435, 0
3810, 1.125, 0.46304347826087, 0
3811, 1.125, 0.41086956521739, 0
3812, 1.125, 0.35869565217391, 0
3813, 1.125, 0.30652173913044, 0
3814, 1.125, 0.25434782608696, 0
3815, 1.125, 0.20217391304348, 0
3816, 1.125, 1.3239130434783, 0
3817, 1.125, 1.2717391304348, 0
3818, 1.125, 1.2195652173913, 0
3819, 1.125, 1.1673913043478, 0
3820, 1.125, 1.1152173913043, 0
3821, 1.125, 1.0630434782609, 0
3822, 1.125, 1.0108695652174, 0
3823, 1.125, 0.95869565217391, 0
3824, 1.125, 0.90652173913044, 0
3825, 1.125, 0.85434782608696, 0
3826, 1.125, 0.80217391304348, 0
3827, 1.125, 0.75, 0
3828, 1.125, 0.69782608695652, 0
3829, 1.125, 0.64565217391304, 0
3830, 1.125, 0.59347826086957, 0
3831, 1.125, 0.54130434782609, 0
3832, 1.125, 0.48913043478261, 0
3833, 1.125, 0.43695652173913, 0
3834, 1.125, 0.38478260869565, 0
3835, 1.125, 0.33260869565217, 0
3836, 1.125, 0.2804347826087, 0
3837, 1.125, 0.22826086956522, 0
3838, 1.125, 0.17608695652174, 0
3839, 1.125, 1.35, 0.055555555555556
3840, 1.125, 1.35, 0.11111111111111
3841, 1.125, 1.35, 0.16666666666667
3842, 1.125, 1.35, 0.22222222222222
3843, 1.125, 1.35, 0.27777777777778
3844, 1.125, 1.35, 0.33333333333333
3845, 1.125, 1.35, 0.38888888888889
3846, 1.125, 1.35, 0.44444444444444
3847, 1.125, 1.35, 0.027777777777778
3848, 1.125, 1.35, 0.083333333333333
3849, 1.125, 1.35, 0.13888888888889
3850, 1.125, 1.35, 0.19444444444444
3851, 1.125, 1.35, 0.25
3852, 1.125, 1.35, 0.30555555555556
3853, 1.125, 1.35, 0.36111111111111
3854, 1.125, 1.35, 0.41666666666667
3855, 1.125, 1.35, 0.47222222222222
3856, 1.125, 0.15, 0.055555555555556
3857, 1.125, 0.15, 0.11111111111111
3858, 1.125, 0.15, 0.16666666666667
3859, 1.125, 0.15, 0.22222222222222
3860, 1.125, 0.15, 0.27777777777778
3861, 1.125, 0.15, 0.33333333333333
3862, 1.125, 0.15, 0.38888888888889
3863, 1.125, 0.15, 0.44444444444444
3864, 1.125, 0.15, 0.027777777777778
3865, 1.125, 0.15, 0.083333333333333
3866, 1.125, 0.15, 0.13888888888889
3867, 1.125, 0.15, 0.19444444444444
3868, 1.125, 0.15, 0.25
3869, 1.125, 0.15, 0.30555555555556
3870, 1.125, 0.15, 0.36111111111111
3871, 1.125, 0.15, 0.41666666666667
3872, 1.125, 0.15, 0.47222222222222
3873, 1, 1.375, 0
3874, 1, 1.3875, 0
3875, 1, 1.3625, 0
3876, 0, 1.375, 0
3877, 0, 1.3875, 0
3878, 0, 1.3625, 0
3879, 1, 1.375, 0.5
3880, 1, 1.3875, 0.5
3881, 1, 1.3625, 0.5
3882, 0, 1.375, 0.5
3883, 0, 1.3875, 0.5
3884, 0, 1.3625, 0.5
3885, 1.2, 1.375, 0.5
3886, 1.2, 1.3875, 0.5
3887, 1.2, 1.3625, 0.5
3888, 2.2, 1.375, 0.5
3889, 2.2, 1.3875, 0.5
3890, 2.2, 1.3625, 0.5
3891, 1.2, 1.375, 0
3892, 1.2, 1.3875, 0
3893, 1.2, 1.3625, 0
3894, 2.2, 1.375, 0
3895, 2.2, 1.3875, 0
3896, 2.2, 1.3625, 0
3897, 1, 0.15, -0.0375
3898, 1, 0.15, -0.01875
3899, 1, 0.15, -0.05625
3900, 1, 1.35, -0.0375
3901, 1, 1.35, -0.01875
3902, 1, 1.35, -0.05625
3903, 1, 0.20217391304348, -0.075
3904, 1, 0.25434782608696, -0.075
3905, 1, 0.30652173913043, -0.075
3906, 1, 0.35869565217391, -0.075
3907, 1, 0.41086956521739, -0.075
3908, 1, 0.46304347826087, -0.075
3909, 1, 0.51521739130435, -0.075
3910, 1, 0.56739130434783, -0.075
3911, 1, 0.6195652173913, -0.075
3912, 1, 0.67173913043478, -0.075
3913, 1, 0.72391304347826, -0.075
3914, 1, 0.77608695652174, -0.075
3915, 1, 0.82826086956522, -0.075
3916, 1, 0.88043478260869, -0.075
3917, 1, 0.93260869565217, -0.075
3918, 1, 0.98478260869565, -0.075
3919, 1, 1.0369565217391, -0.075
3920, 1, 1.0891304347826, -0.075
3921, 1, 1.1413043478261, -0.075
3922, 1, 1.1934782608696, -0.075
3923, 1, 1.245652173913, -0.075
3924, 1, 1.2978260869565, -0.075
3925, 1, 0.17608695652174, -0.075
3926, 1, 0.22826086956522, -0.075
3927, 1, 0.2804347826087, -0.075
3928, 1, 0.33260869565217, -0.075
3929, 1, 0.38478260869565, -0.075
3930, 1, 0.43695652173913, -0.075
3931, 1, 0.48913043478261, -0.075
3932, 1, 0.54130434782609, -0.075
3933, 1, 0.59347826086956, -0.075
3934, 1, 0.64565217391304, -0.075
3935, 1, 0.69782608695652, -0.075
3936, 1, 0.75, -0.075
3937, 1, 0.80217391304348, -0.075
3938, 1, 0.85434782608696, -0.075
3939, 1, 0.90652173913043, -0.075
3940, 1, 0.95869565217391, -0.075
3941, 1, 1.0108695652174, -0.075
3942, 1, 1.0630434782609, -0.075
3943, 1, 1.1152173913043, -0.075
3944, 1, 1.1673913043478, -0.075
3945, 1, 1.2195652173913, -0.075
3946, 1, 1.2717391304348, -0.075
3947, 1, 1.3239130434783, -0.075
3948, 0, 0.15, -0.0375
3949, 0, 0.15, -0.01875
3950, 0, 0.15, -0.05625
3951, 0, 1.35, -0.0375
3952, 0, 1.35, -0.01875
3953, 0, 1.35, -0.05625
3954, 0, 0.20217391304348, -0.075
3955, 0, 0.25434782608696, -0.075
3956, 0, 0.30652173913043, -0.075
3957, 0, 0.35869565217391, -0.075
3958, 0, 0.41086956521739, -0.075
3959, 0, 0.46304347826087, -0.075
3960, 0, 0.51521739130435, -0.075
3961, 0, 0.56739130434783, -0.075
3962, 0, 0.6195652173913, -0.075
3963, 0, 0.67173913043478, -0.075
3964, 0, 0.72391304347826, -0.075
3965, 0, 0.77608695652174, -0.075
3966, 0, 0.82826086956522, -0.075
3967, 0, 0.88043478260869, -0.075
3968, 0, 0.93260869565217, -0.075
3969, 0, 0.98478260869565, -0.075
3970, 0, 1.0369565217391, -0.075
3971, 0, 1.0891304347826, -0.075
3972, 0, 1.1413043478261, -0.075
3973, 0, 1.1934782608696, -0.075
3974, 0, 1.245652173913, -0.075
3975, 0, 1.2978260869565, -0.075
3976, 0, 0.17608695652174, -0.075
3977, 0, 0.22826086956522, -0.075
3978, 0, 0.2804347826087, -0.075
3979, 0, 0.33260869565217, -0.075
3980, 0, 0.38478260869565, -0.075
3981, 0, 0.43695652173913, -0.075
3982, 0, 0.48913043478261, -0.075
3983, 0, 0.54130434782609, -0.075
3984, 0, 0.59347826086956, -0.075
3985, 0, 0.64565217391304, -0.075
3986, 0, 0.69782608695652, -0.075
3987, 0, 0.75, -0.075
3988, 0, 0.80217391304348, -0.075
3989, 0, 0.85434782608696, -0.075
3990, 0, 0.90652173913043, -0.075
3991, 0, 0.95869565217391, -0.075
3992, 0, 1.0108695652174, -0.075
3993, 0, 1.0630434782609, -0.075
3994, 0, 1.1152173913043, -0.075
3995, 0, 1.1673913043478, -0.075
3996, 0, 1.2195652173913, -0.075
3997, 0, 1.2717391304348, -0.075
3998, 0, 1.3239130434783, -0.075
3999, 0.043478260869565, 0.15, -0.075
4000, 0.08695652173913, 0.15, -0.075
4001, 0.1304347826087, 0.15, -0.075
4002, 0.17391304347826, 0.15, -0.075
4003, 0.21739130434783, 0.15, -0.075
4004, 0.26086956521739, 0.15, -0.075
4005, 0.30434782608696, 0.15, -0.075
4006, 0.34782608695652, 0.15, -0.075
4007, 0.39130434782609, 0.15, -0.075
4008, 0.43478260869565, 0.15, -0.075
4009, 0.47826086956522, 0.15, -0.075
4010, 0.52173913043478, 0.15, -0.075
4011, 0.56521739130435, 0.15, -0.075
4012, 0.60869565217391, 0.15, -0.075
4013, 0.65217391304348, 0.15, -0.075
4014, 0.69565217391304, 0.15, -0.075
4015, 0.73913043478261, 0.15, -0.075
4016, 0.78260869565217, 0.15, -0.075
4017, 0.82608695652174, 0.15, -0.075
4018, 0.8695652173913, 0.15, -0.075
4019, 0.91304347826087, 0.15, -0.075
4020, 0.95652173913043, 0.15, -0.075
4021, 0.021739130434783, 0.15, -0.075
4022, 0.065217391304348, 0.15, -0.075
4023, 0.10869565217391, 0.15, -0.075
4024, 0.15217391304348, 0.15, -0.075
4025, 0.19565217391304, 0.15, -0.075
4026, 0.23913043478261, 0.15, -0.075
4027, 0.28260869565217, 0.15, -0.075
4028, 0.32608695652174, 0.15, -0.075
4029, 0.3695652173913, 0.15, -0.075
4030, 0.41304347826087, 0.15, -0.075
4031, 0.45652173913043, 0.15, -0.075
4032, 0.5, 0.15, -0.075
4033, 0.54347826086957, 0.15, -0.075
4034, 0.58695652173913, 0.15, -0.075
4035, 0.6304347826087, 0.15, -0.075
4036, 0.67391304347826, 0.15, -0.075
4037, 0.71739130434783, 0.15, -0.075
4038, 0.76086956521739, 0.15, -0.075
4039, 0.80434782608696, 0.15, -0.075
4040, 0.84782608695652, 0.15, -0.075
4041, 0.89130434782609, 0.15, -0.075
4042, 0.93478260869565, 0.15, -0.075
4043, 0.97826086956522, 0.15, -0.075
4044, 0.043478260869565, 1.35, -0.075
4045, 0.08695652173913, 1.35, -0.075
4046, 0.1304347826087, 1.35, -0.075
4047, 0.17391304347826, 1.35, -0.075
4048, 0.21739130434783, 1.35, -0.075
4049, 0.26086956521739, 1.35, -0.075
4050, 0.30434782608696, 1.35, -0.075
4051, 0.34782608695652, 1.35, -0.075
4052, 0.39130434782609, 1.35, -0.075
4053, 0.43478260869565, 1.35, -0.075
4054, 0.47826086956522, 1.35, -0.075
4055, 0.52173913043478, 1.35, -0.075
4056, 0.56521739130435, 1.35, -0.075
4057, 0.60869565217391, 1.35, -0.075
4058, 0.65217391304348, 1.35, -0.075
4059, 0.69565217391304, 1.35, -0.075
4060, 0.73913043478261, 1.35, -0.075
4061, 0.78260869565217, 1.35, -0.075
4062, 0.82608695652174, 1.35, -0.075
4063, 0.8695652173913, 1.35, -0.075
4064, 0.91304347826087, 1.35, -0.075
4065, 0.95652173913043, 1.35, -0.075
4066, 0.021739130434783, 1.35, -0.075
4067, 0.065217391304348, 1.35, -0.075
4068, 0.10869565217391, 1.35, -0.075
4069, 0.15217391304348, 1.35, -0.075
4070, 0.19565217391304, 1.35, -0.075
4071, 0.23913043478261, 1.35, -0.075
4072, 0.28260869565217, 1.35, -0.075
4073, 0.32608695652174, 1.35, -0.075
4074, 0.3695652173913, 1.35, -0.075
4075, 0.41304347826087, 1.35, -0.075
4076, 0.45652173913043, 1.35, -0.075
4077, 0.5, 1.35, -0.075
4078, 0.54347826086957, 1.35, -0.075
4079, 0.58695652173913, 1.35, -0.075
4080, 0.6304347826087, 1.35, -0.075
4081, 0.67391304347826, 1.35, -0.075
4082, 0.71739130434783, 1.35, -0.075
4083, 0.76086956521739, 1.35, -0.075
4084, 0.80434782608696, 1.35, -0.075
4085, 0.84782608695652, 1.35, -0.075
4086, 0.89130434782609, 1.35, -0.075
4087, 0.93478260869565, 1.35, -0.075
4088, 0.97826086956522, 1.35, -0.075
4089, 1.075, 0.15, -0.0375
4090, 1.075, 0.15, -0.01875
4091, 1.075, 0.15, -0.05625
4092, 1.0375, 0.15, -0.075
4093, 1.01875, 0.15, -0.075
4094, 1.05625, 0.15, -0.075
4095, 1.075, 1.35, -0.0375
4096, 1.075, 1.35, -0.01875
4097, 1.075, 1.35, -0.05625
4098, 1.0375, 1.35, -0.075
4099, 1.01875, 1.35, -0.075
4100, 1.05625, 1.35, -0.075
4101, 1.075, 0.20217391304348, -0.075
4102, 1.075, 0.25434782608696, -0.075
4103, 1.075, 0.30652173913043, -0.075
4104, 1.075, 0.35869565217391, -0.075
4105, 1.075, 0.41086956521739, -0.075
4106, 1.075, 0.46304347826087, -0.075
4107, 1.075, 0.51521739130435, -0.075
4108, 1.075, 0.56739130434783, -0.075
4109, 1.075, 0.6195652173913, -0.075
4110, 1.075, 0.67173913043478, -0.075
4111, 1.075, 0.72391304347826, -0.075
4112, 1.075, 0.77608695652174, -0.075
4113, 1.075, 0.82826086956522, -0.075
4114, 1.075, 0.88043478260869, -0.075
4115, 1.075, 0.93260869565217, -0.075
4116, 1.075, 0.98478260869565, -0.075
4117, 1.075, 1.0369565217391, -0.075
4118, 1.075, 1.0891304347826, -0.075
4119, 1.075, 1.1413043478261, -0.075
4120, 1.075, 1.1934782608696, -0.075
4121, 1.075, 1.245652173913, -0.075
4122, 1.075, 1.2978260869565, -0.075
4123, 1.075, 0.17608695652174, -0.075
4124, 1.075, 0.22826086956522, -0.075
4125, 1.075, 0.2804347826087, -0.075
4126, 1.075, 0.33260869565217, -0.075
4127, 1.075, 0.38478260869565, -0.075
4128, 1.075, 0.43695652173913, -0.075
4129, 1.075, 0.48913043478261, -0.075
4130, 1.075, 0.54130434782609, -0.075
4131, 1.075, 0.59347826086956, -0.075
4132, 1.075, 0.64565217391304, -0.075
4133, 1.075, 0.69782608695652, -0.075
4134, 1.075, 0.75, -0.075
4135, 1.075, 0.80217391304348, -0.075
4136, 1.075, 0.85434782608696, -0.075
4137, 1.075, 0.90652173913043, -0.075
4138, 1.075, 0.95869565217391, -0.075
4139, 1.075, 1.0108695652174, -0.075
4140, 1.075, 1.0630434782609, -0.075
4141, 1.075, 1.1152173913043, -0.075
4142, 1.075, 1.1673913043478, -0.075
4143, 1.075, 1.2195652173913, -0.075
4144, 1.075, 1.2717391304348, -0.075
4145, 1.075, 1.3239130434783, -0.075
4146, 1.2, 1.35, -0.0375
4147, 1.2, 1.35, -0.01875
4148, 1.2, 1.35, -0.05625
4149, 1.125, 1.35, -0.0375
4150, 1.125, 1.35, -0.01875
4151, 1.125, 1.35, -0.05625
4152, 1.1625, 1.35, -0.075
4153, 1.18125, 1.35, -0.075
4154, 1.14375, 1.35, -0.075
4155, 1.2, 0.15, -0.0375
4156, 1.2, 0.15, -0.01875
4157, 1.2, 0.15, -0.05625
4158, 1.125, 0.15, -0.0375
4159, 1.125, 0.15, -0.01875
4160, 1.125, 0.15, -0.05625
4161, 1.1625, 0.15, -0.075
4162, 1.18125, 0.15, -0.075
4163, 1.14375, 0.15, -0.075
4164, 1.2, 1.2978260869565, -0.075
4165, 1.2, 1.245652173913, -0.075
4166, 1.2, 1.1934782608696, -0.075
4167, 1.2, 1.1413043478261, -0.075
4168, 1.2, 1.0891304347826, -0.075
4169, 1.2, 1.0369565217391, -0.075
4170, 1.2, 0.98478260869565, -0.075
4171, 1.2, 0.93260869565217, -0.075
4172, 1.2, 0.8804347826087, -0.075
4173, 1.2, 0.82826086956522, -0.075
4174, 1.2, 0.77608695652174, -0.075
4175, 1.2, 0.72391304347826, -0.075
4176, 1.2, 0.67173913043478, -0.075
4177, 1.2, 0.61956521739131, -0.075
4178, 1.2, 0.56739130434783, -0.075
4179, 1.2, 0.51521739130435, -0.075
4180, 1.2, 0.46304347826087, -0.075
4181, 1.2, 0.41086956521739, -0.075
4182, 1.2, 0.35869565217391, -0.075
4183, 1.2, 0.30652173913044, -0.075
4184, 1.2, 0.25434782608696, -0.075
4185, 1.2, 0.20217391304348, -0.075
4186, 1.2, 1.3239130434783, -0.075
4187, 1.2, 1.2717391304348, -0.075
4188, 1.2, 1.2195652173913, -0.075
4189, 1.2, 1.1673913043478, -0.075
4190, 1.2, 1.1152173913043, -0.075
4191, 1.2, 1.0630434782609, -0.075
4192, 1.2, 1.0108695652174, -0.075
4193, 1.2, 0.95869565217391, -0.075
4194, 1.2, 0.90652173913044, -0.075
4195, 1.2, 0.85434782608696, -0.075
4196, 1.2, 0.80217391304348, -0.075
4197, 1.2, 0.75, -0.075
4198, 1.2, 0.69782608695652, -0.075
4199, 1.2, 0.64565217391304, -0.075
4200, 1.2, 0.59347826086957, -0.075
4201, 1.2, 0.54130434782609, -0.075
4202, 1.2, 0.48913043478261, -0.075
4203, 1.2, 0.43695652173913, -0.075
4204, 1.2, 0.38478260869565, -0.075
4205, 1.2, 0.33260869565217, -0.075
4206, 1.2, 0.2804347826087, -0.075
4207, 1.2, 0.22826086956522, -0.075
4208, 1.2, 0.17608695652174, -0.075
4209, 1.125, 1.2978260869565, -0.075
4210, 1.125, 1.245652173913, -0.075
4211, 1.125, 1.1934782608696, -0.075
4212, 1.125, 1.1413043478261, -0.075
4213, 1.125, 1.0891304347826, -0.075
4214, 1.125, 1.0369565217391, -0.075
4215, 1.125, 0.98478260869565, -0.075
4216, 1.125, 0.93260869565217, -0.075
4217, 1.125, 0.8804347826087, -0.075
4218, 1.125, 0.82826086956522, -0.075
4219, 1.125, 0.77608695652174, -0.075
4220, 1.125, 0.72391304347826, -0.075
4221, 1.125, 0.67173913043478, -0.075
4222, 1.125, 0.61956521739131, -0.075
4223, 1.125, 0.56739130434783, -0.075
4224, 1.125, 0.51521739130435, -0.075
4225, 1.125, 0.46304347826087, -0.075
4226, 1.125, 0.41086956521739, -0.075
4227, 1.125, 0.35869565217391, -0.075
4228, 1.125, 0.30652173913044, -0.075
4229, 1.125, 0.25434782608696, -0.075
4230, 1.125, 0.20217391304348, -0.075
4231, 1.125, 1.3239130434783, -0.075
4232, 1.125, 1.2717391304348, -0.075
4233, 1.125, 1.2195652173913, -0.075
4234, 1.125, 1.1673913043478, -0.075
4235, 1.125, 1.1152173913043, -0.075
4236, 1.125, 1.0630434782609, -0.075
4237, 1.125, 1.0108695652174, -0.075
4238, 1.125, 0.95869565217391, -0.075
4239, 1.125, 0.90652173913044, -0.075
4240, 1.125, 0.85434782608696, -0.075
4241, 1.125, 0.80217391304348, -0.075
4242, 1.125, 0.75, -0.075
4243, 1.125, 0.69782608695652, -0.075
4244, 1.125, 0.64565217391304, -0.075
4245, 1.125, 0.59347826086957, -0.075
4246, 1.125, 0.54130434782609, -0.075
4247, 1.125, 0.48913043478261, -0.075
4248, 1.125, 0.43695652173913, -0.075
4249, 1.125, 0.38478260869565, -0.075
4250, 1.125, 0.33260869565217, -0.075
4251, 1.125, 0.2804347826087, -0.075
4252, 1.125, 0.22826086956522, -0.075
4253, 1.125, 0.17608695652174, -0.075
4254, 2.2, 1.35, -0.0375
4255, 2.2, 1.35, -0.01875
4256, 2.2, 1.35, -0.05625
4257, 2.2, 0.15, -0.0375
4258, 2.2, 0.15, -0.01875
4259, 2.2, 0.15, -0.05625
4260, 2.2, 1.2978260869565, -0.075
4261, 2.2, 1.245652173913, -0.075
4262, 2.2, 1.1934782608696, -0.075
4263, 2.2, 1.1413043478261, -0.075
4264, 2.2, 1.0891304347826, -0.075
4265, 2.2, 1.0369565217391, -0.075
4266, 2.2, 0.98478260869565, -0.075
4267, 2.2, 0.93260869565217, -0.075
4268, 2.2, 0.8804347826087, -0.075
4269, 2.2, 0.82826086956522, -0.075
4270, 2.2, 0.77608695652174, -0.075
4271, 2.2, 0.72391304347826, -0.075
4272, 2.2, 0.67173913043478, -0.075
4273, 2.2, 0.61956521739131, -0.075
4274, 2.2, 0.56739130434783, -0.075
4275, 2.2, 0.51521739130435, -0.075
4276, 2.2, 0.46304347826087, -0.075
4277, 2.2, 0.41086956521739, -0.075
4278, 2.2, 0.35869565217391, -0.075
4279, 2.2, 0.30652173913044, -0.075
4280, 2.2, 0.25434782608696, -0.075
4281, 2.2, 0.20217391304348, -0.075
4282, 2.2, 1.3239130434783, -0.075
4283, 2.2, 1.2717391304348, -0.075
4284, 2.2, 1.2195652173913, -0.075
4285, 2.2, 1.1673913043478, -0.075
4286, 2.2, 1.1152173913043, -0.075
4287, 2.2, 1.0630434782609, -0.075
4288, 2.2, 1.0108695652174, -0.075
4289, 2.2, 0.95869565217391, -0.075
4290, 2.2, 0.90652173913044, -0.075
4291, 2.2, 0.85434782608696, -0.075
4292, 2.2, 0.80217391304348, -0.075
4293, 2.2, 0.75, -0.075
4294, 2.2, 0.69782608695652, -0.075
4295, 2.2, 0.64565217391304, -0.075
4296, 2.2, 0.59347826086957, -0.075
4297, 2.2, 0.54130434782609, -0.075
4298, 2.2, 0.48913043478261, -0.075
4299, 2.2, 0.43695652173913, -0.075
4300, 2.2, 0.38478260869565, -0.075
4301, 2.2, 0.33260869565217, -0.075
4302, 2.2, 0.2804347826087, -0.075
4303, 2.2, 0.22826086956522, -0.075
4304, 2.2, 0.17608695652174, -0.075
4305, 1.2434782608696, 1.35, -0.075
4306, 1.2869565217391, 1.35, -0.075
4307, 1.3304347826087, 1.35, -0.075
4308, 1.3739130434783, 1.35, -0.075
4309, 1.4173913043478, 1.35, -0.075
4310, 1.4608695652174, 1.35, -0.075
4311, 1.504347826087, 1.35, -0.075
4312, 1.5478260869565, 1.35, -0.075
4313, 1.5913043478261, 1.35, -0.075
4314, 1.6347826086957, 1.35, -0.075
4315, 1.6782608695652, 1.35, -0.075
4316, 1.7217391304348, 1.35, -0.075
4317, 1.7652173913043, 1.35, -0.075
4318, 1.8086956521739, 1.35, -0.075
4319, 1.8521739130435, 1.35, -0.075
4320, 1.895652173913, 1.35, -0.075
4321, 1.9391304347826, 1.35, -0.075
4322, 1.9826086956522, 1.35, -0.075
4323, 2.0260869565217, 1.35, -0.075
4324, 2.0695652173913, 1.35, -0.075
4325, 2.1130434782609, 1.35, -0.075
4326, 2.1565217391304, 1.35, -0.075
4327, 1.2217391304348, 1.35, -0.075
4328, 1.2652173913043, 1.35, -0.075
4329, 1.3086956521739, 1.35, -0.075
4330, 1.3521739130435, 1.35, -0.075
4331, 1.395652173913, 1.35, -0.075
4332, 1.4391304347826, 1.35, -0.075
4333, 1.4826086956522, 1.35, -0.075
4334, 1.5260869565217, 1.35, -0.075
4335, 1.5695652173913, 1.35, -0.075
4336, 1.6130434782609, 1.35, -0.075
4337, 1.6565217391304, 1.35, -0.075
4338, 1.7, 1.35, -0.075
4339, 1.7434782608696, 1.35, -0.075
4340, 1.7869565217391, 1.35, -0.075
4341, 1.8304347826087, 1.35, -0.075
4342, 1.8739130434783, 1.35, -0.075
4343, 1.9173913043478, 1.35, -0.075
4344, 1.9608695652174, 1.35, -0.075
4345, 2.004347826087, 1.35, -0.075
4346, 2.0478260869565, 1.35, -0.075
4347, 2.0913043478261, 1.35, -0.075
4348, 2.1347826086957, 1.35, -0.075
4349, 2.1782608695652, 1.35, -0.075
4350, 1.2434782608696, 0.15, -0.075
4351, 1.2869565217391, 0.15, -0.075
4352, 1.3304347826087, 0.15, -0.075
4353, 1.3739130434783, 0.15, -0.075
4354, 1.4173913043478, 0.15, -0.075
4355, 1.4608695652174, 0.15, -0.075
4356, 1.504347826087, 0.15, -0.075
4357, 1.5478260869565, 0.15, -0.075
4358, 1.5913043478261, 0.15, -0.075
4359, 1.6347826086957, 0.15, -0.075
4360, 1.6782608695652, 0.15, -0.075
4361, 1.7217391304348, 0.15, -0.075
4362, 1.7652173913043, 0.15, -0.075
4363, 1.8086956521739, 0.15, -0.075
4364, 1.8521739130435, 0.15, -0.075
4365, 1.895652173913, 0.15, -0.075
4366, 1.9391304347826, 0.15, -0.075
4367, 1.9826086956522, 0.15, -0.075
4368, 2.0260869565217, 0.15, -0.075
4369, 2.0695652173913, 0.15, -0.075
4370, 2.1130434782609, 0.15, -0.075
4371, 2.1565217391304, 0.15, -0.075
4372, 1.2217391304348, 0.15, -0.075
4373, 1.2652173913043, 0.15, -0.075
4374, 1.3086956521739, 0.15, -0.075
4375, 1.3521739130435, 0.15, -0.075
4376, 1.395652173913, 0.15, -0.075
4377, 1.4391304347826, 0.15, -0.075
4378, 1.4826086956522, 0.15, -0.075
4379, 1.5260869565217, 0.15, -0.075
4380, 1.5695652173913, 0.15, -0.075
4381, 1.6130434782609, 0.15, -0.075
4382, 1.6565217391304, 0.15, -0.075
4383, 1.7, 0.15, -0.075
4384, 1.7434782608696, 0.15, -0.075
4385, 1.7869565217391, 0.15, -0.075
4386, 1.8304347826087, 0.15, -0.075
4387, 1.8739130434783, 0.15, -0.075
4388, 1.9173913043478, 0.15, -0.075
4389, 1.9608695652174, 0.15, -0.075
4390, 2.004347826087, 0.15, -0.075
4391, 2.0478260869565, 0.15, -0.075
4392, 2.0913043478261, 0.15, -0.075
4393, 2.1347826086957, 0.15, -0.075
4394, 2.1782608695652, 0.15, -0.075
4395, 0.043478260869565, 0.15, 0.055555555555556
4396, 0.043478260869565, 0.15, 0.11111111111111
4397, 0.043478260869565, 0.15, 0.16666666666667
4398, 0.043478260869565, 0.15, 0.22222222222222
4399, 0.043478260869565, 0.15, 0.27777777777778
4400, 0.043478260869565, 0.15, 0.33333333333333
4401, 0.043478260869565, 0.15, 0.38888888888889
4402, 0.043478260869565, 0.15, 0.44444444444444
4403, 0.08695652173913, 0.15, 0.055555555555556
4404, 0.08695652173913, 0.15, 0.11111111111111
4405, 0.08695652173913, 0.15, 0.16666666666667
4406, 0.08695652173913, 0.15, 0.22222222222222
4407, 0.08695652173913, 0.15, 0.27777777777778
4408, 0.08695652173913, 0.15, 0.33333333333333
4409, 0.08695652173913, 0.15, 0.38888888888889
4410, 0.08695652173913, 0.15, 0.44444444444444
4411, 0.1304347826087, 0.15, 0.055555555555556
4412, 0.1304347826087, 0.15, 0.11111111111111
4413, 0.1304347826087, 0.15, 0.16666666666667
4414, 0.1304347826087, 0.15, 0.22222222222222
4415, 0.1304347826087, 0.15, 0.27777777777778
4416, 0.1304347826087, 0.15, 0.33333333333333
4417, 0.1304347826087, 0.15, 0.38888888888889
4418, 0.1304347826087, 0.15, 0.44444444444444
4419, 0.17391304347826, 0.15, 0.055555555555556
4420, 0.17391304347826, 0.15, 0.11111111111111
4421, 0.17391304347826, 0.15, 0.16666666666667
4422, 0.17391304347826, 0.15, 0.22222222222222
4423, 0.17391304347826, 0.15, 0.27777777777778
4424, 0.17391304347826, 0.15, 0.33333333333333
4425, 0.17391304347826, 0.15, 0.38888888888889
4426, 0.17391304347826, 0.15, 0.44444444444444
4427, 0.21739130434783, 0.15, 0.055555555555556
4428, 0.21739130434783, 0.15, 0.11111111111111
4429, 0.21739130434783, 0.15, 0.16666666666667
4430, 0.21739130434783, 0.15, 0.22222222222222
4431, 0.21739130434783, 0.15, 0.27777777777778
4432, 0.21739130434783, 0.15, 0.33333333333333
4433, 0.21739130434783, 0.15, 0.38888888888889
4434, 0.21739130434783, 0.15, 0.44444444444444
4435, 0.26086956521739, 0.15, 0.055555555555556
4436, 0.26086956521739, 0.15, 0.11111111111111
4437, 0.26086956521739, 0.15, 0.16666666666667
4438, 0.26086956521739, 0.15, 0.22222222222222
4439, 0.26086956521739, 0.15, 0.27777777777778
4440, 0.26086956521739, 0.15, 0.33333333333333
4441, 0.26086956521739, 0.15, 0.38888888888889
4442, 0.26086956521739, 0.15, 0.44444444444444
4443, 0.30434782608696, 0.15, 0.055555555555556
4444, 0.30434782608696, 0.15, 0.11111111111111
4445, 0.30434782608696, 0.15, 0.16666666666667
4446, 0.30434782608696, 0.15, 0.22222222222222
4447, 0.30434782608696, 0.15, 0.27777777777778
4448, 0.30434782608696, 0.15, 0.33333333333333
4449, 0.30434782608696, 0.15, 0.38888888888889
4450, 0.30434782608696, 0.15, 0.44444444444444
4451, 0.34782608695652, 0.15, 0.055555555555556
4452, 0.34782608695652, 0.15, 0.11111111111111
4453, 0.34782608695652, 0.15, 0.16666666666667
4454, 0.34782608695652, 0.15, 0.22222222222222
4455, 0.34782608695652, 0.15, 0.27777777777778
4456, 0.34782608695652, 0.15, 0.33333333333333
4457, 0.34782608695652, 0.15, 0.38888888888889
4458, 0.34782608695652, 0.15, 0.44444444444444
4459, 0.39130434782609, 0.15, 0.055555555555556
4460, 0.39130434782609, 0.15, 0.11111111111111
4461, 0.39130434782609, 0.15, 0.16666666666667
4462, 0.39130434782609, 0.15, 0.22222222222222
4463, 0.39130434782609, 0.15, 0.27777777777778
4464, 0.39130434782609, 0.15, 0.33333333333333
4465, 0.39130434782609, 0.15, 0.38888888888889
4466, 0.39130434782609, 0.15, 0.44444444444444
4467, 0.43478260869565, 0.15, 0.055555555555556
4468, 0.43478260869565, 0.15, 0.11111111111111
4469, 0.43478260869565, 0.15, 0.16666666666667
4470, 0.43478260869565, 0.15, 0.22222222222222
4471, 0.43478260869565, 0.15, 0.27777777777778
4472, 0.43478260869565, 0.15, 0.33333333333333
4473, 0.43478260869565, 0.15, 0.38888888888889
4474, 0.43478260869565, 0.15, 0.44444444444444
4475, 0.47826086956522, 0.15, 0.055555555555556
4476, 0.47826086956522, 0.15, 0.11111111111111
4477, 0.47826086956522, 0.15, 0.16666666666667
4478, 0.47826086956522, 0.15, 0.22222222222222
4479, 0.47826086956522, 0.15, 0.27777777777778
4480, 0.47826086956522, 0.15, 0.33333333333333
4481, 0.47826086956522, 0.15, 0.38888888888889
4482, 0.47826086956522, 0.15, 0.44444444444444
4483, 0.52173913043478, 0.15, 0.055555555555556
4484, 0.52173913043478, 0.15, 0.11111111111111
4485, 0.52173913043478, 0.15, 0.16666666666667
4486, 0.52173913043478, 0.15, 0.22222222222222
4487, 0.52173913043478, 0.15, 0.27777777777778
4488, 0.52173913043478, 0.15, 0.33333333333333
4489, 0.52173913043478, 0.15, 0.38888888888889
4490, 0.52173913043478, 0.15, 0.44444444444444
4491, 0.56521739130435, 0.15, 0.055555555555556
4492, 0.56521739130435, 0.15, 0.11111111111111
4493, 0.56521739130435, 0.15, 0.16666666666667
4494, 0.56521739130435, 0.15, 0.22222222222222
4495, 0.56521739130435, 0.15, 0.27777777777778
4496, 0.56521739130435, 0.15, 0.33333333333333
4497, 0.56521739130435, 0.15, 0.38888888888889
4498, 0.56521739130435, 0.15, 0.44444444444444
4499, 0.60869565217391, 0.15, 0.055555555555556
4500, 0.60869565217391, 0.15, 0.11111111111111
4501, 0.60869565217391, 0.15, 0.16666666666667
4502, 0.60869565217391, 0.15, 0.22222222222222
4503, 0.60869565217391, 0.15, 0.27777777777778
4504, 0.60869565217391, 0.15, 0.33333333333333
4505, 0.60869565217391, 0.15, 0.38888888888889
4506, 0.60869565217391, 0.15, 0.44444444444444
4507, 0.65217391304348, 0.15, 0.055555555555556
4508, 0.65217391304348, 0.15, 0.11111111111111
4509, 0.65217391304348, 0.15, 0.16666666666667
4510, 0.65217391304348, 0.15, 0.22222222222222
4511, 0.65217391304348, 0.15, 0.27777777777778
4512, 0.65217391304348, 0.15, 0.33333333333333
4513, 0.65217391304348, 0.15, 0.38888888888889
4514, 0.65217391304348, 0.15, 0.44444444444444
4515, 0.69565217391304, 0.15, 0.055555555555556
4516, 0.69565217391304, 0.15, 0.11111111111111
4517, 0.69565217391304, 0.15, 0.16666666666667
4518, 0.69565217391304, 0.15, 0.22222222222222
4519, 0.69565217391304, 0.15, 0.27777777777778
4520, 0.69565217391304, 0.15, 0.33333333333333
4521, 0.69565217391304, 0.15, 0.38888888888889
4522, 0.69565217391304, 0.15, 0.44444444444444
4523, 0.73913043478261, 0.15, 0.055555555555556
4524, 0.73913043478261, 0.15, 0.11111111111111
4525, 0.73913043478261, 0.15, 0.16666666666667
4526, 0.73913043478261, 0.15, 0.22222222222222
4527, 0.73913043478261, 0.15, 0.27777777777778
4528, 0.73913043478261, 0.15, 0.33333333333333
4529, 0.73913043478261, 0.15, 0.38888888888889
4530, 0.73913043478261, 0.15, 0.44444444444444
4531, 0.78260869565217, 0.15, 0.055555555555556
4532, 0.78260869565217, 0.15, 0.11111111111111
4533, 0.78260869565217, 0.15, 0.16666666666667
4534, 0.78260869565217, 0.15, 0.22222222222222
4535, 0.78260869565217, 0.15, 0.27777777777778
4536, 0.78260869565217, 0.15, 0.33333333333333
4537, 0.78260869565217, 0.15, 0.38888888888889
4538, 0.78260869565217, 0.15, 0.44444444444444
4539, 0.82608695652174, 0.15, 0.055555555555556
4540, 0.82608695652174, 0.15, 0.11111111111111
4541, 0.82608695652174, 0.15, 0.16666666666667
4542, 0.82608695652174, 0.15, 0.22222222222222
4543, 0.82608695652174, 0.15, 0.27777777777778
4544, 0.82608695652174, 0.15, 0.33333333333333
4545, 0.82608695652174, 0.15, 0.38888888888889
4546, 0.82608695652174, 0.15, 0.44444444444444
4547, 0.8695652173913, 0.15, 0.055555555555556
4548, 0.8695652173913, 0.15, 0.11111111111111
4549, 0.8695652173913, 0.15, 0.16666666666667
4550, 0.8695652173913, 0.15, 0.22222222222222
4551, 0.8695652173913, 0.15, 0.27777777777778
4552, 0.8695652173913, 0.15, 0.33333333333333
4553, 0.8695652173913, 0.15, 0.38888888888889
4554, 0.8695652173913, 0.15, 0.44444444444444
4555, 0.91304347826087, 0.15, 0.055555555555556
4556, 0.91304347826087, 0.15, 0.11111111111111
4557, 0.91304347826087, 0.15, 0.16666666666667
4558, 0.91304347826087, 0.15, 0.22222222222222
4559, 0.91304347826087, 0.15, 0.27777777777778
4560, 0.91304347826087, 0.15, 0.33333333333333
4561, 0.91304347826087, 0.15, 0.38888888888889
4562, 0.91304347826087, 0.15, 0.44444444444444
4563, 0.95652173913043, 0.15, 0.055555555555556
4564, 0.95652173913043, 0.15, 0.11111111111111
4565, 0.95652173913043, 0.15, 0.16666666666667
4566, 0.95652173913043, 0.15, 0.22222222222222
4567, 0.95652173913043, 0.15, 0.27777777777778
4568, 0.95652173913043, 0.15, 0.33333333333333
4569, 0.95652173913043, 0.15, 0.38888888888889
4570, 0.95652173913043, 0.15, 0.44444444444444
4571, 0.021739130434783, 0.15, 0.055555555555556
4572, 0.043478260869565, 0.15, 0.027777777777778
4573, 0.021739130434783, 0.15, 0.11111111111111
4574, 0.043478260869565, 0.15, 0.083333333333333
4575, 0.021739130434783, 0.15, 0.16666666666667
4576, 0.043478260869565, 0.15, 0.13888888888889
4577, 0.021739130434783, 0.15, 0.22222222222222
4578, 0.043478260869565, 0.15, 0.19444444444444
4579, 0.021739130434783, 0.15, 0.27777777777778
4580, 0.043478260869565, 0.15, 0.25
4581, 0.021739130434783, 0.15, 0.33333333333333
4582, 0.043478260869565, 0.15, 0.30555555555556
4583, 0.021739130434783, 0.15, 0.38888888888889
4584, 0.043478260869565, 0.15, 0.36111111111111
4585, 0.021739130434783, 0.15, 0.44444444444444
4586, 0.043478260869565, 0.15, 0.41666666666667
4587, 0.043478260869565, 0.15, 0.47222222222222
4588, 0.065217391304348, 0.15, 0.055555555555556
4589, 0.08695652173913, 0.15, 0.027777777777778
4590, 0.065217391304348, 0.15, 0.11111111111111
4591, 0.08695652173913, 0.15, 0.083333333333333
4592, 0.065217391304348, 0.15, 0.16666666666667
4593, 0.08695652173913, 0.15, 0.13888888888889
4594, 0.065217391304348, 0.15, 0.22222222222222
4595, 0.08695652173913, 0.15, 0.19444444444444
4596, 0.065217391304348, 0.15, 0.27777777777778
4597, 0.08695652173913, 0.15, 0.25
4598, 0.065217391304348, 0.15, 0.33333333333333
4599, 0.08695652173913, 0.15, 0.30555555555556
4600, 0.065217391304348, 0.15, 0.38888888888889
4601, 0.08695652173913, 0.15, 0.36111111111111
4602, 0.065217391304348, 0.15, 0.44444444444444
4603, 0.08695652173913, 0.15, 0.41666666666667
4604, 0.08695652173913, 0.15, 0.47222222222222
4605, 0.10869565217391, 0.15, 0.055555555555556
4606, 0.1304347826087, 0.15, 0.027777777777778
4607, 0.10869565217391, 0.15, 0.11111111111111
4608, 0.1304347826087, 0.15, 0.083333333333333
4609, 0.10869565217391, 0.15, 0.16666666666667
4610, 0.1304347826087, 0.15, 0.13888888888889
4611, 0.10869565217391, 0.15, 0.22222222222222
4612, 0.1304347826087, 0.15, 0.19444444444444
4613, 0.10869565217391, 0.15, 0.27777777777778
4614, 0.1304347826087, 0.15, 0.25
4615, 0.10869565217391, 0.15, 0.33333333333333
4616, 0.1304347826087, 0.15, 0.30555555555556
4617, 0.10869565217391, 0.15, 0.38888888888889
4618, 0.1304347826087, 0.15, 0.36111111111111
4619, 0.10869565217391, 0.15, 0.44444444444444
4620, 0.1304347826087, 0.15, 0.41666666666667
4621, 0.1304347826087, 0.15, 0.47222222222222
4622, 0.15217391304348, 0.15, 0.055555555555556
4623, 0.17391304347826, 0.15, 0.027777777777778
4624, 0.15217391304348, 0.15, 0.11111111111111
4625, 0.17391304347826, 0.15, 0.083333333333333
4626, 0.15217391304348, 0.15, 0.16666666666667
4627, 0.17391304347826, 0.15, 0.13888888888889
4628, 0.15217391304348, 0.15, 0.22222222222222
4629, 0.17391304347826, 0.15, 0.19444444444444
4630, 0.15217391304348, 0.15, 0.27777777777778
4631, 0.17391304347826, 0.15, 0.25
4632, 0.15217391304348, 0.15, 0.33333333333333
4633, 0.17391304347826, 0.15, 0.30555555555556
4634, 0.15217391304348, 0.15, 0.38888888888889
4635, 0.17391304347826, 0.15, 0.36111111111111
4636, 0.15217391304348, 0.15, 0.44444444444444
4637, 0.17391304347826, 0.15, 0.41666666666667
4638, 0.17391304347826, 0.15, 0.47222222222222
4639, 0.19565217391304, 0.15, 0.055555555555556
4640, 0.21739130434783, 0.15, 0.027777777777778
4641, 0.19565217391304, 0.15, 0.11111111111111
4642, 0.21739130434783, 0.15, 0.083333333333333
4643, 0.19565217391304, 0.15, 0.16666666666667
4644, 0.21739130434783, 0.15, 0.13888888888889
4645, 0.19565217391304, 0.15, 0.22222222222222
4646, 0.21739130434783, 0.15, 0.19444444444444
4647, 0.19565217391304, 0.15, 0.27777777777778
4648, 0.21739130434783, 0.15, 0.25
4649, 0.19565217391304, 0.15, 0.33333333333333
4650, 0.21739130434783, 0.15, 0.30555555555556
4651, 0.19565217391304, 0.15, 0.38888888888889
4652, 0.21739130434783, 0.15, 0.36111111111111
4653, 0.19565217391304, 0.15, 0.44444444444444
4654, 0.21739130434783, 0.15, 0.41666666666667
4655, 0.21739130434783, 0.15, 0.47222222222222
4656, 0.23913043478261, 0.15, 0.055555555555556
4657, 0.26086956521739, 0.15, 0.027777777777778
4658, 0.23913043478261, 0.15, 0.11111111111111
4659, 0.26086956521739, 0.15, 0.083333333333333
4660, 0.23913043478261, 0.15, 0.16666666666667
4661, 0.26086956521739, 0.15, 0.13888888888889
4662, 0.23913043478261, 0.15, 0.22222222222222
4663, 0.26086956521739, 0.15, 0.19444444444444
4664, 0.23913043478261, 0.15, 0.27777777777778
4665, 0.26086956521739, 0.15, 0.25
4666, 0.23913043478261, 0.15, 0.33333333333333
4667, 0.26086956521739, 0.15, 0.30555555555556
4668, 0.23913043478261, 0.15, 0.38888888888889
4669, 0.26086956521739, 0.15, 0.36111111111111
4670, 0.23913043478261, 0.15, 0.44444444444444
4671, 0.26086956521739, 0.15, 0.41666666666667
4672, 0.26086956521739, 0.15, 0.47222222222222
4673, 0.28260869565217, 0.15, 0.055555555555556
4674, 0.30434782608696, 0.15, 0.027777777777778
4675, 0.28260869565217, 0.15, 0.11111111111111
4676, 0.30434782608696, 0.15, 0.083333333333333
4677, 0.28260869565217, 0.15, 0.16666666666667
4678, 0.30434782608696, 0.15, 0.13888888888889
4679, 0.28260869565217, 0.15, 0.22222222222222
4680, 0.30434782608696, 0.15, 0.19444444444444
4681, 0.28260869565217, 0.15, 0.27777777777778
4682, 0.30434782608696, 0.15, 0.25
4683, 0.28260869565217, 0.15, 0.33333333333333
4684, 0.30434782608696, 0.15, 0.30555555555556
4685, 0.28260869565217, 0.15, 0.38888888888889
4686, 0.30434782608696, 0.15, 0.36111111111111
4687, 0.28260869565217, 0.15, 0.44444444444444
4688, 0.30434782608696, 0.15, 0.41666666666667
4689, 0.30434782608696, 0.15, 0.47222222222222
4690, 0.32608695652174, 0.15, 0.055555555555556
4691, 0.34782608695652, 0.15, 0.027777777777778
4692, 0.32608695652174, 0.15, 0.11111111111111
4693, 0.34782608695652, 0.15, 0.083333333333333
4694, 0.32608695652174, 0.15, 0.16666666666667
4695, 0.34782608695652, 0.15, 0.13888888888889
4696, 0.32608695652174, 0.15, 0.22222222222222
4697, 0.34782608695652, 0.15, 0.19444444444444
4698, 0.32608695652174, 0.15, 0.27777777777778
4699, 0.34782608695652, 0.15, 0.25
4700, 0.32608695652174, 0.15, 0.33333333333333
4701, 0.34782608695652, 0.15, 0.30555555555556
4702, 0.32608695652174, 0.15, 0.38888888888889
4703, 0.34782608695652, 0.15, 0.36111111111111
4704, 0.32608695652174, 0.15, 0.44444444444444
4705, 0.34782608695652, 0.15, 0.41666666666667
4706, 0.34782608695652, 0.15, 0.47222222222222
4707, 0.3695652173913, 0.15, 0.055555555555556
4708, 0.39130434782609, 0.15, 0.027777777777778
4709, 0.3695652173913, 0.15, 0.11111111111111
4710, 0.39130434782609, 0.15, 0.083333333333333
4711, 0.3695652173913, 0.15, 0.16666666666667
4712, 0.39130434782609, 0.15, 0.13888888888889
4713, 0.3695652173913, 0.15, 0.22222222222222
4714, 0.39130434782609, 0.15, 0.19444444444444
4715, 0.3695652173913, 0.15, 0.27777777777778
4716, 0.39130434782609, 0.15, 0.25
4717, 0.3695652173913, 0.15, 0.33333333333333
4718, 0.39130434782609, 0.15, 0.30555555555556
4719, 0.3695652173913, 0.15, 0.38888888888889
4720, 0.39130434782609, 0.15, 0.36111111111111
4721, 0.3695652173913, 0.15, 0.44444444444444
4722, 0.39130434782609, 0.15, 0.41666666666667
4723, 0.39130434782609, 0.15, 0.47222222222222
4724, 0.41304347826087, 0.15, 0.055555555555556
4725, 0.43478260869565, 0.15, 0.027777777777778
4726, 0.41304347826087, 0.15, 0.11111111111111
4727, 0.43478260869565, 0.15, 0.083333333333333
4728, 0.41304347826087, 0.15, 0.16666666666667
4729, 0.43478260869565, 0.15, 0.13888888888889
4730, 0.41304347826087, 0.15, 0.22222222222222
4731, 0.43478260869565, 0.15, 0.19444444444444
4732, 0.41304347826087, 0.15, 0.27777777777778
4733, 0.43478260869565, 0.15, 0.25
4734, 0.41304347826087, 0.15, 0.33333333333333
4735, 0.43478260869565, 0.15, 0.30555555555556
4736, 0.41304347826087, 0.15, 0.38888888888889
4737, 0.43478260869565, 0.15, 0.36111111111111
4738, 0.41304347826087, 0.15, 0.44444444444444
4739, 0.43478260869565, 0.15, 0.41666666666667
4740, 0.43478260869565, 0.15, 0.47222222222222
4741, 0.45652173913043, 0.15, 0.055555555555556
4742, 0.47826086956522, 0.15, 0.027777777777778
4743, 0.45652173913043, 0.15, 0.11111111111111
4744, 0.47826086956522, 0.15, 0.083333333333333
4745, 0.45652173913043, 0.15, 0.16666666666667
4746, 0.47826086956522, 0.15, 0.13888888888889
4747, 0.45652173913043, 0.15, 0.22222222222222
4748, 0.47826086956522, 0.15, 0.19444444444444
4749, 0.45652173913043, 0.15, 0.27777777777778
4750, 0.47826086956522, 0.15, 0.25
4751, 0.45652173913043, 0.15, 0.33333333333333
4752, 0.47826086956522, 0.15, 0.30555555555556
4753, 0.45652173913043, 0.15, 0.38888888888889
4754, 0.47826086956522, 0.15, 0.36111111111111
4755, 0.45652173913043, 0.15, 0.44444444444444
4756, 0.47826086956522, 0.15, 0.41666666666667
4757, 0.47826086956522, 0.15, 0.47222222222222
4758, 0.5, 0.15, 0.055555555555556
4759, 0.52173913043478, 0.15, 0.027777777777778
4760, 0.5, 0.15, 0.11111111111111
4761, 0.52173913043478, 0.15, 0.083333333333333
4762, 0.5, 0.15, 0.16666666666667
4763, 0.52173913043478, 0.15, 0.13888888888889
4764, 0.5, 0.15, 0.22222222222222
4765, 0.52173913043478, 0.15, 0.19444444444444
4766, 0.5, 0.15, 0.27777777777778
4767, 0.52173913043478, 0.15, 0.25
4768, 0.5, 0.15, 0.33333333333333
4769, 0.52173913043478, 0.15, 0.30555555555556
4770, 0.5, 0.15, 0.38888888888889
4771, 0.52173913043478, 0.15, 0.36111111111111
4772, 0.5, 0.15, 0.44444444444444
4773, 0.52173913043478, 0.15, 0.41666666666667
4774, 0.52173913043478, 0.15, 0.47222222222222
4775, 0.54347826086957, 0.15, 0.055555555555556
4776, 0.56521739130435, 0.15, 0.027777777777778
4777, 0.54347826086957, 0.15, 0.11111111111111
4778, 0.56521739130435, 0.15, 0.083333333333333
4779, 0.54347826086957, 0.15, 0.16666666666667
4780, 0.56521739130435, 0.15, 0.13888888888889
4781, 0.54347826086957, 0.15, 0.22222222222222
4782, 0.56521739130435, 0.15, 0.19444444444444
4783, 0.54347826086957, 0.15, 0.27777777777778
4784, 0.56521739130435, 0.15, 0.25
4785, 0.54347826086957, 0.15, 0.33333333333333
4786, 0.56521739130435, 0.15, 0.30555555555556
4787, 0.54347826086957, 0.15, 0.38888888888889
4788, 0.56521739130435, 0.15, 0.36111111111111
4789, 0.54347826086957, 0.15, 0.44444444444444
4790, 0.56521739130435, 0.15, 0.41666666666667
4791, 0.56521739130435, 0.15, 0.47222222222222
4792, 0.58695652173913, 0.15, 0.055555555555556
4793, 0.60869565217391, 0.15, 0.027777777777778
4794, 0.58695652173913, 0.15, 0.11111111111111
4795, 0.60869565217391, 0.15, 0.083333333333333
4796, 0.58695652173913, 0.15, 0.16666666666667
4797, 0.60869565217391, 0.15, 0.13888888888889
4798, 0.58695652173913, 0.15, 0.22222222222222
4799, 0.60869565217391, 0.15, 0.19444444444444
4800, 0.58695652173913, 0.15, 0.27777777777778
4801, 0.60869565217391, 0.15, 0.25
4802, 0.58695652173913, 0.15, 0.33333333333333
4803, 0.60869565217391, 0.15, 0.30555555555556
4804, 0.58695652173913, 0.15, 0.38888888888889
4805, 0.60869565217391, 0.15, 0.36111111111111
4806, 0.58695652173913, 0.15, 0.44444444444444
4807, 0.60869565217391, 0.15, 0.41666666666667
4808, 0.60869565217391, 0.15, 0.47222222222222
4809, 0.6304347826087, 0.15, 0.055555555555556
4810, 0.65217391304348, 0.15, 0.027777777777778
4811, 0.6304347826087, 0.15, 0.11111111111111
4812, 0.65217391304348, 0.15, 0.083333333333333
4813, 0.6304347826087, 0.15, 0.16666666666667
4814, 0.65217391304348, 0.15, 0.13888888888889
4815, 0.6304347826087, 0.15, 0.22222222222222
4816, 0.65217391304348, 0.15, 0.19444444444444
4817, 0.6304347826087, 0.15, 0.27777777777778
4818, 0.65217391304348, 0.15, 0.25
4819, 0.6304347826087, 0.15, 0.33333333333333
4820, 0.65217391304348, 0.15, 0.30555555555556
4821, 0.6304347826087, 0.15, 0.38888888888889
4822, 0.65217391304348, 0.15, 0.36111111111111
4823, 0.6304347826087, 0.15, 0.44444444444444
4824, 0.65217391304348, 0.15, 0.41666666666667
4825, 0.65217391304348, 0.15, 0.47222222222222
4826, 0.67391304347826, 0.15, 0.055555555555556
4827, 0.69565217391304, 0.15, 0.027777777777778
4828, 0.67391304347826, 0.15, 0.11111111111111
4829, 0.69565217391304, 0.15, 0.083333333333333
4830, 0.67391304347826, 0.15, 0.16666666666667
4831, 0.69565217391304, 0.15, 0.13888888888889
4832, 0.67391304347826, 0.15, 0.22222222222222
4833, 0.69565217391304, 0.15, 0.19444444444444
4834, 0.67391304347826, 0.15, 0.27777777777778
4835, 0.69565217391304, 0.15, 0.25
4836, 0.67391304347826, 0.15, 0.33333333333333
4837, 0.69565217391304, 0.15, 0.30555555555556
4838, 0.67391304347826, 0.15, 0.38888888888889
4839, 0.69565217391304, 0.15, 0.36111111111111
4840, 0.67391304347826, 0.15, 0.44444444444444
4841, 0.69565217391304, 0.15, 0.41666666666667
4842, 0.69565217391304, 0.15, 0.47222222222222
4843, 0.71739130434783, 0.15, 0.055555555555556
4844, 0.73913043478261, 0.15, 0.027777777777778
4845, 0.71739130434783, 0.15, 0.11111111111111
4846, 0.73913043478261, 0.15, 0.083333333333333
4847, 0.71739130434783, 0.15, 0.16666666666667
4848, 0.73913043478261, 0.15, 0.13888888888889
4849, 0.71739130434783, 0.15, 0.22222222222222
4850, 0.73913043478261, 0.15, 0.19444444444444
4851, 0.71739130434783, 0.15, 0.27777777777778
4852, 0.73913043478261, 0.15, 0.25
4853, 0.71739130434783, 0.15, 0.33333333333333
4854, 0.73913043478261, 0.15, 0.30555555555556
4855, 0.71739130434783, 0.15, 0.38888888888889
4856, 0.73913043478261, 0.15, 0.36111111111111
4857, 0.71739130434783, 0.15, 0.44444444444444
4858, 0.73913043478261, 0.15, 0.41666666666667
4859, 0.73913043478261, 0.15, 0.47222222222222
4860, 0.76086956521739, 0.15, 0.055555555555556
4861, 0.78260869565217, 0.15, 0.027777777777778
4862, 0.76086956521739, 0.15, 0.11111111111111
4863, 0.78260869565217, 0.15, 0.083333333333333
4864, 0.76086956521739, 0.15, 0.16666666666667
4865, 0.78260869565217, 0.15, 0.13888888888889
4866, 0.76086956521739, 0.15, 0.22222222222222
4867, 0.78260869565217, 0.15, 0.19444444444444
4868, 0.76086956521739, 0.15, 0.27777777777778
4869, 0.78260869565217, 0.15, 0.25
4870, 0.76086956521739, 0.15, 0.33333333333333
4871, 0.78260869565217, 0.15, 0.30555555555556
4872, 0.76086956521739, 0.15, 0.38888888888889
4873, 0.78260869565217, 0.15, 0.36111111111111
4874, 0.76086956521739, 0.15, 0.44444444444444
4875, 0.78260869565217, 0.15, 0.41666666666667
4876, 0.78260869565217, 0.15, 0.47222222222222
4877, 0.80434782608696, 0.15, 0.055555555555556
4878, 0.82608695652174, 0.15, 0.027777777777778
4879, 0.80434782608696, 0.15, 0.11111111111111
4880, 0.82608695652174, 0.15, 0.083333333333333
4881, 0.80434782608696, 0.15, 0.16666666666667
4882, 0.82608695652174, 0.15, 0.13888888888889
4883, 0.80434782608696, 0.15, 0.22222222222222
4884, 0.82608695652174, 0.15, 0.19444444444444
4885, 0.80434782608696, 0.15, 0.27777777777778
4886, 0.82608695652174, 0.15, 0.25
4887, 0.80434782608696, 0.15, 0.33333333333333
4888, 0.82608695652174, 0.15, 0.30555555555556
4889, 0.80434782608696, 0.15, 0.38888888888889
4890, 0.82608695652174, 0.15, 0.36111111111111
4891, 0.80434782608696, 0.15, 0.44444444444444
4892, 0.82608695652174, 0.15, 0.41666666666667
4893, 0.82608695652174, 0.15, 0.47222222222222
4894, 0.84782608695652, 0.15, 0.055555555555556
4895, 0.8695652173913, 0.15, 0.027777777777778
4896, 0.84782608695652, 0.15, 0.11111111111111
4897, 0.8695652173913, 0.15, 0.083333333333333
4898, 0.84782608695652, 0.15, 0.16666666666667
4899, 0.8695652173913, 0.15, 0.13888888888889
4900, 0.84782608695652, 0.15, 0.22222222222222
4901, 0.8695652173913, 0.15, 0.19444444444444
4902, 0.84782608695652, 0.15, 0.27777777777778
4903, 0.8695652173913, 0.15, 0.25
4904, 0.84782608695652, 0.15, 0.33333333333333
4905, 0.8695652173913, 0.15, 0.30555555555556
4906, 0.84782608695652, 0.15, 0.38888888888889
4907, 0.8695652173913, 0.15, 0.36111111111111
4908, 0.84782608695652, 0.15, 0.44444444444444
4909, 0.8695652173913, 0.15, 0.41666666666667
4910, 0.8695652173913, 0.15, 0.47222222222222
4911, 0.89130434782609, 0.15, 0.055555555555556
4912, 0.91304347826087, 0.15, 0.027777777777778
4913, 0.89130434782609, 0.15, 0.11111111111111
4914, 0.91304347826087, 0.15, 0.083333333333333
4915, 0.89130434782609, 0.15, 0.16666666666667
4916, 0.91304347826087, 0.15, 0.13888888888889
4917, 0.89130434782609, 0.15, 0.22222222222222
4918, 0.91304347826087, 0.15, 0.19444444444444
4919, 0.89130434782609, 0.15, 0.27777777777778
4920, 0.91304347826087, 0.15, 0.25
4921, 0.89130434782609, 0.15, 0.33333333333333
4922, 0.91304347826087, 0.15, 0.30555555555556
4923, 0.89130434782609, 0.15, 0.38888888888889
4924, 0.91304347826087, 0.15, 0.36111111111111
4925, 0.89130434782609, 0.15, 0.44444444444444
4926, 0.91304347826087, 0.15, 0.41666666666667
4927, 0.91304347826087, 0.15, 0.47222222222222
4928, 0.93478260869565, 0.15, 0.055555555555556
4929, 0.95652173913043, 0.15, 0.027777777777778
4930, 0.93478260869565, 0.15, 0.11111111111111
4931, 0.95652173913043, 0.15, 0.083333333333333
4932, 0.93478260869565, 0.15, 0.16666666666667
4933, 0.95652173913043, 0.15, 0.13888888888889
4934, 0.93478260869565, 0.15, 0.22222222222222
4935, 0.95652173913043, 0.15, 0.19444444444444
4936, 0.93478260869565, 0.15, 0.27777777777778
4937, 0.95652173913043, 0.15, 0.25
4938, 0.93478260869565, 0.15, 0.33333333333333
4939, 0.95652173913043, 0.15, 0.30555555555556
4940, 0.93478260869565, 0.15, 0.38888888888889
4941, 0.95652173913043, 0.15, 0.36111111111111
4942, 0.93478260869565, 0.15, 0.44444444444444
4943, 0.95652173913043, 0.15, 0.41666666666667
4944, 0.95652173913043, 0.15, 0.47222222222222
4945, 0.97826086956522, 0.15, 0.055555555555556
4946, 0.97826086956522, 0.15, 0.11111111111111
4947, 0.97826086956522, 0.15, 0.16666666666667
4948, 0.97826086956522, 0.15, 0.22222222222222
4949, 0.97826086956522, 0.15, 0.27777777777778
4950, 0.97826086956522, 0.15, 0.33333333333333
4951, 0.97826086956522, 0.15, 0.38888888888889
4952, 0.97826086956522, 0.15, 0.44444444444444
4953, 1.2434782608696, 0.15, 0.44444444444444
4954, 1.2434782608696, 0.15, 0.38888888888889
4955, 1.2434782608696, 0.15, 0.33333333333333
4956, 1.2434782608696, 0.15, 0.27777777777778
4957, 1.2434782608696, 0.15, 0.22222222222222
4958, 1.2434782608696, 0.15, 0.16666666666667
4959, 1.2434782608696, 0.15, 0.11111111111111
4960, 1.2434782608696, 0.15, 0.055555555555556
4961, 1.2869565217391, 0.15, 0.44444444444444
4962, 1.2869565217391, 0.15, 0.38888888888889
4963, 1.2869565217391, 0.15, 0.33333333333333
4964, 1.2869565217391, 0.15, 0.27777777777778
4965, 1.2869565217391, 0.15, 0.22222222222222
4966, 1.2869565217391, 0.15, 0.16666666666667
4967, 1.2869565217391, 0.15, 0.11111111111111
4968, 1.2869565217391, 0.15, 0.055555555555556
4969, 1.3304347826087, 0.15, 0.44444444444444
4970, 1.3304347826087, 0.15, 0.38888888888889
4971, 1.3304347826087, 0.15, 0.33333333333333
4972, 1.3304347826087, 0.15, 0.27777777777778
4973, 1.3304347826087, 0.15, 0.22222222222222
4974, 1.3304347826087, 0.15, 0.16666666666667
4975, 1.3304347826087, 0.15, 0.11111111111111
4976, 1.3304347826087, 0.15, 0.055555555555556
4977, 1.3739130434783, 0.15, 0.44444444444444
4978, 1.3739130434783, 0.15, 0.38888888888889
4979, 1.3739130434783, 0.15, 0.33333333333333
4980, 1.3739130434783, 0.15, 0.27777777777778
4981, 1.3739130434783, 0.15, 0.22222222222222
4982, 1.3739130434783, 0.15, 0.16666666666667
4983, 1.3739130434783, 0.15, 0.11111111111111
4984, 1.3739130434783, 0.15, 0.055555555555556
4985, 1.4173913043478, 0.15, 0.44444444444444
4986, 1.4173913043478, 0.15, 0.38888888888889
4987, 1.4173913043478, 0.15, 0.33333333333333
4988, 1.4173913043478, 0.15, 0.27777777777778
4989, 1.4173913043478, 0.15, 0.22222222222222
4990, 1.4173913043478, 0.15, 0.16666666666667
4991, 1.4173913043478, 0.15, 0.11111111111111
4992, 1.4173913043478, 0.15, 0.055555555555556
4993, 1.4608695652174, 0.15, 0.44444444444444
4994, 1.4608695652174, 0.15, 0.38888888888889
4995, 1.4608695652174, 0.15, 0.33333333333333
4996, 1.4608695652174, 0.15, 0.27777777777778
4997, 1.4608695652174, 0.15, 0.22222222222222
4998, 1.4608695652174, 0.15, 0.16666666666667
4999, 1.4608695652174, 0.15, 0.11111111111111
5000, 1.4608695652174, 0.15, 0.055555555555556
5001, 1.504347826087, 0.15, 0.44444444444444
5002, 1.504347826087, 0.15, 0.38888888888889
5003, 1.504347826087, 0.15, 0.33333333333333
5004, 1.504347826087, 0.15, 0.27777777777778
5005, 1.504347826087, 0.15, 0.22222222222222
5006, 1.504347826087, 0.15, 0.16666666666667
5007, 1.504347826087, 0.15, 0.11111111111111
5008, 1.504347826087, 0.15, 0.055555555555556
5009, 1.5478260869565, 0.15, 0.44444444444444
5010, 1.5478260869565, 0.15, 0.38888888888889
5011, 1.5478260869565, 0.15, 0.33333333333333
5012, 1.5478260869565, 0.15, 0.27777777777778
5013, 1.5478260869565, 0.15, 0.22222222222222
5014, 1.5478260869565, 0.15, 0.16666666666667
5015, 1.5478260869565, 0.15, 0.11111111111111
5016, 1.5478260869565, 0.15, 0.055555555555556
5017, 1.5913043478261, 0.15, 0.44444444444444
5018, 1.5913043478261, 0.15, 0.38888888888889
5019, 1.5913043478261, 0.15, 0.33333333333333
5020, 1.5913043478261, 0.15, 0.27777777777778
5021, 1.5913043478261, 0.15, 0.22222222222222
5022, 1.5913043478261, 0.15, 0.16666666666667
5023, 1.5913043478261, 0.15, 0.11111111111111
5024, 1.5913043478261, 0.15, 0.055555555555556
5025, 1.6347826086957, 0.15, 0.44444444444444
5026, 1.6347826086957, 0.15, 0.38888888888889
5027, 1.6347826086957, 0.15, 0.33333333333333
5028, 1.6347826086957, 0.15, 0.27777777777778
5029, 1.6347826086957, 0.15, 0.22222222222222
5030, 1.6347826086957, 0.15, 0.16666666666667
5031, 1.6347826086957, 0.15, 0.11111111111111
5032, 1.6347826086957, 0.15, 0.055555555555556
5033, 1.6782608695652, 0.15, 0.44444444444444
5034, 1.6782608695652, 0.15, 0.38888888888889
5035, 1.6782608695652, 0.15, 0.33333333333333
5036, 1.6782608695652, 0.15, 0.27777777777778
5037, 1.6782608695652, 0.15, 0.22222222222222
5038, 1.6782608695652, 0.15, 0.16666666666667
5039, 1.6782608695652, 0.15, 0.11111111111111
5040, 1.6782608695652, 0.15, 0.055555555555556
5041, 1.7217391304348, 0.15, 0.44444444444444
5042, 1.7217391304348, 0.15, 0.38888888888889
5043, 1.7217391304348, 0.15, 0.33333333333333
5044, 1.7217391304348, 0.15, 0.27777777777778
5045, 1.7217391304348, 0.15, 0.22222222222222
5046, 1.7217391304348, 0.15, 0.16666666666667
5047, 1.7217391304348, 0.15, 0.11111111111111
5048, 1.7217391304348, 0.15, 0.055555555555556
5049, 1.7652173913043, 0.15, 0.44444444444444
5050, 1.7652173913043, 0.15, 0.38888888888889
5051, 1.7652173913043, 0.15, 0.33333333333333
5052, 1.7652173913043, 0.15, 0.27777777777778
5053, 1.7652173913043, 0.15, 0.22222222222222
5054, 1.7652173913043, 0.15, 0.16666666666667
5055, 1.7652173913043, 0.15, 0.11111111111111
5056, 1.7652173913043, 0.15, 0.055555555555556
5057, 1.8086956521739, 0.15, 0.44444444444444
5058, 1.8086956521739, 0.15, 0.38888888888889
5059, 1.8086956521739, 0.15, 0.33333333333333
5060, 1.8086956521739, 0.15, 0.27777777777778
5061, 1.8086956521739, 0.15, 0.22222222222222
5062, 1.8086956521739, 0.15, 0.16666666666667
5063, 1.8086956521739, 0.15, 0.11111111111111
5064, 1.8086956521739, 0.15, 0.055555555555556
5065, 1.8521739130435, 0.15, 0.44444444444444
5066, 1.8521739130435, 0.15, 0.38888888888889
5067, 1.8521739130435, 0.15, 0.33333333333333
5068, 1.8521739130435, 0.15, 0.27777777777778
5069, 1.8521739130435, 0.15, 0.22222222222222
5070, 1.8521739130435, 0.15, 0.16666666666667
5071, 1.8521739130435, 0.15, 0.11111111111111
5072, 1.8521739130435, 0.15, 0.055555555555556
5073, 1.895652173913, 0.15, 0.44444444444444
5074, 1.895652173913, 0.15, 0.38888888888889
5075, 1.895652173913, 0.15, 0.33333333333333
5076, 1.895652173913, 0.15, 0.27777777777778
5077, 1.895652173913, 0.15, 0.22222222222222
5078, 1.895652173913, 0.15, 0.16666666666667
5079, 1.895652173913, 0.15, 0.11111111111111
5080, 1.895652173913, 0.15, 0.055555555555556
5081, 1.9391304347826, 0.15, 0.44444444444444
5082, 1.9391304347826, 0.15, 0.38888888888889
5083, 1.9391304347826, 0.15, 0.33333333333333
5084, 1.9391304347826, 0.15, 0.27777777777778
5085, 1.9391304347826, 0.15, 0.22222222222222
5086, 1.9391304347826, 0.15, 0.16666666666667
5087, 1.9391304347826, 0.15, 0.11111111111111
5088, 1.9391304347826, 0.15, 0.055555555555556
5089, 1.9826086956522, 0.15, 0.44444444444444
5090, 1.9826086956522, 0.15, 0.38888888888889
5091, 1.9826086956522, 0.15, 0.33333333333333
5092, 1.9826086956522, 0.15, 0.27777777777778
5093, 1.9826086956522, 0.15, 0.22222222222222
5094, 1.9826086956522, 0.15, 0.16666666666667
5095, 1.9826086956522, 0.15, 0.11111111111111
5096, 1.9826086956522, 0.15, 0.055555555555556
5097, 2.0260869565217, 0.15, 0.44444444444444
5098, 2.0260869565217, 0.15, 0.38888888888889
5099, 2.0260869565217, 0.15, 0.33333333333333
5100, 2.0260869565217, 0.15, 0.27777777777778
5101, 2.0260869565217, 0.15, 0.22222222222222
5102, 2.0260869565217, 0.15, 0.16666666666667
5103, 2.0260869565217, 0.15, 0.11111111111111
5104, 2.0260869565217, 0.15, 0.055555555555556
5105, 2.0695652173913, 0.15, 0.44444444444444
5106, 2.0695652173913, 0.15, 0.38888888888889
5107, 2.0695652173913, 0.15, 0.33333333333333
5108, 2.0695652173913, 0.15, 0.27777777777778
5109, 2.0695652173913, 0.15, 0.22222222222222
5110, 2.0695652173913, 0.15, 0.16666666666667
5111, 2.0695652173913, 0.15, 0.11111111111111
5112, 2.0695652173913, 0.15, 0.055555555555556
5113, 2.1130434782609, 0.15, 0.44444444444444
5114, 2.1130434782609, 0.15, 0.38888888888889
5115, 2.1130434782609, 0.15, 0.33333333333333
5116, 2.1130434782609, 0.15, 0.27777777777778
5117, 2.1130434782609, 0.15, 0.22222222222222
5118, 2.1130434782609, 0.15, 0.16666666666667
5119, 2.1130434782609, 0.15, 0.11111111111111
5120, 2.1130434782609, 0.15, 0.055555555555556
5121, 2.1565217391304, 0.15, 0.44444444444444
5122, 2.1565217391304, 0.15, 0.38888888888889
5123, 2.1565217391304, 0.15, 0.33333333333333
5124, 2.1565217391304, 0.15, 0.27777777777778
5125, 2.1565217391304, 0.15, 0.22222222222222
5126, 2.1565217391304, 0.15, 0.16666666666667
5127, 2.1565217391304, 0.15, 0.11111111111111
5128, 2.1565217391304, 0.15, 0.055555555555556
5129, 1.2217391304348, 0.15, 0.44444444444444
5130, 1.2434782608696, 0.15, 0.47222222222222
5131, 1.2217391304348, 0.15, 0.38888888888889
5132, 1.2434782608696, 0.15, 0.41666666666667
5133, 1.2217391304348, 0.15, 0.33333333333333
5134, 1.2434782608696, 0.15, 0.36111111111111
5135, 1.2217391304348, 0.15, 0.27777777777778
5136, 1.2434782608696, 0.15, 0.30555555555556
5137, 1.2217391304348, 0.15, 0.22222222222222
5138, 1.2434782608696, 0.15, 0.25
5139, 1.2217391304348, 0.15, 0.16666666666667
5140, 1.2434782608696, 0.15, 0.19444444444444
5141, 1.2217391304348, 0.15, 0.11111111111111
5142, 1.2434782608696, 0.15, 0.13888888888889
5143, 1.2217391304348, 0.15, 0.055555555555556
5144, 1.2434782608696, 0.15, 0.083333333333333
5145, 1.2434782608696, 0.15, 0.027777777777778
5146, 1.2652173913043, 0.15, 0.44444444444444
5147, 1.2869565217391, 0.15, 0.47222222222222
5148, 1.2652173913043, 0.15, 0.38888888888889
5149, 1.2869565217391, 0.15, 0.41666666666667
5150, 1.2652173913043, 0.15, 0.33333333333333
5151, 1.2869565217391, 0.15, 0.36111111111111
5152, 1.2652173913043, 0.15, 0.27777777777778
5153, 1.2869565217391, 0.15, 0.30555555555556
5154, 1.2652173913043, 0.15, 0.22222222222222
5155, 1.2869565217391, 0.15, 0.25
5156, 1.2652173913043, 0.15, 0.16666666666667
5157, 1.2869565217391, 0.15, 0.19444444444444
5158, 1.2652173913043, 0.15, 0.11111111111111
5159, 1.2869565217391, 0.15, 0.13888888888889
5160, 1.2652173913043, 0.15, 0.055555555555556
5161, 1.2869565217391, 0.15, 0.083333333333333
5162, 1.2869565217391, 0.15, 0.027777777777778
5163, 1.3086956521739, 0.15, 0.44444444444444
5164, 1.3304347826087, 0.15, 0.47222222222222
5165, 1.3086956521739, 0.15, 0.38888888888889
5166, 1.3304347826087, 0.15, 0.41666666666667
5167, 1.3086956521739, 0.15, 0.33333333333333
5168, 1.3304347826087, 0.15, 0.36111111111111
5169, 1.3086956521739, 0.15, 0.27777777777778
5170, 1.3304347826087, 0.15, 0.30555555555556
5171, 1.3086956521739, 0.15, 0.22222222222222
5172, 1.3304347826087, 0.15, 0.25
5173, 1.3086956521739, 0.15, 0.16666666666667
5174, 1.3304347826087, 0.15, 0.19444444444444
5175, 1.3086956521739, 0.15, 0.11111111111111
5176, 1.3304347826087, 0.15, 0.13888888888889
5177, 1.3086956521739, 0.15, 0.055555555555556
5178, 1.3304347826087, 0.15, 0.083333333333333
5179, 1.3304347826087, 0.15, 0.027777777777778
5180, 1.3521739130435, 0.15, 0.44444444444444
5181, 1.3739130434783, 0.15, 0.47222222222222
5182, 1.3521739130435, 0.15, 0.38888888888889
5183, 1.3739130434783, 0.15, 0.41666666666667
5184, 1.3521739130435, 0.15, 0.33333333333333
5185, 1.3739130434783, 0.15, 0.36111111111111
5186, 1.3521739130435, 0.15, 0.27777777777778
5187, 1.3739130434783, 0.15, 0.30555555555556
5188, 1.3521739130435, 0.15, 0.22222222222222
5189, 1.3739130434783, 0.15, 0.25
5190, 1.3521739130435, 0.15, 0.16666666666667
5191, 1.3739130434783, 0.15, 0.19444444444444
5192, 1.3521739130435, 0.15, 0.11111111111111
5193, 1.3739130434783, 0.15, 0.13888888888889
5194, 1.3521739130435, 0.15, 0.055555555555556
5195, 1.3739130434783, 0.15, 0.083333333333333
5196, 1.3739130434783, 0.15, 0.027777777777778
5197, 1.395652173913, 0.15, 0.44444444444444
5198, 1.4173913043478, 0.15, 0.47222222222222
5199, 1.395652173913, 0.15, 0.38888888888889
5200, 1.4173913043478, 0.15, 0.41666666666667
5201, 1.395652173913, 0.15, 0.33333333333333
5202, 1.4173913043478, 0.15, 0.36111111111111
5203, 1.395652173913, 0.15, 0.27777777777778
5204, 1.4173913043478, 0.15, 0.30555555555556
5205, 1.395652173913, 0.15, 0.22222222222222
5206, 1.4173913043478, 0.15, 0.25
5207, 1.395652173913, 0.15, 0.16666666666667
5208, 1.4173913043478, 0.15, 0.19444444444444
5209, 1.395652173913, 0.15, 0.11111111111111
5210, 1.4173913043478, 0.15, 0.13888888888889
5211, 1.395652173913, 0.15, 0.055555555555556
5212, 1.4173913043478, 0.15, 0.083333333333333
5213, 1.4173913043478, 0.15, 0.027777777777778
5214, 1.4391304347826, 0.15, 0.44444444444444
5215, 1.4608695652174, 0.15, 0.47222222222222
5216, 1.4391304347826, 0.15, 0.38888888888889
5217, 1.4608695652174, 0.15, 0.41666666666667
5218, 1.4391304347826, 0.15, 0.33333333333333
5219, 1.4608695652174, 0.15, 0.36111111111111
5220, 1.4391304347826, 0.15, 0.27777777777778
5221, 1.4608695652174, 0.15, 0.30555555555556
5222, 1.4391304347826, 0.15, 0.22222222222222
5223, 1.4608695652174, 0.15, 0.25
5224, 1.4391304347826, 0.15, 0.16666666666667
5225, 1.4608695652174, 0.15, 0.19444444444444
5226, 1.4391304347826, 0.15, 0.11111111111111
5227, 1.4608695652174, 0.15, 0.13888888888889
5228, 1.4391304347826, 0.15, 0.055555555555556
5229, 1.4608695652174, 0.15, 0.083333333333333
5230, 1.4608695652174, 0.15, 0.027777777777778
5231, 1.4826086956522, 0.15, 0.44444444444444
5232, 1.504347826087, 0.15, 0.47222222222222
5233, 1.4826086956522, 0.15, 0.38888888888889
5234, 1.504347826087, 0.15, 0.41666666666667
5235, 1.4826086956522, 0.15, 0.33333333333333
5236, 1.504347826087, 0.15, 0.36111111111111
5237, 1.4826086956522, 0.15, 0.27777777777778
5238, 1.504347826087, 0.15, 0.30555555555556
5239, 1.4826086956522, 0.15, 0.22222222222222
5240, 1.504347826087, 0.15, 0.25
5241, 1.4826086956522, 0.15, 0.16666666666667
5242, 1.504347826087, 0.15, 0.19444444444444
5243, 1.4826086956522, 0.15, 0.11111111111111
5244, 1.504347826087, 0.15, 0.13888888888889
5245, 1.4826086956522, 0.15, 0.055555555555556
5246, 1.504347826087, 0.15, 0.083333333333333
5247, 1.504347826087, 0.15, 0.027777777777778
5248, 1.5260869565217, 0.15, 0.44444444444444
5249, 1.5478260869565, 0.15, 0.47222222222222
5250, 1.5260869565217, 0.15, 0.38888888888889
5251, 1.5478260869565, 0.15, 0.41666666666667
5252, 1.5260869565217, 0.15, 0.33333333333333
5253, 1.5478260869565, 0.15, 0.36111111111111
5254, 1.5260869565217, 0.15, 0.27777777777778
5255, 1.5478260869565, 0.15, 0.30555555555556
5256, 1.5260869565217, 0.15, 0.22222222222222
5257, 1.5478260869565, 0.15, 0.25
5258, 1.5260869565217, 0.15, 0.16666666666667
5259, 1.5478260869565, 0.15, 0.19444444444444
5260, 1.5260869565217, 0.15, 0.11111111111111
5261, 1.5478260869565, 0.15, 0.13888888888889
5262, 1.5260869565217, 0.15, 0.055555555555556
5263, 1.5478260869565, 0.15, 0.083333333333333
5264, 1.5478260869565, 0.15, 0.027777777777778
5265, 1.5695652173913, 0.15, 0.44444444444444
5266, 1.5913043478261, 0.15, 0.47222222222222
5267, 1.5695652173913, 0.15, 0.38888888888889
5268, 1.5913043478261, 0.15, 0.41666666666667
5269, 1.5695652173913, 0.15, 0.33333333333333
5270, 1.5913043478261, 0.15, 0.36111111111111
5271, 1.5695652173913, 0.15, 0.27777777777778
5272, 1.5913043478261, 0.15, 0.30555555555556
5273, 1.5695652173913, 0.15, 0.22222222222222
5274, 1.5913043478261, 0.15, 0.25
5275, 1.5695652173913, 0.15, 0.16666666666667
5276, 1.5913043478261, 0.15, 0.19444444444444
5277, 1.5695652173913, 0.15, 0.11111111111111
5278, 1.5913043478261, 0.15, 0.13888888888889
5279, 1.5695652173913, 0.15, 0.055555555555556
5280, 1.5913043478261, 0.15, 0.083333333333333
5281, 1.5913043478261, 0.15, 0.027777777777778
5282, 1.6130434782609, 0.15, 0.44444444444444
5283, 1.6347826086957, 0.15, 0.47222222222222
5284, 1.6130434782609, 0.15, 0.38888888888889
5285, 1.6347826086957, 0.15, 0.41666666666667
5286, 1.6130434782609, 0.15, 0.33333333333333
5287, 1.6347826086957, 0.15, 0.36111111111111
5288, 1.6130434782609, 0.15, 0.27777777777778
5289, 1.6347826086957, 0.15, 0.30555555555556
5290, 1.6130434782609, 0.15, 0.22222222222222
5291, 1.6347826086957, 0.15, 0.25
5292, 1.6130434782609, 0.15, 0.16666666666667
5293, 1.6347826086957, 0.15, 0.19444444444444
5294, 1.6130434782609, 0.15, 0.11111111111111
5295, 1.6347826086957, 0.15, 0.13888888888889
5296, 1.6130434782609, 0.15, 0.055555555555556
5297, 1.6347826086957, 0.15, 0.083333333333333
5298, 1.6347826086957, 0.15, 0.027777777777778
5299, 1.6565217391304, 0.15, 0.44444444444444
5300, 1.6782608695652, 0.15, 0.47222222222222
5301, 1.6565217391304, 0.15, 0.38888888888889
5302, 1.6782608695652, 0.15, 0.41666666666667
5303, 1.6565217391304, 0.15, 0.33333333333333
5304, 1.6782608695652, 0.15, 0.36111111111111
5305, 1.6565217391304, 0.15, 0.27777777777778
5306, 1.6782608695652, 0.15, 0.30555555555556
5307, 1.6565217391304, 0.15, 0.22222222222222
5308, 1.6782608695652, 0.15, 0.25
5309, 1.6565217391304, 0.15, 0.16666666666667
5310, 1.6782608695652, 0.15, 0.19444444444444
5311, 1.6565217391304, 0.15, 0.11111111111111
5312, 1.6782608695652, 0.15, 0.13888888888889
5313, 1.6565217391304, 0.15, 0.055555555555556
5314, 1.6782608695652, 0.15, 0.083333333333333
5315, 1.6782608695652, 0.15, 0.027777777777778
5316, 1.7, 0.15, 0.44444444444444
5317, 1.7217391304348, 0.15, 0.47222222222222
5318, 1.7, 0.15, 0.38888888888889
5319, 1.7217391304348, 0.15, 0.41666666666667
5320, 1.7, 0.15, 0.33333333333333
5321, 1.7217391304348, 0.15, 0.36111111111111
5322, 1.7, 0.15, 0.27777777777778
5323, 1.7217391304348, 0.15, 0.30555555555556
5324, 1.7, 0.15, 0.22222222222222
5325, 1.7217391304348, 0.15, 0.25
5326, 1.7, 0.15, 0.16666666666667
5327, 1.7217391304348, 0.15, 0.19444444444444
5328, 1.7, 0.15, 0.11111111111111
5329, 1.7217391304348, 0.15, 0.13888888888889
5330, 1.7, 0.15, 0.055555555555556
5331, 1.7217391304348, 0.15, 0.083333333333333
5332, 1.7217391304348, 0.15, 0.027777777777778
5333, 1.7434782608696, 0.15, 0.44444444444444
5334, 1.7652173913043, 0.15, 0.47222222222222
5335, 1.7434782608696, 0.15, 0.38888888888889
5336, 1.7652173913043, 0.15, 0.41666666666667
5337, 1.7434782608696, 0.15, 0.33333333333333
5338, 1.7652173913043, 0.15, 0.36111111111111
5339, 1.7434782608696, 0.15, 0.27777777777778
5340, 1.7652173913043, 0.15, 0.30555555555556
5341, 1.7434782608696, 0.15, 0.22222222222222
5342, 1.7652173913043, 0.15, 0.25
5343, 1.7434782608696, 0.15, 0.16666666666667
5344, 1.7652173913043, 0.15, 0.19444444444444
5345, 1.7434782608696, 0.15, 0.11111111111111
5346, 1.7652173913043, 0.15, 0.13888888888889
5347, 1.7434782608696, 0.15, 0.055555555555556
5348, 1.7652173913043, 0.15, 0.083333333333333
5349, 1.7652173913043, 0.15, 0.027777777777778
5350, 1.7869565217391, 0.15, 0.44444444444444
5351, 1.8086956521739, 0.15, 0.47222222222222
5352, 1.7869565217391, 0.15, 0.38888888888889
5353, 1.8086956521739, 0.15, 0.41666666666667
5354, 1.7869565217391, 0.15, 0.33333333333333
5355, 1.8086956521739, 0.15, 0.36111111111111
5356, 1.7869565217391, 0.15, 0.27777777777778
5357, 1.8086956521739, 0.15, 0.30555555555556
5358, 1.7869565217391, 0.15, 0.22222222222222
5359, 1.8086956521739, 0.15, 0.25
5360, 1.7869565217391, 0.15, 0.16666666666667
5361, 1.8086956521739, 0.15, 0.19444444444444
5362, 1.7869565217391, 0.15, 0.11111111111111
5363, 1.8086956521739, 0.15, 0.13888888888889
5364, 1.7869565217391, 0.15, 0.055555555555556
5365, 1.8086956521739, 0.15, 0.083333333333333
5366, 1.8086956521739, 0.15, 0.027777777777778
5367, 1.8304347826087, 0.15, 0.44444444444444
5368, 1.8521739130435, 0.15, 0.47222222222222
5369, 1.8304347826087, 0.15, 0.38888888888889
5370, 1.8521739130435, 0.15, 0.41666666666667
5371, 1.8304347826087, 0.15, 0.33333333333333
5372, 1.8521739130435, 0.15, 0.36111111111111
5373, 1.8304347826087, 0.15, 0.27777777777778
5374, 1.8521739130435, 0.15, 0.30555555555556
5375, 1.8304347826087, 0.15, 0.22222222222222
5376, 1.8521739130435, 0.15, 0.25
5377, 1.8304347826087, 0.15, 0.16666666666667
5378, 1.8521739130435, 0.15, 0.19444444444444
5379, 1.8304347826087, 0.15, 0.11111111111111
5380, 1.8521739130435, 0.15, 0.13888888888889
5381, 1.8304347826087, 0.15, 0.055555555555556
5382, 1.8521739130435, 0.15, 0.083333333333333
5383, 1.8521739130435, 0.15, 0.027777777777778
5384, 1.8739130434783, 0.15, 0.44444444444444
5385, 1.895652173913, 0.15, 0.47222222222222
5386, 1.8739130434783, 0.15, 0.38888888888889
5387, 1.895652173913, 0.15, 0.41666666666667
5388, 1.8739130434783, 0.15, 0.33333333333333
5389, 1.895652173913, 0.15, 0.36111111111111
5390, 1.8739130434783, 0.15, 0.27777777777778
5391, 1.895652173913, 0.15, 0.30555555555556
5392, 1.8739130434783, 0.15, 0.22222222222222
5393, 1.895652173913, 0.15, 0.25
5394, 1.8739130434783, 0.15, 0.16666666666667
5395, 1.895652173913, 0.15, 0.19444444444444
5396, 1.8739130434783, 0.15, 0.11111111111111
5397, 1.895652173913, 0.15, 0.13888888888889
5398, 1.8739130434783, 0.15, 0.055555555555556
5399, 1.895652173913, 0.15, 0.083333333333333
5400, 1.895652173913, 0.15, 0.027777777777778
5401, 1.9173913043478, 0.15, 0.44444444444444
5402, 1.9391304347826, 0.15, 0.47222222222222
5403, 1.9173913043478, 0.15, 0.38888888888889
5404, 1.9391304347826, 0.15, 0.41666666666667
5405, 1.9173913043478, 0.15, 0.33333333333333
5406, 1.9391304347826, 0.15, 0.36111111111111
5407, 1.9173913043478, 0.15, 0.27777777777778
5408, 1.9391304347826, 0.15, 0.30555555555556
5409, 1.9173913043478, 0.15, 0.22222222222222
5410, 1.9391304347826, 0.15, 0.25
5411, 1.9173913043478, 0.15, 0.16666666666667
5412, 1.9391304347826, 0.15, 0.19444444444444
5413, 1.9173913043478, 0.15, 0.11111111111111
5414, 1.9391304347826, 0.15, 0.13888888888889
5415, 1.9173913043478, 0.15, 0.055555555555556
5416, 1.9391304347826, 0.15, 0.083333333333333
5417, 1.9391304347826, 0.15, 0.027777777777778
5418, 1.9608695652174, 0.15, 0.44444444444444
5419, 1.9826086956522, 0.15, 0.47222222222222
5420, 1.9608695652174, 0.15, 0.38888888888889
5421, 1.9826086956522, 0.15, 0.41666666666667
5422, 1.9608695652174, 0.15, 0.33333333333333
5423, 1.9826086956522, 0.15, 0.36111111111111
5424, 1.9608695652174, 0.15, 0.27777777777778
5425, 1.9826086956522, 0.15, 0.30555555555556
5426, 1.9608695652174, 0.15, 0.22222222222222
5427, 1.9826086956522, 0.15, 0.25
5428, 1.9608695652174, 0.15, 0.16666666666667
5429, 1.9826086956522, 0.15, 0.19444444444444
5430, 1.9608695652174, 0.15, 0.11111111111111
5431, 1.9826086956522, 0.15, 0.13888888888889
5432, 1.9608695652174, 0.15, 0.055555555555556
5433, 1.9826086956522, 0.15, 0.083333333333333
5434, 1.9826086956522, 0.15, 0.027777777777778
5435, 2.004347826087, 0.15, 0.44444444444444
5436, 2.0260869565217, 0.15, 0.47222222222222
5437, 2.004347826087, 0.15, 0.38888888888889
5438, 2.0260869565217, 0.15, 0.41666666666667
5439, 2.004347826087, 0.15, 0.33333333333333
5440, 2.0260869565217, 0.15, 0.36111111111111
5441, 2.004347826087, 0.15, 0.27777777777778
5442, 2.0260869565217, 0.15, 0.30555555555556
5443, 2.004347826087, 0.15, 0.22222222222222
5444, 2.0260869565217, 0.15, 0.25
5445, 2.004347826087, 0.15, 0.16666666666667
5446, 2.0260869565217, 0.15, 0.19444444444444
5447, 2.004347826087, 0.15, 0.11111111111111
5448, 2.0260869565217, 0.15, 0.13888888888889
5449, 2.004347826087, 0.15, 0.055555555555556
5450, 2.0260869565217, 0.15, 0.083333333333333
5451, 2.0260869565217, 0.15, 0.027777777777778
5452, 2.0478260869565, 0.15, 0.44444444444444
5453, 2.0695652173913, 0.15, 0.47222222222222
5454, 2.0478260869565, 0.15, 0.38888888888889
5455, 2.0695652173913, 0.15, 0.41666666666667
5456, 2.0478260869565, 0.15, 0.33333333333333
5457, 2.0695652173913, 0.15, 0.36111111111111
5458, 2.0478260869565, 0.15, 0.27777777777778
5459, 2.0695652173913, 0.15, 0.30555555555556
5460, 2.0478260869565, 0.15, 0.22222222222222
5461, 2.0695652173913, 0.15, 0.25
5462, 2.0478260869565, 0.15, 0.16666666666667
5463, 2.0695652173913, 0.15, 0.19444444444444
5464, 2.0478260869565, 0.15, 0.11111111111111
5465, 2.0695652173913, 0.15, 0.13888888888889
5466, 2.0478260869565, 0.15, 0.055555555555556
5467, 2.0695652173913, 0.15, 0.083333333333333
5468, 2.0695652173913, 0.15, 0.027777777777778
5469, 2.0913043478261, 0.15, 0.44444444444444
5470, 2.1130434782609, 0.15, 0.47222222222222
5471, 2.0913043478261, 0.15, 0.38888888888889
5472, 2.1130434782609, 0.15, 0.41666666666667
5473, 2.0913043478261, 0.15, 0.33333333333333
5474, 2.1130434782609, 0.15, 0.36111111111111
5475, 2.0913043478261, 0.15, 0.27777777777778
5476, 2.1130434782609, 0.15, 0.30555555555556
5477, 2.0913043478261, 0.15, 0.22222222222222
5478, 2.1130434782609, 0.15, 0.25
5479, 2.0913043478261, 0.15, 0.16666666666667
5480, 2.1130434782609, 0.15, 0.19444444444444
5481, 2.0913043478261, 0.15, 0.11111111111111
5482, 2.1130434782609, 0.15, 0.13888888888889
5483, 2.0913043478261, 0.15, 0.055555555555556
5484, 2.1130434782609, 0.15, 0.083333333333333
5485, 2.1130434782609, 0.15, 0.027777777777778
5486, 2.1347826086957, 0.15, 0.44444444444444
5487, 2.1565217391304, 0.15, 0.47222222222222
5488, 2.1347826086957, 0.15, 0.38888888888889
5489, 2.1565217391304, 0.15, 0.41666666666667
5490, 2.1347826086957, 0.15, 0.33333333333333
5491, 2.1565217391304, 0.15, 0.36111111111111
5492, 2.1347826086957, 0.15, 0.27777777777778
5493, 2.1565217391304, 0.15, 0.30555555555556
5494, 2.1347826086957, 0.15, 0.22222222222222
5495, 2.1565217391304, 0.15, 0.25
5496, 2.1347826086957, 0.15, 0.16666666666667
5497, 2.1565217391304, 0.15, 0.19444444444444
5498, 2.1347826086957, 0.15, 0.11111111111111
5499, 2.1565217391304, 0.15, 0.13888888888889
5500, 2.1347826086957, 0.15, 0.055555555555556
5501, 2.1565217391304, 0.15, 0.083333333333333
5502, 2.1565217391304, 0.15, 0.027777777777778
5503, 2.1782608695652, 0.15, 0.44444444444444
5504, 2.1782608695652, 0.15, 0.38888888888889
5505, 2.1782608695652, 0.15, 0.33333333333333
5506, 2.1782608695652, 0.15, 0.27777777777778
5507, 2.1782608695652, 0.15, 0.22222222222222
5508, 2.1782608695652, 0.15, 0.16666666666667
5509, 2.1782608695652, 0.15, 0.11111111111111
5510, 2.1782608695652, 0.15, 0.055555555555556
5511, -0.05, 0.016666666666667, 0.5
5512, -0.05, -0.016666666666667, 0.5
5513, -0.05, 0.033333333333333, 0.5
5514, -0.025, 0.016666666666667, 0.5
5515, -0.05, 5.5511151231258e-17, 0.5
5516, -0.025, -0.016666666666667, 0.5
5517, -0.05, -0.033333333333333, 0.5
5518, -0.075, 0.016666666666667, 0.5
5519, -0.075, -0.016666666666667, 0.5
5520, -0.05, -0.05, 0.44444444444444
5521, -0.05, -0.05, 0.38888888888889
5522, -0.05, -0.05, 0.33333333333333
5523, -0.05, -0.05, 0.27777777777778
5524, -0.05, -0.05, 0.22222222222222
5525, -0.05, -0.05, 0.16666666666667
5526, -0.05, -0.05, 0.11111111111111
5527, -0.05, -0.05, 0.055555555555556
5528, -0.05, -0.05, 0.47222222222222
5529, -0.025, -0.05, 0.44444444444444
5530, -0.05, -0.05, 0.41666666666667
5531, -0.025, -0.05, 0.38888888888889
5532, -0.05, -0.05, 0.36111111111111
5533, -0.025, -0.05, 0.33333333333333
5534, -0.05, -0.05, 0.30555555555556
5535, -0.025, -0.05, 0.27777777777778
5536, -0.05, -0.05, 0.25
5537, -0.025, -0.05, 0.22222222222222
5538, -0.05, -0.05, 0.19444444444444
5539, -0.025, -0.05, 0.16666666666667
5540, -0.05, -0.05, 0.13888888888889
5541, -0.025, -0.05, 0.11111111111111
5542, -0.05, -0.05, 0.083333333333333
5543, -0.025, -0.05, 0.055555555555556
5544, -0.05, -0.05, 0.027777777777778
5545, -0.075, -0.05, 0.44444444444444
5546, -0.075, -0.05, 0.38888888888889
5547, -0.075, -0.05, 0.33333333333333
5548, -0.075, -0.05, 0.27777777777778
5549, -0.075, -0.05, 0.22222222222222
5550, -0.075, -0.05, 0.16666666666667
5551, -0.075, -0.05, 0.11111111111111
5552, -0.075, -0.05, 0.055555555555556
5553, -0.05, 0.05, 0.44444444444444
5554, -0.05, 0.05, 0.38888888888889
5555, -0.05, 0.05, 0.33333333333333
5556, -0.05, 0.05, 0.27777777777778
5557, -0.05, 0.05, 0.22222222222222
5558, -0.05, 0.05, 0.16666666666667
5559, -0.05, 0.05, 0.11111111111111
5560, -0.05, 0.05, 0.055555555555556
5561, -0.025, 0.05, 0.44444444444444
5562, -0.05, 0.05, 0.47222222222222
5563, -0.025, 0.05, 0.38888888888889
5564, -0.05, 0.05, 0.41666666666667
5565, -0.025, 0.05, 0.33333333333333
5566, -0.05, 0.05, 0.36111111111111
5567, -0.025, 0.05, 0.27777777777778
5568, -0.05, 0.05, 0.30555555555556
5569, -0.025, 0.05, 0.22222222222222
5570, -0.05, 0.05, 0.25
5571, -0.025, 0.05, 0.16666666666667
5572, -0.05, 0.05, 0.19444444444444
5573, -0.025, 0.05, 0.11111111111111
5574, -0.05, 0.05, 0.13888888888889
5575, -0.025, 0.05, 0.055555555555556
5576, -0.05, 0.05, 0.083333333333333
5577, -0.05, 0.05, 0.027777777777778
5578, -0.075, 0.05, 0.44444444444444
5579, -0.075, 0.05, 0.38888888888889
5580, -0.075, 0.05, 0.33333333333333
5581, -0.075, 0.05, 0.27777777777778
5582, -0.075, 0.05, 0.22222222222222
5583, -0.075, 0.05, 0.16666666666667
5584, -0.075, 0.05, 0.11111111111111
5585, -0.075, 0.05, 0.055555555555556
5586, -0.05, 0.016666666666667, 0
5587, -0.05, -0.016666666666667, 0
5588, -0.025, 0.016666666666667, 0
5589, -0.05, 0.033333333333333, 0
5590, -0.025, -0.016666666666667, 0
5591, -0.05, 5.5511151231258e-17, 0
5592, -0.05, -0.033333333333333, 0
5593, -0.075, 0.016666666666667, 0
5594, -0.075, -0.016666666666667, 0
5595, 0, -0.016666666666667, 0.055555555555556
5596, 0, 0.016666666666667, 0.055555555555556
5597, 0, -0.016666666666667, 0.11111111111111
5598, 0, 0.016666666666667, 0.11111111111111
5599, 0, -0.016666666666667, 0.16666666666667
5600, 0, 0.016666666666667, 0.16666666666667
5601, 0, -0.016666666666667, 0.22222222222222
5602, 0, 0.016666666666667, 0.22222222222222
5603, 0, -0.016666666666667, 0.27777777777778
5604, 0, 0.016666666666667, 0.27777777777778
5605, 0, -0.016666666666667, 0.33333333333333
5606, 0, 0.016666666666667, 0.33333333333333
5607, 0, -0.016666666666667, 0.38888888888889
5608, 0, 0.016666666666667, 0.38888888888889
5609, 0, -0.016666666666667, 0.44444444444444
5610, 0, 0.016666666666667, 0.44444444444444
5611, 0, -0.016666666666667, 0.027777777777778
5612, 0, -0.033333333333333, 0.055555555555556
5613, 0, 0.016666666666667, 0.027777777777778
5614, 0, 5.5511151231258e-17, 0.055555555555556
5615, 0, 0.033333333333333, 0.055555555555556
5616, 0, -0.016666666666667, 0.083333333333333
5617, 0, -0.033333333333333, 0.11111111111111
5618, 0, 0.016666666666667, 0.083333333333333
5619, 0, 5.5511151231258e-17, 0.11111111111111
5620, 0, 0.033333333333333, 0.11111111111111
5621, 0, -0.016666666666667, 0.13888888888889
5622, 0, -0.033333333333333, 0.16666666666667
5623, 0, 0.016666666666667, 0.13888888888889
5624, 0, 6.2450045135165e-17, 0.16666666666667
5625, 0, 0.033333333333333, 0.16666666666667
5626, 0, -0.016666666666667, 0.19444444444444
5627, 0, -0.033333333333333, 0.22222222222222
5628, 0, 0.016666666666667, 0.19444444444444
5629, 0, 5.5511151231258e-17, 0.22222222222222
5630, 0, 0.033333333333333, 0.22222222222222
5631, 0, -0.016666666666667, 0.25
5632, 0, -0.033333333333333, 0.27777777777778
5633, 0, 0.016666666666667, 0.25
5634, 0, 5.5511151231258e-17, 0.27777777777778
5635, 0, 0.033333333333333, 0.27777777777778
5636, 0, -0.016666666666667, 0.30555555555556
5637, 0, -0.033333333333333, 0.33333333333333
5638, 0, 0.016666666666667, 0.30555555555556
5639, 0, 5.5511151231258e-17, 0.33333333333333
5640, 0, 0.033333333333333, 0.33333333333333
5641, 0, -0.016666666666667, 0.36111111111111
5642, 0, -0.033333333333333, 0.38888888888889
5643, 0, 0.016666666666667, 0.36111111111111
5644, 0, 5.5511151231258e-17, 0.38888888888889
5645, 0, 0.033333333333333, 0.38888888888889
5646, 0, -0.016666666666667, 0.41666666666667
5647, 0, -0.033333333333333, 0.44444444444444
5648, 0, 0.016666666666667, 0.41666666666667
5649, 0, 5.5511151231258e-17, 0.44444444444444
5650, 0, 0.033333333333333, 0.44444444444444
5651, 0, -0.016666666666667, 0.47222222222222
5652, 0, 0.016666666666667, 0.47222222222222
5653, -0.1, -0.016666666666667, 0.055555555555556
5654, -0.1, 0.016666666666667, 0.055555555555556
5655, -0.1, -0.016666666666667, 0.11111111111111
5656, -0.1, 0.016666666666667, 0.11111111111111
5657, -0.1, -0.016666666666667, 0.16666666666667
5658, -0.1, 0.016666666666667, 0.16666666666667
5659, -0.1, -0.016666666666667, 0.22222222222222
5660, -0.1, 0.016666666666667, 0.22222222222222
5661, -0.1, -0.016666666666667, 0.27777777777778
5662, -0.1, 0.016666666666667, 0.27777777777778
5663, -0.1, -0.016666666666667, 0.33333333333333
5664, -0.1, 0.016666666666667, 0.33333333333333
5665, -0.1, -0.016666666666667, 0.38888888888889
5666, -0.1, 0.016666666666667, 0.38888888888889
5667, -0.1, -0.016666666666667, 0.44444444444444
5668, -0.1, 0.016666666666667, 0.44444444444444
5669, -0.1, -0.033333333333333, 0.055555555555556
5670, -0.1, -0.016666666666667, 0.027777777777778
5671, -0.1, 5.5511151231258e-17, 0.055555555555556
5672, -0.1, 0.016666666666667, 0.027777777777778
5673, -0.1, 0.033333333333333, 0.055555555555556
5674, -0.1, -0.033333333333333, 0.11111111111111
5675, -0.1, -0.016666666666667, 0.083333333333333
5676, -0.1, 5.5511151231258e-17, 0.11111111111111
5677, -0.1, 0.016666666666667, 0.083333333333333
5678, -0.1, 0.033333333333333, 0.11111111111111
5679, -0.1, -0.033333333333333, 0.16666666666667
5680, -0.1, -0.016666666666667, 0.13888888888889
5681, -0.1, 6.2450045135165e-17, 0.16666666666667
5682, -0.1, 0.016666666666667, 0.13888888888889
5683, -0.1, 0.033333333333333, 0.16666666666667
5684, -0.1, -0.033333333333333, 0.22222222222222
5685, -0.1, -0.016666666666667, 0.19444444444444
5686, -0.1, 5.5511151231258e-17, 0.22222222222222
5687, -0.1, 0.016666666666667, 0.19444444444444
5688, -0.1, 0.033333333333333, 0.22222222222222
5689, -0.1, -0.033333333333333, 0.27777777777778
5690, -0.1, -0.016666666666667, 0.25
5691, -0.1, 5.5511151231258e-17, 0.27777777777778
5692, -0.1, 0.016666666666667, 0.25
5693, -0.1, 0.033333333333333, 0.27777777777778
5694, -0.1, -0.033333333333333, 0.33333333333333
5695, -0.1, -0.016666666666667, 0.30555555555556
5696, -0.1, 5.5511151231258e-17, 0.33333333333333
5697, -0.1, 0.016666666666667, 0.30555555555556
5698, -0.1, 0.033333333333333, 0.33333333333333
5699, -0.1, -0.033333333333333, 0.38888888888889
5700, -0.1, -0.016666666666667, 0.36111111111111
5701, -0.1, 5.5511151231258e-17, 0.38888888888889
5702, -0.1, 0.016666666666667, 0.36111111111111
5703, -0.1, 0.033333333333333, 0.38888888888889
5704, -0.1, -0.033333333333333, 0.44444444444444
5705, -0.1, -0.016666666666667, 0.41666666666667
5706, -0.1, 5.5511151231258e-17, 0.44444444444444
5707, -0.1, 0.016666666666667, 0.41666666666667
5708, -0.1, 0.033333333333333, 0.44444444444444
5709, -0.1, -0.016666666666667, 0.47222222222222
5710, -0.1, 0.016666666666667, 0.47222222222222
5711, -0.05, -0.1, 0.5
5712, -0.05, -0.15, 0.5
5713, -0.05, -0.2, 0.5
5714, -0.05, -0.075, 0.5
5715, -0.025, -0.1, 0.5
5716, -0.075, -0.1, 0.5
5717, -0.05, -0.125, 0.5
5718, -0.025, -0.15, 0.5
5719, -0.075, -0.15, 0.5
5720, -0.05, -0.175, 0.5
5721, -0.025, -0.2, 0.5
5722, -0.075, -0.2, 0.5
5723, -0.05, -0.225, 0.5
5724, -0.05, -0.1, 0
5725, -0.05, -0.15, 0
5726, -0.05, -0.2, 0
5727, -0.025, -0.1, 0
5728, -0.05, -0.075, 0
5729, -0.075, -0.1, 0
5730, -0.025, -0.15, 0
5731, -0.05, -0.125, 0
5732, -0.075, -0.15, 0
5733, -0.025, -0.2, 0
5734, -0.05, -0.175, 0
5735, -0.075, -0.2, 0
5736, -0.05, -0.225, 0
5737, 0, -0.1, 0.44444444444444
5738, 0, -0.1, 0.38888888888889
5739, 0, -0.1, 0.33333333333333
5740, 0, -0.1, 0.27777777777778
5741, 0, -0.1, 0.22222222222222
5742, 0, -0.1, 0.16666666666667
5743, 0, -0.1, 0.11111111111111
5744, 0, -0.1, 0.055555555555556
5745, 0, -0.15, 0.44444444444444
5746, 0, -0.15, 0.38888888888889
5747, 0, -0.15, 0.33333333333333
5748, 0, -0.15, 0.27777777777778
5749, 0, -0.15, 0.22222222222222
5750, 0, -0.15, 0.16666666666667
5751, 0, -0.15, 0.11111111111111
5752, 0, -0.15, 0.055555555555556
5753, 0, -0.2, 0.44444444444444
5754, 0, -0.2, 0.38888888888889
5755, 0, -0.2, 0.33333333333333
5756, 0, -0.2, 0.27777777777778
5757, 0, -0.2, 0.22222222222222
5758, 0, -0.2, 0.16666666666667
5759, 0, -0.2, 0.11111111111111
5760, 0, -0.2, 0.055555555555556
5761, 0, -0.1, 0.47222222222222
5762, 0, -0.075, 0.44444444444444
5763, 0, -0.1, 0.41666666666667
5764, 0, -0.075, 0.38888888888889
5765, 0, -0.1, 0.36111111111111
5766, 0, -0.075, 0.33333333333333
5767, 0, -0.1, 0.30555555555556
5768, 0, -0.075, 0.27777777777778
5769, 0, -0.1, 0.25
5770, 0, -0.075, 0.22222222222222
5771, 0, -0.1, 0.19444444444444
5772, 0, -0.075, 0.16666666666667
5773, 0, -0.1, 0.13888888888889
5774, 0, -0.075, 0.11111111111111
5775, 0, -0.1, 0.083333333333333
5776, 0, -0.075, 0.055555555555556
5777, 0, -0.1, 0.027777777777778
5778, 0, -0.15, 0.47222222222222
5779, 0, -0.125, 0.44444444444444
5780, 0, -0.15, 0.41666666666667
5781, 0, -0.125, 0.38888888888889
5782, 0, -0.15, 0.36111111111111
5783, 0, -0.125, 0.33333333333333
5784, 0, -0.15, 0.30555555555556
5785, 0, -0.125, 0.27777777777778
5786, 0, -0.15, 0.25
5787, 0, -0.125, 0.22222222222222
5788, 0, -0.15, 0.19444444444444
5789, 0, -0.125, 0.16666666666667
5790, 0, -0.15, 0.13888888888889
5791, 0, -0.125, 0.11111111111111
5792, 0, -0.15, 0.083333333333333
5793, 0, -0.125, 0.055555555555556
5794, 0, -0.15, 0.027777777777778
5795, 0, -0.2, 0.47222222222222
5796, 0, -0.175, 0.44444444444444
5797, 0, -0.2, 0.41666666666667
5798, 0, -0.175, 0.38888888888889
5799, 0, -0.2, 0.36111111111111
5800, 0, -0.175, 0.33333333333333
5801, 0, -0.2, 0.30555555555556
5802, 0, -0.175, 0.27777777777778
5803, 0, -0.2, 0.25
5804, 0, -0.175, 0.22222222222222
5805, 0, -0.2, 0.19444444444444
5806, 0, -0.175, 0.16666666666667
5807, 0, -0.2, 0.13888888888889
5808, 0, -0.175, 0.11111111111111
5809, 0, -0.2, 0.083333333333333
5810, 0, -0.175, 0.055555555555556
5811, 0, -0.2, 0.027777777777778
5812, 0, -0.225, 0.44444444444444
5813, 0, -0.225, 0.38888888888889
5814, 0, -0.225, 0.33333333333333
5815, 0, -0.225, 0.27777777777778
5816, 0, -0.225, 0.22222222222222
5817, 0, -0.225, 0.16666666666667
5818, 0, -0.225, 0.11111111111111
5819, 0, -0.225, 0.055555555555556
5820, -0.1, -0.1, 0.44444444444444
5821, -0.1, -0.1, 0.38888888888889
5822, -0.1, -0.1, 0.33333333333333
5823, -0.1, -0.1, 0.27777777777778
5824, -0.1, -0.1, 0.22222222222222
5825, -0.1, -0.1, 0.16666666666667
5826, -0.1, -0.1, 0.11111111111111
5827, -0.1, -0.1, 0.055555555555556
5828, -0.1, -0.15, 0.44444444444444
5829, -0.1, -0.15, 0.38888888888889
5830, -0.1, -0.15, 0.33333333333333
5831, -0.1, -0.15, 0.27777777777778
5832, -0.1, -0.15, 0.22222222222222
5833, -0.1, -0.15, 0.16666666666667
5834, -0.1, -0.15, 0.11111111111111
5835, -0.1, -0.15, 0.055555555555556
5836, -0.1, -0.2, 0.44444444444444
5837, -0.1, -0.2, 0.38888888888889
5838, -0.1, -0.2, 0.33333333333333
5839, -0.1, -0.2, 0.27777777777778
5840, -0.1, -0.2, 0.22222222222222
5841, -0.1, -0.2, 0.16666666666667
5842, -0.1, -0.2, 0.11111111111111
5843, -0.1, -0.2, 0.055555555555556
5844, -0.1, -0.075, 0.44444444444444
5845, -0.1, -0.1, 0.47222222222222
5846, -0.1, -0.075, 0.38888888888889
5847, -0.1, -0.1, 0.41666666666667
5848, -0.1, -0.075, 0.33333333333333
