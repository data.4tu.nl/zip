52978, 0.043478260869565, 1.0369565217391, 0.41666666666667
52979, 0.065217391304348, 1.0369565217391, 0.44444444444444
52980, 0.043478260869565, 1.0108695652174, 0.44444444444444
52981, 0.043478260869565, 1.0369565217391, 0.47222222222222
52982, 0.021739130434783, 1.0369565217391, 0.055555555555556
52983, 0.021739130434783, 1.0369565217391, 0.11111111111111
52984, 0.021739130434783, 1.0369565217391, 0.16666666666667
52985, 0.021739130434783, 1.0369565217391, 0.22222222222222
52986, 0.021739130434783, 1.0369565217391, 0.27777777777778
52987, 0.021739130434783, 1.0369565217391, 0.33333333333333
52988, 0.021739130434783, 1.0369565217391, 0.38888888888889
52989, 0.021739130434783, 1.0369565217391, 0.44444444444444
52990, 0.95652173913043, 1.0891304347826, 0.027777777777778
52991, 0.97826086956522, 1.0891304347826, 0.055555555555556
52992, 0.95652173913043, 1.0630434782609, 0.055555555555556
52993, 0.95652173913043, 1.0891304347826, 0.083333333333333
52994, 0.97826086956522, 1.0891304347826, 0.11111111111111
52995, 0.95652173913044, 1.0630434782609, 0.11111111111111
52996, 0.95652173913043, 1.0891304347826, 0.13888888888889
52997, 0.97826086956522, 1.0891304347826, 0.16666666666667
52998, 0.95652173913043, 1.0630434782609, 0.16666666666667
52999, 0.95652173913043, 1.0891304347826, 0.19444444444444
53000, 0.97826086956522, 1.0891304347826, 0.22222222222222
53001, 0.95652173913044, 1.0630434782609, 0.22222222222222
53002, 0.95652173913044, 1.0891304347826, 0.25
53003, 0.97826086956522, 1.0891304347826, 0.27777777777778
53004, 0.95652173913044, 1.0630434782609, 0.27777777777778
53005, 0.95652173913044, 1.0891304347826, 0.30555555555556
53006, 0.97826086956522, 1.0891304347826, 0.33333333333333
53007, 0.95652173913044, 1.0630434782609, 0.33333333333333
53008, 0.95652173913043, 1.0891304347826, 0.36111111111111
53009, 0.97826086956522, 1.0891304347826, 0.38888888888889
53010, 0.95652173913043, 1.0630434782609, 0.38888888888889
53011, 0.95652173913043, 1.0891304347826, 0.41666666666667
53012, 0.97826086956522, 1.0891304347826, 0.44444444444444
53013, 0.95652173913044, 1.0630434782609, 0.44444444444444
53014, 0.95652173913043, 1.0891304347826, 0.47222222222222
53015, 0.91304347826087, 1.0891304347826, 0.027777777777778
53016, 0.93478260869565, 1.0891304347826, 0.055555555555556
53017, 0.91304347826087, 1.0630434782609, 0.055555555555556
53018, 0.91304347826087, 1.0891304347826, 0.083333333333333
53019, 0.93478260869565, 1.0891304347826, 0.11111111111111
53020, 0.91304347826087, 1.0630434782609, 0.11111111111111
53021, 0.91304347826087, 1.0891304347826, 0.13888888888889
53022, 0.93478260869565, 1.0891304347826, 0.16666666666667
53023, 0.91304347826087, 1.0630434782609, 0.16666666666667
53024, 0.91304347826087, 1.0891304347826, 0.19444444444444
53025, 0.93478260869565, 1.0891304347826, 0.22222222222222
53026, 0.91304347826087, 1.0630434782609, 0.22222222222222
53027, 0.91304347826087, 1.0891304347826, 0.25
53028, 0.93478260869565, 1.0891304347826, 0.27777777777778
53029, 0.91304347826087, 1.0630434782609, 0.27777777777778
53030, 0.91304347826087, 1.0891304347826, 0.30555555555556
53031, 0.93478260869565, 1.0891304347826, 0.33333333333333
53032, 0.91304347826087, 1.0630434782609, 0.33333333333333
53033, 0.91304347826087, 1.0891304347826, 0.36111111111111
53034, 0.93478260869565, 1.0891304347826, 0.38888888888889
53035, 0.91304347826087, 1.0630434782609, 0.38888888888889
53036, 0.91304347826087, 1.0891304347826, 0.41666666666667
53037, 0.93478260869565, 1.0891304347826, 0.44444444444444
53038, 0.91304347826087, 1.0630434782609, 0.44444444444444
53039, 0.91304347826087, 1.0891304347826, 0.47222222222222
53040, 0.8695652173913, 1.0891304347826, 0.027777777777778
53041, 0.89130434782609, 1.0891304347826, 0.055555555555556
53042, 0.8695652173913, 1.0630434782609, 0.055555555555556
53043, 0.8695652173913, 1.0891304347826, 0.083333333333333
53044, 0.89130434782609, 1.0891304347826, 0.11111111111111
53045, 0.8695652173913, 1.0630434782609, 0.11111111111111
53046, 0.8695652173913, 1.0891304347826, 0.13888888888889
53047, 0.89130434782609, 1.0891304347826, 0.16666666666667
53048, 0.8695652173913, 1.0630434782609, 0.16666666666667
53049, 0.8695652173913, 1.0891304347826, 0.19444444444444
53050, 0.89130434782609, 1.0891304347826, 0.22222222222222
53051, 0.8695652173913, 1.0630434782609, 0.22222222222222
53052, 0.8695652173913, 1.0891304347826, 0.25
53053, 0.89130434782609, 1.0891304347826, 0.27777777777778
53054, 0.8695652173913, 1.0630434782609, 0.27777777777778
53055, 0.8695652173913, 1.0891304347826, 0.30555555555556
53056, 0.89130434782609, 1.0891304347826, 0.33333333333333
53057, 0.8695652173913, 1.0630434782609, 0.33333333333333
53058, 0.8695652173913, 1.0891304347826, 0.36111111111111
53059, 0.89130434782609, 1.0891304347826, 0.38888888888889
53060, 0.8695652173913, 1.0630434782609, 0.38888888888889
53061, 0.8695652173913, 1.0891304347826, 0.41666666666667
53062, 0.89130434782609, 1.0891304347826, 0.44444444444444
53063, 0.8695652173913, 1.0630434782609, 0.44444444444444
53064, 0.8695652173913, 1.0891304347826, 0.47222222222222
53065, 0.82608695652174, 1.0891304347826, 0.027777777777778
53066, 0.84782608695652, 1.0891304347826, 0.055555555555556
53067, 0.82608695652174, 1.0630434782609, 0.055555555555556
53068, 0.82608695652174, 1.0891304347826, 0.083333333333333
53069, 0.84782608695652, 1.0891304347826, 0.11111111111111
53070, 0.82608695652174, 1.0630434782609, 0.11111111111111
53071, 0.82608695652174, 1.0891304347826, 0.13888888888889
53072, 0.84782608695652, 1.0891304347826, 0.16666666666667
53073, 0.82608695652174, 1.0630434782609, 0.16666666666667
53074, 0.82608695652174, 1.0891304347826, 0.19444444444444
53075, 0.84782608695652, 1.0891304347826, 0.22222222222222
53076, 0.82608695652174, 1.0630434782609, 0.22222222222222
53077, 0.82608695652174, 1.0891304347826, 0.25
53078, 0.84782608695652, 1.0891304347826, 0.27777777777778
53079, 0.82608695652174, 1.0630434782609, 0.27777777777778
53080, 0.82608695652174, 1.0891304347826, 0.30555555555556
53081, 0.84782608695652, 1.0891304347826, 0.33333333333333
53082, 0.82608695652174, 1.0630434782609, 0.33333333333333
53083, 0.82608695652174, 1.0891304347826, 0.36111111111111
53084, 0.84782608695652, 1.0891304347826, 0.38888888888889
53085, 0.82608695652174, 1.0630434782609, 0.38888888888889
53086, 0.82608695652174, 1.0891304347826, 0.41666666666667
53087, 0.84782608695652, 1.0891304347826, 0.44444444444444
53088, 0.82608695652174, 1.0630434782609, 0.44444444444444
53089, 0.82608695652174, 1.0891304347826, 0.47222222222222
53090, 0.78260869565217, 1.0891304347826, 0.027777777777778
53091, 0.80434782608696, 1.0891304347826, 0.055555555555556
53092, 0.78260869565217, 1.0630434782609, 0.055555555555556
53093, 0.78260869565217, 1.0891304347826, 0.083333333333333
53094, 0.80434782608696, 1.0891304347826, 0.11111111111111
53095, 0.78260869565217, 1.0630434782609, 0.11111111111111
53096, 0.78260869565217, 1.0891304347826, 0.13888888888889
53097, 0.80434782608696, 1.0891304347826, 0.16666666666667
53098, 0.78260869565217, 1.0630434782609, 0.16666666666667
53099, 0.78260869565217, 1.0891304347826, 0.19444444444444
53100, 0.80434782608696, 1.0891304347826, 0.22222222222222
53101, 0.78260869565217, 1.0630434782609, 0.22222222222222
53102, 0.78260869565217, 1.0891304347826, 0.25
53103, 0.80434782608696, 1.0891304347826, 0.27777777777778
53104, 0.78260869565217, 1.0630434782609, 0.27777777777778
53105, 0.78260869565217, 1.0891304347826, 0.30555555555556
53106, 0.80434782608696, 1.0891304347826, 0.33333333333333
53107, 0.78260869565217, 1.0630434782609, 0.33333333333333
53108, 0.78260869565217, 1.0891304347826, 0.36111111111111
53109, 0.80434782608696, 1.0891304347826, 0.38888888888889
53110, 0.78260869565217, 1.0630434782609, 0.38888888888889
53111, 0.78260869565217, 1.0891304347826, 0.41666666666667
53112, 0.80434782608696, 1.0891304347826, 0.44444444444444
53113, 0.78260869565217, 1.0630434782609, 0.44444444444444
53114, 0.78260869565217, 1.0891304347826, 0.47222222222222
53115, 0.73913043478261, 1.0891304347826, 0.027777777777778
53116, 0.76086956521739, 1.0891304347826, 0.055555555555556
53117, 0.73913043478261, 1.0630434782609, 0.055555555555556
53118, 0.73913043478261, 1.0891304347826, 0.083333333333333
53119, 0.76086956521739, 1.0891304347826, 0.11111111111111
53120, 0.73913043478261, 1.0630434782609, 0.11111111111111
53121, 0.73913043478261, 1.0891304347826, 0.13888888888889
53122, 0.76086956521739, 1.0891304347826, 0.16666666666667
53123, 0.73913043478261, 1.0630434782609, 0.16666666666667
53124, 0.73913043478261, 1.0891304347826, 0.19444444444444
53125, 0.76086956521739, 1.0891304347826, 0.22222222222222
53126, 0.73913043478261, 1.0630434782609, 0.22222222222222
53127, 0.73913043478261, 1.0891304347826, 0.25
53128, 0.76086956521739, 1.0891304347826, 0.27777777777778
53129, 0.73913043478261, 1.0630434782609, 0.27777777777778
53130, 0.73913043478261, 1.0891304347826, 0.30555555555556
53131, 0.76086956521739, 1.0891304347826, 0.33333333333333
53132, 0.73913043478261, 1.0630434782609, 0.33333333333333
53133, 0.73913043478261, 1.0891304347826, 0.36111111111111
53134, 0.76086956521739, 1.0891304347826, 0.38888888888889
53135, 0.73913043478261, 1.0630434782609, 0.38888888888889
53136, 0.73913043478261, 1.0891304347826, 0.41666666666667
53137, 0.76086956521739, 1.0891304347826, 0.44444444444444
53138, 0.73913043478261, 1.0630434782609, 0.44444444444444
53139, 0.73913043478261, 1.0891304347826, 0.47222222222222
53140, 0.69565217391304, 1.0891304347826, 0.027777777777778
53141, 0.71739130434783, 1.0891304347826, 0.055555555555556
53142, 0.69565217391304, 1.0630434782609, 0.055555555555556
53143, 0.69565217391304, 1.0891304347826, 0.083333333333333
53144, 0.71739130434783, 1.0891304347826, 0.11111111111111
53145, 0.69565217391304, 1.0630434782609, 0.11111111111111
53146, 0.69565217391304, 1.0891304347826, 0.13888888888889
53147, 0.71739130434783, 1.0891304347826, 0.16666666666667
53148, 0.69565217391304, 1.0630434782609, 0.16666666666667
53149, 0.69565217391304, 1.0891304347826, 0.19444444444444
53150, 0.71739130434783, 1.0891304347826, 0.22222222222222
53151, 0.69565217391304, 1.0630434782609, 0.22222222222222
53152, 0.69565217391304, 1.0891304347826, 0.25
53153, 0.71739130434783, 1.0891304347826, 0.27777777777778
53154, 0.69565217391304, 1.0630434782609, 0.27777777777778
53155, 0.69565217391304, 1.0891304347826, 0.30555555555556
53156, 0.71739130434783, 1.0891304347826, 0.33333333333333
53157, 0.69565217391304, 1.0630434782609, 0.33333333333333
53158, 0.69565217391304, 1.0891304347826, 0.36111111111111
53159, 0.71739130434783, 1.0891304347826, 0.38888888888889
53160, 0.69565217391304, 1.0630434782609, 0.38888888888889
53161, 0.69565217391304, 1.0891304347826, 0.41666666666667
53162, 0.71739130434783, 1.0891304347826, 0.44444444444444
53163, 0.69565217391304, 1.0630434782609, 0.44444444444444
53164, 0.69565217391304, 1.0891304347826, 0.47222222222222
53165, 0.65217391304348, 1.0891304347826, 0.027777777777778
53166, 0.67391304347826, 1.0891304347826, 0.055555555555556
53167, 0.65217391304348, 1.0630434782609, 0.055555555555556
53168, 0.65217391304348, 1.0891304347826, 0.083333333333333
53169, 0.67391304347826, 1.0891304347826, 0.11111111111111
53170, 0.65217391304348, 1.0630434782609, 0.11111111111111
53171, 0.65217391304348, 1.0891304347826, 0.13888888888889
53172, 0.67391304347826, 1.0891304347826, 0.16666666666667
53173, 0.65217391304348, 1.0630434782609, 0.16666666666667
53174, 0.65217391304348, 1.0891304347826, 0.19444444444444
53175, 0.67391304347826, 1.0891304347826, 0.22222222222222
53176, 0.65217391304348, 1.0630434782609, 0.22222222222222
53177, 0.65217391304348, 1.0891304347826, 0.25
53178, 0.67391304347826, 1.0891304347826, 0.27777777777778
53179, 0.65217391304348, 1.0630434782609, 0.27777777777778
53180, 0.65217391304348, 1.0891304347826, 0.30555555555556
53181, 0.67391304347826, 1.0891304347826, 0.33333333333333
53182, 0.65217391304348, 1.0630434782609, 0.33333333333333
53183, 0.65217391304348, 1.0891304347826, 0.36111111111111
53184, 0.67391304347826, 1.0891304347826, 0.38888888888889
53185, 0.65217391304348, 1.0630434782609, 0.38888888888889
53186, 0.65217391304348, 1.0891304347826, 0.41666666666667
53187, 0.67391304347826, 1.0891304347826, 0.44444444444444
53188, 0.65217391304348, 1.0630434782609, 0.44444444444444
53189, 0.65217391304348, 1.0891304347826, 0.47222222222222
53190, 0.60869565217391, 1.0891304347826, 0.027777777777778
53191, 0.6304347826087, 1.0891304347826, 0.055555555555556
53192, 0.60869565217391, 1.0630434782609, 0.055555555555556
53193, 0.60869565217391, 1.0891304347826, 0.083333333333333
53194, 0.6304347826087, 1.0891304347826, 0.11111111111111
53195, 0.60869565217391, 1.0630434782609, 0.11111111111111
53196, 0.60869565217391, 1.0891304347826, 0.13888888888889
53197, 0.6304347826087, 1.0891304347826, 0.16666666666667
53198, 0.60869565217391, 1.0630434782609, 0.16666666666667
53199, 0.60869565217391, 1.0891304347826, 0.19444444444444
53200, 0.6304347826087, 1.0891304347826, 0.22222222222222
53201, 0.60869565217391, 1.0630434782609, 0.22222222222222
53202, 0.60869565217391, 1.0891304347826, 0.25
53203, 0.6304347826087, 1.0891304347826, 0.27777777777778
53204, 0.60869565217391, 1.0630434782609, 0.27777777777778
53205, 0.60869565217391, 1.0891304347826, 0.30555555555556
53206, 0.6304347826087, 1.0891304347826, 0.33333333333333
53207, 0.60869565217391, 1.0630434782609, 0.33333333333333
53208, 0.60869565217391, 1.0891304347826, 0.36111111111111
53209, 0.6304347826087, 1.0891304347826, 0.38888888888889
53210, 0.60869565217391, 1.0630434782609, 0.38888888888889
53211, 0.60869565217391, 1.0891304347826, 0.41666666666667
53212, 0.6304347826087, 1.0891304347826, 0.44444444444444
53213, 0.60869565217391, 1.0630434782609, 0.44444444444444
53214, 0.60869565217391, 1.0891304347826, 0.47222222222222
53215, 0.56521739130435, 1.0891304347826, 0.027777777777778
53216, 0.58695652173913, 1.0891304347826, 0.055555555555556
53217, 0.56521739130435, 1.0630434782609, 0.055555555555556
53218, 0.56521739130435, 1.0891304347826, 0.083333333333333
53219, 0.58695652173913, 1.0891304347826, 0.11111111111111
53220, 0.56521739130435, 1.0630434782609, 0.11111111111111
53221, 0.56521739130435, 1.0891304347826, 0.13888888888889
53222, 0.58695652173913, 1.0891304347826, 0.16666666666667
53223, 0.56521739130435, 1.0630434782609, 0.16666666666667
53224, 0.56521739130435, 1.0891304347826, 0.19444444444444
53225, 0.58695652173913, 1.0891304347826, 0.22222222222222
53226, 0.56521739130435, 1.0630434782609, 0.22222222222222
53227, 0.56521739130435, 1.0891304347826, 0.25
53228, 0.58695652173913, 1.0891304347826, 0.27777777777778
53229, 0.56521739130435, 1.0630434782609, 0.27777777777778
53230, 0.56521739130435, 1.0891304347826, 0.30555555555556
53231, 0.58695652173913, 1.0891304347826, 0.33333333333333
53232, 0.56521739130435, 1.0630434782609, 0.33333333333333
53233, 0.56521739130435, 1.0891304347826, 0.36111111111111
53234, 0.58695652173913, 1.0891304347826, 0.38888888888889
53235, 0.56521739130435, 1.0630434782609, 0.38888888888889
53236, 0.56521739130435, 1.0891304347826, 0.41666666666667
53237, 0.58695652173913, 1.0891304347826, 0.44444444444444
53238, 0.56521739130435, 1.0630434782609, 0.44444444444444
53239, 0.56521739130435, 1.0891304347826, 0.47222222222222
53240, 0.52173913043478, 1.0891304347826, 0.027777777777778
53241, 0.54347826086957, 1.0891304347826, 0.055555555555556
53242, 0.52173913043478, 1.0630434782609, 0.055555555555556
53243, 0.52173913043478, 1.0891304347826, 0.083333333333333
53244, 0.54347826086957, 1.0891304347826, 0.11111111111111
53245, 0.52173913043478, 1.0630434782609, 0.11111111111111
53246, 0.52173913043478, 1.0891304347826, 0.13888888888889
53247, 0.54347826086957, 1.0891304347826, 0.16666666666667
53248, 0.52173913043478, 1.0630434782609, 0.16666666666667
53249, 0.52173913043478, 1.0891304347826, 0.19444444444444
53250, 0.54347826086956, 1.0891304347826, 0.22222222222222
53251, 0.52173913043478, 1.0630434782609, 0.22222222222222
53252, 0.52173913043478, 1.0891304347826, 0.25
53253, 0.54347826086956, 1.0891304347826, 0.27777777777778
53254, 0.52173913043478, 1.0630434782609, 0.27777777777778
53255, 0.52173913043478, 1.0891304347826, 0.30555555555556
53256, 0.54347826086956, 1.0891304347826, 0.33333333333333
53257, 0.52173913043478, 1.0630434782609, 0.33333333333333
53258, 0.52173913043478, 1.0891304347826, 0.36111111111111
53259, 0.54347826086956, 1.0891304347826, 0.38888888888889
53260, 0.52173913043478, 1.0630434782609, 0.38888888888889
53261, 0.52173913043478, 1.0891304347826, 0.41666666666667
53262, 0.54347826086956, 1.0891304347826, 0.44444444444444
53263, 0.52173913043478, 1.0630434782609, 0.44444444444444
53264, 0.52173913043478, 1.0891304347826, 0.47222222222222
53265, 0.47826086956522, 1.0891304347826, 0.027777777777778
53266, 0.5, 1.0891304347826, 0.055555555555556
53267, 0.47826086956522, 1.0630434782609, 0.055555555555556
53268, 0.47826086956522, 1.0891304347826, 0.083333333333333
53269, 0.5, 1.0891304347826, 0.11111111111111
53270, 0.47826086956522, 1.0630434782609, 0.11111111111111
53271, 0.47826086956522, 1.0891304347826, 0.13888888888889
53272, 0.5, 1.0891304347826, 0.16666666666667
53273, 0.47826086956522, 1.0630434782609, 0.16666666666667
53274, 0.47826086956522, 1.0891304347826, 0.19444444444444
53275, 0.5, 1.0891304347826, 0.22222222222222
53276, 0.47826086956522, 1.0630434782609, 0.22222222222222
53277, 0.47826086956522, 1.0891304347826, 0.25
53278, 0.5, 1.0891304347826, 0.27777777777778
53279, 0.47826086956522, 1.0630434782609, 0.27777777777778
53280, 0.47826086956522, 1.0891304347826, 0.30555555555556
53281, 0.5, 1.0891304347826, 0.33333333333333
53282, 0.47826086956522, 1.0630434782609, 0.33333333333333
53283, 0.47826086956522, 1.0891304347826, 0.36111111111111
53284, 0.5, 1.0891304347826, 0.38888888888889
53285, 0.47826086956522, 1.0630434782609, 0.38888888888889
53286, 0.47826086956522, 1.0891304347826, 0.41666666666667
53287, 0.5, 1.0891304347826, 0.44444444444444
53288, 0.47826086956522, 1.0630434782609, 0.44444444444444
53289, 0.47826086956522, 1.0891304347826, 0.47222222222222
53290, 0.43478260869565, 1.0891304347826, 0.027777777777778
53291, 0.45652173913043, 1.0891304347826, 0.055555555555556
53292, 0.43478260869565, 1.0630434782609, 0.055555555555556
53293, 0.43478260869565, 1.0891304347826, 0.083333333333333
53294, 0.45652173913043, 1.0891304347826, 0.11111111111111
53295, 0.43478260869565, 1.0630434782609, 0.11111111111111
53296, 0.43478260869565, 1.0891304347826, 0.13888888888889
53297, 0.45652173913043, 1.0891304347826, 0.16666666666667
53298, 0.43478260869565, 1.0630434782609, 0.16666666666667
53299, 0.43478260869565, 1.0891304347826, 0.19444444444444
53300, 0.45652173913043, 1.0891304347826, 0.22222222222222
53301, 0.43478260869565, 1.0630434782609, 0.22222222222222
53302, 0.43478260869565, 1.0891304347826, 0.25
53303, 0.45652173913043, 1.0891304347826, 0.27777777777778
53304, 0.43478260869565, 1.0630434782609, 0.27777777777778
53305, 0.43478260869565, 1.0891304347826, 0.30555555555556
53306, 0.45652173913043, 1.0891304347826, 0.33333333333333
53307, 0.43478260869565, 1.0630434782609, 0.33333333333333
53308, 0.43478260869565, 1.0891304347826, 0.36111111111111
53309, 0.45652173913043, 1.0891304347826, 0.38888888888889
53310, 0.43478260869565, 1.0630434782609, 0.38888888888889
53311, 0.43478260869565, 1.0891304347826, 0.41666666666667
53312, 0.45652173913043, 1.0891304347826, 0.44444444444444
53313, 0.43478260869565, 1.0630434782609, 0.44444444444444
53314, 0.43478260869565, 1.0891304347826, 0.47222222222222
53315, 0.39130434782609, 1.0891304347826, 0.027777777777778
53316, 0.41304347826087, 1.0891304347826, 0.055555555555556
53317, 0.39130434782609, 1.0630434782609, 0.055555555555556
53318, 0.39130434782609, 1.0891304347826, 0.083333333333333
53319, 0.41304347826087, 1.0891304347826, 0.11111111111111
53320, 0.39130434782609, 1.0630434782609, 0.11111111111111
53321, 0.39130434782609, 1.0891304347826, 0.13888888888889
53322, 0.41304347826087, 1.0891304347826, 0.16666666666667
53323, 0.39130434782609, 1.0630434782609, 0.16666666666667
53324, 0.39130434782609, 1.0891304347826, 0.19444444444444
53325, 0.41304347826087, 1.0891304347826, 0.22222222222222
53326, 0.39130434782609, 1.0630434782609, 0.22222222222222
53327, 0.39130434782609, 1.0891304347826, 0.25
53328, 0.41304347826087, 1.0891304347826, 0.27777777777778
53329, 0.39130434782609, 1.0630434782609, 0.27777777777778
53330, 0.39130434782609, 1.0891304347826, 0.30555555555556
53331, 0.41304347826087, 1.0891304347826, 0.33333333333333
53332, 0.39130434782609, 1.0630434782609, 0.33333333333333
53333, 0.39130434782609, 1.0891304347826, 0.36111111111111
53334, 0.41304347826087, 1.0891304347826, 0.38888888888889
53335, 0.39130434782609, 1.0630434782609, 0.38888888888889
53336, 0.39130434782609, 1.0891304347826, 0.41666666666667
53337, 0.41304347826087, 1.0891304347826, 0.44444444444444
53338, 0.39130434782609, 1.0630434782609, 0.44444444444444
53339, 0.39130434782609, 1.0891304347826, 0.47222222222222
53340, 0.34782608695652, 1.0891304347826, 0.027777777777778
53341, 0.3695652173913, 1.0891304347826, 0.055555555555556
53342, 0.34782608695652, 1.0630434782609, 0.055555555555556
53343, 0.34782608695652, 1.0891304347826, 0.083333333333333
53344, 0.3695652173913, 1.0891304347826, 0.11111111111111
53345, 0.34782608695652, 1.0630434782609, 0.11111111111111
53346, 0.34782608695652, 1.0891304347826, 0.13888888888889
53347, 0.3695652173913, 1.0891304347826, 0.16666666666667
53348, 0.34782608695652, 1.0630434782609, 0.16666666666667
53349, 0.34782608695652, 1.0891304347826, 0.19444444444444
53350, 0.3695652173913, 1.0891304347826, 0.22222222222222
53351, 0.34782608695652, 1.0630434782609, 0.22222222222222
53352, 0.34782608695652, 1.0891304347826, 0.25
53353, 0.3695652173913, 1.0891304347826, 0.27777777777778
53354, 0.34782608695652, 1.0630434782609, 0.27777777777778
53355, 0.34782608695652, 1.0891304347826, 0.30555555555556
53356, 0.3695652173913, 1.0891304347826, 0.33333333333333
53357, 0.34782608695652, 1.0630434782609, 0.33333333333333
53358, 0.34782608695652, 1.0891304347826, 0.36111111111111
53359, 0.3695652173913, 1.0891304347826, 0.38888888888889
53360, 0.34782608695652, 1.0630434782609, 0.38888888888889
53361, 0.34782608695652, 1.0891304347826, 0.41666666666667
53362, 0.3695652173913, 1.0891304347826, 0.44444444444444
53363, 0.34782608695652, 1.0630434782609, 0.44444444444444
53364, 0.34782608695652, 1.0891304347826, 0.47222222222222
53365, 0.30434782608696, 1.0891304347826, 0.027777777777778
53366, 0.32608695652174, 1.0891304347826, 0.055555555555556
53367, 0.30434782608696, 1.0630434782609, 0.055555555555556
53368, 0.30434782608696, 1.0891304347826, 0.083333333333333
53369, 0.32608695652174, 1.0891304347826, 0.11111111111111
53370, 0.30434782608696, 1.0630434782609, 0.11111111111111
53371, 0.30434782608696, 1.0891304347826, 0.13888888888889
53372, 0.32608695652174, 1.0891304347826, 0.16666666666667
53373, 0.30434782608696, 1.0630434782609, 0.16666666666667
53374, 0.30434782608696, 1.0891304347826, 0.19444444444444
53375, 0.32608695652174, 1.0891304347826, 0.22222222222222
53376, 0.30434782608696, 1.0630434782609, 0.22222222222222
53377, 0.30434782608696, 1.0891304347826, 0.25
53378, 0.32608695652174, 1.0891304347826, 0.27777777777778
53379, 0.30434782608696, 1.0630434782609, 0.27777777777778
53380, 0.30434782608696, 1.0891304347826, 0.30555555555556
53381, 0.32608695652174, 1.0891304347826, 0.33333333333333
53382, 0.30434782608696, 1.0630434782609, 0.33333333333333
53383, 0.30434782608696, 1.0891304347826, 0.36111111111111
53384, 0.32608695652174, 1.0891304347826, 0.38888888888889
53385, 0.30434782608696, 1.0630434782609, 0.38888888888889
53386, 0.30434782608696, 1.0891304347826, 0.41666666666667
53387, 0.32608695652174, 1.0891304347826, 0.44444444444444
53388, 0.30434782608696, 1.0630434782609, 0.44444444444444
53389, 0.30434782608696, 1.0891304347826, 0.47222222222222
53390, 0.26086956521739, 1.0891304347826, 0.027777777777778
53391, 0.28260869565217, 1.0891304347826, 0.055555555555556
53392, 0.26086956521739, 1.0630434782609, 0.055555555555556
53393, 0.26086956521739, 1.0891304347826, 0.083333333333333
53394, 0.28260869565217, 1.0891304347826, 0.11111111111111
53395, 0.26086956521739, 1.0630434782609, 0.11111111111111
53396, 0.26086956521739, 1.0891304347826, 0.13888888888889
53397, 0.28260869565217, 1.0891304347826, 0.16666666666667
53398, 0.26086956521739, 1.0630434782609, 0.16666666666667
53399, 0.26086956521739, 1.0891304347826, 0.19444444444444
53400, 0.28260869565217, 1.0891304347826, 0.22222222222222
53401, 0.26086956521739, 1.0630434782609, 0.22222222222222
53402, 0.26086956521739, 1.0891304347826, 0.25
53403, 0.28260869565217, 1.0891304347826, 0.27777777777778
53404, 0.26086956521739, 1.0630434782609, 0.27777777777778
53405, 0.26086956521739, 1.0891304347826, 0.30555555555556
53406, 0.28260869565217, 1.0891304347826, 0.33333333333333
53407, 0.26086956521739, 1.0630434782609, 0.33333333333333
53408, 0.26086956521739, 1.0891304347826, 0.36111111111111
53409, 0.28260869565217, 1.0891304347826, 0.38888888888889
53410, 0.26086956521739, 1.0630434782609, 0.38888888888889
53411, 0.26086956521739, 1.0891304347826, 0.41666666666667
53412, 0.28260869565217, 1.0891304347826, 0.44444444444444
53413, 0.26086956521739, 1.0630434782609, 0.44444444444444
53414, 0.26086956521739, 1.0891304347826, 0.47222222222222
53415, 0.21739130434783, 1.0891304347826, 0.027777777777778
53416, 0.23913043478261, 1.0891304347826, 0.055555555555556
53417, 0.21739130434783, 1.0630434782609, 0.055555555555556
53418, 0.21739130434783, 1.0891304347826, 0.083333333333333
53419, 0.23913043478261, 1.0891304347826, 0.11111111111111
53420, 0.21739130434783, 1.0630434782609, 0.11111111111111
53421, 0.21739130434783, 1.0891304347826, 0.13888888888889
53422, 0.23913043478261, 1.0891304347826, 0.16666666666667
53423, 0.21739130434783, 1.0630434782609, 0.16666666666667
53424, 0.21739130434783, 1.0891304347826, 0.19444444444444
53425, 0.23913043478261, 1.0891304347826, 0.22222222222222
53426, 0.21739130434783, 1.0630434782609, 0.22222222222222
53427, 0.21739130434783, 1.0891304347826, 0.25
53428, 0.23913043478261, 1.0891304347826, 0.27777777777778
53429, 0.21739130434783, 1.0630434782609, 0.27777777777778
53430, 0.21739130434783, 1.0891304347826, 0.30555555555556
53431, 0.23913043478261, 1.0891304347826, 0.33333333333333
53432, 0.21739130434783, 1.0630434782609, 0.33333333333333
53433, 0.21739130434783, 1.0891304347826, 0.36111111111111
53434, 0.23913043478261, 1.0891304347826, 0.38888888888889
53435, 0.21739130434783, 1.0630434782609, 0.38888888888889
53436, 0.21739130434783, 1.0891304347826, 0.41666666666667
53437, 0.23913043478261, 1.0891304347826, 0.44444444444444
53438, 0.21739130434783, 1.0630434782609, 0.44444444444444
53439, 0.21739130434783, 1.0891304347826, 0.47222222222222
53440, 0.17391304347826, 1.0891304347826, 0.027777777777778
53441, 0.19565217391304, 1.0891304347826, 0.055555555555556
53442, 0.17391304347826, 1.0630434782609, 0.055555555555556
53443, 0.17391304347826, 1.0891304347826, 0.083333333333333
53444, 0.19565217391304, 1.0891304347826, 0.11111111111111
53445, 0.17391304347826, 1.0630434782609, 0.11111111111111
53446, 0.17391304347826, 1.0891304347826, 0.13888888888889
53447, 0.19565217391304, 1.0891304347826, 0.16666666666667
53448, 0.17391304347826, 1.0630434782609, 0.16666666666667
53449, 0.17391304347826, 1.0891304347826, 0.19444444444444
53450, 0.19565217391304, 1.0891304347826, 0.22222222222222
53451, 0.17391304347826, 1.0630434782609, 0.22222222222222
53452, 0.17391304347826, 1.0891304347826, 0.25
53453, 0.19565217391304, 1.0891304347826, 0.27777777777778
53454, 0.17391304347826, 1.0630434782609, 0.27777777777778
53455, 0.17391304347826, 1.0891304347826, 0.30555555555556
53456, 0.19565217391304, 1.0891304347826, 0.33333333333333
53457, 0.17391304347826, 1.0630434782609, 0.33333333333333
53458, 0.17391304347826, 1.0891304347826, 0.36111111111111
53459, 0.19565217391304, 1.0891304347826, 0.38888888888889
53460, 0.17391304347826, 1.0630434782609, 0.38888888888889
53461, 0.17391304347826, 1.0891304347826, 0.41666666666667
53462, 0.19565217391304, 1.0891304347826, 0.44444444444444
53463, 0.17391304347826, 1.0630434782609, 0.44444444444444
53464, 0.17391304347826, 1.0891304347826, 0.47222222222222
53465, 0.1304347826087, 1.0891304347826, 0.027777777777778
53466, 0.15217391304348, 1.0891304347826, 0.055555555555556
53467, 0.1304347826087, 1.0630434782609, 0.055555555555556
53468, 0.1304347826087, 1.0891304347826, 0.083333333333333
53469, 0.15217391304348, 1.0891304347826, 0.11111111111111
53470, 0.1304347826087, 1.0630434782609, 0.11111111111111
53471, 0.1304347826087, 1.0891304347826, 0.13888888888889
53472, 0.15217391304348, 1.0891304347826, 0.16666666666667
53473, 0.1304347826087, 1.0630434782609, 0.16666666666667
53474, 0.1304347826087, 1.0891304347826, 0.19444444444444
53475, 0.15217391304348, 1.0891304347826, 0.22222222222222
53476, 0.1304347826087, 1.0630434782609, 0.22222222222222
53477, 0.1304347826087, 1.0891304347826, 0.25
53478, 0.15217391304348, 1.0891304347826, 0.27777777777778
53479, 0.1304347826087, 1.0630434782609, 0.27777777777778
53480, 0.1304347826087, 1.0891304347826, 0.30555555555556
53481, 0.15217391304348, 1.0891304347826, 0.33333333333333
53482, 0.1304347826087, 1.0630434782609, 0.33333333333333
53483, 0.1304347826087, 1.0891304347826, 0.36111111111111
53484, 0.15217391304348, 1.0891304347826, 0.38888888888889
53485, 0.1304347826087, 1.0630434782609, 0.38888888888889
53486, 0.1304347826087, 1.0891304347826, 0.41666666666667
53487, 0.15217391304348, 1.0891304347826, 0.44444444444444
53488, 0.1304347826087, 1.0630434782609, 0.44444444444444
53489, 0.1304347826087, 1.0891304347826, 0.47222222222222
53490, 0.08695652173913, 1.0891304347826, 0.027777777777778
53491, 0.10869565217391, 1.0891304347826, 0.055555555555556
53492, 0.08695652173913, 1.0630434782609, 0.055555555555556
53493, 0.08695652173913, 1.0891304347826, 0.083333333333333
53494, 0.10869565217391, 1.0891304347826, 0.11111111111111
53495, 0.08695652173913, 1.0630434782609, 0.11111111111111
53496, 0.08695652173913, 1.0891304347826, 0.13888888888889
53497, 0.10869565217391, 1.0891304347826, 0.16666666666667
53498, 0.08695652173913, 1.0630434782609, 0.16666666666667
53499, 0.08695652173913, 1.0891304347826, 0.19444444444444
53500, 0.10869565217391, 1.0891304347826, 0.22222222222222
53501, 0.08695652173913, 1.0630434782609, 0.22222222222222
53502, 0.08695652173913, 1.0891304347826, 0.25
53503, 0.10869565217391, 1.0891304347826, 0.27777777777778
53504, 0.08695652173913, 1.0630434782609, 0.27777777777778
53505, 0.08695652173913, 1.0891304347826, 0.30555555555556
53506, 0.10869565217391, 1.0891304347826, 0.33333333333333
53507, 0.08695652173913, 1.0630434782609, 0.33333333333333
53508, 0.08695652173913, 1.0891304347826, 0.36111111111111
53509, 0.10869565217391, 1.0891304347826, 0.38888888888889
53510, 0.08695652173913, 1.0630434782609, 0.38888888888889
53511, 0.08695652173913, 1.0891304347826, 0.41666666666667
53512, 0.10869565217391, 1.0891304347826, 0.44444444444444
53513, 0.08695652173913, 1.0630434782609, 0.44444444444444
53514, 0.08695652173913, 1.0891304347826, 0.47222222222222
53515, 0.043478260869565, 1.0891304347826, 0.027777777777778
53516, 0.065217391304348, 1.0891304347826, 0.055555555555556
53517, 0.043478260869565, 1.0630434782609, 0.055555555555556
53518, 0.043478260869565, 1.0891304347826, 0.083333333333333
53519, 0.065217391304348, 1.0891304347826, 0.11111111111111
53520, 0.043478260869565, 1.0630434782609, 0.11111111111111
53521, 0.043478260869565, 1.0891304347826, 0.13888888888889
53522, 0.065217391304348, 1.0891304347826, 0.16666666666667
53523, 0.043478260869565, 1.0630434782609, 0.16666666666667
53524, 0.043478260869565, 1.0891304347826, 0.19444444444444
53525, 0.065217391304348, 1.0891304347826, 0.22222222222222
53526, 0.043478260869565, 1.0630434782609, 0.22222222222222
53527, 0.043478260869565, 1.0891304347826, 0.25
53528, 0.065217391304348, 1.0891304347826, 0.27777777777778
53529, 0.043478260869565, 1.0630434782609, 0.27777777777778
53530, 0.043478260869565, 1.0891304347826, 0.30555555555556
53531, 0.065217391304348, 1.0891304347826, 0.33333333333333
53532, 0.043478260869565, 1.0630434782609, 0.33333333333333
53533, 0.043478260869565, 1.0891304347826, 0.36111111111111
53534, 0.065217391304348, 1.0891304347826, 0.38888888888889
53535, 0.043478260869565, 1.0630434782609, 0.38888888888889
53536, 0.043478260869565, 1.0891304347826, 0.41666666666667
53537, 0.065217391304348, 1.0891304347826, 0.44444444444444
53538, 0.043478260869565, 1.0630434782609, 0.44444444444444
53539, 0.043478260869565, 1.0891304347826, 0.47222222222222
53540, 0.021739130434783, 1.0891304347826, 0.055555555555556
53541, 0.021739130434783, 1.0891304347826, 0.11111111111111
53542, 0.021739130434783, 1.0891304347826, 0.16666666666667
53543, 0.021739130434783, 1.0891304347826, 0.22222222222222
53544, 0.021739130434783, 1.0891304347826, 0.27777777777778
53545, 0.021739130434783, 1.0891304347826, 0.33333333333333
53546, 0.021739130434783, 1.0891304347826, 0.38888888888889
53547, 0.021739130434783, 1.0891304347826, 0.44444444444444
53548, 0.95652173913043, 1.1413043478261, 0.027777777777778
53549, 0.97826086956522, 1.1413043478261, 0.055555555555556
53550, 0.95652173913043, 1.1152173913043, 0.055555555555556
53551, 0.95652173913043, 1.1413043478261, 0.083333333333333
53552, 0.97826086956522, 1.1413043478261, 0.11111111111111
53553, 0.95652173913043, 1.1152173913043, 0.11111111111111
53554, 0.95652173913043, 1.1413043478261, 0.13888888888889
53555, 0.97826086956522, 1.1413043478261, 0.16666666666667
53556, 0.95652173913043, 1.1152173913043, 0.16666666666667
53557, 0.95652173913043, 1.1413043478261, 0.19444444444444
53558, 0.97826086956522, 1.1413043478261, 0.22222222222222
53559, 0.95652173913044, 1.1152173913043, 0.22222222222222
53560, 0.95652173913044, 1.1413043478261, 0.25
53561, 0.97826086956522, 1.1413043478261, 0.27777777777778
53562, 0.95652173913044, 1.1152173913043, 0.27777777777778
53563, 0.95652173913043, 1.1413043478261, 0.30555555555556
53564, 0.97826086956522, 1.1413043478261, 0.33333333333333
53565, 0.95652173913043, 1.1152173913043, 0.33333333333333
53566, 0.95652173913043, 1.1413043478261, 0.36111111111111
53567, 0.97826086956522, 1.1413043478261, 0.38888888888889
53568, 0.95652173913043, 1.1152173913043, 0.38888888888889
53569, 0.95652173913044, 1.1413043478261, 0.41666666666667
53570, 0.97826086956522, 1.1413043478261, 0.44444444444444
53571, 0.95652173913044, 1.1152173913043, 0.44444444444444
53572, 0.95652173913043, 1.1413043478261, 0.47222222222222
53573, 0.91304347826087, 1.1413043478261, 0.027777777777778
53574, 0.93478260869565, 1.1413043478261, 0.055555555555556
53575, 0.91304347826087, 1.1152173913043, 0.055555555555556
53576, 0.91304347826087, 1.1413043478261, 0.083333333333333
53577, 0.93478260869565, 1.1413043478261, 0.11111111111111
53578, 0.91304347826087, 1.1152173913043, 0.11111111111111
53579, 0.91304347826087, 1.1413043478261, 0.13888888888889
53580, 0.93478260869565, 1.1413043478261, 0.16666666666667
53581, 0.91304347826087, 1.1152173913043, 0.16666666666667
53582, 0.91304347826087, 1.1413043478261, 0.19444444444444
53583, 0.93478260869565, 1.1413043478261, 0.22222222222222
53584, 0.91304347826087, 1.1152173913043, 0.22222222222222
53585, 0.91304347826087, 1.1413043478261, 0.25
53586, 0.93478260869565, 1.1413043478261, 0.27777777777778
53587, 0.91304347826087, 1.1152173913043, 0.27777777777778
53588, 0.91304347826087, 1.1413043478261, 0.30555555555556
53589, 0.93478260869565, 1.1413043478261, 0.33333333333333
53590, 0.91304347826087, 1.1152173913043, 0.33333333333333
53591, 0.91304347826087, 1.1413043478261, 0.36111111111111
53592, 0.93478260869565, 1.1413043478261, 0.38888888888889
53593, 0.91304347826087, 1.1152173913043, 0.38888888888889
53594, 0.91304347826087, 1.1413043478261, 0.41666666666667
53595, 0.93478260869565, 1.1413043478261, 0.44444444444444
53596, 0.91304347826087, 1.1152173913043, 0.44444444444444
53597, 0.91304347826087, 1.1413043478261, 0.47222222222222
53598, 0.8695652173913, 1.1413043478261, 0.027777777777778
53599, 0.89130434782609, 1.1413043478261, 0.055555555555556
53600, 0.8695652173913, 1.1152173913043, 0.055555555555556
53601, 0.8695652173913, 1.1413043478261, 0.083333333333333
53602, 0.89130434782609, 1.1413043478261, 0.11111111111111
53603, 0.8695652173913, 1.1152173913043, 0.11111111111111
53604, 0.8695652173913, 1.1413043478261, 0.13888888888889
53605, 0.89130434782609, 1.1413043478261, 0.16666666666667
53606, 0.8695652173913, 1.1152173913043, 0.16666666666667
53607, 0.8695652173913, 1.1413043478261, 0.19444444444444
53608, 0.89130434782609, 1.1413043478261, 0.22222222222222
53609, 0.8695652173913, 1.1152173913043, 0.22222222222222
53610, 0.8695652173913, 1.1413043478261, 0.25
53611, 0.89130434782609, 1.1413043478261, 0.27777777777778
53612, 0.8695652173913, 1.1152173913043, 0.27777777777778
53613, 0.8695652173913, 1.1413043478261, 0.30555555555556
53614, 0.89130434782609, 1.1413043478261, 0.33333333333333
53615, 0.8695652173913, 1.1152173913043, 0.33333333333333
53616, 0.8695652173913, 1.1413043478261, 0.36111111111111
53617, 0.89130434782609, 1.1413043478261, 0.38888888888889
53618, 0.8695652173913, 1.1152173913043, 0.38888888888889
53619, 0.8695652173913, 1.1413043478261, 0.41666666666667
53620, 0.89130434782609, 1.1413043478261, 0.44444444444444
53621, 0.8695652173913, 1.1152173913043, 0.44444444444444
53622, 0.8695652173913, 1.1413043478261, 0.47222222222222
53623, 0.82608695652174, 1.1413043478261, 0.027777777777778
53624, 0.84782608695652, 1.1413043478261, 0.055555555555556
53625, 0.82608695652174, 1.1152173913043, 0.055555555555556
53626, 0.82608695652174, 1.1413043478261, 0.083333333333333
53627, 0.84782608695652, 1.1413043478261, 0.11111111111111
53628, 0.82608695652174, 1.1152173913043, 0.11111111111111
53629, 0.82608695652174, 1.1413043478261, 0.13888888888889
53630, 0.84782608695652, 1.1413043478261, 0.16666666666667
53631, 0.82608695652174, 1.1152173913043, 0.16666666666667
53632, 0.82608695652174, 1.1413043478261, 0.19444444444444
53633, 0.84782608695652, 1.1413043478261, 0.22222222222222
53634, 0.82608695652174, 1.1152173913043, 0.22222222222222
53635, 0.82608695652174, 1.1413043478261, 0.25
53636, 0.84782608695652, 1.1413043478261, 0.27777777777778
53637, 0.82608695652174, 1.1152173913043, 0.27777777777778
53638, 0.82608695652174, 1.1413043478261, 0.30555555555556
53639, 0.84782608695652, 1.1413043478261, 0.33333333333333
53640, 0.82608695652174, 1.1152173913043, 0.33333333333333
53641, 0.82608695652174, 1.1413043478261, 0.36111111111111
53642, 0.84782608695652, 1.1413043478261, 0.38888888888889
53643, 0.82608695652174, 1.1152173913043, 0.38888888888889
53644, 0.82608695652174, 1.1413043478261, 0.41666666666667
53645, 0.84782608695652, 1.1413043478261, 0.44444444444444
53646, 0.82608695652174, 1.1152173913043, 0.44444444444444
53647, 0.82608695652174, 1.1413043478261, 0.47222222222222
53648, 0.78260869565217, 1.1413043478261, 0.027777777777778
53649, 0.80434782608696, 1.1413043478261, 0.055555555555556
53650, 0.78260869565217, 1.1152173913043, 0.055555555555556
53651, 0.78260869565217, 1.1413043478261, 0.083333333333333
53652, 0.80434782608696, 1.1413043478261, 0.11111111111111
53653, 0.78260869565217, 1.1152173913043, 0.11111111111111
53654, 0.78260869565217, 1.1413043478261, 0.13888888888889
53655, 0.80434782608696, 1.1413043478261, 0.16666666666667
53656, 0.78260869565217, 1.1152173913043, 0.16666666666667
53657, 0.78260869565217, 1.1413043478261, 0.19444444444444
53658, 0.80434782608696, 1.1413043478261, 0.22222222222222
53659, 0.78260869565217, 1.1152173913043, 0.22222222222222
53660, 0.78260869565217, 1.1413043478261, 0.25
53661, 0.80434782608696, 1.1413043478261, 0.27777777777778
53662, 0.78260869565217, 1.1152173913043, 0.27777777777778
53663, 0.78260869565217, 1.1413043478261, 0.30555555555556
53664, 0.80434782608696, 1.1413043478261, 0.33333333333333
53665, 0.78260869565217, 1.1152173913043, 0.33333333333333
53666, 0.78260869565217, 1.1413043478261, 0.36111111111111
53667, 0.80434782608696, 1.1413043478261, 0.38888888888889
53668, 0.78260869565217, 1.1152173913043, 0.38888888888889
53669, 0.78260869565217, 1.1413043478261, 0.41666666666667
53670, 0.80434782608696, 1.1413043478261, 0.44444444444444
53671, 0.78260869565217, 1.1152173913043, 0.44444444444444
53672, 0.78260869565217, 1.1413043478261, 0.47222222222222
53673, 0.73913043478261, 1.1413043478261, 0.027777777777778
53674, 0.76086956521739, 1.1413043478261, 0.055555555555556
53675, 0.73913043478261, 1.1152173913043, 0.055555555555556
53676, 0.73913043478261, 1.1413043478261, 0.083333333333333
53677, 0.76086956521739, 1.1413043478261, 0.11111111111111
53678, 0.73913043478261, 1.1152173913043, 0.11111111111111
53679, 0.73913043478261, 1.1413043478261, 0.13888888888889
53680, 0.76086956521739, 1.1413043478261, 0.16666666666667
53681, 0.73913043478261, 1.1152173913043, 0.16666666666667
53682, 0.73913043478261, 1.1413043478261, 0.19444444444444
53683, 0.76086956521739, 1.1413043478261, 0.22222222222222
53684, 0.73913043478261, 1.1152173913043, 0.22222222222222
53685, 0.73913043478261, 1.1413043478261, 0.25
53686, 0.76086956521739, 1.1413043478261, 0.27777777777778
53687, 0.73913043478261, 1.1152173913043, 0.27777777777778
53688, 0.73913043478261, 1.1413043478261, 0.30555555555556
53689, 0.76086956521739, 1.1413043478261, 0.33333333333333
53690, 0.73913043478261, 1.1152173913043, 0.33333333333333
53691, 0.73913043478261, 1.1413043478261, 0.36111111111111
53692, 0.76086956521739, 1.1413043478261, 0.38888888888889
53693, 0.73913043478261, 1.1152173913043, 0.38888888888889
53694, 0.73913043478261, 1.1413043478261, 0.41666666666667
53695, 0.76086956521739, 1.1413043478261, 0.44444444444444
53696, 0.73913043478261, 1.1152173913043, 0.44444444444444
53697, 0.73913043478261, 1.1413043478261, 0.47222222222222
53698, 0.69565217391304, 1.1413043478261, 0.027777777777778
53699, 0.71739130434783, 1.1413043478261, 0.055555555555556
53700, 0.69565217391304, 1.1152173913043, 0.055555555555556
53701, 0.69565217391304, 1.1413043478261, 0.083333333333333
53702, 0.71739130434783, 1.1413043478261, 0.11111111111111
53703, 0.69565217391304, 1.1152173913043, 0.11111111111111
53704, 0.69565217391304, 1.1413043478261, 0.13888888888889
53705, 0.71739130434783, 1.1413043478261, 0.16666666666667
53706, 0.69565217391304, 1.1152173913043, 0.16666666666667
53707, 0.69565217391304, 1.1413043478261, 0.19444444444444
53708, 0.71739130434783, 1.1413043478261, 0.22222222222222
53709, 0.69565217391304, 1.1152173913043, 0.22222222222222
53710, 0.69565217391304, 1.1413043478261, 0.25
53711, 0.71739130434783, 1.1413043478261, 0.27777777777778
53712, 0.69565217391304, 1.1152173913043, 0.27777777777778
53713, 0.69565217391304, 1.1413043478261, 0.30555555555556
53714, 0.71739130434783, 1.1413043478261, 0.33333333333333
53715, 0.69565217391304, 1.1152173913043, 0.33333333333333
53716, 0.69565217391304, 1.1413043478261, 0.36111111111111
53717, 0.71739130434783, 1.1413043478261, 0.38888888888889
53718, 0.69565217391304, 1.1152173913043, 0.38888888888889
53719, 0.69565217391304, 1.1413043478261, 0.41666666666667
53720, 0.71739130434783, 1.1413043478261, 0.44444444444444
53721, 0.69565217391304, 1.1152173913043, 0.44444444444444
53722, 0.69565217391304, 1.1413043478261, 0.47222222222222
53723, 0.65217391304348, 1.1413043478261, 0.027777777777778
53724, 0.67391304347826, 1.1413043478261, 0.055555555555556
53725, 0.65217391304348, 1.1152173913043, 0.055555555555556
53726, 0.65217391304348, 1.1413043478261, 0.083333333333333
53727, 0.67391304347826, 1.1413043478261, 0.11111111111111
53728, 0.65217391304348, 1.1152173913043, 0.11111111111111
53729, 0.65217391304348, 1.1413043478261, 0.13888888888889
53730, 0.67391304347826, 1.1413043478261, 0.16666666666667
53731, 0.65217391304348, 1.1152173913043, 0.16666666666667
53732, 0.65217391304348, 1.1413043478261, 0.19444444444444
53733, 0.67391304347826, 1.1413043478261, 0.22222222222222
53734, 0.65217391304348, 1.1152173913043, 0.22222222222222
53735, 0.65217391304348, 1.1413043478261, 0.25
53736, 0.67391304347826, 1.1413043478261, 0.27777777777778
53737, 0.65217391304348, 1.1152173913043, 0.27777777777778
53738, 0.65217391304348, 1.1413043478261, 0.30555555555556
53739, 0.67391304347826, 1.1413043478261, 0.33333333333333
53740, 0.65217391304348, 1.1152173913043, 0.33333333333333
53741, 0.65217391304348, 1.1413043478261, 0.36111111111111
53742, 0.67391304347826, 1.1413043478261, 0.38888888888889
53743, 0.65217391304348, 1.1152173913043, 0.38888888888889
53744, 0.65217391304348, 1.1413043478261, 0.41666666666667
53745, 0.67391304347826, 1.1413043478261, 0.44444444444444
53746, 0.65217391304348, 1.1152173913043, 0.44444444444444
53747, 0.65217391304348, 1.1413043478261, 0.47222222222222
53748, 0.60869565217391, 1.1413043478261, 0.027777777777778
53749, 0.6304347826087, 1.1413043478261, 0.055555555555556
53750, 0.60869565217391, 1.1152173913043, 0.055555555555556
53751, 0.60869565217391, 1.1413043478261, 0.083333333333333
53752, 0.6304347826087, 1.1413043478261, 0.11111111111111
53753, 0.60869565217391, 1.1152173913043, 0.11111111111111
53754, 0.60869565217391, 1.1413043478261, 0.13888888888889
53755, 0.6304347826087, 1.1413043478261, 0.16666666666667
53756, 0.60869565217391, 1.1152173913043, 0.16666666666667
53757, 0.60869565217391, 1.1413043478261, 0.19444444444444
53758, 0.6304347826087, 1.1413043478261, 0.22222222222222
53759, 0.60869565217391, 1.1152173913043, 0.22222222222222
53760, 0.60869565217391, 1.1413043478261, 0.25
53761, 0.6304347826087, 1.1413043478261, 0.27777777777778
53762, 0.60869565217391, 1.1152173913043, 0.27777777777778
53763, 0.60869565217391, 1.1413043478261, 0.30555555555556
53764, 0.6304347826087, 1.1413043478261, 0.33333333333333
53765, 0.60869565217391, 1.1152173913043, 0.33333333333333
53766, 0.60869565217391, 1.1413043478261, 0.36111111111111
53767, 0.6304347826087, 1.1413043478261, 0.38888888888889
53768, 0.60869565217391, 1.1152173913043, 0.38888888888889
53769, 0.60869565217391, 1.1413043478261, 0.41666666666667
53770, 0.6304347826087, 1.1413043478261, 0.44444444444444
53771, 0.60869565217391, 1.1152173913043, 0.44444444444444
53772, 0.60869565217391, 1.1413043478261, 0.47222222222222
53773, 0.56521739130435, 1.1413043478261, 0.027777777777778
53774, 0.58695652173913, 1.1413043478261, 0.055555555555556
53775, 0.56521739130435, 1.1152173913043, 0.055555555555556
53776, 0.56521739130435, 1.1413043478261, 0.083333333333333
53777, 0.58695652173913, 1.1413043478261, 0.11111111111111
53778, 0.56521739130435, 1.1152173913043, 0.11111111111111
53779, 0.56521739130435, 1.1413043478261, 0.13888888888889
53780, 0.58695652173913, 1.1413043478261, 0.16666666666667
53781, 0.56521739130435, 1.1152173913043, 0.16666666666667
53782, 0.56521739130435, 1.1413043478261, 0.19444444444444
53783, 0.58695652173913, 1.1413043478261, 0.22222222222222
53784, 0.56521739130435, 1.1152173913043, 0.22222222222222
53785, 0.56521739130435, 1.1413043478261, 0.25
53786, 0.58695652173913, 1.1413043478261, 0.27777777777778
53787, 0.56521739130435, 1.1152173913043, 0.27777777777778
53788, 0.56521739130435, 1.1413043478261, 0.30555555555556
53789, 0.58695652173913, 1.1413043478261, 0.33333333333333
53790, 0.56521739130435, 1.1152173913043, 0.33333333333333
53791, 0.56521739130435, 1.1413043478261, 0.36111111111111
53792, 0.58695652173913, 1.1413043478261, 0.38888888888889
53793, 0.56521739130435, 1.1152173913043, 0.38888888888889
53794, 0.56521739130435, 1.1413043478261, 0.41666666666667
53795, 0.58695652173913, 1.1413043478261, 0.44444444444444
53796, 0.56521739130435, 1.1152173913043, 0.44444444444444
53797, 0.56521739130435, 1.1413043478261, 0.47222222222222
53798, 0.52173913043478, 1.1413043478261, 0.027777777777778
53799, 0.54347826086957, 1.1413043478261, 0.055555555555556
53800, 0.52173913043478, 1.1152173913043, 0.055555555555556
53801, 0.52173913043478, 1.1413043478261, 0.083333333333333
53802, 0.54347826086957, 1.1413043478261, 0.11111111111111
53803, 0.52173913043478, 1.1152173913043, 0.11111111111111
53804, 0.52173913043478, 1.1413043478261, 0.13888888888889
53805, 0.54347826086957, 1.1413043478261, 0.16666666666667
53806, 0.52173913043478, 1.1152173913043, 0.16666666666667
53807, 0.52173913043478, 1.1413043478261, 0.19444444444444
53808, 0.54347826086956, 1.1413043478261, 0.22222222222222
53809, 0.52173913043478, 1.1152173913043, 0.22222222222222
53810, 0.52173913043478, 1.1413043478261, 0.25
53811, 0.54347826086956, 1.1413043478261, 0.27777777777778
53812, 0.52173913043478, 1.1152173913043, 0.27777777777778
53813, 0.52173913043478, 1.1413043478261, 0.30555555555556
53814, 0.54347826086956, 1.1413043478261, 0.33333333333333
53815, 0.52173913043478, 1.1152173913043, 0.33333333333333
53816, 0.52173913043478, 1.1413043478261, 0.36111111111111
53817, 0.54347826086956, 1.1413043478261, 0.38888888888889
53818, 0.52173913043478, 1.1152173913043, 0.38888888888889
53819, 0.52173913043478, 1.1413043478261, 0.41666666666667
53820, 0.54347826086956, 1.1413043478261, 0.44444444444444
53821, 0.52173913043478, 1.1152173913043, 0.44444444444444
53822, 0.52173913043478, 1.1413043478261, 0.47222222222222
53823, 0.47826086956522, 1.1413043478261, 0.027777777777778
53824, 0.5, 1.1413043478261, 0.055555555555556
53825, 0.47826086956522, 1.1152173913043, 0.055555555555556
53826, 0.47826086956522, 1.1413043478261, 0.083333333333333
53827, 0.5, 1.1413043478261, 0.11111111111111
53828, 0.47826086956522, 1.1152173913043, 0.11111111111111
53829, 0.47826086956522, 1.1413043478261, 0.13888888888889
53830, 0.5, 1.1413043478261, 0.16666666666667
53831, 0.47826086956522, 1.1152173913043, 0.16666666666667
53832, 0.47826086956522, 1.1413043478261, 0.19444444444444
53833, 0.5, 1.1413043478261, 0.22222222222222
53834, 0.47826086956522, 1.1152173913043, 0.22222222222222
53835, 0.47826086956522, 1.1413043478261, 0.25
53836, 0.5, 1.1413043478261, 0.27777777777778
53837, 0.47826086956522, 1.1152173913043, 0.27777777777778
53838, 0.47826086956522, 1.1413043478261, 0.30555555555556
53839, 0.5, 1.1413043478261, 0.33333333333333
53840, 0.47826086956522, 1.1152173913043, 0.33333333333333
53841, 0.47826086956522, 1.1413043478261, 0.36111111111111
53842, 0.5, 1.1413043478261, 0.38888888888889
53843, 0.47826086956522, 1.1152173913043, 0.38888888888889
53844, 0.47826086956522, 1.1413043478261, 0.41666666666667
53845, 0.5, 1.1413043478261, 0.44444444444444
53846, 0.47826086956522, 1.1152173913043, 0.44444444444444
53847, 0.47826086956522, 1.1413043478261, 0.47222222222222
53848, 0.43478260869565, 1.1413043478261, 0.027777777777778
53849, 0.45652173913043, 1.1413043478261, 0.055555555555556
53850, 0.43478260869565, 1.1152173913043, 0.055555555555556
53851, 0.43478260869565, 1.1413043478261, 0.083333333333333
53852, 0.45652173913043, 1.1413043478261, 0.11111111111111
53853, 0.43478260869565, 1.1152173913043, 0.11111111111111
53854, 0.43478260869565, 1.1413043478261, 0.13888888888889
53855, 0.45652173913043, 1.1413043478261, 0.16666666666667
53856, 0.43478260869565, 1.1152173913043, 0.16666666666667
53857, 0.43478260869565, 1.1413043478261, 0.19444444444444
53858, 0.45652173913043, 1.1413043478261, 0.22222222222222
53859, 0.43478260869565, 1.1152173913043, 0.22222222222222
53860, 0.43478260869565, 1.1413043478261, 0.25
53861, 0.45652173913043, 1.1413043478261, 0.27777777777778
53862, 0.43478260869565, 1.1152173913043, 0.27777777777778
53863, 0.43478260869565, 1.1413043478261, 0.30555555555556
53864, 0.45652173913043, 1.1413043478261, 0.33333333333333
53865, 0.43478260869565, 1.1152173913043, 0.33333333333333
53866, 0.43478260869565, 1.1413043478261, 0.36111111111111
53867, 0.45652173913043, 1.1413043478261, 0.38888888888889
53868, 0.43478260869565, 1.1152173913043, 0.38888888888889
53869, 0.43478260869565, 1.1413043478261, 0.41666666666667
53870, 0.45652173913043, 1.1413043478261, 0.44444444444444
53871, 0.43478260869565, 1.1152173913043, 0.44444444444444
53872, 0.43478260869565, 1.1413043478261, 0.47222222222222
53873, 0.39130434782609, 1.1413043478261, 0.027777777777778
53874, 0.41304347826087, 1.1413043478261, 0.055555555555556
53875, 0.39130434782609, 1.1152173913043, 0.055555555555556
53876, 0.39130434782609, 1.1413043478261, 0.083333333333333
53877, 0.41304347826087, 1.1413043478261, 0.11111111111111
53878, 0.39130434782609, 1.1152173913043, 0.11111111111111
53879, 0.39130434782609, 1.1413043478261, 0.13888888888889
53880, 0.41304347826087, 1.1413043478261, 0.16666666666667
53881, 0.39130434782609, 1.1152173913043, 0.16666666666667
53882, 0.39130434782609, 1.1413043478261, 0.19444444444444
53883, 0.41304347826087, 1.1413043478261, 0.22222222222222
53884, 0.39130434782609, 1.1152173913043, 0.22222222222222
53885, 0.39130434782609, 1.1413043478261, 0.25
53886, 0.41304347826087, 1.1413043478261, 0.27777777777778
53887, 0.39130434782609, 1.1152173913043, 0.27777777777778
53888, 0.39130434782609, 1.1413043478261, 0.30555555555556
53889, 0.41304347826087, 1.1413043478261, 0.33333333333333
53890, 0.39130434782609, 1.1152173913043, 0.33333333333333
53891, 0.39130434782609, 1.1413043478261, 0.36111111111111
53892, 0.41304347826087, 1.1413043478261, 0.38888888888889
53893, 0.39130434782609, 1.1152173913043, 0.38888888888889
53894, 0.39130434782609, 1.1413043478261, 0.41666666666667
53895, 0.41304347826087, 1.1413043478261, 0.44444444444444
53896, 0.39130434782609, 1.1152173913043, 0.44444444444444
53897, 0.39130434782609, 1.1413043478261, 0.47222222222222
53898, 0.34782608695652, 1.1413043478261, 0.027777777777778
53899, 0.3695652173913, 1.1413043478261, 0.055555555555556
53900, 0.34782608695652, 1.1152173913043, 0.055555555555556
53901, 0.34782608695652, 1.1413043478261, 0.083333333333333
53902, 0.3695652173913, 1.1413043478261, 0.11111111111111
53903, 0.34782608695652, 1.1152173913043, 0.11111111111111
53904, 0.34782608695652, 1.1413043478261, 0.13888888888889
53905, 0.3695652173913, 1.1413043478261, 0.16666666666667
53906, 0.34782608695652, 1.1152173913043, 0.16666666666667
53907, 0.34782608695652, 1.1413043478261, 0.19444444444444
53908, 0.3695652173913, 1.1413043478261, 0.22222222222222
53909, 0.34782608695652, 1.1152173913043, 0.22222222222222
53910, 0.34782608695652, 1.1413043478261, 0.25
53911, 0.3695652173913, 1.1413043478261, 0.27777777777778
53912, 0.34782608695652, 1.1152173913043, 0.27777777777778
53913, 0.34782608695652, 1.1413043478261, 0.30555555555556
53914, 0.3695652173913, 1.1413043478261, 0.33333333333333
53915, 0.34782608695652, 1.1152173913043, 0.33333333333333
53916, 0.34782608695652, 1.1413043478261, 0.36111111111111
53917, 0.3695652173913, 1.1413043478261, 0.38888888888889
53918, 0.34782608695652, 1.1152173913043, 0.38888888888889
53919, 0.34782608695652, 1.1413043478261, 0.41666666666667
53920, 0.3695652173913, 1.1413043478261, 0.44444444444444
53921, 0.34782608695652, 1.1152173913043, 0.44444444444444
53922, 0.34782608695652, 1.1413043478261, 0.47222222222222
53923, 0.30434782608696, 1.1413043478261, 0.027777777777778
53924, 0.32608695652174, 1.1413043478261, 0.055555555555556
53925, 0.30434782608696, 1.1152173913043, 0.055555555555556
53926, 0.30434782608696, 1.1413043478261, 0.083333333333333
53927, 0.32608695652174, 1.1413043478261, 0.11111111111111
53928, 0.30434782608696, 1.1152173913043, 0.11111111111111
53929, 0.30434782608696, 1.1413043478261, 0.13888888888889
53930, 0.32608695652174, 1.1413043478261, 0.16666666666667
53931, 0.30434782608696, 1.1152173913043, 0.16666666666667
53932, 0.30434782608696, 1.1413043478261, 0.19444444444444
53933, 0.32608695652174, 1.1413043478261, 0.22222222222222
53934, 0.30434782608696, 1.1152173913043, 0.22222222222222
53935, 0.30434782608696, 1.1413043478261, 0.25
53936, 0.32608695652174, 1.1413043478261, 0.27777777777778
53937, 0.30434782608696, 1.1152173913043, 0.27777777777778
53938, 0.30434782608696, 1.1413043478261, 0.30555555555556
53939, 0.32608695652174, 1.1413043478261, 0.33333333333333
53940, 0.30434782608696, 1.1152173913043, 0.33333333333333
53941, 0.30434782608696, 1.1413043478261, 0.36111111111111
53942, 0.32608695652174, 1.1413043478261, 0.38888888888889
53943, 0.30434782608696, 1.1152173913043, 0.38888888888889
53944, 0.30434782608696, 1.1413043478261, 0.41666666666667
53945, 0.32608695652174, 1.1413043478261, 0.44444444444444
53946, 0.30434782608696, 1.1152173913043, 0.44444444444444
53947, 0.30434782608696, 1.1413043478261, 0.47222222222222
53948, 0.26086956521739, 1.1413043478261, 0.027777777777778
53949, 0.28260869565217, 1.1413043478261, 0.055555555555556
53950, 0.26086956521739, 1.1152173913043, 0.055555555555556
53951, 0.26086956521739, 1.1413043478261, 0.083333333333333
53952, 0.28260869565217, 1.1413043478261, 0.11111111111111
53953, 0.26086956521739, 1.1152173913043, 0.11111111111111
53954, 0.26086956521739, 1.1413043478261, 0.13888888888889
53955, 0.28260869565217, 1.1413043478261, 0.16666666666667
53956, 0.26086956521739, 1.1152173913043, 0.16666666666667
53957, 0.26086956521739, 1.1413043478261, 0.19444444444444
53958, 0.28260869565217, 1.1413043478261, 0.22222222222222
53959, 0.26086956521739, 1.1152173913043, 0.22222222222222
53960, 0.26086956521739, 1.1413043478261, 0.25
53961, 0.28260869565217, 1.1413043478261, 0.27777777777778
53962, 0.26086956521739, 1.1152173913043, 0.27777777777778
53963, 0.26086956521739, 1.1413043478261, 0.30555555555556
53964, 0.28260869565217, 1.1413043478261, 0.33333333333333
53965, 0.26086956521739, 1.1152173913043, 0.33333333333333
53966, 0.26086956521739, 1.1413043478261, 0.36111111111111
53967, 0.28260869565217, 1.1413043478261, 0.38888888888889
53968, 0.26086956521739, 1.1152173913043, 0.38888888888889
53969, 0.26086956521739, 1.1413043478261, 0.41666666666667
53970, 0.28260869565217, 1.1413043478261, 0.44444444444444
53971, 0.26086956521739, 1.1152173913043, 0.44444444444444
53972, 0.26086956521739, 1.1413043478261, 0.47222222222222
53973, 0.21739130434783, 1.1413043478261, 0.027777777777778
53974, 0.23913043478261, 1.1413043478261, 0.055555555555556
53975, 0.21739130434783, 1.1152173913043, 0.055555555555556
53976, 0.21739130434783, 1.1413043478261, 0.083333333333333
53977, 0.23913043478261, 1.1413043478261, 0.11111111111111
53978, 0.21739130434783, 1.1152173913043, 0.11111111111111
53979, 0.21739130434783, 1.1413043478261, 0.13888888888889
53980, 0.23913043478261, 1.1413043478261, 0.16666666666667
53981, 0.21739130434783, 1.1152173913043, 0.16666666666667
53982, 0.21739130434783, 1.1413043478261, 0.19444444444444
53983, 0.23913043478261, 1.1413043478261, 0.22222222222222
53984, 0.21739130434783, 1.1152173913043, 0.22222222222222
53985, 0.21739130434783, 1.1413043478261, 0.25
53986, 0.23913043478261, 1.1413043478261, 0.27777777777778
53987, 0.21739130434783, 1.1152173913043, 0.27777777777778
53988, 0.21739130434783, 1.1413043478261, 0.30555555555556
53989, 0.23913043478261, 1.1413043478261, 0.33333333333333
53990, 0.21739130434783, 1.1152173913043, 0.33333333333333
53991, 0.21739130434783, 1.1413043478261, 0.36111111111111
53992, 0.23913043478261, 1.1413043478261, 0.38888888888889
53993, 0.21739130434783, 1.1152173913043, 0.38888888888889
53994, 0.21739130434783, 1.1413043478261, 0.41666666666667
53995, 0.23913043478261, 1.1413043478261, 0.44444444444444
53996, 0.21739130434783, 1.1152173913043, 0.44444444444444
53997, 0.21739130434783, 1.1413043478261, 0.47222222222222
53998, 0.17391304347826, 1.1413043478261, 0.027777777777778
53999, 0.19565217391304, 1.1413043478261, 0.055555555555556
54000, 0.17391304347826, 1.1152173913043, 0.055555555555556
54001, 0.17391304347826, 1.1413043478261, 0.083333333333333
54002, 0.19565217391304, 1.1413043478261, 0.11111111111111
54003, 0.17391304347826, 1.1152173913043, 0.11111111111111
54004, 0.17391304347826, 1.1413043478261, 0.13888888888889
54005, 0.19565217391304, 1.1413043478261, 0.16666666666667
54006, 0.17391304347826, 1.1152173913043, 0.16666666666667
54007, 0.17391304347826, 1.1413043478261, 0.19444444444444
54008, 0.19565217391304, 1.1413043478261, 0.22222222222222
54009, 0.17391304347826, 1.1152173913043, 0.22222222222222
54010, 0.17391304347826, 1.1413043478261, 0.25
54011, 0.19565217391304, 1.1413043478261, 0.27777777777778
54012, 0.17391304347826, 1.1152173913043, 0.27777777777778
54013, 0.17391304347826, 1.1413043478261, 0.30555555555556
54014, 0.19565217391304, 1.1413043478261, 0.33333333333333
54015, 0.17391304347826, 1.1152173913043, 0.33333333333333
54016, 0.17391304347826, 1.1413043478261, 0.36111111111111
54017, 0.19565217391304, 1.1413043478261, 0.38888888888889
54018, 0.17391304347826, 1.1152173913043, 0.38888888888889
54019, 0.17391304347826, 1.1413043478261, 0.41666666666667
54020, 0.19565217391304, 1.1413043478261, 0.44444444444444
54021, 0.17391304347826, 1.1152173913043, 0.44444444444444
54022, 0.17391304347826, 1.1413043478261, 0.47222222222222
54023, 0.1304347826087, 1.1413043478261, 0.027777777777778
54024, 0.15217391304348, 1.1413043478261, 0.055555555555556
54025, 0.1304347826087, 1.1152173913043, 0.055555555555556
54026, 0.1304347826087, 1.1413043478261, 0.083333333333333
54027, 0.15217391304348, 1.1413043478261, 0.11111111111111
54028, 0.1304347826087, 1.1152173913043, 0.11111111111111
54029, 0.1304347826087, 1.1413043478261, 0.13888888888889
54030, 0.15217391304348, 1.1413043478261, 0.16666666666667
54031, 0.1304347826087, 1.1152173913043, 0.16666666666667
54032, 0.1304347826087, 1.1413043478261, 0.19444444444444
54033, 0.15217391304348, 1.1413043478261, 0.22222222222222
54034, 0.1304347826087, 1.1152173913043, 0.22222222222222
54035, 0.1304347826087, 1.1413043478261, 0.25
54036, 0.15217391304348, 1.1413043478261, 0.27777777777778
54037, 0.1304347826087, 1.1152173913043, 0.27777777777778
54038, 0.1304347826087, 1.1413043478261, 0.30555555555556
54039, 0.15217391304348, 1.1413043478261, 0.33333333333333
54040, 0.1304347826087, 1.1152173913043, 0.33333333333333
54041, 0.1304347826087, 1.1413043478261, 0.36111111111111
54042, 0.15217391304348, 1.1413043478261, 0.38888888888889
54043, 0.1304347826087, 1.1152173913043, 0.38888888888889
54044, 0.1304347826087, 1.1413043478261, 0.41666666666667
54045, 0.15217391304348, 1.1413043478261, 0.44444444444444
54046, 0.1304347826087, 1.1152173913043, 0.44444444444444
54047, 0.1304347826087, 1.1413043478261, 0.47222222222222
54048, 0.08695652173913, 1.1413043478261, 0.027777777777778
54049, 0.10869565217391, 1.1413043478261, 0.055555555555556
54050, 0.08695652173913, 1.1152173913043, 0.055555555555556
54051, 0.08695652173913, 1.1413043478261, 0.083333333333333
54052, 0.10869565217391, 1.1413043478261, 0.11111111111111
54053, 0.08695652173913, 1.1152173913043, 0.11111111111111
54054, 0.08695652173913, 1.1413043478261, 0.13888888888889
54055, 0.10869565217391, 1.1413043478261, 0.16666666666667
54056, 0.08695652173913, 1.1152173913043, 0.16666666666667
54057, 0.08695652173913, 1.1413043478261, 0.19444444444444
54058, 0.10869565217391, 1.1413043478261, 0.22222222222222
54059, 0.08695652173913, 1.1152173913043, 0.22222222222222
54060, 0.08695652173913, 1.1413043478261, 0.25
54061, 0.10869565217391, 1.1413043478261, 0.27777777777778
54062, 0.08695652173913, 1.1152173913043, 0.27777777777778
54063, 0.08695652173913, 1.1413043478261, 0.30555555555556
54064, 0.10869565217391, 1.1413043478261, 0.33333333333333
54065, 0.08695652173913, 1.1152173913043, 0.33333333333333
54066, 0.08695652173913, 1.1413043478261, 0.36111111111111
54067, 0.10869565217391, 1.1413043478261, 0.38888888888889
54068, 0.08695652173913, 1.1152173913043, 0.38888888888889
54069, 0.08695652173913, 1.1413043478261, 0.41666666666667
54070, 0.10869565217391, 1.1413043478261, 0.44444444444444
54071, 0.08695652173913, 1.1152173913043, 0.44444444444444
54072, 0.08695652173913, 1.1413043478261, 0.47222222222222
54073, 0.043478260869565, 1.1413043478261, 0.027777777777778
54074, 0.065217391304348, 1.1413043478261, 0.055555555555556
54075, 0.043478260869565, 1.1152173913043, 0.055555555555556
54076, 0.043478260869565, 1.1413043478261, 0.083333333333333
54077, 0.065217391304348, 1.1413043478261, 0.11111111111111
54078, 0.043478260869565, 1.1152173913043, 0.11111111111111
54079, 0.043478260869565, 1.1413043478261, 0.13888888888889
54080, 0.065217391304348, 1.1413043478261, 0.16666666666667
54081, 0.043478260869565, 1.1152173913043, 0.16666666666667
54082, 0.043478260869565, 1.1413043478261, 0.19444444444444
54083, 0.065217391304348, 1.1413043478261, 0.22222222222222
54084, 0.043478260869565, 1.1152173913043, 0.22222222222222
54085, 0.043478260869565, 1.1413043478261, 0.25
54086, 0.065217391304348, 1.1413043478261, 0.27777777777778
54087, 0.043478260869565, 1.1152173913043, 0.27777777777778
54088, 0.043478260869565, 1.1413043478261, 0.30555555555556
54089, 0.065217391304348, 1.1413043478261, 0.33333333333333
54090, 0.043478260869565, 1.1152173913043, 0.33333333333333
54091, 0.043478260869565, 1.1413043478261, 0.36111111111111
54092, 0.065217391304348, 1.1413043478261, 0.38888888888889
54093, 0.043478260869565, 1.1152173913043, 0.38888888888889
54094, 0.043478260869565, 1.1413043478261, 0.41666666666667
54095, 0.065217391304348, 1.1413043478261, 0.44444444444444
54096, 0.043478260869565, 1.1152173913043, 0.44444444444444
54097, 0.043478260869565, 1.1413043478261, 0.47222222222222
54098, 0.021739130434783, 1.1413043478261, 0.055555555555556
54099, 0.021739130434783, 1.1413043478261, 0.11111111111111
54100, 0.021739130434783, 1.1413043478261, 0.16666666666667
54101, 0.021739130434783, 1.1413043478261, 0.22222222222222
54102, 0.021739130434783, 1.1413043478261, 0.27777777777778
54103, 0.021739130434783, 1.1413043478261, 0.33333333333333
54104, 0.021739130434783, 1.1413043478261, 0.38888888888889
54105, 0.021739130434783, 1.1413043478261, 0.44444444444444
54106, 0.95652173913043, 1.1934782608696, 0.027777777777778
54107, 0.97826086956522, 1.1934782608696, 0.055555555555556
54108, 0.95652173913043, 1.1673913043478, 0.055555555555556
54109, 0.95652173913043, 1.1934782608696, 0.083333333333333
54110, 0.97826086956522, 1.1934782608696, 0.11111111111111
54111, 0.95652173913043, 1.1673913043478, 0.11111111111111
54112, 0.95652173913044, 1.1934782608696, 0.13888888888889
54113, 0.97826086956522, 1.1934782608696, 0.16666666666667
54114, 0.95652173913044, 1.1673913043478, 0.16666666666667
54115, 0.95652173913044, 1.1934782608696, 0.19444444444444
54116, 0.97826086956522, 1.1934782608696, 0.22222222222222
54117, 0.95652173913044, 1.1673913043478, 0.22222222222222
54118, 0.95652173913044, 1.1934782608696, 0.25
54119, 0.97826086956522, 1.1934782608696, 0.27777777777778
54120, 0.95652173913044, 1.1673913043478, 0.27777777777778
54121, 0.95652173913044, 1.1934782608696, 0.30555555555556
54122, 0.97826086956522, 1.1934782608696, 0.33333333333333
54123, 0.95652173913044, 1.1673913043478, 0.33333333333333
54124, 0.95652173913044, 1.1934782608696, 0.36111111111111
54125, 0.97826086956522, 1.1934782608696, 0.38888888888889
54126, 0.95652173913044, 1.1673913043478, 0.38888888888889
54127, 0.95652173913044, 1.1934782608696, 0.41666666666667
54128, 0.97826086956522, 1.1934782608696, 0.44444444444444
54129, 0.95652173913044, 1.1673913043478, 0.44444444444444
54130, 0.95652173913043, 1.1934782608696, 0.47222222222222
54131, 0.91304347826087, 1.1934782608696, 0.027777777777778
54132, 0.93478260869565, 1.1934782608696, 0.055555555555556
54133, 0.91304347826087, 1.1673913043478, 0.055555555555556
54134, 0.91304347826087, 1.1934782608696, 0.083333333333333
54135, 0.93478260869565, 1.1934782608696, 0.11111111111111
54136, 0.91304347826087, 1.1673913043478, 0.11111111111111
54137, 0.91304347826087, 1.1934782608696, 0.13888888888889
54138, 0.93478260869565, 1.1934782608696, 0.16666666666667
54139, 0.91304347826087, 1.1673913043478, 0.16666666666667
54140, 0.91304347826087, 1.1934782608696, 0.19444444444444
54141, 0.93478260869565, 1.1934782608696, 0.22222222222222
54142, 0.91304347826087, 1.1673913043478, 0.22222222222222
54143, 0.91304347826087, 1.1934782608696, 0.25
54144, 0.93478260869565, 1.1934782608696, 0.27777777777778
54145, 0.91304347826087, 1.1673913043478, 0.27777777777778
54146, 0.91304347826087, 1.1934782608696, 0.30555555555556
54147, 0.93478260869565, 1.1934782608696, 0.33333333333333
54148, 0.91304347826087, 1.1673913043478, 0.33333333333333
54149, 0.91304347826087, 1.1934782608696, 0.36111111111111
54150, 0.93478260869565, 1.1934782608696, 0.38888888888889
54151, 0.91304347826087, 1.1673913043478, 0.38888888888889
54152, 0.91304347826087, 1.1934782608696, 0.41666666666667
54153, 0.93478260869565, 1.1934782608696, 0.44444444444444
54154, 0.91304347826087, 1.1673913043478, 0.44444444444444
54155, 0.91304347826087, 1.1934782608696, 0.47222222222222
54156, 0.8695652173913, 1.1934782608696, 0.027777777777778
54157, 0.89130434782609, 1.1934782608696, 0.055555555555556
54158, 0.8695652173913, 1.1673913043478, 0.055555555555556
54159, 0.8695652173913, 1.1934782608696, 0.083333333333333
54160, 0.89130434782609, 1.1934782608696, 0.11111111111111
54161, 0.8695652173913, 1.1673913043478, 0.11111111111111
54162, 0.8695652173913, 1.1934782608696, 0.13888888888889
54163, 0.89130434782609, 1.1934782608696, 0.16666666666667
54164, 0.8695652173913, 1.1673913043478, 0.16666666666667
54165, 0.8695652173913, 1.1934782608696, 0.19444444444444
54166, 0.89130434782609, 1.1934782608696, 0.22222222222222
54167, 0.8695652173913, 1.1673913043478, 0.22222222222222
54168, 0.8695652173913, 1.1934782608696, 0.25
54169, 0.89130434782609, 1.1934782608696, 0.27777777777778
54170, 0.8695652173913, 1.1673913043478, 0.27777777777778
54171, 0.8695652173913, 1.1934782608696, 0.30555555555556
54172, 0.89130434782609, 1.1934782608696, 0.33333333333333
54173, 0.8695652173913, 1.1673913043478, 0.33333333333333
54174, 0.8695652173913, 1.1934782608696, 0.36111111111111
54175, 0.89130434782609, 1.1934782608696, 0.38888888888889
54176, 0.8695652173913, 1.1673913043478, 0.38888888888889
54177, 0.8695652173913, 1.1934782608696, 0.41666666666667
54178, 0.89130434782609, 1.1934782608696, 0.44444444444444
54179, 0.8695652173913, 1.1673913043478, 0.44444444444444
54180, 0.8695652173913, 1.1934782608696, 0.47222222222222
54181, 0.82608695652174, 1.1934782608696, 0.027777777777778
54182, 0.84782608695652, 1.1934782608696, 0.055555555555556
54183, 0.82608695652174, 1.1673913043478, 0.055555555555556
54184, 0.82608695652174, 1.1934782608696, 0.083333333333333
54185, 0.84782608695652, 1.1934782608696, 0.11111111111111
54186, 0.82608695652174, 1.1673913043478, 0.11111111111111
54187, 0.82608695652174, 1.1934782608696, 0.13888888888889
54188, 0.84782608695652, 1.1934782608696, 0.16666666666667
54189, 0.82608695652174, 1.1673913043478, 0.16666666666667
54190, 0.82608695652174, 1.1934782608696, 0.19444444444444
54191, 0.84782608695652, 1.1934782608696, 0.22222222222222
54192, 0.82608695652174, 1.1673913043478, 0.22222222222222
54193, 0.82608695652174, 1.1934782608696, 0.25
54194, 0.84782608695652, 1.1934782608696, 0.27777777777778
54195, 0.82608695652174, 1.1673913043478, 0.27777777777778
54196, 0.82608695652174, 1.1934782608696, 0.30555555555556
54197, 0.84782608695652, 1.1934782608696, 0.33333333333333
54198, 0.82608695652174, 1.1673913043478, 0.33333333333333
54199, 0.82608695652174, 1.1934782608696, 0.36111111111111
54200, 0.84782608695652, 1.1934782608696, 0.38888888888889
54201, 0.82608695652174, 1.1673913043478, 0.38888888888889
54202, 0.82608695652174, 1.1934782608696, 0.41666666666667
54203, 0.84782608695652, 1.1934782608696, 0.44444444444444
54204, 0.82608695652174, 1.1673913043478, 0.44444444444444
54205, 0.82608695652174, 1.1934782608696, 0.47222222222222
54206, 0.78260869565217, 1.1934782608696, 0.027777777777778
54207, 0.80434782608696, 1.1934782608696, 0.055555555555556
54208, 0.78260869565217, 1.1673913043478, 0.055555555555556
54209, 0.78260869565217, 1.1934782608696, 0.083333333333333
54210, 0.80434782608696, 1.1934782608696, 0.11111111111111
54211, 0.78260869565217, 1.1673913043478, 0.11111111111111
54212, 0.78260869565217, 1.1934782608696, 0.13888888888889
54213, 0.80434782608696, 1.1934782608696, 0.16666666666667
54214, 0.78260869565217, 1.1673913043478, 0.16666666666667
54215, 0.78260869565217, 1.1934782608696, 0.19444444444444
54216, 0.80434782608696, 1.1934782608696, 0.22222222222222
54217, 0.78260869565217, 1.1673913043478, 0.22222222222222
54218, 0.78260869565217, 1.1934782608696, 0.25
54219, 0.80434782608696, 1.1934782608696, 0.27777777777778
54220, 0.78260869565217, 1.1673913043478, 0.27777777777778
54221, 0.78260869565217, 1.1934782608696, 0.30555555555556
54222, 0.80434782608696, 1.1934782608696, 0.33333333333333
54223, 0.78260869565217, 1.1673913043478, 0.33333333333333
54224, 0.78260869565217, 1.1934782608696, 0.36111111111111
54225, 0.80434782608696, 1.1934782608696, 0.38888888888889
54226, 0.78260869565217, 1.1673913043478, 0.38888888888889
54227, 0.78260869565217, 1.1934782608696, 0.41666666666667
54228, 0.80434782608696, 1.1934782608696, 0.44444444444444
54229, 0.78260869565217, 1.1673913043478, 0.44444444444444
54230, 0.78260869565217, 1.1934782608696, 0.47222222222222
54231, 0.73913043478261, 1.1934782608696, 0.027777777777778
54232, 0.76086956521739, 1.1934782608696, 0.055555555555556
54233, 0.73913043478261, 1.1673913043478, 0.055555555555556
54234, 0.73913043478261, 1.1934782608696, 0.083333333333333
54235, 0.76086956521739, 1.1934782608696, 0.11111111111111
54236, 0.73913043478261, 1.1673913043478, 0.11111111111111
54237, 0.73913043478261, 1.1934782608696, 0.13888888888889
54238, 0.76086956521739, 1.1934782608696, 0.16666666666667
54239, 0.73913043478261, 1.1673913043478, 0.16666666666667
54240, 0.73913043478261, 1.1934782608696, 0.19444444444444
54241, 0.76086956521739, 1.1934782608696, 0.22222222222222
54242, 0.73913043478261, 1.1673913043478, 0.22222222222222
54243, 0.73913043478261, 1.1934782608696, 0.25
54244, 0.76086956521739, 1.1934782608696, 0.27777777777778
54245, 0.73913043478261, 1.1673913043478, 0.27777777777778
54246, 0.73913043478261, 1.1934782608696, 0.30555555555556
54247, 0.76086956521739, 1.1934782608696, 0.33333333333333
54248, 0.73913043478261, 1.1673913043478, 0.33333333333333
54249, 0.73913043478261, 1.1934782608696, 0.36111111111111
54250, 0.76086956521739, 1.1934782608696, 0.38888888888889
54251, 0.73913043478261, 1.1673913043478, 0.38888888888889
54252, 0.73913043478261, 1.1934782608696, 0.41666666666667
54253, 0.76086956521739, 1.1934782608696, 0.44444444444444
54254, 0.73913043478261, 1.1673913043478, 0.44444444444444
54255, 0.73913043478261, 1.1934782608696, 0.47222222222222
54256, 0.69565217391304, 1.1934782608696, 0.027777777777778
54257, 0.71739130434783, 1.1934782608696, 0.055555555555556
54258, 0.69565217391304, 1.1673913043478, 0.055555555555556
54259, 0.69565217391304, 1.1934782608696, 0.083333333333333
54260, 0.71739130434783, 1.1934782608696, 0.11111111111111
54261, 0.69565217391304, 1.1673913043478, 0.11111111111111
54262, 0.69565217391304, 1.1934782608696, 0.13888888888889
54263, 0.71739130434783, 1.1934782608696, 0.16666666666667
54264, 0.69565217391304, 1.1673913043478, 0.16666666666667
54265, 0.69565217391304, 1.1934782608696, 0.19444444444444
54266, 0.71739130434783, 1.1934782608696, 0.22222222222222
54267, 0.69565217391304, 1.1673913043478, 0.22222222222222
54268, 0.69565217391304, 1.1934782608696, 0.25
54269, 0.71739130434783, 1.1934782608696, 0.27777777777778
54270, 0.69565217391304, 1.1673913043478, 0.27777777777778
54271, 0.69565217391304, 1.1934782608696, 0.30555555555556
54272, 0.71739130434783, 1.1934782608696, 0.33333333333333
54273, 0.69565217391304, 1.1673913043478, 0.33333333333333
54274, 0.69565217391304, 1.1934782608696, 0.36111111111111
54275, 0.71739130434783, 1.1934782608696, 0.38888888888889
54276, 0.69565217391304, 1.1673913043478, 0.38888888888889
54277, 0.69565217391304, 1.1934782608696, 0.41666666666667
54278, 0.71739130434783, 1.1934782608696, 0.44444444444444
54279, 0.69565217391304, 1.1673913043478, 0.44444444444444
54280, 0.69565217391304, 1.1934782608696, 0.47222222222222
54281, 0.65217391304348, 1.1934782608696, 0.027777777777778
54282, 0.67391304347826, 1.1934782608696, 0.055555555555556
54283, 0.65217391304348, 1.1673913043478, 0.055555555555556
54284, 0.65217391304348, 1.1934782608696, 0.083333333333333
54285, 0.67391304347826, 1.1934782608696, 0.11111111111111
54286, 0.65217391304348, 1.1673913043478, 0.11111111111111
54287, 0.65217391304348, 1.1934782608696, 0.13888888888889
54288, 0.67391304347826, 1.1934782608696, 0.16666666666667
54289, 0.65217391304348, 1.1673913043478, 0.16666666666667
54290, 0.65217391304348, 1.1934782608696, 0.19444444444444
54291, 0.67391304347826, 1.1934782608696, 0.22222222222222
54292, 0.65217391304348, 1.1673913043478, 0.22222222222222
54293, 0.65217391304348, 1.1934782608696, 0.25
54294, 0.67391304347826, 1.1934782608696, 0.27777777777778
54295, 0.65217391304348, 1.1673913043478, 0.27777777777778
54296, 0.65217391304348, 1.1934782608696, 0.30555555555556
54297, 0.67391304347826, 1.1934782608696, 0.33333333333333
54298, 0.65217391304348, 1.1673913043478, 0.33333333333333
54299, 0.65217391304348, 1.1934782608696, 0.36111111111111
54300, 0.67391304347826, 1.1934782608696, 0.38888888888889
54301, 0.65217391304348, 1.1673913043478, 0.38888888888889
54302, 0.65217391304348, 1.1934782608696, 0.41666666666667
54303, 0.67391304347826, 1.1934782608696, 0.44444444444444
54304, 0.65217391304348, 1.1673913043478, 0.44444444444444
54305, 0.65217391304348, 1.1934782608696, 0.47222222222222
54306, 0.60869565217391, 1.1934782608696, 0.027777777777778
54307, 0.6304347826087, 1.1934782608696, 0.055555555555556
54308, 0.60869565217391, 1.1673913043478, 0.055555555555556
54309, 0.60869565217391, 1.1934782608696, 0.083333333333333
54310, 0.6304347826087, 1.1934782608696, 0.11111111111111
54311, 0.60869565217391, 1.1673913043478, 0.11111111111111
54312, 0.60869565217391, 1.1934782608696, 0.13888888888889
54313, 0.6304347826087, 1.1934782608696, 0.16666666666667
54314, 0.60869565217391, 1.1673913043478, 0.16666666666667
54315, 0.60869565217391, 1.1934782608696, 0.19444444444444
54316, 0.6304347826087, 1.1934782608696, 0.22222222222222
54317, 0.60869565217391, 1.1673913043478, 0.22222222222222
54318, 0.60869565217391, 1.1934782608696, 0.25
54319, 0.6304347826087, 1.1934782608696, 0.27777777777778
54320, 0.60869565217391, 1.1673913043478, 0.27777777777778
54321, 0.60869565217391, 1.1934782608696, 0.30555555555556
54322, 0.6304347826087, 1.1934782608696, 0.33333333333333
54323, 0.60869565217391, 1.1673913043478, 0.33333333333333
54324, 0.60869565217391, 1.1934782608696, 0.36111111111111
54325, 0.6304347826087, 1.1934782608696, 0.38888888888889
54326, 0.60869565217391, 1.1673913043478, 0.38888888888889
54327, 0.60869565217391, 1.1934782608696, 0.41666666666667
54328, 0.6304347826087, 1.1934782608696, 0.44444444444444
54329, 0.60869565217391, 1.1673913043478, 0.44444444444444
54330, 0.60869565217391, 1.1934782608696, 0.47222222222222
54331, 0.56521739130435, 1.1934782608696, 0.027777777777778
54332, 0.58695652173913, 1.1934782608696, 0.055555555555556
54333, 0.56521739130435, 1.1673913043478, 0.055555555555556
54334, 0.56521739130435, 1.1934782608696, 0.083333333333333
54335, 0.58695652173913, 1.1934782608696, 0.11111111111111
54336, 0.56521739130435, 1.1673913043478, 0.11111111111111
54337, 0.56521739130435, 1.1934782608696, 0.13888888888889
54338, 0.58695652173913, 1.1934782608696, 0.16666666666667
54339, 0.56521739130435, 1.1673913043478, 0.16666666666667
54340, 0.56521739130435, 1.1934782608696, 0.19444444444444
54341, 0.58695652173913, 1.1934782608696, 0.22222222222222
54342, 0.56521739130435, 1.1673913043478, 0.22222222222222
54343, 0.56521739130435, 1.1934782608696, 0.25
54344, 0.58695652173913, 1.1934782608696, 0.27777777777778
54345, 0.56521739130435, 1.1673913043478, 0.27777777777778
54346, 0.56521739130435, 1.1934782608696, 0.30555555555556
54347, 0.58695652173913, 1.1934782608696, 0.33333333333333
54348, 0.56521739130435, 1.1673913043478, 0.33333333333333
54349, 0.56521739130435, 1.1934782608696, 0.36111111111111
54350, 0.58695652173913, 1.1934782608696, 0.38888888888889
54351, 0.56521739130435, 1.1673913043478, 0.38888888888889
54352, 0.56521739130435, 1.1934782608696, 0.41666666666667
54353, 0.58695652173913, 1.1934782608696, 0.44444444444444
54354, 0.56521739130435, 1.1673913043478, 0.44444444444444
54355, 0.56521739130435, 1.1934782608696, 0.47222222222222
54356, 0.52173913043478, 1.1934782608696, 0.027777777777778
54357, 0.54347826086956, 1.1934782608696, 0.055555555555556
54358, 0.52173913043478, 1.1673913043478, 0.055555555555556
54359, 0.52173913043478, 1.1934782608696, 0.083333333333333
54360, 0.54347826086956, 1.1934782608696, 0.11111111111111
54361, 0.52173913043478, 1.1673913043478, 0.11111111111111
54362, 0.52173913043478, 1.1934782608696, 0.13888888888889
54363, 0.54347826086957, 1.1934782608696, 0.16666666666667
54364, 0.52173913043478, 1.1673913043478, 0.16666666666667
54365, 0.52173913043478, 1.1934782608696, 0.19444444444444
54366, 0.54347826086957, 1.1934782608696, 0.22222222222222
54367, 0.52173913043478, 1.1673913043478, 0.22222222222222
54368, 0.52173913043478, 1.1934782608696, 0.25
54369, 0.54347826086956, 1.1934782608696, 0.27777777777778
54370, 0.52173913043478, 1.1673913043478, 0.27777777777778
54371, 0.52173913043478, 1.1934782608696, 0.30555555555556
54372, 0.54347826086956, 1.1934782608696, 0.33333333333333
54373, 0.52173913043478, 1.1673913043478, 0.33333333333333
54374, 0.52173913043478, 1.1934782608696, 0.36111111111111
54375, 0.54347826086956, 1.1934782608696, 0.38888888888889
54376, 0.52173913043478, 1.1673913043478, 0.38888888888889
54377, 0.52173913043478, 1.1934782608696, 0.41666666666667
54378, 0.54347826086956, 1.1934782608696, 0.44444444444444
54379, 0.52173913043478, 1.1673913043478, 0.44444444444444
54380, 0.52173913043478, 1.1934782608696, 0.47222222222222
54381, 0.47826086956522, 1.1934782608696, 0.027777777777778
54382, 0.5, 1.1934782608696, 0.055555555555556
54383, 0.47826086956522, 1.1673913043478, 0.055555555555556
54384, 0.47826086956522, 1.1934782608696, 0.083333333333333
54385, 0.5, 1.1934782608696, 0.11111111111111
54386, 0.47826086956522, 1.1673913043478, 0.11111111111111
54387, 0.47826086956522, 1.1934782608696, 0.13888888888889
54388, 0.5, 1.1934782608696, 0.16666666666667
54389, 0.47826086956522, 1.1673913043478, 0.16666666666667
54390, 0.47826086956522, 1.1934782608696, 0.19444444444444
54391, 0.5, 1.1934782608696, 0.22222222222222
54392, 0.47826086956522, 1.1673913043478, 0.22222222222222
54393, 0.47826086956522, 1.1934782608696, 0.25
54394, 0.5, 1.1934782608696, 0.27777777777778
54395, 0.47826086956522, 1.1673913043478, 0.27777777777778
54396, 0.47826086956522, 1.1934782608696, 0.30555555555556
54397, 0.5, 1.1934782608696, 0.33333333333333
54398, 0.47826086956522, 1.1673913043478, 0.33333333333333
54399, 0.47826086956522, 1.1934782608696, 0.36111111111111
54400, 0.5, 1.1934782608696, 0.38888888888889
54401, 0.47826086956522, 1.1673913043478, 0.38888888888889
54402, 0.47826086956522, 1.1934782608696, 0.41666666666667
54403, 0.5, 1.1934782608696, 0.44444444444444
54404, 0.47826086956522, 1.1673913043478, 0.44444444444444
54405, 0.47826086956522, 1.1934782608696, 0.47222222222222
54406, 0.43478260869565, 1.1934782608696, 0.027777777777778
54407, 0.45652173913043, 1.1934782608696, 0.055555555555556
54408, 0.43478260869565, 1.1673913043478, 0.055555555555556
54409, 0.43478260869565, 1.1934782608696, 0.083333333333333
54410, 0.45652173913043, 1.1934782608696, 0.11111111111111
54411, 0.43478260869565, 1.1673913043478, 0.11111111111111
54412, 0.43478260869565, 1.1934782608696, 0.13888888888889
54413, 0.45652173913043, 1.1934782608696, 0.16666666666667
54414, 0.43478260869565, 1.1673913043478, 0.16666666666667
54415, 0.43478260869565, 1.1934782608696, 0.19444444444444
54416, 0.45652173913043, 1.1934782608696, 0.22222222222222
54417, 0.43478260869565, 1.1673913043478, 0.22222222222222
54418, 0.43478260869565, 1.1934782608696, 0.25
54419, 0.45652173913043, 1.1934782608696, 0.27777777777778
54420, 0.43478260869565, 1.1673913043478, 0.27777777777778
54421, 0.43478260869565, 1.1934782608696, 0.30555555555556
54422, 0.45652173913043, 1.1934782608696, 0.33333333333333
54423, 0.43478260869565, 1.1673913043478, 0.33333333333333
54424, 0.43478260869565, 1.1934782608696, 0.36111111111111
54425, 0.45652173913044, 1.1934782608696, 0.38888888888889
54426, 0.43478260869565, 1.1673913043478, 0.38888888888889
54427, 0.43478260869565, 1.1934782608696, 0.41666666666667
54428, 0.45652173913043, 1.1934782608696, 0.44444444444444
54429, 0.43478260869565, 1.1673913043478, 0.44444444444444
54430, 0.43478260869565, 1.1934782608696, 0.47222222222222
54431, 0.39130434782609, 1.1934782608696, 0.027777777777778
54432, 0.41304347826087, 1.1934782608696, 0.055555555555556
54433, 0.39130434782609, 1.1673913043478, 0.055555555555556
54434, 0.39130434782609, 1.1934782608696, 0.083333333333333
54435, 0.41304347826087, 1.1934782608696, 0.11111111111111
54436, 0.39130434782609, 1.1673913043478, 0.11111111111111
54437, 0.39130434782609, 1.1934782608696, 0.13888888888889
54438, 0.41304347826087, 1.1934782608696, 0.16666666666667
54439, 0.39130434782609, 1.1673913043478, 0.16666666666667
54440, 0.39130434782609, 1.1934782608696, 0.19444444444444
54441, 0.41304347826087, 1.1934782608696, 0.22222222222222
54442, 0.39130434782609, 1.1673913043478, 0.22222222222222
54443, 0.39130434782609, 1.1934782608696, 0.25
54444, 0.41304347826087, 1.1934782608696, 0.27777777777778
54445, 0.39130434782609, 1.1673913043478, 0.27777777777778
54446, 0.39130434782609, 1.1934782608696, 0.30555555555556
54447, 0.41304347826087, 1.1934782608696, 0.33333333333333
54448, 0.39130434782609, 1.1673913043478, 0.33333333333333
54449, 0.39130434782609, 1.1934782608696, 0.36111111111111
54450, 0.41304347826087, 1.1934782608696, 0.38888888888889
54451, 0.39130434782609, 1.1673913043478, 0.38888888888889
54452, 0.39130434782609, 1.1934782608696, 0.41666666666667
54453, 0.41304347826087, 1.1934782608696, 0.44444444444444
54454, 0.39130434782609, 1.1673913043478, 0.44444444444444
54455, 0.39130434782609, 1.1934782608696, 0.47222222222222
54456, 0.34782608695652, 1.1934782608696, 0.027777777777778
54457, 0.3695652173913, 1.1934782608696, 0.055555555555556
54458, 0.34782608695652, 1.1673913043478, 0.055555555555556
54459, 0.34782608695652, 1.1934782608696, 0.083333333333333
54460, 0.3695652173913, 1.1934782608696, 0.11111111111111
54461, 0.34782608695652, 1.1673913043478, 0.11111111111111
54462, 0.34782608695652, 1.1934782608696, 0.13888888888889
54463, 0.3695652173913, 1.1934782608696, 0.16666666666667
54464, 0.34782608695652, 1.1673913043478, 0.16666666666667
54465, 0.34782608695652, 1.1934782608696, 0.19444444444444
54466, 0.3695652173913, 1.1934782608696, 0.22222222222222
54467, 0.34782608695652, 1.1673913043478, 0.22222222222222
54468, 0.34782608695652, 1.1934782608696, 0.25
54469, 0.3695652173913, 1.1934782608696, 0.27777777777778
54470, 0.34782608695652, 1.1673913043478, 0.27777777777778
54471, 0.34782608695652, 1.1934782608696, 0.30555555555556
54472, 0.3695652173913, 1.1934782608696, 0.33333333333333
54473, 0.34782608695652, 1.1673913043478, 0.33333333333333
54474, 0.34782608695652, 1.1934782608696, 0.36111111111111
54475, 0.3695652173913, 1.1934782608696, 0.38888888888889
54476, 0.34782608695652, 1.1673913043478, 0.38888888888889
54477, 0.34782608695652, 1.1934782608696, 0.41666666666667
54478, 0.3695652173913, 1.1934782608696, 0.44444444444444
54479, 0.34782608695652, 1.1673913043478, 0.44444444444444
54480, 0.34782608695652, 1.1934782608696, 0.47222222222222
54481, 0.30434782608696, 1.1934782608696, 0.027777777777778
54482, 0.32608695652174, 1.1934782608696, 0.055555555555556
54483, 0.30434782608696, 1.1673913043478, 0.055555555555556
54484, 0.30434782608696, 1.1934782608696, 0.083333333333333
54485, 0.32608695652174, 1.1934782608696, 0.11111111111111
54486, 0.30434782608696, 1.1673913043478, 0.11111111111111
54487, 0.30434782608696, 1.1934782608696, 0.13888888888889
54488, 0.32608695652174, 1.1934782608696, 0.16666666666667
54489, 0.30434782608696, 1.1673913043478, 0.16666666666667
54490, 0.30434782608696, 1.1934782608696, 0.19444444444444
54491, 0.32608695652174, 1.1934782608696, 0.22222222222222
54492, 0.30434782608696, 1.1673913043478, 0.22222222222222
54493, 0.30434782608696, 1.1934782608696, 0.25
54494, 0.32608695652174, 1.1934782608696, 0.27777777777778
54495, 0.30434782608696, 1.1673913043478, 0.27777777777778
54496, 0.30434782608696, 1.1934782608696, 0.30555555555556
54497, 0.32608695652174, 1.1934782608696, 0.33333333333333
54498, 0.30434782608696, 1.1673913043478, 0.33333333333333
54499, 0.30434782608696, 1.1934782608696, 0.36111111111111
54500, 0.32608695652174, 1.1934782608696, 0.38888888888889
54501, 0.30434782608696, 1.1673913043478, 0.38888888888889
54502, 0.30434782608696, 1.1934782608696, 0.41666666666667
54503, 0.32608695652174, 1.1934782608696, 0.44444444444444
54504, 0.30434782608696, 1.1673913043478, 0.44444444444444
54505, 0.30434782608696, 1.1934782608696, 0.47222222222222
54506, 0.26086956521739, 1.1934782608696, 0.027777777777778
54507, 0.28260869565217, 1.1934782608696, 0.055555555555556
54508, 0.26086956521739, 1.1673913043478, 0.055555555555556
54509, 0.26086956521739, 1.1934782608696, 0.083333333333333
54510, 0.28260869565217, 1.1934782608696, 0.11111111111111
54511, 0.26086956521739, 1.1673913043478, 0.11111111111111
54512, 0.26086956521739, 1.1934782608696, 0.13888888888889
54513, 0.28260869565217, 1.1934782608696, 0.16666666666667
54514, 0.26086956521739, 1.1673913043478, 0.16666666666667
54515, 0.26086956521739, 1.1934782608696, 0.19444444444444
54516, 0.28260869565217, 1.1934782608696, 0.22222222222222
54517, 0.26086956521739, 1.1673913043478, 0.22222222222222
54518, 0.26086956521739, 1.1934782608696, 0.25
54519, 0.28260869565217, 1.1934782608696, 0.27777777777778
54520, 0.26086956521739, 1.1673913043478, 0.27777777777778
54521, 0.26086956521739, 1.1934782608696, 0.30555555555556
54522, 0.28260869565217, 1.1934782608696, 0.33333333333333
54523, 0.26086956521739, 1.1673913043478, 0.33333333333333
54524, 0.26086956521739, 1.1934782608696, 0.36111111111111
54525, 0.28260869565217, 1.1934782608696, 0.38888888888889
54526, 0.26086956521739, 1.1673913043478, 0.38888888888889
54527, 0.26086956521739, 1.1934782608696, 0.41666666666667
54528, 0.28260869565217, 1.1934782608696, 0.44444444444444
54529, 0.26086956521739, 1.1673913043478, 0.44444444444444
54530, 0.26086956521739, 1.1934782608696, 0.47222222222222
54531, 0.21739130434783, 1.1934782608696, 0.027777777777778
54532, 0.23913043478261, 1.1934782608696, 0.055555555555556
54533, 0.21739130434783, 1.1673913043478, 0.055555555555556
54534, 0.21739130434783, 1.1934782608696, 0.083333333333333
54535, 0.23913043478261, 1.1934782608696, 0.11111111111111
54536, 0.21739130434783, 1.1673913043478, 0.11111111111111
54537, 0.21739130434783, 1.1934782608696, 0.13888888888889
54538, 0.23913043478261, 1.1934782608696, 0.16666666666667
54539, 0.21739130434783, 1.1673913043478, 0.16666666666667
54540, 0.21739130434783, 1.1934782608696, 0.19444444444444
54541, 0.23913043478261, 1.1934782608696, 0.22222222222222
54542, 0.21739130434783, 1.1673913043478, 0.22222222222222
54543, 0.21739130434783, 1.1934782608696, 0.25
54544, 0.23913043478261, 1.1934782608696, 0.27777777777778
54545, 0.21739130434783, 1.1673913043478, 0.27777777777778
54546, 0.21739130434783, 1.1934782608696, 0.30555555555556
54547, 0.23913043478261, 1.1934782608696, 0.33333333333333
54548, 0.21739130434783, 1.1673913043478, 0.33333333333333
54549, 0.21739130434783, 1.1934782608696, 0.36111111111111
54550, 0.23913043478261, 1.1934782608696, 0.38888888888889
54551, 0.21739130434783, 1.1673913043478, 0.38888888888889
54552, 0.21739130434783, 1.1934782608696, 0.41666666666667
54553, 0.23913043478261, 1.1934782608696, 0.44444444444444
54554, 0.21739130434783, 1.1673913043478, 0.44444444444444
54555, 0.21739130434783, 1.1934782608696, 0.47222222222222
54556, 0.17391304347826, 1.1934782608696, 0.027777777777778
54557, 0.19565217391304, 1.1934782608696, 0.055555555555556
54558, 0.17391304347826, 1.1673913043478, 0.055555555555556
54559, 0.17391304347826, 1.1934782608696, 0.083333333333333
54560, 0.19565217391304, 1.1934782608696, 0.11111111111111
54561, 0.17391304347826, 1.1673913043478, 0.11111111111111
54562, 0.17391304347826, 1.1934782608696, 0.13888888888889
54563, 0.19565217391304, 1.1934782608696, 0.16666666666667
54564, 0.17391304347826, 1.1673913043478, 0.16666666666667
54565, 0.17391304347826, 1.1934782608696, 0.19444444444444
54566, 0.19565217391304, 1.1934782608696, 0.22222222222222
54567, 0.17391304347826, 1.1673913043478, 0.22222222222222
54568, 0.17391304347826, 1.1934782608696, 0.25
54569, 0.19565217391304, 1.1934782608696, 0.27777777777778
54570, 0.17391304347826, 1.1673913043478, 0.27777777777778
54571, 0.17391304347826, 1.1934782608696, 0.30555555555556
54572, 0.19565217391304, 1.1934782608696, 0.33333333333333
54573, 0.17391304347826, 1.1673913043478, 0.33333333333333
54574, 0.17391304347826, 1.1934782608696, 0.36111111111111
54575, 0.19565217391304, 1.1934782608696, 0.38888888888889
54576, 0.17391304347826, 1.1673913043478, 0.38888888888889
54577, 0.17391304347826, 1.1934782608696, 0.41666666666667
54578, 0.19565217391304, 1.1934782608696, 0.44444444444444
54579, 0.17391304347826, 1.1673913043478, 0.44444444444444
54580, 0.17391304347826, 1.1934782608696, 0.47222222222222
54581, 0.1304347826087, 1.1934782608696, 0.027777777777778
54582, 0.15217391304348, 1.1934782608696, 0.055555555555556
54583, 0.1304347826087, 1.1673913043478, 0.055555555555556
54584, 0.1304347826087, 1.1934782608696, 0.083333333333333
54585, 0.15217391304348, 1.1934782608696, 0.11111111111111
54586, 0.1304347826087, 1.1673913043478, 0.11111111111111
54587, 0.1304347826087, 1.1934782608696, 0.13888888888889
54588, 0.15217391304348, 1.1934782608696, 0.16666666666667
54589, 0.1304347826087, 1.1673913043478, 0.16666666666667
54590, 0.1304347826087, 1.1934782608696, 0.19444444444444
54591, 0.15217391304348, 1.1934782608696, 0.22222222222222
54592, 0.1304347826087, 1.1673913043478, 0.22222222222222
54593, 0.1304347826087, 1.1934782608696, 0.25
54594, 0.15217391304348, 1.1934782608696, 0.27777777777778
54595, 0.1304347826087, 1.1673913043478, 0.27777777777778
54596, 0.1304347826087, 1.1934782608696, 0.30555555555556
54597, 0.15217391304348, 1.1934782608696, 0.33333333333333
54598, 0.1304347826087, 1.1673913043478, 0.33333333333333
54599, 0.1304347826087, 1.1934782608696, 0.36111111111111
54600, 0.15217391304348, 1.1934782608696, 0.38888888888889
54601, 0.1304347826087, 1.1673913043478, 0.38888888888889
54602, 0.1304347826087, 1.1934782608696, 0.41666666666667
54603, 0.15217391304348, 1.1934782608696, 0.44444444444444
54604, 0.1304347826087, 1.1673913043478, 0.44444444444444
54605, 0.1304347826087, 1.1934782608696, 0.47222222222222
54606, 0.08695652173913, 1.1934782608696, 0.027777777777778
54607, 0.10869565217391, 1.1934782608696, 0.055555555555556
54608, 0.08695652173913, 1.1673913043478, 0.055555555555556
54609, 0.08695652173913, 1.1934782608696, 0.083333333333333
54610, 0.10869565217391, 1.1934782608696, 0.11111111111111
54611, 0.08695652173913, 1.1673913043478, 0.11111111111111
54612, 0.08695652173913, 1.1934782608696, 0.13888888888889
54613, 0.10869565217391, 1.1934782608696, 0.16666666666667
54614, 0.08695652173913, 1.1673913043478, 0.16666666666667
54615, 0.08695652173913, 1.1934782608696, 0.19444444444444
54616, 0.10869565217391, 1.1934782608696, 0.22222222222222
54617, 0.08695652173913, 1.1673913043478, 0.22222222222222
54618, 0.08695652173913, 1.1934782608696, 0.25
54619, 0.10869565217391, 1.1934782608696, 0.27777777777778
54620, 0.08695652173913, 1.1673913043478, 0.27777777777778
54621, 0.08695652173913, 1.1934782608696, 0.30555555555556
54622, 0.10869565217391, 1.1934782608696, 0.33333333333333
54623, 0.08695652173913, 1.1673913043478, 0.33333333333333
54624, 0.08695652173913, 1.1934782608696, 0.36111111111111
54625, 0.10869565217391, 1.1934782608696, 0.38888888888889
54626, 0.08695652173913, 1.1673913043478, 0.38888888888889
54627, 0.08695652173913, 1.1934782608696, 0.41666666666667
54628, 0.10869565217391, 1.1934782608696, 0.44444444444444
54629, 0.08695652173913, 1.1673913043478, 0.44444444444444
54630, 0.08695652173913, 1.1934782608696, 0.47222222222222
54631, 0.043478260869565, 1.1934782608696, 0.027777777777778
54632, 0.065217391304348, 1.1934782608696, 0.055555555555556
54633, 0.043478260869565, 1.1673913043478, 0.055555555555556
54634, 0.043478260869565, 1.1934782608696, 0.083333333333333
54635, 0.065217391304348, 1.1934782608696, 0.11111111111111
54636, 0.043478260869565, 1.1673913043478, 0.11111111111111
54637, 0.043478260869565, 1.1934782608696, 0.13888888888889
54638, 0.065217391304348, 1.1934782608696, 0.16666666666667
54639, 0.043478260869565, 1.1673913043478, 0.16666666666667
54640, 0.043478260869565, 1.1934782608696, 0.19444444444444
54641, 0.065217391304348, 1.1934782608696, 0.22222222222222
54642, 0.043478260869565, 1.1673913043478, 0.22222222222222
54643, 0.043478260869565, 1.1934782608696, 0.25
54644, 0.065217391304348, 1.1934782608696, 0.27777777777778
54645, 0.043478260869565, 1.1673913043478, 0.27777777777778
54646, 0.043478260869565, 1.1934782608696, 0.30555555555556
54647, 0.065217391304348, 1.1934782608696, 0.33333333333333
54648, 0.043478260869565, 1.1673913043478, 0.33333333333333
54649, 0.043478260869565, 1.1934782608696, 0.36111111111111
54650, 0.065217391304348, 1.1934782608696, 0.38888888888889
54651, 0.043478260869565, 1.1673913043478, 0.38888888888889
54652, 0.043478260869565, 1.1934782608696, 0.41666666666667
54653, 0.065217391304348, 1.1934782608696, 0.44444444444444
54654, 0.043478260869565, 1.1673913043478, 0.44444444444444
54655, 0.043478260869565, 1.1934782608696, 0.47222222222222
54656, 0.021739130434783, 1.1934782608696, 0.055555555555556
54657, 0.021739130434783, 1.1934782608696, 0.11111111111111
54658, 0.021739130434783, 1.1934782608696, 0.16666666666667
54659, 0.021739130434783, 1.1934782608696, 0.22222222222222
54660, 0.021739130434783, 1.1934782608696, 0.27777777777778
54661, 0.021739130434783, 1.1934782608696, 0.33333333333333
54662, 0.021739130434783, 1.1934782608696, 0.38888888888889
54663, 0.021739130434783, 1.1934782608696, 0.44444444444444
54664, 0.95652173913043, 1.245652173913, 0.027777777777778
54665, 0.97826086956522, 1.245652173913, 0.055555555555556
54666, 0.95652173913043, 1.2195652173913, 0.055555555555556
54667, 0.95652173913043, 1.245652173913, 0.083333333333333
54668, 0.97826086956522, 1.245652173913, 0.11111111111111
54669, 0.95652173913043, 1.2195652173913, 0.11111111111111
54670, 0.95652173913044, 1.245652173913, 0.13888888888889
54671, 0.97826086956522, 1.245652173913, 0.16666666666667
54672, 0.95652173913044, 1.2195652173913, 0.16666666666667
54673, 0.95652173913044, 1.245652173913, 0.19444444444444
54674, 0.97826086956522, 1.245652173913, 0.22222222222222
54675, 0.95652173913044, 1.2195652173913, 0.22222222222222
54676, 0.95652173913044, 1.245652173913, 0.25
54677, 0.97826086956522, 1.245652173913, 0.27777777777778
54678, 0.95652173913044, 1.2195652173913, 0.27777777777778
54679, 0.95652173913044, 1.245652173913, 0.30555555555556
54680, 0.97826086956522, 1.245652173913, 0.33333333333333
54681, 0.95652173913044, 1.2195652173913, 0.33333333333333
54682, 0.95652173913044, 1.245652173913, 0.36111111111111
54683, 0.97826086956522, 1.245652173913, 0.38888888888889
54684, 0.95652173913044, 1.2195652173913, 0.38888888888889
54685, 0.95652173913044, 1.245652173913, 0.41666666666667
54686, 0.97826086956522, 1.245652173913, 0.44444444444444
54687, 0.95652173913044, 1.2195652173913, 0.44444444444444
