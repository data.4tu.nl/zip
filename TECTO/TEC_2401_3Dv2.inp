79332, 1.9608695652174, 0.016666666666667, 0.11111111111111
79333, 1.9826086956522, 0.033333333333333, 0.11111111111111
79334, 1.9826086956522, 0.016666666666667, 0.083333333333333
79335, 1.9608695652174, 0.016666666666667, 0.055555555555556
79336, 1.9826086956522, 0.033333333333333, 0.055555555555556
79337, 1.9826086956522, 0.016666666666667, 0.027777777777778
79338, 2.0260869565217, 0.016666666666667, 0.47222222222222
79339, 2.004347826087, 0.016666666666667, 0.44444444444444
79340, 2.0260869565217, 0.033333333333333, 0.44444444444444
79341, 2.0260869565217, 0.016666666666667, 0.41666666666667
79342, 2.004347826087, 0.016666666666667, 0.38888888888889
79343, 2.0260869565217, 0.033333333333333, 0.38888888888889
79344, 2.0260869565217, 0.016666666666667, 0.36111111111111
79345, 2.004347826087, 0.016666666666667, 0.33333333333333
79346, 2.0260869565217, 0.033333333333333, 0.33333333333333
79347, 2.0260869565217, 0.016666666666667, 0.30555555555556
79348, 2.004347826087, 0.016666666666667, 0.27777777777778
79349, 2.0260869565217, 0.033333333333333, 0.27777777777778
79350, 2.0260869565217, 0.016666666666667, 0.25
79351, 2.004347826087, 0.016666666666667, 0.22222222222222
79352, 2.0260869565217, 0.033333333333333, 0.22222222222222
79353, 2.0260869565217, 0.016666666666667, 0.19444444444444
79354, 2.004347826087, 0.016666666666667, 0.16666666666667
79355, 2.0260869565217, 0.033333333333333, 0.16666666666667
79356, 2.0260869565217, 0.016666666666667, 0.13888888888889
79357, 2.004347826087, 0.016666666666667, 0.11111111111111
79358, 2.0260869565217, 0.033333333333333, 0.11111111111111
79359, 2.0260869565217, 0.016666666666667, 0.083333333333333
79360, 2.004347826087, 0.016666666666667, 0.055555555555556
79361, 2.0260869565217, 0.033333333333333, 0.055555555555556
79362, 2.0260869565217, 0.016666666666667, 0.027777777777778
79363, 2.0695652173913, 0.016666666666667, 0.47222222222222
79364, 2.0478260869565, 0.016666666666667, 0.44444444444444
79365, 2.0695652173913, 0.033333333333333, 0.44444444444444
79366, 2.0695652173913, 0.016666666666667, 0.41666666666667
79367, 2.0478260869565, 0.016666666666667, 0.38888888888889
79368, 2.0695652173913, 0.033333333333333, 0.38888888888889
79369, 2.0695652173913, 0.016666666666667, 0.36111111111111
79370, 2.0478260869565, 0.016666666666667, 0.33333333333333
79371, 2.0695652173913, 0.033333333333333, 0.33333333333333
79372, 2.0695652173913, 0.016666666666667, 0.30555555555556
79373, 2.0478260869565, 0.016666666666667, 0.27777777777778
79374, 2.0695652173913, 0.033333333333333, 0.27777777777778
79375, 2.0695652173913, 0.016666666666667, 0.25
79376, 2.0478260869565, 0.016666666666667, 0.22222222222222
79377, 2.0695652173913, 0.033333333333333, 0.22222222222222
79378, 2.0695652173913, 0.016666666666667, 0.19444444444444
79379, 2.0478260869565, 0.016666666666667, 0.16666666666667
79380, 2.0695652173913, 0.033333333333333, 0.16666666666667
79381, 2.0695652173913, 0.016666666666667, 0.13888888888889
79382, 2.0478260869565, 0.016666666666667, 0.11111111111111
79383, 2.0695652173913, 0.033333333333333, 0.11111111111111
79384, 2.0695652173913, 0.016666666666667, 0.083333333333333
79385, 2.0478260869565, 0.016666666666667, 0.055555555555556
79386, 2.0695652173913, 0.033333333333333, 0.055555555555556
79387, 2.0695652173913, 0.016666666666667, 0.027777777777778
79388, 2.1130434782609, 0.016666666666667, 0.47222222222222
79389, 2.0913043478261, 0.016666666666667, 0.44444444444444
79390, 2.1130434782609, 0.033333333333333, 0.44444444444444
79391, 2.1130434782609, 0.016666666666667, 0.41666666666667
79392, 2.0913043478261, 0.016666666666667, 0.38888888888889
79393, 2.1130434782609, 0.033333333333333, 0.38888888888889
79394, 2.1130434782609, 0.016666666666667, 0.36111111111111
79395, 2.0913043478261, 0.016666666666667, 0.33333333333333
79396, 2.1130434782609, 0.033333333333333, 0.33333333333333
79397, 2.1130434782609, 0.016666666666667, 0.30555555555556
79398, 2.0913043478261, 0.016666666666667, 0.27777777777778
79399, 2.1130434782609, 0.033333333333333, 0.27777777777778
79400, 2.1130434782609, 0.016666666666667, 0.25
79401, 2.0913043478261, 0.016666666666667, 0.22222222222222
79402, 2.1130434782609, 0.033333333333333, 0.22222222222222
79403, 2.1130434782609, 0.016666666666667, 0.19444444444444
79404, 2.0913043478261, 0.016666666666667, 0.16666666666667
79405, 2.1130434782609, 0.033333333333333, 0.16666666666667
79406, 2.1130434782609, 0.016666666666667, 0.13888888888889
79407, 2.0913043478261, 0.016666666666667, 0.11111111111111
79408, 2.1130434782609, 0.033333333333333, 0.11111111111111
79409, 2.1130434782609, 0.016666666666667, 0.083333333333333
79410, 2.0913043478261, 0.016666666666667, 0.055555555555556
79411, 2.1130434782609, 0.033333333333333, 0.055555555555556
79412, 2.1130434782609, 0.016666666666667, 0.027777777777778
79413, 2.1565217391304, 0.016666666666667, 0.47222222222222
79414, 2.1347826086957, 0.016666666666667, 0.44444444444444
79415, 2.1565217391304, 0.033333333333333, 0.44444444444444
79416, 2.1565217391304, 0.016666666666667, 0.41666666666667
79417, 2.1347826086957, 0.016666666666667, 0.38888888888889
79418, 2.1565217391304, 0.033333333333333, 0.38888888888889
79419, 2.1565217391304, 0.016666666666667, 0.36111111111111
79420, 2.1347826086957, 0.016666666666667, 0.33333333333333
79421, 2.1565217391304, 0.033333333333333, 0.33333333333333
79422, 2.1565217391304, 0.016666666666667, 0.30555555555556
79423, 2.1347826086957, 0.016666666666667, 0.27777777777778
79424, 2.1565217391304, 0.033333333333333, 0.27777777777778
79425, 2.1565217391304, 0.016666666666667, 0.25
79426, 2.1347826086957, 0.016666666666667, 0.22222222222222
79427, 2.1565217391304, 0.033333333333333, 0.22222222222222
79428, 2.1565217391304, 0.016666666666667, 0.19444444444444
79429, 2.1347826086957, 0.016666666666667, 0.16666666666667
79430, 2.1565217391304, 0.033333333333333, 0.16666666666667
79431, 2.1565217391304, 0.016666666666667, 0.13888888888889
79432, 2.1347826086957, 0.016666666666667, 0.11111111111111
79433, 2.1565217391304, 0.033333333333333, 0.11111111111111
79434, 2.1565217391304, 0.016666666666667, 0.083333333333333
79435, 2.1347826086957, 0.016666666666667, 0.055555555555556
79436, 2.1565217391304, 0.033333333333333, 0.055555555555556
79437, 2.1565217391304, 0.016666666666667, 0.027777777777778
79438, 2.1782608695652, 0.016666666666667, 0.44444444444444
79439, 2.1782608695652, 0.016666666666667, 0.38888888888889
79440, 2.1782608695652, 0.016666666666667, 0.33333333333333
79441, 2.1782608695652, 0.016666666666667, 0.27777777777778
79442, 2.1782608695652, 0.016666666666667, 0.22222222222222
79443, 2.1782608695652, 0.016666666666667, 0.16666666666667
79444, 2.1782608695652, 0.016666666666667, 0.11111111111111
79445, 2.1782608695652, 0.016666666666667, 0.055555555555556
79446, 1.2434782608696, -0.016666666666667, 0.47222222222222
79447, 1.2217391304348, -0.016666666666667, 0.44444444444444
79448, 1.2434782608696, -1.0061396160665e-16, 0.44444444444444
79449, 1.2434782608696, -0.016666666666667, 0.41666666666667
79450, 1.2217391304348, -0.016666666666667, 0.38888888888889
79451, 1.2434782608696, -1.0061396160665e-16, 0.38888888888889
79452, 1.2434782608696, -0.016666666666667, 0.36111111111111
79453, 1.2217391304348, -0.016666666666667, 0.33333333333333
79454, 1.2434782608696, -1.1102230246252e-16, 0.33333333333333
79455, 1.2434782608696, -0.016666666666667, 0.30555555555556
79456, 1.2217391304348, -0.016666666666667, 0.27777777777778
79457, 1.2434782608696, -1.0928757898654e-16, 0.27777777777778
79458, 1.2434782608696, -0.016666666666667, 0.25
79459, 1.2217391304348, -0.016666666666667, 0.22222222222222
79460, 1.2434782608696, -1.1275702593849e-16, 0.22222222222222
79461, 1.2434782608696, -0.016666666666667, 0.19444444444444
79462, 1.2217391304348, -0.016666666666667, 0.16666666666667
79463, 1.2434782608696, -1.0755285551056e-16, 0.16666666666667
79464, 1.2434782608696, -0.016666666666667, 0.13888888888889
79465, 1.2217391304348, -0.016666666666667, 0.11111111111111
79466, 1.2434782608696, -1.0928757898654e-16, 0.11111111111111
79467, 1.2434782608696, -0.016666666666667, 0.083333333333333
79468, 1.2217391304348, -0.016666666666667, 0.055555555555556
79469, 1.2434782608696, -1.0581813203459e-16, 0.055555555555556
79470, 1.2434782608696, -0.016666666666667, 0.027777777777778
79471, 1.2869565217391, -0.016666666666667, 0.47222222222222
79472, 1.2652173913043, -0.016666666666667, 0.44444444444444
79473, 1.2869565217391, -8.5001450322864e-17, 0.44444444444444
79474, 1.2869565217391, -0.016666666666667, 0.41666666666667
79475, 1.2652173913043, -0.016666666666667, 0.38888888888889
79476, 1.2869565217391, -9.5409791178724e-17, 0.38888888888889
79477, 1.2869565217391, -0.016666666666667, 0.36111111111111
79478, 1.2652173913043, -0.016666666666667, 0.33333333333333
79479, 1.2869565217391, -1.0234868508263e-16, 0.33333333333333
79480, 1.2869565217391, -0.016666666666667, 0.30555555555556
79481, 1.2652173913043, -0.016666666666667, 0.27777777777778
79482, 1.2869565217391, -1.0061396160665e-16, 0.27777777777778
79483, 1.2869565217391, -0.016666666666667, 0.25
79484, 1.2652173913043, -0.016666666666667, 0.22222222222222
79485, 1.2869565217391, -1.0234868508263e-16, 0.22222222222222
79486, 1.2869565217391, -0.016666666666667, 0.19444444444444
79487, 1.2652173913043, -0.016666666666667, 0.16666666666667
79488, 1.2869565217391, -9.8879238130678e-17, 0.16666666666667
79489, 1.2869565217391, -0.016666666666667, 0.13888888888889
79490, 1.2652173913043, -0.016666666666667, 0.11111111111111
79491, 1.2869565217391, -1.0408340855861e-16, 0.11111111111111
79492, 1.2869565217391, -0.016666666666667, 0.083333333333333
79493, 1.2652173913043, -0.016666666666667, 0.055555555555556
79494, 1.2869565217391, -9.3675067702748e-17, 0.055555555555556
79495, 1.2869565217391, -0.016666666666667, 0.027777777777778
79496, 1.3304347826087, -0.016666666666667, 0.47222222222222
79497, 1.3086956521739, -0.016666666666667, 0.44444444444444
79498, 1.3304347826087, -8.8470897274817e-17, 0.44444444444444
79499, 1.3304347826087, -0.016666666666667, 0.41666666666667
79500, 1.3086956521739, -0.016666666666667, 0.38888888888889
79501, 1.3304347826087, -9.0205620750794e-17, 0.38888888888889
79502, 1.3304347826087, -0.016666666666667, 0.36111111111111
79503, 1.3086956521739, -0.016666666666667, 0.33333333333333
79504, 1.3304347826087, -8.8470897274817e-17, 0.33333333333333
79505, 1.3304347826087, -0.016666666666667, 0.30555555555556
79506, 1.3086956521739, -0.016666666666667, 0.27777777777778
79507, 1.3304347826087, -9.1940344226771e-17, 0.27777777777778
79508, 1.3304347826087, -0.016666666666667, 0.25
79509, 1.3086956521739, -0.016666666666667, 0.22222222222222
79510, 1.3304347826087, -9.0205620750794e-17, 0.22222222222222
79511, 1.3304347826087, -0.016666666666667, 0.19444444444444
79512, 1.3086956521739, -0.016666666666667, 0.16666666666667
79513, 1.3304347826087, -9.1940344226771e-17, 0.16666666666667
79514, 1.3304347826087, -0.016666666666667, 0.13888888888889
79515, 1.3086956521739, -0.016666666666667, 0.11111111111111
79516, 1.3304347826087, -9.0205620750794e-17, 0.11111111111111
79517, 1.3304347826087, -0.016666666666667, 0.083333333333333
79518, 1.3086956521739, -0.016666666666667, 0.055555555555556
79519, 1.3304347826087, -9.0205620750794e-17, 0.055555555555556
79520, 1.3304347826087, -0.016666666666667, 0.027777777777778
79521, 1.3739130434783, -0.016666666666667, 0.47222222222222
79522, 1.3521739130435, -0.016666666666667, 0.44444444444444
79523, 1.3739130434783, -1.0061396160665e-16, 0.44444444444444
79524, 1.3739130434783, -0.016666666666667, 0.41666666666667
79525, 1.3521739130435, -0.016666666666667, 0.38888888888889
79526, 1.3739130434783, -9.8879238130678e-17, 0.38888888888889
79527, 1.3739130434783, -0.016666666666667, 0.36111111111111
79528, 1.3521739130435, -0.016666666666667, 0.33333333333333
79529, 1.3739130434783, -9.8879238130678e-17, 0.33333333333333
79530, 1.3739130434783, -0.016666666666667, 0.30555555555556
79531, 1.3521739130435, -0.016666666666667, 0.27777777777778
79532, 1.3739130434783, -1.0408340855861e-16, 0.27777777777778
79533, 1.3739130434783, -0.016666666666667, 0.25
79534, 1.3521739130435, -0.016666666666667, 0.22222222222222
79535, 1.3739130434783, -1.0408340855861e-16, 0.22222222222222
79536, 1.3739130434783, -0.016666666666667, 0.19444444444444
79537, 1.3521739130435, -0.016666666666667, 0.16666666666667
79538, 1.3739130434783, -1.0234868508263e-16, 0.16666666666667
79539, 1.3739130434783, -0.016666666666667, 0.13888888888889
79540, 1.3521739130435, -0.016666666666667, 0.11111111111111
79541, 1.3739130434783, -1.0408340855861e-16, 0.11111111111111
79542, 1.3739130434783, -0.016666666666667, 0.083333333333333
79543, 1.3521739130435, -0.016666666666667, 0.055555555555556
79544, 1.3739130434783, -1.0061396160665e-16, 0.055555555555556
79545, 1.3739130434783, -0.016666666666667, 0.027777777777778
79546, 1.4173913043478, -0.016666666666667, 0.47222222222222
79547, 1.395652173913, -0.016666666666667, 0.44444444444444
79548, 1.4173913043478, -9.1940344226771e-17, 0.44444444444444
79549, 1.4173913043478, -0.016666666666667, 0.41666666666667
79550, 1.395652173913, -0.016666666666667, 0.38888888888889
79551, 1.4173913043478, -7.9797279894933e-17, 0.38888888888889
79552, 1.4173913043478, -0.016666666666667, 0.36111111111111
79553, 1.395652173913, -0.016666666666667, 0.33333333333333
79554, 1.4173913043478, -9.1940344226771e-17, 0.33333333333333
79555, 1.4173913043478, -0.016666666666667, 0.30555555555556
79556, 1.395652173913, -0.016666666666667, 0.27777777777778
79557, 1.4173913043478, -8.5001450322864e-17, 0.27777777777778
79558, 1.4173913043478, -0.016666666666667, 0.25
79559, 1.395652173913, -0.016666666666667, 0.22222222222222
79560, 1.4173913043478, -8.673617379884e-17, 0.22222222222222
79561, 1.4173913043478, -0.016666666666667, 0.19444444444444
79562, 1.395652173913, -0.016666666666667, 0.16666666666667
79563, 1.4173913043478, -8.673617379884e-17, 0.16666666666667
79564, 1.4173913043478, -0.016666666666667, 0.13888888888889
79565, 1.395652173913, -0.016666666666667, 0.11111111111111
79566, 1.4173913043478, -8.5001450322864e-17, 0.11111111111111
79567, 1.4173913043478, -0.016666666666667, 0.083333333333333
79568, 1.395652173913, -0.016666666666667, 0.055555555555556
79569, 1.4173913043478, -9.1940344226771e-17, 0.055555555555556
79570, 1.4173913043478, -0.016666666666667, 0.027777777777778
79571, 1.4608695652174, -0.016666666666667, 0.47222222222222
79572, 1.4391304347826, -0.016666666666667, 0.44444444444444
79573, 1.4608695652174, -7.4593109467003e-17, 0.44444444444444
79574, 1.4608695652174, -0.016666666666667, 0.41666666666667
79575, 1.4391304347826, -0.016666666666667, 0.38888888888889
79576, 1.4608695652174, -7.8062556418956e-17, 0.38888888888889
79577, 1.4608695652174, -0.016666666666667, 0.36111111111111
79578, 1.4391304347826, -0.016666666666667, 0.33333333333333
79579, 1.4608695652174, -8.5001450322864e-17, 0.33333333333333
79580, 1.4608695652174, -0.016666666666667, 0.30555555555556
79581, 1.4391304347826, -0.016666666666667, 0.27777777777778
79582, 1.4608695652174, -8.3266726846887e-17, 0.27777777777778
79583, 1.4608695652174, -0.016666666666667, 0.25
79584, 1.4391304347826, -0.016666666666667, 0.22222222222222
79585, 1.4608695652174, -7.8062556418956e-17, 0.22222222222222
79586, 1.4608695652174, -0.016666666666667, 0.19444444444444
79587, 1.4391304347826, -0.016666666666667, 0.16666666666667
79588, 1.4608695652174, -7.8062556418956e-17, 0.16666666666667
79589, 1.4608695652174, -0.016666666666667, 0.13888888888889
79590, 1.4391304347826, -0.016666666666667, 0.11111111111111
79591, 1.4608695652174, -7.8062556418956e-17, 0.11111111111111
79592, 1.4608695652174, -0.016666666666667, 0.083333333333333
79593, 1.4391304347826, -0.016666666666667, 0.055555555555556
79594, 1.4608695652174, -6.9388939039072e-17, 0.055555555555556
79595, 1.4608695652174, -0.016666666666667, 0.027777777777778
79596, 1.504347826087, -0.016666666666667, 0.47222222222222
79597, 1.4826086956522, -0.016666666666667, 0.44444444444444
79598, 1.504347826087, -7.2858385991026e-17, 0.44444444444444
79599, 1.504347826087, -0.016666666666667, 0.41666666666667
79600, 1.4826086956522, -0.016666666666667, 0.38888888888889
79601, 1.504347826087, -7.2858385991026e-17, 0.38888888888889
79602, 1.504347826087, -0.016666666666667, 0.36111111111111
79603, 1.4826086956522, -0.016666666666667, 0.33333333333333
79604, 1.504347826087, -8.5001450322864e-17, 0.33333333333333
79605, 1.504347826087, -0.016666666666667, 0.30555555555556
79606, 1.4826086956522, -0.016666666666667, 0.27777777777778
79607, 1.504347826087, -8.3266726846887e-17, 0.27777777777778
79608, 1.504347826087, -0.016666666666667, 0.25
79609, 1.4826086956522, -0.016666666666667, 0.22222222222222
79610, 1.504347826087, -7.632783294298e-17, 0.22222222222222
79611, 1.504347826087, -0.016666666666667, 0.19444444444444
79612, 1.4826086956522, -0.016666666666667, 0.16666666666667
79613, 1.504347826087, -7.9797279894933e-17, 0.16666666666667
79614, 1.504347826087, -0.016666666666667, 0.13888888888889
79615, 1.4826086956522, -0.016666666666667, 0.11111111111111
79616, 1.504347826087, -8.153200337091e-17, 0.11111111111111
79617, 1.504347826087, -0.016666666666667, 0.083333333333333
79618, 1.4826086956522, -0.016666666666667, 0.055555555555556
79619, 1.504347826087, -7.1123662515049e-17, 0.055555555555556
79620, 1.504347826087, -0.016666666666667, 0.027777777777778
79621, 1.5478260869565, -0.016666666666667, 0.47222222222222
79622, 1.5260869565217, -0.016666666666667, 0.44444444444444
79623, 1.5478260869565, -9.7144514654701e-17, 0.44444444444444
79624, 1.5478260869565, -0.016666666666667, 0.41666666666667
79625, 1.5260869565217, -0.016666666666667, 0.38888888888889
79626, 1.5478260869565, -9.0205620750794e-17, 0.38888888888889
79627, 1.5478260869565, -0.016666666666667, 0.36111111111111
79628, 1.5260869565217, -0.016666666666667, 0.33333333333333
79629, 1.5478260869565, -9.8879238130678e-17, 0.33333333333333
79630, 1.5478260869565, -0.016666666666667, 0.30555555555556
79631, 1.5260869565217, -0.016666666666667, 0.27777777777778
79632, 1.5478260869565, -9.5409791178724e-17, 0.27777777777778
79633, 1.5478260869565, -0.016666666666667, 0.25
79634, 1.5260869565217, -0.016666666666667, 0.22222222222222
79635, 1.5478260869565, -9.5409791178724e-17, 0.22222222222222
79636, 1.5478260869565, -0.016666666666667, 0.19444444444444
79637, 1.5260869565217, -0.016666666666667, 0.16666666666667
79638, 1.5478260869565, -9.3675067702748e-17, 0.16666666666667
79639, 1.5478260869565, -0.016666666666667, 0.13888888888889
79640, 1.5260869565217, -0.016666666666667, 0.11111111111111
79641, 1.5478260869565, -1.0061396160665e-16, 0.11111111111111
79642, 1.5478260869565, -0.016666666666667, 0.083333333333333
79643, 1.5260869565217, -0.016666666666667, 0.055555555555556
79644, 1.5478260869565, -9.1940344226771e-17, 0.055555555555556
79645, 1.5478260869565, -0.016666666666667, 0.027777777777778
79646, 1.5913043478261, -0.016666666666667, 0.47222222222222
79647, 1.5695652173913, -0.016666666666667, 0.44444444444444
79648, 1.5913043478261, -7.4593109467003e-17, 0.44444444444444
79649, 1.5913043478261, -0.016666666666667, 0.41666666666667
79650, 1.5695652173913, -0.016666666666667, 0.38888888888889
79651, 1.5913043478261, -7.2858385991026e-17, 0.38888888888889
79652, 1.5913043478261, -0.016666666666667, 0.36111111111111
79653, 1.5695652173913, -0.016666666666667, 0.33333333333333
79654, 1.5913043478261, -8.8470897274817e-17, 0.33333333333333
79655, 1.5913043478261, -0.016666666666667, 0.30555555555556
79656, 1.5695652173913, -0.016666666666667, 0.27777777777778
79657, 1.5913043478261, -8.3266726846887e-17, 0.27777777777778
79658, 1.5913043478261, -0.016666666666667, 0.25
79659, 1.5695652173913, -0.016666666666667, 0.22222222222222
79660, 1.5913043478261, -8.3266726846887e-17, 0.22222222222222
79661, 1.5913043478261, -0.016666666666667, 0.19444444444444
79662, 1.5695652173913, -0.016666666666667, 0.16666666666667
79663, 1.5913043478261, -8.673617379884e-17, 0.16666666666667
79664, 1.5913043478261, -0.016666666666667, 0.13888888888889
79665, 1.5695652173913, -0.016666666666667, 0.11111111111111
79666, 1.5913043478261, -8.673617379884e-17, 0.11111111111111
79667, 1.5913043478261, -0.016666666666667, 0.083333333333333
79668, 1.5695652173913, -0.016666666666667, 0.055555555555556
79669, 1.5913043478261, -7.4593109467003e-17, 0.055555555555556
79670, 1.5913043478261, -0.016666666666667, 0.027777777777778
79671, 1.6347826086957, -0.016666666666667, 0.47222222222222
79672, 1.6130434782609, -0.016666666666667, 0.44444444444444
79673, 1.6347826086957, -8.673617379884e-17, 0.44444444444444
79674, 1.6347826086957, -0.016666666666667, 0.41666666666667
79675, 1.6130434782609, -0.016666666666667, 0.38888888888889
79676, 1.6347826086957, -8.3266726846887e-17, 0.38888888888889
79677, 1.6347826086957, -0.016666666666667, 0.36111111111111
79678, 1.6130434782609, -0.016666666666667, 0.33333333333333
79679, 1.6347826086957, -9.0205620750794e-17, 0.33333333333333
79680, 1.6347826086957, -0.016666666666667, 0.30555555555556
79681, 1.6130434782609, -0.016666666666667, 0.27777777777778
79682, 1.6347826086957, -9.0205620750794e-17, 0.27777777777778
79683, 1.6347826086957, -0.016666666666667, 0.25
79684, 1.6130434782609, -0.016666666666667, 0.22222222222222
79685, 1.6347826086957, -8.8470897274817e-17, 0.22222222222222
79686, 1.6347826086957, -0.016666666666667, 0.19444444444444
79687, 1.6130434782609, -0.016666666666667, 0.16666666666667
79688, 1.6347826086957, -8.8470897274817e-17, 0.16666666666667
79689, 1.6347826086957, -0.016666666666667, 0.13888888888889
79690, 1.6130434782609, -0.016666666666667, 0.11111111111111
79691, 1.6347826086957, -8.8470897274817e-17, 0.11111111111111
79692, 1.6347826086957, -0.016666666666667, 0.083333333333333
79693, 1.6130434782609, -0.016666666666667, 0.055555555555556
79694, 1.6347826086957, -8.5001450322864e-17, 0.055555555555556
79695, 1.6347826086957, -0.016666666666667, 0.027777777777778
79696, 1.6782608695652, -0.016666666666667, 0.47222222222222
79697, 1.6565217391304, -0.016666666666667, 0.44444444444444
79698, 1.6782608695652, -8.153200337091e-17, 0.44444444444444
79699, 1.6782608695652, -0.016666666666667, 0.41666666666667
79700, 1.6565217391304, -0.016666666666667, 0.38888888888889
79701, 1.6782608695652, -8.5001450322864e-17, 0.38888888888889
79702, 1.6782608695652, -0.016666666666667, 0.36111111111111
79703, 1.6565217391304, -0.016666666666667, 0.33333333333333
79704, 1.6782608695652, -8.673617379884e-17, 0.33333333333333
79705, 1.6782608695652, -0.016666666666667, 0.30555555555556
79706, 1.6565217391304, -0.016666666666667, 0.27777777777778
79707, 1.6782608695652, -9.1940344226771e-17, 0.27777777777778
79708, 1.6782608695652, -0.016666666666667, 0.25
79709, 1.6565217391304, -0.016666666666667, 0.22222222222222
79710, 1.6782608695652, -8.673617379884e-17, 0.22222222222222
79711, 1.6782608695652, -0.016666666666667, 0.19444444444444
79712, 1.6565217391304, -0.016666666666667, 0.16666666666667
79713, 1.6782608695652, -8.8470897274817e-17, 0.16666666666667
79714, 1.6782608695652, -0.016666666666667, 0.13888888888889
79715, 1.6565217391304, -0.016666666666667, 0.11111111111111
79716, 1.6782608695652, -8.8470897274817e-17, 0.11111111111111
79717, 1.6782608695652, -0.016666666666667, 0.083333333333333
79718, 1.6565217391304, -0.016666666666667, 0.055555555555556
79719, 1.6782608695652, -8.153200337091e-17, 0.055555555555556
79720, 1.6782608695652, -0.016666666666667, 0.027777777777778
79721, 1.7217391304348, -0.016666666666667, 0.47222222222222
79722, 1.7, -0.016666666666667, 0.44444444444444
79723, 1.7217391304348, -7.4593109467003e-17, 0.44444444444444
79724, 1.7217391304348, -0.016666666666667, 0.41666666666667
79725, 1.7, -0.016666666666667, 0.38888888888889
79726, 1.7217391304348, -8.153200337091e-17, 0.38888888888889
79727, 1.7217391304348, -0.016666666666667, 0.36111111111111
79728, 1.7, -0.016666666666667, 0.33333333333333
79729, 1.7217391304348, -9.0205620750794e-17, 0.33333333333333
79730, 1.7217391304348, -0.016666666666667, 0.30555555555556
79731, 1.7, -0.016666666666667, 0.27777777777778
79732, 1.7217391304348, -8.5001450322864e-17, 0.27777777777778
79733, 1.7217391304348, -0.016666666666667, 0.25
79734, 1.7, -0.016666666666667, 0.22222222222222
79735, 1.7217391304348, -8.673617379884e-17, 0.22222222222222
79736, 1.7217391304348, -0.016666666666667, 0.19444444444444
79737, 1.7, -0.016666666666667, 0.16666666666667
79738, 1.7217391304348, -8.673617379884e-17, 0.16666666666667
79739, 1.7217391304348, -0.016666666666667, 0.13888888888889
79740, 1.7, -0.016666666666667, 0.11111111111111
79741, 1.7217391304348, -8.673617379884e-17, 0.11111111111111
79742, 1.7217391304348, -0.016666666666667, 0.083333333333333
79743, 1.7, -0.016666666666667, 0.055555555555556
79744, 1.7217391304348, -7.8062556418956e-17, 0.055555555555556
79745, 1.7217391304348, -0.016666666666667, 0.027777777777778
79746, 1.7652173913043, -0.016666666666667, 0.47222222222222
79747, 1.7434782608696, -0.016666666666667, 0.44444444444444
79748, 1.7652173913043, -6.9388939039072e-17, 0.44444444444444
79749, 1.7652173913043, -0.016666666666667, 0.41666666666667
79750, 1.7434782608696, -0.016666666666667, 0.38888888888889
79751, 1.7652173913043, -6.9388939039072e-17, 0.38888888888889
79752, 1.7652173913043, -0.016666666666667, 0.36111111111111
79753, 1.7434782608696, -0.016666666666667, 0.33333333333333
79754, 1.7652173913043, -7.1123662515049e-17, 0.33333333333333
79755, 1.7652173913043, -0.016666666666667, 0.30555555555556
79756, 1.7434782608696, -0.016666666666667, 0.27777777777778
79757, 1.7652173913043, -7.2858385991026e-17, 0.27777777777778
79758, 1.7652173913043, -0.016666666666667, 0.25
79759, 1.7434782608696, -0.016666666666667, 0.22222222222222
79760, 1.7652173913043, -7.2858385991026e-17, 0.22222222222222
79761, 1.7652173913043, -0.016666666666667, 0.19444444444444
79762, 1.7434782608696, -0.016666666666667, 0.16666666666667
79763, 1.7652173913043, -7.2858385991026e-17, 0.16666666666667
79764, 1.7652173913043, -0.016666666666667, 0.13888888888889
79765, 1.7434782608696, -0.016666666666667, 0.11111111111111
79766, 1.7652173913043, -7.4593109467003e-17, 0.11111111111111
79767, 1.7652173913043, -0.016666666666667, 0.083333333333333
79768, 1.7434782608696, -0.016666666666667, 0.055555555555556
79769, 1.7652173913043, -6.9388939039072e-17, 0.055555555555556
79770, 1.7652173913043, -0.016666666666667, 0.027777777777778
79771, 1.8086956521739, -0.016666666666667, 0.47222222222222
79772, 1.7869565217391, -0.016666666666667, 0.44444444444444
79773, 1.8086956521739, -5.0306980803327e-17, 0.44444444444444
79774, 1.8086956521739, -0.016666666666667, 0.41666666666667
79775, 1.7869565217391, -0.016666666666667, 0.38888888888889
79776, 1.8086956521739, -5.5511151231258e-17, 0.38888888888889
79777, 1.8086956521739, -0.016666666666667, 0.36111111111111
79778, 1.7869565217391, -0.016666666666667, 0.33333333333333
79779, 1.8086956521739, -5.8980598183211e-17, 0.33333333333333
79780, 1.8086956521739, -0.016666666666667, 0.30555555555556
79781, 1.7869565217391, -0.016666666666667, 0.27777777777778
79782, 1.8086956521739, -5.8980598183211e-17, 0.27777777777778
79783, 1.8086956521739, -0.016666666666667, 0.25
79784, 1.7869565217391, -0.016666666666667, 0.22222222222222
79785, 1.8086956521739, -5.5511151231258e-17, 0.22222222222222
79786, 1.8086956521739, -0.016666666666667, 0.19444444444444
79787, 1.7869565217391, -0.016666666666667, 0.16666666666667
79788, 1.8086956521739, -5.5511151231258e-17, 0.16666666666667
79789, 1.8086956521739, -0.016666666666667, 0.13888888888889
79790, 1.7869565217391, -0.016666666666667, 0.11111111111111
79791, 1.8086956521739, -6.2450045135165e-17, 0.11111111111111
79792, 1.8086956521739, -0.016666666666667, 0.083333333333333
79793, 1.7869565217391, -0.016666666666667, 0.055555555555556
79794, 1.8086956521739, -5.0306980803327e-17, 0.055555555555556
79795, 1.8086956521739, -0.016666666666667, 0.027777777777778
79796, 1.8521739130435, -0.016666666666667, 0.47222222222222
79797, 1.8304347826087, -0.016666666666667, 0.44444444444444
79798, 1.8521739130435, -6.4184768611142e-17, 0.44444444444444
79799, 1.8521739130435, -0.016666666666667, 0.41666666666667
79800, 1.8304347826087, -0.016666666666667, 0.38888888888889
79801, 1.8521739130435, -6.5919492087119e-17, 0.38888888888889
79802, 1.8521739130435, -0.016666666666667, 0.36111111111111
79803, 1.8304347826087, -0.016666666666667, 0.33333333333333
79804, 1.8521739130435, -6.7654215563095e-17, 0.33333333333333
79805, 1.8521739130435, -0.016666666666667, 0.30555555555556
79806, 1.8304347826087, -0.016666666666667, 0.27777777777778
79807, 1.8521739130435, -6.9388939039072e-17, 0.27777777777778
79808, 1.8521739130435, -0.016666666666667, 0.25
79809, 1.8304347826087, -0.016666666666667, 0.22222222222222
79810, 1.8521739130435, -6.9388939039072e-17, 0.22222222222222
79811, 1.8521739130435, -0.016666666666667, 0.19444444444444
79812, 1.8304347826087, -0.016666666666667, 0.16666666666667
79813, 1.8521739130435, -6.9388939039072e-17, 0.16666666666667
79814, 1.8521739130435, -0.016666666666667, 0.13888888888889
79815, 1.8304347826087, -0.016666666666667, 0.11111111111111
79816, 1.8521739130435, -7.1123662515049e-17, 0.11111111111111
79817, 1.8521739130435, -0.016666666666667, 0.083333333333333
79818, 1.8304347826087, -0.016666666666667, 0.055555555555556
79819, 1.8521739130435, -6.4184768611142e-17, 0.055555555555556
79820, 1.8521739130435, -0.016666666666667, 0.027777777777778
79821, 1.895652173913, -0.016666666666667, 0.47222222222222
79822, 1.8739130434783, -0.016666666666667, 0.44444444444444
79823, 1.895652173913, -6.2450045135165e-17, 0.44444444444444
79824, 1.895652173913, -0.016666666666667, 0.41666666666667
79825, 1.8739130434783, -0.016666666666667, 0.38888888888889
79826, 1.895652173913, -6.5919492087119e-17, 0.38888888888889
79827, 1.895652173913, -0.016666666666667, 0.36111111111111
79828, 1.8739130434783, -0.016666666666667, 0.33333333333333
79829, 1.895652173913, -6.9388939039072e-17, 0.33333333333333
79830, 1.895652173913, -0.016666666666667, 0.30555555555556
79831, 1.8739130434783, -0.016666666666667, 0.27777777777778
79832, 1.895652173913, -6.9388939039072e-17, 0.27777777777778
79833, 1.895652173913, -0.016666666666667, 0.25
79834, 1.8739130434783, -0.016666666666667, 0.22222222222222
79835, 1.895652173913, -6.5919492087119e-17, 0.22222222222222
79836, 1.895652173913, -0.016666666666667, 0.19444444444444
79837, 1.8739130434783, -0.016666666666667, 0.16666666666667
79838, 1.895652173913, -6.7654215563095e-17, 0.16666666666667
79839, 1.895652173913, -0.016666666666667, 0.13888888888889
79840, 1.8739130434783, -0.016666666666667, 0.11111111111111
79841, 1.895652173913, -7.1123662515049e-17, 0.11111111111111
79842, 1.895652173913, -0.016666666666667, 0.083333333333333
79843, 1.8739130434783, -0.016666666666667, 0.055555555555556
79844, 1.895652173913, -6.4184768611142e-17, 0.055555555555556
79845, 1.895652173913, -0.016666666666667, 0.027777777777778
79846, 1.9391304347826, -0.016666666666667, 0.47222222222222
79847, 1.9173913043478, -0.016666666666667, 0.44444444444444
79848, 1.9391304347826, -4.336808689942e-17, 0.44444444444444
79849, 1.9391304347826, -0.016666666666667, 0.41666666666667
79850, 1.9173913043478, -0.016666666666667, 0.38888888888889
79851, 1.9391304347826, -4.1633363423443e-17, 0.38888888888889
79852, 1.9391304347826, -0.016666666666667, 0.36111111111111
79853, 1.9173913043478, -0.016666666666667, 0.33333333333333
79854, 1.9391304347826, -4.8572257327351e-17, 0.33333333333333
79855, 1.9391304347826, -0.016666666666667, 0.30555555555556
79856, 1.9173913043478, -0.016666666666667, 0.27777777777778
79857, 1.9391304347826, -4.6837533851374e-17, 0.27777777777778
79858, 1.9391304347826, -0.016666666666667, 0.25
79859, 1.9173913043478, -0.016666666666667, 0.22222222222222
79860, 1.9391304347826, -4.336808689942e-17, 0.22222222222222
79861, 1.9391304347826, -0.016666666666667, 0.19444444444444
79862, 1.9173913043478, -0.016666666666667, 0.16666666666667
79863, 1.9391304347826, -4.5102810375397e-17, 0.16666666666667
79864, 1.9391304347826, -0.016666666666667, 0.13888888888889
79865, 1.9173913043478, -0.016666666666667, 0.11111111111111
79866, 1.9391304347826, -4.336808689942e-17, 0.11111111111111
79867, 1.9391304347826, -0.016666666666667, 0.083333333333333
79868, 1.9173913043478, -0.016666666666667, 0.055555555555556
79869, 1.9391304347826, -4.1633363423443e-17, 0.055555555555556
79870, 1.9391304347826, -0.016666666666667, 0.027777777777778
79871, 1.9826086956522, -0.016666666666667, 0.47222222222222
79872, 1.9608695652174, -0.016666666666667, 0.44444444444444
79873, 1.9826086956522, -5.0306980803327e-17, 0.44444444444444
79874, 1.9826086956522, -0.016666666666667, 0.41666666666667
79875, 1.9608695652174, -0.016666666666667, 0.38888888888889
79876, 1.9826086956522, -5.0306980803327e-17, 0.38888888888889
79877, 1.9826086956522, -0.016666666666667, 0.36111111111111
79878, 1.9608695652174, -0.016666666666667, 0.33333333333333
79879, 1.9826086956522, -5.5511151231258e-17, 0.33333333333333
79880, 1.9826086956522, -0.016666666666667, 0.30555555555556
79881, 1.9608695652174, -0.016666666666667, 0.27777777777778
79882, 1.9826086956522, -5.3776427755281e-17, 0.27777777777778
79883, 1.9826086956522, -0.016666666666667, 0.25
79884, 1.9608695652174, -0.016666666666667, 0.22222222222222
79885, 1.9826086956522, -5.7245874707235e-17, 0.22222222222222
79886, 1.9826086956522, -0.016666666666667, 0.19444444444444
79887, 1.9608695652174, -0.016666666666667, 0.16666666666667
79888, 1.9826086956522, -5.7245874707235e-17, 0.16666666666667
79889, 1.9826086956522, -0.016666666666667, 0.13888888888889
79890, 1.9608695652174, -0.016666666666667, 0.11111111111111
79891, 1.9826086956522, -5.8980598183211e-17, 0.11111111111111
79892, 1.9826086956522, -0.016666666666667, 0.083333333333333
79893, 1.9608695652174, -0.016666666666667, 0.055555555555556
79894, 1.9826086956522, -5.2041704279304e-17, 0.055555555555556
79895, 1.9826086956522, -0.016666666666667, 0.027777777777778
79896, 2.0260869565217, -0.016666666666667, 0.47222222222222
79897, 2.004347826087, -0.016666666666667, 0.44444444444444
79898, 2.0260869565217, -3.6429192995513e-17, 0.44444444444444
79899, 2.0260869565217, -0.016666666666667, 0.41666666666667
79900, 2.004347826087, -0.016666666666667, 0.38888888888889
79901, 2.0260869565217, -4.6837533851374e-17, 0.38888888888889
79902, 2.0260869565217, -0.016666666666667, 0.36111111111111
79903, 2.004347826087, -0.016666666666667, 0.33333333333333
79904, 2.0260869565217, -4.5102810375397e-17, 0.33333333333333
79905, 2.0260869565217, -0.016666666666667, 0.30555555555556
79906, 2.004347826087, -0.016666666666667, 0.27777777777778
79907, 2.0260869565217, -4.6837533851374e-17, 0.27777777777778
79908, 2.0260869565217, -0.016666666666667, 0.25
79909, 2.004347826087, -0.016666666666667, 0.22222222222222
79910, 2.0260869565217, -4.6837533851374e-17, 0.22222222222222
79911, 2.0260869565217, -0.016666666666667, 0.19444444444444
79912, 2.004347826087, -0.016666666666667, 0.16666666666667
79913, 2.0260869565217, -4.5102810375397e-17, 0.16666666666667
79914, 2.0260869565217, -0.016666666666667, 0.13888888888889
79915, 2.004347826087, -0.016666666666667, 0.11111111111111
79916, 2.0260869565217, -4.5102810375397e-17, 0.11111111111111
79917, 2.0260869565217, -0.016666666666667, 0.083333333333333
79918, 2.004347826087, -0.016666666666667, 0.055555555555556
79919, 2.0260869565217, -3.6429192995513e-17, 0.055555555555556
79920, 2.0260869565217, -0.016666666666667, 0.027777777777778
79921, 2.0695652173913, -0.016666666666667, 0.47222222222222
79922, 2.0478260869565, -0.016666666666667, 0.44444444444444
79923, 2.0695652173913, -4.336808689942e-17, 0.44444444444444
79924, 2.0695652173913, -0.016666666666667, 0.41666666666667
79925, 2.0478260869565, -0.016666666666667, 0.38888888888889
79926, 2.0695652173913, -5.0306980803327e-17, 0.38888888888889
79927, 2.0695652173913, -0.016666666666667, 0.36111111111111
79928, 2.0478260869565, -0.016666666666667, 0.33333333333333
79929, 2.0695652173913, -5.7245874707235e-17, 0.33333333333333
79930, 2.0695652173913, -0.016666666666667, 0.30555555555556
79931, 2.0478260869565, -0.016666666666667, 0.27777777777778
79932, 2.0695652173913, -4.6837533851374e-17, 0.27777777777778
79933, 2.0695652173913, -0.016666666666667, 0.25
79934, 2.0478260869565, -0.016666666666667, 0.22222222222222
79935, 2.0695652173913, -5.2041704279304e-17, 0.22222222222222
79936, 2.0695652173913, -0.016666666666667, 0.19444444444444
79937, 2.0478260869565, -0.016666666666667, 0.16666666666667
79938, 2.0695652173913, -5.2041704279304e-17, 0.16666666666667
79939, 2.0695652173913, -0.016666666666667, 0.13888888888889
79940, 2.0478260869565, -0.016666666666667, 0.11111111111111
79941, 2.0695652173913, -5.3776427755281e-17, 0.11111111111111
79942, 2.0695652173913, -0.016666666666667, 0.083333333333333
79943, 2.0478260869565, -0.016666666666667, 0.055555555555556
79944, 2.0695652173913, -4.6837533851374e-17, 0.055555555555556
79945, 2.0695652173913, -0.016666666666667, 0.027777777777778
79946, 2.1130434782609, -0.016666666666667, 0.47222222222222
79947, 2.0913043478261, -0.016666666666667, 0.44444444444444
79948, 2.1130434782609, -3.1225022567583e-17, 0.44444444444444
79949, 2.1130434782609, -0.016666666666667, 0.41666666666667
79950, 2.0913043478261, -0.016666666666667, 0.38888888888889
79951, 2.1130434782609, -3.816391647149e-17, 0.38888888888889
79952, 2.1130434782609, -0.016666666666667, 0.36111111111111
79953, 2.0913043478261, -0.016666666666667, 0.33333333333333
79954, 2.1130434782609, -4.1633363423443e-17, 0.33333333333333
79955, 2.1130434782609, -0.016666666666667, 0.30555555555556
79956, 2.0913043478261, -0.016666666666667, 0.27777777777778
79957, 2.1130434782609, -4.6837533851374e-17, 0.27777777777778
79958, 2.1130434782609, -0.016666666666667, 0.25
79959, 2.0913043478261, -0.016666666666667, 0.22222222222222
79960, 2.1130434782609, -3.6429192995513e-17, 0.22222222222222
79961, 2.1130434782609, -0.016666666666667, 0.19444444444444
79962, 2.0913043478261, -0.016666666666667, 0.16666666666667
79963, 2.1130434782609, -3.4694469519536e-17, 0.16666666666667
79964, 2.1130434782609, -0.016666666666667, 0.13888888888889
79965, 2.0913043478261, -0.016666666666667, 0.11111111111111
79966, 2.1130434782609, -3.9898639947467e-17, 0.11111111111111
79967, 2.1130434782609, -0.016666666666667, 0.083333333333333
79968, 2.0913043478261, -0.016666666666667, 0.055555555555556
79969, 2.1130434782609, -3.1225022567583e-17, 0.055555555555556
79970, 2.1130434782609, -0.016666666666667, 0.027777777777778
79971, 2.1565217391304, -0.016666666666667, 0.47222222222222
79972, 2.1347826086957, -0.016666666666667, 0.44444444444444
79973, 2.1565217391304, -3.816391647149e-17, 0.44444444444444
79974, 2.1565217391304, -0.016666666666667, 0.41666666666667
79975, 2.1347826086957, -0.016666666666667, 0.38888888888889
79976, 2.1565217391304, -4.5102810375397e-17, 0.38888888888889
79977, 2.1565217391304, -0.016666666666667, 0.36111111111111
79978, 2.1347826086957, -0.016666666666667, 0.33333333333333
79979, 2.1565217391304, -4.336808689942e-17, 0.33333333333333
79980, 2.1565217391304, -0.016666666666667, 0.30555555555556
79981, 2.1347826086957, -0.016666666666667, 0.27777777777778
79982, 2.1565217391304, -4.5102810375397e-17, 0.27777777777778
79983, 2.1565217391304, -0.016666666666667, 0.25
79984, 2.1347826086957, -0.016666666666667, 0.22222222222222
79985, 2.1565217391304, -4.5102810375397e-17, 0.22222222222222
79986, 2.1565217391304, -0.016666666666667, 0.19444444444444
79987, 2.1347826086957, -0.016666666666667, 0.16666666666667
79988, 2.1565217391304, -4.336808689942e-17, 0.16666666666667
79989, 2.1565217391304, -0.016666666666667, 0.13888888888889
79990, 2.1347826086957, -0.016666666666667, 0.11111111111111
79991, 2.1565217391304, -5.0306980803327e-17, 0.11111111111111
79992, 2.1565217391304, -0.016666666666667, 0.083333333333333
79993, 2.1347826086957, -0.016666666666667, 0.055555555555556
79994, 2.1565217391304, -3.6429192995513e-17, 0.055555555555556
79995, 2.1565217391304, -0.016666666666667, 0.027777777777778
79996, 2.1782608695652, -0.016666666666667, 0.44444444444444
79997, 2.1782608695652, -0.016666666666667, 0.38888888888889
79998, 2.1782608695652, -0.016666666666667, 0.33333333333333
79999, 2.1782608695652, -0.016666666666667, 0.27777777777778
80000, 2.1782608695652, -0.016666666666667, 0.22222222222222
80001, 2.1782608695652, -0.016666666666667, 0.16666666666667
80002, 2.1782608695652, -0.016666666666667, 0.11111111111111
80003, 2.1782608695652, -0.016666666666667, 0.055555555555556
80004, 1.2434782608696, -0.033333333333333, 0.44444444444444
80005, 1.2434782608696, -0.033333333333333, 0.38888888888889
80006, 1.2434782608696, -0.033333333333333, 0.33333333333333
80007, 1.2434782608696, -0.033333333333333, 0.27777777777778
80008, 1.2434782608696, -0.033333333333333, 0.22222222222222
80009, 1.2434782608696, -0.033333333333333, 0.16666666666667
80010, 1.2434782608696, -0.033333333333333, 0.11111111111111
80011, 1.2434782608696, -0.033333333333333, 0.055555555555556
80012, 1.2869565217391, -0.033333333333333, 0.44444444444444
80013, 1.2869565217391, -0.033333333333333, 0.38888888888889
80014, 1.2869565217391, -0.033333333333333, 0.33333333333333
80015, 1.2869565217391, -0.033333333333333, 0.27777777777778
80016, 1.2869565217391, -0.033333333333333, 0.22222222222222
80017, 1.2869565217391, -0.033333333333333, 0.16666666666667
80018, 1.2869565217391, -0.033333333333333, 0.11111111111111
80019, 1.2869565217391, -0.033333333333333, 0.055555555555556
80020, 1.3304347826087, -0.033333333333333, 0.44444444444444
80021, 1.3304347826087, -0.033333333333333, 0.38888888888889
80022, 1.3304347826087, -0.033333333333333, 0.33333333333333
80023, 1.3304347826087, -0.033333333333333, 0.27777777777778
80024, 1.3304347826087, -0.033333333333333, 0.22222222222222
80025, 1.3304347826087, -0.033333333333333, 0.16666666666667
80026, 1.3304347826087, -0.033333333333333, 0.11111111111111
80027, 1.3304347826087, -0.033333333333333, 0.055555555555556
80028, 1.3739130434783, -0.033333333333333, 0.44444444444444
80029, 1.3739130434783, -0.033333333333333, 0.38888888888889
80030, 1.3739130434783, -0.033333333333333, 0.33333333333333
80031, 1.3739130434783, -0.033333333333333, 0.27777777777778
80032, 1.3739130434783, -0.033333333333333, 0.22222222222222
80033, 1.3739130434783, -0.033333333333333, 0.16666666666667
80034, 1.3739130434783, -0.033333333333333, 0.11111111111111
80035, 1.3739130434783, -0.033333333333333, 0.055555555555556
80036, 1.4173913043478, -0.033333333333333, 0.44444444444444
80037, 1.4173913043478, -0.033333333333333, 0.38888888888889
80038, 1.4173913043478, -0.033333333333333, 0.33333333333333
80039, 1.4173913043478, -0.033333333333333, 0.27777777777778
80040, 1.4173913043478, -0.033333333333333, 0.22222222222222
80041, 1.4173913043478, -0.033333333333333, 0.16666666666667
80042, 1.4173913043478, -0.033333333333333, 0.11111111111111
80043, 1.4173913043478, -0.033333333333333, 0.055555555555556
80044, 1.4608695652174, -0.033333333333333, 0.44444444444444
80045, 1.4608695652174, -0.033333333333333, 0.38888888888889
80046, 1.4608695652174, -0.033333333333333, 0.33333333333333
80047, 1.4608695652174, -0.033333333333333, 0.27777777777778
80048, 1.4608695652174, -0.033333333333333, 0.22222222222222
80049, 1.4608695652174, -0.033333333333333, 0.16666666666667
80050, 1.4608695652174, -0.033333333333333, 0.11111111111111
80051, 1.4608695652174, -0.033333333333333, 0.055555555555556
80052, 1.504347826087, -0.033333333333333, 0.44444444444444
80053, 1.504347826087, -0.033333333333333, 0.38888888888889
80054, 1.504347826087, -0.033333333333333, 0.33333333333333
80055, 1.504347826087, -0.033333333333333, 0.27777777777778
80056, 1.504347826087, -0.033333333333333, 0.22222222222222
80057, 1.504347826087, -0.033333333333333, 0.16666666666667
80058, 1.504347826087, -0.033333333333333, 0.11111111111111
80059, 1.504347826087, -0.033333333333333, 0.055555555555556
80060, 1.5478260869565, -0.033333333333333, 0.44444444444444
80061, 1.5478260869565, -0.033333333333333, 0.38888888888889
80062, 1.5478260869565, -0.033333333333333, 0.33333333333333
80063, 1.5478260869565, -0.033333333333333, 0.27777777777778
80064, 1.5478260869565, -0.033333333333333, 0.22222222222222
80065, 1.5478260869565, -0.033333333333333, 0.16666666666667
80066, 1.5478260869565, -0.033333333333333, 0.11111111111111
80067, 1.5478260869565, -0.033333333333333, 0.055555555555556
80068, 1.5913043478261, -0.033333333333333, 0.44444444444444
80069, 1.5913043478261, -0.033333333333333, 0.38888888888889
80070, 1.5913043478261, -0.033333333333333, 0.33333333333333
80071, 1.5913043478261, -0.033333333333333, 0.27777777777778
80072, 1.5913043478261, -0.033333333333333, 0.22222222222222
80073, 1.5913043478261, -0.033333333333333, 0.16666666666667
80074, 1.5913043478261, -0.033333333333333, 0.11111111111111
80075, 1.5913043478261, -0.033333333333333, 0.055555555555556
80076, 1.6347826086957, -0.033333333333333, 0.44444444444444
80077, 1.6347826086957, -0.033333333333333, 0.38888888888889
80078, 1.6347826086957, -0.033333333333333, 0.33333333333333
80079, 1.6347826086957, -0.033333333333333, 0.27777777777778
80080, 1.6347826086957, -0.033333333333333, 0.22222222222222
80081, 1.6347826086957, -0.033333333333333, 0.16666666666667
80082, 1.6347826086957, -0.033333333333333, 0.11111111111111
80083, 1.6347826086957, -0.033333333333333, 0.055555555555556
80084, 1.6782608695652, -0.033333333333333, 0.44444444444444
80085, 1.6782608695652, -0.033333333333333, 0.38888888888889
80086, 1.6782608695652, -0.033333333333333, 0.33333333333333
80087, 1.6782608695652, -0.033333333333333, 0.27777777777778
80088, 1.6782608695652, -0.033333333333333, 0.22222222222222
80089, 1.6782608695652, -0.033333333333333, 0.16666666666667
80090, 1.6782608695652, -0.033333333333333, 0.11111111111111
80091, 1.6782608695652, -0.033333333333333, 0.055555555555556
80092, 1.7217391304348, -0.033333333333333, 0.44444444444444
80093, 1.7217391304348, -0.033333333333333, 0.38888888888889
80094, 1.7217391304348, -0.033333333333333, 0.33333333333333
80095, 1.7217391304348, -0.033333333333333, 0.27777777777778
80096, 1.7217391304348, -0.033333333333333, 0.22222222222222
80097, 1.7217391304348, -0.033333333333333, 0.16666666666667
80098, 1.7217391304348, -0.033333333333333, 0.11111111111111
80099, 1.7217391304348, -0.033333333333333, 0.055555555555556
80100, 1.7652173913043, -0.033333333333333, 0.44444444444444
80101, 1.7652173913043, -0.033333333333333, 0.38888888888889
80102, 1.7652173913043, -0.033333333333333, 0.33333333333333
80103, 1.7652173913043, -0.033333333333333, 0.27777777777778
80104, 1.7652173913043, -0.033333333333333, 0.22222222222222
80105, 1.7652173913043, -0.033333333333333, 0.16666666666667
80106, 1.7652173913043, -0.033333333333333, 0.11111111111111
80107, 1.7652173913043, -0.033333333333333, 0.055555555555556
80108, 1.8086956521739, -0.033333333333333, 0.44444444444444
80109, 1.8086956521739, -0.033333333333333, 0.38888888888889
80110, 1.8086956521739, -0.033333333333333, 0.33333333333333
80111, 1.8086956521739, -0.033333333333333, 0.27777777777778
80112, 1.8086956521739, -0.033333333333333, 0.22222222222222
80113, 1.8086956521739, -0.033333333333333, 0.16666666666667
80114, 1.8086956521739, -0.033333333333333, 0.11111111111111
80115, 1.8086956521739, -0.033333333333333, 0.055555555555556
80116, 1.8521739130435, -0.033333333333333, 0.44444444444444
80117, 1.8521739130435, -0.033333333333333, 0.38888888888889
80118, 1.8521739130435, -0.033333333333333, 0.33333333333333
80119, 1.8521739130435, -0.033333333333333, 0.27777777777778
80120, 1.8521739130435, -0.033333333333333, 0.22222222222222
80121, 1.8521739130435, -0.033333333333333, 0.16666666666667
80122, 1.8521739130435, -0.033333333333333, 0.11111111111111
80123, 1.8521739130435, -0.033333333333333, 0.055555555555556
80124, 1.895652173913, -0.033333333333333, 0.44444444444444
80125, 1.895652173913, -0.033333333333333, 0.38888888888889
80126, 1.895652173913, -0.033333333333333, 0.33333333333333
80127, 1.895652173913, -0.033333333333333, 0.27777777777778
80128, 1.895652173913, -0.033333333333333, 0.22222222222222
80129, 1.895652173913, -0.033333333333333, 0.16666666666667
80130, 1.895652173913, -0.033333333333333, 0.11111111111111
80131, 1.895652173913, -0.033333333333333, 0.055555555555556
80132, 1.9391304347826, -0.033333333333333, 0.44444444444444
80133, 1.9391304347826, -0.033333333333333, 0.38888888888889
80134, 1.9391304347826, -0.033333333333333, 0.33333333333333
80135, 1.9391304347826, -0.033333333333333, 0.27777777777778
80136, 1.9391304347826, -0.033333333333333, 0.22222222222222
80137, 1.9391304347826, -0.033333333333333, 0.16666666666667
80138, 1.9391304347826, -0.033333333333333, 0.11111111111111
80139, 1.9391304347826, -0.033333333333333, 0.055555555555556
80140, 1.9826086956522, -0.033333333333333, 0.44444444444444
80141, 1.9826086956522, -0.033333333333333, 0.38888888888889
80142, 1.9826086956522, -0.033333333333333, 0.33333333333333
80143, 1.9826086956522, -0.033333333333333, 0.27777777777778
80144, 1.9826086956522, -0.033333333333333, 0.22222222222222
80145, 1.9826086956522, -0.033333333333333, 0.16666666666667
80146, 1.9826086956522, -0.033333333333333, 0.11111111111111
80147, 1.9826086956522, -0.033333333333333, 0.055555555555556
80148, 2.0260869565217, -0.033333333333333, 0.44444444444444
80149, 2.0260869565217, -0.033333333333333, 0.38888888888889
80150, 2.0260869565217, -0.033333333333333, 0.33333333333333
80151, 2.0260869565217, -0.033333333333333, 0.27777777777778
80152, 2.0260869565217, -0.033333333333333, 0.22222222222222
80153, 2.0260869565217, -0.033333333333333, 0.16666666666667
80154, 2.0260869565217, -0.033333333333333, 0.11111111111111
80155, 2.0260869565217, -0.033333333333333, 0.055555555555556
80156, 2.0695652173913, -0.033333333333333, 0.44444444444444
80157, 2.0695652173913, -0.033333333333333, 0.38888888888889
80158, 2.0695652173913, -0.033333333333333, 0.33333333333333
80159, 2.0695652173913, -0.033333333333333, 0.27777777777778
80160, 2.0695652173913, -0.033333333333333, 0.22222222222222
80161, 2.0695652173913, -0.033333333333333, 0.16666666666667
80162, 2.0695652173913, -0.033333333333333, 0.11111111111111
80163, 2.0695652173913, -0.033333333333333, 0.055555555555556
80164, 2.1130434782609, -0.033333333333333, 0.44444444444444
80165, 2.1130434782609, -0.033333333333333, 0.38888888888889
80166, 2.1130434782609, -0.033333333333333, 0.33333333333333
80167, 2.1130434782609, -0.033333333333333, 0.27777777777778
80168, 2.1130434782609, -0.033333333333333, 0.22222222222222
80169, 2.1130434782609, -0.033333333333333, 0.16666666666667
80170, 2.1130434782609, -0.033333333333333, 0.11111111111111
80171, 2.1130434782609, -0.033333333333333, 0.055555555555556
80172, 2.1565217391304, -0.033333333333333, 0.44444444444444
80173, 2.1565217391304, -0.033333333333333, 0.38888888888889
80174, 2.1565217391304, -0.033333333333333, 0.33333333333333
80175, 2.1565217391304, -0.033333333333333, 0.27777777777778
80176, 2.1565217391304, -0.033333333333333, 0.22222222222222
80177, 2.1565217391304, -0.033333333333333, 0.16666666666667
80178, 2.1565217391304, -0.033333333333333, 0.11111111111111
80179, 2.1565217391304, -0.033333333333333, 0.055555555555556
80180, 2.25, 0.016666666666667, 0.44444444444444
80181, 2.25, 0.016666666666667, 0.38888888888889
80182, 2.25, 0.016666666666667, 0.33333333333333
80183, 2.25, 0.016666666666667, 0.27777777777778
80184, 2.25, 0.016666666666667, 0.22222222222222
80185, 2.25, 0.016666666666667, 0.16666666666667
80186, 2.25, 0.016666666666667, 0.11111111111111
80187, 2.25, 0.016666666666667, 0.055555555555556
80188, 2.25, -0.016666666666667, 0.44444444444444
80189, 2.25, -0.016666666666667, 0.38888888888889
80190, 2.25, -0.016666666666667, 0.33333333333333
80191, 2.25, -0.016666666666667, 0.27777777777778
80192, 2.25, -0.016666666666667, 0.22222222222222
80193, 2.25, -0.016666666666667, 0.16666666666667
80194, 2.25, -0.016666666666667, 0.11111111111111
80195, 2.25, -0.016666666666667, 0.055555555555556
80196, 2.25, 0.016666666666667, 0.47222222222222
80197, 2.25, 0.033333333333333, 0.44444444444444
80198, 2.225, 0.016666666666667, 0.44444444444444
80199, 2.25, 0.016666666666667, 0.41666666666667
80200, 2.25, 0.033333333333333, 0.38888888888889
80201, 2.225, 0.016666666666667, 0.38888888888889
80202, 2.25, 0.016666666666667, 0.36111111111111
80203, 2.25, 0.033333333333333, 0.33333333333333
80204, 2.225, 0.016666666666667, 0.33333333333333
80205, 2.25, 0.016666666666667, 0.30555555555556
80206, 2.25, 0.033333333333333, 0.27777777777778
80207, 2.225, 0.016666666666667, 0.27777777777778
80208, 2.25, 0.016666666666667, 0.25
80209, 2.25, 0.033333333333333, 0.22222222222222
80210, 2.225, 0.016666666666667, 0.22222222222222
80211, 2.25, 0.016666666666667, 0.19444444444444
80212, 2.25, 0.033333333333333, 0.16666666666667
80213, 2.225, 0.016666666666667, 0.16666666666667
80214, 2.25, 0.016666666666667, 0.13888888888889
80215, 2.25, 0.033333333333333, 0.11111111111111
80216, 2.225, 0.016666666666667, 0.11111111111111
80217, 2.25, 0.016666666666667, 0.083333333333333
80218, 2.25, 0.033333333333333, 0.055555555555556
80219, 2.225, 0.016666666666667, 0.055555555555556
80220, 2.25, 0.016666666666667, 0.027777777777778
80221, 2.25, -0.016666666666667, 0.47222222222222
80222, 2.25, -1.2316536679435e-16, 0.44444444444444
80223, 2.225, -0.016666666666667, 0.44444444444444
80224, 2.25, -0.016666666666667, 0.41666666666667
80225, 2.25, -1.3183898417424e-16, 0.38888888888889
80226, 2.225, -0.016666666666667, 0.38888888888889
80227, 2.25, -0.016666666666667, 0.36111111111111
80228, 2.25, -1.3010426069826e-16, 0.33333333333333
80229, 2.225, -0.016666666666667, 0.33333333333333
80230, 2.25, -0.016666666666667, 0.30555555555556
80231, 2.25, -1.2143064331838e-16, 0.27777777777778
80232, 2.225, -0.016666666666667, 0.27777777777778
80233, 2.25, -0.016666666666667, 0.25
80234, 2.25, -1.2490009027033e-16, 0.22222222222222
80235, 2.225, -0.016666666666667, 0.22222222222222
80236, 2.25, -0.016666666666667, 0.19444444444444
80237, 2.25, -1.2836953722228e-16, 0.16666666666667
80238, 2.225, -0.016666666666667, 0.16666666666667
80239, 2.25, -0.016666666666667, 0.13888888888889
80240, 2.25, -1.3010426069826e-16, 0.11111111111111
80241, 2.225, -0.016666666666667, 0.11111111111111
80242, 2.25, -0.016666666666667, 0.083333333333333
80243, 2.25, -1.2836953722228e-16, 0.055555555555556
80244, 2.225, -0.016666666666667, 0.055555555555556
80245, 2.25, -0.016666666666667, 0.027777777777778
80246, 2.25, -0.033333333333333, 0.44444444444444
80247, 2.25, -0.033333333333333, 0.38888888888889
80248, 2.25, -0.033333333333333, 0.33333333333333
80249, 2.25, -0.033333333333333, 0.27777777777778
80250, 2.25, -0.033333333333333, 0.22222222222222
80251, 2.25, -0.033333333333333, 0.16666666666667
80252, 2.25, -0.033333333333333, 0.11111111111111
80253, 2.25, -0.033333333333333, 0.055555555555556
80254, 2.275, 0.016666666666667, 0.44444444444444
80255, 2.275, 0.016666666666667, 0.38888888888889
80256, 2.275, 0.016666666666667, 0.33333333333333
80257, 2.275, 0.016666666666667, 0.27777777777778
80258, 2.275, 0.016666666666667, 0.22222222222222
80259, 2.275, 0.016666666666667, 0.16666666666667
80260, 2.275, 0.016666666666667, 0.11111111111111
80261, 2.275, 0.016666666666667, 0.055555555555556
80262, 2.275, -0.016666666666667, 0.44444444444444
80263, 2.275, -0.016666666666667, 0.38888888888889
80264, 2.275, -0.016666666666667, 0.33333333333333
80265, 2.275, -0.016666666666667, 0.27777777777778
80266, 2.275, -0.016666666666667, 0.22222222222222
80267, 2.275, -0.016666666666667, 0.16666666666667
80268, 2.275, -0.016666666666667, 0.11111111111111
80269, 2.275, -0.016666666666667, 0.055555555555556
80270, -0.05, -0.016666666666667, 0.44444444444444
80271, -0.05, 0.016666666666667, 0.44444444444444
80272, -0.05, -0.016666666666667, 0.38888888888889
80273, -0.05, 0.016666666666667, 0.38888888888889
80274, -0.05, -0.016666666666667, 0.33333333333333
80275, -0.05, 0.016666666666667, 0.33333333333333
80276, -0.05, -0.016666666666667, 0.27777777777778
80277, -0.05, 0.016666666666667, 0.27777777777778
80278, -0.05, -0.016666666666667, 0.22222222222222
80279, -0.05, 0.016666666666667, 0.22222222222222
80280, -0.05, -0.016666666666667, 0.16666666666667
80281, -0.05, 0.016666666666667, 0.16666666666667
80282, -0.05, -0.016666666666667, 0.11111111111111
80283, -0.05, 0.016666666666667, 0.11111111111111
80284, -0.05, -0.016666666666667, 0.055555555555556
80285, -0.05, 0.016666666666667, 0.055555555555556
80286, -0.05, -0.033333333333333, 0.44444444444444
80287, -0.05, -0.016666666666667, 0.47222222222222
80288, -0.025, -0.016666666666667, 0.44444444444444
80289, -0.05, 5.7245874707235e-17, 0.44444444444444
80290, -0.05, 0.016666666666667, 0.47222222222222
80291, -0.025, 0.016666666666667, 0.44444444444444
80292, -0.05, 0.033333333333333, 0.44444444444444
80293, -0.05, -0.033333333333333, 0.38888888888889
80294, -0.05, -0.016666666666667, 0.41666666666667
80295, -0.025, -0.016666666666667, 0.38888888888889
80296, -0.05, 5.8980598183211e-17, 0.38888888888889
80297, -0.05, 0.016666666666667, 0.41666666666667
80298, -0.025, 0.016666666666667, 0.38888888888889
80299, -0.05, 0.033333333333333, 0.38888888888889
80300, -0.05, -0.033333333333333, 0.33333333333333
80301, -0.05, -0.016666666666667, 0.36111111111111
80302, -0.025, -0.016666666666667, 0.33333333333333
80303, -0.05, 6.0715321659188e-17, 0.33333333333333
80304, -0.05, 0.016666666666667, 0.36111111111111
80305, -0.025, 0.016666666666667, 0.33333333333333
80306, -0.05, 0.033333333333333, 0.33333333333333
80307, -0.05, -0.033333333333333, 0.27777777777778
80308, -0.05, -0.016666666666667, 0.30555555555556
80309, -0.025, -0.016666666666667, 0.27777777777778
80310, -0.05, 5.8980598183211e-17, 0.27777777777778
80311, -0.05, 0.016666666666667, 0.30555555555556
80312, -0.025, 0.016666666666667, 0.27777777777778
80313, -0.05, 0.033333333333333, 0.27777777777778
80314, -0.05, -0.033333333333333, 0.22222222222222
80315, -0.05, -0.016666666666667, 0.25
80316, -0.025, -0.016666666666667, 0.22222222222222
80317, -0.05, 5.8980598183211e-17, 0.22222222222222
80318, -0.05, 0.016666666666667, 0.25
80319, -0.025, 0.016666666666667, 0.22222222222222
80320, -0.05, 0.033333333333333, 0.22222222222222
80321, -0.05, -0.033333333333333, 0.16666666666667
80322, -0.05, -0.016666666666667, 0.19444444444444
80323, -0.025, -0.016666666666667, 0.16666666666667
80324, -0.05, 6.5919492087119e-17, 0.16666666666667
80325, -0.05, 0.016666666666667, 0.19444444444444
80326, -0.025, 0.016666666666667, 0.16666666666667
80327, -0.05, 0.033333333333333, 0.16666666666667
80328, -0.05, -0.033333333333333, 0.11111111111111
80329, -0.05, -0.016666666666667, 0.13888888888889
80330, -0.025, -0.016666666666667, 0.11111111111111
80331, -0.05, 5.8980598183211e-17, 0.11111111111111
80332, -0.05, 0.016666666666667, 0.13888888888889
80333, -0.025, 0.016666666666667, 0.11111111111111
80334, -0.05, 0.033333333333333, 0.11111111111111
80335, -0.05, -0.033333333333333, 0.055555555555556
80336, -0.05, -0.016666666666667, 0.083333333333333
80337, -0.025, -0.016666666666667, 0.055555555555556
80338, -0.05, 5.7245874707235e-17, 0.055555555555556
80339, -0.05, 0.016666666666667, 0.083333333333333
80340, -0.025, 0.016666666666667, 0.055555555555556
80341, -0.05, 0.033333333333333, 0.055555555555556
80342, -0.05, -0.016666666666667, 0.027777777777778
80343, -0.05, 0.016666666666667, 0.027777777777778
80344, -0.075, -0.016666666666667, 0.44444444444444
80345, -0.075, 0.016666666666667, 0.44444444444444
80346, -0.075, -0.016666666666667, 0.38888888888889
80347, -0.075, 0.016666666666667, 0.38888888888889
80348, -0.075, -0.016666666666667, 0.33333333333333
80349, -0.075, 0.016666666666667, 0.33333333333333
80350, -0.075, -0.016666666666667, 0.27777777777778
80351, -0.075, 0.016666666666667, 0.27777777777778
80352, -0.075, -0.016666666666667, 0.22222222222222
80353, -0.075, 0.016666666666667, 0.22222222222222
80354, -0.075, -0.016666666666667, 0.16666666666667
80355, -0.075, 0.016666666666667, 0.16666666666667
80356, -0.075, -0.016666666666667, 0.11111111111111
80357, -0.075, 0.016666666666667, 0.11111111111111
80358, -0.075, -0.016666666666667, 0.055555555555556
80359, -0.075, 0.016666666666667, 0.055555555555556
80360, 0.95652173913043, 1.6, 0.055555555555556
80361, 0.95652173913044, 1.6, 0.11111111111111
80362, 0.95652173913043, 1.6, 0.16666666666667
80363, 0.95652173913043, 1.6, 0.22222222222222
80364, 0.95652173913044, 1.6, 0.27777777777778
80365, 0.95652173913043, 1.6, 0.33333333333333
80366, 0.95652173913043, 1.6, 0.38888888888889
80367, 0.95652173913044, 1.6, 0.44444444444444
80368, 0.91304347826087, 1.6, 0.055555555555556
80369, 0.91304347826087, 1.6, 0.11111111111111
80370, 0.91304347826087, 1.6, 0.16666666666667
80371, 0.91304347826087, 1.6, 0.22222222222222
80372, 0.91304347826087, 1.6, 0.27777777777778
80373, 0.91304347826087, 1.6, 0.33333333333333
80374, 0.91304347826087, 1.6, 0.38888888888889
80375, 0.91304347826087, 1.6, 0.44444444444444
80376, 0.8695652173913, 1.6, 0.055555555555556
80377, 0.8695652173913, 1.6, 0.11111111111111
80378, 0.8695652173913, 1.6, 0.16666666666667
80379, 0.8695652173913, 1.6, 0.22222222222222
80380, 0.8695652173913, 1.6, 0.27777777777778
80381, 0.8695652173913, 1.6, 0.33333333333333
80382, 0.8695652173913, 1.6, 0.38888888888889
80383, 0.8695652173913, 1.6, 0.44444444444444
80384, 0.82608695652174, 1.6, 0.055555555555556
80385, 0.82608695652174, 1.6, 0.11111111111111
80386, 0.82608695652174, 1.6, 0.16666666666667
80387, 0.82608695652174, 1.6, 0.22222222222222
80388, 0.82608695652174, 1.6, 0.27777777777778
80389, 0.82608695652174, 1.6, 0.33333333333333
80390, 0.82608695652174, 1.6, 0.38888888888889
80391, 0.82608695652174, 1.6, 0.44444444444444
80392, 0.78260869565217, 1.6, 0.055555555555556
80393, 0.78260869565217, 1.6, 0.11111111111111
80394, 0.78260869565217, 1.6, 0.16666666666667
80395, 0.78260869565217, 1.6, 0.22222222222222
80396, 0.78260869565217, 1.6, 0.27777777777778
80397, 0.78260869565217, 1.6, 0.33333333333333
80398, 0.78260869565217, 1.6, 0.38888888888889
80399, 0.78260869565217, 1.6, 0.44444444444444
80400, 0.73913043478261, 1.6, 0.055555555555556
80401, 0.73913043478261, 1.6, 0.11111111111111
80402, 0.73913043478261, 1.6, 0.16666666666667
80403, 0.73913043478261, 1.6, 0.22222222222222
80404, 0.73913043478261, 1.6, 0.27777777777778
80405, 0.73913043478261, 1.6, 0.33333333333333
80406, 0.73913043478261, 1.6, 0.38888888888889
80407, 0.73913043478261, 1.6, 0.44444444444444
80408, 0.69565217391304, 1.6, 0.055555555555556
80409, 0.69565217391304, 1.6, 0.11111111111111
80410, 0.69565217391304, 1.6, 0.16666666666667
80411, 0.69565217391304, 1.6, 0.22222222222222
80412, 0.69565217391304, 1.6, 0.27777777777778
80413, 0.69565217391304, 1.6, 0.33333333333333
80414, 0.69565217391304, 1.6, 0.38888888888889
80415, 0.69565217391304, 1.6, 0.44444444444444
80416, 0.65217391304348, 1.6, 0.055555555555556
80417, 0.65217391304348, 1.6, 0.11111111111111
80418, 0.65217391304348, 1.6, 0.16666666666667
80419, 0.65217391304348, 1.6, 0.22222222222222
80420, 0.65217391304348, 1.6, 0.27777777777778
80421, 0.65217391304348, 1.6, 0.33333333333333
80422, 0.65217391304348, 1.6, 0.38888888888889
80423, 0.65217391304348, 1.6, 0.44444444444444
80424, 0.60869565217391, 1.6, 0.055555555555556
80425, 0.60869565217391, 1.6, 0.11111111111111
80426, 0.60869565217391, 1.6, 0.16666666666667
80427, 0.60869565217391, 1.6, 0.22222222222222
80428, 0.60869565217391, 1.6, 0.27777777777778
80429, 0.60869565217391, 1.6, 0.33333333333333
80430, 0.60869565217391, 1.6, 0.38888888888889
80431, 0.60869565217391, 1.6, 0.44444444444444
80432, 0.56521739130435, 1.6, 0.055555555555556
80433, 0.56521739130435, 1.6, 0.11111111111111
80434, 0.56521739130435, 1.6, 0.16666666666667
80435, 0.56521739130435, 1.6, 0.22222222222222
80436, 0.56521739130435, 1.6, 0.27777777777778
80437, 0.56521739130435, 1.6, 0.33333333333333
80438, 0.56521739130435, 1.6, 0.38888888888889
80439, 0.56521739130435, 1.6, 0.44444444444444
80440, 0.52173913043478, 1.6, 0.055555555555556
80441, 0.52173913043478, 1.6, 0.11111111111111
80442, 0.52173913043478, 1.6, 0.16666666666667
80443, 0.52173913043478, 1.6, 0.22222222222222
80444, 0.52173913043478, 1.6, 0.27777777777778
80445, 0.52173913043478, 1.6, 0.33333333333333
80446, 0.52173913043478, 1.6, 0.38888888888889
80447, 0.52173913043478, 1.6, 0.44444444444444
80448, 0.47826086956522, 1.6, 0.055555555555556
80449, 0.47826086956522, 1.6, 0.11111111111111
80450, 0.47826086956522, 1.6, 0.16666666666667
80451, 0.47826086956522, 1.6, 0.22222222222222
80452, 0.47826086956522, 1.6, 0.27777777777778
80453, 0.47826086956522, 1.6, 0.33333333333333
80454, 0.47826086956522, 1.6, 0.38888888888889
80455, 0.47826086956522, 1.6, 0.44444444444444
80456, 0.43478260869565, 1.6, 0.055555555555556
80457, 0.43478260869565, 1.6, 0.11111111111111
80458, 0.43478260869565, 1.6, 0.16666666666667
80459, 0.43478260869565, 1.6, 0.22222222222222
80460, 0.43478260869565, 1.6, 0.27777777777778
80461, 0.43478260869565, 1.6, 0.33333333333333
80462, 0.43478260869565, 1.6, 0.38888888888889
80463, 0.43478260869565, 1.6, 0.44444444444444
80464, 0.39130434782609, 1.6, 0.055555555555556
80465, 0.39130434782609, 1.6, 0.11111111111111
80466, 0.39130434782609, 1.6, 0.16666666666667
80467, 0.39130434782609, 1.6, 0.22222222222222
80468, 0.39130434782609, 1.6, 0.27777777777778
80469, 0.39130434782609, 1.6, 0.33333333333333
80470, 0.39130434782609, 1.6, 0.38888888888889
80471, 0.39130434782609, 1.6, 0.44444444444444
80472, 0.34782608695652, 1.6, 0.055555555555556
80473, 0.34782608695652, 1.6, 0.11111111111111
80474, 0.34782608695652, 1.6, 0.16666666666667
80475, 0.34782608695652, 1.6, 0.22222222222222
80476, 0.34782608695652, 1.6, 0.27777777777778
80477, 0.34782608695652, 1.6, 0.33333333333333
80478, 0.34782608695652, 1.6, 0.38888888888889
80479, 0.34782608695652, 1.6, 0.44444444444444
80480, 0.30434782608696, 1.6, 0.055555555555556
80481, 0.30434782608696, 1.6, 0.11111111111111
80482, 0.30434782608696, 1.6, 0.16666666666667
80483, 0.30434782608696, 1.6, 0.22222222222222
80484, 0.30434782608696, 1.6, 0.27777777777778
80485, 0.30434782608696, 1.6, 0.33333333333333
80486, 0.30434782608696, 1.6, 0.38888888888889
80487, 0.30434782608696, 1.6, 0.44444444444444
80488, 0.26086956521739, 1.6, 0.055555555555556
80489, 0.26086956521739, 1.6, 0.11111111111111
80490, 0.26086956521739, 1.6, 0.16666666666667
80491, 0.26086956521739, 1.6, 0.22222222222222
80492, 0.26086956521739, 1.6, 0.27777777777778
80493, 0.26086956521739, 1.6, 0.33333333333333
80494, 0.26086956521739, 1.6, 0.38888888888889
80495, 0.26086956521739, 1.6, 0.44444444444444
80496, 0.21739130434783, 1.6, 0.055555555555556
80497, 0.21739130434783, 1.6, 0.11111111111111
80498, 0.21739130434783, 1.6, 0.16666666666667
80499, 0.21739130434783, 1.6, 0.22222222222222
80500, 0.21739130434783, 1.6, 0.27777777777778
80501, 0.21739130434783, 1.6, 0.33333333333333
80502, 0.21739130434783, 1.6, 0.38888888888889
80503, 0.21739130434783, 1.6, 0.44444444444444
80504, 0.17391304347826, 1.6, 0.055555555555556
80505, 0.17391304347826, 1.6, 0.11111111111111
80506, 0.17391304347826, 1.6, 0.16666666666667
80507, 0.17391304347826, 1.6, 0.22222222222222
80508, 0.17391304347826, 1.6, 0.27777777777778
80509, 0.17391304347826, 1.6, 0.33333333333333
80510, 0.17391304347826, 1.6, 0.38888888888889
80511, 0.17391304347826, 1.6, 0.44444444444444
80512, 0.1304347826087, 1.6, 0.055555555555556
80513, 0.1304347826087, 1.6, 0.11111111111111
80514, 0.1304347826087, 1.6, 0.16666666666667
80515, 0.1304347826087, 1.6, 0.22222222222222
80516, 0.1304347826087, 1.6, 0.27777777777778
80517, 0.1304347826087, 1.6, 0.33333333333333
80518, 0.1304347826087, 1.6, 0.38888888888889
80519, 0.1304347826087, 1.6, 0.44444444444444
80520, 0.08695652173913, 1.6, 0.055555555555556
80521, 0.08695652173913, 1.6, 0.11111111111111
80522, 0.08695652173913, 1.6, 0.16666666666667
80523, 0.08695652173913, 1.6, 0.22222222222222
80524, 0.08695652173913, 1.6, 0.27777777777778
80525, 0.08695652173913, 1.6, 0.33333333333333
80526, 0.08695652173913, 1.6, 0.38888888888889
80527, 0.08695652173913, 1.6, 0.44444444444444
80528, 0.043478260869565, 1.6, 0.055555555555556
80529, 0.043478260869565, 1.6, 0.11111111111111
80530, 0.043478260869565, 1.6, 0.16666666666667
80531, 0.043478260869565, 1.6, 0.22222222222222
80532, 0.043478260869565, 1.6, 0.27777777777778
80533, 0.043478260869565, 1.6, 0.33333333333333
80534, 0.043478260869565, 1.6, 0.38888888888889
80535, 0.043478260869565, 1.6, 0.44444444444444
80536, 0.95652173913043, 1.65, 0.055555555555556
80537, 0.95652173913043, 1.65, 0.11111111111111
80538, 0.95652173913044, 1.65, 0.16666666666667
80539, 0.95652173913044, 1.65, 0.22222222222222
80540, 0.95652173913044, 1.65, 0.27777777777778
80541, 0.95652173913044, 1.65, 0.33333333333333
80542, 0.95652173913044, 1.65, 0.38888888888889
80543, 0.95652173913044, 1.65, 0.44444444444444
80544, 0.91304347826087, 1.65, 0.055555555555556
80545, 0.91304347826087, 1.65, 0.11111111111111
80546, 0.91304347826087, 1.65, 0.16666666666667
80547, 0.91304347826087, 1.65, 0.22222222222222
80548, 0.91304347826087, 1.65, 0.27777777777778
80549, 0.91304347826087, 1.65, 0.33333333333333
80550, 0.91304347826087, 1.65, 0.38888888888889
80551, 0.91304347826087, 1.65, 0.44444444444444
80552, 0.8695652173913, 1.65, 0.055555555555556
80553, 0.8695652173913, 1.65, 0.11111111111111
80554, 0.8695652173913, 1.65, 0.16666666666667
80555, 0.8695652173913, 1.65, 0.22222222222222
80556, 0.8695652173913, 1.65, 0.27777777777778
80557, 0.8695652173913, 1.65, 0.33333333333333
80558, 0.8695652173913, 1.65, 0.38888888888889
80559, 0.8695652173913, 1.65, 0.44444444444444
80560, 0.82608695652174, 1.65, 0.055555555555556
80561, 0.82608695652174, 1.65, 0.11111111111111
80562, 0.82608695652174, 1.65, 0.16666666666667
80563, 0.82608695652174, 1.65, 0.22222222222222
80564, 0.82608695652174, 1.65, 0.27777777777778
80565, 0.82608695652174, 1.65, 0.33333333333333
80566, 0.82608695652174, 1.65, 0.38888888888889
80567, 0.82608695652174, 1.65, 0.44444444444444
80568, 0.78260869565217, 1.65, 0.055555555555556
80569, 0.78260869565217, 1.65, 0.11111111111111
80570, 0.78260869565217, 1.65, 0.16666666666667
80571, 0.78260869565217, 1.65, 0.22222222222222
80572, 0.78260869565217, 1.65, 0.27777777777778
80573, 0.78260869565217, 1.65, 0.33333333333333
80574, 0.78260869565217, 1.65, 0.38888888888889
80575, 0.78260869565217, 1.65, 0.44444444444444
80576, 0.73913043478261, 1.65, 0.055555555555556
80577, 0.73913043478261, 1.65, 0.11111111111111
80578, 0.73913043478261, 1.65, 0.16666666666667
80579, 0.73913043478261, 1.65, 0.22222222222222
80580, 0.73913043478261, 1.65, 0.27777777777778
80581, 0.73913043478261, 1.65, 0.33333333333333
80582, 0.73913043478261, 1.65, 0.38888888888889
80583, 0.73913043478261, 1.65, 0.44444444444444
80584, 0.69565217391304, 1.65, 0.055555555555556
80585, 0.69565217391304, 1.65, 0.11111111111111
80586, 0.69565217391304, 1.65, 0.16666666666667
80587, 0.69565217391304, 1.65, 0.22222222222222
80588, 0.69565217391304, 1.65, 0.27777777777778
80589, 0.69565217391304, 1.65, 0.33333333333333
80590, 0.69565217391304, 1.65, 0.38888888888889
80591, 0.69565217391304, 1.65, 0.44444444444444
80592, 0.65217391304348, 1.65, 0.055555555555556
80593, 0.65217391304348, 1.65, 0.11111111111111
80594, 0.65217391304348, 1.65, 0.16666666666667
80595, 0.65217391304348, 1.65, 0.22222222222222
80596, 0.65217391304348, 1.65, 0.27777777777778
80597, 0.65217391304348, 1.65, 0.33333333333333
80598, 0.65217391304348, 1.65, 0.38888888888889
80599, 0.65217391304348, 1.65, 0.44444444444444
80600, 0.60869565217391, 1.65, 0.055555555555556
80601, 0.60869565217391, 1.65, 0.11111111111111
80602, 0.60869565217391, 1.65, 0.16666666666667
80603, 0.60869565217391, 1.65, 0.22222222222222
80604, 0.60869565217391, 1.65, 0.27777777777778
80605, 0.60869565217391, 1.65, 0.33333333333333
80606, 0.60869565217391, 1.65, 0.38888888888889
80607, 0.60869565217391, 1.65, 0.44444444444444
80608, 0.56521739130435, 1.65, 0.055555555555556
80609, 0.56521739130435, 1.65, 0.11111111111111
80610, 0.56521739130435, 1.65, 0.16666666666667
80611, 0.56521739130435, 1.65, 0.22222222222222
80612, 0.56521739130435, 1.65, 0.27777777777778
80613, 0.56521739130435, 1.65, 0.33333333333333
80614, 0.56521739130435, 1.65, 0.38888888888889
80615, 0.56521739130435, 1.65, 0.44444444444444
80616, 0.52173913043478, 1.65, 0.055555555555556
80617, 0.52173913043478, 1.65, 0.11111111111111
80618, 0.52173913043478, 1.65, 0.16666666666667
80619, 0.52173913043478, 1.65, 0.22222222222222
80620, 0.52173913043478, 1.65, 0.27777777777778
80621, 0.52173913043478, 1.65, 0.33333333333333
80622, 0.52173913043478, 1.65, 0.38888888888889
80623, 0.52173913043478, 1.65, 0.44444444444444
80624, 0.47826086956522, 1.65, 0.055555555555556
80625, 0.47826086956522, 1.65, 0.11111111111111
80626, 0.47826086956522, 1.65, 0.16666666666667
80627, 0.47826086956522, 1.65, 0.22222222222222
80628, 0.47826086956522, 1.65, 0.27777777777778
80629, 0.47826086956522, 1.65, 0.33333333333333
80630, 0.47826086956522, 1.65, 0.38888888888889
80631, 0.47826086956522, 1.65, 0.44444444444444
80632, 0.43478260869565, 1.65, 0.055555555555556
80633, 0.43478260869565, 1.65, 0.11111111111111
80634, 0.43478260869565, 1.65, 0.16666666666667
80635, 0.43478260869565, 1.65, 0.22222222222222
80636, 0.43478260869565, 1.65, 0.27777777777778
80637, 0.43478260869565, 1.65, 0.33333333333333
80638, 0.43478260869565, 1.65, 0.38888888888889
80639, 0.43478260869565, 1.65, 0.44444444444444
80640, 0.39130434782609, 1.65, 0.055555555555556
80641, 0.39130434782609, 1.65, 0.11111111111111
80642, 0.39130434782609, 1.65, 0.16666666666667
80643, 0.39130434782609, 1.65, 0.22222222222222
80644, 0.39130434782609, 1.65, 0.27777777777778
80645, 0.39130434782609, 1.65, 0.33333333333333
80646, 0.39130434782609, 1.65, 0.38888888888889
80647, 0.39130434782609, 1.65, 0.44444444444444
80648, 0.34782608695652, 1.65, 0.055555555555556
80649, 0.34782608695652, 1.65, 0.11111111111111
80650, 0.34782608695652, 1.65, 0.16666666666667
80651, 0.34782608695652, 1.65, 0.22222222222222
80652, 0.34782608695652, 1.65, 0.27777777777778
80653, 0.34782608695652, 1.65, 0.33333333333333
80654, 0.34782608695652, 1.65, 0.38888888888889
80655, 0.34782608695652, 1.65, 0.44444444444444
80656, 0.30434782608696, 1.65, 0.055555555555556
80657, 0.30434782608696, 1.65, 0.11111111111111
80658, 0.30434782608696, 1.65, 0.16666666666667
80659, 0.30434782608696, 1.65, 0.22222222222222
80660, 0.30434782608696, 1.65, 0.27777777777778
80661, 0.30434782608696, 1.65, 0.33333333333333
80662, 0.30434782608696, 1.65, 0.38888888888889
80663, 0.30434782608696, 1.65, 0.44444444444444
80664, 0.26086956521739, 1.65, 0.055555555555556
80665, 0.26086956521739, 1.65, 0.11111111111111
80666, 0.26086956521739, 1.65, 0.16666666666667
80667, 0.26086956521739, 1.65, 0.22222222222222
80668, 0.26086956521739, 1.65, 0.27777777777778
80669, 0.26086956521739, 1.65, 0.33333333333333
80670, 0.26086956521739, 1.65, 0.38888888888889
80671, 0.26086956521739, 1.65, 0.44444444444444
80672, 0.21739130434783, 1.65, 0.055555555555556
80673, 0.21739130434783, 1.65, 0.11111111111111
80674, 0.21739130434783, 1.65, 0.16666666666667
80675, 0.21739130434783, 1.65, 0.22222222222222
80676, 0.21739130434783, 1.65, 0.27777777777778
80677, 0.21739130434783, 1.65, 0.33333333333333
80678, 0.21739130434783, 1.65, 0.38888888888889
80679, 0.21739130434783, 1.65, 0.44444444444444
80680, 0.17391304347826, 1.65, 0.055555555555556
80681, 0.17391304347826, 1.65, 0.11111111111111
80682, 0.17391304347826, 1.65, 0.16666666666667
80683, 0.17391304347826, 1.65, 0.22222222222222
80684, 0.17391304347826, 1.65, 0.27777777777778
80685, 0.17391304347826, 1.65, 0.33333333333333
80686, 0.17391304347826, 1.65, 0.38888888888889
80687, 0.17391304347826, 1.65, 0.44444444444444
80688, 0.1304347826087, 1.65, 0.055555555555556
80689, 0.1304347826087, 1.65, 0.11111111111111
80690, 0.1304347826087, 1.65, 0.16666666666667
80691, 0.1304347826087, 1.65, 0.22222222222222
80692, 0.1304347826087, 1.65, 0.27777777777778
80693, 0.1304347826087, 1.65, 0.33333333333333
80694, 0.1304347826087, 1.65, 0.38888888888889
80695, 0.1304347826087, 1.65, 0.44444444444444
80696, 0.08695652173913, 1.65, 0.055555555555556
80697, 0.08695652173913, 1.65, 0.11111111111111
80698, 0.08695652173913, 1.65, 0.16666666666667
80699, 0.08695652173913, 1.65, 0.22222222222222
80700, 0.08695652173913, 1.65, 0.27777777777778
80701, 0.08695652173913, 1.65, 0.33333333333333
80702, 0.08695652173913, 1.65, 0.38888888888889
80703, 0.08695652173913, 1.65, 0.44444444444444
80704, 0.043478260869565, 1.65, 0.055555555555556
80705, 0.043478260869565, 1.65, 0.11111111111111
80706, 0.043478260869565, 1.65, 0.16666666666667
80707, 0.043478260869565, 1.65, 0.22222222222222
80708, 0.043478260869565, 1.65, 0.27777777777778
80709, 0.043478260869565, 1.65, 0.33333333333333
80710, 0.043478260869565, 1.65, 0.38888888888889
80711, 0.043478260869565, 1.65, 0.44444444444444
80712, 0.95652173913043, 1.7, 0.055555555555556
80713, 0.95652173913044, 1.7, 0.11111111111111
80714, 0.95652173913043, 1.7, 0.16666666666667
80715, 0.95652173913044, 1.7, 0.22222222222222
80716, 0.95652173913044, 1.7, 0.27777777777778
80717, 0.95652173913044, 1.7, 0.33333333333333
80718, 0.95652173913044, 1.7, 0.38888888888889
80719, 0.95652173913044, 1.7, 0.44444444444444
80720, 0.91304347826087, 1.7, 0.055555555555556
80721, 0.91304347826087, 1.7, 0.11111111111111
80722, 0.91304347826087, 1.7, 0.16666666666667
80723, 0.91304347826087, 1.7, 0.22222222222222
80724, 0.91304347826087, 1.7, 0.27777777777778
80725, 0.91304347826087, 1.7, 0.33333333333333
80726, 0.91304347826087, 1.7, 0.38888888888889
80727, 0.91304347826087, 1.7, 0.44444444444444
80728, 0.8695652173913, 1.7, 0.055555555555556
80729, 0.8695652173913, 1.7, 0.11111111111111
80730, 0.8695652173913, 1.7, 0.16666666666667
80731, 0.8695652173913, 1.7, 0.22222222222222
80732, 0.8695652173913, 1.7, 0.27777777777778
80733, 0.8695652173913, 1.7, 0.33333333333333
80734, 0.8695652173913, 1.7, 0.38888888888889
80735, 0.8695652173913, 1.7, 0.44444444444444
80736, 0.82608695652174, 1.7, 0.055555555555556
80737, 0.82608695652174, 1.7, 0.11111111111111
80738, 0.82608695652174, 1.7, 0.16666666666667
80739, 0.82608695652174, 1.7, 0.22222222222222
80740, 0.82608695652174, 1.7, 0.27777777777778
80741, 0.82608695652174, 1.7, 0.33333333333333
80742, 0.82608695652174, 1.7, 0.38888888888889
80743, 0.82608695652174, 1.7, 0.44444444444444
80744, 0.78260869565217, 1.7, 0.055555555555556
80745, 0.78260869565217, 1.7, 0.11111111111111
80746, 0.78260869565217, 1.7, 0.16666666666667
80747, 0.78260869565217, 1.7, 0.22222222222222
80748, 0.78260869565217, 1.7, 0.27777777777778
80749, 0.78260869565217, 1.7, 0.33333333333333
80750, 0.78260869565217, 1.7, 0.38888888888889
80751, 0.78260869565217, 1.7, 0.44444444444444
80752, 0.73913043478261, 1.7, 0.055555555555556
80753, 0.73913043478261, 1.7, 0.11111111111111
80754, 0.73913043478261, 1.7, 0.16666666666667
80755, 0.73913043478261, 1.7, 0.22222222222222
80756, 0.73913043478261, 1.7, 0.27777777777778
80757, 0.73913043478261, 1.7, 0.33333333333333
80758, 0.73913043478261, 1.7, 0.38888888888889
80759, 0.73913043478261, 1.7, 0.44444444444444
80760, 0.69565217391304, 1.7, 0.055555555555556
80761, 0.69565217391304, 1.7, 0.11111111111111
80762, 0.69565217391304, 1.7, 0.16666666666667
80763, 0.69565217391304, 1.7, 0.22222222222222
80764, 0.69565217391304, 1.7, 0.27777777777778
80765, 0.69565217391304, 1.7, 0.33333333333333
80766, 0.69565217391304, 1.7, 0.38888888888889
80767, 0.69565217391304, 1.7, 0.44444444444444
80768, 0.65217391304348, 1.7, 0.055555555555556
80769, 0.65217391304348, 1.7, 0.11111111111111
80770, 0.65217391304348, 1.7, 0.16666666666667
80771, 0.65217391304348, 1.7, 0.22222222222222
80772, 0.65217391304348, 1.7, 0.27777777777778
80773, 0.65217391304348, 1.7, 0.33333333333333
80774, 0.65217391304348, 1.7, 0.38888888888889
80775, 0.65217391304348, 1.7, 0.44444444444444
80776, 0.60869565217391, 1.7, 0.055555555555556
80777, 0.60869565217391, 1.7, 0.11111111111111
80778, 0.60869565217391, 1.7, 0.16666666666667
80779, 0.60869565217391, 1.7, 0.22222222222222
80780, 0.60869565217391, 1.7, 0.27777777777778
80781, 0.60869565217391, 1.7, 0.33333333333333
80782, 0.60869565217391, 1.7, 0.38888888888889
80783, 0.60869565217391, 1.7, 0.44444444444444
80784, 0.56521739130435, 1.7, 0.055555555555556
80785, 0.56521739130435, 1.7, 0.11111111111111
80786, 0.56521739130435, 1.7, 0.16666666666667
80787, 0.56521739130435, 1.7, 0.22222222222222
80788, 0.56521739130435, 1.7, 0.27777777777778
80789, 0.56521739130435, 1.7, 0.33333333333333
80790, 0.56521739130435, 1.7, 0.38888888888889
80791, 0.56521739130435, 1.7, 0.44444444444444
80792, 0.52173913043478, 1.7, 0.055555555555556
80793, 0.52173913043478, 1.7, 0.11111111111111
80794, 0.52173913043478, 1.7, 0.16666666666667
80795, 0.52173913043478, 1.7, 0.22222222222222
80796, 0.52173913043478, 1.7, 0.27777777777778
80797, 0.52173913043478, 1.7, 0.33333333333333
80798, 0.52173913043478, 1.7, 0.38888888888889
80799, 0.52173913043478, 1.7, 0.44444444444444
80800, 0.47826086956522, 1.7, 0.055555555555556
80801, 0.47826086956522, 1.7, 0.11111111111111
80802, 0.47826086956522, 1.7, 0.16666666666667
80803, 0.47826086956522, 1.7, 0.22222222222222
80804, 0.47826086956522, 1.7, 0.27777777777778
80805, 0.47826086956522, 1.7, 0.33333333333333
80806, 0.47826086956522, 1.7, 0.38888888888889
80807, 0.47826086956522, 1.7, 0.44444444444444
80808, 0.43478260869565, 1.7, 0.055555555555556
80809, 0.43478260869565, 1.7, 0.11111111111111
80810, 0.43478260869565, 1.7, 0.16666666666667
80811, 0.43478260869565, 1.7, 0.22222222222222
80812, 0.43478260869565, 1.7, 0.27777777777778
80813, 0.43478260869565, 1.7, 0.33333333333333
80814, 0.43478260869565, 1.7, 0.38888888888889
80815, 0.43478260869565, 1.7, 0.44444444444444
80816, 0.39130434782609, 1.7, 0.055555555555556
80817, 0.39130434782609, 1.7, 0.11111111111111
80818, 0.39130434782609, 1.7, 0.16666666666667
80819, 0.39130434782609, 1.7, 0.22222222222222
80820, 0.39130434782609, 1.7, 0.27777777777778
80821, 0.39130434782609, 1.7, 0.33333333333333
80822, 0.39130434782609, 1.7, 0.38888888888889
80823, 0.39130434782609, 1.7, 0.44444444444444
80824, 0.34782608695652, 1.7, 0.055555555555556
80825, 0.34782608695652, 1.7, 0.11111111111111
80826, 0.34782608695652, 1.7, 0.16666666666667
80827, 0.34782608695652, 1.7, 0.22222222222222
80828, 0.34782608695652, 1.7, 0.27777777777778
80829, 0.34782608695652, 1.7, 0.33333333333333
80830, 0.34782608695652, 1.7, 0.38888888888889
80831, 0.34782608695652, 1.7, 0.44444444444444
80832, 0.30434782608696, 1.7, 0.055555555555556
80833, 0.30434782608696, 1.7, 0.11111111111111
80834, 0.30434782608696, 1.7, 0.16666666666667
80835, 0.30434782608696, 1.7, 0.22222222222222
80836, 0.30434782608696, 1.7, 0.27777777777778
80837, 0.30434782608696, 1.7, 0.33333333333333
80838, 0.30434782608696, 1.7, 0.38888888888889
80839, 0.30434782608696, 1.7, 0.44444444444444
80840, 0.26086956521739, 1.7, 0.055555555555556
80841, 0.26086956521739, 1.7, 0.11111111111111
80842, 0.26086956521739, 1.7, 0.16666666666667
80843, 0.26086956521739, 1.7, 0.22222222222222
80844, 0.26086956521739, 1.7, 0.27777777777778
80845, 0.26086956521739, 1.7, 0.33333333333333
80846, 0.26086956521739, 1.7, 0.38888888888889
80847, 0.26086956521739, 1.7, 0.44444444444444
80848, 0.21739130434783, 1.7, 0.055555555555556
80849, 0.21739130434783, 1.7, 0.11111111111111
80850, 0.21739130434783, 1.7, 0.16666666666667
80851, 0.21739130434783, 1.7, 0.22222222222222
80852, 0.21739130434783, 1.7, 0.27777777777778
80853, 0.21739130434783, 1.7, 0.33333333333333
80854, 0.21739130434783, 1.7, 0.38888888888889
80855, 0.21739130434783, 1.7, 0.44444444444444
80856, 0.17391304347826, 1.7, 0.055555555555556
80857, 0.17391304347826, 1.7, 0.11111111111111
80858, 0.17391304347826, 1.7, 0.16666666666667
80859, 0.17391304347826, 1.7, 0.22222222222222
80860, 0.17391304347826, 1.7, 0.27777777777778
80861, 0.17391304347826, 1.7, 0.33333333333333
80862, 0.17391304347826, 1.7, 0.38888888888889
80863, 0.17391304347826, 1.7, 0.44444444444444
80864, 0.1304347826087, 1.7, 0.055555555555556
80865, 0.1304347826087, 1.7, 0.11111111111111
80866, 0.1304347826087, 1.7, 0.16666666666667
80867, 0.1304347826087, 1.7, 0.22222222222222
80868, 0.1304347826087, 1.7, 0.27777777777778
80869, 0.1304347826087, 1.7, 0.33333333333333
80870, 0.1304347826087, 1.7, 0.38888888888889
80871, 0.1304347826087, 1.7, 0.44444444444444
80872, 0.08695652173913, 1.7, 0.055555555555556
80873, 0.08695652173913, 1.7, 0.11111111111111
80874, 0.08695652173913, 1.7, 0.16666666666667
80875, 0.08695652173913, 1.7, 0.22222222222222
80876, 0.08695652173913, 1.7, 0.27777777777778
80877, 0.08695652173913, 1.7, 0.33333333333333
80878, 0.08695652173913, 1.7, 0.38888888888889
80879, 0.08695652173913, 1.7, 0.44444444444444
80880, 0.043478260869565, 1.7, 0.055555555555556
80881, 0.043478260869565, 1.7, 0.11111111111111
80882, 0.043478260869565, 1.7, 0.16666666666667
80883, 0.043478260869565, 1.7, 0.22222222222222
80884, 0.043478260869565, 1.7, 0.27777777777778
80885, 0.043478260869565, 1.7, 0.33333333333333
80886, 0.043478260869565, 1.7, 0.38888888888889
80887, 0.043478260869565, 1.7, 0.44444444444444
80888, 0.95652173913043, 1.6, 0.027777777777778
80889, 0.97826086956522, 1.6, 0.055555555555556
80890, 0.95652173913043, 1.575, 0.055555555555556
80891, 0.95652173913043, 1.6, 0.083333333333333
80892, 0.97826086956522, 1.6, 0.11111111111111
80893, 0.95652173913043, 1.575, 0.11111111111111
80894, 0.95652173913044, 1.6, 0.13888888888889
80895, 0.97826086956522, 1.6, 0.16666666666667
80896, 0.95652173913043, 1.575, 0.16666666666667
80897, 0.95652173913043, 1.6, 0.19444444444444
80898, 0.97826086956522, 1.6, 0.22222222222222
80899, 0.95652173913043, 1.575, 0.22222222222222
80900, 0.95652173913044, 1.6, 0.25
80901, 0.97826086956522, 1.6, 0.27777777777778
80902, 0.95652173913043, 1.575, 0.27777777777778
80903, 0.95652173913043, 1.6, 0.30555555555556
80904, 0.97826086956522, 1.6, 0.33333333333333
80905, 0.95652173913043, 1.575, 0.33333333333333
80906, 0.95652173913043, 1.6, 0.36111111111111
80907, 0.97826086956522, 1.6, 0.38888888888889
80908, 0.95652173913043, 1.575, 0.38888888888889
80909, 0.95652173913043, 1.6, 0.41666666666667
80910, 0.97826086956522, 1.6, 0.44444444444444
80911, 0.95652173913043, 1.575, 0.44444444444444
80912, 0.95652173913043, 1.6, 0.47222222222222
80913, 0.91304347826087, 1.6, 0.027777777777778
80914, 0.93478260869565, 1.6, 0.055555555555556
80915, 0.91304347826087, 1.575, 0.055555555555556
80916, 0.91304347826087, 1.6, 0.083333333333333
80917, 0.93478260869565, 1.6, 0.11111111111111
80918, 0.91304347826087, 1.575, 0.11111111111111
80919, 0.91304347826087, 1.6, 0.13888888888889
80920, 0.93478260869565, 1.6, 0.16666666666667
80921, 0.91304347826087, 1.575, 0.16666666666667
80922, 0.91304347826087, 1.6, 0.19444444444444
80923, 0.93478260869565, 1.6, 0.22222222222222
80924, 0.91304347826087, 1.575, 0.22222222222222
80925, 0.91304347826087, 1.6, 0.25
80926, 0.93478260869565, 1.6, 0.27777777777778
80927, 0.91304347826087, 1.575, 0.27777777777778
80928, 0.91304347826087, 1.6, 0.30555555555556
80929, 0.93478260869565, 1.6, 0.33333333333333
80930, 0.91304347826087, 1.575, 0.33333333333333
80931, 0.91304347826087, 1.6, 0.36111111111111
80932, 0.93478260869565, 1.6, 0.38888888888889
80933, 0.91304347826087, 1.575, 0.38888888888889
80934, 0.91304347826087, 1.6, 0.41666666666667
80935, 0.93478260869565, 1.6, 0.44444444444444
80936, 0.91304347826087, 1.575, 0.44444444444444
80937, 0.91304347826087, 1.6, 0.47222222222222
80938, 0.8695652173913, 1.6, 0.027777777777778
80939, 0.89130434782609, 1.6, 0.055555555555556
80940, 0.8695652173913, 1.575, 0.055555555555556
80941, 0.8695652173913, 1.6, 0.083333333333333
80942, 0.89130434782609, 1.6, 0.11111111111111
80943, 0.8695652173913, 1.575, 0.11111111111111
80944, 0.8695652173913, 1.6, 0.13888888888889
80945, 0.89130434782609, 1.6, 0.16666666666667
80946, 0.8695652173913, 1.575, 0.16666666666667
80947, 0.8695652173913, 1.6, 0.19444444444444
80948, 0.89130434782609, 1.6, 0.22222222222222
80949, 0.8695652173913, 1.575, 0.22222222222222
80950, 0.8695652173913, 1.6, 0.25
80951, 0.89130434782609, 1.6, 0.27777777777778
80952, 0.8695652173913, 1.575, 0.27777777777778
80953, 0.8695652173913, 1.6, 0.30555555555556
80954, 0.89130434782609, 1.6, 0.33333333333333
80955, 0.8695652173913, 1.575, 0.33333333333333
80956, 0.8695652173913, 1.6, 0.36111111111111
80957, 0.89130434782609, 1.6, 0.38888888888889
80958, 0.8695652173913, 1.575, 0.38888888888889
80959, 0.8695652173913, 1.6, 0.41666666666667
80960, 0.89130434782609, 1.6, 0.44444444444444
80961, 0.8695652173913, 1.575, 0.44444444444444
80962, 0.8695652173913, 1.6, 0.47222222222222
80963, 0.82608695652174, 1.6, 0.027777777777778
80964, 0.84782608695652, 1.6, 0.055555555555556
80965, 0.82608695652174, 1.575, 0.055555555555556
80966, 0.82608695652174, 1.6, 0.083333333333333
80967, 0.84782608695652, 1.6, 0.11111111111111
80968, 0.82608695652174, 1.575, 0.11111111111111
80969, 0.82608695652174, 1.6, 0.13888888888889
80970, 0.84782608695652, 1.6, 0.16666666666667
80971, 0.82608695652174, 1.575, 0.16666666666667
80972, 0.82608695652174, 1.6, 0.19444444444444
80973, 0.84782608695652, 1.6, 0.22222222222222
80974, 0.82608695652174, 1.575, 0.22222222222222
80975, 0.82608695652174, 1.6, 0.25
80976, 0.84782608695652, 1.6, 0.27777777777778
80977, 0.82608695652174, 1.575, 0.27777777777778
80978, 0.82608695652174, 1.6, 0.30555555555556
80979, 0.84782608695652, 1.6, 0.33333333333333
80980, 0.82608695652174, 1.575, 0.33333333333333
80981, 0.82608695652174, 1.6, 0.36111111111111
80982, 0.84782608695652, 1.6, 0.38888888888889
80983, 0.82608695652174, 1.575, 0.38888888888889
80984, 0.82608695652174, 1.6, 0.41666666666667
80985, 0.84782608695652, 1.6, 0.44444444444444
80986, 0.82608695652174, 1.575, 0.44444444444444
80987, 0.82608695652174, 1.6, 0.47222222222222
80988, 0.78260869565217, 1.6, 0.027777777777778
80989, 0.80434782608696, 1.6, 0.055555555555556
80990, 0.78260869565217, 1.575, 0.055555555555556
80991, 0.78260869565217, 1.6, 0.083333333333333
80992, 0.80434782608696, 1.6, 0.11111111111111
80993, 0.78260869565217, 1.575, 0.11111111111111
80994, 0.78260869565217, 1.6, 0.13888888888889
80995, 0.80434782608696, 1.6, 0.16666666666667
80996, 0.78260869565217, 1.575, 0.16666666666667
80997, 0.78260869565217, 1.6, 0.19444444444444
80998, 0.80434782608696, 1.6, 0.22222222222222
80999, 0.78260869565217, 1.575, 0.22222222222222
81000, 0.78260869565217, 1.6, 0.25
81001, 0.80434782608696, 1.6, 0.27777777777778
81002, 0.78260869565217, 1.575, 0.27777777777778
81003, 0.78260869565217, 1.6, 0.30555555555556
81004, 0.80434782608696, 1.6, 0.33333333333333
81005, 0.78260869565217, 1.575, 0.33333333333333
81006, 0.78260869565217, 1.6, 0.36111111111111
81007, 0.80434782608696, 1.6, 0.38888888888889
81008, 0.78260869565217, 1.575, 0.38888888888889
81009, 0.78260869565217, 1.6, 0.41666666666667
81010, 0.80434782608696, 1.6, 0.44444444444444
81011, 0.78260869565217, 1.575, 0.44444444444444
81012, 0.78260869565217, 1.6, 0.47222222222222
81013, 0.73913043478261, 1.6, 0.027777777777778
81014, 0.76086956521739, 1.6, 0.055555555555556
81015, 0.73913043478261, 1.575, 0.055555555555556
81016, 0.73913043478261, 1.6, 0.083333333333333
81017, 0.76086956521739, 1.6, 0.11111111111111
81018, 0.73913043478261, 1.575, 0.11111111111111
81019, 0.73913043478261, 1.6, 0.13888888888889
81020, 0.76086956521739, 1.6, 0.16666666666667
81021, 0.73913043478261, 1.575, 0.16666666666667
81022, 0.73913043478261, 1.6, 0.19444444444444
81023, 0.76086956521739, 1.6, 0.22222222222222
81024, 0.73913043478261, 1.575, 0.22222222222222
81025, 0.73913043478261, 1.6, 0.25
81026, 0.76086956521739, 1.6, 0.27777777777778
81027, 0.73913043478261, 1.575, 0.27777777777778
81028, 0.73913043478261, 1.6, 0.30555555555556
81029, 0.76086956521739, 1.6, 0.33333333333333
81030, 0.73913043478261, 1.575, 0.33333333333333
81031, 0.73913043478261, 1.6, 0.36111111111111
81032, 0.76086956521739, 1.6, 0.38888888888889
81033, 0.73913043478261, 1.575, 0.38888888888889
81034, 0.73913043478261, 1.6, 0.41666666666667
81035, 0.76086956521739, 1.6, 0.44444444444444
81036, 0.73913043478261, 1.575, 0.44444444444444
81037, 0.73913043478261, 1.6, 0.47222222222222
81038, 0.69565217391304, 1.6, 0.027777777777778
81039, 0.71739130434783, 1.6, 0.055555555555556
81040, 0.69565217391304, 1.575, 0.055555555555556
81041, 0.69565217391304, 1.6, 0.083333333333333
81042, 0.71739130434783, 1.6, 0.11111111111111
81043, 0.69565217391304, 1.575, 0.11111111111111
81044, 0.69565217391304, 1.6, 0.13888888888889
81045, 0.71739130434783, 1.6, 0.16666666666667
81046, 0.69565217391304, 1.575, 0.16666666666667
81047, 0.69565217391304, 1.6, 0.19444444444444
81048, 0.71739130434783, 1.6, 0.22222222222222
81049, 0.69565217391304, 1.575, 0.22222222222222
81050, 0.69565217391304, 1.6, 0.25
81051, 0.71739130434783, 1.6, 0.27777777777778
81052, 0.69565217391304, 1.575, 0.27777777777778
81053, 0.69565217391304, 1.6, 0.30555555555556
81054, 0.71739130434783, 1.6, 0.33333333333333
81055, 0.69565217391304, 1.575, 0.33333333333333
81056, 0.69565217391304, 1.6, 0.36111111111111
81057, 0.71739130434783, 1.6, 0.38888888888889
81058, 0.69565217391304, 1.575, 0.38888888888889
81059, 0.69565217391304, 1.6, 0.41666666666667
81060, 0.71739130434783, 1.6, 0.44444444444444
81061, 0.69565217391304, 1.575, 0.44444444444444
81062, 0.69565217391304, 1.6, 0.47222222222222
81063, 0.65217391304348, 1.6, 0.027777777777778
81064, 0.67391304347826, 1.6, 0.055555555555556
81065, 0.65217391304348, 1.575, 0.055555555555556
81066, 0.65217391304348, 1.6, 0.083333333333333
81067, 0.67391304347826, 1.6, 0.11111111111111
81068, 0.65217391304348, 1.575, 0.11111111111111
81069, 0.65217391304348, 1.6, 0.13888888888889
81070, 0.67391304347826, 1.6, 0.16666666666667
81071, 0.65217391304348, 1.575, 0.16666666666667
81072, 0.65217391304348, 1.6, 0.19444444444444
81073, 0.67391304347826, 1.6, 0.22222222222222
81074, 0.65217391304348, 1.575, 0.22222222222222
81075, 0.65217391304348, 1.6, 0.25
81076, 0.67391304347826, 1.6, 0.27777777777778
81077, 0.65217391304348, 1.575, 0.27777777777778
81078, 0.65217391304348, 1.6, 0.30555555555556
81079, 0.67391304347826, 1.6, 0.33333333333333
81080, 0.65217391304348, 1.575, 0.33333333333333
81081, 0.65217391304348, 1.6, 0.36111111111111
81082, 0.67391304347826, 1.6, 0.38888888888889
81083, 0.65217391304348, 1.575, 0.38888888888889
81084, 0.65217391304348, 1.6, 0.41666666666667
81085, 0.67391304347826, 1.6, 0.44444444444444
81086, 0.65217391304348, 1.575, 0.44444444444444
81087, 0.65217391304348, 1.6, 0.47222222222222
81088, 0.60869565217391, 1.6, 0.027777777777778
81089, 0.6304347826087, 1.6, 0.055555555555556
81090, 0.60869565217391, 1.575, 0.055555555555556
81091, 0.60869565217391, 1.6, 0.083333333333333
81092, 0.6304347826087, 1.6, 0.11111111111111
81093, 0.60869565217391, 1.575, 0.11111111111111
81094, 0.60869565217391, 1.6, 0.13888888888889
81095, 0.6304347826087, 1.6, 0.16666666666667
81096, 0.60869565217391, 1.575, 0.16666666666667
81097, 0.60869565217391, 1.6, 0.19444444444444
81098, 0.6304347826087, 1.6, 0.22222222222222
81099, 0.60869565217391, 1.575, 0.22222222222222
81100, 0.60869565217391, 1.6, 0.25
81101, 0.6304347826087, 1.6, 0.27777777777778
81102, 0.60869565217391, 1.575, 0.27777777777778
81103, 0.60869565217391, 1.6, 0.30555555555556
81104, 0.6304347826087, 1.6, 0.33333333333333
81105, 0.60869565217391, 1.575, 0.33333333333333
81106, 0.60869565217391, 1.6, 0.36111111111111
81107, 0.6304347826087, 1.6, 0.38888888888889
81108, 0.60869565217391, 1.575, 0.38888888888889
81109, 0.60869565217391, 1.6, 0.41666666666667
81110, 0.6304347826087, 1.6, 0.44444444444444
81111, 0.60869565217391, 1.575, 0.44444444444444
81112, 0.60869565217391, 1.6, 0.47222222222222
81113, 0.56521739130435, 1.6, 0.027777777777778
81114, 0.58695652173913, 1.6, 0.055555555555556
81115, 0.56521739130435, 1.575, 0.055555555555556
81116, 0.56521739130435, 1.6, 0.083333333333333
81117, 0.58695652173913, 1.6, 0.11111111111111
81118, 0.56521739130435, 1.575, 0.11111111111111
81119, 0.56521739130435, 1.6, 0.13888888888889
81120, 0.58695652173913, 1.6, 0.16666666666667
81121, 0.56521739130435, 1.575, 0.16666666666667
81122, 0.56521739130435, 1.6, 0.19444444444444
81123, 0.58695652173913, 1.6, 0.22222222222222
81124, 0.56521739130435, 1.575, 0.22222222222222
81125, 0.56521739130435, 1.6, 0.25
81126, 0.58695652173913, 1.6, 0.27777777777778
81127, 0.56521739130435, 1.575, 0.27777777777778
81128, 0.56521739130435, 1.6, 0.30555555555556
81129, 0.58695652173913, 1.6, 0.33333333333333
81130, 0.56521739130435, 1.575, 0.33333333333333
81131, 0.56521739130435, 1.6, 0.36111111111111
81132, 0.58695652173913, 1.6, 0.38888888888889
81133, 0.56521739130435, 1.575, 0.38888888888889
81134, 0.56521739130435, 1.6, 0.41666666666667
81135, 0.58695652173913, 1.6, 0.44444444444444
81136, 0.56521739130435, 1.575, 0.44444444444444
81137, 0.56521739130435, 1.6, 0.47222222222222
81138, 0.52173913043478, 1.6, 0.027777777777778
81139, 0.54347826086957, 1.6, 0.055555555555556
81140, 0.52173913043478, 1.575, 0.055555555555556
81141, 0.52173913043478, 1.6, 0.083333333333333
81142, 0.54347826086956, 1.6, 0.11111111111111
81143, 0.52173913043478, 1.575, 0.11111111111111
81144, 0.52173913043478, 1.6, 0.13888888888889
81145, 0.54347826086956, 1.6, 0.16666666666667
81146, 0.52173913043478, 1.575, 0.16666666666667
81147, 0.52173913043478, 1.6, 0.19444444444444
81148, 0.54347826086956, 1.6, 0.22222222222222
81149, 0.52173913043478, 1.575, 0.22222222222222
81150, 0.52173913043478, 1.6, 0.25
81151, 0.54347826086956, 1.6, 0.27777777777778
81152, 0.52173913043478, 1.575, 0.27777777777778
81153, 0.52173913043478, 1.6, 0.30555555555556
81154, 0.54347826086956, 1.6, 0.33333333333333
81155, 0.52173913043478, 1.575, 0.33333333333333
81156, 0.52173913043478, 1.6, 0.36111111111111
81157, 0.54347826086956, 1.6, 0.38888888888889
81158, 0.52173913043478, 1.575, 0.38888888888889
81159, 0.52173913043478, 1.6, 0.41666666666667
81160, 0.54347826086956, 1.6, 0.44444444444444
81161, 0.52173913043478, 1.575, 0.44444444444444
81162, 0.52173913043478, 1.6, 0.47222222222222
81163, 0.47826086956522, 1.6, 0.027777777777778
81164, 0.5, 1.6, 0.055555555555556
81165, 0.47826086956522, 1.575, 0.055555555555556
81166, 0.47826086956522, 1.6, 0.083333333333333
81167, 0.5, 1.6, 0.11111111111111
81168, 0.47826086956522, 1.575, 0.11111111111111
81169, 0.47826086956522, 1.6, 0.13888888888889
81170, 0.5, 1.6, 0.16666666666667
81171, 0.47826086956522, 1.575, 0.16666666666667
81172, 0.47826086956522, 1.6, 0.19444444444444
81173, 0.5, 1.6, 0.22222222222222
81174, 0.47826086956522, 1.575, 0.22222222222222
81175, 0.47826086956522, 1.6, 0.25
81176, 0.5, 1.6, 0.27777777777778
81177, 0.47826086956522, 1.575, 0.27777777777778
81178, 0.47826086956522, 1.6, 0.30555555555556
81179, 0.5, 1.6, 0.33333333333333
81180, 0.47826086956522, 1.575, 0.33333333333333
81181, 0.47826086956522, 1.6, 0.36111111111111
81182, 0.5, 1.6, 0.38888888888889
81183, 0.47826086956522, 1.575, 0.38888888888889
81184, 0.47826086956522, 1.6, 0.41666666666667
81185, 0.5, 1.6, 0.44444444444444
81186, 0.47826086956522, 1.575, 0.44444444444444
81187, 0.47826086956522, 1.6, 0.47222222222222
81188, 0.43478260869565, 1.6, 0.027777777777778
81189, 0.45652173913043, 1.6, 0.055555555555556
81190, 0.43478260869565, 1.575, 0.055555555555556
81191, 0.43478260869565, 1.6, 0.083333333333333
