41156, 0.34782608695652, 0.6195652173913, 0.27777777777778
41157, 0.34782608695652, 0.6195652173913, 0.33333333333333
41158, 0.34782608695652, 0.6195652173913, 0.38888888888889
41159, 0.34782608695652, 0.6195652173913, 0.44444444444444
41160, 0.30434782608696, 0.6195652173913, 0.055555555555556
41161, 0.30434782608696, 0.6195652173913, 0.11111111111111
41162, 0.30434782608696, 0.6195652173913, 0.16666666666667
41163, 0.30434782608696, 0.6195652173913, 0.22222222222222
41164, 0.30434782608696, 0.6195652173913, 0.27777777777778
41165, 0.30434782608696, 0.6195652173913, 0.33333333333333
41166, 0.30434782608696, 0.6195652173913, 0.38888888888889
41167, 0.30434782608696, 0.6195652173913, 0.44444444444444
41168, 0.26086956521739, 0.6195652173913, 0.055555555555556
41169, 0.26086956521739, 0.6195652173913, 0.11111111111111
41170, 0.26086956521739, 0.6195652173913, 0.16666666666667
41171, 0.26086956521739, 0.6195652173913, 0.22222222222222
41172, 0.26086956521739, 0.6195652173913, 0.27777777777778
41173, 0.26086956521739, 0.6195652173913, 0.33333333333333
41174, 0.26086956521739, 0.6195652173913, 0.38888888888889
41175, 0.26086956521739, 0.6195652173913, 0.44444444444444
41176, 0.21739130434783, 0.6195652173913, 0.055555555555556
41177, 0.21739130434783, 0.6195652173913, 0.11111111111111
41178, 0.21739130434783, 0.6195652173913, 0.16666666666667
41179, 0.21739130434783, 0.6195652173913, 0.22222222222222
41180, 0.21739130434783, 0.6195652173913, 0.27777777777778
41181, 0.21739130434783, 0.6195652173913, 0.33333333333333
41182, 0.21739130434783, 0.6195652173913, 0.38888888888889
41183, 0.21739130434783, 0.6195652173913, 0.44444444444444
41184, 0.17391304347826, 0.6195652173913, 0.055555555555556
41185, 0.17391304347826, 0.6195652173913, 0.11111111111111
41186, 0.17391304347826, 0.6195652173913, 0.16666666666667
41187, 0.17391304347826, 0.6195652173913, 0.22222222222222
41188, 0.17391304347826, 0.6195652173913, 0.27777777777778
41189, 0.17391304347826, 0.6195652173913, 0.33333333333333
41190, 0.17391304347826, 0.6195652173913, 0.38888888888889
41191, 0.17391304347826, 0.6195652173913, 0.44444444444444
41192, 0.1304347826087, 0.6195652173913, 0.055555555555556
41193, 0.1304347826087, 0.6195652173913, 0.11111111111111
41194, 0.1304347826087, 0.6195652173913, 0.16666666666667
41195, 0.1304347826087, 0.6195652173913, 0.22222222222222
41196, 0.1304347826087, 0.6195652173913, 0.27777777777778
41197, 0.1304347826087, 0.6195652173913, 0.33333333333333
41198, 0.1304347826087, 0.6195652173913, 0.38888888888889
41199, 0.1304347826087, 0.6195652173913, 0.44444444444444
41200, 0.08695652173913, 0.6195652173913, 0.055555555555556
41201, 0.08695652173913, 0.6195652173913, 0.11111111111111
41202, 0.08695652173913, 0.6195652173913, 0.16666666666667
41203, 0.08695652173913, 0.6195652173913, 0.22222222222222
41204, 0.08695652173913, 0.6195652173913, 0.27777777777778
41205, 0.08695652173913, 0.6195652173913, 0.33333333333333
41206, 0.08695652173913, 0.6195652173913, 0.38888888888889
41207, 0.08695652173913, 0.6195652173913, 0.44444444444444
41208, 0.043478260869565, 0.6195652173913, 0.055555555555556
41209, 0.043478260869565, 0.6195652173913, 0.11111111111111
41210, 0.043478260869565, 0.6195652173913, 0.16666666666667
41211, 0.043478260869565, 0.6195652173913, 0.22222222222222
41212, 0.043478260869565, 0.6195652173913, 0.27777777777778
41213, 0.043478260869565, 0.6195652173913, 0.33333333333333
41214, 0.043478260869565, 0.6195652173913, 0.38888888888889
41215, 0.043478260869565, 0.6195652173913, 0.44444444444444
41216, 0.95652173913043, 0.67173913043478, 0.055555555555556
41217, 0.95652173913044, 0.67173913043478, 0.11111111111111
41218, 0.95652173913044, 0.67173913043478, 0.16666666666667
41219, 0.95652173913044, 0.67173913043478, 0.22222222222222
41220, 0.95652173913043, 0.67173913043478, 0.27777777777778
41221, 0.95652173913044, 0.67173913043478, 0.33333333333333
41222, 0.95652173913044, 0.67173913043478, 0.38888888888889
41223, 0.95652173913044, 0.67173913043478, 0.44444444444444
41224, 0.91304347826087, 0.67173913043478, 0.055555555555556
41225, 0.91304347826087, 0.67173913043478, 0.11111111111111
41226, 0.91304347826087, 0.67173913043478, 0.16666666666667
41227, 0.91304347826087, 0.67173913043478, 0.22222222222222
41228, 0.91304347826087, 0.67173913043478, 0.27777777777778
41229, 0.91304347826087, 0.67173913043478, 0.33333333333333
41230, 0.91304347826087, 0.67173913043478, 0.38888888888889
41231, 0.91304347826087, 0.67173913043478, 0.44444444444444
41232, 0.8695652173913, 0.67173913043478, 0.055555555555556
41233, 0.8695652173913, 0.67173913043478, 0.11111111111111
41234, 0.8695652173913, 0.67173913043478, 0.16666666666667
41235, 0.8695652173913, 0.67173913043478, 0.22222222222222
41236, 0.8695652173913, 0.67173913043478, 0.27777777777778
41237, 0.8695652173913, 0.67173913043478, 0.33333333333333
41238, 0.8695652173913, 0.67173913043478, 0.38888888888889
41239, 0.8695652173913, 0.67173913043478, 0.44444444444444
41240, 0.82608695652174, 0.67173913043478, 0.055555555555556
41241, 0.82608695652174, 0.67173913043478, 0.11111111111111
41242, 0.82608695652174, 0.67173913043478, 0.16666666666667
41243, 0.82608695652174, 0.67173913043478, 0.22222222222222
41244, 0.82608695652174, 0.67173913043478, 0.27777777777778
41245, 0.82608695652174, 0.67173913043478, 0.33333333333333
41246, 0.82608695652174, 0.67173913043478, 0.38888888888889
41247, 0.82608695652174, 0.67173913043478, 0.44444444444444
41248, 0.78260869565217, 0.67173913043478, 0.055555555555556
41249, 0.78260869565217, 0.67173913043478, 0.11111111111111
41250, 0.78260869565217, 0.67173913043478, 0.16666666666667
41251, 0.78260869565217, 0.67173913043478, 0.22222222222222
41252, 0.78260869565217, 0.67173913043478, 0.27777777777778
41253, 0.78260869565217, 0.67173913043478, 0.33333333333333
41254, 0.78260869565217, 0.67173913043478, 0.38888888888889
41255, 0.78260869565217, 0.67173913043478, 0.44444444444444
41256, 0.73913043478261, 0.67173913043478, 0.055555555555556
41257, 0.73913043478261, 0.67173913043478, 0.11111111111111
41258, 0.73913043478261, 0.67173913043478, 0.16666666666667
41259, 0.73913043478261, 0.67173913043478, 0.22222222222222
41260, 0.73913043478261, 0.67173913043478, 0.27777777777778
41261, 0.73913043478261, 0.67173913043478, 0.33333333333333
41262, 0.73913043478261, 0.67173913043478, 0.38888888888889
41263, 0.73913043478261, 0.67173913043478, 0.44444444444444
41264, 0.69565217391304, 0.67173913043478, 0.055555555555556
41265, 0.69565217391304, 0.67173913043478, 0.11111111111111
41266, 0.69565217391304, 0.67173913043478, 0.16666666666667
41267, 0.69565217391304, 0.67173913043478, 0.22222222222222
41268, 0.69565217391304, 0.67173913043478, 0.27777777777778
41269, 0.69565217391304, 0.67173913043478, 0.33333333333333
41270, 0.69565217391304, 0.67173913043478, 0.38888888888889
41271, 0.69565217391304, 0.67173913043478, 0.44444444444444
41272, 0.65217391304348, 0.67173913043478, 0.055555555555556
41273, 0.65217391304348, 0.67173913043478, 0.11111111111111
41274, 0.65217391304348, 0.67173913043478, 0.16666666666667
41275, 0.65217391304348, 0.67173913043478, 0.22222222222222
41276, 0.65217391304348, 0.67173913043478, 0.27777777777778
41277, 0.65217391304348, 0.67173913043478, 0.33333333333333
41278, 0.65217391304348, 0.67173913043478, 0.38888888888889
41279, 0.65217391304348, 0.67173913043478, 0.44444444444444
41280, 0.60869565217391, 0.67173913043478, 0.055555555555556
41281, 0.60869565217391, 0.67173913043478, 0.11111111111111
41282, 0.60869565217391, 0.67173913043478, 0.16666666666667
41283, 0.60869565217391, 0.67173913043478, 0.22222222222222
41284, 0.60869565217391, 0.67173913043478, 0.27777777777778
41285, 0.60869565217391, 0.67173913043478, 0.33333333333333
41286, 0.60869565217391, 0.67173913043478, 0.38888888888889
41287, 0.60869565217391, 0.67173913043478, 0.44444444444444
41288, 0.56521739130435, 0.67173913043478, 0.055555555555556
41289, 0.56521739130435, 0.67173913043478, 0.11111111111111
41290, 0.56521739130435, 0.67173913043478, 0.16666666666667
41291, 0.56521739130435, 0.67173913043478, 0.22222222222222
41292, 0.56521739130435, 0.67173913043478, 0.27777777777778
41293, 0.56521739130435, 0.67173913043478, 0.33333333333333
41294, 0.56521739130435, 0.67173913043478, 0.38888888888889
41295, 0.56521739130435, 0.67173913043478, 0.44444444444444
41296, 0.52173913043478, 0.67173913043478, 0.055555555555556
41297, 0.52173913043478, 0.67173913043478, 0.11111111111111
41298, 0.52173913043478, 0.67173913043478, 0.16666666666667
41299, 0.52173913043478, 0.67173913043478, 0.22222222222222
41300, 0.52173913043478, 0.67173913043478, 0.27777777777778
41301, 0.52173913043478, 0.67173913043478, 0.33333333333333
41302, 0.52173913043478, 0.67173913043478, 0.38888888888889
41303, 0.52173913043478, 0.67173913043478, 0.44444444444444
41304, 0.47826086956522, 0.67173913043478, 0.055555555555556
41305, 0.47826086956522, 0.67173913043478, 0.11111111111111
41306, 0.47826086956522, 0.67173913043478, 0.16666666666667
41307, 0.47826086956522, 0.67173913043478, 0.22222222222222
41308, 0.47826086956522, 0.67173913043478, 0.27777777777778
41309, 0.47826086956522, 0.67173913043478, 0.33333333333333
41310, 0.47826086956522, 0.67173913043478, 0.38888888888889
41311, 0.47826086956522, 0.67173913043478, 0.44444444444444
41312, 0.43478260869565, 0.67173913043478, 0.055555555555556
41313, 0.43478260869565, 0.67173913043478, 0.11111111111111
41314, 0.43478260869565, 0.67173913043478, 0.16666666666667
41315, 0.43478260869565, 0.67173913043478, 0.22222222222222
41316, 0.43478260869565, 0.67173913043478, 0.27777777777778
41317, 0.43478260869565, 0.67173913043478, 0.33333333333333
41318, 0.43478260869565, 0.67173913043478, 0.38888888888889
41319, 0.43478260869565, 0.67173913043478, 0.44444444444444
41320, 0.39130434782609, 0.67173913043478, 0.055555555555556
41321, 0.39130434782609, 0.67173913043478, 0.11111111111111
41322, 0.39130434782609, 0.67173913043478, 0.16666666666667
41323, 0.39130434782609, 0.67173913043478, 0.22222222222222
41324, 0.39130434782609, 0.67173913043478, 0.27777777777778
41325, 0.39130434782609, 0.67173913043478, 0.33333333333333
41326, 0.39130434782609, 0.67173913043478, 0.38888888888889
41327, 0.39130434782609, 0.67173913043478, 0.44444444444444
41328, 0.34782608695652, 0.67173913043478, 0.055555555555556
41329, 0.34782608695652, 0.67173913043478, 0.11111111111111
41330, 0.34782608695652, 0.67173913043478, 0.16666666666667
41331, 0.34782608695652, 0.67173913043478, 0.22222222222222
41332, 0.34782608695652, 0.67173913043478, 0.27777777777778
41333, 0.34782608695652, 0.67173913043478, 0.33333333333333
41334, 0.34782608695652, 0.67173913043478, 0.38888888888889
41335, 0.34782608695652, 0.67173913043478, 0.44444444444444
41336, 0.30434782608696, 0.67173913043478, 0.055555555555556
41337, 0.30434782608696, 0.67173913043478, 0.11111111111111
41338, 0.30434782608696, 0.67173913043478, 0.16666666666667
41339, 0.30434782608696, 0.67173913043478, 0.22222222222222
41340, 0.30434782608696, 0.67173913043478, 0.27777777777778
41341, 0.30434782608696, 0.67173913043478, 0.33333333333333
41342, 0.30434782608696, 0.67173913043478, 0.38888888888889
41343, 0.30434782608696, 0.67173913043478, 0.44444444444444
41344, 0.26086956521739, 0.67173913043478, 0.055555555555556
41345, 0.26086956521739, 0.67173913043478, 0.11111111111111
41346, 0.26086956521739, 0.67173913043478, 0.16666666666667
41347, 0.26086956521739, 0.67173913043478, 0.22222222222222
41348, 0.26086956521739, 0.67173913043478, 0.27777777777778
41349, 0.26086956521739, 0.67173913043478, 0.33333333333333
41350, 0.26086956521739, 0.67173913043478, 0.38888888888889
41351, 0.26086956521739, 0.67173913043478, 0.44444444444444
41352, 0.21739130434783, 0.67173913043478, 0.055555555555556
41353, 0.21739130434783, 0.67173913043478, 0.11111111111111
41354, 0.21739130434783, 0.67173913043478, 0.16666666666667
41355, 0.21739130434783, 0.67173913043478, 0.22222222222222
41356, 0.21739130434783, 0.67173913043478, 0.27777777777778
41357, 0.21739130434783, 0.67173913043478, 0.33333333333333
41358, 0.21739130434783, 0.67173913043478, 0.38888888888889
41359, 0.21739130434783, 0.67173913043478, 0.44444444444444
41360, 0.17391304347826, 0.67173913043478, 0.055555555555556
41361, 0.17391304347826, 0.67173913043478, 0.11111111111111
41362, 0.17391304347826, 0.67173913043478, 0.16666666666667
41363, 0.17391304347826, 0.67173913043478, 0.22222222222222
41364, 0.17391304347826, 0.67173913043478, 0.27777777777778
41365, 0.17391304347826, 0.67173913043478, 0.33333333333333
41366, 0.17391304347826, 0.67173913043478, 0.38888888888889
41367, 0.17391304347826, 0.67173913043478, 0.44444444444444
41368, 0.1304347826087, 0.67173913043478, 0.055555555555556
41369, 0.1304347826087, 0.67173913043478, 0.11111111111111
41370, 0.1304347826087, 0.67173913043478, 0.16666666666667
41371, 0.1304347826087, 0.67173913043478, 0.22222222222222
41372, 0.1304347826087, 0.67173913043478, 0.27777777777778
41373, 0.1304347826087, 0.67173913043478, 0.33333333333333
41374, 0.1304347826087, 0.67173913043478, 0.38888888888889
41375, 0.1304347826087, 0.67173913043478, 0.44444444444444
41376, 0.08695652173913, 0.67173913043478, 0.055555555555556
41377, 0.08695652173913, 0.67173913043478, 0.11111111111111
41378, 0.08695652173913, 0.67173913043478, 0.16666666666667
41379, 0.08695652173913, 0.67173913043478, 0.22222222222222
41380, 0.08695652173913, 0.67173913043478, 0.27777777777778
41381, 0.08695652173913, 0.67173913043478, 0.33333333333333
41382, 0.08695652173913, 0.67173913043478, 0.38888888888889
41383, 0.08695652173913, 0.67173913043478, 0.44444444444444
41384, 0.043478260869565, 0.67173913043478, 0.055555555555556
41385, 0.043478260869565, 0.67173913043478, 0.11111111111111
41386, 0.043478260869565, 0.67173913043478, 0.16666666666667
41387, 0.043478260869565, 0.67173913043478, 0.22222222222222
41388, 0.043478260869565, 0.67173913043478, 0.27777777777778
41389, 0.043478260869565, 0.67173913043478, 0.33333333333333
41390, 0.043478260869565, 0.67173913043478, 0.38888888888889
41391, 0.043478260869565, 0.67173913043478, 0.44444444444444
41392, 0.95652173913043, 0.72391304347826, 0.055555555555556
41393, 0.95652173913044, 0.72391304347826, 0.11111111111111
41394, 0.95652173913044, 0.72391304347826, 0.16666666666667
41395, 0.95652173913044, 0.72391304347826, 0.22222222222222
41396, 0.95652173913044, 0.72391304347826, 0.27777777777778
41397, 0.95652173913044, 0.72391304347826, 0.33333333333333
41398, 0.95652173913044, 0.72391304347826, 0.38888888888889
41399, 0.95652173913044, 0.72391304347826, 0.44444444444444
41400, 0.91304347826087, 0.72391304347826, 0.055555555555556
41401, 0.91304347826087, 0.72391304347826, 0.11111111111111
41402, 0.91304347826087, 0.72391304347826, 0.16666666666667
41403, 0.91304347826087, 0.72391304347826, 0.22222222222222
41404, 0.91304347826087, 0.72391304347826, 0.27777777777778
41405, 0.91304347826087, 0.72391304347826, 0.33333333333333
41406, 0.91304347826087, 0.72391304347826, 0.38888888888889
41407, 0.91304347826087, 0.72391304347826, 0.44444444444444
41408, 0.8695652173913, 0.72391304347826, 0.055555555555556
41409, 0.8695652173913, 0.72391304347826, 0.11111111111111
41410, 0.8695652173913, 0.72391304347826, 0.16666666666667
41411, 0.8695652173913, 0.72391304347826, 0.22222222222222
41412, 0.8695652173913, 0.72391304347826, 0.27777777777778
41413, 0.8695652173913, 0.72391304347826, 0.33333333333333
41414, 0.8695652173913, 0.72391304347826, 0.38888888888889
41415, 0.8695652173913, 0.72391304347826, 0.44444444444444
41416, 0.82608695652174, 0.72391304347826, 0.055555555555556
41417, 0.82608695652174, 0.72391304347826, 0.11111111111111
41418, 0.82608695652174, 0.72391304347826, 0.16666666666667
41419, 0.82608695652174, 0.72391304347826, 0.22222222222222
41420, 0.82608695652174, 0.72391304347826, 0.27777777777778
41421, 0.82608695652174, 0.72391304347826, 0.33333333333333
41422, 0.82608695652174, 0.72391304347826, 0.38888888888889
41423, 0.82608695652174, 0.72391304347826, 0.44444444444444
41424, 0.78260869565217, 0.72391304347826, 0.055555555555556
41425, 0.78260869565217, 0.72391304347826, 0.11111111111111
41426, 0.78260869565217, 0.72391304347826, 0.16666666666667
41427, 0.78260869565217, 0.72391304347826, 0.22222222222222
41428, 0.78260869565217, 0.72391304347826, 0.27777777777778
41429, 0.78260869565217, 0.72391304347826, 0.33333333333333
41430, 0.78260869565217, 0.72391304347826, 0.38888888888889
41431, 0.78260869565217, 0.72391304347826, 0.44444444444444
41432, 0.73913043478261, 0.72391304347826, 0.055555555555556
41433, 0.73913043478261, 0.72391304347826, 0.11111111111111
41434, 0.73913043478261, 0.72391304347826, 0.16666666666667
41435, 0.73913043478261, 0.72391304347826, 0.22222222222222
41436, 0.73913043478261, 0.72391304347826, 0.27777777777778
41437, 0.73913043478261, 0.72391304347826, 0.33333333333333
41438, 0.73913043478261, 0.72391304347826, 0.38888888888889
41439, 0.73913043478261, 0.72391304347826, 0.44444444444444
41440, 0.69565217391304, 0.72391304347826, 0.055555555555556
41441, 0.69565217391304, 0.72391304347826, 0.11111111111111
41442, 0.69565217391304, 0.72391304347826, 0.16666666666667
41443, 0.69565217391304, 0.72391304347826, 0.22222222222222
41444, 0.69565217391304, 0.72391304347826, 0.27777777777778
41445, 0.69565217391304, 0.72391304347826, 0.33333333333333
41446, 0.69565217391304, 0.72391304347826, 0.38888888888889
41447, 0.69565217391304, 0.72391304347826, 0.44444444444444
41448, 0.65217391304348, 0.72391304347826, 0.055555555555556
41449, 0.65217391304348, 0.72391304347826, 0.11111111111111
41450, 0.65217391304348, 0.72391304347826, 0.16666666666667
41451, 0.65217391304348, 0.72391304347826, 0.22222222222222
41452, 0.65217391304348, 0.72391304347826, 0.27777777777778
41453, 0.65217391304348, 0.72391304347826, 0.33333333333333
41454, 0.65217391304348, 0.72391304347826, 0.38888888888889
41455, 0.65217391304348, 0.72391304347826, 0.44444444444444
41456, 0.60869565217391, 0.72391304347826, 0.055555555555556
41457, 0.60869565217391, 0.72391304347826, 0.11111111111111
41458, 0.60869565217391, 0.72391304347826, 0.16666666666667
41459, 0.60869565217391, 0.72391304347826, 0.22222222222222
41460, 0.60869565217391, 0.72391304347826, 0.27777777777778
41461, 0.60869565217391, 0.72391304347826, 0.33333333333333
41462, 0.60869565217391, 0.72391304347826, 0.38888888888889
41463, 0.60869565217391, 0.72391304347826, 0.44444444444444
41464, 0.56521739130435, 0.72391304347826, 0.055555555555556
41465, 0.56521739130435, 0.72391304347826, 0.11111111111111
41466, 0.56521739130435, 0.72391304347826, 0.16666666666667
41467, 0.56521739130435, 0.72391304347826, 0.22222222222222
41468, 0.56521739130435, 0.72391304347826, 0.27777777777778
41469, 0.56521739130435, 0.72391304347826, 0.33333333333333
41470, 0.56521739130435, 0.72391304347826, 0.38888888888889
41471, 0.56521739130435, 0.72391304347826, 0.44444444444444
41472, 0.52173913043478, 0.72391304347826, 0.055555555555556
41473, 0.52173913043478, 0.72391304347826, 0.11111111111111
41474, 0.52173913043478, 0.72391304347826, 0.16666666666667
41475, 0.52173913043478, 0.72391304347826, 0.22222222222222
41476, 0.52173913043478, 0.72391304347826, 0.27777777777778
41477, 0.52173913043478, 0.72391304347826, 0.33333333333333
41478, 0.52173913043478, 0.72391304347826, 0.38888888888889
41479, 0.52173913043478, 0.72391304347826, 0.44444444444444
41480, 0.47826086956522, 0.72391304347826, 0.055555555555556
41481, 0.47826086956522, 0.72391304347826, 0.11111111111111
41482, 0.47826086956522, 0.72391304347826, 0.16666666666667
41483, 0.47826086956522, 0.72391304347826, 0.22222222222222
41484, 0.47826086956522, 0.72391304347826, 0.27777777777778
41485, 0.47826086956522, 0.72391304347826, 0.33333333333333
41486, 0.47826086956522, 0.72391304347826, 0.38888888888889
41487, 0.47826086956522, 0.72391304347826, 0.44444444444444
41488, 0.43478260869565, 0.72391304347826, 0.055555555555556
41489, 0.43478260869565, 0.72391304347826, 0.11111111111111
41490, 0.43478260869565, 0.72391304347826, 0.16666666666667
41491, 0.43478260869565, 0.72391304347826, 0.22222222222222
41492, 0.43478260869565, 0.72391304347826, 0.27777777777778
41493, 0.43478260869565, 0.72391304347826, 0.33333333333333
41494, 0.43478260869565, 0.72391304347826, 0.38888888888889
41495, 0.43478260869565, 0.72391304347826, 0.44444444444444
41496, 0.39130434782609, 0.72391304347826, 0.055555555555556
41497, 0.39130434782609, 0.72391304347826, 0.11111111111111
41498, 0.39130434782609, 0.72391304347826, 0.16666666666667
41499, 0.39130434782609, 0.72391304347826, 0.22222222222222
41500, 0.39130434782609, 0.72391304347826, 0.27777777777778
41501, 0.39130434782609, 0.72391304347826, 0.33333333333333
41502, 0.39130434782609, 0.72391304347826, 0.38888888888889
41503, 0.39130434782609, 0.72391304347826, 0.44444444444444
41504, 0.34782608695652, 0.72391304347826, 0.055555555555556
41505, 0.34782608695652, 0.72391304347826, 0.11111111111111
41506, 0.34782608695652, 0.72391304347826, 0.16666666666667
41507, 0.34782608695652, 0.72391304347826, 0.22222222222222
41508, 0.34782608695652, 0.72391304347826, 0.27777777777778
41509, 0.34782608695652, 0.72391304347826, 0.33333333333333
41510, 0.34782608695652, 0.72391304347826, 0.38888888888889
41511, 0.34782608695652, 0.72391304347826, 0.44444444444444
41512, 0.30434782608696, 0.72391304347826, 0.055555555555556
41513, 0.30434782608696, 0.72391304347826, 0.11111111111111
41514, 0.30434782608696, 0.72391304347826, 0.16666666666667
41515, 0.30434782608696, 0.72391304347826, 0.22222222222222
41516, 0.30434782608696, 0.72391304347826, 0.27777777777778
41517, 0.30434782608696, 0.72391304347826, 0.33333333333333
41518, 0.30434782608696, 0.72391304347826, 0.38888888888889
41519, 0.30434782608696, 0.72391304347826, 0.44444444444444
41520, 0.26086956521739, 0.72391304347826, 0.055555555555556
41521, 0.26086956521739, 0.72391304347826, 0.11111111111111
41522, 0.26086956521739, 0.72391304347826, 0.16666666666667
41523, 0.26086956521739, 0.72391304347826, 0.22222222222222
41524, 0.26086956521739, 0.72391304347826, 0.27777777777778
41525, 0.26086956521739, 0.72391304347826, 0.33333333333333
41526, 0.26086956521739, 0.72391304347826, 0.38888888888889
41527, 0.26086956521739, 0.72391304347826, 0.44444444444444
41528, 0.21739130434783, 0.72391304347826, 0.055555555555556
41529, 0.21739130434783, 0.72391304347826, 0.11111111111111
41530, 0.21739130434783, 0.72391304347826, 0.16666666666667
41531, 0.21739130434783, 0.72391304347826, 0.22222222222222
41532, 0.21739130434783, 0.72391304347826, 0.27777777777778
41533, 0.21739130434783, 0.72391304347826, 0.33333333333333
41534, 0.21739130434783, 0.72391304347826, 0.38888888888889
41535, 0.21739130434783, 0.72391304347826, 0.44444444444444
41536, 0.17391304347826, 0.72391304347826, 0.055555555555556
41537, 0.17391304347826, 0.72391304347826, 0.11111111111111
41538, 0.17391304347826, 0.72391304347826, 0.16666666666667
41539, 0.17391304347826, 0.72391304347826, 0.22222222222222
41540, 0.17391304347826, 0.72391304347826, 0.27777777777778
41541, 0.17391304347826, 0.72391304347826, 0.33333333333333
41542, 0.17391304347826, 0.72391304347826, 0.38888888888889
41543, 0.17391304347826, 0.72391304347826, 0.44444444444444
41544, 0.1304347826087, 0.72391304347826, 0.055555555555556
41545, 0.1304347826087, 0.72391304347826, 0.11111111111111
41546, 0.1304347826087, 0.72391304347826, 0.16666666666667
41547, 0.1304347826087, 0.72391304347826, 0.22222222222222
41548, 0.1304347826087, 0.72391304347826, 0.27777777777778
41549, 0.1304347826087, 0.72391304347826, 0.33333333333333
41550, 0.1304347826087, 0.72391304347826, 0.38888888888889
41551, 0.1304347826087, 0.72391304347826, 0.44444444444444
41552, 0.08695652173913, 0.72391304347826, 0.055555555555556
41553, 0.08695652173913, 0.72391304347826, 0.11111111111111
41554, 0.08695652173913, 0.72391304347826, 0.16666666666667
41555, 0.08695652173913, 0.72391304347826, 0.22222222222222
41556, 0.08695652173913, 0.72391304347826, 0.27777777777778
41557, 0.08695652173913, 0.72391304347826, 0.33333333333333
41558, 0.08695652173913, 0.72391304347826, 0.38888888888889
41559, 0.08695652173913, 0.72391304347826, 0.44444444444444
41560, 0.043478260869565, 0.72391304347826, 0.055555555555556
41561, 0.043478260869565, 0.72391304347826, 0.11111111111111
41562, 0.043478260869565, 0.72391304347826, 0.16666666666667
41563, 0.043478260869565, 0.72391304347826, 0.22222222222222
41564, 0.043478260869565, 0.72391304347826, 0.27777777777778
41565, 0.043478260869565, 0.72391304347826, 0.33333333333333
41566, 0.043478260869565, 0.72391304347826, 0.38888888888889
41567, 0.043478260869565, 0.72391304347826, 0.44444444444444
41568, 0.95652173913043, 0.77608695652174, 0.055555555555556
41569, 0.95652173913044, 0.77608695652174, 0.11111111111111
41570, 0.95652173913044, 0.77608695652174, 0.16666666666667
41571, 0.95652173913044, 0.77608695652174, 0.22222222222222
41572, 0.95652173913044, 0.77608695652174, 0.27777777777778
41573, 0.95652173913044, 0.77608695652174, 0.33333333333333
41574, 0.95652173913044, 0.77608695652174, 0.38888888888889
41575, 0.95652173913044, 0.77608695652174, 0.44444444444444
41576, 0.91304347826087, 0.77608695652174, 0.055555555555556
41577, 0.91304347826087, 0.77608695652174, 0.11111111111111
41578, 0.91304347826087, 0.77608695652174, 0.16666666666667
41579, 0.91304347826087, 0.77608695652174, 0.22222222222222
41580, 0.91304347826087, 0.77608695652174, 0.27777777777778
41581, 0.91304347826087, 0.77608695652174, 0.33333333333333
41582, 0.91304347826087, 0.77608695652174, 0.38888888888889
41583, 0.91304347826087, 0.77608695652174, 0.44444444444444
41584, 0.8695652173913, 0.77608695652174, 0.055555555555556
41585, 0.8695652173913, 0.77608695652174, 0.11111111111111
41586, 0.8695652173913, 0.77608695652174, 0.16666666666667
41587, 0.8695652173913, 0.77608695652174, 0.22222222222222
41588, 0.8695652173913, 0.77608695652174, 0.27777777777778
41589, 0.8695652173913, 0.77608695652174, 0.33333333333333
41590, 0.8695652173913, 0.77608695652174, 0.38888888888889
41591, 0.8695652173913, 0.77608695652174, 0.44444444444444
41592, 0.82608695652174, 0.77608695652174, 0.055555555555556
41593, 0.82608695652174, 0.77608695652174, 0.11111111111111
41594, 0.82608695652174, 0.77608695652174, 0.16666666666667
41595, 0.82608695652174, 0.77608695652174, 0.22222222222222
41596, 0.82608695652174, 0.77608695652174, 0.27777777777778
41597, 0.82608695652174, 0.77608695652174, 0.33333333333333
41598, 0.82608695652174, 0.77608695652174, 0.38888888888889
41599, 0.82608695652174, 0.77608695652174, 0.44444444444444
41600, 0.78260869565217, 0.77608695652174, 0.055555555555556
41601, 0.78260869565217, 0.77608695652174, 0.11111111111111
41602, 0.78260869565217, 0.77608695652174, 0.16666666666667
41603, 0.78260869565217, 0.77608695652174, 0.22222222222222
41604, 0.78260869565217, 0.77608695652174, 0.27777777777778
41605, 0.78260869565217, 0.77608695652174, 0.33333333333333
41606, 0.78260869565217, 0.77608695652174, 0.38888888888889
41607, 0.78260869565217, 0.77608695652174, 0.44444444444444
41608, 0.73913043478261, 0.77608695652174, 0.055555555555556
41609, 0.73913043478261, 0.77608695652174, 0.11111111111111
41610, 0.73913043478261, 0.77608695652174, 0.16666666666667
41611, 0.73913043478261, 0.77608695652174, 0.22222222222222
41612, 0.73913043478261, 0.77608695652174, 0.27777777777778
41613, 0.73913043478261, 0.77608695652174, 0.33333333333333
41614, 0.73913043478261, 0.77608695652174, 0.38888888888889
41615, 0.73913043478261, 0.77608695652174, 0.44444444444444
41616, 0.69565217391304, 0.77608695652174, 0.055555555555556
41617, 0.69565217391304, 0.77608695652174, 0.11111111111111
41618, 0.69565217391304, 0.77608695652174, 0.16666666666667
41619, 0.69565217391304, 0.77608695652174, 0.22222222222222
41620, 0.69565217391304, 0.77608695652174, 0.27777777777778
41621, 0.69565217391304, 0.77608695652174, 0.33333333333333
41622, 0.69565217391304, 0.77608695652174, 0.38888888888889
41623, 0.69565217391304, 0.77608695652174, 0.44444444444444
41624, 0.65217391304348, 0.77608695652174, 0.055555555555556
41625, 0.65217391304348, 0.77608695652174, 0.11111111111111
41626, 0.65217391304348, 0.77608695652174, 0.16666666666667
41627, 0.65217391304348, 0.77608695652174, 0.22222222222222
41628, 0.65217391304348, 0.77608695652174, 0.27777777777778
41629, 0.65217391304348, 0.77608695652174, 0.33333333333333
41630, 0.65217391304348, 0.77608695652174, 0.38888888888889
41631, 0.65217391304348, 0.77608695652174, 0.44444444444444
41632, 0.60869565217391, 0.77608695652174, 0.055555555555556
41633, 0.60869565217391, 0.77608695652174, 0.11111111111111
41634, 0.60869565217391, 0.77608695652174, 0.16666666666667
41635, 0.60869565217391, 0.77608695652174, 0.22222222222222
41636, 0.60869565217391, 0.77608695652174, 0.27777777777778
41637, 0.60869565217391, 0.77608695652174, 0.33333333333333
41638, 0.60869565217391, 0.77608695652174, 0.38888888888889
41639, 0.60869565217391, 0.77608695652174, 0.44444444444444
41640, 0.56521739130435, 0.77608695652174, 0.055555555555556
41641, 0.56521739130435, 0.77608695652174, 0.11111111111111
41642, 0.56521739130435, 0.77608695652174, 0.16666666666667
41643, 0.56521739130435, 0.77608695652174, 0.22222222222222
41644, 0.56521739130435, 0.77608695652174, 0.27777777777778
41645, 0.56521739130435, 0.77608695652174, 0.33333333333333
41646, 0.56521739130435, 0.77608695652174, 0.38888888888889
41647, 0.56521739130435, 0.77608695652174, 0.44444444444444
41648, 0.52173913043478, 0.77608695652174, 0.055555555555556
41649, 0.52173913043478, 0.77608695652174, 0.11111111111111
41650, 0.52173913043478, 0.77608695652174, 0.16666666666667
41651, 0.52173913043478, 0.77608695652174, 0.22222222222222
41652, 0.52173913043478, 0.77608695652174, 0.27777777777778
41653, 0.52173913043478, 0.77608695652174, 0.33333333333333
41654, 0.52173913043478, 0.77608695652174, 0.38888888888889
41655, 0.52173913043478, 0.77608695652174, 0.44444444444444
41656, 0.47826086956522, 0.77608695652174, 0.055555555555556
41657, 0.47826086956522, 0.77608695652174, 0.11111111111111
41658, 0.47826086956522, 0.77608695652174, 0.16666666666667
41659, 0.47826086956522, 0.77608695652174, 0.22222222222222
41660, 0.47826086956522, 0.77608695652174, 0.27777777777778
41661, 0.47826086956522, 0.77608695652174, 0.33333333333333
41662, 0.47826086956522, 0.77608695652174, 0.38888888888889
41663, 0.47826086956522, 0.77608695652174, 0.44444444444444
41664, 0.43478260869565, 0.77608695652174, 0.055555555555556
41665, 0.43478260869565, 0.77608695652174, 0.11111111111111
41666, 0.43478260869565, 0.77608695652174, 0.16666666666667
41667, 0.43478260869565, 0.77608695652174, 0.22222222222222
41668, 0.43478260869565, 0.77608695652174, 0.27777777777778
41669, 0.43478260869565, 0.77608695652174, 0.33333333333333
41670, 0.43478260869565, 0.77608695652174, 0.38888888888889
41671, 0.43478260869565, 0.77608695652174, 0.44444444444444
41672, 0.39130434782609, 0.77608695652174, 0.055555555555556
41673, 0.39130434782609, 0.77608695652174, 0.11111111111111
41674, 0.39130434782609, 0.77608695652174, 0.16666666666667
41675, 0.39130434782609, 0.77608695652174, 0.22222222222222
41676, 0.39130434782609, 0.77608695652174, 0.27777777777778
41677, 0.39130434782609, 0.77608695652174, 0.33333333333333
41678, 0.39130434782609, 0.77608695652174, 0.38888888888889
41679, 0.39130434782609, 0.77608695652174, 0.44444444444444
41680, 0.34782608695652, 0.77608695652174, 0.055555555555556
41681, 0.34782608695652, 0.77608695652174, 0.11111111111111
41682, 0.34782608695652, 0.77608695652174, 0.16666666666667
41683, 0.34782608695652, 0.77608695652174, 0.22222222222222
41684, 0.34782608695652, 0.77608695652174, 0.27777777777778
41685, 0.34782608695652, 0.77608695652174, 0.33333333333333
41686, 0.34782608695652, 0.77608695652174, 0.38888888888889
41687, 0.34782608695652, 0.77608695652174, 0.44444444444444
41688, 0.30434782608696, 0.77608695652174, 0.055555555555556
41689, 0.30434782608696, 0.77608695652174, 0.11111111111111
41690, 0.30434782608696, 0.77608695652174, 0.16666666666667
41691, 0.30434782608696, 0.77608695652174, 0.22222222222222
41692, 0.30434782608696, 0.77608695652174, 0.27777777777778
41693, 0.30434782608696, 0.77608695652174, 0.33333333333333
41694, 0.30434782608696, 0.77608695652174, 0.38888888888889
41695, 0.30434782608696, 0.77608695652174, 0.44444444444444
41696, 0.26086956521739, 0.77608695652174, 0.055555555555556
41697, 0.26086956521739, 0.77608695652174, 0.11111111111111
41698, 0.26086956521739, 0.77608695652174, 0.16666666666667
41699, 0.26086956521739, 0.77608695652174, 0.22222222222222
41700, 0.26086956521739, 0.77608695652174, 0.27777777777778
41701, 0.26086956521739, 0.77608695652174, 0.33333333333333
41702, 0.26086956521739, 0.77608695652174, 0.38888888888889
41703, 0.26086956521739, 0.77608695652174, 0.44444444444444
41704, 0.21739130434783, 0.77608695652174, 0.055555555555556
41705, 0.21739130434783, 0.77608695652174, 0.11111111111111
41706, 0.21739130434783, 0.77608695652174, 0.16666666666667
41707, 0.21739130434783, 0.77608695652174, 0.22222222222222
41708, 0.21739130434783, 0.77608695652174, 0.27777777777778
41709, 0.21739130434783, 0.77608695652174, 0.33333333333333
41710, 0.21739130434783, 0.77608695652174, 0.38888888888889
41711, 0.21739130434783, 0.77608695652174, 0.44444444444444
41712, 0.17391304347826, 0.77608695652174, 0.055555555555556
41713, 0.17391304347826, 0.77608695652174, 0.11111111111111
41714, 0.17391304347826, 0.77608695652174, 0.16666666666667
41715, 0.17391304347826, 0.77608695652174, 0.22222222222222
41716, 0.17391304347826, 0.77608695652174, 0.27777777777778
41717, 0.17391304347826, 0.77608695652174, 0.33333333333333
41718, 0.17391304347826, 0.77608695652174, 0.38888888888889
41719, 0.17391304347826, 0.77608695652174, 0.44444444444444
41720, 0.1304347826087, 0.77608695652174, 0.055555555555556
41721, 0.1304347826087, 0.77608695652174, 0.11111111111111
41722, 0.1304347826087, 0.77608695652174, 0.16666666666667
41723, 0.1304347826087, 0.77608695652174, 0.22222222222222
41724, 0.1304347826087, 0.77608695652174, 0.27777777777778
41725, 0.1304347826087, 0.77608695652174, 0.33333333333333
41726, 0.1304347826087, 0.77608695652174, 0.38888888888889
41727, 0.1304347826087, 0.77608695652174, 0.44444444444444
41728, 0.08695652173913, 0.77608695652174, 0.055555555555556
41729, 0.08695652173913, 0.77608695652174, 0.11111111111111
41730, 0.08695652173913, 0.77608695652174, 0.16666666666667
41731, 0.08695652173913, 0.77608695652174, 0.22222222222222
41732, 0.08695652173913, 0.77608695652174, 0.27777777777778
41733, 0.08695652173913, 0.77608695652174, 0.33333333333333
41734, 0.08695652173913, 0.77608695652174, 0.38888888888889
41735, 0.08695652173913, 0.77608695652174, 0.44444444444444
41736, 0.043478260869565, 0.77608695652174, 0.055555555555556
41737, 0.043478260869565, 0.77608695652174, 0.11111111111111
41738, 0.043478260869565, 0.77608695652174, 0.16666666666667
41739, 0.043478260869565, 0.77608695652174, 0.22222222222222
41740, 0.043478260869565, 0.77608695652174, 0.27777777777778
41741, 0.043478260869565, 0.77608695652174, 0.33333333333333
41742, 0.043478260869565, 0.77608695652174, 0.38888888888889
41743, 0.043478260869565, 0.77608695652174, 0.44444444444444
41744, 0.95652173913043, 0.82826086956522, 0.055555555555556
41745, 0.95652173913044, 0.82826086956522, 0.11111111111111
41746, 0.95652173913044, 0.82826086956522, 0.16666666666667
41747, 0.95652173913044, 0.82826086956522, 0.22222222222222
41748, 0.95652173913044, 0.82826086956522, 0.27777777777778
41749, 0.95652173913044, 0.82826086956522, 0.33333333333333
41750, 0.95652173913044, 0.82826086956522, 0.38888888888889
41751, 0.95652173913044, 0.82826086956522, 0.44444444444444
41752, 0.91304347826087, 0.82826086956522, 0.055555555555556
41753, 0.91304347826087, 0.82826086956522, 0.11111111111111
41754, 0.91304347826087, 0.82826086956522, 0.16666666666667
41755, 0.91304347826087, 0.82826086956522, 0.22222222222222
41756, 0.91304347826087, 0.82826086956522, 0.27777777777778
41757, 0.91304347826087, 0.82826086956522, 0.33333333333333
41758, 0.91304347826087, 0.82826086956522, 0.38888888888889
41759, 0.91304347826087, 0.82826086956522, 0.44444444444444
41760, 0.8695652173913, 0.82826086956522, 0.055555555555556
41761, 0.8695652173913, 0.82826086956522, 0.11111111111111
41762, 0.8695652173913, 0.82826086956522, 0.16666666666667
41763, 0.8695652173913, 0.82826086956522, 0.22222222222222
41764, 0.8695652173913, 0.82826086956522, 0.27777777777778
41765, 0.8695652173913, 0.82826086956522, 0.33333333333333
41766, 0.8695652173913, 0.82826086956522, 0.38888888888889
41767, 0.8695652173913, 0.82826086956522, 0.44444444444444
41768, 0.82608695652174, 0.82826086956522, 0.055555555555556
41769, 0.82608695652174, 0.82826086956522, 0.11111111111111
41770, 0.82608695652174, 0.82826086956522, 0.16666666666667
41771, 0.82608695652174, 0.82826086956522, 0.22222222222222
41772, 0.82608695652174, 0.82826086956522, 0.27777777777778
41773, 0.82608695652174, 0.82826086956522, 0.33333333333333
41774, 0.82608695652174, 0.82826086956522, 0.38888888888889
41775, 0.82608695652174, 0.82826086956522, 0.44444444444444
41776, 0.78260869565217, 0.82826086956522, 0.055555555555556
41777, 0.78260869565217, 0.82826086956522, 0.11111111111111
41778, 0.78260869565217, 0.82826086956522, 0.16666666666667
41779, 0.78260869565217, 0.82826086956522, 0.22222222222222
41780, 0.78260869565217, 0.82826086956522, 0.27777777777778
41781, 0.78260869565217, 0.82826086956522, 0.33333333333333
41782, 0.78260869565217, 0.82826086956522, 0.38888888888889
41783, 0.78260869565217, 0.82826086956522, 0.44444444444444
41784, 0.73913043478261, 0.82826086956522, 0.055555555555556
41785, 0.73913043478261, 0.82826086956522, 0.11111111111111
41786, 0.73913043478261, 0.82826086956522, 0.16666666666667
41787, 0.73913043478261, 0.82826086956522, 0.22222222222222
41788, 0.73913043478261, 0.82826086956522, 0.27777777777778
41789, 0.73913043478261, 0.82826086956522, 0.33333333333333
41790, 0.73913043478261, 0.82826086956522, 0.38888888888889
41791, 0.73913043478261, 0.82826086956522, 0.44444444444444
41792, 0.69565217391304, 0.82826086956522, 0.055555555555556
41793, 0.69565217391304, 0.82826086956522, 0.11111111111111
41794, 0.69565217391304, 0.82826086956522, 0.16666666666667
41795, 0.69565217391304, 0.82826086956522, 0.22222222222222
41796, 0.69565217391304, 0.82826086956522, 0.27777777777778
41797, 0.69565217391304, 0.82826086956522, 0.33333333333333
41798, 0.69565217391304, 0.82826086956522, 0.38888888888889
41799, 0.69565217391304, 0.82826086956522, 0.44444444444444
41800, 0.65217391304348, 0.82826086956522, 0.055555555555556
41801, 0.65217391304348, 0.82826086956522, 0.11111111111111
41802, 0.65217391304348, 0.82826086956522, 0.16666666666667
41803, 0.65217391304348, 0.82826086956522, 0.22222222222222
41804, 0.65217391304348, 0.82826086956522, 0.27777777777778
41805, 0.65217391304348, 0.82826086956522, 0.33333333333333
41806, 0.65217391304348, 0.82826086956522, 0.38888888888889
41807, 0.65217391304348, 0.82826086956522, 0.44444444444444
41808, 0.60869565217391, 0.82826086956522, 0.055555555555556
41809, 0.60869565217391, 0.82826086956522, 0.11111111111111
41810, 0.60869565217391, 0.82826086956522, 0.16666666666667
41811, 0.60869565217391, 0.82826086956522, 0.22222222222222
41812, 0.60869565217391, 0.82826086956522, 0.27777777777778
41813, 0.60869565217391, 0.82826086956522, 0.33333333333333
41814, 0.60869565217391, 0.82826086956522, 0.38888888888889
41815, 0.60869565217391, 0.82826086956522, 0.44444444444444
41816, 0.56521739130435, 0.82826086956522, 0.055555555555556
41817, 0.56521739130435, 0.82826086956522, 0.11111111111111
41818, 0.56521739130435, 0.82826086956522, 0.16666666666667
41819, 0.56521739130435, 0.82826086956522, 0.22222222222222
41820, 0.56521739130435, 0.82826086956522, 0.27777777777778
41821, 0.56521739130435, 0.82826086956522, 0.33333333333333
41822, 0.56521739130435, 0.82826086956522, 0.38888888888889
41823, 0.56521739130435, 0.82826086956522, 0.44444444444444
41824, 0.52173913043478, 0.82826086956522, 0.055555555555556
41825, 0.52173913043478, 0.82826086956522, 0.11111111111111
41826, 0.52173913043478, 0.82826086956522, 0.16666666666667
41827, 0.52173913043478, 0.82826086956522, 0.22222222222222
41828, 0.52173913043478, 0.82826086956522, 0.27777777777778
41829, 0.52173913043478, 0.82826086956522, 0.33333333333333
41830, 0.52173913043478, 0.82826086956522, 0.38888888888889
41831, 0.52173913043478, 0.82826086956522, 0.44444444444444
41832, 0.47826086956522, 0.82826086956522, 0.055555555555556
41833, 0.47826086956522, 0.82826086956522, 0.11111111111111
41834, 0.47826086956522, 0.82826086956522, 0.16666666666667
41835, 0.47826086956522, 0.82826086956522, 0.22222222222222
41836, 0.47826086956522, 0.82826086956522, 0.27777777777778
41837, 0.47826086956522, 0.82826086956522, 0.33333333333333
41838, 0.47826086956522, 0.82826086956522, 0.38888888888889
41839, 0.47826086956522, 0.82826086956522, 0.44444444444444
41840, 0.43478260869565, 0.82826086956522, 0.055555555555556
41841, 0.43478260869565, 0.82826086956522, 0.11111111111111
41842, 0.43478260869565, 0.82826086956522, 0.16666666666667
41843, 0.43478260869565, 0.82826086956522, 0.22222222222222
41844, 0.43478260869565, 0.82826086956522, 0.27777777777778
41845, 0.43478260869565, 0.82826086956522, 0.33333333333333
41846, 0.43478260869565, 0.82826086956522, 0.38888888888889
41847, 0.43478260869565, 0.82826086956522, 0.44444444444444
41848, 0.39130434782609, 0.82826086956522, 0.055555555555556
41849, 0.39130434782609, 0.82826086956522, 0.11111111111111
41850, 0.39130434782609, 0.82826086956522, 0.16666666666667
41851, 0.39130434782609, 0.82826086956522, 0.22222222222222
41852, 0.39130434782609, 0.82826086956522, 0.27777777777778
41853, 0.39130434782609, 0.82826086956522, 0.33333333333333
41854, 0.39130434782609, 0.82826086956522, 0.38888888888889
41855, 0.39130434782609, 0.82826086956522, 0.44444444444444
41856, 0.34782608695652, 0.82826086956522, 0.055555555555556
41857, 0.34782608695652, 0.82826086956522, 0.11111111111111
41858, 0.34782608695652, 0.82826086956522, 0.16666666666667
41859, 0.34782608695652, 0.82826086956522, 0.22222222222222
41860, 0.34782608695652, 0.82826086956522, 0.27777777777778
41861, 0.34782608695652, 0.82826086956522, 0.33333333333333
41862, 0.34782608695652, 0.82826086956522, 0.38888888888889
41863, 0.34782608695652, 0.82826086956522, 0.44444444444444
41864, 0.30434782608696, 0.82826086956522, 0.055555555555556
41865, 0.30434782608696, 0.82826086956522, 0.11111111111111
41866, 0.30434782608696, 0.82826086956522, 0.16666666666667
41867, 0.30434782608696, 0.82826086956522, 0.22222222222222
41868, 0.30434782608696, 0.82826086956522, 0.27777777777778
41869, 0.30434782608696, 0.82826086956522, 0.33333333333333
41870, 0.30434782608696, 0.82826086956522, 0.38888888888889
41871, 0.30434782608696, 0.82826086956522, 0.44444444444444
41872, 0.26086956521739, 0.82826086956522, 0.055555555555556
41873, 0.26086956521739, 0.82826086956522, 0.11111111111111
41874, 0.26086956521739, 0.82826086956522, 0.16666666666667
41875, 0.26086956521739, 0.82826086956522, 0.22222222222222
41876, 0.26086956521739, 0.82826086956522, 0.27777777777778
41877, 0.26086956521739, 0.82826086956522, 0.33333333333333
41878, 0.26086956521739, 0.82826086956522, 0.38888888888889
41879, 0.26086956521739, 0.82826086956522, 0.44444444444444
41880, 0.21739130434783, 0.82826086956522, 0.055555555555556
41881, 0.21739130434783, 0.82826086956522, 0.11111111111111
41882, 0.21739130434783, 0.82826086956522, 0.16666666666667
41883, 0.21739130434783, 0.82826086956522, 0.22222222222222
41884, 0.21739130434783, 0.82826086956522, 0.27777777777778
41885, 0.21739130434783, 0.82826086956522, 0.33333333333333
41886, 0.21739130434783, 0.82826086956522, 0.38888888888889
41887, 0.21739130434783, 0.82826086956522, 0.44444444444444
41888, 0.17391304347826, 0.82826086956522, 0.055555555555556
41889, 0.17391304347826, 0.82826086956522, 0.11111111111111
41890, 0.17391304347826, 0.82826086956522, 0.16666666666667
41891, 0.17391304347826, 0.82826086956522, 0.22222222222222
41892, 0.17391304347826, 0.82826086956522, 0.27777777777778
41893, 0.17391304347826, 0.82826086956522, 0.33333333333333
41894, 0.17391304347826, 0.82826086956522, 0.38888888888889
41895, 0.17391304347826, 0.82826086956522, 0.44444444444444
41896, 0.1304347826087, 0.82826086956522, 0.055555555555556
41897, 0.1304347826087, 0.82826086956522, 0.11111111111111
41898, 0.1304347826087, 0.82826086956522, 0.16666666666667
41899, 0.1304347826087, 0.82826086956522, 0.22222222222222
41900, 0.1304347826087, 0.82826086956522, 0.27777777777778
41901, 0.1304347826087, 0.82826086956522, 0.33333333333333
41902, 0.1304347826087, 0.82826086956522, 0.38888888888889
41903, 0.1304347826087, 0.82826086956522, 0.44444444444444
41904, 0.08695652173913, 0.82826086956522, 0.055555555555556
41905, 0.08695652173913, 0.82826086956522, 0.11111111111111
41906, 0.08695652173913, 0.82826086956522, 0.16666666666667
41907, 0.08695652173913, 0.82826086956522, 0.22222222222222
41908, 0.08695652173913, 0.82826086956522, 0.27777777777778
41909, 0.08695652173913, 0.82826086956522, 0.33333333333333
41910, 0.08695652173913, 0.82826086956522, 0.38888888888889
41911, 0.08695652173913, 0.82826086956522, 0.44444444444444
41912, 0.043478260869565, 0.82826086956522, 0.055555555555556
41913, 0.043478260869565, 0.82826086956522, 0.11111111111111
41914, 0.043478260869565, 0.82826086956522, 0.16666666666667
41915, 0.043478260869565, 0.82826086956522, 0.22222222222222
41916, 0.043478260869565, 0.82826086956522, 0.27777777777778
41917, 0.043478260869565, 0.82826086956522, 0.33333333333333
41918, 0.043478260869565, 0.82826086956522, 0.38888888888889
41919, 0.043478260869565, 0.82826086956522, 0.44444444444444
41920, 0.95652173913043, 0.88043478260869, 0.055555555555556
41921, 0.95652173913044, 0.88043478260869, 0.11111111111111
41922, 0.95652173913044, 0.8804347826087, 0.16666666666667
41923, 0.95652173913044, 0.8804347826087, 0.22222222222222
41924, 0.95652173913044, 0.88043478260869, 0.27777777777778
41925, 0.95652173913044, 0.8804347826087, 0.33333333333333
41926, 0.95652173913044, 0.88043478260869, 0.38888888888889
41927, 0.95652173913044, 0.88043478260869, 0.44444444444444
41928, 0.91304347826087, 0.8804347826087, 0.055555555555556
41929, 0.91304347826087, 0.88043478260869, 0.11111111111111
41930, 0.91304347826087, 0.8804347826087, 0.16666666666667
41931, 0.91304347826087, 0.8804347826087, 0.22222222222222
41932, 0.91304347826087, 0.8804347826087, 0.27777777777778
41933, 0.91304347826087, 0.88043478260869, 0.33333333333333
41934, 0.91304347826087, 0.88043478260869, 0.38888888888889
41935, 0.91304347826087, 0.8804347826087, 0.44444444444444
41936, 0.8695652173913, 0.88043478260869, 0.055555555555556
41937, 0.8695652173913, 0.88043478260869, 0.11111111111111
41938, 0.8695652173913, 0.8804347826087, 0.16666666666667
41939, 0.8695652173913, 0.88043478260869, 0.22222222222222
41940, 0.8695652173913, 0.8804347826087, 0.27777777777778
41941, 0.8695652173913, 0.8804347826087, 0.33333333333333
41942, 0.8695652173913, 0.88043478260869, 0.38888888888889
41943, 0.8695652173913, 0.88043478260869, 0.44444444444444
41944, 0.82608695652174, 0.8804347826087, 0.055555555555556
41945, 0.82608695652174, 0.8804347826087, 0.11111111111111
41946, 0.82608695652174, 0.8804347826087, 0.16666666666667
41947, 0.82608695652174, 0.8804347826087, 0.22222222222222
41948, 0.82608695652174, 0.8804347826087, 0.27777777777778
41949, 0.82608695652174, 0.8804347826087, 0.33333333333333
41950, 0.82608695652174, 0.8804347826087, 0.38888888888889
41951, 0.82608695652174, 0.8804347826087, 0.44444444444444
41952, 0.78260869565217, 0.88043478260869, 0.055555555555556
41953, 0.78260869565217, 0.88043478260869, 0.11111111111111
41954, 0.78260869565217, 0.88043478260869, 0.16666666666667
41955, 0.78260869565217, 0.8804347826087, 0.22222222222222
41956, 0.78260869565217, 0.88043478260869, 0.27777777777778
41957, 0.78260869565217, 0.88043478260869, 0.33333333333333
41958, 0.78260869565217, 0.8804347826087, 0.38888888888889
41959, 0.78260869565217, 0.88043478260869, 0.44444444444444
41960, 0.73913043478261, 0.8804347826087, 0.055555555555556
41961, 0.73913043478261, 0.8804347826087, 0.11111111111111
41962, 0.73913043478261, 0.88043478260869, 0.16666666666667
41963, 0.73913043478261, 0.88043478260869, 0.22222222222222
41964, 0.73913043478261, 0.88043478260869, 0.27777777777778
41965, 0.73913043478261, 0.88043478260869, 0.33333333333333
41966, 0.73913043478261, 0.88043478260869, 0.38888888888889
41967, 0.73913043478261, 0.8804347826087, 0.44444444444444
41968, 0.69565217391304, 0.88043478260869, 0.055555555555556
41969, 0.69565217391304, 0.88043478260869, 0.11111111111111
41970, 0.69565217391304, 0.88043478260869, 0.16666666666667
41971, 0.69565217391304, 0.8804347826087, 0.22222222222222
41972, 0.69565217391304, 0.8804347826087, 0.27777777777778
41973, 0.69565217391304, 0.8804347826087, 0.33333333333333
41974, 0.69565217391304, 0.88043478260869, 0.38888888888889
41975, 0.69565217391304, 0.88043478260869, 0.44444444444444
41976, 0.65217391304348, 0.8804347826087, 0.055555555555556
41977, 0.65217391304348, 0.8804347826087, 0.11111111111111
41978, 0.65217391304348, 0.8804347826087, 0.16666666666667
41979, 0.65217391304348, 0.8804347826087, 0.22222222222222
41980, 0.65217391304348, 0.8804347826087, 0.27777777777778
41981, 0.65217391304348, 0.8804347826087, 0.33333333333333
41982, 0.65217391304348, 0.8804347826087, 0.38888888888889
41983, 0.65217391304348, 0.8804347826087, 0.44444444444444
41984, 0.60869565217391, 0.8804347826087, 0.055555555555556
41985, 0.60869565217391, 0.8804347826087, 0.11111111111111
41986, 0.60869565217391, 0.8804347826087, 0.16666666666667
41987, 0.60869565217391, 0.8804347826087, 0.22222222222222
41988, 0.60869565217391, 0.8804347826087, 0.27777777777778
41989, 0.60869565217391, 0.8804347826087, 0.33333333333333
41990, 0.60869565217391, 0.8804347826087, 0.38888888888889
41991, 0.60869565217391, 0.8804347826087, 0.44444444444444
41992, 0.56521739130435, 0.88043478260869, 0.055555555555556
41993, 0.56521739130435, 0.88043478260869, 0.11111111111111
41994, 0.56521739130435, 0.8804347826087, 0.16666666666667
41995, 0.56521739130435, 0.88043478260869, 0.22222222222222
41996, 0.56521739130435, 0.88043478260869, 0.27777777777778
41997, 0.56521739130435, 0.8804347826087, 0.33333333333333
41998, 0.56521739130435, 0.88043478260869, 0.38888888888889
41999, 0.56521739130435, 0.88043478260869, 0.44444444444444
42000, 0.52173913043478, 0.88043478260869, 0.055555555555556
42001, 0.52173913043478, 0.88043478260869, 0.11111111111111
42002, 0.52173913043478, 0.88043478260869, 0.16666666666667
42003, 0.52173913043478, 0.88043478260869, 0.22222222222222
42004, 0.52173913043478, 0.88043478260869, 0.27777777777778
42005, 0.52173913043478, 0.8804347826087, 0.33333333333333
42006, 0.52173913043478, 0.88043478260869, 0.38888888888889
42007, 0.52173913043478, 0.88043478260869, 0.44444444444444
42008, 0.47826086956522, 0.88043478260869, 0.055555555555556
42009, 0.47826086956522, 0.88043478260869, 0.11111111111111
42010, 0.47826086956522, 0.88043478260869, 0.16666666666667
42011, 0.47826086956522, 0.88043478260869, 0.22222222222222
42012, 0.47826086956522, 0.88043478260869, 0.27777777777778
42013, 0.47826086956522, 0.88043478260869, 0.33333333333333
42014, 0.47826086956522, 0.88043478260869, 0.38888888888889
42015, 0.47826086956522, 0.88043478260869, 0.44444444444444
42016, 0.43478260869565, 0.88043478260869, 0.055555555555556
42017, 0.43478260869565, 0.88043478260869, 0.11111111111111
42018, 0.43478260869565, 0.88043478260869, 0.16666666666667
42019, 0.43478260869565, 0.88043478260869, 0.22222222222222
42020, 0.43478260869565, 0.88043478260869, 0.27777777777778
42021, 0.43478260869565, 0.88043478260869, 0.33333333333333
42022, 0.43478260869565, 0.88043478260869, 0.38888888888889
42023, 0.43478260869565, 0.88043478260869, 0.44444444444444
42024, 0.39130434782609, 0.88043478260869, 0.055555555555556
42025, 0.39130434782609, 0.88043478260869, 0.11111111111111
42026, 0.39130434782609, 0.8804347826087, 0.16666666666667
42027, 0.39130434782609, 0.88043478260869, 0.22222222222222
42028, 0.39130434782609, 0.88043478260869, 0.27777777777778
42029, 0.39130434782609, 0.88043478260869, 0.33333333333333
42030, 0.39130434782609, 0.88043478260869, 0.38888888888889
42031, 0.39130434782609, 0.88043478260869, 0.44444444444444
42032, 0.34782608695652, 0.88043478260869, 0.055555555555556
42033, 0.34782608695652, 0.8804347826087, 0.11111111111111
42034, 0.34782608695652, 0.88043478260869, 0.16666666666667
42035, 0.34782608695652, 0.8804347826087, 0.22222222222222
42036, 0.34782608695652, 0.8804347826087, 0.27777777777778
42037, 0.34782608695652, 0.88043478260869, 0.33333333333333
42038, 0.34782608695652, 0.8804347826087, 0.38888888888889
42039, 0.34782608695652, 0.88043478260869, 0.44444444444444
42040, 0.30434782608696, 0.88043478260869, 0.055555555555556
42041, 0.30434782608696, 0.88043478260869, 0.11111111111111
42042, 0.30434782608696, 0.88043478260869, 0.16666666666667
42043, 0.30434782608696, 0.88043478260869, 0.22222222222222
42044, 0.30434782608696, 0.88043478260869, 0.27777777777778
42045, 0.30434782608696, 0.8804347826087, 0.33333333333333
42046, 0.30434782608696, 0.88043478260869, 0.38888888888889
42047, 0.30434782608696, 0.88043478260869, 0.44444444444444
42048, 0.26086956521739, 0.88043478260869, 0.055555555555556
42049, 0.26086956521739, 0.88043478260869, 0.11111111111111
42050, 0.26086956521739, 0.88043478260869, 0.16666666666667
42051, 0.26086956521739, 0.88043478260869, 0.22222222222222
42052, 0.26086956521739, 0.88043478260869, 0.27777777777778
42053, 0.26086956521739, 0.8804347826087, 0.33333333333333
42054, 0.26086956521739, 0.88043478260869, 0.38888888888889
42055, 0.26086956521739, 0.88043478260869, 0.44444444444444
42056, 0.21739130434783, 0.88043478260869, 0.055555555555556
42057, 0.21739130434783, 0.88043478260869, 0.11111111111111
42058, 0.21739130434783, 0.88043478260869, 0.16666666666667
42059, 0.21739130434783, 0.88043478260869, 0.22222222222222
42060, 0.21739130434783, 0.88043478260869, 0.27777777777778
42061, 0.21739130434783, 0.88043478260869, 0.33333333333333
42062, 0.21739130434783, 0.88043478260869, 0.38888888888889
42063, 0.21739130434783, 0.88043478260869, 0.44444444444444
42064, 0.17391304347826, 0.8804347826087, 0.055555555555556
42065, 0.17391304347826, 0.88043478260869, 0.11111111111111
42066, 0.17391304347826, 0.8804347826087, 0.16666666666667
42067, 0.17391304347826, 0.88043478260869, 0.22222222222222
42068, 0.17391304347826, 0.88043478260869, 0.27777777777778
42069, 0.17391304347826, 0.88043478260869, 0.33333333333333
42070, 0.17391304347826, 0.88043478260869, 0.38888888888889
42071, 0.17391304347826, 0.88043478260869, 0.44444444444444
42072, 0.1304347826087, 0.8804347826087, 0.055555555555556
42073, 0.1304347826087, 0.88043478260869, 0.11111111111111
42074, 0.1304347826087, 0.8804347826087, 0.16666666666667
42075, 0.1304347826087, 0.88043478260869, 0.22222222222222
42076, 0.1304347826087, 0.88043478260869, 0.27777777777778
42077, 0.1304347826087, 0.88043478260869, 0.33333333333333
42078, 0.1304347826087, 0.88043478260869, 0.38888888888889
42079, 0.1304347826087, 0.88043478260869, 0.44444444444444
42080, 0.08695652173913, 0.8804347826087, 0.055555555555556
42081, 0.08695652173913, 0.8804347826087, 0.11111111111111
42082, 0.08695652173913, 0.8804347826087, 0.16666666666667
42083, 0.08695652173913, 0.8804347826087, 0.22222222222222
42084, 0.08695652173913, 0.88043478260869, 0.27777777777778
42085, 0.08695652173913, 0.8804347826087, 0.33333333333333
42086, 0.08695652173913, 0.8804347826087, 0.38888888888889
42087, 0.08695652173913, 0.8804347826087, 0.44444444444444
42088, 0.043478260869565, 0.88043478260869, 0.055555555555556
42089, 0.043478260869565, 0.88043478260869, 0.11111111111111
42090, 0.043478260869565, 0.8804347826087, 0.16666666666667
42091, 0.043478260869565, 0.88043478260869, 0.22222222222222
42092, 0.043478260869565, 0.88043478260869, 0.27777777777778
42093, 0.043478260869565, 0.88043478260869, 0.33333333333333
42094, 0.043478260869565, 0.88043478260869, 0.38888888888889
42095, 0.043478260869565, 0.88043478260869, 0.44444444444444
42096, 0.95652173913043, 0.93260869565217, 0.055555555555556
42097, 0.95652173913044, 0.93260869565217, 0.11111111111111
42098, 0.95652173913043, 0.93260869565217, 0.16666666666667
42099, 0.95652173913044, 0.93260869565217, 0.22222222222222
42100, 0.95652173913044, 0.93260869565217, 0.27777777777778
42101, 0.95652173913044, 0.93260869565217, 0.33333333333333
42102, 0.95652173913044, 0.93260869565217, 0.38888888888889
42103, 0.95652173913044, 0.93260869565217, 0.44444444444444
42104, 0.91304347826087, 0.93260869565217, 0.055555555555556
42105, 0.91304347826087, 0.93260869565217, 0.11111111111111
42106, 0.91304347826087, 0.93260869565217, 0.16666666666667
42107, 0.91304347826087, 0.93260869565217, 0.22222222222222
42108, 0.91304347826087, 0.93260869565217, 0.27777777777778
42109, 0.91304347826087, 0.93260869565217, 0.33333333333333
42110, 0.91304347826087, 0.93260869565217, 0.38888888888889
42111, 0.91304347826087, 0.93260869565217, 0.44444444444444
42112, 0.8695652173913, 0.93260869565217, 0.055555555555556
42113, 0.8695652173913, 0.93260869565217, 0.11111111111111
42114, 0.8695652173913, 0.93260869565217, 0.16666666666667
42115, 0.8695652173913, 0.93260869565217, 0.22222222222222
42116, 0.8695652173913, 0.93260869565217, 0.27777777777778
42117, 0.8695652173913, 0.93260869565217, 0.33333333333333
42118, 0.8695652173913, 0.93260869565217, 0.38888888888889
42119, 0.8695652173913, 0.93260869565217, 0.44444444444444
42120, 0.82608695652174, 0.93260869565217, 0.055555555555556
42121, 0.82608695652174, 0.93260869565217, 0.11111111111111
42122, 0.82608695652174, 0.93260869565217, 0.16666666666667
42123, 0.82608695652174, 0.93260869565217, 0.22222222222222
42124, 0.82608695652174, 0.93260869565217, 0.27777777777778
42125, 0.82608695652174, 0.93260869565217, 0.33333333333333
42126, 0.82608695652174, 0.93260869565217, 0.38888888888889
42127, 0.82608695652174, 0.93260869565217, 0.44444444444444
42128, 0.78260869565217, 0.93260869565217, 0.055555555555556
42129, 0.78260869565217, 0.93260869565217, 0.11111111111111
42130, 0.78260869565217, 0.93260869565217, 0.16666666666667
42131, 0.78260869565217, 0.93260869565217, 0.22222222222222
42132, 0.78260869565217, 0.93260869565217, 0.27777777777778
42133, 0.78260869565217, 0.93260869565217, 0.33333333333333
42134, 0.78260869565217, 0.93260869565217, 0.38888888888889
42135, 0.78260869565217, 0.93260869565217, 0.44444444444444
42136, 0.73913043478261, 0.93260869565217, 0.055555555555556
42137, 0.73913043478261, 0.93260869565217, 0.11111111111111
42138, 0.73913043478261, 0.93260869565217, 0.16666666666667
42139, 0.73913043478261, 0.93260869565217, 0.22222222222222
42140, 0.73913043478261, 0.93260869565217, 0.27777777777778
42141, 0.73913043478261, 0.93260869565217, 0.33333333333333
42142, 0.73913043478261, 0.93260869565217, 0.38888888888889
42143, 0.73913043478261, 0.93260869565217, 0.44444444444444
42144, 0.69565217391304, 0.93260869565217, 0.055555555555556
42145, 0.69565217391304, 0.93260869565217, 0.11111111111111
42146, 0.69565217391304, 0.93260869565217, 0.16666666666667
42147, 0.69565217391304, 0.93260869565217, 0.22222222222222
42148, 0.69565217391304, 0.93260869565217, 0.27777777777778
42149, 0.69565217391304, 0.93260869565217, 0.33333333333333
42150, 0.69565217391304, 0.93260869565217, 0.38888888888889
42151, 0.69565217391304, 0.93260869565217, 0.44444444444444
42152, 0.65217391304348, 0.93260869565217, 0.055555555555556
42153, 0.65217391304348, 0.93260869565217, 0.11111111111111
42154, 0.65217391304348, 0.93260869565217, 0.16666666666667
42155, 0.65217391304348, 0.93260869565217, 0.22222222222222
42156, 0.65217391304348, 0.93260869565217, 0.27777777777778
42157, 0.65217391304348, 0.93260869565217, 0.33333333333333
42158, 0.65217391304348, 0.93260869565217, 0.38888888888889
42159, 0.65217391304348, 0.93260869565217, 0.44444444444444
42160, 0.60869565217391, 0.93260869565217, 0.055555555555556
42161, 0.60869565217391, 0.93260869565217, 0.11111111111111
42162, 0.60869565217391, 0.93260869565217, 0.16666666666667
42163, 0.60869565217391, 0.93260869565217, 0.22222222222222
42164, 0.60869565217391, 0.93260869565217, 0.27777777777778
42165, 0.60869565217391, 0.93260869565217, 0.33333333333333
42166, 0.60869565217391, 0.93260869565217, 0.38888888888889
42167, 0.60869565217391, 0.93260869565217, 0.44444444444444
42168, 0.56521739130435, 0.93260869565217, 0.055555555555556
42169, 0.56521739130435, 0.93260869565217, 0.11111111111111
42170, 0.56521739130435, 0.93260869565217, 0.16666666666667
42171, 0.56521739130435, 0.93260869565217, 0.22222222222222
42172, 0.56521739130435, 0.93260869565217, 0.27777777777778
42173, 0.56521739130435, 0.93260869565217, 0.33333333333333
42174, 0.56521739130435, 0.93260869565217, 0.38888888888889
42175, 0.56521739130435, 0.93260869565217, 0.44444444444444
42176, 0.52173913043478, 0.93260869565217, 0.055555555555556
42177, 0.52173913043478, 0.93260869565217, 0.11111111111111
42178, 0.52173913043478, 0.93260869565217, 0.16666666666667
42179, 0.52173913043478, 0.93260869565217, 0.22222222222222
42180, 0.52173913043478, 0.93260869565217, 0.27777777777778
42181, 0.52173913043478, 0.93260869565217, 0.33333333333333
42182, 0.52173913043478, 0.93260869565217, 0.38888888888889
42183, 0.52173913043478, 0.93260869565217, 0.44444444444444
42184, 0.47826086956522, 0.93260869565217, 0.055555555555556
42185, 0.47826086956522, 0.93260869565217, 0.11111111111111
42186, 0.47826086956522, 0.93260869565217, 0.16666666666667
42187, 0.47826086956522, 0.93260869565217, 0.22222222222222
42188, 0.47826086956522, 0.93260869565217, 0.27777777777778
42189, 0.47826086956522, 0.93260869565217, 0.33333333333333
42190, 0.47826086956522, 0.93260869565217, 0.38888888888889
42191, 0.47826086956522, 0.93260869565217, 0.44444444444444
42192, 0.43478260869565, 0.93260869565217, 0.055555555555556
42193, 0.43478260869565, 0.93260869565217, 0.11111111111111
42194, 0.43478260869565, 0.93260869565217, 0.16666666666667
42195, 0.43478260869565, 0.93260869565217, 0.22222222222222
42196, 0.43478260869565, 0.93260869565217, 0.27777777777778
42197, 0.43478260869565, 0.93260869565217, 0.33333333333333
42198, 0.43478260869565, 0.93260869565217, 0.38888888888889
42199, 0.43478260869565, 0.93260869565217, 0.44444444444444
42200, 0.39130434782609, 0.93260869565217, 0.055555555555556
42201, 0.39130434782609, 0.93260869565217, 0.11111111111111
42202, 0.39130434782609, 0.93260869565217, 0.16666666666667
42203, 0.39130434782609, 0.93260869565217, 0.22222222222222
42204, 0.39130434782609, 0.93260869565217, 0.27777777777778
42205, 0.39130434782609, 0.93260869565217, 0.33333333333333
42206, 0.39130434782609, 0.93260869565217, 0.38888888888889
42207, 0.39130434782609, 0.93260869565217, 0.44444444444444
42208, 0.34782608695652, 0.93260869565217, 0.055555555555556
42209, 0.34782608695652, 0.93260869565217, 0.11111111111111
42210, 0.34782608695652, 0.93260869565217, 0.16666666666667
42211, 0.34782608695652, 0.93260869565217, 0.22222222222222
42212, 0.34782608695652, 0.93260869565217, 0.27777777777778
42213, 0.34782608695652, 0.93260869565217, 0.33333333333333
42214, 0.34782608695652, 0.93260869565217, 0.38888888888889
42215, 0.34782608695652, 0.93260869565217, 0.44444444444444
42216, 0.30434782608696, 0.93260869565217, 0.055555555555556
42217, 0.30434782608696, 0.93260869565217, 0.11111111111111
42218, 0.30434782608696, 0.93260869565217, 0.16666666666667
42219, 0.30434782608696, 0.93260869565217, 0.22222222222222
42220, 0.30434782608696, 0.93260869565217, 0.27777777777778
42221, 0.30434782608696, 0.93260869565217, 0.33333333333333
42222, 0.30434782608696, 0.93260869565217, 0.38888888888889
42223, 0.30434782608696, 0.93260869565217, 0.44444444444444
42224, 0.26086956521739, 0.93260869565217, 0.055555555555556
42225, 0.26086956521739, 0.93260869565217, 0.11111111111111
42226, 0.26086956521739, 0.93260869565217, 0.16666666666667
42227, 0.26086956521739, 0.93260869565217, 0.22222222222222
42228, 0.26086956521739, 0.93260869565217, 0.27777777777778
42229, 0.26086956521739, 0.93260869565217, 0.33333333333333
42230, 0.26086956521739, 0.93260869565217, 0.38888888888889
42231, 0.26086956521739, 0.93260869565217, 0.44444444444444
42232, 0.21739130434783, 0.93260869565217, 0.055555555555556
42233, 0.21739130434783, 0.93260869565217, 0.11111111111111
42234, 0.21739130434783, 0.93260869565217, 0.16666666666667
42235, 0.21739130434783, 0.93260869565217, 0.22222222222222
42236, 0.21739130434783, 0.93260869565217, 0.27777777777778
42237, 0.21739130434783, 0.93260869565217, 0.33333333333333
42238, 0.21739130434783, 0.93260869565217, 0.38888888888889
42239, 0.21739130434783, 0.93260869565217, 0.44444444444444
42240, 0.17391304347826, 0.93260869565217, 0.055555555555556
42241, 0.17391304347826, 0.93260869565217, 0.11111111111111
42242, 0.17391304347826, 0.93260869565217, 0.16666666666667
42243, 0.17391304347826, 0.93260869565217, 0.22222222222222
42244, 0.17391304347826, 0.93260869565217, 0.27777777777778
42245, 0.17391304347826, 0.93260869565217, 0.33333333333333
42246, 0.17391304347826, 0.93260869565217, 0.38888888888889
42247, 0.17391304347826, 0.93260869565217, 0.44444444444444
42248, 0.1304347826087, 0.93260869565217, 0.055555555555556
42249, 0.1304347826087, 0.93260869565217, 0.11111111111111
42250, 0.1304347826087, 0.93260869565217, 0.16666666666667
42251, 0.1304347826087, 0.93260869565217, 0.22222222222222
42252, 0.1304347826087, 0.93260869565217, 0.27777777777778
42253, 0.1304347826087, 0.93260869565217, 0.33333333333333
42254, 0.1304347826087, 0.93260869565217, 0.38888888888889
42255, 0.1304347826087, 0.93260869565217, 0.44444444444444
42256, 0.08695652173913, 0.93260869565217, 0.055555555555556
42257, 0.08695652173913, 0.93260869565217, 0.11111111111111
42258, 0.08695652173913, 0.93260869565217, 0.16666666666667
42259, 0.08695652173913, 0.93260869565217, 0.22222222222222
42260, 0.08695652173913, 0.93260869565217, 0.27777777777778
42261, 0.08695652173913, 0.93260869565217, 0.33333333333333
42262, 0.08695652173913, 0.93260869565217, 0.38888888888889
42263, 0.08695652173913, 0.93260869565217, 0.44444444444444
42264, 0.043478260869565, 0.93260869565217, 0.055555555555556
42265, 0.043478260869565, 0.93260869565217, 0.11111111111111
42266, 0.043478260869565, 0.93260869565217, 0.16666666666667
42267, 0.043478260869565, 0.93260869565217, 0.22222222222222
42268, 0.043478260869565, 0.93260869565217, 0.27777777777778
42269, 0.043478260869565, 0.93260869565217, 0.33333333333333
42270, 0.043478260869565, 0.93260869565217, 0.38888888888889
42271, 0.043478260869565, 0.93260869565217, 0.44444444444444
42272, 0.95652173913043, 0.98478260869565, 0.055555555555556
42273, 0.95652173913044, 0.98478260869565, 0.11111111111111
42274, 0.95652173913044, 0.98478260869565, 0.16666666666667
42275, 0.95652173913044, 0.98478260869565, 0.22222222222222
42276, 0.95652173913044, 0.98478260869565, 0.27777777777778
42277, 0.95652173913044, 0.98478260869565, 0.33333333333333
42278, 0.95652173913043, 0.98478260869565, 0.38888888888889
42279, 0.95652173913044, 0.98478260869565, 0.44444444444444
42280, 0.91304347826087, 0.98478260869565, 0.055555555555556
42281, 0.91304347826087, 0.98478260869565, 0.11111111111111
42282, 0.91304347826087, 0.98478260869565, 0.16666666666667
42283, 0.91304347826087, 0.98478260869565, 0.22222222222222
42284, 0.91304347826087, 0.98478260869565, 0.27777777777778
42285, 0.91304347826087, 0.98478260869565, 0.33333333333333
42286, 0.91304347826087, 0.98478260869565, 0.38888888888889
42287, 0.91304347826087, 0.98478260869565, 0.44444444444444
42288, 0.8695652173913, 0.98478260869565, 0.055555555555556
42289, 0.8695652173913, 0.98478260869565, 0.11111111111111
42290, 0.8695652173913, 0.98478260869565, 0.16666666666667
42291, 0.8695652173913, 0.98478260869565, 0.22222222222222
42292, 0.8695652173913, 0.98478260869565, 0.27777777777778
42293, 0.8695652173913, 0.98478260869565, 0.33333333333333
42294, 0.8695652173913, 0.98478260869565, 0.38888888888889
42295, 0.8695652173913, 0.98478260869565, 0.44444444444444
42296, 0.82608695652174, 0.98478260869565, 0.055555555555556
42297, 0.82608695652174, 0.98478260869565, 0.11111111111111
42298, 0.82608695652174, 0.98478260869565, 0.16666666666667
42299, 0.82608695652174, 0.98478260869565, 0.22222222222222
42300, 0.82608695652174, 0.98478260869565, 0.27777777777778
42301, 0.82608695652174, 0.98478260869565, 0.33333333333333
42302, 0.82608695652174, 0.98478260869565, 0.38888888888889
42303, 0.82608695652174, 0.98478260869565, 0.44444444444444
42304, 0.78260869565217, 0.98478260869565, 0.055555555555556
42305, 0.78260869565217, 0.98478260869565, 0.11111111111111
42306, 0.78260869565217, 0.98478260869565, 0.16666666666667
42307, 0.78260869565217, 0.98478260869565, 0.22222222222222
42308, 0.78260869565217, 0.98478260869565, 0.27777777777778
42309, 0.78260869565217, 0.98478260869565, 0.33333333333333
42310, 0.78260869565217, 0.98478260869565, 0.38888888888889
42311, 0.78260869565217, 0.98478260869565, 0.44444444444444
42312, 0.73913043478261, 0.98478260869565, 0.055555555555556
42313, 0.73913043478261, 0.98478260869565, 0.11111111111111
42314, 0.73913043478261, 0.98478260869565, 0.16666666666667
42315, 0.73913043478261, 0.98478260869565, 0.22222222222222
42316, 0.73913043478261, 0.98478260869565, 0.27777777777778
42317, 0.73913043478261, 0.98478260869565, 0.33333333333333
42318, 0.73913043478261, 0.98478260869565, 0.38888888888889
42319, 0.73913043478261, 0.98478260869565, 0.44444444444444
42320, 0.69565217391304, 0.98478260869565, 0.055555555555556
42321, 0.69565217391304, 0.98478260869565, 0.11111111111111
42322, 0.69565217391304, 0.98478260869565, 0.16666666666667
42323, 0.69565217391304, 0.98478260869565, 0.22222222222222
42324, 0.69565217391304, 0.98478260869565, 0.27777777777778
42325, 0.69565217391304, 0.98478260869565, 0.33333333333333
42326, 0.69565217391304, 0.98478260869565, 0.38888888888889
42327, 0.69565217391304, 0.98478260869565, 0.44444444444444
42328, 0.65217391304348, 0.98478260869565, 0.055555555555556
42329, 0.65217391304348, 0.98478260869565, 0.11111111111111
42330, 0.65217391304348, 0.98478260869565, 0.16666666666667
42331, 0.65217391304348, 0.98478260869565, 0.22222222222222
42332, 0.65217391304348, 0.98478260869565, 0.27777777777778
42333, 0.65217391304348, 0.98478260869565, 0.33333333333333
42334, 0.65217391304348, 0.98478260869565, 0.38888888888889
42335, 0.65217391304348, 0.98478260869565, 0.44444444444444
42336, 0.60869565217391, 0.98478260869565, 0.055555555555556
42337, 0.60869565217391, 0.98478260869565, 0.11111111111111
42338, 0.60869565217391, 0.98478260869565, 0.16666666666667
42339, 0.60869565217391, 0.98478260869565, 0.22222222222222
42340, 0.60869565217391, 0.98478260869565, 0.27777777777778
42341, 0.60869565217391, 0.98478260869565, 0.33333333333333
42342, 0.60869565217391, 0.98478260869565, 0.38888888888889
42343, 0.60869565217391, 0.98478260869565, 0.44444444444444
42344, 0.56521739130435, 0.98478260869565, 0.055555555555556
42345, 0.56521739130435, 0.98478260869565, 0.11111111111111
42346, 0.56521739130435, 0.98478260869565, 0.16666666666667
42347, 0.56521739130435, 0.98478260869565, 0.22222222222222
42348, 0.56521739130435, 0.98478260869565, 0.27777777777778
42349, 0.56521739130435, 0.98478260869565, 0.33333333333333
42350, 0.56521739130435, 0.98478260869565, 0.38888888888889
42351, 0.56521739130435, 0.98478260869565, 0.44444444444444
42352, 0.52173913043478, 0.98478260869565, 0.055555555555556
42353, 0.52173913043478, 0.98478260869565, 0.11111111111111
42354, 0.52173913043478, 0.98478260869565, 0.16666666666667
42355, 0.52173913043478, 0.98478260869565, 0.22222222222222
42356, 0.52173913043478, 0.98478260869565, 0.27777777777778
42357, 0.52173913043478, 0.98478260869565, 0.33333333333333
42358, 0.52173913043478, 0.98478260869565, 0.38888888888889
42359, 0.52173913043478, 0.98478260869565, 0.44444444444444
42360, 0.47826086956522, 0.98478260869565, 0.055555555555556
42361, 0.47826086956522, 0.98478260869565, 0.11111111111111
42362, 0.47826086956522, 0.98478260869565, 0.16666666666667
42363, 0.47826086956522, 0.98478260869565, 0.22222222222222
42364, 0.47826086956522, 0.98478260869565, 0.27777777777778
42365, 0.47826086956522, 0.98478260869565, 0.33333333333333
42366, 0.47826086956522, 0.98478260869565, 0.38888888888889
42367, 0.47826086956522, 0.98478260869565, 0.44444444444444
42368, 0.43478260869565, 0.98478260869565, 0.055555555555556
42369, 0.43478260869565, 0.98478260869565, 0.11111111111111
42370, 0.43478260869565, 0.98478260869565, 0.16666666666667
42371, 0.43478260869565, 0.98478260869565, 0.22222222222222
42372, 0.43478260869565, 0.98478260869565, 0.27777777777778
42373, 0.43478260869565, 0.98478260869565, 0.33333333333333
42374, 0.43478260869565, 0.98478260869565, 0.38888888888889
42375, 0.43478260869565, 0.98478260869565, 0.44444444444444
42376, 0.39130434782609, 0.98478260869565, 0.055555555555556
42377, 0.39130434782609, 0.98478260869565, 0.11111111111111
42378, 0.39130434782609, 0.98478260869565, 0.16666666666667
42379, 0.39130434782609, 0.98478260869565, 0.22222222222222
42380, 0.39130434782609, 0.98478260869565, 0.27777777777778
42381, 0.39130434782609, 0.98478260869565, 0.33333333333333
42382, 0.39130434782609, 0.98478260869565, 0.38888888888889
42383, 0.39130434782609, 0.98478260869565, 0.44444444444444
42384, 0.34782608695652, 0.98478260869565, 0.055555555555556
42385, 0.34782608695652, 0.98478260869565, 0.11111111111111
42386, 0.34782608695652, 0.98478260869565, 0.16666666666667
42387, 0.34782608695652, 0.98478260869565, 0.22222222222222
42388, 0.34782608695652, 0.98478260869565, 0.27777777777778
42389, 0.34782608695652, 0.98478260869565, 0.33333333333333
42390, 0.34782608695652, 0.98478260869565, 0.38888888888889
42391, 0.34782608695652, 0.98478260869565, 0.44444444444444
42392, 0.30434782608696, 0.98478260869565, 0.055555555555556
42393, 0.30434782608696, 0.98478260869565, 0.11111111111111
42394, 0.30434782608696, 0.98478260869565, 0.16666666666667
42395, 0.30434782608696, 0.98478260869565, 0.22222222222222
42396, 0.30434782608696, 0.98478260869565, 0.27777777777778
42397, 0.30434782608696, 0.98478260869565, 0.33333333333333
42398, 0.30434782608696, 0.98478260869565, 0.38888888888889
42399, 0.30434782608696, 0.98478260869565, 0.44444444444444
42400, 0.26086956521739, 0.98478260869565, 0.055555555555556
42401, 0.26086956521739, 0.98478260869565, 0.11111111111111
42402, 0.26086956521739, 0.98478260869565, 0.16666666666667
42403, 0.26086956521739, 0.98478260869565, 0.22222222222222
42404, 0.26086956521739, 0.98478260869565, 0.27777777777778
42405, 0.26086956521739, 0.98478260869565, 0.33333333333333
42406, 0.26086956521739, 0.98478260869565, 0.38888888888889
42407, 0.26086956521739, 0.98478260869565, 0.44444444444444
42408, 0.21739130434783, 0.98478260869565, 0.055555555555556
42409, 0.21739130434783, 0.98478260869565, 0.11111111111111
42410, 0.21739130434783, 0.98478260869565, 0.16666666666667
42411, 0.21739130434783, 0.98478260869565, 0.22222222222222
42412, 0.21739130434783, 0.98478260869565, 0.27777777777778
42413, 0.21739130434783, 0.98478260869565, 0.33333333333333
42414, 0.21739130434783, 0.98478260869565, 0.38888888888889
42415, 0.21739130434783, 0.98478260869565, 0.44444444444444
42416, 0.17391304347826, 0.98478260869565, 0.055555555555556
42417, 0.17391304347826, 0.98478260869565, 0.11111111111111
42418, 0.17391304347826, 0.98478260869565, 0.16666666666667
42419, 0.17391304347826, 0.98478260869565, 0.22222222222222
42420, 0.17391304347826, 0.98478260869565, 0.27777777777778
42421, 0.17391304347826, 0.98478260869565, 0.33333333333333
42422, 0.17391304347826, 0.98478260869565, 0.38888888888889
42423, 0.17391304347826, 0.98478260869565, 0.44444444444444
42424, 0.1304347826087, 0.98478260869565, 0.055555555555556
42425, 0.1304347826087, 0.98478260869565, 0.11111111111111
42426, 0.1304347826087, 0.98478260869565, 0.16666666666667
42427, 0.1304347826087, 0.98478260869565, 0.22222222222222
42428, 0.1304347826087, 0.98478260869565, 0.27777777777778
42429, 0.1304347826087, 0.98478260869565, 0.33333333333333
42430, 0.1304347826087, 0.98478260869565, 0.38888888888889
42431, 0.1304347826087, 0.98478260869565, 0.44444444444444
42432, 0.08695652173913, 0.98478260869565, 0.055555555555556
42433, 0.08695652173913, 0.98478260869565, 0.11111111111111
42434, 0.08695652173913, 0.98478260869565, 0.16666666666667
42435, 0.08695652173913, 0.98478260869565, 0.22222222222222
42436, 0.08695652173913, 0.98478260869565, 0.27777777777778
42437, 0.08695652173913, 0.98478260869565, 0.33333333333333
42438, 0.08695652173913, 0.98478260869565, 0.38888888888889
42439, 0.08695652173913, 0.98478260869565, 0.44444444444444
42440, 0.043478260869565, 0.98478260869565, 0.055555555555556
42441, 0.043478260869565, 0.98478260869565, 0.11111111111111
42442, 0.043478260869565, 0.98478260869565, 0.16666666666667
42443, 0.043478260869565, 0.98478260869565, 0.22222222222222
42444, 0.043478260869565, 0.98478260869565, 0.27777777777778
42445, 0.043478260869565, 0.98478260869565, 0.33333333333333
42446, 0.043478260869565, 0.98478260869565, 0.38888888888889
42447, 0.043478260869565, 0.98478260869565, 0.44444444444444
42448, 0.95652173913043, 1.0369565217391, 0.055555555555556
42449, 0.95652173913044, 1.0369565217391, 0.11111111111111
42450, 0.95652173913044, 1.0369565217391, 0.16666666666667
42451, 0.95652173913044, 1.0369565217391, 0.22222222222222
42452, 0.95652173913044, 1.0369565217391, 0.27777777777778
42453, 0.95652173913044, 1.0369565217391, 0.33333333333333
42454, 0.95652173913044, 1.0369565217391, 0.38888888888889
42455, 0.95652173913044, 1.0369565217391, 0.44444444444444
42456, 0.91304347826087, 1.0369565217391, 0.055555555555556
42457, 0.91304347826087, 1.0369565217391, 0.11111111111111
42458, 0.91304347826087, 1.0369565217391, 0.16666666666667
42459, 0.91304347826087, 1.0369565217391, 0.22222222222222
42460, 0.91304347826087, 1.0369565217391, 0.27777777777778
42461, 0.91304347826087, 1.0369565217391, 0.33333333333333
42462, 0.91304347826087, 1.0369565217391, 0.38888888888889
42463, 0.91304347826087, 1.0369565217391, 0.44444444444444
42464, 0.8695652173913, 1.0369565217391, 0.055555555555556
42465, 0.8695652173913, 1.0369565217391, 0.11111111111111
42466, 0.8695652173913, 1.0369565217391, 0.16666666666667
42467, 0.8695652173913, 1.0369565217391, 0.22222222222222
42468, 0.8695652173913, 1.0369565217391, 0.27777777777778
42469, 0.8695652173913, 1.0369565217391, 0.33333333333333
42470, 0.8695652173913, 1.0369565217391, 0.38888888888889
42471, 0.8695652173913, 1.0369565217391, 0.44444444444444
42472, 0.82608695652174, 1.0369565217391, 0.055555555555556
42473, 0.82608695652174, 1.0369565217391, 0.11111111111111
42474, 0.82608695652174, 1.0369565217391, 0.16666666666667
42475, 0.82608695652174, 1.0369565217391, 0.22222222222222
42476, 0.82608695652174, 1.0369565217391, 0.27777777777778
42477, 0.82608695652174, 1.0369565217391, 0.33333333333333
42478, 0.82608695652174, 1.0369565217391, 0.38888888888889
42479, 0.82608695652174, 1.0369565217391, 0.44444444444444
42480, 0.78260869565217, 1.0369565217391, 0.055555555555556
42481, 0.78260869565217, 1.0369565217391, 0.11111111111111
42482, 0.78260869565217, 1.0369565217391, 0.16666666666667
42483, 0.78260869565217, 1.0369565217391, 0.22222222222222
42484, 0.78260869565217, 1.0369565217391, 0.27777777777778
42485, 0.78260869565217, 1.0369565217391, 0.33333333333333
42486, 0.78260869565217, 1.0369565217391, 0.38888888888889
42487, 0.78260869565217, 1.0369565217391, 0.44444444444444
42488, 0.73913043478261, 1.0369565217391, 0.055555555555556
42489, 0.73913043478261, 1.0369565217391, 0.11111111111111
42490, 0.73913043478261, 1.0369565217391, 0.16666666666667
42491, 0.73913043478261, 1.0369565217391, 0.22222222222222
42492, 0.73913043478261, 1.0369565217391, 0.27777777777778
42493, 0.73913043478261, 1.0369565217391, 0.33333333333333
42494, 0.73913043478261, 1.0369565217391, 0.38888888888889
42495, 0.73913043478261, 1.0369565217391, 0.44444444444444
42496, 0.69565217391304, 1.0369565217391, 0.055555555555556
42497, 0.69565217391304, 1.0369565217391, 0.11111111111111
42498, 0.69565217391304, 1.0369565217391, 0.16666666666667
42499, 0.69565217391304, 1.0369565217391, 0.22222222222222
42500, 0.69565217391304, 1.0369565217391, 0.27777777777778
42501, 0.69565217391304, 1.0369565217391, 0.33333333333333
42502, 0.69565217391304, 1.0369565217391, 0.38888888888889
42503, 0.69565217391304, 1.0369565217391, 0.44444444444444
42504, 0.65217391304348, 1.0369565217391, 0.055555555555556
42505, 0.65217391304348, 1.0369565217391, 0.11111111111111
42506, 0.65217391304348, 1.0369565217391, 0.16666666666667
42507, 0.65217391304348, 1.0369565217391, 0.22222222222222
42508, 0.65217391304348, 1.0369565217391, 0.27777777777778
42509, 0.65217391304348, 1.0369565217391, 0.33333333333333
42510, 0.65217391304348, 1.0369565217391, 0.38888888888889
42511, 0.65217391304348, 1.0369565217391, 0.44444444444444
42512, 0.60869565217391, 1.0369565217391, 0.055555555555556
42513, 0.60869565217391, 1.0369565217391, 0.11111111111111
42514, 0.60869565217391, 1.0369565217391, 0.16666666666667
42515, 0.60869565217391, 1.0369565217391, 0.22222222222222
42516, 0.60869565217391, 1.0369565217391, 0.27777777777778
42517, 0.60869565217391, 1.0369565217391, 0.33333333333333
42518, 0.60869565217391, 1.0369565217391, 0.38888888888889
42519, 0.60869565217391, 1.0369565217391, 0.44444444444444
42520, 0.56521739130435, 1.0369565217391, 0.055555555555556
42521, 0.56521739130435, 1.0369565217391, 0.11111111111111
42522, 0.56521739130435, 1.0369565217391, 0.16666666666667
42523, 0.56521739130435, 1.0369565217391, 0.22222222222222
42524, 0.56521739130435, 1.0369565217391, 0.27777777777778
42525, 0.56521739130435, 1.0369565217391, 0.33333333333333
42526, 0.56521739130435, 1.0369565217391, 0.38888888888889
42527, 0.56521739130435, 1.0369565217391, 0.44444444444444
42528, 0.52173913043478, 1.0369565217391, 0.055555555555556
42529, 0.52173913043478, 1.0369565217391, 0.11111111111111
42530, 0.52173913043478, 1.0369565217391, 0.16666666666667
42531, 0.52173913043478, 1.0369565217391, 0.22222222222222
42532, 0.52173913043478, 1.0369565217391, 0.27777777777778
42533, 0.52173913043478, 1.0369565217391, 0.33333333333333
42534, 0.52173913043478, 1.0369565217391, 0.38888888888889
42535, 0.52173913043478, 1.0369565217391, 0.44444444444444
42536, 0.47826086956522, 1.0369565217391, 0.055555555555556
42537, 0.47826086956522, 1.0369565217391, 0.11111111111111
42538, 0.47826086956522, 1.0369565217391, 0.16666666666667
42539, 0.47826086956522, 1.0369565217391, 0.22222222222222
42540, 0.47826086956522, 1.0369565217391, 0.27777777777778
42541, 0.47826086956522, 1.0369565217391, 0.33333333333333
42542, 0.47826086956522, 1.0369565217391, 0.38888888888889
42543, 0.47826086956522, 1.0369565217391, 0.44444444444444
42544, 0.43478260869565, 1.0369565217391, 0.055555555555556
42545, 0.43478260869565, 1.0369565217391, 0.11111111111111
42546, 0.43478260869565, 1.0369565217391, 0.16666666666667
42547, 0.43478260869565, 1.0369565217391, 0.22222222222222
42548, 0.43478260869565, 1.0369565217391, 0.27777777777778
42549, 0.43478260869565, 1.0369565217391, 0.33333333333333
42550, 0.43478260869565, 1.0369565217391, 0.38888888888889
42551, 0.43478260869565, 1.0369565217391, 0.44444444444444
42552, 0.39130434782609, 1.0369565217391, 0.055555555555556
42553, 0.39130434782609, 1.0369565217391, 0.11111111111111
42554, 0.39130434782609, 1.0369565217391, 0.16666666666667
42555, 0.39130434782609, 1.0369565217391, 0.22222222222222
42556, 0.39130434782609, 1.0369565217391, 0.27777777777778
42557, 0.39130434782609, 1.0369565217391, 0.33333333333333
42558, 0.39130434782609, 1.0369565217391, 0.38888888888889
42559, 0.39130434782609, 1.0369565217391, 0.44444444444444
42560, 0.34782608695652, 1.0369565217391, 0.055555555555556
42561, 0.34782608695652, 1.0369565217391, 0.11111111111111
42562, 0.34782608695652, 1.0369565217391, 0.16666666666667
42563, 0.34782608695652, 1.0369565217391, 0.22222222222222
42564, 0.34782608695652, 1.0369565217391, 0.27777777777778
42565, 0.34782608695652, 1.0369565217391, 0.33333333333333
42566, 0.34782608695652, 1.0369565217391, 0.38888888888889
42567, 0.34782608695652, 1.0369565217391, 0.44444444444444
42568, 0.30434782608696, 1.0369565217391, 0.055555555555556
42569, 0.30434782608696, 1.0369565217391, 0.11111111111111
42570, 0.30434782608696, 1.0369565217391, 0.16666666666667
42571, 0.30434782608696, 1.0369565217391, 0.22222222222222
42572, 0.30434782608696, 1.0369565217391, 0.27777777777778
42573, 0.30434782608696, 1.0369565217391, 0.33333333333333
42574, 0.30434782608696, 1.0369565217391, 0.38888888888889
42575, 0.30434782608696, 1.0369565217391, 0.44444444444444
42576, 0.26086956521739, 1.0369565217391, 0.055555555555556
42577, 0.26086956521739, 1.0369565217391, 0.11111111111111
42578, 0.26086956521739, 1.0369565217391, 0.16666666666667
42579, 0.26086956521739, 1.0369565217391, 0.22222222222222
42580, 0.26086956521739, 1.0369565217391, 0.27777777777778
42581, 0.26086956521739, 1.0369565217391, 0.33333333333333
42582, 0.26086956521739, 1.0369565217391, 0.38888888888889
42583, 0.26086956521739, 1.0369565217391, 0.44444444444444
42584, 0.21739130434783, 1.0369565217391, 0.055555555555556
42585, 0.21739130434783, 1.0369565217391, 0.11111111111111
42586, 0.21739130434783, 1.0369565217391, 0.16666666666667
42587, 0.21739130434783, 1.0369565217391, 0.22222222222222
42588, 0.21739130434783, 1.0369565217391, 0.27777777777778
42589, 0.21739130434783, 1.0369565217391, 0.33333333333333
42590, 0.21739130434783, 1.0369565217391, 0.38888888888889
42591, 0.21739130434783, 1.0369565217391, 0.44444444444444
42592, 0.17391304347826, 1.0369565217391, 0.055555555555556
42593, 0.17391304347826, 1.0369565217391, 0.11111111111111
42594, 0.17391304347826, 1.0369565217391, 0.16666666666667
42595, 0.17391304347826, 1.0369565217391, 0.22222222222222
42596, 0.17391304347826, 1.0369565217391, 0.27777777777778
42597, 0.17391304347826, 1.0369565217391, 0.33333333333333
42598, 0.17391304347826, 1.0369565217391, 0.38888888888889
42599, 0.17391304347826, 1.0369565217391, 0.44444444444444
42600, 0.1304347826087, 1.0369565217391, 0.055555555555556
42601, 0.1304347826087, 1.0369565217391, 0.11111111111111
42602, 0.1304347826087, 1.0369565217391, 0.16666666666667
42603, 0.1304347826087, 1.0369565217391, 0.22222222222222
42604, 0.1304347826087, 1.0369565217391, 0.27777777777778
42605, 0.1304347826087, 1.0369565217391, 0.33333333333333
42606, 0.1304347826087, 1.0369565217391, 0.38888888888889
42607, 0.1304347826087, 1.0369565217391, 0.44444444444444
42608, 0.08695652173913, 1.0369565217391, 0.055555555555556
42609, 0.08695652173913, 1.0369565217391, 0.11111111111111
42610, 0.08695652173913, 1.0369565217391, 0.16666666666667
42611, 0.08695652173913, 1.0369565217391, 0.22222222222222
42612, 0.08695652173913, 1.0369565217391, 0.27777777777778
42613, 0.08695652173913, 1.0369565217391, 0.33333333333333
42614, 0.08695652173913, 1.0369565217391, 0.38888888888889
42615, 0.08695652173913, 1.0369565217391, 0.44444444444444
42616, 0.043478260869565, 1.0369565217391, 0.055555555555556
42617, 0.043478260869565, 1.0369565217391, 0.11111111111111
42618, 0.043478260869565, 1.0369565217391, 0.16666666666667
42619, 0.043478260869565, 1.0369565217391, 0.22222222222222
42620, 0.043478260869565, 1.0369565217391, 0.27777777777778
42621, 0.043478260869565, 1.0369565217391, 0.33333333333333
42622, 0.043478260869565, 1.0369565217391, 0.38888888888889
42623, 0.043478260869565, 1.0369565217391, 0.44444444444444
42624, 0.95652173913043, 1.0891304347826, 0.055555555555556
42625, 0.95652173913043, 1.0891304347826, 0.11111111111111
42626, 0.95652173913043, 1.0891304347826, 0.16666666666667
42627, 0.95652173913043, 1.0891304347826, 0.22222222222222
42628, 0.95652173913044, 1.0891304347826, 0.27777777777778
42629, 0.95652173913044, 1.0891304347826, 0.33333333333333
42630, 0.95652173913043, 1.0891304347826, 0.38888888888889
42631, 0.95652173913044, 1.0891304347826, 0.44444444444444
42632, 0.91304347826087, 1.0891304347826, 0.055555555555556
42633, 0.91304347826087, 1.0891304347826, 0.11111111111111
42634, 0.91304347826087, 1.0891304347826, 0.16666666666667
42635, 0.91304347826087, 1.0891304347826, 0.22222222222222
42636, 0.91304347826087, 1.0891304347826, 0.27777777777778
42637, 0.91304347826087, 1.0891304347826, 0.33333333333333
42638, 0.91304347826087, 1.0891304347826, 0.38888888888889
42639, 0.91304347826087, 1.0891304347826, 0.44444444444444
42640, 0.8695652173913, 1.0891304347826, 0.055555555555556
42641, 0.8695652173913, 1.0891304347826, 0.11111111111111
42642, 0.8695652173913, 1.0891304347826, 0.16666666666667
42643, 0.8695652173913, 1.0891304347826, 0.22222222222222
42644, 0.8695652173913, 1.0891304347826, 0.27777777777778
42645, 0.8695652173913, 1.0891304347826, 0.33333333333333
42646, 0.8695652173913, 1.0891304347826, 0.38888888888889
42647, 0.8695652173913, 1.0891304347826, 0.44444444444444
42648, 0.82608695652174, 1.0891304347826, 0.055555555555556
42649, 0.82608695652174, 1.0891304347826, 0.11111111111111
42650, 0.82608695652174, 1.0891304347826, 0.16666666666667
42651, 0.82608695652174, 1.0891304347826, 0.22222222222222
42652, 0.82608695652174, 1.0891304347826, 0.27777777777778
42653, 0.82608695652174, 1.0891304347826, 0.33333333333333
42654, 0.82608695652174, 1.0891304347826, 0.38888888888889
42655, 0.82608695652174, 1.0891304347826, 0.44444444444444
42656, 0.78260869565217, 1.0891304347826, 0.055555555555556
42657, 0.78260869565217, 1.0891304347826, 0.11111111111111
42658, 0.78260869565217, 1.0891304347826, 0.16666666666667
42659, 0.78260869565217, 1.0891304347826, 0.22222222222222
42660, 0.78260869565217, 1.0891304347826, 0.27777777777778
42661, 0.78260869565217, 1.0891304347826, 0.33333333333333
42662, 0.78260869565217, 1.0891304347826, 0.38888888888889
42663, 0.78260869565217, 1.0891304347826, 0.44444444444444
42664, 0.73913043478261, 1.0891304347826, 0.055555555555556
42665, 0.73913043478261, 1.0891304347826, 0.11111111111111
42666, 0.73913043478261, 1.0891304347826, 0.16666666666667
42667, 0.73913043478261, 1.0891304347826, 0.22222222222222
42668, 0.73913043478261, 1.0891304347826, 0.27777777777778
42669, 0.73913043478261, 1.0891304347826, 0.33333333333333
42670, 0.73913043478261, 1.0891304347826, 0.38888888888889
42671, 0.73913043478261, 1.0891304347826, 0.44444444444444
42672, 0.69565217391304, 1.0891304347826, 0.055555555555556
42673, 0.69565217391304, 1.0891304347826, 0.11111111111111
42674, 0.69565217391304, 1.0891304347826, 0.16666666666667
42675, 0.69565217391304, 1.0891304347826, 0.22222222222222
42676, 0.69565217391304, 1.0891304347826, 0.27777777777778
42677, 0.69565217391304, 1.0891304347826, 0.33333333333333
42678, 0.69565217391304, 1.0891304347826, 0.38888888888889
42679, 0.69565217391304, 1.0891304347826, 0.44444444444444
42680, 0.65217391304348, 1.0891304347826, 0.055555555555556
42681, 0.65217391304348, 1.0891304347826, 0.11111111111111
42682, 0.65217391304348, 1.0891304347826, 0.16666666666667
42683, 0.65217391304348, 1.0891304347826, 0.22222222222222
42684, 0.65217391304348, 1.0891304347826, 0.27777777777778
42685, 0.65217391304348, 1.0891304347826, 0.33333333333333
42686, 0.65217391304348, 1.0891304347826, 0.38888888888889
42687, 0.65217391304348, 1.0891304347826, 0.44444444444444
42688, 0.60869565217391, 1.0891304347826, 0.055555555555556
42689, 0.60869565217391, 1.0891304347826, 0.11111111111111
42690, 0.60869565217391, 1.0891304347826, 0.16666666666667
42691, 0.60869565217391, 1.0891304347826, 0.22222222222222
42692, 0.60869565217391, 1.0891304347826, 0.27777777777778
42693, 0.60869565217391, 1.0891304347826, 0.33333333333333
42694, 0.60869565217391, 1.0891304347826, 0.38888888888889
42695, 0.60869565217391, 1.0891304347826, 0.44444444444444
42696, 0.56521739130435, 1.0891304347826, 0.055555555555556
42697, 0.56521739130435, 1.0891304347826, 0.11111111111111
42698, 0.56521739130435, 1.0891304347826, 0.16666666666667
42699, 0.56521739130435, 1.0891304347826, 0.22222222222222
42700, 0.56521739130435, 1.0891304347826, 0.27777777777778
42701, 0.56521739130435, 1.0891304347826, 0.33333333333333
42702, 0.56521739130435, 1.0891304347826, 0.38888888888889
42703, 0.56521739130435, 1.0891304347826, 0.44444444444444
42704, 0.52173913043478, 1.0891304347826, 0.055555555555556
42705, 0.52173913043478, 1.0891304347826, 0.11111111111111
42706, 0.52173913043478, 1.0891304347826, 0.16666666666667
42707, 0.52173913043478, 1.0891304347826, 0.22222222222222
42708, 0.52173913043478, 1.0891304347826, 0.27777777777778
42709, 0.52173913043478, 1.0891304347826, 0.33333333333333
42710, 0.52173913043478, 1.0891304347826, 0.38888888888889
42711, 0.52173913043478, 1.0891304347826, 0.44444444444444
42712, 0.47826086956522, 1.0891304347826, 0.055555555555556
42713, 0.47826086956522, 1.0891304347826, 0.11111111111111
42714, 0.47826086956522, 1.0891304347826, 0.16666666666667
42715, 0.47826086956522, 1.0891304347826, 0.22222222222222
42716, 0.47826086956522, 1.0891304347826, 0.27777777777778
42717, 0.47826086956522, 1.0891304347826, 0.33333333333333
42718, 0.47826086956522, 1.0891304347826, 0.38888888888889
42719, 0.47826086956522, 1.0891304347826, 0.44444444444444
42720, 0.43478260869565, 1.0891304347826, 0.055555555555556
42721, 0.43478260869565, 1.0891304347826, 0.11111111111111
42722, 0.43478260869565, 1.0891304347826, 0.16666666666667
42723, 0.43478260869565, 1.0891304347826, 0.22222222222222
42724, 0.43478260869565, 1.0891304347826, 0.27777777777778
42725, 0.43478260869565, 1.0891304347826, 0.33333333333333
42726, 0.43478260869565, 1.0891304347826, 0.38888888888889
42727, 0.43478260869565, 1.0891304347826, 0.44444444444444
42728, 0.39130434782609, 1.0891304347826, 0.055555555555556
42729, 0.39130434782609, 1.0891304347826, 0.11111111111111
42730, 0.39130434782609, 1.0891304347826, 0.16666666666667
42731, 0.39130434782609, 1.0891304347826, 0.22222222222222
42732, 0.39130434782609, 1.0891304347826, 0.27777777777778
42733, 0.39130434782609, 1.0891304347826, 0.33333333333333
42734, 0.39130434782609, 1.0891304347826, 0.38888888888889
42735, 0.39130434782609, 1.0891304347826, 0.44444444444444
42736, 0.34782608695652, 1.0891304347826, 0.055555555555556
42737, 0.34782608695652, 1.0891304347826, 0.11111111111111
42738, 0.34782608695652, 1.0891304347826, 0.16666666666667
42739, 0.34782608695652, 1.0891304347826, 0.22222222222222
42740, 0.34782608695652, 1.0891304347826, 0.27777777777778
42741, 0.34782608695652, 1.0891304347826, 0.33333333333333
42742, 0.34782608695652, 1.0891304347826, 0.38888888888889
42743, 0.34782608695652, 1.0891304347826, 0.44444444444444
42744, 0.30434782608696, 1.0891304347826, 0.055555555555556
42745, 0.30434782608696, 1.0891304347826, 0.11111111111111
42746, 0.30434782608696, 1.0891304347826, 0.16666666666667
42747, 0.30434782608696, 1.0891304347826, 0.22222222222222
42748, 0.30434782608696, 1.0891304347826, 0.27777777777778
42749, 0.30434782608696, 1.0891304347826, 0.33333333333333
42750, 0.30434782608696, 1.0891304347826, 0.38888888888889
42751, 0.30434782608696, 1.0891304347826, 0.44444444444444
42752, 0.26086956521739, 1.0891304347826, 0.055555555555556
42753, 0.26086956521739, 1.0891304347826, 0.11111111111111
42754, 0.26086956521739, 1.0891304347826, 0.16666666666667
42755, 0.26086956521739, 1.0891304347826, 0.22222222222222
42756, 0.26086956521739, 1.0891304347826, 0.27777777777778
42757, 0.26086956521739, 1.0891304347826, 0.33333333333333
42758, 0.26086956521739, 1.0891304347826, 0.38888888888889
42759, 0.26086956521739, 1.0891304347826, 0.44444444444444
42760, 0.21739130434783, 1.0891304347826, 0.055555555555556
42761, 0.21739130434783, 1.0891304347826, 0.11111111111111
42762, 0.21739130434783, 1.0891304347826, 0.16666666666667
42763, 0.21739130434783, 1.0891304347826, 0.22222222222222
42764, 0.21739130434783, 1.0891304347826, 0.27777777777778
42765, 0.21739130434783, 1.0891304347826, 0.33333333333333
42766, 0.21739130434783, 1.0891304347826, 0.38888888888889
42767, 0.21739130434783, 1.0891304347826, 0.44444444444444
42768, 0.17391304347826, 1.0891304347826, 0.055555555555556
42769, 0.17391304347826, 1.0891304347826, 0.11111111111111
42770, 0.17391304347826, 1.0891304347826, 0.16666666666667
42771, 0.17391304347826, 1.0891304347826, 0.22222222222222
42772, 0.17391304347826, 1.0891304347826, 0.27777777777778
42773, 0.17391304347826, 1.0891304347826, 0.33333333333333
42774, 0.17391304347826, 1.0891304347826, 0.38888888888889
42775, 0.17391304347826, 1.0891304347826, 0.44444444444444
42776, 0.1304347826087, 1.0891304347826, 0.055555555555556
42777, 0.1304347826087, 1.0891304347826, 0.11111111111111
42778, 0.1304347826087, 1.0891304347826, 0.16666666666667
42779, 0.1304347826087, 1.0891304347826, 0.22222222222222
42780, 0.1304347826087, 1.0891304347826, 0.27777777777778
42781, 0.1304347826087, 1.0891304347826, 0.33333333333333
42782, 0.1304347826087, 1.0891304347826, 0.38888888888889
42783, 0.1304347826087, 1.0891304347826, 0.44444444444444
42784, 0.08695652173913, 1.0891304347826, 0.055555555555556
42785, 0.08695652173913, 1.0891304347826, 0.11111111111111
42786, 0.08695652173913, 1.0891304347826, 0.16666666666667
42787, 0.08695652173913, 1.0891304347826, 0.22222222222222
42788, 0.08695652173913, 1.0891304347826, 0.27777777777778
42789, 0.08695652173913, 1.0891304347826, 0.33333333333333
42790, 0.08695652173913, 1.0891304347826, 0.38888888888889
42791, 0.08695652173913, 1.0891304347826, 0.44444444444444
42792, 0.043478260869565, 1.0891304347826, 0.055555555555556
42793, 0.043478260869565, 1.0891304347826, 0.11111111111111
42794, 0.043478260869565, 1.0891304347826, 0.16666666666667
42795, 0.043478260869565, 1.0891304347826, 0.22222222222222
42796, 0.043478260869565, 1.0891304347826, 0.27777777777778
42797, 0.043478260869565, 1.0891304347826, 0.33333333333333
42798, 0.043478260869565, 1.0891304347826, 0.38888888888889
42799, 0.043478260869565, 1.0891304347826, 0.44444444444444
42800, 0.95652173913043, 1.1413043478261, 0.055555555555556
42801, 0.95652173913043, 1.1413043478261, 0.11111111111111
42802, 0.95652173913043, 1.1413043478261, 0.16666666666667
42803, 0.95652173913044, 1.1413043478261, 0.22222222222222
42804, 0.95652173913044, 1.1413043478261, 0.27777777777778
42805, 0.95652173913043, 1.1413043478261, 0.33333333333333
42806, 0.95652173913044, 1.1413043478261, 0.38888888888889
42807, 0.95652173913044, 1.1413043478261, 0.44444444444444
42808, 0.91304347826087, 1.1413043478261, 0.055555555555556
42809, 0.91304347826087, 1.1413043478261, 0.11111111111111
42810, 0.91304347826087, 1.1413043478261, 0.16666666666667
42811, 0.91304347826087, 1.1413043478261, 0.22222222222222
42812, 0.91304347826087, 1.1413043478261, 0.27777777777778
42813, 0.91304347826087, 1.1413043478261, 0.33333333333333
42814, 0.91304347826087, 1.1413043478261, 0.38888888888889
42815, 0.91304347826087, 1.1413043478261, 0.44444444444444
42816, 0.8695652173913, 1.1413043478261, 0.055555555555556
42817, 0.8695652173913, 1.1413043478261, 0.11111111111111
42818, 0.8695652173913, 1.1413043478261, 0.16666666666667
42819, 0.8695652173913, 1.1413043478261, 0.22222222222222
42820, 0.8695652173913, 1.1413043478261, 0.27777777777778
42821, 0.8695652173913, 1.1413043478261, 0.33333333333333
42822, 0.8695652173913, 1.1413043478261, 0.38888888888889
42823, 0.8695652173913, 1.1413043478261, 0.44444444444444
42824, 0.82608695652174, 1.1413043478261, 0.055555555555556
42825, 0.82608695652174, 1.1413043478261, 0.11111111111111
42826, 0.82608695652174, 1.1413043478261, 0.16666666666667
42827, 0.82608695652174, 1.1413043478261, 0.22222222222222
