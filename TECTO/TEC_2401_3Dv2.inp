27596, 25409, 25408, 25386, 25387, 64974, 64966, 64790, 64798, 26372, 26371, 26327, 26373, 76810, 76786, 76252, 
76811, 76809, 76784, 76226, 76251
27597, 64974, 64966, 64790, 64798, 64975, 64967, 64791, 64799, 76810, 76786, 76252, 76811, 76813, 76789, 76255, 
76814, 76812, 76787, 76229, 76254
27598, 64975, 64967, 64791, 64799, 64976, 64968, 64792, 64800, 76813, 76789, 76255, 76814, 76816, 76792, 76258, 
76817, 76815, 76790, 76232, 76257
27599, 64976, 64968, 64792, 64800, 64977, 64969, 64793, 64801, 76816, 76792, 76258, 76817, 76819, 76795, 76261, 
76820, 76818, 76793, 76235, 76260
27600, 64977, 64969, 64793, 64801, 64978, 64970, 64794, 64802, 76819, 76795, 76261, 76820, 76822, 76798, 76264, 
76823, 76821, 76796, 76238, 76263
27601, 64978, 64970, 64794, 64802, 64979, 64971, 64795, 64803, 76822, 76798, 76264, 76823, 76825, 76801, 76267, 
76826, 76824, 76799, 76241, 76266
27602, 64979, 64971, 64795, 64803, 64980, 64972, 64796, 64804, 76825, 76801, 76267, 76826, 76828, 76804, 76270, 
76829, 76827, 76802, 76244, 76269
27603, 64980, 64972, 64796, 64804, 64981, 64973, 64797, 64805, 76828, 76804, 76270, 76829, 76831, 76807, 76273, 
76832, 76830, 76805, 76247, 76272
27604, 64981, 64973, 64797, 64805, 26905, 26904, 26882, 26883, 76831, 76807, 76273, 76832, 27869, 27866, 27824, 
27868, 76833, 76808, 76250, 76275
27605, 25410, 25409, 25387, 25388, 64982, 64974, 64798, 64806, 26374, 26373, 26329, 26375, 76835, 76811, 76277, 
76836, 76834, 76809, 76251, 76276
27606, 64982, 64974, 64798, 64806, 64983, 64975, 64799, 64807, 76835, 76811, 76277, 76836, 76838, 76814, 76280, 
76839, 76837, 76812, 76254, 76279
27607, 64983, 64975, 64799, 64807, 64984, 64976, 64800, 64808, 76838, 76814, 76280, 76839, 76841, 76817, 76283, 
76842, 76840, 76815, 76257, 76282
27608, 64984, 64976, 64800, 64808, 64985, 64977, 64801, 64809, 76841, 76817, 76283, 76842, 76844, 76820, 76286, 
76845, 76843, 76818, 76260, 76285
27609, 64985, 64977, 64801, 64809, 64986, 64978, 64802, 64810, 76844, 76820, 76286, 76845, 76847, 76823, 76289, 
76848, 76846, 76821, 76263, 76288
27610, 64986, 64978, 64802, 64810, 64987, 64979, 64803, 64811, 76847, 76823, 76289, 76848, 76850, 76826, 76292, 
76851, 76849, 76824, 76266, 76291
27611, 64987, 64979, 64803, 64811, 64988, 64980, 64804, 64812, 76850, 76826, 76292, 76851, 76853, 76829, 76295, 
76854, 76852, 76827, 76269, 76294
27612, 64988, 64980, 64804, 64812, 64989, 64981, 64805, 64813, 76853, 76829, 76295, 76854, 76856, 76832, 76298, 
76857, 76855, 76830, 76272, 76297
27613, 64989, 64981, 64805, 64813, 26906, 26905, 26883, 26884, 76856, 76832, 76298, 76857, 27871, 27868, 27826, 
27870, 76858, 76833, 76275, 76300
27614, 25411, 25410, 25388, 25389, 64990, 64982, 64806, 64814, 26376, 26375, 26331, 26377, 76860, 76836, 76302, 
76861, 76859, 76834, 76276, 76301
27615, 64990, 64982, 64806, 64814, 64991, 64983, 64807, 64815, 76860, 76836, 76302, 76861, 76863, 76839, 76305, 
76864, 76862, 76837, 76279, 76304
27616, 64991, 64983, 64807, 64815, 64992, 64984, 64808, 64816, 76863, 76839, 76305, 76864, 76866, 76842, 76308, 
76867, 76865, 76840, 76282, 76307
27617, 64992, 64984, 64808, 64816, 64993, 64985, 64809, 64817, 76866, 76842, 76308, 76867, 76869, 76845, 76311, 
76870, 76868, 76843, 76285, 76310
27618, 64993, 64985, 64809, 64817, 64994, 64986, 64810, 64818, 76869, 76845, 76311, 76870, 76872, 76848, 76314, 
76873, 76871, 76846, 76288, 76313
27619, 64994, 64986, 64810, 64818, 64995, 64987, 64811, 64819, 76872, 76848, 76314, 76873, 76875, 76851, 76317, 
76876, 76874, 76849, 76291, 76316
27620, 64995, 64987, 64811, 64819, 64996, 64988, 64812, 64820, 76875, 76851, 76317, 76876, 76878, 76854, 76320, 
76879, 76877, 76852, 76294, 76319
27621, 64996, 64988, 64812, 64820, 64997, 64989, 64813, 64821, 76878, 76854, 76320, 76879, 76881, 76857, 76323, 
76882, 76880, 76855, 76297, 76322
27622, 64997, 64989, 64813, 64821, 26907, 26906, 26884, 26885, 76881, 76857, 76323, 76882, 27873, 27870, 27828, 
27872, 76883, 76858, 76300, 76325
27623, 3202, 25411, 25389, 3201, 28660, 64990, 64814, 28652, 26378, 26377, 26333, 3224, 76884, 76861, 76326, 
29017, 29016, 76859, 76301, 28999
27624, 28660, 64990, 64814, 28652, 28661, 64991, 64815, 28653, 76884, 76861, 76326, 29017, 76885, 76864, 76327, 
29019, 29018, 76862, 76304, 29001
27625, 28661, 64991, 64815, 28653, 28662, 64992, 64816, 28654, 76885, 76864, 76327, 29019, 76886, 76867, 76328, 
29021, 29020, 76865, 76307, 29003
27626, 28662, 64992, 64816, 28654, 28663, 64993, 64817, 28655, 76886, 76867, 76328, 29021, 76887, 76870, 76329, 
29023, 29022, 76868, 76310, 29005
27627, 28663, 64993, 64817, 28655, 28664, 64994, 64818, 28656, 76887, 76870, 76329, 29023, 76888, 76873, 76330, 
29025, 29024, 76871, 76313, 29007
27628, 28664, 64994, 64818, 28656, 28665, 64995, 64819, 28657, 76888, 76873, 76330, 29025, 76889, 76876, 76331, 
29027, 29026, 76874, 76316, 29009
27629, 28665, 64995, 64819, 28657, 28666, 64996, 64820, 28658, 76889, 76876, 76331, 29027, 76890, 76879, 76332, 
29029, 29028, 76877, 76319, 29011
27630, 28666, 64996, 64820, 28658, 28667, 64997, 64821, 28659, 76890, 76879, 76332, 29029, 76891, 76882, 76333, 
29031, 29030, 76880, 76322, 29013
27631, 28667, 64997, 64821, 28659, 3337, 26907, 26885, 3336, 76891, 76882, 76333, 29031, 27874, 27872, 27829, 
3359, 29032, 76883, 76325, 29015
27632, 25412, 3158, 3157, 25390, 64998, 28110, 28102, 64822, 26379, 3180, 26334, 26380, 76893, 28475, 76335, 
76894, 76892, 28476, 28459, 76334
27633, 64998, 28110, 28102, 64822, 64999, 28111, 28103, 64823, 76893, 28475, 76335, 76894, 76896, 28477, 76338, 
76897, 76895, 28478, 28461, 76337
27634, 64999, 28111, 28103, 64823, 65000, 28112, 28104, 64824, 76896, 28477, 76338, 76897, 76899, 28479, 76341, 
76900, 76898, 28480, 28463, 76340
27635, 65000, 28112, 28104, 64824, 65001, 28113, 28105, 64825, 76899, 28479, 76341, 76900, 76902, 28481, 76344, 
76903, 76901, 28482, 28465, 76343
27636, 65001, 28113, 28105, 64825, 65002, 28114, 28106, 64826, 76902, 28481, 76344, 76903, 76905, 28483, 76347, 
76906, 76904, 28484, 28467, 76346
27637, 65002, 28114, 28106, 64826, 65003, 28115, 28107, 64827, 76905, 28483, 76347, 76906, 76908, 28485, 76350, 
76909, 76907, 28486, 28469, 76349
27638, 65003, 28115, 28107, 64827, 65004, 28116, 28108, 64828, 76908, 28485, 76350, 76909, 76911, 28487, 76353, 
76912, 76910, 28488, 28471, 76352
27639, 65004, 28116, 28108, 64828, 65005, 28117, 28109, 64829, 76911, 28487, 76353, 76912, 76914, 28489, 76356, 
76915, 76913, 28490, 28473, 76355
27640, 65005, 28117, 28109, 64829, 26908, 3293, 3292, 26886, 76914, 28489, 76356, 76915, 27876, 3315, 27831, 
27875, 76916, 28491, 28474, 76358
27641, 25413, 25412, 25390, 25391, 65006, 64998, 64822, 64830, 26381, 26380, 26336, 26382, 76918, 76894, 76360, 
76919, 76917, 76892, 76334, 76359
27642, 65006, 64998, 64822, 64830, 65007, 64999, 64823, 64831, 76918, 76894, 76360, 76919, 76921, 76897, 76363, 
76922, 76920, 76895, 76337, 76362
27643, 65007, 64999, 64823, 64831, 65008, 65000, 64824, 64832, 76921, 76897, 76363, 76922, 76924, 76900, 76366, 
76925, 76923, 76898, 76340, 76365
27644, 65008, 65000, 64824, 64832, 65009, 65001, 64825, 64833, 76924, 76900, 76366, 76925, 76927, 76903, 76369, 
76928, 76926, 76901, 76343, 76368
27645, 65009, 65001, 64825, 64833, 65010, 65002, 64826, 64834, 76927, 76903, 76369, 76928, 76930, 76906, 76372, 
76931, 76929, 76904, 76346, 76371
27646, 65010, 65002, 64826, 64834, 65011, 65003, 64827, 64835, 76930, 76906, 76372, 76931, 76933, 76909, 76375, 
76934, 76932, 76907, 76349, 76374
27647, 65011, 65003, 64827, 64835, 65012, 65004, 64828, 64836, 76933, 76909, 76375, 76934, 76936, 76912, 76378, 
76937, 76935, 76910, 76352, 76377
27648, 65012, 65004, 64828, 64836, 65013, 65005, 64829, 64837, 76936, 76912, 76378, 76937, 76939, 76915, 76381, 
76940, 76938, 76913, 76355, 76380
27649, 65013, 65005, 64829, 64837, 26909, 26908, 26886, 26887, 76939, 76915, 76381, 76940, 27878, 27875, 27833, 
27877, 76941, 76916, 76358, 76383
27650, 25414, 25413, 25391, 25392, 65014, 65006, 64830, 64838, 26383, 26382, 26338, 26384, 76943, 76919, 76385, 
76944, 76942, 76917, 76359, 76384
27651, 65014, 65006, 64830, 64838, 65015, 65007, 64831, 64839, 76943, 76919, 76385, 76944, 76946, 76922, 76388, 
76947, 76945, 76920, 76362, 76387
27652, 65015, 65007, 64831, 64839, 65016, 65008, 64832, 64840, 76946, 76922, 76388, 76947, 76949, 76925, 76391, 
76950, 76948, 76923, 76365, 76390
27653, 65016, 65008, 64832, 64840, 65017, 65009, 64833, 64841, 76949, 76925, 76391, 76950, 76952, 76928, 76394, 
76953, 76951, 76926, 76368, 76393
27654, 65017, 65009, 64833, 64841, 65018, 65010, 64834, 64842, 76952, 76928, 76394, 76953, 76955, 76931, 76397, 
76956, 76954, 76929, 76371, 76396
27655, 65018, 65010, 64834, 64842, 65019, 65011, 64835, 64843, 76955, 76931, 76397, 76956, 76958, 76934, 76400, 
76959, 76957, 76932, 76374, 76399
27656, 65019, 65011, 64835, 64843, 65020, 65012, 64836, 64844, 76958, 76934, 76400, 76959, 76961, 76937, 76403, 
76962, 76960, 76935, 76377, 76402
27657, 65020, 65012, 64836, 64844, 65021, 65013, 64837, 64845, 76961, 76937, 76403, 76962, 76964, 76940, 76406, 
76965, 76963, 76938, 76380, 76405
27658, 65021, 65013, 64837, 64845, 26910, 26909, 26887, 26888, 76964, 76940, 76406, 76965, 27880, 27877, 27835, 
27879, 76966, 76941, 76383, 76408
27659, 25415, 25414, 25392, 25393, 65022, 65014, 64838, 64846, 26385, 26384, 26340, 26386, 76968, 76944, 76410, 
76969, 76967, 76942, 76384, 76409
27660, 65022, 65014, 64838, 64846, 65023, 65015, 64839, 64847, 76968, 76944, 76410, 76969, 76971, 76947, 76413, 
76972, 76970, 76945, 76387, 76412
27661, 65023, 65015, 64839, 64847, 65024, 65016, 64840, 64848, 76971, 76947, 76413, 76972, 76974, 76950, 76416, 
76975, 76973, 76948, 76390, 76415
27662, 65024, 65016, 64840, 64848, 65025, 65017, 64841, 64849, 76974, 76950, 76416, 76975, 76977, 76953, 76419, 
76978, 76976, 76951, 76393, 76418
27663, 65025, 65017, 64841, 64849, 65026, 65018, 64842, 64850, 76977, 76953, 76419, 76978, 76980, 76956, 76422, 
76981, 76979, 76954, 76396, 76421
27664, 65026, 65018, 64842, 64850, 65027, 65019, 64843, 64851, 76980, 76956, 76422, 76981, 76983, 76959, 76425, 
76984, 76982, 76957, 76399, 76424
27665, 65027, 65019, 64843, 64851, 65028, 65020, 64844, 64852, 76983, 76959, 76425, 76984, 76986, 76962, 76428, 
76987, 76985, 76960, 76402, 76427
27666, 65028, 65020, 64844, 64852, 65029, 65021, 64845, 64853, 76986, 76962, 76428, 76987, 76989, 76965, 76431, 
76990, 76988, 76963, 76405, 76430
27667, 65029, 65021, 64845, 64853, 26911, 26910, 26888, 26889, 76989, 76965, 76431, 76990, 27882, 27879, 27837, 
27881, 76991, 76966, 76408, 76433
27668, 25416, 25415, 25393, 25394, 65030, 65022, 64846, 64854, 26387, 26386, 26342, 26388, 76993, 76969, 76435, 
76994, 76992, 76967, 76409, 76434
27669, 65030, 65022, 64846, 64854, 65031, 65023, 64847, 64855, 76993, 76969, 76435, 76994, 76996, 76972, 76438, 
76997, 76995, 76970, 76412, 76437
27670, 65031, 65023, 64847, 64855, 65032, 65024, 64848, 64856, 76996, 76972, 76438, 76997, 76999, 76975, 76441, 
77000, 76998, 76973, 76415, 76440
27671, 65032, 65024, 64848, 64856, 65033, 65025, 64849, 64857, 76999, 76975, 76441, 77000, 77002, 76978, 76444, 
77003, 77001, 76976, 76418, 76443
27672, 65033, 65025, 64849, 64857, 65034, 65026, 64850, 64858, 77002, 76978, 76444, 77003, 77005, 76981, 76447, 
77006, 77004, 76979, 76421, 76446
27673, 65034, 65026, 64850, 64858, 65035, 65027, 64851, 64859, 77005, 76981, 76447, 77006, 77008, 76984, 76450, 
77009, 77007, 76982, 76424, 76449
27674, 65035, 65027, 64851, 64859, 65036, 65028, 64852, 64860, 77008, 76984, 76450, 77009, 77011, 76987, 76453, 
77012, 77010, 76985, 76427, 76452
27675, 65036, 65028, 64852, 64860, 65037, 65029, 64853, 64861, 77011, 76987, 76453, 77012, 77014, 76990, 76456, 
77015, 77013, 76988, 76430, 76455
27676, 65037, 65029, 64853, 64861, 26912, 26911, 26889, 26890, 77014, 76990, 76456, 77015, 27884, 27881, 27839, 
27883, 77016, 76991, 76433, 76458
27677, 25417, 25416, 25394, 25395, 65038, 65030, 64854, 64862, 26389, 26388, 26344, 26390, 77018, 76994, 76460, 
77019, 77017, 76992, 76434, 76459
27678, 65038, 65030, 64854, 64862, 65039, 65031, 64855, 64863, 77018, 76994, 76460, 77019, 77021, 76997, 76463, 
77022, 77020, 76995, 76437, 76462
27679, 65039, 65031, 64855, 64863, 65040, 65032, 64856, 64864, 77021, 76997, 76463, 77022, 77024, 77000, 76466, 
77025, 77023, 76998, 76440, 76465
27680, 65040, 65032, 64856, 64864, 65041, 65033, 64857, 64865, 77024, 77000, 76466, 77025, 77027, 77003, 76469, 
77028, 77026, 77001, 76443, 76468
27681, 65041, 65033, 64857, 64865, 65042, 65034, 64858, 64866, 77027, 77003, 76469, 77028, 77030, 77006, 76472, 
77031, 77029, 77004, 76446, 76471
27682, 65042, 65034, 64858, 64866, 65043, 65035, 64859, 64867, 77030, 77006, 76472, 77031, 77033, 77009, 76475, 
77034, 77032, 77007, 76449, 76474
27683, 65043, 65035, 64859, 64867, 65044, 65036, 64860, 64868, 77033, 77009, 76475, 77034, 77036, 77012, 76478, 
77037, 77035, 77010, 76452, 76477
27684, 65044, 65036, 64860, 64868, 65045, 65037, 64861, 64869, 77036, 77012, 76478, 77037, 77039, 77015, 76481, 
77040, 77038, 77013, 76455, 76480
27685, 65045, 65037, 64861, 64869, 26913, 26912, 26890, 26891, 77039, 77015, 76481, 77040, 27886, 27883, 27841, 
27885, 77041, 77016, 76458, 76483
27686, 25418, 25417, 25395, 25396, 65046, 65038, 64862, 64870, 26391, 26390, 26346, 26392, 77043, 77019, 76485, 
77044, 77042, 77017, 76459, 76484
27687, 65046, 65038, 64862, 64870, 65047, 65039, 64863, 64871, 77043, 77019, 76485, 77044, 77046, 77022, 76488, 
77047, 77045, 77020, 76462, 76487
27688, 65047, 65039, 64863, 64871, 65048, 65040, 64864, 64872, 77046, 77022, 76488, 77047, 77049, 77025, 76491, 
77050, 77048, 77023, 76465, 76490
27689, 65048, 65040, 64864, 64872, 65049, 65041, 64865, 64873, 77049, 77025, 76491, 77050, 77052, 77028, 76494, 
77053, 77051, 77026, 76468, 76493
27690, 65049, 65041, 64865, 64873, 65050, 65042, 64866, 64874, 77052, 77028, 76494, 77053, 77055, 77031, 76497, 
77056, 77054, 77029, 76471, 76496
27691, 65050, 65042, 64866, 64874, 65051, 65043, 64867, 64875, 77055, 77031, 76497, 77056, 77058, 77034, 76500, 
77059, 77057, 77032, 76474, 76499
27692, 65051, 65043, 64867, 64875, 65052, 65044, 64868, 64876, 77058, 77034, 76500, 77059, 77061, 77037, 76503, 
77062, 77060, 77035, 76477, 76502
27693, 65052, 65044, 64868, 64876, 65053, 65045, 64869, 64877, 77061, 77037, 76503, 77062, 77064, 77040, 76506, 
77065, 77063, 77038, 76480, 76505
27694, 65053, 65045, 64869, 64877, 26914, 26913, 26891, 26892, 77064, 77040, 76506, 77065, 27888, 27885, 27843, 
27887, 77066, 77041, 76483, 76508
27695, 25419, 25418, 25396, 25397, 65054, 65046, 64870, 64878, 26393, 26392, 26348, 26394, 77068, 77044, 76510, 
77069, 77067, 77042, 76484, 76509
27696, 65054, 65046, 64870, 64878, 65055, 65047, 64871, 64879, 77068, 77044, 76510, 77069, 77071, 77047, 76513, 
77072, 77070, 77045, 76487, 76512
27697, 65055, 65047, 64871, 64879, 65056, 65048, 64872, 64880, 77071, 77047, 76513, 77072, 77074, 77050, 76516, 
77075, 77073, 77048, 76490, 76515
27698, 65056, 65048, 64872, 64880, 65057, 65049, 64873, 64881, 77074, 77050, 76516, 77075, 77077, 77053, 76519, 
77078, 77076, 77051, 76493, 76518
27699, 65057, 65049, 64873, 64881, 65058, 65050, 64874, 64882, 77077, 77053, 76519, 77078, 77080, 77056, 76522, 
77081, 77079, 77054, 76496, 76521
27700, 65058, 65050, 64874, 64882, 65059, 65051, 64875, 64883, 77080, 77056, 76522, 77081, 77083, 77059, 76525, 
77084, 77082, 77057, 76499, 76524
27701, 65059, 65051, 64875, 64883, 65060, 65052, 64876, 64884, 77083, 77059, 76525, 77084, 77086, 77062, 76528, 
77087, 77085, 77060, 76502, 76527
27702, 65060, 65052, 64876, 64884, 65061, 65053, 64877, 64885, 77086, 77062, 76528, 77087, 77089, 77065, 76531, 
77090, 77088, 77063, 76505, 76530
27703, 65061, 65053, 64877, 64885, 26915, 26914, 26892, 26893, 77089, 77065, 76531, 77090, 27890, 27887, 27845, 
27889, 77091, 77066, 76508, 76533
27704, 25420, 25419, 25397, 25398, 65062, 65054, 64878, 64886, 26395, 26394, 26350, 26396, 77093, 77069, 76535, 
77094, 77092, 77067, 76509, 76534
27705, 65062, 65054, 64878, 64886, 65063, 65055, 64879, 64887, 77093, 77069, 76535, 77094, 77096, 77072, 76538, 
77097, 77095, 77070, 76512, 76537
27706, 65063, 65055, 64879, 64887, 65064, 65056, 64880, 64888, 77096, 77072, 76538, 77097, 77099, 77075, 76541, 
77100, 77098, 77073, 76515, 76540
27707, 65064, 65056, 64880, 64888, 65065, 65057, 64881, 64889, 77099, 77075, 76541, 77100, 77102, 77078, 76544, 
77103, 77101, 77076, 76518, 76543
27708, 65065, 65057, 64881, 64889, 65066, 65058, 64882, 64890, 77102, 77078, 76544, 77103, 77105, 77081, 76547, 
77106, 77104, 77079, 76521, 76546
27709, 65066, 65058, 64882, 64890, 65067, 65059, 64883, 64891, 77105, 77081, 76547, 77106, 77108, 77084, 76550, 
77109, 77107, 77082, 76524, 76549
27710, 65067, 65059, 64883, 64891, 65068, 65060, 64884, 64892, 77108, 77084, 76550, 77109, 77111, 77087, 76553, 
77112, 77110, 77085, 76527, 76552
27711, 65068, 65060, 64884, 64892, 65069, 65061, 64885, 64893, 77111, 77087, 76553, 77112, 77114, 77090, 76556, 
77115, 77113, 77088, 76530, 76555
27712, 65069, 65061, 64885, 64893, 26916, 26915, 26893, 26894, 77114, 77090, 76556, 77115, 27892, 27889, 27847, 
27891, 77116, 77091, 76533, 76558
27713, 25421, 25420, 25398, 25399, 65070, 65062, 64886, 64894, 26397, 26396, 26352, 26398, 77118, 77094, 76560, 
77119, 77117, 77092, 76534, 76559
27714, 65070, 65062, 64886, 64894, 65071, 65063, 64887, 64895, 77118, 77094, 76560, 77119, 77121, 77097, 76563, 
77122, 77120, 77095, 76537, 76562
27715, 65071, 65063, 64887, 64895, 65072, 65064, 64888, 64896, 77121, 77097, 76563, 77122, 77124, 77100, 76566, 
77125, 77123, 77098, 76540, 76565
27716, 65072, 65064, 64888, 64896, 65073, 65065, 64889, 64897, 77124, 77100, 76566, 77125, 77127, 77103, 76569, 
77128, 77126, 77101, 76543, 76568
27717, 65073, 65065, 64889, 64897, 65074, 65066, 64890, 64898, 77127, 77103, 76569, 77128, 77130, 77106, 76572, 
77131, 77129, 77104, 76546, 76571
27718, 65074, 65066, 64890, 64898, 65075, 65067, 64891, 64899, 77130, 77106, 76572, 77131, 77133, 77109, 76575, 
77134, 77132, 77107, 76549, 76574
27719, 65075, 65067, 64891, 64899, 65076, 65068, 64892, 64900, 77133, 77109, 76575, 77134, 77136, 77112, 76578, 
77137, 77135, 77110, 76552, 76577
27720, 65076, 65068, 64892, 64900, 65077, 65069, 64893, 64901, 77136, 77112, 76578, 77137, 77139, 77115, 76581, 
77140, 77138, 77113, 76555, 76580
27721, 65077, 65069, 64893, 64901, 26917, 26916, 26894, 26895, 77139, 77115, 76581, 77140, 27894, 27891, 27849, 
27893, 77141, 77116, 76558, 76583
27722, 25422, 25421, 25399, 25400, 65078, 65070, 64894, 64902, 26399, 26398, 26354, 26400, 77143, 77119, 76585, 
77144, 77142, 77117, 76559, 76584
27723, 65078, 65070, 64894, 64902, 65079, 65071, 64895, 64903, 77143, 77119, 76585, 77144, 77146, 77122, 76588, 
77147, 77145, 77120, 76562, 76587
27724, 65079, 65071, 64895, 64903, 65080, 65072, 64896, 64904, 77146, 77122, 76588, 77147, 77149, 77125, 76591, 
77150, 77148, 77123, 76565, 76590
27725, 65080, 65072, 64896, 64904, 65081, 65073, 64897, 64905, 77149, 77125, 76591, 77150, 77152, 77128, 76594, 
77153, 77151, 77126, 76568, 76593
27726, 65081, 65073, 64897, 64905, 65082, 65074, 64898, 64906, 77152, 77128, 76594, 77153, 77155, 77131, 76597, 
77156, 77154, 77129, 76571, 76596
27727, 65082, 65074, 64898, 64906, 65083, 65075, 64899, 64907, 77155, 77131, 76597, 77156, 77158, 77134, 76600, 
77159, 77157, 77132, 76574, 76599
27728, 65083, 65075, 64899, 64907, 65084, 65076, 64900, 64908, 77158, 77134, 76600, 77159, 77161, 77137, 76603, 
77162, 77160, 77135, 76577, 76602
27729, 65084, 65076, 64900, 64908, 65085, 65077, 64901, 64909, 77161, 77137, 76603, 77162, 77164, 77140, 76606, 
77165, 77163, 77138, 76580, 76605
27730, 65085, 65077, 64901, 64909, 26918, 26917, 26895, 26896, 77164, 77140, 76606, 77165, 27896, 27893, 27851, 
27895, 77166, 77141, 76583, 76608
27731, 25423, 25422, 25400, 25401, 65086, 65078, 64902, 64910, 26401, 26400, 26356, 26402, 77168, 77144, 76610, 
77169, 77167, 77142, 76584, 76609
27732, 65086, 65078, 64902, 64910, 65087, 65079, 64903, 64911, 77168, 77144, 76610, 77169, 77171, 77147, 76613, 
77172, 77170, 77145, 76587, 76612
27733, 65087, 65079, 64903, 64911, 65088, 65080, 64904, 64912, 77171, 77147, 76613, 77172, 77174, 77150, 76616, 
77175, 77173, 77148, 76590, 76615
27734, 65088, 65080, 64904, 64912, 65089, 65081, 64905, 64913, 77174, 77150, 76616, 77175, 77177, 77153, 76619, 
77178, 77176, 77151, 76593, 76618
27735, 65089, 65081, 64905, 64913, 65090, 65082, 64906, 64914, 77177, 77153, 76619, 77178, 77180, 77156, 76622, 
77181, 77179, 77154, 76596, 76621
27736, 65090, 65082, 64906, 64914, 65091, 65083, 64907, 64915, 77180, 77156, 76622, 77181, 77183, 77159, 76625, 
77184, 77182, 77157, 76599, 76624
27737, 65091, 65083, 64907, 64915, 65092, 65084, 64908, 64916, 77183, 77159, 76625, 77184, 77186, 77162, 76628, 
77187, 77185, 77160, 76602, 76627
27738, 65092, 65084, 64908, 64916, 65093, 65085, 64909, 64917, 77186, 77162, 76628, 77187, 77189, 77165, 76631, 
77190, 77188, 77163, 76605, 76630
27739, 65093, 65085, 64909, 64917, 26919, 26918, 26896, 26897, 77189, 77165, 76631, 77190, 27898, 27895, 27853, 
27897, 77191, 77166, 76608, 76633
27740, 25424, 25423, 25401, 25402, 65094, 65086, 64910, 64918, 26403, 26402, 26358, 26404, 77193, 77169, 76635, 
77194, 77192, 77167, 76609, 76634
27741, 65094, 65086, 64910, 64918, 65095, 65087, 64911, 64919, 77193, 77169, 76635, 77194, 77196, 77172, 76638, 
77197, 77195, 77170, 76612, 76637
27742, 65095, 65087, 64911, 64919, 65096, 65088, 64912, 64920, 77196, 77172, 76638, 77197, 77199, 77175, 76641, 
77200, 77198, 77173, 76615, 76640
27743, 65096, 65088, 64912, 64920, 65097, 65089, 64913, 64921, 77199, 77175, 76641, 77200, 77202, 77178, 76644, 
77203, 77201, 77176, 76618, 76643
27744, 65097, 65089, 64913, 64921, 65098, 65090, 64914, 64922, 77202, 77178, 76644, 77203, 77205, 77181, 76647, 
77206, 77204, 77179, 76621, 76646
27745, 65098, 65090, 64914, 64922, 65099, 65091, 64915, 64923, 77205, 77181, 76647, 77206, 77208, 77184, 76650, 
77209, 77207, 77182, 76624, 76649
27746, 65099, 65091, 64915, 64923, 65100, 65092, 64916, 64924, 77208, 77184, 76650, 77209, 77211, 77187, 76653, 
77212, 77210, 77185, 76627, 76652
27747, 65100, 65092, 64916, 64924, 65101, 65093, 64917, 64925, 77211, 77187, 76653, 77212, 77214, 77190, 76656, 
77215, 77213, 77188, 76630, 76655
27748, 65101, 65093, 64917, 64925, 26920, 26919, 26897, 26898, 77214, 77190, 76656, 77215, 27900, 27897, 27855, 
27899, 77216, 77191, 76633, 76658
27749, 25425, 25424, 25402, 25403, 65102, 65094, 64918, 64926, 26405, 26404, 26360, 26406, 77218, 77194, 76660, 
77219, 77217, 77192, 76634, 76659
27750, 65102, 65094, 64918, 64926, 65103, 65095, 64919, 64927, 77218, 77194, 76660, 77219, 77221, 77197, 76663, 
77222, 77220, 77195, 76637, 76662
27751, 65103, 65095, 64919, 64927, 65104, 65096, 64920, 64928, 77221, 77197, 76663, 77222, 77224, 77200, 76666, 
77225, 77223, 77198, 76640, 76665
27752, 65104, 65096, 64920, 64928, 65105, 65097, 64921, 64929, 77224, 77200, 76666, 77225, 77227, 77203, 76669, 
77228, 77226, 77201, 76643, 76668
27753, 65105, 65097, 64921, 64929, 65106, 65098, 64922, 64930, 77227, 77203, 76669, 77228, 77230, 77206, 76672, 
77231, 77229, 77204, 76646, 76671
27754, 65106, 65098, 64922, 64930, 65107, 65099, 64923, 64931, 77230, 77206, 76672, 77231, 77233, 77209, 76675, 
77234, 77232, 77207, 76649, 76674
27755, 65107, 65099, 64923, 64931, 65108, 65100, 64924, 64932, 77233, 77209, 76675, 77234, 77236, 77212, 76678, 
77237, 77235, 77210, 76652, 76677
27756, 65108, 65100, 64924, 64932, 65109, 65101, 64925, 64933, 77236, 77212, 76678, 77237, 77239, 77215, 76681, 
77240, 77238, 77213, 76655, 76680
27757, 65109, 65101, 64925, 64933, 26921, 26920, 26898, 26899, 77239, 77215, 76681, 77240, 27902, 27899, 27857, 
27901, 77241, 77216, 76658, 76683
27758, 25426, 25425, 25403, 25404, 65110, 65102, 64926, 64934, 26407, 26406, 26362, 26408, 77243, 77219, 76685, 
77244, 77242, 77217, 76659, 76684
27759, 65110, 65102, 64926, 64934, 65111, 65103, 64927, 64935, 77243, 77219, 76685, 77244, 77246, 77222, 76688, 
77247, 77245, 77220, 76662, 76687
27760, 65111, 65103, 64927, 64935, 65112, 65104, 64928, 64936, 77246, 77222, 76688, 77247, 77249, 77225, 76691, 
77250, 77248, 77223, 76665, 76690
27761, 65112, 65104, 64928, 64936, 65113, 65105, 64929, 64937, 77249, 77225, 76691, 77250, 77252, 77228, 76694, 
77253, 77251, 77226, 76668, 76693
27762, 65113, 65105, 64929, 64937, 65114, 65106, 64930, 64938, 77252, 77228, 76694, 77253, 77255, 77231, 76697, 
77256, 77254, 77229, 76671, 76696
27763, 65114, 65106, 64930, 64938, 65115, 65107, 64931, 64939, 77255, 77231, 76697, 77256, 77258, 77234, 76700, 
77259, 77257, 77232, 76674, 76699
27764, 65115, 65107, 64931, 64939, 65116, 65108, 64932, 64940, 77258, 77234, 76700, 77259, 77261, 77237, 76703, 
77262, 77260, 77235, 76677, 76702
27765, 65116, 65108, 64932, 64940, 65117, 65109, 64933, 64941, 77261, 77237, 76703, 77262, 77264, 77240, 76706, 
77265, 77263, 77238, 76680, 76705
27766, 65117, 65109, 64933, 64941, 26922, 26921, 26899, 26900, 77264, 77240, 76706, 77265, 27904, 27901, 27859, 
27903, 77266, 77241, 76683, 76708
27767, 25427, 25426, 25404, 25405, 65118, 65110, 64934, 64942, 26409, 26408, 26364, 26410, 77268, 77244, 76710, 
77269, 77267, 77242, 76684, 76709
27768, 65118, 65110, 64934, 64942, 65119, 65111, 64935, 64943, 77268, 77244, 76710, 77269, 77271, 77247, 76713, 
77272, 77270, 77245, 76687, 76712
27769, 65119, 65111, 64935, 64943, 65120, 65112, 64936, 64944, 77271, 77247, 76713, 77272, 77274, 77250, 76716, 
77275, 77273, 77248, 76690, 76715
27770, 65120, 65112, 64936, 64944, 65121, 65113, 64937, 64945, 77274, 77250, 76716, 77275, 77277, 77253, 76719, 
77278, 77276, 77251, 76693, 76718
27771, 65121, 65113, 64937, 64945, 65122, 65114, 64938, 64946, 77277, 77253, 76719, 77278, 77280, 77256, 76722, 
77281, 77279, 77254, 76696, 76721
27772, 65122, 65114, 64938, 64946, 65123, 65115, 64939, 64947, 77280, 77256, 76722, 77281, 77283, 77259, 76725, 
77284, 77282, 77257, 76699, 76724
27773, 65123, 65115, 64939, 64947, 65124, 65116, 64940, 64948, 77283, 77259, 76725, 77284, 77286, 77262, 76728, 
77287, 77285, 77260, 76702, 76727
27774, 65124, 65116, 64940, 64948, 65125, 65117, 64941, 64949, 77286, 77262, 76728, 77287, 77289, 77265, 76731, 
77290, 77288, 77263, 76705, 76730
27775, 65125, 65117, 64941, 64949, 26923, 26922, 26900, 26901, 77289, 77265, 76731, 77290, 27906, 27903, 27861, 
27905, 77291, 77266, 76708, 76733
27776, 25428, 25427, 25405, 25406, 65126, 65118, 64942, 64950, 26411, 26410, 26366, 26412, 77293, 77269, 76735, 
77294, 77292, 77267, 76709, 76734
27777, 65126, 65118, 64942, 64950, 65127, 65119, 64943, 64951, 77293, 77269, 76735, 77294, 77296, 77272, 76738, 
77297, 77295, 77270, 76712, 76737
27778, 65127, 65119, 64943, 64951, 65128, 65120, 64944, 64952, 77296, 77272, 76738, 77297, 77299, 77275, 76741, 
77300, 77298, 77273, 76715, 76740
27779, 65128, 65120, 64944, 64952, 65129, 65121, 64945, 64953, 77299, 77275, 76741, 77300, 77302, 77278, 76744, 
77303, 77301, 77276, 76718, 76743
27780, 65129, 65121, 64945, 64953, 65130, 65122, 64946, 64954, 77302, 77278, 76744, 77303, 77305, 77281, 76747, 
77306, 77304, 77279, 76721, 76746
27781, 65130, 65122, 64946, 64954, 65131, 65123, 64947, 64955, 77305, 77281, 76747, 77306, 77308, 77284, 76750, 
77309, 77307, 77282, 76724, 76749
27782, 65131, 65123, 64947, 64955, 65132, 65124, 64948, 64956, 77308, 77284, 76750, 77309, 77311, 77287, 76753, 
77312, 77310, 77285, 76727, 76752
27783, 65132, 65124, 64948, 64956, 65133, 65125, 64949, 64957, 77311, 77287, 76753, 77312, 77314, 77290, 76756, 
77315, 77313, 77288, 76730, 76755
27784, 65133, 65125, 64949, 64957, 26924, 26923, 26901, 26902, 77314, 77290, 76756, 77315, 27908, 27905, 27863, 
27907, 77316, 77291, 76733, 76758
27785, 25429, 25428, 25406, 25407, 65134, 65126, 64950, 64958, 26413, 26412, 26368, 26414, 77318, 77294, 76760, 
77319, 77317, 77292, 76734, 76759
27786, 65134, 65126, 64950, 64958, 65135, 65127, 64951, 64959, 77318, 77294, 76760, 77319, 77321, 77297, 76763, 
77322, 77320, 77295, 76737, 76762
27787, 65135, 65127, 64951, 64959, 65136, 65128, 64952, 64960, 77321, 77297, 76763, 77322, 77324, 77300, 76766, 
77325, 77323, 77298, 76740, 76765
27788, 65136, 65128, 64952, 64960, 65137, 65129, 64953, 64961, 77324, 77300, 76766, 77325, 77327, 77303, 76769, 
77328, 77326, 77301, 76743, 76768
27789, 65137, 65129, 64953, 64961, 65138, 65130, 64954, 64962, 77327, 77303, 76769, 77328, 77330, 77306, 76772, 
77331, 77329, 77304, 76746, 76771
27790, 65138, 65130, 64954, 64962, 65139, 65131, 64955, 64963, 77330, 77306, 76772, 77331, 77333, 77309, 76775, 
77334, 77332, 77307, 76749, 76774
27791, 65139, 65131, 64955, 64963, 65140, 65132, 64956, 64964, 77333, 77309, 76775, 77334, 77336, 77312, 76778, 
77337, 77335, 77310, 76752, 76777
27792, 65140, 65132, 64956, 64964, 65141, 65133, 64957, 64965, 77336, 77312, 76778, 77337, 77339, 77315, 76781, 
77340, 77338, 77313, 76755, 76780
27793, 65141, 65133, 64957, 64965, 26925, 26924, 26902, 26903, 77339, 77315, 76781, 77340, 27910, 27907, 27865, 
27909, 77341, 77316, 76758, 76783
27794, 25430, 25429, 25407, 25408, 65142, 65134, 64958, 64966, 26415, 26414, 26370, 26416, 77343, 77319, 76785, 
77344, 77342, 77317, 76759, 76784
27795, 65142, 65134, 64958, 64966, 65143, 65135, 64959, 64967, 77343, 77319, 76785, 77344, 77346, 77322, 76788, 
77347, 77345, 77320, 76762, 76787
27796, 65143, 65135, 64959, 64967, 65144, 65136, 64960, 64968, 77346, 77322, 76788, 77347, 77349, 77325, 76791, 
77350, 77348, 77323, 76765, 76790
27797, 65144, 65136, 64960, 64968, 65145, 65137, 64961, 64969, 77349, 77325, 76791, 77350, 77352, 77328, 76794, 
77353, 77351, 77326, 76768, 76793
27798, 65145, 65137, 64961, 64969, 65146, 65138, 64962, 64970, 77352, 77328, 76794, 77353, 77355, 77331, 76797, 
77356, 77354, 77329, 76771, 76796
27799, 65146, 65138, 64962, 64970, 65147, 65139, 64963, 64971, 77355, 77331, 76797, 77356, 77358, 77334, 76800, 
77359, 77357, 77332, 76774, 76799
27800, 65147, 65139, 64963, 64971, 65148, 65140, 64964, 64972, 77358, 77334, 76800, 77359, 77361, 77337, 76803, 
77362, 77360, 77335, 76777, 76802
27801, 65148, 65140, 64964, 64972, 65149, 65141, 64965, 64973, 77361, 77337, 76803, 77362, 77364, 77340, 76806, 
77365, 77363, 77338, 76780, 76805
27802, 65149, 65141, 64965, 64973, 26926, 26925, 26903, 26904, 77364, 77340, 76806, 77365, 27912, 27909, 27867, 
27911, 77366, 77341, 76783, 76808
27803, 25431, 25430, 25408, 25409, 65150, 65142, 64966, 64974, 26417, 26416, 26372, 26418, 77368, 77344, 76810, 
77369, 77367, 77342, 76784, 76809
27804, 65150, 65142, 64966, 64974, 65151, 65143, 64967, 64975, 77368, 77344, 76810, 77369, 77371, 77347, 76813, 
77372, 77370, 77345, 76787, 76812
27805, 65151, 65143, 64967, 64975, 65152, 65144, 64968, 64976, 77371, 77347, 76813, 77372, 77374, 77350, 76816, 
77375, 77373, 77348, 76790, 76815
27806, 65152, 65144, 64968, 64976, 65153, 65145, 64969, 64977, 77374, 77350, 76816, 77375, 77377, 77353, 76819, 
77378, 77376, 77351, 76793, 76818
27807, 65153, 65145, 64969, 64977, 65154, 65146, 64970, 64978, 77377, 77353, 76819, 77378, 77380, 77356, 76822, 
77381, 77379, 77354, 76796, 76821
27808, 65154, 65146, 64970, 64978, 65155, 65147, 64971, 64979, 77380, 77356, 76822, 77381, 77383, 77359, 76825, 
77384, 77382, 77357, 76799, 76824
27809, 65155, 65147, 64971, 64979, 65156, 65148, 64972, 64980, 77383, 77359, 76825, 77384, 77386, 77362, 76828, 
77387, 77385, 77360, 76802, 76827
27810, 65156, 65148, 64972, 64980, 65157, 65149, 64973, 64981, 77386, 77362, 76828, 77387, 77389, 77365, 76831, 
77390, 77388, 77363, 76805, 76830
27811, 65157, 65149, 64973, 64981, 26927, 26926, 26904, 26905, 77389, 77365, 76831, 77390, 27914, 27911, 27869, 
27913, 77391, 77366, 76808, 76833
27812, 25432, 25431, 25409, 25410, 65158, 65150, 64974, 64982, 26419, 26418, 26374, 26420, 77393, 77369, 76835, 
77394, 77392, 77367, 76809, 76834
27813, 65158, 65150, 64974, 64982, 65159, 65151, 64975, 64983, 77393, 77369, 76835, 77394, 77396, 77372, 76838, 
77397, 77395, 77370, 76812, 76837
27814, 65159, 65151, 64975, 64983, 65160, 65152, 64976, 64984, 77396, 77372, 76838, 77397, 77399, 77375, 76841, 
77400, 77398, 77373, 76815, 76840
27815, 65160, 65152, 64976, 64984, 65161, 65153, 64977, 64985, 77399, 77375, 76841, 77400, 77402, 77378, 76844, 
77403, 77401, 77376, 76818, 76843
27816, 65161, 65153, 64977, 64985, 65162, 65154, 64978, 64986, 77402, 77378, 76844, 77403, 77405, 77381, 76847, 
77406, 77404, 77379, 76821, 76846
27817, 65162, 65154, 64978, 64986, 65163, 65155, 64979, 64987, 77405, 77381, 76847, 77406, 77408, 77384, 76850, 
77409, 77407, 77382, 76824, 76849
27818, 65163, 65155, 64979, 64987, 65164, 65156, 64980, 64988, 77408, 77384, 76850, 77409, 77411, 77387, 76853, 
77412, 77410, 77385, 76827, 76852
27819, 65164, 65156, 64980, 64988, 65165, 65157, 64981, 64989, 77411, 77387, 76853, 77412, 77414, 77390, 76856, 
77415, 77413, 77388, 76830, 76855
27820, 65165, 65157, 64981, 64989, 26928, 26927, 26905, 26906, 77414, 77390, 76856, 77415, 27916, 27913, 27871, 
27915, 77416, 77391, 76833, 76858
27821, 25433, 25432, 25410, 25411, 65166, 65158, 64982, 64990, 26421, 26420, 26376, 26422, 77418, 77394, 76860, 
77419, 77417, 77392, 76834, 76859
27822, 65166, 65158, 64982, 64990, 65167, 65159, 64983, 64991, 77418, 77394, 76860, 77419, 77421, 77397, 76863, 
77422, 77420, 77395, 76837, 76862
27823, 65167, 65159, 64983, 64991, 65168, 65160, 64984, 64992, 77421, 77397, 76863, 77422, 77424, 77400, 76866, 
77425, 77423, 77398, 76840, 76865
27824, 65168, 65160, 64984, 64992, 65169, 65161, 64985, 64993, 77424, 77400, 76866, 77425, 77427, 77403, 76869, 
77428, 77426, 77401, 76843, 76868
27825, 65169, 65161, 64985, 64993, 65170, 65162, 64986, 64994, 77427, 77403, 76869, 77428, 77430, 77406, 76872, 
77431, 77429, 77404, 76846, 76871
27826, 65170, 65162, 64986, 64994, 65171, 65163, 64987, 64995, 77430, 77406, 76872, 77431, 77433, 77409, 76875, 
77434, 77432, 77407, 76849, 76874
27827, 65171, 65163, 64987, 64995, 65172, 65164, 64988, 64996, 77433, 77409, 76875, 77434, 77436, 77412, 76878, 
77437, 77435, 77410, 76852, 76877
27828, 65172, 65164, 64988, 64996, 65173, 65165, 64989, 64997, 77436, 77412, 76878, 77437, 77439, 77415, 76881, 
77440, 77438, 77413, 76855, 76880
27829, 65173, 65165, 64989, 64997, 26929, 26928, 26906, 26907, 77439, 77415, 76881, 77440, 27918, 27915, 27873, 
27917, 77441, 77416, 76858, 76883
27830, 3203, 25433, 25411, 3202, 28668, 65166, 64990, 28660, 26423, 26422, 26378, 3225, 77442, 77419, 76884, 
29034, 29033, 77417, 76859, 29016
27831, 28668, 65166, 64990, 28660, 28669, 65167, 64991, 28661, 77442, 77419, 76884, 29034, 77443, 77422, 76885, 
29036, 29035, 77420, 76862, 29018
27832, 28669, 65167, 64991, 28661, 28670, 65168, 64992, 28662, 77443, 77422, 76885, 29036, 77444, 77425, 76886, 
29038, 29037, 77423, 76865, 29020
27833, 28670, 65168, 64992, 28662, 28671, 65169, 64993, 28663, 77444, 77425, 76886, 29038, 77445, 77428, 76887, 
29040, 29039, 77426, 76868, 29022
27834, 28671, 65169, 64993, 28663, 28672, 65170, 64994, 28664, 77445, 77428, 76887, 29040, 77446, 77431, 76888, 
29042, 29041, 77429, 76871, 29024
27835, 28672, 65170, 64994, 28664, 28673, 65171, 64995, 28665, 77446, 77431, 76888, 29042, 77447, 77434, 76889, 
29044, 29043, 77432, 76874, 29026
27836, 28673, 65171, 64995, 28665, 28674, 65172, 64996, 28666, 77447, 77434, 76889, 29044, 77448, 77437, 76890, 
29046, 29045, 77435, 76877, 29028
27837, 28674, 65172, 64996, 28666, 28675, 65173, 64997, 28667, 77448, 77437, 76890, 29046, 77449, 77440, 76891, 
29048, 29047, 77438, 76880, 29030
27838, 28675, 65173, 64997, 28667, 3338, 26929, 26907, 3337, 77449, 77440, 76891, 29048, 27919, 27917, 27874, 
3360, 29049, 77441, 76883, 29032
27839, 245, 5, 3158, 25412, 4953, 342, 28110, 64998, 267, 3181, 26379, 26424, 5129, 28492, 76893, 
77450, 5130, 351, 28476, 76892
27840, 4953, 342, 28110, 64998, 4954, 341, 28111, 64999, 5129, 28492, 76893, 77450, 5131, 28493, 76896, 
77451, 5132, 350, 28478, 76895
27841, 4954, 341, 28111, 64999, 4955, 340, 28112, 65000, 5131, 28493, 76896, 77451, 5133, 28494, 76899, 
77452, 5134, 349, 28480, 76898
27842, 4955, 340, 28112, 65000, 4956, 339, 28113, 65001, 5133, 28494, 76899, 77452, 5135, 28495, 76902, 
77453, 5136, 348, 28482, 76901
27843, 4956, 339, 28113, 65001, 4957, 338, 28114, 65002, 5135, 28495, 76902, 77453, 5137, 28496, 76905, 
77454, 5138, 347, 28484, 76904
27844, 4957, 338, 28114, 65002, 4958, 337, 28115, 65003, 5137, 28496, 76905, 77454, 5139, 28497, 76908, 
77455, 5140, 346, 28486, 76907
27845, 4958, 337, 28115, 65003, 4959, 336, 28116, 65004, 5139, 28497, 76908, 77455, 5141, 28498, 76911, 
77456, 5142, 345, 28488, 76910
27846, 4959, 336, 28116, 65004, 4960, 335, 28117, 65005, 5141, 28498, 76911, 77456, 5143, 28499, 76914, 
77457, 5144, 344, 28490, 76913
27847, 4960, 335, 28117, 65005, 290, 7, 3293, 26908, 5143, 28499, 76914, 77457, 312, 3316, 27876, 
27920, 5145, 343, 28491, 76916
27848, 246, 245, 25412, 25413, 4961, 4953, 64998, 65006, 268, 26424, 26381, 26425, 5146, 77450, 76918, 
77458, 5147, 5130, 76892, 76917
27849, 4961, 4953, 64998, 65006, 4962, 4954, 64999, 65007, 5146, 77450, 76918, 77458, 5148, 77451, 76921, 
77459, 5149, 5132, 76895, 76920
27850, 4962, 4954, 64999, 65007, 4963, 4955, 65000, 65008, 5148, 77451, 76921, 77459, 5150, 77452, 76924, 
77460, 5151, 5134, 76898, 76923
27851, 4963, 4955, 65000, 65008, 4964, 4956, 65001, 65009, 5150, 77452, 76924, 77460, 5152, 77453, 76927, 
77461, 5153, 5136, 76901, 76926
27852, 4964, 4956, 65001, 65009, 4965, 4957, 65002, 65010, 5152, 77453, 76927, 77461, 5154, 77454, 76930, 
77462, 5155, 5138, 76904, 76929
27853, 4965, 4957, 65002, 65010, 4966, 4958, 65003, 65011, 5154, 77454, 76930, 77462, 5156, 77455, 76933, 
77463, 5157, 5140, 76907, 76932
27854, 4966, 4958, 65003, 65011, 4967, 4959, 65004, 65012, 5156, 77455, 76933, 77463, 5158, 77456, 76936, 
77464, 5159, 5142, 76910, 76935
27855, 4967, 4959, 65004, 65012, 4968, 4960, 65005, 65013, 5158, 77456, 76936, 77464, 5160, 77457, 76939, 
77465, 5161, 5144, 76913, 76938
27856, 4968, 4960, 65005, 65013, 291, 290, 26908, 26909, 5160, 77457, 76939, 77465, 313, 27920, 27878, 
27921, 5162, 5145, 76916, 76941
27857, 247, 246, 25413, 25414, 4969, 4961, 65006, 65014, 269, 26425, 26383, 26426, 5163, 77458, 76943, 
77466, 5164, 5147, 76917, 76942
27858, 4969, 4961, 65006, 65014, 4970, 4962, 65007, 65015, 5163, 77458, 76943, 77466, 5165, 77459, 76946, 
77467, 5166, 5149, 76920, 76945
27859, 4970, 4962, 65007, 65015, 4971, 4963, 65008, 65016, 5165, 77459, 76946, 77467, 5167, 77460, 76949, 
77468, 5168, 5151, 76923, 76948
27860, 4971, 4963, 65008, 65016, 4972, 4964, 65009, 65017, 5167, 77460, 76949, 77468, 5169, 77461, 76952, 
77469, 5170, 5153, 76926, 76951
27861, 4972, 4964, 65009, 65017, 4973, 4965, 65010, 65018, 5169, 77461, 76952, 77469, 5171, 77462, 76955, 
77470, 5172, 5155, 76929, 76954
27862, 4973, 4965, 65010, 65018, 4974, 4966, 65011, 65019, 5171, 77462, 76955, 77470, 5173, 77463, 76958, 
77471, 5174, 5157, 76932, 76957
27863, 4974, 4966, 65011, 65019, 4975, 4967, 65012, 65020, 5173, 77463, 76958, 77471, 5175, 77464, 76961, 
77472, 5176, 5159, 76935, 76960
27864, 4975, 4967, 65012, 65020, 4976, 4968, 65013, 65021, 5175, 77464, 76961, 77472, 5177, 77465, 76964, 
77473, 5178, 5161, 76938, 76963
27865, 4976, 4968, 65013, 65021, 292, 291, 26909, 26910, 5177, 77465, 76964, 77473, 314, 27921, 27880, 
27922, 5179, 5162, 76941, 76966
27866, 248, 247, 25414, 25415, 4977, 4969, 65014, 65022, 270, 26426, 26385, 26427, 5180, 77466, 76968, 
77474, 5181, 5164, 76942, 76967
27867, 4977, 4969, 65014, 65022, 4978, 4970, 65015, 65023, 5180, 77466, 76968, 77474, 5182, 77467, 76971, 
77475, 5183, 5166, 76945, 76970
27868, 4978, 4970, 65015, 65023, 4979, 4971, 65016, 65024, 5182, 77467, 76971, 77475, 5184, 77468, 76974, 
77476, 5185, 5168, 76948, 76973
27869, 4979, 4971, 65016, 65024, 4980, 4972, 65017, 65025, 5184, 77468, 76974, 77476, 5186, 77469, 76977, 
77477, 5187, 5170, 76951, 76976
27870, 4980, 4972, 65017, 65025, 4981, 4973, 65018, 65026, 5186, 77469, 76977, 77477, 5188, 77470, 76980, 
77478, 5189, 5172, 76954, 76979
27871, 4981, 4973, 65018, 65026, 4982, 4974, 65019, 65027, 5188, 77470, 76980, 77478, 5190, 77471, 76983, 
77479, 5191, 5174, 76957, 76982
27872, 4982, 4974, 65019, 65027, 4983, 4975, 65020, 65028, 5190, 77471, 76983, 77479, 5192, 77472, 76986, 
77480, 5193, 5176, 76960, 76985
27873, 4983, 4975, 65020, 65028, 4984, 4976, 65021, 65029, 5192, 77472, 76986, 77480, 5194, 77473, 76989, 
77481, 5195, 5178, 76963, 76988
27874, 4984, 4976, 65021, 65029, 293, 292, 26910, 26911, 5194, 77473, 76989, 77481, 315, 27922, 27882, 
27923, 5196, 5179, 76966, 76991
27875, 249, 248, 25415, 25416, 4985, 4977, 65022, 65030, 271, 26427, 26387, 26428, 5197, 77474, 76993, 
77482, 5198, 5181, 76967, 76992
27876, 4985, 4977, 65022, 65030, 4986, 4978, 65023, 65031, 5197, 77474, 76993, 77482, 5199, 77475, 76996, 
77483, 5200, 5183, 76970, 76995
27877, 4986, 4978, 65023, 65031, 4987, 4979, 65024, 65032, 5199, 77475, 76996, 77483, 5201, 77476, 76999, 
77484, 5202, 5185, 76973, 76998
27878, 4987, 4979, 65024, 65032, 4988, 4980, 65025, 65033, 5201, 77476, 76999, 77484, 5203, 77477, 77002, 
77485, 5204, 5187, 76976, 77001
27879, 4988, 4980, 65025, 65033, 4989, 4981, 65026, 65034, 5203, 77477, 77002, 77485, 5205, 77478, 77005, 
77486, 5206, 5189, 76979, 77004
27880, 4989, 4981, 65026, 65034, 4990, 4982, 65027, 65035, 5205, 77478, 77005, 77486, 5207, 77479, 77008, 
77487, 5208, 5191, 76982, 77007
27881, 4990, 4982, 65027, 65035, 4991, 4983, 65028, 65036, 5207, 77479, 77008, 77487, 5209, 77480, 77011, 
77488, 5210, 5193, 76985, 77010
27882, 4991, 4983, 65028, 65036, 4992, 4984, 65029, 65037, 5209, 77480, 77011, 77488, 5211, 77481, 77014, 
77489, 5212, 5195, 76988, 77013
27883, 4992, 4984, 65029, 65037, 294, 293, 26911, 26912, 5211, 77481, 77014, 77489, 316, 27923, 27884, 
27924, 5213, 5196, 76991, 77016
27884, 250, 249, 25416, 25417, 4993, 4985, 65030, 65038, 272, 26428, 26389, 26429, 5214, 77482, 77018, 
77490, 5215, 5198, 76992, 77017
27885, 4993, 4985, 65030, 65038, 4994, 4986, 65031, 65039, 5214, 77482, 77018, 77490, 5216, 77483, 77021, 
77491, 5217, 5200, 76995, 77020
27886, 4994, 4986, 65031, 65039, 4995, 4987, 65032, 65040, 5216, 77483, 77021, 77491, 5218, 77484, 77024, 
77492, 5219, 5202, 76998, 77023
27887, 4995, 4987, 65032, 65040, 4996, 4988, 65033, 65041, 5218, 77484, 77024, 77492, 5220, 77485, 77027, 
77493, 5221, 5204, 77001, 77026
27888, 4996, 4988, 65033, 65041, 4997, 4989, 65034, 65042, 5220, 77485, 77027, 77493, 5222, 77486, 77030, 
77494, 5223, 5206, 77004, 77029
27889, 4997, 4989, 65034, 65042, 4998, 4990, 65035, 65043, 5222, 77486, 77030, 77494, 5224, 77487, 77033, 
77495, 5225, 5208, 77007, 77032
27890, 4998, 4990, 65035, 65043, 4999, 4991, 65036, 65044, 5224, 77487, 77033, 77495, 5226, 77488, 77036, 
77496, 5227, 5210, 77010, 77035
27891, 4999, 4991, 65036, 65044, 5000, 4992, 65037, 65045, 5226, 77488, 77036, 77496, 5228, 77489, 77039, 
77497, 5229, 5212, 77013, 77038
27892, 5000, 4992, 65037, 65045, 295, 294, 26912, 26913, 5228, 77489, 77039, 77497, 317, 27924, 27886, 
27925, 5230, 5213, 77016, 77041
27893, 251, 250, 25417, 25418, 5001, 4993, 65038, 65046, 273, 26429, 26391, 26430, 5231, 77490, 77043, 
77498, 5232, 5215, 77017, 77042
27894, 5001, 4993, 65038, 65046, 5002, 4994, 65039, 65047, 5231, 77490, 77043, 77498, 5233, 77491, 77046, 
77499, 5234, 5217, 77020, 77045
27895, 5002, 4994, 65039, 65047, 5003, 4995, 65040, 65048, 5233, 77491, 77046, 77499, 5235, 77492, 77049, 
77500, 5236, 5219, 77023, 77048
27896, 5003, 4995, 65040, 65048, 5004, 4996, 65041, 65049, 5235, 77492, 77049, 77500, 5237, 77493, 77052, 
77501, 5238, 5221, 77026, 77051
27897, 5004, 4996, 65041, 65049, 5005, 4997, 65042, 65050, 5237, 77493, 77052, 77501, 5239, 77494, 77055, 
77502, 5240, 5223, 77029, 77054
27898, 5005, 4997, 65042, 65050, 5006, 4998, 65043, 65051, 5239, 77494, 77055, 77502, 5241, 77495, 77058, 
77503, 5242, 5225, 77032, 77057
27899, 5006, 4998, 65043, 65051, 5007, 4999, 65044, 65052, 5241, 77495, 77058, 77503, 5243, 77496, 77061, 
77504, 5244, 5227, 77035, 77060
27900, 5007, 4999, 65044, 65052, 5008, 5000, 65045, 65053, 5243, 77496, 77061, 77504, 5245, 77497, 77064, 
77505, 5246, 5229, 77038, 77063
27901, 5008, 5000, 65045, 65053, 296, 295, 26913, 26914, 5245, 77497, 77064, 77505, 318, 27925, 27888, 
27926, 5247, 5230, 77041, 77066
27902, 252, 251, 25418, 25419, 5009, 5001, 65046, 65054, 274, 26430, 26393, 26431, 5248, 77498, 77068, 
77506, 5249, 5232, 77042, 77067
27903, 5009, 5001, 65046, 65054, 5010, 5002, 65047, 65055, 5248, 77498, 77068, 77506, 5250, 77499, 77071, 
77507, 5251, 5234, 77045, 77070
27904, 5010, 5002, 65047, 65055, 5011, 5003, 65048, 65056, 5250, 77499, 77071, 77507, 5252, 77500, 77074, 
77508, 5253, 5236, 77048, 77073
27905, 5011, 5003, 65048, 65056, 5012, 5004, 65049, 65057, 5252, 77500, 77074, 77508, 5254, 77501, 77077, 
77509, 5255, 5238, 77051, 77076
27906, 5012, 5004, 65049, 65057, 5013, 5005, 65050, 65058, 5254, 77501, 77077, 77509, 5256, 77502, 77080, 
77510, 5257, 5240, 77054, 77079
27907, 5013, 5005, 65050, 65058, 5014, 5006, 65051, 65059, 5256, 77502, 77080, 77510, 5258, 77503, 77083, 
77511, 5259, 5242, 77057, 77082
27908, 5014, 5006, 65051, 65059, 5015, 5007, 65052, 65060, 5258, 77503, 77083, 77511, 5260, 77504, 77086, 
77512, 5261, 5244, 77060, 77085
27909, 5015, 5007, 65052, 65060, 5016, 5008, 65053, 65061, 5260, 77504, 77086, 77512, 5262, 77505, 77089, 
77513, 5263, 5246, 77063, 77088
27910, 5016, 5008, 65053, 65061, 297, 296, 26914, 26915, 5262, 77505, 77089, 77513, 319, 27926, 27890, 
27927, 5264, 5247, 77066, 77091
27911, 253, 252, 25419, 25420, 5017, 5009, 65054, 65062, 275, 26431, 26395, 26432, 5265, 77506, 77093, 
77514, 5266, 5249, 77067, 77092
27912, 5017, 5009, 65054, 65062, 5018, 5010, 65055, 65063, 5265, 77506, 77093, 77514, 5267, 77507, 77096, 
77515, 5268, 5251, 77070, 77095
27913, 5018, 5010, 65055, 65063, 5019, 5011, 65056, 65064, 5267, 77507, 77096, 77515, 5269, 77508, 77099, 
77516, 5270, 5253, 77073, 77098
27914, 5019, 5011, 65056, 65064, 5020, 5012, 65057, 65065, 5269, 77508, 77099, 77516, 5271, 77509, 77102, 
77517, 5272, 5255, 77076, 77101
27915, 5020, 5012, 65057, 65065, 5021, 5013, 65058, 65066, 5271, 77509, 77102, 77517, 5273, 77510, 77105, 
77518, 5274, 5257, 77079, 77104
27916, 5021, 5013, 65058, 65066, 5022, 5014, 65059, 65067, 5273, 77510, 77105, 77518, 5275, 77511, 77108, 
77519, 5276, 5259, 77082, 77107
27917, 5022, 5014, 65059, 65067, 5023, 5015, 65060, 65068, 5275, 77511, 77108, 77519, 5277, 77512, 77111, 
77520, 5278, 5261, 77085, 77110
27918, 5023, 5015, 65060, 65068, 5024, 5016, 65061, 65069, 5277, 77512, 77111, 77520, 5279, 77513, 77114, 
77521, 5280, 5263, 77088, 77113
27919, 5024, 5016, 65061, 65069, 298, 297, 26915, 26916, 5279, 77513, 77114, 77521, 320, 27927, 27892, 
27928, 5281, 5264, 77091, 77116
27920, 254, 253, 25420, 25421, 5025, 5017, 65062, 65070, 276, 26432, 26397, 26433, 5282, 77514, 77118, 
77522, 5283, 5266, 77092, 77117
27921, 5025, 5017, 65062, 65070, 5026, 5018, 65063, 65071, 5282, 77514, 77118, 77522, 5284, 77515, 77121, 
77523, 5285, 5268, 77095, 77120
27922, 5026, 5018, 65063, 65071, 5027, 5019, 65064, 65072, 5284, 77515, 77121, 77523, 5286, 77516, 77124, 
77524, 5287, 5270, 77098, 77123
27923, 5027, 5019, 65064, 65072, 5028, 5020, 65065, 65073, 5286, 77516, 77124, 77524, 5288, 77517, 77127, 
77525, 5289, 5272, 77101, 77126
27924, 5028, 5020, 65065, 65073, 5029, 5021, 65066, 65074, 5288, 77517, 77127, 77525, 5290, 77518, 77130, 
77526, 5291, 5274, 77104, 77129
27925, 5029, 5021, 65066, 65074, 5030, 5022, 65067, 65075, 5290, 77518, 77130, 77526, 5292, 77519, 77133, 
77527, 5293, 5276, 77107, 77132
27926, 5030, 5022, 65067, 65075, 5031, 5023, 65068, 65076, 5292, 77519, 77133, 77527, 5294, 77520, 77136, 
77528, 5295, 5278, 77110, 77135
27927, 5031, 5023, 65068, 65076, 5032, 5024, 65069, 65077, 5294, 77520, 77136, 77528, 5296, 77521, 77139, 
77529, 5297, 5280, 77113, 77138
27928, 5032, 5024, 65069, 65077, 299, 298, 26916, 26917, 5296, 77521, 77139, 77529, 321, 27928, 27894, 
27929, 5298, 5281, 77116, 77141
27929, 255, 254, 25421, 25422, 5033, 5025, 65070, 65078, 277, 26433, 26399, 26434, 5299, 77522, 77143, 
77530, 5300, 5283, 77117, 77142
27930, 5033, 5025, 65070, 65078, 5034, 5026, 65071, 65079, 5299, 77522, 77143, 77530, 5301, 77523, 77146, 
77531, 5302, 5285, 77120, 77145
27931, 5034, 5026, 65071, 65079, 5035, 5027, 65072, 65080, 5301, 77523, 77146, 77531, 5303, 77524, 77149, 
77532, 5304, 5287, 77123, 77148
27932, 5035, 5027, 65072, 65080, 5036, 5028, 65073, 65081, 5303, 77524, 77149, 77532, 5305, 77525, 77152, 
77533, 5306, 5289, 77126, 77151
27933, 5036, 5028, 65073, 65081, 5037, 5029, 65074, 65082, 5305, 77525, 77152, 77533, 5307, 77526, 77155, 
77534, 5308, 5291, 77129, 77154
27934, 5037, 5029, 65074, 65082, 5038, 5030, 65075, 65083, 5307, 77526, 77155, 77534, 5309, 77527, 77158, 
77535, 5310, 5293, 77132, 77157
27935, 5038, 5030, 65075, 65083, 5039, 5031, 65076, 65084, 5309, 77527, 77158, 77535, 5311, 77528, 77161, 
77536, 5312, 5295, 77135, 77160
27936, 5039, 5031, 65076, 65084, 5040, 5032, 65077, 65085, 5311, 77528, 77161, 77536, 5313, 77529, 77164, 
77537, 5314, 5297, 77138, 77163
27937, 5040, 5032, 65077, 65085, 300, 299, 26917, 26918, 5313, 77529, 77164, 77537, 322, 27929, 27896, 
27930, 5315, 5298, 77141, 77166
27938, 256, 255, 25422, 25423, 5041, 5033, 65078, 65086, 278, 26434, 26401, 26435, 5316, 77530, 77168, 
77538, 5317, 5300, 77142, 77167
27939, 5041, 5033, 65078, 65086, 5042, 5034, 65079, 65087, 5316, 77530, 77168, 77538, 5318, 77531, 77171, 
77539, 5319, 5302, 77145, 77170
27940, 5042, 5034, 65079, 65087, 5043, 5035, 65080, 65088, 5318, 77531, 77171, 77539, 5320, 77532, 77174, 
77540, 5321, 5304, 77148, 77173
27941, 5043, 5035, 65080, 65088, 5044, 5036, 65081, 65089, 5320, 77532, 77174, 77540, 5322, 77533, 77177, 
77541, 5323, 5306, 77151, 77176
27942, 5044, 5036, 65081, 65089, 5045, 5037, 65082, 65090, 5322, 77533, 77177, 77541, 5324, 77534, 77180, 
77542, 5325, 5308, 77154, 77179
27943, 5045, 5037, 65082, 65090, 5046, 5038, 65083, 65091, 5324, 77534, 77180, 77542, 5326, 77535, 77183, 
77543, 5327, 5310, 77157, 77182
27944, 5046, 5038, 65083, 65091, 5047, 5039, 65084, 65092, 5326, 77535, 77183, 77543, 5328, 77536, 77186, 
77544, 5329, 5312, 77160, 77185
27945, 5047, 5039, 65084, 65092, 5048, 5040, 65085, 65093, 5328, 77536, 77186, 77544, 5330, 77537, 77189, 
77545, 5331, 5314, 77163, 77188
27946, 5048, 5040, 65085, 65093, 301, 300, 26918, 26919, 5330, 77537, 77189, 77545, 323, 27930, 27898, 
27931, 5332, 5315, 77166, 77191
27947, 257, 256, 25423, 25424, 5049, 5041, 65086, 65094, 279, 26435, 26403, 26436, 5333, 77538, 77193, 
77546, 5334, 5317, 77167, 77192
27948, 5049, 5041, 65086, 65094, 5050, 5042, 65087, 65095, 5333, 77538, 77193, 77546, 5335, 77539, 77196, 
77547, 5336, 5319, 77170, 77195
27949, 5050, 5042, 65087, 65095, 5051, 5043, 65088, 65096, 5335, 77539, 77196, 77547, 5337, 77540, 77199, 
77548, 5338, 5321, 77173, 77198
27950, 5051, 5043, 65088, 65096, 5052, 5044, 65089, 65097, 5337, 77540, 77199, 77548, 5339, 77541, 77202, 
77549, 5340, 5323, 77176, 77201
27951, 5052, 5044, 65089, 65097, 5053, 5045, 65090, 65098, 5339, 77541, 77202, 77549, 5341, 77542, 77205, 
77550, 5342, 5325, 77179, 77204
27952, 5053, 5045, 65090, 65098, 5054, 5046, 65091, 65099, 5341, 77542, 77205, 77550, 5343, 77543, 77208, 
77551, 5344, 5327, 77182, 77207
27953, 5054, 5046, 65091, 65099, 5055, 5047, 65092, 65100, 5343, 77543, 77208, 77551, 5345, 77544, 77211, 
77552, 5346, 5329, 77185, 77210
27954, 5055, 5047, 65092, 65100, 5056, 5048, 65093, 65101, 5345, 77544, 77211, 77552, 5347, 77545, 77214, 
77553, 5348, 5331, 77188, 77213
27955, 5056, 5048, 65093, 65101, 302, 301, 26919, 26920, 5347, 77545, 77214, 77553, 324, 27931, 27900, 
27932, 5349, 5332, 77191, 77216
27956, 258, 257, 25424, 25425, 5057, 5049, 65094, 65102, 280, 26436, 26405, 26437, 5350, 77546, 77218, 
77554, 5351, 5334, 77192, 77217
27957, 5057, 5049, 65094, 65102, 5058, 5050, 65095, 65103, 5350, 77546, 77218, 77554, 5352, 77547, 77221, 
77555, 5353, 5336, 77195, 77220
27958, 5058, 5050, 65095, 65103, 5059, 5051, 65096, 65104, 5352, 77547, 77221, 77555, 5354, 77548, 77224, 
77556, 5355, 5338, 77198, 77223
27959, 5059, 5051, 65096, 65104, 5060, 5052, 65097, 65105, 5354, 77548, 77224, 77556, 5356, 77549, 77227, 
77557, 5357, 5340, 77201, 77226
27960, 5060, 5052, 65097, 65105, 5061, 5053, 65098, 65106, 5356, 77549, 77227, 77557, 5358, 77550, 77230, 
77558, 5359, 5342, 77204, 77229
27961, 5061, 5053, 65098, 65106, 5062, 5054, 65099, 65107, 5358, 77550, 77230, 77558, 5360, 77551, 77233, 
77559, 5361, 5344, 77207, 77232
27962, 5062, 5054, 65099, 65107, 5063, 5055, 65100, 65108, 5360, 77551, 77233, 77559, 5362, 77552, 77236, 
77560, 5363, 5346, 77210, 77235
27963, 5063, 5055, 65100, 65108, 5064, 5056, 65101, 65109, 5362, 77552, 77236, 77560, 5364, 77553, 77239, 
77561, 5365, 5348, 77213, 77238
27964, 5064, 5056, 65101, 65109, 303, 302, 26920, 26921, 5364, 77553, 77239, 77561, 325, 27932, 27902, 
27933, 5366, 5349, 77216, 77241
27965, 259, 258, 25425, 25426, 5065, 5057, 65102, 65110, 281, 26437, 26407, 26438, 5367, 77554, 77243, 
77562, 5368, 5351, 77217, 77242
27966, 5065, 5057, 65102, 65110, 5066, 5058, 65103, 65111, 5367, 77554, 77243, 77562, 5369, 77555, 77246, 
77563, 5370, 5353, 77220, 77245
27967, 5066, 5058, 65103, 65111, 5067, 5059, 65104, 65112, 5369, 77555, 77246, 77563, 5371, 77556, 77249, 
77564, 5372, 5355, 77223, 77248
27968, 5067, 5059, 65104, 65112, 5068, 5060, 65105, 65113, 5371, 77556, 77249, 77564, 5373, 77557, 77252, 
77565, 5374, 5357, 77226, 77251
27969, 5068, 5060, 65105, 65113, 5069, 5061, 65106, 65114, 5373, 77557, 77252, 77565, 5375, 77558, 77255, 
77566, 5376, 5359, 77229, 77254
27970, 5069, 5061, 65106, 65114, 5070, 5062, 65107, 65115, 5375, 77558, 77255, 77566, 5377, 77559, 77258, 
77567, 5378, 5361, 77232, 77257
27971, 5070, 5062, 65107, 65115, 5071, 5063, 65108, 65116, 5377, 77559, 77258, 77567, 5379, 77560, 77261, 
77568, 5380, 5363, 77235, 77260
27972, 5071, 5063, 65108, 65116, 5072, 5064, 65109, 65117, 5379, 77560, 77261, 77568, 5381, 77561, 77264, 
77569, 5382, 5365, 77238, 77263
27973, 5072, 5064, 65109, 65117, 304, 303, 26921, 26922, 5381, 77561, 77264, 77569, 326, 27933, 27904, 
27934, 5383, 5366, 77241, 77266
27974, 260, 259, 25426, 25427, 5073, 5065, 65110, 65118, 282, 26438, 26409, 26439, 5384, 77562, 77268, 
77570, 5385, 5368, 77242, 77267
27975, 5073, 5065, 65110, 65118, 5074, 5066, 65111, 65119, 5384, 77562, 77268, 77570, 5386, 77563, 77271, 
77571, 5387, 5370, 77245, 77270
27976, 5074, 5066, 65111, 65119, 5075, 5067, 65112, 65120, 5386, 77563, 77271, 77571, 5388, 77564, 77274, 
77572, 5389, 5372, 77248, 77273
27977, 5075, 5067, 65112, 65120, 5076, 5068, 65113, 65121, 5388, 77564, 77274, 77572, 5390, 77565, 77277, 
77573, 5391, 5374, 77251, 77276
27978, 5076, 5068, 65113, 65121, 5077, 5069, 65114, 65122, 5390, 77565, 77277, 77573, 5392, 77566, 77280, 
77574, 5393, 5376, 77254, 77279
27979, 5077, 5069, 65114, 65122, 5078, 5070, 65115, 65123, 5392, 77566, 77280, 77574, 5394, 77567, 77283, 
77575, 5395, 5378, 77257, 77282
27980, 5078, 5070, 65115, 65123, 5079, 5071, 65116, 65124, 5394, 77567, 77283, 77575, 5396, 77568, 77286, 
77576, 5397, 5380, 77260, 77285
27981, 5079, 5071, 65116, 65124, 5080, 5072, 65117, 65125, 5396, 77568, 77286, 77576, 5398, 77569, 77289, 
77577, 5399, 5382, 77263, 77288
27982, 5080, 5072, 65117, 65125, 305, 304, 26922, 26923, 5398, 77569, 77289, 77577, 327, 27934, 27906, 
27935, 5400, 5383, 77266, 77291
27983, 261, 260, 25427, 25428, 5081, 5073, 65118, 65126, 283, 26439, 26411, 26440, 5401, 77570, 77293, 
77578, 5402, 5385, 77267, 77292
27984, 5081, 5073, 65118, 65126, 5082, 5074, 65119, 65127, 5401, 77570, 77293, 77578, 5403, 77571, 77296, 
77579, 5404, 5387, 77270, 77295
27985, 5082, 5074, 65119, 65127, 5083, 5075, 65120, 65128, 5403, 77571, 77296, 77579, 5405, 77572, 77299, 
77580, 5406, 5389, 77273, 77298
27986, 5083, 5075, 65120, 65128, 5084, 5076, 65121, 65129, 5405, 77572, 77299, 77580, 5407, 77573, 77302, 
77581, 5408, 5391, 77276, 77301
27987, 5084, 5076, 65121, 65129, 5085, 5077, 65122, 65130, 5407, 77573, 77302, 77581, 5409, 77574, 77305, 
77582, 5410, 5393, 77279, 77304
27988, 5085, 5077, 65122, 65130, 5086, 5078, 65123, 65131, 5409, 77574, 77305, 77582, 5411, 77575, 77308, 
77583, 5412, 5395, 77282, 77307
27989, 5086, 5078, 65123, 65131, 5087, 5079, 65124, 65132, 5411, 77575, 77308, 77583, 5413, 77576, 77311, 
77584, 5414, 5397, 77285, 77310
27990, 5087, 5079, 65124, 65132, 5088, 5080, 65125, 65133, 5413, 77576, 77311, 77584, 5415, 77577, 77314, 
77585, 5416, 5399, 77288, 77313
27991, 5088, 5080, 65125, 65133, 306, 305, 26923, 26924, 5415, 77577, 77314, 77585, 328, 27935, 27908, 
27936, 5417, 5400, 77291, 77316
27992, 262, 261, 25428, 25429, 5089, 5081, 65126, 65134, 284, 26440, 26413, 26441, 5418, 77578, 77318, 
77586, 5419, 5402, 77292, 77317
27993, 5089, 5081, 65126, 65134, 5090, 5082, 65127, 65135, 5418, 77578, 77318, 77586, 5420, 77579, 77321, 
77587, 5421, 5404, 77295, 77320
27994, 5090, 5082, 65127, 65135, 5091, 5083, 65128, 65136, 5420, 77579, 77321, 77587, 5422, 77580, 77324, 
77588, 5423, 5406, 77298, 77323
27995, 5091, 5083, 65128, 65136, 5092, 5084, 65129, 65137, 5422, 77580, 77324, 77588, 5424, 77581, 77327, 
77589, 5425, 5408, 77301, 77326
27996, 5092, 5084, 65129, 65137, 5093, 5085, 65130, 65138, 5424, 77581, 77327, 77589, 5426, 77582, 77330, 
77590, 5427, 5410, 77304, 77329
27997, 5093, 5085, 65130, 65138, 5094, 5086, 65131, 65139, 5426, 77582, 77330, 77590, 5428, 77583, 77333, 
77591, 5429, 5412, 77307, 77332
27998, 5094, 5086, 65131, 65139, 5095, 5087, 65132, 65140, 5428, 77583, 77333, 77591, 5430, 77584, 77336, 
77592, 5431, 5414, 77310, 77335
27999, 5095, 5087, 65132, 65140, 5096, 5088, 65133, 65141, 5430, 77584, 77336, 77592, 5432, 77585, 77339, 
77593, 5433, 5416, 77313, 77338
28000, 5096, 5088, 65133, 65141, 307, 306, 26924, 26925, 5432, 77585, 77339, 77593, 329, 27936, 27910, 
27937, 5434, 5417, 77316, 77341
28001, 263, 262, 25429, 25430, 5097, 5089, 65134, 65142, 285, 26441, 26415, 26442, 5435, 77586, 77343, 
77594, 5436, 5419, 77317, 77342
28002, 5097, 5089, 65134, 65142, 5098, 5090, 65135, 65143, 5435, 77586, 77343, 77594, 5437, 77587, 77346, 
77595, 5438, 5421, 77320, 77345
28003, 5098, 5090, 65135, 65143, 5099, 5091, 65136, 65144, 5437, 77587, 77346, 77595, 5439, 77588, 77349, 
77596, 5440, 5423, 77323, 77348
28004, 5099, 5091, 65136, 65144, 5100, 5092, 65137, 65145, 5439, 77588, 77349, 77596, 5441, 77589, 77352, 
77597, 5442, 5425, 77326, 77351
28005, 5100, 5092, 65137, 65145, 5101, 5093, 65138, 65146, 5441, 77589, 77352, 77597, 5443, 77590, 77355, 
77598, 5444, 5427, 77329, 77354
28006, 5101, 5093, 65138, 65146, 5102, 5094, 65139, 65147, 5443, 77590, 77355, 77598, 5445, 77591, 77358, 
77599, 5446, 5429, 77332, 77357
28007, 5102, 5094, 65139, 65147, 5103, 5095, 65140, 65148, 5445, 77591, 77358, 77599, 5447, 77592, 77361, 
77600, 5448, 5431, 77335, 77360
28008, 5103, 5095, 65140, 65148, 5104, 5096, 65141, 65149, 5447, 77592, 77361, 77600, 5449, 77593, 77364, 
77601, 5450, 5433, 77338, 77363
28009, 5104, 5096, 65141, 65149, 308, 307, 26925, 26926, 5449, 77593, 77364, 77601, 330, 27937, 27912, 
27938, 5451, 5434, 77341, 77366
28010, 264, 263, 25430, 25431, 5105, 5097, 65142, 65150, 286, 26442, 26417, 26443, 5452, 77594, 77368, 
77602, 5453, 5436, 77342, 77367
28011, 5105, 5097, 65142, 65150, 5106, 5098, 65143, 65151, 5452, 77594, 77368, 77602, 5454, 77595, 77371, 
77603, 5455, 5438, 77345, 77370
28012, 5106, 5098, 65143, 65151, 5107, 5099, 65144, 65152, 5454, 77595, 77371, 77603, 5456, 77596, 77374, 
77604, 5457, 5440, 77348, 77373
28013, 5107, 5099, 65144, 65152, 5108, 5100, 65145, 65153, 5456, 77596, 77374, 77604, 5458, 77597, 77377, 
77605, 5459, 5442, 77351, 77376
28014, 5108, 5100, 65145, 65153, 5109, 5101, 65146, 65154, 5458, 77597, 77377, 77605, 5460, 77598, 77380, 
77606, 5461, 5444, 77354, 77379
28015, 5109, 5101, 65146, 65154, 5110, 5102, 65147, 65155, 5460, 77598, 77380, 77606, 5462, 77599, 77383, 
77607, 5463, 5446, 77357, 77382
28016, 5110, 5102, 65147, 65155, 5111, 5103, 65148, 65156, 5462, 77599, 77383, 77607, 5464, 77600, 77386, 
77608, 5465, 5448, 77360, 77385
28017, 5111, 5103, 65148, 65156, 5112, 5104, 65149, 65157, 5464, 77600, 77386, 77608, 5466, 77601, 77389, 
77609, 5467, 5450, 77363, 77388
28018, 5112, 5104, 65149, 65157, 309, 308, 26926, 26927, 5466, 77601, 77389, 77609, 331, 27938, 27914, 
27939, 5468, 5451, 77366, 77391
28019, 265, 264, 25431, 25432, 5113, 5105, 65150, 65158, 287, 26443, 26419, 26444, 5469, 77602, 77393, 
77610, 5470, 5453, 77367, 77392
28020, 5113, 5105, 65150, 65158, 5114, 5106, 65151, 65159, 5469, 77602, 77393, 77610, 5471, 77603, 77396, 
77611, 5472, 5455, 77370, 77395
28021, 5114, 5106, 65151, 65159, 5115, 5107, 65152, 65160, 5471, 77603, 77396, 77611, 5473, 77604, 77399, 
77612, 5474, 5457, 77373, 77398
28022, 5115, 5107, 65152, 65160, 5116, 5108, 65153, 65161, 5473, 77604, 77399, 77612, 5475, 77605, 77402, 
77613, 5476, 5459, 77376, 77401
28023, 5116, 5108, 65153, 65161, 5117, 5109, 65154, 65162, 5475, 77605, 77402, 77613, 5477, 77606, 77405, 
77614, 5478, 5461, 77379, 77404
28024, 5117, 5109, 65154, 65162, 5118, 5110, 65155, 65163, 5477, 77606, 77405, 77614, 5479, 77607, 77408, 
77615, 5480, 5463, 77382, 77407
28025, 5118, 5110, 65155, 65163, 5119, 5111, 65156, 65164, 5479, 77607, 77408, 77615, 5481, 77608, 77411, 
77616, 5482, 5465, 77385, 77410
28026, 5119, 5111, 65156, 65164, 5120, 5112, 65157, 65165, 5481, 77608, 77411, 77616, 5483, 77609, 77414, 
77617, 5484, 5467, 77388, 77413
28027, 5120, 5112, 65157, 65165, 310, 309, 26927, 26928, 5483, 77609, 77414, 77617, 332, 27939, 27916, 
27940, 5485, 5468, 77391, 77416
28028, 266, 265, 25432, 25433, 5121, 5113, 65158, 65166, 288, 26444, 26421, 26445, 5486, 77610, 77418, 
77618, 5487, 5470, 77392, 77417
28029, 5121, 5113, 65158, 65166, 5122, 5114, 65159, 65167, 5486, 77610, 77418, 77618, 5488, 77611, 77421, 
77619, 5489, 5472, 77395, 77420
28030, 5122, 5114, 65159, 65167, 5123, 5115, 65160, 65168, 5488, 77611, 77421, 77619, 5490, 77612, 77424, 
77620, 5491, 5474, 77398, 77423
28031, 5123, 5115, 65160, 65168, 5124, 5116, 65161, 65169, 5490, 77612, 77424, 77620, 5492, 77613, 77427, 
77621, 5493, 5476, 77401, 77426
28032, 5124, 5116, 65161, 65169, 5125, 5117, 65162, 65170, 5492, 77613, 77427, 77621, 5494, 77614, 77430, 
77622, 5495, 5478, 77404, 77429
28033, 5125, 5117, 65162, 65170, 5126, 5118, 65163, 65171, 5494, 77614, 77430, 77622, 5496, 77615, 77433, 
77623, 5497, 5480, 77407, 77432
28034, 5126, 5118, 65163, 65171, 5127, 5119, 65164, 65172, 5496, 77615, 77433, 77623, 5498, 77616, 77436, 
77624, 5499, 5482, 77410, 77435
28035, 5127, 5119, 65164, 65172, 5128, 5120, 65165, 65173, 5498, 77616, 77436, 77624, 5500, 77617, 77439, 
77625, 5501, 5484, 77413, 77438
28036, 5128, 5120, 65165, 65173, 311, 310, 26928, 26929, 5500, 77617, 77439, 77625, 333, 27940, 27918, 
27941, 5502, 5485, 77416, 77441
28037, 6, 266, 25433, 3203, 359, 5121, 65166, 28668, 289, 26445, 26423, 3226, 5503, 77618, 77442, 
29050, 368, 5487, 77417, 29033
28038, 359, 5121, 65166, 28668, 358, 5122, 65167, 28669, 5503, 77618, 77442, 29050, 5504, 77619, 77443, 
29051, 367, 5489, 77420, 29035
28039, 358, 5122, 65167, 28669, 357, 5123, 65168, 28670, 5504, 77619, 77443, 29051, 5505, 77620, 77444, 
29052, 366, 5491, 77423, 29037
28040, 357, 5123, 65168, 28670, 356, 5124, 65169, 28671, 5505, 77620, 77444, 29052, 5506, 77621, 77445, 
29053, 365, 5493, 77426, 29039
28041, 356, 5124, 65169, 28671, 355, 5125, 65170, 28672, 5506, 77621, 77445, 29053, 5507, 77622, 77446, 
29054, 364, 5495, 77429, 29041
28042, 355, 5125, 65170, 28672, 354, 5126, 65171, 28673, 5507, 77622, 77446, 29054, 5508, 77623, 77447, 
29055, 363, 5497, 77432, 29043
28043, 354, 5126, 65171, 28673, 353, 5127, 65172, 28674, 5508, 77623, 77447, 29055, 5509, 77624, 77448, 
29056, 362, 5499, 77435, 29045
28044, 353, 5127, 65172, 28674, 352, 5128, 65173, 28675, 5509, 77624, 77448, 29056, 5510, 77625, 77449, 
29057, 361, 5501, 77438, 29047
28045, 352, 5128, 65173, 28675, 8, 311, 26929, 3338, 5510, 77625, 77449, 29057, 334, 27941, 27919, 
3361, 360, 5502, 77441, 29049
*ELEMENT, type=C3D20, ELSET=Volume10
28046, 29616, 3441, 5, 245, 77626, 29794, 342, 4953, 29638, 3442, 267, 29639, 77803, 29802, 5129, 
77804, 77802, 29803, 351, 5130
28047, 77626, 29794, 342, 4953, 77627, 29795, 341, 4954, 77803, 29802, 5129, 77804, 77806, 29804, 5131, 
77807, 77805, 29805, 350, 5132
28048, 77627, 29795, 341, 4954, 77628, 29796, 340, 4955, 77806, 29804, 5131, 77807, 77809, 29806, 5133, 
77810, 77808, 29807, 349, 5134
28049, 77628, 29796, 340, 4955, 77629, 29797, 339, 4956, 77809, 29806, 5133, 77810, 77812, 29808, 5135, 
77813, 77811, 29809, 348, 5136
28050, 77629, 29797, 339, 4956, 77630, 29798, 338, 4957, 77812, 29808, 5135, 77813, 77815, 29810, 5137, 
77816, 77814, 29811, 347, 5138
28051, 77630, 29798, 338, 4957, 77631, 29799, 337, 4958, 77815, 29810, 5137, 77816, 77818, 29812, 5139, 
77819, 77817, 29813, 346, 5140
28052, 77631, 29799, 337, 4958, 77632, 29800, 336, 4959, 77818, 29812, 5139, 77819, 77821, 29814, 5141, 
77822, 77820, 29815, 345, 5142
28053, 77632, 29800, 336, 4959, 77633, 29801, 335, 4960, 77821, 29814, 5141, 77822, 77824, 29816, 5143, 
77825, 77823, 29817, 344, 5144
28054, 77633, 29801, 335, 4960, 29705, 3492, 7, 290, 77824, 29816, 5143, 77825, 29728, 3493, 312, 
29727, 77826, 29818, 343, 5145
28055, 29617, 29616, 245, 246, 77634, 77626, 4953, 4961, 29640, 29639, 268, 29641, 77828, 77804, 5146, 
77829, 77827, 77802, 5130, 5147
28056, 77634, 77626, 4953, 4961, 77635, 77627, 4954, 4962, 77828, 77804, 5146, 77829, 77831, 77807, 5148, 
77832, 77830, 77805, 5132, 5149
28057, 77635, 77627, 4954, 4962, 77636, 77628, 4955, 4963, 77831, 77807, 5148, 77832, 77834, 77810, 5150, 
77835, 77833, 77808, 5134, 5151
28058, 77636, 77628, 4955, 4963, 77637, 77629, 4956, 4964, 77834, 77810, 5150, 77835, 77837, 77813, 5152, 
77838, 77836, 77811, 5136, 5153
28059, 77637, 77629, 4956, 4964, 77638, 77630, 4957, 4965, 77837, 77813, 5152, 77838, 77840, 77816, 5154, 
77841, 77839, 77814, 5138, 5155
28060, 77638, 77630, 4957, 4965, 77639, 77631, 4958, 4966, 77840, 77816, 5154, 77841, 77843, 77819, 5156, 
77844, 77842, 77817, 5140, 5157
28061, 77639, 77631, 4958, 4966, 77640, 77632, 4959, 4967, 77843, 77819, 5156, 77844, 77846, 77822, 5158, 
77847, 77845, 77820, 5142, 5159
28062, 77640, 77632, 4959, 4967, 77641, 77633, 4960, 4968, 77846, 77822, 5158, 77847, 77849, 77825, 5160, 
77850, 77848, 77823, 5144, 5161
28063, 77641, 77633, 4960, 4968, 29706, 29705, 290, 291, 77849, 77825, 5160, 77850, 29730, 29727, 313, 
29729, 77851, 77826, 5145, 5162
28064, 29618, 29617, 246, 247, 77642, 77634, 4961, 4969, 29642, 29641, 269, 29643, 77853, 77829, 5163, 
77854, 77852, 77827, 5147, 5164
28065, 77642, 77634, 4961, 4969, 77643, 77635, 4962, 4970, 77853, 77829, 5163, 77854, 77856, 77832, 5165, 
77857, 77855, 77830, 5149, 5166
28066, 77643, 77635, 4962, 4970, 77644, 77636, 4963, 4971, 77856, 77832, 5165, 77857, 77859, 77835, 5167, 
77860, 77858, 77833, 5151, 5168
28067, 77644, 77636, 4963, 4971, 77645, 77637, 4964, 4972, 77859, 77835, 5167, 77860, 77862, 77838, 5169, 
77863, 77861, 77836, 5153, 5170
28068, 77645, 77637, 4964, 4972, 77646, 77638, 4965, 4973, 77862, 77838, 5169, 77863, 77865, 77841, 5171, 
77866, 77864, 77839, 5155, 5172
28069, 77646, 77638, 4965, 4973, 77647, 77639, 4966, 4974, 77865, 77841, 5171, 77866, 77868, 77844, 5173, 
77869, 77867, 77842, 5157, 5174
28070, 77647, 77639, 4966, 4974, 77648, 77640, 4967, 4975, 77868, 77844, 5173, 77869, 77871, 77847, 5175, 
77872, 77870, 77845, 5159, 5176
28071, 77648, 77640, 4967, 4975, 77649, 77641, 4968, 4976, 77871, 77847, 5175, 77872, 77874, 77850, 5177, 
77875, 77873, 77848, 5161, 5178
28072, 77649, 77641, 4968, 4976, 29707, 29706, 291, 292, 77874, 77850, 5177, 77875, 29732, 29729, 314, 
29731, 77876, 77851, 5162, 5179
28073, 29619, 29618, 247, 248, 77650, 77642, 4969, 4977, 29644, 29643, 270, 29645, 77878, 77854, 5180, 
77879, 77877, 77852, 5164, 5181
28074, 77650, 77642, 4969, 4977, 77651, 77643, 4970, 4978, 77878, 77854, 5180, 77879, 77881, 77857, 5182, 
77882, 77880, 77855, 5166, 5183
28075, 77651, 77643, 4970, 4978, 77652, 77644, 4971, 4979, 77881, 77857, 5182, 77882, 77884, 77860, 5184, 
77885, 77883, 77858, 5168, 5185
28076, 77652, 77644, 4971, 4979, 77653, 77645, 4972, 4980, 77884, 77860, 5184, 77885, 77887, 77863, 5186, 
77888, 77886, 77861, 5170, 5187
28077, 77653, 77645, 4972, 4980, 77654, 77646, 4973, 4981, 77887, 77863, 5186, 77888, 77890, 77866, 5188, 
77891, 77889, 77864, 5172, 5189
28078, 77654, 77646, 4973, 4981, 77655, 77647, 4974, 4982, 77890, 77866, 5188, 77891, 77893, 77869, 5190, 
77894, 77892, 77867, 5174, 5191
28079, 77655, 77647, 4974, 4982, 77656, 77648, 4975, 4983, 77893, 77869, 5190, 77894, 77896, 77872, 5192, 
77897, 77895, 77870, 5176, 5193
28080, 77656, 77648, 4975, 4983, 77657, 77649, 4976, 4984, 77896, 77872, 5192, 77897, 77899, 77875, 5194, 
77900, 77898, 77873, 5178, 5195
28081, 77657, 77649, 4976, 4984, 29708, 29707, 292, 293, 77899, 77875, 5194, 77900, 29734, 29731, 315, 
29733, 77901, 77876, 5179, 5196
28082, 29620, 29619, 248, 249, 77658, 77650, 4977, 4985, 29646, 29645, 271, 29647, 77903, 77879, 5197, 
77904, 77902, 77877, 5181, 5198
28083, 77658, 77650, 4977, 4985, 77659, 77651, 4978, 4986, 77903, 77879, 5197, 77904, 77906, 77882, 5199, 
77907, 77905, 77880, 5183, 5200
28084, 77659, 77651, 4978, 4986, 77660, 77652, 4979, 4987, 77906, 77882, 5199, 77907, 77909, 77885, 5201, 
77910, 77908, 77883, 5185, 5202
28085, 77660, 77652, 4979, 4987, 77661, 77653, 4980, 4988, 77909, 77885, 5201, 77910, 77912, 77888, 5203, 
77913, 77911, 77886, 5187, 5204
28086, 77661, 77653, 4980, 4988, 77662, 77654, 4981, 4989, 77912, 77888, 5203, 77913, 77915, 77891, 5205, 
77916, 77914, 77889, 5189, 5206
28087, 77662, 77654, 4981, 4989, 77663, 77655, 4982, 4990, 77915, 77891, 5205, 77916, 77918, 77894, 5207, 
77919, 77917, 77892, 5191, 5208
28088, 77663, 77655, 4982, 4990, 77664, 77656, 4983, 4991, 77918, 77894, 5207, 77919, 77921, 77897, 5209, 
77922, 77920, 77895, 5193, 5210
28089, 77664, 77656, 4983, 4991, 77665, 77657, 4984, 4992, 77921, 77897, 5209, 77922, 77924, 77900, 5211, 
77925, 77923, 77898, 5195, 5212
28090, 77665, 77657, 4984, 4992, 29709, 29708, 293, 294, 77924, 77900, 5211, 77925, 29736, 29733, 316, 
29735, 77926, 77901, 5196, 5213
28091, 29621, 29620, 249, 250, 77666, 77658, 4985, 4993, 29648, 29647, 272, 29649, 77928, 77904, 5214, 
77929, 77927, 77902, 5198, 5215
28092, 77666, 77658, 4985, 4993, 77667, 77659, 4986, 4994, 77928, 77904, 5214, 77929, 77931, 77907, 5216, 
77932, 77930, 77905, 5200, 5217
28093, 77667, 77659, 4986, 4994, 77668, 77660, 4987, 4995, 77931, 77907, 5216, 77932, 77934, 77910, 5218, 
77935, 77933, 77908, 5202, 5219
28094, 77668, 77660, 4987, 4995, 77669, 77661, 4988, 4996, 77934, 77910, 5218, 77935, 77937, 77913, 5220, 
77938, 77936, 77911, 5204, 5221
28095, 77669, 77661, 4988, 4996, 77670, 77662, 4989, 4997, 77937, 77913, 5220, 77938, 77940, 77916, 5222, 
77941, 77939, 77914, 5206, 5223
28096, 77670, 77662, 4989, 4997, 77671, 77663, 4990, 4998, 77940, 77916, 5222, 77941, 77943, 77919, 5224, 
77944, 77942, 77917, 5208, 5225
28097, 77671, 77663, 4990, 4998, 77672, 77664, 4991, 4999, 77943, 77919, 5224, 77944, 77946, 77922, 5226, 
77947, 77945, 77920, 5210, 5227
28098, 77672, 77664, 4991, 4999, 77673, 77665, 4992, 5000, 77946, 77922, 5226, 77947, 77949, 77925, 5228, 
77950, 77948, 77923, 5212, 5229
28099, 77673, 77665, 4992, 5000, 29710, 29709, 294, 295, 77949, 77925, 5228, 77950, 29738, 29735, 317, 
29737, 77951, 77926, 5213, 5230
28100, 29622, 29621, 250, 251, 77674, 77666, 4993, 5001, 29650, 29649, 273, 29651, 77953, 77929, 5231, 
77954, 77952, 77927, 5215, 5232
28101, 77674, 77666, 4993, 5001, 77675, 77667, 4994, 5002, 77953, 77929, 5231, 77954, 77956, 77932, 5233, 
77957, 77955, 77930, 5217, 5234
28102, 77675, 77667, 4994, 5002, 77676, 77668, 4995, 5003, 77956, 77932, 5233, 77957, 77959, 77935, 5235, 
77960, 77958, 77933, 5219, 5236
28103, 77676, 77668, 4995, 5003, 77677, 77669, 4996, 5004, 77959, 77935, 5235, 77960, 77962, 77938, 5237, 
77963, 77961, 77936, 5221, 5238
28104, 77677, 77669, 4996, 5004, 77678, 77670, 4997, 5005, 77962, 77938, 5237, 77963, 77965, 77941, 5239, 
77966, 77964, 77939, 5223, 5240
28105, 77678, 77670, 4997, 5005, 77679, 77671, 4998, 5006, 77965, 77941, 5239, 77966, 77968, 77944, 5241, 
77969, 77967, 77942, 5225, 5242
28106, 77679, 77671, 4998, 5006, 77680, 77672, 4999, 5007, 77968, 77944, 5241, 77969, 77971, 77947, 5243, 
77972, 77970, 77945, 5227, 5244
28107, 77680, 77672, 4999, 5007, 77681, 77673, 5000, 5008, 77971, 77947, 5243, 77972, 77974, 77950, 5245, 
77975, 77973, 77948, 5229, 5246
28108, 77681, 77673, 5000, 5008, 29711, 29710, 295, 296, 77974, 77950, 5245, 77975, 29740, 29737, 318, 
29739, 77976, 77951, 5230, 5247
28109, 29623, 29622, 251, 252, 77682, 77674, 5001, 5009, 29652, 29651, 274, 29653, 77978, 77954, 5248, 
77979, 77977, 77952, 5232, 5249
28110, 77682, 77674, 5001, 5009, 77683, 77675, 5002, 5010, 77978, 77954, 5248, 77979, 77981, 77957, 5250, 
77982, 77980, 77955, 5234, 5251
28111, 77683, 77675, 5002, 5010, 77684, 77676, 5003, 5011, 77981, 77957, 5250, 77982, 77984, 77960, 5252, 
77985, 77983, 77958, 5236, 5253
28112, 77684, 77676, 5003, 5011, 77685, 77677, 5004, 5012, 77984, 77960, 5252, 77985, 77987, 77963, 5254, 
77988, 77986, 77961, 5238, 5255
28113, 77685, 77677, 5004, 5012, 77686, 77678, 5005, 5013, 77987, 77963, 5254, 77988, 77990, 77966, 5256, 
77991, 77989, 77964, 5240, 5257
28114, 77686, 77678, 5005, 5013, 77687, 77679, 5006, 5014, 77990, 77966, 5256, 77991, 77993, 77969, 5258, 
77994, 77992, 77967, 5242, 5259
28115, 77687, 77679, 5006, 5014, 77688, 77680, 5007, 5015, 77993, 77969, 5258, 77994, 77996, 77972, 5260, 
77997, 77995, 77970, 5244, 5261
28116, 77688, 77680, 5007, 5015, 77689, 77681, 5008, 5016, 77996, 77972, 5260, 77997, 77999, 77975, 5262, 
78000, 77998, 77973, 5246, 5263
28117, 77689, 77681, 5008, 5016, 29712, 29711, 296, 297, 77999, 77975, 5262, 78000, 29742, 29739, 319, 
29741, 78001, 77976, 5247, 5264
28118, 29624, 29623, 252, 253, 77690, 77682, 5009, 5017, 29654, 29653, 275, 29655, 78003, 77979, 5265, 
78004, 78002, 77977, 5249, 5266
28119, 77690, 77682, 5009, 5017, 77691, 77683, 5010, 5018, 78003, 77979, 5265, 78004, 78006, 77982, 5267, 
78007, 78005, 77980, 5251, 5268
28120, 77691, 77683, 5010, 5018, 77692, 77684, 5011, 5019, 78006, 77982, 5267, 78007, 78009, 77985, 5269, 
78010, 78008, 77983, 5253, 5270
28121, 77692, 77684, 5011, 5019, 77693, 77685, 5012, 5020, 78009, 77985, 5269, 78010, 78012, 77988, 5271, 
78013, 78011, 77986, 5255, 5272
28122, 77693, 77685, 5012, 5020, 77694, 77686, 5013, 5021, 78012, 77988, 5271, 78013, 78015, 77991, 5273, 
78016, 78014, 77989, 5257, 5274
28123, 77694, 77686, 5013, 5021, 77695, 77687, 5014, 5022, 78015, 77991, 5273, 78016, 78018, 77994, 5275, 
78019, 78017, 77992, 5259, 5276
28124, 77695, 77687, 5014, 5022, 77696, 77688, 5015, 5023, 78018, 77994, 5275, 78019, 78021, 77997, 5277, 
78022, 78020, 77995, 5261, 5278
28125, 77696, 77688, 5015, 5023, 77697, 77689, 5016, 5024, 78021, 77997, 5277, 78022, 78024, 78000, 5279, 
78025, 78023, 77998, 5263, 5280
28126, 77697, 77689, 5016, 5024, 29713, 29712, 297, 298, 78024, 78000, 5279, 78025, 29744, 29741, 320, 
29743, 78026, 78001, 5264, 5281
28127, 29625, 29624, 253, 254, 77698, 77690, 5017, 5025, 29656, 29655, 276, 29657, 78028, 78004, 5282, 
78029, 78027, 78002, 5266, 5283
28128, 77698, 77690, 5017, 5025, 77699, 77691, 5018, 5026, 78028, 78004, 5282, 78029, 78031, 78007, 5284, 
78032, 78030, 78005, 5268, 5285
28129, 77699, 77691, 5018, 5026, 77700, 77692, 5019, 5027, 78031, 78007, 5284, 78032, 78034, 78010, 5286, 
78035, 78033, 78008, 5270, 5287
28130, 77700, 77692, 5019, 5027, 77701, 77693, 5020, 5028, 78034, 78010, 5286, 78035, 78037, 78013, 5288, 
78038, 78036, 78011, 5272, 5289
28131, 77701, 77693, 5020, 5028, 77702, 77694, 5021, 5029, 78037, 78013, 5288, 78038, 78040, 78016, 5290, 
78041, 78039, 78014, 5274, 5291
28132, 77702, 77694, 5021, 5029, 77703, 77695, 5022, 5030, 78040, 78016, 5290, 78041, 78043, 78019, 5292, 
78044, 78042, 78017, 5276, 5293
28133, 77703, 77695, 5022, 5030, 77704, 77696, 5023, 5031, 78043, 78019, 5292, 78044, 78046, 78022, 5294, 
78047, 78045, 78020, 5278, 5295
28134, 77704, 77696, 5023, 5031, 77705, 77697, 5024, 5032, 78046, 78022, 5294, 78047, 78049, 78025, 5296, 
78050, 78048, 78023, 5280, 5297
28135, 77705, 77697, 5024, 5032, 29714, 29713, 298, 299, 78049, 78025, 5296, 78050, 29746, 29743, 321, 
29745, 78051, 78026, 5281, 5298
28136, 29626, 29625, 254, 255, 77706, 77698, 5025, 5033, 29658, 29657, 277, 29659, 78053, 78029, 5299, 
78054, 78052, 78027, 5283, 5300
28137, 77706, 77698, 5025, 5033, 77707, 77699, 5026, 5034, 78053, 78029, 5299, 78054, 78056, 78032, 5301, 
78057, 78055, 78030, 5285, 5302
28138, 77707, 77699, 5026, 5034, 77708, 77700, 5027, 5035, 78056, 78032, 5301, 78057, 78059, 78035, 5303, 
78060, 78058, 78033, 5287, 5304
28139, 77708, 77700, 5027, 5035, 77709, 77701, 5028, 5036, 78059, 78035, 5303, 78060, 78062, 78038, 5305, 
78063, 78061, 78036, 5289, 5306
28140, 77709, 77701, 5028, 5036, 77710, 77702, 5029, 5037, 78062, 78038, 5305, 78063, 78065, 78041, 5307, 
78066, 78064, 78039, 5291, 5308
28141, 77710, 77702, 5029, 5037, 77711, 77703, 5030, 5038, 78065, 78041, 5307, 78066, 78068, 78044, 5309, 
78069, 78067, 78042, 5293, 5310
28142, 77711, 77703, 5030, 5038, 77712, 77704, 5031, 5039, 78068, 78044, 5309, 78069, 78071, 78047, 5311, 
78072, 78070, 78045, 5295, 5312
28143, 77712, 77704, 5031, 5039, 77713, 77705, 5032, 5040, 78071, 78047, 5311, 78072, 78074, 78050, 5313, 
78075, 78073, 78048, 5297, 5314
28144, 77713, 77705, 5032, 5040, 29715, 29714, 299, 300, 78074, 78050, 5313, 78075, 29748, 29745, 322, 
29747, 78076, 78051, 5298, 5315
28145, 29627, 29626, 255, 256, 77714, 77706, 5033, 5041, 29660, 29659, 278, 29661, 78078, 78054, 5316, 
78079, 78077, 78052, 5300, 5317
28146, 77714, 77706, 5033, 5041, 77715, 77707, 5034, 5042, 78078, 78054, 5316, 78079, 78081, 78057, 5318, 
78082, 78080, 78055, 5302, 5319
28147, 77715, 77707, 5034, 5042, 77716, 77708, 5035, 5043, 78081, 78057, 5318, 78082, 78084, 78060, 5320, 
78085, 78083, 78058, 5304, 5321
28148, 77716, 77708, 5035, 5043, 77717, 77709, 5036, 5044, 78084, 78060, 5320, 78085, 78087, 78063, 5322, 
78088, 78086, 78061, 5306, 5323
28149, 77717, 77709, 5036, 5044, 77718, 77710, 5037, 5045, 78087, 78063, 5322, 78088, 78090, 78066, 5324, 
78091, 78089, 78064, 5308, 5325
28150, 77718, 77710, 5037, 5045, 77719, 77711, 5038, 5046, 78090, 78066, 5324, 78091, 78093, 78069, 5326, 
78094, 78092, 78067, 5310, 5327
28151, 77719, 77711, 5038, 5046, 77720, 77712, 5039, 5047, 78093, 78069, 5326, 78094, 78096, 78072, 5328, 
78097, 78095, 78070, 5312, 5329
28152, 77720, 77712, 5039, 5047, 77721, 77713, 5040, 5048, 78096, 78072, 5328, 78097, 78099, 78075, 5330, 
78100, 78098, 78073, 5314, 5331
28153, 77721, 77713, 5040, 5048, 29716, 29715, 300, 301, 78099, 78075, 5330, 78100, 29750, 29747, 323, 
29749, 78101, 78076, 5315, 5332
28154, 29628, 29627, 256, 257, 77722, 77714, 5041, 5049, 29662, 29661, 279, 29663, 78103, 78079, 5333, 
78104, 78102, 78077, 5317, 5334
28155, 77722, 77714, 5041, 5049, 77723, 77715, 5042, 5050, 78103, 78079, 5333, 78104, 78106, 78082, 5335, 
78107, 78105, 78080, 5319, 5336
28156, 77723, 77715, 5042, 5050, 77724, 77716, 5043, 5051, 78106, 78082, 5335, 78107, 78109, 78085, 5337, 
78110, 78108, 78083, 5321, 5338
28157, 77724, 77716, 5043, 5051, 77725, 77717, 5044, 5052, 78109, 78085, 5337, 78110, 78112, 78088, 5339, 
78113, 78111, 78086, 5323, 5340
28158, 77725, 77717, 5044, 5052, 77726, 77718, 5045, 5053, 78112, 78088, 5339, 78113, 78115, 78091, 5341, 
78116, 78114, 78089, 5325, 5342
28159, 77726, 77718, 5045, 5053, 77727, 77719, 5046, 5054, 78115, 78091, 5341, 78116, 78118, 78094, 5343, 
78119, 78117, 78092, 5327, 5344
28160, 77727, 77719, 5046, 5054, 77728, 77720, 5047, 5055, 78118, 78094, 5343, 78119, 78121, 78097, 5345, 
78122, 78120, 78095, 5329, 5346
28161, 77728, 77720, 5047, 5055, 77729, 77721, 5048, 5056, 78121, 78097, 5345, 78122, 78124, 78100, 5347, 
78125, 78123, 78098, 5331, 5348
28162, 77729, 77721, 5048, 5056, 29717, 29716, 301, 302, 78124, 78100, 5347, 78125, 29752, 29749, 324, 
29751, 78126, 78101, 5332, 5349
28163, 29629, 29628, 257, 258, 77730, 77722, 5049, 5057, 29664, 29663, 280, 29665, 78128, 78104, 5350, 
78129, 78127, 78102, 5334, 5351
28164, 77730, 77722, 5049, 5057, 77731, 77723, 5050, 5058, 78128, 78104, 5350, 78129, 78131, 78107, 5352, 
78132, 78130, 78105, 5336, 5353
28165, 77731, 77723, 5050, 5058, 77732, 77724, 5051, 5059, 78131, 78107, 5352, 78132, 78134, 78110, 5354, 
78135, 78133, 78108, 5338, 5355
28166, 77732, 77724, 5051, 5059, 77733, 77725, 5052, 5060, 78134, 78110, 5354, 78135, 78137, 78113, 5356, 
78138, 78136, 78111, 5340, 5357
28167, 77733, 77725, 5052, 5060, 77734, 77726, 5053, 5061, 78137, 78113, 5356, 78138, 78140, 78116, 5358, 
78141, 78139, 78114, 5342, 5359
28168, 77734, 77726, 5053, 5061, 77735, 77727, 5054, 5062, 78140, 78116, 5358, 78141, 78143, 78119, 5360, 
78144, 78142, 78117, 5344, 5361
28169, 77735, 77727, 5054, 5062, 77736, 77728, 5055, 5063, 78143, 78119, 5360, 78144, 78146, 78122, 5362, 
78147, 78145, 78120, 5346, 5363
28170, 77736, 77728, 5055, 5063, 77737, 77729, 5056, 5064, 78146, 78122, 5362, 78147, 78149, 78125, 5364, 
78150, 78148, 78123, 5348, 5365
28171, 77737, 77729, 5056, 5064, 29718, 29717, 302, 303, 78149, 78125, 5364, 78150, 29754, 29751, 325, 
29753, 78151, 78126, 5349, 5366
28172, 29630, 29629, 258, 259, 77738, 77730, 5057, 5065, 29666, 29665, 281, 29667, 78153, 78129, 5367, 
78154, 78152, 78127, 5351, 5368
28173, 77738, 77730, 5057, 5065, 77739, 77731, 5058, 5066, 78153, 78129, 5367, 78154, 78156, 78132, 5369, 
78157, 78155, 78130, 5353, 5370
28174, 77739, 77731, 5058, 5066, 77740, 77732, 5059, 5067, 78156, 78132, 5369, 78157, 78159, 78135, 5371, 
78160, 78158, 78133, 5355, 5372
28175, 77740, 77732, 5059, 5067, 77741, 77733, 5060, 5068, 78159, 78135, 5371, 78160, 78162, 78138, 5373, 
78163, 78161, 78136, 5357, 5374
28176, 77741, 77733, 5060, 5068, 77742, 77734, 5061, 5069, 78162, 78138, 5373, 78163, 78165, 78141, 5375, 
78166, 78164, 78139, 5359, 5376
28177, 77742, 77734, 5061, 5069, 77743, 77735, 5062, 5070, 78165, 78141, 5375, 78166, 78168, 78144, 5377, 
78169, 78167, 78142, 5361, 5378
28178, 77743, 77735, 5062, 5070, 77744, 77736, 5063, 5071, 78168, 78144, 5377, 78169, 78171, 78147, 5379, 
78172, 78170, 78145, 5363, 5380
28179, 77744, 77736, 5063, 5071, 77745, 77737, 5064, 5072, 78171, 78147, 5379, 78172, 78174, 78150, 5381, 
78175, 78173, 78148, 5365, 5382
28180, 77745, 77737, 5064, 5072, 29719, 29718, 303, 304, 78174, 78150, 5381, 78175, 29756, 29753, 326, 
29755, 78176, 78151, 5366, 5383
28181, 29631, 29630, 259, 260, 77746, 77738, 5065, 5073, 29668, 29667, 282, 29669, 78178, 78154, 5384, 
78179, 78177, 78152, 5368, 5385
28182, 77746, 77738, 5065, 5073, 77747, 77739, 5066, 5074, 78178, 78154, 5384, 78179, 78181, 78157, 5386, 
78182, 78180, 78155, 5370, 5387
28183, 77747, 77739, 5066, 5074, 77748, 77740, 5067, 5075, 78181, 78157, 5386, 78182, 78184, 78160, 5388, 
78185, 78183, 78158, 5372, 5389
28184, 77748, 77740, 5067, 5075, 77749, 77741, 5068, 5076, 78184, 78160, 5388, 78185, 78187, 78163, 5390, 
78188, 78186, 78161, 5374, 5391
28185, 77749, 77741, 5068, 5076, 77750, 77742, 5069, 5077, 78187, 78163, 5390, 78188, 78190, 78166, 5392, 
78191, 78189, 78164, 5376, 5393
28186, 77750, 77742, 5069, 5077, 77751, 77743, 5070, 5078, 78190, 78166, 5392, 78191, 78193, 78169, 5394, 
78194, 78192, 78167, 5378, 5395
28187, 77751, 77743, 5070, 5078, 77752, 77744, 5071, 5079, 78193, 78169, 5394, 78194, 78196, 78172, 5396, 
78197, 78195, 78170, 5380, 5397
28188, 77752, 77744, 5071, 5079, 77753, 77745, 5072, 5080, 78196, 78172, 5396, 78197, 78199, 78175, 5398, 
78200, 78198, 78173, 5382, 5399
28189, 77753, 77745, 5072, 5080, 29720, 29719, 304, 305, 78199, 78175, 5398, 78200, 29758, 29755, 327, 
29757, 78201, 78176, 5383, 5400
28190, 29632, 29631, 260, 261, 77754, 77746, 5073, 5081, 29670, 29669, 283, 29671, 78203, 78179, 5401, 
78204, 78202, 78177, 5385, 5402
28191, 77754, 77746, 5073, 5081, 77755, 77747, 5074, 5082, 78203, 78179, 5401, 78204, 78206, 78182, 5403, 
78207, 78205, 78180, 5387, 5404
28192, 77755, 77747, 5074, 5082, 77756, 77748, 5075, 5083, 78206, 78182, 5403, 78207, 78209, 78185, 5405, 
78210, 78208, 78183, 5389, 5406
28193, 77756, 77748, 5075, 5083, 77757, 77749, 5076, 5084, 78209, 78185, 5405, 78210, 78212, 78188, 5407, 
78213, 78211, 78186, 5391, 5408
28194, 77757, 77749, 5076, 5084, 77758, 77750, 5077, 5085, 78212, 78188, 5407, 78213, 78215, 78191, 5409, 
78216, 78214, 78189, 5393, 5410
28195, 77758, 77750, 5077, 5085, 77759, 77751, 5078, 5086, 78215, 78191, 5409, 78216, 78218, 78194, 5411, 
78219, 78217, 78192, 5395, 5412
28196, 77759, 77751, 5078, 5086, 77760, 77752, 5079, 5087, 78218, 78194, 5411, 78219, 78221, 78197, 5413, 
78222, 78220, 78195, 5397, 5414
28197, 77760, 77752, 5079, 5087, 77761, 77753, 5080, 5088, 78221, 78197, 5413, 78222, 78224, 78200, 5415, 
78225, 78223, 78198, 5399, 5416
28198, 77761, 77753, 5080, 5088, 29721, 29720, 305, 306, 78224, 78200, 5415, 78225, 29760, 29757, 328, 
29759, 78226, 78201, 5400, 5417
28199, 29633, 29632, 261, 262, 77762, 77754, 5081, 5089, 29672, 29671, 284, 29673, 78228, 78204, 5418, 
78229, 78227, 78202, 5402, 5419
28200, 77762, 77754, 5081, 5089, 77763, 77755, 5082, 5090, 78228, 78204, 5418, 78229, 78231, 78207, 5420, 
78232, 78230, 78205, 5404, 5421
28201, 77763, 77755, 5082, 5090, 77764, 77756, 5083, 5091, 78231, 78207, 5420, 78232, 78234, 78210, 5422, 
78235, 78233, 78208, 5406, 5423
28202, 77764, 77756, 5083, 5091, 77765, 77757, 5084, 5092, 78234, 78210, 5422, 78235, 78237, 78213, 5424, 
78238, 78236, 78211, 5408, 5425
28203, 77765, 77757, 5084, 5092, 77766, 77758, 5085, 5093, 78237, 78213, 5424, 78238, 78240, 78216, 5426, 
78241, 78239, 78214, 5410, 5427
28204, 77766, 77758, 5085, 5093, 77767, 77759, 5086, 5094, 78240, 78216, 5426, 78241, 78243, 78219, 5428, 
78244, 78242, 78217, 5412, 5429
28205, 77767, 77759, 5086, 5094, 77768, 77760, 5087, 5095, 78243, 78219, 5428, 78244, 78246, 78222, 5430, 
78247, 78245, 78220, 5414, 5431
28206, 77768, 77760, 5087, 5095, 77769, 77761, 5088, 5096, 78246, 78222, 5430, 78247, 78249, 78225, 5432, 
78250, 78248, 78223, 5416, 5433
28207, 77769, 77761, 5088, 5096, 29722, 29721, 306, 307, 78249, 78225, 5432, 78250, 29762, 29759, 329, 
29761, 78251, 78226, 5417, 5434
28208, 29634, 29633, 262, 263, 77770, 77762, 5089, 5097, 29674, 29673, 285, 29675, 78253, 78229, 5435, 
78254, 78252, 78227, 5419, 5436
28209, 77770, 77762, 5089, 5097, 77771, 77763, 5090, 5098, 78253, 78229, 5435, 78254, 78256, 78232, 5437, 
78257, 78255, 78230, 5421, 5438
28210, 77771, 77763, 5090, 5098, 77772, 77764, 5091, 5099, 78256, 78232, 5437, 78257, 78259, 78235, 5439, 
78260, 78258, 78233, 5423, 5440
28211, 77772, 77764, 5091, 5099, 77773, 77765, 5092, 5100, 78259, 78235, 5439, 78260, 78262, 78238, 5441, 
78263, 78261, 78236, 5425, 5442
28212, 77773, 77765, 5092, 5100, 77774, 77766, 5093, 5101, 78262, 78238, 5441, 78263, 78265, 78241, 5443, 
78266, 78264, 78239, 5427, 5444
28213, 77774, 77766, 5093, 5101, 77775, 77767, 5094, 5102, 78265, 78241, 5443, 78266, 78268, 78244, 5445, 
78269, 78267, 78242, 5429, 5446
28214, 77775, 77767, 5094, 5102, 77776, 77768, 5095, 5103, 78268, 78244, 5445, 78269, 78271, 78247, 5447, 
78272, 78270, 78245, 5431, 5448
28215, 77776, 77768, 5095, 5103, 77777, 77769, 5096, 5104, 78271, 78247, 5447, 78272, 78274, 78250, 5449, 
78275, 78273, 78248, 5433, 5450
28216, 77777, 77769, 5096, 5104, 29723, 29722, 307, 308, 78274, 78250, 5449, 78275, 29764, 29761, 330, 
29763, 78276, 78251, 5434, 5451
28217, 29635, 29634, 263, 264, 77778, 77770, 5097, 5105, 29676, 29675, 286, 29677, 78278, 78254, 5452, 
78279, 78277, 78252, 5436, 5453
28218, 77778, 77770, 5097, 5105, 77779, 77771, 5098, 5106, 78278, 78254, 5452, 78279, 78281, 78257, 5454, 
78282, 78280, 78255, 5438, 5455
28219, 77779, 77771, 5098, 5106, 77780, 77772, 5099, 5107, 78281, 78257, 5454, 78282, 78284, 78260, 5456, 
78285, 78283, 78258, 5440, 5457
28220, 77780, 77772, 5099, 5107, 77781, 77773, 5100, 5108, 78284, 78260, 5456, 78285, 78287, 78263, 5458, 
78288, 78286, 78261, 5442, 5459
28221, 77781, 77773, 5100, 5108, 77782, 77774, 5101, 5109, 78287, 78263, 5458, 78288, 78290, 78266, 5460, 
78291, 78289, 78264, 5444, 5461
28222, 77782, 77774, 5101, 5109, 77783, 77775, 5102, 5110, 78290, 78266, 5460, 78291, 78293, 78269, 5462, 
78294, 78292, 78267, 5446, 5463
28223, 77783, 77775, 5102, 5110, 77784, 77776, 5103, 5111, 78293, 78269, 5462, 78294, 78296, 78272, 5464, 
78297, 78295, 78270, 5448, 5465
28224, 77784, 77776, 5103, 5111, 77785, 77777, 5104, 5112, 78296, 78272, 5464, 78297, 78299, 78275, 5466, 
78300, 78298, 78273, 5450, 5467
28225, 77785, 77777, 5104, 5112, 29724, 29723, 308, 309, 78299, 78275, 5466, 78300, 29766, 29763, 331, 
29765, 78301, 78276, 5451, 5468
28226, 29636, 29635, 264, 265, 77786, 77778, 5105, 5113, 29678, 29677, 287, 29679, 78303, 78279, 5469, 
78304, 78302, 78277, 5453, 5470
28227, 77786, 77778, 5105, 5113, 77787, 77779, 5106, 5114, 78303, 78279, 5469, 78304, 78306, 78282, 5471, 
78307, 78305, 78280, 5455, 5472
28228, 77787, 77779, 5106, 5114, 77788, 77780, 5107, 5115, 78306, 78282, 5471, 78307, 78309, 78285, 5473, 
78310, 78308, 78283, 5457, 5474
28229, 77788, 77780, 5107, 5115, 77789, 77781, 5108, 5116, 78309, 78285, 5473, 78310, 78312, 78288, 5475, 
78313, 78311, 78286, 5459, 5476
28230, 77789, 77781, 5108, 5116, 77790, 77782, 5109, 5117, 78312, 78288, 5475, 78313, 78315, 78291, 5477, 
78316, 78314, 78289, 5461, 5478
28231, 77790, 77782, 5109, 5117, 77791, 77783, 5110, 5118, 78315, 78291, 5477, 78316, 78318, 78294, 5479, 
78319, 78317, 78292, 5463, 5480
28232, 77791, 77783, 5110, 5118, 77792, 77784, 5111, 5119, 78318, 78294, 5479, 78319, 78321, 78297, 5481, 
78322, 78320, 78295, 5465, 5482
28233, 77792, 77784, 5111, 5119, 77793, 77785, 5112, 5120, 78321, 78297, 5481, 78322, 78324, 78300, 5483, 
78325, 78323, 78298, 5467, 5484
28234, 77793, 77785, 5112, 5120, 29725, 29724, 309, 310, 78324, 78300, 5483, 78325, 29768, 29765, 332, 
29767, 78326, 78301, 5468, 5485
28235, 29637, 29636, 265, 266, 77794, 77786, 5113, 5121, 29680, 29679, 288, 29681, 78328, 78304, 5486, 
78329, 78327, 78302, 5470, 5487
28236, 77794, 77786, 5113, 5121, 77795, 77787, 5114, 5122, 78328, 78304, 5486, 78329, 78331, 78307, 5488, 
78332, 78330, 78305, 5472, 5489
28237, 77795, 77787, 5114, 5122, 77796, 77788, 5115, 5123, 78331, 78307, 5488, 78332, 78334, 78310, 5490, 
78335, 78333, 78308, 5474, 5491
28238, 77796, 77788, 5115, 5123, 77797, 77789, 5116, 5124, 78334, 78310, 5490, 78335, 78337, 78313, 5492, 
78338, 78336, 78311, 5476, 5493
28239, 77797, 77789, 5116, 5124, 77798, 77790, 5117, 5125, 78337, 78313, 5492, 78338, 78340, 78316, 5494, 
78341, 78339, 78314, 5478, 5495
28240, 77798, 77790, 5117, 5125, 77799, 77791, 5118, 5126, 78340, 78316, 5494, 78341, 78343, 78319, 5496, 
78344, 78342, 78317, 5480, 5497
28241, 77799, 77791, 5118, 5126, 77800, 77792, 5119, 5127, 78343, 78319, 5496, 78344, 78346, 78322, 5498, 
78347, 78345, 78320, 5482, 5499
28242, 77800, 77792, 5119, 5127, 77801, 77793, 5120, 5128, 78346, 78322, 5498, 78347, 78349, 78325, 5500, 
78350, 78348, 78323, 5484, 5501
28243, 77801, 77793, 5120, 5128, 29726, 29725, 310, 311, 78349, 78325, 5500, 78350, 29770, 29767, 333, 
29769, 78351, 78326, 5485, 5502
28244, 3444, 29637, 266, 6, 29827, 77794, 5121, 359, 29682, 29681, 289, 3445, 78352, 78329, 5503, 
29836, 29835, 78327, 5487, 368
28245, 29827, 77794, 5121, 359, 29828, 77795, 5122, 358, 78352, 78329, 5503, 29836, 78353, 78332, 5504, 
29838, 29837, 78330, 5489, 367
28246, 29828, 77795, 5122, 358, 29829, 77796, 5123, 357, 78353, 78332, 5504, 29838, 78354, 78335, 5505, 
29840, 29839, 78333, 5491, 366
28247, 29829, 77796, 5123, 357, 29830, 77797, 5124, 356, 78354, 78335, 5505, 29840, 78355, 78338, 5506, 
29842, 29841, 78336, 5493, 365
28248, 29830, 77797, 5124, 356, 29831, 77798, 5125, 355, 78355, 78338, 5506, 29842, 78356, 78341, 5507, 
29844, 29843, 78339, 5495, 364
28249, 29831, 77798, 5125, 355, 29832, 77799, 5126, 354, 78356, 78341, 5507, 29844, 78357, 78344, 5508, 
29846, 29845, 78342, 5497, 363
28250, 29832, 77799, 5126, 354, 29833, 77800, 5127, 353, 78357, 78344, 5508, 29846, 78358, 78347, 5509, 
29848, 29847, 78345, 5499, 362
28251, 29833, 77800, 5127, 353, 29834, 77801, 5128, 352, 78358, 78347, 5509, 29848, 78359, 78350, 5510, 
29850, 29849, 78348, 5501, 361
28252, 29834, 77801, 5128, 352, 3495, 29726, 311, 8, 78359, 78350, 5510, 29850, 29771, 29769, 334, 
3496, 29851, 78351, 5502, 360
28253, 3447, 97, 3441, 29616, 29860, 3550, 29794, 77626, 3469, 3443, 29638, 29683, 30036, 29819, 77803, 
78360, 30037, 3559, 29803, 77802
28254, 29860, 3550, 29794, 77626, 29861, 3549, 29795, 77627, 30036, 29819, 77803, 78360, 30038, 29820, 77806, 
78361, 30039, 3558, 29805, 77805
28255, 29861, 3549, 29795, 77627, 29862, 3548, 29796, 77628, 30038, 29820, 77806, 78361, 30040, 29821, 77809, 
78362, 30041, 3557, 29807, 77808
28256, 29862, 3548, 29796, 77628, 29863, 3547, 29797, 77629, 30040, 29821, 77809, 78362, 30042, 29822, 77812, 
78363, 30043, 3556, 29809, 77811
28257, 29863, 3547, 29797, 77629, 29864, 3546, 29798, 77630, 30042, 29822, 77812, 78363, 30044, 29823, 77815, 
78364, 30045, 3555, 29811, 77814
28258, 29864, 3546, 29798, 77630, 29865, 3545, 29799, 77631, 30044, 29823, 77815, 78364, 30046, 29824, 77818, 
78365, 30047, 3554, 29813, 77817
28259, 29865, 3545, 29799, 77631, 29866, 3544, 29800, 77632, 30046, 29824, 77818, 78365, 30048, 29825, 77821, 
78366, 30049, 3553, 29815, 77820
28260, 29866, 3544, 29800, 77632, 29867, 3543, 29801, 77633, 30048, 29825, 77821, 78366, 30050, 29826, 77824, 
78367, 30051, 3552, 29817, 77823
28261, 29867, 3543, 29801, 77633, 3498, 99, 3492, 29705, 30050, 29826, 77824, 78367, 3520, 3494, 29728, 
29772, 30052, 3551, 29818, 77826
28262, 3448, 3447, 29616, 29617, 29868, 29860, 77626, 77634, 3470, 29683, 29640, 29684, 30053, 78360, 77828, 
78368, 30054, 30037, 77802, 77827
28263, 29868, 29860, 77626, 77634, 29869, 29861, 77627, 77635, 30053, 78360, 77828, 78368, 30055, 78361, 77831, 
78369, 30056, 30039, 77805, 77830
28264, 29869, 29861, 77627, 77635, 29870, 29862, 77628, 77636, 30055, 78361, 77831, 78369, 30057, 78362, 77834, 
78370, 30058, 30041, 77808, 77833
28265, 29870, 29862, 77628, 77636, 29871, 29863, 77629, 77637, 30057, 78362, 77834, 78370, 30059, 78363, 77837, 
78371, 30060, 30043, 77811, 77836
28266, 29871, 29863, 77629, 77637, 29872, 29864, 77630, 77638, 30059, 78363, 77837, 78371, 30061, 78364, 77840, 
78372, 30062, 30045, 77814, 77839
28267, 29872, 29864, 77630, 77638, 29873, 29865, 77631, 77639, 30061, 78364, 77840, 78372, 30063, 78365, 77843, 
78373, 30064, 30047, 77817, 77842
28268, 29873, 29865, 77631, 77639, 29874, 29866, 77632, 77640, 30063, 78365, 77843, 78373, 30065, 78366, 77846, 
78374, 30066, 30049, 77820, 77845
28269, 29874, 29866, 77632, 77640, 29875, 29867, 77633, 77641, 30065, 78366, 77846, 78374, 30067, 78367, 77849, 
78375, 30068, 30051, 77823, 77848
28270, 29875, 29867, 77633, 77641, 3499, 3498, 29705, 29706, 30067, 78367, 77849, 78375, 3521, 29772, 29730, 
29773, 30069, 30052, 77826, 77851
28271, 3449, 3448, 29617, 29618, 29876, 29868, 77634, 77642, 3471, 29684, 29642, 29685, 30070, 78368, 77853, 
78376, 30071, 30054, 77827, 77852
28272, 29876, 29868, 77634, 77642, 29877, 29869, 77635, 77643, 30070, 78368, 77853, 78376, 30072, 78369, 77856, 
78377, 30073, 30056, 77830, 77855
28273, 29877, 29869, 77635, 77643, 29878, 29870, 77636, 77644, 30072, 78369, 77856, 78377, 30074, 78370, 77859, 
78378, 30075, 30058, 77833, 77858
28274, 29878, 29870, 77636, 77644, 29879, 29871, 77637, 77645, 30074, 78370, 77859, 78378, 30076, 78371, 77862, 
78379, 30077, 30060, 77836, 77861
28275, 29879, 29871, 77637, 77645, 29880, 29872, 77638, 77646, 30076, 78371, 77862, 78379, 30078, 78372, 77865, 
78380, 30079, 30062, 77839, 77864
28276, 29880, 29872, 77638, 77646, 29881, 29873, 77639, 77647, 30078, 78372, 77865, 78380, 30080, 78373, 77868, 
78381, 30081, 30064, 77842, 77867
28277, 29881, 29873, 77639, 77647, 29882, 29874, 77640, 77648, 30080, 78373, 77868, 78381, 30082, 78374, 77871, 
78382, 30083, 30066, 77845, 77870
28278, 29882, 29874, 77640, 77648, 29883, 29875, 77641, 77649, 30082, 78374, 77871, 78382, 30084, 78375, 77874, 
78383, 30085, 30068, 77848, 77873
28279, 29883, 29875, 77641, 77649, 3500, 3499, 29706, 29707, 30084, 78375, 77874, 78383, 3522, 29773, 29732, 
29774, 30086, 30069, 77851, 77876
28280, 3450, 3449, 29618, 29619, 29884, 29876, 77642, 77650, 3472, 29685, 29644, 29686, 30087, 78376, 77878, 
78384, 30088, 30071, 77852, 77877
28281, 29884, 29876, 77642, 77650, 29885, 29877, 77643, 77651, 30087, 78376, 77878, 78384, 30089, 78377, 77881, 
78385, 30090, 30073, 77855, 77880
28282, 29885, 29877, 77643, 77651, 29886, 29878, 77644, 77652, 30089, 78377, 77881, 78385, 30091, 78378, 77884, 
78386, 30092, 30075, 77858, 77883
28283, 29886, 29878, 77644, 77652, 29887, 29879, 77645, 77653, 30091, 78378, 77884, 78386, 30093, 78379, 77887, 
78387, 30094, 30077, 77861, 77886
28284, 29887, 29879, 77645, 77653, 29888, 29880, 77646, 77654, 30093, 78379, 77887, 78387, 30095, 78380, 77890, 
78388, 30096, 30079, 77864, 77889
28285, 29888, 29880, 77646, 77654, 29889, 29881, 77647, 77655, 30095, 78380, 77890, 78388, 30097, 78381, 77893, 
78389, 30098, 30081, 77867, 77892
28286, 29889, 29881, 77647, 77655, 29890, 29882, 77648, 77656, 30097, 78381, 77893, 78389, 30099, 78382, 77896, 
78390, 30100, 30083, 77870, 77895
28287, 29890, 29882, 77648, 77656, 29891, 29883, 77649, 77657, 30099, 78382, 77896, 78390, 30101, 78383, 77899, 
78391, 30102, 30085, 77873, 77898
28288, 29891, 29883, 77649, 77657, 3501, 3500, 29707, 29708, 30101, 78383, 77899, 78391, 3523, 29774, 29734, 
29775, 30103, 30086, 77876, 77901
28289, 3451, 3450, 29619, 29620, 29892, 29884, 77650, 77658, 3473, 29686, 29646, 29687, 30104, 78384, 77903, 
78392, 30105, 30088, 77877, 77902
28290, 29892, 29884, 77650, 77658, 29893, 29885, 77651, 77659, 30104, 78384, 77903, 78392, 30106, 78385, 77906, 
78393, 30107, 30090, 77880, 77905
28291, 29893, 29885, 77651, 77659, 29894, 29886, 77652, 77660, 30106, 78385, 77906, 78393, 30108, 78386, 77909, 
78394, 30109, 30092, 77883, 77908
28292, 29894, 29886, 77652, 77660, 29895, 29887, 77653, 77661, 30108, 78386, 77909, 78394, 30110, 78387, 77912, 
78395, 30111, 30094, 77886, 77911
28293, 29895, 29887, 77653, 77661, 29896, 29888, 77654, 77662, 30110, 78387, 77912, 78395, 30112, 78388, 77915, 
78396, 30113, 30096, 77889, 77914
28294, 29896, 29888, 77654, 77662, 29897, 29889, 77655, 77663, 30112, 78388, 77915, 78396, 30114, 78389, 77918, 
78397, 30115, 30098, 77892, 77917
28295, 29897, 29889, 77655, 77663, 29898, 29890, 77656, 77664, 30114, 78389, 77918, 78397, 30116, 78390, 77921, 
78398, 30117, 30100, 77895, 77920
28296, 29898, 29890, 77656, 77664, 29899, 29891, 77657, 77665, 30116, 78390, 77921, 78398, 30118, 78391, 77924, 
78399, 30119, 30102, 77898, 77923
28297, 29899, 29891, 77657, 77665, 3502, 3501, 29708, 29709, 30118, 78391, 77924, 78399, 3524, 29775, 29736, 
29776, 30120, 30103, 77901, 77926
28298, 3452, 3451, 29620, 29621, 29900, 29892, 77658, 77666, 3474, 29687, 29648, 29688, 30121, 78392, 77928, 
78400, 30122, 30105, 77902, 77927
28299, 29900, 29892, 77658, 77666, 29901, 29893, 77659, 77667, 30121, 78392, 77928, 78400, 30123, 78393, 77931, 
78401, 30124, 30107, 77905, 77930
28300, 29901, 29893, 77659, 77667, 29902, 29894, 77660, 77668, 30123, 78393, 77931, 78401, 30125, 78394, 77934, 
78402, 30126, 30109, 77908, 77933
28301, 29902, 29894, 77660, 77668, 29903, 29895, 77661, 77669, 30125, 78394, 77934, 78402, 30127, 78395, 77937, 
