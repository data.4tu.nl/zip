14218, 81645, 82203, 82228, 81670
29684, 13898, 13920, 13921, 13899, 80600, 80776, 80784, 80608, 14040, 14043, 14042, 13998, 82206, 82230, 82231, 
81672, 81646, 82204, 82229, 81671
29685, 80600, 80776, 80784, 80608, 80601, 80777, 80785, 80609, 82206, 82230, 82231, 81672, 82209, 82233, 82234, 
81675, 81649, 82207, 82232, 81674
29686, 80601, 80777, 80785, 80609, 80602, 80778, 80786, 80610, 82209, 82233, 82234, 81675, 82212, 82236, 82237, 
81678, 81652, 82210, 82235, 81677
29687, 80602, 80778, 80786, 80610, 80603, 80779, 80787, 80611, 82212, 82236, 82237, 81678, 82215, 82239, 82240, 
81681, 81655, 82213, 82238, 81680
29688, 80603, 80779, 80787, 80611, 80604, 80780, 80788, 80612, 82215, 82239, 82240, 81681, 82218, 82242, 82243, 
81684, 81658, 82216, 82241, 81683
29689, 80604, 80780, 80788, 80612, 80605, 80781, 80789, 80613, 82218, 82242, 82243, 81684, 82221, 82245, 82246, 
81687, 81661, 82219, 82244, 81686
29690, 80605, 80781, 80789, 80613, 80606, 80782, 80790, 80614, 82221, 82245, 82246, 81687, 82224, 82248, 82249, 
81690, 81664, 82222, 82247, 81689
29691, 80606, 80782, 80790, 80614, 80607, 80783, 80791, 80615, 82224, 82248, 82249, 81690, 82227, 82251, 82252, 
81693, 81667, 82225, 82250, 81692
29692, 80607, 80783, 80791, 80615, 14121, 14143, 14144, 14122, 82227, 82251, 82252, 81693, 14264, 14265, 14266, 
14220, 81670, 82228, 82253, 81695
29693, 13899, 13921, 13922, 13900, 80608, 80784, 80792, 80616, 14042, 14045, 14044, 14000, 82231, 82255, 82256, 
81697, 81671, 82229, 82254, 81696
29694, 80608, 80784, 80792, 80616, 80609, 80785, 80793, 80617, 82231, 82255, 82256, 81697, 82234, 82258, 82259, 
81700, 81674, 82232, 82257, 81699
29695, 80609, 80785, 80793, 80617, 80610, 80786, 80794, 80618, 82234, 82258, 82259, 81700, 82237, 82261, 82262, 
81703, 81677, 82235, 82260, 81702
29696, 80610, 80786, 80794, 80618, 80611, 80787, 80795, 80619, 82237, 82261, 82262, 81703, 82240, 82264, 82265, 
81706, 81680, 82238, 82263, 81705
29697, 80611, 80787, 80795, 80619, 80612, 80788, 80796, 80620, 82240, 82264, 82265, 81706, 82243, 82267, 82268, 
81709, 81683, 82241, 82266, 81708
29698, 80612, 80788, 80796, 80620, 80613, 80789, 80797, 80621, 82243, 82267, 82268, 81709, 82246, 82270, 82271, 
81712, 81686, 82244, 82269, 81711
29699, 80613, 80789, 80797, 80621, 80614, 80790, 80798, 80622, 82246, 82270, 82271, 81712, 82249, 82273, 82274, 
81715, 81689, 82247, 82272, 81714
29700, 80614, 80790, 80798, 80622, 80615, 80791, 80799, 80623, 82249, 82273, 82274, 81715, 82252, 82276, 82277, 
81718, 81692, 82250, 82275, 81717
29701, 80615, 80791, 80799, 80623, 14122, 14144, 14145, 14123, 82252, 82276, 82277, 81718, 14266, 14267, 14268, 
14222, 81695, 82253, 82278, 81720
29702, 13900, 13922, 13923, 13901, 80616, 80792, 80800, 80624, 14044, 14047, 14046, 14002, 82256, 82280, 82281, 
81722, 81696, 82254, 82279, 81721
29703, 80616, 80792, 80800, 80624, 80617, 80793, 80801, 80625, 82256, 82280, 82281, 81722, 82259, 82283, 82284, 
81725, 81699, 82257, 82282, 81724
29704, 80617, 80793, 80801, 80625, 80618, 80794, 80802, 80626, 82259, 82283, 82284, 81725, 82262, 82286, 82287, 
81728, 81702, 82260, 82285, 81727
29705, 80618, 80794, 80802, 80626, 80619, 80795, 80803, 80627, 82262, 82286, 82287, 81728, 82265, 82289, 82290, 
81731, 81705, 82263, 82288, 81730
29706, 80619, 80795, 80803, 80627, 80620, 80796, 80804, 80628, 82265, 82289, 82290, 81731, 82268, 82292, 82293, 
81734, 81708, 82266, 82291, 81733
29707, 80620, 80796, 80804, 80628, 80621, 80797, 80805, 80629, 82268, 82292, 82293, 81734, 82271, 82295, 82296, 
81737, 81711, 82269, 82294, 81736
29708, 80621, 80797, 80805, 80629, 80622, 80798, 80806, 80630, 82271, 82295, 82296, 81737, 82274, 82298, 82299, 
81740, 81714, 82272, 82297, 81739
29709, 80622, 80798, 80806, 80630, 80623, 80799, 80807, 80631, 82274, 82298, 82299, 81740, 82277, 82301, 82302, 
81743, 81717, 82275, 82300, 81742
29710, 80623, 80799, 80807, 80631, 14123, 14145, 14146, 14124, 82277, 82301, 82302, 81743, 14268, 14269, 14270, 
14224, 81720, 82278, 82303, 81745
29711, 13901, 13923, 13924, 13902, 80624, 80800, 80808, 80632, 14046, 14049, 14048, 14004, 82281, 82305, 82306, 
81747, 81721, 82279, 82304, 81746
29712, 80624, 80800, 80808, 80632, 80625, 80801, 80809, 80633, 82281, 82305, 82306, 81747, 82284, 82308, 82309, 
81750, 81724, 82282, 82307, 81749
29713, 80625, 80801, 80809, 80633, 80626, 80802, 80810, 80634, 82284, 82308, 82309, 81750, 82287, 82311, 82312, 
81753, 81727, 82285, 82310, 81752
29714, 80626, 80802, 80810, 80634, 80627, 80803, 80811, 80635, 82287, 82311, 82312, 81753, 82290, 82314, 82315, 
81756, 81730, 82288, 82313, 81755
29715, 80627, 80803, 80811, 80635, 80628, 80804, 80812, 80636, 82290, 82314, 82315, 81756, 82293, 82317, 82318, 
81759, 81733, 82291, 82316, 81758
29716, 80628, 80804, 80812, 80636, 80629, 80805, 80813, 80637, 82293, 82317, 82318, 81759, 82296, 82320, 82321, 
81762, 81736, 82294, 82319, 81761
29717, 80629, 80805, 80813, 80637, 80630, 80806, 80814, 80638, 82296, 82320, 82321, 81762, 82299, 82323, 82324, 
81765, 81739, 82297, 82322, 81764
29718, 80630, 80806, 80814, 80638, 80631, 80807, 80815, 80639, 82299, 82323, 82324, 81765, 82302, 82326, 82327, 
81768, 81742, 82300, 82325, 81767
29719, 80631, 80807, 80815, 80639, 14124, 14146, 14147, 14125, 82302, 82326, 82327, 81768, 14270, 14271, 14272, 
14226, 81745, 82303, 82328, 81770
29720, 13902, 13924, 13925, 13903, 80632, 80808, 80816, 80640, 14048, 14051, 14050, 14006, 82306, 82330, 82331, 
81772, 81746, 82304, 82329, 81771
29721, 80632, 80808, 80816, 80640, 80633, 80809, 80817, 80641, 82306, 82330, 82331, 81772, 82309, 82333, 82334, 
81775, 81749, 82307, 82332, 81774
29722, 80633, 80809, 80817, 80641, 80634, 80810, 80818, 80642, 82309, 82333, 82334, 81775, 82312, 82336, 82337, 
81778, 81752, 82310, 82335, 81777
29723, 80634, 80810, 80818, 80642, 80635, 80811, 80819, 80643, 82312, 82336, 82337, 81778, 82315, 82339, 82340, 
81781, 81755, 82313, 82338, 81780
29724, 80635, 80811, 80819, 80643, 80636, 80812, 80820, 80644, 82315, 82339, 82340, 81781, 82318, 82342, 82343, 
81784, 81758, 82316, 82341, 81783
29725, 80636, 80812, 80820, 80644, 80637, 80813, 80821, 80645, 82318, 82342, 82343, 81784, 82321, 82345, 82346, 
81787, 81761, 82319, 82344, 81786
29726, 80637, 80813, 80821, 80645, 80638, 80814, 80822, 80646, 82321, 82345, 82346, 81787, 82324, 82348, 82349, 
81790, 81764, 82322, 82347, 81789
29727, 80638, 80814, 80822, 80646, 80639, 80815, 80823, 80647, 82324, 82348, 82349, 81790, 82327, 82351, 82352, 
81793, 81767, 82325, 82350, 81792
29728, 80639, 80815, 80823, 80647, 14125, 14147, 14148, 14126, 82327, 82351, 82352, 81793, 14272, 14273, 14274, 
14228, 81770, 82328, 82353, 81795
29729, 13903, 13925, 13926, 13904, 80640, 80816, 80824, 80648, 14050, 14053, 14052, 14008, 82331, 82355, 82356, 
81797, 81771, 82329, 82354, 81796
29730, 80640, 80816, 80824, 80648, 80641, 80817, 80825, 80649, 82331, 82355, 82356, 81797, 82334, 82358, 82359, 
81800, 81774, 82332, 82357, 81799
29731, 80641, 80817, 80825, 80649, 80642, 80818, 80826, 80650, 82334, 82358, 82359, 81800, 82337, 82361, 82362, 
81803, 81777, 82335, 82360, 81802
29732, 80642, 80818, 80826, 80650, 80643, 80819, 80827, 80651, 82337, 82361, 82362, 81803, 82340, 82364, 82365, 
81806, 81780, 82338, 82363, 81805
29733, 80643, 80819, 80827, 80651, 80644, 80820, 80828, 80652, 82340, 82364, 82365, 81806, 82343, 82367, 82368, 
81809, 81783, 82341, 82366, 81808
29734, 80644, 80820, 80828, 80652, 80645, 80821, 80829, 80653, 82343, 82367, 82368, 81809, 82346, 82370, 82371, 
81812, 81786, 82344, 82369, 81811
29735, 80645, 80821, 80829, 80653, 80646, 80822, 80830, 80654, 82346, 82370, 82371, 81812, 82349, 82373, 82374, 
81815, 81789, 82347, 82372, 81814
29736, 80646, 80822, 80830, 80654, 80647, 80823, 80831, 80655, 82349, 82373, 82374, 81815, 82352, 82376, 82377, 
81818, 81792, 82350, 82375, 81817
29737, 80647, 80823, 80831, 80655, 14126, 14148, 14149, 14127, 82352, 82376, 82377, 81818, 14274, 14275, 14276, 
14230, 81795, 82353, 82378, 81820
29738, 13904, 13926, 13927, 13905, 80648, 80824, 80832, 80656, 14052, 14055, 14054, 14010, 82356, 82380, 82381, 
81822, 81796, 82354, 82379, 81821
29739, 80648, 80824, 80832, 80656, 80649, 80825, 80833, 80657, 82356, 82380, 82381, 81822, 82359, 82383, 82384, 
81825, 81799, 82357, 82382, 81824
29740, 80649, 80825, 80833, 80657, 80650, 80826, 80834, 80658, 82359, 82383, 82384, 81825, 82362, 82386, 82387, 
81828, 81802, 82360, 82385, 81827
29741, 80650, 80826, 80834, 80658, 80651, 80827, 80835, 80659, 82362, 82386, 82387, 81828, 82365, 82389, 82390, 
81831, 81805, 82363, 82388, 81830
29742, 80651, 80827, 80835, 80659, 80652, 80828, 80836, 80660, 82365, 82389, 82390, 81831, 82368, 82392, 82393, 
81834, 81808, 82366, 82391, 81833
29743, 80652, 80828, 80836, 80660, 80653, 80829, 80837, 80661, 82368, 82392, 82393, 81834, 82371, 82395, 82396, 
81837, 81811, 82369, 82394, 81836
29744, 80653, 80829, 80837, 80661, 80654, 80830, 80838, 80662, 82371, 82395, 82396, 81837, 82374, 82398, 82399, 
81840, 81814, 82372, 82397, 81839
29745, 80654, 80830, 80838, 80662, 80655, 80831, 80839, 80663, 82374, 82398, 82399, 81840, 82377, 82401, 82402, 
81843, 81817, 82375, 82400, 81842
29746, 80655, 80831, 80839, 80663, 14127, 14149, 14150, 14128, 82377, 82401, 82402, 81843, 14276, 14277, 14278, 
14232, 81820, 82378, 82403, 81845
29747, 13905, 13927, 13928, 13906, 80656, 80832, 80840, 80664, 14054, 14057, 14056, 14012, 82381, 82405, 82406, 
81847, 81821, 82379, 82404, 81846
29748, 80656, 80832, 80840, 80664, 80657, 80833, 80841, 80665, 82381, 82405, 82406, 81847, 82384, 82408, 82409, 
81850, 81824, 82382, 82407, 81849
29749, 80657, 80833, 80841, 80665, 80658, 80834, 80842, 80666, 82384, 82408, 82409, 81850, 82387, 82411, 82412, 
81853, 81827, 82385, 82410, 81852
29750, 80658, 80834, 80842, 80666, 80659, 80835, 80843, 80667, 82387, 82411, 82412, 81853, 82390, 82414, 82415, 
81856, 81830, 82388, 82413, 81855
29751, 80659, 80835, 80843, 80667, 80660, 80836, 80844, 80668, 82390, 82414, 82415, 81856, 82393, 82417, 82418, 
81859, 81833, 82391, 82416, 81858
29752, 80660, 80836, 80844, 80668, 80661, 80837, 80845, 80669, 82393, 82417, 82418, 81859, 82396, 82420, 82421, 
81862, 81836, 82394, 82419, 81861
29753, 80661, 80837, 80845, 80669, 80662, 80838, 80846, 80670, 82396, 82420, 82421, 81862, 82399, 82423, 82424, 
81865, 81839, 82397, 82422, 81864
29754, 80662, 80838, 80846, 80670, 80663, 80839, 80847, 80671, 82399, 82423, 82424, 81865, 82402, 82426, 82427, 
81868, 81842, 82400, 82425, 81867
29755, 80663, 80839, 80847, 80671, 14128, 14150, 14151, 14129, 82402, 82426, 82427, 81868, 14278, 14279, 14280, 
14234, 81845, 82403, 82428, 81870
29756, 13906, 13928, 13929, 13907, 80664, 80840, 80848, 80672, 14056, 14059, 14058, 14014, 82406, 82430, 82431, 
81872, 81846, 82404, 82429, 81871
29757, 80664, 80840, 80848, 80672, 80665, 80841, 80849, 80673, 82406, 82430, 82431, 81872, 82409, 82433, 82434, 
81875, 81849, 82407, 82432, 81874
29758, 80665, 80841, 80849, 80673, 80666, 80842, 80850, 80674, 82409, 82433, 82434, 81875, 82412, 82436, 82437, 
81878, 81852, 82410, 82435, 81877
29759, 80666, 80842, 80850, 80674, 80667, 80843, 80851, 80675, 82412, 82436, 82437, 81878, 82415, 82439, 82440, 
81881, 81855, 82413, 82438, 81880
29760, 80667, 80843, 80851, 80675, 80668, 80844, 80852, 80676, 82415, 82439, 82440, 81881, 82418, 82442, 82443, 
81884, 81858, 82416, 82441, 81883
29761, 80668, 80844, 80852, 80676, 80669, 80845, 80853, 80677, 82418, 82442, 82443, 81884, 82421, 82445, 82446, 
81887, 81861, 82419, 82444, 81886
29762, 80669, 80845, 80853, 80677, 80670, 80846, 80854, 80678, 82421, 82445, 82446, 81887, 82424, 82448, 82449, 
81890, 81864, 82422, 82447, 81889
29763, 80670, 80846, 80854, 80678, 80671, 80847, 80855, 80679, 82424, 82448, 82449, 81890, 82427, 82451, 82452, 
81893, 81867, 82425, 82450, 81892
29764, 80671, 80847, 80855, 80679, 14129, 14151, 14152, 14130, 82427, 82451, 82452, 81893, 14280, 14281, 14282, 
14236, 81870, 82428, 82453, 81895
29765, 13907, 13929, 13930, 13908, 80672, 80848, 80856, 80680, 14058, 14061, 14060, 14016, 82431, 82455, 82456, 
81897, 81871, 82429, 82454, 81896
29766, 80672, 80848, 80856, 80680, 80673, 80849, 80857, 80681, 82431, 82455, 82456, 81897, 82434, 82458, 82459, 
81900, 81874, 82432, 82457, 81899
29767, 80673, 80849, 80857, 80681, 80674, 80850, 80858, 80682, 82434, 82458, 82459, 81900, 82437, 82461, 82462, 
81903, 81877, 82435, 82460, 81902
29768, 80674, 80850, 80858, 80682, 80675, 80851, 80859, 80683, 82437, 82461, 82462, 81903, 82440, 82464, 82465, 
81906, 81880, 82438, 82463, 81905
29769, 80675, 80851, 80859, 80683, 80676, 80852, 80860, 80684, 82440, 82464, 82465, 81906, 82443, 82467, 82468, 
81909, 81883, 82441, 82466, 81908
29770, 80676, 80852, 80860, 80684, 80677, 80853, 80861, 80685, 82443, 82467, 82468, 81909, 82446, 82470, 82471, 
81912, 81886, 82444, 82469, 81911
29771, 80677, 80853, 80861, 80685, 80678, 80854, 80862, 80686, 82446, 82470, 82471, 81912, 82449, 82473, 82474, 
81915, 81889, 82447, 82472, 81914
29772, 80678, 80854, 80862, 80686, 80679, 80855, 80863, 80687, 82449, 82473, 82474, 81915, 82452, 82476, 82477, 
81918, 81892, 82450, 82475, 81917
29773, 80679, 80855, 80863, 80687, 14130, 14152, 14153, 14131, 82452, 82476, 82477, 81918, 14282, 14283, 14284, 
14238, 81895, 82453, 82478, 81920
29774, 13908, 13930, 13931, 13909, 80680, 80856, 80864, 80688, 14060, 14063, 14062, 14018, 82456, 82480, 82481, 
81922, 81896, 82454, 82479, 81921
29775, 80680, 80856, 80864, 80688, 80681, 80857, 80865, 80689, 82456, 82480, 82481, 81922, 82459, 82483, 82484, 
81925, 81899, 82457, 82482, 81924
29776, 80681, 80857, 80865, 80689, 80682, 80858, 80866, 80690, 82459, 82483, 82484, 81925, 82462, 82486, 82487, 
81928, 81902, 82460, 82485, 81927
29777, 80682, 80858, 80866, 80690, 80683, 80859, 80867, 80691, 82462, 82486, 82487, 81928, 82465, 82489, 82490, 
81931, 81905, 82463, 82488, 81930
29778, 80683, 80859, 80867, 80691, 80684, 80860, 80868, 80692, 82465, 82489, 82490, 81931, 82468, 82492, 82493, 
81934, 81908, 82466, 82491, 81933
29779, 80684, 80860, 80868, 80692, 80685, 80861, 80869, 80693, 82468, 82492, 82493, 81934, 82471, 82495, 82496, 
81937, 81911, 82469, 82494, 81936
29780, 80685, 80861, 80869, 80693, 80686, 80862, 80870, 80694, 82471, 82495, 82496, 81937, 82474, 82498, 82499, 
81940, 81914, 82472, 82497, 81939
29781, 80686, 80862, 80870, 80694, 80687, 80863, 80871, 80695, 82474, 82498, 82499, 81940, 82477, 82501, 82502, 
81943, 81917, 82475, 82500, 81942
29782, 80687, 80863, 80871, 80695, 14131, 14153, 14154, 14132, 82477, 82501, 82502, 81943, 14284, 14285, 14286, 
14240, 81920, 82478, 82503, 81945
29783, 13909, 13931, 13932, 13910, 80688, 80864, 80872, 80696, 14062, 14065, 14064, 14020, 82481, 82505, 82506, 
81947, 81921, 82479, 82504, 81946
29784, 80688, 80864, 80872, 80696, 80689, 80865, 80873, 80697, 82481, 82505, 82506, 81947, 82484, 82508, 82509, 
81950, 81924, 82482, 82507, 81949
29785, 80689, 80865, 80873, 80697, 80690, 80866, 80874, 80698, 82484, 82508, 82509, 81950, 82487, 82511, 82512, 
81953, 81927, 82485, 82510, 81952
29786, 80690, 80866, 80874, 80698, 80691, 80867, 80875, 80699, 82487, 82511, 82512, 81953, 82490, 82514, 82515, 
81956, 81930, 82488, 82513, 81955
29787, 80691, 80867, 80875, 80699, 80692, 80868, 80876, 80700, 82490, 82514, 82515, 81956, 82493, 82517, 82518, 
81959, 81933, 82491, 82516, 81958
29788, 80692, 80868, 80876, 80700, 80693, 80869, 80877, 80701, 82493, 82517, 82518, 81959, 82496, 82520, 82521, 
81962, 81936, 82494, 82519, 81961
29789, 80693, 80869, 80877, 80701, 80694, 80870, 80878, 80702, 82496, 82520, 82521, 81962, 82499, 82523, 82524, 
81965, 81939, 82497, 82522, 81964
29790, 80694, 80870, 80878, 80702, 80695, 80871, 80879, 80703, 82499, 82523, 82524, 81965, 82502, 82526, 82527, 
81968, 81942, 82500, 82525, 81967
29791, 80695, 80871, 80879, 80703, 14132, 14154, 14155, 14133, 82502, 82526, 82527, 81968, 14286, 14287, 14288, 
14242, 81945, 82503, 82528, 81970
29792, 13910, 13932, 13933, 13911, 80696, 80872, 80880, 80704, 14064, 14067, 14066, 14022, 82506, 82530, 82531, 
81972, 81946, 82504, 82529, 81971
29793, 80696, 80872, 80880, 80704, 80697, 80873, 80881, 80705, 82506, 82530, 82531, 81972, 82509, 82533, 82534, 
81975, 81949, 82507, 82532, 81974
29794, 80697, 80873, 80881, 80705, 80698, 80874, 80882, 80706, 82509, 82533, 82534, 81975, 82512, 82536, 82537, 
81978, 81952, 82510, 82535, 81977
29795, 80698, 80874, 80882, 80706, 80699, 80875, 80883, 80707, 82512, 82536, 82537, 81978, 82515, 82539, 82540, 
81981, 81955, 82513, 82538, 81980
29796, 80699, 80875, 80883, 80707, 80700, 80876, 80884, 80708, 82515, 82539, 82540, 81981, 82518, 82542, 82543, 
81984, 81958, 82516, 82541, 81983
29797, 80700, 80876, 80884, 80708, 80701, 80877, 80885, 80709, 82518, 82542, 82543, 81984, 82521, 82545, 82546, 
81987, 81961, 82519, 82544, 81986
29798, 80701, 80877, 80885, 80709, 80702, 80878, 80886, 80710, 82521, 82545, 82546, 81987, 82524, 82548, 82549, 
81990, 81964, 82522, 82547, 81989
29799, 80702, 80878, 80886, 80710, 80703, 80879, 80887, 80711, 82524, 82548, 82549, 81990, 82527, 82551, 82552, 
81993, 81967, 82525, 82550, 81992
29800, 80703, 80879, 80887, 80711, 14133, 14155, 14156, 14134, 82527, 82551, 82552, 81993, 14288, 14289, 14290, 
14244, 81970, 82528, 82553, 81995
29801, 13911, 13933, 1841, 1840, 80704, 80880, 14337, 14329, 14066, 14068, 1844, 14023, 82531, 82554, 14387, 
81996, 81971, 82529, 14388, 14371
29802, 80704, 80880, 14337, 14329, 80705, 80881, 14336, 14328, 82531, 82554, 14387, 81996, 82534, 82555, 14385, 
81997, 81974, 82532, 14386, 14369
29803, 80705, 80881, 14336, 14328, 80706, 80882, 14335, 14327, 82534, 82555, 14385, 81997, 82537, 82556, 14383, 
81998, 81977, 82535, 14384, 14367
29804, 80706, 80882, 14335, 14327, 80707, 80883, 14334, 14326, 82537, 82556, 14383, 81998, 82540, 82557, 14381, 
81999, 81980, 82538, 14382, 14365
29805, 80707, 80883, 14334, 14326, 80708, 80884, 14333, 14325, 82540, 82557, 14381, 81999, 82543, 82558, 14379, 
82000, 81983, 82541, 14380, 14363
29806, 80708, 80884, 14333, 14325, 80709, 80885, 14332, 14324, 82543, 82558, 14379, 82000, 82546, 82559, 14377, 
82001, 81986, 82544, 14378, 14361
29807, 80709, 80885, 14332, 14324, 80710, 80886, 14331, 14323, 82546, 82559, 14377, 82001, 82549, 82560, 14375, 
82002, 81989, 82547, 14376, 14359
29808, 80710, 80886, 14331, 14323, 80711, 80887, 14330, 14322, 82549, 82560, 14375, 82002, 82552, 82561, 14373, 
82003, 81992, 82550, 14374, 14357
29809, 80711, 80887, 14330, 14322, 14134, 14156, 1893, 1892, 82552, 82561, 14373, 82003, 14290, 14291, 1896, 
14246, 81995, 82553, 14372, 14355
29810, 1786, 59, 1867, 13912, 13642, 1805, 14565, 80712, 1790, 1890, 14069, 14025, 13701, 14947, 82562, 
82005, 13693, 1813, 14931, 82004
29811, 13642, 1805, 14565, 80712, 13641, 1806, 14566, 80713, 13701, 14947, 82562, 82005, 13700, 14948, 82563, 
82008, 13691, 1814, 14933, 82007
29812, 13641, 1806, 14566, 80713, 13640, 1807, 14567, 80714, 13700, 14948, 82563, 82008, 13699, 14949, 82564, 
82011, 13689, 1815, 14935, 82010
29813, 13640, 1807, 14567, 80714, 13639, 1808, 14568, 80715, 13699, 14949, 82564, 82011, 13698, 14950, 82565, 
82014, 13687, 1816, 14937, 82013
29814, 13639, 1808, 14568, 80715, 13638, 1809, 14569, 80716, 13698, 14950, 82565, 82014, 13697, 14951, 82566, 
82017, 13685, 1817, 14939, 82016
29815, 13638, 1809, 14569, 80716, 13637, 1810, 14570, 80717, 13697, 14951, 82566, 82017, 13696, 14952, 82567, 
82020, 13683, 1818, 14941, 82019
29816, 13637, 1810, 14570, 80717, 13636, 1811, 14571, 80718, 13696, 14952, 82567, 82020, 13695, 14953, 82568, 
82023, 13681, 1819, 14943, 82022
29817, 13636, 1811, 14571, 80718, 13635, 1812, 14572, 80719, 13695, 14953, 82568, 82023, 13694, 14954, 82569, 
82026, 13679, 1820, 14945, 82025
29818, 13635, 1812, 14572, 80719, 1765, 57, 1919, 14135, 13694, 14954, 82569, 82026, 1769, 1942, 14292, 
14247, 13677, 1821, 14946, 82028
29819, 13912, 1867, 1866, 13913, 80712, 14565, 14557, 80720, 14069, 1889, 14070, 14027, 82562, 14930, 82570, 
82030, 82004, 14931, 14914, 82029
29820, 80712, 14565, 14557, 80720, 80713, 14566, 14558, 80721, 82562, 14930, 82570, 82030, 82563, 14932, 82571, 
82033, 82007, 14933, 14916, 82032
29821, 80713, 14566, 14558, 80721, 80714, 14567, 14559, 80722, 82563, 14932, 82571, 82033, 82564, 14934, 82572, 
82036, 82010, 14935, 14918, 82035
29822, 80714, 14567, 14559, 80722, 80715, 14568, 14560, 80723, 82564, 14934, 82572, 82036, 82565, 14936, 82573, 
82039, 82013, 14937, 14920, 82038
29823, 80715, 14568, 14560, 80723, 80716, 14569, 14561, 80724, 82565, 14936, 82573, 82039, 82566, 14938, 82574, 
82042, 82016, 14939, 14922, 82041
29824, 80716, 14569, 14561, 80724, 80717, 14570, 14562, 80725, 82566, 14938, 82574, 82042, 82567, 14940, 82575, 
82045, 82019, 14941, 14924, 82044
29825, 80717, 14570, 14562, 80725, 80718, 14571, 14563, 80726, 82567, 14940, 82575, 82045, 82568, 14942, 82576, 
82048, 82022, 14943, 14926, 82047
29826, 80718, 14571, 14563, 80726, 80719, 14572, 14564, 80727, 82568, 14942, 82576, 82048, 82569, 14944, 82577, 
82051, 82025, 14945, 14928, 82050
29827, 80719, 14572, 14564, 80727, 14135, 1919, 1918, 14136, 82569, 14944, 82577, 82051, 14292, 1941, 14293, 
14249, 82028, 14946, 14929, 82053
29828, 13913, 1866, 1865, 13914, 80720, 14557, 14549, 80728, 14070, 1888, 14071, 14029, 82570, 14913, 82578, 
82055, 82029, 14914, 14897, 82054
29829, 80720, 14557, 14549, 80728, 80721, 14558, 14550, 80729, 82570, 14913, 82578, 82055, 82571, 14915, 82579, 
82058, 82032, 14916, 14899, 82057
29830, 80721, 14558, 14550, 80729, 80722, 14559, 14551, 80730, 82571, 14915, 82579, 82058, 82572, 14917, 82580, 
82061, 82035, 14918, 14901, 82060
29831, 80722, 14559, 14551, 80730, 80723, 14560, 14552, 80731, 82572, 14917, 82580, 82061, 82573, 14919, 82581, 
82064, 82038, 14920, 14903, 82063
29832, 80723, 14560, 14552, 80731, 80724, 14561, 14553, 80732, 82573, 14919, 82581, 82064, 82574, 14921, 82582, 
82067, 82041, 14922, 14905, 82066
29833, 80724, 14561, 14553, 80732, 80725, 14562, 14554, 80733, 82574, 14921, 82582, 82067, 82575, 14923, 82583, 
82070, 82044, 14924, 14907, 82069
29834, 80725, 14562, 14554, 80733, 80726, 14563, 14555, 80734, 82575, 14923, 82583, 82070, 82576, 14925, 82584, 
82073, 82047, 14926, 14909, 82072
29835, 80726, 14563, 14555, 80734, 80727, 14564, 14556, 80735, 82576, 14925, 82584, 82073, 82577, 14927, 82585, 
82076, 82050, 14928, 14911, 82075
29836, 80727, 14564, 14556, 80735, 14136, 1918, 1917, 14137, 82577, 14927, 82585, 82076, 14293, 1940, 14294, 
14251, 82053, 14929, 14912, 82078
29837, 13914, 1865, 1864, 13915, 80728, 14549, 14541, 80736, 14071, 1887, 14072, 14031, 82578, 14896, 82586, 
82080, 82054, 14897, 14880, 82079
29838, 80728, 14549, 14541, 80736, 80729, 14550, 14542, 80737, 82578, 14896, 82586, 82080, 82579, 14898, 82587, 
82083, 82057, 14899, 14882, 82082
29839, 80729, 14550, 14542, 80737, 80730, 14551, 14543, 80738, 82579, 14898, 82587, 82083, 82580, 14900, 82588, 
82086, 82060, 14901, 14884, 82085
29840, 80730, 14551, 14543, 80738, 80731, 14552, 14544, 80739, 82580, 14900, 82588, 82086, 82581, 14902, 82589, 
82089, 82063, 14903, 14886, 82088
29841, 80731, 14552, 14544, 80739, 80732, 14553, 14545, 80740, 82581, 14902, 82589, 82089, 82582, 14904, 82590, 
82092, 82066, 14905, 14888, 82091
29842, 80732, 14553, 14545, 80740, 80733, 14554, 14546, 80741, 82582, 14904, 82590, 82092, 82583, 14906, 82591, 
82095, 82069, 14907, 14890, 82094
29843, 80733, 14554, 14546, 80741, 80734, 14555, 14547, 80742, 82583, 14906, 82591, 82095, 82584, 14908, 82592, 
82098, 82072, 14909, 14892, 82097
29844, 80734, 14555, 14547, 80742, 80735, 14556, 14548, 80743, 82584, 14908, 82592, 82098, 82585, 14910, 82593, 
82101, 82075, 14911, 14894, 82100
29845, 80735, 14556, 14548, 80743, 14137, 1917, 1916, 14138, 82585, 14910, 82593, 82101, 14294, 1939, 14295, 
14253, 82078, 14912, 14895, 82103
29846, 13915, 1864, 1863, 13916, 80736, 14541, 14533, 80744, 14072, 1886, 14073, 14033, 82586, 14879, 82594, 
82105, 82079, 14880, 14863, 82104
29847, 80736, 14541, 14533, 80744, 80737, 14542, 14534, 80745, 82586, 14879, 82594, 82105, 82587, 14881, 82595, 
82108, 82082, 14882, 14865, 82107
29848, 80737, 14542, 14534, 80745, 80738, 14543, 14535, 80746, 82587, 14881, 82595, 82108, 82588, 14883, 82596, 
82111, 82085, 14884, 14867, 82110
29849, 80738, 14543, 14535, 80746, 80739, 14544, 14536, 80747, 82588, 14883, 82596, 82111, 82589, 14885, 82597, 
82114, 82088, 14886, 14869, 82113
29850, 80739, 14544, 14536, 80747, 80740, 14545, 14537, 80748, 82589, 14885, 82597, 82114, 82590, 14887, 82598, 
82117, 82091, 14888, 14871, 82116
29851, 80740, 14545, 14537, 80748, 80741, 14546, 14538, 80749, 82590, 14887, 82598, 82117, 82591, 14889, 82599, 
82120, 82094, 14890, 14873, 82119
29852, 80741, 14546, 14538, 80749, 80742, 14547, 14539, 80750, 82591, 14889, 82599, 82120, 82592, 14891, 82600, 
82123, 82097, 14892, 14875, 82122
29853, 80742, 14547, 14539, 80750, 80743, 14548, 14540, 80751, 82592, 14891, 82600, 82123, 82593, 14893, 82601, 
82126, 82100, 14894, 14877, 82125
29854, 80743, 14548, 14540, 80751, 14138, 1916, 1915, 14139, 82593, 14893, 82601, 82126, 14295, 1938, 14296, 
14255, 82103, 14895, 14878, 82128
29855, 13916, 1863, 1862, 13917, 80744, 14533, 14525, 80752, 14073, 1885, 14074, 14035, 82594, 14862, 82602, 
82130, 82104, 14863, 14846, 82129
29856, 80744, 14533, 14525, 80752, 80745, 14534, 14526, 80753, 82594, 14862, 82602, 82130, 82595, 14864, 82603, 
82133, 82107, 14865, 14848, 82132
29857, 80745, 14534, 14526, 80753, 80746, 14535, 14527, 80754, 82595, 14864, 82603, 82133, 82596, 14866, 82604, 
82136, 82110, 14867, 14850, 82135
29858, 80746, 14535, 14527, 80754, 80747, 14536, 14528, 80755, 82596, 14866, 82604, 82136, 82597, 14868, 82605, 
82139, 82113, 14869, 14852, 82138
29859, 80747, 14536, 14528, 80755, 80748, 14537, 14529, 80756, 82597, 14868, 82605, 82139, 82598, 14870, 82606, 
82142, 82116, 14871, 14854, 82141
29860, 80748, 14537, 14529, 80756, 80749, 14538, 14530, 80757, 82598, 14870, 82606, 82142, 82599, 14872, 82607, 
82145, 82119, 14873, 14856, 82144
29861, 80749, 14538, 14530, 80757, 80750, 14539, 14531, 80758, 82599, 14872, 82607, 82145, 82600, 14874, 82608, 
82148, 82122, 14875, 14858, 82147
29862, 80750, 14539, 14531, 80758, 80751, 14540, 14532, 80759, 82600, 14874, 82608, 82148, 82601, 14876, 82609, 
82151, 82125, 14877, 14860, 82150
29863, 80751, 14540, 14532, 80759, 14139, 1915, 1914, 14140, 82601, 14876, 82609, 82151, 14296, 1937, 14297, 
14257, 82128, 14878, 14861, 82153
29864, 13917, 1862, 1861, 13918, 80752, 14525, 14517, 80760, 14074, 1884, 14075, 14037, 82602, 14845, 82610, 
82155, 82129, 14846, 14829, 82154
29865, 80752, 14525, 14517, 80760, 80753, 14526, 14518, 80761, 82602, 14845, 82610, 82155, 82603, 14847, 82611, 
82158, 82132, 14848, 14831, 82157
29866, 80753, 14526, 14518, 80761, 80754, 14527, 14519, 80762, 82603, 14847, 82611, 82158, 82604, 14849, 82612, 
82161, 82135, 14850, 14833, 82160
29867, 80754, 14527, 14519, 80762, 80755, 14528, 14520, 80763, 82604, 14849, 82612, 82161, 82605, 14851, 82613, 
82164, 82138, 14852, 14835, 82163
29868, 80755, 14528, 14520, 80763, 80756, 14529, 14521, 80764, 82605, 14851, 82613, 82164, 82606, 14853, 82614, 
82167, 82141, 14854, 14837, 82166
29869, 80756, 14529, 14521, 80764, 80757, 14530, 14522, 80765, 82606, 14853, 82614, 82167, 82607, 14855, 82615, 
82170, 82144, 14856, 14839, 82169
29870, 80757, 14530, 14522, 80765, 80758, 14531, 14523, 80766, 82607, 14855, 82615, 82170, 82608, 14857, 82616, 
82173, 82147, 14858, 14841, 82172
29871, 80758, 14531, 14523, 80766, 80759, 14532, 14524, 80767, 82608, 14857, 82616, 82173, 82609, 14859, 82617, 
82176, 82150, 14860, 14843, 82175
29872, 80759, 14532, 14524, 80767, 14140, 1914, 1913, 14141, 82609, 14859, 82617, 82176, 14297, 1936, 14298, 
14259, 82153, 14861, 14844, 82178
29873, 13918, 1861, 1860, 13919, 80760, 14517, 14509, 80768, 14075, 1883, 14076, 14039, 82610, 14828, 82618, 
82180, 82154, 14829, 14812, 82179
29874, 80760, 14517, 14509, 80768, 80761, 14518, 14510, 80769, 82610, 14828, 82618, 82180, 82611, 14830, 82619, 
82183, 82157, 14831, 14814, 82182
29875, 80761, 14518, 14510, 80769, 80762, 14519, 14511, 80770, 82611, 14830, 82619, 82183, 82612, 14832, 82620, 
82186, 82160, 14833, 14816, 82185
29876, 80762, 14519, 14511, 80770, 80763, 14520, 14512, 80771, 82612, 14832, 82620, 82186, 82613, 14834, 82621, 
82189, 82163, 14835, 14818, 82188
29877, 80763, 14520, 14512, 80771, 80764, 14521, 14513, 80772, 82613, 14834, 82621, 82189, 82614, 14836, 82622, 
82192, 82166, 14837, 14820, 82191
29878, 80764, 14521, 14513, 80772, 80765, 14522, 14514, 80773, 82614, 14836, 82622, 82192, 82615, 14838, 82623, 
82195, 82169, 14839, 14822, 82194
29879, 80765, 14522, 14514, 80773, 80766, 14523, 14515, 80774, 82615, 14838, 82623, 82195, 82616, 14840, 82624, 
82198, 82172, 14841, 14824, 82197
29880, 80766, 14523, 14515, 80774, 80767, 14524, 14516, 80775, 82616, 14840, 82624, 82198, 82617, 14842, 82625, 
82201, 82175, 14843, 14826, 82200
29881, 80767, 14524, 14516, 80775, 14141, 1913, 1912, 14142, 82617, 14842, 82625, 82201, 14298, 1935, 14299, 
14261, 82178, 14844, 14827, 82203
29882, 13919, 1860, 1859, 13920, 80768, 14509, 14501, 80776, 14076, 1882, 14077, 14041, 82618, 14811, 82626, 
82205, 82179, 14812, 14795, 82204
29883, 80768, 14509, 14501, 80776, 80769, 14510, 14502, 80777, 82618, 14811, 82626, 82205, 82619, 14813, 82627, 
82208, 82182, 14814, 14797, 82207
29884, 80769, 14510, 14502, 80777, 80770, 14511, 14503, 80778, 82619, 14813, 82627, 82208, 82620, 14815, 82628, 
82211, 82185, 14816, 14799, 82210
29885, 80770, 14511, 14503, 80778, 80771, 14512, 14504, 80779, 82620, 14815, 82628, 82211, 82621, 14817, 82629, 
82214, 82188, 14818, 14801, 82213
29886, 80771, 14512, 14504, 80779, 80772, 14513, 14505, 80780, 82621, 14817, 82629, 82214, 82622, 14819, 82630, 
82217, 82191, 14820, 14803, 82216
29887, 80772, 14513, 14505, 80780, 80773, 14514, 14506, 80781, 82622, 14819, 82630, 82217, 82623, 14821, 82631, 
82220, 82194, 14822, 14805, 82219
29888, 80773, 14514, 14506, 80781, 80774, 14515, 14507, 80782, 82623, 14821, 82631, 82220, 82624, 14823, 82632, 
82223, 82197, 14824, 14807, 82222
29889, 80774, 14515, 14507, 80782, 80775, 14516, 14508, 80783, 82624, 14823, 82632, 82223, 82625, 14825, 82633, 
82226, 82200, 14826, 14809, 82225
29890, 80775, 14516, 14508, 80783, 14142, 1912, 1911, 14143, 82625, 14825, 82633, 82226, 14299, 1934, 14300, 
14263, 82203, 14827, 14810, 82228
29891, 13920, 1859, 1858, 13921, 80776, 14501, 14493, 80784, 14077, 1881, 14078, 14043, 82626, 14794, 82634, 
82230, 82204, 14795, 14778, 82229
29892, 80776, 14501, 14493, 80784, 80777, 14502, 14494, 80785, 82626, 14794, 82634, 82230, 82627, 14796, 82635, 
82233, 82207, 14797, 14780, 82232
29893, 80777, 14502, 14494, 80785, 80778, 14503, 14495, 80786, 82627, 14796, 82635, 82233, 82628, 14798, 82636, 
82236, 82210, 14799, 14782, 82235
29894, 80778, 14503, 14495, 80786, 80779, 14504, 14496, 80787, 82628, 14798, 82636, 82236, 82629, 14800, 82637, 
82239, 82213, 14801, 14784, 82238
29895, 80779, 14504, 14496, 80787, 80780, 14505, 14497, 80788, 82629, 14800, 82637, 82239, 82630, 14802, 82638, 
82242, 82216, 14803, 14786, 82241
29896, 80780, 14505, 14497, 80788, 80781, 14506, 14498, 80789, 82630, 14802, 82638, 82242, 82631, 14804, 82639, 
82245, 82219, 14805, 14788, 82244
29897, 80781, 14506, 14498, 80789, 80782, 14507, 14499, 80790, 82631, 14804, 82639, 82245, 82632, 14806, 82640, 
82248, 82222, 14807, 14790, 82247
29898, 80782, 14507, 14499, 80790, 80783, 14508, 14500, 80791, 82632, 14806, 82640, 82248, 82633, 14808, 82641, 
82251, 82225, 14809, 14792, 82250
29899, 80783, 14508, 14500, 80791, 14143, 1911, 1910, 14144, 82633, 14808, 82641, 82251, 14300, 1933, 14301, 
14265, 82228, 14810, 14793, 82253
29900, 13921, 1858, 1857, 13922, 80784, 14493, 14485, 80792, 14078, 1880, 14079, 14045, 82634, 14777, 82642, 
82255, 82229, 14778, 14761, 82254
29901, 80784, 14493, 14485, 80792, 80785, 14494, 14486, 80793, 82634, 14777, 82642, 82255, 82635, 14779, 82643, 
82258, 82232, 14780, 14763, 82257
29902, 80785, 14494, 14486, 80793, 80786, 14495, 14487, 80794, 82635, 14779, 82643, 82258, 82636, 14781, 82644, 
82261, 82235, 14782, 14765, 82260
29903, 80786, 14495, 14487, 80794, 80787, 14496, 14488, 80795, 82636, 14781, 82644, 82261, 82637, 14783, 82645, 
82264, 82238, 14784, 14767, 82263
29904, 80787, 14496, 14488, 80795, 80788, 14497, 14489, 80796, 82637, 14783, 82645, 82264, 82638, 14785, 82646, 
82267, 82241, 14786, 14769, 82266
29905, 80788, 14497, 14489, 80796, 80789, 14498, 14490, 80797, 82638, 14785, 82646, 82267, 82639, 14787, 82647, 
82270, 82244, 14788, 14771, 82269
29906, 80789, 14498, 14490, 80797, 80790, 14499, 14491, 80798, 82639, 14787, 82647, 82270, 82640, 14789, 82648, 
82273, 82247, 14790, 14773, 82272
29907, 80790, 14499, 14491, 80798, 80791, 14500, 14492, 80799, 82640, 14789, 82648, 82273, 82641, 14791, 82649, 
82276, 82250, 14792, 14775, 82275
29908, 80791, 14500, 14492, 80799, 14144, 1910, 1909, 14145, 82641, 14791, 82649, 82276, 14301, 1932, 14302, 
14267, 82253, 14793, 14776, 82278
29909, 13922, 1857, 1856, 13923, 80792, 14485, 14477, 80800, 14079, 1879, 14080, 14047, 82642, 14760, 82650, 
82280, 82254, 14761, 14744, 82279
29910, 80792, 14485, 14477, 80800, 80793, 14486, 14478, 80801, 82642, 14760, 82650, 82280, 82643, 14762, 82651, 
82283, 82257, 14763, 14746, 82282
29911, 80793, 14486, 14478, 80801, 80794, 14487, 14479, 80802, 82643, 14762, 82651, 82283, 82644, 14764, 82652, 
82286, 82260, 14765, 14748, 82285
29912, 80794, 14487, 14479, 80802, 80795, 14488, 14480, 80803, 82644, 14764, 82652, 82286, 82645, 14766, 82653, 
82289, 82263, 14767, 14750, 82288
29913, 80795, 14488, 14480, 80803, 80796, 14489, 14481, 80804, 82645, 14766, 82653, 82289, 82646, 14768, 82654, 
82292, 82266, 14769, 14752, 82291
29914, 80796, 14489, 14481, 80804, 80797, 14490, 14482, 80805, 82646, 14768, 82654, 82292, 82647, 14770, 82655, 
82295, 82269, 14771, 14754, 82294
29915, 80797, 14490, 14482, 80805, 80798, 14491, 14483, 80806, 82647, 14770, 82655, 82295, 82648, 14772, 82656, 
82298, 82272, 14773, 14756, 82297
29916, 80798, 14491, 14483, 80806, 80799, 14492, 14484, 80807, 82648, 14772, 82656, 82298, 82649, 14774, 82657, 
82301, 82275, 14775, 14758, 82300
29917, 80799, 14492, 14484, 80807, 14145, 1909, 1908, 14146, 82649, 14774, 82657, 82301, 14302, 1931, 14303, 
14269, 82278, 14776, 14759, 82303
29918, 13923, 1856, 1855, 13924, 80800, 14477, 14469, 80808, 14080, 1878, 14081, 14049, 82650, 14743, 82658, 
82305, 82279, 14744, 14727, 82304
29919, 80800, 14477, 14469, 80808, 80801, 14478, 14470, 80809, 82650, 14743, 82658, 82305, 82651, 14745, 82659, 
82308, 82282, 14746, 14729, 82307
29920, 80801, 14478, 14470, 80809, 80802, 14479, 14471, 80810, 82651, 14745, 82659, 82308, 82652, 14747, 82660, 
82311, 82285, 14748, 14731, 82310
29921, 80802, 14479, 14471, 80810, 80803, 14480, 14472, 80811, 82652, 14747, 82660, 82311, 82653, 14749, 82661, 
82314, 82288, 14750, 14733, 82313
29922, 80803, 14480, 14472, 80811, 80804, 14481, 14473, 80812, 82653, 14749, 82661, 82314, 82654, 14751, 82662, 
82317, 82291, 14752, 14735, 82316
29923, 80804, 14481, 14473, 80812, 80805, 14482, 14474, 80813, 82654, 14751, 82662, 82317, 82655, 14753, 82663, 
82320, 82294, 14754, 14737, 82319
29924, 80805, 14482, 14474, 80813, 80806, 14483, 14475, 80814, 82655, 14753, 82663, 82320, 82656, 14755, 82664, 
82323, 82297, 14756, 14739, 82322
29925, 80806, 14483, 14475, 80814, 80807, 14484, 14476, 80815, 82656, 14755, 82664, 82323, 82657, 14757, 82665, 
82326, 82300, 14758, 14741, 82325
29926, 80807, 14484, 14476, 80815, 14146, 1908, 1907, 14147, 82657, 14757, 82665, 82326, 14303, 1930, 14304, 
14271, 82303, 14759, 14742, 82328
29927, 13924, 1855, 1854, 13925, 80808, 14469, 14461, 80816, 14081, 1877, 14082, 14051, 82658, 14726, 82666, 
82330, 82304, 14727, 14710, 82329
29928, 80808, 14469, 14461, 80816, 80809, 14470, 14462, 80817, 82658, 14726, 82666, 82330, 82659, 14728, 82667, 
82333, 82307, 14729, 14712, 82332
29929, 80809, 14470, 14462, 80817, 80810, 14471, 14463, 80818, 82659, 14728, 82667, 82333, 82660, 14730, 82668, 
82336, 82310, 14731, 14714, 82335
29930, 80810, 14471, 14463, 80818, 80811, 14472, 14464, 80819, 82660, 14730, 82668, 82336, 82661, 14732, 82669, 
82339, 82313, 14733, 14716, 82338
29931, 80811, 14472, 14464, 80819, 80812, 14473, 14465, 80820, 82661, 14732, 82669, 82339, 82662, 14734, 82670, 
82342, 82316, 14735, 14718, 82341
29932, 80812, 14473, 14465, 80820, 80813, 14474, 14466, 80821, 82662, 14734, 82670, 82342, 82663, 14736, 82671, 
82345, 82319, 14737, 14720, 82344
29933, 80813, 14474, 14466, 80821, 80814, 14475, 14467, 80822, 82663, 14736, 82671, 82345, 82664, 14738, 82672, 
82348, 82322, 14739, 14722, 82347
29934, 80814, 14475, 14467, 80822, 80815, 14476, 14468, 80823, 82664, 14738, 82672, 82348, 82665, 14740, 82673, 
82351, 82325, 14741, 14724, 82350
29935, 80815, 14476, 14468, 80823, 14147, 1907, 1906, 14148, 82665, 14740, 82673, 82351, 14304, 1929, 14305, 
14273, 82328, 14742, 14725, 82353
29936, 13925, 1854, 1853, 13926, 80816, 14461, 14453, 80824, 14082, 1876, 14083, 14053, 82666, 14709, 82674, 
82355, 82329, 14710, 14693, 82354
29937, 80816, 14461, 14453, 80824, 80817, 14462, 14454, 80825, 82666, 14709, 82674, 82355, 82667, 14711, 82675, 
82358, 82332, 14712, 14695, 82357
29938, 80817, 14462, 14454, 80825, 80818, 14463, 14455, 80826, 82667, 14711, 82675, 82358, 82668, 14713, 82676, 
82361, 82335, 14714, 14697, 82360
29939, 80818, 14463, 14455, 80826, 80819, 14464, 14456, 80827, 82668, 14713, 82676, 82361, 82669, 14715, 82677, 
82364, 82338, 14716, 14699, 82363
29940, 80819, 14464, 14456, 80827, 80820, 14465, 14457, 80828, 82669, 14715, 82677, 82364, 82670, 14717, 82678, 
82367, 82341, 14718, 14701, 82366
29941, 80820, 14465, 14457, 80828, 80821, 14466, 14458, 80829, 82670, 14717, 82678, 82367, 82671, 14719, 82679, 
82370, 82344, 14720, 14703, 82369
29942, 80821, 14466, 14458, 80829, 80822, 14467, 14459, 80830, 82671, 14719, 82679, 82370, 82672, 14721, 82680, 
82373, 82347, 14722, 14705, 82372
29943, 80822, 14467, 14459, 80830, 80823, 14468, 14460, 80831, 82672, 14721, 82680, 82373, 82673, 14723, 82681, 
82376, 82350, 14724, 14707, 82375
29944, 80823, 14468, 14460, 80831, 14148, 1906, 1905, 14149, 82673, 14723, 82681, 82376, 14305, 1928, 14306, 
14275, 82353, 14725, 14708, 82378
29945, 13926, 1853, 1852, 13927, 80824, 14453, 14445, 80832, 14083, 1875, 14084, 14055, 82674, 14692, 82682, 
82380, 82354, 14693, 14676, 82379
29946, 80824, 14453, 14445, 80832, 80825, 14454, 14446, 80833, 82674, 14692, 82682, 82380, 82675, 14694, 82683, 
82383, 82357, 14695, 14678, 82382
29947, 80825, 14454, 14446, 80833, 80826, 14455, 14447, 80834, 82675, 14694, 82683, 82383, 82676, 14696, 82684, 
82386, 82360, 14697, 14680, 82385
29948, 80826, 14455, 14447, 80834, 80827, 14456, 14448, 80835, 82676, 14696, 82684, 82386, 82677, 14698, 82685, 
82389, 82363, 14699, 14682, 82388
29949, 80827, 14456, 14448, 80835, 80828, 14457, 14449, 80836, 82677, 14698, 82685, 82389, 82678, 14700, 82686, 
82392, 82366, 14701, 14684, 82391
29950, 80828, 14457, 14449, 80836, 80829, 14458, 14450, 80837, 82678, 14700, 82686, 82392, 82679, 14702, 82687, 
82395, 82369, 14703, 14686, 82394
29951, 80829, 14458, 14450, 80837, 80830, 14459, 14451, 80838, 82679, 14702, 82687, 82395, 82680, 14704, 82688, 
82398, 82372, 14705, 14688, 82397
29952, 80830, 14459, 14451, 80838, 80831, 14460, 14452, 80839, 82680, 14704, 82688, 82398, 82681, 14706, 82689, 
82401, 82375, 14707, 14690, 82400
29953, 80831, 14460, 14452, 80839, 14149, 1905, 1904, 14150, 82681, 14706, 82689, 82401, 14306, 1927, 14307, 
14277, 82378, 14708, 14691, 82403
29954, 13927, 1852, 1851, 13928, 80832, 14445, 14437, 80840, 14084, 1874, 14085, 14057, 82682, 14675, 82690, 
82405, 82379, 14676, 14659, 82404
29955, 80832, 14445, 14437, 80840, 80833, 14446, 14438, 80841, 82682, 14675, 82690, 82405, 82683, 14677, 82691, 
82408, 82382, 14678, 14661, 82407
29956, 80833, 14446, 14438, 80841, 80834, 14447, 14439, 80842, 82683, 14677, 82691, 82408, 82684, 14679, 82692, 
82411, 82385, 14680, 14663, 82410
29957, 80834, 14447, 14439, 80842, 80835, 14448, 14440, 80843, 82684, 14679, 82692, 82411, 82685, 14681, 82693, 
82414, 82388, 14682, 14665, 82413
29958, 80835, 14448, 14440, 80843, 80836, 14449, 14441, 80844, 82685, 14681, 82693, 82414, 82686, 14683, 82694, 
82417, 82391, 14684, 14667, 82416
29959, 80836, 14449, 14441, 80844, 80837, 14450, 14442, 80845, 82686, 14683, 82694, 82417, 82687, 14685, 82695, 
82420, 82394, 14686, 14669, 82419
29960, 80837, 14450, 14442, 80845, 80838, 14451, 14443, 80846, 82687, 14685, 82695, 82420, 82688, 14687, 82696, 
82423, 82397, 14688, 14671, 82422
29961, 80838, 14451, 14443, 80846, 80839, 14452, 14444, 80847, 82688, 14687, 82696, 82423, 82689, 14689, 82697, 
82426, 82400, 14690, 14673, 82425
29962, 80839, 14452, 14444, 80847, 14150, 1904, 1903, 14151, 82689, 14689, 82697, 82426, 14307, 1926, 14308, 
14279, 82403, 14691, 14674, 82428
29963, 13928, 1851, 1850, 13929, 80840, 14437, 14429, 80848, 14085, 1873, 14086, 14059, 82690, 14658, 82698, 
82430, 82404, 14659, 14642, 82429
29964, 80840, 14437, 14429, 80848, 80841, 14438, 14430, 80849, 82690, 14658, 82698, 82430, 82691, 14660, 82699, 
82433, 82407, 14661, 14644, 82432
29965, 80841, 14438, 14430, 80849, 80842, 14439, 14431, 80850, 82691, 14660, 82699, 82433, 82692, 14662, 82700, 
82436, 82410, 14663, 14646, 82435
29966, 80842, 14439, 14431, 80850, 80843, 14440, 14432, 80851, 82692, 14662, 82700, 82436, 82693, 14664, 82701, 
82439, 82413, 14665, 14648, 82438
29967, 80843, 14440, 14432, 80851, 80844, 14441, 14433, 80852, 82693, 14664, 82701, 82439, 82694, 14666, 82702, 
82442, 82416, 14667, 14650, 82441
29968, 80844, 14441, 14433, 80852, 80845, 14442, 14434, 80853, 82694, 14666, 82702, 82442, 82695, 14668, 82703, 
82445, 82419, 14669, 14652, 82444
29969, 80845, 14442, 14434, 80853, 80846, 14443, 14435, 80854, 82695, 14668, 82703, 82445, 82696, 14670, 82704, 
82448, 82422, 14671, 14654, 82447
29970, 80846, 14443, 14435, 80854, 80847, 14444, 14436, 80855, 82696, 14670, 82704, 82448, 82697, 14672, 82705, 
82451, 82425, 14673, 14656, 82450
29971, 80847, 14444, 14436, 80855, 14151, 1903, 1902, 14152, 82697, 14672, 82705, 82451, 14308, 1925, 14309, 
14281, 82428, 14674, 14657, 82453
29972, 13929, 1850, 1849, 13930, 80848, 14429, 14421, 80856, 14086, 1872, 14087, 14061, 82698, 14641, 82706, 
82455, 82429, 14642, 14625, 82454
29973, 80848, 14429, 14421, 80856, 80849, 14430, 14422, 80857, 82698, 14641, 82706, 82455, 82699, 14643, 82707, 
82458, 82432, 14644, 14627, 82457
29974, 80849, 14430, 14422, 80857, 80850, 14431, 14423, 80858, 82699, 14643, 82707, 82458, 82700, 14645, 82708, 
82461, 82435, 14646, 14629, 82460
29975, 80850, 14431, 14423, 80858, 80851, 14432, 14424, 80859, 82700, 14645, 82708, 82461, 82701, 14647, 82709, 
82464, 82438, 14648, 14631, 82463
29976, 80851, 14432, 14424, 80859, 80852, 14433, 14425, 80860, 82701, 14647, 82709, 82464, 82702, 14649, 82710, 
82467, 82441, 14650, 14633, 82466
29977, 80852, 14433, 14425, 80860, 80853, 14434, 14426, 80861, 82702, 14649, 82710, 82467, 82703, 14651, 82711, 
82470, 82444, 14652, 14635, 82469
29978, 80853, 14434, 14426, 80861, 80854, 14435, 14427, 80862, 82703, 14651, 82711, 82470, 82704, 14653, 82712, 
82473, 82447, 14654, 14637, 82472
29979, 80854, 14435, 14427, 80862, 80855, 14436, 14428, 80863, 82704, 14653, 82712, 82473, 82705, 14655, 82713, 
82476, 82450, 14656, 14639, 82475
29980, 80855, 14436, 14428, 80863, 14152, 1902, 1901, 14153, 82705, 14655, 82713, 82476, 14309, 1924, 14310, 
14283, 82453, 14657, 14640, 82478
29981, 13930, 1849, 1848, 13931, 80856, 14421, 14413, 80864, 14087, 1871, 14088, 14063, 82706, 14624, 82714, 
82480, 82454, 14625, 14608, 82479
29982, 80856, 14421, 14413, 80864, 80857, 14422, 14414, 80865, 82706, 14624, 82714, 82480, 82707, 14626, 82715, 
82483, 82457, 14627, 14610, 82482
29983, 80857, 14422, 14414, 80865, 80858, 14423, 14415, 80866, 82707, 14626, 82715, 82483, 82708, 14628, 82716, 
82486, 82460, 14629, 14612, 82485
29984, 80858, 14423, 14415, 80866, 80859, 14424, 14416, 80867, 82708, 14628, 82716, 82486, 82709, 14630, 82717, 
82489, 82463, 14631, 14614, 82488
29985, 80859, 14424, 14416, 80867, 80860, 14425, 14417, 80868, 82709, 14630, 82717, 82489, 82710, 14632, 82718, 
82492, 82466, 14633, 14616, 82491
29986, 80860, 14425, 14417, 80868, 80861, 14426, 14418, 80869, 82710, 14632, 82718, 82492, 82711, 14634, 82719, 
82495, 82469, 14635, 14618, 82494
29987, 80861, 14426, 14418, 80869, 80862, 14427, 14419, 80870, 82711, 14634, 82719, 82495, 82712, 14636, 82720, 
82498, 82472, 14637, 14620, 82497
29988, 80862, 14427, 14419, 80870, 80863, 14428, 14420, 80871, 82712, 14636, 82720, 82498, 82713, 14638, 82721, 
82501, 82475, 14639, 14622, 82500
29989, 80863, 14428, 14420, 80871, 14153, 1901, 1900, 14154, 82713, 14638, 82721, 82501, 14310, 1923, 14311, 
14285, 82478, 14640, 14623, 82503
29990, 13931, 1848, 1847, 13932, 80864, 14413, 14405, 80872, 14088, 1870, 14089, 14065, 82714, 14607, 82722, 
82505, 82479, 14608, 14591, 82504
29991, 80864, 14413, 14405, 80872, 80865, 14414, 14406, 80873, 82714, 14607, 82722, 82505, 82715, 14609, 82723, 
82508, 82482, 14610, 14593, 82507
29992, 80865, 14414, 14406, 80873, 80866, 14415, 14407, 80874, 82715, 14609, 82723, 82508, 82716, 14611, 82724, 
82511, 82485, 14612, 14595, 82510
29993, 80866, 14415, 14407, 80874, 80867, 14416, 14408, 80875, 82716, 14611, 82724, 82511, 82717, 14613, 82725, 
82514, 82488, 14614, 14597, 82513
29994, 80867, 14416, 14408, 80875, 80868, 14417, 14409, 80876, 82717, 14613, 82725, 82514, 82718, 14615, 82726, 
82517, 82491, 14616, 14599, 82516
29995, 80868, 14417, 14409, 80876, 80869, 14418, 14410, 80877, 82718, 14615, 82726, 82517, 82719, 14617, 82727, 
82520, 82494, 14618, 14601, 82519
29996, 80869, 14418, 14410, 80877, 80870, 14419, 14411, 80878, 82719, 14617, 82727, 82520, 82720, 14619, 82728, 
82523, 82497, 14620, 14603, 82522
29997, 80870, 14419, 14411, 80878, 80871, 14420, 14412, 80879, 82720, 14619, 82728, 82523, 82721, 14621, 82729, 
82526, 82500, 14622, 14605, 82525
29998, 80871, 14420, 14412, 80879, 14154, 1900, 1899, 14155, 82721, 14621, 82729, 82526, 14311, 1922, 14312, 
14287, 82503, 14623, 14606, 82528
29999, 13932, 1847, 1846, 13933, 80872, 14405, 14397, 80880, 14089, 1869, 14090, 14067, 82722, 14590, 82730, 
82530, 82504, 14591, 14574, 82529
30000, 80872, 14405, 14397, 80880, 80873, 14406, 14398, 80881, 82722, 14590, 82730, 82530, 82723, 14592, 82731, 
82533, 82507, 14593, 14576, 82532
30001, 80873, 14406, 14398, 80881, 80874, 14407, 14399, 80882, 82723, 14592, 82731, 82533, 82724, 14594, 82732, 
82536, 82510, 14595, 14578, 82535
30002, 80874, 14407, 14399, 80882, 80875, 14408, 14400, 80883, 82724, 14594, 82732, 82536, 82725, 14596, 82733, 
82539, 82513, 14597, 14580, 82538
30003, 80875, 14408, 14400, 80883, 80876, 14409, 14401, 80884, 82725, 14596, 82733, 82539, 82726, 14598, 82734, 
82542, 82516, 14599, 14582, 82541
30004, 80876, 14409, 14401, 80884, 80877, 14410, 14402, 80885, 82726, 14598, 82734, 82542, 82727, 14600, 82735, 
82545, 82519, 14601, 14584, 82544
30005, 80877, 14410, 14402, 80885, 80878, 14411, 14403, 80886, 82727, 14600, 82735, 82545, 82728, 14602, 82736, 
82548, 82522, 14603, 14586, 82547
30006, 80878, 14411, 14403, 80886, 80879, 14412, 14404, 80887, 82728, 14602, 82736, 82548, 82729, 14604, 82737, 
82551, 82525, 14605, 14588, 82550
30007, 80879, 14412, 14404, 80887, 14155, 1899, 1898, 14156, 82729, 14604, 82737, 82551, 14312, 1921, 14313, 
14289, 82528, 14606, 14589, 82553
30008, 13933, 1846, 61, 1841, 80880, 14397, 1943, 14337, 14090, 1868, 1845, 14068, 82730, 14573, 14396, 
82554, 82529, 14574, 1951, 14388
30009, 80880, 14397, 1943, 14337, 80881, 14398, 1944, 14336, 82730, 14573, 14396, 82554, 82731, 14575, 14395, 
82555, 82532, 14576, 1952, 14386
30010, 80881, 14398, 1944, 14336, 80882, 14399, 1945, 14335, 82731, 14575, 14395, 82555, 82732, 14577, 14394, 
82556, 82535, 14578, 1953, 14384
30011, 80882, 14399, 1945, 14335, 80883, 14400, 1946, 14334, 82732, 14577, 14394, 82556, 82733, 14579, 14393, 
82557, 82538, 14580, 1954, 14382
30012, 80883, 14400, 1946, 14334, 80884, 14401, 1947, 14333, 82733, 14579, 14393, 82557, 82734, 14581, 14392, 
82558, 82541, 14582, 1955, 14380
30013, 80884, 14401, 1947, 14333, 80885, 14402, 1948, 14332, 82734, 14581, 14392, 82558, 82735, 14583, 14391, 
82559, 82544, 14584, 1956, 14378
30014, 80885, 14402, 1948, 14332, 80886, 14403, 1949, 14331, 82735, 14583, 14391, 82559, 82736, 14585, 14390, 
82560, 82547, 14586, 1957, 14376
30015, 80886, 14403, 1949, 14331, 80887, 14404, 1950, 14330, 82736, 14585, 14390, 82560, 82737, 14587, 14389, 
82561, 82550, 14588, 1958, 14374
30016, 80887, 14404, 1950, 14330, 14156, 1898, 62, 1893, 82737, 14587, 14389, 82561, 14313, 1920, 1897, 
14291, 82553, 14589, 1959, 14372
*ELEMENT, type=C3D20, ELSET=Volume21
30017, 50, 1763, 13553, 1698, 1552, 13619, 82738, 13412, 1766, 13563, 13562, 1701, 13644, 82811, 82812, 
13437, 1561, 13643, 82810, 13436
30018, 1552, 13619, 82738, 13412, 1551, 13620, 82739, 13413, 13644, 82811, 82812, 13437, 13646, 82814, 82815, 
13439, 1560, 13645, 82813, 13438
30019, 1551, 13620, 82739, 13413, 1550, 13621, 82740, 13414, 13646, 82814, 82815, 13439, 13648, 82817, 82818, 
13441, 1559, 13647, 82816, 13440
30020, 1550, 13621, 82740, 13414, 1549, 13622, 82741, 13415, 13648, 82817, 82818, 13441, 13650, 82820, 82821, 
13443, 1558, 13649, 82819, 13442
30021, 1549, 13622, 82741, 13415, 1548, 13623, 82742, 13416, 13650, 82820, 82821, 13443, 13652, 82823, 82824, 
13445, 1557, 13651, 82822, 13444
30022, 1548, 13623, 82742, 13416, 1547, 13624, 82743, 13417, 13652, 82823, 82824, 13445, 13654, 82826, 82827, 
13447, 1556, 13653, 82825, 13446
30023, 1547, 13624, 82743, 13417, 1546, 13625, 82744, 13418, 13654, 82826, 82827, 13447, 13656, 82829, 82830, 
13449, 1555, 13655, 82828, 13448
30024, 1546, 13625, 82744, 13418, 1545, 13626, 82745, 13419, 13656, 82829, 82830, 13449, 13658, 82832, 82833, 
13451, 1554, 13657, 82831, 13450
30025, 1545, 13626, 82745, 13419, 46, 1784, 13586, 1717, 13658, 82832, 82833, 13451, 1787, 13595, 13596, 
1720, 1553, 13659, 82834, 13452
30026, 1698, 13553, 13554, 1699, 13412, 82738, 82746, 13420, 13562, 13565, 13564, 1702, 82812, 82836, 82837, 
13454, 13436, 82810, 82835, 13453
30027, 13412, 82738, 82746, 13420, 13413, 82739, 82747, 13421, 82812, 82836, 82837, 13454, 82815, 82839, 82840, 
13456, 13438, 82813, 82838, 13455
30028, 13413, 82739, 82747, 13421, 13414, 82740, 82748, 13422, 82815, 82839, 82840, 13456, 82818, 82842, 82843, 
13458, 13440, 82816, 82841, 13457
30029, 13414, 82740, 82748, 13422, 13415, 82741, 82749, 13423, 82818, 82842, 82843, 13458, 82821, 82845, 82846, 
13460, 13442, 82819, 82844, 13459
30030, 13415, 82741, 82749, 13423, 13416, 82742, 82750, 13424, 82821, 82845, 82846, 13460, 82824, 82848, 82849, 
13462, 13444, 82822, 82847, 13461
30031, 13416, 82742, 82750, 13424, 13417, 82743, 82751, 13425, 82824, 82848, 82849, 13462, 82827, 82851, 82852, 
13464, 13446, 82825, 82850, 13463
30032, 13417, 82743, 82751, 13425, 13418, 82744, 82752, 13426, 82827, 82851, 82852, 13464, 82830, 82854, 82855, 
13466, 13448, 82828, 82853, 13465
30033, 13418, 82744, 82752, 13426, 13419, 82745, 82753, 13427, 82830, 82854, 82855, 13466, 82833, 82857, 82858, 
13468, 13450, 82831, 82856, 13467
30034, 13419, 82745, 82753, 13427, 1717, 13586, 13587, 1718, 82833, 82857, 82858, 13468, 13596, 13597, 13598, 
1721, 13452, 82834, 82859, 13469
30035, 1699, 13554, 13555, 1700, 13420, 82746, 82754, 13428, 13564, 13567, 13566, 1703, 82837, 82861, 82862, 
13471, 13453, 82835, 82860, 13470
30036, 13420, 82746, 82754, 13428, 13421, 82747, 82755, 13429, 82837, 82861, 82862, 13471, 82840, 82864, 82865, 
13473, 13455, 82838, 82863, 13472
30037, 13421, 82747, 82755, 13429, 13422, 82748, 82756, 13430, 82840, 82864, 82865, 13473, 82843, 82867, 82868, 
13475, 13457, 82841, 82866, 13474
30038, 13422, 82748, 82756, 13430, 13423, 82749, 82757, 13431, 82843, 82867, 82868, 13475, 82846, 82870, 82871, 
13477, 13459, 82844, 82869, 13476
30039, 13423, 82749, 82757, 13431, 13424, 82750, 82758, 13432, 82846, 82870, 82871, 13477, 82849, 82873, 82874, 
13479, 13461, 82847, 82872, 13478
30040, 13424, 82750, 82758, 13432, 13425, 82751, 82759, 13433, 82849, 82873, 82874, 13479, 82852, 82876, 82877, 
13481, 13463, 82850, 82875, 13480
30041, 13425, 82751, 82759, 13433, 13426, 82752, 82760, 13434, 82852, 82876, 82877, 13481, 82855, 82879, 82880, 
13483, 13465, 82853, 82878, 13482
30042, 13426, 82752, 82760, 13434, 13427, 82753, 82761, 13435, 82855, 82879, 82880, 13483, 82858, 82882, 82883, 
13485, 13467, 82856, 82881, 13484
30043, 13427, 82753, 82761, 13435, 1718, 13587, 13588, 1719, 82858, 82882, 82883, 13485, 13598, 13599, 13600, 
1722, 13469, 82859, 82884, 13486
30044, 1700, 13555, 1770, 54, 13428, 82754, 13702, 1753, 13566, 13568, 1773, 1704, 82862, 82885, 13726, 
13487, 13470, 82860, 13727, 1762
30045, 13428, 82754, 13702, 1753, 13429, 82755, 13703, 1752, 82862, 82885, 13726, 13487, 82865, 82886, 13728, 
13488, 13472, 82863, 13729, 1761
30046, 13429, 82755, 13703, 1752, 13430, 82756, 13704, 1751, 82865, 82886, 13728, 13488, 82868, 82887, 13730, 
13489, 13474, 82866, 13731, 1760
30047, 13430, 82756, 13704, 1751, 13431, 82757, 13705, 1750, 82868, 82887, 13730, 13489, 82871, 82888, 13732, 
13490, 13476, 82869, 13733, 1759
30048, 13431, 82757, 13705, 1750, 13432, 82758, 13706, 1749, 82871, 82888, 13732, 13490, 82874, 82889, 13734, 
13491, 13478, 82872, 13735, 1758
30049, 13432, 82758, 13706, 1749, 13433, 82759, 13707, 1748, 82874, 82889, 13734, 13491, 82877, 82890, 13736, 
13492, 13480, 82875, 13737, 1757
30050, 13433, 82759, 13707, 1748, 13434, 82760, 13708, 1747, 82877, 82890, 13736, 13492, 82880, 82891, 13738, 
13493, 13482, 82878, 13739, 1756
30051, 13434, 82760, 13708, 1747, 13435, 82761, 13709, 1746, 82880, 82891, 13738, 13493, 82883, 82892, 13740, 
13494, 13484, 82881, 13741, 1755
30052, 13435, 82761, 13709, 1746, 1719, 13588, 1791, 56, 82883, 82892, 13740, 13494, 13600, 13601, 1794, 
1723, 13486, 82884, 13742, 1754
30053, 1763, 1764, 13556, 13553, 13619, 13627, 82762, 82738, 1767, 13570, 13569, 13563, 13661, 82894, 82895, 
82811, 13643, 13660, 82893, 82810
30054, 13619, 13627, 82762, 82738, 13620, 13628, 82763, 82739, 13661, 82894, 82895, 82811, 13663, 82897, 82898, 
82814, 13645, 13662, 82896, 82813
30055, 13620, 13628, 82763, 82739, 13621, 13629, 82764, 82740, 13663, 82897, 82898, 82814, 13665, 82900, 82901, 
82817, 13647, 13664, 82899, 82816
30056, 13621, 13629, 82764, 82740, 13622, 13630, 82765, 82741, 13665, 82900, 82901, 82817, 13667, 82903, 82904, 
82820, 13649, 13666, 82902, 82819
30057, 13622, 13630, 82765, 82741, 13623, 13631, 82766, 82742, 13667, 82903, 82904, 82820, 13669, 82906, 82907, 
82823, 13651, 13668, 82905, 82822
30058, 13623, 13631, 82766, 82742, 13624, 13632, 82767, 82743, 13669, 82906, 82907, 82823, 13671, 82909, 82910, 
82826, 13653, 13670, 82908, 82825
30059, 13624, 13632, 82767, 82743, 13625, 13633, 82768, 82744, 13671, 82909, 82910, 82826, 13673, 82912, 82913, 
82829, 13655, 13672, 82911, 82828
30060, 13625, 13633, 82768, 82744, 13626, 13634, 82769, 82745, 13673, 82912, 82913, 82829, 13675, 82915, 82916, 
82832, 13657, 13674, 82914, 82831
30061, 13626, 13634, 82769, 82745, 1784, 1785, 13589, 13586, 13675, 82915, 82916, 82832, 1788, 13602, 13603, 
13595, 13659, 13676, 82917, 82834
30062, 13553, 13556, 13557, 13554, 82738, 82762, 82770, 82746, 13569, 13572, 13571, 13565, 82895, 82919, 82920, 
82836, 82810, 82893, 82918, 82835
30063, 82738, 82762, 82770, 82746, 82739, 82763, 82771, 82747, 82895, 82919, 82920, 82836, 82898, 82922, 82923, 
82839, 82813, 82896, 82921, 82838
30064, 82739, 82763, 82771, 82747, 82740, 82764, 82772, 82748, 82898, 82922, 82923, 82839, 82901, 82925, 82926, 
82842, 82816, 82899, 82924, 82841
30065, 82740, 82764, 82772, 82748, 82741, 82765, 82773, 82749, 82901, 82925, 82926, 82842, 82904, 82928, 82929, 
82845, 82819, 82902, 82927, 82844
30066, 82741, 82765, 82773, 82749, 82742, 82766, 82774, 82750, 82904, 82928, 82929, 82845, 82907, 82931, 82932, 
82848, 82822, 82905, 82930, 82847
30067, 82742, 82766, 82774, 82750, 82743, 82767, 82775, 82751, 82907, 82931, 82932, 82848, 82910, 82934, 82935, 
82851, 82825, 82908, 82933, 82850
30068, 82743, 82767, 82775, 82751, 82744, 82768, 82776, 82752, 82910, 82934, 82935, 82851, 82913, 82937, 82938, 
82854, 82828, 82911, 82936, 82853
30069, 82744, 82768, 82776, 82752, 82745, 82769, 82777, 82753, 82913, 82937, 82938, 82854, 82916, 82940, 82941, 
82857, 82831, 82914, 82939, 82856
30070, 82745, 82769, 82777, 82753, 13586, 13589, 13590, 13587, 82916, 82940, 82941, 82857, 13603, 13604, 13605, 
13597, 82834, 82917, 82942, 82859
30071, 13554, 13557, 13558, 13555, 82746, 82770, 82778, 82754, 13571, 13574, 13573, 13567, 82920, 82944, 82945, 
82861, 82835, 82918, 82943, 82860
30072, 82746, 82770, 82778, 82754, 82747, 82771, 82779, 82755, 82920, 82944, 82945, 82861, 82923, 82947, 82948, 
82864, 82838, 82921, 82946, 82863
30073, 82747, 82771, 82779, 82755, 82748, 82772, 82780, 82756, 82923, 82947, 82948, 82864, 82926, 82950, 82951, 
82867, 82841, 82924, 82949, 82866
30074, 82748, 82772, 82780, 82756, 82749, 82773, 82781, 82757, 82926, 82950, 82951, 82867, 82929, 82953, 82954, 
82870, 82844, 82927, 82952, 82869
30075, 82749, 82773, 82781, 82757, 82750, 82774, 82782, 82758, 82929, 82953, 82954, 82870, 82932, 82956, 82957, 
82873, 82847, 82930, 82955, 82872
30076, 82750, 82774, 82782, 82758, 82751, 82775, 82783, 82759, 82932, 82956, 82957, 82873, 82935, 82959, 82960, 
82876, 82850, 82933, 82958, 82875
30077, 82751, 82775, 82783, 82759, 82752, 82776, 82784, 82760, 82935, 82959, 82960, 82876, 82938, 82962, 82963, 
82879, 82853, 82936, 82961, 82878
30078, 82752, 82776, 82784, 82760, 82753, 82777, 82785, 82761, 82938, 82962, 82963, 82879, 82941, 82965, 82966, 
82882, 82856, 82939, 82964, 82881
30079, 82753, 82777, 82785, 82761, 13587, 13590, 13591, 13588, 82941, 82965, 82966, 82882, 13605, 13606, 13607, 
13599, 82859, 82942, 82967, 82884
30080, 13555, 13558, 1771, 1770, 82754, 82778, 13710, 13702, 13573, 13575, 1774, 13568, 82945, 82968, 13743, 
82885, 82860, 82943, 13744, 13727
30081, 82754, 82778, 13710, 13702, 82755, 82779, 13711, 13703, 82945, 82968, 13743, 82885, 82948, 82969, 13745, 
82886, 82863, 82946, 13746, 13729
30082, 82755, 82779, 13711, 13703, 82756, 82780, 13712, 13704, 82948, 82969, 13745, 82886, 82951, 82970, 13747, 
82887, 82866, 82949, 13748, 13731
30083, 82756, 82780, 13712, 13704, 82757, 82781, 13713, 13705, 82951, 82970, 13747, 82887, 82954, 82971, 13749, 
82888, 82869, 82952, 13750, 13733
30084, 82757, 82781, 13713, 13705, 82758, 82782, 13714, 13706, 82954, 82971, 13749, 82888, 82957, 82972, 13751, 
82889, 82872, 82955, 13752, 13735
30085, 82758, 82782, 13714, 13706, 82759, 82783, 13715, 13707, 82957, 82972, 13751, 82889, 82960, 82973, 13753, 
82890, 82875, 82958, 13754, 13737
30086, 82759, 82783, 13715, 13707, 82760, 82784, 13716, 13708, 82960, 82973, 13753, 82890, 82963, 82974, 13755, 
82891, 82878, 82961, 13756, 13739
30087, 82760, 82784, 13716, 13708, 82761, 82785, 13717, 13709, 82963, 82974, 13755, 82891, 82966, 82975, 13757, 
82892, 82881, 82964, 13758, 13741
30088, 82761, 82785, 13717, 13709, 13588, 13591, 1792, 1791, 82966, 82975, 13757, 82892, 13607, 13608, 1795, 
13601, 82884, 82967, 13759, 13742
30089, 1764, 1765, 13559, 13556, 13627, 13635, 82786, 82762, 1768, 13577, 13576, 13570, 13678, 82977, 82978, 
82894, 13660, 13677, 82976, 82893
30090, 13627, 13635, 82786, 82762, 13628, 13636, 82787, 82763, 13678, 82977, 82978, 82894, 13680, 82980, 82981, 
82897, 13662, 13679, 82979, 82896
30091, 13628, 13636, 82787, 82763, 13629, 13637, 82788, 82764, 13680, 82980, 82981, 82897, 13682, 82983, 82984, 
82900, 13664, 13681, 82982, 82899
30092, 13629, 13637, 82788, 82764, 13630, 13638, 82789, 82765, 13682, 82983, 82984, 82900, 13684, 82986, 82987, 
82903, 13666, 13683, 82985, 82902
30093, 13630, 13638, 82789, 82765, 13631, 13639, 82790, 82766, 13684, 82986, 82987, 82903, 13686, 82989, 82990, 
82906, 13668, 13685, 82988, 82905
30094, 13631, 13639, 82790, 82766, 13632, 13640, 82791, 82767, 13686, 82989, 82990, 82906, 13688, 82992, 82993, 
82909, 13670, 13687, 82991, 82908
30095, 13632, 13640, 82791, 82767, 13633, 13641, 82792, 82768, 13688, 82992, 82993, 82909, 13690, 82995, 82996, 
82912, 13672, 13689, 82994, 82911
30096, 13633, 13641, 82792, 82768, 13634, 13642, 82793, 82769, 13690, 82995, 82996, 82912, 13692, 82998, 82999, 
82915, 13674, 13691, 82997, 82914
30097, 13634, 13642, 82793, 82769, 1785, 1786, 13592, 13589, 13692, 82998, 82999, 82915, 1789, 13609, 13610, 
13602, 13676, 13693, 83000, 82917
30098, 13556, 13559, 13560, 13557, 82762, 82786, 82794, 82770, 13576, 13579, 13578, 13572, 82978, 83002, 83003, 
82919, 82893, 82976, 83001, 82918
30099, 82762, 82786, 82794, 82770, 82763, 82787, 82795, 82771, 82978, 83002, 83003, 82919, 82981, 83005, 83006, 
82922, 82896, 82979, 83004, 82921
30100, 82763, 82787, 82795, 82771, 82764, 82788, 82796, 82772, 82981, 83005, 83006, 82922, 82984, 83008, 83009, 
82925, 82899, 82982, 83007, 82924
30101, 82764, 82788, 82796, 82772, 82765, 82789, 82797, 82773, 82984, 83008, 83009, 82925, 82987, 83011, 83012, 
82928, 82902, 82985, 83010, 82927
30102, 82765, 82789, 82797, 82773, 82766, 82790, 82798, 82774, 82987, 83011, 83012, 82928, 82990, 83014, 83015, 
82931, 82905, 82988, 83013, 82930
30103, 82766, 82790, 82798, 82774, 82767, 82791, 82799, 82775, 82990, 83014, 83015, 82931, 82993, 83017, 83018, 
82934, 82908, 82991, 83016, 82933
30104, 82767, 82791, 82799, 82775, 82768, 82792, 82800, 82776, 82993, 83017, 83018, 82934, 82996, 83020, 83021, 
82937, 82911, 82994, 83019, 82936
30105, 82768, 82792, 82800, 82776, 82769, 82793, 82801, 82777, 82996, 83020, 83021, 82937, 82999, 83023, 83024, 
82940, 82914, 82997, 83022, 82939
30106, 82769, 82793, 82801, 82777, 13589, 13592, 13593, 13590, 82999, 83023, 83024, 82940, 13610, 13611, 13612, 
13604, 82917, 83000, 83025, 82942
30107, 13557, 13560, 13561, 13558, 82770, 82794, 82802, 82778, 13578, 13581, 13580, 13574, 83003, 83027, 83028, 
82944, 82918, 83001, 83026, 82943
30108, 82770, 82794, 82802, 82778, 82771, 82795, 82803, 82779, 83003, 83027, 83028, 82944, 83006, 83030, 83031, 
82947, 82921, 83004, 83029, 82946
30109, 82771, 82795, 82803, 82779, 82772, 82796, 82804, 82780, 83006, 83030, 83031, 82947, 83009, 83033, 83034, 
82950, 82924, 83007, 83032, 82949
30110, 82772, 82796, 82804, 82780, 82773, 82797, 82805, 82781, 83009, 83033, 83034, 82950, 83012, 83036, 83037, 
82953, 82927, 83010, 83035, 82952
30111, 82773, 82797, 82805, 82781, 82774, 82798, 82806, 82782, 83012, 83036, 83037, 82953, 83015, 83039, 83040, 
82956, 82930, 83013, 83038, 82955
30112, 82774, 82798, 82806, 82782, 82775, 82799, 82807, 82783, 83015, 83039, 83040, 82956, 83018, 83042, 83043, 
82959, 82933, 83016, 83041, 82958
30113, 82775, 82799, 82807, 82783, 82776, 82800, 82808, 82784, 83018, 83042, 83043, 82959, 83021, 83045, 83046, 
82962, 82936, 83019, 83044, 82961
30114, 82776, 82800, 82808, 82784, 82777, 82801, 82809, 82785, 83021, 83045, 83046, 82962, 83024, 83048, 83049, 
82965, 82939, 83022, 83047, 82964
30115, 82777, 82801, 82809, 82785, 13590, 13593, 13594, 13591, 83024, 83048, 83049, 82965, 13612, 13613, 13614, 
13606, 82942, 83025, 83050, 82967
30116, 13558, 13561, 1772, 1771, 82778, 82802, 13718, 13710, 13580, 13582, 1775, 13575, 83028, 83051, 13760, 
82968, 82943, 83026, 13761, 13744
30117, 82778, 82802, 13718, 13710, 82779, 82803, 13719, 13711, 83028, 83051, 13760, 82968, 83031, 83052, 13762, 
82969, 82946, 83029, 13763, 13746
30118, 82779, 82803, 13719, 13711, 82780, 82804, 13720, 13712, 83031, 83052, 13762, 82969, 83034, 83053, 13764, 
82970, 82949, 83032, 13765, 13748
30119, 82780, 82804, 13720, 13712, 82781, 82805, 13721, 13713, 83034, 83053, 13764, 82970, 83037, 83054, 13766, 
82971, 82952, 83035, 13767, 13750
30120, 82781, 82805, 13721, 13713, 82782, 82806, 13722, 13714, 83037, 83054, 13766, 82971, 83040, 83055, 13768, 
82972, 82955, 83038, 13769, 13752
30121, 82782, 82806, 13722, 13714, 82783, 82807, 13723, 13715, 83040, 83055, 13768, 82972, 83043, 83056, 13770, 
82973, 82958, 83041, 13771, 13754
30122, 82783, 82807, 13723, 13715, 82784, 82808, 13724, 13716, 83043, 83056, 13770, 82973, 83046, 83057, 13772, 
82974, 82961, 83044, 13773, 13756
30123, 82784, 82808, 13724, 13716, 82785, 82809, 13725, 13717, 83046, 83057, 13772, 82974, 83049, 83058, 13774, 
82975, 82964, 83047, 13775, 13758
30124, 82785, 82809, 13725, 13717, 13591, 13594, 1793, 1792, 83049, 83058, 13774, 82975, 13614, 13615, 1796, 
13608, 82967, 83050, 13776, 13759
30125, 1765, 57, 1777, 13559, 13635, 1812, 13785, 82786, 1769, 1780, 13583, 13577, 13694, 13810, 83059, 
82977, 13677, 1821, 13809, 82976
30126, 13635, 1812, 13785, 82786, 13636, 1811, 13786, 82787, 13694, 13810, 83059, 82977, 13695, 13812, 83060, 
82980, 13679, 1820, 13811, 82979
30127, 13636, 1811, 13786, 82787, 13637, 1810, 13787, 82788, 13695, 13812, 83060, 82980, 13696, 13814, 83061, 
82983, 13681, 1819, 13813, 82982
30128, 13637, 1810, 13787, 82788, 13638, 1809, 13788, 82789, 13696, 13814, 83061, 82983, 13697, 13816, 83062, 
82986, 13683, 1818, 13815, 82985
30129, 13638, 1809, 13788, 82789, 13639, 1808, 13789, 82790, 13697, 13816, 83062, 82986, 13698, 13818, 83063, 
82989, 13685, 1817, 13817, 82988
30130, 13639, 1808, 13789, 82790, 13640, 1807, 13790, 82791, 13698, 13818, 83063, 82989, 13699, 13820, 83064, 
82992, 13687, 1816, 13819, 82991
30131, 13640, 1807, 13790, 82791, 13641, 1806, 13791, 82792, 13699, 13820, 83064, 82992, 13700, 13822, 83065, 
82995, 13689, 1815, 13821, 82994
30132, 13641, 1806, 13791, 82792, 13642, 1805, 13792, 82793, 13700, 13822, 83065, 82995, 13701, 13824, 83066, 
82998, 13691, 1814, 13823, 82997
30133, 13642, 1805, 13792, 82793, 1786, 59, 1798, 13592, 13701, 13824, 83066, 82998, 1790, 1801, 13616, 
13609, 13693, 1813, 13825, 83000
30134, 13559, 1777, 1778, 13560, 82786, 13785, 13793, 82794, 13583, 1781, 13584, 13579, 83059, 13827, 83067, 
83002, 82976, 13809, 13826, 83001
30135, 82786, 13785, 13793, 82794, 82787, 13786, 13794, 82795, 83059, 13827, 83067, 83002, 83060, 13829, 83068, 
83005, 82979, 13811, 13828, 83004
30136, 82787, 13786, 13794, 82795, 82788, 13787, 13795, 82796, 83060, 13829, 83068, 83005, 83061, 13831, 83069, 
83008, 82982, 13813, 13830, 83007
30137, 82788, 13787, 13795, 82796, 82789, 13788, 13796, 82797, 83061, 13831, 83069, 83008, 83062, 13833, 83070, 
83011, 82985, 13815, 13832, 83010
30138, 82789, 13788, 13796, 82797, 82790, 13789, 13797, 82798, 83062, 13833, 83070, 83011, 83063, 13835, 83071, 
83014, 82988, 13817, 13834, 83013
30139, 82790, 13789, 13797, 82798, 82791, 13790, 13798, 82799, 83063, 13835, 83071, 83014, 83064, 13837, 83072, 
83017, 82991, 13819, 13836, 83016
30140, 82791, 13790, 13798, 82799, 82792, 13791, 13799, 82800, 83064, 13837, 83072, 83017, 83065, 13839, 83073, 
83020, 82994, 13821, 13838, 83019
30141, 82792, 13791, 13799, 82800, 82793, 13792, 13800, 82801, 83065, 13839, 83073, 83020, 83066, 13841, 83074, 
83023, 82997, 13823, 13840, 83022
30142, 82793, 13792, 13800, 82801, 13592, 1798, 1799, 13593, 83066, 13841, 83074, 83023, 13616, 1802, 13617, 
13611, 83000, 13825, 13842, 83025
30143, 13560, 1778, 1779, 13561, 82794, 13793, 13801, 82802, 13584, 1782, 13585, 13581, 83067, 13844, 83075, 
83027, 83001, 13826, 13843, 83026
30144, 82794, 13793, 13801, 82802, 82795, 13794, 13802, 82803, 83067, 13844, 83075, 83027, 83068, 13846, 83076, 
83030, 83004, 13828, 13845, 83029
30145, 82795, 13794, 13802, 82803, 82796, 13795, 13803, 82804, 83068, 13846, 83076, 83030, 83069, 13848, 83077, 
83033, 83007, 13830, 13847, 83032
30146, 82796, 13795, 13803, 82804, 82797, 13796, 13804, 82805, 83069, 13848, 83077, 83033, 83070, 13850, 83078, 
83036, 83010, 13832, 13849, 83035
30147, 82797, 13796, 13804, 82805, 82798, 13797, 13805, 82806, 83070, 13850, 83078, 83036, 83071, 13852, 83079, 
83039, 83013, 13834, 13851, 83038
30148, 82798, 13797, 13805, 82806, 82799, 13798, 13806, 82807, 83071, 13852, 83079, 83039, 83072, 13854, 83080, 
83042, 83016, 13836, 13853, 83041
30149, 82799, 13798, 13806, 82807, 82800, 13799, 13807, 82808, 83072, 13854, 83080, 83042, 83073, 13856, 83081, 
83045, 83019, 13838, 13855, 83044
30150, 82800, 13799, 13807, 82808, 82801, 13800, 13808, 82809, 83073, 13856, 83081, 83045, 83074, 13858, 83082, 
83048, 83022, 13840, 13857, 83047
30151, 82801, 13800, 13808, 82809, 13593, 1799, 1800, 13594, 83074, 13858, 83082, 83048, 13617, 1803, 13618, 
13613, 83025, 13842, 13859, 83050
30152, 13561, 1779, 58, 1772, 82802, 13801, 1829, 13718, 13585, 1783, 1776, 13582, 83075, 13860, 13777, 
83051, 83026, 13843, 1838, 13761
30153, 82802, 13801, 1829, 13718, 82803, 13802, 1828, 13719, 83075, 13860, 13777, 83051, 83076, 13861, 13778, 
83052, 83029, 13845, 1837, 13763
30154, 82803, 13802, 1828, 13719, 82804, 13803, 1827, 13720, 83076, 13861, 13778, 83052, 83077, 13862, 13779, 
83053, 83032, 13847, 1836, 13765
30155, 82804, 13803, 1827, 13720, 82805, 13804, 1826, 13721, 83077, 13862, 13779, 83053, 83078, 13863, 13780, 
83054, 83035, 13849, 1835, 13767
30156, 82805, 13804, 1826, 13721, 82806, 13805, 1825, 13722, 83078, 13863, 13780, 83054, 83079, 13864, 13781, 
83055, 83038, 13851, 1834, 13769
30157, 82806, 13805, 1825, 13722, 82807, 13806, 1824, 13723, 83079, 13864, 13781, 83055, 83080, 13865, 13782, 
83056, 83041, 13853, 1833, 13771
30158, 82807, 13806, 1824, 13723, 82808, 13807, 1823, 13724, 83080, 13865, 13782, 83056, 83081, 13866, 13783, 
83057, 83044, 13855, 1832, 13773
30159, 82808, 13807, 1823, 13724, 82809, 13808, 1822, 13725, 83081, 13866, 13783, 83057, 83082, 13867, 13784, 
83058, 83047, 13857, 1831, 13775
30160, 82809, 13808, 1822, 13725, 13594, 1800, 60, 1793, 83082, 13867, 13784, 83058, 13618, 1804, 1797, 
13615, 83050, 13859, 1830, 13776
*ELEMENT, type=C3D20, ELSET=Volume22
30161, 54, 1770, 18220, 2399, 1753, 13702, 83083, 17604, 1773, 18287, 18286, 2421, 13726, 83612, 83613, 
17781, 1762, 13727, 83611, 17780
30162, 1753, 13702, 83083, 17604, 1752, 13703, 83084, 17605, 13726, 83612, 83613, 17781, 13728, 83615, 83616, 
17783, 1761, 13729, 83614, 17782
30163, 1752, 13703, 83084, 17605, 1751, 13704, 83085, 17606, 13728, 83615, 83616, 17783, 13730, 83618, 83619, 
17785, 1760, 13731, 83617, 17784
30164, 1751, 13704, 83085, 17606, 1750, 13705, 83086, 17607, 13730, 83618, 83619, 17785, 13732, 83621, 83622, 
17787, 1759, 13733, 83620, 17786
30165, 1750, 13705, 83086, 17607, 1749, 13706, 83087, 17608, 13732, 83621, 83622, 17787, 13734, 83624, 83625, 
17789, 1758, 13735, 83623, 17788
30166, 1749, 13706, 83087, 17608, 1748, 13707, 83088, 17609, 13734, 83624, 83625, 17789, 13736, 83627, 83628, 
17791, 1757, 13737, 83626, 17790
30167, 1748, 13707, 83088, 17609, 1747, 13708, 83089, 17610, 13736, 83627, 83628, 17791, 13738, 83630, 83631, 
17793, 1756, 13739, 83629, 17792
30168, 1747, 13708, 83089, 17610, 1746, 13709, 83090, 17611, 13738, 83630, 83631, 17793, 13740, 83633, 83634, 
17795, 1755, 13741, 83632, 17794
30169, 1746, 13709, 83090, 17611, 56, 1791, 18443, 2449, 13740, 83633, 83634, 17795, 1794, 18509, 18510, 
2471, 1754, 13742, 83635, 17796
30170, 2399, 18220, 18221, 2400, 17604, 83083, 83091, 17612, 18286, 18289, 18288, 2422, 83613, 83637, 83638, 
17798, 17780, 83611, 83636, 17797
30171, 17604, 83083, 83091, 17612, 17605, 83084, 83092, 17613, 83613, 83637, 83638, 17798, 83616, 83640, 83641, 
17800, 17782, 83614, 83639, 17799
30172, 17605, 83084, 83092, 17613, 17606, 83085, 83093, 17614, 83616, 83640, 83641, 17800, 83619, 83643, 83644, 
17802, 17784, 83617, 83642, 17801
30173, 17606, 83085, 83093, 17614, 17607, 83086, 83094, 17615, 83619, 83643, 83644, 17802, 83622, 83646, 83647, 
17804, 17786, 83620, 83645, 17803
30174, 17607, 83086, 83094, 17615, 17608, 83087, 83095, 17616, 83622, 83646, 83647, 17804, 83625, 83649, 83650, 
17806, 17788, 83623, 83648, 17805
30175, 17608, 83087, 83095, 17616, 17609, 83088, 83096, 17617, 83625, 83649, 83650, 17806, 83628, 83652, 83653, 
17808, 17790, 83626, 83651, 17807
30176, 17609, 83088, 83096, 17617, 17610, 83089, 83097, 17618, 83628, 83652, 83653, 17808, 83631, 83655, 83656, 
17810, 17792, 83629, 83654, 17809
30177, 17610, 83089, 83097, 17618, 17611, 83090, 83098, 17619, 83631, 83655, 83656, 17810, 83634, 83658, 83659, 
17812, 17794, 83632, 83657, 17811
30178, 17611, 83090, 83098, 17619, 2449, 18443, 18444, 2450, 83634, 83658, 83659, 17812, 18510, 18511, 18512, 
2472, 17796, 83635, 83660, 17813
30179, 2400, 18221, 18222, 2401, 17612, 83091, 83099, 17620, 18288, 18291, 18290, 2423, 83638, 83662, 83663, 
17815, 17797, 83636, 83661, 17814
30180, 17612, 83091, 83099, 17620, 17613, 83092, 83100, 17621, 83638, 83662, 83663, 17815, 83641, 83665, 83666, 
17817, 17799, 83639, 83664, 17816
30181, 17613, 83092, 83100, 17621, 17614, 83093, 83101, 17622, 83641, 83665, 83666, 17817, 83644, 83668, 83669, 
17819, 17801, 83642, 83667, 17818
30182, 17614, 83093, 83101, 17622, 17615, 83094, 83102, 17623, 83644, 83668, 83669, 17819, 83647, 83671, 83672, 
17821, 17803, 83645, 83670, 17820
30183, 17615, 83094, 83102, 17623, 17616, 83095, 83103, 17624, 83647, 83671, 83672, 17821, 83650, 83674, 83675, 
17823, 17805, 83648, 83673, 17822
30184, 17616, 83095, 83103, 17624, 17617, 83096, 83104, 17625, 83650, 83674, 83675, 17823, 83653, 83677, 83678, 
17825, 17807, 83651, 83676, 17824
30185, 17617, 83096, 83104, 17625, 17618, 83097, 83105, 17626, 83653, 83677, 83678, 17825, 83656, 83680, 83681, 
17827, 17809, 83654, 83679, 17826
30186, 17618, 83097, 83105, 17626, 17619, 83098, 83106, 17627, 83656, 83680, 83681, 17827, 83659, 83683, 83684, 
17829, 17811, 83657, 83682, 17828
30187, 17619, 83098, 83106, 17627, 2450, 18444, 18445, 2451, 83659, 83683, 83684, 17829, 18512, 18513, 18514, 
2473, 17813, 83660, 83685, 17830
30188, 2401, 18222, 18223, 2402, 17620, 83099, 83107, 17628, 18290, 18293, 18292, 2424, 83663, 83687, 83688, 
17832, 17814, 83661, 83686, 17831
30189, 17620, 83099, 83107, 17628, 17621, 83100, 83108, 17629, 83663, 83687, 83688, 17832, 83666, 83690, 83691, 
17834, 17816, 83664, 83689, 17833
30190, 17621, 83100, 83108, 17629, 17622, 83101, 83109, 17630, 83666, 83690, 83691, 17834, 83669, 83693, 83694, 
17836, 17818, 83667, 83692, 17835
30191, 17622, 83101, 83109, 17630, 17623, 83102, 83110, 17631, 83669, 83693, 83694, 17836, 83672, 83696, 83697, 
17838, 17820, 83670, 83695, 17837
30192, 17623, 83102, 83110, 17631, 17624, 83103, 83111, 17632, 83672, 83696, 83697, 17838, 83675, 83699, 83700, 
17840, 17822, 83673, 83698, 17839
30193, 17624, 83103, 83111, 17632, 17625, 83104, 83112, 17633, 83675, 83699, 83700, 17840, 83678, 83702, 83703, 
17842, 17824, 83676, 83701, 17841
30194, 17625, 83104, 83112, 17633, 17626, 83105, 83113, 17634, 83678, 83702, 83703, 17842, 83681, 83705, 83706, 
17844, 17826, 83679, 83704, 17843
30195, 17626, 83105, 83113, 17634, 17627, 83106, 83114, 17635, 83681, 83705, 83706, 17844, 83684, 83708, 83709, 
17846, 17828, 83682, 83707, 17845
30196, 17627, 83106, 83114, 17635, 2451, 18445, 18446, 2452, 83684, 83708, 83709, 17846, 18514, 18515, 18516, 
2474, 17830, 83685, 83710, 17847
30197, 2402, 18223, 18224, 2403, 17628, 83107, 83115, 17636, 18292, 18295, 18294, 2425, 83688, 83712, 83713, 
17849, 17831, 83686, 83711, 17848
30198, 17628, 83107, 83115, 17636, 17629, 83108, 83116, 17637, 83688, 83712, 83713, 17849, 83691, 83715, 83716, 
17851, 17833, 83689, 83714, 17850
30199, 17629, 83108, 83116, 17637, 17630, 83109, 83117, 17638, 83691, 83715, 83716, 17851, 83694, 83718, 83719, 
17853, 17835, 83692, 83717, 17852
30200, 17630, 83109, 83117, 17638, 17631, 83110, 83118, 17639, 83694, 83718, 83719, 17853, 83697, 83721, 83722, 
17855, 17837, 83695, 83720, 17854
30201, 17631, 83110, 83118, 17639, 17632, 83111, 83119, 17640, 83697, 83721, 83722, 17855, 83700, 83724, 83725, 
17857, 17839, 83698, 83723, 17856
30202, 17632, 83111, 83119, 17640, 17633, 83112, 83120, 17641, 83700, 83724, 83725, 17857, 83703, 83727, 83728, 
17859, 17841, 83701, 83726, 17858
30203, 17633, 83112, 83120, 17641, 17634, 83113, 83121, 17642, 83703, 83727, 83728, 17859, 83706, 83730, 83731, 
17861, 17843, 83704, 83729, 17860
30204, 17634, 83113, 83121, 17642, 17635, 83114, 83122, 17643, 83706, 83730, 83731, 17861, 83709, 83733, 83734, 
17863, 17845, 83707, 83732, 17862
30205, 17635, 83114, 83122, 17643, 2452, 18446, 18447, 2453, 83709, 83733, 83734, 17863, 18516, 18517, 18518, 
2475, 17847, 83710, 83735, 17864
30206, 2403, 18224, 18225, 2404, 17636, 83115, 83123, 17644, 18294, 18297, 18296, 2426, 83713, 83737, 83738, 
17866, 17848, 83711, 83736, 17865
30207, 17636, 83115, 83123, 17644, 17637, 83116, 83124, 17645, 83713, 83737, 83738, 17866, 83716, 83740, 83741, 
17868, 17850, 83714, 83739, 17867
30208, 17637, 83116, 83124, 17645, 17638, 83117, 83125, 17646, 83716, 83740, 83741, 17868, 83719, 83743, 83744, 
17870, 17852, 83717, 83742, 17869
30209, 17638, 83117, 83125, 17646, 17639, 83118, 83126, 17647, 83719, 83743, 83744, 17870, 83722, 83746, 83747, 
17872, 17854, 83720, 83745, 17871
30210, 17639, 83118, 83126, 17647, 17640, 83119, 83127, 17648, 83722, 83746, 83747, 17872, 83725, 83749, 83750, 
17874, 17856, 83723, 83748, 17873
30211, 17640, 83119, 83127, 17648, 17641, 83120, 83128, 17649, 83725, 83749, 83750, 17874, 83728, 83752, 83753, 
17876, 17858, 83726, 83751, 17875
30212, 17641, 83120, 83128, 17649, 17642, 83121, 83129, 17650, 83728, 83752, 83753, 17876, 83731, 83755, 83756, 
17878, 17860, 83729, 83754, 17877
30213, 17642, 83121, 83129, 17650, 17643, 83122, 83130, 17651, 83731, 83755, 83756, 17878, 83734, 83758, 83759, 
17880, 17862, 83732, 83757, 17879
30214, 17643, 83122, 83130, 17651, 2453, 18447, 18448, 2454, 83734, 83758, 83759, 17880, 18518, 18519, 18520, 
2476, 17864, 83735, 83760, 17881
30215, 2404, 18225, 18226, 2405, 17644, 83123, 83131, 17652, 18296, 18299, 18298, 2427, 83738, 83762, 83763, 
17883, 17865, 83736, 83761, 17882
30216, 17644, 83123, 83131, 17652, 17645, 83124, 83132, 17653, 83738, 83762, 83763, 17883, 83741, 83765, 83766, 
17885, 17867, 83739, 83764, 17884
30217, 17645, 83124, 83132, 17653, 17646, 83125, 83133, 17654, 83741, 83765, 83766, 17885, 83744, 83768, 83769, 
17887, 17869, 83742, 83767, 17886
30218, 17646, 83125, 83133, 17654, 17647, 83126, 83134, 17655, 83744, 83768, 83769, 17887, 83747, 83771, 83772, 
17889, 17871, 83745, 83770, 17888
30219, 17647, 83126, 83134, 17655, 17648, 83127, 83135, 17656, 83747, 83771, 83772, 17889, 83750, 83774, 83775, 
17891, 17873, 83748, 83773, 17890
30220, 17648, 83127, 83135, 17656, 17649, 83128, 83136, 17657, 83750, 83774, 83775, 17891, 83753, 83777, 83778, 
17893, 17875, 83751, 83776, 17892
30221, 17649, 83128, 83136, 17657, 17650, 83129, 83137, 17658, 83753, 83777, 83778, 17893, 83756, 83780, 83781, 
17895, 17877, 83754, 83779, 17894
30222, 17650, 83129, 83137, 17658, 17651, 83130, 83138, 17659, 83756, 83780, 83781, 17895, 83759, 83783, 83784, 
17897, 17879, 83757, 83782, 17896
30223, 17651, 83130, 83138, 17659, 2454, 18448, 18449, 2455, 83759, 83783, 83784, 17897, 18520, 18521, 18522, 
2477, 17881, 83760, 83785, 17898
30224, 2405, 18226, 18227, 2406, 17652, 83131, 83139, 17660, 18298, 18301, 18300, 2428, 83763, 83787, 83788, 
17900, 17882, 83761, 83786, 17899
30225, 17652, 83131, 83139, 17660, 17653, 83132, 83140, 17661, 83763, 83787, 83788, 17900, 83766, 83790, 83791, 
17902, 17884, 83764, 83789, 17901
30226, 17653, 83132, 83140, 17661, 17654, 83133, 83141, 17662, 83766, 83790, 83791, 17902, 83769, 83793, 83794, 
17904, 17886, 83767, 83792, 17903
30227, 17654, 83133, 83141, 17662, 17655, 83134, 83142, 17663, 83769, 83793, 83794, 17904, 83772, 83796, 83797, 
17906, 17888, 83770, 83795, 17905
30228, 17655, 83134, 83142, 17663, 17656, 83135, 83143, 17664, 83772, 83796, 83797, 17906, 83775, 83799, 83800, 
17908, 17890, 83773, 83798, 17907
30229, 17656, 83135, 83143, 17664, 17657, 83136, 83144, 17665, 83775, 83799, 83800, 17908, 83778, 83802, 83803, 
17910, 17892, 83776, 83801, 17909
30230, 17657, 83136, 83144, 17665, 17658, 83137, 83145, 17666, 83778, 83802, 83803, 17910, 83781, 83805, 83806, 
17912, 17894, 83779, 83804, 17911
30231, 17658, 83137, 83145, 17666, 17659, 83138, 83146, 17667, 83781, 83805, 83806, 17912, 83784, 83808, 83809, 
17914, 17896, 83782, 83807, 17913
30232, 17659, 83138, 83146, 17667, 2455, 18449, 18450, 2456, 83784, 83808, 83809, 17914, 18522, 18523, 18524, 
2478, 17898, 83785, 83810, 17915
30233, 2406, 18227, 18228, 2407, 17660, 83139, 83147, 17668, 18300, 18303, 18302, 2429, 83788, 83812, 83813, 
17917, 17899, 83786, 83811, 17916
30234, 17660, 83139, 83147, 17668, 17661, 83140, 83148, 17669, 83788, 83812, 83813, 17917, 83791, 83815, 83816, 
17919, 17901, 83789, 83814, 17918
30235, 17661, 83140, 83148, 17669, 17662, 83141, 83149, 17670, 83791, 83815, 83816, 17919, 83794, 83818, 83819, 
17921, 17903, 83792, 83817, 17920
30236, 17662, 83141, 83149, 17670, 17663, 83142, 83150, 17671, 83794, 83818, 83819, 17921, 83797, 83821, 83822, 
17923, 17905, 83795, 83820, 17922
30237, 17663, 83142, 83150, 17671, 17664, 83143, 83151, 17672, 83797, 83821, 83822, 17923, 83800, 83824, 83825, 
17925, 17907, 83798, 83823, 17924
30238, 17664, 83143, 83151, 17672, 17665, 83144, 83152, 17673, 83800, 83824, 83825, 17925, 83803, 83827, 83828, 
17927, 17909, 83801, 83826, 17926
30239, 17665, 83144, 83152, 17673, 17666, 83145, 83153, 17674, 83803, 83827, 83828, 17927, 83806, 83830, 83831, 
17929, 17911, 83804, 83829, 17928
30240, 17666, 83145, 83153, 17674, 17667, 83146, 83154, 17675, 83806, 83830, 83831, 17929, 83809, 83833, 83834, 
17931, 17913, 83807, 83832, 17930
30241, 17667, 83146, 83154, 17675, 2456, 18450, 18451, 2457, 83809, 83833, 83834, 17931, 18524, 18525, 18526, 
2479, 17915, 83810, 83835, 17932
30242, 2407, 18228, 18229, 2408, 17668, 83147, 83155, 17676, 18302, 18305, 18304, 2430, 83813, 83837, 83838, 
17934, 17916, 83811, 83836, 17933
30243, 17668, 83147, 83155, 17676, 17669, 83148, 83156, 17677, 83813, 83837, 83838, 17934, 83816, 83840, 83841, 
17936, 17918, 83814, 83839, 17935
30244, 17669, 83148, 83156, 17677, 17670, 83149, 83157, 17678, 83816, 83840, 83841, 17936, 83819, 83843, 83844, 
17938, 17920, 83817, 83842, 17937
30245, 17670, 83149, 83157, 17678, 17671, 83150, 83158, 17679, 83819, 83843, 83844, 17938, 83822, 83846, 83847, 
17940, 17922, 83820, 83845, 17939
30246, 17671, 83150, 83158, 17679, 17672, 83151, 83159, 17680, 83822, 83846, 83847, 17940, 83825, 83849, 83850, 
17942, 17924, 83823, 83848, 17941
30247, 17672, 83151, 83159, 17680, 17673, 83152, 83160, 17681, 83825, 83849, 83850, 17942, 83828, 83852, 83853, 
17944, 17926, 83826, 83851, 17943
30248, 17673, 83152, 83160, 17681, 17674, 83153, 83161, 17682, 83828, 83852, 83853, 17944, 83831, 83855, 83856, 
17946, 17928, 83829, 83854, 17945
30249, 17674, 83153, 83161, 17682, 17675, 83154, 83162, 17683, 83831, 83855, 83856, 17946, 83834, 83858, 83859, 
17948, 17930, 83832, 83857, 17947
30250, 17675, 83154, 83162, 17683, 2457, 18451, 18452, 2458, 83834, 83858, 83859, 17948, 18526, 18527, 18528, 
2480, 17932, 83835, 83860, 17949
30251, 2408, 18229, 18230, 2409, 17676, 83155, 83163, 17684, 18304, 18307, 18306, 2431, 83838, 83862, 83863, 
17951, 17933, 83836, 83861, 17950
30252, 17676, 83155, 83163, 17684, 17677, 83156, 83164, 17685, 83838, 83862, 83863, 17951, 83841, 83865, 83866, 
17953, 17935, 83839, 83864, 17952
30253, 17677, 83156, 83164, 17685, 17678, 83157, 83165, 17686, 83841, 83865, 83866, 17953, 83844, 83868, 83869, 
17955, 17937, 83842, 83867, 17954
30254, 17678, 83157, 83165, 17686, 17679, 83158, 83166, 17687, 83844, 83868, 83869, 17955, 83847, 83871, 83872, 
17957, 17939, 83845, 83870, 17956
30255, 17679, 83158, 83166, 17687, 17680, 83159, 83167, 17688, 83847, 83871, 83872, 17957, 83850, 83874, 83875, 
17959, 17941, 83848, 83873, 17958
30256, 17680, 83159, 83167, 17688, 17681, 83160, 83168, 17689, 83850, 83874, 83875, 17959, 83853, 83877, 83878, 
17961, 17943, 83851, 83876, 17960
30257, 17681, 83160, 83168, 17689, 17682, 83161, 83169, 17690, 83853, 83877, 83878, 17961, 83856, 83880, 83881, 
17963, 17945, 83854, 83879, 17962
30258, 17682, 83161, 83169, 17690, 17683, 83162, 83170, 17691, 83856, 83880, 83881, 17963, 83859, 83883, 83884, 
17965, 17947, 83857, 83882, 17964
30259, 17683, 83162, 83170, 17691, 2458, 18452, 18453, 2459, 83859, 83883, 83884, 17965, 18528, 18529, 18530, 
2481, 17949, 83860, 83885, 17966
30260, 2409, 18230, 18231, 2410, 17684, 83163, 83171, 17692, 18306, 18309, 18308, 2432, 83863, 83887, 83888, 
17968, 17950, 83861, 83886, 17967
30261, 17684, 83163, 83171, 17692, 17685, 83164, 83172, 17693, 83863, 83887, 83888, 17968, 83866, 83890, 83891, 
17970, 17952, 83864, 83889, 17969
30262, 17685, 83164, 83172, 17693, 17686, 83165, 83173, 17694, 83866, 83890, 83891, 17970, 83869, 83893, 83894, 
17972, 17954, 83867, 83892, 17971
30263, 17686, 83165, 83173, 17694, 17687, 83166, 83174, 17695, 83869, 83893, 83894, 17972, 83872, 83896, 83897, 
17974, 17956, 83870, 83895, 17973
30264, 17687, 83166, 83174, 17695, 17688, 83167, 83175, 17696, 83872, 83896, 83897, 17974, 83875, 83899, 83900, 
17976, 17958, 83873, 83898, 17975
30265, 17688, 83167, 83175, 17696, 17689, 83168, 83176, 17697, 83875, 83899, 83900, 17976, 83878, 83902, 83903, 
17978, 17960, 83876, 83901, 17977
30266, 17689, 83168, 83176, 17697, 17690, 83169, 83177, 17698, 83878, 83902, 83903, 17978, 83881, 83905, 83906, 
17980, 17962, 83879, 83904, 17979
30267, 17690, 83169, 83177, 17698, 17691, 83170, 83178, 17699, 83881, 83905, 83906, 17980, 83884, 83908, 83909, 
17982, 17964, 83882, 83907, 17981
30268, 17691, 83170, 83178, 17699, 2459, 18453, 18454, 2460, 83884, 83908, 83909, 17982, 18530, 18531, 18532, 
2482, 17966, 83885, 83910, 17983
30269, 2410, 18231, 18232, 2411, 17692, 83171, 83179, 17700, 18308, 18311, 18310, 2433, 83888, 83912, 83913, 
17985, 17967, 83886, 83911, 17984
30270, 17692, 83171, 83179, 17700, 17693, 83172, 83180, 17701, 83888, 83912, 83913, 17985, 83891, 83915, 83916, 
17987, 17969, 83889, 83914, 17986
30271, 17693, 83172, 83180, 17701, 17694, 83173, 83181, 17702, 83891, 83915, 83916, 17987, 83894, 83918, 83919, 
17989, 17971, 83892, 83917, 17988
30272, 17694, 83173, 83181, 17702, 17695, 83174, 83182, 17703, 83894, 83918, 83919, 17989, 83897, 83921, 83922, 
17991, 17973, 83895, 83920, 17990
30273, 17695, 83174, 83182, 17703, 17696, 83175, 83183, 17704, 83897, 83921, 83922, 17991, 83900, 83924, 83925, 
17993, 17975, 83898, 83923, 17992
30274, 17696, 83175, 83183, 17704, 17697, 83176, 83184, 17705, 83900, 83924, 83925, 17993, 83903, 83927, 83928, 
17995, 17977, 83901, 83926, 17994
30275, 17697, 83176, 83184, 17705, 17698, 83177, 83185, 17706, 83903, 83927, 83928, 17995, 83906, 83930, 83931, 
17997, 17979, 83904, 83929, 17996
30276, 17698, 83177, 83185, 17706, 17699, 83178, 83186, 17707, 83906, 83930, 83931, 17997, 83909, 83933, 83934, 
17999, 17981, 83907, 83932, 17998
30277, 17699, 83178, 83186, 17707, 2460, 18454, 18455, 2461, 83909, 83933, 83934, 17999, 18532, 18533, 18534, 
2483, 17983, 83910, 83935, 18000
30278, 2411, 18232, 18233, 2412, 17700, 83179, 83187, 17708, 18310, 18313, 18312, 2434, 83913, 83937, 83938, 
18002, 17984, 83911, 83936, 18001
30279, 17700, 83179, 83187, 17708, 17701, 83180, 83188, 17709, 83913, 83937, 83938, 18002, 83916, 83940, 83941, 
18004, 17986, 83914, 83939, 18003
30280, 17701, 83180, 83188, 17709, 17702, 83181, 83189, 17710, 83916, 83940, 83941, 18004, 83919, 83943, 83944, 
18006, 17988, 83917, 83942, 18005
30281, 17702, 83181, 83189, 17710, 17703, 83182, 83190, 17711, 83919, 83943, 83944, 18006, 83922, 83946, 83947, 
18008, 17990, 83920, 83945, 18007
30282, 17703, 83182, 83190, 17711, 17704, 83183, 83191, 17712, 83922, 83946, 83947, 18008, 83925, 83949, 83950, 
18010, 17992, 83923, 83948, 18009
30283, 17704, 83183, 83191, 17712, 17705, 83184, 83192, 17713, 83925, 83949, 83950, 18010, 83928, 83952, 83953, 
18012, 17994, 83926, 83951, 18011
30284, 17705, 83184, 83192, 17713, 17706, 83185, 83193, 17714, 83928, 83952, 83953, 18012, 83931, 83955, 83956, 
18014, 17996, 83929, 83954, 18013
30285, 17706, 83185, 83193, 17714, 17707, 83186, 83194, 17715, 83931, 83955, 83956, 18014, 83934, 83958, 83959, 
18016, 17998, 83932, 83957, 18015
30286, 17707, 83186, 83194, 17715, 2461, 18455, 18456, 2462, 83934, 83958, 83959, 18016, 18534, 18535, 18536, 
2484, 18000, 83935, 83960, 18017
30287, 2412, 18233, 18234, 2413, 17708, 83187, 83195, 17716, 18312, 18315, 18314, 2435, 83938, 83962, 83963, 
18019, 18001, 83936, 83961, 18018
30288, 17708, 83187, 83195, 17716, 17709, 83188, 83196, 17717, 83938, 83962, 83963, 18019, 83941, 83965, 83966, 
18021, 18003, 83939, 83964, 18020
30289, 17709, 83188, 83196, 17717, 17710, 83189, 83197, 17718, 83941, 83965, 83966, 18021, 83944, 83968, 83969, 
18023, 18005, 83942, 83967, 18022
30290, 17710, 83189, 83197, 17718, 17711, 83190, 83198, 17719, 83944, 83968, 83969, 18023, 83947, 83971, 83972, 
18025, 18007, 83945, 83970, 18024
30291, 17711, 83190, 83198, 17719, 17712, 83191, 83199, 17720, 83947, 83971, 83972, 18025, 83950, 83974, 83975, 
18027, 18009, 83948, 83973, 18026
30292, 17712, 83191, 83199, 17720, 17713, 83192, 83200, 17721, 83950, 83974, 83975, 18027, 83953, 83977, 83978, 
18029, 18011, 83951, 83976, 18028
30293, 17713, 83192, 83200, 17721, 17714, 83193, 83201, 17722, 83953, 83977, 83978, 18029, 83956, 83980, 83981, 
18031, 18013, 83954, 83979, 18030
30294, 17714, 83193, 83201, 17722, 17715, 83194, 83202, 17723, 83956, 83980, 83981, 18031, 83959, 83983, 83984, 
18033, 18015, 83957, 83982, 18032
30295, 17715, 83194, 83202, 17723, 2462, 18456, 18457, 2463, 83959, 83983, 83984, 18033, 18536, 18537, 18538, 
2485, 18017, 83960, 83985, 18034
30296, 2413, 18234, 18235, 2414, 17716, 83195, 83203, 17724, 18314, 18317, 18316, 2436, 83963, 83987, 83988, 
18036, 18018, 83961, 83986, 18035
30297, 17716, 83195, 83203, 17724, 17717, 83196, 83204, 17725, 83963, 83987, 83988, 18036, 83966, 83990, 83991, 
18038, 18020, 83964, 83989, 18037
30298, 17717, 83196, 83204, 17725, 17718, 83197, 83205, 17726, 83966, 83990, 83991, 18038, 83969, 83993, 83994, 
18040, 18022, 83967, 83992, 18039
30299, 17718, 83197, 83205, 17726, 17719, 83198, 83206, 17727, 83969, 83993, 83994, 18040, 83972, 83996, 83997, 
18042, 18024, 83970, 83995, 18041
30300, 17719, 83198, 83206, 17727, 17720, 83199, 83207, 17728, 83972, 83996, 83997, 18042, 83975, 83999, 84000, 
18044, 18026, 83973, 83998, 18043
30301, 17720, 83199, 83207, 17728, 17721, 83200, 83208, 17729, 83975, 83999, 84000, 18044, 83978, 84002, 84003, 
18046, 18028, 83976, 84001, 18045
30302, 17721, 83200, 83208, 17729, 17722, 83201, 83209, 17730, 83978, 84002, 84003, 18046, 83981, 84005, 84006, 
18048, 18030, 83979, 84004, 18047
30303, 17722, 83201, 83209, 17730, 17723, 83202, 83210, 17731, 83981, 84005, 84006, 18048, 83984, 84008, 84009, 
18050, 18032, 83982, 84007, 18049
30304, 17723, 83202, 83210, 17731, 2463, 18457, 18458, 2464, 83984, 84008, 84009, 18050, 18538, 18539, 18540, 
2486, 18034, 83985, 84010, 18051
30305, 2414, 18235, 18236, 2415, 17724, 83203, 83211, 17732, 18316, 18319, 18318, 2437, 83988, 84012, 84013, 
18053, 18035, 83986, 84011, 18052
30306, 17724, 83203, 83211, 17732, 17725, 83204, 83212, 17733, 83988, 84012, 84013, 18053, 83991, 84015, 84016, 
18055, 18037, 83989, 84014, 18054
30307, 17725, 83204, 83212, 17733, 17726, 83205, 83213, 17734, 83991, 84015, 84016, 18055, 83994, 84018, 84019, 
18057, 18039, 83992, 84017, 18056
30308, 17726, 83205, 83213, 17734, 17727, 83206, 83214, 17735, 83994, 84018, 84019, 18057, 83997, 84021, 84022, 
18059, 18041, 83995, 84020, 18058
30309, 17727, 83206, 83214, 17735, 17728, 83207, 83215, 17736, 83997, 84021, 84022, 18059, 84000, 84024, 84025, 
18061, 18043, 83998, 84023, 18060
30310, 17728, 83207, 83215, 17736, 17729, 83208, 83216, 17737, 84000, 84024, 84025, 18061, 84003, 84027, 84028, 
18063, 18045, 84001, 84026, 18062
30311, 17729, 83208, 83216, 17737, 17730, 83209, 83217, 17738, 84003, 84027, 84028, 18063, 84006, 84030, 84031, 
18065, 18047, 84004, 84029, 18064
30312, 17730, 83209, 83217, 17738, 17731, 83210, 83218, 17739, 84006, 84030, 84031, 18065, 84009, 84033, 84034, 
18067, 18049, 84007, 84032, 18066
30313, 17731, 83210, 83218, 17739, 2464, 18458, 18459, 2465, 84009, 84033, 84034, 18067, 18540, 18541, 18542, 
2487, 18051, 84010, 84035, 18068
30314, 2415, 18236, 18237, 2416, 17732, 83211, 83219, 17740, 18318, 18321, 18320, 2438, 84013, 84037, 84038, 
18070, 18052, 84011, 84036, 18069
30315, 17732, 83211, 83219, 17740, 17733, 83212, 83220, 17741, 84013, 84037, 84038, 18070, 84016, 84040, 84041, 
18072, 18054, 84014, 84039, 18071
30316, 17733, 83212, 83220, 17741, 17734, 83213, 83221, 17742, 84016, 84040, 84041, 18072, 84019, 84043, 84044, 
18074, 18056, 84017, 84042, 18073
30317, 17734, 83213, 83221, 17742, 17735, 83214, 83222, 17743, 84019, 84043, 84044, 18074, 84022, 84046, 84047, 
18076, 18058, 84020, 84045, 18075
30318, 17735, 83214, 83222, 17743, 17736, 83215, 83223, 17744, 84022, 84046, 84047, 18076, 84025, 84049, 84050, 
18078, 18060, 84023, 84048, 18077
30319, 17736, 83215, 83223, 17744, 17737, 83216, 83224, 17745, 84025, 84049, 84050, 18078, 84028, 84052, 84053, 
18080, 18062, 84026, 84051, 18079
30320, 17737, 83216, 83224, 17745, 17738, 83217, 83225, 17746, 84028, 84052, 84053, 18080, 84031, 84055, 84056, 
18082, 18064, 84029, 84054, 18081
30321, 17738, 83217, 83225, 17746, 17739, 83218, 83226, 17747, 84031, 84055, 84056, 18082, 84034, 84058, 84059, 
18084, 18066, 84032, 84057, 18083
30322, 17739, 83218, 83226, 17747, 2465, 18459, 18460, 2466, 84034, 84058, 84059, 18084, 18542, 18543, 18544, 
2488, 18068, 84035, 84060, 18085
30323, 2416, 18237, 18238, 2417, 17740, 83219, 83227, 17748, 18320, 18323, 18322, 2439, 84038, 84062, 84063, 
18087, 18069, 84036, 84061, 18086
30324, 17740, 83219, 83227, 17748, 17741, 83220, 83228, 17749, 84038, 84062, 84063, 18087, 84041, 84065, 84066, 
18089, 18071, 84039, 84064, 18088
30325, 17741, 83220, 83228, 17749, 17742, 83221, 83229, 17750, 84041, 84065, 84066, 18089, 84044, 84068, 84069, 
18091, 18073, 84042, 84067, 18090
30326, 17742, 83221, 83229, 17750, 17743, 83222, 83230, 17751, 84044, 84068, 84069, 18091, 84047, 84071, 84072, 
18093, 18075, 84045, 84070, 18092
30327, 17743, 83222, 83230, 17751, 17744, 83223, 83231, 17752, 84047, 84071, 84072, 18093, 84050, 84074, 84075, 
18095, 18077, 84048, 84073, 18094
30328, 17744, 83223, 83231, 17752, 17745, 83224, 83232, 17753, 84050, 84074, 84075, 18095, 84053, 84077, 84078, 
18097, 18079, 84051, 84076, 18096
30329, 17745, 83224, 83232, 17753, 17746, 83225, 83233, 17754, 84053, 84077, 84078, 18097, 84056, 84080, 84081, 
18099, 18081, 84054, 84079, 18098
30330, 17746, 83225, 83233, 17754, 17747, 83226, 83234, 17755, 84056, 84080, 84081, 18099, 84059, 84083, 84084, 
18101, 18083, 84057, 84082, 18100
30331, 17747, 83226, 83234, 17755, 2466, 18460, 18461, 2467, 84059, 84083, 84084, 18101, 18544, 18545, 18546, 
2489, 18085, 84060, 84085, 18102
30332, 2417, 18238, 18239, 2418, 17748, 83227, 83235, 17756, 18322, 18325, 18324, 2440, 84063, 84087, 84088, 
18104, 18086, 84061, 84086, 18103
30333, 17748, 83227, 83235, 17756, 17749, 83228, 83236, 17757, 84063, 84087, 84088, 18104, 84066, 84090, 84091, 
18106, 18088, 84064, 84089, 18105
30334, 17749, 83228, 83236, 17757, 17750, 83229, 83237, 17758, 84066, 84090, 84091, 18106, 84069, 84093, 84094, 
18108, 18090, 84067, 84092, 18107
30335, 17750, 83229, 83237, 17758, 17751, 83230, 83238, 17759, 84069, 84093, 84094, 18108, 84072, 84096, 84097, 
18110, 18092, 84070, 84095, 18109
30336, 17751, 83230, 83238, 17759, 17752, 83231, 83239, 17760, 84072, 84096, 84097, 18110, 84075, 84099, 84100, 
18112, 18094, 84073, 84098, 18111
30337, 17752, 83231, 83239, 17760, 17753, 83232, 83240, 17761, 84075, 84099, 84100, 18112, 84078, 84102, 84103, 
18114, 18096, 84076, 84101, 18113
30338, 17753, 83232, 83240, 17761, 17754, 83233, 83241, 17762, 84078, 84102, 84103, 18114, 84081, 84105, 84106, 
18116, 18098, 84079, 84104, 18115
30339, 17754, 83233, 83241, 17762, 17755, 83234, 83242, 17763, 84081, 84105, 84106, 18116, 84084, 84108, 84109, 
18118, 18100, 84082, 84107, 18117
30340, 17755, 83234, 83242, 17763, 2467, 18461, 18462, 2468, 84084, 84108, 84109, 18118, 18546, 18547, 18548, 
2490, 18102, 84085, 84110, 18119
30341, 2418, 18239, 18240, 2419, 17756, 83235, 83243, 17764, 18324, 18327, 18326, 2441, 84088, 84112, 84113, 
18121, 18103, 84086, 84111, 18120
30342, 17756, 83235, 83243, 17764, 17757, 83236, 83244, 17765, 84088, 84112, 84113, 18121, 84091, 84115, 84116, 
18123, 18105, 84089, 84114, 18122
30343, 17757, 83236, 83244, 17765, 17758, 83237, 83245, 17766, 84091, 84115, 84116, 18123, 84094, 84118, 84119, 
18125, 18107, 84092, 84117, 18124
30344, 17758, 83237, 83245, 17766, 17759, 83238, 83246, 17767, 84094, 84118, 84119, 18125, 84097, 84121, 84122, 
18127, 18109, 84095, 84120, 18126
30345, 17759, 83238, 83246, 17767, 17760, 83239, 83247, 17768, 84097, 84121, 84122, 18127, 84100, 84124, 84125, 
18129, 18111, 84098, 84123, 18128
30346, 17760, 83239, 83247, 17768, 17761, 83240, 83248, 17769, 84100, 84124, 84125, 18129, 84103, 84127, 84128, 
18131, 18113, 84101, 84126, 18130
30347, 17761, 83240, 83248, 17769, 17762, 83241, 83249, 17770, 84103, 84127, 84128, 18131, 84106, 84130, 84131, 
18133, 18115, 84104, 84129, 18132
30348, 17762, 83241, 83249, 17770, 17763, 83242, 83250, 17771, 84106, 84130, 84131, 18133, 84109, 84133, 84134, 
18135, 18117, 84107, 84132, 18134
30349, 17763, 83242, 83250, 17771, 2468, 18462, 18463, 2469, 84109, 84133, 84134, 18135, 18548, 18549, 18550, 
2491, 18119, 84110, 84135, 18136
30350, 2419, 18240, 18241, 2420, 17764, 83243, 83251, 17772, 18326, 18329, 18328, 2442, 84113, 84137, 84138, 
18138, 18120, 84111, 84136, 18137
30351, 17764, 83243, 83251, 17772, 17765, 83244, 83252, 17773, 84113, 84137, 84138, 18138, 84116, 84140, 84141, 
18140, 18122, 84114, 84139, 18139
30352, 17765, 83244, 83252, 17773, 17766, 83245, 83253, 17774, 84116, 84140, 84141, 18140, 84119, 84143, 84144, 
18142, 18124, 84117, 84142, 18141
30353, 17766, 83245, 83253, 17774, 17767, 83246, 83254, 17775, 84119, 84143, 84144, 18142, 84122, 84146, 84147, 
18144, 18126, 84120, 84145, 18143
30354, 17767, 83246, 83254, 17775, 17768, 83247, 83255, 17776, 84122, 84146, 84147, 18144, 84125, 84149, 84150, 
18146, 18128, 84123, 84148, 18145
30355, 17768, 83247, 83255, 17776, 17769, 83248, 83256, 17777, 84125, 84149, 84150, 18146, 84128, 84152, 84153, 
18148, 18130, 84126, 84151, 18147
30356, 17769, 83248, 83256, 17777, 17770, 83249, 83257, 17778, 84128, 84152, 84153, 18148, 84131, 84155, 84156, 
18150, 18132, 84129, 84154, 18149
30357, 17770, 83249, 83257, 17778, 17771, 83250, 83258, 17779, 84131, 84155, 84156, 18150, 84134, 84158, 84159, 
18152, 18134, 84132, 84157, 18151
30358, 17771, 83250, 83258, 17779, 2469, 18463, 18464, 2470, 84134, 84158, 84159, 18152, 18550, 18551, 18552, 
2492, 18136, 84135, 84160, 18153
30359, 2420, 18241, 2516, 77, 17772, 83251, 18666, 2506, 18328, 18330, 2519, 2443, 84138, 84161, 18690, 
18154, 18137, 84136, 18691, 2515
30360, 17772, 83251, 18666, 2506, 17773, 83252, 18667, 2505, 84138, 84161, 18690, 18154, 84141, 84162, 18692, 
18155, 18139, 84139, 18693, 2514
30361, 17773, 83252, 18667, 2505, 17774, 83253, 18668, 2504, 84141, 84162, 18692, 18155, 84144, 84163, 18694, 
18156, 18141, 84142, 18695, 2513
30362, 17774, 83253, 18668, 2504, 17775, 83254, 18669, 2503, 84144, 84163, 18694, 18156, 84147, 84164, 18696, 
18157, 18143, 84145, 18697, 2512
30363, 17775, 83254, 18669, 2503, 17776, 83255, 18670, 2502, 84147, 84164, 18696, 18157, 84150, 84165, 18698, 
18158, 18145, 84148, 18699, 2511
30364, 17776, 83255, 18670, 2502, 17777, 83256, 18671, 2501, 84150, 84165, 18698, 18158, 84153, 84166, 18700, 
18159, 18147, 84151, 18701, 2510
30365, 17777, 83256, 18671, 2501, 17778, 83257, 18672, 2500, 84153, 84166, 18700, 18159, 84156, 84167, 18702, 
18160, 18149, 84154, 18703, 2509
30366, 17778, 83257, 18672, 2500, 17779, 83258, 18673, 2499, 84156, 84167, 18702, 18160, 84159, 84168, 18704, 
18161, 18151, 84157, 18705, 2508
