60099, 1.9826086956522, 1.4666666666667, 0.22222222222222
60100, 1.9608695652174, 1.4833333333333, 0.22222222222222
60101, 1.9826086956522, 1.4833333333333, 0.19444444444444
60102, 1.9826086956522, 1.4666666666667, 0.16666666666667
60103, 1.9608695652174, 1.4833333333333, 0.16666666666667
60104, 1.9826086956522, 1.4833333333333, 0.13888888888889
60105, 1.9826086956522, 1.4666666666667, 0.11111111111111
60106, 1.9608695652174, 1.4833333333333, 0.11111111111111
60107, 1.9826086956522, 1.4833333333333, 0.083333333333333
60108, 1.9826086956522, 1.4666666666667, 0.055555555555556
60109, 1.9608695652174, 1.4833333333333, 0.055555555555556
60110, 1.9826086956522, 1.4833333333333, 0.027777777777778
60111, 1.9826086956522, 1.5166666666667, 0.47222222222222
60112, 1.9826086956522, 1.5, 0.44444444444444
60113, 1.9608695652174, 1.5166666666667, 0.44444444444444
60114, 1.9826086956522, 1.5166666666667, 0.41666666666667
60115, 1.9826086956522, 1.5, 0.38888888888889
60116, 1.9608695652174, 1.5166666666667, 0.38888888888889
60117, 1.9826086956522, 1.5166666666667, 0.36111111111111
60118, 1.9826086956522, 1.5, 0.33333333333333
60119, 1.9608695652174, 1.5166666666667, 0.33333333333333
60120, 1.9826086956522, 1.5166666666667, 0.30555555555556
60121, 1.9826086956522, 1.5, 0.27777777777778
60122, 1.9608695652174, 1.5166666666667, 0.27777777777778
60123, 1.9826086956522, 1.5166666666667, 0.25
60124, 1.9826086956522, 1.5, 0.22222222222222
60125, 1.9608695652174, 1.5166666666667, 0.22222222222222
60126, 1.9826086956522, 1.5166666666667, 0.19444444444444
60127, 1.9826086956522, 1.5, 0.16666666666667
60128, 1.9608695652174, 1.5166666666667, 0.16666666666667
60129, 1.9826086956522, 1.5166666666667, 0.13888888888889
60130, 1.9826086956522, 1.5, 0.11111111111111
60131, 1.9608695652174, 1.5166666666667, 0.11111111111111
60132, 1.9826086956522, 1.5166666666667, 0.083333333333333
60133, 1.9826086956522, 1.5, 0.055555555555556
60134, 1.9608695652174, 1.5166666666667, 0.055555555555556
60135, 1.9826086956522, 1.5166666666667, 0.027777777777778
60136, 1.9826086956522, 1.5333333333333, 0.44444444444444
60137, 1.9826086956522, 1.5333333333333, 0.38888888888889
60138, 1.9826086956522, 1.5333333333333, 0.33333333333333
60139, 1.9826086956522, 1.5333333333333, 0.27777777777778
60140, 1.9826086956522, 1.5333333333333, 0.22222222222222
60141, 1.9826086956522, 1.5333333333333, 0.16666666666667
60142, 1.9826086956522, 1.5333333333333, 0.11111111111111
60143, 1.9826086956522, 1.5333333333333, 0.055555555555556
60144, 2.0260869565217, 1.4833333333333, 0.47222222222222
60145, 2.0260869565217, 1.4666666666667, 0.44444444444444
60146, 2.004347826087, 1.4833333333333, 0.44444444444444
60147, 2.0260869565217, 1.4833333333333, 0.41666666666667
60148, 2.0260869565217, 1.4666666666667, 0.38888888888889
60149, 2.004347826087, 1.4833333333333, 0.38888888888889
60150, 2.0260869565217, 1.4833333333333, 0.36111111111111
60151, 2.0260869565217, 1.4666666666667, 0.33333333333333
60152, 2.004347826087, 1.4833333333333, 0.33333333333333
60153, 2.0260869565217, 1.4833333333333, 0.30555555555556
60154, 2.0260869565217, 1.4666666666667, 0.27777777777778
60155, 2.004347826087, 1.4833333333333, 0.27777777777778
60156, 2.0260869565217, 1.4833333333333, 0.25
60157, 2.0260869565217, 1.4666666666667, 0.22222222222222
60158, 2.004347826087, 1.4833333333333, 0.22222222222222
60159, 2.0260869565217, 1.4833333333333, 0.19444444444444
60160, 2.0260869565217, 1.4666666666667, 0.16666666666667
60161, 2.004347826087, 1.4833333333333, 0.16666666666667
60162, 2.0260869565217, 1.4833333333333, 0.13888888888889
60163, 2.0260869565217, 1.4666666666667, 0.11111111111111
60164, 2.004347826087, 1.4833333333333, 0.11111111111111
60165, 2.0260869565217, 1.4833333333333, 0.083333333333333
60166, 2.0260869565217, 1.4666666666667, 0.055555555555556
60167, 2.004347826087, 1.4833333333333, 0.055555555555556
60168, 2.0260869565217, 1.4833333333333, 0.027777777777778
60169, 2.0260869565217, 1.5166666666667, 0.47222222222222
60170, 2.0260869565217, 1.5, 0.44444444444444
60171, 2.004347826087, 1.5166666666667, 0.44444444444444
60172, 2.0260869565217, 1.5166666666667, 0.41666666666667
60173, 2.0260869565217, 1.5, 0.38888888888889
60174, 2.004347826087, 1.5166666666667, 0.38888888888889
60175, 2.0260869565217, 1.5166666666667, 0.36111111111111
60176, 2.0260869565217, 1.5, 0.33333333333333
60177, 2.004347826087, 1.5166666666667, 0.33333333333333
60178, 2.0260869565217, 1.5166666666667, 0.30555555555556
60179, 2.0260869565217, 1.5, 0.27777777777778
60180, 2.004347826087, 1.5166666666667, 0.27777777777778
60181, 2.0260869565217, 1.5166666666667, 0.25
60182, 2.0260869565217, 1.5, 0.22222222222222
60183, 2.004347826087, 1.5166666666667, 0.22222222222222
60184, 2.0260869565217, 1.5166666666667, 0.19444444444444
60185, 2.0260869565217, 1.5, 0.16666666666667
60186, 2.004347826087, 1.5166666666667, 0.16666666666667
60187, 2.0260869565217, 1.5166666666667, 0.13888888888889
60188, 2.0260869565217, 1.5, 0.11111111111111
60189, 2.004347826087, 1.5166666666667, 0.11111111111111
60190, 2.0260869565217, 1.5166666666667, 0.083333333333333
60191, 2.0260869565217, 1.5, 0.055555555555556
60192, 2.004347826087, 1.5166666666667, 0.055555555555556
60193, 2.0260869565217, 1.5166666666667, 0.027777777777778
60194, 2.0260869565217, 1.5333333333333, 0.44444444444444
60195, 2.0260869565217, 1.5333333333333, 0.38888888888889
60196, 2.0260869565217, 1.5333333333333, 0.33333333333333
60197, 2.0260869565217, 1.5333333333333, 0.27777777777778
60198, 2.0260869565217, 1.5333333333333, 0.22222222222222
60199, 2.0260869565217, 1.5333333333333, 0.16666666666667
60200, 2.0260869565217, 1.5333333333333, 0.11111111111111
60201, 2.0260869565217, 1.5333333333333, 0.055555555555556
60202, 2.0695652173913, 1.4833333333333, 0.47222222222222
60203, 2.0695652173913, 1.4666666666667, 0.44444444444444
60204, 2.0478260869565, 1.4833333333333, 0.44444444444444
60205, 2.0695652173913, 1.4833333333333, 0.41666666666667
60206, 2.0695652173913, 1.4666666666667, 0.38888888888889
60207, 2.0478260869565, 1.4833333333333, 0.38888888888889
60208, 2.0695652173913, 1.4833333333333, 0.36111111111111
60209, 2.0695652173913, 1.4666666666667, 0.33333333333333
60210, 2.0478260869565, 1.4833333333333, 0.33333333333333
60211, 2.0695652173913, 1.4833333333333, 0.30555555555556
60212, 2.0695652173913, 1.4666666666667, 0.27777777777778
60213, 2.0478260869565, 1.4833333333333, 0.27777777777778
60214, 2.0695652173913, 1.4833333333333, 0.25
60215, 2.0695652173913, 1.4666666666667, 0.22222222222222
60216, 2.0478260869565, 1.4833333333333, 0.22222222222222
60217, 2.0695652173913, 1.4833333333333, 0.19444444444444
60218, 2.0695652173913, 1.4666666666667, 0.16666666666667
60219, 2.0478260869565, 1.4833333333333, 0.16666666666667
60220, 2.0695652173913, 1.4833333333333, 0.13888888888889
60221, 2.0695652173913, 1.4666666666667, 0.11111111111111
60222, 2.0478260869565, 1.4833333333333, 0.11111111111111
60223, 2.0695652173913, 1.4833333333333, 0.083333333333333
60224, 2.0695652173913, 1.4666666666667, 0.055555555555556
60225, 2.0478260869565, 1.4833333333333, 0.055555555555556
60226, 2.0695652173913, 1.4833333333333, 0.027777777777778
60227, 2.0695652173913, 1.5166666666667, 0.47222222222222
60228, 2.0695652173913, 1.5, 0.44444444444444
60229, 2.0478260869565, 1.5166666666667, 0.44444444444444
60230, 2.0695652173913, 1.5166666666667, 0.41666666666667
60231, 2.0695652173913, 1.5, 0.38888888888889
60232, 2.0478260869565, 1.5166666666667, 0.38888888888889
60233, 2.0695652173913, 1.5166666666667, 0.36111111111111
60234, 2.0695652173913, 1.5, 0.33333333333333
60235, 2.0478260869565, 1.5166666666667, 0.33333333333333
60236, 2.0695652173913, 1.5166666666667, 0.30555555555556
60237, 2.0695652173913, 1.5, 0.27777777777778
60238, 2.0478260869565, 1.5166666666667, 0.27777777777778
60239, 2.0695652173913, 1.5166666666667, 0.25
60240, 2.0695652173913, 1.5, 0.22222222222222
60241, 2.0478260869565, 1.5166666666667, 0.22222222222222
60242, 2.0695652173913, 1.5166666666667, 0.19444444444444
60243, 2.0695652173913, 1.5, 0.16666666666667
60244, 2.0478260869565, 1.5166666666667, 0.16666666666667
60245, 2.0695652173913, 1.5166666666667, 0.13888888888889
60246, 2.0695652173913, 1.5, 0.11111111111111
60247, 2.0478260869565, 1.5166666666667, 0.11111111111111
60248, 2.0695652173913, 1.5166666666667, 0.083333333333333
60249, 2.0695652173913, 1.5, 0.055555555555556
60250, 2.0478260869565, 1.5166666666667, 0.055555555555556
60251, 2.0695652173913, 1.5166666666667, 0.027777777777778
60252, 2.0695652173913, 1.5333333333333, 0.44444444444444
60253, 2.0695652173913, 1.5333333333333, 0.38888888888889
60254, 2.0695652173913, 1.5333333333333, 0.33333333333333
60255, 2.0695652173913, 1.5333333333333, 0.27777777777778
60256, 2.0695652173913, 1.5333333333333, 0.22222222222222
60257, 2.0695652173913, 1.5333333333333, 0.16666666666667
60258, 2.0695652173913, 1.5333333333333, 0.11111111111111
60259, 2.0695652173913, 1.5333333333333, 0.055555555555556
60260, 2.1130434782609, 1.4833333333333, 0.47222222222222
60261, 2.1130434782609, 1.4666666666667, 0.44444444444444
60262, 2.0913043478261, 1.4833333333333, 0.44444444444444
60263, 2.1130434782609, 1.4833333333333, 0.41666666666667
60264, 2.1130434782609, 1.4666666666667, 0.38888888888889
60265, 2.0913043478261, 1.4833333333333, 0.38888888888889
60266, 2.1130434782609, 1.4833333333333, 0.36111111111111
60267, 2.1130434782609, 1.4666666666667, 0.33333333333333
60268, 2.0913043478261, 1.4833333333333, 0.33333333333333
60269, 2.1130434782609, 1.4833333333333, 0.30555555555556
60270, 2.1130434782609, 1.4666666666667, 0.27777777777778
60271, 2.0913043478261, 1.4833333333333, 0.27777777777778
60272, 2.1130434782609, 1.4833333333333, 0.25
60273, 2.1130434782609, 1.4666666666667, 0.22222222222222
60274, 2.0913043478261, 1.4833333333333, 0.22222222222222
60275, 2.1130434782609, 1.4833333333333, 0.19444444444444
60276, 2.1130434782609, 1.4666666666667, 0.16666666666667
60277, 2.0913043478261, 1.4833333333333, 0.16666666666667
60278, 2.1130434782609, 1.4833333333333, 0.13888888888889
60279, 2.1130434782609, 1.4666666666667, 0.11111111111111
60280, 2.0913043478261, 1.4833333333333, 0.11111111111111
60281, 2.1130434782609, 1.4833333333333, 0.083333333333333
60282, 2.1130434782609, 1.4666666666667, 0.055555555555556
60283, 2.0913043478261, 1.4833333333333, 0.055555555555556
60284, 2.1130434782609, 1.4833333333333, 0.027777777777778
60285, 2.1130434782609, 1.5166666666667, 0.47222222222222
60286, 2.1130434782609, 1.5, 0.44444444444444
60287, 2.0913043478261, 1.5166666666667, 0.44444444444444
60288, 2.1130434782609, 1.5166666666667, 0.41666666666667
60289, 2.1130434782609, 1.5, 0.38888888888889
60290, 2.0913043478261, 1.5166666666667, 0.38888888888889
60291, 2.1130434782609, 1.5166666666667, 0.36111111111111
60292, 2.1130434782609, 1.5, 0.33333333333333
60293, 2.0913043478261, 1.5166666666667, 0.33333333333333
60294, 2.1130434782609, 1.5166666666667, 0.30555555555556
60295, 2.1130434782609, 1.5, 0.27777777777778
60296, 2.0913043478261, 1.5166666666667, 0.27777777777778
60297, 2.1130434782609, 1.5166666666667, 0.25
60298, 2.1130434782609, 1.5, 0.22222222222222
60299, 2.0913043478261, 1.5166666666667, 0.22222222222222
60300, 2.1130434782609, 1.5166666666667, 0.19444444444444
60301, 2.1130434782609, 1.5, 0.16666666666667
60302, 2.0913043478261, 1.5166666666667, 0.16666666666667
60303, 2.1130434782609, 1.5166666666667, 0.13888888888889
60304, 2.1130434782609, 1.5, 0.11111111111111
60305, 2.0913043478261, 1.5166666666667, 0.11111111111111
60306, 2.1130434782609, 1.5166666666667, 0.083333333333333
60307, 2.1130434782609, 1.5, 0.055555555555556
60308, 2.0913043478261, 1.5166666666667, 0.055555555555556
60309, 2.1130434782609, 1.5166666666667, 0.027777777777778
60310, 2.1130434782609, 1.5333333333333, 0.44444444444444
60311, 2.1130434782609, 1.5333333333333, 0.38888888888889
60312, 2.1130434782609, 1.5333333333333, 0.33333333333333
60313, 2.1130434782609, 1.5333333333333, 0.27777777777778
60314, 2.1130434782609, 1.5333333333333, 0.22222222222222
60315, 2.1130434782609, 1.5333333333333, 0.16666666666667
60316, 2.1130434782609, 1.5333333333333, 0.11111111111111
60317, 2.1130434782609, 1.5333333333333, 0.055555555555556
60318, 2.1565217391304, 1.4833333333333, 0.47222222222222
60319, 2.1565217391304, 1.4666666666667, 0.44444444444444
60320, 2.1347826086957, 1.4833333333333, 0.44444444444444
60321, 2.1565217391304, 1.4833333333333, 0.41666666666667
60322, 2.1565217391304, 1.4666666666667, 0.38888888888889
60323, 2.1347826086957, 1.4833333333333, 0.38888888888889
60324, 2.1565217391304, 1.4833333333333, 0.36111111111111
60325, 2.1565217391304, 1.4666666666667, 0.33333333333333
60326, 2.1347826086957, 1.4833333333333, 0.33333333333333
60327, 2.1565217391304, 1.4833333333333, 0.30555555555556
60328, 2.1565217391304, 1.4666666666667, 0.27777777777778
60329, 2.1347826086957, 1.4833333333333, 0.27777777777778
60330, 2.1565217391304, 1.4833333333333, 0.25
60331, 2.1565217391304, 1.4666666666667, 0.22222222222222
60332, 2.1347826086957, 1.4833333333333, 0.22222222222222
60333, 2.1565217391304, 1.4833333333333, 0.19444444444444
60334, 2.1565217391304, 1.4666666666667, 0.16666666666667
60335, 2.1347826086957, 1.4833333333333, 0.16666666666667
60336, 2.1565217391304, 1.4833333333333, 0.13888888888889
60337, 2.1565217391304, 1.4666666666667, 0.11111111111111
60338, 2.1347826086957, 1.4833333333333, 0.11111111111111
60339, 2.1565217391304, 1.4833333333333, 0.083333333333333
60340, 2.1565217391304, 1.4666666666667, 0.055555555555556
60341, 2.1347826086957, 1.4833333333333, 0.055555555555556
60342, 2.1565217391304, 1.4833333333333, 0.027777777777778
60343, 2.1565217391304, 1.5166666666667, 0.47222222222222
60344, 2.1565217391304, 1.5, 0.44444444444444
60345, 2.1347826086957, 1.5166666666667, 0.44444444444444
60346, 2.1565217391304, 1.5166666666667, 0.41666666666667
60347, 2.1565217391304, 1.5, 0.38888888888889
60348, 2.1347826086957, 1.5166666666667, 0.38888888888889
60349, 2.1565217391304, 1.5166666666667, 0.36111111111111
60350, 2.1565217391304, 1.5, 0.33333333333333
60351, 2.1347826086957, 1.5166666666667, 0.33333333333333
60352, 2.1565217391304, 1.5166666666667, 0.30555555555556
60353, 2.1565217391304, 1.5, 0.27777777777778
60354, 2.1347826086957, 1.5166666666667, 0.27777777777778
60355, 2.1565217391304, 1.5166666666667, 0.25
60356, 2.1565217391304, 1.5, 0.22222222222222
60357, 2.1347826086957, 1.5166666666667, 0.22222222222222
60358, 2.1565217391304, 1.5166666666667, 0.19444444444444
60359, 2.1565217391304, 1.5, 0.16666666666667
60360, 2.1347826086957, 1.5166666666667, 0.16666666666667
60361, 2.1565217391304, 1.5166666666667, 0.13888888888889
60362, 2.1565217391304, 1.5, 0.11111111111111
60363, 2.1347826086957, 1.5166666666667, 0.11111111111111
60364, 2.1565217391304, 1.5166666666667, 0.083333333333333
60365, 2.1565217391304, 1.5, 0.055555555555556
60366, 2.1347826086957, 1.5166666666667, 0.055555555555556
60367, 2.1565217391304, 1.5166666666667, 0.027777777777778
60368, 2.1565217391304, 1.5333333333333, 0.44444444444444
60369, 2.1565217391304, 1.5333333333333, 0.38888888888889
60370, 2.1565217391304, 1.5333333333333, 0.33333333333333
60371, 2.1565217391304, 1.5333333333333, 0.27777777777778
60372, 2.1565217391304, 1.5333333333333, 0.22222222222222
60373, 2.1565217391304, 1.5333333333333, 0.16666666666667
60374, 2.1565217391304, 1.5333333333333, 0.11111111111111
60375, 2.1565217391304, 1.5333333333333, 0.055555555555556
60376, 2.1782608695652, 1.4833333333333, 0.44444444444444
60377, 2.1782608695652, 1.4833333333333, 0.38888888888889
60378, 2.1782608695652, 1.4833333333333, 0.33333333333333
60379, 2.1782608695652, 1.4833333333333, 0.27777777777778
60380, 2.1782608695652, 1.4833333333333, 0.22222222222222
60381, 2.1782608695652, 1.4833333333333, 0.16666666666667
60382, 2.1782608695652, 1.4833333333333, 0.11111111111111
60383, 2.1782608695652, 1.4833333333333, 0.055555555555556
60384, 2.1782608695652, 1.5166666666667, 0.44444444444444
60385, 2.1782608695652, 1.5166666666667, 0.38888888888889
60386, 2.1782608695652, 1.5166666666667, 0.33333333333333
60387, 2.1782608695652, 1.5166666666667, 0.27777777777778
60388, 2.1782608695652, 1.5166666666667, 0.22222222222222
60389, 2.1782608695652, 1.5166666666667, 0.16666666666667
60390, 2.1782608695652, 1.5166666666667, 0.11111111111111
60391, 2.1782608695652, 1.5166666666667, 0.055555555555556
60392, 1.2434782608696, 1.425, 0.44444444444444
60393, 1.2434782608696, 1.425, 0.38888888888889
60394, 1.2434782608696, 1.425, 0.33333333333333
60395, 1.2434782608696, 1.425, 0.27777777777778
60396, 1.2434782608696, 1.425, 0.22222222222222
60397, 1.2434782608696, 1.425, 0.16666666666667
60398, 1.2434782608696, 1.425, 0.11111111111111
60399, 1.2434782608696, 1.425, 0.055555555555556
60400, 1.2869565217391, 1.425, 0.44444444444444
60401, 1.2869565217391, 1.425, 0.38888888888889
60402, 1.2869565217391, 1.425, 0.33333333333333
60403, 1.2869565217391, 1.425, 0.27777777777778
60404, 1.2869565217391, 1.425, 0.22222222222222
60405, 1.2869565217391, 1.425, 0.16666666666667
60406, 1.2869565217391, 1.425, 0.11111111111111
60407, 1.2869565217391, 1.425, 0.055555555555556
60408, 1.3304347826087, 1.425, 0.44444444444444
60409, 1.3304347826087, 1.425, 0.38888888888889
60410, 1.3304347826087, 1.425, 0.33333333333333
60411, 1.3304347826087, 1.425, 0.27777777777778
60412, 1.3304347826087, 1.425, 0.22222222222222
60413, 1.3304347826087, 1.425, 0.16666666666667
60414, 1.3304347826087, 1.425, 0.11111111111111
60415, 1.3304347826087, 1.425, 0.055555555555556
60416, 1.3739130434783, 1.425, 0.44444444444444
60417, 1.3739130434783, 1.425, 0.38888888888889
60418, 1.3739130434783, 1.425, 0.33333333333333
60419, 1.3739130434783, 1.425, 0.27777777777778
60420, 1.3739130434783, 1.425, 0.22222222222222
60421, 1.3739130434783, 1.425, 0.16666666666667
60422, 1.3739130434783, 1.425, 0.11111111111111
60423, 1.3739130434783, 1.425, 0.055555555555556
60424, 1.4173913043478, 1.425, 0.44444444444444
60425, 1.4173913043478, 1.425, 0.38888888888889
60426, 1.4173913043478, 1.425, 0.33333333333333
60427, 1.4173913043478, 1.425, 0.27777777777778
60428, 1.4173913043478, 1.425, 0.22222222222222
60429, 1.4173913043478, 1.425, 0.16666666666667
60430, 1.4173913043478, 1.425, 0.11111111111111
60431, 1.4173913043478, 1.425, 0.055555555555556
60432, 1.4608695652174, 1.425, 0.44444444444444
60433, 1.4608695652174, 1.425, 0.38888888888889
60434, 1.4608695652174, 1.425, 0.33333333333333
60435, 1.4608695652174, 1.425, 0.27777777777778
60436, 1.4608695652174, 1.425, 0.22222222222222
60437, 1.4608695652174, 1.425, 0.16666666666667
60438, 1.4608695652174, 1.425, 0.11111111111111
60439, 1.4608695652174, 1.425, 0.055555555555556
60440, 1.504347826087, 1.425, 0.44444444444444
60441, 1.504347826087, 1.425, 0.38888888888889
60442, 1.504347826087, 1.425, 0.33333333333333
60443, 1.504347826087, 1.425, 0.27777777777778
60444, 1.504347826087, 1.425, 0.22222222222222
60445, 1.504347826087, 1.425, 0.16666666666667
60446, 1.504347826087, 1.425, 0.11111111111111
60447, 1.504347826087, 1.425, 0.055555555555556
60448, 1.5478260869565, 1.425, 0.44444444444444
60449, 1.5478260869565, 1.425, 0.38888888888889
60450, 1.5478260869565, 1.425, 0.33333333333333
60451, 1.5478260869565, 1.425, 0.27777777777778
60452, 1.5478260869565, 1.425, 0.22222222222222
60453, 1.5478260869565, 1.425, 0.16666666666667
60454, 1.5478260869565, 1.425, 0.11111111111111
60455, 1.5478260869565, 1.425, 0.055555555555556
60456, 1.5913043478261, 1.425, 0.44444444444444
60457, 1.5913043478261, 1.425, 0.38888888888889
60458, 1.5913043478261, 1.425, 0.33333333333333
60459, 1.5913043478261, 1.425, 0.27777777777778
60460, 1.5913043478261, 1.425, 0.22222222222222
60461, 1.5913043478261, 1.425, 0.16666666666667
60462, 1.5913043478261, 1.425, 0.11111111111111
60463, 1.5913043478261, 1.425, 0.055555555555556
60464, 1.6347826086957, 1.425, 0.44444444444444
60465, 1.6347826086957, 1.425, 0.38888888888889
60466, 1.6347826086957, 1.425, 0.33333333333333
60467, 1.6347826086957, 1.425, 0.27777777777778
60468, 1.6347826086957, 1.425, 0.22222222222222
60469, 1.6347826086957, 1.425, 0.16666666666667
60470, 1.6347826086957, 1.425, 0.11111111111111
60471, 1.6347826086957, 1.425, 0.055555555555556
60472, 1.6782608695652, 1.425, 0.44444444444444
60473, 1.6782608695652, 1.425, 0.38888888888889
60474, 1.6782608695652, 1.425, 0.33333333333333
60475, 1.6782608695652, 1.425, 0.27777777777778
60476, 1.6782608695652, 1.425, 0.22222222222222
60477, 1.6782608695652, 1.425, 0.16666666666667
60478, 1.6782608695652, 1.425, 0.11111111111111
60479, 1.6782608695652, 1.425, 0.055555555555556
60480, 1.7217391304348, 1.425, 0.44444444444444
60481, 1.7217391304348, 1.425, 0.38888888888889
60482, 1.7217391304348, 1.425, 0.33333333333333
60483, 1.7217391304348, 1.425, 0.27777777777778
60484, 1.7217391304348, 1.425, 0.22222222222222
60485, 1.7217391304348, 1.425, 0.16666666666667
60486, 1.7217391304348, 1.425, 0.11111111111111
60487, 1.7217391304348, 1.425, 0.055555555555556
60488, 1.7652173913043, 1.425, 0.44444444444444
60489, 1.7652173913043, 1.425, 0.38888888888889
60490, 1.7652173913043, 1.425, 0.33333333333333
60491, 1.7652173913043, 1.425, 0.27777777777778
60492, 1.7652173913043, 1.425, 0.22222222222222
60493, 1.7652173913043, 1.425, 0.16666666666667
60494, 1.7652173913043, 1.425, 0.11111111111111
60495, 1.7652173913043, 1.425, 0.055555555555556
60496, 1.8086956521739, 1.425, 0.44444444444444
60497, 1.8086956521739, 1.425, 0.38888888888889
60498, 1.8086956521739, 1.425, 0.33333333333333
60499, 1.8086956521739, 1.425, 0.27777777777778
60500, 1.8086956521739, 1.425, 0.22222222222222
60501, 1.8086956521739, 1.425, 0.16666666666667
60502, 1.8086956521739, 1.425, 0.11111111111111
60503, 1.8086956521739, 1.425, 0.055555555555556
60504, 1.8521739130435, 1.425, 0.44444444444444
60505, 1.8521739130435, 1.425, 0.38888888888889
60506, 1.8521739130435, 1.425, 0.33333333333333
60507, 1.8521739130435, 1.425, 0.27777777777778
60508, 1.8521739130435, 1.425, 0.22222222222222
60509, 1.8521739130435, 1.425, 0.16666666666667
60510, 1.8521739130435, 1.425, 0.11111111111111
60511, 1.8521739130435, 1.425, 0.055555555555556
60512, 1.895652173913, 1.425, 0.44444444444444
60513, 1.895652173913, 1.425, 0.38888888888889
60514, 1.895652173913, 1.425, 0.33333333333333
60515, 1.895652173913, 1.425, 0.27777777777778
60516, 1.895652173913, 1.425, 0.22222222222222
60517, 1.895652173913, 1.425, 0.16666666666667
60518, 1.895652173913, 1.425, 0.11111111111111
60519, 1.895652173913, 1.425, 0.055555555555556
60520, 1.9391304347826, 1.425, 0.44444444444444
60521, 1.9391304347826, 1.425, 0.38888888888889
60522, 1.9391304347826, 1.425, 0.33333333333333
60523, 1.9391304347826, 1.425, 0.27777777777778
60524, 1.9391304347826, 1.425, 0.22222222222222
60525, 1.9391304347826, 1.425, 0.16666666666667
60526, 1.9391304347826, 1.425, 0.11111111111111
60527, 1.9391304347826, 1.425, 0.055555555555556
60528, 1.9826086956522, 1.425, 0.44444444444444
60529, 1.9826086956522, 1.425, 0.38888888888889
60530, 1.9826086956522, 1.425, 0.33333333333333
60531, 1.9826086956522, 1.425, 0.27777777777778
60532, 1.9826086956522, 1.425, 0.22222222222222
60533, 1.9826086956522, 1.425, 0.16666666666667
60534, 1.9826086956522, 1.425, 0.11111111111111
60535, 1.9826086956522, 1.425, 0.055555555555556
60536, 2.0260869565217, 1.425, 0.44444444444444
60537, 2.0260869565217, 1.425, 0.38888888888889
60538, 2.0260869565217, 1.425, 0.33333333333333
60539, 2.0260869565217, 1.425, 0.27777777777778
60540, 2.0260869565217, 1.425, 0.22222222222222
60541, 2.0260869565217, 1.425, 0.16666666666667
60542, 2.0260869565217, 1.425, 0.11111111111111
60543, 2.0260869565217, 1.425, 0.055555555555556
60544, 2.0695652173913, 1.425, 0.44444444444444
60545, 2.0695652173913, 1.425, 0.38888888888889
60546, 2.0695652173913, 1.425, 0.33333333333333
60547, 2.0695652173913, 1.425, 0.27777777777778
60548, 2.0695652173913, 1.425, 0.22222222222222
60549, 2.0695652173913, 1.425, 0.16666666666667
60550, 2.0695652173913, 1.425, 0.11111111111111
60551, 2.0695652173913, 1.425, 0.055555555555556
60552, 2.1130434782609, 1.425, 0.44444444444444
60553, 2.1130434782609, 1.425, 0.38888888888889
60554, 2.1130434782609, 1.425, 0.33333333333333
60555, 2.1130434782609, 1.425, 0.27777777777778
60556, 2.1130434782609, 1.425, 0.22222222222222
60557, 2.1130434782609, 1.425, 0.16666666666667
60558, 2.1130434782609, 1.425, 0.11111111111111
60559, 2.1130434782609, 1.425, 0.055555555555556
60560, 2.1565217391304, 1.425, 0.44444444444444
60561, 2.1565217391304, 1.425, 0.38888888888889
60562, 2.1565217391304, 1.425, 0.33333333333333
60563, 2.1565217391304, 1.425, 0.27777777777778
60564, 2.1565217391304, 1.425, 0.22222222222222
60565, 2.1565217391304, 1.425, 0.16666666666667
60566, 2.1565217391304, 1.425, 0.11111111111111
60567, 2.1565217391304, 1.425, 0.055555555555556
60568, 1.2434782608696, 1.425, 0.47222222222222
60569, 1.2217391304348, 1.425, 0.44444444444444
60570, 1.2434782608696, 1.4375, 0.44444444444444
60571, 1.2434782608696, 1.425, 0.41666666666667
60572, 1.2217391304348, 1.425, 0.38888888888889
60573, 1.2434782608696, 1.4375, 0.38888888888889
60574, 1.2434782608696, 1.425, 0.36111111111111
60575, 1.2217391304348, 1.425, 0.33333333333333
60576, 1.2434782608696, 1.4375, 0.33333333333333
60577, 1.2434782608696, 1.425, 0.30555555555556
60578, 1.2217391304348, 1.425, 0.27777777777778
60579, 1.2434782608696, 1.4375, 0.27777777777778
60580, 1.2434782608696, 1.425, 0.25
60581, 1.2217391304348, 1.425, 0.22222222222222
60582, 1.2434782608696, 1.4375, 0.22222222222222
60583, 1.2434782608696, 1.425, 0.19444444444444
60584, 1.2217391304348, 1.425, 0.16666666666667
60585, 1.2434782608696, 1.4375, 0.16666666666667
60586, 1.2434782608696, 1.425, 0.13888888888889
60587, 1.2217391304348, 1.425, 0.11111111111111
60588, 1.2434782608696, 1.4375, 0.11111111111111
60589, 1.2434782608696, 1.425, 0.083333333333333
60590, 1.2217391304348, 1.425, 0.055555555555556
60591, 1.2434782608696, 1.4375, 0.055555555555556
60592, 1.2434782608696, 1.425, 0.027777777777778
60593, 1.2869565217391, 1.425, 0.47222222222222
60594, 1.2652173913043, 1.425, 0.44444444444444
60595, 1.2869565217391, 1.4375, 0.44444444444444
60596, 1.2869565217391, 1.425, 0.41666666666667
60597, 1.2652173913043, 1.425, 0.38888888888889
60598, 1.2869565217391, 1.4375, 0.38888888888889
60599, 1.2869565217391, 1.425, 0.36111111111111
60600, 1.2652173913043, 1.425, 0.33333333333333
60601, 1.2869565217391, 1.4375, 0.33333333333333
60602, 1.2869565217391, 1.425, 0.30555555555556
60603, 1.2652173913043, 1.425, 0.27777777777778
60604, 1.2869565217391, 1.4375, 0.27777777777778
60605, 1.2869565217391, 1.425, 0.25
60606, 1.2652173913043, 1.425, 0.22222222222222
60607, 1.2869565217391, 1.4375, 0.22222222222222
60608, 1.2869565217391, 1.425, 0.19444444444444
60609, 1.2652173913043, 1.425, 0.16666666666667
60610, 1.2869565217391, 1.4375, 0.16666666666667
60611, 1.2869565217391, 1.425, 0.13888888888889
60612, 1.2652173913043, 1.425, 0.11111111111111
60613, 1.2869565217391, 1.4375, 0.11111111111111
60614, 1.2869565217391, 1.425, 0.083333333333333
60615, 1.2652173913043, 1.425, 0.055555555555556
60616, 1.2869565217391, 1.4375, 0.055555555555556
60617, 1.2869565217391, 1.425, 0.027777777777778
60618, 1.3304347826087, 1.425, 0.47222222222222
60619, 1.3086956521739, 1.425, 0.44444444444444
60620, 1.3304347826087, 1.4375, 0.44444444444444
60621, 1.3304347826087, 1.425, 0.41666666666667
60622, 1.3086956521739, 1.425, 0.38888888888889
60623, 1.3304347826087, 1.4375, 0.38888888888889
60624, 1.3304347826087, 1.425, 0.36111111111111
60625, 1.3086956521739, 1.425, 0.33333333333333
60626, 1.3304347826087, 1.4375, 0.33333333333333
60627, 1.3304347826087, 1.425, 0.30555555555556
60628, 1.3086956521739, 1.425, 0.27777777777778
60629, 1.3304347826087, 1.4375, 0.27777777777778
60630, 1.3304347826087, 1.425, 0.25
60631, 1.3086956521739, 1.425, 0.22222222222222
60632, 1.3304347826087, 1.4375, 0.22222222222222
60633, 1.3304347826087, 1.425, 0.19444444444444
60634, 1.3086956521739, 1.425, 0.16666666666667
60635, 1.3304347826087, 1.4375, 0.16666666666667
60636, 1.3304347826087, 1.425, 0.13888888888889
60637, 1.3086956521739, 1.425, 0.11111111111111
60638, 1.3304347826087, 1.4375, 0.11111111111111
60639, 1.3304347826087, 1.425, 0.083333333333333
60640, 1.3086956521739, 1.425, 0.055555555555556
60641, 1.3304347826087, 1.4375, 0.055555555555556
60642, 1.3304347826087, 1.425, 0.027777777777778
60643, 1.3739130434783, 1.425, 0.47222222222222
60644, 1.3521739130435, 1.425, 0.44444444444444
60645, 1.3739130434783, 1.4375, 0.44444444444444
60646, 1.3739130434783, 1.425, 0.41666666666667
60647, 1.3521739130435, 1.425, 0.38888888888889
60648, 1.3739130434783, 1.4375, 0.38888888888889
60649, 1.3739130434783, 1.425, 0.36111111111111
60650, 1.3521739130435, 1.425, 0.33333333333333
60651, 1.3739130434783, 1.4375, 0.33333333333333
60652, 1.3739130434783, 1.425, 0.30555555555556
60653, 1.3521739130435, 1.425, 0.27777777777778
60654, 1.3739130434783, 1.4375, 0.27777777777778
60655, 1.3739130434783, 1.425, 0.25
60656, 1.3521739130435, 1.425, 0.22222222222222
60657, 1.3739130434783, 1.4375, 0.22222222222222
60658, 1.3739130434783, 1.425, 0.19444444444444
60659, 1.3521739130435, 1.425, 0.16666666666667
60660, 1.3739130434783, 1.4375, 0.16666666666667
60661, 1.3739130434783, 1.425, 0.13888888888889
60662, 1.3521739130435, 1.425, 0.11111111111111
60663, 1.3739130434783, 1.4375, 0.11111111111111
60664, 1.3739130434783, 1.425, 0.083333333333333
60665, 1.3521739130435, 1.425, 0.055555555555556
60666, 1.3739130434783, 1.4375, 0.055555555555556
60667, 1.3739130434783, 1.425, 0.027777777777778
60668, 1.4173913043478, 1.425, 0.47222222222222
60669, 1.395652173913, 1.425, 0.44444444444444
60670, 1.4173913043478, 1.4375, 0.44444444444444
60671, 1.4173913043478, 1.425, 0.41666666666667
60672, 1.395652173913, 1.425, 0.38888888888889
60673, 1.4173913043478, 1.4375, 0.38888888888889
60674, 1.4173913043478, 1.425, 0.36111111111111
60675, 1.395652173913, 1.425, 0.33333333333333
60676, 1.4173913043478, 1.4375, 0.33333333333333
60677, 1.4173913043478, 1.425, 0.30555555555556
60678, 1.395652173913, 1.425, 0.27777777777778
60679, 1.4173913043478, 1.4375, 0.27777777777778
60680, 1.4173913043478, 1.425, 0.25
60681, 1.395652173913, 1.425, 0.22222222222222
60682, 1.4173913043478, 1.4375, 0.22222222222222
60683, 1.4173913043478, 1.425, 0.19444444444444
60684, 1.395652173913, 1.425, 0.16666666666667
60685, 1.4173913043478, 1.4375, 0.16666666666667
60686, 1.4173913043478, 1.425, 0.13888888888889
60687, 1.395652173913, 1.425, 0.11111111111111
60688, 1.4173913043478, 1.4375, 0.11111111111111
60689, 1.4173913043478, 1.425, 0.083333333333333
60690, 1.395652173913, 1.425, 0.055555555555556
60691, 1.4173913043478, 1.4375, 0.055555555555556
60692, 1.4173913043478, 1.425, 0.027777777777778
60693, 1.4608695652174, 1.425, 0.47222222222222
60694, 1.4391304347826, 1.425, 0.44444444444444
60695, 1.4608695652174, 1.4375, 0.44444444444444
60696, 1.4608695652174, 1.425, 0.41666666666667
60697, 1.4391304347826, 1.425, 0.38888888888889
60698, 1.4608695652174, 1.4375, 0.38888888888889
60699, 1.4608695652174, 1.425, 0.36111111111111
60700, 1.4391304347826, 1.425, 0.33333333333333
60701, 1.4608695652174, 1.4375, 0.33333333333333
60702, 1.4608695652174, 1.425, 0.30555555555556
60703, 1.4391304347826, 1.425, 0.27777777777778
60704, 1.4608695652174, 1.4375, 0.27777777777778
60705, 1.4608695652174, 1.425, 0.25
60706, 1.4391304347826, 1.425, 0.22222222222222
60707, 1.4608695652174, 1.4375, 0.22222222222222
60708, 1.4608695652174, 1.425, 0.19444444444444
60709, 1.4391304347826, 1.425, 0.16666666666667
60710, 1.4608695652174, 1.4375, 0.16666666666667
60711, 1.4608695652174, 1.425, 0.13888888888889
60712, 1.4391304347826, 1.425, 0.11111111111111
60713, 1.4608695652174, 1.4375, 0.11111111111111
60714, 1.4608695652174, 1.425, 0.083333333333333
60715, 1.4391304347826, 1.425, 0.055555555555556
60716, 1.4608695652174, 1.4375, 0.055555555555556
60717, 1.4608695652174, 1.425, 0.027777777777778
60718, 1.504347826087, 1.425, 0.47222222222222
60719, 1.4826086956522, 1.425, 0.44444444444444
60720, 1.504347826087, 1.4375, 0.44444444444444
60721, 1.504347826087, 1.425, 0.41666666666667
60722, 1.4826086956522, 1.425, 0.38888888888889
60723, 1.504347826087, 1.4375, 0.38888888888889
60724, 1.504347826087, 1.425, 0.36111111111111
60725, 1.4826086956522, 1.425, 0.33333333333333
60726, 1.504347826087, 1.4375, 0.33333333333333
60727, 1.504347826087, 1.425, 0.30555555555556
60728, 1.4826086956522, 1.425, 0.27777777777778
60729, 1.504347826087, 1.4375, 0.27777777777778
60730, 1.504347826087, 1.425, 0.25
60731, 1.4826086956522, 1.425, 0.22222222222222
60732, 1.504347826087, 1.4375, 0.22222222222222
60733, 1.504347826087, 1.425, 0.19444444444444
60734, 1.4826086956522, 1.425, 0.16666666666667
60735, 1.504347826087, 1.4375, 0.16666666666667
60736, 1.504347826087, 1.425, 0.13888888888889
60737, 1.4826086956522, 1.425, 0.11111111111111
60738, 1.504347826087, 1.4375, 0.11111111111111
60739, 1.504347826087, 1.425, 0.083333333333333
60740, 1.4826086956522, 1.425, 0.055555555555556
60741, 1.504347826087, 1.4375, 0.055555555555556
60742, 1.504347826087, 1.425, 0.027777777777778
60743, 1.5478260869565, 1.425, 0.47222222222222
60744, 1.5260869565217, 1.425, 0.44444444444444
60745, 1.5478260869565, 1.4375, 0.44444444444444
60746, 1.5478260869565, 1.425, 0.41666666666667
60747, 1.5260869565217, 1.425, 0.38888888888889
60748, 1.5478260869565, 1.4375, 0.38888888888889
60749, 1.5478260869565, 1.425, 0.36111111111111
60750, 1.5260869565217, 1.425, 0.33333333333333
60751, 1.5478260869565, 1.4375, 0.33333333333333
60752, 1.5478260869565, 1.425, 0.30555555555556
60753, 1.5260869565217, 1.425, 0.27777777777778
60754, 1.5478260869565, 1.4375, 0.27777777777778
60755, 1.5478260869565, 1.425, 0.25
60756, 1.5260869565217, 1.425, 0.22222222222222
60757, 1.5478260869565, 1.4375, 0.22222222222222
60758, 1.5478260869565, 1.425, 0.19444444444444
60759, 1.5260869565217, 1.425, 0.16666666666667
60760, 1.5478260869565, 1.4375, 0.16666666666667
60761, 1.5478260869565, 1.425, 0.13888888888889
60762, 1.5260869565217, 1.425, 0.11111111111111
60763, 1.5478260869565, 1.4375, 0.11111111111111
60764, 1.5478260869565, 1.425, 0.083333333333333
60765, 1.5260869565217, 1.425, 0.055555555555556
60766, 1.5478260869565, 1.4375, 0.055555555555556
60767, 1.5478260869565, 1.425, 0.027777777777778
60768, 1.5913043478261, 1.425, 0.47222222222222
60769, 1.5695652173913, 1.425, 0.44444444444444
60770, 1.5913043478261, 1.4375, 0.44444444444444
60771, 1.5913043478261, 1.425, 0.41666666666667
60772, 1.5695652173913, 1.425, 0.38888888888889
60773, 1.5913043478261, 1.4375, 0.38888888888889
60774, 1.5913043478261, 1.425, 0.36111111111111
60775, 1.5695652173913, 1.425, 0.33333333333333
60776, 1.5913043478261, 1.4375, 0.33333333333333
60777, 1.5913043478261, 1.425, 0.30555555555556
60778, 1.5695652173913, 1.425, 0.27777777777778
60779, 1.5913043478261, 1.4375, 0.27777777777778
60780, 1.5913043478261, 1.425, 0.25
60781, 1.5695652173913, 1.425, 0.22222222222222
60782, 1.5913043478261, 1.4375, 0.22222222222222
60783, 1.5913043478261, 1.425, 0.19444444444444
60784, 1.5695652173913, 1.425, 0.16666666666667
60785, 1.5913043478261, 1.4375, 0.16666666666667
60786, 1.5913043478261, 1.425, 0.13888888888889
60787, 1.5695652173913, 1.425, 0.11111111111111
60788, 1.5913043478261, 1.4375, 0.11111111111111
60789, 1.5913043478261, 1.425, 0.083333333333333
60790, 1.5695652173913, 1.425, 0.055555555555556
60791, 1.5913043478261, 1.4375, 0.055555555555556
60792, 1.5913043478261, 1.425, 0.027777777777778
60793, 1.6347826086957, 1.425, 0.47222222222222
60794, 1.6130434782609, 1.425, 0.44444444444444
60795, 1.6347826086957, 1.4375, 0.44444444444444
60796, 1.6347826086957, 1.425, 0.41666666666667
60797, 1.6130434782609, 1.425, 0.38888888888889
60798, 1.6347826086957, 1.4375, 0.38888888888889
60799, 1.6347826086957, 1.425, 0.36111111111111
60800, 1.6130434782609, 1.425, 0.33333333333333
60801, 1.6347826086957, 1.4375, 0.33333333333333
60802, 1.6347826086957, 1.425, 0.30555555555556
60803, 1.6130434782609, 1.425, 0.27777777777778
60804, 1.6347826086957, 1.4375, 0.27777777777778
60805, 1.6347826086957, 1.425, 0.25
60806, 1.6130434782609, 1.425, 0.22222222222222
60807, 1.6347826086957, 1.4375, 0.22222222222222
60808, 1.6347826086957, 1.425, 0.19444444444444
60809, 1.6130434782609, 1.425, 0.16666666666667
60810, 1.6347826086957, 1.4375, 0.16666666666667
60811, 1.6347826086957, 1.425, 0.13888888888889
60812, 1.6130434782609, 1.425, 0.11111111111111
60813, 1.6347826086957, 1.4375, 0.11111111111111
60814, 1.6347826086957, 1.425, 0.083333333333333
60815, 1.6130434782609, 1.425, 0.055555555555556
60816, 1.6347826086957, 1.4375, 0.055555555555556
60817, 1.6347826086957, 1.425, 0.027777777777778
60818, 1.6782608695652, 1.425, 0.47222222222222
60819, 1.6565217391304, 1.425, 0.44444444444444
60820, 1.6782608695652, 1.4375, 0.44444444444444
60821, 1.6782608695652, 1.425, 0.41666666666667
60822, 1.6565217391304, 1.425, 0.38888888888889
60823, 1.6782608695652, 1.4375, 0.38888888888889
60824, 1.6782608695652, 1.425, 0.36111111111111
60825, 1.6565217391304, 1.425, 0.33333333333333
60826, 1.6782608695652, 1.4375, 0.33333333333333
60827, 1.6782608695652, 1.425, 0.30555555555556
60828, 1.6565217391304, 1.425, 0.27777777777778
60829, 1.6782608695652, 1.4375, 0.27777777777778
60830, 1.6782608695652, 1.425, 0.25
60831, 1.6565217391304, 1.425, 0.22222222222222
60832, 1.6782608695652, 1.4375, 0.22222222222222
60833, 1.6782608695652, 1.425, 0.19444444444444
60834, 1.6565217391304, 1.425, 0.16666666666667
60835, 1.6782608695652, 1.4375, 0.16666666666667
60836, 1.6782608695652, 1.425, 0.13888888888889
60837, 1.6565217391304, 1.425, 0.11111111111111
60838, 1.6782608695652, 1.4375, 0.11111111111111
60839, 1.6782608695652, 1.425, 0.083333333333333
60840, 1.6565217391304, 1.425, 0.055555555555556
60841, 1.6782608695652, 1.4375, 0.055555555555556
60842, 1.6782608695652, 1.425, 0.027777777777778
60843, 1.7217391304348, 1.425, 0.47222222222222
60844, 1.7, 1.425, 0.44444444444444
60845, 1.7217391304348, 1.4375, 0.44444444444444
60846, 1.7217391304348, 1.425, 0.41666666666667
60847, 1.7, 1.425, 0.38888888888889
60848, 1.7217391304348, 1.4375, 0.38888888888889
60849, 1.7217391304348, 1.425, 0.36111111111111
60850, 1.7, 1.425, 0.33333333333333
60851, 1.7217391304348, 1.4375, 0.33333333333333
60852, 1.7217391304348, 1.425, 0.30555555555556
60853, 1.7, 1.425, 0.27777777777778
60854, 1.7217391304348, 1.4375, 0.27777777777778
60855, 1.7217391304348, 1.425, 0.25
60856, 1.7, 1.425, 0.22222222222222
60857, 1.7217391304348, 1.4375, 0.22222222222222
60858, 1.7217391304348, 1.425, 0.19444444444444
60859, 1.7, 1.425, 0.16666666666667
60860, 1.7217391304348, 1.4375, 0.16666666666667
60861, 1.7217391304348, 1.425, 0.13888888888889
60862, 1.7, 1.425, 0.11111111111111
60863, 1.7217391304348, 1.4375, 0.11111111111111
60864, 1.7217391304348, 1.425, 0.083333333333333
60865, 1.7, 1.425, 0.055555555555556
60866, 1.7217391304348, 1.4375, 0.055555555555556
60867, 1.7217391304348, 1.425, 0.027777777777778
60868, 1.7652173913043, 1.425, 0.47222222222222
60869, 1.7434782608696, 1.425, 0.44444444444444
60870, 1.7652173913043, 1.4375, 0.44444444444444
60871, 1.7652173913043, 1.425, 0.41666666666667
60872, 1.7434782608696, 1.425, 0.38888888888889
60873, 1.7652173913043, 1.4375, 0.38888888888889
60874, 1.7652173913043, 1.425, 0.36111111111111
60875, 1.7434782608696, 1.425, 0.33333333333333
60876, 1.7652173913043, 1.4375, 0.33333333333333
60877, 1.7652173913043, 1.425, 0.30555555555556
60878, 1.7434782608696, 1.425, 0.27777777777778
60879, 1.7652173913043, 1.4375, 0.27777777777778
60880, 1.7652173913043, 1.425, 0.25
60881, 1.7434782608696, 1.425, 0.22222222222222
60882, 1.7652173913043, 1.4375, 0.22222222222222
60883, 1.7652173913043, 1.425, 0.19444444444444
60884, 1.7434782608696, 1.425, 0.16666666666667
60885, 1.7652173913043, 1.4375, 0.16666666666667
60886, 1.7652173913043, 1.425, 0.13888888888889
60887, 1.7434782608696, 1.425, 0.11111111111111
60888, 1.7652173913043, 1.4375, 0.11111111111111
60889, 1.7652173913043, 1.425, 0.083333333333333
60890, 1.7434782608696, 1.425, 0.055555555555556
60891, 1.7652173913043, 1.4375, 0.055555555555556
60892, 1.7652173913043, 1.425, 0.027777777777778
60893, 1.8086956521739, 1.425, 0.47222222222222
60894, 1.7869565217391, 1.425, 0.44444444444444
60895, 1.8086956521739, 1.4375, 0.44444444444444
60896, 1.8086956521739, 1.425, 0.41666666666667
60897, 1.7869565217391, 1.425, 0.38888888888889
60898, 1.8086956521739, 1.4375, 0.38888888888889
60899, 1.8086956521739, 1.425, 0.36111111111111
60900, 1.7869565217391, 1.425, 0.33333333333333
60901, 1.8086956521739, 1.4375, 0.33333333333333
60902, 1.8086956521739, 1.425, 0.30555555555556
60903, 1.7869565217391, 1.425, 0.27777777777778
60904, 1.8086956521739, 1.4375, 0.27777777777778
60905, 1.8086956521739, 1.425, 0.25
60906, 1.7869565217391, 1.425, 0.22222222222222
60907, 1.8086956521739, 1.4375, 0.22222222222222
60908, 1.8086956521739, 1.425, 0.19444444444444
60909, 1.7869565217391, 1.425, 0.16666666666667
60910, 1.8086956521739, 1.4375, 0.16666666666667
60911, 1.8086956521739, 1.425, 0.13888888888889
60912, 1.7869565217391, 1.425, 0.11111111111111
60913, 1.8086956521739, 1.4375, 0.11111111111111
60914, 1.8086956521739, 1.425, 0.083333333333333
60915, 1.7869565217391, 1.425, 0.055555555555556
60916, 1.8086956521739, 1.4375, 0.055555555555556
60917, 1.8086956521739, 1.425, 0.027777777777778
60918, 1.8521739130435, 1.425, 0.47222222222222
60919, 1.8304347826087, 1.425, 0.44444444444444
60920, 1.8521739130435, 1.4375, 0.44444444444444
60921, 1.8521739130435, 1.425, 0.41666666666667
60922, 1.8304347826087, 1.425, 0.38888888888889
60923, 1.8521739130435, 1.4375, 0.38888888888889
60924, 1.8521739130435, 1.425, 0.36111111111111
60925, 1.8304347826087, 1.425, 0.33333333333333
60926, 1.8521739130435, 1.4375, 0.33333333333333
60927, 1.8521739130435, 1.425, 0.30555555555556
60928, 1.8304347826087, 1.425, 0.27777777777778
60929, 1.8521739130435, 1.4375, 0.27777777777778
60930, 1.8521739130435, 1.425, 0.25
60931, 1.8304347826087, 1.425, 0.22222222222222
60932, 1.8521739130435, 1.4375, 0.22222222222222
60933, 1.8521739130435, 1.425, 0.19444444444444
60934, 1.8304347826087, 1.425, 0.16666666666667
60935, 1.8521739130435, 1.4375, 0.16666666666667
60936, 1.8521739130435, 1.425, 0.13888888888889
60937, 1.8304347826087, 1.425, 0.11111111111111
60938, 1.8521739130435, 1.4375, 0.11111111111111
60939, 1.8521739130435, 1.425, 0.083333333333333
60940, 1.8304347826087, 1.425, 0.055555555555556
60941, 1.8521739130435, 1.4375, 0.055555555555556
60942, 1.8521739130435, 1.425, 0.027777777777778
60943, 1.895652173913, 1.425, 0.47222222222222
60944, 1.8739130434783, 1.425, 0.44444444444444
60945, 1.895652173913, 1.4375, 0.44444444444444
60946, 1.895652173913, 1.425, 0.41666666666667
60947, 1.8739130434783, 1.425, 0.38888888888889
60948, 1.895652173913, 1.4375, 0.38888888888889
60949, 1.895652173913, 1.425, 0.36111111111111
60950, 1.8739130434783, 1.425, 0.33333333333333
60951, 1.895652173913, 1.4375, 0.33333333333333
60952, 1.895652173913, 1.425, 0.30555555555556
60953, 1.8739130434783, 1.425, 0.27777777777778
60954, 1.895652173913, 1.4375, 0.27777777777778
60955, 1.895652173913, 1.425, 0.25
60956, 1.8739130434783, 1.425, 0.22222222222222
60957, 1.895652173913, 1.4375, 0.22222222222222
60958, 1.895652173913, 1.425, 0.19444444444444
60959, 1.8739130434783, 1.425, 0.16666666666667
60960, 1.895652173913, 1.4375, 0.16666666666667
60961, 1.895652173913, 1.425, 0.13888888888889
60962, 1.8739130434783, 1.425, 0.11111111111111
60963, 1.895652173913, 1.4375, 0.11111111111111
60964, 1.895652173913, 1.425, 0.083333333333333
60965, 1.8739130434783, 1.425, 0.055555555555556
60966, 1.895652173913, 1.4375, 0.055555555555556
60967, 1.895652173913, 1.425, 0.027777777777778
60968, 1.9391304347826, 1.425, 0.47222222222222
60969, 1.9173913043478, 1.425, 0.44444444444444
60970, 1.9391304347826, 1.4375, 0.44444444444444
60971, 1.9391304347826, 1.425, 0.41666666666667
60972, 1.9173913043478, 1.425, 0.38888888888889
60973, 1.9391304347826, 1.4375, 0.38888888888889
60974, 1.9391304347826, 1.425, 0.36111111111111
60975, 1.9173913043478, 1.425, 0.33333333333333
60976, 1.9391304347826, 1.4375, 0.33333333333333
60977, 1.9391304347826, 1.425, 0.30555555555556
60978, 1.9173913043478, 1.425, 0.27777777777778
60979, 1.9391304347826, 1.4375, 0.27777777777778
60980, 1.9391304347826, 1.425, 0.25
60981, 1.9173913043478, 1.425, 0.22222222222222
60982, 1.9391304347826, 1.4375, 0.22222222222222
60983, 1.9391304347826, 1.425, 0.19444444444444
60984, 1.9173913043478, 1.425, 0.16666666666667
60985, 1.9391304347826, 1.4375, 0.16666666666667
60986, 1.9391304347826, 1.425, 0.13888888888889
60987, 1.9173913043478, 1.425, 0.11111111111111
60988, 1.9391304347826, 1.4375, 0.11111111111111
60989, 1.9391304347826, 1.425, 0.083333333333333
60990, 1.9173913043478, 1.425, 0.055555555555556
60991, 1.9391304347826, 1.4375, 0.055555555555556
60992, 1.9391304347826, 1.425, 0.027777777777778
60993, 1.9826086956522, 1.425, 0.47222222222222
60994, 1.9608695652174, 1.425, 0.44444444444444
60995, 1.9826086956522, 1.4375, 0.44444444444444
60996, 1.9826086956522, 1.425, 0.41666666666667
60997, 1.9608695652174, 1.425, 0.38888888888889
60998, 1.9826086956522, 1.4375, 0.38888888888889
60999, 1.9826086956522, 1.425, 0.36111111111111
61000, 1.9608695652174, 1.425, 0.33333333333333
61001, 1.9826086956522, 1.4375, 0.33333333333333
61002, 1.9826086956522, 1.425, 0.30555555555556
61003, 1.9608695652174, 1.425, 0.27777777777778
61004, 1.9826086956522, 1.4375, 0.27777777777778
61005, 1.9826086956522, 1.425, 0.25
61006, 1.9608695652174, 1.425, 0.22222222222222
61007, 1.9826086956522, 1.4375, 0.22222222222222
61008, 1.9826086956522, 1.425, 0.19444444444444
61009, 1.9608695652174, 1.425, 0.16666666666667
61010, 1.9826086956522, 1.4375, 0.16666666666667
61011, 1.9826086956522, 1.425, 0.13888888888889
61012, 1.9608695652174, 1.425, 0.11111111111111
61013, 1.9826086956522, 1.4375, 0.11111111111111
61014, 1.9826086956522, 1.425, 0.083333333333333
61015, 1.9608695652174, 1.425, 0.055555555555556
61016, 1.9826086956522, 1.4375, 0.055555555555556
61017, 1.9826086956522, 1.425, 0.027777777777778
61018, 2.0260869565217, 1.425, 0.47222222222222
61019, 2.004347826087, 1.425, 0.44444444444444
61020, 2.0260869565217, 1.4375, 0.44444444444444
61021, 2.0260869565217, 1.425, 0.41666666666667
61022, 2.004347826087, 1.425, 0.38888888888889
61023, 2.0260869565217, 1.4375, 0.38888888888889
61024, 2.0260869565217, 1.425, 0.36111111111111
61025, 2.004347826087, 1.425, 0.33333333333333
61026, 2.0260869565217, 1.4375, 0.33333333333333
61027, 2.0260869565217, 1.425, 0.30555555555556
61028, 2.004347826087, 1.425, 0.27777777777778
61029, 2.0260869565217, 1.4375, 0.27777777777778
61030, 2.0260869565217, 1.425, 0.25
61031, 2.004347826087, 1.425, 0.22222222222222
61032, 2.0260869565217, 1.4375, 0.22222222222222
61033, 2.0260869565217, 1.425, 0.19444444444444
61034, 2.004347826087, 1.425, 0.16666666666667
61035, 2.0260869565217, 1.4375, 0.16666666666667
61036, 2.0260869565217, 1.425, 0.13888888888889
61037, 2.004347826087, 1.425, 0.11111111111111
61038, 2.0260869565217, 1.4375, 0.11111111111111
61039, 2.0260869565217, 1.425, 0.083333333333333
61040, 2.004347826087, 1.425, 0.055555555555556
61041, 2.0260869565217, 1.4375, 0.055555555555556
61042, 2.0260869565217, 1.425, 0.027777777777778
61043, 2.0695652173913, 1.425, 0.47222222222222
61044, 2.0478260869565, 1.425, 0.44444444444444
61045, 2.0695652173913, 1.4375, 0.44444444444444
61046, 2.0695652173913, 1.425, 0.41666666666667
61047, 2.0478260869565, 1.425, 0.38888888888889
61048, 2.0695652173913, 1.4375, 0.38888888888889
61049, 2.0695652173913, 1.425, 0.36111111111111
61050, 2.0478260869565, 1.425, 0.33333333333333
61051, 2.0695652173913, 1.4375, 0.33333333333333
61052, 2.0695652173913, 1.425, 0.30555555555556
61053, 2.0478260869565, 1.425, 0.27777777777778
61054, 2.0695652173913, 1.4375, 0.27777777777778
61055, 2.0695652173913, 1.425, 0.25
61056, 2.0478260869565, 1.425, 0.22222222222222
61057, 2.0695652173913, 1.4375, 0.22222222222222
61058, 2.0695652173913, 1.425, 0.19444444444444
61059, 2.0478260869565, 1.425, 0.16666666666667
61060, 2.0695652173913, 1.4375, 0.16666666666667
61061, 2.0695652173913, 1.425, 0.13888888888889
61062, 2.0478260869565, 1.425, 0.11111111111111
61063, 2.0695652173913, 1.4375, 0.11111111111111
61064, 2.0695652173913, 1.425, 0.083333333333333
61065, 2.0478260869565, 1.425, 0.055555555555556
61066, 2.0695652173913, 1.4375, 0.055555555555556
61067, 2.0695652173913, 1.425, 0.027777777777778
61068, 2.1130434782609, 1.425, 0.47222222222222
61069, 2.0913043478261, 1.425, 0.44444444444444
61070, 2.1130434782609, 1.4375, 0.44444444444444
61071, 2.1130434782609, 1.425, 0.41666666666667
61072, 2.0913043478261, 1.425, 0.38888888888889
61073, 2.1130434782609, 1.4375, 0.38888888888889
61074, 2.1130434782609, 1.425, 0.36111111111111
61075, 2.0913043478261, 1.425, 0.33333333333333
61076, 2.1130434782609, 1.4375, 0.33333333333333
61077, 2.1130434782609, 1.425, 0.30555555555556
61078, 2.0913043478261, 1.425, 0.27777777777778
61079, 2.1130434782609, 1.4375, 0.27777777777778
61080, 2.1130434782609, 1.425, 0.25
61081, 2.0913043478261, 1.425, 0.22222222222222
61082, 2.1130434782609, 1.4375, 0.22222222222222
61083, 2.1130434782609, 1.425, 0.19444444444444
61084, 2.0913043478261, 1.425, 0.16666666666667
61085, 2.1130434782609, 1.4375, 0.16666666666667
61086, 2.1130434782609, 1.425, 0.13888888888889
61087, 2.0913043478261, 1.425, 0.11111111111111
61088, 2.1130434782609, 1.4375, 0.11111111111111
61089, 2.1130434782609, 1.425, 0.083333333333333
61090, 2.0913043478261, 1.425, 0.055555555555556
61091, 2.1130434782609, 1.4375, 0.055555555555556
61092, 2.1130434782609, 1.425, 0.027777777777778
61093, 2.1565217391304, 1.425, 0.47222222222222
61094, 2.1347826086957, 1.425, 0.44444444444444
61095, 2.1565217391304, 1.4375, 0.44444444444444
61096, 2.1565217391304, 1.425, 0.41666666666667
61097, 2.1347826086957, 1.425, 0.38888888888889
61098, 2.1565217391304, 1.4375, 0.38888888888889
61099, 2.1565217391304, 1.425, 0.36111111111111
61100, 2.1347826086957, 1.425, 0.33333333333333
61101, 2.1565217391304, 1.4375, 0.33333333333333
61102, 2.1565217391304, 1.425, 0.30555555555556
61103, 2.1347826086957, 1.425, 0.27777777777778
61104, 2.1565217391304, 1.4375, 0.27777777777778
61105, 2.1565217391304, 1.425, 0.25
61106, 2.1347826086957, 1.425, 0.22222222222222
61107, 2.1565217391304, 1.4375, 0.22222222222222
61108, 2.1565217391304, 1.425, 0.19444444444444
61109, 2.1347826086957, 1.425, 0.16666666666667
61110, 2.1565217391304, 1.4375, 0.16666666666667
61111, 2.1565217391304, 1.425, 0.13888888888889
61112, 2.1347826086957, 1.425, 0.11111111111111
61113, 2.1565217391304, 1.4375, 0.11111111111111
61114, 2.1565217391304, 1.425, 0.083333333333333
61115, 2.1347826086957, 1.425, 0.055555555555556
61116, 2.1565217391304, 1.4375, 0.055555555555556
61117, 2.1565217391304, 1.425, 0.027777777777778
61118, 2.1782608695652, 1.425, 0.44444444444444
61119, 2.1782608695652, 1.425, 0.38888888888889
61120, 2.1782608695652, 1.425, 0.33333333333333
61121, 2.1782608695652, 1.425, 0.27777777777778
61122, 2.1782608695652, 1.425, 0.22222222222222
61123, 2.1782608695652, 1.425, 0.16666666666667
61124, 2.1782608695652, 1.425, 0.11111111111111
61125, 2.1782608695652, 1.425, 0.055555555555556
61126, 1.2434782608696, 1.4125, 0.44444444444444
61127, 1.2434782608696, 1.4125, 0.38888888888889
61128, 1.2434782608696, 1.4125, 0.33333333333333
61129, 1.2434782608696, 1.4125, 0.27777777777778
61130, 1.2434782608696, 1.4125, 0.22222222222222
61131, 1.2434782608696, 1.4125, 0.16666666666667
61132, 1.2434782608696, 1.4125, 0.11111111111111
61133, 1.2434782608696, 1.4125, 0.055555555555556
61134, 1.2869565217391, 1.4125, 0.44444444444444
61135, 1.2869565217391, 1.4125, 0.38888888888889
61136, 1.2869565217391, 1.4125, 0.33333333333333
61137, 1.2869565217391, 1.4125, 0.27777777777778
61138, 1.2869565217391, 1.4125, 0.22222222222222
61139, 1.2869565217391, 1.4125, 0.16666666666667
61140, 1.2869565217391, 1.4125, 0.11111111111111
61141, 1.2869565217391, 1.4125, 0.055555555555556
61142, 1.3304347826087, 1.4125, 0.44444444444444
61143, 1.3304347826087, 1.4125, 0.38888888888889
61144, 1.3304347826087, 1.4125, 0.33333333333333
61145, 1.3304347826087, 1.4125, 0.27777777777778
61146, 1.3304347826087, 1.4125, 0.22222222222222
61147, 1.3304347826087, 1.4125, 0.16666666666667
61148, 1.3304347826087, 1.4125, 0.11111111111111
61149, 1.3304347826087, 1.4125, 0.055555555555556
61150, 1.3739130434783, 1.4125, 0.44444444444444
61151, 1.3739130434783, 1.4125, 0.38888888888889
61152, 1.3739130434783, 1.4125, 0.33333333333333
61153, 1.3739130434783, 1.4125, 0.27777777777778
61154, 1.3739130434783, 1.4125, 0.22222222222222
61155, 1.3739130434783, 1.4125, 0.16666666666667
61156, 1.3739130434783, 1.4125, 0.11111111111111
61157, 1.3739130434783, 1.4125, 0.055555555555556
61158, 1.4173913043478, 1.4125, 0.44444444444444
61159, 1.4173913043478, 1.4125, 0.38888888888889
61160, 1.4173913043478, 1.4125, 0.33333333333333
61161, 1.4173913043478, 1.4125, 0.27777777777778
61162, 1.4173913043478, 1.4125, 0.22222222222222
61163, 1.4173913043478, 1.4125, 0.16666666666667
61164, 1.4173913043478, 1.4125, 0.11111111111111
61165, 1.4173913043478, 1.4125, 0.055555555555556
61166, 1.4608695652174, 1.4125, 0.44444444444444
61167, 1.4608695652174, 1.4125, 0.38888888888889
61168, 1.4608695652174, 1.4125, 0.33333333333333
61169, 1.4608695652174, 1.4125, 0.27777777777778
61170, 1.4608695652174, 1.4125, 0.22222222222222
61171, 1.4608695652174, 1.4125, 0.16666666666667
61172, 1.4608695652174, 1.4125, 0.11111111111111
61173, 1.4608695652174, 1.4125, 0.055555555555556
61174, 1.504347826087, 1.4125, 0.44444444444444
61175, 1.504347826087, 1.4125, 0.38888888888889
61176, 1.504347826087, 1.4125, 0.33333333333333
61177, 1.504347826087, 1.4125, 0.27777777777778
61178, 1.504347826087, 1.4125, 0.22222222222222
61179, 1.504347826087, 1.4125, 0.16666666666667
61180, 1.504347826087, 1.4125, 0.11111111111111
61181, 1.504347826087, 1.4125, 0.055555555555556
61182, 1.5478260869565, 1.4125, 0.44444444444444
61183, 1.5478260869565, 1.4125, 0.38888888888889
61184, 1.5478260869565, 1.4125, 0.33333333333333
61185, 1.5478260869565, 1.4125, 0.27777777777778
61186, 1.5478260869565, 1.4125, 0.22222222222222
61187, 1.5478260869565, 1.4125, 0.16666666666667
61188, 1.5478260869565, 1.4125, 0.11111111111111
61189, 1.5478260869565, 1.4125, 0.055555555555556
61190, 1.5913043478261, 1.4125, 0.44444444444444
61191, 1.5913043478261, 1.4125, 0.38888888888889
61192, 1.5913043478261, 1.4125, 0.33333333333333
61193, 1.5913043478261, 1.4125, 0.27777777777778
61194, 1.5913043478261, 1.4125, 0.22222222222222
61195, 1.5913043478261, 1.4125, 0.16666666666667
61196, 1.5913043478261, 1.4125, 0.11111111111111
61197, 1.5913043478261, 1.4125, 0.055555555555556
61198, 1.6347826086957, 1.4125, 0.44444444444444
61199, 1.6347826086957, 1.4125, 0.38888888888889
61200, 1.6347826086957, 1.4125, 0.33333333333333
61201, 1.6347826086957, 1.4125, 0.27777777777778
61202, 1.6347826086957, 1.4125, 0.22222222222222
61203, 1.6347826086957, 1.4125, 0.16666666666667
61204, 1.6347826086957, 1.4125, 0.11111111111111
61205, 1.6347826086957, 1.4125, 0.055555555555556
61206, 1.6782608695652, 1.4125, 0.44444444444444
61207, 1.6782608695652, 1.4125, 0.38888888888889
61208, 1.6782608695652, 1.4125, 0.33333333333333
61209, 1.6782608695652, 1.4125, 0.27777777777778
61210, 1.6782608695652, 1.4125, 0.22222222222222
61211, 1.6782608695652, 1.4125, 0.16666666666667
61212, 1.6782608695652, 1.4125, 0.11111111111111
61213, 1.6782608695652, 1.4125, 0.055555555555556
61214, 1.7217391304348, 1.4125, 0.44444444444444
61215, 1.7217391304348, 1.4125, 0.38888888888889
61216, 1.7217391304348, 1.4125, 0.33333333333333
61217, 1.7217391304348, 1.4125, 0.27777777777778
61218, 1.7217391304348, 1.4125, 0.22222222222222
61219, 1.7217391304348, 1.4125, 0.16666666666667
61220, 1.7217391304348, 1.4125, 0.11111111111111
61221, 1.7217391304348, 1.4125, 0.055555555555556
61222, 1.7652173913043, 1.4125, 0.44444444444444
61223, 1.7652173913043, 1.4125, 0.38888888888889
61224, 1.7652173913043, 1.4125, 0.33333333333333
61225, 1.7652173913043, 1.4125, 0.27777777777778
61226, 1.7652173913043, 1.4125, 0.22222222222222
61227, 1.7652173913043, 1.4125, 0.16666666666667
61228, 1.7652173913043, 1.4125, 0.11111111111111
61229, 1.7652173913043, 1.4125, 0.055555555555556
61230, 1.8086956521739, 1.4125, 0.44444444444444
61231, 1.8086956521739, 1.4125, 0.38888888888889
61232, 1.8086956521739, 1.4125, 0.33333333333333
61233, 1.8086956521739, 1.4125, 0.27777777777778
61234, 1.8086956521739, 1.4125, 0.22222222222222
61235, 1.8086956521739, 1.4125, 0.16666666666667
61236, 1.8086956521739, 1.4125, 0.11111111111111
61237, 1.8086956521739, 1.4125, 0.055555555555556
61238, 1.8521739130435, 1.4125, 0.44444444444444
61239, 1.8521739130435, 1.4125, 0.38888888888889
61240, 1.8521739130435, 1.4125, 0.33333333333333
61241, 1.8521739130435, 1.4125, 0.27777777777778
61242, 1.8521739130435, 1.4125, 0.22222222222222
61243, 1.8521739130435, 1.4125, 0.16666666666667
61244, 1.8521739130435, 1.4125, 0.11111111111111
61245, 1.8521739130435, 1.4125, 0.055555555555556
61246, 1.895652173913, 1.4125, 0.44444444444444
61247, 1.895652173913, 1.4125, 0.38888888888889
61248, 1.895652173913, 1.4125, 0.33333333333333
61249, 1.895652173913, 1.4125, 0.27777777777778
61250, 1.895652173913, 1.4125, 0.22222222222222
61251, 1.895652173913, 1.4125, 0.16666666666667
61252, 1.895652173913, 1.4125, 0.11111111111111
61253, 1.895652173913, 1.4125, 0.055555555555556
61254, 1.9391304347826, 1.4125, 0.44444444444444
61255, 1.9391304347826, 1.4125, 0.38888888888889
61256, 1.9391304347826, 1.4125, 0.33333333333333
61257, 1.9391304347826, 1.4125, 0.27777777777778
61258, 1.9391304347826, 1.4125, 0.22222222222222
61259, 1.9391304347826, 1.4125, 0.16666666666667
61260, 1.9391304347826, 1.4125, 0.11111111111111
61261, 1.9391304347826, 1.4125, 0.055555555555556
61262, 1.9826086956522, 1.4125, 0.44444444444444
61263, 1.9826086956522, 1.4125, 0.38888888888889
61264, 1.9826086956522, 1.4125, 0.33333333333333
61265, 1.9826086956522, 1.4125, 0.27777777777778
61266, 1.9826086956522, 1.4125, 0.22222222222222
61267, 1.9826086956522, 1.4125, 0.16666666666667
61268, 1.9826086956522, 1.4125, 0.11111111111111
61269, 1.9826086956522, 1.4125, 0.055555555555556
61270, 2.0260869565217, 1.4125, 0.44444444444444
61271, 2.0260869565217, 1.4125, 0.38888888888889
61272, 2.0260869565217, 1.4125, 0.33333333333333
61273, 2.0260869565217, 1.4125, 0.27777777777778
61274, 2.0260869565217, 1.4125, 0.22222222222222
61275, 2.0260869565217, 1.4125, 0.16666666666667
61276, 2.0260869565217, 1.4125, 0.11111111111111
61277, 2.0260869565217, 1.4125, 0.055555555555556
61278, 2.0695652173913, 1.4125, 0.44444444444444
61279, 2.0695652173913, 1.4125, 0.38888888888889
61280, 2.0695652173913, 1.4125, 0.33333333333333
61281, 2.0695652173913, 1.4125, 0.27777777777778
61282, 2.0695652173913, 1.4125, 0.22222222222222
61283, 2.0695652173913, 1.4125, 0.16666666666667
61284, 2.0695652173913, 1.4125, 0.11111111111111
61285, 2.0695652173913, 1.4125, 0.055555555555556
61286, 2.1130434782609, 1.4125, 0.44444444444444
61287, 2.1130434782609, 1.4125, 0.38888888888889
61288, 2.1130434782609, 1.4125, 0.33333333333333
61289, 2.1130434782609, 1.4125, 0.27777777777778
61290, 2.1130434782609, 1.4125, 0.22222222222222
61291, 2.1130434782609, 1.4125, 0.16666666666667
61292, 2.1130434782609, 1.4125, 0.11111111111111
61293, 2.1130434782609, 1.4125, 0.055555555555556
61294, 2.1565217391304, 1.4125, 0.44444444444444
61295, 2.1565217391304, 1.4125, 0.38888888888889
61296, 2.1565217391304, 1.4125, 0.33333333333333
61297, 2.1565217391304, 1.4125, 0.27777777777778
61298, 2.1565217391304, 1.4125, 0.22222222222222
61299, 2.1565217391304, 1.4125, 0.16666666666667
61300, 2.1565217391304, 1.4125, 0.11111111111111
61301, 2.1565217391304, 1.4125, 0.055555555555556
61302, 1.2434782608696, 1.2978260869565, 0.44444444444444
61303, 1.2434782608696, 1.2978260869565, 0.38888888888889
61304, 1.2434782608696, 1.2978260869565, 0.33333333333333
61305, 1.2434782608696, 1.2978260869565, 0.27777777777778
61306, 1.2434782608696, 1.2978260869565, 0.22222222222222
61307, 1.2434782608696, 1.2978260869565, 0.16666666666667
61308, 1.2434782608696, 1.2978260869565, 0.11111111111111
61309, 1.2434782608696, 1.2978260869565, 0.055555555555556
61310, 1.2869565217391, 1.2978260869565, 0.44444444444444
61311, 1.2869565217391, 1.2978260869565, 0.38888888888889
61312, 1.2869565217391, 1.2978260869565, 0.33333333333333
61313, 1.2869565217391, 1.2978260869565, 0.27777777777778
61314, 1.2869565217391, 1.2978260869565, 0.22222222222222
61315, 1.2869565217391, 1.2978260869565, 0.16666666666667
61316, 1.2869565217391, 1.2978260869565, 0.11111111111111
61317, 1.2869565217391, 1.2978260869565, 0.055555555555556
61318, 1.3304347826087, 1.2978260869565, 0.44444444444444
61319, 1.3304347826087, 1.2978260869565, 0.38888888888889
61320, 1.3304347826087, 1.2978260869565, 0.33333333333333
61321, 1.3304347826087, 1.2978260869565, 0.27777777777778
61322, 1.3304347826087, 1.2978260869565, 0.22222222222222
61323, 1.3304347826087, 1.2978260869565, 0.16666666666667
61324, 1.3304347826087, 1.2978260869565, 0.11111111111111
61325, 1.3304347826087, 1.2978260869565, 0.055555555555556
61326, 1.3739130434783, 1.2978260869565, 0.44444444444444
61327, 1.3739130434783, 1.2978260869565, 0.38888888888889
61328, 1.3739130434783, 1.2978260869565, 0.33333333333333
61329, 1.3739130434783, 1.2978260869565, 0.27777777777778
61330, 1.3739130434783, 1.2978260869565, 0.22222222222222
61331, 1.3739130434783, 1.2978260869565, 0.16666666666667
61332, 1.3739130434783, 1.2978260869565, 0.11111111111111
61333, 1.3739130434783, 1.2978260869565, 0.055555555555556
61334, 1.4173913043478, 1.2978260869565, 0.44444444444444
61335, 1.4173913043478, 1.2978260869565, 0.38888888888889
61336, 1.4173913043478, 1.2978260869565, 0.33333333333333
61337, 1.4173913043478, 1.2978260869565, 0.27777777777778
61338, 1.4173913043478, 1.2978260869565, 0.22222222222222
61339, 1.4173913043478, 1.2978260869565, 0.16666666666667
61340, 1.4173913043478, 1.2978260869565, 0.11111111111111
61341, 1.4173913043478, 1.2978260869565, 0.055555555555556
61342, 1.4608695652174, 1.2978260869565, 0.44444444444444
61343, 1.4608695652174, 1.2978260869565, 0.38888888888889
61344, 1.4608695652174, 1.2978260869565, 0.33333333333333
61345, 1.4608695652174, 1.2978260869565, 0.27777777777778
61346, 1.4608695652174, 1.2978260869565, 0.22222222222222
61347, 1.4608695652174, 1.2978260869565, 0.16666666666667
61348, 1.4608695652174, 1.2978260869565, 0.11111111111111
61349, 1.4608695652174, 1.2978260869565, 0.055555555555556
61350, 1.504347826087, 1.2978260869565, 0.44444444444444
61351, 1.504347826087, 1.2978260869565, 0.38888888888889
61352, 1.504347826087, 1.2978260869565, 0.33333333333333
61353, 1.504347826087, 1.2978260869565, 0.27777777777778
61354, 1.504347826087, 1.2978260869565, 0.22222222222222
61355, 1.504347826087, 1.2978260869565, 0.16666666666667
61356, 1.504347826087, 1.2978260869565, 0.11111111111111
61357, 1.504347826087, 1.2978260869565, 0.055555555555556
61358, 1.5478260869565, 1.2978260869565, 0.44444444444444
61359, 1.5478260869565, 1.2978260869565, 0.38888888888889
61360, 1.5478260869565, 1.2978260869565, 0.33333333333333
61361, 1.5478260869565, 1.2978260869565, 0.27777777777778
61362, 1.5478260869565, 1.2978260869565, 0.22222222222222
61363, 1.5478260869565, 1.2978260869565, 0.16666666666667
61364, 1.5478260869565, 1.2978260869565, 0.11111111111111
61365, 1.5478260869565, 1.2978260869565, 0.055555555555556
61366, 1.5913043478261, 1.2978260869565, 0.44444444444444
61367, 1.5913043478261, 1.2978260869565, 0.38888888888889
61368, 1.5913043478261, 1.2978260869565, 0.33333333333333
61369, 1.5913043478261, 1.2978260869565, 0.27777777777778
61370, 1.5913043478261, 1.2978260869565, 0.22222222222222
61371, 1.5913043478261, 1.2978260869565, 0.16666666666667
61372, 1.5913043478261, 1.2978260869565, 0.11111111111111
61373, 1.5913043478261, 1.2978260869565, 0.055555555555556
61374, 1.6347826086957, 1.2978260869565, 0.44444444444444
61375, 1.6347826086957, 1.2978260869565, 0.38888888888889
61376, 1.6347826086957, 1.2978260869565, 0.33333333333333
61377, 1.6347826086957, 1.2978260869565, 0.27777777777778
61378, 1.6347826086957, 1.2978260869565, 0.22222222222222
61379, 1.6347826086957, 1.2978260869565, 0.16666666666667
61380, 1.6347826086957, 1.2978260869565, 0.11111111111111
61381, 1.6347826086957, 1.2978260869565, 0.055555555555556
61382, 1.6782608695652, 1.2978260869565, 0.44444444444444
61383, 1.6782608695652, 1.2978260869565, 0.38888888888889
61384, 1.6782608695652, 1.2978260869565, 0.33333333333333
61385, 1.6782608695652, 1.2978260869565, 0.27777777777778
61386, 1.6782608695652, 1.2978260869565, 0.22222222222222
61387, 1.6782608695652, 1.2978260869565, 0.16666666666667
61388, 1.6782608695652, 1.2978260869565, 0.11111111111111
61389, 1.6782608695652, 1.2978260869565, 0.055555555555556
61390, 1.7217391304348, 1.2978260869565, 0.44444444444444
61391, 1.7217391304348, 1.2978260869565, 0.38888888888889
61392, 1.7217391304348, 1.2978260869565, 0.33333333333333
61393, 1.7217391304348, 1.2978260869565, 0.27777777777778
61394, 1.7217391304348, 1.2978260869565, 0.22222222222222
61395, 1.7217391304348, 1.2978260869565, 0.16666666666667
61396, 1.7217391304348, 1.2978260869565, 0.11111111111111
61397, 1.7217391304348, 1.2978260869565, 0.055555555555556
61398, 1.7652173913043, 1.2978260869565, 0.44444444444444
61399, 1.7652173913043, 1.2978260869565, 0.38888888888889
61400, 1.7652173913043, 1.2978260869565, 0.33333333333333
61401, 1.7652173913043, 1.2978260869565, 0.27777777777778
61402, 1.7652173913043, 1.2978260869565, 0.22222222222222
61403, 1.7652173913043, 1.2978260869565, 0.16666666666667
61404, 1.7652173913043, 1.2978260869565, 0.11111111111111
61405, 1.7652173913043, 1.2978260869565, 0.055555555555556
61406, 1.8086956521739, 1.2978260869565, 0.44444444444444
61407, 1.8086956521739, 1.2978260869565, 0.38888888888889
61408, 1.8086956521739, 1.2978260869565, 0.33333333333333
61409, 1.8086956521739, 1.2978260869565, 0.27777777777778
61410, 1.8086956521739, 1.2978260869565, 0.22222222222222
61411, 1.8086956521739, 1.2978260869565, 0.16666666666667
61412, 1.8086956521739, 1.2978260869565, 0.11111111111111
61413, 1.8086956521739, 1.2978260869565, 0.055555555555556
61414, 1.8521739130435, 1.2978260869565, 0.44444444444444
61415, 1.8521739130435, 1.2978260869565, 0.38888888888889
61416, 1.8521739130435, 1.2978260869565, 0.33333333333333
61417, 1.8521739130435, 1.2978260869565, 0.27777777777778
61418, 1.8521739130435, 1.2978260869565, 0.22222222222222
61419, 1.8521739130435, 1.2978260869565, 0.16666666666667
61420, 1.8521739130435, 1.2978260869565, 0.11111111111111
61421, 1.8521739130435, 1.2978260869565, 0.055555555555556
61422, 1.895652173913, 1.2978260869565, 0.44444444444444
61423, 1.895652173913, 1.2978260869565, 0.38888888888889
61424, 1.895652173913, 1.2978260869565, 0.33333333333333
61425, 1.895652173913, 1.2978260869565, 0.27777777777778
61426, 1.895652173913, 1.2978260869565, 0.22222222222222
61427, 1.895652173913, 1.2978260869565, 0.16666666666667
61428, 1.895652173913, 1.2978260869565, 0.11111111111111
61429, 1.895652173913, 1.2978260869565, 0.055555555555556
61430, 1.9391304347826, 1.2978260869565, 0.44444444444444
61431, 1.9391304347826, 1.2978260869565, 0.38888888888889
61432, 1.9391304347826, 1.2978260869565, 0.33333333333333
61433, 1.9391304347826, 1.2978260869565, 0.27777777777778
61434, 1.9391304347826, 1.2978260869565, 0.22222222222222
61435, 1.9391304347826, 1.2978260869565, 0.16666666666667
61436, 1.9391304347826, 1.2978260869565, 0.11111111111111
61437, 1.9391304347826, 1.2978260869565, 0.055555555555556
61438, 1.9826086956522, 1.2978260869565, 0.44444444444444
61439, 1.9826086956522, 1.2978260869565, 0.38888888888889
61440, 1.9826086956522, 1.2978260869565, 0.33333333333333
61441, 1.9826086956522, 1.2978260869565, 0.27777777777778
61442, 1.9826086956522, 1.2978260869565, 0.22222222222222
61443, 1.9826086956522, 1.2978260869565, 0.16666666666667
61444, 1.9826086956522, 1.2978260869565, 0.11111111111111
61445, 1.9826086956522, 1.2978260869565, 0.055555555555556
61446, 2.0260869565217, 1.2978260869565, 0.44444444444444
61447, 2.0260869565217, 1.2978260869565, 0.38888888888889
61448, 2.0260869565217, 1.2978260869565, 0.33333333333333
61449, 2.0260869565217, 1.2978260869565, 0.27777777777778
61450, 2.0260869565217, 1.2978260869565, 0.22222222222222
61451, 2.0260869565217, 1.2978260869565, 0.16666666666667
61452, 2.0260869565217, 1.2978260869565, 0.11111111111111
61453, 2.0260869565217, 1.2978260869565, 0.055555555555556
61454, 2.0695652173913, 1.2978260869565, 0.44444444444444
61455, 2.0695652173913, 1.2978260869565, 0.38888888888889
61456, 2.0695652173913, 1.2978260869565, 0.33333333333333
61457, 2.0695652173913, 1.2978260869565, 0.27777777777778
61458, 2.0695652173913, 1.2978260869565, 0.22222222222222
61459, 2.0695652173913, 1.2978260869565, 0.16666666666667
61460, 2.0695652173913, 1.2978260869565, 0.11111111111111
61461, 2.0695652173913, 1.2978260869565, 0.055555555555556
61462, 2.1130434782609, 1.2978260869565, 0.44444444444444
61463, 2.1130434782609, 1.2978260869565, 0.38888888888889
61464, 2.1130434782609, 1.2978260869565, 0.33333333333333
61465, 2.1130434782609, 1.2978260869565, 0.27777777777778
61466, 2.1130434782609, 1.2978260869565, 0.22222222222222
61467, 2.1130434782609, 1.2978260869565, 0.16666666666667
61468, 2.1130434782609, 1.2978260869565, 0.11111111111111
61469, 2.1130434782609, 1.2978260869565, 0.055555555555556
61470, 2.1565217391304, 1.2978260869565, 0.44444444444444
61471, 2.1565217391304, 1.2978260869565, 0.38888888888889
61472, 2.1565217391304, 1.2978260869565, 0.33333333333333
61473, 2.1565217391304, 1.2978260869565, 0.27777777777778
61474, 2.1565217391304, 1.2978260869565, 0.22222222222222
61475, 2.1565217391304, 1.2978260869565, 0.16666666666667
61476, 2.1565217391304, 1.2978260869565, 0.11111111111111
61477, 2.1565217391304, 1.2978260869565, 0.055555555555556
61478, 1.2434782608696, 1.245652173913, 0.44444444444444
61479, 1.2434782608696, 1.245652173913, 0.38888888888889
61480, 1.2434782608696, 1.245652173913, 0.33333333333333
61481, 1.2434782608696, 1.245652173913, 0.27777777777778
61482, 1.2434782608696, 1.245652173913, 0.22222222222222
61483, 1.2434782608696, 1.245652173913, 0.16666666666667
61484, 1.2434782608696, 1.245652173913, 0.11111111111111
61485, 1.2434782608696, 1.245652173913, 0.055555555555556
61486, 1.2869565217391, 1.245652173913, 0.44444444444444
61487, 1.2869565217391, 1.245652173913, 0.38888888888889
61488, 1.2869565217391, 1.245652173913, 0.33333333333333
61489, 1.2869565217391, 1.245652173913, 0.27777777777778
61490, 1.2869565217391, 1.245652173913, 0.22222222222222
61491, 1.2869565217391, 1.245652173913, 0.16666666666667
61492, 1.2869565217391, 1.245652173913, 0.11111111111111
61493, 1.2869565217391, 1.245652173913, 0.055555555555556
61494, 1.3304347826087, 1.245652173913, 0.44444444444444
61495, 1.3304347826087, 1.245652173913, 0.38888888888889
61496, 1.3304347826087, 1.245652173913, 0.33333333333333
61497, 1.3304347826087, 1.245652173913, 0.27777777777778
61498, 1.3304347826087, 1.245652173913, 0.22222222222222
61499, 1.3304347826087, 1.245652173913, 0.16666666666667
61500, 1.3304347826087, 1.245652173913, 0.11111111111111
61501, 1.3304347826087, 1.245652173913, 0.055555555555556
61502, 1.3739130434783, 1.245652173913, 0.44444444444444
61503, 1.3739130434783, 1.245652173913, 0.38888888888889
61504, 1.3739130434783, 1.245652173913, 0.33333333333333
61505, 1.3739130434783, 1.245652173913, 0.27777777777778
61506, 1.3739130434783, 1.245652173913, 0.22222222222222
61507, 1.3739130434783, 1.245652173913, 0.16666666666667
61508, 1.3739130434783, 1.245652173913, 0.11111111111111
61509, 1.3739130434783, 1.245652173913, 0.055555555555556
61510, 1.4173913043478, 1.245652173913, 0.44444444444444
61511, 1.4173913043478, 1.245652173913, 0.38888888888889
61512, 1.4173913043478, 1.245652173913, 0.33333333333333
61513, 1.4173913043478, 1.245652173913, 0.27777777777778
61514, 1.4173913043478, 1.245652173913, 0.22222222222222
61515, 1.4173913043478, 1.245652173913, 0.16666666666667
61516, 1.4173913043478, 1.245652173913, 0.11111111111111
61517, 1.4173913043478, 1.245652173913, 0.055555555555556
61518, 1.4608695652174, 1.245652173913, 0.44444444444444
61519, 1.4608695652174, 1.245652173913, 0.38888888888889
61520, 1.4608695652174, 1.245652173913, 0.33333333333333
61521, 1.4608695652174, 1.245652173913, 0.27777777777778
61522, 1.4608695652174, 1.245652173913, 0.22222222222222
61523, 1.4608695652174, 1.245652173913, 0.16666666666667
61524, 1.4608695652174, 1.245652173913, 0.11111111111111
61525, 1.4608695652174, 1.245652173913, 0.055555555555556
61526, 1.504347826087, 1.245652173913, 0.44444444444444
61527, 1.504347826087, 1.245652173913, 0.38888888888889
61528, 1.504347826087, 1.245652173913, 0.33333333333333
61529, 1.504347826087, 1.245652173913, 0.27777777777778
61530, 1.504347826087, 1.245652173913, 0.22222222222222
61531, 1.504347826087, 1.245652173913, 0.16666666666667
61532, 1.504347826087, 1.245652173913, 0.11111111111111
61533, 1.504347826087, 1.245652173913, 0.055555555555556
61534, 1.5478260869565, 1.245652173913, 0.44444444444444
61535, 1.5478260869565, 1.245652173913, 0.38888888888889
61536, 1.5478260869565, 1.245652173913, 0.33333333333333
61537, 1.5478260869565, 1.245652173913, 0.27777777777778
61538, 1.5478260869565, 1.245652173913, 0.22222222222222
61539, 1.5478260869565, 1.245652173913, 0.16666666666667
61540, 1.5478260869565, 1.245652173913, 0.11111111111111
61541, 1.5478260869565, 1.245652173913, 0.055555555555556
61542, 1.5913043478261, 1.245652173913, 0.44444444444444
61543, 1.5913043478261, 1.245652173913, 0.38888888888889
61544, 1.5913043478261, 1.245652173913, 0.33333333333333
61545, 1.5913043478261, 1.245652173913, 0.27777777777778
61546, 1.5913043478261, 1.245652173913, 0.22222222222222
61547, 1.5913043478261, 1.245652173913, 0.16666666666667
61548, 1.5913043478261, 1.245652173913, 0.11111111111111
61549, 1.5913043478261, 1.245652173913, 0.055555555555556
61550, 1.6347826086957, 1.245652173913, 0.44444444444444
61551, 1.6347826086957, 1.245652173913, 0.38888888888889
61552, 1.6347826086957, 1.245652173913, 0.33333333333333
61553, 1.6347826086957, 1.245652173913, 0.27777777777778
61554, 1.6347826086957, 1.245652173913, 0.22222222222222
61555, 1.6347826086957, 1.245652173913, 0.16666666666667
61556, 1.6347826086957, 1.245652173913, 0.11111111111111
61557, 1.6347826086957, 1.245652173913, 0.055555555555556
61558, 1.6782608695652, 1.245652173913, 0.44444444444444
61559, 1.6782608695652, 1.245652173913, 0.38888888888889
61560, 1.6782608695652, 1.245652173913, 0.33333333333333
61561, 1.6782608695652, 1.245652173913, 0.27777777777778
61562, 1.6782608695652, 1.245652173913, 0.22222222222222
61563, 1.6782608695652, 1.245652173913, 0.16666666666667
61564, 1.6782608695652, 1.245652173913, 0.11111111111111
61565, 1.6782608695652, 1.245652173913, 0.055555555555556
61566, 1.7217391304348, 1.245652173913, 0.44444444444444
61567, 1.7217391304348, 1.245652173913, 0.38888888888889
61568, 1.7217391304348, 1.245652173913, 0.33333333333333
61569, 1.7217391304348, 1.245652173913, 0.27777777777778
61570, 1.7217391304348, 1.245652173913, 0.22222222222222
61571, 1.7217391304348, 1.245652173913, 0.16666666666667
61572, 1.7217391304348, 1.245652173913, 0.11111111111111
61573, 1.7217391304348, 1.245652173913, 0.055555555555556
61574, 1.7652173913043, 1.245652173913, 0.44444444444444
61575, 1.7652173913043, 1.245652173913, 0.38888888888889
61576, 1.7652173913043, 1.245652173913, 0.33333333333333
61577, 1.7652173913043, 1.245652173913, 0.27777777777778
61578, 1.7652173913043, 1.245652173913, 0.22222222222222
61579, 1.7652173913043, 1.245652173913, 0.16666666666667
61580, 1.7652173913043, 1.245652173913, 0.11111111111111
61581, 1.7652173913043, 1.245652173913, 0.055555555555556
61582, 1.8086956521739, 1.245652173913, 0.44444444444444
61583, 1.8086956521739, 1.245652173913, 0.38888888888889
61584, 1.8086956521739, 1.245652173913, 0.33333333333333
61585, 1.8086956521739, 1.245652173913, 0.27777777777778
61586, 1.8086956521739, 1.245652173913, 0.22222222222222
61587, 1.8086956521739, 1.245652173913, 0.16666666666667
61588, 1.8086956521739, 1.245652173913, 0.11111111111111
61589, 1.8086956521739, 1.245652173913, 0.055555555555556
61590, 1.8521739130435, 1.245652173913, 0.44444444444444
61591, 1.8521739130435, 1.245652173913, 0.38888888888889
61592, 1.8521739130435, 1.245652173913, 0.33333333333333
61593, 1.8521739130435, 1.245652173913, 0.27777777777778
61594, 1.8521739130435, 1.245652173913, 0.22222222222222
61595, 1.8521739130435, 1.245652173913, 0.16666666666667
61596, 1.8521739130435, 1.245652173913, 0.11111111111111
61597, 1.8521739130435, 1.245652173913, 0.055555555555556
61598, 1.895652173913, 1.245652173913, 0.44444444444444
61599, 1.895652173913, 1.245652173913, 0.38888888888889
61600, 1.895652173913, 1.245652173913, 0.33333333333333
61601, 1.895652173913, 1.245652173913, 0.27777777777778
61602, 1.895652173913, 1.245652173913, 0.22222222222222
61603, 1.895652173913, 1.245652173913, 0.16666666666667
61604, 1.895652173913, 1.245652173913, 0.11111111111111
61605, 1.895652173913, 1.245652173913, 0.055555555555556
61606, 1.9391304347826, 1.245652173913, 0.44444444444444
61607, 1.9391304347826, 1.245652173913, 0.38888888888889
61608, 1.9391304347826, 1.245652173913, 0.33333333333333
61609, 1.9391304347826, 1.245652173913, 0.27777777777778
61610, 1.9391304347826, 1.245652173913, 0.22222222222222
61611, 1.9391304347826, 1.245652173913, 0.16666666666667
61612, 1.9391304347826, 1.245652173913, 0.11111111111111
61613, 1.9391304347826, 1.245652173913, 0.055555555555556
61614, 1.9826086956522, 1.245652173913, 0.44444444444444
61615, 1.9826086956522, 1.245652173913, 0.38888888888889
61616, 1.9826086956522, 1.245652173913, 0.33333333333333
61617, 1.9826086956522, 1.245652173913, 0.27777777777778
61618, 1.9826086956522, 1.245652173913, 0.22222222222222
61619, 1.9826086956522, 1.245652173913, 0.16666666666667
61620, 1.9826086956522, 1.245652173913, 0.11111111111111
61621, 1.9826086956522, 1.245652173913, 0.055555555555556
61622, 2.0260869565217, 1.245652173913, 0.44444444444444
61623, 2.0260869565217, 1.245652173913, 0.38888888888889
61624, 2.0260869565217, 1.245652173913, 0.33333333333333
61625, 2.0260869565217, 1.245652173913, 0.27777777777778
61626, 2.0260869565217, 1.245652173913, 0.22222222222222
61627, 2.0260869565217, 1.245652173913, 0.16666666666667
61628, 2.0260869565217, 1.245652173913, 0.11111111111111
61629, 2.0260869565217, 1.245652173913, 0.055555555555556
61630, 2.0695652173913, 1.245652173913, 0.44444444444444
61631, 2.0695652173913, 1.245652173913, 0.38888888888889
61632, 2.0695652173913, 1.245652173913, 0.33333333333333
61633, 2.0695652173913, 1.245652173913, 0.27777777777778
61634, 2.0695652173913, 1.245652173913, 0.22222222222222
61635, 2.0695652173913, 1.245652173913, 0.16666666666667
61636, 2.0695652173913, 1.245652173913, 0.11111111111111
61637, 2.0695652173913, 1.245652173913, 0.055555555555556
61638, 2.1130434782609, 1.245652173913, 0.44444444444444
61639, 2.1130434782609, 1.245652173913, 0.38888888888889
61640, 2.1130434782609, 1.245652173913, 0.33333333333333
61641, 2.1130434782609, 1.245652173913, 0.27777777777778
61642, 2.1130434782609, 1.245652173913, 0.22222222222222
61643, 2.1130434782609, 1.245652173913, 0.16666666666667
61644, 2.1130434782609, 1.245652173913, 0.11111111111111
61645, 2.1130434782609, 1.245652173913, 0.055555555555556
61646, 2.1565217391304, 1.245652173913, 0.44444444444444
61647, 2.1565217391304, 1.245652173913, 0.38888888888889
61648, 2.1565217391304, 1.245652173913, 0.33333333333333
61649, 2.1565217391304, 1.245652173913, 0.27777777777778
61650, 2.1565217391304, 1.245652173913, 0.22222222222222
61651, 2.1565217391304, 1.245652173913, 0.16666666666667
61652, 2.1565217391304, 1.245652173913, 0.11111111111111
61653, 2.1565217391304, 1.245652173913, 0.055555555555556
61654, 1.2434782608696, 1.1934782608696, 0.44444444444444
61655, 1.2434782608696, 1.1934782608696, 0.38888888888889
61656, 1.2434782608696, 1.1934782608696, 0.33333333333333
61657, 1.2434782608696, 1.1934782608696, 0.27777777777778
61658, 1.2434782608696, 1.1934782608696, 0.22222222222222
61659, 1.2434782608696, 1.1934782608696, 0.16666666666667
61660, 1.2434782608696, 1.1934782608696, 0.11111111111111
61661, 1.2434782608696, 1.1934782608696, 0.055555555555556
61662, 1.2869565217391, 1.1934782608696, 0.44444444444444
61663, 1.2869565217391, 1.1934782608696, 0.38888888888889
61664, 1.2869565217391, 1.1934782608696, 0.33333333333333
61665, 1.2869565217391, 1.1934782608696, 0.27777777777778
61666, 1.2869565217391, 1.1934782608696, 0.22222222222222
61667, 1.2869565217391, 1.1934782608696, 0.16666666666667
61668, 1.2869565217391, 1.1934782608696, 0.11111111111111
61669, 1.2869565217391, 1.1934782608696, 0.055555555555556
61670, 1.3304347826087, 1.1934782608696, 0.44444444444444
61671, 1.3304347826087, 1.1934782608696, 0.38888888888889
61672, 1.3304347826087, 1.1934782608696, 0.33333333333333
61673, 1.3304347826087, 1.1934782608696, 0.27777777777778
61674, 1.3304347826087, 1.1934782608696, 0.22222222222222
61675, 1.3304347826087, 1.1934782608696, 0.16666666666667
61676, 1.3304347826087, 1.1934782608696, 0.11111111111111
61677, 1.3304347826087, 1.1934782608696, 0.055555555555556
61678, 1.3739130434783, 1.1934782608696, 0.44444444444444
61679, 1.3739130434783, 1.1934782608696, 0.38888888888889
61680, 1.3739130434783, 1.1934782608696, 0.33333333333333
61681, 1.3739130434783, 1.1934782608696, 0.27777777777778
61682, 1.3739130434783, 1.1934782608696, 0.22222222222222
61683, 1.3739130434783, 1.1934782608696, 0.16666666666667
61684, 1.3739130434783, 1.1934782608696, 0.11111111111111
61685, 1.3739130434783, 1.1934782608696, 0.055555555555556
61686, 1.4173913043478, 1.1934782608696, 0.44444444444444
61687, 1.4173913043478, 1.1934782608696, 0.38888888888889
61688, 1.4173913043478, 1.1934782608696, 0.33333333333333
61689, 1.4173913043478, 1.1934782608696, 0.27777777777778
61690, 1.4173913043478, 1.1934782608696, 0.22222222222222
61691, 1.4173913043478, 1.1934782608696, 0.16666666666667
61692, 1.4173913043478, 1.1934782608696, 0.11111111111111
61693, 1.4173913043478, 1.1934782608696, 0.055555555555556
61694, 1.4608695652174, 1.1934782608696, 0.44444444444444
61695, 1.4608695652174, 1.1934782608696, 0.38888888888889
61696, 1.4608695652174, 1.1934782608696, 0.33333333333333
61697, 1.4608695652174, 1.1934782608696, 0.27777777777778
61698, 1.4608695652174, 1.1934782608696, 0.22222222222222
61699, 1.4608695652174, 1.1934782608696, 0.16666666666667
61700, 1.4608695652174, 1.1934782608696, 0.11111111111111
61701, 1.4608695652174, 1.1934782608696, 0.055555555555556
61702, 1.504347826087, 1.1934782608696, 0.44444444444444
61703, 1.504347826087, 1.1934782608696, 0.38888888888889
61704, 1.504347826087, 1.1934782608696, 0.33333333333333
61705, 1.504347826087, 1.1934782608696, 0.27777777777778
61706, 1.504347826087, 1.1934782608696, 0.22222222222222
61707, 1.504347826087, 1.1934782608696, 0.16666666666667
61708, 1.504347826087, 1.1934782608696, 0.11111111111111
61709, 1.504347826087, 1.1934782608696, 0.055555555555556
61710, 1.5478260869565, 1.1934782608696, 0.44444444444444
61711, 1.5478260869565, 1.1934782608696, 0.38888888888889
61712, 1.5478260869565, 1.1934782608696, 0.33333333333333
61713, 1.5478260869565, 1.1934782608696, 0.27777777777778
61714, 1.5478260869565, 1.1934782608696, 0.22222222222222
61715, 1.5478260869565, 1.1934782608696, 0.16666666666667
61716, 1.5478260869565, 1.1934782608696, 0.11111111111111
61717, 1.5478260869565, 1.1934782608696, 0.055555555555556
61718, 1.5913043478261, 1.1934782608696, 0.44444444444444
61719, 1.5913043478261, 1.1934782608696, 0.38888888888889
61720, 1.5913043478261, 1.1934782608696, 0.33333333333333
61721, 1.5913043478261, 1.1934782608696, 0.27777777777778
61722, 1.5913043478261, 1.1934782608696, 0.22222222222222
61723, 1.5913043478261, 1.1934782608696, 0.16666666666667
61724, 1.5913043478261, 1.1934782608696, 0.11111111111111
61725, 1.5913043478261, 1.1934782608696, 0.055555555555556
61726, 1.6347826086957, 1.1934782608696, 0.44444444444444
61727, 1.6347826086957, 1.1934782608696, 0.38888888888889
61728, 1.6347826086957, 1.1934782608696, 0.33333333333333
61729, 1.6347826086957, 1.1934782608696, 0.27777777777778
61730, 1.6347826086957, 1.1934782608696, 0.22222222222222
61731, 1.6347826086957, 1.1934782608696, 0.16666666666667
61732, 1.6347826086957, 1.1934782608696, 0.11111111111111
61733, 1.6347826086957, 1.1934782608696, 0.055555555555556
61734, 1.6782608695652, 1.1934782608696, 0.44444444444444
61735, 1.6782608695652, 1.1934782608696, 0.38888888888889
61736, 1.6782608695652, 1.1934782608696, 0.33333333333333
61737, 1.6782608695652, 1.1934782608696, 0.27777777777778
61738, 1.6782608695652, 1.1934782608696, 0.22222222222222
61739, 1.6782608695652, 1.1934782608696, 0.16666666666667
61740, 1.6782608695652, 1.1934782608696, 0.11111111111111
61741, 1.6782608695652, 1.1934782608696, 0.055555555555556
61742, 1.7217391304348, 1.1934782608696, 0.44444444444444
61743, 1.7217391304348, 1.1934782608696, 0.38888888888889
61744, 1.7217391304348, 1.1934782608696, 0.33333333333333
61745, 1.7217391304348, 1.1934782608696, 0.27777777777778
61746, 1.7217391304348, 1.1934782608696, 0.22222222222222
61747, 1.7217391304348, 1.1934782608696, 0.16666666666667
61748, 1.7217391304348, 1.1934782608696, 0.11111111111111
61749, 1.7217391304348, 1.1934782608696, 0.055555555555556
61750, 1.7652173913043, 1.1934782608696, 0.44444444444444
61751, 1.7652173913043, 1.1934782608696, 0.38888888888889
61752, 1.7652173913043, 1.1934782608696, 0.33333333333333
61753, 1.7652173913043, 1.1934782608696, 0.27777777777778
61754, 1.7652173913043, 1.1934782608696, 0.22222222222222
61755, 1.7652173913043, 1.1934782608696, 0.16666666666667
61756, 1.7652173913043, 1.1934782608696, 0.11111111111111
61757, 1.7652173913043, 1.1934782608696, 0.055555555555556
61758, 1.8086956521739, 1.1934782608696, 0.44444444444444
61759, 1.8086956521739, 1.1934782608696, 0.38888888888889
61760, 1.8086956521739, 1.1934782608696, 0.33333333333333
61761, 1.8086956521739, 1.1934782608696, 0.27777777777778
61762, 1.8086956521739, 1.1934782608696, 0.22222222222222
61763, 1.8086956521739, 1.1934782608696, 0.16666666666667
61764, 1.8086956521739, 1.1934782608696, 0.11111111111111
61765, 1.8086956521739, 1.1934782608696, 0.055555555555556
61766, 1.8521739130435, 1.1934782608696, 0.44444444444444
61767, 1.8521739130435, 1.1934782608696, 0.38888888888889
61768, 1.8521739130435, 1.1934782608696, 0.33333333333333
61769, 1.8521739130435, 1.1934782608696, 0.27777777777778
61770, 1.8521739130435, 1.1934782608696, 0.22222222222222
61771, 1.8521739130435, 1.1934782608696, 0.16666666666667
61772, 1.8521739130435, 1.1934782608696, 0.11111111111111
61773, 1.8521739130435, 1.1934782608696, 0.055555555555556
61774, 1.895652173913, 1.1934782608696, 0.44444444444444
61775, 1.895652173913, 1.1934782608696, 0.38888888888889
61776, 1.895652173913, 1.1934782608696, 0.33333333333333
61777, 1.895652173913, 1.1934782608696, 0.27777777777778
61778, 1.895652173913, 1.1934782608696, 0.22222222222222
61779, 1.895652173913, 1.1934782608696, 0.16666666666667
61780, 1.895652173913, 1.1934782608696, 0.11111111111111
61781, 1.895652173913, 1.1934782608696, 0.055555555555556
61782, 1.9391304347826, 1.1934782608696, 0.44444444444444
61783, 1.9391304347826, 1.1934782608696, 0.38888888888889
61784, 1.9391304347826, 1.1934782608696, 0.33333333333333
61785, 1.9391304347826, 1.1934782608696, 0.27777777777778
61786, 1.9391304347826, 1.1934782608696, 0.22222222222222
61787, 1.9391304347826, 1.1934782608696, 0.16666666666667
61788, 1.9391304347826, 1.1934782608696, 0.11111111111111
61789, 1.9391304347826, 1.1934782608696, 0.055555555555556
61790, 1.9826086956522, 1.1934782608696, 0.44444444444444
61791, 1.9826086956522, 1.1934782608696, 0.38888888888889
61792, 1.9826086956522, 1.1934782608696, 0.33333333333333
61793, 1.9826086956522, 1.1934782608696, 0.27777777777778
61794, 1.9826086956522, 1.1934782608696, 0.22222222222222
61795, 1.9826086956522, 1.1934782608696, 0.16666666666667
61796, 1.9826086956522, 1.1934782608696, 0.11111111111111
61797, 1.9826086956522, 1.1934782608696, 0.055555555555556
61798, 2.0260869565217, 1.1934782608696, 0.44444444444444
61799, 2.0260869565217, 1.1934782608696, 0.38888888888889
61800, 2.0260869565217, 1.1934782608696, 0.33333333333333
61801, 2.0260869565217, 1.1934782608696, 0.27777777777778
61802, 2.0260869565217, 1.1934782608696, 0.22222222222222
61803, 2.0260869565217, 1.1934782608696, 0.16666666666667
61804, 2.0260869565217, 1.1934782608696, 0.11111111111111
61805, 2.0260869565217, 1.1934782608696, 0.055555555555556
61806, 2.0695652173913, 1.1934782608696, 0.44444444444444
61807, 2.0695652173913, 1.1934782608696, 0.38888888888889
61808, 2.0695652173913, 1.1934782608696, 0.33333333333333
61809, 2.0695652173913, 1.1934782608696, 0.27777777777778
61810, 2.0695652173913, 1.1934782608696, 0.22222222222222
61811, 2.0695652173913, 1.1934782608696, 0.16666666666667
61812, 2.0695652173913, 1.1934782608696, 0.11111111111111
61813, 2.0695652173913, 1.1934782608696, 0.055555555555556
61814, 2.1130434782609, 1.1934782608696, 0.44444444444444
61815, 2.1130434782609, 1.1934782608696, 0.38888888888889
61816, 2.1130434782609, 1.1934782608696, 0.33333333333333
61817, 2.1130434782609, 1.1934782608696, 0.27777777777778
61818, 2.1130434782609, 1.1934782608696, 0.22222222222222
61819, 2.1130434782609, 1.1934782608696, 0.16666666666667
61820, 2.1130434782609, 1.1934782608696, 0.11111111111111
61821, 2.1130434782609, 1.1934782608696, 0.055555555555556
61822, 2.1565217391304, 1.1934782608696, 0.44444444444444
61823, 2.1565217391304, 1.1934782608696, 0.38888888888889
61824, 2.1565217391304, 1.1934782608696, 0.33333333333333
61825, 2.1565217391304, 1.1934782608696, 0.27777777777778
61826, 2.1565217391304, 1.1934782608696, 0.22222222222222
61827, 2.1565217391304, 1.1934782608696, 0.16666666666667
61828, 2.1565217391304, 1.1934782608696, 0.11111111111111
61829, 2.1565217391304, 1.1934782608696, 0.055555555555556
61830, 1.2434782608696, 1.1413043478261, 0.44444444444444
61831, 1.2434782608696, 1.1413043478261, 0.38888888888889
61832, 1.2434782608696, 1.1413043478261, 0.33333333333333
61833, 1.2434782608696, 1.1413043478261, 0.27777777777778
61834, 1.2434782608696, 1.1413043478261, 0.22222222222222
61835, 1.2434782608696, 1.1413043478261, 0.16666666666667
61836, 1.2434782608696, 1.1413043478261, 0.11111111111111
61837, 1.2434782608696, 1.1413043478261, 0.055555555555556
61838, 1.2869565217391, 1.1413043478261, 0.44444444444444
61839, 1.2869565217391, 1.1413043478261, 0.38888888888889
61840, 1.2869565217391, 1.1413043478261, 0.33333333333333
61841, 1.2869565217391, 1.1413043478261, 0.27777777777778
61842, 1.2869565217391, 1.1413043478261, 0.22222222222222
61843, 1.2869565217391, 1.1413043478261, 0.16666666666667
61844, 1.2869565217391, 1.1413043478261, 0.11111111111111
61845, 1.2869565217391, 1.1413043478261, 0.055555555555556
61846, 1.3304347826087, 1.1413043478261, 0.44444444444444
61847, 1.3304347826087, 1.1413043478261, 0.38888888888889
61848, 1.3304347826087, 1.1413043478261, 0.33333333333333
61849, 1.3304347826087, 1.1413043478261, 0.27777777777778
61850, 1.3304347826087, 1.1413043478261, 0.22222222222222
61851, 1.3304347826087, 1.1413043478261, 0.16666666666667
61852, 1.3304347826087, 1.1413043478261, 0.11111111111111
61853, 1.3304347826087, 1.1413043478261, 0.055555555555556
61854, 1.3739130434783, 1.1413043478261, 0.44444444444444
61855, 1.3739130434783, 1.1413043478261, 0.38888888888889
61856, 1.3739130434783, 1.1413043478261, 0.33333333333333
61857, 1.3739130434783, 1.1413043478261, 0.27777777777778
61858, 1.3739130434783, 1.1413043478261, 0.22222222222222
61859, 1.3739130434783, 1.1413043478261, 0.16666666666667
61860, 1.3739130434783, 1.1413043478261, 0.11111111111111
61861, 1.3739130434783, 1.1413043478261, 0.055555555555556
61862, 1.4173913043478, 1.1413043478261, 0.44444444444444
61863, 1.4173913043478, 1.1413043478261, 0.38888888888889
61864, 1.4173913043478, 1.1413043478261, 0.33333333333333
61865, 1.4173913043478, 1.1413043478261, 0.27777777777778
61866, 1.4173913043478, 1.1413043478261, 0.22222222222222
61867, 1.4173913043478, 1.1413043478261, 0.16666666666667
61868, 1.4173913043478, 1.1413043478261, 0.11111111111111
61869, 1.4173913043478, 1.1413043478261, 0.055555555555556
61870, 1.4608695652174, 1.1413043478261, 0.44444444444444
61871, 1.4608695652174, 1.1413043478261, 0.38888888888889
61872, 1.4608695652174, 1.1413043478261, 0.33333333333333
61873, 1.4608695652174, 1.1413043478261, 0.27777777777778
61874, 1.4608695652174, 1.1413043478261, 0.22222222222222
61875, 1.4608695652174, 1.1413043478261, 0.16666666666667
61876, 1.4608695652174, 1.1413043478261, 0.11111111111111
61877, 1.4608695652174, 1.1413043478261, 0.055555555555556
61878, 1.504347826087, 1.1413043478261, 0.44444444444444
61879, 1.504347826087, 1.1413043478261, 0.38888888888889
61880, 1.504347826087, 1.1413043478261, 0.33333333333333
61881, 1.504347826087, 1.1413043478261, 0.27777777777778
61882, 1.504347826087, 1.1413043478261, 0.22222222222222
61883, 1.504347826087, 1.1413043478261, 0.16666666666667
61884, 1.504347826087, 1.1413043478261, 0.11111111111111
61885, 1.504347826087, 1.1413043478261, 0.055555555555556
61886, 1.5478260869565, 1.1413043478261, 0.44444444444444
61887, 1.5478260869565, 1.1413043478261, 0.38888888888889
61888, 1.5478260869565, 1.1413043478261, 0.33333333333333
61889, 1.5478260869565, 1.1413043478261, 0.27777777777778
61890, 1.5478260869565, 1.1413043478261, 0.22222222222222
61891, 1.5478260869565, 1.1413043478261, 0.16666666666667
61892, 1.5478260869565, 1.1413043478261, 0.11111111111111
61893, 1.5478260869565, 1.1413043478261, 0.055555555555556
61894, 1.5913043478261, 1.1413043478261, 0.44444444444444
61895, 1.5913043478261, 1.1413043478261, 0.38888888888889
61896, 1.5913043478261, 1.1413043478261, 0.33333333333333
61897, 1.5913043478261, 1.1413043478261, 0.27777777777778
61898, 1.5913043478261, 1.1413043478261, 0.22222222222222
61899, 1.5913043478261, 1.1413043478261, 0.16666666666667
61900, 1.5913043478261, 1.1413043478261, 0.11111111111111
61901, 1.5913043478261, 1.1413043478261, 0.055555555555556
61902, 1.6347826086957, 1.1413043478261, 0.44444444444444
61903, 1.6347826086957, 1.1413043478261, 0.38888888888889
61904, 1.6347826086957, 1.1413043478261, 0.33333333333333
61905, 1.6347826086957, 1.1413043478261, 0.27777777777778
61906, 1.6347826086957, 1.1413043478261, 0.22222222222222
61907, 1.6347826086957, 1.1413043478261, 0.16666666666667
61908, 1.6347826086957, 1.1413043478261, 0.11111111111111
61909, 1.6347826086957, 1.1413043478261, 0.055555555555556
61910, 1.6782608695652, 1.1413043478261, 0.44444444444444
61911, 1.6782608695652, 1.1413043478261, 0.38888888888889
61912, 1.6782608695652, 1.1413043478261, 0.33333333333333
61913, 1.6782608695652, 1.1413043478261, 0.27777777777778
61914, 1.6782608695652, 1.1413043478261, 0.22222222222222
61915, 1.6782608695652, 1.1413043478261, 0.16666666666667
61916, 1.6782608695652, 1.1413043478261, 0.11111111111111
61917, 1.6782608695652, 1.1413043478261, 0.055555555555556
61918, 1.7217391304348, 1.1413043478261, 0.44444444444444
61919, 1.7217391304348, 1.1413043478261, 0.38888888888889
61920, 1.7217391304348, 1.1413043478261, 0.33333333333333
61921, 1.7217391304348, 1.1413043478261, 0.27777777777778
61922, 1.7217391304348, 1.1413043478261, 0.22222222222222
61923, 1.7217391304348, 1.1413043478261, 0.16666666666667
61924, 1.7217391304348, 1.1413043478261, 0.11111111111111
61925, 1.7217391304348, 1.1413043478261, 0.055555555555556
61926, 1.7652173913043, 1.1413043478261, 0.44444444444444
61927, 1.7652173913043, 1.1413043478261, 0.38888888888889
61928, 1.7652173913043, 1.1413043478261, 0.33333333333333
61929, 1.7652173913043, 1.1413043478261, 0.27777777777778
61930, 1.7652173913043, 1.1413043478261, 0.22222222222222
61931, 1.7652173913043, 1.1413043478261, 0.16666666666667
61932, 1.7652173913043, 1.1413043478261, 0.11111111111111
61933, 1.7652173913043, 1.1413043478261, 0.055555555555556
61934, 1.8086956521739, 1.1413043478261, 0.44444444444444
61935, 1.8086956521739, 1.1413043478261, 0.38888888888889
61936, 1.8086956521739, 1.1413043478261, 0.33333333333333
61937, 1.8086956521739, 1.1413043478261, 0.27777777777778
61938, 1.8086956521739, 1.1413043478261, 0.22222222222222
61939, 1.8086956521739, 1.1413043478261, 0.16666666666667
61940, 1.8086956521739, 1.1413043478261, 0.11111111111111
61941, 1.8086956521739, 1.1413043478261, 0.055555555555556
61942, 1.8521739130435, 1.1413043478261, 0.44444444444444
61943, 1.8521739130435, 1.1413043478261, 0.38888888888889
61944, 1.8521739130435, 1.1413043478261, 0.33333333333333
61945, 1.8521739130435, 1.1413043478261, 0.27777777777778
61946, 1.8521739130435, 1.1413043478261, 0.22222222222222
61947, 1.8521739130435, 1.1413043478261, 0.16666666666667
61948, 1.8521739130435, 1.1413043478261, 0.11111111111111
61949, 1.8521739130435, 1.1413043478261, 0.055555555555556
61950, 1.895652173913, 1.1413043478261, 0.44444444444444
61951, 1.895652173913, 1.1413043478261, 0.38888888888889
61952, 1.895652173913, 1.1413043478261, 0.33333333333333
61953, 1.895652173913, 1.1413043478261, 0.27777777777778
61954, 1.895652173913, 1.1413043478261, 0.22222222222222
61955, 1.895652173913, 1.1413043478261, 0.16666666666667
61956, 1.895652173913, 1.1413043478261, 0.11111111111111
61957, 1.895652173913, 1.1413043478261, 0.055555555555556
61958, 1.9391304347826, 1.1413043478261, 0.44444444444444
61959, 1.9391304347826, 1.1413043478261, 0.38888888888889
61960, 1.9391304347826, 1.1413043478261, 0.33333333333333
61961, 1.9391304347826, 1.1413043478261, 0.27777777777778
61962, 1.9391304347826, 1.1413043478261, 0.22222222222222
61963, 1.9391304347826, 1.1413043478261, 0.16666666666667
61964, 1.9391304347826, 1.1413043478261, 0.11111111111111
61965, 1.9391304347826, 1.1413043478261, 0.055555555555556
61966, 1.9826086956522, 1.1413043478261, 0.44444444444444
61967, 1.9826086956522, 1.1413043478261, 0.38888888888889
61968, 1.9826086956522, 1.1413043478261, 0.33333333333333
61969, 1.9826086956522, 1.1413043478261, 0.27777777777778
61970, 1.9826086956522, 1.1413043478261, 0.22222222222222
61971, 1.9826086956522, 1.1413043478261, 0.16666666666667
61972, 1.9826086956522, 1.1413043478261, 0.11111111111111
61973, 1.9826086956522, 1.1413043478261, 0.055555555555556
61974, 2.0260869565217, 1.1413043478261, 0.44444444444444
61975, 2.0260869565217, 1.1413043478261, 0.38888888888889
61976, 2.0260869565217, 1.1413043478261, 0.33333333333333
61977, 2.0260869565217, 1.1413043478261, 0.27777777777778
61978, 2.0260869565217, 1.1413043478261, 0.22222222222222
61979, 2.0260869565217, 1.1413043478261, 0.16666666666667
61980, 2.0260869565217, 1.1413043478261, 0.11111111111111
61981, 2.0260869565217, 1.1413043478261, 0.055555555555556
61982, 2.0695652173913, 1.1413043478261, 0.44444444444444
61983, 2.0695652173913, 1.1413043478261, 0.38888888888889
61984, 2.0695652173913, 1.1413043478261, 0.33333333333333
61985, 2.0695652173913, 1.1413043478261, 0.27777777777778
61986, 2.0695652173913, 1.1413043478261, 0.22222222222222
61987, 2.0695652173913, 1.1413043478261, 0.16666666666667
61988, 2.0695652173913, 1.1413043478261, 0.11111111111111
61989, 2.0695652173913, 1.1413043478261, 0.055555555555556
61990, 2.1130434782609, 1.1413043478261, 0.44444444444444
