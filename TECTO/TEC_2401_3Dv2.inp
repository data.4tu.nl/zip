33578, 0.78260869565217, 0.72391304347826, -0.075
33579, 0.73913043478261, 0.72391304347826, -0.075
33580, 0.69565217391304, 0.72391304347826, -0.075
33581, 0.65217391304348, 0.72391304347826, -0.075
33582, 0.60869565217391, 0.72391304347826, -0.075
33583, 0.56521739130435, 0.72391304347826, -0.075
33584, 0.52173913043478, 0.72391304347826, -0.075
33585, 0.47826086956522, 0.72391304347826, -0.075
33586, 0.43478260869565, 0.72391304347826, -0.075
33587, 0.39130434782609, 0.72391304347826, -0.075
33588, 0.34782608695652, 0.72391304347826, -0.075
33589, 0.30434782608696, 0.72391304347826, -0.075
33590, 0.26086956521739, 0.72391304347826, -0.075
33591, 0.21739130434783, 0.72391304347826, -0.075
33592, 0.17391304347826, 0.72391304347826, -0.075
33593, 0.1304347826087, 0.72391304347826, -0.075
33594, 0.08695652173913, 0.72391304347826, -0.075
33595, 0.043478260869565, 0.72391304347826, -0.075
33596, 0.95652173913043, 0.77608695652174, -0.075
33597, 0.91304347826087, 0.77608695652174, -0.075
33598, 0.8695652173913, 0.77608695652174, -0.075
33599, 0.82608695652174, 0.77608695652174, -0.075
33600, 0.78260869565217, 0.77608695652174, -0.075
33601, 0.73913043478261, 0.77608695652174, -0.075
33602, 0.69565217391304, 0.77608695652174, -0.075
33603, 0.65217391304348, 0.77608695652174, -0.075
33604, 0.60869565217391, 0.77608695652174, -0.075
33605, 0.56521739130435, 0.77608695652174, -0.075
33606, 0.52173913043478, 0.77608695652174, -0.075
33607, 0.47826086956522, 0.77608695652174, -0.075
33608, 0.43478260869565, 0.77608695652174, -0.075
33609, 0.39130434782609, 0.77608695652174, -0.075
33610, 0.34782608695652, 0.77608695652174, -0.075
33611, 0.30434782608696, 0.77608695652174, -0.075
33612, 0.26086956521739, 0.77608695652174, -0.075
33613, 0.21739130434783, 0.77608695652174, -0.075
33614, 0.17391304347826, 0.77608695652174, -0.075
33615, 0.1304347826087, 0.77608695652174, -0.075
33616, 0.08695652173913, 0.77608695652174, -0.075
33617, 0.043478260869565, 0.77608695652174, -0.075
33618, 0.95652173913043, 0.82826086956522, -0.075
33619, 0.91304347826087, 0.82826086956522, -0.075
33620, 0.8695652173913, 0.82826086956522, -0.075
33621, 0.82608695652174, 0.82826086956522, -0.075
33622, 0.78260869565217, 0.82826086956522, -0.075
33623, 0.73913043478261, 0.82826086956522, -0.075
33624, 0.69565217391304, 0.82826086956522, -0.075
33625, 0.65217391304348, 0.82826086956522, -0.075
33626, 0.60869565217391, 0.82826086956522, -0.075
33627, 0.56521739130435, 0.82826086956522, -0.075
33628, 0.52173913043478, 0.82826086956522, -0.075
33629, 0.47826086956522, 0.82826086956522, -0.075
33630, 0.43478260869565, 0.82826086956522, -0.075
33631, 0.39130434782609, 0.82826086956522, -0.075
33632, 0.34782608695652, 0.82826086956522, -0.075
33633, 0.30434782608696, 0.82826086956522, -0.075
33634, 0.26086956521739, 0.82826086956522, -0.075
33635, 0.21739130434783, 0.82826086956522, -0.075
33636, 0.17391304347826, 0.82826086956522, -0.075
33637, 0.1304347826087, 0.82826086956522, -0.075
33638, 0.08695652173913, 0.82826086956522, -0.075
33639, 0.043478260869565, 0.82826086956522, -0.075
33640, 0.95652173913043, 0.8804347826087, -0.075
33641, 0.91304347826087, 0.8804347826087, -0.075
33642, 0.8695652173913, 0.88043478260869, -0.075
33643, 0.82608695652174, 0.8804347826087, -0.075
33644, 0.78260869565217, 0.8804347826087, -0.075
33645, 0.73913043478261, 0.8804347826087, -0.075
33646, 0.69565217391304, 0.8804347826087, -0.075
33647, 0.65217391304348, 0.8804347826087, -0.075
33648, 0.60869565217391, 0.8804347826087, -0.075
33649, 0.56521739130435, 0.8804347826087, -0.075
33650, 0.52173913043478, 0.88043478260869, -0.075
33651, 0.47826086956522, 0.8804347826087, -0.075
33652, 0.43478260869565, 0.8804347826087, -0.075
33653, 0.39130434782609, 0.88043478260869, -0.075
33654, 0.34782608695652, 0.8804347826087, -0.075
33655, 0.30434782608696, 0.8804347826087, -0.075
33656, 0.26086956521739, 0.8804347826087, -0.075
33657, 0.21739130434783, 0.8804347826087, -0.075
33658, 0.17391304347826, 0.8804347826087, -0.075
33659, 0.1304347826087, 0.8804347826087, -0.075
33660, 0.08695652173913, 0.8804347826087, -0.075
33661, 0.043478260869565, 0.8804347826087, -0.075
33662, 0.95652173913043, 0.93260869565217, -0.075
33663, 0.91304347826087, 0.93260869565217, -0.075
33664, 0.8695652173913, 0.93260869565217, -0.075
33665, 0.82608695652174, 0.93260869565217, -0.075
33666, 0.78260869565217, 0.93260869565217, -0.075
33667, 0.73913043478261, 0.93260869565217, -0.075
33668, 0.69565217391304, 0.93260869565217, -0.075
33669, 0.65217391304348, 0.93260869565217, -0.075
33670, 0.60869565217391, 0.93260869565217, -0.075
33671, 0.56521739130435, 0.93260869565217, -0.075
33672, 0.52173913043478, 0.93260869565217, -0.075
33673, 0.47826086956522, 0.93260869565217, -0.075
33674, 0.43478260869565, 0.93260869565217, -0.075
33675, 0.39130434782609, 0.93260869565217, -0.075
33676, 0.34782608695652, 0.93260869565217, -0.075
33677, 0.30434782608696, 0.93260869565217, -0.075
33678, 0.26086956521739, 0.93260869565217, -0.075
33679, 0.21739130434783, 0.93260869565217, -0.075
33680, 0.17391304347826, 0.93260869565217, -0.075
33681, 0.1304347826087, 0.93260869565217, -0.075
33682, 0.08695652173913, 0.93260869565217, -0.075
33683, 0.043478260869565, 0.93260869565217, -0.075
33684, 0.95652173913043, 0.98478260869565, -0.075
33685, 0.91304347826087, 0.98478260869565, -0.075
33686, 0.8695652173913, 0.98478260869565, -0.075
33687, 0.82608695652174, 0.98478260869565, -0.075
33688, 0.78260869565217, 0.98478260869565, -0.075
33689, 0.73913043478261, 0.98478260869565, -0.075
33690, 0.69565217391304, 0.98478260869565, -0.075
33691, 0.65217391304348, 0.98478260869565, -0.075
33692, 0.60869565217391, 0.98478260869565, -0.075
33693, 0.56521739130435, 0.98478260869565, -0.075
33694, 0.52173913043478, 0.98478260869565, -0.075
33695, 0.47826086956522, 0.98478260869565, -0.075
33696, 0.43478260869565, 0.98478260869565, -0.075
33697, 0.39130434782609, 0.98478260869565, -0.075
33698, 0.34782608695652, 0.98478260869565, -0.075
33699, 0.30434782608696, 0.98478260869565, -0.075
33700, 0.26086956521739, 0.98478260869565, -0.075
33701, 0.21739130434783, 0.98478260869565, -0.075
33702, 0.17391304347826, 0.98478260869565, -0.075
33703, 0.1304347826087, 0.98478260869565, -0.075
33704, 0.08695652173913, 0.98478260869565, -0.075
33705, 0.043478260869565, 0.98478260869565, -0.075
33706, 0.95652173913043, 1.0369565217391, -0.075
33707, 0.91304347826087, 1.0369565217391, -0.075
33708, 0.8695652173913, 1.0369565217391, -0.075
33709, 0.82608695652174, 1.0369565217391, -0.075
33710, 0.78260869565217, 1.0369565217391, -0.075
33711, 0.73913043478261, 1.0369565217391, -0.075
33712, 0.69565217391304, 1.0369565217391, -0.075
33713, 0.65217391304348, 1.0369565217391, -0.075
33714, 0.60869565217391, 1.0369565217391, -0.075
33715, 0.56521739130435, 1.0369565217391, -0.075
33716, 0.52173913043478, 1.0369565217391, -0.075
33717, 0.47826086956522, 1.0369565217391, -0.075
33718, 0.43478260869565, 1.0369565217391, -0.075
33719, 0.39130434782609, 1.0369565217391, -0.075
33720, 0.34782608695652, 1.0369565217391, -0.075
33721, 0.30434782608696, 1.0369565217391, -0.075
33722, 0.26086956521739, 1.0369565217391, -0.075
33723, 0.21739130434783, 1.0369565217391, -0.075
33724, 0.17391304347826, 1.0369565217391, -0.075
33725, 0.1304347826087, 1.0369565217391, -0.075
33726, 0.08695652173913, 1.0369565217391, -0.075
33727, 0.043478260869565, 1.0369565217391, -0.075
33728, 0.95652173913043, 1.0891304347826, -0.075
33729, 0.91304347826087, 1.0891304347826, -0.075
33730, 0.8695652173913, 1.0891304347826, -0.075
33731, 0.82608695652174, 1.0891304347826, -0.075
33732, 0.78260869565217, 1.0891304347826, -0.075
33733, 0.73913043478261, 1.0891304347826, -0.075
33734, 0.69565217391304, 1.0891304347826, -0.075
33735, 0.65217391304348, 1.0891304347826, -0.075
33736, 0.60869565217391, 1.0891304347826, -0.075
33737, 0.56521739130435, 1.0891304347826, -0.075
33738, 0.52173913043478, 1.0891304347826, -0.075
33739, 0.47826086956522, 1.0891304347826, -0.075
33740, 0.43478260869565, 1.0891304347826, -0.075
33741, 0.39130434782609, 1.0891304347826, -0.075
33742, 0.34782608695652, 1.0891304347826, -0.075
33743, 0.30434782608696, 1.0891304347826, -0.075
33744, 0.26086956521739, 1.0891304347826, -0.075
33745, 0.21739130434783, 1.0891304347826, -0.075
33746, 0.17391304347826, 1.0891304347826, -0.075
33747, 0.1304347826087, 1.0891304347826, -0.075
33748, 0.08695652173913, 1.0891304347826, -0.075
33749, 0.043478260869565, 1.0891304347826, -0.075
33750, 0.95652173913043, 1.1413043478261, -0.075
33751, 0.91304347826087, 1.1413043478261, -0.075
33752, 0.8695652173913, 1.1413043478261, -0.075
33753, 0.82608695652174, 1.1413043478261, -0.075
33754, 0.78260869565217, 1.1413043478261, -0.075
33755, 0.73913043478261, 1.1413043478261, -0.075
33756, 0.69565217391304, 1.1413043478261, -0.075
33757, 0.65217391304348, 1.1413043478261, -0.075
33758, 0.60869565217391, 1.1413043478261, -0.075
33759, 0.56521739130435, 1.1413043478261, -0.075
33760, 0.52173913043478, 1.1413043478261, -0.075
33761, 0.47826086956522, 1.1413043478261, -0.075
33762, 0.43478260869565, 1.1413043478261, -0.075
33763, 0.39130434782609, 1.1413043478261, -0.075
33764, 0.34782608695652, 1.1413043478261, -0.075
33765, 0.30434782608696, 1.1413043478261, -0.075
33766, 0.26086956521739, 1.1413043478261, -0.075
33767, 0.21739130434783, 1.1413043478261, -0.075
33768, 0.17391304347826, 1.1413043478261, -0.075
33769, 0.1304347826087, 1.1413043478261, -0.075
33770, 0.08695652173913, 1.1413043478261, -0.075
33771, 0.043478260869565, 1.1413043478261, -0.075
33772, 0.95652173913043, 1.1934782608696, -0.075
33773, 0.91304347826087, 1.1934782608696, -0.075
33774, 0.8695652173913, 1.1934782608696, -0.075
33775, 0.82608695652174, 1.1934782608696, -0.075
33776, 0.78260869565217, 1.1934782608696, -0.075
33777, 0.73913043478261, 1.1934782608696, -0.075
33778, 0.69565217391304, 1.1934782608696, -0.075
33779, 0.65217391304348, 1.1934782608696, -0.075
33780, 0.60869565217391, 1.1934782608696, -0.075
33781, 0.56521739130435, 1.1934782608696, -0.075
33782, 0.52173913043478, 1.1934782608696, -0.075
33783, 0.47826086956522, 1.1934782608696, -0.075
33784, 0.43478260869565, 1.1934782608696, -0.075
33785, 0.39130434782609, 1.1934782608696, -0.075
33786, 0.34782608695652, 1.1934782608696, -0.075
33787, 0.30434782608696, 1.1934782608696, -0.075
33788, 0.26086956521739, 1.1934782608696, -0.075
33789, 0.21739130434783, 1.1934782608696, -0.075
33790, 0.17391304347826, 1.1934782608696, -0.075
33791, 0.1304347826087, 1.1934782608696, -0.075
33792, 0.08695652173913, 1.1934782608696, -0.075
33793, 0.043478260869565, 1.1934782608696, -0.075
33794, 0.95652173913043, 1.245652173913, -0.075
33795, 0.91304347826087, 1.245652173913, -0.075
33796, 0.8695652173913, 1.245652173913, -0.075
33797, 0.82608695652174, 1.245652173913, -0.075
33798, 0.78260869565217, 1.245652173913, -0.075
33799, 0.73913043478261, 1.245652173913, -0.075
33800, 0.69565217391304, 1.245652173913, -0.075
33801, 0.65217391304348, 1.245652173913, -0.075
33802, 0.60869565217391, 1.245652173913, -0.075
33803, 0.56521739130435, 1.245652173913, -0.075
33804, 0.52173913043478, 1.245652173913, -0.075
33805, 0.47826086956522, 1.245652173913, -0.075
33806, 0.43478260869565, 1.245652173913, -0.075
33807, 0.39130434782609, 1.245652173913, -0.075
33808, 0.34782608695652, 1.245652173913, -0.075
33809, 0.30434782608696, 1.245652173913, -0.075
33810, 0.26086956521739, 1.245652173913, -0.075
33811, 0.21739130434783, 1.245652173913, -0.075
33812, 0.17391304347826, 1.245652173913, -0.075
33813, 0.1304347826087, 1.245652173913, -0.075
33814, 0.08695652173913, 1.245652173913, -0.075
33815, 0.043478260869565, 1.245652173913, -0.075
33816, 0.95652173913043, 1.2978260869565, -0.075
33817, 0.91304347826087, 1.2978260869565, -0.075
33818, 0.8695652173913, 1.2978260869565, -0.075
33819, 0.82608695652174, 1.2978260869565, -0.075
33820, 0.78260869565217, 1.2978260869565, -0.075
33821, 0.73913043478261, 1.2978260869565, -0.075
33822, 0.69565217391304, 1.2978260869565, -0.075
33823, 0.65217391304348, 1.2978260869565, -0.075
33824, 0.60869565217391, 1.2978260869565, -0.075
33825, 0.56521739130435, 1.2978260869565, -0.075
33826, 0.52173913043478, 1.2978260869565, -0.075
33827, 0.47826086956522, 1.2978260869565, -0.075
33828, 0.43478260869565, 1.2978260869565, -0.075
33829, 0.39130434782609, 1.2978260869565, -0.075
33830, 0.34782608695652, 1.2978260869565, -0.075
33831, 0.30434782608696, 1.2978260869565, -0.075
33832, 0.26086956521739, 1.2978260869565, -0.075
33833, 0.21739130434783, 1.2978260869565, -0.075
33834, 0.17391304347826, 1.2978260869565, -0.075
33835, 0.1304347826087, 1.2978260869565, -0.075
33836, 0.08695652173913, 1.2978260869565, -0.075
33837, 0.043478260869565, 1.2978260869565, -0.075
33838, 0.95652173913043, 0.17608695652174, -0.075
33839, 0.97826086956522, 0.20217391304348, -0.075
33840, 0.91304347826087, 0.17608695652174, -0.075
33841, 0.93478260869565, 0.20217391304348, -0.075
33842, 0.8695652173913, 0.17608695652174, -0.075
33843, 0.89130434782609, 0.20217391304348, -0.075
33844, 0.82608695652174, 0.17608695652174, -0.075
33845, 0.84782608695652, 0.20217391304348, -0.075
33846, 0.78260869565217, 0.17608695652174, -0.075
33847, 0.80434782608696, 0.20217391304348, -0.075
33848, 0.73913043478261, 0.17608695652174, -0.075
33849, 0.76086956521739, 0.20217391304348, -0.075
33850, 0.69565217391304, 0.17608695652174, -0.075
33851, 0.71739130434783, 0.20217391304348, -0.075
33852, 0.65217391304348, 0.17608695652174, -0.075
33853, 0.67391304347826, 0.20217391304348, -0.075
33854, 0.60869565217391, 0.17608695652174, -0.075
33855, 0.6304347826087, 0.20217391304348, -0.075
33856, 0.56521739130435, 0.17608695652174, -0.075
33857, 0.58695652173913, 0.20217391304348, -0.075
33858, 0.52173913043478, 0.17608695652174, -0.075
33859, 0.54347826086957, 0.20217391304348, -0.075
33860, 0.47826086956522, 0.17608695652174, -0.075
33861, 0.5, 0.20217391304348, -0.075
33862, 0.43478260869565, 0.17608695652174, -0.075
33863, 0.45652173913043, 0.20217391304348, -0.075
33864, 0.39130434782609, 0.17608695652174, -0.075
33865, 0.41304347826087, 0.20217391304348, -0.075
33866, 0.34782608695652, 0.17608695652174, -0.075
33867, 0.3695652173913, 0.20217391304348, -0.075
33868, 0.30434782608696, 0.17608695652174, -0.075
33869, 0.32608695652174, 0.20217391304348, -0.075
33870, 0.26086956521739, 0.17608695652174, -0.075
33871, 0.28260869565217, 0.20217391304348, -0.075
33872, 0.21739130434783, 0.17608695652174, -0.075
33873, 0.23913043478261, 0.20217391304348, -0.075
33874, 0.17391304347826, 0.17608695652174, -0.075
33875, 0.19565217391304, 0.20217391304348, -0.075
33876, 0.1304347826087, 0.17608695652174, -0.075
33877, 0.15217391304348, 0.20217391304348, -0.075
33878, 0.08695652173913, 0.17608695652174, -0.075
33879, 0.10869565217391, 0.20217391304348, -0.075
33880, 0.043478260869565, 0.17608695652174, -0.075
33881, 0.065217391304348, 0.20217391304348, -0.075
33882, 0.021739130434783, 0.20217391304348, -0.075
33883, 0.95652173913043, 0.22826086956522, -0.075
33884, 0.97826086956522, 0.25434782608696, -0.075
33885, 0.91304347826087, 0.22826086956522, -0.075
33886, 0.93478260869565, 0.25434782608696, -0.075
33887, 0.8695652173913, 0.22826086956522, -0.075
33888, 0.89130434782609, 0.25434782608696, -0.075
33889, 0.82608695652174, 0.22826086956522, -0.075
33890, 0.84782608695652, 0.25434782608696, -0.075
33891, 0.78260869565217, 0.22826086956522, -0.075
33892, 0.80434782608696, 0.25434782608696, -0.075
33893, 0.73913043478261, 0.22826086956522, -0.075
33894, 0.76086956521739, 0.25434782608696, -0.075
33895, 0.69565217391304, 0.22826086956522, -0.075
33896, 0.71739130434783, 0.25434782608696, -0.075
33897, 0.65217391304348, 0.22826086956522, -0.075
33898, 0.67391304347826, 0.25434782608696, -0.075
33899, 0.60869565217391, 0.22826086956522, -0.075
33900, 0.6304347826087, 0.25434782608696, -0.075
33901, 0.56521739130435, 0.22826086956522, -0.075
33902, 0.58695652173913, 0.25434782608696, -0.075
33903, 0.52173913043478, 0.22826086956522, -0.075
33904, 0.54347826086957, 0.25434782608696, -0.075
33905, 0.47826086956522, 0.22826086956522, -0.075
33906, 0.5, 0.25434782608696, -0.075
33907, 0.43478260869565, 0.22826086956522, -0.075
33908, 0.45652173913043, 0.25434782608696, -0.075
33909, 0.39130434782609, 0.22826086956522, -0.075
33910, 0.41304347826087, 0.25434782608696, -0.075
33911, 0.34782608695652, 0.22826086956522, -0.075
33912, 0.3695652173913, 0.25434782608696, -0.075
33913, 0.30434782608696, 0.22826086956522, -0.075
33914, 0.32608695652174, 0.25434782608696, -0.075
33915, 0.26086956521739, 0.22826086956522, -0.075
33916, 0.28260869565217, 0.25434782608696, -0.075
33917, 0.21739130434783, 0.22826086956522, -0.075
33918, 0.23913043478261, 0.25434782608696, -0.075
33919, 0.17391304347826, 0.22826086956522, -0.075
33920, 0.19565217391304, 0.25434782608696, -0.075
33921, 0.1304347826087, 0.22826086956522, -0.075
33922, 0.15217391304348, 0.25434782608696, -0.075
33923, 0.08695652173913, 0.22826086956522, -0.075
33924, 0.10869565217391, 0.25434782608696, -0.075
33925, 0.043478260869565, 0.22826086956522, -0.075
33926, 0.065217391304348, 0.25434782608696, -0.075
33927, 0.021739130434783, 0.25434782608696, -0.075
33928, 0.95652173913043, 0.2804347826087, -0.075
33929, 0.97826086956522, 0.30652173913043, -0.075
33930, 0.91304347826087, 0.2804347826087, -0.075
33931, 0.93478260869565, 0.30652173913043, -0.075
33932, 0.8695652173913, 0.2804347826087, -0.075
33933, 0.89130434782609, 0.30652173913043, -0.075
33934, 0.82608695652174, 0.2804347826087, -0.075
33935, 0.84782608695652, 0.30652173913043, -0.075
33936, 0.78260869565217, 0.2804347826087, -0.075
33937, 0.80434782608696, 0.30652173913043, -0.075
33938, 0.73913043478261, 0.2804347826087, -0.075
33939, 0.76086956521739, 0.30652173913043, -0.075
33940, 0.69565217391304, 0.2804347826087, -0.075
33941, 0.71739130434783, 0.30652173913043, -0.075
33942, 0.65217391304348, 0.2804347826087, -0.075
33943, 0.67391304347826, 0.30652173913043, -0.075
33944, 0.60869565217391, 0.2804347826087, -0.075
33945, 0.6304347826087, 0.30652173913043, -0.075
33946, 0.56521739130435, 0.2804347826087, -0.075
33947, 0.58695652173913, 0.30652173913043, -0.075
33948, 0.52173913043478, 0.2804347826087, -0.075
33949, 0.54347826086957, 0.30652173913043, -0.075
33950, 0.47826086956522, 0.2804347826087, -0.075
33951, 0.5, 0.30652173913043, -0.075
33952, 0.43478260869565, 0.2804347826087, -0.075
33953, 0.45652173913043, 0.30652173913043, -0.075
33954, 0.39130434782609, 0.2804347826087, -0.075
33955, 0.41304347826087, 0.30652173913043, -0.075
33956, 0.34782608695652, 0.2804347826087, -0.075
33957, 0.3695652173913, 0.30652173913043, -0.075
33958, 0.30434782608696, 0.2804347826087, -0.075
33959, 0.32608695652174, 0.30652173913043, -0.075
33960, 0.26086956521739, 0.2804347826087, -0.075
33961, 0.28260869565217, 0.30652173913043, -0.075
33962, 0.21739130434783, 0.2804347826087, -0.075
33963, 0.23913043478261, 0.30652173913043, -0.075
33964, 0.17391304347826, 0.2804347826087, -0.075
33965, 0.19565217391304, 0.30652173913043, -0.075
33966, 0.1304347826087, 0.2804347826087, -0.075
33967, 0.15217391304348, 0.30652173913043, -0.075
33968, 0.08695652173913, 0.2804347826087, -0.075
33969, 0.10869565217391, 0.30652173913043, -0.075
33970, 0.043478260869565, 0.2804347826087, -0.075
33971, 0.065217391304348, 0.30652173913043, -0.075
33972, 0.021739130434783, 0.30652173913043, -0.075
33973, 0.95652173913043, 0.33260869565217, -0.075
33974, 0.97826086956522, 0.35869565217391, -0.075
33975, 0.91304347826087, 0.33260869565217, -0.075
33976, 0.93478260869565, 0.35869565217391, -0.075
33977, 0.8695652173913, 0.33260869565217, -0.075
33978, 0.89130434782609, 0.35869565217391, -0.075
33979, 0.82608695652174, 0.33260869565217, -0.075
33980, 0.84782608695652, 0.35869565217391, -0.075
33981, 0.78260869565217, 0.33260869565217, -0.075
33982, 0.80434782608696, 0.35869565217391, -0.075
33983, 0.73913043478261, 0.33260869565217, -0.075
33984, 0.76086956521739, 0.35869565217391, -0.075
33985, 0.69565217391304, 0.33260869565217, -0.075
33986, 0.71739130434783, 0.35869565217391, -0.075
33987, 0.65217391304348, 0.33260869565217, -0.075
33988, 0.67391304347826, 0.35869565217391, -0.075
33989, 0.60869565217391, 0.33260869565217, -0.075
33990, 0.6304347826087, 0.35869565217391, -0.075
33991, 0.56521739130435, 0.33260869565217, -0.075
33992, 0.58695652173913, 0.35869565217391, -0.075
33993, 0.52173913043478, 0.33260869565217, -0.075
33994, 0.54347826086957, 0.35869565217391, -0.075
33995, 0.47826086956522, 0.33260869565217, -0.075
33996, 0.5, 0.35869565217391, -0.075
33997, 0.43478260869565, 0.33260869565217, -0.075
33998, 0.45652173913043, 0.35869565217391, -0.075
33999, 0.39130434782609, 0.33260869565217, -0.075
34000, 0.41304347826087, 0.35869565217391, -0.075
34001, 0.34782608695652, 0.33260869565217, -0.075
34002, 0.3695652173913, 0.35869565217391, -0.075
34003, 0.30434782608696, 0.33260869565217, -0.075
34004, 0.32608695652174, 0.35869565217391, -0.075
34005, 0.26086956521739, 0.33260869565217, -0.075
34006, 0.28260869565217, 0.35869565217391, -0.075
34007, 0.21739130434783, 0.33260869565217, -0.075
34008, 0.23913043478261, 0.35869565217391, -0.075
34009, 0.17391304347826, 0.33260869565217, -0.075
34010, 0.19565217391304, 0.35869565217391, -0.075
34011, 0.1304347826087, 0.33260869565217, -0.075
34012, 0.15217391304348, 0.35869565217391, -0.075
34013, 0.08695652173913, 0.33260869565217, -0.075
34014, 0.10869565217391, 0.35869565217391, -0.075
34015, 0.043478260869565, 0.33260869565217, -0.075
34016, 0.065217391304348, 0.35869565217391, -0.075
34017, 0.021739130434783, 0.35869565217391, -0.075
34018, 0.95652173913043, 0.38478260869565, -0.075
34019, 0.97826086956522, 0.41086956521739, -0.075
34020, 0.91304347826087, 0.38478260869565, -0.075
34021, 0.93478260869565, 0.41086956521739, -0.075
34022, 0.8695652173913, 0.38478260869565, -0.075
34023, 0.89130434782609, 0.41086956521739, -0.075
34024, 0.82608695652174, 0.38478260869565, -0.075
34025, 0.84782608695652, 0.41086956521739, -0.075
34026, 0.78260869565217, 0.38478260869565, -0.075
34027, 0.80434782608696, 0.41086956521739, -0.075
34028, 0.73913043478261, 0.38478260869565, -0.075
34029, 0.76086956521739, 0.41086956521739, -0.075
34030, 0.69565217391304, 0.38478260869565, -0.075
34031, 0.71739130434783, 0.41086956521739, -0.075
34032, 0.65217391304348, 0.38478260869565, -0.075
34033, 0.67391304347826, 0.41086956521739, -0.075
34034, 0.60869565217391, 0.38478260869565, -0.075
34035, 0.6304347826087, 0.41086956521739, -0.075
34036, 0.56521739130435, 0.38478260869565, -0.075
34037, 0.58695652173913, 0.41086956521739, -0.075
34038, 0.52173913043478, 0.38478260869565, -0.075
34039, 0.54347826086957, 0.41086956521739, -0.075
34040, 0.47826086956522, 0.38478260869565, -0.075
34041, 0.5, 0.41086956521739, -0.075
34042, 0.43478260869565, 0.38478260869565, -0.075
34043, 0.45652173913043, 0.41086956521739, -0.075
34044, 0.39130434782609, 0.38478260869565, -0.075
34045, 0.41304347826087, 0.41086956521739, -0.075
34046, 0.34782608695652, 0.38478260869565, -0.075
34047, 0.3695652173913, 0.41086956521739, -0.075
34048, 0.30434782608696, 0.38478260869565, -0.075
34049, 0.32608695652174, 0.41086956521739, -0.075
34050, 0.26086956521739, 0.38478260869565, -0.075
34051, 0.28260869565217, 0.41086956521739, -0.075
34052, 0.21739130434783, 0.38478260869565, -0.075
34053, 0.23913043478261, 0.41086956521739, -0.075
34054, 0.17391304347826, 0.38478260869565, -0.075
34055, 0.19565217391304, 0.41086956521739, -0.075
34056, 0.1304347826087, 0.38478260869565, -0.075
34057, 0.15217391304348, 0.41086956521739, -0.075
34058, 0.08695652173913, 0.38478260869565, -0.075
34059, 0.10869565217391, 0.41086956521739, -0.075
34060, 0.043478260869565, 0.38478260869565, -0.075
34061, 0.065217391304348, 0.41086956521739, -0.075
34062, 0.021739130434783, 0.41086956521739, -0.075
34063, 0.95652173913043, 0.43695652173913, -0.075
34064, 0.97826086956522, 0.46304347826087, -0.075
34065, 0.91304347826087, 0.43695652173913, -0.075
34066, 0.93478260869565, 0.46304347826087, -0.075
34067, 0.8695652173913, 0.43695652173913, -0.075
34068, 0.89130434782609, 0.46304347826087, -0.075
34069, 0.82608695652174, 0.43695652173913, -0.075
34070, 0.84782608695652, 0.46304347826087, -0.075
34071, 0.78260869565217, 0.43695652173913, -0.075
34072, 0.80434782608696, 0.46304347826087, -0.075
34073, 0.73913043478261, 0.43695652173913, -0.075
34074, 0.76086956521739, 0.46304347826087, -0.075
34075, 0.69565217391304, 0.43695652173913, -0.075
34076, 0.71739130434783, 0.46304347826087, -0.075
34077, 0.65217391304348, 0.43695652173913, -0.075
34078, 0.67391304347826, 0.46304347826087, -0.075
34079, 0.60869565217391, 0.43695652173913, -0.075
34080, 0.6304347826087, 0.46304347826087, -0.075
34081, 0.56521739130435, 0.43695652173913, -0.075
34082, 0.58695652173913, 0.46304347826087, -0.075
34083, 0.52173913043478, 0.43695652173913, -0.075
34084, 0.54347826086957, 0.46304347826087, -0.075
34085, 0.47826086956522, 0.43695652173913, -0.075
34086, 0.5, 0.46304347826087, -0.075
34087, 0.43478260869565, 0.43695652173913, -0.075
34088, 0.45652173913043, 0.46304347826087, -0.075
34089, 0.39130434782609, 0.43695652173913, -0.075
34090, 0.41304347826087, 0.46304347826087, -0.075
34091, 0.34782608695652, 0.43695652173913, -0.075
34092, 0.3695652173913, 0.46304347826087, -0.075
34093, 0.30434782608696, 0.43695652173913, -0.075
34094, 0.32608695652174, 0.46304347826087, -0.075
34095, 0.26086956521739, 0.43695652173913, -0.075
34096, 0.28260869565217, 0.46304347826087, -0.075
34097, 0.21739130434783, 0.43695652173913, -0.075
34098, 0.23913043478261, 0.46304347826087, -0.075
34099, 0.17391304347826, 0.43695652173913, -0.075
34100, 0.19565217391304, 0.46304347826087, -0.075
34101, 0.1304347826087, 0.43695652173913, -0.075
34102, 0.15217391304348, 0.46304347826087, -0.075
34103, 0.08695652173913, 0.43695652173913, -0.075
34104, 0.10869565217391, 0.46304347826087, -0.075
34105, 0.043478260869565, 0.43695652173913, -0.075
34106, 0.065217391304348, 0.46304347826087, -0.075
34107, 0.021739130434783, 0.46304347826087, -0.075
34108, 0.95652173913043, 0.48913043478261, -0.075
34109, 0.97826086956522, 0.51521739130435, -0.075
34110, 0.91304347826087, 0.48913043478261, -0.075
34111, 0.93478260869565, 0.51521739130435, -0.075
34112, 0.8695652173913, 0.48913043478261, -0.075
34113, 0.89130434782609, 0.51521739130435, -0.075
34114, 0.82608695652174, 0.48913043478261, -0.075
34115, 0.84782608695652, 0.51521739130435, -0.075
34116, 0.78260869565217, 0.48913043478261, -0.075
34117, 0.80434782608696, 0.51521739130435, -0.075
34118, 0.73913043478261, 0.48913043478261, -0.075
34119, 0.76086956521739, 0.51521739130435, -0.075
34120, 0.69565217391304, 0.48913043478261, -0.075
34121, 0.71739130434783, 0.51521739130435, -0.075
34122, 0.65217391304348, 0.48913043478261, -0.075
34123, 0.67391304347826, 0.51521739130435, -0.075
34124, 0.60869565217391, 0.48913043478261, -0.075
34125, 0.6304347826087, 0.51521739130435, -0.075
34126, 0.56521739130435, 0.48913043478261, -0.075
34127, 0.58695652173913, 0.51521739130435, -0.075
34128, 0.52173913043478, 0.48913043478261, -0.075
34129, 0.54347826086957, 0.51521739130435, -0.075
34130, 0.47826086956522, 0.48913043478261, -0.075
34131, 0.5, 0.51521739130435, -0.075
34132, 0.43478260869565, 0.48913043478261, -0.075
34133, 0.45652173913043, 0.51521739130435, -0.075
34134, 0.39130434782609, 0.48913043478261, -0.075
34135, 0.41304347826087, 0.51521739130435, -0.075
34136, 0.34782608695652, 0.48913043478261, -0.075
34137, 0.3695652173913, 0.51521739130435, -0.075
34138, 0.30434782608696, 0.48913043478261, -0.075
34139, 0.32608695652174, 0.51521739130435, -0.075
34140, 0.26086956521739, 0.48913043478261, -0.075
34141, 0.28260869565217, 0.51521739130435, -0.075
34142, 0.21739130434783, 0.48913043478261, -0.075
34143, 0.23913043478261, 0.51521739130435, -0.075
34144, 0.17391304347826, 0.48913043478261, -0.075
34145, 0.19565217391304, 0.51521739130435, -0.075
34146, 0.1304347826087, 0.48913043478261, -0.075
34147, 0.15217391304348, 0.51521739130435, -0.075
34148, 0.08695652173913, 0.48913043478261, -0.075
34149, 0.10869565217391, 0.51521739130435, -0.075
34150, 0.043478260869565, 0.48913043478261, -0.075
34151, 0.065217391304348, 0.51521739130435, -0.075
34152, 0.021739130434783, 0.51521739130435, -0.075
34153, 0.95652173913043, 0.54130434782609, -0.075
34154, 0.97826086956522, 0.56739130434783, -0.075
34155, 0.91304347826087, 0.54130434782609, -0.075
34156, 0.93478260869565, 0.56739130434783, -0.075
34157, 0.8695652173913, 0.54130434782609, -0.075
34158, 0.89130434782609, 0.56739130434783, -0.075
34159, 0.82608695652174, 0.54130434782609, -0.075
34160, 0.84782608695652, 0.56739130434783, -0.075
34161, 0.78260869565217, 0.54130434782609, -0.075
34162, 0.80434782608696, 0.56739130434783, -0.075
34163, 0.73913043478261, 0.54130434782609, -0.075
34164, 0.76086956521739, 0.56739130434783, -0.075
34165, 0.69565217391304, 0.54130434782609, -0.075
34166, 0.71739130434783, 0.56739130434783, -0.075
34167, 0.65217391304348, 0.54130434782609, -0.075
34168, 0.67391304347826, 0.56739130434783, -0.075
34169, 0.60869565217391, 0.54130434782609, -0.075
34170, 0.6304347826087, 0.56739130434783, -0.075
34171, 0.56521739130435, 0.54130434782609, -0.075
34172, 0.58695652173913, 0.56739130434783, -0.075
34173, 0.52173913043478, 0.54130434782609, -0.075
34174, 0.54347826086957, 0.56739130434783, -0.075
34175, 0.47826086956522, 0.54130434782609, -0.075
34176, 0.5, 0.56739130434783, -0.075
34177, 0.43478260869565, 0.54130434782609, -0.075
34178, 0.45652173913043, 0.56739130434783, -0.075
34179, 0.39130434782609, 0.54130434782609, -0.075
34180, 0.41304347826087, 0.56739130434783, -0.075
34181, 0.34782608695652, 0.54130434782609, -0.075
34182, 0.3695652173913, 0.56739130434783, -0.075
34183, 0.30434782608696, 0.54130434782609, -0.075
34184, 0.32608695652174, 0.56739130434783, -0.075
34185, 0.26086956521739, 0.54130434782609, -0.075
34186, 0.28260869565217, 0.56739130434783, -0.075
34187, 0.21739130434783, 0.54130434782609, -0.075
34188, 0.23913043478261, 0.56739130434783, -0.075
34189, 0.17391304347826, 0.54130434782609, -0.075
34190, 0.19565217391304, 0.56739130434783, -0.075
34191, 0.1304347826087, 0.54130434782609, -0.075
34192, 0.15217391304348, 0.56739130434783, -0.075
34193, 0.08695652173913, 0.54130434782609, -0.075
34194, 0.10869565217391, 0.56739130434783, -0.075
34195, 0.043478260869565, 0.54130434782609, -0.075
34196, 0.065217391304348, 0.56739130434783, -0.075
34197, 0.021739130434783, 0.56739130434783, -0.075
34198, 0.95652173913043, 0.59347826086956, -0.075
34199, 0.97826086956522, 0.6195652173913, -0.075
34200, 0.91304347826087, 0.59347826086956, -0.075
34201, 0.93478260869565, 0.6195652173913, -0.075
34202, 0.8695652173913, 0.59347826086956, -0.075
34203, 0.89130434782609, 0.6195652173913, -0.075
34204, 0.82608695652174, 0.59347826086956, -0.075
34205, 0.84782608695652, 0.6195652173913, -0.075
34206, 0.78260869565217, 0.59347826086956, -0.075
34207, 0.80434782608696, 0.6195652173913, -0.075
34208, 0.73913043478261, 0.59347826086956, -0.075
34209, 0.76086956521739, 0.6195652173913, -0.075
34210, 0.69565217391304, 0.59347826086956, -0.075
34211, 0.71739130434783, 0.6195652173913, -0.075
34212, 0.65217391304348, 0.59347826086956, -0.075
34213, 0.67391304347826, 0.6195652173913, -0.075
34214, 0.60869565217391, 0.59347826086956, -0.075
34215, 0.6304347826087, 0.6195652173913, -0.075
34216, 0.56521739130435, 0.59347826086956, -0.075
34217, 0.58695652173913, 0.6195652173913, -0.075
34218, 0.52173913043478, 0.59347826086956, -0.075
34219, 0.54347826086957, 0.6195652173913, -0.075
34220, 0.47826086956522, 0.59347826086956, -0.075
34221, 0.5, 0.6195652173913, -0.075
34222, 0.43478260869565, 0.59347826086956, -0.075
34223, 0.45652173913043, 0.6195652173913, -0.075
34224, 0.39130434782609, 0.59347826086956, -0.075
34225, 0.41304347826087, 0.6195652173913, -0.075
34226, 0.34782608695652, 0.59347826086956, -0.075
34227, 0.3695652173913, 0.6195652173913, -0.075
34228, 0.30434782608696, 0.59347826086956, -0.075
34229, 0.32608695652174, 0.6195652173913, -0.075
34230, 0.26086956521739, 0.59347826086956, -0.075
34231, 0.28260869565217, 0.6195652173913, -0.075
34232, 0.21739130434783, 0.59347826086956, -0.075
34233, 0.23913043478261, 0.6195652173913, -0.075
34234, 0.17391304347826, 0.59347826086956, -0.075
34235, 0.19565217391304, 0.6195652173913, -0.075
34236, 0.1304347826087, 0.59347826086956, -0.075
34237, 0.15217391304348, 0.6195652173913, -0.075
34238, 0.08695652173913, 0.59347826086956, -0.075
34239, 0.10869565217391, 0.6195652173913, -0.075
34240, 0.043478260869565, 0.59347826086956, -0.075
34241, 0.065217391304348, 0.6195652173913, -0.075
34242, 0.021739130434783, 0.6195652173913, -0.075
34243, 0.95652173913043, 0.64565217391304, -0.075
34244, 0.97826086956522, 0.67173913043478, -0.075
34245, 0.91304347826087, 0.64565217391304, -0.075
34246, 0.93478260869565, 0.67173913043478, -0.075
34247, 0.8695652173913, 0.64565217391304, -0.075
34248, 0.89130434782609, 0.67173913043478, -0.075
34249, 0.82608695652174, 0.64565217391304, -0.075
34250, 0.84782608695652, 0.67173913043478, -0.075
34251, 0.78260869565217, 0.64565217391304, -0.075
34252, 0.80434782608696, 0.67173913043478, -0.075
34253, 0.73913043478261, 0.64565217391304, -0.075
34254, 0.76086956521739, 0.67173913043478, -0.075
34255, 0.69565217391304, 0.64565217391304, -0.075
34256, 0.71739130434783, 0.67173913043478, -0.075
34257, 0.65217391304348, 0.64565217391304, -0.075
34258, 0.67391304347826, 0.67173913043478, -0.075
34259, 0.60869565217391, 0.64565217391304, -0.075
34260, 0.6304347826087, 0.67173913043478, -0.075
34261, 0.56521739130435, 0.64565217391304, -0.075
34262, 0.58695652173913, 0.67173913043478, -0.075
34263, 0.52173913043478, 0.64565217391304, -0.075
34264, 0.54347826086957, 0.67173913043478, -0.075
34265, 0.47826086956522, 0.64565217391304, -0.075
34266, 0.5, 0.67173913043478, -0.075
34267, 0.43478260869565, 0.64565217391304, -0.075
34268, 0.45652173913043, 0.67173913043478, -0.075
34269, 0.39130434782609, 0.64565217391304, -0.075
34270, 0.41304347826087, 0.67173913043478, -0.075
34271, 0.34782608695652, 0.64565217391304, -0.075
34272, 0.3695652173913, 0.67173913043478, -0.075
34273, 0.30434782608696, 0.64565217391304, -0.075
34274, 0.32608695652174, 0.67173913043478, -0.075
34275, 0.26086956521739, 0.64565217391304, -0.075
34276, 0.28260869565217, 0.67173913043478, -0.075
34277, 0.21739130434783, 0.64565217391304, -0.075
34278, 0.23913043478261, 0.67173913043478, -0.075
34279, 0.17391304347826, 0.64565217391304, -0.075
34280, 0.19565217391304, 0.67173913043478, -0.075
34281, 0.1304347826087, 0.64565217391304, -0.075
34282, 0.15217391304348, 0.67173913043478, -0.075
34283, 0.08695652173913, 0.64565217391304, -0.075
34284, 0.10869565217391, 0.67173913043478, -0.075
34285, 0.043478260869565, 0.64565217391304, -0.075
34286, 0.065217391304348, 0.67173913043478, -0.075
34287, 0.021739130434783, 0.67173913043478, -0.075
34288, 0.95652173913043, 0.69782608695652, -0.075
34289, 0.97826086956522, 0.72391304347826, -0.075
34290, 0.91304347826087, 0.69782608695652, -0.075
34291, 0.93478260869565, 0.72391304347826, -0.075
34292, 0.8695652173913, 0.69782608695652, -0.075
34293, 0.89130434782609, 0.72391304347826, -0.075
34294, 0.82608695652174, 0.69782608695652, -0.075
34295, 0.84782608695652, 0.72391304347826, -0.075
34296, 0.78260869565217, 0.69782608695652, -0.075
34297, 0.80434782608696, 0.72391304347826, -0.075
34298, 0.73913043478261, 0.69782608695652, -0.075
34299, 0.76086956521739, 0.72391304347826, -0.075
34300, 0.69565217391304, 0.69782608695652, -0.075
34301, 0.71739130434783, 0.72391304347826, -0.075
34302, 0.65217391304348, 0.69782608695652, -0.075
34303, 0.67391304347826, 0.72391304347826, -0.075
34304, 0.60869565217391, 0.69782608695652, -0.075
34305, 0.6304347826087, 0.72391304347826, -0.075
34306, 0.56521739130435, 0.69782608695652, -0.075
34307, 0.58695652173913, 0.72391304347826, -0.075
34308, 0.52173913043478, 0.69782608695652, -0.075
34309, 0.54347826086957, 0.72391304347826, -0.075
34310, 0.47826086956522, 0.69782608695652, -0.075
34311, 0.5, 0.72391304347826, -0.075
34312, 0.43478260869565, 0.69782608695652, -0.075
34313, 0.45652173913043, 0.72391304347826, -0.075
34314, 0.39130434782609, 0.69782608695652, -0.075
34315, 0.41304347826087, 0.72391304347826, -0.075
34316, 0.34782608695652, 0.69782608695652, -0.075
34317, 0.3695652173913, 0.72391304347826, -0.075
34318, 0.30434782608696, 0.69782608695652, -0.075
34319, 0.32608695652174, 0.72391304347826, -0.075
34320, 0.26086956521739, 0.69782608695652, -0.075
34321, 0.28260869565217, 0.72391304347826, -0.075
34322, 0.21739130434783, 0.69782608695652, -0.075
34323, 0.23913043478261, 0.72391304347826, -0.075
34324, 0.17391304347826, 0.69782608695652, -0.075
34325, 0.19565217391304, 0.72391304347826, -0.075
34326, 0.1304347826087, 0.69782608695652, -0.075
34327, 0.15217391304348, 0.72391304347826, -0.075
34328, 0.08695652173913, 0.69782608695652, -0.075
34329, 0.10869565217391, 0.72391304347826, -0.075
34330, 0.043478260869565, 0.69782608695652, -0.075
34331, 0.065217391304348, 0.72391304347826, -0.075
34332, 0.021739130434783, 0.72391304347826, -0.075
34333, 0.95652173913043, 0.75, -0.075
34334, 0.97826086956522, 0.77608695652174, -0.075
34335, 0.91304347826087, 0.75, -0.075
34336, 0.93478260869565, 0.77608695652174, -0.075
34337, 0.8695652173913, 0.75, -0.075
34338, 0.89130434782609, 0.77608695652174, -0.075
34339, 0.82608695652174, 0.75, -0.075
34340, 0.84782608695652, 0.77608695652174, -0.075
34341, 0.78260869565217, 0.75, -0.075
34342, 0.80434782608696, 0.77608695652174, -0.075
34343, 0.73913043478261, 0.75, -0.075
34344, 0.76086956521739, 0.77608695652174, -0.075
34345, 0.69565217391304, 0.75, -0.075
34346, 0.71739130434783, 0.77608695652174, -0.075
34347, 0.65217391304348, 0.75, -0.075
34348, 0.67391304347826, 0.77608695652174, -0.075
34349, 0.60869565217391, 0.75, -0.075
34350, 0.6304347826087, 0.77608695652174, -0.075
34351, 0.56521739130435, 0.75, -0.075
34352, 0.58695652173913, 0.77608695652174, -0.075
34353, 0.52173913043478, 0.75, -0.075
34354, 0.54347826086957, 0.77608695652174, -0.075
34355, 0.47826086956522, 0.75, -0.075
34356, 0.5, 0.77608695652174, -0.075
34357, 0.43478260869565, 0.75, -0.075
34358, 0.45652173913043, 0.77608695652174, -0.075
34359, 0.39130434782609, 0.75, -0.075
34360, 0.41304347826087, 0.77608695652174, -0.075
34361, 0.34782608695652, 0.75, -0.075
34362, 0.3695652173913, 0.77608695652174, -0.075
34363, 0.30434782608696, 0.75, -0.075
34364, 0.32608695652174, 0.77608695652174, -0.075
34365, 0.26086956521739, 0.75, -0.075
34366, 0.28260869565217, 0.77608695652174, -0.075
34367, 0.21739130434783, 0.75, -0.075
34368, 0.23913043478261, 0.77608695652174, -0.075
34369, 0.17391304347826, 0.75, -0.075
34370, 0.19565217391304, 0.77608695652174, -0.075
34371, 0.1304347826087, 0.75, -0.075
34372, 0.15217391304348, 0.77608695652174, -0.075
34373, 0.08695652173913, 0.75, -0.075
34374, 0.10869565217391, 0.77608695652174, -0.075
34375, 0.043478260869565, 0.75, -0.075
34376, 0.065217391304348, 0.77608695652174, -0.075
34377, 0.021739130434783, 0.77608695652174, -0.075
34378, 0.95652173913043, 0.80217391304348, -0.075
34379, 0.97826086956522, 0.82826086956522, -0.075
34380, 0.91304347826087, 0.80217391304348, -0.075
34381, 0.93478260869565, 0.82826086956522, -0.075
34382, 0.8695652173913, 0.80217391304348, -0.075
34383, 0.89130434782609, 0.82826086956522, -0.075
34384, 0.82608695652174, 0.80217391304348, -0.075
34385, 0.84782608695652, 0.82826086956522, -0.075
34386, 0.78260869565217, 0.80217391304348, -0.075
34387, 0.80434782608696, 0.82826086956522, -0.075
34388, 0.73913043478261, 0.80217391304348, -0.075
34389, 0.76086956521739, 0.82826086956522, -0.075
34390, 0.69565217391304, 0.80217391304348, -0.075
34391, 0.71739130434783, 0.82826086956522, -0.075
34392, 0.65217391304348, 0.80217391304348, -0.075
34393, 0.67391304347826, 0.82826086956522, -0.075
34394, 0.60869565217391, 0.80217391304348, -0.075
34395, 0.6304347826087, 0.82826086956522, -0.075
34396, 0.56521739130435, 0.80217391304348, -0.075
34397, 0.58695652173913, 0.82826086956522, -0.075
34398, 0.52173913043478, 0.80217391304348, -0.075
34399, 0.54347826086957, 0.82826086956522, -0.075
34400, 0.47826086956522, 0.80217391304348, -0.075
34401, 0.5, 0.82826086956522, -0.075
34402, 0.43478260869565, 0.80217391304348, -0.075
34403, 0.45652173913043, 0.82826086956522, -0.075
34404, 0.39130434782609, 0.80217391304348, -0.075
34405, 0.41304347826087, 0.82826086956522, -0.075
34406, 0.34782608695652, 0.80217391304348, -0.075
34407, 0.3695652173913, 0.82826086956522, -0.075
34408, 0.30434782608696, 0.80217391304348, -0.075
34409, 0.32608695652174, 0.82826086956522, -0.075
34410, 0.26086956521739, 0.80217391304348, -0.075
34411, 0.28260869565217, 0.82826086956522, -0.075
34412, 0.21739130434783, 0.80217391304348, -0.075
34413, 0.23913043478261, 0.82826086956522, -0.075
34414, 0.17391304347826, 0.80217391304348, -0.075
34415, 0.19565217391304, 0.82826086956522, -0.075
34416, 0.1304347826087, 0.80217391304348, -0.075
34417, 0.15217391304348, 0.82826086956522, -0.075
34418, 0.08695652173913, 0.80217391304348, -0.075
34419, 0.10869565217391, 0.82826086956522, -0.075
34420, 0.043478260869565, 0.80217391304348, -0.075
34421, 0.065217391304348, 0.82826086956522, -0.075
34422, 0.021739130434783, 0.82826086956522, -0.075
34423, 0.95652173913043, 0.85434782608696, -0.075
34424, 0.97826086956522, 0.8804347826087, -0.075
34425, 0.91304347826087, 0.85434782608696, -0.075
34426, 0.93478260869565, 0.8804347826087, -0.075
34427, 0.8695652173913, 0.85434782608696, -0.075
34428, 0.89130434782609, 0.8804347826087, -0.075
34429, 0.82608695652174, 0.85434782608696, -0.075
34430, 0.84782608695652, 0.8804347826087, -0.075
34431, 0.78260869565217, 0.85434782608696, -0.075
34432, 0.80434782608696, 0.8804347826087, -0.075
34433, 0.73913043478261, 0.85434782608696, -0.075
34434, 0.76086956521739, 0.8804347826087, -0.075
34435, 0.69565217391304, 0.85434782608696, -0.075
34436, 0.71739130434783, 0.8804347826087, -0.075
34437, 0.65217391304348, 0.85434782608696, -0.075
34438, 0.67391304347826, 0.8804347826087, -0.075
34439, 0.60869565217391, 0.85434782608696, -0.075
34440, 0.6304347826087, 0.8804347826087, -0.075
34441, 0.56521739130435, 0.85434782608696, -0.075
34442, 0.58695652173913, 0.8804347826087, -0.075
34443, 0.52173913043478, 0.85434782608696, -0.075
34444, 0.54347826086957, 0.88043478260869, -0.075
34445, 0.47826086956522, 0.85434782608696, -0.075
34446, 0.5, 0.88043478260869, -0.075
34447, 0.43478260869565, 0.85434782608696, -0.075
34448, 0.45652173913043, 0.8804347826087, -0.075
34449, 0.39130434782609, 0.85434782608696, -0.075
34450, 0.41304347826087, 0.88043478260869, -0.075
34451, 0.34782608695652, 0.85434782608696, -0.075
34452, 0.3695652173913, 0.8804347826087, -0.075
34453, 0.30434782608696, 0.85434782608696, -0.075
34454, 0.32608695652174, 0.8804347826087, -0.075
34455, 0.26086956521739, 0.85434782608696, -0.075
34456, 0.28260869565217, 0.8804347826087, -0.075
34457, 0.21739130434783, 0.85434782608696, -0.075
34458, 0.23913043478261, 0.8804347826087, -0.075
34459, 0.17391304347826, 0.85434782608696, -0.075
34460, 0.19565217391304, 0.8804347826087, -0.075
34461, 0.1304347826087, 0.85434782608696, -0.075
34462, 0.15217391304348, 0.8804347826087, -0.075
34463, 0.08695652173913, 0.85434782608696, -0.075
34464, 0.10869565217391, 0.8804347826087, -0.075
34465, 0.043478260869565, 0.85434782608696, -0.075
34466, 0.065217391304348, 0.8804347826087, -0.075
34467, 0.021739130434783, 0.8804347826087, -0.075
34468, 0.95652173913043, 0.90652173913043, -0.075
34469, 0.97826086956522, 0.93260869565217, -0.075
34470, 0.91304347826087, 0.90652173913043, -0.075
34471, 0.93478260869565, 0.93260869565217, -0.075
34472, 0.8695652173913, 0.90652173913043, -0.075
34473, 0.89130434782609, 0.93260869565217, -0.075
34474, 0.82608695652174, 0.90652173913043, -0.075
34475, 0.84782608695652, 0.93260869565217, -0.075
34476, 0.78260869565217, 0.90652173913043, -0.075
34477, 0.80434782608696, 0.93260869565217, -0.075
34478, 0.73913043478261, 0.90652173913043, -0.075
34479, 0.76086956521739, 0.93260869565217, -0.075
34480, 0.69565217391304, 0.90652173913043, -0.075
34481, 0.71739130434783, 0.93260869565217, -0.075
34482, 0.65217391304348, 0.90652173913043, -0.075
34483, 0.67391304347826, 0.93260869565217, -0.075
34484, 0.60869565217391, 0.90652173913043, -0.075
34485, 0.6304347826087, 0.93260869565217, -0.075
34486, 0.56521739130435, 0.90652173913043, -0.075
34487, 0.58695652173913, 0.93260869565217, -0.075
34488, 0.52173913043478, 0.90652173913043, -0.075
34489, 0.54347826086957, 0.93260869565217, -0.075
34490, 0.47826086956522, 0.90652173913043, -0.075
34491, 0.5, 0.93260869565217, -0.075
34492, 0.43478260869565, 0.90652173913043, -0.075
34493, 0.45652173913043, 0.93260869565217, -0.075
34494, 0.39130434782609, 0.90652173913043, -0.075
34495, 0.41304347826087, 0.93260869565217, -0.075
34496, 0.34782608695652, 0.90652173913043, -0.075
34497, 0.3695652173913, 0.93260869565217, -0.075
34498, 0.30434782608696, 0.90652173913043, -0.075
34499, 0.32608695652174, 0.93260869565217, -0.075
34500, 0.26086956521739, 0.90652173913043, -0.075
34501, 0.28260869565217, 0.93260869565217, -0.075
34502, 0.21739130434783, 0.90652173913043, -0.075
34503, 0.23913043478261, 0.93260869565217, -0.075
34504, 0.17391304347826, 0.90652173913043, -0.075
34505, 0.19565217391304, 0.93260869565217, -0.075
34506, 0.1304347826087, 0.90652173913043, -0.075
34507, 0.15217391304348, 0.93260869565217, -0.075
34508, 0.08695652173913, 0.90652173913043, -0.075
34509, 0.10869565217391, 0.93260869565217, -0.075
34510, 0.043478260869565, 0.90652173913043, -0.075
34511, 0.065217391304348, 0.93260869565217, -0.075
34512, 0.021739130434783, 0.93260869565217, -0.075
34513, 0.95652173913043, 0.95869565217391, -0.075
34514, 0.97826086956522, 0.98478260869565, -0.075
34515, 0.91304347826087, 0.95869565217391, -0.075
34516, 0.93478260869565, 0.98478260869565, -0.075
34517, 0.8695652173913, 0.95869565217391, -0.075
34518, 0.89130434782609, 0.98478260869565, -0.075
34519, 0.82608695652174, 0.95869565217391, -0.075
34520, 0.84782608695652, 0.98478260869565, -0.075
34521, 0.78260869565217, 0.95869565217391, -0.075
34522, 0.80434782608696, 0.98478260869565, -0.075
34523, 0.73913043478261, 0.95869565217391, -0.075
34524, 0.76086956521739, 0.98478260869565, -0.075
34525, 0.69565217391304, 0.95869565217391, -0.075
34526, 0.71739130434783, 0.98478260869565, -0.075
34527, 0.65217391304348, 0.95869565217391, -0.075
34528, 0.67391304347826, 0.98478260869565, -0.075
34529, 0.60869565217391, 0.95869565217391, -0.075
34530, 0.6304347826087, 0.98478260869565, -0.075
34531, 0.56521739130435, 0.95869565217391, -0.075
34532, 0.58695652173913, 0.98478260869565, -0.075
34533, 0.52173913043478, 0.95869565217391, -0.075
34534, 0.54347826086957, 0.98478260869565, -0.075
34535, 0.47826086956522, 0.95869565217391, -0.075
34536, 0.5, 0.98478260869565, -0.075
34537, 0.43478260869565, 0.95869565217391, -0.075
34538, 0.45652173913043, 0.98478260869565, -0.075
34539, 0.39130434782609, 0.95869565217391, -0.075
34540, 0.41304347826087, 0.98478260869565, -0.075
34541, 0.34782608695652, 0.95869565217391, -0.075
34542, 0.3695652173913, 0.98478260869565, -0.075
34543, 0.30434782608696, 0.95869565217391, -0.075
34544, 0.32608695652174, 0.98478260869565, -0.075
34545, 0.26086956521739, 0.95869565217391, -0.075
34546, 0.28260869565217, 0.98478260869565, -0.075
34547, 0.21739130434783, 0.95869565217391, -0.075
34548, 0.23913043478261, 0.98478260869565, -0.075
34549, 0.17391304347826, 0.95869565217391, -0.075
34550, 0.19565217391304, 0.98478260869565, -0.075
34551, 0.1304347826087, 0.95869565217391, -0.075
34552, 0.15217391304348, 0.98478260869565, -0.075
34553, 0.08695652173913, 0.95869565217391, -0.075
34554, 0.10869565217391, 0.98478260869565, -0.075
34555, 0.043478260869565, 0.95869565217391, -0.075
34556, 0.065217391304348, 0.98478260869565, -0.075
34557, 0.021739130434783, 0.98478260869565, -0.075
34558, 0.95652173913043, 1.0108695652174, -0.075
34559, 0.97826086956522, 1.0369565217391, -0.075
34560, 0.91304347826087, 1.0108695652174, -0.075
34561, 0.93478260869565, 1.0369565217391, -0.075
34562, 0.8695652173913, 1.0108695652174, -0.075
34563, 0.89130434782609, 1.0369565217391, -0.075
34564, 0.82608695652174, 1.0108695652174, -0.075
34565, 0.84782608695652, 1.0369565217391, -0.075
34566, 0.78260869565217, 1.0108695652174, -0.075
34567, 0.80434782608696, 1.0369565217391, -0.075
34568, 0.73913043478261, 1.0108695652174, -0.075
34569, 0.76086956521739, 1.0369565217391, -0.075
34570, 0.69565217391304, 1.0108695652174, -0.075
34571, 0.71739130434783, 1.0369565217391, -0.075
34572, 0.65217391304348, 1.0108695652174, -0.075
34573, 0.67391304347826, 1.0369565217391, -0.075
34574, 0.60869565217391, 1.0108695652174, -0.075
34575, 0.6304347826087, 1.0369565217391, -0.075
34576, 0.56521739130435, 1.0108695652174, -0.075
34577, 0.58695652173913, 1.0369565217391, -0.075
34578, 0.52173913043478, 1.0108695652174, -0.075
34579, 0.54347826086957, 1.0369565217391, -0.075
34580, 0.47826086956522, 1.0108695652174, -0.075
34581, 0.5, 1.0369565217391, -0.075
34582, 0.43478260869565, 1.0108695652174, -0.075
34583, 0.45652173913043, 1.0369565217391, -0.075
34584, 0.39130434782609, 1.0108695652174, -0.075
34585, 0.41304347826087, 1.0369565217391, -0.075
34586, 0.34782608695652, 1.0108695652174, -0.075
34587, 0.3695652173913, 1.0369565217391, -0.075
34588, 0.30434782608696, 1.0108695652174, -0.075
34589, 0.32608695652174, 1.0369565217391, -0.075
34590, 0.26086956521739, 1.0108695652174, -0.075
34591, 0.28260869565217, 1.0369565217391, -0.075
34592, 0.21739130434783, 1.0108695652174, -0.075
34593, 0.23913043478261, 1.0369565217391, -0.075
34594, 0.17391304347826, 1.0108695652174, -0.075
34595, 0.19565217391304, 1.0369565217391, -0.075
34596, 0.1304347826087, 1.0108695652174, -0.075
34597, 0.15217391304348, 1.0369565217391, -0.075
34598, 0.08695652173913, 1.0108695652174, -0.075
34599, 0.10869565217391, 1.0369565217391, -0.075
34600, 0.043478260869565, 1.0108695652174, -0.075
34601, 0.065217391304348, 1.0369565217391, -0.075
34602, 0.021739130434783, 1.0369565217391, -0.075
34603, 0.95652173913043, 1.0630434782609, -0.075
34604, 0.97826086956522, 1.0891304347826, -0.075
34605, 0.91304347826087, 1.0630434782609, -0.075
34606, 0.93478260869565, 1.0891304347826, -0.075
34607, 0.8695652173913, 1.0630434782609, -0.075
34608, 0.89130434782609, 1.0891304347826, -0.075
34609, 0.82608695652174, 1.0630434782609, -0.075
34610, 0.84782608695652, 1.0891304347826, -0.075
34611, 0.78260869565217, 1.0630434782609, -0.075
34612, 0.80434782608696, 1.0891304347826, -0.075
34613, 0.73913043478261, 1.0630434782609, -0.075
34614, 0.76086956521739, 1.0891304347826, -0.075
34615, 0.69565217391304, 1.0630434782609, -0.075
34616, 0.71739130434783, 1.0891304347826, -0.075
34617, 0.65217391304348, 1.0630434782609, -0.075
34618, 0.67391304347826, 1.0891304347826, -0.075
34619, 0.60869565217391, 1.0630434782609, -0.075
34620, 0.6304347826087, 1.0891304347826, -0.075
34621, 0.56521739130435, 1.0630434782609, -0.075
34622, 0.58695652173913, 1.0891304347826, -0.075
34623, 0.52173913043478, 1.0630434782609, -0.075
34624, 0.54347826086957, 1.0891304347826, -0.075
34625, 0.47826086956522, 1.0630434782609, -0.075
34626, 0.5, 1.0891304347826, -0.075
34627, 0.43478260869565, 1.0630434782609, -0.075
34628, 0.45652173913043, 1.0891304347826, -0.075
34629, 0.39130434782609, 1.0630434782609, -0.075
34630, 0.41304347826087, 1.0891304347826, -0.075
34631, 0.34782608695652, 1.0630434782609, -0.075
34632, 0.3695652173913, 1.0891304347826, -0.075
34633, 0.30434782608696, 1.0630434782609, -0.075
34634, 0.32608695652174, 1.0891304347826, -0.075
34635, 0.26086956521739, 1.0630434782609, -0.075
34636, 0.28260869565217, 1.0891304347826, -0.075
34637, 0.21739130434783, 1.0630434782609, -0.075
34638, 0.23913043478261, 1.0891304347826, -0.075
34639, 0.17391304347826, 1.0630434782609, -0.075
34640, 0.19565217391304, 1.0891304347826, -0.075
34641, 0.1304347826087, 1.0630434782609, -0.075
34642, 0.15217391304348, 1.0891304347826, -0.075
34643, 0.08695652173913, 1.0630434782609, -0.075
34644, 0.10869565217391, 1.0891304347826, -0.075
34645, 0.043478260869565, 1.0630434782609, -0.075
34646, 0.065217391304348, 1.0891304347826, -0.075
34647, 0.021739130434783, 1.0891304347826, -0.075
34648, 0.95652173913043, 1.1152173913043, -0.075
34649, 0.97826086956522, 1.1413043478261, -0.075
34650, 0.91304347826087, 1.1152173913043, -0.075
34651, 0.93478260869565, 1.1413043478261, -0.075
34652, 0.8695652173913, 1.1152173913043, -0.075
34653, 0.89130434782609, 1.1413043478261, -0.075
34654, 0.82608695652174, 1.1152173913043, -0.075
34655, 0.84782608695652, 1.1413043478261, -0.075
34656, 0.78260869565217, 1.1152173913043, -0.075
34657, 0.80434782608696, 1.1413043478261, -0.075
34658, 0.73913043478261, 1.1152173913043, -0.075
34659, 0.76086956521739, 1.1413043478261, -0.075
34660, 0.69565217391304, 1.1152173913043, -0.075
34661, 0.71739130434783, 1.1413043478261, -0.075
34662, 0.65217391304348, 1.1152173913043, -0.075
34663, 0.67391304347826, 1.1413043478261, -0.075
34664, 0.60869565217391, 1.1152173913043, -0.075
34665, 0.6304347826087, 1.1413043478261, -0.075
34666, 0.56521739130435, 1.1152173913043, -0.075
34667, 0.58695652173913, 1.1413043478261, -0.075
34668, 0.52173913043478, 1.1152173913043, -0.075
34669, 0.54347826086957, 1.1413043478261, -0.075
34670, 0.47826086956522, 1.1152173913043, -0.075
34671, 0.5, 1.1413043478261, -0.075
34672, 0.43478260869565, 1.1152173913043, -0.075
34673, 0.45652173913043, 1.1413043478261, -0.075
34674, 0.39130434782609, 1.1152173913043, -0.075
34675, 0.41304347826087, 1.1413043478261, -0.075
34676, 0.34782608695652, 1.1152173913043, -0.075
34677, 0.3695652173913, 1.1413043478261, -0.075
34678, 0.30434782608696, 1.1152173913043, -0.075
34679, 0.32608695652174, 1.1413043478261, -0.075
34680, 0.26086956521739, 1.1152173913043, -0.075
34681, 0.28260869565217, 1.1413043478261, -0.075
34682, 0.21739130434783, 1.1152173913043, -0.075
34683, 0.23913043478261, 1.1413043478261, -0.075
34684, 0.17391304347826, 1.1152173913043, -0.075
34685, 0.19565217391304, 1.1413043478261, -0.075
34686, 0.1304347826087, 1.1152173913043, -0.075
34687, 0.15217391304348, 1.1413043478261, -0.075
34688, 0.08695652173913, 1.1152173913043, -0.075
34689, 0.10869565217391, 1.1413043478261, -0.075
34690, 0.043478260869565, 1.1152173913043, -0.075
34691, 0.065217391304348, 1.1413043478261, -0.075
34692, 0.021739130434783, 1.1413043478261, -0.075
34693, 0.95652173913043, 1.1673913043478, -0.075
34694, 0.97826086956522, 1.1934782608696, -0.075
34695, 0.91304347826087, 1.1673913043478, -0.075
34696, 0.93478260869565, 1.1934782608696, -0.075
34697, 0.8695652173913, 1.1673913043478, -0.075
34698, 0.89130434782609, 1.1934782608696, -0.075
34699, 0.82608695652174, 1.1673913043478, -0.075
34700, 0.84782608695652, 1.1934782608696, -0.075
34701, 0.78260869565217, 1.1673913043478, -0.075
34702, 0.80434782608696, 1.1934782608696, -0.075
34703, 0.73913043478261, 1.1673913043478, -0.075
34704, 0.76086956521739, 1.1934782608696, -0.075
34705, 0.69565217391304, 1.1673913043478, -0.075
34706, 0.71739130434783, 1.1934782608696, -0.075
34707, 0.65217391304348, 1.1673913043478, -0.075
34708, 0.67391304347826, 1.1934782608696, -0.075
34709, 0.60869565217391, 1.1673913043478, -0.075
34710, 0.6304347826087, 1.1934782608696, -0.075
34711, 0.56521739130435, 1.1673913043478, -0.075
34712, 0.58695652173913, 1.1934782608696, -0.075
34713, 0.52173913043478, 1.1673913043478, -0.075
34714, 0.54347826086957, 1.1934782608696, -0.075
34715, 0.47826086956522, 1.1673913043478, -0.075
34716, 0.5, 1.1934782608696, -0.075
34717, 0.43478260869565, 1.1673913043478, -0.075
34718, 0.45652173913043, 1.1934782608696, -0.075
34719, 0.39130434782609, 1.1673913043478, -0.075
34720, 0.41304347826087, 1.1934782608696, -0.075
34721, 0.34782608695652, 1.1673913043478, -0.075
34722, 0.3695652173913, 1.1934782608696, -0.075
34723, 0.30434782608696, 1.1673913043478, -0.075
34724, 0.32608695652174, 1.1934782608696, -0.075
34725, 0.26086956521739, 1.1673913043478, -0.075
34726, 0.28260869565217, 1.1934782608696, -0.075
34727, 0.21739130434783, 1.1673913043478, -0.075
34728, 0.23913043478261, 1.1934782608696, -0.075
34729, 0.17391304347826, 1.1673913043478, -0.075
34730, 0.19565217391304, 1.1934782608696, -0.075
34731, 0.1304347826087, 1.1673913043478, -0.075
34732, 0.15217391304348, 1.1934782608696, -0.075
34733, 0.08695652173913, 1.1673913043478, -0.075
34734, 0.10869565217391, 1.1934782608696, -0.075
34735, 0.043478260869565, 1.1673913043478, -0.075
34736, 0.065217391304348, 1.1934782608696, -0.075
34737, 0.021739130434783, 1.1934782608696, -0.075
34738, 0.95652173913043, 1.2195652173913, -0.075
34739, 0.97826086956522, 1.245652173913, -0.075
34740, 0.91304347826087, 1.2195652173913, -0.075
34741, 0.93478260869565, 1.245652173913, -0.075
34742, 0.8695652173913, 1.2195652173913, -0.075
34743, 0.89130434782609, 1.245652173913, -0.075
34744, 0.82608695652174, 1.2195652173913, -0.075
34745, 0.84782608695652, 1.245652173913, -0.075
34746, 0.78260869565217, 1.2195652173913, -0.075
34747, 0.80434782608696, 1.245652173913, -0.075
34748, 0.73913043478261, 1.2195652173913, -0.075
34749, 0.76086956521739, 1.245652173913, -0.075
34750, 0.69565217391304, 1.2195652173913, -0.075
34751, 0.71739130434783, 1.245652173913, -0.075
34752, 0.65217391304348, 1.2195652173913, -0.075
34753, 0.67391304347826, 1.245652173913, -0.075
34754, 0.60869565217391, 1.2195652173913, -0.075
34755, 0.6304347826087, 1.245652173913, -0.075
34756, 0.56521739130435, 1.2195652173913, -0.075
34757, 0.58695652173913, 1.245652173913, -0.075
34758, 0.52173913043478, 1.2195652173913, -0.075
34759, 0.54347826086957, 1.245652173913, -0.075
34760, 0.47826086956522, 1.2195652173913, -0.075
34761, 0.5, 1.245652173913, -0.075
34762, 0.43478260869565, 1.2195652173913, -0.075
34763, 0.45652173913043, 1.245652173913, -0.075
34764, 0.39130434782609, 1.2195652173913, -0.075
34765, 0.41304347826087, 1.245652173913, -0.075
34766, 0.34782608695652, 1.2195652173913, -0.075
34767, 0.3695652173913, 1.245652173913, -0.075
34768, 0.30434782608696, 1.2195652173913, -0.075
34769, 0.32608695652174, 1.245652173913, -0.075
34770, 0.26086956521739, 1.2195652173913, -0.075
34771, 0.28260869565217, 1.245652173913, -0.075
34772, 0.21739130434783, 1.2195652173913, -0.075
34773, 0.23913043478261, 1.245652173913, -0.075
34774, 0.17391304347826, 1.2195652173913, -0.075
34775, 0.19565217391304, 1.245652173913, -0.075
34776, 0.1304347826087, 1.2195652173913, -0.075
34777, 0.15217391304348, 1.245652173913, -0.075
34778, 0.08695652173913, 1.2195652173913, -0.075
34779, 0.10869565217391, 1.245652173913, -0.075
34780, 0.043478260869565, 1.2195652173913, -0.075
34781, 0.065217391304348, 1.245652173913, -0.075
34782, 0.021739130434783, 1.245652173913, -0.075
34783, 0.95652173913043, 1.2717391304348, -0.075
34784, 0.97826086956522, 1.2978260869565, -0.075
34785, 0.91304347826087, 1.2717391304348, -0.075
34786, 0.93478260869565, 1.2978260869565, -0.075
34787, 0.8695652173913, 1.2717391304348, -0.075
34788, 0.89130434782609, 1.2978260869565, -0.075
34789, 0.82608695652174, 1.2717391304348, -0.075
34790, 0.84782608695652, 1.2978260869565, -0.075
34791, 0.78260869565217, 1.2717391304348, -0.075
34792, 0.80434782608696, 1.2978260869565, -0.075
34793, 0.73913043478261, 1.2717391304348, -0.075
34794, 0.76086956521739, 1.2978260869565, -0.075
34795, 0.69565217391304, 1.2717391304348, -0.075
34796, 0.71739130434783, 1.2978260869565, -0.075
34797, 0.65217391304348, 1.2717391304348, -0.075
34798, 0.67391304347826, 1.2978260869565, -0.075
34799, 0.60869565217391, 1.2717391304348, -0.075
34800, 0.6304347826087, 1.2978260869565, -0.075
34801, 0.56521739130435, 1.2717391304348, -0.075
34802, 0.58695652173913, 1.2978260869565, -0.075
34803, 0.52173913043478, 1.2717391304348, -0.075
34804, 0.54347826086957, 1.2978260869565, -0.075
34805, 0.47826086956522, 1.2717391304348, -0.075
34806, 0.5, 1.2978260869565, -0.075
34807, 0.43478260869565, 1.2717391304348, -0.075
34808, 0.45652173913043, 1.2978260869565, -0.075
34809, 0.39130434782609, 1.2717391304348, -0.075
34810, 0.41304347826087, 1.2978260869565, -0.075
34811, 0.34782608695652, 1.2717391304348, -0.075
34812, 0.3695652173913, 1.2978260869565, -0.075
34813, 0.30434782608696, 1.2717391304348, -0.075
34814, 0.32608695652174, 1.2978260869565, -0.075
34815, 0.26086956521739, 1.2717391304348, -0.075
34816, 0.28260869565217, 1.2978260869565, -0.075
34817, 0.21739130434783, 1.2717391304348, -0.075
34818, 0.23913043478261, 1.2978260869565, -0.075
34819, 0.17391304347826, 1.2717391304348, -0.075
34820, 0.19565217391304, 1.2978260869565, -0.075
34821, 0.1304347826087, 1.2717391304348, -0.075
34822, 0.15217391304348, 1.2978260869565, -0.075
34823, 0.08695652173913, 1.2717391304348, -0.075
34824, 0.10869565217391, 1.2978260869565, -0.075
34825, 0.043478260869565, 1.2717391304348, -0.075
34826, 0.065217391304348, 1.2978260869565, -0.075
34827, 0.021739130434783, 1.2978260869565, -0.075
34828, 0.95652173913043, 1.3239130434783, -0.075
34829, 0.91304347826087, 1.3239130434783, -0.075
34830, 0.8695652173913, 1.3239130434783, -0.075
34831, 0.82608695652174, 1.3239130434783, -0.075
34832, 0.78260869565217, 1.3239130434783, -0.075
34833, 0.73913043478261, 1.3239130434783, -0.075
34834, 0.69565217391304, 1.3239130434783, -0.075
34835, 0.65217391304348, 1.3239130434783, -0.075
34836, 0.60869565217391, 1.3239130434783, -0.075
34837, 0.56521739130435, 1.3239130434783, -0.075
34838, 0.52173913043478, 1.3239130434783, -0.075
34839, 0.47826086956522, 1.3239130434783, -0.075
34840, 0.43478260869565, 1.3239130434783, -0.075
34841, 0.39130434782609, 1.3239130434783, -0.075
34842, 0.34782608695652, 1.3239130434783, -0.075
34843, 0.30434782608696, 1.3239130434783, -0.075
34844, 0.26086956521739, 1.3239130434783, -0.075
34845, 0.21739130434783, 1.3239130434783, -0.075
34846, 0.17391304347826, 1.3239130434783, -0.075
34847, 0.1304347826087, 1.3239130434783, -0.075
34848, 0.08695652173913, 1.3239130434783, -0.075
34849, 0.043478260869565, 1.3239130434783, -0.075
34850, 1.0375, 0.15, -0.0375
34851, 1.01875, 0.15, -0.0375
34852, 1.0375, 0.15, -0.01875
34853, 1.05625, 0.15, -0.0375
34854, 1.0375, 0.15, -0.05625
34855, 1.0375, 1.35, -0.0375
34856, 1.0375, 1.35, -0.01875
34857, 1.01875, 1.35, -0.0375
34858, 1.05625, 1.35, -0.0375
34859, 1.0375, 1.35, -0.05625
34860, 1.075, 0.20217391304348, -0.0375
34861, 1.075, 0.25434782608696, -0.0375
34862, 1.075, 0.30652173913043, -0.0375
34863, 1.075, 0.35869565217391, -0.0375
34864, 1.075, 0.41086956521739, -0.0375
34865, 1.075, 0.46304347826087, -0.0375
34866, 1.075, 0.51521739130435, -0.0375
34867, 1.075, 0.56739130434783, -0.0375
34868, 1.075, 0.6195652173913, -0.0375
34869, 1.075, 0.67173913043478, -0.0375
34870, 1.075, 0.72391304347826, -0.0375
34871, 1.075, 0.77608695652174, -0.0375
34872, 1.075, 0.82826086956522, -0.0375
34873, 1.075, 0.8804347826087, -0.0375
34874, 1.075, 0.93260869565217, -0.0375
34875, 1.075, 0.98478260869565, -0.0375
34876, 1.075, 1.0369565217391, -0.0375
34877, 1.075, 1.0891304347826, -0.0375
34878, 1.075, 1.1413043478261, -0.0375
34879, 1.075, 1.1934782608696, -0.0375
34880, 1.075, 1.245652173913, -0.0375
34881, 1.075, 1.2978260869565, -0.0375
34882, 1.075, 0.17608695652174, -0.0375
34883, 1.075, 0.20217391304348, -0.01875
34884, 1.075, 0.22826086956522, -0.0375
34885, 1.075, 0.25434782608696, -0.01875
34886, 1.075, 0.2804347826087, -0.0375
34887, 1.075, 0.30652173913043, -0.01875
34888, 1.075, 0.33260869565217, -0.0375
34889, 1.075, 0.35869565217391, -0.01875
34890, 1.075, 0.38478260869565, -0.0375
34891, 1.075, 0.41086956521739, -0.01875
34892, 1.075, 0.43695652173913, -0.0375
34893, 1.075, 0.46304347826087, -0.01875
34894, 1.075, 0.48913043478261, -0.0375
34895, 1.075, 0.51521739130435, -0.01875
34896, 1.075, 0.54130434782609, -0.0375
34897, 1.075, 0.56739130434783, -0.01875
34898, 1.075, 0.59347826086956, -0.0375
34899, 1.075, 0.6195652173913, -0.01875
34900, 1.075, 0.64565217391304, -0.0375
34901, 1.075, 0.67173913043478, -0.01875
34902, 1.075, 0.69782608695652, -0.0375
34903, 1.075, 0.72391304347826, -0.01875
34904, 1.075, 0.75, -0.0375
34905, 1.075, 0.77608695652174, -0.01875
34906, 1.075, 0.80217391304348, -0.0375
34907, 1.075, 0.82826086956522, -0.01875
34908, 1.075, 0.85434782608696, -0.0375
34909, 1.075, 0.8804347826087, -0.01875
34910, 1.075, 0.90652173913043, -0.0375
34911, 1.075, 0.93260869565217, -0.01875
34912, 1.075, 0.95869565217391, -0.0375
34913, 1.075, 0.98478260869565, -0.01875
34914, 1.075, 1.0108695652174, -0.0375
34915, 1.075, 1.0369565217391, -0.01875
34916, 1.075, 1.0630434782609, -0.0375
34917, 1.075, 1.0891304347826, -0.01875
34918, 1.075, 1.1152173913043, -0.0375
34919, 1.075, 1.1413043478261, -0.01875
34920, 1.075, 1.1673913043478, -0.0375
34921, 1.075, 1.1934782608696, -0.01875
34922, 1.075, 1.2195652173913, -0.0375
34923, 1.075, 1.245652173913, -0.01875
34924, 1.075, 1.2717391304348, -0.0375
34925, 1.075, 1.2978260869565, -0.01875
34926, 1.075, 1.3239130434783, -0.0375
34927, 1.075, 0.20217391304348, -0.05625
34928, 1.075, 0.25434782608696, -0.05625
34929, 1.075, 0.30652173913043, -0.05625
34930, 1.075, 0.35869565217391, -0.05625
34931, 1.075, 0.41086956521739, -0.05625
34932, 1.075, 0.46304347826087, -0.05625
34933, 1.075, 0.51521739130435, -0.05625
34934, 1.075, 0.56739130434783, -0.05625
34935, 1.075, 0.6195652173913, -0.05625
34936, 1.075, 0.67173913043478, -0.05625
34937, 1.075, 0.72391304347826, -0.05625
34938, 1.075, 0.77608695652174, -0.05625
34939, 1.075, 0.82826086956522, -0.05625
34940, 1.075, 0.8804347826087, -0.05625
34941, 1.075, 0.93260869565217, -0.05625
34942, 1.075, 0.98478260869565, -0.05625
34943, 1.075, 1.0369565217391, -0.05625
34944, 1.075, 1.0891304347826, -0.05625
34945, 1.075, 1.1413043478261, -0.05625
34946, 1.075, 1.1934782608696, -0.05625
34947, 1.075, 1.245652173913, -0.05625
34948, 1.075, 1.2978260869565, -0.05625
34949, 1.0375, 0.20217391304348, -0.075
34950, 1.0375, 0.25434782608696, -0.075
34951, 1.0375, 0.30652173913043, -0.075
34952, 1.0375, 0.35869565217391, -0.075
34953, 1.0375, 0.41086956521739, -0.075
34954, 1.0375, 0.46304347826087, -0.075
34955, 1.0375, 0.51521739130435, -0.075
34956, 1.0375, 0.56739130434783, -0.075
34957, 1.0375, 0.6195652173913, -0.075
34958, 1.0375, 0.67173913043478, -0.075
34959, 1.0375, 0.72391304347826, -0.075
34960, 1.0375, 0.77608695652174, -0.075
34961, 1.0375, 0.82826086956522, -0.075
34962, 1.0375, 0.88043478260869, -0.075
34963, 1.0375, 0.93260869565217, -0.075
34964, 1.0375, 0.98478260869565, -0.075
34965, 1.0375, 1.0369565217391, -0.075
34966, 1.0375, 1.0891304347826, -0.075
34967, 1.0375, 1.1413043478261, -0.075
34968, 1.0375, 1.1934782608696, -0.075
34969, 1.0375, 1.245652173913, -0.075
34970, 1.0375, 1.2978260869565, -0.075
34971, 1.01875, 0.20217391304348, -0.075
34972, 1.0375, 0.17608695652174, -0.075
34973, 1.01875, 0.25434782608696, -0.075
34974, 1.0375, 0.22826086956522, -0.075
34975, 1.01875, 0.30652173913043, -0.075
34976, 1.0375, 0.2804347826087, -0.075
34977, 1.01875, 0.35869565217391, -0.075
34978, 1.0375, 0.33260869565217, -0.075
34979, 1.01875, 0.41086956521739, -0.075
34980, 1.0375, 0.38478260869565, -0.075
34981, 1.01875, 0.46304347826087, -0.075
34982, 1.0375, 0.43695652173913, -0.075
34983, 1.01875, 0.51521739130435, -0.075
34984, 1.0375, 0.48913043478261, -0.075
34985, 1.01875, 0.56739130434783, -0.075
34986, 1.0375, 0.54130434782609, -0.075
34987, 1.01875, 0.6195652173913, -0.075
34988, 1.0375, 0.59347826086956, -0.075
34989, 1.01875, 0.67173913043478, -0.075
34990, 1.0375, 0.64565217391304, -0.075
34991, 1.01875, 0.72391304347826, -0.075
34992, 1.0375, 0.69782608695652, -0.075
34993, 1.01875, 0.77608695652174, -0.075
34994, 1.0375, 0.75, -0.075
34995, 1.01875, 0.82826086956522, -0.075
34996, 1.0375, 0.80217391304348, -0.075
34997, 1.01875, 0.88043478260869, -0.075
34998, 1.0375, 0.85434782608696, -0.075
34999, 1.01875, 0.93260869565217, -0.075
35000, 1.0375, 0.90652173913043, -0.075
35001, 1.01875, 0.98478260869565, -0.075
35002, 1.0375, 0.95869565217391, -0.075
35003, 1.01875, 1.0369565217391, -0.075
35004, 1.0375, 1.0108695652174, -0.075
35005, 1.01875, 1.0891304347826, -0.075
35006, 1.0375, 1.0630434782609, -0.075
35007, 1.01875, 1.1413043478261, -0.075
35008, 1.0375, 1.1152173913043, -0.075
35009, 1.01875, 1.1934782608696, -0.075
35010, 1.0375, 1.1673913043478, -0.075
35011, 1.01875, 1.245652173913, -0.075
35012, 1.0375, 1.2195652173913, -0.075
35013, 1.01875, 1.2978260869565, -0.075
35014, 1.0375, 1.2717391304348, -0.075
35015, 1.0375, 1.3239130434783, -0.075
35016, 1.05625, 0.20217391304348, -0.075
35017, 1.05625, 0.25434782608696, -0.075
35018, 1.05625, 0.30652173913043, -0.075
35019, 1.05625, 0.35869565217391, -0.075
35020, 1.05625, 0.41086956521739, -0.075
35021, 1.05625, 0.46304347826087, -0.075
35022, 1.05625, 0.51521739130435, -0.075
35023, 1.05625, 0.56739130434783, -0.075
35024, 1.05625, 0.6195652173913, -0.075
35025, 1.05625, 0.67173913043478, -0.075
35026, 1.05625, 0.72391304347826, -0.075
35027, 1.05625, 0.77608695652174, -0.075
35028, 1.05625, 0.82826086956522, -0.075
35029, 1.05625, 0.88043478260869, -0.075
35030, 1.05625, 0.93260869565217, -0.075
35031, 1.05625, 0.98478260869565, -0.075
35032, 1.05625, 1.0369565217391, -0.075
35033, 1.05625, 1.0891304347826, -0.075
35034, 1.05625, 1.1413043478261, -0.075
35035, 1.05625, 1.1934782608696, -0.075
35036, 1.05625, 1.245652173913, -0.075
35037, 1.05625, 1.2978260869565, -0.075
35038, 1.1625, 1.35, -0.0375
35039, 1.18125, 1.35, -0.0375
35040, 1.1625, 1.35, -0.01875
35041, 1.14375, 1.35, -0.0375
35042, 1.1625, 1.35, -0.05625
35043, 1.1625, 0.15, -0.0375
35044, 1.1625, 0.15, -0.01875
35045, 1.18125, 0.15, -0.0375
35046, 1.14375, 0.15, -0.0375
35047, 1.1625, 0.15, -0.05625
35048, 1.2, 1.2978260869565, -0.0375
35049, 1.2, 1.245652173913, -0.0375
35050, 1.2, 1.1934782608696, -0.0375
35051, 1.2, 1.1413043478261, -0.0375
35052, 1.2, 1.0891304347826, -0.0375
35053, 1.2, 1.0369565217391, -0.0375
35054, 1.2, 0.98478260869565, -0.0375
35055, 1.2, 0.93260869565217, -0.0375
35056, 1.2, 0.8804347826087, -0.0375
35057, 1.2, 0.82826086956522, -0.0375
35058, 1.2, 0.77608695652174, -0.0375
35059, 1.2, 0.72391304347826, -0.0375
35060, 1.2, 0.67173913043478, -0.0375
35061, 1.2, 0.6195652173913, -0.0375
35062, 1.2, 0.56739130434783, -0.0375
35063, 1.2, 0.51521739130435, -0.0375
35064, 1.2, 0.46304347826087, -0.0375
35065, 1.2, 0.41086956521739, -0.0375
35066, 1.2, 0.35869565217391, -0.0375
35067, 1.2, 0.30652173913044, -0.0375
35068, 1.2, 0.25434782608696, -0.0375
35069, 1.2, 0.20217391304348, -0.0375
35070, 1.2, 1.2978260869565, -0.01875
35071, 1.2, 1.3239130434783, -0.0375
35072, 1.2, 1.245652173913, -0.01875
35073, 1.2, 1.2717391304348, -0.0375
35074, 1.2, 1.1934782608696, -0.01875
35075, 1.2, 1.2195652173913, -0.0375
35076, 1.2, 1.1413043478261, -0.01875
35077, 1.2, 1.1673913043478, -0.0375
35078, 1.2, 1.0891304347826, -0.01875
35079, 1.2, 1.1152173913043, -0.0375
35080, 1.2, 1.0369565217391, -0.01875
35081, 1.2, 1.0630434782609, -0.0375
35082, 1.2, 0.98478260869565, -0.01875
35083, 1.2, 1.0108695652174, -0.0375
35084, 1.2, 0.93260869565217, -0.01875
35085, 1.2, 0.95869565217391, -0.0375
35086, 1.2, 0.8804347826087, -0.01875
35087, 1.2, 0.90652173913044, -0.0375
35088, 1.2, 0.82826086956522, -0.01875
35089, 1.2, 0.85434782608696, -0.0375
35090, 1.2, 0.77608695652174, -0.01875
35091, 1.2, 0.80217391304348, -0.0375
35092, 1.2, 0.72391304347826, -0.01875
35093, 1.2, 0.75, -0.0375
35094, 1.2, 0.67173913043478, -0.01875
35095, 1.2, 0.69782608695652, -0.0375
35096, 1.2, 0.61956521739131, -0.01875
35097, 1.2, 0.64565217391304, -0.0375
35098, 1.2, 0.56739130434783, -0.01875
35099, 1.2, 0.59347826086957, -0.0375
35100, 1.2, 0.51521739130435, -0.01875
35101, 1.2, 0.54130434782609, -0.0375
35102, 1.2, 0.46304347826087, -0.01875
35103, 1.2, 0.48913043478261, -0.0375
35104, 1.2, 0.41086956521739, -0.01875
35105, 1.2, 0.43695652173913, -0.0375
35106, 1.2, 0.35869565217391, -0.01875
35107, 1.2, 0.38478260869565, -0.0375
35108, 1.2, 0.30652173913044, -0.01875
35109, 1.2, 0.33260869565217, -0.0375
35110, 1.2, 0.25434782608696, -0.01875
35111, 1.2, 0.2804347826087, -0.0375
35112, 1.2, 0.20217391304348, -0.01875
35113, 1.2, 0.22826086956522, -0.0375
35114, 1.2, 0.17608695652174, -0.0375
35115, 1.2, 1.2978260869565, -0.05625
35116, 1.2, 1.245652173913, -0.05625
35117, 1.2, 1.1934782608696, -0.05625
35118, 1.2, 1.1413043478261, -0.05625
35119, 1.2, 1.0891304347826, -0.05625
35120, 1.2, 1.0369565217391, -0.05625
35121, 1.2, 0.98478260869565, -0.05625
35122, 1.2, 0.93260869565217, -0.05625
35123, 1.2, 0.8804347826087, -0.05625
35124, 1.2, 0.82826086956522, -0.05625
35125, 1.2, 0.77608695652174, -0.05625
35126, 1.2, 0.72391304347826, -0.05625
35127, 1.2, 0.67173913043478, -0.05625
35128, 1.2, 0.61956521739131, -0.05625
35129, 1.2, 0.56739130434783, -0.05625
35130, 1.2, 0.51521739130435, -0.05625
35131, 1.2, 0.46304347826087, -0.05625
35132, 1.2, 0.41086956521739, -0.05625
35133, 1.2, 0.35869565217391, -0.05625
35134, 1.2, 0.30652173913044, -0.05625
35135, 1.2, 0.25434782608696, -0.05625
35136, 1.2, 0.20217391304348, -0.05625
35137, 1.125, 1.2978260869565, -0.0375
35138, 1.125, 1.245652173913, -0.0375
35139, 1.125, 1.1934782608696, -0.0375
35140, 1.125, 1.1413043478261, -0.0375
35141, 1.125, 1.0891304347826, -0.0375
35142, 1.125, 1.0369565217391, -0.0375
35143, 1.125, 0.98478260869565, -0.0375
35144, 1.125, 0.93260869565217, -0.0375
35145, 1.125, 0.8804347826087, -0.0375
35146, 1.125, 0.82826086956522, -0.0375
35147, 1.125, 0.77608695652174, -0.0375
35148, 1.125, 0.72391304347826, -0.0375
35149, 1.125, 0.67173913043478, -0.0375
35150, 1.125, 0.6195652173913, -0.0375
35151, 1.125, 0.56739130434783, -0.0375
35152, 1.125, 0.51521739130435, -0.0375
35153, 1.125, 0.46304347826087, -0.0375
35154, 1.125, 0.41086956521739, -0.0375
35155, 1.125, 0.35869565217391, -0.0375
35156, 1.125, 0.30652173913044, -0.0375
35157, 1.125, 0.25434782608696, -0.0375
35158, 1.125, 0.20217391304348, -0.0375
35159, 1.125, 1.3239130434783, -0.0375
35160, 1.125, 1.2978260869565, -0.01875
35161, 1.125, 1.2717391304348, -0.0375
35162, 1.125, 1.245652173913, -0.01875
35163, 1.125, 1.2195652173913, -0.0375
35164, 1.125, 1.1934782608696, -0.01875
35165, 1.125, 1.1673913043478, -0.0375
35166, 1.125, 1.1413043478261, -0.01875
35167, 1.125, 1.1152173913043, -0.0375
35168, 1.125, 1.0891304347826, -0.01875
35169, 1.125, 1.0630434782609, -0.0375
35170, 1.125, 1.0369565217391, -0.01875
35171, 1.125, 1.0108695652174, -0.0375
35172, 1.125, 0.98478260869565, -0.01875
35173, 1.125, 0.95869565217391, -0.0375
35174, 1.125, 0.93260869565217, -0.01875
35175, 1.125, 0.90652173913044, -0.0375
35176, 1.125, 0.8804347826087, -0.01875
35177, 1.125, 0.85434782608696, -0.0375
35178, 1.125, 0.82826086956522, -0.01875
35179, 1.125, 0.80217391304348, -0.0375
35180, 1.125, 0.77608695652174, -0.01875
35181, 1.125, 0.75, -0.0375
35182, 1.125, 0.72391304347826, -0.01875
35183, 1.125, 0.69782608695652, -0.0375
35184, 1.125, 0.67173913043478, -0.01875
35185, 1.125, 0.64565217391304, -0.0375
35186, 1.125, 0.61956521739131, -0.01875
35187, 1.125, 0.59347826086957, -0.0375
35188, 1.125, 0.56739130434783, -0.01875
35189, 1.125, 0.54130434782609, -0.0375
35190, 1.125, 0.51521739130435, -0.01875
35191, 1.125, 0.48913043478261, -0.0375
35192, 1.125, 0.46304347826087, -0.01875
35193, 1.125, 0.43695652173913, -0.0375
35194, 1.125, 0.41086956521739, -0.01875
35195, 1.125, 0.38478260869565, -0.0375
35196, 1.125, 0.35869565217391, -0.01875
35197, 1.125, 0.33260869565217, -0.0375
35198, 1.125, 0.30652173913044, -0.01875
35199, 1.125, 0.2804347826087, -0.0375
35200, 1.125, 0.25434782608696, -0.01875
35201, 1.125, 0.22826086956522, -0.0375
35202, 1.125, 0.20217391304348, -0.01875
35203, 1.125, 0.17608695652174, -0.0375
35204, 1.125, 1.2978260869565, -0.05625
35205, 1.125, 1.245652173913, -0.05625
35206, 1.125, 1.1934782608696, -0.05625
35207, 1.125, 1.1413043478261, -0.05625
35208, 1.125, 1.0891304347826, -0.05625
35209, 1.125, 1.0369565217391, -0.05625
35210, 1.125, 0.98478260869565, -0.05625
35211, 1.125, 0.93260869565217, -0.05625
35212, 1.125, 0.8804347826087, -0.05625
35213, 1.125, 0.82826086956522, -0.05625
35214, 1.125, 0.77608695652174, -0.05625
35215, 1.125, 0.72391304347826, -0.05625
35216, 1.125, 0.67173913043478, -0.05625
35217, 1.125, 0.61956521739131, -0.05625
35218, 1.125, 0.56739130434783, -0.05625
35219, 1.125, 0.51521739130435, -0.05625
35220, 1.125, 0.46304347826087, -0.05625
35221, 1.125, 0.41086956521739, -0.05625
35222, 1.125, 0.35869565217391, -0.05625
35223, 1.125, 0.30652173913044, -0.05625
35224, 1.125, 0.25434782608696, -0.05625
35225, 1.125, 0.20217391304348, -0.05625
35226, 1.1625, 1.2978260869565, -0.075
35227, 1.1625, 1.245652173913, -0.075
35228, 1.1625, 1.1934782608696, -0.075
35229, 1.1625, 1.1413043478261, -0.075
35230, 1.1625, 1.0891304347826, -0.075
35231, 1.1625, 1.0369565217391, -0.075
35232, 1.1625, 0.98478260869565, -0.075
35233, 1.1625, 0.93260869565217, -0.075
35234, 1.1625, 0.8804347826087, -0.075
35235, 1.1625, 0.82826086956522, -0.075
35236, 1.1625, 0.77608695652174, -0.075
35237, 1.1625, 0.72391304347826, -0.075
35238, 1.1625, 0.67173913043478, -0.075
35239, 1.1625, 0.61956521739131, -0.075
35240, 1.1625, 0.56739130434783, -0.075
35241, 1.1625, 0.51521739130435, -0.075
35242, 1.1625, 0.46304347826087, -0.075
35243, 1.1625, 0.41086956521739, -0.075
35244, 1.1625, 0.35869565217391, -0.075
35245, 1.1625, 0.30652173913044, -0.075
35246, 1.1625, 0.25434782608696, -0.075
35247, 1.1625, 0.20217391304348, -0.075
35248, 1.18125, 1.2978260869565, -0.075
35249, 1.1625, 1.3239130434783, -0.075
35250, 1.18125, 1.245652173913, -0.075
35251, 1.1625, 1.2717391304348, -0.075
35252, 1.18125, 1.1934782608696, -0.075
35253, 1.1625, 1.2195652173913, -0.075
35254, 1.18125, 1.1413043478261, -0.075
35255, 1.1625, 1.1673913043478, -0.075
35256, 1.18125, 1.0891304347826, -0.075
35257, 1.1625, 1.1152173913043, -0.075
35258, 1.18125, 1.0369565217391, -0.075
35259, 1.1625, 1.0630434782609, -0.075
35260, 1.18125, 0.98478260869565, -0.075
35261, 1.1625, 1.0108695652174, -0.075
35262, 1.18125, 0.93260869565217, -0.075
35263, 1.1625, 0.95869565217391, -0.075
35264, 1.18125, 0.8804347826087, -0.075
35265, 1.1625, 0.90652173913044, -0.075
35266, 1.18125, 0.82826086956522, -0.075
35267, 1.1625, 0.85434782608696, -0.075
35268, 1.18125, 0.77608695652174, -0.075
35269, 1.1625, 0.80217391304348, -0.075
35270, 1.18125, 0.72391304347826, -0.075
35271, 1.1625, 0.75, -0.075
35272, 1.18125, 0.67173913043478, -0.075
35273, 1.1625, 0.69782608695652, -0.075
35274, 1.18125, 0.61956521739131, -0.075
35275, 1.1625, 0.64565217391304, -0.075
35276, 1.18125, 0.56739130434783, -0.075
35277, 1.1625, 0.59347826086957, -0.075
35278, 1.18125, 0.51521739130435, -0.075
35279, 1.1625, 0.54130434782609, -0.075
35280, 1.18125, 0.46304347826087, -0.075
35281, 1.1625, 0.48913043478261, -0.075
35282, 1.18125, 0.41086956521739, -0.075
35283, 1.1625, 0.43695652173913, -0.075
35284, 1.18125, 0.35869565217391, -0.075
35285, 1.1625, 0.38478260869565, -0.075
35286, 1.18125, 0.30652173913044, -0.075
35287, 1.1625, 0.33260869565217, -0.075
35288, 1.18125, 0.25434782608696, -0.075
35289, 1.1625, 0.2804347826087, -0.075
35290, 1.18125, 0.20217391304348, -0.075
35291, 1.1625, 0.22826086956522, -0.075
35292, 1.1625, 0.17608695652174, -0.075
35293, 1.14375, 1.2978260869565, -0.075
35294, 1.14375, 1.245652173913, -0.075
35295, 1.14375, 1.1934782608696, -0.075
35296, 1.14375, 1.1413043478261, -0.075
35297, 1.14375, 1.0891304347826, -0.075
35298, 1.14375, 1.0369565217391, -0.075
35299, 1.14375, 0.98478260869565, -0.075
35300, 1.14375, 0.93260869565217, -0.075
35301, 1.14375, 0.8804347826087, -0.075
35302, 1.14375, 0.82826086956522, -0.075
35303, 1.14375, 0.77608695652174, -0.075
35304, 1.14375, 0.72391304347826, -0.075
35305, 1.14375, 0.67173913043478, -0.075
35306, 1.14375, 0.61956521739131, -0.075
35307, 1.14375, 0.56739130434783, -0.075
35308, 1.14375, 0.51521739130435, -0.075
35309, 1.14375, 0.46304347826087, -0.075
35310, 1.14375, 0.41086956521739, -0.075
35311, 1.14375, 0.35869565217391, -0.075
35312, 1.14375, 0.30652173913044, -0.075
35313, 1.14375, 0.25434782608696, -0.075
35314, 1.14375, 0.20217391304348, -0.075
35315, 2.2, 1.2978260869565, -0.0375
35316, 2.2, 1.245652173913, -0.0375
35317, 2.2, 1.1934782608696, -0.0375
35318, 2.2, 1.1413043478261, -0.0375
35319, 2.2, 1.0891304347826, -0.0375
35320, 2.2, 1.0369565217391, -0.0375
35321, 2.2, 0.98478260869565, -0.0375
35322, 2.2, 0.93260869565217, -0.0375
35323, 2.2, 0.8804347826087, -0.0375
35324, 2.2, 0.82826086956522, -0.0375
35325, 2.2, 0.77608695652174, -0.0375
35326, 2.2, 0.72391304347826, -0.0375
35327, 2.2, 0.67173913043478, -0.0375
35328, 2.2, 0.6195652173913, -0.0375
35329, 2.2, 0.56739130434783, -0.0375
35330, 2.2, 0.51521739130435, -0.0375
35331, 2.2, 0.46304347826087, -0.0375
35332, 2.2, 0.41086956521739, -0.0375
35333, 2.2, 0.35869565217391, -0.0375
35334, 2.2, 0.30652173913044, -0.0375
35335, 2.2, 0.25434782608696, -0.0375
35336, 2.2, 0.20217391304348, -0.0375
35337, 2.2, 1.2978260869565, -0.01875
35338, 2.2, 1.3239130434783, -0.0375
35339, 2.2, 1.245652173913, -0.01875
35340, 2.2, 1.2717391304348, -0.0375
35341, 2.2, 1.1934782608696, -0.01875
35342, 2.2, 1.2195652173913, -0.0375
35343, 2.2, 1.1413043478261, -0.01875
35344, 2.2, 1.1673913043478, -0.0375
35345, 2.2, 1.0891304347826, -0.01875
35346, 2.2, 1.1152173913043, -0.0375
35347, 2.2, 1.0369565217391, -0.01875
35348, 2.2, 1.0630434782609, -0.0375
35349, 2.2, 0.98478260869565, -0.01875
35350, 2.2, 1.0108695652174, -0.0375
35351, 2.2, 0.93260869565217, -0.01875
35352, 2.2, 0.95869565217391, -0.0375
35353, 2.2, 0.8804347826087, -0.01875
35354, 2.2, 0.90652173913044, -0.0375
35355, 2.2, 0.82826086956522, -0.01875
35356, 2.2, 0.85434782608696, -0.0375
35357, 2.2, 0.77608695652174, -0.01875
35358, 2.2, 0.80217391304348, -0.0375
35359, 2.2, 0.72391304347826, -0.01875
35360, 2.2, 0.75, -0.0375
35361, 2.2, 0.67173913043478, -0.01875
35362, 2.2, 0.69782608695652, -0.0375
35363, 2.2, 0.61956521739131, -0.01875
35364, 2.2, 0.64565217391304, -0.0375
35365, 2.2, 0.56739130434783, -0.01875
35366, 2.2, 0.59347826086957, -0.0375
35367, 2.2, 0.51521739130435, -0.01875
35368, 2.2, 0.54130434782609, -0.0375
35369, 2.2, 0.46304347826087, -0.01875
35370, 2.2, 0.48913043478261, -0.0375
35371, 2.2, 0.41086956521739, -0.01875
35372, 2.2, 0.43695652173913, -0.0375
35373, 2.2, 0.35869565217391, -0.01875
35374, 2.2, 0.38478260869565, -0.0375
35375, 2.2, 0.30652173913044, -0.01875
35376, 2.2, 0.33260869565217, -0.0375
35377, 2.2, 0.25434782608696, -0.01875
35378, 2.2, 0.2804347826087, -0.0375
35379, 2.2, 0.20217391304348, -0.01875
35380, 2.2, 0.22826086956522, -0.0375
35381, 2.2, 0.17608695652174, -0.0375
35382, 2.2, 1.2978260869565, -0.05625
35383, 2.2, 1.245652173913, -0.05625
35384, 2.2, 1.1934782608696, -0.05625
35385, 2.2, 1.1413043478261, -0.05625
35386, 2.2, 1.0891304347826, -0.05625
35387, 2.2, 1.0369565217391, -0.05625
35388, 2.2, 0.98478260869565, -0.05625
35389, 2.2, 0.93260869565217, -0.05625
35390, 2.2, 0.8804347826087, -0.05625
35391, 2.2, 0.82826086956522, -0.05625
35392, 2.2, 0.77608695652174, -0.05625
35393, 2.2, 0.72391304347826, -0.05625
35394, 2.2, 0.67173913043478, -0.05625
35395, 2.2, 0.61956521739131, -0.05625
35396, 2.2, 0.56739130434783, -0.05625
35397, 2.2, 0.51521739130435, -0.05625
35398, 2.2, 0.46304347826087, -0.05625
35399, 2.2, 0.41086956521739, -0.05625
35400, 2.2, 0.35869565217391, -0.05625
35401, 2.2, 0.30652173913044, -0.05625
35402, 2.2, 0.25434782608696, -0.05625
35403, 2.2, 0.20217391304348, -0.05625
35404, 1.2434782608696, 1.35, -0.0375
35405, 1.2869565217391, 1.35, -0.0375
35406, 1.3304347826087, 1.35, -0.0375
35407, 1.3739130434783, 1.35, -0.0375
35408, 1.4173913043478, 1.35, -0.0375
35409, 1.4608695652174, 1.35, -0.0375
35410, 1.504347826087, 1.35, -0.0375
35411, 1.5478260869565, 1.35, -0.0375
35412, 1.5913043478261, 1.35, -0.0375
35413, 1.6347826086957, 1.35, -0.0375
35414, 1.6782608695652, 1.35, -0.0375
35415, 1.7217391304348, 1.35, -0.0375
35416, 1.7652173913043, 1.35, -0.0375
35417, 1.8086956521739, 1.35, -0.0375
35418, 1.8521739130435, 1.35, -0.0375
35419, 1.895652173913, 1.35, -0.0375
35420, 1.9391304347826, 1.35, -0.0375
35421, 1.9826086956522, 1.35, -0.0375
35422, 2.0260869565217, 1.35, -0.0375
35423, 2.0695652173913, 1.35, -0.0375
35424, 2.1130434782609, 1.35, -0.0375
35425, 2.1565217391304, 1.35, -0.0375
35426, 1.2434782608696, 1.35, -0.01875
35427, 1.2217391304348, 1.35, -0.0375
35428, 1.2869565217391, 1.35, -0.01875
35429, 1.2652173913043, 1.35, -0.0375
35430, 1.3304347826087, 1.35, -0.01875
35431, 1.3086956521739, 1.35, -0.0375
35432, 1.3739130434783, 1.35, -0.01875
35433, 1.3521739130435, 1.35, -0.0375
35434, 1.4173913043478, 1.35, -0.01875
35435, 1.395652173913, 1.35, -0.0375
35436, 1.4608695652174, 1.35, -0.01875
35437, 1.4391304347826, 1.35, -0.0375
35438, 1.504347826087, 1.35, -0.01875
35439, 1.4826086956522, 1.35, -0.0375
35440, 1.5478260869565, 1.35, -0.01875
35441, 1.5260869565217, 1.35, -0.0375
35442, 1.5913043478261, 1.35, -0.01875
35443, 1.5695652173913, 1.35, -0.0375
35444, 1.6347826086957, 1.35, -0.01875
35445, 1.6130434782609, 1.35, -0.0375
35446, 1.6782608695652, 1.35, -0.01875
35447, 1.6565217391304, 1.35, -0.0375
35448, 1.7217391304348, 1.35, -0.01875
35449, 1.7, 1.35, -0.0375
35450, 1.7652173913043, 1.35, -0.01875
35451, 1.7434782608696, 1.35, -0.0375
35452, 1.8086956521739, 1.35, -0.01875
35453, 1.7869565217391, 1.35, -0.0375
35454, 1.8521739130435, 1.35, -0.01875
35455, 1.8304347826087, 1.35, -0.0375
35456, 1.895652173913, 1.35, -0.01875
35457, 1.8739130434783, 1.35, -0.0375
35458, 1.9391304347826, 1.35, -0.01875
35459, 1.9173913043478, 1.35, -0.0375
35460, 1.9826086956522, 1.35, -0.01875
35461, 1.9608695652174, 1.35, -0.0375
35462, 2.0260869565217, 1.35, -0.01875
35463, 2.004347826087, 1.35, -0.0375
35464, 2.0695652173913, 1.35, -0.01875
35465, 2.0478260869565, 1.35, -0.0375
35466, 2.1130434782609, 1.35, -0.01875
35467, 2.0913043478261, 1.35, -0.0375
35468, 2.1565217391304, 1.35, -0.01875
35469, 2.1347826086957, 1.35, -0.0375
35470, 2.1782608695652, 1.35, -0.0375
35471, 1.2434782608696, 1.35, -0.05625
35472, 1.2869565217391, 1.35, -0.05625
35473, 1.3304347826087, 1.35, -0.05625
35474, 1.3739130434783, 1.35, -0.05625
35475, 1.4173913043478, 1.35, -0.05625
35476, 1.4608695652174, 1.35, -0.05625
35477, 1.504347826087, 1.35, -0.05625
35478, 1.5478260869565, 1.35, -0.05625
35479, 1.5913043478261, 1.35, -0.05625
35480, 1.6347826086957, 1.35, -0.05625
35481, 1.6782608695652, 1.35, -0.05625
35482, 1.7217391304348, 1.35, -0.05625
35483, 1.7652173913043, 1.35, -0.05625
35484, 1.8086956521739, 1.35, -0.05625
35485, 1.8521739130435, 1.35, -0.05625
35486, 1.895652173913, 1.35, -0.05625
35487, 1.9391304347826, 1.35, -0.05625
35488, 1.9826086956522, 1.35, -0.05625
35489, 2.0260869565217, 1.35, -0.05625
35490, 2.0695652173913, 1.35, -0.05625
35491, 2.1130434782609, 1.35, -0.05625
35492, 2.1565217391304, 1.35, -0.05625
35493, 1.2434782608696, 0.15, -0.0375
35494, 1.2869565217391, 0.15, -0.0375
35495, 1.3304347826087, 0.15, -0.0375
35496, 1.3739130434783, 0.15, -0.0375
35497, 1.4173913043478, 0.15, -0.0375
35498, 1.4608695652174, 0.15, -0.0375
35499, 1.504347826087, 0.15, -0.0375
35500, 1.5478260869565, 0.15, -0.0375
35501, 1.5913043478261, 0.15, -0.0375
35502, 1.6347826086957, 0.15, -0.0375
35503, 1.6782608695652, 0.15, -0.0375
35504, 1.7217391304348, 0.15, -0.0375
35505, 1.7652173913043, 0.15, -0.0375
35506, 1.8086956521739, 0.15, -0.0375
35507, 1.8521739130435, 0.15, -0.0375
35508, 1.895652173913, 0.15, -0.0375
35509, 1.9391304347826, 0.15, -0.0375
35510, 1.9826086956522, 0.15, -0.0375
35511, 2.0260869565217, 0.15, -0.0375
35512, 2.0695652173913, 0.15, -0.0375
35513, 2.1130434782609, 0.15, -0.0375
35514, 2.1565217391304, 0.15, -0.0375
35515, 1.2217391304348, 0.15, -0.0375
35516, 1.2434782608696, 0.15, -0.01875
35517, 1.2652173913043, 0.15, -0.0375
35518, 1.2869565217391, 0.15, -0.01875
35519, 1.3086956521739, 0.15, -0.0375
35520, 1.3304347826087, 0.15, -0.01875
35521, 1.3521739130435, 0.15, -0.0375
35522, 1.3739130434783, 0.15, -0.01875
35523, 1.395652173913, 0.15, -0.0375
35524, 1.4173913043478, 0.15, -0.01875
35525, 1.4391304347826, 0.15, -0.0375
35526, 1.4608695652174, 0.15, -0.01875
35527, 1.4826086956522, 0.15, -0.0375
35528, 1.504347826087, 0.15, -0.01875
35529, 1.5260869565217, 0.15, -0.0375
35530, 1.5478260869565, 0.15, -0.01875
35531, 1.5695652173913, 0.15, -0.0375
35532, 1.5913043478261, 0.15, -0.01875
35533, 1.6130434782609, 0.15, -0.0375
35534, 1.6347826086957, 0.15, -0.01875
35535, 1.6565217391304, 0.15, -0.0375
35536, 1.6782608695652, 0.15, -0.01875
35537, 1.7, 0.15, -0.0375
35538, 1.7217391304348, 0.15, -0.01875
35539, 1.7434782608696, 0.15, -0.0375
35540, 1.7652173913043, 0.15, -0.01875
35541, 1.7869565217391, 0.15, -0.0375
35542, 1.8086956521739, 0.15, -0.01875
35543, 1.8304347826087, 0.15, -0.0375
35544, 1.8521739130435, 0.15, -0.01875
35545, 1.8739130434783, 0.15, -0.0375
35546, 1.895652173913, 0.15, -0.01875
35547, 1.9173913043478, 0.15, -0.0375
35548, 1.9391304347826, 0.15, -0.01875
35549, 1.9608695652174, 0.15, -0.0375
35550, 1.9826086956522, 0.15, -0.01875
35551, 2.004347826087, 0.15, -0.0375
35552, 2.0260869565217, 0.15, -0.01875
35553, 2.0478260869565, 0.15, -0.0375
35554, 2.0695652173913, 0.15, -0.01875
35555, 2.0913043478261, 0.15, -0.0375
35556, 2.1130434782609, 0.15, -0.01875
35557, 2.1347826086957, 0.15, -0.0375
35558, 2.1565217391304, 0.15, -0.01875
35559, 2.1782608695652, 0.15, -0.0375
35560, 1.2434782608696, 0.15, -0.05625
35561, 1.2869565217391, 0.15, -0.05625
35562, 1.3304347826087, 0.15, -0.05625
35563, 1.3739130434783, 0.15, -0.05625
35564, 1.4173913043478, 0.15, -0.05625
35565, 1.4608695652174, 0.15, -0.05625
35566, 1.504347826087, 0.15, -0.05625
35567, 1.5478260869565, 0.15, -0.05625
35568, 1.5913043478261, 0.15, -0.05625
35569, 1.6347826086957, 0.15, -0.05625
35570, 1.6782608695652, 0.15, -0.05625
35571, 1.7217391304348, 0.15, -0.05625
35572, 1.7652173913043, 0.15, -0.05625
35573, 1.8086956521739, 0.15, -0.05625
35574, 1.8521739130435, 0.15, -0.05625
35575, 1.895652173913, 0.15, -0.05625
35576, 1.9391304347826, 0.15, -0.05625
35577, 1.9826086956522, 0.15, -0.05625
35578, 2.0260869565217, 0.15, -0.05625
35579, 2.0695652173913, 0.15, -0.05625
35580, 2.1130434782609, 0.15, -0.05625
35581, 2.1565217391304, 0.15, -0.05625
35582, 1.2434782608696, 1.2978260869565, -0.075
35583, 1.2869565217391, 1.2978260869565, -0.075
35584, 1.3304347826087, 1.2978260869565, -0.075
35585, 1.3739130434783, 1.2978260869565, -0.075
35586, 1.4173913043478, 1.2978260869565, -0.075
35587, 1.4608695652174, 1.2978260869565, -0.075
35588, 1.504347826087, 1.2978260869565, -0.075
35589, 1.5478260869565, 1.2978260869565, -0.075
35590, 1.5913043478261, 1.2978260869565, -0.075
35591, 1.6347826086957, 1.2978260869565, -0.075
35592, 1.6782608695652, 1.2978260869565, -0.075
35593, 1.7217391304348, 1.2978260869565, -0.075
35594, 1.7652173913043, 1.2978260869565, -0.075
35595, 1.8086956521739, 1.2978260869565, -0.075
35596, 1.8521739130435, 1.2978260869565, -0.075
35597, 1.895652173913, 1.2978260869565, -0.075
35598, 1.9391304347826, 1.2978260869565, -0.075
35599, 1.9826086956522, 1.2978260869565, -0.075
35600, 2.0260869565217, 1.2978260869565, -0.075
35601, 2.0695652173913, 1.2978260869565, -0.075
35602, 2.1130434782609, 1.2978260869565, -0.075
35603, 2.1565217391304, 1.2978260869565, -0.075
35604, 1.2434782608696, 1.245652173913, -0.075
35605, 1.2869565217391, 1.245652173913, -0.075
35606, 1.3304347826087, 1.245652173913, -0.075
35607, 1.3739130434783, 1.245652173913, -0.075
35608, 1.4173913043478, 1.245652173913, -0.075
35609, 1.4608695652174, 1.245652173913, -0.075
35610, 1.504347826087, 1.245652173913, -0.075
35611, 1.5478260869565, 1.245652173913, -0.075
35612, 1.5913043478261, 1.245652173913, -0.075
35613, 1.6347826086957, 1.245652173913, -0.075
35614, 1.6782608695652, 1.245652173913, -0.075
35615, 1.7217391304348, 1.245652173913, -0.075
35616, 1.7652173913043, 1.245652173913, -0.075
35617, 1.8086956521739, 1.245652173913, -0.075
35618, 1.8521739130435, 1.245652173913, -0.075
35619, 1.895652173913, 1.245652173913, -0.075
35620, 1.9391304347826, 1.245652173913, -0.075
35621, 1.9826086956522, 1.245652173913, -0.075
35622, 2.0260869565217, 1.245652173913, -0.075
35623, 2.0695652173913, 1.245652173913, -0.075
35624, 2.1130434782609, 1.245652173913, -0.075
35625, 2.1565217391304, 1.245652173913, -0.075
35626, 1.2434782608696, 1.1934782608696, -0.075
35627, 1.2869565217391, 1.1934782608696, -0.075
35628, 1.3304347826087, 1.1934782608696, -0.075
35629, 1.3739130434783, 1.1934782608696, -0.075
35630, 1.4173913043478, 1.1934782608696, -0.075
35631, 1.4608695652174, 1.1934782608696, -0.075
35632, 1.504347826087, 1.1934782608696, -0.075
35633, 1.5478260869565, 1.1934782608696, -0.075
35634, 1.5913043478261, 1.1934782608696, -0.075
35635, 1.6347826086957, 1.1934782608696, -0.075
35636, 1.6782608695652, 1.1934782608696, -0.075
35637, 1.7217391304348, 1.1934782608696, -0.075
35638, 1.7652173913043, 1.1934782608696, -0.075
35639, 1.8086956521739, 1.1934782608696, -0.075
35640, 1.8521739130435, 1.1934782608696, -0.075
35641, 1.895652173913, 1.1934782608696, -0.075
35642, 1.9391304347826, 1.1934782608696, -0.075
35643, 1.9826086956522, 1.1934782608696, -0.075
35644, 2.0260869565217, 1.1934782608696, -0.075
35645, 2.0695652173913, 1.1934782608696, -0.075
35646, 2.1130434782609, 1.1934782608696, -0.075
35647, 2.1565217391304, 1.1934782608696, -0.075
35648, 1.2434782608696, 1.1413043478261, -0.075
35649, 1.2869565217391, 1.1413043478261, -0.075
35650, 1.3304347826087, 1.1413043478261, -0.075
35651, 1.3739130434783, 1.1413043478261, -0.075
35652, 1.4173913043478, 1.1413043478261, -0.075
35653, 1.4608695652174, 1.1413043478261, -0.075
35654, 1.504347826087, 1.1413043478261, -0.075
35655, 1.5478260869565, 1.1413043478261, -0.075
35656, 1.5913043478261, 1.1413043478261, -0.075
35657, 1.6347826086957, 1.1413043478261, -0.075
35658, 1.6782608695652, 1.1413043478261, -0.075
35659, 1.7217391304348, 1.1413043478261, -0.075
35660, 1.7652173913043, 1.1413043478261, -0.075
35661, 1.8086956521739, 1.1413043478261, -0.075
35662, 1.8521739130435, 1.1413043478261, -0.075
35663, 1.895652173913, 1.1413043478261, -0.075
35664, 1.9391304347826, 1.1413043478261, -0.075
35665, 1.9826086956522, 1.1413043478261, -0.075
35666, 2.0260869565217, 1.1413043478261, -0.075
35667, 2.0695652173913, 1.1413043478261, -0.075
35668, 2.1130434782609, 1.1413043478261, -0.075
35669, 2.1565217391304, 1.1413043478261, -0.075
35670, 1.2434782608696, 1.0891304347826, -0.075
35671, 1.2869565217391, 1.0891304347826, -0.075
35672, 1.3304347826087, 1.0891304347826, -0.075
35673, 1.3739130434783, 1.0891304347826, -0.075
35674, 1.4173913043478, 1.0891304347826, -0.075
35675, 1.4608695652174, 1.0891304347826, -0.075
35676, 1.504347826087, 1.0891304347826, -0.075
35677, 1.5478260869565, 1.0891304347826, -0.075
35678, 1.5913043478261, 1.0891304347826, -0.075
35679, 1.6347826086957, 1.0891304347826, -0.075
35680, 1.6782608695652, 1.0891304347826, -0.075
35681, 1.7217391304348, 1.0891304347826, -0.075
35682, 1.7652173913043, 1.0891304347826, -0.075
35683, 1.8086956521739, 1.0891304347826, -0.075
35684, 1.8521739130435, 1.0891304347826, -0.075
35685, 1.895652173913, 1.0891304347826, -0.075
35686, 1.9391304347826, 1.0891304347826, -0.075
35687, 1.9826086956522, 1.0891304347826, -0.075
35688, 2.0260869565217, 1.0891304347826, -0.075
35689, 2.0695652173913, 1.0891304347826, -0.075
35690, 2.1130434782609, 1.0891304347826, -0.075
35691, 2.1565217391304, 1.0891304347826, -0.075
35692, 1.2434782608696, 1.0369565217391, -0.075
35693, 1.2869565217391, 1.0369565217391, -0.075
35694, 1.3304347826087, 1.0369565217391, -0.075
35695, 1.3739130434783, 1.0369565217391, -0.075
35696, 1.4173913043478, 1.0369565217391, -0.075
35697, 1.4608695652174, 1.0369565217391, -0.075
35698, 1.504347826087, 1.0369565217391, -0.075
35699, 1.5478260869565, 1.0369565217391, -0.075
35700, 1.5913043478261, 1.0369565217391, -0.075
35701, 1.6347826086957, 1.0369565217391, -0.075
35702, 1.6782608695652, 1.0369565217391, -0.075
35703, 1.7217391304348, 1.0369565217391, -0.075
35704, 1.7652173913043, 1.0369565217391, -0.075
35705, 1.8086956521739, 1.0369565217391, -0.075
35706, 1.8521739130435, 1.0369565217391, -0.075
35707, 1.895652173913, 1.0369565217391, -0.075
35708, 1.9391304347826, 1.0369565217391, -0.075
35709, 1.9826086956522, 1.0369565217391, -0.075
35710, 2.0260869565217, 1.0369565217391, -0.075
35711, 2.0695652173913, 1.0369565217391, -0.075
35712, 2.1130434782609, 1.0369565217391, -0.075
35713, 2.1565217391304, 1.0369565217391, -0.075
35714, 1.2434782608696, 0.98478260869565, -0.075
35715, 1.2869565217391, 0.98478260869565, -0.075
35716, 1.3304347826087, 0.98478260869565, -0.075
35717, 1.3739130434783, 0.98478260869565, -0.075
35718, 1.4173913043478, 0.98478260869565, -0.075
35719, 1.4608695652174, 0.98478260869565, -0.075
35720, 1.504347826087, 0.98478260869565, -0.075
35721, 1.5478260869565, 0.98478260869565, -0.075
35722, 1.5913043478261, 0.98478260869565, -0.075
35723, 1.6347826086957, 0.98478260869565, -0.075
35724, 1.6782608695652, 0.98478260869565, -0.075
35725, 1.7217391304348, 0.98478260869565, -0.075
35726, 1.7652173913043, 0.98478260869565, -0.075
35727, 1.8086956521739, 0.98478260869565, -0.075
35728, 1.8521739130435, 0.98478260869565, -0.075
35729, 1.895652173913, 0.98478260869565, -0.075
35730, 1.9391304347826, 0.98478260869565, -0.075
35731, 1.9826086956522, 0.98478260869565, -0.075
35732, 2.0260869565217, 0.98478260869565, -0.075
35733, 2.0695652173913, 0.98478260869565, -0.075
35734, 2.1130434782609, 0.98478260869565, -0.075
35735, 2.1565217391304, 0.98478260869565, -0.075
35736, 1.2434782608696, 0.93260869565217, -0.075
35737, 1.2869565217391, 0.93260869565217, -0.075
35738, 1.3304347826087, 0.93260869565217, -0.075
35739, 1.3739130434783, 0.93260869565217, -0.075
35740, 1.4173913043478, 0.93260869565217, -0.075
35741, 1.4608695652174, 0.93260869565217, -0.075
35742, 1.504347826087, 0.93260869565217, -0.075
35743, 1.5478260869565, 0.93260869565217, -0.075
35744, 1.5913043478261, 0.93260869565217, -0.075
35745, 1.6347826086957, 0.93260869565217, -0.075
35746, 1.6782608695652, 0.93260869565217, -0.075
35747, 1.7217391304348, 0.93260869565217, -0.075
35748, 1.7652173913043, 0.93260869565217, -0.075
35749, 1.8086956521739, 0.93260869565217, -0.075
35750, 1.8521739130435, 0.93260869565217, -0.075
35751, 1.895652173913, 0.93260869565217, -0.075
35752, 1.9391304347826, 0.93260869565217, -0.075
35753, 1.9826086956522, 0.93260869565217, -0.075
35754, 2.0260869565217, 0.93260869565217, -0.075
35755, 2.0695652173913, 0.93260869565217, -0.075
35756, 2.1130434782609, 0.93260869565217, -0.075
35757, 2.1565217391304, 0.93260869565217, -0.075
35758, 1.2434782608696, 0.8804347826087, -0.075
35759, 1.2869565217391, 0.8804347826087, -0.075
35760, 1.3304347826087, 0.8804347826087, -0.075
35761, 1.3739130434783, 0.8804347826087, -0.075
35762, 1.4173913043478, 0.8804347826087, -0.075
35763, 1.4608695652174, 0.8804347826087, -0.075
35764, 1.504347826087, 0.8804347826087, -0.075
35765, 1.5478260869565, 0.8804347826087, -0.075
35766, 1.5913043478261, 0.8804347826087, -0.075
35767, 1.6347826086957, 0.8804347826087, -0.075
35768, 1.6782608695652, 0.8804347826087, -0.075
35769, 1.7217391304348, 0.8804347826087, -0.075
35770, 1.7652173913043, 0.8804347826087, -0.075
35771, 1.8086956521739, 0.8804347826087, -0.075
