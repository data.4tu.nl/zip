28842, 2.2, 0.85434782608696, 0.11111111111111
28843, 2.2, 0.82826086956522, 0.083333333333333
28844, 2.2, 0.85434782608696, 0.055555555555556
28845, 2.2, 0.82826086956522, 0.027777777777778
28846, 2.2, 0.77608695652174, 0.47222222222222
28847, 2.2, 0.80217391304348, 0.44444444444444
28848, 2.2, 0.77608695652174, 0.41666666666667
28849, 2.2, 0.80217391304348, 0.38888888888889
28850, 2.2, 0.77608695652174, 0.36111111111111
28851, 2.2, 0.80217391304348, 0.33333333333333
28852, 2.2, 0.77608695652174, 0.30555555555556
28853, 2.2, 0.80217391304348, 0.27777777777778
28854, 2.2, 0.77608695652174, 0.25
28855, 2.2, 0.80217391304348, 0.22222222222222
28856, 2.2, 0.77608695652174, 0.19444444444444
28857, 2.2, 0.80217391304348, 0.16666666666667
28858, 2.2, 0.77608695652174, 0.13888888888889
28859, 2.2, 0.80217391304348, 0.11111111111111
28860, 2.2, 0.77608695652174, 0.083333333333333
28861, 2.2, 0.80217391304348, 0.055555555555556
28862, 2.2, 0.77608695652174, 0.027777777777778
28863, 2.2, 0.72391304347826, 0.47222222222222
28864, 2.2, 0.75, 0.44444444444444
28865, 2.2, 0.72391304347826, 0.41666666666667
28866, 2.2, 0.75, 0.38888888888889
28867, 2.2, 0.72391304347826, 0.36111111111111
28868, 2.2, 0.75, 0.33333333333333
28869, 2.2, 0.72391304347826, 0.30555555555556
28870, 2.2, 0.75, 0.27777777777778
28871, 2.2, 0.72391304347826, 0.25
28872, 2.2, 0.75, 0.22222222222222
28873, 2.2, 0.72391304347826, 0.19444444444444
28874, 2.2, 0.75, 0.16666666666667
28875, 2.2, 0.72391304347826, 0.13888888888889
28876, 2.2, 0.75, 0.11111111111111
28877, 2.2, 0.72391304347826, 0.083333333333333
28878, 2.2, 0.75, 0.055555555555556
28879, 2.2, 0.72391304347826, 0.027777777777778
28880, 2.2, 0.67173913043478, 0.47222222222222
28881, 2.2, 0.69782608695652, 0.44444444444444
28882, 2.2, 0.67173913043478, 0.41666666666667
28883, 2.2, 0.69782608695652, 0.38888888888889
28884, 2.2, 0.67173913043478, 0.36111111111111
28885, 2.2, 0.69782608695652, 0.33333333333333
28886, 2.2, 0.67173913043478, 0.30555555555556
28887, 2.2, 0.69782608695652, 0.27777777777778
28888, 2.2, 0.67173913043478, 0.25
28889, 2.2, 0.69782608695652, 0.22222222222222
28890, 2.2, 0.67173913043478, 0.19444444444444
28891, 2.2, 0.69782608695652, 0.16666666666667
28892, 2.2, 0.67173913043478, 0.13888888888889
28893, 2.2, 0.69782608695652, 0.11111111111111
28894, 2.2, 0.67173913043478, 0.083333333333333
28895, 2.2, 0.69782608695652, 0.055555555555556
28896, 2.2, 0.67173913043478, 0.027777777777778
28897, 2.2, 0.61956521739131, 0.47222222222222
28898, 2.2, 0.64565217391304, 0.44444444444444
28899, 2.2, 0.61956521739131, 0.41666666666667
28900, 2.2, 0.64565217391304, 0.38888888888889
28901, 2.2, 0.61956521739131, 0.36111111111111
28902, 2.2, 0.64565217391304, 0.33333333333333
28903, 2.2, 0.61956521739131, 0.30555555555556
28904, 2.2, 0.64565217391304, 0.27777777777778
28905, 2.2, 0.61956521739131, 0.25
28906, 2.2, 0.64565217391304, 0.22222222222222
28907, 2.2, 0.61956521739131, 0.19444444444444
28908, 2.2, 0.64565217391304, 0.16666666666667
28909, 2.2, 0.61956521739131, 0.13888888888889
28910, 2.2, 0.64565217391304, 0.11111111111111
28911, 2.2, 0.61956521739131, 0.083333333333333
28912, 2.2, 0.64565217391304, 0.055555555555556
28913, 2.2, 0.61956521739131, 0.027777777777778
28914, 2.2, 0.56739130434783, 0.47222222222222
28915, 2.2, 0.59347826086957, 0.44444444444444
28916, 2.2, 0.56739130434783, 0.41666666666667
28917, 2.2, 0.59347826086957, 0.38888888888889
28918, 2.2, 0.56739130434783, 0.36111111111111
28919, 2.2, 0.59347826086957, 0.33333333333333
28920, 2.2, 0.56739130434783, 0.30555555555556
28921, 2.2, 0.59347826086957, 0.27777777777778
28922, 2.2, 0.56739130434783, 0.25
28923, 2.2, 0.59347826086957, 0.22222222222222
28924, 2.2, 0.56739130434783, 0.19444444444444
28925, 2.2, 0.59347826086957, 0.16666666666667
28926, 2.2, 0.56739130434783, 0.13888888888889
28927, 2.2, 0.59347826086957, 0.11111111111111
28928, 2.2, 0.56739130434783, 0.083333333333333
28929, 2.2, 0.59347826086957, 0.055555555555556
28930, 2.2, 0.56739130434783, 0.027777777777778
28931, 2.2, 0.51521739130435, 0.47222222222222
28932, 2.2, 0.54130434782609, 0.44444444444444
28933, 2.2, 0.51521739130435, 0.41666666666667
28934, 2.2, 0.54130434782609, 0.38888888888889
28935, 2.2, 0.51521739130435, 0.36111111111111
28936, 2.2, 0.54130434782609, 0.33333333333333
28937, 2.2, 0.51521739130435, 0.30555555555556
28938, 2.2, 0.54130434782609, 0.27777777777778
28939, 2.2, 0.51521739130435, 0.25
28940, 2.2, 0.54130434782609, 0.22222222222222
28941, 2.2, 0.51521739130435, 0.19444444444444
28942, 2.2, 0.54130434782609, 0.16666666666667
28943, 2.2, 0.51521739130435, 0.13888888888889
28944, 2.2, 0.54130434782609, 0.11111111111111
28945, 2.2, 0.51521739130435, 0.083333333333333
28946, 2.2, 0.54130434782609, 0.055555555555556
28947, 2.2, 0.51521739130435, 0.027777777777778
28948, 2.2, 0.46304347826087, 0.47222222222222
28949, 2.2, 0.48913043478261, 0.44444444444444
28950, 2.2, 0.46304347826087, 0.41666666666667
28951, 2.2, 0.48913043478261, 0.38888888888889
28952, 2.2, 0.46304347826087, 0.36111111111111
28953, 2.2, 0.48913043478261, 0.33333333333333
28954, 2.2, 0.46304347826087, 0.30555555555556
28955, 2.2, 0.48913043478261, 0.27777777777778
28956, 2.2, 0.46304347826087, 0.25
28957, 2.2, 0.48913043478261, 0.22222222222222
28958, 2.2, 0.46304347826087, 0.19444444444444
28959, 2.2, 0.48913043478261, 0.16666666666667
28960, 2.2, 0.46304347826087, 0.13888888888889
28961, 2.2, 0.48913043478261, 0.11111111111111
28962, 2.2, 0.46304347826087, 0.083333333333333
28963, 2.2, 0.48913043478261, 0.055555555555556
28964, 2.2, 0.46304347826087, 0.027777777777778
28965, 2.2, 0.41086956521739, 0.47222222222222
28966, 2.2, 0.43695652173913, 0.44444444444444
28967, 2.2, 0.41086956521739, 0.41666666666667
28968, 2.2, 0.43695652173913, 0.38888888888889
28969, 2.2, 0.41086956521739, 0.36111111111111
28970, 2.2, 0.43695652173913, 0.33333333333333
28971, 2.2, 0.41086956521739, 0.30555555555556
28972, 2.2, 0.43695652173913, 0.27777777777778
28973, 2.2, 0.41086956521739, 0.25
28974, 2.2, 0.43695652173913, 0.22222222222222
28975, 2.2, 0.41086956521739, 0.19444444444444
28976, 2.2, 0.43695652173913, 0.16666666666667
28977, 2.2, 0.41086956521739, 0.13888888888889
28978, 2.2, 0.43695652173913, 0.11111111111111
28979, 2.2, 0.41086956521739, 0.083333333333333
28980, 2.2, 0.43695652173913, 0.055555555555556
28981, 2.2, 0.41086956521739, 0.027777777777778
28982, 2.2, 0.35869565217391, 0.47222222222222
28983, 2.2, 0.38478260869565, 0.44444444444444
28984, 2.2, 0.35869565217391, 0.41666666666667
28985, 2.2, 0.38478260869565, 0.38888888888889
28986, 2.2, 0.35869565217391, 0.36111111111111
28987, 2.2, 0.38478260869565, 0.33333333333333
28988, 2.2, 0.35869565217391, 0.30555555555556
28989, 2.2, 0.38478260869565, 0.27777777777778
28990, 2.2, 0.35869565217391, 0.25
28991, 2.2, 0.38478260869565, 0.22222222222222
28992, 2.2, 0.35869565217391, 0.19444444444444
28993, 2.2, 0.38478260869565, 0.16666666666667
28994, 2.2, 0.35869565217391, 0.13888888888889
28995, 2.2, 0.38478260869565, 0.11111111111111
28996, 2.2, 0.35869565217391, 0.083333333333333
28997, 2.2, 0.38478260869565, 0.055555555555556
28998, 2.2, 0.35869565217391, 0.027777777777778
28999, 2.2, 0.30652173913044, 0.47222222222222
29000, 2.2, 0.33260869565217, 0.44444444444444
29001, 2.2, 0.30652173913044, 0.41666666666667
29002, 2.2, 0.33260869565217, 0.38888888888889
29003, 2.2, 0.30652173913044, 0.36111111111111
29004, 2.2, 0.33260869565217, 0.33333333333333
29005, 2.2, 0.30652173913044, 0.30555555555556
29006, 2.2, 0.33260869565217, 0.27777777777778
29007, 2.2, 0.30652173913044, 0.25
29008, 2.2, 0.33260869565217, 0.22222222222222
29009, 2.2, 0.30652173913044, 0.19444444444444
29010, 2.2, 0.33260869565217, 0.16666666666667
29011, 2.2, 0.30652173913044, 0.13888888888889
29012, 2.2, 0.33260869565217, 0.11111111111111
29013, 2.2, 0.30652173913044, 0.083333333333333
29014, 2.2, 0.33260869565217, 0.055555555555556
29015, 2.2, 0.30652173913044, 0.027777777777778
29016, 2.2, 0.25434782608696, 0.47222222222222
29017, 2.2, 0.2804347826087, 0.44444444444444
29018, 2.2, 0.25434782608696, 0.41666666666667
29019, 2.2, 0.2804347826087, 0.38888888888889
29020, 2.2, 0.25434782608696, 0.36111111111111
29021, 2.2, 0.2804347826087, 0.33333333333333
29022, 2.2, 0.25434782608696, 0.30555555555556
29023, 2.2, 0.2804347826087, 0.27777777777778
29024, 2.2, 0.25434782608696, 0.25
29025, 2.2, 0.2804347826087, 0.22222222222222
29026, 2.2, 0.25434782608696, 0.19444444444444
29027, 2.2, 0.2804347826087, 0.16666666666667
29028, 2.2, 0.25434782608696, 0.13888888888889
29029, 2.2, 0.2804347826087, 0.11111111111111
29030, 2.2, 0.25434782608696, 0.083333333333333
29031, 2.2, 0.2804347826087, 0.055555555555556
29032, 2.2, 0.25434782608696, 0.027777777777778
29033, 2.2, 0.20217391304348, 0.47222222222222
29034, 2.2, 0.22826086956522, 0.44444444444444
29035, 2.2, 0.20217391304348, 0.41666666666667
29036, 2.2, 0.22826086956522, 0.38888888888889
29037, 2.2, 0.20217391304348, 0.36111111111111
29038, 2.2, 0.22826086956522, 0.33333333333333
29039, 2.2, 0.20217391304348, 0.30555555555556
29040, 2.2, 0.22826086956522, 0.27777777777778
29041, 2.2, 0.20217391304348, 0.25
29042, 2.2, 0.22826086956522, 0.22222222222222
29043, 2.2, 0.20217391304348, 0.19444444444444
29044, 2.2, 0.22826086956522, 0.16666666666667
29045, 2.2, 0.20217391304348, 0.13888888888889
29046, 2.2, 0.22826086956522, 0.11111111111111
29047, 2.2, 0.20217391304348, 0.083333333333333
29048, 2.2, 0.22826086956522, 0.055555555555556
29049, 2.2, 0.20217391304348, 0.027777777777778
29050, 2.2, 0.17608695652174, 0.44444444444444
29051, 2.2, 0.17608695652174, 0.38888888888889
29052, 2.2, 0.17608695652174, 0.33333333333333
29053, 2.2, 0.17608695652174, 0.27777777777778
29054, 2.2, 0.17608695652174, 0.22222222222222
29055, 2.2, 0.17608695652174, 0.16666666666667
29056, 2.2, 0.17608695652174, 0.11111111111111
29057, 2.2, 0.17608695652174, 0.055555555555556
29058, 1.2434782608696, 1.35, 0.44444444444444
29059, 1.2434782608696, 1.35, 0.38888888888889
29060, 1.2434782608696, 1.35, 0.33333333333333
29061, 1.2434782608696, 1.35, 0.27777777777778
29062, 1.2434782608696, 1.35, 0.22222222222222
29063, 1.2434782608696, 1.35, 0.16666666666667
29064, 1.2434782608696, 1.35, 0.11111111111111
29065, 1.2434782608696, 1.35, 0.055555555555556
29066, 1.2869565217391, 1.35, 0.44444444444444
29067, 1.2869565217391, 1.35, 0.38888888888889
29068, 1.2869565217391, 1.35, 0.33333333333333
29069, 1.2869565217391, 1.35, 0.27777777777778
29070, 1.2869565217391, 1.35, 0.22222222222222
29071, 1.2869565217391, 1.35, 0.16666666666667
29072, 1.2869565217391, 1.35, 0.11111111111111
29073, 1.2869565217391, 1.35, 0.055555555555556
29074, 1.3304347826087, 1.35, 0.44444444444444
29075, 1.3304347826087, 1.35, 0.38888888888889
29076, 1.3304347826087, 1.35, 0.33333333333333
29077, 1.3304347826087, 1.35, 0.27777777777778
29078, 1.3304347826087, 1.35, 0.22222222222222
29079, 1.3304347826087, 1.35, 0.16666666666667
29080, 1.3304347826087, 1.35, 0.11111111111111
29081, 1.3304347826087, 1.35, 0.055555555555556
29082, 1.3739130434783, 1.35, 0.44444444444444
29083, 1.3739130434783, 1.35, 0.38888888888889
29084, 1.3739130434783, 1.35, 0.33333333333333
29085, 1.3739130434783, 1.35, 0.27777777777778
29086, 1.3739130434783, 1.35, 0.22222222222222
29087, 1.3739130434783, 1.35, 0.16666666666667
29088, 1.3739130434783, 1.35, 0.11111111111111
29089, 1.3739130434783, 1.35, 0.055555555555556
29090, 1.4173913043478, 1.35, 0.44444444444444
29091, 1.4173913043478, 1.35, 0.38888888888889
29092, 1.4173913043478, 1.35, 0.33333333333333
29093, 1.4173913043478, 1.35, 0.27777777777778
29094, 1.4173913043478, 1.35, 0.22222222222222
29095, 1.4173913043478, 1.35, 0.16666666666667
29096, 1.4173913043478, 1.35, 0.11111111111111
29097, 1.4173913043478, 1.35, 0.055555555555556
29098, 1.4608695652174, 1.35, 0.44444444444444
29099, 1.4608695652174, 1.35, 0.38888888888889
29100, 1.4608695652174, 1.35, 0.33333333333333
29101, 1.4608695652174, 1.35, 0.27777777777778
29102, 1.4608695652174, 1.35, 0.22222222222222
29103, 1.4608695652174, 1.35, 0.16666666666667
29104, 1.4608695652174, 1.35, 0.11111111111111
29105, 1.4608695652174, 1.35, 0.055555555555556
29106, 1.504347826087, 1.35, 0.44444444444444
29107, 1.504347826087, 1.35, 0.38888888888889
29108, 1.504347826087, 1.35, 0.33333333333333
29109, 1.504347826087, 1.35, 0.27777777777778
29110, 1.504347826087, 1.35, 0.22222222222222
29111, 1.504347826087, 1.35, 0.16666666666667
29112, 1.504347826087, 1.35, 0.11111111111111
29113, 1.504347826087, 1.35, 0.055555555555556
29114, 1.5478260869565, 1.35, 0.44444444444444
29115, 1.5478260869565, 1.35, 0.38888888888889
29116, 1.5478260869565, 1.35, 0.33333333333333
29117, 1.5478260869565, 1.35, 0.27777777777778
29118, 1.5478260869565, 1.35, 0.22222222222222
29119, 1.5478260869565, 1.35, 0.16666666666667
29120, 1.5478260869565, 1.35, 0.11111111111111
29121, 1.5478260869565, 1.35, 0.055555555555556
29122, 1.5913043478261, 1.35, 0.44444444444444
29123, 1.5913043478261, 1.35, 0.38888888888889
29124, 1.5913043478261, 1.35, 0.33333333333333
29125, 1.5913043478261, 1.35, 0.27777777777778
29126, 1.5913043478261, 1.35, 0.22222222222222
29127, 1.5913043478261, 1.35, 0.16666666666667
29128, 1.5913043478261, 1.35, 0.11111111111111
29129, 1.5913043478261, 1.35, 0.055555555555556
29130, 1.6347826086957, 1.35, 0.44444444444444
29131, 1.6347826086957, 1.35, 0.38888888888889
29132, 1.6347826086957, 1.35, 0.33333333333333
29133, 1.6347826086957, 1.35, 0.27777777777778
29134, 1.6347826086957, 1.35, 0.22222222222222
29135, 1.6347826086957, 1.35, 0.16666666666667
29136, 1.6347826086957, 1.35, 0.11111111111111
29137, 1.6347826086957, 1.35, 0.055555555555556
29138, 1.6782608695652, 1.35, 0.44444444444444
29139, 1.6782608695652, 1.35, 0.38888888888889
29140, 1.6782608695652, 1.35, 0.33333333333333
29141, 1.6782608695652, 1.35, 0.27777777777778
29142, 1.6782608695652, 1.35, 0.22222222222222
29143, 1.6782608695652, 1.35, 0.16666666666667
29144, 1.6782608695652, 1.35, 0.11111111111111
29145, 1.6782608695652, 1.35, 0.055555555555556
29146, 1.7217391304348, 1.35, 0.44444444444444
29147, 1.7217391304348, 1.35, 0.38888888888889
29148, 1.7217391304348, 1.35, 0.33333333333333
29149, 1.7217391304348, 1.35, 0.27777777777778
29150, 1.7217391304348, 1.35, 0.22222222222222
29151, 1.7217391304348, 1.35, 0.16666666666667
29152, 1.7217391304348, 1.35, 0.11111111111111
29153, 1.7217391304348, 1.35, 0.055555555555556
29154, 1.7652173913043, 1.35, 0.44444444444444
29155, 1.7652173913043, 1.35, 0.38888888888889
29156, 1.7652173913043, 1.35, 0.33333333333333
29157, 1.7652173913043, 1.35, 0.27777777777778
29158, 1.7652173913043, 1.35, 0.22222222222222
29159, 1.7652173913043, 1.35, 0.16666666666667
29160, 1.7652173913043, 1.35, 0.11111111111111
29161, 1.7652173913043, 1.35, 0.055555555555556
29162, 1.8086956521739, 1.35, 0.44444444444444
29163, 1.8086956521739, 1.35, 0.38888888888889
29164, 1.8086956521739, 1.35, 0.33333333333333
29165, 1.8086956521739, 1.35, 0.27777777777778
29166, 1.8086956521739, 1.35, 0.22222222222222
29167, 1.8086956521739, 1.35, 0.16666666666667
29168, 1.8086956521739, 1.35, 0.11111111111111
29169, 1.8086956521739, 1.35, 0.055555555555556
29170, 1.8521739130435, 1.35, 0.44444444444444
29171, 1.8521739130435, 1.35, 0.38888888888889
29172, 1.8521739130435, 1.35, 0.33333333333333
29173, 1.8521739130435, 1.35, 0.27777777777778
29174, 1.8521739130435, 1.35, 0.22222222222222
29175, 1.8521739130435, 1.35, 0.16666666666667
29176, 1.8521739130435, 1.35, 0.11111111111111
29177, 1.8521739130435, 1.35, 0.055555555555556
29178, 1.895652173913, 1.35, 0.44444444444444
29179, 1.895652173913, 1.35, 0.38888888888889
29180, 1.895652173913, 1.35, 0.33333333333333
29181, 1.895652173913, 1.35, 0.27777777777778
29182, 1.895652173913, 1.35, 0.22222222222222
29183, 1.895652173913, 1.35, 0.16666666666667
29184, 1.895652173913, 1.35, 0.11111111111111
29185, 1.895652173913, 1.35, 0.055555555555556
29186, 1.9391304347826, 1.35, 0.44444444444444
29187, 1.9391304347826, 1.35, 0.38888888888889
29188, 1.9391304347826, 1.35, 0.33333333333333
29189, 1.9391304347826, 1.35, 0.27777777777778
29190, 1.9391304347826, 1.35, 0.22222222222222
29191, 1.9391304347826, 1.35, 0.16666666666667
29192, 1.9391304347826, 1.35, 0.11111111111111
29193, 1.9391304347826, 1.35, 0.055555555555556
29194, 1.9826086956522, 1.35, 0.44444444444444
29195, 1.9826086956522, 1.35, 0.38888888888889
29196, 1.9826086956522, 1.35, 0.33333333333333
29197, 1.9826086956522, 1.35, 0.27777777777778
29198, 1.9826086956522, 1.35, 0.22222222222222
29199, 1.9826086956522, 1.35, 0.16666666666667
29200, 1.9826086956522, 1.35, 0.11111111111111
29201, 1.9826086956522, 1.35, 0.055555555555556
29202, 2.0260869565217, 1.35, 0.44444444444444
29203, 2.0260869565217, 1.35, 0.38888888888889
29204, 2.0260869565217, 1.35, 0.33333333333333
29205, 2.0260869565217, 1.35, 0.27777777777778
29206, 2.0260869565217, 1.35, 0.22222222222222
29207, 2.0260869565217, 1.35, 0.16666666666667
29208, 2.0260869565217, 1.35, 0.11111111111111
29209, 2.0260869565217, 1.35, 0.055555555555556
29210, 2.0695652173913, 1.35, 0.44444444444444
29211, 2.0695652173913, 1.35, 0.38888888888889
29212, 2.0695652173913, 1.35, 0.33333333333333
29213, 2.0695652173913, 1.35, 0.27777777777778
29214, 2.0695652173913, 1.35, 0.22222222222222
29215, 2.0695652173913, 1.35, 0.16666666666667
29216, 2.0695652173913, 1.35, 0.11111111111111
29217, 2.0695652173913, 1.35, 0.055555555555556
29218, 2.1130434782609, 1.35, 0.44444444444444
29219, 2.1130434782609, 1.35, 0.38888888888889
29220, 2.1130434782609, 1.35, 0.33333333333333
29221, 2.1130434782609, 1.35, 0.27777777777778
29222, 2.1130434782609, 1.35, 0.22222222222222
29223, 2.1130434782609, 1.35, 0.16666666666667
29224, 2.1130434782609, 1.35, 0.11111111111111
29225, 2.1130434782609, 1.35, 0.055555555555556
29226, 2.1565217391304, 1.35, 0.44444444444444
29227, 2.1565217391304, 1.35, 0.38888888888889
29228, 2.1565217391304, 1.35, 0.33333333333333
29229, 2.1565217391304, 1.35, 0.27777777777778
29230, 2.1565217391304, 1.35, 0.22222222222222
29231, 2.1565217391304, 1.35, 0.16666666666667
29232, 2.1565217391304, 1.35, 0.11111111111111
29233, 2.1565217391304, 1.35, 0.055555555555556
29234, 1.2434782608696, 1.35, 0.47222222222222
29235, 1.2217391304348, 1.35, 0.44444444444444
29236, 1.2434782608696, 1.35, 0.41666666666667
29237, 1.2217391304348, 1.35, 0.38888888888889
29238, 1.2434782608696, 1.35, 0.36111111111111
29239, 1.2217391304348, 1.35, 0.33333333333333
29240, 1.2434782608696, 1.35, 0.30555555555556
29241, 1.2217391304348, 1.35, 0.27777777777778
29242, 1.2434782608696, 1.35, 0.25
29243, 1.2217391304348, 1.35, 0.22222222222222
29244, 1.2434782608696, 1.35, 0.19444444444444
29245, 1.2217391304348, 1.35, 0.16666666666667
29246, 1.2434782608696, 1.35, 0.13888888888889
29247, 1.2217391304348, 1.35, 0.11111111111111
29248, 1.2434782608696, 1.35, 0.083333333333333
29249, 1.2217391304348, 1.35, 0.055555555555556
29250, 1.2434782608696, 1.35, 0.027777777777778
29251, 1.2869565217391, 1.35, 0.47222222222222
29252, 1.2652173913043, 1.35, 0.44444444444444
29253, 1.2869565217391, 1.35, 0.41666666666667
29254, 1.2652173913043, 1.35, 0.38888888888889
29255, 1.2869565217391, 1.35, 0.36111111111111
29256, 1.2652173913043, 1.35, 0.33333333333333
29257, 1.2869565217391, 1.35, 0.30555555555556
29258, 1.2652173913043, 1.35, 0.27777777777778
29259, 1.2869565217391, 1.35, 0.25
29260, 1.2652173913043, 1.35, 0.22222222222222
29261, 1.2869565217391, 1.35, 0.19444444444444
29262, 1.2652173913043, 1.35, 0.16666666666667
29263, 1.2869565217391, 1.35, 0.13888888888889
29264, 1.2652173913043, 1.35, 0.11111111111111
29265, 1.2869565217391, 1.35, 0.083333333333333
29266, 1.2652173913043, 1.35, 0.055555555555556
29267, 1.2869565217391, 1.35, 0.027777777777778
29268, 1.3304347826087, 1.35, 0.47222222222222
29269, 1.3086956521739, 1.35, 0.44444444444444
29270, 1.3304347826087, 1.35, 0.41666666666667
29271, 1.3086956521739, 1.35, 0.38888888888889
29272, 1.3304347826087, 1.35, 0.36111111111111
29273, 1.3086956521739, 1.35, 0.33333333333333
29274, 1.3304347826087, 1.35, 0.30555555555556
29275, 1.3086956521739, 1.35, 0.27777777777778
29276, 1.3304347826087, 1.35, 0.25
29277, 1.3086956521739, 1.35, 0.22222222222222
29278, 1.3304347826087, 1.35, 0.19444444444444
29279, 1.3086956521739, 1.35, 0.16666666666667
29280, 1.3304347826087, 1.35, 0.13888888888889
29281, 1.3086956521739, 1.35, 0.11111111111111
29282, 1.3304347826087, 1.35, 0.083333333333333
29283, 1.3086956521739, 1.35, 0.055555555555556
29284, 1.3304347826087, 1.35, 0.027777777777778
29285, 1.3739130434783, 1.35, 0.47222222222222
29286, 1.3521739130435, 1.35, 0.44444444444444
29287, 1.3739130434783, 1.35, 0.41666666666667
29288, 1.3521739130435, 1.35, 0.38888888888889
29289, 1.3739130434783, 1.35, 0.36111111111111
29290, 1.3521739130435, 1.35, 0.33333333333333
29291, 1.3739130434783, 1.35, 0.30555555555556
29292, 1.3521739130435, 1.35, 0.27777777777778
29293, 1.3739130434783, 1.35, 0.25
29294, 1.3521739130435, 1.35, 0.22222222222222
29295, 1.3739130434783, 1.35, 0.19444444444444
29296, 1.3521739130435, 1.35, 0.16666666666667
29297, 1.3739130434783, 1.35, 0.13888888888889
29298, 1.3521739130435, 1.35, 0.11111111111111
29299, 1.3739130434783, 1.35, 0.083333333333333
29300, 1.3521739130435, 1.35, 0.055555555555556
29301, 1.3739130434783, 1.35, 0.027777777777778
29302, 1.4173913043478, 1.35, 0.47222222222222
29303, 1.395652173913, 1.35, 0.44444444444444
29304, 1.4173913043478, 1.35, 0.41666666666667
29305, 1.395652173913, 1.35, 0.38888888888889
29306, 1.4173913043478, 1.35, 0.36111111111111
29307, 1.395652173913, 1.35, 0.33333333333333
29308, 1.4173913043478, 1.35, 0.30555555555556
29309, 1.395652173913, 1.35, 0.27777777777778
29310, 1.4173913043478, 1.35, 0.25
29311, 1.395652173913, 1.35, 0.22222222222222
29312, 1.4173913043478, 1.35, 0.19444444444444
29313, 1.395652173913, 1.35, 0.16666666666667
29314, 1.4173913043478, 1.35, 0.13888888888889
29315, 1.395652173913, 1.35, 0.11111111111111
29316, 1.4173913043478, 1.35, 0.083333333333333
29317, 1.395652173913, 1.35, 0.055555555555556
29318, 1.4173913043478, 1.35, 0.027777777777778
29319, 1.4608695652174, 1.35, 0.47222222222222
29320, 1.4391304347826, 1.35, 0.44444444444444
29321, 1.4608695652174, 1.35, 0.41666666666667
29322, 1.4391304347826, 1.35, 0.38888888888889
29323, 1.4608695652174, 1.35, 0.36111111111111
29324, 1.4391304347826, 1.35, 0.33333333333333
29325, 1.4608695652174, 1.35, 0.30555555555556
29326, 1.4391304347826, 1.35, 0.27777777777778
29327, 1.4608695652174, 1.35, 0.25
29328, 1.4391304347826, 1.35, 0.22222222222222
29329, 1.4608695652174, 1.35, 0.19444444444444
29330, 1.4391304347826, 1.35, 0.16666666666667
29331, 1.4608695652174, 1.35, 0.13888888888889
29332, 1.4391304347826, 1.35, 0.11111111111111
29333, 1.4608695652174, 1.35, 0.083333333333333
29334, 1.4391304347826, 1.35, 0.055555555555556
29335, 1.4608695652174, 1.35, 0.027777777777778
29336, 1.504347826087, 1.35, 0.47222222222222
29337, 1.4826086956522, 1.35, 0.44444444444444
29338, 1.504347826087, 1.35, 0.41666666666667
29339, 1.4826086956522, 1.35, 0.38888888888889
29340, 1.504347826087, 1.35, 0.36111111111111
29341, 1.4826086956522, 1.35, 0.33333333333333
29342, 1.504347826087, 1.35, 0.30555555555556
29343, 1.4826086956522, 1.35, 0.27777777777778
29344, 1.504347826087, 1.35, 0.25
29345, 1.4826086956522, 1.35, 0.22222222222222
29346, 1.504347826087, 1.35, 0.19444444444444
29347, 1.4826086956522, 1.35, 0.16666666666667
29348, 1.504347826087, 1.35, 0.13888888888889
29349, 1.4826086956522, 1.35, 0.11111111111111
29350, 1.504347826087, 1.35, 0.083333333333333
29351, 1.4826086956522, 1.35, 0.055555555555556
29352, 1.504347826087, 1.35, 0.027777777777778
29353, 1.5478260869565, 1.35, 0.47222222222222
29354, 1.5260869565217, 1.35, 0.44444444444444
29355, 1.5478260869565, 1.35, 0.41666666666667
29356, 1.5260869565217, 1.35, 0.38888888888889
29357, 1.5478260869565, 1.35, 0.36111111111111
29358, 1.5260869565217, 1.35, 0.33333333333333
29359, 1.5478260869565, 1.35, 0.30555555555556
29360, 1.5260869565217, 1.35, 0.27777777777778
29361, 1.5478260869565, 1.35, 0.25
29362, 1.5260869565217, 1.35, 0.22222222222222
29363, 1.5478260869565, 1.35, 0.19444444444444
29364, 1.5260869565217, 1.35, 0.16666666666667
29365, 1.5478260869565, 1.35, 0.13888888888889
29366, 1.5260869565217, 1.35, 0.11111111111111
29367, 1.5478260869565, 1.35, 0.083333333333333
29368, 1.5260869565217, 1.35, 0.055555555555556
29369, 1.5478260869565, 1.35, 0.027777777777778
29370, 1.5913043478261, 1.35, 0.47222222222222
29371, 1.5695652173913, 1.35, 0.44444444444444
29372, 1.5913043478261, 1.35, 0.41666666666667
29373, 1.5695652173913, 1.35, 0.38888888888889
29374, 1.5913043478261, 1.35, 0.36111111111111
29375, 1.5695652173913, 1.35, 0.33333333333333
29376, 1.5913043478261, 1.35, 0.30555555555556
29377, 1.5695652173913, 1.35, 0.27777777777778
29378, 1.5913043478261, 1.35, 0.25
29379, 1.5695652173913, 1.35, 0.22222222222222
29380, 1.5913043478261, 1.35, 0.19444444444444
29381, 1.5695652173913, 1.35, 0.16666666666667
29382, 1.5913043478261, 1.35, 0.13888888888889
29383, 1.5695652173913, 1.35, 0.11111111111111
29384, 1.5913043478261, 1.35, 0.083333333333333
29385, 1.5695652173913, 1.35, 0.055555555555556
29386, 1.5913043478261, 1.35, 0.027777777777778
29387, 1.6347826086957, 1.35, 0.47222222222222
29388, 1.6130434782609, 1.35, 0.44444444444444
29389, 1.6347826086957, 1.35, 0.41666666666667
29390, 1.6130434782609, 1.35, 0.38888888888889
29391, 1.6347826086957, 1.35, 0.36111111111111
29392, 1.6130434782609, 1.35, 0.33333333333333
29393, 1.6347826086957, 1.35, 0.30555555555556
29394, 1.6130434782609, 1.35, 0.27777777777778
29395, 1.6347826086957, 1.35, 0.25
29396, 1.6130434782609, 1.35, 0.22222222222222
29397, 1.6347826086957, 1.35, 0.19444444444444
29398, 1.6130434782609, 1.35, 0.16666666666667
29399, 1.6347826086957, 1.35, 0.13888888888889
29400, 1.6130434782609, 1.35, 0.11111111111111
29401, 1.6347826086957, 1.35, 0.083333333333333
29402, 1.6130434782609, 1.35, 0.055555555555556
29403, 1.6347826086957, 1.35, 0.027777777777778
29404, 1.6782608695652, 1.35, 0.47222222222222
29405, 1.6565217391304, 1.35, 0.44444444444444
29406, 1.6782608695652, 1.35, 0.41666666666667
29407, 1.6565217391304, 1.35, 0.38888888888889
29408, 1.6782608695652, 1.35, 0.36111111111111
29409, 1.6565217391304, 1.35, 0.33333333333333
29410, 1.6782608695652, 1.35, 0.30555555555556
29411, 1.6565217391304, 1.35, 0.27777777777778
29412, 1.6782608695652, 1.35, 0.25
29413, 1.6565217391304, 1.35, 0.22222222222222
29414, 1.6782608695652, 1.35, 0.19444444444444
29415, 1.6565217391304, 1.35, 0.16666666666667
29416, 1.6782608695652, 1.35, 0.13888888888889
29417, 1.6565217391304, 1.35, 0.11111111111111
29418, 1.6782608695652, 1.35, 0.083333333333333
29419, 1.6565217391304, 1.35, 0.055555555555556
29420, 1.6782608695652, 1.35, 0.027777777777778
29421, 1.7217391304348, 1.35, 0.47222222222222
29422, 1.7, 1.35, 0.44444444444444
29423, 1.7217391304348, 1.35, 0.41666666666667
29424, 1.7, 1.35, 0.38888888888889
29425, 1.7217391304348, 1.35, 0.36111111111111
29426, 1.7, 1.35, 0.33333333333333
29427, 1.7217391304348, 1.35, 0.30555555555556
29428, 1.7, 1.35, 0.27777777777778
29429, 1.7217391304348, 1.35, 0.25
29430, 1.7, 1.35, 0.22222222222222
29431, 1.7217391304348, 1.35, 0.19444444444444
29432, 1.7, 1.35, 0.16666666666667
29433, 1.7217391304348, 1.35, 0.13888888888889
29434, 1.7, 1.35, 0.11111111111111
29435, 1.7217391304348, 1.35, 0.083333333333333
29436, 1.7, 1.35, 0.055555555555556
29437, 1.7217391304348, 1.35, 0.027777777777778
29438, 1.7652173913043, 1.35, 0.47222222222222
29439, 1.7434782608696, 1.35, 0.44444444444444
29440, 1.7652173913043, 1.35, 0.41666666666667
29441, 1.7434782608696, 1.35, 0.38888888888889
29442, 1.7652173913043, 1.35, 0.36111111111111
29443, 1.7434782608696, 1.35, 0.33333333333333
29444, 1.7652173913043, 1.35, 0.30555555555556
29445, 1.7434782608696, 1.35, 0.27777777777778
29446, 1.7652173913043, 1.35, 0.25
29447, 1.7434782608696, 1.35, 0.22222222222222
29448, 1.7652173913043, 1.35, 0.19444444444444
29449, 1.7434782608696, 1.35, 0.16666666666667
29450, 1.7652173913043, 1.35, 0.13888888888889
29451, 1.7434782608696, 1.35, 0.11111111111111
29452, 1.7652173913043, 1.35, 0.083333333333333
29453, 1.7434782608696, 1.35, 0.055555555555556
29454, 1.7652173913043, 1.35, 0.027777777777778
29455, 1.8086956521739, 1.35, 0.47222222222222
29456, 1.7869565217391, 1.35, 0.44444444444444
29457, 1.8086956521739, 1.35, 0.41666666666667
29458, 1.7869565217391, 1.35, 0.38888888888889
29459, 1.8086956521739, 1.35, 0.36111111111111
29460, 1.7869565217391, 1.35, 0.33333333333333
29461, 1.8086956521739, 1.35, 0.30555555555556
29462, 1.7869565217391, 1.35, 0.27777777777778
29463, 1.8086956521739, 1.35, 0.25
29464, 1.7869565217391, 1.35, 0.22222222222222
29465, 1.8086956521739, 1.35, 0.19444444444444
29466, 1.7869565217391, 1.35, 0.16666666666667
29467, 1.8086956521739, 1.35, 0.13888888888889
29468, 1.7869565217391, 1.35, 0.11111111111111
29469, 1.8086956521739, 1.35, 0.083333333333333
29470, 1.7869565217391, 1.35, 0.055555555555556
29471, 1.8086956521739, 1.35, 0.027777777777778
29472, 1.8521739130435, 1.35, 0.47222222222222
29473, 1.8304347826087, 1.35, 0.44444444444444
29474, 1.8521739130435, 1.35, 0.41666666666667
29475, 1.8304347826087, 1.35, 0.38888888888889
29476, 1.8521739130435, 1.35, 0.36111111111111
29477, 1.8304347826087, 1.35, 0.33333333333333
29478, 1.8521739130435, 1.35, 0.30555555555556
29479, 1.8304347826087, 1.35, 0.27777777777778
29480, 1.8521739130435, 1.35, 0.25
29481, 1.8304347826087, 1.35, 0.22222222222222
29482, 1.8521739130435, 1.35, 0.19444444444444
29483, 1.8304347826087, 1.35, 0.16666666666667
29484, 1.8521739130435, 1.35, 0.13888888888889
29485, 1.8304347826087, 1.35, 0.11111111111111
29486, 1.8521739130435, 1.35, 0.083333333333333
29487, 1.8304347826087, 1.35, 0.055555555555556
29488, 1.8521739130435, 1.35, 0.027777777777778
29489, 1.895652173913, 1.35, 0.47222222222222
29490, 1.8739130434783, 1.35, 0.44444444444444
29491, 1.895652173913, 1.35, 0.41666666666667
29492, 1.8739130434783, 1.35, 0.38888888888889
29493, 1.895652173913, 1.35, 0.36111111111111
29494, 1.8739130434783, 1.35, 0.33333333333333
29495, 1.895652173913, 1.35, 0.30555555555556
29496, 1.8739130434783, 1.35, 0.27777777777778
29497, 1.895652173913, 1.35, 0.25
29498, 1.8739130434783, 1.35, 0.22222222222222
29499, 1.895652173913, 1.35, 0.19444444444444
29500, 1.8739130434783, 1.35, 0.16666666666667
29501, 1.895652173913, 1.35, 0.13888888888889
29502, 1.8739130434783, 1.35, 0.11111111111111
29503, 1.895652173913, 1.35, 0.083333333333333
29504, 1.8739130434783, 1.35, 0.055555555555556
29505, 1.895652173913, 1.35, 0.027777777777778
29506, 1.9391304347826, 1.35, 0.47222222222222
29507, 1.9173913043478, 1.35, 0.44444444444444
29508, 1.9391304347826, 1.35, 0.41666666666667
29509, 1.9173913043478, 1.35, 0.38888888888889
29510, 1.9391304347826, 1.35, 0.36111111111111
29511, 1.9173913043478, 1.35, 0.33333333333333
29512, 1.9391304347826, 1.35, 0.30555555555556
29513, 1.9173913043478, 1.35, 0.27777777777778
29514, 1.9391304347826, 1.35, 0.25
29515, 1.9173913043478, 1.35, 0.22222222222222
29516, 1.9391304347826, 1.35, 0.19444444444444
29517, 1.9173913043478, 1.35, 0.16666666666667
29518, 1.9391304347826, 1.35, 0.13888888888889
29519, 1.9173913043478, 1.35, 0.11111111111111
29520, 1.9391304347826, 1.35, 0.083333333333333
29521, 1.9173913043478, 1.35, 0.055555555555556
29522, 1.9391304347826, 1.35, 0.027777777777778
29523, 1.9826086956522, 1.35, 0.47222222222222
29524, 1.9608695652174, 1.35, 0.44444444444444
29525, 1.9826086956522, 1.35, 0.41666666666667
29526, 1.9608695652174, 1.35, 0.38888888888889
29527, 1.9826086956522, 1.35, 0.36111111111111
29528, 1.9608695652174, 1.35, 0.33333333333333
29529, 1.9826086956522, 1.35, 0.30555555555556
29530, 1.9608695652174, 1.35, 0.27777777777778
29531, 1.9826086956522, 1.35, 0.25
29532, 1.9608695652174, 1.35, 0.22222222222222
29533, 1.9826086956522, 1.35, 0.19444444444444
29534, 1.9608695652174, 1.35, 0.16666666666667
29535, 1.9826086956522, 1.35, 0.13888888888889
29536, 1.9608695652174, 1.35, 0.11111111111111
29537, 1.9826086956522, 1.35, 0.083333333333333
29538, 1.9608695652174, 1.35, 0.055555555555556
29539, 1.9826086956522, 1.35, 0.027777777777778
29540, 2.0260869565217, 1.35, 0.47222222222222
29541, 2.004347826087, 1.35, 0.44444444444444
29542, 2.0260869565217, 1.35, 0.41666666666667
29543, 2.004347826087, 1.35, 0.38888888888889
29544, 2.0260869565217, 1.35, 0.36111111111111
29545, 2.004347826087, 1.35, 0.33333333333333
29546, 2.0260869565217, 1.35, 0.30555555555556
29547, 2.004347826087, 1.35, 0.27777777777778
29548, 2.0260869565217, 1.35, 0.25
29549, 2.004347826087, 1.35, 0.22222222222222
29550, 2.0260869565217, 1.35, 0.19444444444444
29551, 2.004347826087, 1.35, 0.16666666666667
29552, 2.0260869565217, 1.35, 0.13888888888889
29553, 2.004347826087, 1.35, 0.11111111111111
29554, 2.0260869565217, 1.35, 0.083333333333333
29555, 2.004347826087, 1.35, 0.055555555555556
29556, 2.0260869565217, 1.35, 0.027777777777778
29557, 2.0695652173913, 1.35, 0.47222222222222
29558, 2.0478260869565, 1.35, 0.44444444444444
29559, 2.0695652173913, 1.35, 0.41666666666667
29560, 2.0478260869565, 1.35, 0.38888888888889
29561, 2.0695652173913, 1.35, 0.36111111111111
29562, 2.0478260869565, 1.35, 0.33333333333333
29563, 2.0695652173913, 1.35, 0.30555555555556
29564, 2.0478260869565, 1.35, 0.27777777777778
29565, 2.0695652173913, 1.35, 0.25
29566, 2.0478260869565, 1.35, 0.22222222222222
29567, 2.0695652173913, 1.35, 0.19444444444444
29568, 2.0478260869565, 1.35, 0.16666666666667
29569, 2.0695652173913, 1.35, 0.13888888888889
29570, 2.0478260869565, 1.35, 0.11111111111111
29571, 2.0695652173913, 1.35, 0.083333333333333
29572, 2.0478260869565, 1.35, 0.055555555555556
29573, 2.0695652173913, 1.35, 0.027777777777778
29574, 2.1130434782609, 1.35, 0.47222222222222
29575, 2.0913043478261, 1.35, 0.44444444444444
29576, 2.1130434782609, 1.35, 0.41666666666667
29577, 2.0913043478261, 1.35, 0.38888888888889
29578, 2.1130434782609, 1.35, 0.36111111111111
29579, 2.0913043478261, 1.35, 0.33333333333333
29580, 2.1130434782609, 1.35, 0.30555555555556
29581, 2.0913043478261, 1.35, 0.27777777777778
29582, 2.1130434782609, 1.35, 0.25
29583, 2.0913043478261, 1.35, 0.22222222222222
29584, 2.1130434782609, 1.35, 0.19444444444444
29585, 2.0913043478261, 1.35, 0.16666666666667
29586, 2.1130434782609, 1.35, 0.13888888888889
29587, 2.0913043478261, 1.35, 0.11111111111111
29588, 2.1130434782609, 1.35, 0.083333333333333
29589, 2.0913043478261, 1.35, 0.055555555555556
29590, 2.1130434782609, 1.35, 0.027777777777778
29591, 2.1565217391304, 1.35, 0.47222222222222
29592, 2.1347826086957, 1.35, 0.44444444444444
29593, 2.1565217391304, 1.35, 0.41666666666667
29594, 2.1347826086957, 1.35, 0.38888888888889
29595, 2.1565217391304, 1.35, 0.36111111111111
29596, 2.1347826086957, 1.35, 0.33333333333333
29597, 2.1565217391304, 1.35, 0.30555555555556
29598, 2.1347826086957, 1.35, 0.27777777777778
29599, 2.1565217391304, 1.35, 0.25
29600, 2.1347826086957, 1.35, 0.22222222222222
29601, 2.1565217391304, 1.35, 0.19444444444444
29602, 2.1347826086957, 1.35, 0.16666666666667
29603, 2.1565217391304, 1.35, 0.13888888888889
29604, 2.1347826086957, 1.35, 0.11111111111111
29605, 2.1565217391304, 1.35, 0.083333333333333
29606, 2.1347826086957, 1.35, 0.055555555555556
29607, 2.1565217391304, 1.35, 0.027777777777778
29608, 2.1782608695652, 1.35, 0.44444444444444
29609, 2.1782608695652, 1.35, 0.38888888888889
29610, 2.1782608695652, 1.35, 0.33333333333333
29611, 2.1782608695652, 1.35, 0.27777777777778
29612, 2.1782608695652, 1.35, 0.22222222222222
29613, 2.1782608695652, 1.35, 0.16666666666667
29614, 2.1782608695652, 1.35, 0.11111111111111
29615, 2.1782608695652, 1.35, 0.055555555555556
29616, 1.2434782608696, 0.125, 0.5
29617, 1.2869565217391, 0.125, 0.5
29618, 1.3304347826087, 0.125, 0.5
29619, 1.3739130434783, 0.125, 0.5
29620, 1.4173913043478, 0.125, 0.5
29621, 1.4608695652174, 0.125, 0.5
29622, 1.504347826087, 0.125, 0.5
29623, 1.5478260869565, 0.125, 0.5
29624, 1.5913043478261, 0.125, 0.5
29625, 1.6347826086957, 0.125, 0.5
29626, 1.6782608695652, 0.125, 0.5
29627, 1.7217391304348, 0.125, 0.5
29628, 1.7652173913043, 0.125, 0.5
29629, 1.8086956521739, 0.125, 0.5
29630, 1.8521739130435, 0.125, 0.5
29631, 1.895652173913, 0.125, 0.5
29632, 1.9391304347826, 0.125, 0.5
29633, 1.9826086956522, 0.125, 0.5
29634, 2.0260869565217, 0.125, 0.5
29635, 2.0695652173913, 0.125, 0.5
29636, 2.1130434782609, 0.125, 0.5
29637, 2.1565217391304, 0.125, 0.5
29638, 1.2217391304348, 0.125, 0.5
29639, 1.2434782608696, 0.1375, 0.5
29640, 1.2652173913043, 0.125, 0.5
29641, 1.2869565217391, 0.1375, 0.5
29642, 1.3086956521739, 0.125, 0.5
29643, 1.3304347826087, 0.1375, 0.5
29644, 1.3521739130435, 0.125, 0.5
29645, 1.3739130434783, 0.1375, 0.5
29646, 1.395652173913, 0.125, 0.5
29647, 1.4173913043478, 0.1375, 0.5
29648, 1.4391304347826, 0.125, 0.5
29649, 1.4608695652174, 0.1375, 0.5
29650, 1.4826086956522, 0.125, 0.5
29651, 1.504347826087, 0.1375, 0.5
29652, 1.5260869565217, 0.125, 0.5
29653, 1.5478260869565, 0.1375, 0.5
29654, 1.5695652173913, 0.125, 0.5
29655, 1.5913043478261, 0.1375, 0.5
29656, 1.6130434782609, 0.125, 0.5
29657, 1.6347826086957, 0.1375, 0.5
29658, 1.6565217391304, 0.125, 0.5
29659, 1.6782608695652, 0.1375, 0.5
29660, 1.7, 0.125, 0.5
29661, 1.7217391304348, 0.1375, 0.5
29662, 1.7434782608696, 0.125, 0.5
29663, 1.7652173913043, 0.1375, 0.5
29664, 1.7869565217391, 0.125, 0.5
29665, 1.8086956521739, 0.1375, 0.5
29666, 1.8304347826087, 0.125, 0.5
29667, 1.8521739130435, 0.1375, 0.5
29668, 1.8739130434783, 0.125, 0.5
29669, 1.895652173913, 0.1375, 0.5
29670, 1.9173913043478, 0.125, 0.5
29671, 1.9391304347826, 0.1375, 0.5
29672, 1.9608695652174, 0.125, 0.5
29673, 1.9826086956522, 0.1375, 0.5
29674, 2.004347826087, 0.125, 0.5
29675, 2.0260869565217, 0.1375, 0.5
29676, 2.0478260869565, 0.125, 0.5
29677, 2.0695652173913, 0.1375, 0.5
29678, 2.0913043478261, 0.125, 0.5
29679, 2.1130434782609, 0.1375, 0.5
29680, 2.1347826086957, 0.125, 0.5
29681, 2.1565217391304, 0.1375, 0.5
29682, 2.1782608695652, 0.125, 0.5
29683, 1.2434782608696, 0.1125, 0.5
29684, 1.2869565217391, 0.1125, 0.5
29685, 1.3304347826087, 0.1125, 0.5
29686, 1.3739130434783, 0.1125, 0.5
29687, 1.4173913043478, 0.1125, 0.5
29688, 1.4608695652174, 0.1125, 0.5
29689, 1.504347826087, 0.1125, 0.5
29690, 1.5478260869565, 0.1125, 0.5
29691, 1.5913043478261, 0.1125, 0.5
29692, 1.6347826086957, 0.1125, 0.5
29693, 1.6782608695652, 0.1125, 0.5
29694, 1.7217391304348, 0.1125, 0.5
29695, 1.7652173913043, 0.1125, 0.5
29696, 1.8086956521739, 0.1125, 0.5
29697, 1.8521739130435, 0.1125, 0.5
29698, 1.895652173913, 0.1125, 0.5
29699, 1.9391304347826, 0.1125, 0.5
29700, 1.9826086956522, 0.1125, 0.5
29701, 2.0260869565217, 0.1125, 0.5
29702, 2.0695652173913, 0.1125, 0.5
29703, 2.1130434782609, 0.1125, 0.5
29704, 2.1565217391304, 0.1125, 0.5
29705, 1.2434782608696, 0.125, 0
29706, 1.2869565217391, 0.125, 0
29707, 1.3304347826087, 0.125, 0
29708, 1.3739130434783, 0.125, 0
29709, 1.4173913043478, 0.125, 0
29710, 1.4608695652174, 0.125, 0
29711, 1.504347826087, 0.125, 0
29712, 1.5478260869565, 0.125, 0
29713, 1.5913043478261, 0.125, 0
29714, 1.6347826086957, 0.125, 0
29715, 1.6782608695652, 0.125, 0
29716, 1.7217391304348, 0.125, 0
29717, 1.7652173913043, 0.125, 0
29718, 1.8086956521739, 0.125, 0
29719, 1.8521739130435, 0.125, 0
29720, 1.895652173913, 0.125, 0
29721, 1.9391304347826, 0.125, 0
29722, 1.9826086956522, 0.125, 0
29723, 2.0260869565217, 0.125, 0
29724, 2.0695652173913, 0.125, 0
29725, 2.1130434782609, 0.125, 0
29726, 2.1565217391304, 0.125, 0
29727, 1.2434782608696, 0.1375, 0
29728, 1.2217391304348, 0.125, 0
29729, 1.2869565217391, 0.1375, 0
29730, 1.2652173913043, 0.125, 0
29731, 1.3304347826087, 0.1375, 0
29732, 1.3086956521739, 0.125, 0
29733, 1.3739130434783, 0.1375, 0
29734, 1.3521739130435, 0.125, 0
29735, 1.4173913043478, 0.1375, 0
29736, 1.395652173913, 0.125, 0
29737, 1.4608695652174, 0.1375, 0
29738, 1.4391304347826, 0.125, 0
29739, 1.504347826087, 0.1375, 0
29740, 1.4826086956522, 0.125, 0
29741, 1.5478260869565, 0.1375, 0
29742, 1.5260869565217, 0.125, 0
29743, 1.5913043478261, 0.1375, 0
29744, 1.5695652173913, 0.125, 0
29745, 1.6347826086957, 0.1375, 0
29746, 1.6130434782609, 0.125, 0
29747, 1.6782608695652, 0.1375, 0
29748, 1.6565217391304, 0.125, 0
29749, 1.7217391304348, 0.1375, 0
29750, 1.7, 0.125, 0
29751, 1.7652173913043, 0.1375, 0
29752, 1.7434782608696, 0.125, 0
29753, 1.8086956521739, 0.1375, 0
29754, 1.7869565217391, 0.125, 0
29755, 1.8521739130435, 0.1375, 0
29756, 1.8304347826087, 0.125, 0
29757, 1.895652173913, 0.1375, 0
29758, 1.8739130434783, 0.125, 0
29759, 1.9391304347826, 0.1375, 0
29760, 1.9173913043478, 0.125, 0
29761, 1.9826086956522, 0.1375, 0
29762, 1.9608695652174, 0.125, 0
29763, 2.0260869565217, 0.1375, 0
29764, 2.004347826087, 0.125, 0
29765, 2.0695652173913, 0.1375, 0
29766, 2.0478260869565, 0.125, 0
29767, 2.1130434782609, 0.1375, 0
29768, 2.0913043478261, 0.125, 0
29769, 2.1565217391304, 0.1375, 0
29770, 2.1347826086957, 0.125, 0
29771, 2.1782608695652, 0.125, 0
29772, 1.2434782608696, 0.1125, 0
29773, 1.2869565217391, 0.1125, 0
29774, 1.3304347826087, 0.1125, 0
29775, 1.3739130434783, 0.1125, 0
29776, 1.4173913043478, 0.1125, 0
29777, 1.4608695652174, 0.1125, 0
29778, 1.504347826087, 0.1125, 0
29779, 1.5478260869565, 0.1125, 0
29780, 1.5913043478261, 0.1125, 0
29781, 1.6347826086957, 0.1125, 0
29782, 1.6782608695652, 0.1125, 0
29783, 1.7217391304348, 0.1125, 0
29784, 1.7652173913043, 0.1125, 0
29785, 1.8086956521739, 0.1125, 0
29786, 1.8521739130435, 0.1125, 0
29787, 1.895652173913, 0.1125, 0
29788, 1.9391304347826, 0.1125, 0
29789, 1.9826086956522, 0.1125, 0
29790, 2.0260869565217, 0.1125, 0
29791, 2.0695652173913, 0.1125, 0
29792, 2.1130434782609, 0.1125, 0
29793, 2.1565217391304, 0.1125, 0
29794, 1.2, 0.125, 0.44444444444444
29795, 1.2, 0.125, 0.38888888888889
29796, 1.2, 0.125, 0.33333333333333
29797, 1.2, 0.125, 0.27777777777778
29798, 1.2, 0.125, 0.22222222222222
29799, 1.2, 0.125, 0.16666666666667
29800, 1.2, 0.125, 0.11111111111111
29801, 1.2, 0.125, 0.055555555555556
29802, 1.2, 0.1375, 0.44444444444444
29803, 1.2, 0.125, 0.47222222222222
29804, 1.2, 0.1375, 0.38888888888889
29805, 1.2, 0.125, 0.41666666666667
29806, 1.2, 0.1375, 0.33333333333333
29807, 1.2, 0.125, 0.36111111111111
29808, 1.2, 0.1375, 0.27777777777778
29809, 1.2, 0.125, 0.30555555555556
29810, 1.2, 0.1375, 0.22222222222222
29811, 1.2, 0.125, 0.25
29812, 1.2, 0.1375, 0.16666666666667
29813, 1.2, 0.125, 0.19444444444444
29814, 1.2, 0.1375, 0.11111111111111
29815, 1.2, 0.125, 0.13888888888889
29816, 1.2, 0.1375, 0.055555555555556
29817, 1.2, 0.125, 0.083333333333333
29818, 1.2, 0.125, 0.027777777777778
29819, 1.2, 0.1125, 0.44444444444444
29820, 1.2, 0.1125, 0.38888888888889
29821, 1.2, 0.1125, 0.33333333333333
29822, 1.2, 0.1125, 0.27777777777778
29823, 1.2, 0.1125, 0.22222222222222
29824, 1.2, 0.1125, 0.16666666666667
29825, 1.2, 0.1125, 0.11111111111111
29826, 1.2, 0.1125, 0.055555555555556
29827, 2.2, 0.125, 0.44444444444444
29828, 2.2, 0.125, 0.38888888888889
29829, 2.2, 0.125, 0.33333333333333
29830, 2.2, 0.125, 0.27777777777778
29831, 2.2, 0.125, 0.22222222222222
29832, 2.2, 0.125, 0.16666666666667
29833, 2.2, 0.125, 0.11111111111111
29834, 2.2, 0.125, 0.055555555555556
29835, 2.2, 0.125, 0.47222222222222
29836, 2.2, 0.1375, 0.44444444444444
29837, 2.2, 0.125, 0.41666666666667
29838, 2.2, 0.1375, 0.38888888888889
29839, 2.2, 0.125, 0.36111111111111
29840, 2.2, 0.1375, 0.33333333333333
29841, 2.2, 0.125, 0.30555555555556
29842, 2.2, 0.1375, 0.27777777777778
29843, 2.2, 0.125, 0.25
29844, 2.2, 0.1375, 0.22222222222222
29845, 2.2, 0.125, 0.19444444444444
29846, 2.2, 0.1375, 0.16666666666667
29847, 2.2, 0.125, 0.13888888888889
29848, 2.2, 0.1375, 0.11111111111111
29849, 2.2, 0.125, 0.083333333333333
29850, 2.2, 0.1375, 0.055555555555556
29851, 2.2, 0.125, 0.027777777777778
29852, 2.2, 0.1125, 0.44444444444444
29853, 2.2, 0.1125, 0.38888888888889
29854, 2.2, 0.1125, 0.33333333333333
29855, 2.2, 0.1125, 0.27777777777778
29856, 2.2, 0.1125, 0.22222222222222
29857, 2.2, 0.1125, 0.16666666666667
29858, 2.2, 0.1125, 0.11111111111111
29859, 2.2, 0.1125, 0.055555555555556
29860, 1.2434782608696, 0.1, 0.44444444444444
29861, 1.2434782608696, 0.1, 0.38888888888889
29862, 1.2434782608696, 0.1, 0.33333333333333
29863, 1.2434782608696, 0.1, 0.27777777777778
29864, 1.2434782608696, 0.1, 0.22222222222222
29865, 1.2434782608696, 0.1, 0.16666666666667
29866, 1.2434782608696, 0.1, 0.11111111111111
29867, 1.2434782608696, 0.1, 0.055555555555556
29868, 1.2869565217391, 0.1, 0.44444444444444
29869, 1.2869565217391, 0.1, 0.38888888888889
29870, 1.2869565217391, 0.1, 0.33333333333333
29871, 1.2869565217391, 0.1, 0.27777777777778
29872, 1.2869565217391, 0.1, 0.22222222222222
29873, 1.2869565217391, 0.1, 0.16666666666667
29874, 1.2869565217391, 0.1, 0.11111111111111
29875, 1.2869565217391, 0.1, 0.055555555555556
29876, 1.3304347826087, 0.1, 0.44444444444444
29877, 1.3304347826087, 0.1, 0.38888888888889
29878, 1.3304347826087, 0.1, 0.33333333333333
29879, 1.3304347826087, 0.1, 0.27777777777778
29880, 1.3304347826087, 0.1, 0.22222222222222
29881, 1.3304347826087, 0.1, 0.16666666666667
29882, 1.3304347826087, 0.1, 0.11111111111111
29883, 1.3304347826087, 0.1, 0.055555555555556
29884, 1.3739130434783, 0.1, 0.44444444444444
29885, 1.3739130434783, 0.1, 0.38888888888889
29886, 1.3739130434783, 0.1, 0.33333333333333
29887, 1.3739130434783, 0.1, 0.27777777777778
29888, 1.3739130434783, 0.1, 0.22222222222222
29889, 1.3739130434783, 0.1, 0.16666666666667
29890, 1.3739130434783, 0.1, 0.11111111111111
29891, 1.3739130434783, 0.1, 0.055555555555556
29892, 1.4173913043478, 0.1, 0.44444444444444
29893, 1.4173913043478, 0.1, 0.38888888888889
29894, 1.4173913043478, 0.1, 0.33333333333333
29895, 1.4173913043478, 0.1, 0.27777777777778
29896, 1.4173913043478, 0.1, 0.22222222222222
29897, 1.4173913043478, 0.1, 0.16666666666667
29898, 1.4173913043478, 0.1, 0.11111111111111
29899, 1.4173913043478, 0.1, 0.055555555555556
29900, 1.4608695652174, 0.1, 0.44444444444444
29901, 1.4608695652174, 0.1, 0.38888888888889
29902, 1.4608695652174, 0.1, 0.33333333333333
29903, 1.4608695652174, 0.1, 0.27777777777778
29904, 1.4608695652174, 0.1, 0.22222222222222
29905, 1.4608695652174, 0.1, 0.16666666666667
29906, 1.4608695652174, 0.1, 0.11111111111111
29907, 1.4608695652174, 0.1, 0.055555555555556
29908, 1.504347826087, 0.1, 0.44444444444444
29909, 1.504347826087, 0.1, 0.38888888888889
29910, 1.504347826087, 0.1, 0.33333333333333
29911, 1.504347826087, 0.1, 0.27777777777778
29912, 1.504347826087, 0.1, 0.22222222222222
29913, 1.504347826087, 0.1, 0.16666666666667
29914, 1.504347826087, 0.1, 0.11111111111111
29915, 1.504347826087, 0.1, 0.055555555555556
29916, 1.5478260869565, 0.1, 0.44444444444444
29917, 1.5478260869565, 0.1, 0.38888888888889
29918, 1.5478260869565, 0.1, 0.33333333333333
29919, 1.5478260869565, 0.1, 0.27777777777778
29920, 1.5478260869565, 0.1, 0.22222222222222
29921, 1.5478260869565, 0.1, 0.16666666666667
29922, 1.5478260869565, 0.1, 0.11111111111111
29923, 1.5478260869565, 0.1, 0.055555555555556
29924, 1.5913043478261, 0.1, 0.44444444444444
29925, 1.5913043478261, 0.1, 0.38888888888889
29926, 1.5913043478261, 0.1, 0.33333333333333
29927, 1.5913043478261, 0.1, 0.27777777777778
29928, 1.5913043478261, 0.1, 0.22222222222222
29929, 1.5913043478261, 0.1, 0.16666666666667
29930, 1.5913043478261, 0.1, 0.11111111111111
29931, 1.5913043478261, 0.1, 0.055555555555556
29932, 1.6347826086957, 0.1, 0.44444444444444
29933, 1.6347826086957, 0.1, 0.38888888888889
29934, 1.6347826086957, 0.1, 0.33333333333333
29935, 1.6347826086957, 0.1, 0.27777777777778
29936, 1.6347826086957, 0.1, 0.22222222222222
29937, 1.6347826086957, 0.1, 0.16666666666667
29938, 1.6347826086957, 0.1, 0.11111111111111
29939, 1.6347826086957, 0.1, 0.055555555555556
29940, 1.6782608695652, 0.1, 0.44444444444444
29941, 1.6782608695652, 0.1, 0.38888888888889
29942, 1.6782608695652, 0.1, 0.33333333333333
29943, 1.6782608695652, 0.1, 0.27777777777778
29944, 1.6782608695652, 0.1, 0.22222222222222
29945, 1.6782608695652, 0.1, 0.16666666666667
29946, 1.6782608695652, 0.1, 0.11111111111111
29947, 1.6782608695652, 0.1, 0.055555555555556
29948, 1.7217391304348, 0.1, 0.44444444444444
29949, 1.7217391304348, 0.1, 0.38888888888889
29950, 1.7217391304348, 0.1, 0.33333333333333
29951, 1.7217391304348, 0.1, 0.27777777777778
29952, 1.7217391304348, 0.1, 0.22222222222222
29953, 1.7217391304348, 0.1, 0.16666666666667
29954, 1.7217391304348, 0.1, 0.11111111111111
29955, 1.7217391304348, 0.1, 0.055555555555556
29956, 1.7652173913043, 0.1, 0.44444444444444
29957, 1.7652173913043, 0.1, 0.38888888888889
29958, 1.7652173913043, 0.1, 0.33333333333333
29959, 1.7652173913043, 0.1, 0.27777777777778
29960, 1.7652173913043, 0.1, 0.22222222222222
29961, 1.7652173913043, 0.1, 0.16666666666667
29962, 1.7652173913043, 0.1, 0.11111111111111
29963, 1.7652173913043, 0.1, 0.055555555555556
29964, 1.8086956521739, 0.1, 0.44444444444444
29965, 1.8086956521739, 0.1, 0.38888888888889
29966, 1.8086956521739, 0.1, 0.33333333333333
29967, 1.8086956521739, 0.1, 0.27777777777778
29968, 1.8086956521739, 0.1, 0.22222222222222
29969, 1.8086956521739, 0.1, 0.16666666666667
29970, 1.8086956521739, 0.1, 0.11111111111111
29971, 1.8086956521739, 0.1, 0.055555555555556
29972, 1.8521739130435, 0.1, 0.44444444444444
29973, 1.8521739130435, 0.1, 0.38888888888889
29974, 1.8521739130435, 0.1, 0.33333333333333
29975, 1.8521739130435, 0.1, 0.27777777777778
29976, 1.8521739130435, 0.1, 0.22222222222222
29977, 1.8521739130435, 0.1, 0.16666666666667
29978, 1.8521739130435, 0.1, 0.11111111111111
29979, 1.8521739130435, 0.1, 0.055555555555556
29980, 1.895652173913, 0.1, 0.44444444444444
29981, 1.895652173913, 0.1, 0.38888888888889
29982, 1.895652173913, 0.1, 0.33333333333333
29983, 1.895652173913, 0.1, 0.27777777777778
29984, 1.895652173913, 0.1, 0.22222222222222
29985, 1.895652173913, 0.1, 0.16666666666667
29986, 1.895652173913, 0.1, 0.11111111111111
29987, 1.895652173913, 0.1, 0.055555555555556
29988, 1.9391304347826, 0.1, 0.44444444444444
29989, 1.9391304347826, 0.1, 0.38888888888889
29990, 1.9391304347826, 0.1, 0.33333333333333
29991, 1.9391304347826, 0.1, 0.27777777777778
29992, 1.9391304347826, 0.1, 0.22222222222222
29993, 1.9391304347826, 0.1, 0.16666666666667
29994, 1.9391304347826, 0.1, 0.11111111111111
29995, 1.9391304347826, 0.1, 0.055555555555556
29996, 1.9826086956522, 0.1, 0.44444444444444
29997, 1.9826086956522, 0.1, 0.38888888888889
29998, 1.9826086956522, 0.1, 0.33333333333333
29999, 1.9826086956522, 0.1, 0.27777777777778
30000, 1.9826086956522, 0.1, 0.22222222222222
30001, 1.9826086956522, 0.1, 0.16666666666667
30002, 1.9826086956522, 0.1, 0.11111111111111
30003, 1.9826086956522, 0.1, 0.055555555555556
30004, 2.0260869565217, 0.1, 0.44444444444444
30005, 2.0260869565217, 0.1, 0.38888888888889
30006, 2.0260869565217, 0.1, 0.33333333333333
30007, 2.0260869565217, 0.1, 0.27777777777778
30008, 2.0260869565217, 0.1, 0.22222222222222
30009, 2.0260869565217, 0.1, 0.16666666666667
30010, 2.0260869565217, 0.1, 0.11111111111111
30011, 2.0260869565217, 0.1, 0.055555555555556
30012, 2.0695652173913, 0.1, 0.44444444444444
30013, 2.0695652173913, 0.1, 0.38888888888889
30014, 2.0695652173913, 0.1, 0.33333333333333
30015, 2.0695652173913, 0.1, 0.27777777777778
30016, 2.0695652173913, 0.1, 0.22222222222222
30017, 2.0695652173913, 0.1, 0.16666666666667
30018, 2.0695652173913, 0.1, 0.11111111111111
30019, 2.0695652173913, 0.1, 0.055555555555556
30020, 2.1130434782609, 0.1, 0.44444444444444
30021, 2.1130434782609, 0.1, 0.38888888888889
30022, 2.1130434782609, 0.1, 0.33333333333333
30023, 2.1130434782609, 0.1, 0.27777777777778
30024, 2.1130434782609, 0.1, 0.22222222222222
30025, 2.1130434782609, 0.1, 0.16666666666667
30026, 2.1130434782609, 0.1, 0.11111111111111
30027, 2.1130434782609, 0.1, 0.055555555555556
30028, 2.1565217391304, 0.1, 0.44444444444444
30029, 2.1565217391304, 0.1, 0.38888888888889
30030, 2.1565217391304, 0.1, 0.33333333333333
30031, 2.1565217391304, 0.1, 0.27777777777778
30032, 2.1565217391304, 0.1, 0.22222222222222
30033, 2.1565217391304, 0.1, 0.16666666666667
30034, 2.1565217391304, 0.1, 0.11111111111111
30035, 2.1565217391304, 0.1, 0.055555555555556
30036, 1.2217391304348, 0.1, 0.44444444444444
30037, 1.2434782608696, 0.1, 0.47222222222222
30038, 1.2217391304348, 0.1, 0.38888888888889
30039, 1.2434782608696, 0.1, 0.41666666666667
30040, 1.2217391304348, 0.1, 0.33333333333333
30041, 1.2434782608696, 0.1, 0.36111111111111
30042, 1.2217391304348, 0.1, 0.27777777777778
30043, 1.2434782608696, 0.1, 0.30555555555556
30044, 1.2217391304348, 0.1, 0.22222222222222
30045, 1.2434782608696, 0.1, 0.25
30046, 1.2217391304348, 0.1, 0.16666666666667
30047, 1.2434782608696, 0.1, 0.19444444444444
30048, 1.2217391304348, 0.1, 0.11111111111111
30049, 1.2434782608696, 0.1, 0.13888888888889
30050, 1.2217391304348, 0.1, 0.055555555555556
30051, 1.2434782608696, 0.1, 0.083333333333333
30052, 1.2434782608696, 0.1, 0.027777777777778
30053, 1.2652173913043, 0.1, 0.44444444444444
30054, 1.2869565217391, 0.1, 0.47222222222222
30055, 1.2652173913043, 0.1, 0.38888888888889
30056, 1.2869565217391, 0.1, 0.41666666666667
30057, 1.2652173913043, 0.1, 0.33333333333333
30058, 1.2869565217391, 0.1, 0.36111111111111
30059, 1.2652173913043, 0.1, 0.27777777777778
30060, 1.2869565217391, 0.1, 0.30555555555556
30061, 1.2652173913043, 0.1, 0.22222222222222
30062, 1.2869565217391, 0.1, 0.25
30063, 1.2652173913043, 0.1, 0.16666666666667
30064, 1.2869565217391, 0.1, 0.19444444444444
30065, 1.2652173913043, 0.1, 0.11111111111111
30066, 1.2869565217391, 0.1, 0.13888888888889
30067, 1.2652173913043, 0.1, 0.055555555555556
30068, 1.2869565217391, 0.1, 0.083333333333333
30069, 1.2869565217391, 0.1, 0.027777777777778
30070, 1.3086956521739, 0.1, 0.44444444444444
30071, 1.3304347826087, 0.1, 0.47222222222222
30072, 1.3086956521739, 0.1, 0.38888888888889
30073, 1.3304347826087, 0.1, 0.41666666666667
30074, 1.3086956521739, 0.1, 0.33333333333333
30075, 1.3304347826087, 0.1, 0.36111111111111
30076, 1.3086956521739, 0.1, 0.27777777777778
30077, 1.3304347826087, 0.1, 0.30555555555556
30078, 1.3086956521739, 0.1, 0.22222222222222
30079, 1.3304347826087, 0.1, 0.25
30080, 1.3086956521739, 0.1, 0.16666666666667
30081, 1.3304347826087, 0.1, 0.19444444444444
30082, 1.3086956521739, 0.1, 0.11111111111111
30083, 1.3304347826087, 0.1, 0.13888888888889
30084, 1.3086956521739, 0.1, 0.055555555555556
30085, 1.3304347826087, 0.1, 0.083333333333333
30086, 1.3304347826087, 0.1, 0.027777777777778
30087, 1.3521739130435, 0.1, 0.44444444444444
30088, 1.3739130434783, 0.1, 0.47222222222222
30089, 1.3521739130435, 0.1, 0.38888888888889
30090, 1.3739130434783, 0.1, 0.41666666666667
30091, 1.3521739130435, 0.1, 0.33333333333333
30092, 1.3739130434783, 0.1, 0.36111111111111
30093, 1.3521739130435, 0.1, 0.27777777777778
30094, 1.3739130434783, 0.1, 0.30555555555556
30095, 1.3521739130435, 0.1, 0.22222222222222
30096, 1.3739130434783, 0.1, 0.25
30097, 1.3521739130435, 0.1, 0.16666666666667
30098, 1.3739130434783, 0.1, 0.19444444444444
30099, 1.3521739130435, 0.1, 0.11111111111111
30100, 1.3739130434783, 0.1, 0.13888888888889
30101, 1.3521739130435, 0.1, 0.055555555555556
30102, 1.3739130434783, 0.1, 0.083333333333333
30103, 1.3739130434783, 0.1, 0.027777777777778
30104, 1.395652173913, 0.1, 0.44444444444444
30105, 1.4173913043478, 0.1, 0.47222222222222
30106, 1.395652173913, 0.1, 0.38888888888889
30107, 1.4173913043478, 0.1, 0.41666666666667
30108, 1.395652173913, 0.1, 0.33333333333333
30109, 1.4173913043478, 0.1, 0.36111111111111
30110, 1.395652173913, 0.1, 0.27777777777778
30111, 1.4173913043478, 0.1, 0.30555555555556
30112, 1.395652173913, 0.1, 0.22222222222222
30113, 1.4173913043478, 0.1, 0.25
30114, 1.395652173913, 0.1, 0.16666666666667
30115, 1.4173913043478, 0.1, 0.19444444444444
30116, 1.395652173913, 0.1, 0.11111111111111
30117, 1.4173913043478, 0.1, 0.13888888888889
30118, 1.395652173913, 0.1, 0.055555555555556
30119, 1.4173913043478, 0.1, 0.083333333333333
30120, 1.4173913043478, 0.1, 0.027777777777778
30121, 1.4391304347826, 0.1, 0.44444444444444
30122, 1.4608695652174, 0.1, 0.47222222222222
30123, 1.4391304347826, 0.1, 0.38888888888889
30124, 1.4608695652174, 0.1, 0.41666666666667
30125, 1.4391304347826, 0.1, 0.33333333333333
30126, 1.4608695652174, 0.1, 0.36111111111111
30127, 1.4391304347826, 0.1, 0.27777777777778
30128, 1.4608695652174, 0.1, 0.30555555555556
30129, 1.4391304347826, 0.1, 0.22222222222222
30130, 1.4608695652174, 0.1, 0.25
30131, 1.4391304347826, 0.1, 0.16666666666667
30132, 1.4608695652174, 0.1, 0.19444444444444
30133, 1.4391304347826, 0.1, 0.11111111111111
30134, 1.4608695652174, 0.1, 0.13888888888889
30135, 1.4391304347826, 0.1, 0.055555555555556
30136, 1.4608695652174, 0.1, 0.083333333333333
30137, 1.4608695652174, 0.1, 0.027777777777778
30138, 1.4826086956522, 0.1, 0.44444444444444
30139, 1.504347826087, 0.1, 0.47222222222222
30140, 1.4826086956522, 0.1, 0.38888888888889
30141, 1.504347826087, 0.1, 0.41666666666667
30142, 1.4826086956522, 0.1, 0.33333333333333
30143, 1.504347826087, 0.1, 0.36111111111111
30144, 1.4826086956522, 0.1, 0.27777777777778
30145, 1.504347826087, 0.1, 0.30555555555556
30146, 1.4826086956522, 0.1, 0.22222222222222
30147, 1.504347826087, 0.1, 0.25
30148, 1.4826086956522, 0.1, 0.16666666666667
30149, 1.504347826087, 0.1, 0.19444444444444
30150, 1.4826086956522, 0.1, 0.11111111111111
30151, 1.504347826087, 0.1, 0.13888888888889
30152, 1.4826086956522, 0.1, 0.055555555555556
30153, 1.504347826087, 0.1, 0.083333333333333
30154, 1.504347826087, 0.1, 0.027777777777778
30155, 1.5260869565217, 0.1, 0.44444444444444
30156, 1.5478260869565, 0.1, 0.47222222222222
30157, 1.5260869565217, 0.1, 0.38888888888889
30158, 1.5478260869565, 0.1, 0.41666666666667
30159, 1.5260869565217, 0.1, 0.33333333333333
30160, 1.5478260869565, 0.1, 0.36111111111111
30161, 1.5260869565217, 0.1, 0.27777777777778
30162, 1.5478260869565, 0.1, 0.30555555555556
30163, 1.5260869565217, 0.1, 0.22222222222222
30164, 1.5478260869565, 0.1, 0.25
30165, 1.5260869565217, 0.1, 0.16666666666667
30166, 1.5478260869565, 0.1, 0.19444444444444
30167, 1.5260869565217, 0.1, 0.11111111111111
30168, 1.5478260869565, 0.1, 0.13888888888889
30169, 1.5260869565217, 0.1, 0.055555555555556
30170, 1.5478260869565, 0.1, 0.083333333333333
30171, 1.5478260869565, 0.1, 0.027777777777778
30172, 1.5695652173913, 0.1, 0.44444444444444
30173, 1.5913043478261, 0.1, 0.47222222222222
30174, 1.5695652173913, 0.1, 0.38888888888889
30175, 1.5913043478261, 0.1, 0.41666666666667
30176, 1.5695652173913, 0.1, 0.33333333333333
30177, 1.5913043478261, 0.1, 0.36111111111111
30178, 1.5695652173913, 0.1, 0.27777777777778
30179, 1.5913043478261, 0.1, 0.30555555555556
30180, 1.5695652173913, 0.1, 0.22222222222222
30181, 1.5913043478261, 0.1, 0.25
30182, 1.5695652173913, 0.1, 0.16666666666667
30183, 1.5913043478261, 0.1, 0.19444444444444
30184, 1.5695652173913, 0.1, 0.11111111111111
30185, 1.5913043478261, 0.1, 0.13888888888889
30186, 1.5695652173913, 0.1, 0.055555555555556
30187, 1.5913043478261, 0.1, 0.083333333333333
30188, 1.5913043478261, 0.1, 0.027777777777778
30189, 1.6130434782609, 0.1, 0.44444444444444
30190, 1.6347826086957, 0.1, 0.47222222222222
30191, 1.6130434782609, 0.1, 0.38888888888889
30192, 1.6347826086957, 0.1, 0.41666666666667
30193, 1.6130434782609, 0.1, 0.33333333333333
30194, 1.6347826086957, 0.1, 0.36111111111111
30195, 1.6130434782609, 0.1, 0.27777777777778
30196, 1.6347826086957, 0.1, 0.30555555555556
30197, 1.6130434782609, 0.1, 0.22222222222222
30198, 1.6347826086957, 0.1, 0.25
30199, 1.6130434782609, 0.1, 0.16666666666667
30200, 1.6347826086957, 0.1, 0.19444444444444
30201, 1.6130434782609, 0.1, 0.11111111111111
30202, 1.6347826086957, 0.1, 0.13888888888889
30203, 1.6130434782609, 0.1, 0.055555555555556
30204, 1.6347826086957, 0.1, 0.083333333333333
30205, 1.6347826086957, 0.1, 0.027777777777778
30206, 1.6565217391304, 0.1, 0.44444444444444
30207, 1.6782608695652, 0.1, 0.47222222222222
30208, 1.6565217391304, 0.1, 0.38888888888889
30209, 1.6782608695652, 0.1, 0.41666666666667
30210, 1.6565217391304, 0.1, 0.33333333333333
30211, 1.6782608695652, 0.1, 0.36111111111111
30212, 1.6565217391304, 0.1, 0.27777777777778
30213, 1.6782608695652, 0.1, 0.30555555555556
30214, 1.6565217391304, 0.1, 0.22222222222222
30215, 1.6782608695652, 0.1, 0.25
30216, 1.6565217391304, 0.1, 0.16666666666667
30217, 1.6782608695652, 0.1, 0.19444444444444
30218, 1.6565217391304, 0.1, 0.11111111111111
30219, 1.6782608695652, 0.1, 0.13888888888889
30220, 1.6565217391304, 0.1, 0.055555555555556
30221, 1.6782608695652, 0.1, 0.083333333333333
30222, 1.6782608695652, 0.1, 0.027777777777778
30223, 1.7, 0.1, 0.44444444444444
30224, 1.7217391304348, 0.1, 0.47222222222222
30225, 1.7, 0.1, 0.38888888888889
30226, 1.7217391304348, 0.1, 0.41666666666667
30227, 1.7, 0.1, 0.33333333333333
30228, 1.7217391304348, 0.1, 0.36111111111111
30229, 1.7, 0.1, 0.27777777777778
30230, 1.7217391304348, 0.1, 0.30555555555556
30231, 1.7, 0.1, 0.22222222222222
30232, 1.7217391304348, 0.1, 0.25
30233, 1.7, 0.1, 0.16666666666667
30234, 1.7217391304348, 0.1, 0.19444444444444
30235, 1.7, 0.1, 0.11111111111111
30236, 1.7217391304348, 0.1, 0.13888888888889
30237, 1.7, 0.1, 0.055555555555556
30238, 1.7217391304348, 0.1, 0.083333333333333
30239, 1.7217391304348, 0.1, 0.027777777777778
30240, 1.7434782608696, 0.1, 0.44444444444444
30241, 1.7652173913043, 0.1, 0.47222222222222
30242, 1.7434782608696, 0.1, 0.38888888888889
30243, 1.7652173913043, 0.1, 0.41666666666667
30244, 1.7434782608696, 0.1, 0.33333333333333
30245, 1.7652173913043, 0.1, 0.36111111111111
30246, 1.7434782608696, 0.1, 0.27777777777778
30247, 1.7652173913043, 0.1, 0.30555555555556
30248, 1.7434782608696, 0.1, 0.22222222222222
30249, 1.7652173913043, 0.1, 0.25
30250, 1.7434782608696, 0.1, 0.16666666666667
30251, 1.7652173913043, 0.1, 0.19444444444444
30252, 1.7434782608696, 0.1, 0.11111111111111
30253, 1.7652173913043, 0.1, 0.13888888888889
30254, 1.7434782608696, 0.1, 0.055555555555556
30255, 1.7652173913043, 0.1, 0.083333333333333
30256, 1.7652173913043, 0.1, 0.027777777777778
30257, 1.7869565217391, 0.1, 0.44444444444444
30258, 1.8086956521739, 0.1, 0.47222222222222
30259, 1.7869565217391, 0.1, 0.38888888888889
30260, 1.8086956521739, 0.1, 0.41666666666667
30261, 1.7869565217391, 0.1, 0.33333333333333
30262, 1.8086956521739, 0.1, 0.36111111111111
30263, 1.7869565217391, 0.1, 0.27777777777778
30264, 1.8086956521739, 0.1, 0.30555555555556
30265, 1.7869565217391, 0.1, 0.22222222222222
30266, 1.8086956521739, 0.1, 0.25
30267, 1.7869565217391, 0.1, 0.16666666666667
30268, 1.8086956521739, 0.1, 0.19444444444444
30269, 1.7869565217391, 0.1, 0.11111111111111
30270, 1.8086956521739, 0.1, 0.13888888888889
30271, 1.7869565217391, 0.1, 0.055555555555556
30272, 1.8086956521739, 0.1, 0.083333333333333
30273, 1.8086956521739, 0.1, 0.027777777777778
30274, 1.8304347826087, 0.1, 0.44444444444444
30275, 1.8521739130435, 0.1, 0.47222222222222
30276, 1.8304347826087, 0.1, 0.38888888888889
30277, 1.8521739130435, 0.1, 0.41666666666667
30278, 1.8304347826087, 0.1, 0.33333333333333
30279, 1.8521739130435, 0.1, 0.36111111111111
30280, 1.8304347826087, 0.1, 0.27777777777778
30281, 1.8521739130435, 0.1, 0.30555555555556
30282, 1.8304347826087, 0.1, 0.22222222222222
30283, 1.8521739130435, 0.1, 0.25
30284, 1.8304347826087, 0.1, 0.16666666666667
30285, 1.8521739130435, 0.1, 0.19444444444444
30286, 1.8304347826087, 0.1, 0.11111111111111
30287, 1.8521739130435, 0.1, 0.13888888888889
30288, 1.8304347826087, 0.1, 0.055555555555556
30289, 1.8521739130435, 0.1, 0.083333333333333
30290, 1.8521739130435, 0.1, 0.027777777777778
30291, 1.8739130434783, 0.1, 0.44444444444444
30292, 1.895652173913, 0.1, 0.47222222222222
30293, 1.8739130434783, 0.1, 0.38888888888889
30294, 1.895652173913, 0.1, 0.41666666666667
30295, 1.8739130434783, 0.1, 0.33333333333333
30296, 1.895652173913, 0.1, 0.36111111111111
30297, 1.8739130434783, 0.1, 0.27777777777778
30298, 1.895652173913, 0.1, 0.30555555555556
30299, 1.8739130434783, 0.1, 0.22222222222222
30300, 1.895652173913, 0.1, 0.25
30301, 1.8739130434783, 0.1, 0.16666666666667
30302, 1.895652173913, 0.1, 0.19444444444444
30303, 1.8739130434783, 0.1, 0.11111111111111
30304, 1.895652173913, 0.1, 0.13888888888889
30305, 1.8739130434783, 0.1, 0.055555555555556
30306, 1.895652173913, 0.1, 0.083333333333333
30307, 1.895652173913, 0.1, 0.027777777777778
30308, 1.9173913043478, 0.1, 0.44444444444444
30309, 1.9391304347826, 0.1, 0.47222222222222
30310, 1.9173913043478, 0.1, 0.38888888888889
30311, 1.9391304347826, 0.1, 0.41666666666667
30312, 1.9173913043478, 0.1, 0.33333333333333
30313, 1.9391304347826, 0.1, 0.36111111111111
30314, 1.9173913043478, 0.1, 0.27777777777778
30315, 1.9391304347826, 0.1, 0.30555555555556
30316, 1.9173913043478, 0.1, 0.22222222222222
30317, 1.9391304347826, 0.1, 0.25
30318, 1.9173913043478, 0.1, 0.16666666666667
30319, 1.9391304347826, 0.1, 0.19444444444444
30320, 1.9173913043478, 0.1, 0.11111111111111
30321, 1.9391304347826, 0.1, 0.13888888888889
30322, 1.9173913043478, 0.1, 0.055555555555556
30323, 1.9391304347826, 0.1, 0.083333333333333
30324, 1.9391304347826, 0.1, 0.027777777777778
30325, 1.9608695652174, 0.1, 0.44444444444444
30326, 1.9826086956522, 0.1, 0.47222222222222
30327, 1.9608695652174, 0.1, 0.38888888888889
30328, 1.9826086956522, 0.1, 0.41666666666667
30329, 1.9608695652174, 0.1, 0.33333333333333
30330, 1.9826086956522, 0.1, 0.36111111111111
30331, 1.9608695652174, 0.1, 0.27777777777778
30332, 1.9826086956522, 0.1, 0.30555555555556
30333, 1.9608695652174, 0.1, 0.22222222222222
30334, 1.9826086956522, 0.1, 0.25
30335, 1.9608695652174, 0.1, 0.16666666666667
30336, 1.9826086956522, 0.1, 0.19444444444444
30337, 1.9608695652174, 0.1, 0.11111111111111
30338, 1.9826086956522, 0.1, 0.13888888888889
30339, 1.9608695652174, 0.1, 0.055555555555556
30340, 1.9826086956522, 0.1, 0.083333333333333
30341, 1.9826086956522, 0.1, 0.027777777777778
30342, 2.004347826087, 0.1, 0.44444444444444
30343, 2.0260869565217, 0.1, 0.47222222222222
30344, 2.004347826087, 0.1, 0.38888888888889
30345, 2.0260869565217, 0.1, 0.41666666666667
30346, 2.004347826087, 0.1, 0.33333333333333
30347, 2.0260869565217, 0.1, 0.36111111111111
30348, 2.004347826087, 0.1, 0.27777777777778
30349, 2.0260869565217, 0.1, 0.30555555555556
30350, 2.004347826087, 0.1, 0.22222222222222
30351, 2.0260869565217, 0.1, 0.25
30352, 2.004347826087, 0.1, 0.16666666666667
30353, 2.0260869565217, 0.1, 0.19444444444444
30354, 2.004347826087, 0.1, 0.11111111111111
30355, 2.0260869565217, 0.1, 0.13888888888889
30356, 2.004347826087, 0.1, 0.055555555555556
30357, 2.0260869565217, 0.1, 0.083333333333333
30358, 2.0260869565217, 0.1, 0.027777777777778
30359, 2.0478260869565, 0.1, 0.44444444444444
30360, 2.0695652173913, 0.1, 0.47222222222222
30361, 2.0478260869565, 0.1, 0.38888888888889
30362, 2.0695652173913, 0.1, 0.41666666666667
30363, 2.0478260869565, 0.1, 0.33333333333333
30364, 2.0695652173913, 0.1, 0.36111111111111
30365, 2.0478260869565, 0.1, 0.27777777777778
30366, 2.0695652173913, 0.1, 0.30555555555556
30367, 2.0478260869565, 0.1, 0.22222222222222
30368, 2.0695652173913, 0.1, 0.25
30369, 2.0478260869565, 0.1, 0.16666666666667
30370, 2.0695652173913, 0.1, 0.19444444444444
30371, 2.0478260869565, 0.1, 0.11111111111111
30372, 2.0695652173913, 0.1, 0.13888888888889
30373, 2.0478260869565, 0.1, 0.055555555555556
30374, 2.0695652173913, 0.1, 0.083333333333333
30375, 2.0695652173913, 0.1, 0.027777777777778
30376, 2.0913043478261, 0.1, 0.44444444444444
30377, 2.1130434782609, 0.1, 0.47222222222222
30378, 2.0913043478261, 0.1, 0.38888888888889
30379, 2.1130434782609, 0.1, 0.41666666666667
30380, 2.0913043478261, 0.1, 0.33333333333333
30381, 2.1130434782609, 0.1, 0.36111111111111
30382, 2.0913043478261, 0.1, 0.27777777777778
30383, 2.1130434782609, 0.1, 0.30555555555556
30384, 2.0913043478261, 0.1, 0.22222222222222
30385, 2.1130434782609, 0.1, 0.25
30386, 2.0913043478261, 0.1, 0.16666666666667
30387, 2.1130434782609, 0.1, 0.19444444444444
30388, 2.0913043478261, 0.1, 0.11111111111111
30389, 2.1130434782609, 0.1, 0.13888888888889
30390, 2.0913043478261, 0.1, 0.055555555555556
30391, 2.1130434782609, 0.1, 0.083333333333333
30392, 2.1130434782609, 0.1, 0.027777777777778
30393, 2.1347826086957, 0.1, 0.44444444444444
30394, 2.1565217391304, 0.1, 0.47222222222222
30395, 2.1347826086957, 0.1, 0.38888888888889
30396, 2.1565217391304, 0.1, 0.41666666666667
30397, 2.1347826086957, 0.1, 0.33333333333333
30398, 2.1565217391304, 0.1, 0.36111111111111
30399, 2.1347826086957, 0.1, 0.27777777777778
30400, 2.1565217391304, 0.1, 0.30555555555556
30401, 2.1347826086957, 0.1, 0.22222222222222
30402, 2.1565217391304, 0.1, 0.25
30403, 2.1347826086957, 0.1, 0.16666666666667
30404, 2.1565217391304, 0.1, 0.19444444444444
30405, 2.1347826086957, 0.1, 0.11111111111111
30406, 2.1565217391304, 0.1, 0.13888888888889
30407, 2.1347826086957, 0.1, 0.055555555555556
30408, 2.1565217391304, 0.1, 0.083333333333333
30409, 2.1565217391304, 0.1, 0.027777777777778
30410, 2.1782608695652, 0.1, 0.44444444444444
30411, 2.1782608695652, 0.1, 0.38888888888889
30412, 2.1782608695652, 0.1, 0.33333333333333
30413, 2.1782608695652, 0.1, 0.27777777777778
30414, 2.1782608695652, 0.1, 0.22222222222222
30415, 2.1782608695652, 0.1, 0.16666666666667
30416, 2.1782608695652, 0.1, 0.11111111111111
30417, 2.1782608695652, 0.1, 0.055555555555556
30418, 1.2434782608696, 0.075, 0.5
30419, 1.2869565217391, 0.075, 0.5
30420, 1.3304347826087, 0.075, 0.5
30421, 1.3739130434783, 0.075, 0.5
30422, 1.4173913043478, 0.075, 0.5
30423, 1.4608695652174, 0.075, 0.5
30424, 1.504347826087, 0.075, 0.5
30425, 1.5478260869565, 0.075, 0.5
30426, 1.5913043478261, 0.075, 0.5
30427, 1.6347826086957, 0.075, 0.5
30428, 1.6782608695652, 0.075, 0.5
30429, 1.7217391304348, 0.075, 0.5
30430, 1.7652173913043, 0.075, 0.5
30431, 1.8086956521739, 0.075, 0.5
30432, 1.8521739130435, 0.075, 0.5
30433, 1.895652173913, 0.075, 0.5
30434, 1.9391304347826, 0.075, 0.5
30435, 1.9826086956522, 0.075, 0.5
30436, 2.0260869565217, 0.075, 0.5
30437, 2.0695652173913, 0.075, 0.5
30438, 2.1130434782609, 0.075, 0.5
30439, 2.1565217391304, 0.075, 0.5
30440, 1.2434782608696, 0.0625, 0.5
30441, 1.2217391304348, 0.075, 0.5
30442, 1.2869565217391, 0.0625, 0.5
30443, 1.2652173913043, 0.075, 0.5
30444, 1.3304347826087, 0.0625, 0.5
30445, 1.3086956521739, 0.075, 0.5
30446, 1.3739130434783, 0.0625, 0.5
30447, 1.3521739130435, 0.075, 0.5
30448, 1.4173913043478, 0.0625, 0.5
30449, 1.395652173913, 0.075, 0.5
30450, 1.4608695652174, 0.0625, 0.5
30451, 1.4391304347826, 0.075, 0.5
30452, 1.504347826087, 0.0625, 0.5
30453, 1.4826086956522, 0.075, 0.5
30454, 1.5478260869565, 0.0625, 0.5
30455, 1.5260869565217, 0.075, 0.5
30456, 1.5913043478261, 0.0625, 0.5
30457, 1.5695652173913, 0.075, 0.5
30458, 1.6347826086957, 0.0625, 0.5
30459, 1.6130434782609, 0.075, 0.5
30460, 1.6782608695652, 0.0625, 0.5
30461, 1.6565217391304, 0.075, 0.5
30462, 1.7217391304348, 0.0625, 0.5
30463, 1.7, 0.075, 0.5
30464, 1.7652173913043, 0.0625, 0.5
30465, 1.7434782608696, 0.075, 0.5
30466, 1.8086956521739, 0.0625, 0.5
30467, 1.7869565217391, 0.075, 0.5
30468, 1.8521739130435, 0.0625, 0.5
30469, 1.8304347826087, 0.075, 0.5
30470, 1.895652173913, 0.0625, 0.5
30471, 1.8739130434783, 0.075, 0.5
30472, 1.9391304347826, 0.0625, 0.5
30473, 1.9173913043478, 0.075, 0.5
30474, 1.9826086956522, 0.0625, 0.5
30475, 1.9608695652174, 0.075, 0.5
30476, 2.0260869565217, 0.0625, 0.5
30477, 2.004347826087, 0.075, 0.5
30478, 2.0695652173913, 0.0625, 0.5
30479, 2.0478260869565, 0.075, 0.5
30480, 2.1130434782609, 0.0625, 0.5
30481, 2.0913043478261, 0.075, 0.5
30482, 2.1565217391304, 0.0625, 0.5
30483, 2.1347826086957, 0.075, 0.5
30484, 2.1782608695652, 0.075, 0.5
30485, 1.2434782608696, 0.0875, 0.5
30486, 1.2869565217391, 0.0875, 0.5
30487, 1.3304347826087, 0.0875, 0.5
30488, 1.3739130434783, 0.0875, 0.5
30489, 1.4173913043478, 0.0875, 0.5
30490, 1.4608695652174, 0.0875, 0.5
30491, 1.504347826087, 0.0875, 0.5
30492, 1.5478260869565, 0.0875, 0.5
30493, 1.5913043478261, 0.0875, 0.5
30494, 1.6347826086957, 0.0875, 0.5
30495, 1.6782608695652, 0.0875, 0.5
30496, 1.7217391304348, 0.0875, 0.5
30497, 1.7652173913043, 0.0875, 0.5
30498, 1.8086956521739, 0.0875, 0.5
30499, 1.8521739130435, 0.0875, 0.5
30500, 1.895652173913, 0.0875, 0.5
30501, 1.9391304347826, 0.0875, 0.5
30502, 1.9826086956522, 0.0875, 0.5
30503, 2.0260869565217, 0.0875, 0.5
30504, 2.0695652173913, 0.0875, 0.5
30505, 2.1130434782609, 0.0875, 0.5
30506, 2.1565217391304, 0.0875, 0.5
30507, 1.2434782608696, 0.075, 0
30508, 1.2869565217391, 0.075, 0
30509, 1.3304347826087, 0.075, 0
30510, 1.3739130434783, 0.075, 0
30511, 1.4173913043478, 0.075, 0
30512, 1.4608695652174, 0.075, 0
30513, 1.504347826087, 0.075, 0
30514, 1.5478260869565, 0.075, 0
30515, 1.5913043478261, 0.075, 0
30516, 1.6347826086957, 0.075, 0
30517, 1.6782608695652, 0.075, 0
30518, 1.7217391304348, 0.075, 0
30519, 1.7652173913043, 0.075, 0
30520, 1.8086956521739, 0.075, 0
30521, 1.8521739130435, 0.075, 0
30522, 1.895652173913, 0.075, 0
30523, 1.9391304347826, 0.075, 0
30524, 1.9826086956522, 0.075, 0
30525, 2.0260869565217, 0.075, 0
30526, 2.0695652173913, 0.075, 0
30527, 2.1130434782609, 0.075, 0
30528, 2.1565217391304, 0.075, 0
30529, 1.2217391304348, 0.075, 0
30530, 1.2434782608696, 0.0625, 0
30531, 1.2652173913043, 0.075, 0
30532, 1.2869565217391, 0.0625, 0
30533, 1.3086956521739, 0.075, 0
30534, 1.3304347826087, 0.0625, 0
30535, 1.3521739130435, 0.075, 0
30536, 1.3739130434783, 0.0625, 0
30537, 1.395652173913, 0.075, 0
30538, 1.4173913043478, 0.0625, 0
30539, 1.4391304347826, 0.075, 0
30540, 1.4608695652174, 0.0625, 0
30541, 1.4826086956522, 0.075, 0
30542, 1.504347826087, 0.0625, 0
30543, 1.5260869565217, 0.075, 0
30544, 1.5478260869565, 0.0625, 0
30545, 1.5695652173913, 0.075, 0
30546, 1.5913043478261, 0.0625, 0
30547, 1.6130434782609, 0.075, 0
30548, 1.6347826086957, 0.0625, 0
30549, 1.6565217391304, 0.075, 0
30550, 1.6782608695652, 0.0625, 0
30551, 1.7, 0.075, 0
30552, 1.7217391304348, 0.0625, 0
30553, 1.7434782608696, 0.075, 0
30554, 1.7652173913043, 0.0625, 0
30555, 1.7869565217391, 0.075, 0
30556, 1.8086956521739, 0.0625, 0
30557, 1.8304347826087, 0.075, 0
30558, 1.8521739130435, 0.0625, 0
30559, 1.8739130434783, 0.075, 0
30560, 1.895652173913, 0.0625, 0
30561, 1.9173913043478, 0.075, 0
30562, 1.9391304347826, 0.0625, 0
30563, 1.9608695652174, 0.075, 0
30564, 1.9826086956522, 0.0625, 0
30565, 2.004347826087, 0.075, 0
30566, 2.0260869565217, 0.0625, 0
30567, 2.0478260869565, 0.075, 0
30568, 2.0695652173913, 0.0625, 0
30569, 2.0913043478261, 0.075, 0
30570, 2.1130434782609, 0.0625, 0
30571, 2.1347826086957, 0.075, 0
30572, 2.1565217391304, 0.0625, 0
30573, 2.1782608695652, 0.075, 0
30574, 1.2434782608696, 0.0875, 0
30575, 1.2869565217391, 0.0875, 0
30576, 1.3304347826087, 0.0875, 0
30577, 1.3739130434783, 0.0875, 0
30578, 1.4173913043478, 0.0875, 0
30579, 1.4608695652174, 0.0875, 0
30580, 1.504347826087, 0.0875, 0
30581, 1.5478260869565, 0.0875, 0
30582, 1.5913043478261, 0.0875, 0
30583, 1.6347826086957, 0.0875, 0
30584, 1.6782608695652, 0.0875, 0
30585, 1.7217391304348, 0.0875, 0
30586, 1.7652173913043, 0.0875, 0
30587, 1.8086956521739, 0.0875, 0
30588, 1.8521739130435, 0.0875, 0
30589, 1.895652173913, 0.0875, 0
30590, 1.9391304347826, 0.0875, 0
30591, 1.9826086956522, 0.0875, 0
30592, 2.0260869565217, 0.0875, 0
30593, 2.0695652173913, 0.0875, 0
30594, 2.1130434782609, 0.0875, 0
30595, 2.1565217391304, 0.0875, 0
30596, 1.2, 0.075, 0.44444444444444
30597, 1.2, 0.075, 0.38888888888889
30598, 1.2, 0.075, 0.33333333333333
30599, 1.2, 0.075, 0.27777777777778
30600, 1.2, 0.075, 0.22222222222222
30601, 1.2, 0.075, 0.16666666666667
30602, 1.2, 0.075, 0.11111111111111
30603, 1.2, 0.075, 0.055555555555556
30604, 1.2, 0.075, 0.47222222222222
30605, 1.2, 0.0625, 0.44444444444444
30606, 1.2, 0.075, 0.41666666666667
30607, 1.2, 0.0625, 0.38888888888889
30608, 1.2, 0.075, 0.36111111111111
30609, 1.2, 0.0625, 0.33333333333333
30610, 1.2, 0.075, 0.30555555555556
30611, 1.2, 0.0625, 0.27777777777778
30612, 1.2, 0.075, 0.25
30613, 1.2, 0.0625, 0.22222222222222
30614, 1.2, 0.075, 0.19444444444444
30615, 1.2, 0.0625, 0.16666666666667
30616, 1.2, 0.075, 0.13888888888889
30617, 1.2, 0.0625, 0.11111111111111
30618, 1.2, 0.075, 0.083333333333333
30619, 1.2, 0.0625, 0.055555555555556
30620, 1.2, 0.075, 0.027777777777778
30621, 1.2, 0.0875, 0.44444444444444
30622, 1.2, 0.0875, 0.38888888888889
30623, 1.2, 0.0875, 0.33333333333333
30624, 1.2, 0.0875, 0.27777777777778
30625, 1.2, 0.0875, 0.22222222222222
30626, 1.2, 0.0875, 0.16666666666667
30627, 1.2, 0.0875, 0.11111111111111
30628, 1.2, 0.0875, 0.055555555555556
30629, 2.2, 0.075, 0.44444444444444
30630, 2.2, 0.075, 0.38888888888889
30631, 2.2, 0.075, 0.33333333333333
30632, 2.2, 0.075, 0.27777777777778
30633, 2.2, 0.075, 0.22222222222222
30634, 2.2, 0.075, 0.16666666666667
30635, 2.2, 0.075, 0.11111111111111
30636, 2.2, 0.075, 0.055555555555556
30637, 2.2, 0.0625, 0.44444444444444
30638, 2.2, 0.075, 0.47222222222222
30639, 2.2, 0.0625, 0.38888888888889
30640, 2.2, 0.075, 0.41666666666667
30641, 2.2, 0.0625, 0.33333333333333
30642, 2.2, 0.075, 0.36111111111111
30643, 2.2, 0.0625, 0.27777777777778
30644, 2.2, 0.075, 0.30555555555556
30645, 2.2, 0.0625, 0.22222222222222
30646, 2.2, 0.075, 0.25
30647, 2.2, 0.0625, 0.16666666666667
30648, 2.2, 0.075, 0.19444444444444
30649, 2.2, 0.0625, 0.11111111111111
30650, 2.2, 0.075, 0.13888888888889
30651, 2.2, 0.0625, 0.055555555555556
30652, 2.2, 0.075, 0.083333333333333
30653, 2.2, 0.075, 0.027777777777778
30654, 2.2, 0.0875, 0.44444444444444
30655, 2.2, 0.0875, 0.38888888888889
30656, 2.2, 0.0875, 0.33333333333333
30657, 2.2, 0.0875, 0.27777777777778
30658, 2.2, 0.0875, 0.22222222222222
30659, 2.2, 0.0875, 0.16666666666667
30660, 2.2, 0.0875, 0.11111111111111
30661, 2.2, 0.0875, 0.055555555555556
30662, 0.95652173913043, 0.075, 0
30663, 0.91304347826087, 0.075, 0
30664, 0.8695652173913, 0.075, 0
30665, 0.82608695652174, 0.075, 0
30666, 0.78260869565217, 0.075, 0
30667, 0.73913043478261, 0.075, 0
30668, 0.69565217391304, 0.075, 0
30669, 0.65217391304348, 0.075, 0
30670, 0.60869565217391, 0.075, 0
30671, 0.56521739130435, 0.075, 0
30672, 0.52173913043478, 0.075, 0
30673, 0.47826086956522, 0.075, 0
30674, 0.43478260869565, 0.075, 0
30675, 0.39130434782609, 0.075, 0
30676, 0.34782608695652, 0.075, 0
30677, 0.30434782608696, 0.075, 0
30678, 0.26086956521739, 0.075, 0
30679, 0.21739130434783, 0.075, 0
30680, 0.17391304347826, 0.075, 0
30681, 0.1304347826087, 0.075, 0
30682, 0.08695652173913, 0.075, 0
30683, 0.043478260869565, 0.075, 0
30684, 0.95652173913043, 0.0625, 0
30685, 0.97826086956522, 0.075, 0
30686, 0.91304347826087, 0.0625, 0
30687, 0.93478260869565, 0.075, 0
30688, 0.8695652173913, 0.0625, 0
30689, 0.89130434782609, 0.075, 0
30690, 0.82608695652174, 0.0625, 0
30691, 0.84782608695652, 0.075, 0
30692, 0.78260869565217, 0.0625, 0
30693, 0.80434782608696, 0.075, 0
30694, 0.73913043478261, 0.0625, 0
30695, 0.76086956521739, 0.075, 0
30696, 0.69565217391304, 0.0625, 0
30697, 0.71739130434783, 0.075, 0
30698, 0.65217391304348, 0.0625, 0
30699, 0.67391304347826, 0.075, 0
30700, 0.60869565217391, 0.0625, 0
30701, 0.6304347826087, 0.075, 0
30702, 0.56521739130435, 0.0625, 0
30703, 0.58695652173913, 0.075, 0
30704, 0.52173913043478, 0.0625, 0
30705, 0.54347826086957, 0.075, 0
30706, 0.47826086956522, 0.0625, 0
30707, 0.5, 0.075, 0
30708, 0.43478260869565, 0.0625, 0
30709, 0.45652173913043, 0.075, 0
30710, 0.39130434782609, 0.0625, 0
30711, 0.41304347826087, 0.075, 0
30712, 0.34782608695652, 0.0625, 0
30713, 0.3695652173913, 0.075, 0
30714, 0.30434782608696, 0.0625, 0
30715, 0.32608695652174, 0.075, 0
30716, 0.26086956521739, 0.0625, 0
30717, 0.28260869565217, 0.075, 0
30718, 0.21739130434783, 0.0625, 0
30719, 0.23913043478261, 0.075, 0
30720, 0.17391304347826, 0.0625, 0
30721, 0.19565217391304, 0.075, 0
30722, 0.1304347826087, 0.0625, 0
30723, 0.15217391304348, 0.075, 0
30724, 0.08695652173913, 0.0625, 0
30725, 0.10869565217391, 0.075, 0
30726, 0.043478260869565, 0.0625, 0
30727, 0.065217391304348, 0.075, 0
30728, 0.021739130434783, 0.075, 0
30729, 0.95652173913043, 0.0875, 0
30730, 0.91304347826087, 0.0875, 0
30731, 0.8695652173913, 0.0875, 0
30732, 0.82608695652174, 0.0875, 0
30733, 0.78260869565217, 0.0875, 0
30734, 0.73913043478261, 0.0875, 0
30735, 0.69565217391304, 0.0875, 0
30736, 0.65217391304348, 0.0875, 0
30737, 0.60869565217391, 0.0875, 0
30738, 0.56521739130435, 0.0875, 0
30739, 0.52173913043478, 0.0875, 0
30740, 0.47826086956522, 0.0875, 0
30741, 0.43478260869565, 0.0875, 0
30742, 0.39130434782609, 0.0875, 0
30743, 0.34782608695652, 0.0875, 0
30744, 0.30434782608696, 0.0875, 0
30745, 0.26086956521739, 0.0875, 0
30746, 0.21739130434783, 0.0875, 0
30747, 0.17391304347826, 0.0875, 0
30748, 0.1304347826087, 0.0875, 0
30749, 0.08695652173913, 0.0875, 0
30750, 0.043478260869565, 0.0875, 0
30751, 1, 0.075, 0.44444444444444
30752, 1, 0.075, 0.38888888888889
30753, 1, 0.075, 0.33333333333333
30754, 1, 0.075, 0.27777777777778
30755, 1, 0.075, 0.22222222222222
30756, 1, 0.075, 0.16666666666667
30757, 1, 0.075, 0.11111111111111
30758, 1, 0.075, 0.055555555555556
30759, 1, 0.0625, 0.44444444444444
30760, 1, 0.075, 0.47222222222222
30761, 1, 0.0625, 0.38888888888889
30762, 1, 0.075, 0.41666666666667
30763, 1, 0.0625, 0.33333333333333
30764, 1, 0.075, 0.36111111111111
30765, 1, 0.0625, 0.27777777777778
30766, 1, 0.075, 0.30555555555556
30767, 1, 0.0625, 0.22222222222222
30768, 1, 0.075, 0.25
30769, 1, 0.0625, 0.16666666666667
30770, 1, 0.075, 0.19444444444444
30771, 1, 0.0625, 0.11111111111111
30772, 1, 0.075, 0.13888888888889
30773, 1, 0.0625, 0.055555555555556
30774, 1, 0.075, 0.083333333333333
30775, 1, 0.075, 0.027777777777778
30776, 1, 0.0875, 0.44444444444444
30777, 1, 0.0875, 0.38888888888889
30778, 1, 0.0875, 0.33333333333333
30779, 1, 0.0875, 0.27777777777778
30780, 1, 0.0875, 0.22222222222222
30781, 1, 0.0875, 0.16666666666667
30782, 1, 0.0875, 0.11111111111111
30783, 1, 0.0875, 0.055555555555556
30784, 0.95652173913043, 0.075, 0.5
30785, 0.91304347826087, 0.075, 0.5
30786, 0.8695652173913, 0.075, 0.5
30787, 0.82608695652174, 0.075, 0.5
30788, 0.78260869565217, 0.075, 0.5
30789, 0.73913043478261, 0.075, 0.5
30790, 0.69565217391304, 0.075, 0.5
30791, 0.65217391304348, 0.075, 0.5
30792, 0.60869565217391, 0.075, 0.5
30793, 0.56521739130435, 0.075, 0.5
30794, 0.52173913043478, 0.075, 0.5
30795, 0.47826086956522, 0.075, 0.5
30796, 0.43478260869565, 0.075, 0.5
30797, 0.39130434782609, 0.075, 0.5
30798, 0.34782608695652, 0.075, 0.5
30799, 0.30434782608696, 0.075, 0.5
30800, 0.26086956521739, 0.075, 0.5
30801, 0.21739130434783, 0.075, 0.5
30802, 0.17391304347826, 0.075, 0.5
30803, 0.1304347826087, 0.075, 0.5
30804, 0.08695652173913, 0.075, 0.5
30805, 0.043478260869565, 0.075, 0.5
30806, 0.97826086956522, 0.075, 0.5
30807, 0.95652173913043, 0.0625, 0.5
30808, 0.93478260869565, 0.075, 0.5
30809, 0.91304347826087, 0.0625, 0.5
30810, 0.89130434782609, 0.075, 0.5
30811, 0.8695652173913, 0.0625, 0.5
30812, 0.84782608695652, 0.075, 0.5
30813, 0.82608695652174, 0.0625, 0.5
30814, 0.80434782608696, 0.075, 0.5
30815, 0.78260869565217, 0.0625, 0.5
30816, 0.76086956521739, 0.075, 0.5
30817, 0.73913043478261, 0.0625, 0.5
30818, 0.71739130434783, 0.075, 0.5
30819, 0.69565217391304, 0.0625, 0.5
30820, 0.67391304347826, 0.075, 0.5
30821, 0.65217391304348, 0.0625, 0.5
30822, 0.6304347826087, 0.075, 0.5
30823, 0.60869565217391, 0.0625, 0.5
30824, 0.58695652173913, 0.075, 0.5
30825, 0.56521739130435, 0.0625, 0.5
30826, 0.54347826086957, 0.075, 0.5
30827, 0.52173913043478, 0.0625, 0.5
30828, 0.5, 0.075, 0.5
30829, 0.47826086956522, 0.0625, 0.5
30830, 0.45652173913043, 0.075, 0.5
30831, 0.43478260869565, 0.0625, 0.5
30832, 0.41304347826087, 0.075, 0.5
30833, 0.39130434782609, 0.0625, 0.5
30834, 0.3695652173913, 0.075, 0.5
30835, 0.34782608695652, 0.0625, 0.5
30836, 0.32608695652174, 0.075, 0.5
30837, 0.30434782608696, 0.0625, 0.5
30838, 0.28260869565217, 0.075, 0.5
30839, 0.26086956521739, 0.0625, 0.5
30840, 0.23913043478261, 0.075, 0.5
30841, 0.21739130434783, 0.0625, 0.5
30842, 0.19565217391304, 0.075, 0.5
30843, 0.17391304347826, 0.0625, 0.5
30844, 0.15217391304348, 0.075, 0.5
30845, 0.1304347826087, 0.0625, 0.5
30846, 0.10869565217391, 0.075, 0.5
30847, 0.08695652173913, 0.0625, 0.5
30848, 0.065217391304348, 0.075, 0.5
30849, 0.043478260869565, 0.0625, 0.5
30850, 0.021739130434783, 0.075, 0.5
30851, 0.95652173913043, 0.0875, 0.5
30852, 0.91304347826087, 0.0875, 0.5
30853, 0.8695652173913, 0.0875, 0.5
30854, 0.82608695652174, 0.0875, 0.5
30855, 0.78260869565217, 0.0875, 0.5
30856, 0.73913043478261, 0.0875, 0.5
30857, 0.69565217391304, 0.0875, 0.5
30858, 0.65217391304348, 0.0875, 0.5
30859, 0.60869565217391, 0.0875, 0.5
30860, 0.56521739130435, 0.0875, 0.5
30861, 0.52173913043478, 0.0875, 0.5
30862, 0.47826086956522, 0.0875, 0.5
30863, 0.43478260869565, 0.0875, 0.5
30864, 0.39130434782609, 0.0875, 0.5
30865, 0.34782608695652, 0.0875, 0.5
30866, 0.30434782608696, 0.0875, 0.5
30867, 0.26086956521739, 0.0875, 0.5
30868, 0.21739130434783, 0.0875, 0.5
30869, 0.17391304347826, 0.0875, 0.5
30870, 0.1304347826087, 0.0875, 0.5
30871, 0.08695652173913, 0.0875, 0.5
30872, 0.043478260869565, 0.0875, 0.5
30873, 0, 0.075, 0.44444444444444
30874, 0, 0.075, 0.38888888888889
30875, 0, 0.075, 0.33333333333333
30876, 0, 0.075, 0.27777777777778
30877, 0, 0.075, 0.22222222222222
30878, 0, 0.075, 0.16666666666667
30879, 0, 0.075, 0.11111111111111
30880, 0, 0.075, 0.055555555555556
30881, 0, 0.075, 0.47222222222222
30882, 0, 0.0625, 0.44444444444444
30883, 0, 0.075, 0.41666666666667
30884, 0, 0.0625, 0.38888888888889
30885, 0, 0.075, 0.36111111111111
30886, 0, 0.0625, 0.33333333333333
30887, 0, 0.075, 0.30555555555556
30888, 0, 0.0625, 0.27777777777778
30889, 0, 0.075, 0.25
30890, 0, 0.0625, 0.22222222222222
30891, 0, 0.075, 0.19444444444444
30892, 0, 0.0625, 0.16666666666667
30893, 0, 0.075, 0.13888888888889
30894, 0, 0.0625, 0.11111111111111
30895, 0, 0.075, 0.083333333333333
30896, 0, 0.0625, 0.055555555555556
30897, 0, 0.075, 0.027777777777778
30898, 0, 0.0875, 0.44444444444444
30899, 0, 0.0875, 0.38888888888889
30900, 0, 0.0875, 0.33333333333333
30901, 0, 0.0875, 0.27777777777778
30902, 0, 0.0875, 0.22222222222222
30903, 0, 0.0875, 0.16666666666667
30904, 0, 0.0875, 0.11111111111111
30905, 0, 0.0875, 0.055555555555556
30906, 1.0375, 0.20217391304348, 0.5
30907, 1.0375, 0.25434782608696, 0.5
30908, 1.0375, 0.30652173913043, 0.5
30909, 1.0375, 0.35869565217391, 0.5
30910, 1.0375, 0.41086956521739, 0.5
30911, 1.0375, 0.46304347826087, 0.5
30912, 1.0375, 0.51521739130435, 0.5
30913, 1.0375, 0.56739130434783, 0.5
30914, 1.0375, 0.6195652173913, 0.5
30915, 1.0375, 0.67173913043478, 0.5
30916, 1.0375, 0.72391304347826, 0.5
30917, 1.0375, 0.77608695652174, 0.5
30918, 1.0375, 0.82826086956522, 0.5
30919, 1.0375, 0.88043478260869, 0.5
30920, 1.0375, 0.93260869565217, 0.5
30921, 1.0375, 0.98478260869565, 0.5
30922, 1.0375, 1.0369565217391, 0.5
30923, 1.0375, 1.0891304347826, 0.5
30924, 1.0375, 1.1413043478261, 0.5
30925, 1.0375, 1.1934782608696, 0.5
30926, 1.0375, 1.245652173913, 0.5
30927, 1.0375, 1.2978260869565, 0.5
30928, 1.0375, 0.17608695652174, 0.5
30929, 1.01875, 0.20217391304348, 0.5
30930, 1.0375, 0.22826086956522, 0.5
30931, 1.01875, 0.25434782608696, 0.5
30932, 1.0375, 0.2804347826087, 0.5
30933, 1.01875, 0.30652173913043, 0.5
30934, 1.0375, 0.33260869565217, 0.5
30935, 1.01875, 0.35869565217391, 0.5
30936, 1.0375, 0.38478260869565, 0.5
30937, 1.01875, 0.41086956521739, 0.5
30938, 1.0375, 0.43695652173913, 0.5
30939, 1.01875, 0.46304347826087, 0.5
30940, 1.0375, 0.48913043478261, 0.5
30941, 1.01875, 0.51521739130435, 0.5
30942, 1.0375, 0.54130434782609, 0.5
30943, 1.01875, 0.56739130434783, 0.5
30944, 1.0375, 0.59347826086956, 0.5
30945, 1.01875, 0.6195652173913, 0.5
30946, 1.0375, 0.64565217391304, 0.5
30947, 1.01875, 0.67173913043478, 0.5
30948, 1.0375, 0.69782608695652, 0.5
30949, 1.01875, 0.72391304347826, 0.5
30950, 1.0375, 0.75, 0.5
30951, 1.01875, 0.77608695652174, 0.5
30952, 1.0375, 0.80217391304348, 0.5
30953, 1.01875, 0.82826086956522, 0.5
30954, 1.0375, 0.85434782608696, 0.5
30955, 1.01875, 0.88043478260869, 0.5
30956, 1.0375, 0.90652173913043, 0.5
30957, 1.01875, 0.93260869565217, 0.5
30958, 1.0375, 0.95869565217391, 0.5
30959, 1.01875, 0.98478260869565, 0.5
30960, 1.0375, 1.0108695652174, 0.5
30961, 1.01875, 1.0369565217391, 0.5
30962, 1.0375, 1.0630434782609, 0.5
30963, 1.01875, 1.0891304347826, 0.5
30964, 1.0375, 1.1152173913043, 0.5
30965, 1.01875, 1.1413043478261, 0.5
30966, 1.0375, 1.1673913043478, 0.5
30967, 1.01875, 1.1934782608696, 0.5
30968, 1.0375, 1.2195652173913, 0.5
30969, 1.01875, 1.245652173913, 0.5
30970, 1.0375, 1.2717391304348, 0.5
30971, 1.01875, 1.2978260869565, 0.5
30972, 1.0375, 1.3239130434783, 0.5
30973, 1.05625, 0.20217391304348, 0.5
30974, 1.05625, 0.25434782608696, 0.5
30975, 1.05625, 0.30652173913043, 0.5
30976, 1.05625, 0.35869565217391, 0.5
30977, 1.05625, 0.41086956521739, 0.5
30978, 1.05625, 0.46304347826087, 0.5
30979, 1.05625, 0.51521739130435, 0.5
30980, 1.05625, 0.56739130434783, 0.5
30981, 1.05625, 0.6195652173913, 0.5
30982, 1.05625, 0.67173913043478, 0.5
30983, 1.05625, 0.72391304347826, 0.5
30984, 1.05625, 0.77608695652174, 0.5
30985, 1.05625, 0.82826086956522, 0.5
30986, 1.05625, 0.88043478260869, 0.5
30987, 1.05625, 0.93260869565217, 0.5
30988, 1.05625, 0.98478260869565, 0.5
30989, 1.05625, 1.0369565217391, 0.5
30990, 1.05625, 1.0891304347826, 0.5
30991, 1.05625, 1.1413043478261, 0.5
30992, 1.05625, 1.1934782608696, 0.5
30993, 1.05625, 1.245652173913, 0.5
30994, 1.05625, 1.2978260869565, 0.5
30995, 1.0375, 0.20217391304348, 0
30996, 1.0375, 0.25434782608696, 0
30997, 1.0375, 0.30652173913043, 0
30998, 1.0375, 0.35869565217391, 0
30999, 1.0375, 0.41086956521739, 0
31000, 1.0375, 0.46304347826087, 0
31001, 1.0375, 0.51521739130435, 0
31002, 1.0375, 0.56739130434783, 0
31003, 1.0375, 0.6195652173913, 0
31004, 1.0375, 0.67173913043478, 0
31005, 1.0375, 0.72391304347826, 0
31006, 1.0375, 0.77608695652174, 0
31007, 1.0375, 0.82826086956522, 0
31008, 1.0375, 0.88043478260869, 0
31009, 1.0375, 0.93260869565217, 0
31010, 1.0375, 0.98478260869565, 0
31011, 1.0375, 1.0369565217391, 0
31012, 1.0375, 1.0891304347826, 0
31013, 1.0375, 1.1413043478261, 0
31014, 1.0375, 1.1934782608696, 0
31015, 1.0375, 1.245652173913, 0
31016, 1.0375, 1.2978260869565, 0
31017, 1.01875, 0.20217391304348, 0
31018, 1.0375, 0.17608695652174, 0
31019, 1.01875, 0.25434782608696, 0
31020, 1.0375, 0.22826086956522, 0
31021, 1.01875, 0.30652173913043, 0
31022, 1.0375, 0.2804347826087, 0
31023, 1.01875, 0.35869565217391, 0
31024, 1.0375, 0.33260869565217, 0
31025, 1.01875, 0.41086956521739, 0
31026, 1.0375, 0.38478260869565, 0
31027, 1.01875, 0.46304347826087, 0
31028, 1.0375, 0.43695652173913, 0
31029, 1.01875, 0.51521739130435, 0
31030, 1.0375, 0.48913043478261, 0
31031, 1.01875, 0.56739130434783, 0
31032, 1.0375, 0.54130434782609, 0
31033, 1.01875, 0.6195652173913, 0
31034, 1.0375, 0.59347826086956, 0
31035, 1.01875, 0.67173913043478, 0
31036, 1.0375, 0.64565217391304, 0
31037, 1.01875, 0.72391304347826, 0
31038, 1.0375, 0.69782608695652, 0
31039, 1.01875, 0.77608695652174, 0
31040, 1.0375, 0.75, 0
31041, 1.01875, 0.82826086956522, 0
31042, 1.0375, 0.80217391304348, 0
31043, 1.01875, 0.88043478260869, 0
31044, 1.0375, 0.85434782608696, 0
31045, 1.01875, 0.93260869565217, 0
31046, 1.0375, 0.90652173913043, 0
31047, 1.01875, 0.98478260869565, 0
31048, 1.0375, 0.95869565217391, 0
31049, 1.01875, 1.0369565217391, 0
31050, 1.0375, 1.0108695652174, 0
31051, 1.01875, 1.0891304347826, 0
31052, 1.0375, 1.0630434782609, 0
31053, 1.01875, 1.1413043478261, 0
31054, 1.0375, 1.1152173913043, 0
31055, 1.01875, 1.1934782608696, 0
31056, 1.0375, 1.1673913043478, 0
31057, 1.01875, 1.245652173913, 0
31058, 1.0375, 1.2195652173913, 0
31059, 1.01875, 1.2978260869565, 0
31060, 1.0375, 1.2717391304348, 0
31061, 1.0375, 1.3239130434783, 0
31062, 1.05625, 0.20217391304348, 0
31063, 1.05625, 0.25434782608696, 0
31064, 1.05625, 0.30652173913043, 0
31065, 1.05625, 0.35869565217391, 0
31066, 1.05625, 0.41086956521739, 0
31067, 1.05625, 0.46304347826087, 0
31068, 1.05625, 0.51521739130435, 0
31069, 1.05625, 0.56739130434783, 0
31070, 1.05625, 0.6195652173913, 0
31071, 1.05625, 0.67173913043478, 0
31072, 1.05625, 0.72391304347826, 0
31073, 1.05625, 0.77608695652174, 0
31074, 1.05625, 0.82826086956522, 0
31075, 1.05625, 0.88043478260869, 0
31076, 1.05625, 0.93260869565217, 0
31077, 1.05625, 0.98478260869565, 0
31078, 1.05625, 1.0369565217391, 0
31079, 1.05625, 1.0891304347826, 0
31080, 1.05625, 1.1413043478261, 0
31081, 1.05625, 1.1934782608696, 0
31082, 1.05625, 1.245652173913, 0
31083, 1.05625, 1.2978260869565, 0
31084, 1.0375, 0.15, 0.44444444444444
31085, 1.0375, 0.15, 0.38888888888889
31086, 1.0375, 0.15, 0.33333333333333
31087, 1.0375, 0.15, 0.27777777777778
31088, 1.0375, 0.15, 0.22222222222222
31089, 1.0375, 0.15, 0.16666666666667
31090, 1.0375, 0.15, 0.11111111111111
31091, 1.0375, 0.15, 0.055555555555556
31092, 1.01875, 0.15, 0.44444444444444
31093, 1.0375, 0.15, 0.47222222222222
31094, 1.01875, 0.15, 0.38888888888889
31095, 1.0375, 0.15, 0.41666666666667
31096, 1.01875, 0.15, 0.33333333333333
31097, 1.0375, 0.15, 0.36111111111111
31098, 1.01875, 0.15, 0.27777777777778
31099, 1.0375, 0.15, 0.30555555555556
31100, 1.01875, 0.15, 0.22222222222222
31101, 1.0375, 0.15, 0.25
31102, 1.01875, 0.15, 0.16666666666667
31103, 1.0375, 0.15, 0.19444444444444
31104, 1.01875, 0.15, 0.11111111111111
31105, 1.0375, 0.15, 0.13888888888889
31106, 1.01875, 0.15, 0.055555555555556
31107, 1.0375, 0.15, 0.083333333333333
31108, 1.0375, 0.15, 0.027777777777778
31109, 1.05625, 0.15, 0.44444444444444
31110, 1.05625, 0.15, 0.38888888888889
31111, 1.05625, 0.15, 0.33333333333333
31112, 1.05625, 0.15, 0.27777777777778
31113, 1.05625, 0.15, 0.22222222222222
31114, 1.05625, 0.15, 0.16666666666667
31115, 1.05625, 0.15, 0.11111111111111
31116, 1.05625, 0.15, 0.055555555555556
31117, 1.0375, 1.35, 0.44444444444444
31118, 1.0375, 1.35, 0.38888888888889
31119, 1.0375, 1.35, 0.33333333333333
31120, 1.0375, 1.35, 0.27777777777778
31121, 1.0375, 1.35, 0.22222222222222
31122, 1.0375, 1.35, 0.16666666666667
31123, 1.0375, 1.35, 0.11111111111111
31124, 1.0375, 1.35, 0.055555555555556
31125, 1.0375, 1.35, 0.47222222222222
31126, 1.01875, 1.35, 0.44444444444444
31127, 1.0375, 1.35, 0.41666666666667
31128, 1.01875, 1.35, 0.38888888888889
31129, 1.0375, 1.35, 0.36111111111111
31130, 1.01875, 1.35, 0.33333333333333
31131, 1.0375, 1.35, 0.30555555555556
31132, 1.01875, 1.35, 0.27777777777778
31133, 1.0375, 1.35, 0.25
31134, 1.01875, 1.35, 0.22222222222222
31135, 1.0375, 1.35, 0.19444444444444
31136, 1.01875, 1.35, 0.16666666666667
31137, 1.0375, 1.35, 0.13888888888889
31138, 1.01875, 1.35, 0.11111111111111
31139, 1.0375, 1.35, 0.083333333333333
31140, 1.01875, 1.35, 0.055555555555556
31141, 1.0375, 1.35, 0.027777777777778
31142, 1.05625, 1.35, 0.44444444444444
31143, 1.05625, 1.35, 0.38888888888889
31144, 1.05625, 1.35, 0.33333333333333
31145, 1.05625, 1.35, 0.27777777777778
31146, 1.05625, 1.35, 0.22222222222222
31147, 1.05625, 1.35, 0.16666666666667
31148, 1.05625, 1.35, 0.11111111111111
31149, 1.05625, 1.35, 0.055555555555556
31150, 1.075, 0.20217391304348, 0.44444444444444
31151, 1.075, 0.20217391304348, 0.38888888888889
31152, 1.075, 0.20217391304348, 0.33333333333333
31153, 1.075, 0.20217391304348, 0.27777777777778
31154, 1.075, 0.20217391304348, 0.22222222222222
31155, 1.075, 0.20217391304348, 0.16666666666667
31156, 1.075, 0.20217391304348, 0.11111111111111
31157, 1.075, 0.20217391304348, 0.055555555555556
31158, 1.075, 0.25434782608696, 0.44444444444444
31159, 1.075, 0.25434782608696, 0.38888888888889
31160, 1.075, 0.25434782608696, 0.33333333333333
31161, 1.075, 0.25434782608696, 0.27777777777778
31162, 1.075, 0.25434782608696, 0.22222222222222
31163, 1.075, 0.25434782608696, 0.16666666666667
31164, 1.075, 0.25434782608696, 0.11111111111111
31165, 1.075, 0.25434782608696, 0.055555555555556
31166, 1.075, 0.30652173913043, 0.44444444444444
31167, 1.075, 0.30652173913043, 0.38888888888889
31168, 1.075, 0.30652173913043, 0.33333333333333
31169, 1.075, 0.30652173913043, 0.27777777777778
31170, 1.075, 0.30652173913043, 0.22222222222222
31171, 1.075, 0.30652173913043, 0.16666666666667
31172, 1.075, 0.30652173913043, 0.11111111111111
31173, 1.075, 0.30652173913043, 0.055555555555556
31174, 1.075, 0.35869565217391, 0.44444444444444
31175, 1.075, 0.35869565217391, 0.38888888888889
31176, 1.075, 0.35869565217391, 0.33333333333333
31177, 1.075, 0.35869565217391, 0.27777777777778
31178, 1.075, 0.35869565217391, 0.22222222222222
31179, 1.075, 0.35869565217391, 0.16666666666667
31180, 1.075, 0.35869565217391, 0.11111111111111
31181, 1.075, 0.35869565217391, 0.055555555555556
31182, 1.075, 0.41086956521739, 0.44444444444444
31183, 1.075, 0.41086956521739, 0.38888888888889
31184, 1.075, 0.41086956521739, 0.33333333333333
31185, 1.075, 0.41086956521739, 0.27777777777778
31186, 1.075, 0.41086956521739, 0.22222222222222
31187, 1.075, 0.41086956521739, 0.16666666666667
31188, 1.075, 0.41086956521739, 0.11111111111111
31189, 1.075, 0.41086956521739, 0.055555555555556
31190, 1.075, 0.46304347826087, 0.44444444444444
31191, 1.075, 0.46304347826087, 0.38888888888889
31192, 1.075, 0.46304347826087, 0.33333333333333
31193, 1.075, 0.46304347826087, 0.27777777777778
31194, 1.075, 0.46304347826087, 0.22222222222222
31195, 1.075, 0.46304347826087, 0.16666666666667
31196, 1.075, 0.46304347826087, 0.11111111111111
31197, 1.075, 0.46304347826087, 0.055555555555556
31198, 1.075, 0.51521739130435, 0.44444444444444
31199, 1.075, 0.51521739130435, 0.38888888888889
31200, 1.075, 0.51521739130435, 0.33333333333333
31201, 1.075, 0.51521739130435, 0.27777777777778
31202, 1.075, 0.51521739130435, 0.22222222222222
31203, 1.075, 0.51521739130435, 0.16666666666667
31204, 1.075, 0.51521739130435, 0.11111111111111
31205, 1.075, 0.51521739130435, 0.055555555555556
31206, 1.075, 0.56739130434783, 0.44444444444444
31207, 1.075, 0.56739130434783, 0.38888888888889
31208, 1.075, 0.56739130434783, 0.33333333333333
31209, 1.075, 0.56739130434783, 0.27777777777778
31210, 1.075, 0.56739130434783, 0.22222222222222
31211, 1.075, 0.56739130434783, 0.16666666666667
31212, 1.075, 0.56739130434783, 0.11111111111111
31213, 1.075, 0.56739130434783, 0.055555555555556
31214, 1.075, 0.6195652173913, 0.44444444444444
31215, 1.075, 0.6195652173913, 0.38888888888889
31216, 1.075, 0.6195652173913, 0.33333333333333
31217, 1.075, 0.6195652173913, 0.27777777777778
31218, 1.075, 0.6195652173913, 0.22222222222222
31219, 1.075, 0.6195652173913, 0.16666666666667
31220, 1.075, 0.6195652173913, 0.11111111111111
31221, 1.075, 0.6195652173913, 0.055555555555556
31222, 1.075, 0.67173913043478, 0.44444444444444
31223, 1.075, 0.67173913043478, 0.38888888888889
31224, 1.075, 0.67173913043478, 0.33333333333333
31225, 1.075, 0.67173913043478, 0.27777777777778
31226, 1.075, 0.67173913043478, 0.22222222222222
31227, 1.075, 0.67173913043478, 0.16666666666667
31228, 1.075, 0.67173913043478, 0.11111111111111
31229, 1.075, 0.67173913043478, 0.055555555555556
31230, 1.075, 0.72391304347826, 0.44444444444444
31231, 1.075, 0.72391304347826, 0.38888888888889
31232, 1.075, 0.72391304347826, 0.33333333333333
31233, 1.075, 0.72391304347826, 0.27777777777778
31234, 1.075, 0.72391304347826, 0.22222222222222
31235, 1.075, 0.72391304347826, 0.16666666666667
31236, 1.075, 0.72391304347826, 0.11111111111111
31237, 1.075, 0.72391304347826, 0.055555555555556
