85537, 0.56521739130435, -0.1, 0.27777777777778
85538, 0.56521739130435, -0.1, 0.33333333333333
85539, 0.56521739130435, -0.1, 0.38888888888889
85540, 0.56521739130435, -0.1, 0.44444444444444
85541, 0.52173913043478, -0.1, 0.055555555555556
85542, 0.52173913043478, -0.1, 0.11111111111111
85543, 0.52173913043478, -0.1, 0.16666666666667
85544, 0.52173913043478, -0.1, 0.22222222222222
85545, 0.52173913043478, -0.1, 0.27777777777778
85546, 0.52173913043478, -0.1, 0.33333333333333
85547, 0.52173913043478, -0.1, 0.38888888888889
85548, 0.52173913043478, -0.1, 0.44444444444444
85549, 0.47826086956522, -0.1, 0.055555555555556
85550, 0.47826086956522, -0.1, 0.11111111111111
85551, 0.47826086956522, -0.1, 0.16666666666667
85552, 0.47826086956522, -0.1, 0.22222222222222
85553, 0.47826086956522, -0.1, 0.27777777777778
85554, 0.47826086956522, -0.1, 0.33333333333333
85555, 0.47826086956522, -0.1, 0.38888888888889
85556, 0.47826086956522, -0.1, 0.44444444444444
85557, 0.43478260869565, -0.1, 0.055555555555556
85558, 0.43478260869565, -0.1, 0.11111111111111
85559, 0.43478260869565, -0.1, 0.16666666666667
85560, 0.43478260869565, -0.1, 0.22222222222222
85561, 0.43478260869565, -0.1, 0.27777777777778
85562, 0.43478260869565, -0.1, 0.33333333333333
85563, 0.43478260869565, -0.1, 0.38888888888889
85564, 0.43478260869565, -0.1, 0.44444444444444
85565, 0.39130434782609, -0.1, 0.055555555555556
85566, 0.39130434782609, -0.1, 0.11111111111111
85567, 0.39130434782609, -0.1, 0.16666666666667
85568, 0.39130434782609, -0.1, 0.22222222222222
85569, 0.39130434782609, -0.1, 0.27777777777778
85570, 0.39130434782609, -0.1, 0.33333333333333
85571, 0.39130434782609, -0.1, 0.38888888888889
85572, 0.39130434782609, -0.1, 0.44444444444444
85573, 0.34782608695652, -0.1, 0.055555555555556
85574, 0.34782608695652, -0.1, 0.11111111111111
85575, 0.34782608695652, -0.1, 0.16666666666667
85576, 0.34782608695652, -0.1, 0.22222222222222
85577, 0.34782608695652, -0.1, 0.27777777777778
85578, 0.34782608695652, -0.1, 0.33333333333333
85579, 0.34782608695652, -0.1, 0.38888888888889
85580, 0.34782608695652, -0.1, 0.44444444444444
85581, 0.30434782608696, -0.1, 0.055555555555556
85582, 0.30434782608696, -0.1, 0.11111111111111
85583, 0.30434782608696, -0.1, 0.16666666666667
85584, 0.30434782608696, -0.1, 0.22222222222222
85585, 0.30434782608696, -0.1, 0.27777777777778
85586, 0.30434782608696, -0.1, 0.33333333333333
85587, 0.30434782608696, -0.1, 0.38888888888889
85588, 0.30434782608696, -0.1, 0.44444444444444
85589, 0.26086956521739, -0.1, 0.055555555555556
85590, 0.26086956521739, -0.1, 0.11111111111111
85591, 0.26086956521739, -0.1, 0.16666666666667
85592, 0.26086956521739, -0.1, 0.22222222222222
85593, 0.26086956521739, -0.1, 0.27777777777778
85594, 0.26086956521739, -0.1, 0.33333333333333
85595, 0.26086956521739, -0.1, 0.38888888888889
85596, 0.26086956521739, -0.1, 0.44444444444444
85597, 0.21739130434783, -0.1, 0.055555555555556
85598, 0.21739130434783, -0.1, 0.11111111111111
85599, 0.21739130434783, -0.1, 0.16666666666667
85600, 0.21739130434783, -0.1, 0.22222222222222
85601, 0.21739130434783, -0.1, 0.27777777777778
85602, 0.21739130434783, -0.1, 0.33333333333333
85603, 0.21739130434783, -0.1, 0.38888888888889
85604, 0.21739130434783, -0.1, 0.44444444444444
85605, 0.17391304347826, -0.1, 0.055555555555556
85606, 0.17391304347826, -0.1, 0.11111111111111
85607, 0.17391304347826, -0.1, 0.16666666666667
85608, 0.17391304347826, -0.1, 0.22222222222222
85609, 0.17391304347826, -0.1, 0.27777777777778
85610, 0.17391304347826, -0.1, 0.33333333333333
85611, 0.17391304347826, -0.1, 0.38888888888889
85612, 0.17391304347826, -0.1, 0.44444444444444
85613, 0.1304347826087, -0.1, 0.055555555555556
85614, 0.1304347826087, -0.1, 0.11111111111111
85615, 0.1304347826087, -0.1, 0.16666666666667
85616, 0.1304347826087, -0.1, 0.22222222222222
85617, 0.1304347826087, -0.1, 0.27777777777778
85618, 0.1304347826087, -0.1, 0.33333333333333
85619, 0.1304347826087, -0.1, 0.38888888888889
85620, 0.1304347826087, -0.1, 0.44444444444444
85621, 0.08695652173913, -0.1, 0.055555555555556
85622, 0.08695652173913, -0.1, 0.11111111111111
85623, 0.08695652173913, -0.1, 0.16666666666667
85624, 0.08695652173913, -0.1, 0.22222222222222
85625, 0.08695652173913, -0.1, 0.27777777777778
85626, 0.08695652173913, -0.1, 0.33333333333333
85627, 0.08695652173913, -0.1, 0.38888888888889
85628, 0.08695652173913, -0.1, 0.44444444444444
85629, 0.043478260869565, -0.1, 0.055555555555556
85630, 0.043478260869565, -0.1, 0.11111111111111
85631, 0.043478260869565, -0.1, 0.16666666666667
85632, 0.043478260869565, -0.1, 0.22222222222222
85633, 0.043478260869565, -0.1, 0.27777777777778
85634, 0.043478260869565, -0.1, 0.33333333333333
85635, 0.043478260869565, -0.1, 0.38888888888889
85636, 0.043478260869565, -0.1, 0.44444444444444
85637, 0.95652173913043, -0.15, 0.055555555555556
85638, 0.95652173913044, -0.15, 0.11111111111111
85639, 0.95652173913044, -0.15, 0.16666666666667
85640, 0.95652173913044, -0.15, 0.22222222222222
85641, 0.95652173913044, -0.15, 0.27777777777778
85642, 0.95652173913043, -0.15, 0.33333333333333
85643, 0.95652173913044, -0.15, 0.38888888888889
85644, 0.95652173913044, -0.15, 0.44444444444444
85645, 0.91304347826087, -0.15, 0.055555555555556
85646, 0.91304347826087, -0.15, 0.11111111111111
85647, 0.91304347826087, -0.15, 0.16666666666667
85648, 0.91304347826087, -0.15, 0.22222222222222
85649, 0.91304347826087, -0.15, 0.27777777777778
85650, 0.91304347826087, -0.15, 0.33333333333333
85651, 0.91304347826087, -0.15, 0.38888888888889
85652, 0.91304347826087, -0.15, 0.44444444444444
85653, 0.8695652173913, -0.15, 0.055555555555556
85654, 0.8695652173913, -0.15, 0.11111111111111
85655, 0.8695652173913, -0.15, 0.16666666666667
85656, 0.8695652173913, -0.15, 0.22222222222222
85657, 0.8695652173913, -0.15, 0.27777777777778
85658, 0.8695652173913, -0.15, 0.33333333333333
85659, 0.8695652173913, -0.15, 0.38888888888889
85660, 0.8695652173913, -0.15, 0.44444444444444
85661, 0.82608695652174, -0.15, 0.055555555555556
85662, 0.82608695652174, -0.15, 0.11111111111111
85663, 0.82608695652174, -0.15, 0.16666666666667
85664, 0.82608695652174, -0.15, 0.22222222222222
85665, 0.82608695652174, -0.15, 0.27777777777778
85666, 0.82608695652174, -0.15, 0.33333333333333
85667, 0.82608695652174, -0.15, 0.38888888888889
85668, 0.82608695652174, -0.15, 0.44444444444444
85669, 0.78260869565217, -0.15, 0.055555555555556
85670, 0.78260869565217, -0.15, 0.11111111111111
85671, 0.78260869565217, -0.15, 0.16666666666667
85672, 0.78260869565217, -0.15, 0.22222222222222
85673, 0.78260869565217, -0.15, 0.27777777777778
85674, 0.78260869565217, -0.15, 0.33333333333333
85675, 0.78260869565217, -0.15, 0.38888888888889
85676, 0.78260869565217, -0.15, 0.44444444444444
85677, 0.73913043478261, -0.15, 0.055555555555556
85678, 0.73913043478261, -0.15, 0.11111111111111
85679, 0.73913043478261, -0.15, 0.16666666666667
85680, 0.73913043478261, -0.15, 0.22222222222222
85681, 0.73913043478261, -0.15, 0.27777777777778
85682, 0.73913043478261, -0.15, 0.33333333333333
85683, 0.73913043478261, -0.15, 0.38888888888889
85684, 0.73913043478261, -0.15, 0.44444444444444
85685, 0.69565217391304, -0.15, 0.055555555555556
85686, 0.69565217391304, -0.15, 0.11111111111111
85687, 0.69565217391304, -0.15, 0.16666666666667
85688, 0.69565217391304, -0.15, 0.22222222222222
85689, 0.69565217391304, -0.15, 0.27777777777778
85690, 0.69565217391304, -0.15, 0.33333333333333
85691, 0.69565217391304, -0.15, 0.38888888888889
85692, 0.69565217391304, -0.15, 0.44444444444444
85693, 0.65217391304348, -0.15, 0.055555555555556
85694, 0.65217391304348, -0.15, 0.11111111111111
85695, 0.65217391304348, -0.15, 0.16666666666667
85696, 0.65217391304348, -0.15, 0.22222222222222
85697, 0.65217391304348, -0.15, 0.27777777777778
85698, 0.65217391304348, -0.15, 0.33333333333333
85699, 0.65217391304348, -0.15, 0.38888888888889
85700, 0.65217391304348, -0.15, 0.44444444444444
85701, 0.60869565217391, -0.15, 0.055555555555556
85702, 0.60869565217391, -0.15, 0.11111111111111
85703, 0.60869565217391, -0.15, 0.16666666666667
85704, 0.60869565217391, -0.15, 0.22222222222222
85705, 0.60869565217391, -0.15, 0.27777777777778
85706, 0.60869565217391, -0.15, 0.33333333333333
85707, 0.60869565217391, -0.15, 0.38888888888889
85708, 0.60869565217391, -0.15, 0.44444444444444
85709, 0.56521739130435, -0.15, 0.055555555555556
85710, 0.56521739130435, -0.15, 0.11111111111111
85711, 0.56521739130435, -0.15, 0.16666666666667
85712, 0.56521739130435, -0.15, 0.22222222222222
85713, 0.56521739130435, -0.15, 0.27777777777778
85714, 0.56521739130435, -0.15, 0.33333333333333
85715, 0.56521739130435, -0.15, 0.38888888888889
85716, 0.56521739130435, -0.15, 0.44444444444444
85717, 0.52173913043478, -0.15, 0.055555555555556
85718, 0.52173913043478, -0.15, 0.11111111111111
85719, 0.52173913043478, -0.15, 0.16666666666667
85720, 0.52173913043478, -0.15, 0.22222222222222
85721, 0.52173913043478, -0.15, 0.27777777777778
85722, 0.52173913043478, -0.15, 0.33333333333333
85723, 0.52173913043478, -0.15, 0.38888888888889
85724, 0.52173913043478, -0.15, 0.44444444444444
85725, 0.47826086956522, -0.15, 0.055555555555556
85726, 0.47826086956522, -0.15, 0.11111111111111
85727, 0.47826086956522, -0.15, 0.16666666666667
85728, 0.47826086956522, -0.15, 0.22222222222222
85729, 0.47826086956522, -0.15, 0.27777777777778
85730, 0.47826086956522, -0.15, 0.33333333333333
85731, 0.47826086956522, -0.15, 0.38888888888889
85732, 0.47826086956522, -0.15, 0.44444444444444
85733, 0.43478260869565, -0.15, 0.055555555555556
85734, 0.43478260869565, -0.15, 0.11111111111111
85735, 0.43478260869565, -0.15, 0.16666666666667
85736, 0.43478260869565, -0.15, 0.22222222222222
85737, 0.43478260869565, -0.15, 0.27777777777778
85738, 0.43478260869565, -0.15, 0.33333333333333
85739, 0.43478260869565, -0.15, 0.38888888888889
85740, 0.43478260869565, -0.15, 0.44444444444444
85741, 0.39130434782609, -0.15, 0.055555555555556
85742, 0.39130434782609, -0.15, 0.11111111111111
85743, 0.39130434782609, -0.15, 0.16666666666667
85744, 0.39130434782609, -0.15, 0.22222222222222
85745, 0.39130434782609, -0.15, 0.27777777777778
85746, 0.39130434782609, -0.15, 0.33333333333333
85747, 0.39130434782609, -0.15, 0.38888888888889
85748, 0.39130434782609, -0.15, 0.44444444444444
85749, 0.34782608695652, -0.15, 0.055555555555556
85750, 0.34782608695652, -0.15, 0.11111111111111
85751, 0.34782608695652, -0.15, 0.16666666666667
85752, 0.34782608695652, -0.15, 0.22222222222222
85753, 0.34782608695652, -0.15, 0.27777777777778
85754, 0.34782608695652, -0.15, 0.33333333333333
85755, 0.34782608695652, -0.15, 0.38888888888889
85756, 0.34782608695652, -0.15, 0.44444444444444
85757, 0.30434782608696, -0.15, 0.055555555555556
85758, 0.30434782608696, -0.15, 0.11111111111111
85759, 0.30434782608696, -0.15, 0.16666666666667
85760, 0.30434782608696, -0.15, 0.22222222222222
85761, 0.30434782608696, -0.15, 0.27777777777778
85762, 0.30434782608696, -0.15, 0.33333333333333
85763, 0.30434782608696, -0.15, 0.38888888888889
85764, 0.30434782608696, -0.15, 0.44444444444444
85765, 0.26086956521739, -0.15, 0.055555555555556
85766, 0.26086956521739, -0.15, 0.11111111111111
85767, 0.26086956521739, -0.15, 0.16666666666667
85768, 0.26086956521739, -0.15, 0.22222222222222
85769, 0.26086956521739, -0.15, 0.27777777777778
85770, 0.26086956521739, -0.15, 0.33333333333333
85771, 0.26086956521739, -0.15, 0.38888888888889
85772, 0.26086956521739, -0.15, 0.44444444444444
85773, 0.21739130434783, -0.15, 0.055555555555556
85774, 0.21739130434783, -0.15, 0.11111111111111
85775, 0.21739130434783, -0.15, 0.16666666666667
85776, 0.21739130434783, -0.15, 0.22222222222222
85777, 0.21739130434783, -0.15, 0.27777777777778
85778, 0.21739130434783, -0.15, 0.33333333333333
85779, 0.21739130434783, -0.15, 0.38888888888889
85780, 0.21739130434783, -0.15, 0.44444444444444
85781, 0.17391304347826, -0.15, 0.055555555555556
85782, 0.17391304347826, -0.15, 0.11111111111111
85783, 0.17391304347826, -0.15, 0.16666666666667
85784, 0.17391304347826, -0.15, 0.22222222222222
85785, 0.17391304347826, -0.15, 0.27777777777778
85786, 0.17391304347826, -0.15, 0.33333333333333
85787, 0.17391304347826, -0.15, 0.38888888888889
85788, 0.17391304347826, -0.15, 0.44444444444444
85789, 0.1304347826087, -0.15, 0.055555555555556
85790, 0.1304347826087, -0.15, 0.11111111111111
85791, 0.1304347826087, -0.15, 0.16666666666667
85792, 0.1304347826087, -0.15, 0.22222222222222
85793, 0.1304347826087, -0.15, 0.27777777777778
85794, 0.1304347826087, -0.15, 0.33333333333333
85795, 0.1304347826087, -0.15, 0.38888888888889
85796, 0.1304347826087, -0.15, 0.44444444444444
85797, 0.08695652173913, -0.15, 0.055555555555556
85798, 0.08695652173913, -0.15, 0.11111111111111
85799, 0.08695652173913, -0.15, 0.16666666666667
85800, 0.08695652173913, -0.15, 0.22222222222222
85801, 0.08695652173913, -0.15, 0.27777777777778
85802, 0.08695652173913, -0.15, 0.33333333333333
85803, 0.08695652173913, -0.15, 0.38888888888889
85804, 0.08695652173913, -0.15, 0.44444444444444
85805, 0.043478260869565, -0.15, 0.055555555555556
85806, 0.043478260869565, -0.15, 0.11111111111111
85807, 0.043478260869565, -0.15, 0.16666666666667
85808, 0.043478260869565, -0.15, 0.22222222222222
85809, 0.043478260869565, -0.15, 0.27777777777778
85810, 0.043478260869565, -0.15, 0.33333333333333
85811, 0.043478260869565, -0.15, 0.38888888888889
85812, 0.043478260869565, -0.15, 0.44444444444444
85813, 0.95652173913043, -0.2, 0.055555555555556
85814, 0.95652173913044, -0.2, 0.11111111111111
85815, 0.95652173913043, -0.2, 0.16666666666667
85816, 0.95652173913044, -0.2, 0.22222222222222
85817, 0.95652173913044, -0.2, 0.27777777777778
85818, 0.95652173913043, -0.2, 0.33333333333333
85819, 0.95652173913044, -0.2, 0.38888888888889
85820, 0.95652173913044, -0.2, 0.44444444444444
85821, 0.91304347826087, -0.2, 0.055555555555556
85822, 0.91304347826087, -0.2, 0.11111111111111
85823, 0.91304347826087, -0.2, 0.16666666666667
85824, 0.91304347826087, -0.2, 0.22222222222222
85825, 0.91304347826087, -0.2, 0.27777777777778
85826, 0.91304347826087, -0.2, 0.33333333333333
85827, 0.91304347826087, -0.2, 0.38888888888889
85828, 0.91304347826087, -0.2, 0.44444444444444
85829, 0.8695652173913, -0.2, 0.055555555555556
85830, 0.8695652173913, -0.2, 0.11111111111111
85831, 0.8695652173913, -0.2, 0.16666666666667
85832, 0.8695652173913, -0.2, 0.22222222222222
85833, 0.8695652173913, -0.2, 0.27777777777778
85834, 0.8695652173913, -0.2, 0.33333333333333
85835, 0.8695652173913, -0.2, 0.38888888888889
85836, 0.8695652173913, -0.2, 0.44444444444444
85837, 0.82608695652174, -0.2, 0.055555555555556
85838, 0.82608695652174, -0.2, 0.11111111111111
85839, 0.82608695652174, -0.2, 0.16666666666667
85840, 0.82608695652174, -0.2, 0.22222222222222
85841, 0.82608695652174, -0.2, 0.27777777777778
85842, 0.82608695652174, -0.2, 0.33333333333333
85843, 0.82608695652174, -0.2, 0.38888888888889
85844, 0.82608695652174, -0.2, 0.44444444444444
85845, 0.78260869565217, -0.2, 0.055555555555556
85846, 0.78260869565217, -0.2, 0.11111111111111
85847, 0.78260869565217, -0.2, 0.16666666666667
85848, 0.78260869565217, -0.2, 0.22222222222222
85849, 0.78260869565217, -0.2, 0.27777777777778
85850, 0.78260869565217, -0.2, 0.33333333333333
85851, 0.78260869565217, -0.2, 0.38888888888889
85852, 0.78260869565217, -0.2, 0.44444444444444
85853, 0.73913043478261, -0.2, 0.055555555555556
85854, 0.73913043478261, -0.2, 0.11111111111111
85855, 0.73913043478261, -0.2, 0.16666666666667
85856, 0.73913043478261, -0.2, 0.22222222222222
85857, 0.73913043478261, -0.2, 0.27777777777778
85858, 0.73913043478261, -0.2, 0.33333333333333
85859, 0.73913043478261, -0.2, 0.38888888888889
85860, 0.73913043478261, -0.2, 0.44444444444444
85861, 0.69565217391304, -0.2, 0.055555555555556
85862, 0.69565217391304, -0.2, 0.11111111111111
85863, 0.69565217391304, -0.2, 0.16666666666667
85864, 0.69565217391304, -0.2, 0.22222222222222
85865, 0.69565217391304, -0.2, 0.27777777777778
85866, 0.69565217391304, -0.2, 0.33333333333333
85867, 0.69565217391304, -0.2, 0.38888888888889
85868, 0.69565217391304, -0.2, 0.44444444444444
85869, 0.65217391304348, -0.2, 0.055555555555556
85870, 0.65217391304348, -0.2, 0.11111111111111
85871, 0.65217391304348, -0.2, 0.16666666666667
85872, 0.65217391304348, -0.2, 0.22222222222222
85873, 0.65217391304348, -0.2, 0.27777777777778
85874, 0.65217391304348, -0.2, 0.33333333333333
85875, 0.65217391304348, -0.2, 0.38888888888889
85876, 0.65217391304348, -0.2, 0.44444444444444
85877, 0.60869565217391, -0.2, 0.055555555555556
85878, 0.60869565217391, -0.2, 0.11111111111111
85879, 0.60869565217391, -0.2, 0.16666666666667
85880, 0.60869565217391, -0.2, 0.22222222222222
85881, 0.60869565217391, -0.2, 0.27777777777778
85882, 0.60869565217391, -0.2, 0.33333333333333
85883, 0.60869565217391, -0.2, 0.38888888888889
85884, 0.60869565217391, -0.2, 0.44444444444444
85885, 0.56521739130435, -0.2, 0.055555555555556
85886, 0.56521739130435, -0.2, 0.11111111111111
85887, 0.56521739130435, -0.2, 0.16666666666667
85888, 0.56521739130435, -0.2, 0.22222222222222
85889, 0.56521739130435, -0.2, 0.27777777777778
85890, 0.56521739130435, -0.2, 0.33333333333333
85891, 0.56521739130435, -0.2, 0.38888888888889
85892, 0.56521739130435, -0.2, 0.44444444444444
85893, 0.52173913043478, -0.2, 0.055555555555556
85894, 0.52173913043478, -0.2, 0.11111111111111
85895, 0.52173913043478, -0.2, 0.16666666666667
85896, 0.52173913043478, -0.2, 0.22222222222222
85897, 0.52173913043478, -0.2, 0.27777777777778
85898, 0.52173913043478, -0.2, 0.33333333333333
85899, 0.52173913043478, -0.2, 0.38888888888889
85900, 0.52173913043478, -0.2, 0.44444444444444
85901, 0.47826086956522, -0.2, 0.055555555555556
85902, 0.47826086956522, -0.2, 0.11111111111111
85903, 0.47826086956522, -0.2, 0.16666666666667
85904, 0.47826086956522, -0.2, 0.22222222222222
85905, 0.47826086956522, -0.2, 0.27777777777778
85906, 0.47826086956522, -0.2, 0.33333333333333
85907, 0.47826086956522, -0.2, 0.38888888888889
85908, 0.47826086956522, -0.2, 0.44444444444444
85909, 0.43478260869565, -0.2, 0.055555555555556
85910, 0.43478260869565, -0.2, 0.11111111111111
85911, 0.43478260869565, -0.2, 0.16666666666667
85912, 0.43478260869565, -0.2, 0.22222222222222
85913, 0.43478260869565, -0.2, 0.27777777777778
85914, 0.43478260869565, -0.2, 0.33333333333333
85915, 0.43478260869565, -0.2, 0.38888888888889
85916, 0.43478260869565, -0.2, 0.44444444444444
85917, 0.39130434782609, -0.2, 0.055555555555556
85918, 0.39130434782609, -0.2, 0.11111111111111
85919, 0.39130434782609, -0.2, 0.16666666666667
85920, 0.39130434782609, -0.2, 0.22222222222222
85921, 0.39130434782609, -0.2, 0.27777777777778
85922, 0.39130434782609, -0.2, 0.33333333333333
85923, 0.39130434782609, -0.2, 0.38888888888889
85924, 0.39130434782609, -0.2, 0.44444444444444
85925, 0.34782608695652, -0.2, 0.055555555555556
85926, 0.34782608695652, -0.2, 0.11111111111111
85927, 0.34782608695652, -0.2, 0.16666666666667
85928, 0.34782608695652, -0.2, 0.22222222222222
85929, 0.34782608695652, -0.2, 0.27777777777778
85930, 0.34782608695652, -0.2, 0.33333333333333
85931, 0.34782608695652, -0.2, 0.38888888888889
85932, 0.34782608695652, -0.2, 0.44444444444444
85933, 0.30434782608696, -0.2, 0.055555555555556
85934, 0.30434782608696, -0.2, 0.11111111111111
85935, 0.30434782608696, -0.2, 0.16666666666667
85936, 0.30434782608696, -0.2, 0.22222222222222
85937, 0.30434782608696, -0.2, 0.27777777777778
85938, 0.30434782608696, -0.2, 0.33333333333333
85939, 0.30434782608696, -0.2, 0.38888888888889
85940, 0.30434782608696, -0.2, 0.44444444444444
85941, 0.26086956521739, -0.2, 0.055555555555556
85942, 0.26086956521739, -0.2, 0.11111111111111
85943, 0.26086956521739, -0.2, 0.16666666666667
85944, 0.26086956521739, -0.2, 0.22222222222222
85945, 0.26086956521739, -0.2, 0.27777777777778
85946, 0.26086956521739, -0.2, 0.33333333333333
85947, 0.26086956521739, -0.2, 0.38888888888889
85948, 0.26086956521739, -0.2, 0.44444444444444
85949, 0.21739130434783, -0.2, 0.055555555555556
85950, 0.21739130434783, -0.2, 0.11111111111111
85951, 0.21739130434783, -0.2, 0.16666666666667
85952, 0.21739130434783, -0.2, 0.22222222222222
85953, 0.21739130434783, -0.2, 0.27777777777778
85954, 0.21739130434783, -0.2, 0.33333333333333
85955, 0.21739130434783, -0.2, 0.38888888888889
85956, 0.21739130434783, -0.2, 0.44444444444444
85957, 0.17391304347826, -0.2, 0.055555555555556
85958, 0.17391304347826, -0.2, 0.11111111111111
85959, 0.17391304347826, -0.2, 0.16666666666667
85960, 0.17391304347826, -0.2, 0.22222222222222
85961, 0.17391304347826, -0.2, 0.27777777777778
85962, 0.17391304347826, -0.2, 0.33333333333333
85963, 0.17391304347826, -0.2, 0.38888888888889
85964, 0.17391304347826, -0.2, 0.44444444444444
85965, 0.1304347826087, -0.2, 0.055555555555556
85966, 0.1304347826087, -0.2, 0.11111111111111
85967, 0.1304347826087, -0.2, 0.16666666666667
85968, 0.1304347826087, -0.2, 0.22222222222222
85969, 0.1304347826087, -0.2, 0.27777777777778
85970, 0.1304347826087, -0.2, 0.33333333333333
85971, 0.1304347826087, -0.2, 0.38888888888889
85972, 0.1304347826087, -0.2, 0.44444444444444
85973, 0.08695652173913, -0.2, 0.055555555555556
85974, 0.08695652173913, -0.2, 0.11111111111111
85975, 0.08695652173913, -0.2, 0.16666666666667
85976, 0.08695652173913, -0.2, 0.22222222222222
85977, 0.08695652173913, -0.2, 0.27777777777778
85978, 0.08695652173913, -0.2, 0.33333333333333
85979, 0.08695652173913, -0.2, 0.38888888888889
85980, 0.08695652173913, -0.2, 0.44444444444444
85981, 0.043478260869565, -0.2, 0.055555555555556
85982, 0.043478260869565, -0.2, 0.11111111111111
85983, 0.043478260869565, -0.2, 0.16666666666667
85984, 0.043478260869565, -0.2, 0.22222222222222
85985, 0.043478260869565, -0.2, 0.27777777777778
85986, 0.043478260869565, -0.2, 0.33333333333333
85987, 0.043478260869565, -0.2, 0.38888888888889
85988, 0.043478260869565, -0.2, 0.44444444444444
85989, 0.95652173913043, -0.1, 0.027777777777778
85990, 0.97826086956522, -0.1, 0.055555555555556
85991, 0.95652173913043, -0.075, 0.055555555555556
85992, 0.95652173913043, -0.1, 0.083333333333333
85993, 0.97826086956522, -0.1, 0.11111111111111
85994, 0.95652173913043, -0.075, 0.11111111111111
85995, 0.95652173913043, -0.1, 0.13888888888889
85996, 0.97826086956522, -0.1, 0.16666666666667
85997, 0.95652173913043, -0.075, 0.16666666666667
85998, 0.95652173913043, -0.1, 0.19444444444444
85999, 0.97826086956522, -0.1, 0.22222222222222
86000, 0.95652173913043, -0.075, 0.22222222222222
86001, 0.95652173913043, -0.1, 0.25
86002, 0.97826086956522, -0.1, 0.27777777777778
86003, 0.95652173913043, -0.075, 0.27777777777778
86004, 0.95652173913043, -0.1, 0.30555555555556
86005, 0.97826086956522, -0.1, 0.33333333333333
86006, 0.95652173913043, -0.075, 0.33333333333333
86007, 0.95652173913043, -0.1, 0.36111111111111
86008, 0.97826086956522, -0.1, 0.38888888888889
86009, 0.95652173913043, -0.075, 0.38888888888889
86010, 0.95652173913043, -0.1, 0.41666666666667
86011, 0.97826086956522, -0.1, 0.44444444444444
86012, 0.95652173913043, -0.075, 0.44444444444444
86013, 0.95652173913043, -0.1, 0.47222222222222
86014, 0.91304347826087, -0.1, 0.027777777777778
86015, 0.93478260869565, -0.1, 0.055555555555556
86016, 0.91304347826087, -0.075, 0.055555555555556
86017, 0.91304347826087, -0.1, 0.083333333333333
86018, 0.93478260869565, -0.1, 0.11111111111111
86019, 0.91304347826087, -0.075, 0.11111111111111
86020, 0.91304347826087, -0.1, 0.13888888888889
86021, 0.93478260869565, -0.1, 0.16666666666667
86022, 0.91304347826087, -0.075, 0.16666666666667
86023, 0.91304347826087, -0.1, 0.19444444444444
86024, 0.93478260869565, -0.1, 0.22222222222222
86025, 0.91304347826087, -0.075, 0.22222222222222
86026, 0.91304347826087, -0.1, 0.25
86027, 0.93478260869565, -0.1, 0.27777777777778
86028, 0.91304347826087, -0.075, 0.27777777777778
86029, 0.91304347826087, -0.1, 0.30555555555556
86030, 0.93478260869565, -0.1, 0.33333333333333
86031, 0.91304347826087, -0.075, 0.33333333333333
86032, 0.91304347826087, -0.1, 0.36111111111111
86033, 0.93478260869565, -0.1, 0.38888888888889
86034, 0.91304347826087, -0.075, 0.38888888888889
86035, 0.91304347826087, -0.1, 0.41666666666667
86036, 0.93478260869565, -0.1, 0.44444444444444
86037, 0.91304347826087, -0.075, 0.44444444444444
86038, 0.91304347826087, -0.1, 0.47222222222222
86039, 0.8695652173913, -0.1, 0.027777777777778
86040, 0.89130434782609, -0.1, 0.055555555555556
86041, 0.8695652173913, -0.075, 0.055555555555556
86042, 0.8695652173913, -0.1, 0.083333333333333
86043, 0.89130434782609, -0.1, 0.11111111111111
86044, 0.8695652173913, -0.075, 0.11111111111111
86045, 0.8695652173913, -0.1, 0.13888888888889
86046, 0.89130434782609, -0.1, 0.16666666666667
86047, 0.8695652173913, -0.075, 0.16666666666667
86048, 0.8695652173913, -0.1, 0.19444444444444
86049, 0.89130434782609, -0.1, 0.22222222222222
86050, 0.8695652173913, -0.075, 0.22222222222222
86051, 0.8695652173913, -0.1, 0.25
86052, 0.89130434782609, -0.1, 0.27777777777778
86053, 0.8695652173913, -0.075, 0.27777777777778
86054, 0.8695652173913, -0.1, 0.30555555555556
86055, 0.89130434782609, -0.1, 0.33333333333333
86056, 0.8695652173913, -0.075, 0.33333333333333
86057, 0.8695652173913, -0.1, 0.36111111111111
86058, 0.89130434782609, -0.1, 0.38888888888889
86059, 0.8695652173913, -0.075, 0.38888888888889
86060, 0.8695652173913, -0.1, 0.41666666666667
86061, 0.89130434782609, -0.1, 0.44444444444444
86062, 0.8695652173913, -0.075, 0.44444444444444
86063, 0.8695652173913, -0.1, 0.47222222222222
86064, 0.82608695652174, -0.1, 0.027777777777778
86065, 0.84782608695652, -0.1, 0.055555555555556
86066, 0.82608695652174, -0.075, 0.055555555555556
86067, 0.82608695652174, -0.1, 0.083333333333333
86068, 0.84782608695652, -0.1, 0.11111111111111
86069, 0.82608695652174, -0.075, 0.11111111111111
86070, 0.82608695652174, -0.1, 0.13888888888889
86071, 0.84782608695652, -0.1, 0.16666666666667
86072, 0.82608695652174, -0.075, 0.16666666666667
86073, 0.82608695652174, -0.1, 0.19444444444444
86074, 0.84782608695652, -0.1, 0.22222222222222
86075, 0.82608695652174, -0.075, 0.22222222222222
86076, 0.82608695652174, -0.1, 0.25
86077, 0.84782608695652, -0.1, 0.27777777777778
86078, 0.82608695652174, -0.075, 0.27777777777778
86079, 0.82608695652174, -0.1, 0.30555555555556
86080, 0.84782608695652, -0.1, 0.33333333333333
86081, 0.82608695652174, -0.075, 0.33333333333333
86082, 0.82608695652174, -0.1, 0.36111111111111
86083, 0.84782608695652, -0.1, 0.38888888888889
86084, 0.82608695652174, -0.075, 0.38888888888889
86085, 0.82608695652174, -0.1, 0.41666666666667
86086, 0.84782608695652, -0.1, 0.44444444444444
86087, 0.82608695652174, -0.075, 0.44444444444444
86088, 0.82608695652174, -0.1, 0.47222222222222
86089, 0.78260869565217, -0.1, 0.027777777777778
86090, 0.80434782608696, -0.1, 0.055555555555556
86091, 0.78260869565217, -0.075, 0.055555555555556
86092, 0.78260869565217, -0.1, 0.083333333333333
86093, 0.80434782608696, -0.1, 0.11111111111111
86094, 0.78260869565217, -0.075, 0.11111111111111
86095, 0.78260869565217, -0.1, 0.13888888888889
86096, 0.80434782608696, -0.1, 0.16666666666667
86097, 0.78260869565217, -0.075, 0.16666666666667
86098, 0.78260869565217, -0.1, 0.19444444444444
86099, 0.80434782608696, -0.1, 0.22222222222222
86100, 0.78260869565217, -0.075, 0.22222222222222
86101, 0.78260869565217, -0.1, 0.25
86102, 0.80434782608696, -0.1, 0.27777777777778
86103, 0.78260869565217, -0.075, 0.27777777777778
86104, 0.78260869565217, -0.1, 0.30555555555556
86105, 0.80434782608696, -0.1, 0.33333333333333
86106, 0.78260869565217, -0.075, 0.33333333333333
86107, 0.78260869565217, -0.1, 0.36111111111111
86108, 0.80434782608696, -0.1, 0.38888888888889
86109, 0.78260869565217, -0.075, 0.38888888888889
86110, 0.78260869565217, -0.1, 0.41666666666667
86111, 0.80434782608696, -0.1, 0.44444444444444
86112, 0.78260869565217, -0.075, 0.44444444444444
86113, 0.78260869565217, -0.1, 0.47222222222222
86114, 0.73913043478261, -0.1, 0.027777777777778
86115, 0.76086956521739, -0.1, 0.055555555555556
86116, 0.73913043478261, -0.075, 0.055555555555556
86117, 0.73913043478261, -0.1, 0.083333333333333
86118, 0.76086956521739, -0.1, 0.11111111111111
86119, 0.73913043478261, -0.075, 0.11111111111111
86120, 0.73913043478261, -0.1, 0.13888888888889
86121, 0.76086956521739, -0.1, 0.16666666666667
86122, 0.73913043478261, -0.075, 0.16666666666667
86123, 0.73913043478261, -0.1, 0.19444444444444
86124, 0.76086956521739, -0.1, 0.22222222222222
86125, 0.73913043478261, -0.075, 0.22222222222222
86126, 0.73913043478261, -0.1, 0.25
86127, 0.76086956521739, -0.1, 0.27777777777778
86128, 0.73913043478261, -0.075, 0.27777777777778
86129, 0.73913043478261, -0.1, 0.30555555555556
86130, 0.76086956521739, -0.1, 0.33333333333333
86131, 0.73913043478261, -0.075, 0.33333333333333
86132, 0.73913043478261, -0.1, 0.36111111111111
86133, 0.76086956521739, -0.1, 0.38888888888889
86134, 0.73913043478261, -0.075, 0.38888888888889
86135, 0.73913043478261, -0.1, 0.41666666666667
86136, 0.76086956521739, -0.1, 0.44444444444444
86137, 0.73913043478261, -0.075, 0.44444444444444
86138, 0.73913043478261, -0.1, 0.47222222222222
86139, 0.69565217391304, -0.1, 0.027777777777778
86140, 0.71739130434783, -0.1, 0.055555555555556
86141, 0.69565217391304, -0.075, 0.055555555555556
86142, 0.69565217391304, -0.1, 0.083333333333333
86143, 0.71739130434783, -0.1, 0.11111111111111
86144, 0.69565217391304, -0.075, 0.11111111111111
86145, 0.69565217391304, -0.1, 0.13888888888889
86146, 0.71739130434783, -0.1, 0.16666666666667
86147, 0.69565217391304, -0.075, 0.16666666666667
86148, 0.69565217391304, -0.1, 0.19444444444444
86149, 0.71739130434783, -0.1, 0.22222222222222
86150, 0.69565217391304, -0.075, 0.22222222222222
86151, 0.69565217391304, -0.1, 0.25
86152, 0.71739130434783, -0.1, 0.27777777777778
86153, 0.69565217391304, -0.075, 0.27777777777778
86154, 0.69565217391304, -0.1, 0.30555555555556
86155, 0.71739130434783, -0.1, 0.33333333333333
86156, 0.69565217391304, -0.075, 0.33333333333333
86157, 0.69565217391304, -0.1, 0.36111111111111
86158, 0.71739130434783, -0.1, 0.38888888888889
86159, 0.69565217391304, -0.075, 0.38888888888889
86160, 0.69565217391304, -0.1, 0.41666666666667
86161, 0.71739130434783, -0.1, 0.44444444444444
86162, 0.69565217391304, -0.075, 0.44444444444444
86163, 0.69565217391304, -0.1, 0.47222222222222
86164, 0.65217391304348, -0.1, 0.027777777777778
86165, 0.67391304347826, -0.1, 0.055555555555556
86166, 0.65217391304348, -0.075, 0.055555555555556
86167, 0.65217391304348, -0.1, 0.083333333333333
86168, 0.67391304347826, -0.1, 0.11111111111111
86169, 0.65217391304348, -0.075, 0.11111111111111
86170, 0.65217391304348, -0.1, 0.13888888888889
86171, 0.67391304347826, -0.1, 0.16666666666667
86172, 0.65217391304348, -0.075, 0.16666666666667
86173, 0.65217391304348, -0.1, 0.19444444444444
86174, 0.67391304347826, -0.1, 0.22222222222222
86175, 0.65217391304348, -0.075, 0.22222222222222
86176, 0.65217391304348, -0.1, 0.25
86177, 0.67391304347826, -0.1, 0.27777777777778
86178, 0.65217391304348, -0.075, 0.27777777777778
86179, 0.65217391304348, -0.1, 0.30555555555556
86180, 0.67391304347826, -0.1, 0.33333333333333
86181, 0.65217391304348, -0.075, 0.33333333333333
86182, 0.65217391304348, -0.1, 0.36111111111111
86183, 0.67391304347826, -0.1, 0.38888888888889
86184, 0.65217391304348, -0.075, 0.38888888888889
86185, 0.65217391304348, -0.1, 0.41666666666667
86186, 0.67391304347826, -0.1, 0.44444444444444
86187, 0.65217391304348, -0.075, 0.44444444444444
86188, 0.65217391304348, -0.1, 0.47222222222222
86189, 0.60869565217391, -0.1, 0.027777777777778
86190, 0.6304347826087, -0.1, 0.055555555555556
86191, 0.60869565217391, -0.075, 0.055555555555556
86192, 0.60869565217391, -0.1, 0.083333333333333
86193, 0.6304347826087, -0.1, 0.11111111111111
86194, 0.60869565217391, -0.075, 0.11111111111111
86195, 0.60869565217391, -0.1, 0.13888888888889
86196, 0.6304347826087, -0.1, 0.16666666666667
86197, 0.60869565217391, -0.075, 0.16666666666667
86198, 0.60869565217391, -0.1, 0.19444444444444
86199, 0.6304347826087, -0.1, 0.22222222222222
86200, 0.60869565217391, -0.075, 0.22222222222222
86201, 0.60869565217391, -0.1, 0.25
86202, 0.6304347826087, -0.1, 0.27777777777778
86203, 0.60869565217391, -0.075, 0.27777777777778
86204, 0.60869565217391, -0.1, 0.30555555555556
86205, 0.6304347826087, -0.1, 0.33333333333333
86206, 0.60869565217391, -0.075, 0.33333333333333
86207, 0.60869565217391, -0.1, 0.36111111111111
86208, 0.6304347826087, -0.1, 0.38888888888889
86209, 0.60869565217391, -0.075, 0.38888888888889
86210, 0.60869565217391, -0.1, 0.41666666666667
86211, 0.6304347826087, -0.1, 0.44444444444444
86212, 0.60869565217391, -0.075, 0.44444444444444
86213, 0.60869565217391, -0.1, 0.47222222222222
86214, 0.56521739130435, -0.1, 0.027777777777778
86215, 0.58695652173913, -0.1, 0.055555555555556
86216, 0.56521739130435, -0.075, 0.055555555555556
86217, 0.56521739130435, -0.1, 0.083333333333333
86218, 0.58695652173913, -0.1, 0.11111111111111
86219, 0.56521739130435, -0.075, 0.11111111111111
86220, 0.56521739130435, -0.1, 0.13888888888889
86221, 0.58695652173913, -0.1, 0.16666666666667
86222, 0.56521739130435, -0.075, 0.16666666666667
86223, 0.56521739130435, -0.1, 0.19444444444444
86224, 0.58695652173913, -0.1, 0.22222222222222
86225, 0.56521739130435, -0.075, 0.22222222222222
86226, 0.56521739130435, -0.1, 0.25
86227, 0.58695652173913, -0.1, 0.27777777777778
86228, 0.56521739130435, -0.075, 0.27777777777778
86229, 0.56521739130435, -0.1, 0.30555555555556
86230, 0.58695652173913, -0.1, 0.33333333333333
86231, 0.56521739130435, -0.075, 0.33333333333333
86232, 0.56521739130435, -0.1, 0.36111111111111
86233, 0.58695652173913, -0.1, 0.38888888888889
86234, 0.56521739130435, -0.075, 0.38888888888889
86235, 0.56521739130435, -0.1, 0.41666666666667
86236, 0.58695652173913, -0.1, 0.44444444444444
86237, 0.56521739130435, -0.075, 0.44444444444444
86238, 0.56521739130435, -0.1, 0.47222222222222
86239, 0.52173913043478, -0.1, 0.027777777777778
86240, 0.54347826086957, -0.1, 0.055555555555556
86241, 0.52173913043478, -0.075, 0.055555555555556
86242, 0.52173913043478, -0.1, 0.083333333333333
86243, 0.54347826086956, -0.1, 0.11111111111111
86244, 0.52173913043478, -0.075, 0.11111111111111
86245, 0.52173913043478, -0.1, 0.13888888888889
86246, 0.54347826086956, -0.1, 0.16666666666667
86247, 0.52173913043478, -0.075, 0.16666666666667
86248, 0.52173913043478, -0.1, 0.19444444444444
86249, 0.54347826086956, -0.1, 0.22222222222222
86250, 0.52173913043478, -0.075, 0.22222222222222
86251, 0.52173913043478, -0.1, 0.25
86252, 0.54347826086956, -0.1, 0.27777777777778
86253, 0.52173913043478, -0.075, 0.27777777777778
86254, 0.52173913043478, -0.1, 0.30555555555556
86255, 0.54347826086956, -0.1, 0.33333333333333
86256, 0.52173913043478, -0.075, 0.33333333333333
86257, 0.52173913043478, -0.1, 0.36111111111111
86258, 0.54347826086956, -0.1, 0.38888888888889
86259, 0.52173913043478, -0.075, 0.38888888888889
86260, 0.52173913043478, -0.1, 0.41666666666667
86261, 0.54347826086956, -0.1, 0.44444444444444
86262, 0.52173913043478, -0.075, 0.44444444444444
86263, 0.52173913043478, -0.1, 0.47222222222222
86264, 0.47826086956522, -0.1, 0.027777777777778
86265, 0.5, -0.1, 0.055555555555556
86266, 0.47826086956522, -0.075, 0.055555555555556
86267, 0.47826086956522, -0.1, 0.083333333333333
86268, 0.5, -0.1, 0.11111111111111
86269, 0.47826086956522, -0.075, 0.11111111111111
86270, 0.47826086956522, -0.1, 0.13888888888889
86271, 0.5, -0.1, 0.16666666666667
86272, 0.47826086956522, -0.075, 0.16666666666667
86273, 0.47826086956522, -0.1, 0.19444444444444
86274, 0.5, -0.1, 0.22222222222222
86275, 0.47826086956522, -0.075, 0.22222222222222
86276, 0.47826086956522, -0.1, 0.25
86277, 0.5, -0.1, 0.27777777777778
86278, 0.47826086956522, -0.075, 0.27777777777778
86279, 0.47826086956522, -0.1, 0.30555555555556
86280, 0.5, -0.1, 0.33333333333333
86281, 0.47826086956522, -0.075, 0.33333333333333
86282, 0.47826086956522, -0.1, 0.36111111111111
86283, 0.5, -0.1, 0.38888888888889
86284, 0.47826086956522, -0.075, 0.38888888888889
86285, 0.47826086956522, -0.1, 0.41666666666667
86286, 0.5, -0.1, 0.44444444444444
86287, 0.47826086956522, -0.075, 0.44444444444444
86288, 0.47826086956522, -0.1, 0.47222222222222
86289, 0.43478260869565, -0.1, 0.027777777777778
86290, 0.45652173913043, -0.1, 0.055555555555556
86291, 0.43478260869565, -0.075, 0.055555555555556
86292, 0.43478260869565, -0.1, 0.083333333333333
86293, 0.45652173913044, -0.1, 0.11111111111111
86294, 0.43478260869565, -0.075, 0.11111111111111
86295, 0.43478260869565, -0.1, 0.13888888888889
86296, 0.45652173913043, -0.1, 0.16666666666667
86297, 0.43478260869565, -0.075, 0.16666666666667
86298, 0.43478260869565, -0.1, 0.19444444444444
86299, 0.45652173913043, -0.1, 0.22222222222222
86300, 0.43478260869565, -0.075, 0.22222222222222
86301, 0.43478260869565, -0.1, 0.25
86302, 0.45652173913043, -0.1, 0.27777777777778
86303, 0.43478260869565, -0.075, 0.27777777777778
86304, 0.43478260869565, -0.1, 0.30555555555556
86305, 0.45652173913043, -0.1, 0.33333333333333
86306, 0.43478260869565, -0.075, 0.33333333333333
86307, 0.43478260869565, -0.1, 0.36111111111111
86308, 0.45652173913044, -0.1, 0.38888888888889
86309, 0.43478260869565, -0.075, 0.38888888888889
86310, 0.43478260869565, -0.1, 0.41666666666667
86311, 0.45652173913043, -0.1, 0.44444444444444
86312, 0.43478260869565, -0.075, 0.44444444444444
86313, 0.43478260869565, -0.1, 0.47222222222222
86314, 0.39130434782609, -0.1, 0.027777777777778
86315, 0.41304347826087, -0.1, 0.055555555555556
86316, 0.39130434782609, -0.075, 0.055555555555556
86317, 0.39130434782609, -0.1, 0.083333333333333
86318, 0.41304347826087, -0.1, 0.11111111111111
86319, 0.39130434782609, -0.075, 0.11111111111111
86320, 0.39130434782609, -0.1, 0.13888888888889
86321, 0.41304347826087, -0.1, 0.16666666666667
86322, 0.39130434782609, -0.075, 0.16666666666667
86323, 0.39130434782609, -0.1, 0.19444444444444
86324, 0.41304347826087, -0.1, 0.22222222222222
86325, 0.39130434782609, -0.075, 0.22222222222222
86326, 0.39130434782609, -0.1, 0.25
86327, 0.41304347826087, -0.1, 0.27777777777778
86328, 0.39130434782609, -0.075, 0.27777777777778
86329, 0.39130434782609, -0.1, 0.30555555555556
86330, 0.41304347826087, -0.1, 0.33333333333333
86331, 0.39130434782609, -0.075, 0.33333333333333
86332, 0.39130434782609, -0.1, 0.36111111111111
86333, 0.41304347826087, -0.1, 0.38888888888889
86334, 0.39130434782609, -0.075, 0.38888888888889
86335, 0.39130434782609, -0.1, 0.41666666666667
86336, 0.41304347826087, -0.1, 0.44444444444444
86337, 0.39130434782609, -0.075, 0.44444444444444
86338, 0.39130434782609, -0.1, 0.47222222222222
86339, 0.34782608695652, -0.1, 0.027777777777778
86340, 0.3695652173913, -0.1, 0.055555555555556
86341, 0.34782608695652, -0.075, 0.055555555555556
86342, 0.34782608695652, -0.1, 0.083333333333333
86343, 0.3695652173913, -0.1, 0.11111111111111
86344, 0.34782608695652, -0.075, 0.11111111111111
86345, 0.34782608695652, -0.1, 0.13888888888889
86346, 0.3695652173913, -0.1, 0.16666666666667
86347, 0.34782608695652, -0.075, 0.16666666666667
86348, 0.34782608695652, -0.1, 0.19444444444444
86349, 0.3695652173913, -0.1, 0.22222222222222
86350, 0.34782608695652, -0.075, 0.22222222222222
86351, 0.34782608695652, -0.1, 0.25
86352, 0.3695652173913, -0.1, 0.27777777777778
86353, 0.34782608695652, -0.075, 0.27777777777778
86354, 0.34782608695652, -0.1, 0.30555555555556
86355, 0.3695652173913, -0.1, 0.33333333333333
86356, 0.34782608695652, -0.075, 0.33333333333333
86357, 0.34782608695652, -0.1, 0.36111111111111
86358, 0.3695652173913, -0.1, 0.38888888888889
86359, 0.34782608695652, -0.075, 0.38888888888889
86360, 0.34782608695652, -0.1, 0.41666666666667
86361, 0.3695652173913, -0.1, 0.44444444444444
86362, 0.34782608695652, -0.075, 0.44444444444444
86363, 0.34782608695652, -0.1, 0.47222222222222
86364, 0.30434782608696, -0.1, 0.027777777777778
86365, 0.32608695652174, -0.1, 0.055555555555556
86366, 0.30434782608696, -0.075, 0.055555555555556
86367, 0.30434782608696, -0.1, 0.083333333333333
86368, 0.32608695652174, -0.1, 0.11111111111111
86369, 0.30434782608696, -0.075, 0.11111111111111
86370, 0.30434782608696, -0.1, 0.13888888888889
86371, 0.32608695652174, -0.1, 0.16666666666667
86372, 0.30434782608696, -0.075, 0.16666666666667
86373, 0.30434782608696, -0.1, 0.19444444444444
86374, 0.32608695652174, -0.1, 0.22222222222222
86375, 0.30434782608696, -0.075, 0.22222222222222
86376, 0.30434782608696, -0.1, 0.25
86377, 0.32608695652174, -0.1, 0.27777777777778
86378, 0.30434782608696, -0.075, 0.27777777777778
86379, 0.30434782608696, -0.1, 0.30555555555556
86380, 0.32608695652174, -0.1, 0.33333333333333
86381, 0.30434782608696, -0.075, 0.33333333333333
86382, 0.30434782608696, -0.1, 0.36111111111111
86383, 0.32608695652174, -0.1, 0.38888888888889
86384, 0.30434782608696, -0.075, 0.38888888888889
86385, 0.30434782608696, -0.1, 0.41666666666667
86386, 0.32608695652174, -0.1, 0.44444444444444
86387, 0.30434782608696, -0.075, 0.44444444444444
86388, 0.30434782608696, -0.1, 0.47222222222222
86389, 0.26086956521739, -0.1, 0.027777777777778
86390, 0.28260869565217, -0.1, 0.055555555555556
86391, 0.26086956521739, -0.075, 0.055555555555556
86392, 0.26086956521739, -0.1, 0.083333333333333
86393, 0.28260869565217, -0.1, 0.11111111111111
86394, 0.26086956521739, -0.075, 0.11111111111111
86395, 0.26086956521739, -0.1, 0.13888888888889
86396, 0.28260869565217, -0.1, 0.16666666666667
86397, 0.26086956521739, -0.075, 0.16666666666667
86398, 0.26086956521739, -0.1, 0.19444444444444
86399, 0.28260869565217, -0.1, 0.22222222222222
86400, 0.26086956521739, -0.075, 0.22222222222222
86401, 0.26086956521739, -0.1, 0.25
86402, 0.28260869565217, -0.1, 0.27777777777778
86403, 0.26086956521739, -0.075, 0.27777777777778
86404, 0.26086956521739, -0.1, 0.30555555555556
86405, 0.28260869565217, -0.1, 0.33333333333333
86406, 0.26086956521739, -0.075, 0.33333333333333
86407, 0.26086956521739, -0.1, 0.36111111111111
86408, 0.28260869565217, -0.1, 0.38888888888889
86409, 0.26086956521739, -0.075, 0.38888888888889
86410, 0.26086956521739, -0.1, 0.41666666666667
86411, 0.28260869565217, -0.1, 0.44444444444444
86412, 0.26086956521739, -0.075, 0.44444444444444
86413, 0.26086956521739, -0.1, 0.47222222222222
86414, 0.21739130434783, -0.1, 0.027777777777778
86415, 0.23913043478261, -0.1, 0.055555555555556
86416, 0.21739130434783, -0.075, 0.055555555555556
86417, 0.21739130434783, -0.1, 0.083333333333333
86418, 0.23913043478261, -0.1, 0.11111111111111
86419, 0.21739130434783, -0.075, 0.11111111111111
86420, 0.21739130434783, -0.1, 0.13888888888889
86421, 0.23913043478261, -0.1, 0.16666666666667
86422, 0.21739130434783, -0.075, 0.16666666666667
86423, 0.21739130434783, -0.1, 0.19444444444444
86424, 0.23913043478261, -0.1, 0.22222222222222
86425, 0.21739130434783, -0.075, 0.22222222222222
86426, 0.21739130434783, -0.1, 0.25
86427, 0.23913043478261, -0.1, 0.27777777777778
86428, 0.21739130434783, -0.075, 0.27777777777778
86429, 0.21739130434783, -0.1, 0.30555555555556
86430, 0.23913043478261, -0.1, 0.33333333333333
86431, 0.21739130434783, -0.075, 0.33333333333333
86432, 0.21739130434783, -0.1, 0.36111111111111
86433, 0.23913043478261, -0.1, 0.38888888888889
86434, 0.21739130434783, -0.075, 0.38888888888889
86435, 0.21739130434783, -0.1, 0.41666666666667
86436, 0.23913043478261, -0.1, 0.44444444444444
86437, 0.21739130434783, -0.075, 0.44444444444444
86438, 0.21739130434783, -0.1, 0.47222222222222
86439, 0.17391304347826, -0.1, 0.027777777777778
86440, 0.19565217391304, -0.1, 0.055555555555556
86441, 0.17391304347826, -0.075, 0.055555555555556
86442, 0.17391304347826, -0.1, 0.083333333333333
86443, 0.19565217391304, -0.1, 0.11111111111111
86444, 0.17391304347826, -0.075, 0.11111111111111
86445, 0.17391304347826, -0.1, 0.13888888888889
86446, 0.19565217391304, -0.1, 0.16666666666667
86447, 0.17391304347826, -0.075, 0.16666666666667
86448, 0.17391304347826, -0.1, 0.19444444444444
86449, 0.19565217391304, -0.1, 0.22222222222222
86450, 0.17391304347826, -0.075, 0.22222222222222
86451, 0.17391304347826, -0.1, 0.25
86452, 0.19565217391304, -0.1, 0.27777777777778
86453, 0.17391304347826, -0.075, 0.27777777777778
86454, 0.17391304347826, -0.1, 0.30555555555556
86455, 0.19565217391304, -0.1, 0.33333333333333
86456, 0.17391304347826, -0.075, 0.33333333333333
86457, 0.17391304347826, -0.1, 0.36111111111111
86458, 0.19565217391304, -0.1, 0.38888888888889
86459, 0.17391304347826, -0.075, 0.38888888888889
86460, 0.17391304347826, -0.1, 0.41666666666667
86461, 0.19565217391304, -0.1, 0.44444444444444
86462, 0.17391304347826, -0.075, 0.44444444444444
86463, 0.17391304347826, -0.1, 0.47222222222222
86464, 0.1304347826087, -0.1, 0.027777777777778
86465, 0.15217391304348, -0.1, 0.055555555555556
86466, 0.1304347826087, -0.075, 0.055555555555556
86467, 0.1304347826087, -0.1, 0.083333333333333
86468, 0.15217391304348, -0.1, 0.11111111111111
86469, 0.1304347826087, -0.075, 0.11111111111111
86470, 0.1304347826087, -0.1, 0.13888888888889
86471, 0.15217391304348, -0.1, 0.16666666666667
86472, 0.1304347826087, -0.075, 0.16666666666667
86473, 0.1304347826087, -0.1, 0.19444444444444
86474, 0.15217391304348, -0.1, 0.22222222222222
86475, 0.1304347826087, -0.075, 0.22222222222222
86476, 0.1304347826087, -0.1, 0.25
86477, 0.15217391304348, -0.1, 0.27777777777778
86478, 0.1304347826087, -0.075, 0.27777777777778
86479, 0.1304347826087, -0.1, 0.30555555555556
86480, 0.15217391304348, -0.1, 0.33333333333333
86481, 0.1304347826087, -0.075, 0.33333333333333
86482, 0.1304347826087, -0.1, 0.36111111111111
86483, 0.15217391304348, -0.1, 0.38888888888889
86484, 0.1304347826087, -0.075, 0.38888888888889
86485, 0.1304347826087, -0.1, 0.41666666666667
86486, 0.15217391304348, -0.1, 0.44444444444444
86487, 0.1304347826087, -0.075, 0.44444444444444
86488, 0.1304347826087, -0.1, 0.47222222222222
86489, 0.08695652173913, -0.1, 0.027777777777778
86490, 0.10869565217391, -0.1, 0.055555555555556
86491, 0.08695652173913, -0.075, 0.055555555555556
86492, 0.08695652173913, -0.1, 0.083333333333333
86493, 0.10869565217391, -0.1, 0.11111111111111
86494, 0.08695652173913, -0.075, 0.11111111111111
86495, 0.08695652173913, -0.1, 0.13888888888889
86496, 0.10869565217391, -0.1, 0.16666666666667
86497, 0.08695652173913, -0.075, 0.16666666666667
86498, 0.08695652173913, -0.1, 0.19444444444444
86499, 0.10869565217391, -0.1, 0.22222222222222
86500, 0.08695652173913, -0.075, 0.22222222222222
86501, 0.08695652173913, -0.1, 0.25
86502, 0.10869565217391, -0.1, 0.27777777777778
86503, 0.08695652173913, -0.075, 0.27777777777778
86504, 0.08695652173913, -0.1, 0.30555555555556
86505, 0.10869565217391, -0.1, 0.33333333333333
86506, 0.08695652173913, -0.075, 0.33333333333333
86507, 0.08695652173913, -0.1, 0.36111111111111
86508, 0.10869565217391, -0.1, 0.38888888888889
86509, 0.08695652173913, -0.075, 0.38888888888889
86510, 0.08695652173913, -0.1, 0.41666666666667
86511, 0.10869565217391, -0.1, 0.44444444444444
86512, 0.08695652173913, -0.075, 0.44444444444444
86513, 0.08695652173913, -0.1, 0.47222222222222
86514, 0.043478260869565, -0.1, 0.027777777777778
86515, 0.065217391304348, -0.1, 0.055555555555556
86516, 0.043478260869565, -0.075, 0.055555555555556
86517, 0.043478260869565, -0.1, 0.083333333333333
86518, 0.065217391304348, -0.1, 0.11111111111111
86519, 0.043478260869565, -0.075, 0.11111111111111
86520, 0.043478260869565, -0.1, 0.13888888888889
86521, 0.065217391304348, -0.1, 0.16666666666667
86522, 0.043478260869565, -0.075, 0.16666666666667
86523, 0.043478260869565, -0.1, 0.19444444444444
86524, 0.065217391304348, -0.1, 0.22222222222222
86525, 0.043478260869565, -0.075, 0.22222222222222
86526, 0.043478260869565, -0.1, 0.25
86527, 0.065217391304348, -0.1, 0.27777777777778
86528, 0.043478260869565, -0.075, 0.27777777777778
86529, 0.043478260869565, -0.1, 0.30555555555556
86530, 0.065217391304348, -0.1, 0.33333333333333
86531, 0.043478260869565, -0.075, 0.33333333333333
86532, 0.043478260869565, -0.1, 0.36111111111111
86533, 0.065217391304348, -0.1, 0.38888888888889
86534, 0.043478260869565, -0.075, 0.38888888888889
86535, 0.043478260869565, -0.1, 0.41666666666667
86536, 0.065217391304348, -0.1, 0.44444444444444
86537, 0.043478260869565, -0.075, 0.44444444444444
86538, 0.043478260869565, -0.1, 0.47222222222222
86539, 0.021739130434783, -0.1, 0.055555555555556
86540, 0.021739130434783, -0.1, 0.11111111111111
86541, 0.021739130434783, -0.1, 0.16666666666667
86542, 0.021739130434783, -0.1, 0.22222222222222
86543, 0.021739130434783, -0.1, 0.27777777777778
86544, 0.021739130434783, -0.1, 0.33333333333333
86545, 0.021739130434783, -0.1, 0.38888888888889
86546, 0.021739130434783, -0.1, 0.44444444444444
86547, 0.95652173913043, -0.15, 0.027777777777778
86548, 0.97826086956522, -0.15, 0.055555555555556
86549, 0.95652173913043, -0.125, 0.055555555555556
86550, 0.95652173913043, -0.15, 0.083333333333333
86551, 0.97826086956522, -0.15, 0.11111111111111
86552, 0.95652173913044, -0.125, 0.11111111111111
86553, 0.95652173913044, -0.15, 0.13888888888889
86554, 0.97826086956522, -0.15, 0.16666666666667
86555, 0.95652173913043, -0.125, 0.16666666666667
86556, 0.95652173913044, -0.15, 0.19444444444444
86557, 0.97826086956522, -0.15, 0.22222222222222
86558, 0.95652173913043, -0.125, 0.22222222222222
86559, 0.95652173913044, -0.15, 0.25
86560, 0.97826086956522, -0.15, 0.27777777777778
86561, 0.95652173913043, -0.125, 0.27777777777778
86562, 0.95652173913044, -0.15, 0.30555555555556
86563, 0.97826086956522, -0.15, 0.33333333333333
86564, 0.95652173913043, -0.125, 0.33333333333333
86565, 0.95652173913044, -0.15, 0.36111111111111
86566, 0.97826086956522, -0.15, 0.38888888888889
86567, 0.95652173913043, -0.125, 0.38888888888889
86568, 0.95652173913044, -0.15, 0.41666666666667
86569, 0.97826086956522, -0.15, 0.44444444444444
86570, 0.95652173913043, -0.125, 0.44444444444444
86571, 0.95652173913043, -0.15, 0.47222222222222
86572, 0.91304347826087, -0.15, 0.027777777777778
86573, 0.93478260869565, -0.15, 0.055555555555556
86574, 0.91304347826087, -0.125, 0.055555555555556
86575, 0.91304347826087, -0.15, 0.083333333333333
86576, 0.93478260869565, -0.15, 0.11111111111111
86577, 0.91304347826087, -0.125, 0.11111111111111
86578, 0.91304347826087, -0.15, 0.13888888888889
86579, 0.93478260869565, -0.15, 0.16666666666667
86580, 0.91304347826087, -0.125, 0.16666666666667
86581, 0.91304347826087, -0.15, 0.19444444444444
86582, 0.93478260869565, -0.15, 0.22222222222222
86583, 0.91304347826087, -0.125, 0.22222222222222
86584, 0.91304347826087, -0.15, 0.25
86585, 0.93478260869565, -0.15, 0.27777777777778
86586, 0.91304347826087, -0.125, 0.27777777777778
86587, 0.91304347826087, -0.15, 0.30555555555556
86588, 0.93478260869565, -0.15, 0.33333333333333
86589, 0.91304347826087, -0.125, 0.33333333333333
86590, 0.91304347826087, -0.15, 0.36111111111111
86591, 0.93478260869565, -0.15, 0.38888888888889
86592, 0.91304347826087, -0.125, 0.38888888888889
86593, 0.91304347826087, -0.15, 0.41666666666667
86594, 0.93478260869565, -0.15, 0.44444444444444
86595, 0.91304347826087, -0.125, 0.44444444444444
86596, 0.91304347826087, -0.15, 0.47222222222222
86597, 0.8695652173913, -0.15, 0.027777777777778
86598, 0.89130434782609, -0.15, 0.055555555555556
86599, 0.8695652173913, -0.125, 0.055555555555556
86600, 0.8695652173913, -0.15, 0.083333333333333
86601, 0.89130434782609, -0.15, 0.11111111111111
86602, 0.8695652173913, -0.125, 0.11111111111111
86603, 0.8695652173913, -0.15, 0.13888888888889
86604, 0.89130434782609, -0.15, 0.16666666666667
86605, 0.8695652173913, -0.125, 0.16666666666667
86606, 0.8695652173913, -0.15, 0.19444444444444
86607, 0.89130434782609, -0.15, 0.22222222222222
86608, 0.8695652173913, -0.125, 0.22222222222222
86609, 0.8695652173913, -0.15, 0.25
86610, 0.89130434782609, -0.15, 0.27777777777778
86611, 0.8695652173913, -0.125, 0.27777777777778
86612, 0.8695652173913, -0.15, 0.30555555555556
86613, 0.89130434782609, -0.15, 0.33333333333333
86614, 0.8695652173913, -0.125, 0.33333333333333
86615, 0.8695652173913, -0.15, 0.36111111111111
86616, 0.89130434782609, -0.15, 0.38888888888889
86617, 0.8695652173913, -0.125, 0.38888888888889
86618, 0.8695652173913, -0.15, 0.41666666666667
86619, 0.89130434782609, -0.15, 0.44444444444444
86620, 0.8695652173913, -0.125, 0.44444444444444
86621, 0.8695652173913, -0.15, 0.47222222222222
86622, 0.82608695652174, -0.15, 0.027777777777778
86623, 0.84782608695652, -0.15, 0.055555555555556
86624, 0.82608695652174, -0.125, 0.055555555555556
86625, 0.82608695652174, -0.15, 0.083333333333333
86626, 0.84782608695652, -0.15, 0.11111111111111
86627, 0.82608695652174, -0.125, 0.11111111111111
86628, 0.82608695652174, -0.15, 0.13888888888889
86629, 0.84782608695652, -0.15, 0.16666666666667
86630, 0.82608695652174, -0.125, 0.16666666666667
86631, 0.82608695652174, -0.15, 0.19444444444444
86632, 0.84782608695652, -0.15, 0.22222222222222
86633, 0.82608695652174, -0.125, 0.22222222222222
86634, 0.82608695652174, -0.15, 0.25
86635, 0.84782608695652, -0.15, 0.27777777777778
86636, 0.82608695652174, -0.125, 0.27777777777778
86637, 0.82608695652174, -0.15, 0.30555555555556
86638, 0.84782608695652, -0.15, 0.33333333333333
86639, 0.82608695652174, -0.125, 0.33333333333333
86640, 0.82608695652174, -0.15, 0.36111111111111
86641, 0.84782608695652, -0.15, 0.38888888888889
86642, 0.82608695652174, -0.125, 0.38888888888889
86643, 0.82608695652174, -0.15, 0.41666666666667
86644, 0.84782608695652, -0.15, 0.44444444444444
86645, 0.82608695652174, -0.125, 0.44444444444444
86646, 0.82608695652174, -0.15, 0.47222222222222
86647, 0.78260869565217, -0.15, 0.027777777777778
86648, 0.80434782608696, -0.15, 0.055555555555556
86649, 0.78260869565217, -0.125, 0.055555555555556
86650, 0.78260869565217, -0.15, 0.083333333333333
86651, 0.80434782608696, -0.15, 0.11111111111111
86652, 0.78260869565217, -0.125, 0.11111111111111
86653, 0.78260869565217, -0.15, 0.13888888888889
86654, 0.80434782608696, -0.15, 0.16666666666667
86655, 0.78260869565217, -0.125, 0.16666666666667
86656, 0.78260869565217, -0.15, 0.19444444444444
86657, 0.80434782608696, -0.15, 0.22222222222222
86658, 0.78260869565217, -0.125, 0.22222222222222
86659, 0.78260869565217, -0.15, 0.25
86660, 0.80434782608696, -0.15, 0.27777777777778
86661, 0.78260869565217, -0.125, 0.27777777777778
86662, 0.78260869565217, -0.15, 0.30555555555556
86663, 0.80434782608696, -0.15, 0.33333333333333
86664, 0.78260869565217, -0.125, 0.33333333333333
86665, 0.78260869565217, -0.15, 0.36111111111111
86666, 0.80434782608696, -0.15, 0.38888888888889
86667, 0.78260869565217, -0.125, 0.38888888888889
86668, 0.78260869565217, -0.15, 0.41666666666667
86669, 0.80434782608696, -0.15, 0.44444444444444
86670, 0.78260869565217, -0.125, 0.44444444444444
86671, 0.78260869565217, -0.15, 0.47222222222222
86672, 0.73913043478261, -0.15, 0.027777777777778
86673, 0.76086956521739, -0.15, 0.055555555555556
86674, 0.73913043478261, -0.125, 0.055555555555556
86675, 0.73913043478261, -0.15, 0.083333333333333
86676, 0.76086956521739, -0.15, 0.11111111111111
86677, 0.73913043478261, -0.125, 0.11111111111111
86678, 0.73913043478261, -0.15, 0.13888888888889
86679, 0.76086956521739, -0.15, 0.16666666666667
86680, 0.73913043478261, -0.125, 0.16666666666667
86681, 0.73913043478261, -0.15, 0.19444444444444
86682, 0.76086956521739, -0.15, 0.22222222222222
86683, 0.73913043478261, -0.125, 0.22222222222222
86684, 0.73913043478261, -0.15, 0.25
86685, 0.76086956521739, -0.15, 0.27777777777778
86686, 0.73913043478261, -0.125, 0.27777777777778
86687, 0.73913043478261, -0.15, 0.30555555555556
86688, 0.76086956521739, -0.15, 0.33333333333333
86689, 0.73913043478261, -0.125, 0.33333333333333
86690, 0.73913043478261, -0.15, 0.36111111111111
86691, 0.76086956521739, -0.15, 0.38888888888889
86692, 0.73913043478261, -0.125, 0.38888888888889
86693, 0.73913043478261, -0.15, 0.41666666666667
86694, 0.76086956521739, -0.15, 0.44444444444444
86695, 0.73913043478261, -0.125, 0.44444444444444
86696, 0.73913043478261, -0.15, 0.47222222222222
86697, 0.69565217391304, -0.15, 0.027777777777778
86698, 0.71739130434783, -0.15, 0.055555555555556
86699, 0.69565217391304, -0.125, 0.055555555555556
86700, 0.69565217391304, -0.15, 0.083333333333333
86701, 0.71739130434783, -0.15, 0.11111111111111
86702, 0.69565217391304, -0.125, 0.11111111111111
86703, 0.69565217391304, -0.15, 0.13888888888889
86704, 0.71739130434783, -0.15, 0.16666666666667
86705, 0.69565217391304, -0.125, 0.16666666666667
86706, 0.69565217391304, -0.15, 0.19444444444444
86707, 0.71739130434783, -0.15, 0.22222222222222
86708, 0.69565217391304, -0.125, 0.22222222222222
86709, 0.69565217391304, -0.15, 0.25
86710, 0.71739130434783, -0.15, 0.27777777777778
86711, 0.69565217391304, -0.125, 0.27777777777778
86712, 0.69565217391304, -0.15, 0.30555555555556
86713, 0.71739130434783, -0.15, 0.33333333333333
86714, 0.69565217391304, -0.125, 0.33333333333333
86715, 0.69565217391304, -0.15, 0.36111111111111
86716, 0.71739130434783, -0.15, 0.38888888888889
86717, 0.69565217391304, -0.125, 0.38888888888889
86718, 0.69565217391304, -0.15, 0.41666666666667
86719, 0.71739130434783, -0.15, 0.44444444444444
86720, 0.69565217391304, -0.125, 0.44444444444444
86721, 0.69565217391304, -0.15, 0.47222222222222
86722, 0.65217391304348, -0.15, 0.027777777777778
86723, 0.67391304347826, -0.15, 0.055555555555556
86724, 0.65217391304348, -0.125, 0.055555555555556
86725, 0.65217391304348, -0.15, 0.083333333333333
86726, 0.67391304347826, -0.15, 0.11111111111111
86727, 0.65217391304348, -0.125, 0.11111111111111
86728, 0.65217391304348, -0.15, 0.13888888888889
86729, 0.67391304347826, -0.15, 0.16666666666667
86730, 0.65217391304348, -0.125, 0.16666666666667
86731, 0.65217391304348, -0.15, 0.19444444444444
86732, 0.67391304347826, -0.15, 0.22222222222222
86733, 0.65217391304348, -0.125, 0.22222222222222
86734, 0.65217391304348, -0.15, 0.25
86735, 0.67391304347826, -0.15, 0.27777777777778
86736, 0.65217391304348, -0.125, 0.27777777777778
86737, 0.65217391304348, -0.15, 0.30555555555556
86738, 0.67391304347826, -0.15, 0.33333333333333
86739, 0.65217391304348, -0.125, 0.33333333333333
86740, 0.65217391304348, -0.15, 0.36111111111111
86741, 0.67391304347826, -0.15, 0.38888888888889
86742, 0.65217391304348, -0.125, 0.38888888888889
86743, 0.65217391304348, -0.15, 0.41666666666667
86744, 0.67391304347826, -0.15, 0.44444444444444
86745, 0.65217391304348, -0.125, 0.44444444444444
86746, 0.65217391304348, -0.15, 0.47222222222222
86747, 0.60869565217391, -0.15, 0.027777777777778
86748, 0.6304347826087, -0.15, 0.055555555555556
86749, 0.60869565217391, -0.125, 0.055555555555556
86750, 0.60869565217391, -0.15, 0.083333333333333
86751, 0.6304347826087, -0.15, 0.11111111111111
86752, 0.60869565217391, -0.125, 0.11111111111111
86753, 0.60869565217391, -0.15, 0.13888888888889
86754, 0.6304347826087, -0.15, 0.16666666666667
86755, 0.60869565217391, -0.125, 0.16666666666667
86756, 0.60869565217391, -0.15, 0.19444444444444
86757, 0.6304347826087, -0.15, 0.22222222222222
86758, 0.60869565217391, -0.125, 0.22222222222222
86759, 0.60869565217391, -0.15, 0.25
86760, 0.6304347826087, -0.15, 0.27777777777778
86761, 0.60869565217391, -0.125, 0.27777777777778
86762, 0.60869565217391, -0.15, 0.30555555555556
86763, 0.6304347826087, -0.15, 0.33333333333333
86764, 0.60869565217391, -0.125, 0.33333333333333
86765, 0.60869565217391, -0.15, 0.36111111111111
86766, 0.6304347826087, -0.15, 0.38888888888889
86767, 0.60869565217391, -0.125, 0.38888888888889
86768, 0.60869565217391, -0.15, 0.41666666666667
86769, 0.6304347826087, -0.15, 0.44444444444444
86770, 0.60869565217391, -0.125, 0.44444444444444
86771, 0.60869565217391, -0.15, 0.47222222222222
86772, 0.56521739130435, -0.15, 0.027777777777778
86773, 0.58695652173913, -0.15, 0.055555555555556
86774, 0.56521739130435, -0.125, 0.055555555555556
86775, 0.56521739130435, -0.15, 0.083333333333333
86776, 0.58695652173913, -0.15, 0.11111111111111
86777, 0.56521739130435, -0.125, 0.11111111111111
86778, 0.56521739130435, -0.15, 0.13888888888889
86779, 0.58695652173913, -0.15, 0.16666666666667
86780, 0.56521739130435, -0.125, 0.16666666666667
86781, 0.56521739130435, -0.15, 0.19444444444444
86782, 0.58695652173913, -0.15, 0.22222222222222
86783, 0.56521739130435, -0.125, 0.22222222222222
86784, 0.56521739130435, -0.15, 0.25
86785, 0.58695652173913, -0.15, 0.27777777777778
86786, 0.56521739130435, -0.125, 0.27777777777778
86787, 0.56521739130435, -0.15, 0.30555555555556
86788, 0.58695652173913, -0.15, 0.33333333333333
86789, 0.56521739130435, -0.125, 0.33333333333333
86790, 0.56521739130435, -0.15, 0.36111111111111
86791, 0.58695652173913, -0.15, 0.38888888888889
86792, 0.56521739130435, -0.125, 0.38888888888889
86793, 0.56521739130435, -0.15, 0.41666666666667
86794, 0.58695652173913, -0.15, 0.44444444444444
86795, 0.56521739130435, -0.125, 0.44444444444444
86796, 0.56521739130435, -0.15, 0.47222222222222
86797, 0.52173913043478, -0.15, 0.027777777777778
86798, 0.54347826086957, -0.15, 0.055555555555556
86799, 0.52173913043478, -0.125, 0.055555555555556
86800, 0.52173913043478, -0.15, 0.083333333333333
86801, 0.54347826086957, -0.15, 0.11111111111111
86802, 0.52173913043478, -0.125, 0.11111111111111
86803, 0.52173913043478, -0.15, 0.13888888888889
86804, 0.54347826086957, -0.15, 0.16666666666667
86805, 0.52173913043478, -0.125, 0.16666666666667
86806, 0.52173913043478, -0.15, 0.19444444444444
86807, 0.54347826086956, -0.15, 0.22222222222222
86808, 0.52173913043478, -0.125, 0.22222222222222
86809, 0.52173913043478, -0.15, 0.25
86810, 0.54347826086956, -0.15, 0.27777777777778
86811, 0.52173913043478, -0.125, 0.27777777777778
86812, 0.52173913043478, -0.15, 0.30555555555556
86813, 0.54347826086956, -0.15, 0.33333333333333
86814, 0.52173913043478, -0.125, 0.33333333333333
86815, 0.52173913043478, -0.15, 0.36111111111111
86816, 0.54347826086956, -0.15, 0.38888888888889
86817, 0.52173913043478, -0.125, 0.38888888888889
86818, 0.52173913043478, -0.15, 0.41666666666667
86819, 0.54347826086956, -0.15, 0.44444444444444
86820, 0.52173913043478, -0.125, 0.44444444444444
86821, 0.52173913043478, -0.15, 0.47222222222222
86822, 0.47826086956522, -0.15, 0.027777777777778
86823, 0.5, -0.15, 0.055555555555556
86824, 0.47826086956522, -0.125, 0.055555555555556
86825, 0.47826086956522, -0.15, 0.083333333333333
86826, 0.5, -0.15, 0.11111111111111
86827, 0.47826086956522, -0.125, 0.11111111111111
86828, 0.47826086956522, -0.15, 0.13888888888889
86829, 0.5, -0.15, 0.16666666666667
86830, 0.47826086956522, -0.125, 0.16666666666667
86831, 0.47826086956522, -0.15, 0.19444444444444
86832, 0.5, -0.15, 0.22222222222222
86833, 0.47826086956522, -0.125, 0.22222222222222
86834, 0.47826086956522, -0.15, 0.25
86835, 0.5, -0.15, 0.27777777777778
86836, 0.47826086956522, -0.125, 0.27777777777778
86837, 0.47826086956522, -0.15, 0.30555555555556
86838, 0.5, -0.15, 0.33333333333333
86839, 0.47826086956522, -0.125, 0.33333333333333
86840, 0.47826086956522, -0.15, 0.36111111111111
86841, 0.5, -0.15, 0.38888888888889
86842, 0.47826086956522, -0.125, 0.38888888888889
86843, 0.47826086956522, -0.15, 0.41666666666667
86844, 0.5, -0.15, 0.44444444444444
86845, 0.47826086956522, -0.125, 0.44444444444444
86846, 0.47826086956522, -0.15, 0.47222222222222
86847, 0.43478260869565, -0.15, 0.027777777777778
86848, 0.45652173913043, -0.15, 0.055555555555556
86849, 0.43478260869565, -0.125, 0.055555555555556
86850, 0.43478260869565, -0.15, 0.083333333333333
86851, 0.45652173913043, -0.15, 0.11111111111111
86852, 0.43478260869565, -0.125, 0.11111111111111
86853, 0.43478260869565, -0.15, 0.13888888888889
86854, 0.45652173913043, -0.15, 0.16666666666667
86855, 0.43478260869565, -0.125, 0.16666666666667
86856, 0.43478260869565, -0.15, 0.19444444444444
86857, 0.45652173913043, -0.15, 0.22222222222222
86858, 0.43478260869565, -0.125, 0.22222222222222
86859, 0.43478260869565, -0.15, 0.25
86860, 0.45652173913043, -0.15, 0.27777777777778
86861, 0.43478260869565, -0.125, 0.27777777777778
86862, 0.43478260869565, -0.15, 0.30555555555556
86863, 0.45652173913043, -0.15, 0.33333333333333
86864, 0.43478260869565, -0.125, 0.33333333333333
86865, 0.43478260869565, -0.15, 0.36111111111111
86866, 0.45652173913044, -0.15, 0.38888888888889
86867, 0.43478260869565, -0.125, 0.38888888888889
86868, 0.43478260869565, -0.15, 0.41666666666667
86869, 0.45652173913043, -0.15, 0.44444444444444
86870, 0.43478260869565, -0.125, 0.44444444444444
86871, 0.43478260869565, -0.15, 0.47222222222222
86872, 0.39130434782609, -0.15, 0.027777777777778
86873, 0.41304347826087, -0.15, 0.055555555555556
86874, 0.39130434782609, -0.125, 0.055555555555556
86875, 0.39130434782609, -0.15, 0.083333333333333
86876, 0.41304347826087, -0.15, 0.11111111111111
86877, 0.39130434782609, -0.125, 0.11111111111111
86878, 0.39130434782609, -0.15, 0.13888888888889
86879, 0.41304347826087, -0.15, 0.16666666666667
86880, 0.39130434782609, -0.125, 0.16666666666667
86881, 0.39130434782609, -0.15, 0.19444444444444
86882, 0.41304347826087, -0.15, 0.22222222222222
86883, 0.39130434782609, -0.125, 0.22222222222222
86884, 0.39130434782609, -0.15, 0.25
86885, 0.41304347826087, -0.15, 0.27777777777778
86886, 0.39130434782609, -0.125, 0.27777777777778
86887, 0.39130434782609, -0.15, 0.30555555555556
86888, 0.41304347826087, -0.15, 0.33333333333333
86889, 0.39130434782609, -0.125, 0.33333333333333
86890, 0.39130434782609, -0.15, 0.36111111111111
86891, 0.41304347826087, -0.15, 0.38888888888889
86892, 0.39130434782609, -0.125, 0.38888888888889
86893, 0.39130434782609, -0.15, 0.41666666666667
86894, 0.41304347826087, -0.15, 0.44444444444444
86895, 0.39130434782609, -0.125, 0.44444444444444
86896, 0.39130434782609, -0.15, 0.47222222222222
86897, 0.34782608695652, -0.15, 0.027777777777778
86898, 0.3695652173913, -0.15, 0.055555555555556
86899, 0.34782608695652, -0.125, 0.055555555555556
86900, 0.34782608695652, -0.15, 0.083333333333333
86901, 0.3695652173913, -0.15, 0.11111111111111
86902, 0.34782608695652, -0.125, 0.11111111111111
86903, 0.34782608695652, -0.15, 0.13888888888889
86904, 0.3695652173913, -0.15, 0.16666666666667
86905, 0.34782608695652, -0.125, 0.16666666666667
86906, 0.34782608695652, -0.15, 0.19444444444444
86907, 0.3695652173913, -0.15, 0.22222222222222
86908, 0.34782608695652, -0.125, 0.22222222222222
86909, 0.34782608695652, -0.15, 0.25
86910, 0.3695652173913, -0.15, 0.27777777777778
86911, 0.34782608695652, -0.125, 0.27777777777778
86912, 0.34782608695652, -0.15, 0.30555555555556
86913, 0.3695652173913, -0.15, 0.33333333333333
86914, 0.34782608695652, -0.125, 0.33333333333333
86915, 0.34782608695652, -0.15, 0.36111111111111
86916, 0.3695652173913, -0.15, 0.38888888888889
86917, 0.34782608695652, -0.125, 0.38888888888889
86918, 0.34782608695652, -0.15, 0.41666666666667
86919, 0.3695652173913, -0.15, 0.44444444444444
86920, 0.34782608695652, -0.125, 0.44444444444444
86921, 0.34782608695652, -0.15, 0.47222222222222
86922, 0.30434782608696, -0.15, 0.027777777777778
86923, 0.32608695652174, -0.15, 0.055555555555556
86924, 0.30434782608696, -0.125, 0.055555555555556
86925, 0.30434782608696, -0.15, 0.083333333333333
86926, 0.32608695652174, -0.15, 0.11111111111111
86927, 0.30434782608696, -0.125, 0.11111111111111
86928, 0.30434782608696, -0.15, 0.13888888888889
86929, 0.32608695652174, -0.15, 0.16666666666667
86930, 0.30434782608696, -0.125, 0.16666666666667
86931, 0.30434782608696, -0.15, 0.19444444444444
86932, 0.32608695652174, -0.15, 0.22222222222222
86933, 0.30434782608696, -0.125, 0.22222222222222
86934, 0.30434782608696, -0.15, 0.25
86935, 0.32608695652174, -0.15, 0.27777777777778
86936, 0.30434782608696, -0.125, 0.27777777777778
86937, 0.30434782608696, -0.15, 0.30555555555556
86938, 0.32608695652174, -0.15, 0.33333333333333
86939, 0.30434782608696, -0.125, 0.33333333333333
86940, 0.30434782608696, -0.15, 0.36111111111111
86941, 0.32608695652174, -0.15, 0.38888888888889
86942, 0.30434782608696, -0.125, 0.38888888888889
86943, 0.30434782608696, -0.15, 0.41666666666667
86944, 0.32608695652174, -0.15, 0.44444444444444
86945, 0.30434782608696, -0.125, 0.44444444444444
86946, 0.30434782608696, -0.15, 0.47222222222222
86947, 0.26086956521739, -0.15, 0.027777777777778
86948, 0.28260869565217, -0.15, 0.055555555555556
86949, 0.26086956521739, -0.125, 0.055555555555556
86950, 0.26086956521739, -0.15, 0.083333333333333
86951, 0.28260869565217, -0.15, 0.11111111111111
86952, 0.26086956521739, -0.125, 0.11111111111111
86953, 0.26086956521739, -0.15, 0.13888888888889
86954, 0.28260869565217, -0.15, 0.16666666666667
86955, 0.26086956521739, -0.125, 0.16666666666667
86956, 0.26086956521739, -0.15, 0.19444444444444
86957, 0.28260869565217, -0.15, 0.22222222222222
86958, 0.26086956521739, -0.125, 0.22222222222222
86959, 0.26086956521739, -0.15, 0.25
86960, 0.28260869565217, -0.15, 0.27777777777778
86961, 0.26086956521739, -0.125, 0.27777777777778
86962, 0.26086956521739, -0.15, 0.30555555555556
86963, 0.28260869565217, -0.15, 0.33333333333333
86964, 0.26086956521739, -0.125, 0.33333333333333
86965, 0.26086956521739, -0.15, 0.36111111111111
86966, 0.28260869565217, -0.15, 0.38888888888889
86967, 0.26086956521739, -0.125, 0.38888888888889
86968, 0.26086956521739, -0.15, 0.41666666666667
86969, 0.28260869565217, -0.15, 0.44444444444444
86970, 0.26086956521739, -0.125, 0.44444444444444
86971, 0.26086956521739, -0.15, 0.47222222222222
86972, 0.21739130434783, -0.15, 0.027777777777778
86973, 0.23913043478261, -0.15, 0.055555555555556
86974, 0.21739130434783, -0.125, 0.055555555555556
86975, 0.21739130434783, -0.15, 0.083333333333333
86976, 0.23913043478261, -0.15, 0.11111111111111
86977, 0.21739130434783, -0.125, 0.11111111111111
86978, 0.21739130434783, -0.15, 0.13888888888889
86979, 0.23913043478261, -0.15, 0.16666666666667
86980, 0.21739130434783, -0.125, 0.16666666666667
86981, 0.21739130434783, -0.15, 0.19444444444444
86982, 0.23913043478261, -0.15, 0.22222222222222
86983, 0.21739130434783, -0.125, 0.22222222222222
86984, 0.21739130434783, -0.15, 0.25
86985, 0.23913043478261, -0.15, 0.27777777777778
86986, 0.21739130434783, -0.125, 0.27777777777778
86987, 0.21739130434783, -0.15, 0.30555555555556
86988, 0.23913043478261, -0.15, 0.33333333333333
86989, 0.21739130434783, -0.125, 0.33333333333333
86990, 0.21739130434783, -0.15, 0.36111111111111
86991, 0.23913043478261, -0.15, 0.38888888888889
86992, 0.21739130434783, -0.125, 0.38888888888889
86993, 0.21739130434783, -0.15, 0.41666666666667
86994, 0.23913043478261, -0.15, 0.44444444444444
86995, 0.21739130434783, -0.125, 0.44444444444444
86996, 0.21739130434783, -0.15, 0.47222222222222
86997, 0.17391304347826, -0.15, 0.027777777777778
86998, 0.19565217391304, -0.15, 0.055555555555556
86999, 0.17391304347826, -0.125, 0.055555555555556
87000, 0.17391304347826, -0.15, 0.083333333333333
87001, 0.19565217391304, -0.15, 0.11111111111111
87002, 0.17391304347826, -0.125, 0.11111111111111
87003, 0.17391304347826, -0.15, 0.13888888888889
87004, 0.19565217391304, -0.15, 0.16666666666667
87005, 0.17391304347826, -0.125, 0.16666666666667
87006, 0.17391304347826, -0.15, 0.19444444444444
87007, 0.19565217391304, -0.15, 0.22222222222222
87008, 0.17391304347826, -0.125, 0.22222222222222
87009, 0.17391304347826, -0.15, 0.25
87010, 0.19565217391304, -0.15, 0.27777777777778
87011, 0.17391304347826, -0.125, 0.27777777777778
87012, 0.17391304347826, -0.15, 0.30555555555556
87013, 0.19565217391304, -0.15, 0.33333333333333
87014, 0.17391304347826, -0.125, 0.33333333333333
87015, 0.17391304347826, -0.15, 0.36111111111111
87016, 0.19565217391304, -0.15, 0.38888888888889
87017, 0.17391304347826, -0.125, 0.38888888888889
87018, 0.17391304347826, -0.15, 0.41666666666667
87019, 0.19565217391304, -0.15, 0.44444444444444
87020, 0.17391304347826, -0.125, 0.44444444444444
87021, 0.17391304347826, -0.15, 0.47222222222222
87022, 0.1304347826087, -0.15, 0.027777777777778
87023, 0.15217391304348, -0.15, 0.055555555555556
87024, 0.1304347826087, -0.125, 0.055555555555556
87025, 0.1304347826087, -0.15, 0.083333333333333
87026, 0.15217391304348, -0.15, 0.11111111111111
87027, 0.1304347826087, -0.125, 0.11111111111111
87028, 0.1304347826087, -0.15, 0.13888888888889
87029, 0.15217391304348, -0.15, 0.16666666666667
87030, 0.1304347826087, -0.125, 0.16666666666667
87031, 0.1304347826087, -0.15, 0.19444444444444
87032, 0.15217391304348, -0.15, 0.22222222222222
87033, 0.1304347826087, -0.125, 0.22222222222222
87034, 0.1304347826087, -0.15, 0.25
87035, 0.15217391304348, -0.15, 0.27777777777778
87036, 0.1304347826087, -0.125, 0.27777777777778
87037, 0.1304347826087, -0.15, 0.30555555555556
87038, 0.15217391304348, -0.15, 0.33333333333333
87039, 0.1304347826087, -0.125, 0.33333333333333
87040, 0.1304347826087, -0.15, 0.36111111111111
87041, 0.15217391304348, -0.15, 0.38888888888889
87042, 0.1304347826087, -0.125, 0.38888888888889
87043, 0.1304347826087, -0.15, 0.41666666666667
87044, 0.15217391304348, -0.15, 0.44444444444444
87045, 0.1304347826087, -0.125, 0.44444444444444
87046, 0.1304347826087, -0.15, 0.47222222222222
87047, 0.08695652173913, -0.15, 0.027777777777778
87048, 0.10869565217391, -0.15, 0.055555555555556
87049, 0.08695652173913, -0.125, 0.055555555555556
87050, 0.08695652173913, -0.15, 0.083333333333333
87051, 0.10869565217391, -0.15, 0.11111111111111
87052, 0.08695652173913, -0.125, 0.11111111111111
87053, 0.08695652173913, -0.15, 0.13888888888889
87054, 0.10869565217391, -0.15, 0.16666666666667
87055, 0.08695652173913, -0.125, 0.16666666666667
87056, 0.08695652173913, -0.15, 0.19444444444444
87057, 0.10869565217391, -0.15, 0.22222222222222
87058, 0.08695652173913, -0.125, 0.22222222222222
87059, 0.08695652173913, -0.15, 0.25
87060, 0.10869565217391, -0.15, 0.27777777777778
87061, 0.08695652173913, -0.125, 0.27777777777778
87062, 0.08695652173913, -0.15, 0.30555555555556
87063, 0.10869565217391, -0.15, 0.33333333333333
87064, 0.08695652173913, -0.125, 0.33333333333333
87065, 0.08695652173913, -0.15, 0.36111111111111
87066, 0.10869565217391, -0.15, 0.38888888888889
87067, 0.08695652173913, -0.125, 0.38888888888889
87068, 0.08695652173913, -0.15, 0.41666666666667
87069, 0.10869565217391, -0.15, 0.44444444444444
87070, 0.08695652173913, -0.125, 0.44444444444444
87071, 0.08695652173913, -0.15, 0.47222222222222
87072, 0.043478260869565, -0.15, 0.027777777777778
87073, 0.065217391304348, -0.15, 0.055555555555556
87074, 0.043478260869565, -0.125, 0.055555555555556
87075, 0.043478260869565, -0.15, 0.083333333333333
87076, 0.065217391304348, -0.15, 0.11111111111111
87077, 0.043478260869565, -0.125, 0.11111111111111
87078, 0.043478260869565, -0.15, 0.13888888888889
87079, 0.065217391304348, -0.15, 0.16666666666667
87080, 0.043478260869565, -0.125, 0.16666666666667
87081, 0.043478260869565, -0.15, 0.19444444444444
87082, 0.065217391304348, -0.15, 0.22222222222222
87083, 0.043478260869565, -0.125, 0.22222222222222
87084, 0.043478260869565, -0.15, 0.25
87085, 0.065217391304348, -0.15, 0.27777777777778
87086, 0.043478260869565, -0.125, 0.27777777777778
87087, 0.043478260869565, -0.15, 0.30555555555556
87088, 0.065217391304348, -0.15, 0.33333333333333
87089, 0.043478260869565, -0.125, 0.33333333333333
87090, 0.043478260869565, -0.15, 0.36111111111111
87091, 0.065217391304348, -0.15, 0.38888888888889
87092, 0.043478260869565, -0.125, 0.38888888888889
87093, 0.043478260869565, -0.15, 0.41666666666667
87094, 0.065217391304348, -0.15, 0.44444444444444
87095, 0.043478260869565, -0.125, 0.44444444444444
87096, 0.043478260869565, -0.15, 0.47222222222222
87097, 0.021739130434783, -0.15, 0.055555555555556
87098, 0.021739130434783, -0.15, 0.11111111111111
87099, 0.021739130434783, -0.15, 0.16666666666667
87100, 0.021739130434783, -0.15, 0.22222222222222
87101, 0.021739130434783, -0.15, 0.27777777777778
87102, 0.021739130434783, -0.15, 0.33333333333333
87103, 0.021739130434783, -0.15, 0.38888888888889
87104, 0.021739130434783, -0.15, 0.44444444444444
87105, 0.95652173913043, -0.2, 0.027777777777778
87106, 0.97826086956522, -0.2, 0.055555555555556
87107, 0.95652173913043, -0.175, 0.055555555555556
87108, 0.95652173913043, -0.2, 0.083333333333333
87109, 0.97826086956522, -0.2, 0.11111111111111
87110, 0.95652173913044, -0.175, 0.11111111111111
87111, 0.95652173913044, -0.2, 0.13888888888889
87112, 0.97826086956522, -0.2, 0.16666666666667
87113, 0.95652173913043, -0.175, 0.16666666666667
87114, 0.95652173913043, -0.2, 0.19444444444444
87115, 0.97826086956522, -0.2, 0.22222222222222
87116, 0.95652173913044, -0.175, 0.22222222222222
87117, 0.95652173913044, -0.2, 0.25
87118, 0.97826086956522, -0.2, 0.27777777777778
87119, 0.95652173913044, -0.175, 0.27777777777778
87120, 0.95652173913043, -0.2, 0.30555555555556
87121, 0.97826086956522, -0.2, 0.33333333333333
87122, 0.95652173913043, -0.175, 0.33333333333333
87123, 0.95652173913043, -0.2, 0.36111111111111
87124, 0.97826086956522, -0.2, 0.38888888888889
87125, 0.95652173913044, -0.175, 0.38888888888889
87126, 0.95652173913044, -0.2, 0.41666666666667
87127, 0.97826086956522, -0.2, 0.44444444444444
87128, 0.95652173913044, -0.175, 0.44444444444444
87129, 0.95652173913043, -0.2, 0.47222222222222
87130, 0.91304347826087, -0.2, 0.027777777777778
87131, 0.93478260869565, -0.2, 0.055555555555556
87132, 0.91304347826087, -0.175, 0.055555555555556
87133, 0.91304347826087, -0.2, 0.083333333333333
87134, 0.93478260869565, -0.2, 0.11111111111111
87135, 0.91304347826087, -0.175, 0.11111111111111
87136, 0.91304347826087, -0.2, 0.13888888888889
87137, 0.93478260869565, -0.2, 0.16666666666667
87138, 0.91304347826087, -0.175, 0.16666666666667
87139, 0.91304347826087, -0.2, 0.19444444444444
87140, 0.93478260869565, -0.2, 0.22222222222222
87141, 0.91304347826087, -0.175, 0.22222222222222
87142, 0.91304347826087, -0.2, 0.25
87143, 0.93478260869565, -0.2, 0.27777777777778
87144, 0.91304347826087, -0.175, 0.27777777777778
87145, 0.91304347826087, -0.2, 0.30555555555556
87146, 0.93478260869565, -0.2, 0.33333333333333
87147, 0.91304347826087, -0.175, 0.33333333333333
87148, 0.91304347826087, -0.2, 0.36111111111111
87149, 0.93478260869565, -0.2, 0.38888888888889
87150, 0.91304347826087, -0.175, 0.38888888888889
87151, 0.91304347826087, -0.2, 0.41666666666667
87152, 0.93478260869565, -0.2, 0.44444444444444
87153, 0.91304347826087, -0.175, 0.44444444444444
87154, 0.91304347826087, -0.2, 0.47222222222222
87155, 0.8695652173913, -0.2, 0.027777777777778
87156, 0.89130434782609, -0.2, 0.055555555555556
87157, 0.8695652173913, -0.175, 0.055555555555556
87158, 0.8695652173913, -0.2, 0.083333333333333
87159, 0.89130434782609, -0.2, 0.11111111111111
87160, 0.8695652173913, -0.175, 0.11111111111111
87161, 0.8695652173913, -0.2, 0.13888888888889
87162, 0.89130434782609, -0.2, 0.16666666666667
87163, 0.8695652173913, -0.175, 0.16666666666667
87164, 0.8695652173913, -0.2, 0.19444444444444
87165, 0.89130434782609, -0.2, 0.22222222222222
87166, 0.8695652173913, -0.175, 0.22222222222222
87167, 0.8695652173913, -0.2, 0.25
87168, 0.89130434782609, -0.2, 0.27777777777778
87169, 0.8695652173913, -0.175, 0.27777777777778
87170, 0.8695652173913, -0.2, 0.30555555555556
87171, 0.89130434782609, -0.2, 0.33333333333333
87172, 0.8695652173913, -0.175, 0.33333333333333
87173, 0.8695652173913, -0.2, 0.36111111111111
87174, 0.89130434782609, -0.2, 0.38888888888889
87175, 0.8695652173913, -0.175, 0.38888888888889
87176, 0.8695652173913, -0.2, 0.41666666666667
87177, 0.89130434782609, -0.2, 0.44444444444444
87178, 0.8695652173913, -0.175, 0.44444444444444
87179, 0.8695652173913, -0.2, 0.47222222222222
87180, 0.82608695652174, -0.2, 0.027777777777778
87181, 0.84782608695652, -0.2, 0.055555555555556
87182, 0.82608695652174, -0.175, 0.055555555555556
87183, 0.82608695652174, -0.2, 0.083333333333333
87184, 0.84782608695652, -0.2, 0.11111111111111
87185, 0.82608695652174, -0.175, 0.11111111111111
87186, 0.82608695652174, -0.2, 0.13888888888889
87187, 0.84782608695652, -0.2, 0.16666666666667
87188, 0.82608695652174, -0.175, 0.16666666666667
87189, 0.82608695652174, -0.2, 0.19444444444444
87190, 0.84782608695652, -0.2, 0.22222222222222
87191, 0.82608695652174, -0.175, 0.22222222222222
87192, 0.82608695652174, -0.2, 0.25
87193, 0.84782608695652, -0.2, 0.27777777777778
87194, 0.82608695652174, -0.175, 0.27777777777778
87195, 0.82608695652174, -0.2, 0.30555555555556
87196, 0.84782608695652, -0.2, 0.33333333333333
87197, 0.82608695652174, -0.175, 0.33333333333333
87198, 0.82608695652174, -0.2, 0.36111111111111
87199, 0.84782608695652, -0.2, 0.38888888888889
87200, 0.82608695652174, -0.175, 0.38888888888889
87201, 0.82608695652174, -0.2, 0.41666666666667
87202, 0.84782608695652, -0.2, 0.44444444444444
87203, 0.82608695652174, -0.175, 0.44444444444444
87204, 0.82608695652174, -0.2, 0.47222222222222
87205, 0.78260869565217, -0.2, 0.027777777777778
87206, 0.80434782608696, -0.2, 0.055555555555556
87207, 0.78260869565217, -0.175, 0.055555555555556
87208, 0.78260869565217, -0.2, 0.083333333333333
87209, 0.80434782608696, -0.2, 0.11111111111111
87210, 0.78260869565217, -0.175, 0.11111111111111
87211, 0.78260869565217, -0.2, 0.13888888888889
87212, 0.80434782608696, -0.2, 0.16666666666667
87213, 0.78260869565217, -0.175, 0.16666666666667
87214, 0.78260869565217, -0.2, 0.19444444444444
87215, 0.80434782608696, -0.2, 0.22222222222222
87216, 0.78260869565217, -0.175, 0.22222222222222
87217, 0.78260869565217, -0.2, 0.25
87218, 0.80434782608696, -0.2, 0.27777777777778
87219, 0.78260869565217, -0.175, 0.27777777777778
87220, 0.78260869565217, -0.2, 0.30555555555556
87221, 0.80434782608696, -0.2, 0.33333333333333
87222, 0.78260869565217, -0.175, 0.33333333333333
87223, 0.78260869565217, -0.2, 0.36111111111111
87224, 0.80434782608696, -0.2, 0.38888888888889
87225, 0.78260869565217, -0.175, 0.38888888888889
87226, 0.78260869565217, -0.2, 0.41666666666667
87227, 0.80434782608696, -0.2, 0.44444444444444
87228, 0.78260869565217, -0.175, 0.44444444444444
87229, 0.78260869565217, -0.2, 0.47222222222222
87230, 0.73913043478261, -0.2, 0.027777777777778
87231, 0.76086956521739, -0.2, 0.055555555555556
87232, 0.73913043478261, -0.175, 0.055555555555556
87233, 0.73913043478261, -0.2, 0.083333333333333
87234, 0.76086956521739, -0.2, 0.11111111111111
87235, 0.73913043478261, -0.175, 0.11111111111111
87236, 0.73913043478261, -0.2, 0.13888888888889
87237, 0.76086956521739, -0.2, 0.16666666666667
87238, 0.73913043478261, -0.175, 0.16666666666667
87239, 0.73913043478261, -0.2, 0.19444444444444
87240, 0.76086956521739, -0.2, 0.22222222222222
87241, 0.73913043478261, -0.175, 0.22222222222222
87242, 0.73913043478261, -0.2, 0.25
87243, 0.76086956521739, -0.2, 0.27777777777778
87244, 0.73913043478261, -0.175, 0.27777777777778
87245, 0.73913043478261, -0.2, 0.30555555555556
87246, 0.76086956521739, -0.2, 0.33333333333333
87247, 0.73913043478261, -0.175, 0.33333333333333
87248, 0.73913043478261, -0.2, 0.36111111111111
87249, 0.76086956521739, -0.2, 0.38888888888889
87250, 0.73913043478261, -0.175, 0.38888888888889
87251, 0.73913043478261, -0.2, 0.41666666666667
87252, 0.76086956521739, -0.2, 0.44444444444444
87253, 0.73913043478261, -0.175, 0.44444444444444
87254, 0.73913043478261, -0.2, 0.47222222222222
87255, 0.69565217391304, -0.2, 0.027777777777778
87256, 0.71739130434783, -0.2, 0.055555555555556
87257, 0.69565217391304, -0.175, 0.055555555555556
87258, 0.69565217391304, -0.2, 0.083333333333333
87259, 0.71739130434783, -0.2, 0.11111111111111
87260, 0.69565217391304, -0.175, 0.11111111111111
87261, 0.69565217391304, -0.2, 0.13888888888889
87262, 0.71739130434783, -0.2, 0.16666666666667
87263, 0.69565217391304, -0.175, 0.16666666666667
87264, 0.69565217391304, -0.2, 0.19444444444444
87265, 0.71739130434783, -0.2, 0.22222222222222
87266, 0.69565217391304, -0.175, 0.22222222222222
87267, 0.69565217391304, -0.2, 0.25
87268, 0.71739130434783, -0.2, 0.27777777777778
87269, 0.69565217391304, -0.175, 0.27777777777778
87270, 0.69565217391304, -0.2, 0.30555555555556
87271, 0.71739130434783, -0.2, 0.33333333333333
87272, 0.69565217391304, -0.175, 0.33333333333333
87273, 0.69565217391304, -0.2, 0.36111111111111
87274, 0.71739130434783, -0.2, 0.38888888888889
87275, 0.69565217391304, -0.175, 0.38888888888889
87276, 0.69565217391304, -0.2, 0.41666666666667
87277, 0.71739130434783, -0.2, 0.44444444444444
87278, 0.69565217391304, -0.175, 0.44444444444444
87279, 0.69565217391304, -0.2, 0.47222222222222
87280, 0.65217391304348, -0.2, 0.027777777777778
87281, 0.67391304347826, -0.2, 0.055555555555556
87282, 0.65217391304348, -0.175, 0.055555555555556
87283, 0.65217391304348, -0.2, 0.083333333333333
87284, 0.67391304347826, -0.2, 0.11111111111111
87285, 0.65217391304348, -0.175, 0.11111111111111
87286, 0.65217391304348, -0.2, 0.13888888888889
87287, 0.67391304347826, -0.2, 0.16666666666667
87288, 0.65217391304348, -0.175, 0.16666666666667
87289, 0.65217391304348, -0.2, 0.19444444444444
87290, 0.67391304347826, -0.2, 0.22222222222222
87291, 0.65217391304348, -0.175, 0.22222222222222
87292, 0.65217391304348, -0.2, 0.25
87293, 0.67391304347826, -0.2, 0.27777777777778
87294, 0.65217391304348, -0.175, 0.27777777777778
87295, 0.65217391304348, -0.2, 0.30555555555556
87296, 0.67391304347826, -0.2, 0.33333333333333
87297, 0.65217391304348, -0.175, 0.33333333333333
87298, 0.65217391304348, -0.2, 0.36111111111111
87299, 0.67391304347826, -0.2, 0.38888888888889
87300, 0.65217391304348, -0.175, 0.38888888888889
87301, 0.65217391304348, -0.2, 0.41666666666667
87302, 0.67391304347826, -0.2, 0.44444444444444
87303, 0.65217391304348, -0.175, 0.44444444444444
87304, 0.65217391304348, -0.2, 0.47222222222222
87305, 0.60869565217391, -0.2, 0.027777777777778
87306, 0.6304347826087, -0.2, 0.055555555555556
87307, 0.60869565217391, -0.175, 0.055555555555556
87308, 0.60869565217391, -0.2, 0.083333333333333
87309, 0.6304347826087, -0.2, 0.11111111111111
87310, 0.60869565217391, -0.175, 0.11111111111111
87311, 0.60869565217391, -0.2, 0.13888888888889
87312, 0.6304347826087, -0.2, 0.16666666666667
87313, 0.60869565217391, -0.175, 0.16666666666667
87314, 0.60869565217391, -0.2, 0.19444444444444
87315, 0.6304347826087, -0.2, 0.22222222222222
87316, 0.60869565217391, -0.175, 0.22222222222222
87317, 0.60869565217391, -0.2, 0.25
87318, 0.6304347826087, -0.2, 0.27777777777778
87319, 0.60869565217391, -0.175, 0.27777777777778
87320, 0.60869565217391, -0.2, 0.30555555555556
87321, 0.6304347826087, -0.2, 0.33333333333333
87322, 0.60869565217391, -0.175, 0.33333333333333
87323, 0.60869565217391, -0.2, 0.36111111111111
87324, 0.6304347826087, -0.2, 0.38888888888889
87325, 0.60869565217391, -0.175, 0.38888888888889
87326, 0.60869565217391, -0.2, 0.41666666666667
87327, 0.6304347826087, -0.2, 0.44444444444444
87328, 0.60869565217391, -0.175, 0.44444444444444
87329, 0.60869565217391, -0.2, 0.47222222222222
87330, 0.56521739130435, -0.2, 0.027777777777778
87331, 0.58695652173913, -0.2, 0.055555555555556
87332, 0.56521739130435, -0.175, 0.055555555555556
87333, 0.56521739130435, -0.2, 0.083333333333333
87334, 0.58695652173913, -0.2, 0.11111111111111
87335, 0.56521739130435, -0.175, 0.11111111111111
87336, 0.56521739130435, -0.2, 0.13888888888889
87337, 0.58695652173913, -0.2, 0.16666666666667
87338, 0.56521739130435, -0.175, 0.16666666666667
87339, 0.56521739130435, -0.2, 0.19444444444444
87340, 0.58695652173913, -0.2, 0.22222222222222
87341, 0.56521739130435, -0.175, 0.22222222222222
87342, 0.56521739130435, -0.2, 0.25
87343, 0.58695652173913, -0.2, 0.27777777777778
87344, 0.56521739130435, -0.175, 0.27777777777778
87345, 0.56521739130435, -0.2, 0.30555555555556
87346, 0.58695652173913, -0.2, 0.33333333333333
87347, 0.56521739130435, -0.175, 0.33333333333333
87348, 0.56521739130435, -0.2, 0.36111111111111
87349, 0.58695652173913, -0.2, 0.38888888888889
87350, 0.56521739130435, -0.175, 0.38888888888889
87351, 0.56521739130435, -0.2, 0.41666666666667
87352, 0.58695652173913, -0.2, 0.44444444444444
87353, 0.56521739130435, -0.175, 0.44444444444444
87354, 0.56521739130435, -0.2, 0.47222222222222
87355, 0.52173913043478, -0.2, 0.027777777777778
87356, 0.54347826086957, -0.2, 0.055555555555556
87357, 0.52173913043478, -0.175, 0.055555555555556
87358, 0.52173913043478, -0.2, 0.083333333333333
87359, 0.54347826086956, -0.2, 0.11111111111111
87360, 0.52173913043478, -0.175, 0.11111111111111
87361, 0.52173913043478, -0.2, 0.13888888888889
87362, 0.54347826086957, -0.2, 0.16666666666667
87363, 0.52173913043478, -0.175, 0.16666666666667
87364, 0.52173913043478, -0.2, 0.19444444444444
87365, 0.54347826086956, -0.2, 0.22222222222222
87366, 0.52173913043478, -0.175, 0.22222222222222
87367, 0.52173913043478, -0.2, 0.25
87368, 0.54347826086956, -0.2, 0.27777777777778
87369, 0.52173913043478, -0.175, 0.27777777777778
87370, 0.52173913043478, -0.2, 0.30555555555556
87371, 0.54347826086956, -0.2, 0.33333333333333
87372, 0.52173913043478, -0.175, 0.33333333333333
87373, 0.52173913043478, -0.2, 0.36111111111111
87374, 0.54347826086956, -0.2, 0.38888888888889
87375, 0.52173913043478, -0.175, 0.38888888888889
87376, 0.52173913043478, -0.2, 0.41666666666667
87377, 0.54347826086956, -0.2, 0.44444444444444
87378, 0.52173913043478, -0.175, 0.44444444444444
87379, 0.52173913043478, -0.2, 0.47222222222222
87380, 0.47826086956522, -0.2, 0.027777777777778
87381, 0.5, -0.2, 0.055555555555556
87382, 0.47826086956522, -0.175, 0.055555555555556
87383, 0.47826086956522, -0.2, 0.083333333333333
87384, 0.5, -0.2, 0.11111111111111
87385, 0.47826086956522, -0.175, 0.11111111111111
87386, 0.47826086956522, -0.2, 0.13888888888889
87387, 0.5, -0.2, 0.16666666666667
87388, 0.47826086956522, -0.175, 0.16666666666667
87389, 0.47826086956522, -0.2, 0.19444444444444
87390, 0.5, -0.2, 0.22222222222222
87391, 0.47826086956522, -0.175, 0.22222222222222
87392, 0.47826086956522, -0.2, 0.25
87393, 0.5, -0.2, 0.27777777777778
87394, 0.47826086956522, -0.175, 0.27777777777778
87395, 0.47826086956522, -0.2, 0.30555555555556
87396, 0.5, -0.2, 0.33333333333333
87397, 0.47826086956522, -0.175, 0.33333333333333
87398, 0.47826086956522, -0.2, 0.36111111111111
87399, 0.5, -0.2, 0.38888888888889
87400, 0.47826086956522, -0.175, 0.38888888888889
87401, 0.47826086956522, -0.2, 0.41666666666667
87402, 0.5, -0.2, 0.44444444444444
87403, 0.47826086956522, -0.175, 0.44444444444444
87404, 0.47826086956522, -0.2, 0.47222222222222
87405, 0.43478260869565, -0.2, 0.027777777777778
87406, 0.45652173913043, -0.2, 0.055555555555556
87407, 0.43478260869565, -0.175, 0.055555555555556
87408, 0.43478260869565, -0.2, 0.083333333333333
87409, 0.45652173913043, -0.2, 0.11111111111111
87410, 0.43478260869565, -0.175, 0.11111111111111
87411, 0.43478260869565, -0.2, 0.13888888888889
87412, 0.45652173913043, -0.2, 0.16666666666667
87413, 0.43478260869565, -0.175, 0.16666666666667
87414, 0.43478260869565, -0.2, 0.19444444444444
87415, 0.45652173913043, -0.2, 0.22222222222222
87416, 0.43478260869565, -0.175, 0.22222222222222
87417, 0.43478260869565, -0.2, 0.25
87418, 0.45652173913043, -0.2, 0.27777777777778
87419, 0.43478260869565, -0.175, 0.27777777777778
87420, 0.43478260869565, -0.2, 0.30555555555556
87421, 0.45652173913043, -0.2, 0.33333333333333
87422, 0.43478260869565, -0.175, 0.33333333333333
87423, 0.43478260869565, -0.2, 0.36111111111111
87424, 0.45652173913044, -0.2, 0.38888888888889
87425, 0.43478260869565, -0.175, 0.38888888888889
87426, 0.43478260869565, -0.2, 0.41666666666667
87427, 0.45652173913043, -0.2, 0.44444444444444
87428, 0.43478260869565, -0.175, 0.44444444444444
87429, 0.43478260869565, -0.2, 0.47222222222222
87430, 0.39130434782609, -0.2, 0.027777777777778
87431, 0.41304347826087, -0.2, 0.055555555555556
87432, 0.39130434782609, -0.175, 0.055555555555556
87433, 0.39130434782609, -0.2, 0.083333333333333
87434, 0.41304347826087, -0.2, 0.11111111111111
87435, 0.39130434782609, -0.175, 0.11111111111111
87436, 0.39130434782609, -0.2, 0.13888888888889
87437, 0.41304347826087, -0.2, 0.16666666666667
87438, 0.39130434782609, -0.175, 0.16666666666667
87439, 0.39130434782609, -0.2, 0.19444444444444
87440, 0.41304347826087, -0.2, 0.22222222222222
87441, 0.39130434782609, -0.175, 0.22222222222222
87442, 0.39130434782609, -0.2, 0.25
87443, 0.41304347826087, -0.2, 0.27777777777778
87444, 0.39130434782609, -0.175, 0.27777777777778
87445, 0.39130434782609, -0.2, 0.30555555555556
87446, 0.41304347826087, -0.2, 0.33333333333333
87447, 0.39130434782609, -0.175, 0.33333333333333
87448, 0.39130434782609, -0.2, 0.36111111111111
87449, 0.41304347826087, -0.2, 0.38888888888889
87450, 0.39130434782609, -0.175, 0.38888888888889
87451, 0.39130434782609, -0.2, 0.41666666666667
87452, 0.41304347826087, -0.2, 0.44444444444444
87453, 0.39130434782609, -0.175, 0.44444444444444
87454, 0.39130434782609, -0.2, 0.47222222222222
87455, 0.34782608695652, -0.2, 0.027777777777778
87456, 0.3695652173913, -0.2, 0.055555555555556
87457, 0.34782608695652, -0.175, 0.055555555555556
87458, 0.34782608695652, -0.2, 0.083333333333333
87459, 0.3695652173913, -0.2, 0.11111111111111
87460, 0.34782608695652, -0.175, 0.11111111111111
87461, 0.34782608695652, -0.2, 0.13888888888889
87462, 0.3695652173913, -0.2, 0.16666666666667
87463, 0.34782608695652, -0.175, 0.16666666666667
87464, 0.34782608695652, -0.2, 0.19444444444444
87465, 0.3695652173913, -0.2, 0.22222222222222
87466, 0.34782608695652, -0.175, 0.22222222222222
87467, 0.34782608695652, -0.2, 0.25
87468, 0.3695652173913, -0.2, 0.27777777777778
87469, 0.34782608695652, -0.175, 0.27777777777778
87470, 0.34782608695652, -0.2, 0.30555555555556
87471, 0.3695652173913, -0.2, 0.33333333333333
87472, 0.34782608695652, -0.175, 0.33333333333333
87473, 0.34782608695652, -0.2, 0.36111111111111
87474, 0.3695652173913, -0.2, 0.38888888888889
87475, 0.34782608695652, -0.175, 0.38888888888889
87476, 0.34782608695652, -0.2, 0.41666666666667
87477, 0.3695652173913, -0.2, 0.44444444444444
87478, 0.34782608695652, -0.175, 0.44444444444444
87479, 0.34782608695652, -0.2, 0.47222222222222
87480, 0.30434782608696, -0.2, 0.027777777777778
87481, 0.32608695652174, -0.2, 0.055555555555556
87482, 0.30434782608696, -0.175, 0.055555555555556
87483, 0.30434782608696, -0.2, 0.083333333333333
87484, 0.32608695652174, -0.2, 0.11111111111111
87485, 0.30434782608696, -0.175, 0.11111111111111
87486, 0.30434782608696, -0.2, 0.13888888888889
87487, 0.32608695652174, -0.2, 0.16666666666667
87488, 0.30434782608696, -0.175, 0.16666666666667
87489, 0.30434782608696, -0.2, 0.19444444444444
87490, 0.32608695652174, -0.2, 0.22222222222222
87491, 0.30434782608696, -0.175, 0.22222222222222
87492, 0.30434782608696, -0.2, 0.25
87493, 0.32608695652174, -0.2, 0.27777777777778
87494, 0.30434782608696, -0.175, 0.27777777777778
87495, 0.30434782608696, -0.2, 0.30555555555556
87496, 0.32608695652174, -0.2, 0.33333333333333
87497, 0.30434782608696, -0.175, 0.33333333333333
87498, 0.30434782608696, -0.2, 0.36111111111111
87499, 0.32608695652174, -0.2, 0.38888888888889
87500, 0.30434782608696, -0.175, 0.38888888888889
87501, 0.30434782608696, -0.2, 0.41666666666667
87502, 0.32608695652174, -0.2, 0.44444444444444
87503, 0.30434782608696, -0.175, 0.44444444444444
87504, 0.30434782608696, -0.2, 0.47222222222222
87505, 0.26086956521739, -0.2, 0.027777777777778
87506, 0.28260869565217, -0.2, 0.055555555555556
87507, 0.26086956521739, -0.175, 0.055555555555556
87508, 0.26086956521739, -0.2, 0.083333333333333
87509, 0.28260869565217, -0.2, 0.11111111111111
87510, 0.26086956521739, -0.175, 0.11111111111111
87511, 0.26086956521739, -0.2, 0.13888888888889
87512, 0.28260869565217, -0.2, 0.16666666666667
87513, 0.26086956521739, -0.175, 0.16666666666667
87514, 0.26086956521739, -0.2, 0.19444444444444
87515, 0.28260869565217, -0.2, 0.22222222222222
87516, 0.26086956521739, -0.175, 0.22222222222222
87517, 0.26086956521739, -0.2, 0.25
87518, 0.28260869565217, -0.2, 0.27777777777778
87519, 0.26086956521739, -0.175, 0.27777777777778
87520, 0.26086956521739, -0.2, 0.30555555555556
87521, 0.28260869565217, -0.2, 0.33333333333333
87522, 0.26086956521739, -0.175, 0.33333333333333
87523, 0.26086956521739, -0.2, 0.36111111111111
87524, 0.28260869565217, -0.2, 0.38888888888889
87525, 0.26086956521739, -0.175, 0.38888888888889
87526, 0.26086956521739, -0.2, 0.41666666666667
87527, 0.28260869565217, -0.2, 0.44444444444444
87528, 0.26086956521739, -0.175, 0.44444444444444
87529, 0.26086956521739, -0.2, 0.47222222222222
87530, 0.21739130434783, -0.2, 0.027777777777778
87531, 0.23913043478261, -0.2, 0.055555555555556
87532, 0.21739130434783, -0.175, 0.055555555555556
87533, 0.21739130434783, -0.2, 0.083333333333333
87534, 0.23913043478261, -0.2, 0.11111111111111
87535, 0.21739130434783, -0.175, 0.11111111111111
87536, 0.21739130434783, -0.2, 0.13888888888889
87537, 0.23913043478261, -0.2, 0.16666666666667
87538, 0.21739130434783, -0.175, 0.16666666666667
87539, 0.21739130434783, -0.2, 0.19444444444444
87540, 0.23913043478261, -0.2, 0.22222222222222
87541, 0.21739130434783, -0.175, 0.22222222222222
87542, 0.21739130434783, -0.2, 0.25
87543, 0.23913043478261, -0.2, 0.27777777777778
87544, 0.21739130434783, -0.175, 0.27777777777778
87545, 0.21739130434783, -0.2, 0.30555555555556
87546, 0.23913043478261, -0.2, 0.33333333333333
87547, 0.21739130434783, -0.175, 0.33333333333333
87548, 0.21739130434783, -0.2, 0.36111111111111
87549, 0.23913043478261, -0.2, 0.38888888888889
87550, 0.21739130434783, -0.175, 0.38888888888889
87551, 0.21739130434783, -0.2, 0.41666666666667
87552, 0.23913043478261, -0.2, 0.44444444444444
87553, 0.21739130434783, -0.175, 0.44444444444444
87554, 0.21739130434783, -0.2, 0.47222222222222
87555, 0.17391304347826, -0.2, 0.027777777777778
87556, 0.19565217391304, -0.2, 0.055555555555556
87557, 0.17391304347826, -0.175, 0.055555555555556
87558, 0.17391304347826, -0.2, 0.083333333333333
87559, 0.19565217391304, -0.2, 0.11111111111111
87560, 0.17391304347826, -0.175, 0.11111111111111
87561, 0.17391304347826, -0.2, 0.13888888888889
87562, 0.19565217391304, -0.2, 0.16666666666667
87563, 0.17391304347826, -0.175, 0.16666666666667
87564, 0.17391304347826, -0.2, 0.19444444444444
87565, 0.19565217391304, -0.2, 0.22222222222222
87566, 0.17391304347826, -0.175, 0.22222222222222
87567, 0.17391304347826, -0.2, 0.25
87568, 0.19565217391304, -0.2, 0.27777777777778
87569, 0.17391304347826, -0.175, 0.27777777777778
87570, 0.17391304347826, -0.2, 0.30555555555556
87571, 0.19565217391304, -0.2, 0.33333333333333
87572, 0.17391304347826, -0.175, 0.33333333333333
87573, 0.17391304347826, -0.2, 0.36111111111111
87574, 0.19565217391304, -0.2, 0.38888888888889
87575, 0.17391304347826, -0.175, 0.38888888888889
87576, 0.17391304347826, -0.2, 0.41666666666667
87577, 0.19565217391304, -0.2, 0.44444444444444
87578, 0.17391304347826, -0.175, 0.44444444444444
87579, 0.17391304347826, -0.2, 0.47222222222222
87580, 0.1304347826087, -0.2, 0.027777777777778
87581, 0.15217391304348, -0.2, 0.055555555555556
87582, 0.1304347826087, -0.175, 0.055555555555556
87583, 0.1304347826087, -0.2, 0.083333333333333
87584, 0.15217391304348, -0.2, 0.11111111111111
87585, 0.1304347826087, -0.175, 0.11111111111111
87586, 0.1304347826087, -0.2, 0.13888888888889
87587, 0.15217391304348, -0.2, 0.16666666666667
87588, 0.1304347826087, -0.175, 0.16666666666667
87589, 0.1304347826087, -0.2, 0.19444444444444
87590, 0.15217391304348, -0.2, 0.22222222222222
87591, 0.1304347826087, -0.175, 0.22222222222222
87592, 0.1304347826087, -0.2, 0.25
87593, 0.15217391304348, -0.2, 0.27777777777778
87594, 0.1304347826087, -0.175, 0.27777777777778
87595, 0.1304347826087, -0.2, 0.30555555555556
87596, 0.15217391304348, -0.2, 0.33333333333333
87597, 0.1304347826087, -0.175, 0.33333333333333
87598, 0.1304347826087, -0.2, 0.36111111111111
87599, 0.15217391304348, -0.2, 0.38888888888889
87600, 0.1304347826087, -0.175, 0.38888888888889
87601, 0.1304347826087, -0.2, 0.41666666666667
87602, 0.15217391304348, -0.2, 0.44444444444444
87603, 0.1304347826087, -0.175, 0.44444444444444
87604, 0.1304347826087, -0.2, 0.47222222222222
