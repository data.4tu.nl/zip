70597, 1.9173913043478, 0.82826086956522, 0.44444444444444
70598, 1.9391304347826, 0.85434782608696, 0.44444444444444
70599, 1.9391304347826, 0.82826086956522, 0.41666666666667
70600, 1.9173913043478, 0.82826086956522, 0.38888888888889
70601, 1.9391304347826, 0.85434782608696, 0.38888888888889
70602, 1.9391304347826, 0.82826086956522, 0.36111111111111
70603, 1.9173913043478, 0.82826086956522, 0.33333333333333
70604, 1.9391304347826, 0.85434782608696, 0.33333333333333
70605, 1.9391304347826, 0.82826086956522, 0.30555555555556
70606, 1.9173913043478, 0.82826086956522, 0.27777777777778
70607, 1.9391304347826, 0.85434782608696, 0.27777777777778
70608, 1.9391304347826, 0.82826086956522, 0.25
70609, 1.9173913043478, 0.82826086956522, 0.22222222222222
70610, 1.9391304347826, 0.85434782608696, 0.22222222222222
70611, 1.9391304347826, 0.82826086956522, 0.19444444444444
70612, 1.9173913043478, 0.82826086956522, 0.16666666666667
70613, 1.9391304347826, 0.85434782608696, 0.16666666666667
70614, 1.9391304347826, 0.82826086956522, 0.13888888888889
70615, 1.9173913043478, 0.82826086956522, 0.11111111111111
70616, 1.9391304347826, 0.85434782608696, 0.11111111111111
70617, 1.9391304347826, 0.82826086956522, 0.083333333333333
70618, 1.9173913043478, 0.82826086956522, 0.055555555555556
70619, 1.9391304347826, 0.85434782608696, 0.055555555555556
70620, 1.9391304347826, 0.82826086956522, 0.027777777777778
70621, 1.9826086956522, 0.82826086956522, 0.47222222222222
70622, 1.9608695652174, 0.82826086956522, 0.44444444444444
70623, 1.9826086956522, 0.85434782608696, 0.44444444444444
70624, 1.9826086956522, 0.82826086956522, 0.41666666666667
70625, 1.9608695652174, 0.82826086956522, 0.38888888888889
70626, 1.9826086956522, 0.85434782608696, 0.38888888888889
70627, 1.9826086956522, 0.82826086956522, 0.36111111111111
70628, 1.9608695652174, 0.82826086956522, 0.33333333333333
70629, 1.9826086956522, 0.85434782608696, 0.33333333333333
70630, 1.9826086956522, 0.82826086956522, 0.30555555555556
70631, 1.9608695652174, 0.82826086956522, 0.27777777777778
70632, 1.9826086956522, 0.85434782608696, 0.27777777777778
70633, 1.9826086956522, 0.82826086956522, 0.25
70634, 1.9608695652174, 0.82826086956522, 0.22222222222222
70635, 1.9826086956522, 0.85434782608696, 0.22222222222222
70636, 1.9826086956522, 0.82826086956522, 0.19444444444444
70637, 1.9608695652174, 0.82826086956522, 0.16666666666667
70638, 1.9826086956522, 0.85434782608696, 0.16666666666667
70639, 1.9826086956522, 0.82826086956522, 0.13888888888889
70640, 1.9608695652174, 0.82826086956522, 0.11111111111111
70641, 1.9826086956522, 0.85434782608696, 0.11111111111111
70642, 1.9826086956522, 0.82826086956522, 0.083333333333333
70643, 1.9608695652174, 0.82826086956522, 0.055555555555556
70644, 1.9826086956522, 0.85434782608696, 0.055555555555556
70645, 1.9826086956522, 0.82826086956522, 0.027777777777778
70646, 2.0260869565217, 0.82826086956522, 0.47222222222222
70647, 2.004347826087, 0.82826086956522, 0.44444444444444
70648, 2.0260869565217, 0.85434782608696, 0.44444444444444
70649, 2.0260869565217, 0.82826086956522, 0.41666666666667
70650, 2.004347826087, 0.82826086956522, 0.38888888888889
70651, 2.0260869565217, 0.85434782608696, 0.38888888888889
70652, 2.0260869565217, 0.82826086956522, 0.36111111111111
70653, 2.004347826087, 0.82826086956522, 0.33333333333333
70654, 2.0260869565217, 0.85434782608696, 0.33333333333333
70655, 2.0260869565217, 0.82826086956522, 0.30555555555556
70656, 2.004347826087, 0.82826086956522, 0.27777777777778
70657, 2.0260869565217, 0.85434782608696, 0.27777777777778
70658, 2.0260869565217, 0.82826086956522, 0.25
70659, 2.004347826087, 0.82826086956522, 0.22222222222222
70660, 2.0260869565217, 0.85434782608696, 0.22222222222222
70661, 2.0260869565217, 0.82826086956522, 0.19444444444444
70662, 2.004347826087, 0.82826086956522, 0.16666666666667
70663, 2.0260869565217, 0.85434782608696, 0.16666666666667
70664, 2.0260869565217, 0.82826086956522, 0.13888888888889
70665, 2.004347826087, 0.82826086956522, 0.11111111111111
70666, 2.0260869565217, 0.85434782608696, 0.11111111111111
70667, 2.0260869565217, 0.82826086956522, 0.083333333333333
70668, 2.004347826087, 0.82826086956522, 0.055555555555556
70669, 2.0260869565217, 0.85434782608696, 0.055555555555556
70670, 2.0260869565217, 0.82826086956522, 0.027777777777778
70671, 2.0695652173913, 0.82826086956522, 0.47222222222222
70672, 2.0478260869565, 0.82826086956522, 0.44444444444444
70673, 2.0695652173913, 0.85434782608696, 0.44444444444444
70674, 2.0695652173913, 0.82826086956522, 0.41666666666667
70675, 2.0478260869565, 0.82826086956522, 0.38888888888889
70676, 2.0695652173913, 0.85434782608696, 0.38888888888889
70677, 2.0695652173913, 0.82826086956522, 0.36111111111111
70678, 2.0478260869565, 0.82826086956522, 0.33333333333333
70679, 2.0695652173913, 0.85434782608696, 0.33333333333333
70680, 2.0695652173913, 0.82826086956522, 0.30555555555556
70681, 2.0478260869565, 0.82826086956522, 0.27777777777778
70682, 2.0695652173913, 0.85434782608696, 0.27777777777778
70683, 2.0695652173913, 0.82826086956522, 0.25
70684, 2.0478260869565, 0.82826086956522, 0.22222222222222
70685, 2.0695652173913, 0.85434782608696, 0.22222222222222
70686, 2.0695652173913, 0.82826086956522, 0.19444444444444
70687, 2.0478260869565, 0.82826086956522, 0.16666666666667
70688, 2.0695652173913, 0.85434782608696, 0.16666666666667
70689, 2.0695652173913, 0.82826086956522, 0.13888888888889
70690, 2.0478260869565, 0.82826086956522, 0.11111111111111
70691, 2.0695652173913, 0.85434782608696, 0.11111111111111
70692, 2.0695652173913, 0.82826086956522, 0.083333333333333
70693, 2.0478260869565, 0.82826086956522, 0.055555555555556
70694, 2.0695652173913, 0.85434782608696, 0.055555555555556
70695, 2.0695652173913, 0.82826086956522, 0.027777777777778
70696, 2.1130434782609, 0.82826086956522, 0.47222222222222
70697, 2.0913043478261, 0.82826086956522, 0.44444444444444
70698, 2.1130434782609, 0.85434782608696, 0.44444444444444
70699, 2.1130434782609, 0.82826086956522, 0.41666666666667
70700, 2.0913043478261, 0.82826086956522, 0.38888888888889
70701, 2.1130434782609, 0.85434782608696, 0.38888888888889
70702, 2.1130434782609, 0.82826086956522, 0.36111111111111
70703, 2.0913043478261, 0.82826086956522, 0.33333333333333
70704, 2.1130434782609, 0.85434782608696, 0.33333333333333
70705, 2.1130434782609, 0.82826086956522, 0.30555555555556
70706, 2.0913043478261, 0.82826086956522, 0.27777777777778
70707, 2.1130434782609, 0.85434782608696, 0.27777777777778
70708, 2.1130434782609, 0.82826086956522, 0.25
70709, 2.0913043478261, 0.82826086956522, 0.22222222222222
70710, 2.1130434782609, 0.85434782608696, 0.22222222222222
70711, 2.1130434782609, 0.82826086956522, 0.19444444444444
70712, 2.0913043478261, 0.82826086956522, 0.16666666666667
70713, 2.1130434782609, 0.85434782608696, 0.16666666666667
70714, 2.1130434782609, 0.82826086956522, 0.13888888888889
70715, 2.0913043478261, 0.82826086956522, 0.11111111111111
70716, 2.1130434782609, 0.85434782608696, 0.11111111111111
70717, 2.1130434782609, 0.82826086956522, 0.083333333333333
70718, 2.0913043478261, 0.82826086956522, 0.055555555555556
70719, 2.1130434782609, 0.85434782608696, 0.055555555555556
70720, 2.1130434782609, 0.82826086956522, 0.027777777777778
70721, 2.1565217391304, 0.82826086956522, 0.47222222222222
70722, 2.1347826086957, 0.82826086956522, 0.44444444444444
70723, 2.1565217391304, 0.85434782608696, 0.44444444444444
70724, 2.1565217391304, 0.82826086956522, 0.41666666666667
70725, 2.1347826086957, 0.82826086956522, 0.38888888888889
70726, 2.1565217391304, 0.85434782608696, 0.38888888888889
70727, 2.1565217391304, 0.82826086956522, 0.36111111111111
70728, 2.1347826086957, 0.82826086956522, 0.33333333333333
70729, 2.1565217391304, 0.85434782608696, 0.33333333333333
70730, 2.1565217391304, 0.82826086956522, 0.30555555555556
70731, 2.1347826086957, 0.82826086956522, 0.27777777777778
70732, 2.1565217391304, 0.85434782608696, 0.27777777777778
70733, 2.1565217391304, 0.82826086956522, 0.25
70734, 2.1347826086957, 0.82826086956522, 0.22222222222222
70735, 2.1565217391304, 0.85434782608696, 0.22222222222222
70736, 2.1565217391304, 0.82826086956522, 0.19444444444444
70737, 2.1347826086957, 0.82826086956522, 0.16666666666667
70738, 2.1565217391304, 0.85434782608696, 0.16666666666667
70739, 2.1565217391304, 0.82826086956522, 0.13888888888889
70740, 2.1347826086957, 0.82826086956522, 0.11111111111111
70741, 2.1565217391304, 0.85434782608696, 0.11111111111111
70742, 2.1565217391304, 0.82826086956522, 0.083333333333333
70743, 2.1347826086957, 0.82826086956522, 0.055555555555556
70744, 2.1565217391304, 0.85434782608696, 0.055555555555556
70745, 2.1565217391304, 0.82826086956522, 0.027777777777778
70746, 2.1782608695652, 0.82826086956522, 0.44444444444444
70747, 2.1782608695652, 0.82826086956522, 0.38888888888889
70748, 2.1782608695652, 0.82826086956522, 0.33333333333333
70749, 2.1782608695652, 0.82826086956522, 0.27777777777778
70750, 2.1782608695652, 0.82826086956522, 0.22222222222222
70751, 2.1782608695652, 0.82826086956522, 0.16666666666667
70752, 2.1782608695652, 0.82826086956522, 0.11111111111111
70753, 2.1782608695652, 0.82826086956522, 0.055555555555556
70754, 1.2434782608696, 0.77608695652174, 0.47222222222222
70755, 1.2217391304348, 0.77608695652174, 0.44444444444444
70756, 1.2434782608696, 0.80217391304348, 0.44444444444444
70757, 1.2434782608696, 0.77608695652174, 0.41666666666667
70758, 1.2217391304348, 0.77608695652174, 0.38888888888889
70759, 1.2434782608696, 0.80217391304348, 0.38888888888889
70760, 1.2434782608696, 0.77608695652174, 0.36111111111111
70761, 1.2217391304348, 0.77608695652174, 0.33333333333333
70762, 1.2434782608696, 0.80217391304348, 0.33333333333333
70763, 1.2434782608696, 0.77608695652174, 0.30555555555556
70764, 1.2217391304348, 0.77608695652174, 0.27777777777778
70765, 1.2434782608696, 0.80217391304348, 0.27777777777778
70766, 1.2434782608696, 0.77608695652174, 0.25
70767, 1.2217391304348, 0.77608695652174, 0.22222222222222
70768, 1.2434782608696, 0.80217391304348, 0.22222222222222
70769, 1.2434782608696, 0.77608695652174, 0.19444444444444
70770, 1.2217391304348, 0.77608695652174, 0.16666666666667
70771, 1.2434782608696, 0.80217391304348, 0.16666666666667
70772, 1.2434782608696, 0.77608695652174, 0.13888888888889
70773, 1.2217391304348, 0.77608695652174, 0.11111111111111
70774, 1.2434782608696, 0.80217391304348, 0.11111111111111
70775, 1.2434782608696, 0.77608695652174, 0.083333333333333
70776, 1.2217391304348, 0.77608695652174, 0.055555555555556
70777, 1.2434782608696, 0.80217391304348, 0.055555555555556
70778, 1.2434782608696, 0.77608695652174, 0.027777777777778
70779, 1.2869565217391, 0.77608695652174, 0.47222222222222
70780, 1.2652173913043, 0.77608695652174, 0.44444444444444
70781, 1.2869565217391, 0.80217391304348, 0.44444444444444
70782, 1.2869565217391, 0.77608695652174, 0.41666666666667
70783, 1.2652173913043, 0.77608695652174, 0.38888888888889
70784, 1.2869565217391, 0.80217391304348, 0.38888888888889
70785, 1.2869565217391, 0.77608695652174, 0.36111111111111
70786, 1.2652173913043, 0.77608695652174, 0.33333333333333
70787, 1.2869565217391, 0.80217391304348, 0.33333333333333
70788, 1.2869565217391, 0.77608695652174, 0.30555555555556
70789, 1.2652173913043, 0.77608695652174, 0.27777777777778
70790, 1.2869565217391, 0.80217391304348, 0.27777777777778
70791, 1.2869565217391, 0.77608695652174, 0.25
70792, 1.2652173913043, 0.77608695652174, 0.22222222222222
70793, 1.2869565217391, 0.80217391304348, 0.22222222222222
70794, 1.2869565217391, 0.77608695652174, 0.19444444444444
70795, 1.2652173913043, 0.77608695652174, 0.16666666666667
70796, 1.2869565217391, 0.80217391304348, 0.16666666666667
70797, 1.2869565217391, 0.77608695652174, 0.13888888888889
70798, 1.2652173913043, 0.77608695652174, 0.11111111111111
70799, 1.2869565217391, 0.80217391304348, 0.11111111111111
70800, 1.2869565217391, 0.77608695652174, 0.083333333333333
70801, 1.2652173913043, 0.77608695652174, 0.055555555555556
70802, 1.2869565217391, 0.80217391304348, 0.055555555555556
70803, 1.2869565217391, 0.77608695652174, 0.027777777777778
70804, 1.3304347826087, 0.77608695652174, 0.47222222222222
70805, 1.3086956521739, 0.77608695652174, 0.44444444444444
70806, 1.3304347826087, 0.80217391304348, 0.44444444444444
70807, 1.3304347826087, 0.77608695652174, 0.41666666666667
70808, 1.3086956521739, 0.77608695652174, 0.38888888888889
70809, 1.3304347826087, 0.80217391304348, 0.38888888888889
70810, 1.3304347826087, 0.77608695652174, 0.36111111111111
70811, 1.3086956521739, 0.77608695652174, 0.33333333333333
70812, 1.3304347826087, 0.80217391304348, 0.33333333333333
70813, 1.3304347826087, 0.77608695652174, 0.30555555555556
70814, 1.3086956521739, 0.77608695652174, 0.27777777777778
70815, 1.3304347826087, 0.80217391304348, 0.27777777777778
70816, 1.3304347826087, 0.77608695652174, 0.25
70817, 1.3086956521739, 0.77608695652174, 0.22222222222222
70818, 1.3304347826087, 0.80217391304348, 0.22222222222222
70819, 1.3304347826087, 0.77608695652174, 0.19444444444444
70820, 1.3086956521739, 0.77608695652174, 0.16666666666667
70821, 1.3304347826087, 0.80217391304348, 0.16666666666667
70822, 1.3304347826087, 0.77608695652174, 0.13888888888889
70823, 1.3086956521739, 0.77608695652174, 0.11111111111111
70824, 1.3304347826087, 0.80217391304348, 0.11111111111111
70825, 1.3304347826087, 0.77608695652174, 0.083333333333333
70826, 1.3086956521739, 0.77608695652174, 0.055555555555556
70827, 1.3304347826087, 0.80217391304348, 0.055555555555556
70828, 1.3304347826087, 0.77608695652174, 0.027777777777778
70829, 1.3739130434783, 0.77608695652174, 0.47222222222222
70830, 1.3521739130435, 0.77608695652174, 0.44444444444444
70831, 1.3739130434783, 0.80217391304348, 0.44444444444444
70832, 1.3739130434783, 0.77608695652174, 0.41666666666667
70833, 1.3521739130435, 0.77608695652174, 0.38888888888889
70834, 1.3739130434783, 0.80217391304348, 0.38888888888889
70835, 1.3739130434783, 0.77608695652174, 0.36111111111111
70836, 1.3521739130435, 0.77608695652174, 0.33333333333333
70837, 1.3739130434783, 0.80217391304348, 0.33333333333333
70838, 1.3739130434783, 0.77608695652174, 0.30555555555556
70839, 1.3521739130435, 0.77608695652174, 0.27777777777778
70840, 1.3739130434783, 0.80217391304348, 0.27777777777778
70841, 1.3739130434783, 0.77608695652174, 0.25
70842, 1.3521739130435, 0.77608695652174, 0.22222222222222
70843, 1.3739130434783, 0.80217391304348, 0.22222222222222
70844, 1.3739130434783, 0.77608695652174, 0.19444444444444
70845, 1.3521739130435, 0.77608695652174, 0.16666666666667
70846, 1.3739130434783, 0.80217391304348, 0.16666666666667
70847, 1.3739130434783, 0.77608695652174, 0.13888888888889
70848, 1.3521739130435, 0.77608695652174, 0.11111111111111
70849, 1.3739130434783, 0.80217391304348, 0.11111111111111
70850, 1.3739130434783, 0.77608695652174, 0.083333333333333
70851, 1.3521739130435, 0.77608695652174, 0.055555555555556
70852, 1.3739130434783, 0.80217391304348, 0.055555555555556
70853, 1.3739130434783, 0.77608695652174, 0.027777777777778
70854, 1.4173913043478, 0.77608695652174, 0.47222222222222
70855, 1.395652173913, 0.77608695652174, 0.44444444444444
70856, 1.4173913043478, 0.80217391304348, 0.44444444444444
70857, 1.4173913043478, 0.77608695652174, 0.41666666666667
70858, 1.395652173913, 0.77608695652174, 0.38888888888889
70859, 1.4173913043478, 0.80217391304348, 0.38888888888889
70860, 1.4173913043478, 0.77608695652174, 0.36111111111111
70861, 1.395652173913, 0.77608695652174, 0.33333333333333
70862, 1.4173913043478, 0.80217391304348, 0.33333333333333
70863, 1.4173913043478, 0.77608695652174, 0.30555555555556
70864, 1.395652173913, 0.77608695652174, 0.27777777777778
70865, 1.4173913043478, 0.80217391304348, 0.27777777777778
70866, 1.4173913043478, 0.77608695652174, 0.25
70867, 1.395652173913, 0.77608695652174, 0.22222222222222
70868, 1.4173913043478, 0.80217391304348, 0.22222222222222
70869, 1.4173913043478, 0.77608695652174, 0.19444444444444
70870, 1.395652173913, 0.77608695652174, 0.16666666666667
70871, 1.4173913043478, 0.80217391304348, 0.16666666666667
70872, 1.4173913043478, 0.77608695652174, 0.13888888888889
70873, 1.395652173913, 0.77608695652174, 0.11111111111111
70874, 1.4173913043478, 0.80217391304348, 0.11111111111111
70875, 1.4173913043478, 0.77608695652174, 0.083333333333333
70876, 1.395652173913, 0.77608695652174, 0.055555555555556
70877, 1.4173913043478, 0.80217391304348, 0.055555555555556
70878, 1.4173913043478, 0.77608695652174, 0.027777777777778
70879, 1.4608695652174, 0.77608695652174, 0.47222222222222
70880, 1.4391304347826, 0.77608695652174, 0.44444444444444
70881, 1.4608695652174, 0.80217391304348, 0.44444444444444
70882, 1.4608695652174, 0.77608695652174, 0.41666666666667
70883, 1.4391304347826, 0.77608695652174, 0.38888888888889
70884, 1.4608695652174, 0.80217391304348, 0.38888888888889
70885, 1.4608695652174, 0.77608695652174, 0.36111111111111
70886, 1.4391304347826, 0.77608695652174, 0.33333333333333
70887, 1.4608695652174, 0.80217391304348, 0.33333333333333
70888, 1.4608695652174, 0.77608695652174, 0.30555555555556
70889, 1.4391304347826, 0.77608695652174, 0.27777777777778
70890, 1.4608695652174, 0.80217391304348, 0.27777777777778
70891, 1.4608695652174, 0.77608695652174, 0.25
70892, 1.4391304347826, 0.77608695652174, 0.22222222222222
70893, 1.4608695652174, 0.80217391304348, 0.22222222222222
70894, 1.4608695652174, 0.77608695652174, 0.19444444444444
70895, 1.4391304347826, 0.77608695652174, 0.16666666666667
70896, 1.4608695652174, 0.80217391304348, 0.16666666666667
70897, 1.4608695652174, 0.77608695652174, 0.13888888888889
70898, 1.4391304347826, 0.77608695652174, 0.11111111111111
70899, 1.4608695652174, 0.80217391304348, 0.11111111111111
70900, 1.4608695652174, 0.77608695652174, 0.083333333333333
70901, 1.4391304347826, 0.77608695652174, 0.055555555555556
70902, 1.4608695652174, 0.80217391304348, 0.055555555555556
70903, 1.4608695652174, 0.77608695652174, 0.027777777777778
70904, 1.504347826087, 0.77608695652174, 0.47222222222222
70905, 1.4826086956522, 0.77608695652174, 0.44444444444444
70906, 1.504347826087, 0.80217391304348, 0.44444444444444
70907, 1.504347826087, 0.77608695652174, 0.41666666666667
70908, 1.4826086956522, 0.77608695652174, 0.38888888888889
70909, 1.504347826087, 0.80217391304348, 0.38888888888889
70910, 1.504347826087, 0.77608695652174, 0.36111111111111
70911, 1.4826086956522, 0.77608695652174, 0.33333333333333
70912, 1.504347826087, 0.80217391304348, 0.33333333333333
70913, 1.504347826087, 0.77608695652174, 0.30555555555556
70914, 1.4826086956522, 0.77608695652174, 0.27777777777778
70915, 1.504347826087, 0.80217391304348, 0.27777777777778
70916, 1.504347826087, 0.77608695652174, 0.25
70917, 1.4826086956522, 0.77608695652174, 0.22222222222222
70918, 1.504347826087, 0.80217391304348, 0.22222222222222
70919, 1.504347826087, 0.77608695652174, 0.19444444444444
70920, 1.4826086956522, 0.77608695652174, 0.16666666666667
70921, 1.504347826087, 0.80217391304348, 0.16666666666667
70922, 1.504347826087, 0.77608695652174, 0.13888888888889
70923, 1.4826086956522, 0.77608695652174, 0.11111111111111
70924, 1.504347826087, 0.80217391304348, 0.11111111111111
70925, 1.504347826087, 0.77608695652174, 0.083333333333333
70926, 1.4826086956522, 0.77608695652174, 0.055555555555556
70927, 1.504347826087, 0.80217391304348, 0.055555555555556
70928, 1.504347826087, 0.77608695652174, 0.027777777777778
70929, 1.5478260869565, 0.77608695652174, 0.47222222222222
70930, 1.5260869565217, 0.77608695652174, 0.44444444444444
70931, 1.5478260869565, 0.80217391304348, 0.44444444444444
70932, 1.5478260869565, 0.77608695652174, 0.41666666666667
70933, 1.5260869565217, 0.77608695652174, 0.38888888888889
70934, 1.5478260869565, 0.80217391304348, 0.38888888888889
70935, 1.5478260869565, 0.77608695652174, 0.36111111111111
70936, 1.5260869565217, 0.77608695652174, 0.33333333333333
70937, 1.5478260869565, 0.80217391304348, 0.33333333333333
70938, 1.5478260869565, 0.77608695652174, 0.30555555555556
70939, 1.5260869565217, 0.77608695652174, 0.27777777777778
70940, 1.5478260869565, 0.80217391304348, 0.27777777777778
70941, 1.5478260869565, 0.77608695652174, 0.25
70942, 1.5260869565217, 0.77608695652174, 0.22222222222222
70943, 1.5478260869565, 0.80217391304348, 0.22222222222222
70944, 1.5478260869565, 0.77608695652174, 0.19444444444444
70945, 1.5260869565217, 0.77608695652174, 0.16666666666667
70946, 1.5478260869565, 0.80217391304348, 0.16666666666667
70947, 1.5478260869565, 0.77608695652174, 0.13888888888889
70948, 1.5260869565217, 0.77608695652174, 0.11111111111111
70949, 1.5478260869565, 0.80217391304348, 0.11111111111111
70950, 1.5478260869565, 0.77608695652174, 0.083333333333333
70951, 1.5260869565217, 0.77608695652174, 0.055555555555556
70952, 1.5478260869565, 0.80217391304348, 0.055555555555556
70953, 1.5478260869565, 0.77608695652174, 0.027777777777778
70954, 1.5913043478261, 0.77608695652174, 0.47222222222222
70955, 1.5695652173913, 0.77608695652174, 0.44444444444444
70956, 1.5913043478261, 0.80217391304348, 0.44444444444444
70957, 1.5913043478261, 0.77608695652174, 0.41666666666667
70958, 1.5695652173913, 0.77608695652174, 0.38888888888889
70959, 1.5913043478261, 0.80217391304348, 0.38888888888889
70960, 1.5913043478261, 0.77608695652174, 0.36111111111111
70961, 1.5695652173913, 0.77608695652174, 0.33333333333333
70962, 1.5913043478261, 0.80217391304348, 0.33333333333333
70963, 1.5913043478261, 0.77608695652174, 0.30555555555556
70964, 1.5695652173913, 0.77608695652174, 0.27777777777778
70965, 1.5913043478261, 0.80217391304348, 0.27777777777778
70966, 1.5913043478261, 0.77608695652174, 0.25
70967, 1.5695652173913, 0.77608695652174, 0.22222222222222
70968, 1.5913043478261, 0.80217391304348, 0.22222222222222
70969, 1.5913043478261, 0.77608695652174, 0.19444444444444
70970, 1.5695652173913, 0.77608695652174, 0.16666666666667
70971, 1.5913043478261, 0.80217391304348, 0.16666666666667
70972, 1.5913043478261, 0.77608695652174, 0.13888888888889
70973, 1.5695652173913, 0.77608695652174, 0.11111111111111
70974, 1.5913043478261, 0.80217391304348, 0.11111111111111
70975, 1.5913043478261, 0.77608695652174, 0.083333333333333
70976, 1.5695652173913, 0.77608695652174, 0.055555555555556
70977, 1.5913043478261, 0.80217391304348, 0.055555555555556
70978, 1.5913043478261, 0.77608695652174, 0.027777777777778
70979, 1.6347826086957, 0.77608695652174, 0.47222222222222
70980, 1.6130434782609, 0.77608695652174, 0.44444444444444
70981, 1.6347826086957, 0.80217391304348, 0.44444444444444
70982, 1.6347826086957, 0.77608695652174, 0.41666666666667
70983, 1.6130434782609, 0.77608695652174, 0.38888888888889
70984, 1.6347826086957, 0.80217391304348, 0.38888888888889
70985, 1.6347826086957, 0.77608695652174, 0.36111111111111
70986, 1.6130434782609, 0.77608695652174, 0.33333333333333
70987, 1.6347826086957, 0.80217391304348, 0.33333333333333
70988, 1.6347826086957, 0.77608695652174, 0.30555555555556
70989, 1.6130434782609, 0.77608695652174, 0.27777777777778
70990, 1.6347826086957, 0.80217391304348, 0.27777777777778
70991, 1.6347826086957, 0.77608695652174, 0.25
70992, 1.6130434782609, 0.77608695652174, 0.22222222222222
70993, 1.6347826086957, 0.80217391304348, 0.22222222222222
70994, 1.6347826086957, 0.77608695652174, 0.19444444444444
70995, 1.6130434782609, 0.77608695652174, 0.16666666666667
70996, 1.6347826086957, 0.80217391304348, 0.16666666666667
70997, 1.6347826086957, 0.77608695652174, 0.13888888888889
70998, 1.6130434782609, 0.77608695652174, 0.11111111111111
70999, 1.6347826086957, 0.80217391304348, 0.11111111111111
71000, 1.6347826086957, 0.77608695652174, 0.083333333333333
71001, 1.6130434782609, 0.77608695652174, 0.055555555555556
71002, 1.6347826086957, 0.80217391304348, 0.055555555555556
71003, 1.6347826086957, 0.77608695652174, 0.027777777777778
71004, 1.6782608695652, 0.77608695652174, 0.47222222222222
71005, 1.6565217391304, 0.77608695652174, 0.44444444444444
71006, 1.6782608695652, 0.80217391304348, 0.44444444444444
71007, 1.6782608695652, 0.77608695652174, 0.41666666666667
71008, 1.6565217391304, 0.77608695652174, 0.38888888888889
71009, 1.6782608695652, 0.80217391304348, 0.38888888888889
71010, 1.6782608695652, 0.77608695652174, 0.36111111111111
71011, 1.6565217391304, 0.77608695652174, 0.33333333333333
71012, 1.6782608695652, 0.80217391304348, 0.33333333333333
71013, 1.6782608695652, 0.77608695652174, 0.30555555555556
71014, 1.6565217391304, 0.77608695652174, 0.27777777777778
71015, 1.6782608695652, 0.80217391304348, 0.27777777777778
71016, 1.6782608695652, 0.77608695652174, 0.25
71017, 1.6565217391304, 0.77608695652174, 0.22222222222222
71018, 1.6782608695652, 0.80217391304348, 0.22222222222222
71019, 1.6782608695652, 0.77608695652174, 0.19444444444444
71020, 1.6565217391304, 0.77608695652174, 0.16666666666667
71021, 1.6782608695652, 0.80217391304348, 0.16666666666667
71022, 1.6782608695652, 0.77608695652174, 0.13888888888889
71023, 1.6565217391304, 0.77608695652174, 0.11111111111111
71024, 1.6782608695652, 0.80217391304348, 0.11111111111111
71025, 1.6782608695652, 0.77608695652174, 0.083333333333333
71026, 1.6565217391304, 0.77608695652174, 0.055555555555556
71027, 1.6782608695652, 0.80217391304348, 0.055555555555556
71028, 1.6782608695652, 0.77608695652174, 0.027777777777778
71029, 1.7217391304348, 0.77608695652174, 0.47222222222222
71030, 1.7, 0.77608695652174, 0.44444444444444
71031, 1.7217391304348, 0.80217391304348, 0.44444444444444
71032, 1.7217391304348, 0.77608695652174, 0.41666666666667
71033, 1.7, 0.77608695652174, 0.38888888888889
71034, 1.7217391304348, 0.80217391304348, 0.38888888888889
71035, 1.7217391304348, 0.77608695652174, 0.36111111111111
71036, 1.7, 0.77608695652174, 0.33333333333333
71037, 1.7217391304348, 0.80217391304348, 0.33333333333333
71038, 1.7217391304348, 0.77608695652174, 0.30555555555556
71039, 1.7, 0.77608695652174, 0.27777777777778
71040, 1.7217391304348, 0.80217391304348, 0.27777777777778
71041, 1.7217391304348, 0.77608695652174, 0.25
71042, 1.7, 0.77608695652174, 0.22222222222222
71043, 1.7217391304348, 0.80217391304348, 0.22222222222222
71044, 1.7217391304348, 0.77608695652174, 0.19444444444444
71045, 1.7, 0.77608695652174, 0.16666666666667
71046, 1.7217391304348, 0.80217391304348, 0.16666666666667
71047, 1.7217391304348, 0.77608695652174, 0.13888888888889
71048, 1.7, 0.77608695652174, 0.11111111111111
71049, 1.7217391304348, 0.80217391304348, 0.11111111111111
71050, 1.7217391304348, 0.77608695652174, 0.083333333333333
71051, 1.7, 0.77608695652174, 0.055555555555556
71052, 1.7217391304348, 0.80217391304348, 0.055555555555556
71053, 1.7217391304348, 0.77608695652174, 0.027777777777778
71054, 1.7652173913043, 0.77608695652174, 0.47222222222222
71055, 1.7434782608696, 0.77608695652174, 0.44444444444444
71056, 1.7652173913043, 0.80217391304348, 0.44444444444444
71057, 1.7652173913043, 0.77608695652174, 0.41666666666667
71058, 1.7434782608696, 0.77608695652174, 0.38888888888889
71059, 1.7652173913043, 0.80217391304348, 0.38888888888889
71060, 1.7652173913043, 0.77608695652174, 0.36111111111111
71061, 1.7434782608696, 0.77608695652174, 0.33333333333333
71062, 1.7652173913043, 0.80217391304348, 0.33333333333333
71063, 1.7652173913043, 0.77608695652174, 0.30555555555556
71064, 1.7434782608696, 0.77608695652174, 0.27777777777778
71065, 1.7652173913043, 0.80217391304348, 0.27777777777778
71066, 1.7652173913043, 0.77608695652174, 0.25
71067, 1.7434782608696, 0.77608695652174, 0.22222222222222
71068, 1.7652173913043, 0.80217391304348, 0.22222222222222
71069, 1.7652173913043, 0.77608695652174, 0.19444444444444
71070, 1.7434782608696, 0.77608695652174, 0.16666666666667
71071, 1.7652173913043, 0.80217391304348, 0.16666666666667
71072, 1.7652173913043, 0.77608695652174, 0.13888888888889
71073, 1.7434782608696, 0.77608695652174, 0.11111111111111
71074, 1.7652173913043, 0.80217391304348, 0.11111111111111
71075, 1.7652173913043, 0.77608695652174, 0.083333333333333
71076, 1.7434782608696, 0.77608695652174, 0.055555555555556
71077, 1.7652173913043, 0.80217391304348, 0.055555555555556
71078, 1.7652173913043, 0.77608695652174, 0.027777777777778
71079, 1.8086956521739, 0.77608695652174, 0.47222222222222
71080, 1.7869565217391, 0.77608695652174, 0.44444444444444
71081, 1.8086956521739, 0.80217391304348, 0.44444444444444
71082, 1.8086956521739, 0.77608695652174, 0.41666666666667
71083, 1.7869565217391, 0.77608695652174, 0.38888888888889
71084, 1.8086956521739, 0.80217391304348, 0.38888888888889
71085, 1.8086956521739, 0.77608695652174, 0.36111111111111
71086, 1.7869565217391, 0.77608695652174, 0.33333333333333
71087, 1.8086956521739, 0.80217391304348, 0.33333333333333
71088, 1.8086956521739, 0.77608695652174, 0.30555555555556
71089, 1.7869565217391, 0.77608695652174, 0.27777777777778
71090, 1.8086956521739, 0.80217391304348, 0.27777777777778
71091, 1.8086956521739, 0.77608695652174, 0.25
71092, 1.7869565217391, 0.77608695652174, 0.22222222222222
71093, 1.8086956521739, 0.80217391304348, 0.22222222222222
71094, 1.8086956521739, 0.77608695652174, 0.19444444444444
71095, 1.7869565217391, 0.77608695652174, 0.16666666666667
71096, 1.8086956521739, 0.80217391304348, 0.16666666666667
71097, 1.8086956521739, 0.77608695652174, 0.13888888888889
71098, 1.7869565217391, 0.77608695652174, 0.11111111111111
71099, 1.8086956521739, 0.80217391304348, 0.11111111111111
71100, 1.8086956521739, 0.77608695652174, 0.083333333333333
71101, 1.7869565217391, 0.77608695652174, 0.055555555555556
71102, 1.8086956521739, 0.80217391304348, 0.055555555555556
71103, 1.8086956521739, 0.77608695652174, 0.027777777777778
71104, 1.8521739130435, 0.77608695652174, 0.47222222222222
71105, 1.8304347826087, 0.77608695652174, 0.44444444444444
71106, 1.8521739130435, 0.80217391304348, 0.44444444444444
71107, 1.8521739130435, 0.77608695652174, 0.41666666666667
71108, 1.8304347826087, 0.77608695652174, 0.38888888888889
71109, 1.8521739130435, 0.80217391304348, 0.38888888888889
71110, 1.8521739130435, 0.77608695652174, 0.36111111111111
71111, 1.8304347826087, 0.77608695652174, 0.33333333333333
71112, 1.8521739130435, 0.80217391304348, 0.33333333333333
71113, 1.8521739130435, 0.77608695652174, 0.30555555555556
71114, 1.8304347826087, 0.77608695652174, 0.27777777777778
71115, 1.8521739130435, 0.80217391304348, 0.27777777777778
71116, 1.8521739130435, 0.77608695652174, 0.25
71117, 1.8304347826087, 0.77608695652174, 0.22222222222222
71118, 1.8521739130435, 0.80217391304348, 0.22222222222222
71119, 1.8521739130435, 0.77608695652174, 0.19444444444444
71120, 1.8304347826087, 0.77608695652174, 0.16666666666667
71121, 1.8521739130435, 0.80217391304348, 0.16666666666667
71122, 1.8521739130435, 0.77608695652174, 0.13888888888889
71123, 1.8304347826087, 0.77608695652174, 0.11111111111111
71124, 1.8521739130435, 0.80217391304348, 0.11111111111111
71125, 1.8521739130435, 0.77608695652174, 0.083333333333333
71126, 1.8304347826087, 0.77608695652174, 0.055555555555556
71127, 1.8521739130435, 0.80217391304348, 0.055555555555556
71128, 1.8521739130435, 0.77608695652174, 0.027777777777778
71129, 1.895652173913, 0.77608695652174, 0.47222222222222
71130, 1.8739130434783, 0.77608695652174, 0.44444444444444
71131, 1.895652173913, 0.80217391304348, 0.44444444444444
71132, 1.895652173913, 0.77608695652174, 0.41666666666667
71133, 1.8739130434783, 0.77608695652174, 0.38888888888889
71134, 1.895652173913, 0.80217391304348, 0.38888888888889
71135, 1.895652173913, 0.77608695652174, 0.36111111111111
71136, 1.8739130434783, 0.77608695652174, 0.33333333333333
71137, 1.895652173913, 0.80217391304348, 0.33333333333333
71138, 1.895652173913, 0.77608695652174, 0.30555555555556
71139, 1.8739130434783, 0.77608695652174, 0.27777777777778
71140, 1.895652173913, 0.80217391304348, 0.27777777777778
71141, 1.895652173913, 0.77608695652174, 0.25
71142, 1.8739130434783, 0.77608695652174, 0.22222222222222
71143, 1.895652173913, 0.80217391304348, 0.22222222222222
71144, 1.895652173913, 0.77608695652174, 0.19444444444444
71145, 1.8739130434783, 0.77608695652174, 0.16666666666667
71146, 1.895652173913, 0.80217391304348, 0.16666666666667
71147, 1.895652173913, 0.77608695652174, 0.13888888888889
71148, 1.8739130434783, 0.77608695652174, 0.11111111111111
71149, 1.895652173913, 0.80217391304348, 0.11111111111111
71150, 1.895652173913, 0.77608695652174, 0.083333333333333
71151, 1.8739130434783, 0.77608695652174, 0.055555555555556
71152, 1.895652173913, 0.80217391304348, 0.055555555555556
71153, 1.895652173913, 0.77608695652174, 0.027777777777778
71154, 1.9391304347826, 0.77608695652174, 0.47222222222222
71155, 1.9173913043478, 0.77608695652174, 0.44444444444444
71156, 1.9391304347826, 0.80217391304348, 0.44444444444444
71157, 1.9391304347826, 0.77608695652174, 0.41666666666667
71158, 1.9173913043478, 0.77608695652174, 0.38888888888889
71159, 1.9391304347826, 0.80217391304348, 0.38888888888889
71160, 1.9391304347826, 0.77608695652174, 0.36111111111111
71161, 1.9173913043478, 0.77608695652174, 0.33333333333333
71162, 1.9391304347826, 0.80217391304348, 0.33333333333333
71163, 1.9391304347826, 0.77608695652174, 0.30555555555556
71164, 1.9173913043478, 0.77608695652174, 0.27777777777778
71165, 1.9391304347826, 0.80217391304348, 0.27777777777778
71166, 1.9391304347826, 0.77608695652174, 0.25
71167, 1.9173913043478, 0.77608695652174, 0.22222222222222
71168, 1.9391304347826, 0.80217391304348, 0.22222222222222
71169, 1.9391304347826, 0.77608695652174, 0.19444444444444
71170, 1.9173913043478, 0.77608695652174, 0.16666666666667
71171, 1.9391304347826, 0.80217391304348, 0.16666666666667
71172, 1.9391304347826, 0.77608695652174, 0.13888888888889
71173, 1.9173913043478, 0.77608695652174, 0.11111111111111
71174, 1.9391304347826, 0.80217391304348, 0.11111111111111
71175, 1.9391304347826, 0.77608695652174, 0.083333333333333
71176, 1.9173913043478, 0.77608695652174, 0.055555555555556
71177, 1.9391304347826, 0.80217391304348, 0.055555555555556
71178, 1.9391304347826, 0.77608695652174, 0.027777777777778
71179, 1.9826086956522, 0.77608695652174, 0.47222222222222
71180, 1.9608695652174, 0.77608695652174, 0.44444444444444
71181, 1.9826086956522, 0.80217391304348, 0.44444444444444
71182, 1.9826086956522, 0.77608695652174, 0.41666666666667
71183, 1.9608695652174, 0.77608695652174, 0.38888888888889
71184, 1.9826086956522, 0.80217391304348, 0.38888888888889
71185, 1.9826086956522, 0.77608695652174, 0.36111111111111
71186, 1.9608695652174, 0.77608695652174, 0.33333333333333
71187, 1.9826086956522, 0.80217391304348, 0.33333333333333
71188, 1.9826086956522, 0.77608695652174, 0.30555555555556
71189, 1.9608695652174, 0.77608695652174, 0.27777777777778
71190, 1.9826086956522, 0.80217391304348, 0.27777777777778
71191, 1.9826086956522, 0.77608695652174, 0.25
71192, 1.9608695652174, 0.77608695652174, 0.22222222222222
71193, 1.9826086956522, 0.80217391304348, 0.22222222222222
71194, 1.9826086956522, 0.77608695652174, 0.19444444444444
71195, 1.9608695652174, 0.77608695652174, 0.16666666666667
71196, 1.9826086956522, 0.80217391304348, 0.16666666666667
71197, 1.9826086956522, 0.77608695652174, 0.13888888888889
71198, 1.9608695652174, 0.77608695652174, 0.11111111111111
71199, 1.9826086956522, 0.80217391304348, 0.11111111111111
71200, 1.9826086956522, 0.77608695652174, 0.083333333333333
71201, 1.9608695652174, 0.77608695652174, 0.055555555555556
71202, 1.9826086956522, 0.80217391304348, 0.055555555555556
71203, 1.9826086956522, 0.77608695652174, 0.027777777777778
71204, 2.0260869565217, 0.77608695652174, 0.47222222222222
71205, 2.004347826087, 0.77608695652174, 0.44444444444444
71206, 2.0260869565217, 0.80217391304348, 0.44444444444444
71207, 2.0260869565217, 0.77608695652174, 0.41666666666667
71208, 2.004347826087, 0.77608695652174, 0.38888888888889
71209, 2.0260869565217, 0.80217391304348, 0.38888888888889
71210, 2.0260869565217, 0.77608695652174, 0.36111111111111
71211, 2.004347826087, 0.77608695652174, 0.33333333333333
71212, 2.0260869565217, 0.80217391304348, 0.33333333333333
71213, 2.0260869565217, 0.77608695652174, 0.30555555555556
71214, 2.004347826087, 0.77608695652174, 0.27777777777778
71215, 2.0260869565217, 0.80217391304348, 0.27777777777778
71216, 2.0260869565217, 0.77608695652174, 0.25
71217, 2.004347826087, 0.77608695652174, 0.22222222222222
71218, 2.0260869565217, 0.80217391304348, 0.22222222222222
71219, 2.0260869565217, 0.77608695652174, 0.19444444444444
71220, 2.004347826087, 0.77608695652174, 0.16666666666667
71221, 2.0260869565217, 0.80217391304348, 0.16666666666667
71222, 2.0260869565217, 0.77608695652174, 0.13888888888889
71223, 2.004347826087, 0.77608695652174, 0.11111111111111
71224, 2.0260869565217, 0.80217391304348, 0.11111111111111
71225, 2.0260869565217, 0.77608695652174, 0.083333333333333
71226, 2.004347826087, 0.77608695652174, 0.055555555555556
71227, 2.0260869565217, 0.80217391304348, 0.055555555555556
71228, 2.0260869565217, 0.77608695652174, 0.027777777777778
71229, 2.0695652173913, 0.77608695652174, 0.47222222222222
71230, 2.0478260869565, 0.77608695652174, 0.44444444444444
71231, 2.0695652173913, 0.80217391304348, 0.44444444444444
71232, 2.0695652173913, 0.77608695652174, 0.41666666666667
71233, 2.0478260869565, 0.77608695652174, 0.38888888888889
71234, 2.0695652173913, 0.80217391304348, 0.38888888888889
71235, 2.0695652173913, 0.77608695652174, 0.36111111111111
71236, 2.0478260869565, 0.77608695652174, 0.33333333333333
71237, 2.0695652173913, 0.80217391304348, 0.33333333333333
71238, 2.0695652173913, 0.77608695652174, 0.30555555555556
71239, 2.0478260869565, 0.77608695652174, 0.27777777777778
71240, 2.0695652173913, 0.80217391304348, 0.27777777777778
71241, 2.0695652173913, 0.77608695652174, 0.25
71242, 2.0478260869565, 0.77608695652174, 0.22222222222222
71243, 2.0695652173913, 0.80217391304348, 0.22222222222222
71244, 2.0695652173913, 0.77608695652174, 0.19444444444444
71245, 2.0478260869565, 0.77608695652174, 0.16666666666667
71246, 2.0695652173913, 0.80217391304348, 0.16666666666667
71247, 2.0695652173913, 0.77608695652174, 0.13888888888889
71248, 2.0478260869565, 0.77608695652174, 0.11111111111111
71249, 2.0695652173913, 0.80217391304348, 0.11111111111111
71250, 2.0695652173913, 0.77608695652174, 0.083333333333333
71251, 2.0478260869565, 0.77608695652174, 0.055555555555556
71252, 2.0695652173913, 0.80217391304348, 0.055555555555556
71253, 2.0695652173913, 0.77608695652174, 0.027777777777778
71254, 2.1130434782609, 0.77608695652174, 0.47222222222222
71255, 2.0913043478261, 0.77608695652174, 0.44444444444444
71256, 2.1130434782609, 0.80217391304348, 0.44444444444444
71257, 2.1130434782609, 0.77608695652174, 0.41666666666667
71258, 2.0913043478261, 0.77608695652174, 0.38888888888889
71259, 2.1130434782609, 0.80217391304348, 0.38888888888889
71260, 2.1130434782609, 0.77608695652174, 0.36111111111111
71261, 2.0913043478261, 0.77608695652174, 0.33333333333333
71262, 2.1130434782609, 0.80217391304348, 0.33333333333333
71263, 2.1130434782609, 0.77608695652174, 0.30555555555556
71264, 2.0913043478261, 0.77608695652174, 0.27777777777778
71265, 2.1130434782609, 0.80217391304348, 0.27777777777778
71266, 2.1130434782609, 0.77608695652174, 0.25
71267, 2.0913043478261, 0.77608695652174, 0.22222222222222
71268, 2.1130434782609, 0.80217391304348, 0.22222222222222
71269, 2.1130434782609, 0.77608695652174, 0.19444444444444
71270, 2.0913043478261, 0.77608695652174, 0.16666666666667
71271, 2.1130434782609, 0.80217391304348, 0.16666666666667
71272, 2.1130434782609, 0.77608695652174, 0.13888888888889
71273, 2.0913043478261, 0.77608695652174, 0.11111111111111
71274, 2.1130434782609, 0.80217391304348, 0.11111111111111
71275, 2.1130434782609, 0.77608695652174, 0.083333333333333
71276, 2.0913043478261, 0.77608695652174, 0.055555555555556
71277, 2.1130434782609, 0.80217391304348, 0.055555555555556
71278, 2.1130434782609, 0.77608695652174, 0.027777777777778
71279, 2.1565217391304, 0.77608695652174, 0.47222222222222
71280, 2.1347826086957, 0.77608695652174, 0.44444444444444
71281, 2.1565217391304, 0.80217391304348, 0.44444444444444
71282, 2.1565217391304, 0.77608695652174, 0.41666666666667
71283, 2.1347826086957, 0.77608695652174, 0.38888888888889
71284, 2.1565217391304, 0.80217391304348, 0.38888888888889
71285, 2.1565217391304, 0.77608695652174, 0.36111111111111
71286, 2.1347826086957, 0.77608695652174, 0.33333333333333
71287, 2.1565217391304, 0.80217391304348, 0.33333333333333
71288, 2.1565217391304, 0.77608695652174, 0.30555555555556
71289, 2.1347826086957, 0.77608695652174, 0.27777777777778
71290, 2.1565217391304, 0.80217391304348, 0.27777777777778
71291, 2.1565217391304, 0.77608695652174, 0.25
71292, 2.1347826086957, 0.77608695652174, 0.22222222222222
71293, 2.1565217391304, 0.80217391304348, 0.22222222222222
71294, 2.1565217391304, 0.77608695652174, 0.19444444444444
71295, 2.1347826086957, 0.77608695652174, 0.16666666666667
71296, 2.1565217391304, 0.80217391304348, 0.16666666666667
71297, 2.1565217391304, 0.77608695652174, 0.13888888888889
71298, 2.1347826086957, 0.77608695652174, 0.11111111111111
71299, 2.1565217391304, 0.80217391304348, 0.11111111111111
71300, 2.1565217391304, 0.77608695652174, 0.083333333333333
71301, 2.1347826086957, 0.77608695652174, 0.055555555555556
71302, 2.1565217391304, 0.80217391304348, 0.055555555555556
71303, 2.1565217391304, 0.77608695652174, 0.027777777777778
71304, 2.1782608695652, 0.77608695652174, 0.44444444444444
71305, 2.1782608695652, 0.77608695652174, 0.38888888888889
71306, 2.1782608695652, 0.77608695652174, 0.33333333333333
71307, 2.1782608695652, 0.77608695652174, 0.27777777777778
71308, 2.1782608695652, 0.77608695652174, 0.22222222222222
71309, 2.1782608695652, 0.77608695652174, 0.16666666666667
71310, 2.1782608695652, 0.77608695652174, 0.11111111111111
71311, 2.1782608695652, 0.77608695652174, 0.055555555555556
71312, 1.2434782608696, 0.72391304347826, 0.47222222222222
71313, 1.2217391304348, 0.72391304347826, 0.44444444444444
71314, 1.2434782608696, 0.75, 0.44444444444444
71315, 1.2434782608696, 0.72391304347826, 0.41666666666667
71316, 1.2217391304348, 0.72391304347826, 0.38888888888889
71317, 1.2434782608696, 0.75, 0.38888888888889
71318, 1.2434782608696, 0.72391304347826, 0.36111111111111
71319, 1.2217391304348, 0.72391304347826, 0.33333333333333
71320, 1.2434782608696, 0.75, 0.33333333333333
71321, 1.2434782608696, 0.72391304347826, 0.30555555555556
71322, 1.2217391304348, 0.72391304347826, 0.27777777777778
71323, 1.2434782608696, 0.75, 0.27777777777778
71324, 1.2434782608696, 0.72391304347826, 0.25
71325, 1.2217391304348, 0.72391304347826, 0.22222222222222
71326, 1.2434782608696, 0.75, 0.22222222222222
71327, 1.2434782608696, 0.72391304347826, 0.19444444444444
71328, 1.2217391304348, 0.72391304347826, 0.16666666666667
71329, 1.2434782608696, 0.75, 0.16666666666667
71330, 1.2434782608696, 0.72391304347826, 0.13888888888889
71331, 1.2217391304348, 0.72391304347826, 0.11111111111111
71332, 1.2434782608696, 0.75, 0.11111111111111
71333, 1.2434782608696, 0.72391304347826, 0.083333333333333
71334, 1.2217391304348, 0.72391304347826, 0.055555555555556
71335, 1.2434782608696, 0.75, 0.055555555555556
71336, 1.2434782608696, 0.72391304347826, 0.027777777777778
71337, 1.2869565217391, 0.72391304347826, 0.47222222222222
71338, 1.2652173913043, 0.72391304347826, 0.44444444444444
71339, 1.2869565217391, 0.75, 0.44444444444444
71340, 1.2869565217391, 0.72391304347826, 0.41666666666667
71341, 1.2652173913043, 0.72391304347826, 0.38888888888889
71342, 1.2869565217391, 0.75, 0.38888888888889
71343, 1.2869565217391, 0.72391304347826, 0.36111111111111
71344, 1.2652173913043, 0.72391304347826, 0.33333333333333
71345, 1.2869565217391, 0.75, 0.33333333333333
71346, 1.2869565217391, 0.72391304347826, 0.30555555555556
71347, 1.2652173913043, 0.72391304347826, 0.27777777777778
71348, 1.2869565217391, 0.75, 0.27777777777778
71349, 1.2869565217391, 0.72391304347826, 0.25
71350, 1.2652173913043, 0.72391304347826, 0.22222222222222
71351, 1.2869565217391, 0.75, 0.22222222222222
71352, 1.2869565217391, 0.72391304347826, 0.19444444444444
71353, 1.2652173913043, 0.72391304347826, 0.16666666666667
71354, 1.2869565217391, 0.75, 0.16666666666667
71355, 1.2869565217391, 0.72391304347826, 0.13888888888889
71356, 1.2652173913043, 0.72391304347826, 0.11111111111111
71357, 1.2869565217391, 0.75, 0.11111111111111
71358, 1.2869565217391, 0.72391304347826, 0.083333333333333
71359, 1.2652173913043, 0.72391304347826, 0.055555555555556
71360, 1.2869565217391, 0.75, 0.055555555555556
71361, 1.2869565217391, 0.72391304347826, 0.027777777777778
71362, 1.3304347826087, 0.72391304347826, 0.47222222222222
71363, 1.3086956521739, 0.72391304347826, 0.44444444444444
71364, 1.3304347826087, 0.75, 0.44444444444444
71365, 1.3304347826087, 0.72391304347826, 0.41666666666667
71366, 1.3086956521739, 0.72391304347826, 0.38888888888889
71367, 1.3304347826087, 0.75, 0.38888888888889
71368, 1.3304347826087, 0.72391304347826, 0.36111111111111
71369, 1.3086956521739, 0.72391304347826, 0.33333333333333
71370, 1.3304347826087, 0.75, 0.33333333333333
71371, 1.3304347826087, 0.72391304347826, 0.30555555555556
71372, 1.3086956521739, 0.72391304347826, 0.27777777777778
71373, 1.3304347826087, 0.75, 0.27777777777778
71374, 1.3304347826087, 0.72391304347826, 0.25
71375, 1.3086956521739, 0.72391304347826, 0.22222222222222
71376, 1.3304347826087, 0.75, 0.22222222222222
71377, 1.3304347826087, 0.72391304347826, 0.19444444444444
71378, 1.3086956521739, 0.72391304347826, 0.16666666666667
71379, 1.3304347826087, 0.75, 0.16666666666667
71380, 1.3304347826087, 0.72391304347826, 0.13888888888889
71381, 1.3086956521739, 0.72391304347826, 0.11111111111111
71382, 1.3304347826087, 0.75, 0.11111111111111
71383, 1.3304347826087, 0.72391304347826, 0.083333333333333
71384, 1.3086956521739, 0.72391304347826, 0.055555555555556
71385, 1.3304347826087, 0.75, 0.055555555555556
71386, 1.3304347826087, 0.72391304347826, 0.027777777777778
71387, 1.3739130434783, 0.72391304347826, 0.47222222222222
71388, 1.3521739130435, 0.72391304347826, 0.44444444444444
71389, 1.3739130434783, 0.75, 0.44444444444444
71390, 1.3739130434783, 0.72391304347826, 0.41666666666667
71391, 1.3521739130435, 0.72391304347826, 0.38888888888889
71392, 1.3739130434783, 0.75, 0.38888888888889
71393, 1.3739130434783, 0.72391304347826, 0.36111111111111
71394, 1.3521739130435, 0.72391304347826, 0.33333333333333
71395, 1.3739130434783, 0.75, 0.33333333333333
71396, 1.3739130434783, 0.72391304347826, 0.30555555555556
71397, 1.3521739130435, 0.72391304347826, 0.27777777777778
71398, 1.3739130434783, 0.75, 0.27777777777778
71399, 1.3739130434783, 0.72391304347826, 0.25
71400, 1.3521739130435, 0.72391304347826, 0.22222222222222
71401, 1.3739130434783, 0.75, 0.22222222222222
71402, 1.3739130434783, 0.72391304347826, 0.19444444444444
71403, 1.3521739130435, 0.72391304347826, 0.16666666666667
71404, 1.3739130434783, 0.75, 0.16666666666667
71405, 1.3739130434783, 0.72391304347826, 0.13888888888889
71406, 1.3521739130435, 0.72391304347826, 0.11111111111111
71407, 1.3739130434783, 0.75, 0.11111111111111
71408, 1.3739130434783, 0.72391304347826, 0.083333333333333
71409, 1.3521739130435, 0.72391304347826, 0.055555555555556
71410, 1.3739130434783, 0.75, 0.055555555555556
71411, 1.3739130434783, 0.72391304347826, 0.027777777777778
71412, 1.4173913043478, 0.72391304347826, 0.47222222222222
71413, 1.395652173913, 0.72391304347826, 0.44444444444444
71414, 1.4173913043478, 0.75, 0.44444444444444
71415, 1.4173913043478, 0.72391304347826, 0.41666666666667
71416, 1.395652173913, 0.72391304347826, 0.38888888888889
71417, 1.4173913043478, 0.75, 0.38888888888889
71418, 1.4173913043478, 0.72391304347826, 0.36111111111111
71419, 1.395652173913, 0.72391304347826, 0.33333333333333
71420, 1.4173913043478, 0.75, 0.33333333333333
71421, 1.4173913043478, 0.72391304347826, 0.30555555555556
71422, 1.395652173913, 0.72391304347826, 0.27777777777778
71423, 1.4173913043478, 0.75, 0.27777777777778
71424, 1.4173913043478, 0.72391304347826, 0.25
71425, 1.395652173913, 0.72391304347826, 0.22222222222222
71426, 1.4173913043478, 0.75, 0.22222222222222
71427, 1.4173913043478, 0.72391304347826, 0.19444444444444
71428, 1.395652173913, 0.72391304347826, 0.16666666666667
71429, 1.4173913043478, 0.75, 0.16666666666667
71430, 1.4173913043478, 0.72391304347826, 0.13888888888889
71431, 1.395652173913, 0.72391304347826, 0.11111111111111
71432, 1.4173913043478, 0.75, 0.11111111111111
71433, 1.4173913043478, 0.72391304347826, 0.083333333333333
71434, 1.395652173913, 0.72391304347826, 0.055555555555556
71435, 1.4173913043478, 0.75, 0.055555555555556
71436, 1.4173913043478, 0.72391304347826, 0.027777777777778
71437, 1.4608695652174, 0.72391304347826, 0.47222222222222
71438, 1.4391304347826, 0.72391304347826, 0.44444444444444
71439, 1.4608695652174, 0.75, 0.44444444444444
71440, 1.4608695652174, 0.72391304347826, 0.41666666666667
71441, 1.4391304347826, 0.72391304347826, 0.38888888888889
71442, 1.4608695652174, 0.75, 0.38888888888889
71443, 1.4608695652174, 0.72391304347826, 0.36111111111111
71444, 1.4391304347826, 0.72391304347826, 0.33333333333333
71445, 1.4608695652174, 0.75, 0.33333333333333
71446, 1.4608695652174, 0.72391304347826, 0.30555555555556
71447, 1.4391304347826, 0.72391304347826, 0.27777777777778
71448, 1.4608695652174, 0.75, 0.27777777777778
71449, 1.4608695652174, 0.72391304347826, 0.25
71450, 1.4391304347826, 0.72391304347826, 0.22222222222222
71451, 1.4608695652174, 0.75, 0.22222222222222
71452, 1.4608695652174, 0.72391304347826, 0.19444444444444
71453, 1.4391304347826, 0.72391304347826, 0.16666666666667
71454, 1.4608695652174, 0.75, 0.16666666666667
71455, 1.4608695652174, 0.72391304347826, 0.13888888888889
71456, 1.4391304347826, 0.72391304347826, 0.11111111111111
71457, 1.4608695652174, 0.75, 0.11111111111111
71458, 1.4608695652174, 0.72391304347826, 0.083333333333333
71459, 1.4391304347826, 0.72391304347826, 0.055555555555556
71460, 1.4608695652174, 0.75, 0.055555555555556
71461, 1.4608695652174, 0.72391304347826, 0.027777777777778
71462, 1.504347826087, 0.72391304347826, 0.47222222222222
71463, 1.4826086956522, 0.72391304347826, 0.44444444444444
71464, 1.504347826087, 0.75, 0.44444444444444
71465, 1.504347826087, 0.72391304347826, 0.41666666666667
71466, 1.4826086956522, 0.72391304347826, 0.38888888888889
71467, 1.504347826087, 0.75, 0.38888888888889
71468, 1.504347826087, 0.72391304347826, 0.36111111111111
71469, 1.4826086956522, 0.72391304347826, 0.33333333333333
71470, 1.504347826087, 0.75, 0.33333333333333
71471, 1.504347826087, 0.72391304347826, 0.30555555555556
71472, 1.4826086956522, 0.72391304347826, 0.27777777777778
71473, 1.504347826087, 0.75, 0.27777777777778
71474, 1.504347826087, 0.72391304347826, 0.25
71475, 1.4826086956522, 0.72391304347826, 0.22222222222222
71476, 1.504347826087, 0.75, 0.22222222222222
71477, 1.504347826087, 0.72391304347826, 0.19444444444444
71478, 1.4826086956522, 0.72391304347826, 0.16666666666667
71479, 1.504347826087, 0.75, 0.16666666666667
71480, 1.504347826087, 0.72391304347826, 0.13888888888889
71481, 1.4826086956522, 0.72391304347826, 0.11111111111111
71482, 1.504347826087, 0.75, 0.11111111111111
71483, 1.504347826087, 0.72391304347826, 0.083333333333333
71484, 1.4826086956522, 0.72391304347826, 0.055555555555556
71485, 1.504347826087, 0.75, 0.055555555555556
71486, 1.504347826087, 0.72391304347826, 0.027777777777778
71487, 1.5478260869565, 0.72391304347826, 0.47222222222222
71488, 1.5260869565217, 0.72391304347826, 0.44444444444444
71489, 1.5478260869565, 0.75, 0.44444444444444
71490, 1.5478260869565, 0.72391304347826, 0.41666666666667
71491, 1.5260869565217, 0.72391304347826, 0.38888888888889
71492, 1.5478260869565, 0.75, 0.38888888888889
71493, 1.5478260869565, 0.72391304347826, 0.36111111111111
71494, 1.5260869565217, 0.72391304347826, 0.33333333333333
71495, 1.5478260869565, 0.75, 0.33333333333333
71496, 1.5478260869565, 0.72391304347826, 0.30555555555556
71497, 1.5260869565217, 0.72391304347826, 0.27777777777778
71498, 1.5478260869565, 0.75, 0.27777777777778
71499, 1.5478260869565, 0.72391304347826, 0.25
71500, 1.5260869565217, 0.72391304347826, 0.22222222222222
71501, 1.5478260869565, 0.75, 0.22222222222222
71502, 1.5478260869565, 0.72391304347826, 0.19444444444444
71503, 1.5260869565217, 0.72391304347826, 0.16666666666667
71504, 1.5478260869565, 0.75, 0.16666666666667
71505, 1.5478260869565, 0.72391304347826, 0.13888888888889
71506, 1.5260869565217, 0.72391304347826, 0.11111111111111
71507, 1.5478260869565, 0.75, 0.11111111111111
71508, 1.5478260869565, 0.72391304347826, 0.083333333333333
71509, 1.5260869565217, 0.72391304347826, 0.055555555555556
71510, 1.5478260869565, 0.75, 0.055555555555556
71511, 1.5478260869565, 0.72391304347826, 0.027777777777778
71512, 1.5913043478261, 0.72391304347826, 0.47222222222222
71513, 1.5695652173913, 0.72391304347826, 0.44444444444444
71514, 1.5913043478261, 0.75, 0.44444444444444
71515, 1.5913043478261, 0.72391304347826, 0.41666666666667
71516, 1.5695652173913, 0.72391304347826, 0.38888888888889
71517, 1.5913043478261, 0.75, 0.38888888888889
71518, 1.5913043478261, 0.72391304347826, 0.36111111111111
71519, 1.5695652173913, 0.72391304347826, 0.33333333333333
71520, 1.5913043478261, 0.75, 0.33333333333333
71521, 1.5913043478261, 0.72391304347826, 0.30555555555556
71522, 1.5695652173913, 0.72391304347826, 0.27777777777778
71523, 1.5913043478261, 0.75, 0.27777777777778
71524, 1.5913043478261, 0.72391304347826, 0.25
71525, 1.5695652173913, 0.72391304347826, 0.22222222222222
71526, 1.5913043478261, 0.75, 0.22222222222222
71527, 1.5913043478261, 0.72391304347826, 0.19444444444444
71528, 1.5695652173913, 0.72391304347826, 0.16666666666667
71529, 1.5913043478261, 0.75, 0.16666666666667
71530, 1.5913043478261, 0.72391304347826, 0.13888888888889
71531, 1.5695652173913, 0.72391304347826, 0.11111111111111
71532, 1.5913043478261, 0.75, 0.11111111111111
71533, 1.5913043478261, 0.72391304347826, 0.083333333333333
71534, 1.5695652173913, 0.72391304347826, 0.055555555555556
71535, 1.5913043478261, 0.75, 0.055555555555556
71536, 1.5913043478261, 0.72391304347826, 0.027777777777778
71537, 1.6347826086957, 0.72391304347826, 0.47222222222222
71538, 1.6130434782609, 0.72391304347826, 0.44444444444444
71539, 1.6347826086957, 0.75, 0.44444444444444
71540, 1.6347826086957, 0.72391304347826, 0.41666666666667
71541, 1.6130434782609, 0.72391304347826, 0.38888888888889
71542, 1.6347826086957, 0.75, 0.38888888888889
71543, 1.6347826086957, 0.72391304347826, 0.36111111111111
71544, 1.6130434782609, 0.72391304347826, 0.33333333333333
71545, 1.6347826086957, 0.75, 0.33333333333333
71546, 1.6347826086957, 0.72391304347826, 0.30555555555556
71547, 1.6130434782609, 0.72391304347826, 0.27777777777778
71548, 1.6347826086957, 0.75, 0.27777777777778
71549, 1.6347826086957, 0.72391304347826, 0.25
71550, 1.6130434782609, 0.72391304347826, 0.22222222222222
71551, 1.6347826086957, 0.75, 0.22222222222222
71552, 1.6347826086957, 0.72391304347826, 0.19444444444444
71553, 1.6130434782609, 0.72391304347826, 0.16666666666667
71554, 1.6347826086957, 0.75, 0.16666666666667
71555, 1.6347826086957, 0.72391304347826, 0.13888888888889
71556, 1.6130434782609, 0.72391304347826, 0.11111111111111
71557, 1.6347826086957, 0.75, 0.11111111111111
71558, 1.6347826086957, 0.72391304347826, 0.083333333333333
71559, 1.6130434782609, 0.72391304347826, 0.055555555555556
71560, 1.6347826086957, 0.75, 0.055555555555556
71561, 1.6347826086957, 0.72391304347826, 0.027777777777778
71562, 1.6782608695652, 0.72391304347826, 0.47222222222222
71563, 1.6565217391304, 0.72391304347826, 0.44444444444444
71564, 1.6782608695652, 0.75, 0.44444444444444
71565, 1.6782608695652, 0.72391304347826, 0.41666666666667
71566, 1.6565217391304, 0.72391304347826, 0.38888888888889
71567, 1.6782608695652, 0.75, 0.38888888888889
71568, 1.6782608695652, 0.72391304347826, 0.36111111111111
71569, 1.6565217391304, 0.72391304347826, 0.33333333333333
71570, 1.6782608695652, 0.75, 0.33333333333333
71571, 1.6782608695652, 0.72391304347826, 0.30555555555556
71572, 1.6565217391304, 0.72391304347826, 0.27777777777778
71573, 1.6782608695652, 0.75, 0.27777777777778
71574, 1.6782608695652, 0.72391304347826, 0.25
71575, 1.6565217391304, 0.72391304347826, 0.22222222222222
71576, 1.6782608695652, 0.75, 0.22222222222222
71577, 1.6782608695652, 0.72391304347826, 0.19444444444444
71578, 1.6565217391304, 0.72391304347826, 0.16666666666667
71579, 1.6782608695652, 0.75, 0.16666666666667
71580, 1.6782608695652, 0.72391304347826, 0.13888888888889
71581, 1.6565217391304, 0.72391304347826, 0.11111111111111
71582, 1.6782608695652, 0.75, 0.11111111111111
71583, 1.6782608695652, 0.72391304347826, 0.083333333333333
71584, 1.6565217391304, 0.72391304347826, 0.055555555555556
71585, 1.6782608695652, 0.75, 0.055555555555556
71586, 1.6782608695652, 0.72391304347826, 0.027777777777778
71587, 1.7217391304348, 0.72391304347826, 0.47222222222222
71588, 1.7, 0.72391304347826, 0.44444444444444
71589, 1.7217391304348, 0.75, 0.44444444444444
71590, 1.7217391304348, 0.72391304347826, 0.41666666666667
71591, 1.7, 0.72391304347826, 0.38888888888889
71592, 1.7217391304348, 0.75, 0.38888888888889
71593, 1.7217391304348, 0.72391304347826, 0.36111111111111
71594, 1.7, 0.72391304347826, 0.33333333333333
71595, 1.7217391304348, 0.75, 0.33333333333333
71596, 1.7217391304348, 0.72391304347826, 0.30555555555556
71597, 1.7, 0.72391304347826, 0.27777777777778
71598, 1.7217391304348, 0.75, 0.27777777777778
71599, 1.7217391304348, 0.72391304347826, 0.25
71600, 1.7, 0.72391304347826, 0.22222222222222
71601, 1.7217391304348, 0.75, 0.22222222222222
71602, 1.7217391304348, 0.72391304347826, 0.19444444444444
71603, 1.7, 0.72391304347826, 0.16666666666667
71604, 1.7217391304348, 0.75, 0.16666666666667
71605, 1.7217391304348, 0.72391304347826, 0.13888888888889
71606, 1.7, 0.72391304347826, 0.11111111111111
71607, 1.7217391304348, 0.75, 0.11111111111111
71608, 1.7217391304348, 0.72391304347826, 0.083333333333333
71609, 1.7, 0.72391304347826, 0.055555555555556
71610, 1.7217391304348, 0.75, 0.055555555555556
71611, 1.7217391304348, 0.72391304347826, 0.027777777777778
71612, 1.7652173913043, 0.72391304347826, 0.47222222222222
71613, 1.7434782608696, 0.72391304347826, 0.44444444444444
71614, 1.7652173913043, 0.75, 0.44444444444444
71615, 1.7652173913043, 0.72391304347826, 0.41666666666667
71616, 1.7434782608696, 0.72391304347826, 0.38888888888889
71617, 1.7652173913043, 0.75, 0.38888888888889
71618, 1.7652173913043, 0.72391304347826, 0.36111111111111
71619, 1.7434782608696, 0.72391304347826, 0.33333333333333
71620, 1.7652173913043, 0.75, 0.33333333333333
71621, 1.7652173913043, 0.72391304347826, 0.30555555555556
71622, 1.7434782608696, 0.72391304347826, 0.27777777777778
71623, 1.7652173913043, 0.75, 0.27777777777778
71624, 1.7652173913043, 0.72391304347826, 0.25
71625, 1.7434782608696, 0.72391304347826, 0.22222222222222
71626, 1.7652173913043, 0.75, 0.22222222222222
71627, 1.7652173913043, 0.72391304347826, 0.19444444444444
71628, 1.7434782608696, 0.72391304347826, 0.16666666666667
71629, 1.7652173913043, 0.75, 0.16666666666667
71630, 1.7652173913043, 0.72391304347826, 0.13888888888889
71631, 1.7434782608696, 0.72391304347826, 0.11111111111111
71632, 1.7652173913043, 0.75, 0.11111111111111
71633, 1.7652173913043, 0.72391304347826, 0.083333333333333
71634, 1.7434782608696, 0.72391304347826, 0.055555555555556
71635, 1.7652173913043, 0.75, 0.055555555555556
71636, 1.7652173913043, 0.72391304347826, 0.027777777777778
71637, 1.8086956521739, 0.72391304347826, 0.47222222222222
71638, 1.7869565217391, 0.72391304347826, 0.44444444444444
71639, 1.8086956521739, 0.75, 0.44444444444444
71640, 1.8086956521739, 0.72391304347826, 0.41666666666667
71641, 1.7869565217391, 0.72391304347826, 0.38888888888889
71642, 1.8086956521739, 0.75, 0.38888888888889
71643, 1.8086956521739, 0.72391304347826, 0.36111111111111
71644, 1.7869565217391, 0.72391304347826, 0.33333333333333
71645, 1.8086956521739, 0.75, 0.33333333333333
71646, 1.8086956521739, 0.72391304347826, 0.30555555555556
71647, 1.7869565217391, 0.72391304347826, 0.27777777777778
71648, 1.8086956521739, 0.75, 0.27777777777778
71649, 1.8086956521739, 0.72391304347826, 0.25
71650, 1.7869565217391, 0.72391304347826, 0.22222222222222
71651, 1.8086956521739, 0.75, 0.22222222222222
71652, 1.8086956521739, 0.72391304347826, 0.19444444444444
71653, 1.7869565217391, 0.72391304347826, 0.16666666666667
71654, 1.8086956521739, 0.75, 0.16666666666667
71655, 1.8086956521739, 0.72391304347826, 0.13888888888889
71656, 1.7869565217391, 0.72391304347826, 0.11111111111111
71657, 1.8086956521739, 0.75, 0.11111111111111
71658, 1.8086956521739, 0.72391304347826, 0.083333333333333
71659, 1.7869565217391, 0.72391304347826, 0.055555555555556
71660, 1.8086956521739, 0.75, 0.055555555555556
71661, 1.8086956521739, 0.72391304347826, 0.027777777777778
71662, 1.8521739130435, 0.72391304347826, 0.47222222222222
71663, 1.8304347826087, 0.72391304347826, 0.44444444444444
71664, 1.8521739130435, 0.75, 0.44444444444444
71665, 1.8521739130435, 0.72391304347826, 0.41666666666667
71666, 1.8304347826087, 0.72391304347826, 0.38888888888889
71667, 1.8521739130435, 0.75, 0.38888888888889
71668, 1.8521739130435, 0.72391304347826, 0.36111111111111
71669, 1.8304347826087, 0.72391304347826, 0.33333333333333
71670, 1.8521739130435, 0.75, 0.33333333333333
71671, 1.8521739130435, 0.72391304347826, 0.30555555555556
71672, 1.8304347826087, 0.72391304347826, 0.27777777777778
71673, 1.8521739130435, 0.75, 0.27777777777778
71674, 1.8521739130435, 0.72391304347826, 0.25
71675, 1.8304347826087, 0.72391304347826, 0.22222222222222
71676, 1.8521739130435, 0.75, 0.22222222222222
71677, 1.8521739130435, 0.72391304347826, 0.19444444444444
71678, 1.8304347826087, 0.72391304347826, 0.16666666666667
71679, 1.8521739130435, 0.75, 0.16666666666667
71680, 1.8521739130435, 0.72391304347826, 0.13888888888889
71681, 1.8304347826087, 0.72391304347826, 0.11111111111111
71682, 1.8521739130435, 0.75, 0.11111111111111
71683, 1.8521739130435, 0.72391304347826, 0.083333333333333
71684, 1.8304347826087, 0.72391304347826, 0.055555555555556
71685, 1.8521739130435, 0.75, 0.055555555555556
71686, 1.8521739130435, 0.72391304347826, 0.027777777777778
71687, 1.895652173913, 0.72391304347826, 0.47222222222222
71688, 1.8739130434783, 0.72391304347826, 0.44444444444444
71689, 1.895652173913, 0.75, 0.44444444444444
71690, 1.895652173913, 0.72391304347826, 0.41666666666667
71691, 1.8739130434783, 0.72391304347826, 0.38888888888889
71692, 1.895652173913, 0.75, 0.38888888888889
71693, 1.895652173913, 0.72391304347826, 0.36111111111111
71694, 1.8739130434783, 0.72391304347826, 0.33333333333333
71695, 1.895652173913, 0.75, 0.33333333333333
71696, 1.895652173913, 0.72391304347826, 0.30555555555556
71697, 1.8739130434783, 0.72391304347826, 0.27777777777778
71698, 1.895652173913, 0.75, 0.27777777777778
71699, 1.895652173913, 0.72391304347826, 0.25
71700, 1.8739130434783, 0.72391304347826, 0.22222222222222
71701, 1.895652173913, 0.75, 0.22222222222222
71702, 1.895652173913, 0.72391304347826, 0.19444444444444
71703, 1.8739130434783, 0.72391304347826, 0.16666666666667
71704, 1.895652173913, 0.75, 0.16666666666667
71705, 1.895652173913, 0.72391304347826, 0.13888888888889
71706, 1.8739130434783, 0.72391304347826, 0.11111111111111
71707, 1.895652173913, 0.75, 0.11111111111111
71708, 1.895652173913, 0.72391304347826, 0.083333333333333
71709, 1.8739130434783, 0.72391304347826, 0.055555555555556
71710, 1.895652173913, 0.75, 0.055555555555556
71711, 1.895652173913, 0.72391304347826, 0.027777777777778
71712, 1.9391304347826, 0.72391304347826, 0.47222222222222
71713, 1.9173913043478, 0.72391304347826, 0.44444444444444
71714, 1.9391304347826, 0.75, 0.44444444444444
71715, 1.9391304347826, 0.72391304347826, 0.41666666666667
71716, 1.9173913043478, 0.72391304347826, 0.38888888888889
71717, 1.9391304347826, 0.75, 0.38888888888889
71718, 1.9391304347826, 0.72391304347826, 0.36111111111111
71719, 1.9173913043478, 0.72391304347826, 0.33333333333333
71720, 1.9391304347826, 0.75, 0.33333333333333
71721, 1.9391304347826, 0.72391304347826, 0.30555555555556
71722, 1.9173913043478, 0.72391304347826, 0.27777777777778
71723, 1.9391304347826, 0.75, 0.27777777777778
71724, 1.9391304347826, 0.72391304347826, 0.25
71725, 1.9173913043478, 0.72391304347826, 0.22222222222222
71726, 1.9391304347826, 0.75, 0.22222222222222
71727, 1.9391304347826, 0.72391304347826, 0.19444444444444
71728, 1.9173913043478, 0.72391304347826, 0.16666666666667
71729, 1.9391304347826, 0.75, 0.16666666666667
71730, 1.9391304347826, 0.72391304347826, 0.13888888888889
71731, 1.9173913043478, 0.72391304347826, 0.11111111111111
71732, 1.9391304347826, 0.75, 0.11111111111111
71733, 1.9391304347826, 0.72391304347826, 0.083333333333333
71734, 1.9173913043478, 0.72391304347826, 0.055555555555556
71735, 1.9391304347826, 0.75, 0.055555555555556
71736, 1.9391304347826, 0.72391304347826, 0.027777777777778
71737, 1.9826086956522, 0.72391304347826, 0.47222222222222
71738, 1.9608695652174, 0.72391304347826, 0.44444444444444
71739, 1.9826086956522, 0.75, 0.44444444444444
71740, 1.9826086956522, 0.72391304347826, 0.41666666666667
71741, 1.9608695652174, 0.72391304347826, 0.38888888888889
71742, 1.9826086956522, 0.75, 0.38888888888889
71743, 1.9826086956522, 0.72391304347826, 0.36111111111111
71744, 1.9608695652174, 0.72391304347826, 0.33333333333333
71745, 1.9826086956522, 0.75, 0.33333333333333
71746, 1.9826086956522, 0.72391304347826, 0.30555555555556
71747, 1.9608695652174, 0.72391304347826, 0.27777777777778
71748, 1.9826086956522, 0.75, 0.27777777777778
71749, 1.9826086956522, 0.72391304347826, 0.25
71750, 1.9608695652174, 0.72391304347826, 0.22222222222222
71751, 1.9826086956522, 0.75, 0.22222222222222
71752, 1.9826086956522, 0.72391304347826, 0.19444444444444
71753, 1.9608695652174, 0.72391304347826, 0.16666666666667
71754, 1.9826086956522, 0.75, 0.16666666666667
71755, 1.9826086956522, 0.72391304347826, 0.13888888888889
71756, 1.9608695652174, 0.72391304347826, 0.11111111111111
71757, 1.9826086956522, 0.75, 0.11111111111111
71758, 1.9826086956522, 0.72391304347826, 0.083333333333333
71759, 1.9608695652174, 0.72391304347826, 0.055555555555556
71760, 1.9826086956522, 0.75, 0.055555555555556
71761, 1.9826086956522, 0.72391304347826, 0.027777777777778
71762, 2.0260869565217, 0.72391304347826, 0.47222222222222
71763, 2.004347826087, 0.72391304347826, 0.44444444444444
71764, 2.0260869565217, 0.75, 0.44444444444444
71765, 2.0260869565217, 0.72391304347826, 0.41666666666667
71766, 2.004347826087, 0.72391304347826, 0.38888888888889
71767, 2.0260869565217, 0.75, 0.38888888888889
71768, 2.0260869565217, 0.72391304347826, 0.36111111111111
71769, 2.004347826087, 0.72391304347826, 0.33333333333333
71770, 2.0260869565217, 0.75, 0.33333333333333
71771, 2.0260869565217, 0.72391304347826, 0.30555555555556
71772, 2.004347826087, 0.72391304347826, 0.27777777777778
71773, 2.0260869565217, 0.75, 0.27777777777778
71774, 2.0260869565217, 0.72391304347826, 0.25
71775, 2.004347826087, 0.72391304347826, 0.22222222222222
71776, 2.0260869565217, 0.75, 0.22222222222222
71777, 2.0260869565217, 0.72391304347826, 0.19444444444444
71778, 2.004347826087, 0.72391304347826, 0.16666666666667
71779, 2.0260869565217, 0.75, 0.16666666666667
71780, 2.0260869565217, 0.72391304347826, 0.13888888888889
71781, 2.004347826087, 0.72391304347826, 0.11111111111111
71782, 2.0260869565217, 0.75, 0.11111111111111
71783, 2.0260869565217, 0.72391304347826, 0.083333333333333
71784, 2.004347826087, 0.72391304347826, 0.055555555555556
71785, 2.0260869565217, 0.75, 0.055555555555556
71786, 2.0260869565217, 0.72391304347826, 0.027777777777778
71787, 2.0695652173913, 0.72391304347826, 0.47222222222222
71788, 2.0478260869565, 0.72391304347826, 0.44444444444444
71789, 2.0695652173913, 0.75, 0.44444444444444
71790, 2.0695652173913, 0.72391304347826, 0.41666666666667
71791, 2.0478260869565, 0.72391304347826, 0.38888888888889
71792, 2.0695652173913, 0.75, 0.38888888888889
71793, 2.0695652173913, 0.72391304347826, 0.36111111111111
71794, 2.0478260869565, 0.72391304347826, 0.33333333333333
71795, 2.0695652173913, 0.75, 0.33333333333333
71796, 2.0695652173913, 0.72391304347826, 0.30555555555556
71797, 2.0478260869565, 0.72391304347826, 0.27777777777778
71798, 2.0695652173913, 0.75, 0.27777777777778
71799, 2.0695652173913, 0.72391304347826, 0.25
71800, 2.0478260869565, 0.72391304347826, 0.22222222222222
71801, 2.0695652173913, 0.75, 0.22222222222222
71802, 2.0695652173913, 0.72391304347826, 0.19444444444444
71803, 2.0478260869565, 0.72391304347826, 0.16666666666667
71804, 2.0695652173913, 0.75, 0.16666666666667
71805, 2.0695652173913, 0.72391304347826, 0.13888888888889
71806, 2.0478260869565, 0.72391304347826, 0.11111111111111
71807, 2.0695652173913, 0.75, 0.11111111111111
71808, 2.0695652173913, 0.72391304347826, 0.083333333333333
71809, 2.0478260869565, 0.72391304347826, 0.055555555555556
71810, 2.0695652173913, 0.75, 0.055555555555556
71811, 2.0695652173913, 0.72391304347826, 0.027777777777778
71812, 2.1130434782609, 0.72391304347826, 0.47222222222222
71813, 2.0913043478261, 0.72391304347826, 0.44444444444444
71814, 2.1130434782609, 0.75, 0.44444444444444
71815, 2.1130434782609, 0.72391304347826, 0.41666666666667
71816, 2.0913043478261, 0.72391304347826, 0.38888888888889
71817, 2.1130434782609, 0.75, 0.38888888888889
71818, 2.1130434782609, 0.72391304347826, 0.36111111111111
71819, 2.0913043478261, 0.72391304347826, 0.33333333333333
71820, 2.1130434782609, 0.75, 0.33333333333333
71821, 2.1130434782609, 0.72391304347826, 0.30555555555556
71822, 2.0913043478261, 0.72391304347826, 0.27777777777778
71823, 2.1130434782609, 0.75, 0.27777777777778
71824, 2.1130434782609, 0.72391304347826, 0.25
71825, 2.0913043478261, 0.72391304347826, 0.22222222222222
71826, 2.1130434782609, 0.75, 0.22222222222222
71827, 2.1130434782609, 0.72391304347826, 0.19444444444444
71828, 2.0913043478261, 0.72391304347826, 0.16666666666667
71829, 2.1130434782609, 0.75, 0.16666666666667
71830, 2.1130434782609, 0.72391304347826, 0.13888888888889
71831, 2.0913043478261, 0.72391304347826, 0.11111111111111
71832, 2.1130434782609, 0.75, 0.11111111111111
71833, 2.1130434782609, 0.72391304347826, 0.083333333333333
71834, 2.0913043478261, 0.72391304347826, 0.055555555555556
71835, 2.1130434782609, 0.75, 0.055555555555556
71836, 2.1130434782609, 0.72391304347826, 0.027777777777778
71837, 2.1565217391304, 0.72391304347826, 0.47222222222222
71838, 2.1347826086957, 0.72391304347826, 0.44444444444444
71839, 2.1565217391304, 0.75, 0.44444444444444
71840, 2.1565217391304, 0.72391304347826, 0.41666666666667
71841, 2.1347826086957, 0.72391304347826, 0.38888888888889
71842, 2.1565217391304, 0.75, 0.38888888888889
71843, 2.1565217391304, 0.72391304347826, 0.36111111111111
71844, 2.1347826086957, 0.72391304347826, 0.33333333333333
71845, 2.1565217391304, 0.75, 0.33333333333333
71846, 2.1565217391304, 0.72391304347826, 0.30555555555556
71847, 2.1347826086957, 0.72391304347826, 0.27777777777778
71848, 2.1565217391304, 0.75, 0.27777777777778
71849, 2.1565217391304, 0.72391304347826, 0.25
71850, 2.1347826086957, 0.72391304347826, 0.22222222222222
71851, 2.1565217391304, 0.75, 0.22222222222222
71852, 2.1565217391304, 0.72391304347826, 0.19444444444444
71853, 2.1347826086957, 0.72391304347826, 0.16666666666667
71854, 2.1565217391304, 0.75, 0.16666666666667
71855, 2.1565217391304, 0.72391304347826, 0.13888888888889
71856, 2.1347826086957, 0.72391304347826, 0.11111111111111
71857, 2.1565217391304, 0.75, 0.11111111111111
71858, 2.1565217391304, 0.72391304347826, 0.083333333333333
71859, 2.1347826086957, 0.72391304347826, 0.055555555555556
71860, 2.1565217391304, 0.75, 0.055555555555556
71861, 2.1565217391304, 0.72391304347826, 0.027777777777778
71862, 2.1782608695652, 0.72391304347826, 0.44444444444444
71863, 2.1782608695652, 0.72391304347826, 0.38888888888889
71864, 2.1782608695652, 0.72391304347826, 0.33333333333333
71865, 2.1782608695652, 0.72391304347826, 0.27777777777778
71866, 2.1782608695652, 0.72391304347826, 0.22222222222222
71867, 2.1782608695652, 0.72391304347826, 0.16666666666667
71868, 2.1782608695652, 0.72391304347826, 0.11111111111111
71869, 2.1782608695652, 0.72391304347826, 0.055555555555556
71870, 1.2434782608696, 0.67173913043478, 0.47222222222222
71871, 1.2217391304348, 0.67173913043478, 0.44444444444444
71872, 1.2434782608696, 0.69782608695652, 0.44444444444444
71873, 1.2434782608696, 0.67173913043478, 0.41666666666667
71874, 1.2217391304348, 0.67173913043478, 0.38888888888889
71875, 1.2434782608696, 0.69782608695652, 0.38888888888889
71876, 1.2434782608696, 0.67173913043478, 0.36111111111111
71877, 1.2217391304348, 0.67173913043478, 0.33333333333333
71878, 1.2434782608696, 0.69782608695652, 0.33333333333333
71879, 1.2434782608696, 0.67173913043478, 0.30555555555556
71880, 1.2217391304348, 0.67173913043478, 0.27777777777778
71881, 1.2434782608696, 0.69782608695652, 0.27777777777778
71882, 1.2434782608696, 0.67173913043478, 0.25
71883, 1.2217391304348, 0.67173913043478, 0.22222222222222
71884, 1.2434782608696, 0.69782608695652, 0.22222222222222
71885, 1.2434782608696, 0.67173913043478, 0.19444444444444
71886, 1.2217391304348, 0.67173913043478, 0.16666666666667
71887, 1.2434782608696, 0.69782608695652, 0.16666666666667
71888, 1.2434782608696, 0.67173913043478, 0.13888888888889
71889, 1.2217391304348, 0.67173913043478, 0.11111111111111
71890, 1.2434782608696, 0.69782608695652, 0.11111111111111
71891, 1.2434782608696, 0.67173913043478, 0.083333333333333
71892, 1.2217391304348, 0.67173913043478, 0.055555555555556
71893, 1.2434782608696, 0.69782608695652, 0.055555555555556
71894, 1.2434782608696, 0.67173913043478, 0.027777777777778
71895, 1.2869565217391, 0.67173913043478, 0.47222222222222
71896, 1.2652173913043, 0.67173913043478, 0.44444444444444
71897, 1.2869565217391, 0.69782608695652, 0.44444444444444
71898, 1.2869565217391, 0.67173913043478, 0.41666666666667
71899, 1.2652173913043, 0.67173913043478, 0.38888888888889
71900, 1.2869565217391, 0.69782608695652, 0.38888888888889
71901, 1.2869565217391, 0.67173913043478, 0.36111111111111
71902, 1.2652173913043, 0.67173913043478, 0.33333333333333
71903, 1.2869565217391, 0.69782608695652, 0.33333333333333
71904, 1.2869565217391, 0.67173913043478, 0.30555555555556
71905, 1.2652173913043, 0.67173913043478, 0.27777777777778
71906, 1.2869565217391, 0.69782608695652, 0.27777777777778
71907, 1.2869565217391, 0.67173913043478, 0.25
71908, 1.2652173913043, 0.67173913043478, 0.22222222222222
71909, 1.2869565217391, 0.69782608695652, 0.22222222222222
71910, 1.2869565217391, 0.67173913043478, 0.19444444444444
71911, 1.2652173913043, 0.67173913043478, 0.16666666666667
71912, 1.2869565217391, 0.69782608695652, 0.16666666666667
71913, 1.2869565217391, 0.67173913043478, 0.13888888888889
71914, 1.2652173913043, 0.67173913043478, 0.11111111111111
71915, 1.2869565217391, 0.69782608695652, 0.11111111111111
71916, 1.2869565217391, 0.67173913043478, 0.083333333333333
71917, 1.2652173913043, 0.67173913043478, 0.055555555555556
71918, 1.2869565217391, 0.69782608695652, 0.055555555555556
71919, 1.2869565217391, 0.67173913043478, 0.027777777777778
71920, 1.3304347826087, 0.67173913043478, 0.47222222222222
71921, 1.3086956521739, 0.67173913043478, 0.44444444444444
71922, 1.3304347826087, 0.69782608695652, 0.44444444444444
71923, 1.3304347826087, 0.67173913043478, 0.41666666666667
71924, 1.3086956521739, 0.67173913043478, 0.38888888888889
71925, 1.3304347826087, 0.69782608695652, 0.38888888888889
71926, 1.3304347826087, 0.67173913043478, 0.36111111111111
71927, 1.3086956521739, 0.67173913043478, 0.33333333333333
71928, 1.3304347826087, 0.69782608695652, 0.33333333333333
71929, 1.3304347826087, 0.67173913043478, 0.30555555555556
71930, 1.3086956521739, 0.67173913043478, 0.27777777777778
71931, 1.3304347826087, 0.69782608695652, 0.27777777777778
71932, 1.3304347826087, 0.67173913043478, 0.25
71933, 1.3086956521739, 0.67173913043478, 0.22222222222222
71934, 1.3304347826087, 0.69782608695652, 0.22222222222222
71935, 1.3304347826087, 0.67173913043478, 0.19444444444444
71936, 1.3086956521739, 0.67173913043478, 0.16666666666667
71937, 1.3304347826087, 0.69782608695652, 0.16666666666667
71938, 1.3304347826087, 0.67173913043478, 0.13888888888889
71939, 1.3086956521739, 0.67173913043478, 0.11111111111111
71940, 1.3304347826087, 0.69782608695652, 0.11111111111111
71941, 1.3304347826087, 0.67173913043478, 0.083333333333333
71942, 1.3086956521739, 0.67173913043478, 0.055555555555556
71943, 1.3304347826087, 0.69782608695652, 0.055555555555556
71944, 1.3304347826087, 0.67173913043478, 0.027777777777778
71945, 1.3739130434783, 0.67173913043478, 0.47222222222222
71946, 1.3521739130435, 0.67173913043478, 0.44444444444444
71947, 1.3739130434783, 0.69782608695652, 0.44444444444444
71948, 1.3739130434783, 0.67173913043478, 0.41666666666667
71949, 1.3521739130435, 0.67173913043478, 0.38888888888889
71950, 1.3739130434783, 0.69782608695652, 0.38888888888889
71951, 1.3739130434783, 0.67173913043478, 0.36111111111111
71952, 1.3521739130435, 0.67173913043478, 0.33333333333333
71953, 1.3739130434783, 0.69782608695652, 0.33333333333333
71954, 1.3739130434783, 0.67173913043478, 0.30555555555556
71955, 1.3521739130435, 0.67173913043478, 0.27777777777778
71956, 1.3739130434783, 0.69782608695652, 0.27777777777778
71957, 1.3739130434783, 0.67173913043478, 0.25
71958, 1.3521739130435, 0.67173913043478, 0.22222222222222
71959, 1.3739130434783, 0.69782608695652, 0.22222222222222
71960, 1.3739130434783, 0.67173913043478, 0.19444444444444
71961, 1.3521739130435, 0.67173913043478, 0.16666666666667
71962, 1.3739130434783, 0.69782608695652, 0.16666666666667
71963, 1.3739130434783, 0.67173913043478, 0.13888888888889
71964, 1.3521739130435, 0.67173913043478, 0.11111111111111
71965, 1.3739130434783, 0.69782608695652, 0.11111111111111
71966, 1.3739130434783, 0.67173913043478, 0.083333333333333
71967, 1.3521739130435, 0.67173913043478, 0.055555555555556
71968, 1.3739130434783, 0.69782608695652, 0.055555555555556
71969, 1.3739130434783, 0.67173913043478, 0.027777777777778
71970, 1.4173913043478, 0.67173913043478, 0.47222222222222
71971, 1.395652173913, 0.67173913043478, 0.44444444444444
71972, 1.4173913043478, 0.69782608695652, 0.44444444444444
71973, 1.4173913043478, 0.67173913043478, 0.41666666666667
71974, 1.395652173913, 0.67173913043478, 0.38888888888889
71975, 1.4173913043478, 0.69782608695652, 0.38888888888889
71976, 1.4173913043478, 0.67173913043478, 0.36111111111111
71977, 1.395652173913, 0.67173913043478, 0.33333333333333
71978, 1.4173913043478, 0.69782608695652, 0.33333333333333
71979, 1.4173913043478, 0.67173913043478, 0.30555555555556
71980, 1.395652173913, 0.67173913043478, 0.27777777777778
71981, 1.4173913043478, 0.69782608695652, 0.27777777777778
71982, 1.4173913043478, 0.67173913043478, 0.25
71983, 1.395652173913, 0.67173913043478, 0.22222222222222
71984, 1.4173913043478, 0.69782608695652, 0.22222222222222
71985, 1.4173913043478, 0.67173913043478, 0.19444444444444
71986, 1.395652173913, 0.67173913043478, 0.16666666666667
71987, 1.4173913043478, 0.69782608695652, 0.16666666666667
71988, 1.4173913043478, 0.67173913043478, 0.13888888888889
71989, 1.395652173913, 0.67173913043478, 0.11111111111111
71990, 1.4173913043478, 0.69782608695652, 0.11111111111111
71991, 1.4173913043478, 0.67173913043478, 0.083333333333333
71992, 1.395652173913, 0.67173913043478, 0.055555555555556
71993, 1.4173913043478, 0.69782608695652, 0.055555555555556
71994, 1.4173913043478, 0.67173913043478, 0.027777777777778
71995, 1.4608695652174, 0.67173913043478, 0.47222222222222
71996, 1.4391304347826, 0.67173913043478, 0.44444444444444
71997, 1.4608695652174, 0.69782608695652, 0.44444444444444
71998, 1.4608695652174, 0.67173913043478, 0.41666666666667
71999, 1.4391304347826, 0.67173913043478, 0.38888888888889
72000, 1.4608695652174, 0.69782608695652, 0.38888888888889
72001, 1.4608695652174, 0.67173913043478, 0.36111111111111
72002, 1.4391304347826, 0.67173913043478, 0.33333333333333
72003, 1.4608695652174, 0.69782608695652, 0.33333333333333
72004, 1.4608695652174, 0.67173913043478, 0.30555555555556
72005, 1.4391304347826, 0.67173913043478, 0.27777777777778
72006, 1.4608695652174, 0.69782608695652, 0.27777777777778
72007, 1.4608695652174, 0.67173913043478, 0.25
72008, 1.4391304347826, 0.67173913043478, 0.22222222222222
72009, 1.4608695652174, 0.69782608695652, 0.22222222222222
72010, 1.4608695652174, 0.67173913043478, 0.19444444444444
72011, 1.4391304347826, 0.67173913043478, 0.16666666666667
72012, 1.4608695652174, 0.69782608695652, 0.16666666666667
72013, 1.4608695652174, 0.67173913043478, 0.13888888888889
72014, 1.4391304347826, 0.67173913043478, 0.11111111111111
72015, 1.4608695652174, 0.69782608695652, 0.11111111111111
72016, 1.4608695652174, 0.67173913043478, 0.083333333333333
72017, 1.4391304347826, 0.67173913043478, 0.055555555555556
72018, 1.4608695652174, 0.69782608695652, 0.055555555555556
72019, 1.4608695652174, 0.67173913043478, 0.027777777777778
72020, 1.504347826087, 0.67173913043478, 0.47222222222222
72021, 1.4826086956522, 0.67173913043478, 0.44444444444444
72022, 1.504347826087, 0.69782608695652, 0.44444444444444
72023, 1.504347826087, 0.67173913043478, 0.41666666666667
72024, 1.4826086956522, 0.67173913043478, 0.38888888888889
72025, 1.504347826087, 0.69782608695652, 0.38888888888889
72026, 1.504347826087, 0.67173913043478, 0.36111111111111
72027, 1.4826086956522, 0.67173913043478, 0.33333333333333
72028, 1.504347826087, 0.69782608695652, 0.33333333333333
72029, 1.504347826087, 0.67173913043478, 0.30555555555556
72030, 1.4826086956522, 0.67173913043478, 0.27777777777778
72031, 1.504347826087, 0.69782608695652, 0.27777777777778
72032, 1.504347826087, 0.67173913043478, 0.25
72033, 1.4826086956522, 0.67173913043478, 0.22222222222222
72034, 1.504347826087, 0.69782608695652, 0.22222222222222
72035, 1.504347826087, 0.67173913043478, 0.19444444444444
72036, 1.4826086956522, 0.67173913043478, 0.16666666666667
72037, 1.504347826087, 0.69782608695652, 0.16666666666667
72038, 1.504347826087, 0.67173913043478, 0.13888888888889
72039, 1.4826086956522, 0.67173913043478, 0.11111111111111
72040, 1.504347826087, 0.69782608695652, 0.11111111111111
72041, 1.504347826087, 0.67173913043478, 0.083333333333333
72042, 1.4826086956522, 0.67173913043478, 0.055555555555556
72043, 1.504347826087, 0.69782608695652, 0.055555555555556
72044, 1.504347826087, 0.67173913043478, 0.027777777777778
72045, 1.5478260869565, 0.67173913043478, 0.47222222222222
72046, 1.5260869565217, 0.67173913043478, 0.44444444444444
72047, 1.5478260869565, 0.69782608695652, 0.44444444444444
72048, 1.5478260869565, 0.67173913043478, 0.41666666666667
72049, 1.5260869565217, 0.67173913043478, 0.38888888888889
72050, 1.5478260869565, 0.69782608695652, 0.38888888888889
72051, 1.5478260869565, 0.67173913043478, 0.36111111111111
72052, 1.5260869565217, 0.67173913043478, 0.33333333333333
72053, 1.5478260869565, 0.69782608695652, 0.33333333333333
72054, 1.5478260869565, 0.67173913043478, 0.30555555555556
72055, 1.5260869565217, 0.67173913043478, 0.27777777777778
72056, 1.5478260869565, 0.69782608695652, 0.27777777777778
72057, 1.5478260869565, 0.67173913043478, 0.25
72058, 1.5260869565217, 0.67173913043478, 0.22222222222222
72059, 1.5478260869565, 0.69782608695652, 0.22222222222222
72060, 1.5478260869565, 0.67173913043478, 0.19444444444444
72061, 1.5260869565217, 0.67173913043478, 0.16666666666667
72062, 1.5478260869565, 0.69782608695652, 0.16666666666667
72063, 1.5478260869565, 0.67173913043478, 0.13888888888889
72064, 1.5260869565217, 0.67173913043478, 0.11111111111111
72065, 1.5478260869565, 0.69782608695652, 0.11111111111111
72066, 1.5478260869565, 0.67173913043478, 0.083333333333333
72067, 1.5260869565217, 0.67173913043478, 0.055555555555556
72068, 1.5478260869565, 0.69782608695652, 0.055555555555556
72069, 1.5478260869565, 0.67173913043478, 0.027777777777778
72070, 1.5913043478261, 0.67173913043478, 0.47222222222222
72071, 1.5695652173913, 0.67173913043478, 0.44444444444444
72072, 1.5913043478261, 0.69782608695652, 0.44444444444444
72073, 1.5913043478261, 0.67173913043478, 0.41666666666667
72074, 1.5695652173913, 0.67173913043478, 0.38888888888889
72075, 1.5913043478261, 0.69782608695652, 0.38888888888889
72076, 1.5913043478261, 0.67173913043478, 0.36111111111111
72077, 1.5695652173913, 0.67173913043478, 0.33333333333333
72078, 1.5913043478261, 0.69782608695652, 0.33333333333333
72079, 1.5913043478261, 0.67173913043478, 0.30555555555556
72080, 1.5695652173913, 0.67173913043478, 0.27777777777778
72081, 1.5913043478261, 0.69782608695652, 0.27777777777778
72082, 1.5913043478261, 0.67173913043478, 0.25
72083, 1.5695652173913, 0.67173913043478, 0.22222222222222
72084, 1.5913043478261, 0.69782608695652, 0.22222222222222
72085, 1.5913043478261, 0.67173913043478, 0.19444444444444
72086, 1.5695652173913, 0.67173913043478, 0.16666666666667
72087, 1.5913043478261, 0.69782608695652, 0.16666666666667
72088, 1.5913043478261, 0.67173913043478, 0.13888888888889
72089, 1.5695652173913, 0.67173913043478, 0.11111111111111
72090, 1.5913043478261, 0.69782608695652, 0.11111111111111
72091, 1.5913043478261, 0.67173913043478, 0.083333333333333
72092, 1.5695652173913, 0.67173913043478, 0.055555555555556
72093, 1.5913043478261, 0.69782608695652, 0.055555555555556
72094, 1.5913043478261, 0.67173913043478, 0.027777777777778
72095, 1.6347826086957, 0.67173913043478, 0.47222222222222
72096, 1.6130434782609, 0.67173913043478, 0.44444444444444
72097, 1.6347826086957, 0.69782608695652, 0.44444444444444
72098, 1.6347826086957, 0.67173913043478, 0.41666666666667
72099, 1.6130434782609, 0.67173913043478, 0.38888888888889
72100, 1.6347826086957, 0.69782608695652, 0.38888888888889
72101, 1.6347826086957, 0.67173913043478, 0.36111111111111
72102, 1.6130434782609, 0.67173913043478, 0.33333333333333
72103, 1.6347826086957, 0.69782608695652, 0.33333333333333
72104, 1.6347826086957, 0.67173913043478, 0.30555555555556
72105, 1.6130434782609, 0.67173913043478, 0.27777777777778
72106, 1.6347826086957, 0.69782608695652, 0.27777777777778
72107, 1.6347826086957, 0.67173913043478, 0.25
72108, 1.6130434782609, 0.67173913043478, 0.22222222222222
72109, 1.6347826086957, 0.69782608695652, 0.22222222222222
72110, 1.6347826086957, 0.67173913043478, 0.19444444444444
72111, 1.6130434782609, 0.67173913043478, 0.16666666666667
72112, 1.6347826086957, 0.69782608695652, 0.16666666666667
72113, 1.6347826086957, 0.67173913043478, 0.13888888888889
72114, 1.6130434782609, 0.67173913043478, 0.11111111111111
72115, 1.6347826086957, 0.69782608695652, 0.11111111111111
72116, 1.6347826086957, 0.67173913043478, 0.083333333333333
72117, 1.6130434782609, 0.67173913043478, 0.055555555555556
72118, 1.6347826086957, 0.69782608695652, 0.055555555555556
72119, 1.6347826086957, 0.67173913043478, 0.027777777777778
72120, 1.6782608695652, 0.67173913043478, 0.47222222222222
72121, 1.6565217391304, 0.67173913043478, 0.44444444444444
72122, 1.6782608695652, 0.69782608695652, 0.44444444444444
72123, 1.6782608695652, 0.67173913043478, 0.41666666666667
72124, 1.6565217391304, 0.67173913043478, 0.38888888888889
72125, 1.6782608695652, 0.69782608695652, 0.38888888888889
72126, 1.6782608695652, 0.67173913043478, 0.36111111111111
72127, 1.6565217391304, 0.67173913043478, 0.33333333333333
72128, 1.6782608695652, 0.69782608695652, 0.33333333333333
72129, 1.6782608695652, 0.67173913043478, 0.30555555555556
72130, 1.6565217391304, 0.67173913043478, 0.27777777777778
72131, 1.6782608695652, 0.69782608695652, 0.27777777777778
72132, 1.6782608695652, 0.67173913043478, 0.25
72133, 1.6565217391304, 0.67173913043478, 0.22222222222222
72134, 1.6782608695652, 0.69782608695652, 0.22222222222222
72135, 1.6782608695652, 0.67173913043478, 0.19444444444444
72136, 1.6565217391304, 0.67173913043478, 0.16666666666667
72137, 1.6782608695652, 0.69782608695652, 0.16666666666667
72138, 1.6782608695652, 0.67173913043478, 0.13888888888889
72139, 1.6565217391304, 0.67173913043478, 0.11111111111111
72140, 1.6782608695652, 0.69782608695652, 0.11111111111111
72141, 1.6782608695652, 0.67173913043478, 0.083333333333333
72142, 1.6565217391304, 0.67173913043478, 0.055555555555556
72143, 1.6782608695652, 0.69782608695652, 0.055555555555556
72144, 1.6782608695652, 0.67173913043478, 0.027777777777778
72145, 1.7217391304348, 0.67173913043478, 0.47222222222222
72146, 1.7, 0.67173913043478, 0.44444444444444
72147, 1.7217391304348, 0.69782608695652, 0.44444444444444
72148, 1.7217391304348, 0.67173913043478, 0.41666666666667
72149, 1.7, 0.67173913043478, 0.38888888888889
72150, 1.7217391304348, 0.69782608695652, 0.38888888888889
72151, 1.7217391304348, 0.67173913043478, 0.36111111111111
72152, 1.7, 0.67173913043478, 0.33333333333333
72153, 1.7217391304348, 0.69782608695652, 0.33333333333333
72154, 1.7217391304348, 0.67173913043478, 0.30555555555556
72155, 1.7, 0.67173913043478, 0.27777777777778
72156, 1.7217391304348, 0.69782608695652, 0.27777777777778
72157, 1.7217391304348, 0.67173913043478, 0.25
72158, 1.7, 0.67173913043478, 0.22222222222222
72159, 1.7217391304348, 0.69782608695652, 0.22222222222222
72160, 1.7217391304348, 0.67173913043478, 0.19444444444444
72161, 1.7, 0.67173913043478, 0.16666666666667
72162, 1.7217391304348, 0.69782608695652, 0.16666666666667
72163, 1.7217391304348, 0.67173913043478, 0.13888888888889
72164, 1.7, 0.67173913043478, 0.11111111111111
72165, 1.7217391304348, 0.69782608695652, 0.11111111111111
72166, 1.7217391304348, 0.67173913043478, 0.083333333333333
72167, 1.7, 0.67173913043478, 0.055555555555556
72168, 1.7217391304348, 0.69782608695652, 0.055555555555556
72169, 1.7217391304348, 0.67173913043478, 0.027777777777778
72170, 1.7652173913043, 0.67173913043478, 0.47222222222222
72171, 1.7434782608696, 0.67173913043478, 0.44444444444444
72172, 1.7652173913043, 0.69782608695652, 0.44444444444444
72173, 1.7652173913043, 0.67173913043478, 0.41666666666667
72174, 1.7434782608696, 0.67173913043478, 0.38888888888889
72175, 1.7652173913043, 0.69782608695652, 0.38888888888889
72176, 1.7652173913043, 0.67173913043478, 0.36111111111111
72177, 1.7434782608696, 0.67173913043478, 0.33333333333333
72178, 1.7652173913043, 0.69782608695652, 0.33333333333333
72179, 1.7652173913043, 0.67173913043478, 0.30555555555556
72180, 1.7434782608696, 0.67173913043478, 0.27777777777778
72181, 1.7652173913043, 0.69782608695652, 0.27777777777778
72182, 1.7652173913043, 0.67173913043478, 0.25
72183, 1.7434782608696, 0.67173913043478, 0.22222222222222
72184, 1.7652173913043, 0.69782608695652, 0.22222222222222
72185, 1.7652173913043, 0.67173913043478, 0.19444444444444
72186, 1.7434782608696, 0.67173913043478, 0.16666666666667
72187, 1.7652173913043, 0.69782608695652, 0.16666666666667
72188, 1.7652173913043, 0.67173913043478, 0.13888888888889
72189, 1.7434782608696, 0.67173913043478, 0.11111111111111
72190, 1.7652173913043, 0.69782608695652, 0.11111111111111
72191, 1.7652173913043, 0.67173913043478, 0.083333333333333
72192, 1.7434782608696, 0.67173913043478, 0.055555555555556
72193, 1.7652173913043, 0.69782608695652, 0.055555555555556
72194, 1.7652173913043, 0.67173913043478, 0.027777777777778
72195, 1.8086956521739, 0.67173913043478, 0.47222222222222
72196, 1.7869565217391, 0.67173913043478, 0.44444444444444
72197, 1.8086956521739, 0.69782608695652, 0.44444444444444
72198, 1.8086956521739, 0.67173913043478, 0.41666666666667
72199, 1.7869565217391, 0.67173913043478, 0.38888888888889
72200, 1.8086956521739, 0.69782608695652, 0.38888888888889
72201, 1.8086956521739, 0.67173913043478, 0.36111111111111
72202, 1.7869565217391, 0.67173913043478, 0.33333333333333
72203, 1.8086956521739, 0.69782608695652, 0.33333333333333
72204, 1.8086956521739, 0.67173913043478, 0.30555555555556
72205, 1.7869565217391, 0.67173913043478, 0.27777777777778
72206, 1.8086956521739, 0.69782608695652, 0.27777777777778
72207, 1.8086956521739, 0.67173913043478, 0.25
72208, 1.7869565217391, 0.67173913043478, 0.22222222222222
72209, 1.8086956521739, 0.69782608695652, 0.22222222222222
72210, 1.8086956521739, 0.67173913043478, 0.19444444444444
72211, 1.7869565217391, 0.67173913043478, 0.16666666666667
72212, 1.8086956521739, 0.69782608695652, 0.16666666666667
72213, 1.8086956521739, 0.67173913043478, 0.13888888888889
72214, 1.7869565217391, 0.67173913043478, 0.11111111111111
72215, 1.8086956521739, 0.69782608695652, 0.11111111111111
72216, 1.8086956521739, 0.67173913043478, 0.083333333333333
72217, 1.7869565217391, 0.67173913043478, 0.055555555555556
72218, 1.8086956521739, 0.69782608695652, 0.055555555555556
72219, 1.8086956521739, 0.67173913043478, 0.027777777777778
72220, 1.8521739130435, 0.67173913043478, 0.47222222222222
72221, 1.8304347826087, 0.67173913043478, 0.44444444444444
72222, 1.8521739130435, 0.69782608695652, 0.44444444444444
72223, 1.8521739130435, 0.67173913043478, 0.41666666666667
72224, 1.8304347826087, 0.67173913043478, 0.38888888888889
72225, 1.8521739130435, 0.69782608695652, 0.38888888888889
72226, 1.8521739130435, 0.67173913043478, 0.36111111111111
72227, 1.8304347826087, 0.67173913043478, 0.33333333333333
72228, 1.8521739130435, 0.69782608695652, 0.33333333333333
72229, 1.8521739130435, 0.67173913043478, 0.30555555555556
72230, 1.8304347826087, 0.67173913043478, 0.27777777777778
72231, 1.8521739130435, 0.69782608695652, 0.27777777777778
72232, 1.8521739130435, 0.67173913043478, 0.25
72233, 1.8304347826087, 0.67173913043478, 0.22222222222222
72234, 1.8521739130435, 0.69782608695652, 0.22222222222222
72235, 1.8521739130435, 0.67173913043478, 0.19444444444444
72236, 1.8304347826087, 0.67173913043478, 0.16666666666667
72237, 1.8521739130435, 0.69782608695652, 0.16666666666667
72238, 1.8521739130435, 0.67173913043478, 0.13888888888889
72239, 1.8304347826087, 0.67173913043478, 0.11111111111111
72240, 1.8521739130435, 0.69782608695652, 0.11111111111111
72241, 1.8521739130435, 0.67173913043478, 0.083333333333333
72242, 1.8304347826087, 0.67173913043478, 0.055555555555556
72243, 1.8521739130435, 0.69782608695652, 0.055555555555556
72244, 1.8521739130435, 0.67173913043478, 0.027777777777778
72245, 1.895652173913, 0.67173913043478, 0.47222222222222
72246, 1.8739130434783, 0.67173913043478, 0.44444444444444
72247, 1.895652173913, 0.69782608695652, 0.44444444444444
72248, 1.895652173913, 0.67173913043478, 0.41666666666667
72249, 1.8739130434783, 0.67173913043478, 0.38888888888889
72250, 1.895652173913, 0.69782608695652, 0.38888888888889
72251, 1.895652173913, 0.67173913043478, 0.36111111111111
72252, 1.8739130434783, 0.67173913043478, 0.33333333333333
72253, 1.895652173913, 0.69782608695652, 0.33333333333333
72254, 1.895652173913, 0.67173913043478, 0.30555555555556
72255, 1.8739130434783, 0.67173913043478, 0.27777777777778
72256, 1.895652173913, 0.69782608695652, 0.27777777777778
72257, 1.895652173913, 0.67173913043478, 0.25
72258, 1.8739130434783, 0.67173913043478, 0.22222222222222
72259, 1.895652173913, 0.69782608695652, 0.22222222222222
72260, 1.895652173913, 0.67173913043478, 0.19444444444444
72261, 1.8739130434783, 0.67173913043478, 0.16666666666667
72262, 1.895652173913, 0.69782608695652, 0.16666666666667
72263, 1.895652173913, 0.67173913043478, 0.13888888888889
72264, 1.8739130434783, 0.67173913043478, 0.11111111111111
72265, 1.895652173913, 0.69782608695652, 0.11111111111111
72266, 1.895652173913, 0.67173913043478, 0.083333333333333
72267, 1.8739130434783, 0.67173913043478, 0.055555555555556
72268, 1.895652173913, 0.69782608695652, 0.055555555555556
72269, 1.895652173913, 0.67173913043478, 0.027777777777778
72270, 1.9391304347826, 0.67173913043478, 0.47222222222222
72271, 1.9173913043478, 0.67173913043478, 0.44444444444444
72272, 1.9391304347826, 0.69782608695652, 0.44444444444444
72273, 1.9391304347826, 0.67173913043478, 0.41666666666667
72274, 1.9173913043478, 0.67173913043478, 0.38888888888889
72275, 1.9391304347826, 0.69782608695652, 0.38888888888889
72276, 1.9391304347826, 0.67173913043478, 0.36111111111111
72277, 1.9173913043478, 0.67173913043478, 0.33333333333333
72278, 1.9391304347826, 0.69782608695652, 0.33333333333333
72279, 1.9391304347826, 0.67173913043478, 0.30555555555556
72280, 1.9173913043478, 0.67173913043478, 0.27777777777778
72281, 1.9391304347826, 0.69782608695652, 0.27777777777778
72282, 1.9391304347826, 0.67173913043478, 0.25
72283, 1.9173913043478, 0.67173913043478, 0.22222222222222
72284, 1.9391304347826, 0.69782608695652, 0.22222222222222
72285, 1.9391304347826, 0.67173913043478, 0.19444444444444
72286, 1.9173913043478, 0.67173913043478, 0.16666666666667
72287, 1.9391304347826, 0.69782608695652, 0.16666666666667
72288, 1.9391304347826, 0.67173913043478, 0.13888888888889
72289, 1.9173913043478, 0.67173913043478, 0.11111111111111
72290, 1.9391304347826, 0.69782608695652, 0.11111111111111
72291, 1.9391304347826, 0.67173913043478, 0.083333333333333
72292, 1.9173913043478, 0.67173913043478, 0.055555555555556
72293, 1.9391304347826, 0.69782608695652, 0.055555555555556
72294, 1.9391304347826, 0.67173913043478, 0.027777777777778
72295, 1.9826086956522, 0.67173913043478, 0.47222222222222
72296, 1.9608695652174, 0.67173913043478, 0.44444444444444
72297, 1.9826086956522, 0.69782608695652, 0.44444444444444
72298, 1.9826086956522, 0.67173913043478, 0.41666666666667
72299, 1.9608695652174, 0.67173913043478, 0.38888888888889
72300, 1.9826086956522, 0.69782608695652, 0.38888888888889
72301, 1.9826086956522, 0.67173913043478, 0.36111111111111
72302, 1.9608695652174, 0.67173913043478, 0.33333333333333
72303, 1.9826086956522, 0.69782608695652, 0.33333333333333
72304, 1.9826086956522, 0.67173913043478, 0.30555555555556
72305, 1.9608695652174, 0.67173913043478, 0.27777777777778
72306, 1.9826086956522, 0.69782608695652, 0.27777777777778
72307, 1.9826086956522, 0.67173913043478, 0.25
72308, 1.9608695652174, 0.67173913043478, 0.22222222222222
72309, 1.9826086956522, 0.69782608695652, 0.22222222222222
72310, 1.9826086956522, 0.67173913043478, 0.19444444444444
72311, 1.9608695652174, 0.67173913043478, 0.16666666666667
72312, 1.9826086956522, 0.69782608695652, 0.16666666666667
72313, 1.9826086956522, 0.67173913043478, 0.13888888888889
72314, 1.9608695652174, 0.67173913043478, 0.11111111111111
72315, 1.9826086956522, 0.69782608695652, 0.11111111111111
72316, 1.9826086956522, 0.67173913043478, 0.083333333333333
72317, 1.9608695652174, 0.67173913043478, 0.055555555555556
72318, 1.9826086956522, 0.69782608695652, 0.055555555555556
72319, 1.9826086956522, 0.67173913043478, 0.027777777777778
72320, 2.0260869565217, 0.67173913043478, 0.47222222222222
72321, 2.004347826087, 0.67173913043478, 0.44444444444444
72322, 2.0260869565217, 0.69782608695652, 0.44444444444444
72323, 2.0260869565217, 0.67173913043478, 0.41666666666667
72324, 2.004347826087, 0.67173913043478, 0.38888888888889
72325, 2.0260869565217, 0.69782608695652, 0.38888888888889
72326, 2.0260869565217, 0.67173913043478, 0.36111111111111
72327, 2.004347826087, 0.67173913043478, 0.33333333333333
72328, 2.0260869565217, 0.69782608695652, 0.33333333333333
72329, 2.0260869565217, 0.67173913043478, 0.30555555555556
72330, 2.004347826087, 0.67173913043478, 0.27777777777778
72331, 2.0260869565217, 0.69782608695652, 0.27777777777778
72332, 2.0260869565217, 0.67173913043478, 0.25
72333, 2.004347826087, 0.67173913043478, 0.22222222222222
72334, 2.0260869565217, 0.69782608695652, 0.22222222222222
72335, 2.0260869565217, 0.67173913043478, 0.19444444444444
72336, 2.004347826087, 0.67173913043478, 0.16666666666667
72337, 2.0260869565217, 0.69782608695652, 0.16666666666667
72338, 2.0260869565217, 0.67173913043478, 0.13888888888889
72339, 2.004347826087, 0.67173913043478, 0.11111111111111
72340, 2.0260869565217, 0.69782608695652, 0.11111111111111
72341, 2.0260869565217, 0.67173913043478, 0.083333333333333
72342, 2.004347826087, 0.67173913043478, 0.055555555555556
72343, 2.0260869565217, 0.69782608695652, 0.055555555555556
