5312, 1174, 1173, 11709, 11708, 1182, 11720, 11721, 11718
5313, 1173, 1172, 11710, 11709, 1181, 11722, 11723, 11720
5314, 1172, 1171, 11711, 11710, 1180, 11724, 11725, 11722
5315, 1171, 1170, 11712, 11711, 1179, 11726, 11727, 11724
5316, 1170, 1169, 11713, 11712, 1178, 11728, 11729, 11726
5317, 1169, 34, 1403, 11713, 1177, 1404, 11730, 11728
5318, 1393, 11706, 1413, 43, 11715, 11731, 1422, 1395
5319, 11706, 11707, 1412, 1413, 11717, 11732, 1421, 11731
5320, 11707, 11708, 1411, 1412, 11719, 11733, 1420, 11732
5321, 11708, 11709, 1410, 1411, 11721, 11734, 1419, 11733
5322, 11709, 11710, 1409, 1410, 11723, 11735, 1418, 11734
5323, 11710, 11711, 1408, 1409, 11725, 11736, 1417, 11735
5324, 11711, 11712, 1407, 1408, 11727, 11737, 1416, 11736
5325, 11712, 11713, 1406, 1407, 11729, 11738, 1415, 11737
5326, 11713, 1403, 44, 1406, 11730, 1405, 1414, 11738
*ELEMENT, type=CPS8, ELSET=Surface206
5327, 45, 1454, 11739, 1423, 1477, 11783, 11784, 1425
5328, 1454, 1453, 11740, 11739, 1476, 11785, 11786, 11783
5329, 1453, 1452, 11741, 11740, 1475, 11787, 11788, 11785
5330, 1452, 1451, 11742, 11741, 1474, 11789, 11790, 11787
5331, 1451, 1450, 11743, 11742, 1473, 11791, 11792, 11789
5332, 1450, 1449, 11744, 11743, 1472, 11793, 11794, 11791
5333, 1449, 1448, 11745, 11744, 1471, 11795, 11796, 11793
5334, 1448, 1447, 11746, 11745, 1470, 11797, 11798, 11795
5335, 1447, 1446, 11747, 11746, 1469, 11799, 11800, 11797
5336, 1446, 1445, 11748, 11747, 1468, 11801, 11802, 11799
5337, 1445, 1444, 11749, 11748, 1467, 11803, 11804, 11801
5338, 1444, 1443, 11750, 11749, 1466, 11805, 11806, 11803
5339, 1443, 1442, 11751, 11750, 1465, 11807, 11808, 11805
5340, 1442, 1441, 11752, 11751, 1464, 11809, 11810, 11807
5341, 1441, 1440, 11753, 11752, 1463, 11811, 11812, 11809
5342, 1440, 1439, 11754, 11753, 1462, 11813, 11814, 11811
5343, 1439, 1438, 11755, 11754, 1461, 11815, 11816, 11813
5344, 1438, 1437, 11756, 11755, 1460, 11817, 11818, 11815
5345, 1437, 1436, 11757, 11756, 1459, 11819, 11820, 11817
5346, 1436, 1435, 11758, 11757, 1458, 11821, 11822, 11819
5347, 1435, 1434, 11759, 11758, 1457, 11823, 11824, 11821
5348, 1434, 1433, 11760, 11759, 1456, 11825, 11826, 11823
5349, 1433, 47, 1428, 11760, 1455, 1430, 11827, 11825
5350, 1423, 11739, 11761, 1424, 11784, 11828, 11829, 1426
5351, 11739, 11740, 11762, 11761, 11786, 11830, 11831, 11828
5352, 11740, 11741, 11763, 11762, 11788, 11832, 11833, 11830
5353, 11741, 11742, 11764, 11763, 11790, 11834, 11835, 11832
5354, 11742, 11743, 11765, 11764, 11792, 11836, 11837, 11834
5355, 11743, 11744, 11766, 11765, 11794, 11838, 11839, 11836
5356, 11744, 11745, 11767, 11766, 11796, 11840, 11841, 11838
5357, 11745, 11746, 11768, 11767, 11798, 11842, 11843, 11840
5358, 11746, 11747, 11769, 11768, 11800, 11844, 11845, 11842
5359, 11747, 11748, 11770, 11769, 11802, 11846, 11847, 11844
5360, 11748, 11749, 11771, 11770, 11804, 11848, 11849, 11846
5361, 11749, 11750, 11772, 11771, 11806, 11850, 11851, 11848
5362, 11750, 11751, 11773, 11772, 11808, 11852, 11853, 11850
5363, 11751, 11752, 11774, 11773, 11810, 11854, 11855, 11852
5364, 11752, 11753, 11775, 11774, 11812, 11856, 11857, 11854
5365, 11753, 11754, 11776, 11775, 11814, 11858, 11859, 11856
5366, 11754, 11755, 11777, 11776, 11816, 11860, 11861, 11858
5367, 11755, 11756, 11778, 11777, 11818, 11862, 11863, 11860
5368, 11756, 11757, 11779, 11778, 11820, 11864, 11865, 11862
5369, 11757, 11758, 11780, 11779, 11822, 11866, 11867, 11864
5370, 11758, 11759, 11781, 11780, 11824, 11868, 11869, 11866
5371, 11759, 11760, 11782, 11781, 11826, 11870, 11871, 11868
5372, 11760, 1428, 1429, 11782, 11827, 1431, 11872, 11870
5373, 1424, 11761, 1499, 46, 11829, 11873, 1522, 1427
5374, 11761, 11762, 1498, 1499, 11831, 11874, 1521, 11873
5375, 11762, 11763, 1497, 1498, 11833, 11875, 1520, 11874
5376, 11763, 11764, 1496, 1497, 11835, 11876, 1519, 11875
5377, 11764, 11765, 1495, 1496, 11837, 11877, 1518, 11876
5378, 11765, 11766, 1494, 1495, 11839, 11878, 1517, 11877
5379, 11766, 11767, 1493, 1494, 11841, 11879, 1516, 11878
5380, 11767, 11768, 1492, 1493, 11843, 11880, 1515, 11879
5381, 11768, 11769, 1491, 1492, 11845, 11881, 1514, 11880
5382, 11769, 11770, 1490, 1491, 11847, 11882, 1513, 11881
5383, 11770, 11771, 1489, 1490, 11849, 11883, 1512, 11882
5384, 11771, 11772, 1488, 1489, 11851, 11884, 1511, 11883
5385, 11772, 11773, 1487, 1488, 11853, 11885, 1510, 11884
5386, 11773, 11774, 1486, 1487, 11855, 11886, 1509, 11885
5387, 11774, 11775, 1485, 1486, 11857, 11887, 1508, 11886
5388, 11775, 11776, 1484, 1485, 11859, 11888, 1507, 11887
5389, 11776, 11777, 1483, 1484, 11861, 11889, 1506, 11888
5390, 11777, 11778, 1482, 1483, 11863, 11890, 1505, 11889
5391, 11778, 11779, 1481, 1482, 11865, 11891, 1504, 11890
5392, 11779, 11780, 1480, 1481, 11867, 11892, 1503, 11891
5393, 11780, 11781, 1479, 1480, 11869, 11893, 1502, 11892
5394, 11781, 11782, 1478, 1479, 11871, 11894, 1501, 11893
5395, 11782, 1429, 48, 1478, 11872, 1432, 1500, 11894
*ELEMENT, type=CPS8, ELSET=Surface207
5396, 49, 1535, 11895, 1523, 1544, 11911, 11912, 1525
5397, 1535, 1534, 11896, 11895, 1543, 11913, 11914, 11911
5398, 1534, 1533, 11897, 11896, 1542, 11915, 11916, 11913
5399, 1533, 1532, 11898, 11897, 1541, 11917, 11918, 11915
5400, 1532, 1531, 11899, 11898, 1540, 11919, 11920, 11917
5401, 1531, 1530, 11900, 11899, 1539, 11921, 11922, 11919
5402, 1530, 1529, 11901, 11900, 1538, 11923, 11924, 11921
5403, 1529, 1528, 11902, 11901, 1537, 11925, 11926, 11923
5404, 1528, 45, 1423, 11902, 1536, 1425, 11927, 11925
5405, 1523, 11895, 11903, 1524, 11912, 11928, 11929, 1526
5406, 11895, 11896, 11904, 11903, 11914, 11930, 11931, 11928
5407, 11896, 11897, 11905, 11904, 11916, 11932, 11933, 11930
5408, 11897, 11898, 11906, 11905, 11918, 11934, 11935, 11932
5409, 11898, 11899, 11907, 11906, 11920, 11936, 11937, 11934
5410, 11899, 11900, 11908, 11907, 11922, 11938, 11939, 11936
5411, 11900, 11901, 11909, 11908, 11924, 11940, 11941, 11938
5412, 11901, 11902, 11910, 11909, 11926, 11942, 11943, 11940
5413, 11902, 1423, 1424, 11910, 11927, 1426, 11944, 11942
5414, 1524, 11903, 1552, 50, 11929, 11945, 1561, 1527
5415, 11903, 11904, 1551, 1552, 11931, 11946, 1560, 11945
5416, 11904, 11905, 1550, 1551, 11933, 11947, 1559, 11946
5417, 11905, 11906, 1549, 1550, 11935, 11948, 1558, 11947
5418, 11906, 11907, 1548, 1549, 11937, 11949, 1557, 11948
5419, 11907, 11908, 1547, 1548, 11939, 11950, 1556, 11949
5420, 11908, 11909, 1546, 1547, 11941, 11951, 1555, 11950
5421, 11909, 11910, 1545, 1546, 11943, 11952, 1554, 11951
5422, 11910, 1424, 46, 1545, 11944, 1427, 1553, 11952
*ELEMENT, type=CPS8, ELSET=Surface208
5423, 49, 1523, 11953, 1588, 1525, 11997, 11998, 1611
5424, 1588, 11953, 11954, 1587, 11998, 11999, 12000, 1610
5425, 1587, 11954, 11955, 1586, 12000, 12001, 12002, 1609
5426, 1586, 11955, 11956, 1585, 12002, 12003, 12004, 1608
5427, 1585, 11956, 11957, 1584, 12004, 12005, 12006, 1607
5428, 1584, 11957, 11958, 1583, 12006, 12007, 12008, 1606
5429, 1583, 11958, 11959, 1582, 12008, 12009, 12010, 1605
5430, 1582, 11959, 11960, 1581, 12010, 12011, 12012, 1604
5431, 1581, 11960, 11961, 1580, 12012, 12013, 12014, 1603
5432, 1580, 11961, 11962, 1579, 12014, 12015, 12016, 1602
5433, 1579, 11962, 11963, 1578, 12016, 12017, 12018, 1601
5434, 1578, 11963, 11964, 1577, 12018, 12019, 12020, 1600
5435, 1577, 11964, 11965, 1576, 12020, 12021, 12022, 1599
5436, 1576, 11965, 11966, 1575, 12022, 12023, 12024, 1598
5437, 1575, 11966, 11967, 1574, 12024, 12025, 12026, 1597
5438, 1574, 11967, 11968, 1573, 12026, 12027, 12028, 1596
5439, 1573, 11968, 11969, 1572, 12028, 12029, 12030, 1595
5440, 1572, 11969, 11970, 1571, 12030, 12031, 12032, 1594
5441, 1571, 11970, 11971, 1570, 12032, 12033, 12034, 1593
5442, 1570, 11971, 11972, 1569, 12034, 12035, 12036, 1592
5443, 1569, 11972, 11973, 1568, 12036, 12037, 12038, 1591
5444, 1568, 11973, 11974, 1567, 12038, 12039, 12040, 1590
5445, 1567, 11974, 1562, 51, 12040, 12041, 1564, 1589
5446, 1523, 1524, 11975, 11953, 1526, 12042, 12043, 11997
5447, 11953, 11975, 11976, 11954, 12043, 12044, 12045, 11999
5448, 11954, 11976, 11977, 11955, 12045, 12046, 12047, 12001
5449, 11955, 11977, 11978, 11956, 12047, 12048, 12049, 12003
5450, 11956, 11978, 11979, 11957, 12049, 12050, 12051, 12005
5451, 11957, 11979, 11980, 11958, 12051, 12052, 12053, 12007
5452, 11958, 11980, 11981, 11959, 12053, 12054, 12055, 12009
5453, 11959, 11981, 11982, 11960, 12055, 12056, 12057, 12011
5454, 11960, 11982, 11983, 11961, 12057, 12058, 12059, 12013
5455, 11961, 11983, 11984, 11962, 12059, 12060, 12061, 12015
5456, 11962, 11984, 11985, 11963, 12061, 12062, 12063, 12017
5457, 11963, 11985, 11986, 11964, 12063, 12064, 12065, 12019
5458, 11964, 11986, 11987, 11965, 12065, 12066, 12067, 12021
5459, 11965, 11987, 11988, 11966, 12067, 12068, 12069, 12023
5460, 11966, 11988, 11989, 11967, 12069, 12070, 12071, 12025
5461, 11967, 11989, 11990, 11968, 12071, 12072, 12073, 12027
5462, 11968, 11990, 11991, 11969, 12073, 12074, 12075, 12029
5463, 11969, 11991, 11992, 11970, 12075, 12076, 12077, 12031
5464, 11970, 11992, 11993, 11971, 12077, 12078, 12079, 12033
5465, 11971, 11993, 11994, 11972, 12079, 12080, 12081, 12035
5466, 11972, 11994, 11995, 11973, 12081, 12082, 12083, 12037
5467, 11973, 11995, 11996, 11974, 12083, 12084, 12085, 12039
5468, 11974, 11996, 1563, 1562, 12085, 12086, 1565, 12041
5469, 1524, 50, 1633, 11975, 1527, 1656, 12087, 12042
5470, 11975, 1633, 1632, 11976, 12087, 1655, 12088, 12044
5471, 11976, 1632, 1631, 11977, 12088, 1654, 12089, 12046
5472, 11977, 1631, 1630, 11978, 12089, 1653, 12090, 12048
5473, 11978, 1630, 1629, 11979, 12090, 1652, 12091, 12050
5474, 11979, 1629, 1628, 11980, 12091, 1651, 12092, 12052
5475, 11980, 1628, 1627, 11981, 12092, 1650, 12093, 12054
5476, 11981, 1627, 1626, 11982, 12093, 1649, 12094, 12056
5477, 11982, 1626, 1625, 11983, 12094, 1648, 12095, 12058
5478, 11983, 1625, 1624, 11984, 12095, 1647, 12096, 12060
5479, 11984, 1624, 1623, 11985, 12096, 1646, 12097, 12062
5480, 11985, 1623, 1622, 11986, 12097, 1645, 12098, 12064
5481, 11986, 1622, 1621, 11987, 12098, 1644, 12099, 12066
5482, 11987, 1621, 1620, 11988, 12099, 1643, 12100, 12068
5483, 11988, 1620, 1619, 11989, 12100, 1642, 12101, 12070
5484, 11989, 1619, 1618, 11990, 12101, 1641, 12102, 12072
5485, 11990, 1618, 1617, 11991, 12102, 1640, 12103, 12074
5486, 11991, 1617, 1616, 11992, 12103, 1639, 12104, 12076
5487, 11992, 1616, 1615, 11993, 12104, 1638, 12105, 12078
5488, 11993, 1615, 1614, 11994, 12105, 1637, 12106, 12080
5489, 11994, 1614, 1613, 11995, 12106, 1636, 12107, 12082
5490, 11995, 1613, 1612, 11996, 12107, 1635, 12108, 12084
5491, 11996, 1612, 52, 1563, 12108, 1634, 1566, 12086
*ELEMENT, type=CPS8, ELSET=Surface209
5492, 51, 1562, 12109, 1664, 1564, 12125, 12126, 1673
5493, 1664, 12109, 12110, 1663, 12126, 12127, 12128, 1672
5494, 1663, 12110, 12111, 1662, 12128, 12129, 12130, 1671
5495, 1662, 12111, 12112, 1661, 12130, 12131, 12132, 1670
5496, 1661, 12112, 12113, 1660, 12132, 12133, 12134, 1669
5497, 1660, 12113, 12114, 1659, 12134, 12135, 12136, 1668
5498, 1659, 12114, 12115, 1658, 12136, 12137, 12138, 1667
5499, 1658, 12115, 12116, 1657, 12138, 12139, 12140, 1666
5500, 1657, 12116, 1428, 47, 12140, 12141, 1430, 1665
5501, 1562, 1563, 12117, 12109, 1565, 12142, 12143, 12125
5502, 12109, 12117, 12118, 12110, 12143, 12144, 12145, 12127
5503, 12110, 12118, 12119, 12111, 12145, 12146, 12147, 12129
5504, 12111, 12119, 12120, 12112, 12147, 12148, 12149, 12131
5505, 12112, 12120, 12121, 12113, 12149, 12150, 12151, 12133
5506, 12113, 12121, 12122, 12114, 12151, 12152, 12153, 12135
5507, 12114, 12122, 12123, 12115, 12153, 12154, 12155, 12137
5508, 12115, 12123, 12124, 12116, 12155, 12156, 12157, 12139
5509, 12116, 12124, 1429, 1428, 12157, 12158, 1431, 12141
5510, 1563, 52, 1681, 12117, 1566, 1690, 12159, 12142
5511, 12117, 1681, 1680, 12118, 12159, 1689, 12160, 12144
5512, 12118, 1680, 1679, 12119, 12160, 1688, 12161, 12146
5513, 12119, 1679, 1678, 12120, 12161, 1687, 12162, 12148
5514, 12120, 1678, 1677, 12121, 12162, 1686, 12163, 12150
5515, 12121, 1677, 1676, 12122, 12163, 1685, 12164, 12152
5516, 12122, 1676, 1675, 12123, 12164, 1684, 12165, 12154
5517, 12123, 1675, 1674, 12124, 12165, 1683, 12166, 12156
5518, 12124, 1674, 48, 1429, 12166, 1682, 1432, 12158
*ELEMENT, type=CPS8, ELSET=Surface210
5519, 47, 1433, 12167, 1657, 1455, 12343, 12344, 1665
5520, 1657, 12167, 12168, 1658, 12344, 12345, 12346, 1666
5521, 1658, 12168, 12169, 1659, 12346, 12347, 12348, 1667
5522, 1659, 12169, 12170, 1660, 12348, 12349, 12350, 1668
5523, 1660, 12170, 12171, 1661, 12350, 12351, 12352, 1669
5524, 1661, 12171, 12172, 1662, 12352, 12353, 12354, 1670
5525, 1662, 12172, 12173, 1663, 12354, 12355, 12356, 1671
5526, 1663, 12173, 12174, 1664, 12356, 12357, 12358, 1672
5527, 1664, 12174, 1567, 51, 12358, 12359, 1589, 1673
5528, 1433, 1434, 12175, 12167, 1456, 12360, 12361, 12343
5529, 12167, 12175, 12176, 12168, 12361, 12362, 12363, 12345
5530, 12168, 12176, 12177, 12169, 12363, 12364, 12365, 12347
5531, 12169, 12177, 12178, 12170, 12365, 12366, 12367, 12349
5532, 12170, 12178, 12179, 12171, 12367, 12368, 12369, 12351
5533, 12171, 12179, 12180, 12172, 12369, 12370, 12371, 12353
5534, 12172, 12180, 12181, 12173, 12371, 12372, 12373, 12355
5535, 12173, 12181, 12182, 12174, 12373, 12374, 12375, 12357
5536, 12174, 12182, 1568, 1567, 12375, 12376, 1590, 12359
5537, 1434, 1435, 12183, 12175, 1457, 12377, 12378, 12360
5538, 12175, 12183, 12184, 12176, 12378, 12379, 12380, 12362
5539, 12176, 12184, 12185, 12177, 12380, 12381, 12382, 12364
5540, 12177, 12185, 12186, 12178, 12382, 12383, 12384, 12366
5541, 12178, 12186, 12187, 12179, 12384, 12385, 12386, 12368
5542, 12179, 12187, 12188, 12180, 12386, 12387, 12388, 12370
5543, 12180, 12188, 12189, 12181, 12388, 12389, 12390, 12372
5544, 12181, 12189, 12190, 12182, 12390, 12391, 12392, 12374
5545, 12182, 12190, 1569, 1568, 12392, 12393, 1591, 12376
5546, 1435, 1436, 12191, 12183, 1458, 12394, 12395, 12377
5547, 12183, 12191, 12192, 12184, 12395, 12396, 12397, 12379
5548, 12184, 12192, 12193, 12185, 12397, 12398, 12399, 12381
5549, 12185, 12193, 12194, 12186, 12399, 12400, 12401, 12383
5550, 12186, 12194, 12195, 12187, 12401, 12402, 12403, 12385
5551, 12187, 12195, 12196, 12188, 12403, 12404, 12405, 12387
5552, 12188, 12196, 12197, 12189, 12405, 12406, 12407, 12389
5553, 12189, 12197, 12198, 12190, 12407, 12408, 12409, 12391
5554, 12190, 12198, 1570, 1569, 12409, 12410, 1592, 12393
5555, 1436, 1437, 12199, 12191, 1459, 12411, 12412, 12394
5556, 12191, 12199, 12200, 12192, 12412, 12413, 12414, 12396
5557, 12192, 12200, 12201, 12193, 12414, 12415, 12416, 12398
5558, 12193, 12201, 12202, 12194, 12416, 12417, 12418, 12400
5559, 12194, 12202, 12203, 12195, 12418, 12419, 12420, 12402
5560, 12195, 12203, 12204, 12196, 12420, 12421, 12422, 12404
5561, 12196, 12204, 12205, 12197, 12422, 12423, 12424, 12406
5562, 12197, 12205, 12206, 12198, 12424, 12425, 12426, 12408
5563, 12198, 12206, 1571, 1570, 12426, 12427, 1593, 12410
5564, 1437, 1438, 12207, 12199, 1460, 12428, 12429, 12411
5565, 12199, 12207, 12208, 12200, 12429, 12430, 12431, 12413
5566, 12200, 12208, 12209, 12201, 12431, 12432, 12433, 12415
5567, 12201, 12209, 12210, 12202, 12433, 12434, 12435, 12417
5568, 12202, 12210, 12211, 12203, 12435, 12436, 12437, 12419
5569, 12203, 12211, 12212, 12204, 12437, 12438, 12439, 12421
5570, 12204, 12212, 12213, 12205, 12439, 12440, 12441, 12423
5571, 12205, 12213, 12214, 12206, 12441, 12442, 12443, 12425
5572, 12206, 12214, 1572, 1571, 12443, 12444, 1594, 12427
5573, 1438, 1439, 12215, 12207, 1461, 12445, 12446, 12428
5574, 12207, 12215, 12216, 12208, 12446, 12447, 12448, 12430
5575, 12208, 12216, 12217, 12209, 12448, 12449, 12450, 12432
5576, 12209, 12217, 12218, 12210, 12450, 12451, 12452, 12434
5577, 12210, 12218, 12219, 12211, 12452, 12453, 12454, 12436
5578, 12211, 12219, 12220, 12212, 12454, 12455, 12456, 12438
5579, 12212, 12220, 12221, 12213, 12456, 12457, 12458, 12440
5580, 12213, 12221, 12222, 12214, 12458, 12459, 12460, 12442
5581, 12214, 12222, 1573, 1572, 12460, 12461, 1595, 12444
5582, 1439, 1440, 12223, 12215, 1462, 12462, 12463, 12445
5583, 12215, 12223, 12224, 12216, 12463, 12464, 12465, 12447
5584, 12216, 12224, 12225, 12217, 12465, 12466, 12467, 12449
5585, 12217, 12225, 12226, 12218, 12467, 12468, 12469, 12451
5586, 12218, 12226, 12227, 12219, 12469, 12470, 12471, 12453
5587, 12219, 12227, 12228, 12220, 12471, 12472, 12473, 12455
5588, 12220, 12228, 12229, 12221, 12473, 12474, 12475, 12457
5589, 12221, 12229, 12230, 12222, 12475, 12476, 12477, 12459
5590, 12222, 12230, 1574, 1573, 12477, 12478, 1596, 12461
5591, 1440, 1441, 12231, 12223, 1463, 12479, 12480, 12462
5592, 12223, 12231, 12232, 12224, 12480, 12481, 12482, 12464
5593, 12224, 12232, 12233, 12225, 12482, 12483, 12484, 12466
5594, 12225, 12233, 12234, 12226, 12484, 12485, 12486, 12468
5595, 12226, 12234, 12235, 12227, 12486, 12487, 12488, 12470
5596, 12227, 12235, 12236, 12228, 12488, 12489, 12490, 12472
5597, 12228, 12236, 12237, 12229, 12490, 12491, 12492, 12474
5598, 12229, 12237, 12238, 12230, 12492, 12493, 12494, 12476
5599, 12230, 12238, 1575, 1574, 12494, 12495, 1597, 12478
5600, 1441, 1442, 12239, 12231, 1464, 12496, 12497, 12479
5601, 12231, 12239, 12240, 12232, 12497, 12498, 12499, 12481
5602, 12232, 12240, 12241, 12233, 12499, 12500, 12501, 12483
5603, 12233, 12241, 12242, 12234, 12501, 12502, 12503, 12485
5604, 12234, 12242, 12243, 12235, 12503, 12504, 12505, 12487
5605, 12235, 12243, 12244, 12236, 12505, 12506, 12507, 12489
5606, 12236, 12244, 12245, 12237, 12507, 12508, 12509, 12491
5607, 12237, 12245, 12246, 12238, 12509, 12510, 12511, 12493
5608, 12238, 12246, 1576, 1575, 12511, 12512, 1598, 12495
5609, 1442, 1443, 12247, 12239, 1465, 12513, 12514, 12496
5610, 12239, 12247, 12248, 12240, 12514, 12515, 12516, 12498
5611, 12240, 12248, 12249, 12241, 12516, 12517, 12518, 12500
5612, 12241, 12249, 12250, 12242, 12518, 12519, 12520, 12502
5613, 12242, 12250, 12251, 12243, 12520, 12521, 12522, 12504
5614, 12243, 12251, 12252, 12244, 12522, 12523, 12524, 12506
5615, 12244, 12252, 12253, 12245, 12524, 12525, 12526, 12508
5616, 12245, 12253, 12254, 12246, 12526, 12527, 12528, 12510
5617, 12246, 12254, 1577, 1576, 12528, 12529, 1599, 12512
5618, 1443, 1444, 12255, 12247, 1466, 12530, 12531, 12513
5619, 12247, 12255, 12256, 12248, 12531, 12532, 12533, 12515
5620, 12248, 12256, 12257, 12249, 12533, 12534, 12535, 12517
5621, 12249, 12257, 12258, 12250, 12535, 12536, 12537, 12519
5622, 12250, 12258, 12259, 12251, 12537, 12538, 12539, 12521
5623, 12251, 12259, 12260, 12252, 12539, 12540, 12541, 12523
5624, 12252, 12260, 12261, 12253, 12541, 12542, 12543, 12525
5625, 12253, 12261, 12262, 12254, 12543, 12544, 12545, 12527
5626, 12254, 12262, 1578, 1577, 12545, 12546, 1600, 12529
5627, 1444, 1445, 12263, 12255, 1467, 12547, 12548, 12530
5628, 12255, 12263, 12264, 12256, 12548, 12549, 12550, 12532
5629, 12256, 12264, 12265, 12257, 12550, 12551, 12552, 12534
5630, 12257, 12265, 12266, 12258, 12552, 12553, 12554, 12536
5631, 12258, 12266, 12267, 12259, 12554, 12555, 12556, 12538
5632, 12259, 12267, 12268, 12260, 12556, 12557, 12558, 12540
5633, 12260, 12268, 12269, 12261, 12558, 12559, 12560, 12542
5634, 12261, 12269, 12270, 12262, 12560, 12561, 12562, 12544
5635, 12262, 12270, 1579, 1578, 12562, 12563, 1601, 12546
5636, 1445, 1446, 12271, 12263, 1468, 12564, 12565, 12547
5637, 12263, 12271, 12272, 12264, 12565, 12566, 12567, 12549
5638, 12264, 12272, 12273, 12265, 12567, 12568, 12569, 12551
5639, 12265, 12273, 12274, 12266, 12569, 12570, 12571, 12553
5640, 12266, 12274, 12275, 12267, 12571, 12572, 12573, 12555
5641, 12267, 12275, 12276, 12268, 12573, 12574, 12575, 12557
5642, 12268, 12276, 12277, 12269, 12575, 12576, 12577, 12559
5643, 12269, 12277, 12278, 12270, 12577, 12578, 12579, 12561
5644, 12270, 12278, 1580, 1579, 12579, 12580, 1602, 12563
5645, 1446, 1447, 12279, 12271, 1469, 12581, 12582, 12564
5646, 12271, 12279, 12280, 12272, 12582, 12583, 12584, 12566
5647, 12272, 12280, 12281, 12273, 12584, 12585, 12586, 12568
5648, 12273, 12281, 12282, 12274, 12586, 12587, 12588, 12570
5649, 12274, 12282, 12283, 12275, 12588, 12589, 12590, 12572
5650, 12275, 12283, 12284, 12276, 12590, 12591, 12592, 12574
5651, 12276, 12284, 12285, 12277, 12592, 12593, 12594, 12576
5652, 12277, 12285, 12286, 12278, 12594, 12595, 12596, 12578
5653, 12278, 12286, 1581, 1580, 12596, 12597, 1603, 12580
5654, 1447, 1448, 12287, 12279, 1470, 12598, 12599, 12581
5655, 12279, 12287, 12288, 12280, 12599, 12600, 12601, 12583
5656, 12280, 12288, 12289, 12281, 12601, 12602, 12603, 12585
5657, 12281, 12289, 12290, 12282, 12603, 12604, 12605, 12587
5658, 12282, 12290, 12291, 12283, 12605, 12606, 12607, 12589
5659, 12283, 12291, 12292, 12284, 12607, 12608, 12609, 12591
5660, 12284, 12292, 12293, 12285, 12609, 12610, 12611, 12593
5661, 12285, 12293, 12294, 12286, 12611, 12612, 12613, 12595
5662, 12286, 12294, 1582, 1581, 12613, 12614, 1604, 12597
5663, 1448, 1449, 12295, 12287, 1471, 12615, 12616, 12598
5664, 12287, 12295, 12296, 12288, 12616, 12617, 12618, 12600
5665, 12288, 12296, 12297, 12289, 12618, 12619, 12620, 12602
5666, 12289, 12297, 12298, 12290, 12620, 12621, 12622, 12604
5667, 12290, 12298, 12299, 12291, 12622, 12623, 12624, 12606
5668, 12291, 12299, 12300, 12292, 12624, 12625, 12626, 12608
5669, 12292, 12300, 12301, 12293, 12626, 12627, 12628, 12610
5670, 12293, 12301, 12302, 12294, 12628, 12629, 12630, 12612
5671, 12294, 12302, 1583, 1582, 12630, 12631, 1605, 12614
5672, 1449, 1450, 12303, 12295, 1472, 12632, 12633, 12615
5673, 12295, 12303, 12304, 12296, 12633, 12634, 12635, 12617
5674, 12296, 12304, 12305, 12297, 12635, 12636, 12637, 12619
5675, 12297, 12305, 12306, 12298, 12637, 12638, 12639, 12621
5676, 12298, 12306, 12307, 12299, 12639, 12640, 12641, 12623
5677, 12299, 12307, 12308, 12300, 12641, 12642, 12643, 12625
5678, 12300, 12308, 12309, 12301, 12643, 12644, 12645, 12627
5679, 12301, 12309, 12310, 12302, 12645, 12646, 12647, 12629
5680, 12302, 12310, 1584, 1583, 12647, 12648, 1606, 12631
5681, 1450, 1451, 12311, 12303, 1473, 12649, 12650, 12632
5682, 12303, 12311, 12312, 12304, 12650, 12651, 12652, 12634
5683, 12304, 12312, 12313, 12305, 12652, 12653, 12654, 12636
5684, 12305, 12313, 12314, 12306, 12654, 12655, 12656, 12638
5685, 12306, 12314, 12315, 12307, 12656, 12657, 12658, 12640
5686, 12307, 12315, 12316, 12308, 12658, 12659, 12660, 12642
5687, 12308, 12316, 12317, 12309, 12660, 12661, 12662, 12644
5688, 12309, 12317, 12318, 12310, 12662, 12663, 12664, 12646
5689, 12310, 12318, 1585, 1584, 12664, 12665, 1607, 12648
5690, 1451, 1452, 12319, 12311, 1474, 12666, 12667, 12649
5691, 12311, 12319, 12320, 12312, 12667, 12668, 12669, 12651
5692, 12312, 12320, 12321, 12313, 12669, 12670, 12671, 12653
5693, 12313, 12321, 12322, 12314, 12671, 12672, 12673, 12655
5694, 12314, 12322, 12323, 12315, 12673, 12674, 12675, 12657
5695, 12315, 12323, 12324, 12316, 12675, 12676, 12677, 12659
5696, 12316, 12324, 12325, 12317, 12677, 12678, 12679, 12661
5697, 12317, 12325, 12326, 12318, 12679, 12680, 12681, 12663
5698, 12318, 12326, 1586, 1585, 12681, 12682, 1608, 12665
5699, 1452, 1453, 12327, 12319, 1475, 12683, 12684, 12666
5700, 12319, 12327, 12328, 12320, 12684, 12685, 12686, 12668
5701, 12320, 12328, 12329, 12321, 12686, 12687, 12688, 12670
5702, 12321, 12329, 12330, 12322, 12688, 12689, 12690, 12672
5703, 12322, 12330, 12331, 12323, 12690, 12691, 12692, 12674
5704, 12323, 12331, 12332, 12324, 12692, 12693, 12694, 12676
5705, 12324, 12332, 12333, 12325, 12694, 12695, 12696, 12678
5706, 12325, 12333, 12334, 12326, 12696, 12697, 12698, 12680
5707, 12326, 12334, 1587, 1586, 12698, 12699, 1609, 12682
5708, 1453, 1454, 12335, 12327, 1476, 12700, 12701, 12683
5709, 12327, 12335, 12336, 12328, 12701, 12702, 12703, 12685
5710, 12328, 12336, 12337, 12329, 12703, 12704, 12705, 12687
5711, 12329, 12337, 12338, 12330, 12705, 12706, 12707, 12689
5712, 12330, 12338, 12339, 12331, 12707, 12708, 12709, 12691
5713, 12331, 12339, 12340, 12332, 12709, 12710, 12711, 12693
5714, 12332, 12340, 12341, 12333, 12711, 12712, 12713, 12695
5715, 12333, 12341, 12342, 12334, 12713, 12714, 12715, 12697
5716, 12334, 12342, 1588, 1587, 12715, 12716, 1610, 12699
5717, 1454, 45, 1528, 12335, 1477, 1536, 12717, 12700
5718, 12335, 1528, 1529, 12336, 12717, 1537, 12718, 12702
5719, 12336, 1529, 1530, 12337, 12718, 1538, 12719, 12704
5720, 12337, 1530, 1531, 12338, 12719, 1539, 12720, 12706
5721, 12338, 1531, 1532, 12339, 12720, 1540, 12721, 12708
5722, 12339, 1532, 1533, 12340, 12721, 1541, 12722, 12710
5723, 12340, 1533, 1534, 12341, 12722, 1542, 12723, 12712
5724, 12341, 1534, 1535, 12342, 12723, 1543, 12724, 12714
5725, 12342, 1535, 49, 1588, 12724, 1544, 1611, 12716
*ELEMENT, type=CPS8, ELSET=Surface211
5726, 48, 1674, 12725, 1478, 1682, 12901, 12902, 1500
5727, 1674, 1675, 12726, 12725, 1683, 12903, 12904, 12901
5728, 1675, 1676, 12727, 12726, 1684, 12905, 12906, 12903
5729, 1676, 1677, 12728, 12727, 1685, 12907, 12908, 12905
5730, 1677, 1678, 12729, 12728, 1686, 12909, 12910, 12907
5731, 1678, 1679, 12730, 12729, 1687, 12911, 12912, 12909
5732, 1679, 1680, 12731, 12730, 1688, 12913, 12914, 12911
5733, 1680, 1681, 12732, 12731, 1689, 12915, 12916, 12913
5734, 1681, 52, 1612, 12732, 1690, 1634, 12917, 12915
5735, 1478, 12725, 12733, 1479, 12902, 12918, 12919, 1501
5736, 12725, 12726, 12734, 12733, 12904, 12920, 12921, 12918
5737, 12726, 12727, 12735, 12734, 12906, 12922, 12923, 12920
5738, 12727, 12728, 12736, 12735, 12908, 12924, 12925, 12922
5739, 12728, 12729, 12737, 12736, 12910, 12926, 12927, 12924
5740, 12729, 12730, 12738, 12737, 12912, 12928, 12929, 12926
5741, 12730, 12731, 12739, 12738, 12914, 12930, 12931, 12928
5742, 12731, 12732, 12740, 12739, 12916, 12932, 12933, 12930
5743, 12732, 1612, 1613, 12740, 12917, 1635, 12934, 12932
5744, 1479, 12733, 12741, 1480, 12919, 12935, 12936, 1502
5745, 12733, 12734, 12742, 12741, 12921, 12937, 12938, 12935
5746, 12734, 12735, 12743, 12742, 12923, 12939, 12940, 12937
5747, 12735, 12736, 12744, 12743, 12925, 12941, 12942, 12939
5748, 12736, 12737, 12745, 12744, 12927, 12943, 12944, 12941
5749, 12737, 12738, 12746, 12745, 12929, 12945, 12946, 12943
5750, 12738, 12739, 12747, 12746, 12931, 12947, 12948, 12945
5751, 12739, 12740, 12748, 12747, 12933, 12949, 12950, 12947
5752, 12740, 1613, 1614, 12748, 12934, 1636, 12951, 12949
5753, 1480, 12741, 12749, 1481, 12936, 12952, 12953, 1503
5754, 12741, 12742, 12750, 12749, 12938, 12954, 12955, 12952
5755, 12742, 12743, 12751, 12750, 12940, 12956, 12957, 12954
5756, 12743, 12744, 12752, 12751, 12942, 12958, 12959, 12956
5757, 12744, 12745, 12753, 12752, 12944, 12960, 12961, 12958
5758, 12745, 12746, 12754, 12753, 12946, 12962, 12963, 12960
5759, 12746, 12747, 12755, 12754, 12948, 12964, 12965, 12962
5760, 12747, 12748, 12756, 12755, 12950, 12966, 12967, 12964
5761, 12748, 1614, 1615, 12756, 12951, 1637, 12968, 12966
5762, 1481, 12749, 12757, 1482, 12953, 12969, 12970, 1504
5763, 12749, 12750, 12758, 12757, 12955, 12971, 12972, 12969
5764, 12750, 12751, 12759, 12758, 12957, 12973, 12974, 12971
5765, 12751, 12752, 12760, 12759, 12959, 12975, 12976, 12973
5766, 12752, 12753, 12761, 12760, 12961, 12977, 12978, 12975
5767, 12753, 12754, 12762, 12761, 12963, 12979, 12980, 12977
5768, 12754, 12755, 12763, 12762, 12965, 12981, 12982, 12979
5769, 12755, 12756, 12764, 12763, 12967, 12983, 12984, 12981
5770, 12756, 1615, 1616, 12764, 12968, 1638, 12985, 12983
5771, 1482, 12757, 12765, 1483, 12970, 12986, 12987, 1505
5772, 12757, 12758, 12766, 12765, 12972, 12988, 12989, 12986
5773, 12758, 12759, 12767, 12766, 12974, 12990, 12991, 12988
5774, 12759, 12760, 12768, 12767, 12976, 12992, 12993, 12990
5775, 12760, 12761, 12769, 12768, 12978, 12994, 12995, 12992
5776, 12761, 12762, 12770, 12769, 12980, 12996, 12997, 12994
5777, 12762, 12763, 12771, 12770, 12982, 12998, 12999, 12996
5778, 12763, 12764, 12772, 12771, 12984, 13000, 13001, 12998
5779, 12764, 1616, 1617, 12772, 12985, 1639, 13002, 13000
5780, 1483, 12765, 12773, 1484, 12987, 13003, 13004, 1506
5781, 12765, 12766, 12774, 12773, 12989, 13005, 13006, 13003
5782, 12766, 12767, 12775, 12774, 12991, 13007, 13008, 13005
5783, 12767, 12768, 12776, 12775, 12993, 13009, 13010, 13007
5784, 12768, 12769, 12777, 12776, 12995, 13011, 13012, 13009
5785, 12769, 12770, 12778, 12777, 12997, 13013, 13014, 13011
5786, 12770, 12771, 12779, 12778, 12999, 13015, 13016, 13013
5787, 12771, 12772, 12780, 12779, 13001, 13017, 13018, 13015
5788, 12772, 1617, 1618, 12780, 13002, 1640, 13019, 13017
5789, 1484, 12773, 12781, 1485, 13004, 13020, 13021, 1507
5790, 12773, 12774, 12782, 12781, 13006, 13022, 13023, 13020
5791, 12774, 12775, 12783, 12782, 13008, 13024, 13025, 13022
5792, 12775, 12776, 12784, 12783, 13010, 13026, 13027, 13024
5793, 12776, 12777, 12785, 12784, 13012, 13028, 13029, 13026
5794, 12777, 12778, 12786, 12785, 13014, 13030, 13031, 13028
5795, 12778, 12779, 12787, 12786, 13016, 13032, 13033, 13030
5796, 12779, 12780, 12788, 12787, 13018, 13034, 13035, 13032
5797, 12780, 1618, 1619, 12788, 13019, 1641, 13036, 13034
5798, 1485, 12781, 12789, 1486, 13021, 13037, 13038, 1508
5799, 12781, 12782, 12790, 12789, 13023, 13039, 13040, 13037
5800, 12782, 12783, 12791, 12790, 13025, 13041, 13042, 13039
5801, 12783, 12784, 12792, 12791, 13027, 13043, 13044, 13041
5802, 12784, 12785, 12793, 12792, 13029, 13045, 13046, 13043
5803, 12785, 12786, 12794, 12793, 13031, 13047, 13048, 13045
5804, 12786, 12787, 12795, 12794, 13033, 13049, 13050, 13047
5805, 12787, 12788, 12796, 12795, 13035, 13051, 13052, 13049
5806, 12788, 1619, 1620, 12796, 13036, 1642, 13053, 13051
5807, 1486, 12789, 12797, 1487, 13038, 13054, 13055, 1509
5808, 12789, 12790, 12798, 12797, 13040, 13056, 13057, 13054
5809, 12790, 12791, 12799, 12798, 13042, 13058, 13059, 13056
5810, 12791, 12792, 12800, 12799, 13044, 13060, 13061, 13058
5811, 12792, 12793, 12801, 12800, 13046, 13062, 13063, 13060
5812, 12793, 12794, 12802, 12801, 13048, 13064, 13065, 13062
5813, 12794, 12795, 12803, 12802, 13050, 13066, 13067, 13064
5814, 12795, 12796, 12804, 12803, 13052, 13068, 13069, 13066
5815, 12796, 1620, 1621, 12804, 13053, 1643, 13070, 13068
5816, 1487, 12797, 12805, 1488, 13055, 13071, 13072, 1510
5817, 12797, 12798, 12806, 12805, 13057, 13073, 13074, 13071
5818, 12798, 12799, 12807, 12806, 13059, 13075, 13076, 13073
5819, 12799, 12800, 12808, 12807, 13061, 13077, 13078, 13075
5820, 12800, 12801, 12809, 12808, 13063, 13079, 13080, 13077
5821, 12801, 12802, 12810, 12809, 13065, 13081, 13082, 13079
5822, 12802, 12803, 12811, 12810, 13067, 13083, 13084, 13081
5823, 12803, 12804, 12812, 12811, 13069, 13085, 13086, 13083
5824, 12804, 1621, 1622, 12812, 13070, 1644, 13087, 13085
5825, 1488, 12805, 12813, 1489, 13072, 13088, 13089, 1511
5826, 12805, 12806, 12814, 12813, 13074, 13090, 13091, 13088
5827, 12806, 12807, 12815, 12814, 13076, 13092, 13093, 13090
5828, 12807, 12808, 12816, 12815, 13078, 13094, 13095, 13092
5829, 12808, 12809, 12817, 12816, 13080, 13096, 13097, 13094
5830, 12809, 12810, 12818, 12817, 13082, 13098, 13099, 13096
5831, 12810, 12811, 12819, 12818, 13084, 13100, 13101, 13098
5832, 12811, 12812, 12820, 12819, 13086, 13102, 13103, 13100
5833, 12812, 1622, 1623, 12820, 13087, 1645, 13104, 13102
5834, 1489, 12813, 12821, 1490, 13089, 13105, 13106, 1512
5835, 12813, 12814, 12822, 12821, 13091, 13107, 13108, 13105
5836, 12814, 12815, 12823, 12822, 13093, 13109, 13110, 13107
5837, 12815, 12816, 12824, 12823, 13095, 13111, 13112, 13109
5838, 12816, 12817, 12825, 12824, 13097, 13113, 13114, 13111
5839, 12817, 12818, 12826, 12825, 13099, 13115, 13116, 13113
5840, 12818, 12819, 12827, 12826, 13101, 13117, 13118, 13115
5841, 12819, 12820, 12828, 12827, 13103, 13119, 13120, 13117
5842, 12820, 1623, 1624, 12828, 13104, 1646, 13121, 13119
5843, 1490, 12821, 12829, 1491, 13106, 13122, 13123, 1513
5844, 12821, 12822, 12830, 12829, 13108, 13124, 13125, 13122
5845, 12822, 12823, 12831, 12830, 13110, 13126, 13127, 13124
5846, 12823, 12824, 12832, 12831, 13112, 13128, 13129, 13126
5847, 12824, 12825, 12833, 12832, 13114, 13130, 13131, 13128
5848, 12825, 12826, 12834, 12833, 13116, 13132, 13133, 13130
5849, 12826, 12827, 12835, 12834, 13118, 13134, 13135, 13132
5850, 12827, 12828, 12836, 12835, 13120, 13136, 13137, 13134
5851, 12828, 1624, 1625, 12836, 13121, 1647, 13138, 13136
5852, 1491, 12829, 12837, 1492, 13123, 13139, 13140, 1514
5853, 12829, 12830, 12838, 12837, 13125, 13141, 13142, 13139
5854, 12830, 12831, 12839, 12838, 13127, 13143, 13144, 13141
5855, 12831, 12832, 12840, 12839, 13129, 13145, 13146, 13143
5856, 12832, 12833, 12841, 12840, 13131, 13147, 13148, 13145
5857, 12833, 12834, 12842, 12841, 13133, 13149, 13150, 13147
5858, 12834, 12835, 12843, 12842, 13135, 13151, 13152, 13149
5859, 12835, 12836, 12844, 12843, 13137, 13153, 13154, 13151
5860, 12836, 1625, 1626, 12844, 13138, 1648, 13155, 13153
5861, 1492, 12837, 12845, 1493, 13140, 13156, 13157, 1515
5862, 12837, 12838, 12846, 12845, 13142, 13158, 13159, 13156
5863, 12838, 12839, 12847, 12846, 13144, 13160, 13161, 13158
5864, 12839, 12840, 12848, 12847, 13146, 13162, 13163, 13160
5865, 12840, 12841, 12849, 12848, 13148, 13164, 13165, 13162
5866, 12841, 12842, 12850, 12849, 13150, 13166, 13167, 13164
5867, 12842, 12843, 12851, 12850, 13152, 13168, 13169, 13166
5868, 12843, 12844, 12852, 12851, 13154, 13170, 13171, 13168
5869, 12844, 1626, 1627, 12852, 13155, 1649, 13172, 13170
5870, 1493, 12845, 12853, 1494, 13157, 13173, 13174, 1516
5871, 12845, 12846, 12854, 12853, 13159, 13175, 13176, 13173
5872, 12846, 12847, 12855, 12854, 13161, 13177, 13178, 13175
5873, 12847, 12848, 12856, 12855, 13163, 13179, 13180, 13177
5874, 12848, 12849, 12857, 12856, 13165, 13181, 13182, 13179
5875, 12849, 12850, 12858, 12857, 13167, 13183, 13184, 13181
5876, 12850, 12851, 12859, 12858, 13169, 13185, 13186, 13183
5877, 12851, 12852, 12860, 12859, 13171, 13187, 13188, 13185
5878, 12852, 1627, 1628, 12860, 13172, 1650, 13189, 13187
5879, 1494, 12853, 12861, 1495, 13174, 13190, 13191, 1517
5880, 12853, 12854, 12862, 12861, 13176, 13192, 13193, 13190
5881, 12854, 12855, 12863, 12862, 13178, 13194, 13195, 13192
5882, 12855, 12856, 12864, 12863, 13180, 13196, 13197, 13194
5883, 12856, 12857, 12865, 12864, 13182, 13198, 13199, 13196
5884, 12857, 12858, 12866, 12865, 13184, 13200, 13201, 13198
5885, 12858, 12859, 12867, 12866, 13186, 13202, 13203, 13200
5886, 12859, 12860, 12868, 12867, 13188, 13204, 13205, 13202
5887, 12860, 1628, 1629, 12868, 13189, 1651, 13206, 13204
5888, 1495, 12861, 12869, 1496, 13191, 13207, 13208, 1518
5889, 12861, 12862, 12870, 12869, 13193, 13209, 13210, 13207
5890, 12862, 12863, 12871, 12870, 13195, 13211, 13212, 13209
5891, 12863, 12864, 12872, 12871, 13197, 13213, 13214, 13211
5892, 12864, 12865, 12873, 12872, 13199, 13215, 13216, 13213
5893, 12865, 12866, 12874, 12873, 13201, 13217, 13218, 13215
5894, 12866, 12867, 12875, 12874, 13203, 13219, 13220, 13217
5895, 12867, 12868, 12876, 12875, 13205, 13221, 13222, 13219
5896, 12868, 1629, 1630, 12876, 13206, 1652, 13223, 13221
5897, 1496, 12869, 12877, 1497, 13208, 13224, 13225, 1519
5898, 12869, 12870, 12878, 12877, 13210, 13226, 13227, 13224
5899, 12870, 12871, 12879, 12878, 13212, 13228, 13229, 13226
5900, 12871, 12872, 12880, 12879, 13214, 13230, 13231, 13228
5901, 12872, 12873, 12881, 12880, 13216, 13232, 13233, 13230
5902, 12873, 12874, 12882, 12881, 13218, 13234, 13235, 13232
5903, 12874, 12875, 12883, 12882, 13220, 13236, 13237, 13234
5904, 12875, 12876, 12884, 12883, 13222, 13238, 13239, 13236
5905, 12876, 1630, 1631, 12884, 13223, 1653, 13240, 13238
5906, 1497, 12877, 12885, 1498, 13225, 13241, 13242, 1520
5907, 12877, 12878, 12886, 12885, 13227, 13243, 13244, 13241
5908, 12878, 12879, 12887, 12886, 13229, 13245, 13246, 13243
5909, 12879, 12880, 12888, 12887, 13231, 13247, 13248, 13245
5910, 12880, 12881, 12889, 12888, 13233, 13249, 13250, 13247
5911, 12881, 12882, 12890, 12889, 13235, 13251, 13252, 13249
5912, 12882, 12883, 12891, 12890, 13237, 13253, 13254, 13251
5913, 12883, 12884, 12892, 12891, 13239, 13255, 13256, 13253
5914, 12884, 1631, 1632, 12892, 13240, 1654, 13257, 13255
5915, 1498, 12885, 12893, 1499, 13242, 13258, 13259, 1521
5916, 12885, 12886, 12894, 12893, 13244, 13260, 13261, 13258
5917, 12886, 12887, 12895, 12894, 13246, 13262, 13263, 13260
5918, 12887, 12888, 12896, 12895, 13248, 13264, 13265, 13262
5919, 12888, 12889, 12897, 12896, 13250, 13266, 13267, 13264
5920, 12889, 12890, 12898, 12897, 13252, 13268, 13269, 13266
5921, 12890, 12891, 12899, 12898, 13254, 13270, 13271, 13268
5922, 12891, 12892, 12900, 12899, 13256, 13272, 13273, 13270
5923, 12892, 1632, 1633, 12900, 13257, 1655, 13274, 13272
5924, 1499, 12893, 1545, 46, 13259, 13275, 1553, 1522
5925, 12893, 12894, 1546, 1545, 13261, 13276, 1554, 13275
5926, 12894, 12895, 1547, 1546, 13263, 13277, 1555, 13276
5927, 12895, 12896, 1548, 1547, 13265, 13278, 1556, 13277
5928, 12896, 12897, 1549, 1548, 13267, 13279, 1557, 13278
5929, 12897, 12898, 1550, 1549, 13269, 13280, 1558, 13279
5930, 12898, 12899, 1551, 1550, 13271, 13281, 1559, 13280
5931, 12899, 12900, 1552, 1551, 13273, 13282, 1560, 13281
5932, 12900, 1633, 50, 1552, 13274, 1656, 1561, 13282
*ELEMENT, type=CPS8, ELSET=Surface212
5933, 49, 1691, 13283, 1523, 1694, 13289, 13290, 1525
5934, 1523, 13283, 13284, 1524, 13290, 13291, 13292, 1526
5935, 1524, 13284, 1698, 50, 13292, 13293, 1701, 1527
5936, 1691, 1692, 13285, 13283, 1695, 13294, 13295, 13289
5937, 13283, 13285, 13286, 13284, 13295, 13296, 13297, 13291
5938, 13284, 13286, 1699, 1698, 13297, 13298, 1702, 13293
5939, 1692, 1693, 13287, 13285, 1696, 13299, 13300, 13294
5940, 13285, 13287, 13288, 13286, 13300, 13301, 13302, 13296
5941, 13286, 13288, 1700, 1699, 13302, 13303, 1703, 13298
5942, 1693, 53, 1705, 13287, 1697, 1707, 13304, 13299
5943, 13287, 1705, 1706, 13288, 13304, 1708, 13305, 13301
5944, 13288, 1706, 54, 1700, 13305, 1709, 1704, 13303
*ELEMENT, type=CPS8, ELSET=Surface213
5945, 45, 1423, 13306, 1710, 1425, 13312, 13313, 1713
5946, 1423, 1424, 13307, 13306, 1426, 13314, 13315, 13312
5947, 1424, 46, 1717, 13307, 1427, 1720, 13316, 13314
5948, 1710, 13306, 13308, 1711, 13313, 13317, 13318, 1714
5949, 13306, 13307, 13309, 13308, 13315, 13319, 13320, 13317
5950, 13307, 1717, 1718, 13309, 13316, 1721, 13321, 13319
5951, 1711, 13308, 13310, 1712, 13318, 13322, 13323, 1715
5952, 13308, 13309, 13311, 13310, 13320, 13324, 13325, 13322
5953, 13309, 1718, 1719, 13311, 13321, 1722, 13326, 13324
5954, 1712, 13310, 1724, 55, 13323, 13327, 1726, 1716
5955, 13310, 13311, 1725, 1724, 13325, 13328, 1727, 13327
5956, 13311, 1719, 56, 1725, 13326, 1723, 1728, 13328
*ELEMENT, type=CPS8, ELSET=Surface214
5957, 49, 1535, 13329, 1691, 1544, 13353, 13354, 1694
5958, 1535, 1534, 13330, 13329, 1543, 13355, 13356, 13353
5959, 1534, 1533, 13331, 13330, 1542, 13357, 13358, 13355
5960, 1533, 1532, 13332, 13331, 1541, 13359, 13360, 13357
5961, 1532, 1531, 13333, 13332, 1540, 13361, 13362, 13359
5962, 1531, 1530, 13334, 13333, 1539, 13363, 13364, 13361
5963, 1530, 1529, 13335, 13334, 1538, 13365, 13366, 13363
5964, 1529, 1528, 13336, 13335, 1537, 13367, 13368, 13365
5965, 1528, 45, 1710, 13336, 1536, 1713, 13369, 13367
5966, 1691, 13329, 13337, 1692, 13354, 13370, 13371, 1695
5967, 13329, 13330, 13338, 13337, 13356, 13372, 13373, 13370
5968, 13330, 13331, 13339, 13338, 13358, 13374, 13375, 13372
5969, 13331, 13332, 13340, 13339, 13360, 13376, 13377, 13374
5970, 13332, 13333, 13341, 13340, 13362, 13378, 13379, 13376
5971, 13333, 13334, 13342, 13341, 13364, 13380, 13381, 13378
5972, 13334, 13335, 13343, 13342, 13366, 13382, 13383, 13380
5973, 13335, 13336, 13344, 13343, 13368, 13384, 13385, 13382
5974, 13336, 1710, 1711, 13344, 13369, 1714, 13386, 13384
5975, 1692, 13337, 13345, 1693, 13371, 13387, 13388, 1696
5976, 13337, 13338, 13346, 13345, 13373, 13389, 13390, 13387
5977, 13338, 13339, 13347, 13346, 13375, 13391, 13392, 13389
5978, 13339, 13340, 13348, 13347, 13377, 13393, 13394, 13391
5979, 13340, 13341, 13349, 13348, 13379, 13395, 13396, 13393
5980, 13341, 13342, 13350, 13349, 13381, 13397, 13398, 13395
5981, 13342, 13343, 13351, 13350, 13383, 13399, 13400, 13397
5982, 13343, 13344, 13352, 13351, 13385, 13401, 13402, 13399
5983, 13344, 1711, 1712, 13352, 13386, 1715, 13403, 13401
5984, 1693, 13345, 1736, 53, 13388, 13404, 1745, 1697
5985, 13345, 13346, 1735, 1736, 13390, 13405, 1744, 13404
5986, 13346, 13347, 1734, 1735, 13392, 13406, 1743, 13405
5987, 13347, 13348, 1733, 1734, 13394, 13407, 1742, 13406
5988, 13348, 13349, 1732, 1733, 13396, 13408, 1741, 13407
5989, 13349, 13350, 1731, 1732, 13398, 13409, 1740, 13408
5990, 13350, 13351, 1730, 1731, 13400, 13410, 1739, 13409
5991, 13351, 13352, 1729, 1730, 13402, 13411, 1738, 13410
5992, 13352, 1712, 55, 1729, 13403, 1716, 1737, 13411
*ELEMENT, type=CPS8, ELSET=Surface215
5993, 50, 1698, 13412, 1552, 1701, 13436, 13437, 1561
5994, 1552, 13412, 13413, 1551, 13437, 13438, 13439, 1560
5995, 1551, 13413, 13414, 1550, 13439, 13440, 13441, 1559
5996, 1550, 13414, 13415, 1549, 13441, 13442, 13443, 1558
5997, 1549, 13415, 13416, 1548, 13443, 13444, 13445, 1557
5998, 1548, 13416, 13417, 1547, 13445, 13446, 13447, 1556
5999, 1547, 13417, 13418, 1546, 13447, 13448, 13449, 1555
6000, 1546, 13418, 13419, 1545, 13449, 13450, 13451, 1554
6001, 1545, 13419, 1717, 46, 13451, 13452, 1720, 1553
6002, 1698, 1699, 13420, 13412, 1702, 13453, 13454, 13436
6003, 13412, 13420, 13421, 13413, 13454, 13455, 13456, 13438
6004, 13413, 13421, 13422, 13414, 13456, 13457, 13458, 13440
6005, 13414, 13422, 13423, 13415, 13458, 13459, 13460, 13442
6006, 13415, 13423, 13424, 13416, 13460, 13461, 13462, 13444
6007, 13416, 13424, 13425, 13417, 13462, 13463, 13464, 13446
6008, 13417, 13425, 13426, 13418, 13464, 13465, 13466, 13448
6009, 13418, 13426, 13427, 13419, 13466, 13467, 13468, 13450
6010, 13419, 13427, 1718, 1717, 13468, 13469, 1721, 13452
6011, 1699, 1700, 13428, 13420, 1703, 13470, 13471, 13453
6012, 13420, 13428, 13429, 13421, 13471, 13472, 13473, 13455
6013, 13421, 13429, 13430, 13422, 13473, 13474, 13475, 13457
6014, 13422, 13430, 13431, 13423, 13475, 13476, 13477, 13459
6015, 13423, 13431, 13432, 13424, 13477, 13478, 13479, 13461
6016, 13424, 13432, 13433, 13425, 13479, 13480, 13481, 13463
6017, 13425, 13433, 13434, 13426, 13481, 13482, 13483, 13465
6018, 13426, 13434, 13435, 13427, 13483, 13484, 13485, 13467
6019, 13427, 13435, 1719, 1718, 13485, 13486, 1722, 13469
6020, 1700, 54, 1753, 13428, 1704, 1762, 13487, 13470
6021, 13428, 1753, 1752, 13429, 13487, 1761, 13488, 13472
6022, 13429, 1752, 1751, 13430, 13488, 1760, 13489, 13474
6023, 13430, 1751, 1750, 13431, 13489, 1759, 13490, 13476
6024, 13431, 1750, 1749, 13432, 13490, 1758, 13491, 13478
6025, 13432, 1749, 1748, 13433, 13491, 1757, 13492, 13480
6026, 13433, 1748, 1747, 13434, 13492, 1756, 13493, 13482
6027, 13434, 1747, 1746, 13435, 13493, 1755, 13494, 13484
6028, 13435, 1746, 56, 1719, 13494, 1754, 1723, 13486
*ELEMENT, type=CPS8, ELSET=Surface216
6029, 53, 1736, 13495, 1705, 1745, 13511, 13512, 1707
6030, 1736, 1735, 13496, 13495, 1744, 13513, 13514, 13511
6031, 1735, 1734, 13497, 13496, 1743, 13515, 13516, 13513
6032, 1734, 1733, 13498, 13497, 1742, 13517, 13518, 13515
6033, 1733, 1732, 13499, 13498, 1741, 13519, 13520, 13517
6034, 1732, 1731, 13500, 13499, 1740, 13521, 13522, 13519
6035, 1731, 1730, 13501, 13500, 1739, 13523, 13524, 13521
6036, 1730, 1729, 13502, 13501, 1738, 13525, 13526, 13523
6037, 1729, 55, 1724, 13502, 1737, 1726, 13527, 13525
6038, 1705, 13495, 13503, 1706, 13512, 13528, 13529, 1708
6039, 13495, 13496, 13504, 13503, 13514, 13530, 13531, 13528
6040, 13496, 13497, 13505, 13504, 13516, 13532, 13533, 13530
6041, 13497, 13498, 13506, 13505, 13518, 13534, 13535, 13532
6042, 13498, 13499, 13507, 13506, 13520, 13536, 13537, 13534
6043, 13499, 13500, 13508, 13507, 13522, 13538, 13539, 13536
6044, 13500, 13501, 13509, 13508, 13524, 13540, 13541, 13538
6045, 13501, 13502, 13510, 13509, 13526, 13542, 13543, 13540
6046, 13502, 1724, 1725, 13510, 13527, 1727, 13544, 13542
6047, 1706, 13503, 1753, 54, 13529, 13545, 1762, 1709
6048, 13503, 13504, 1752, 1753, 13531, 13546, 1761, 13545
6049, 13504, 13505, 1751, 1752, 13533, 13547, 1760, 13546
6050, 13505, 13506, 1750, 1751, 13535, 13548, 1759, 13547
6051, 13506, 13507, 1749, 1750, 13537, 13549, 1758, 13548
6052, 13507, 13508, 1748, 1749, 13539, 13550, 1757, 13549
6053, 13508, 13509, 1747, 1748, 13541, 13551, 1756, 13550
6054, 13509, 13510, 1746, 1747, 13543, 13552, 1755, 13551
6055, 13510, 1725, 56, 1746, 13544, 1728, 1754, 13552
*ELEMENT, type=CPS8, ELSET=Surface217
6056, 50, 1698, 13553, 1763, 1701, 13562, 13563, 1766
6057, 1698, 1699, 13554, 13553, 1702, 13564, 13565, 13562
6058, 1699, 1700, 13555, 13554, 1703, 13566, 13567, 13564
6059, 1700, 54, 1770, 13555, 1704, 1773, 13568, 13566
6060, 1763, 13553, 13556, 1764, 13563, 13569, 13570, 1767
6061, 13553, 13554, 13557, 13556, 13565, 13571, 13572, 13569
6062, 13554, 13555, 13558, 13557, 13567, 13573, 13574, 13571
6063, 13555, 1770, 1771, 13558, 13568, 1774, 13575, 13573
6064, 1764, 13556, 13559, 1765, 13570, 13576, 13577, 1768
6065, 13556, 13557, 13560, 13559, 13572, 13578, 13579, 13576
6066, 13557, 13558, 13561, 13560, 13574, 13580, 13581, 13578
6067, 13558, 1771, 1772, 13561, 13575, 1775, 13582, 13580
6068, 1765, 13559, 1777, 57, 13577, 13583, 1780, 1769
6069, 13559, 13560, 1778, 1777, 13579, 13584, 1781, 13583
6070, 13560, 13561, 1779, 1778, 13581, 13585, 1782, 13584
6071, 13561, 1772, 58, 1779, 13582, 1776, 1783, 13585
*ELEMENT, type=CPS8, ELSET=Surface218
6072, 46, 1784, 13586, 1717, 1787, 13595, 13596, 1720
6073, 1717, 13586, 13587, 1718, 13596, 13597, 13598, 1721
6074, 1718, 13587, 13588, 1719, 13598, 13599, 13600, 1722
6075, 1719, 13588, 1791, 56, 13600, 13601, 1794, 1723
6076, 1784, 1785, 13589, 13586, 1788, 13602, 13603, 13595
6077, 13586, 13589, 13590, 13587, 13603, 13604, 13605, 13597
6078, 13587, 13590, 13591, 13588, 13605, 13606, 13607, 13599
6079, 13588, 13591, 1792, 1791, 13607, 13608, 1795, 13601
6080, 1785, 1786, 13592, 13589, 1789, 13609, 13610, 13602
6081, 13589, 13592, 13593, 13590, 13610, 13611, 13612, 13604
6082, 13590, 13593, 13594, 13591, 13612, 13613, 13614, 13606
6083, 13591, 13594, 1793, 1792, 13614, 13615, 1796, 13608
6084, 1786, 59, 1798, 13592, 1790, 1801, 13616, 13609
6085, 13592, 1798, 1799, 13593, 13616, 1802, 13617, 13611
6086, 13593, 1799, 1800, 13594, 13617, 1803, 13618, 13613
6087, 13594, 1800, 60, 1793, 13618, 1804, 1797, 13615
*ELEMENT, type=CPS8, ELSET=Surface219
6088, 50, 1763, 13619, 1552, 1766, 13643, 13644, 1561
6089, 1552, 13619, 13620, 1551, 13644, 13645, 13646, 1560
6090, 1551, 13620, 13621, 1550, 13646, 13647, 13648, 1559
6091, 1550, 13621, 13622, 1549, 13648, 13649, 13650, 1558
6092, 1549, 13622, 13623, 1548, 13650, 13651, 13652, 1557
6093, 1548, 13623, 13624, 1547, 13652, 13653, 13654, 1556
6094, 1547, 13624, 13625, 1546, 13654, 13655, 13656, 1555
6095, 1546, 13625, 13626, 1545, 13656, 13657, 13658, 1554
6096, 1545, 13626, 1784, 46, 13658, 13659, 1787, 1553
6097, 1763, 1764, 13627, 13619, 1767, 13660, 13661, 13643
6098, 13619, 13627, 13628, 13620, 13661, 13662, 13663, 13645
6099, 13620, 13628, 13629, 13621, 13663, 13664, 13665, 13647
6100, 13621, 13629, 13630, 13622, 13665, 13666, 13667, 13649
6101, 13622, 13630, 13631, 13623, 13667, 13668, 13669, 13651
6102, 13623, 13631, 13632, 13624, 13669, 13670, 13671, 13653
6103, 13624, 13632, 13633, 13625, 13671, 13672, 13673, 13655
6104, 13625, 13633, 13634, 13626, 13673, 13674, 13675, 13657
6105, 13626, 13634, 1785, 1784, 13675, 13676, 1788, 13659
6106, 1764, 1765, 13635, 13627, 1768, 13677, 13678, 13660
6107, 13627, 13635, 13636, 13628, 13678, 13679, 13680, 13662
6108, 13628, 13636, 13637, 13629, 13680, 13681, 13682, 13664
6109, 13629, 13637, 13638, 13630, 13682, 13683, 13684, 13666
6110, 13630, 13638, 13639, 13631, 13684, 13685, 13686, 13668
6111, 13631, 13639, 13640, 13632, 13686, 13687, 13688, 13670
6112, 13632, 13640, 13641, 13633, 13688, 13689, 13690, 13672
6113, 13633, 13641, 13642, 13634, 13690, 13691, 13692, 13674
6114, 13634, 13642, 1786, 1785, 13692, 13693, 1789, 13676
6115, 1765, 57, 1812, 13635, 1769, 1821, 13694, 13677
6116, 13635, 1812, 1811, 13636, 13694, 1820, 13695, 13679
6117, 13636, 1811, 1810, 13637, 13695, 1819, 13696, 13681
6118, 13637, 1810, 1809, 13638, 13696, 1818, 13697, 13683
6119, 13638, 1809, 1808, 13639, 13697, 1817, 13698, 13685
6120, 13639, 1808, 1807, 13640, 13698, 1816, 13699, 13687
6121, 13640, 1807, 1806, 13641, 13699, 1815, 13700, 13689
6122, 13641, 1806, 1805, 13642, 13700, 1814, 13701, 13691
6123, 13642, 1805, 59, 1786, 13701, 1813, 1790, 13693
*ELEMENT, type=CPS8, ELSET=Surface220
6124, 54, 1753, 13702, 1770, 1762, 13726, 13727, 1773
6125, 1753, 1752, 13703, 13702, 1761, 13728, 13729, 13726
6126, 1752, 1751, 13704, 13703, 1760, 13730, 13731, 13728
6127, 1751, 1750, 13705, 13704, 1759, 13732, 13733, 13730
6128, 1750, 1749, 13706, 13705, 1758, 13734, 13735, 13732
6129, 1749, 1748, 13707, 13706, 1757, 13736, 13737, 13734
6130, 1748, 1747, 13708, 13707, 1756, 13738, 13739, 13736
6131, 1747, 1746, 13709, 13708, 1755, 13740, 13741, 13738
6132, 1746, 56, 1791, 13709, 1754, 1794, 13742, 13740
6133, 1770, 13702, 13710, 1771, 13727, 13743, 13744, 1774
6134, 13702, 13703, 13711, 13710, 13729, 13745, 13746, 13743
6135, 13703, 13704, 13712, 13711, 13731, 13747, 13748, 13745
6136, 13704, 13705, 13713, 13712, 13733, 13749, 13750, 13747
6137, 13705, 13706, 13714, 13713, 13735, 13751, 13752, 13749
6138, 13706, 13707, 13715, 13714, 13737, 13753, 13754, 13751
6139, 13707, 13708, 13716, 13715, 13739, 13755, 13756, 13753
6140, 13708, 13709, 13717, 13716, 13741, 13757, 13758, 13755
6141, 13709, 1791, 1792, 13717, 13742, 1795, 13759, 13757
6142, 1771, 13710, 13718, 1772, 13744, 13760, 13761, 1775
6143, 13710, 13711, 13719, 13718, 13746, 13762, 13763, 13760
6144, 13711, 13712, 13720, 13719, 13748, 13764, 13765, 13762
6145, 13712, 13713, 13721, 13720, 13750, 13766, 13767, 13764
6146, 13713, 13714, 13722, 13721, 13752, 13768, 13769, 13766
6147, 13714, 13715, 13723, 13722, 13754, 13770, 13771, 13768
6148, 13715, 13716, 13724, 13723, 13756, 13772, 13773, 13770
6149, 13716, 13717, 13725, 13724, 13758, 13774, 13775, 13772
6150, 13717, 1792, 1793, 13725, 13759, 1796, 13776, 13774
6151, 1772, 13718, 1829, 58, 13761, 13777, 1838, 1776
6152, 13718, 13719, 1828, 1829, 13763, 13778, 1837, 13777
6153, 13719, 13720, 1827, 1828, 13765, 13779, 1836, 13778
6154, 13720, 13721, 1826, 1827, 13767, 13780, 1835, 13779
6155, 13721, 13722, 1825, 1826, 13769, 13781, 1834, 13780
6156, 13722, 13723, 1824, 1825, 13771, 13782, 1833, 13781
6157, 13723, 13724, 1823, 1824, 13773, 13783, 1832, 13782
6158, 13724, 13725, 1822, 1823, 13775, 13784, 1831, 13783
6159, 13725, 1793, 60, 1822, 13776, 1797, 1830, 13784
*ELEMENT, type=CPS8, ELSET=Surface221
6160, 57, 1777, 13785, 1812, 1780, 13809, 13810, 1821
6161, 1812, 13785, 13786, 1811, 13810, 13811, 13812, 1820
6162, 1811, 13786, 13787, 1810, 13812, 13813, 13814, 1819
6163, 1810, 13787, 13788, 1809, 13814, 13815, 13816, 1818
6164, 1809, 13788, 13789, 1808, 13816, 13817, 13818, 1817
6165, 1808, 13789, 13790, 1807, 13818, 13819, 13820, 1816
6166, 1807, 13790, 13791, 1806, 13820, 13821, 13822, 1815
6167, 1806, 13791, 13792, 1805, 13822, 13823, 13824, 1814
6168, 1805, 13792, 1798, 59, 13824, 13825, 1801, 1813
6169, 1777, 1778, 13793, 13785, 1781, 13826, 13827, 13809
6170, 13785, 13793, 13794, 13786, 13827, 13828, 13829, 13811
6171, 13786, 13794, 13795, 13787, 13829, 13830, 13831, 13813
6172, 13787, 13795, 13796, 13788, 13831, 13832, 13833, 13815
6173, 13788, 13796, 13797, 13789, 13833, 13834, 13835, 13817
6174, 13789, 13797, 13798, 13790, 13835, 13836, 13837, 13819
6175, 13790, 13798, 13799, 13791, 13837, 13838, 13839, 13821
6176, 13791, 13799, 13800, 13792, 13839, 13840, 13841, 13823
6177, 13792, 13800, 1799, 1798, 13841, 13842, 1802, 13825
6178, 1778, 1779, 13801, 13793, 1782, 13843, 13844, 13826
6179, 13793, 13801, 13802, 13794, 13844, 13845, 13846, 13828
6180, 13794, 13802, 13803, 13795, 13846, 13847, 13848, 13830
6181, 13795, 13803, 13804, 13796, 13848, 13849, 13850, 13832
6182, 13796, 13804, 13805, 13797, 13850, 13851, 13852, 13834
6183, 13797, 13805, 13806, 13798, 13852, 13853, 13854, 13836
6184, 13798, 13806, 13807, 13799, 13854, 13855, 13856, 13838
6185, 13799, 13807, 13808, 13800, 13856, 13857, 13858, 13840
6186, 13800, 13808, 1800, 1799, 13858, 13859, 1803, 13842
6187, 1779, 58, 1829, 13801, 1783, 1838, 13860, 13843
6188, 13801, 1829, 1828, 13802, 13860, 1837, 13861, 13845
6189, 13802, 1828, 1827, 13803, 13861, 1836, 13862, 13847
6190, 13803, 1827, 1826, 13804, 13862, 1835, 13863, 13849
6191, 13804, 1826, 1825, 13805, 13863, 1834, 13864, 13851
6192, 13805, 1825, 1824, 13806, 13864, 1833, 13865, 13853
6193, 13806, 1824, 1823, 13807, 13865, 1832, 13866, 13855
6194, 13807, 1823, 1822, 13808, 13866, 1831, 13867, 13857
6195, 13808, 1822, 60, 1800, 13867, 1830, 1804, 13859
*ELEMENT, type=CPS8, ELSET=Surface222
6196, 46, 1499, 13868, 1784, 1522, 13934, 13935, 1787
6197, 1499, 1498, 13869, 13868, 1521, 13936, 13937, 13934
6198, 1498, 1497, 13870, 13869, 1520, 13938, 13939, 13936
6199, 1497, 1496, 13871, 13870, 1519, 13940, 13941, 13938
6200, 1496, 1495, 13872, 13871, 1518, 13942, 13943, 13940
6201, 1495, 1494, 13873, 13872, 1517, 13944, 13945, 13942
6202, 1494, 1493, 13874, 13873, 1516, 13946, 13947, 13944
6203, 1493, 1492, 13875, 13874, 1515, 13948, 13949, 13946
6204, 1492, 1491, 13876, 13875, 1514, 13950, 13951, 13948
6205, 1491, 1490, 13877, 13876, 1513, 13952, 13953, 13950
6206, 1490, 1489, 13878, 13877, 1512, 13954, 13955, 13952
6207, 1489, 1488, 13879, 13878, 1511, 13956, 13957, 13954
6208, 1488, 1487, 13880, 13879, 1510, 13958, 13959, 13956
6209, 1487, 1486, 13881, 13880, 1509, 13960, 13961, 13958
6210, 1486, 1485, 13882, 13881, 1508, 13962, 13963, 13960
6211, 1485, 1484, 13883, 13882, 1507, 13964, 13965, 13962
6212, 1484, 1483, 13884, 13883, 1506, 13966, 13967, 13964
6213, 1483, 1482, 13885, 13884, 1505, 13968, 13969, 13966
6214, 1482, 1481, 13886, 13885, 1504, 13970, 13971, 13968
6215, 1481, 1480, 13887, 13886, 1503, 13972, 13973, 13970
6216, 1480, 1479, 13888, 13887, 1502, 13974, 13975, 13972
6217, 1479, 1478, 13889, 13888, 1501, 13976, 13977, 13974
6218, 1478, 48, 1839, 13889, 1500, 1842, 13978, 13976
6219, 1784, 13868, 13890, 1785, 13935, 13979, 13980, 1788
6220, 13868, 13869, 13891, 13890, 13937, 13981, 13982, 13979
6221, 13869, 13870, 13892, 13891, 13939, 13983, 13984, 13981
6222, 13870, 13871, 13893, 13892, 13941, 13985, 13986, 13983
6223, 13871, 13872, 13894, 13893, 13943, 13987, 13988, 13985
6224, 13872, 13873, 13895, 13894, 13945, 13989, 13990, 13987
6225, 13873, 13874, 13896, 13895, 13947, 13991, 13992, 13989
6226, 13874, 13875, 13897, 13896, 13949, 13993, 13994, 13991
6227, 13875, 13876, 13898, 13897, 13951, 13995, 13996, 13993
6228, 13876, 13877, 13899, 13898, 13953, 13997, 13998, 13995
6229, 13877, 13878, 13900, 13899, 13955, 13999, 14000, 13997
6230, 13878, 13879, 13901, 13900, 13957, 14001, 14002, 13999
6231, 13879, 13880, 13902, 13901, 13959, 14003, 14004, 14001
6232, 13880, 13881, 13903, 13902, 13961, 14005, 14006, 14003
6233, 13881, 13882, 13904, 13903, 13963, 14007, 14008, 14005
6234, 13882, 13883, 13905, 13904, 13965, 14009, 14010, 14007
6235, 13883, 13884, 13906, 13905, 13967, 14011, 14012, 14009
6236, 13884, 13885, 13907, 13906, 13969, 14013, 14014, 14011
6237, 13885, 13886, 13908, 13907, 13971, 14015, 14016, 14013
6238, 13886, 13887, 13909, 13908, 13973, 14017, 14018, 14015
6239, 13887, 13888, 13910, 13909, 13975, 14019, 14020, 14017
6240, 13888, 13889, 13911, 13910, 13977, 14021, 14022, 14019
6241, 13889, 1839, 1840, 13911, 13978, 1843, 14023, 14021
6242, 1785, 13890, 13912, 1786, 13980, 14024, 14025, 1789
6243, 13890, 13891, 13913, 13912, 13982, 14026, 14027, 14024
6244, 13891, 13892, 13914, 13913, 13984, 14028, 14029, 14026
6245, 13892, 13893, 13915, 13914, 13986, 14030, 14031, 14028
6246, 13893, 13894, 13916, 13915, 13988, 14032, 14033, 14030
6247, 13894, 13895, 13917, 13916, 13990, 14034, 14035, 14032
6248, 13895, 13896, 13918, 13917, 13992, 14036, 14037, 14034
6249, 13896, 13897, 13919, 13918, 13994, 14038, 14039, 14036
6250, 13897, 13898, 13920, 13919, 13996, 14040, 14041, 14038
6251, 13898, 13899, 13921, 13920, 13998, 14042, 14043, 14040
6252, 13899, 13900, 13922, 13921, 14000, 14044, 14045, 14042
6253, 13900, 13901, 13923, 13922, 14002, 14046, 14047, 14044
6254, 13901, 13902, 13924, 13923, 14004, 14048, 14049, 14046
6255, 13902, 13903, 13925, 13924, 14006, 14050, 14051, 14048
6256, 13903, 13904, 13926, 13925, 14008, 14052, 14053, 14050
6257, 13904, 13905, 13927, 13926, 14010, 14054, 14055, 14052
6258, 13905, 13906, 13928, 13927, 14012, 14056, 14057, 14054
6259, 13906, 13907, 13929, 13928, 14014, 14058, 14059, 14056
6260, 13907, 13908, 13930, 13929, 14016, 14060, 14061, 14058
6261, 13908, 13909, 13931, 13930, 14018, 14062, 14063, 14060
6262, 13909, 13910, 13932, 13931, 14020, 14064, 14065, 14062
6263, 13910, 13911, 13933, 13932, 14022, 14066, 14067, 14064
6264, 13911, 1840, 1841, 13933, 14023, 1844, 14068, 14066
6265, 1786, 13912, 1867, 59, 14025, 14069, 1890, 1790
6266, 13912, 13913, 1866, 1867, 14027, 14070, 1889, 14069
6267, 13913, 13914, 1865, 1866, 14029, 14071, 1888, 14070
6268, 13914, 13915, 1864, 1865, 14031, 14072, 1887, 14071
6269, 13915, 13916, 1863, 1864, 14033, 14073, 1886, 14072
6270, 13916, 13917, 1862, 1863, 14035, 14074, 1885, 14073
6271, 13917, 13918, 1861, 1862, 14037, 14075, 1884, 14074
6272, 13918, 13919, 1860, 1861, 14039, 14076, 1883, 14075
6273, 13919, 13920, 1859, 1860, 14041, 14077, 1882, 14076
6274, 13920, 13921, 1858, 1859, 14043, 14078, 1881, 14077
6275, 13921, 13922, 1857, 1858, 14045, 14079, 1880, 14078
6276, 13922, 13923, 1856, 1857, 14047, 14080, 1879, 14079
6277, 13923, 13924, 1855, 1856, 14049, 14081, 1878, 14080
6278, 13924, 13925, 1854, 1855, 14051, 14082, 1877, 14081
6279, 13925, 13926, 1853, 1854, 14053, 14083, 1876, 14082
6280, 13926, 13927, 1852, 1853, 14055, 14084, 1875, 14083
6281, 13927, 13928, 1851, 1852, 14057, 14085, 1874, 14084
6282, 13928, 13929, 1850, 1851, 14059, 14086, 1873, 14085
6283, 13929, 13930, 1849, 1850, 14061, 14087, 1872, 14086
6284, 13930, 13931, 1848, 1849, 14063, 14088, 1871, 14087
6285, 13931, 13932, 1847, 1848, 14065, 14089, 1870, 14088
6286, 13932, 13933, 1846, 1847, 14067, 14090, 1869, 14089
6287, 13933, 1841, 61, 1846, 14068, 1845, 1868, 14090
*ELEMENT, type=CPS8, ELSET=Surface223
6288, 50, 1763, 14091, 1633, 1766, 14157, 14158, 1656
6289, 1633, 14091, 14092, 1632, 14158, 14159, 14160, 1655
6290, 1632, 14092, 14093, 1631, 14160, 14161, 14162, 1654
6291, 1631, 14093, 14094, 1630, 14162, 14163, 14164, 1653
6292, 1630, 14094, 14095, 1629, 14164, 14165, 14166, 1652
6293, 1629, 14095, 14096, 1628, 14166, 14167, 14168, 1651
6294, 1628, 14096, 14097, 1627, 14168, 14169, 14170, 1650
6295, 1627, 14097, 14098, 1626, 14170, 14171, 14172, 1649
6296, 1626, 14098, 14099, 1625, 14172, 14173, 14174, 1648
6297, 1625, 14099, 14100, 1624, 14174, 14175, 14176, 1647
6298, 1624, 14100, 14101, 1623, 14176, 14177, 14178, 1646
6299, 1623, 14101, 14102, 1622, 14178, 14179, 14180, 1645
6300, 1622, 14102, 14103, 1621, 14180, 14181, 14182, 1644
6301, 1621, 14103, 14104, 1620, 14182, 14183, 14184, 1643
6302, 1620, 14104, 14105, 1619, 14184, 14185, 14186, 1642
6303, 1619, 14105, 14106, 1618, 14186, 14187, 14188, 1641
6304, 1618, 14106, 14107, 1617, 14188, 14189, 14190, 1640
6305, 1617, 14107, 14108, 1616, 14190, 14191, 14192, 1639
6306, 1616, 14108, 14109, 1615, 14192, 14193, 14194, 1638
6307, 1615, 14109, 14110, 1614, 14194, 14195, 14196, 1637
6308, 1614, 14110, 14111, 1613, 14196, 14197, 14198, 1636
6309, 1613, 14111, 14112, 1612, 14198, 14199, 14200, 1635
6310, 1612, 14112, 1891, 52, 14200, 14201, 1894, 1634
6311, 1763, 1764, 14113, 14091, 1767, 14202, 14203, 14157
6312, 14091, 14113, 14114, 14092, 14203, 14204, 14205, 14159
6313, 14092, 14114, 14115, 14093, 14205, 14206, 14207, 14161
6314, 14093, 14115, 14116, 14094, 14207, 14208, 14209, 14163
6315, 14094, 14116, 14117, 14095, 14209, 14210, 14211, 14165
6316, 14095, 14117, 14118, 14096, 14211, 14212, 14213, 14167
6317, 14096, 14118, 14119, 14097, 14213, 14214, 14215, 14169
6318, 14097, 14119, 14120, 14098, 14215, 14216, 14217, 14171
6319, 14098, 14120, 14121, 14099, 14217, 14218, 14219, 14173
6320, 14099, 14121, 14122, 14100, 14219, 14220, 14221, 14175
6321, 14100, 14122, 14123, 14101, 14221, 14222, 14223, 14177
6322, 14101, 14123, 14124, 14102, 14223, 14224, 14225, 14179
6323, 14102, 14124, 14125, 14103, 14225, 14226, 14227, 14181
6324, 14103, 14125, 14126, 14104, 14227, 14228, 14229, 14183
6325, 14104, 14126, 14127, 14105, 14229, 14230, 14231, 14185
6326, 14105, 14127, 14128, 14106, 14231, 14232, 14233, 14187
6327, 14106, 14128, 14129, 14107, 14233, 14234, 14235, 14189
6328, 14107, 14129, 14130, 14108, 14235, 14236, 14237, 14191
6329, 14108, 14130, 14131, 14109, 14237, 14238, 14239, 14193
6330, 14109, 14131, 14132, 14110, 14239, 14240, 14241, 14195
6331, 14110, 14132, 14133, 14111, 14241, 14242, 14243, 14197
6332, 14111, 14133, 14134, 14112, 14243, 14244, 14245, 14199
6333, 14112, 14134, 1892, 1891, 14245, 14246, 1895, 14201
6334, 1764, 1765, 14135, 14113, 1768, 14247, 14248, 14202
6335, 14113, 14135, 14136, 14114, 14248, 14249, 14250, 14204
6336, 14114, 14136, 14137, 14115, 14250, 14251, 14252, 14206
6337, 14115, 14137, 14138, 14116, 14252, 14253, 14254, 14208
6338, 14116, 14138, 14139, 14117, 14254, 14255, 14256, 14210
6339, 14117, 14139, 14140, 14118, 14256, 14257, 14258, 14212
6340, 14118, 14140, 14141, 14119, 14258, 14259, 14260, 14214
6341, 14119, 14141, 14142, 14120, 14260, 14261, 14262, 14216
6342, 14120, 14142, 14143, 14121, 14262, 14263, 14264, 14218
6343, 14121, 14143, 14144, 14122, 14264, 14265, 14266, 14220
6344, 14122, 14144, 14145, 14123, 14266, 14267, 14268, 14222
6345, 14123, 14145, 14146, 14124, 14268, 14269, 14270, 14224
6346, 14124, 14146, 14147, 14125, 14270, 14271, 14272, 14226
6347, 14125, 14147, 14148, 14126, 14272, 14273, 14274, 14228
6348, 14126, 14148, 14149, 14127, 14274, 14275, 14276, 14230
6349, 14127, 14149, 14150, 14128, 14276, 14277, 14278, 14232
6350, 14128, 14150, 14151, 14129, 14278, 14279, 14280, 14234
6351, 14129, 14151, 14152, 14130, 14280, 14281, 14282, 14236
6352, 14130, 14152, 14153, 14131, 14282, 14283, 14284, 14238
6353, 14131, 14153, 14154, 14132, 14284, 14285, 14286, 14240
6354, 14132, 14154, 14155, 14133, 14286, 14287, 14288, 14242
6355, 14133, 14155, 14156, 14134, 14288, 14289, 14290, 14244
6356, 14134, 14156, 1893, 1892, 14290, 14291, 1896, 14246
6357, 1765, 57, 1919, 14135, 1769, 1942, 14292, 14247
6358, 14135, 1919, 1918, 14136, 14292, 1941, 14293, 14249
6359, 14136, 1918, 1917, 14137, 14293, 1940, 14294, 14251
6360, 14137, 1917, 1916, 14138, 14294, 1939, 14295, 14253
6361, 14138, 1916, 1915, 14139, 14295, 1938, 14296, 14255
6362, 14139, 1915, 1914, 14140, 14296, 1937, 14297, 14257
6363, 14140, 1914, 1913, 14141, 14297, 1936, 14298, 14259
6364, 14141, 1913, 1912, 14142, 14298, 1935, 14299, 14261
6365, 14142, 1912, 1911, 14143, 14299, 1934, 14300, 14263
6366, 14143, 1911, 1910, 14144, 14300, 1933, 14301, 14265
6367, 14144, 1910, 1909, 14145, 14301, 1932, 14302, 14267
6368, 14145, 1909, 1908, 14146, 14302, 1931, 14303, 14269
6369, 14146, 1908, 1907, 14147, 14303, 1930, 14304, 14271
6370, 14147, 1907, 1906, 14148, 14304, 1929, 14305, 14273
6371, 14148, 1906, 1905, 14149, 14305, 1928, 14306, 14275
6372, 14149, 1905, 1904, 14150, 14306, 1927, 14307, 14277
6373, 14150, 1904, 1903, 14151, 14307, 1926, 14308, 14279
6374, 14151, 1903, 1902, 14152, 14308, 1925, 14309, 14281
6375, 14152, 1902, 1901, 14153, 14309, 1924, 14310, 14283
6376, 14153, 1901, 1900, 14154, 14310, 1923, 14311, 14285
6377, 14154, 1900, 1899, 14155, 14311, 1922, 14312, 14287
6378, 14155, 1899, 1898, 14156, 14312, 1921, 14313, 14289
6379, 14156, 1898, 62, 1893, 14313, 1920, 1897, 14291
*ELEMENT, type=CPS8, ELSET=Surface224
6380, 52, 1891, 14314, 1681, 1894, 14338, 14339, 1690
6381, 1681, 14314, 14315, 1680, 14339, 14340, 14341, 1689
6382, 1680, 14315, 14316, 1679, 14341, 14342, 14343, 1688
6383, 1679, 14316, 14317, 1678, 14343, 14344, 14345, 1687
6384, 1678, 14317, 14318, 1677, 14345, 14346, 14347, 1686
6385, 1677, 14318, 14319, 1676, 14347, 14348, 14349, 1685
6386, 1676, 14319, 14320, 1675, 14349, 14350, 14351, 1684
6387, 1675, 14320, 14321, 1674, 14351, 14352, 14353, 1683
6388, 1674, 14321, 1839, 48, 14353, 14354, 1842, 1682
6389, 1891, 1892, 14322, 14314, 1895, 14355, 14356, 14338
6390, 14314, 14322, 14323, 14315, 14356, 14357, 14358, 14340
6391, 14315, 14323, 14324, 14316, 14358, 14359, 14360, 14342
6392, 14316, 14324, 14325, 14317, 14360, 14361, 14362, 14344
6393, 14317, 14325, 14326, 14318, 14362, 14363, 14364, 14346
6394, 14318, 14326, 14327, 14319, 14364, 14365, 14366, 14348
6395, 14319, 14327, 14328, 14320, 14366, 14367, 14368, 14350
6396, 14320, 14328, 14329, 14321, 14368, 14369, 14370, 14352
6397, 14321, 14329, 1840, 1839, 14370, 14371, 1843, 14354
6398, 1892, 1893, 14330, 14322, 1896, 14372, 14373, 14355
6399, 14322, 14330, 14331, 14323, 14373, 14374, 14375, 14357
6400, 14323, 14331, 14332, 14324, 14375, 14376, 14377, 14359
6401, 14324, 14332, 14333, 14325, 14377, 14378, 14379, 14361
6402, 14325, 14333, 14334, 14326, 14379, 14380, 14381, 14363
6403, 14326, 14334, 14335, 14327, 14381, 14382, 14383, 14365
6404, 14327, 14335, 14336, 14328, 14383, 14384, 14385, 14367
6405, 14328, 14336, 14337, 14329, 14385, 14386, 14387, 14369
6406, 14329, 14337, 1841, 1840, 14387, 14388, 1844, 14371
6407, 1893, 62, 1950, 14330, 1897, 1959, 14389, 14372
6408, 14330, 1950, 1949, 14331, 14389, 1958, 14390, 14374
6409, 14331, 1949, 1948, 14332, 14390, 1957, 14391, 14376
6410, 14332, 1948, 1947, 14333, 14391, 1956, 14392, 14378
6411, 14333, 1947, 1946, 14334, 14392, 1955, 14393, 14380
6412, 14334, 1946, 1945, 14335, 14393, 1954, 14394, 14382
6413, 14335, 1945, 1944, 14336, 14394, 1953, 14395, 14384
6414, 14336, 1944, 1943, 14337, 14395, 1952, 14396, 14386
6415, 14337, 1943, 61, 1841, 14396, 1951, 1845, 14388
*ELEMENT, type=CPS8, ELSET=Surface225
6416, 61, 1943, 14397, 1846, 1951, 14573, 14574, 1868
6417, 1943, 1944, 14398, 14397, 1952, 14575, 14576, 14573
6418, 1944, 1945, 14399, 14398, 1953, 14577, 14578, 14575
6419, 1945, 1946, 14400, 14399, 1954, 14579, 14580, 14577
6420, 1946, 1947, 14401, 14400, 1955, 14581, 14582, 14579
6421, 1947, 1948, 14402, 14401, 1956, 14583, 14584, 14581
6422, 1948, 1949, 14403, 14402, 1957, 14585, 14586, 14583
6423, 1949, 1950, 14404, 14403, 1958, 14587, 14588, 14585
6424, 1950, 62, 1898, 14404, 1959, 1920, 14589, 14587
6425, 1846, 14397, 14405, 1847, 14574, 14590, 14591, 1869
6426, 14397, 14398, 14406, 14405, 14576, 14592, 14593, 14590
6427, 14398, 14399, 14407, 14406, 14578, 14594, 14595, 14592
6428, 14399, 14400, 14408, 14407, 14580, 14596, 14597, 14594
6429, 14400, 14401, 14409, 14408, 14582, 14598, 14599, 14596
6430, 14401, 14402, 14410, 14409, 14584, 14600, 14601, 14598
6431, 14402, 14403, 14411, 14410, 14586, 14602, 14603, 14600
6432, 14403, 14404, 14412, 14411, 14588, 14604, 14605, 14602
6433, 14404, 1898, 1899, 14412, 14589, 1921, 14606, 14604
6434, 1847, 14405, 14413, 1848, 14591, 14607, 14608, 1870
6435, 14405, 14406, 14414, 14413, 14593, 14609, 14610, 14607
6436, 14406, 14407, 14415, 14414, 14595, 14611, 14612, 14609
6437, 14407, 14408, 14416, 14415, 14597, 14613, 14614, 14611
6438, 14408, 14409, 14417, 14416, 14599, 14615, 14616, 14613
6439, 14409, 14410, 14418, 14417, 14601, 14617, 14618, 14615
6440, 14410, 14411, 14419, 14418, 14603, 14619, 14620, 14617
6441, 14411, 14412, 14420, 14419, 14605, 14621, 14622, 14619
6442, 14412, 1899, 1900, 14420, 14606, 1922, 14623, 14621
6443, 1848, 14413, 14421, 1849, 14608, 14624, 14625, 1871
6444, 14413, 14414, 14422, 14421, 14610, 14626, 14627, 14624
6445, 14414, 14415, 14423, 14422, 14612, 14628, 14629, 14626
6446, 14415, 14416, 14424, 14423, 14614, 14630, 14631, 14628
6447, 14416, 14417, 14425, 14424, 14616, 14632, 14633, 14630
6448, 14417, 14418, 14426, 14425, 14618, 14634, 14635, 14632
6449, 14418, 14419, 14427, 14426, 14620, 14636, 14637, 14634
6450, 14419, 14420, 14428, 14427, 14622, 14638, 14639, 14636
6451, 14420, 1900, 1901, 14428, 14623, 1923, 14640, 14638
6452, 1849, 14421, 14429, 1850, 14625, 14641, 14642, 1872
6453, 14421, 14422, 14430, 14429, 14627, 14643, 14644, 14641
6454, 14422, 14423, 14431, 14430, 14629, 14645, 14646, 14643
6455, 14423, 14424, 14432, 14431, 14631, 14647, 14648, 14645
6456, 14424, 14425, 14433, 14432, 14633, 14649, 14650, 14647
6457, 14425, 14426, 14434, 14433, 14635, 14651, 14652, 14649
6458, 14426, 14427, 14435, 14434, 14637, 14653, 14654, 14651
6459, 14427, 14428, 14436, 14435, 14639, 14655, 14656, 14653
6460, 14428, 1901, 1902, 14436, 14640, 1924, 14657, 14655
6461, 1850, 14429, 14437, 1851, 14642, 14658, 14659, 1873
6462, 14429, 14430, 14438, 14437, 14644, 14660, 14661, 14658
6463, 14430, 14431, 14439, 14438, 14646, 14662, 14663, 14660
6464, 14431, 14432, 14440, 14439, 14648, 14664, 14665, 14662
6465, 14432, 14433, 14441, 14440, 14650, 14666, 14667, 14664
6466, 14433, 14434, 14442, 14441, 14652, 14668, 14669, 14666
6467, 14434, 14435, 14443, 14442, 14654, 14670, 14671, 14668
6468, 14435, 14436, 14444, 14443, 14656, 14672, 14673, 14670
6469, 14436, 1902, 1903, 14444, 14657, 1925, 14674, 14672
6470, 1851, 14437, 14445, 1852, 14659, 14675, 14676, 1874
6471, 14437, 14438, 14446, 14445, 14661, 14677, 14678, 14675
6472, 14438, 14439, 14447, 14446, 14663, 14679, 14680, 14677
6473, 14439, 14440, 14448, 14447, 14665, 14681, 14682, 14679
6474, 14440, 14441, 14449, 14448, 14667, 14683, 14684, 14681
6475, 14441, 14442, 14450, 14449, 14669, 14685, 14686, 14683
6476, 14442, 14443, 14451, 14450, 14671, 14687, 14688, 14685
6477, 14443, 14444, 14452, 14451, 14673, 14689, 14690, 14687
6478, 14444, 1903, 1904, 14452, 14674, 1926, 14691, 14689
6479, 1852, 14445, 14453, 1853, 14676, 14692, 14693, 1875
6480, 14445, 14446, 14454, 14453, 14678, 14694, 14695, 14692
6481, 14446, 14447, 14455, 14454, 14680, 14696, 14697, 14694
6482, 14447, 14448, 14456, 14455, 14682, 14698, 14699, 14696
6483, 14448, 14449, 14457, 14456, 14684, 14700, 14701, 14698
6484, 14449, 14450, 14458, 14457, 14686, 14702, 14703, 14700
6485, 14450, 14451, 14459, 14458, 14688, 14704, 14705, 14702
6486, 14451, 14452, 14460, 14459, 14690, 14706, 14707, 14704
6487, 14452, 1904, 1905, 14460, 14691, 1927, 14708, 14706
6488, 1853, 14453, 14461, 1854, 14693, 14709, 14710, 1876
6489, 14453, 14454, 14462, 14461, 14695, 14711, 14712, 14709
6490, 14454, 14455, 14463, 14462, 14697, 14713, 14714, 14711
6491, 14455, 14456, 14464, 14463, 14699, 14715, 14716, 14713
6492, 14456, 14457, 14465, 14464, 14701, 14717, 14718, 14715
6493, 14457, 14458, 14466, 14465, 14703, 14719, 14720, 14717
6494, 14458, 14459, 14467, 14466, 14705, 14721, 14722, 14719
6495, 14459, 14460, 14468, 14467, 14707, 14723, 14724, 14721
6496, 14460, 1905, 1906, 14468, 14708, 1928, 14725, 14723
6497, 1854, 14461, 14469, 1855, 14710, 14726, 14727, 1877
6498, 14461, 14462, 14470, 14469, 14712, 14728, 14729, 14726
6499, 14462, 14463, 14471, 14470, 14714, 14730, 14731, 14728
6500, 14463, 14464, 14472, 14471, 14716, 14732, 14733, 14730
6501, 14464, 14465, 14473, 14472, 14718, 14734, 14735, 14732
6502, 14465, 14466, 14474, 14473, 14720, 14736, 14737, 14734
6503, 14466, 14467, 14475, 14474, 14722, 14738, 14739, 14736
6504, 14467, 14468, 14476, 14475, 14724, 14740, 14741, 14738
6505, 14468, 1906, 1907, 14476, 14725, 1929, 14742, 14740
6506, 1855, 14469, 14477, 1856, 14727, 14743, 14744, 1878
6507, 14469, 14470, 14478, 14477, 14729, 14745, 14746, 14743
6508, 14470, 14471, 14479, 14478, 14731, 14747, 14748, 14745
6509, 14471, 14472, 14480, 14479, 14733, 14749, 14750, 14747
6510, 14472, 14473, 14481, 14480, 14735, 14751, 14752, 14749
6511, 14473, 14474, 14482, 14481, 14737, 14753, 14754, 14751
6512, 14474, 14475, 14483, 14482, 14739, 14755, 14756, 14753
6513, 14475, 14476, 14484, 14483, 14741, 14757, 14758, 14755
6514, 14476, 1907, 1908, 14484, 14742, 1930, 14759, 14757
6515, 1856, 14477, 14485, 1857, 14744, 14760, 14761, 1879
6516, 14477, 14478, 14486, 14485, 14746, 14762, 14763, 14760
6517, 14478, 14479, 14487, 14486, 14748, 14764, 14765, 14762
6518, 14479, 14480, 14488, 14487, 14750, 14766, 14767, 14764
6519, 14480, 14481, 14489, 14488, 14752, 14768, 14769, 14766
6520, 14481, 14482, 14490, 14489, 14754, 14770, 14771, 14768
6521, 14482, 14483, 14491, 14490, 14756, 14772, 14773, 14770
6522, 14483, 14484, 14492, 14491, 14758, 14774, 14775, 14772
6523, 14484, 1908, 1909, 14492, 14759, 1931, 14776, 14774
6524, 1857, 14485, 14493, 1858, 14761, 14777, 14778, 1880
6525, 14485, 14486, 14494, 14493, 14763, 14779, 14780, 14777
6526, 14486, 14487, 14495, 14494, 14765, 14781, 14782, 14779
6527, 14487, 14488, 14496, 14495, 14767, 14783, 14784, 14781
6528, 14488, 14489, 14497, 14496, 14769, 14785, 14786, 14783
6529, 14489, 14490, 14498, 14497, 14771, 14787, 14788, 14785
6530, 14490, 14491, 14499, 14498, 14773, 14789, 14790, 14787
6531, 14491, 14492, 14500, 14499, 14775, 14791, 14792, 14789
6532, 14492, 1909, 1910, 14500, 14776, 1932, 14793, 14791
6533, 1858, 14493, 14501, 1859, 14778, 14794, 14795, 1881
6534, 14493, 14494, 14502, 14501, 14780, 14796, 14797, 14794
6535, 14494, 14495, 14503, 14502, 14782, 14798, 14799, 14796
6536, 14495, 14496, 14504, 14503, 14784, 14800, 14801, 14798
6537, 14496, 14497, 14505, 14504, 14786, 14802, 14803, 14800
6538, 14497, 14498, 14506, 14505, 14788, 14804, 14805, 14802
6539, 14498, 14499, 14507, 14506, 14790, 14806, 14807, 14804
6540, 14499, 14500, 14508, 14507, 14792, 14808, 14809, 14806
6541, 14500, 1910, 1911, 14508, 14793, 1933, 14810, 14808
6542, 1859, 14501, 14509, 1860, 14795, 14811, 14812, 1882
6543, 14501, 14502, 14510, 14509, 14797, 14813, 14814, 14811
6544, 14502, 14503, 14511, 14510, 14799, 14815, 14816, 14813
6545, 14503, 14504, 14512, 14511, 14801, 14817, 14818, 14815
6546, 14504, 14505, 14513, 14512, 14803, 14819, 14820, 14817
6547, 14505, 14506, 14514, 14513, 14805, 14821, 14822, 14819
6548, 14506, 14507, 14515, 14514, 14807, 14823, 14824, 14821
6549, 14507, 14508, 14516, 14515, 14809, 14825, 14826, 14823
6550, 14508, 1911, 1912, 14516, 14810, 1934, 14827, 14825
6551, 1860, 14509, 14517, 1861, 14812, 14828, 14829, 1883
6552, 14509, 14510, 14518, 14517, 14814, 14830, 14831, 14828
6553, 14510, 14511, 14519, 14518, 14816, 14832, 14833, 14830
6554, 14511, 14512, 14520, 14519, 14818, 14834, 14835, 14832
6555, 14512, 14513, 14521, 14520, 14820, 14836, 14837, 14834
6556, 14513, 14514, 14522, 14521, 14822, 14838, 14839, 14836
6557, 14514, 14515, 14523, 14522, 14824, 14840, 14841, 14838
6558, 14515, 14516, 14524, 14523, 14826, 14842, 14843, 14840
6559, 14516, 1912, 1913, 14524, 14827, 1935, 14844, 14842
6560, 1861, 14517, 14525, 1862, 14829, 14845, 14846, 1884
6561, 14517, 14518, 14526, 14525, 14831, 14847, 14848, 14845
6562, 14518, 14519, 14527, 14526, 14833, 14849, 14850, 14847
6563, 14519, 14520, 14528, 14527, 14835, 14851, 14852, 14849
6564, 14520, 14521, 14529, 14528, 14837, 14853, 14854, 14851
6565, 14521, 14522, 14530, 14529, 14839, 14855, 14856, 14853
6566, 14522, 14523, 14531, 14530, 14841, 14857, 14858, 14855
6567, 14523, 14524, 14532, 14531, 14843, 14859, 14860, 14857
6568, 14524, 1913, 1914, 14532, 14844, 1936, 14861, 14859
6569, 1862, 14525, 14533, 1863, 14846, 14862, 14863, 1885
6570, 14525, 14526, 14534, 14533, 14848, 14864, 14865, 14862
6571, 14526, 14527, 14535, 14534, 14850, 14866, 14867, 14864
6572, 14527, 14528, 14536, 14535, 14852, 14868, 14869, 14866
6573, 14528, 14529, 14537, 14536, 14854, 14870, 14871, 14868
6574, 14529, 14530, 14538, 14537, 14856, 14872, 14873, 14870
6575, 14530, 14531, 14539, 14538, 14858, 14874, 14875, 14872
6576, 14531, 14532, 14540, 14539, 14860, 14876, 14877, 14874
6577, 14532, 1914, 1915, 14540, 14861, 1937, 14878, 14876
6578, 1863, 14533, 14541, 1864, 14863, 14879, 14880, 1886
6579, 14533, 14534, 14542, 14541, 14865, 14881, 14882, 14879
6580, 14534, 14535, 14543, 14542, 14867, 14883, 14884, 14881
6581, 14535, 14536, 14544, 14543, 14869, 14885, 14886, 14883
6582, 14536, 14537, 14545, 14544, 14871, 14887, 14888, 14885
6583, 14537, 14538, 14546, 14545, 14873, 14889, 14890, 14887
6584, 14538, 14539, 14547, 14546, 14875, 14891, 14892, 14889
6585, 14539, 14540, 14548, 14547, 14877, 14893, 14894, 14891
6586, 14540, 1915, 1916, 14548, 14878, 1938, 14895, 14893
6587, 1864, 14541, 14549, 1865, 14880, 14896, 14897, 1887
6588, 14541, 14542, 14550, 14549, 14882, 14898, 14899, 14896
6589, 14542, 14543, 14551, 14550, 14884, 14900, 14901, 14898
6590, 14543, 14544, 14552, 14551, 14886, 14902, 14903, 14900
6591, 14544, 14545, 14553, 14552, 14888, 14904, 14905, 14902
6592, 14545, 14546, 14554, 14553, 14890, 14906, 14907, 14904
6593, 14546, 14547, 14555, 14554, 14892, 14908, 14909, 14906
6594, 14547, 14548, 14556, 14555, 14894, 14910, 14911, 14908
6595, 14548, 1916, 1917, 14556, 14895, 1939, 14912, 14910
6596, 1865, 14549, 14557, 1866, 14897, 14913, 14914, 1888
6597, 14549, 14550, 14558, 14557, 14899, 14915, 14916, 14913
6598, 14550, 14551, 14559, 14558, 14901, 14917, 14918, 14915
6599, 14551, 14552, 14560, 14559, 14903, 14919, 14920, 14917
6600, 14552, 14553, 14561, 14560, 14905, 14921, 14922, 14919
6601, 14553, 14554, 14562, 14561, 14907, 14923, 14924, 14921
6602, 14554, 14555, 14563, 14562, 14909, 14925, 14926, 14923
6603, 14555, 14556, 14564, 14563, 14911, 14927, 14928, 14925
6604, 14556, 1917, 1918, 14564, 14912, 1940, 14929, 14927
6605, 1866, 14557, 14565, 1867, 14914, 14930, 14931, 1889
6606, 14557, 14558, 14566, 14565, 14916, 14932, 14933, 14930
6607, 14558, 14559, 14567, 14566, 14918, 14934, 14935, 14932
6608, 14559, 14560, 14568, 14567, 14920, 14936, 14937, 14934
6609, 14560, 14561, 14569, 14568, 14922, 14938, 14939, 14936
6610, 14561, 14562, 14570, 14569, 14924, 14940, 14941, 14938
6611, 14562, 14563, 14571, 14570, 14926, 14942, 14943, 14940
6612, 14563, 14564, 14572, 14571, 14928, 14944, 14945, 14942
6613, 14564, 1918, 1919, 14572, 14929, 1941, 14946, 14944
6614, 1867, 14565, 1805, 59, 14931, 14947, 1813, 1890
6615, 14565, 14566, 1806, 1805, 14933, 14948, 1814, 14947
6616, 14566, 14567, 1807, 1806, 14935, 14949, 1815, 14948
6617, 14567, 14568, 1808, 1807, 14937, 14950, 1816, 14949
6618, 14568, 14569, 1809, 1808, 14939, 14951, 1817, 14950
6619, 14569, 14570, 1810, 1809, 14941, 14952, 1818, 14951
6620, 14570, 14571, 1811, 1810, 14943, 14953, 1819, 14952
6621, 14571, 14572, 1812, 1811, 14945, 14954, 1820, 14953
6622, 14572, 1919, 57, 1812, 14946, 1942, 1821, 14954
*ELEMENT, type=CPS8, ELSET=Surface226
6623, 52, 1891, 14955, 1960, 1894, 14958, 14959, 1961
6624, 1891, 1892, 14956, 14955, 1895, 14960, 14961, 14958
6625, 1892, 1893, 14957, 14956, 1896, 14962, 14963, 14960
6626, 1893, 62, 1963, 14957, 1897, 1964, 14964, 14962
6627, 1960, 14955, 1966, 63, 14959, 14965, 1969, 1962
6628, 14955, 14956, 1967, 1966, 14961, 14966, 1970, 14965
6629, 14956, 14957, 1968, 1967, 14963, 14967, 1971, 14966
6630, 14957, 1963, 64, 1968, 14964, 1965, 1972, 14967
*ELEMENT, type=CPS8, ELSET=Surface227
6631, 48, 1973, 14968, 1839, 1974, 14971, 14972, 1842
6632, 1839, 14968, 14969, 1840, 14972, 14973, 14974, 1843
6633, 1840, 14969, 14970, 1841, 14974, 14975, 14976, 1844
6634, 1841, 14970, 1976, 61, 14976, 14977, 1977, 1845
6635, 1973, 65, 1979, 14968, 1975, 1982, 14978, 14971
6636, 14968, 1979, 1980, 14969, 14978, 1983, 14979, 14973
6637, 14969, 1980, 1981, 14970, 14979, 1984, 14980, 14975
6638, 14970, 1981, 66, 1976, 14980, 1985, 1978, 14977
*ELEMENT, type=CPS8, ELSET=Surface228
6639, 52, 1960, 14981, 1681, 1961, 14989, 14990, 1690
6640, 1681, 14981, 14982, 1680, 14990, 14991, 14992, 1689
6641, 1680, 14982, 14983, 1679, 14992, 14993, 14994, 1688
6642, 1679, 14983, 14984, 1678, 14994, 14995, 14996, 1687
6643, 1678, 14984, 14985, 1677, 14996, 14997, 14998, 1686
6644, 1677, 14985, 14986, 1676, 14998, 14999, 15000, 1685
6645, 1676, 14986, 14987, 1675, 15000, 15001, 15002, 1684
6646, 1675, 14987, 14988, 1674, 15002, 15003, 15004, 1683
6647, 1674, 14988, 1973, 48, 15004, 15005, 1974, 1682
6648, 1960, 63, 1993, 14981, 1962, 2002, 15006, 14989
6649, 14981, 1993, 1992, 14982, 15006, 2001, 15007, 14991
6650, 14982, 1992, 1991, 14983, 15007, 2000, 15008, 14993
6651, 14983, 1991, 1990, 14984, 15008, 1999, 15009, 14995
6652, 14984, 1990, 1989, 14985, 15009, 1998, 15010, 14997
6653, 14985, 1989, 1988, 14986, 15010, 1997, 15011, 14999
6654, 14986, 1988, 1987, 14987, 15011, 1996, 15012, 15001
6655, 14987, 1987, 1986, 14988, 15012, 1995, 15013, 15003
6656, 14988, 1986, 65, 1973, 15013, 1994, 1975, 15005
*ELEMENT, type=CPS8, ELSET=Surface229
6657, 62, 1950, 15014, 1963, 1959, 15022, 15023, 1964
6658, 1950, 1949, 15015, 15014, 1958, 15024, 15025, 15022
6659, 1949, 1948, 15016, 15015, 1957, 15026, 15027, 15024
6660, 1948, 1947, 15017, 15016, 1956, 15028, 15029, 15026
6661, 1947, 1946, 15018, 15017, 1955, 15030, 15031, 15028
6662, 1946, 1945, 15019, 15018, 1954, 15032, 15033, 15030
6663, 1945, 1944, 15020, 15019, 1953, 15034, 15035, 15032
6664, 1944, 1943, 15021, 15020, 1952, 15036, 15037, 15034
6665, 1943, 61, 1976, 15021, 1951, 1977, 15038, 15036
6666, 1963, 15014, 2010, 64, 15023, 15039, 2019, 1965
6667, 15014, 15015, 2009, 2010, 15025, 15040, 2018, 15039
6668, 15015, 15016, 2008, 2009, 15027, 15041, 2017, 15040
6669, 15016, 15017, 2007, 2008, 15029, 15042, 2016, 15041
6670, 15017, 15018, 2006, 2007, 15031, 15043, 2015, 15042
6671, 15018, 15019, 2005, 2006, 15033, 15044, 2014, 15043
6672, 15019, 15020, 2004, 2005, 15035, 15045, 2013, 15044
6673, 15020, 15021, 2003, 2004, 15037, 15046, 2012, 15045
6674, 15021, 1976, 66, 2003, 15038, 1978, 2011, 15046
*ELEMENT, type=CPS8, ELSET=Surface230
6675, 63, 1966, 15047, 1993, 1969, 15071, 15072, 2002
6676, 1993, 15047, 15048, 1992, 15072, 15073, 15074, 2001
6677, 1992, 15048, 15049, 1991, 15074, 15075, 15076, 2000
6678, 1991, 15049, 15050, 1990, 15076, 15077, 15078, 1999
6679, 1990, 15050, 15051, 1989, 15078, 15079, 15080, 1998
6680, 1989, 15051, 15052, 1988, 15080, 15081, 15082, 1997
6681, 1988, 15052, 15053, 1987, 15082, 15083, 15084, 1996
6682, 1987, 15053, 15054, 1986, 15084, 15085, 15086, 1995
6683, 1986, 15054, 1979, 65, 15086, 15087, 1982, 1994
6684, 1966, 1967, 15055, 15047, 1970, 15088, 15089, 15071
6685, 15047, 15055, 15056, 15048, 15089, 15090, 15091, 15073
6686, 15048, 15056, 15057, 15049, 15091, 15092, 15093, 15075
6687, 15049, 15057, 15058, 15050, 15093, 15094, 15095, 15077
6688, 15050, 15058, 15059, 15051, 15095, 15096, 15097, 15079
6689, 15051, 15059, 15060, 15052, 15097, 15098, 15099, 15081
6690, 15052, 15060, 15061, 15053, 15099, 15100, 15101, 15083
6691, 15053, 15061, 15062, 15054, 15101, 15102, 15103, 15085
6692, 15054, 15062, 1980, 1979, 15103, 15104, 1983, 15087
6693, 1967, 1968, 15063, 15055, 1971, 15105, 15106, 15088
6694, 15055, 15063, 15064, 15056, 15106, 15107, 15108, 15090
6695, 15056, 15064, 15065, 15057, 15108, 15109, 15110, 15092
6696, 15057, 15065, 15066, 15058, 15110, 15111, 15112, 15094
6697, 15058, 15066, 15067, 15059, 15112, 15113, 15114, 15096
6698, 15059, 15067, 15068, 15060, 15114, 15115, 15116, 15098
6699, 15060, 15068, 15069, 15061, 15116, 15117, 15118, 15100
6700, 15061, 15069, 15070, 15062, 15118, 15119, 15120, 15102
6701, 15062, 15070, 1981, 1980, 15120, 15121, 1984, 15104
6702, 1968, 64, 2010, 15063, 1972, 2019, 15122, 15105
6703, 15063, 2010, 2009, 15064, 15122, 2018, 15123, 15107
6704, 15064, 2009, 2008, 15065, 15123, 2017, 15124, 15109
6705, 15065, 2008, 2007, 15066, 15124, 2016, 15125, 15111
6706, 15066, 2007, 2006, 15067, 15125, 2015, 15126, 15113
6707, 15067, 2006, 2005, 15068, 15126, 2014, 15127, 15115
6708, 15068, 2005, 2004, 15069, 15127, 2013, 15128, 15117
6709, 15069, 2004, 2003, 15070, 15128, 2012, 15129, 15119
6710, 15070, 2003, 66, 1981, 15129, 2011, 1985, 15121
*ELEMENT, type=CPS8, ELSET=Surface231
6711, 67, 2047, 15130, 2020, 2070, 15152, 15153, 2021
6712, 2047, 2046, 15131, 15130, 2069, 15154, 15155, 15152
6713, 2046, 2045, 15132, 15131, 2068, 15156, 15157, 15154
6714, 2045, 2044, 15133, 15132, 2067, 15158, 15159, 15156
6715, 2044, 2043, 15134, 15133, 2066, 15160, 15161, 15158
6716, 2043, 2042, 15135, 15134, 2065, 15162, 15163, 15160
6717, 2042, 2041, 15136, 15135, 2064, 15164, 15165, 15162
6718, 2041, 2040, 15137, 15136, 2063, 15166, 15167, 15164
6719, 2040, 2039, 15138, 15137, 2062, 15168, 15169, 15166
6720, 2039, 2038, 15139, 15138, 2061, 15170, 15171, 15168
6721, 2038, 2037, 15140, 15139, 2060, 15172, 15173, 15170
6722, 2037, 2036, 15141, 15140, 2059, 15174, 15175, 15172
6723, 2036, 2035, 15142, 15141, 2058, 15176, 15177, 15174
6724, 2035, 2034, 15143, 15142, 2057, 15178, 15179, 15176
6725, 2034, 2033, 15144, 15143, 2056, 15180, 15181, 15178
6726, 2033, 2032, 15145, 15144, 2055, 15182, 15183, 15180
6727, 2032, 2031, 15146, 15145, 2054, 15184, 15185, 15182
6728, 2031, 2030, 15147, 15146, 2053, 15186, 15187, 15184
6729, 2030, 2029, 15148, 15147, 2052, 15188, 15189, 15186
6730, 2029, 2028, 15149, 15148, 2051, 15190, 15191, 15188
6731, 2028, 2027, 15150, 15149, 2050, 15192, 15193, 15190
6732, 2027, 2026, 15151, 15150, 2049, 15194, 15195, 15192
6733, 2026, 68, 2023, 15151, 2048, 2024, 15196, 15194
6734, 2020, 15130, 1454, 45, 15153, 15197, 1477, 2022
6735, 15130, 15131, 1453, 1454, 15155, 15198, 1476, 15197
6736, 15131, 15132, 1452, 1453, 15157, 15199, 1475, 15198
6737, 15132, 15133, 1451, 1452, 15159, 15200, 1474, 15199
6738, 15133, 15134, 1450, 1451, 15161, 15201, 1473, 15200
6739, 15134, 15135, 1449, 1450, 15163, 15202, 1472, 15201
6740, 15135, 15136, 1448, 1449, 15165, 15203, 1471, 15202
6741, 15136, 15137, 1447, 1448, 15167, 15204, 1470, 15203
6742, 15137, 15138, 1446, 1447, 15169, 15205, 1469, 15204
6743, 15138, 15139, 1445, 1446, 15171, 15206, 1468, 15205
6744, 15139, 15140, 1444, 1445, 15173, 15207, 1467, 15206
6745, 15140, 15141, 1443, 1444, 15175, 15208, 1466, 15207
6746, 15141, 15142, 1442, 1443, 15177, 15209, 1465, 15208
6747, 15142, 15143, 1441, 1442, 15179, 15210, 1464, 15209
6748, 15143, 15144, 1440, 1441, 15181, 15211, 1463, 15210
6749, 15144, 15145, 1439, 1440, 15183, 15212, 1462, 15211
6750, 15145, 15146, 1438, 1439, 15185, 15213, 1461, 15212
6751, 15146, 15147, 1437, 1438, 15187, 15214, 1460, 15213
6752, 15147, 15148, 1436, 1437, 15189, 15215, 1459, 15214
6753, 15148, 15149, 1435, 1436, 15191, 15216, 1458, 15215
6754, 15149, 15150, 1434, 1435, 15193, 15217, 1457, 15216
6755, 15150, 15151, 1433, 1434, 15195, 15218, 1456, 15217
6756, 15151, 2023, 47, 1433, 15196, 2025, 1455, 15218
*ELEMENT, type=CPS8, ELSET=Surface232
6757, 69, 2081, 15219, 2071, 2090, 15227, 15228, 2072
6758, 2081, 2080, 15220, 15219, 2089, 15229, 15230, 15227
6759, 2080, 2079, 15221, 15220, 2088, 15231, 15232, 15229
6760, 2079, 2078, 15222, 15221, 2087, 15233, 15234, 15231
6761, 2078, 2077, 15223, 15222, 2086, 15235, 15236, 15233
6762, 2077, 2076, 15224, 15223, 2085, 15237, 15238, 15235
6763, 2076, 2075, 15225, 15224, 2084, 15239, 15240, 15237
6764, 2075, 2074, 15226, 15225, 2083, 15241, 15242, 15239
6765, 2074, 67, 2020, 15226, 2082, 2021, 15243, 15241
6766, 2071, 15219, 1535, 49, 15228, 15244, 1544, 2073
6767, 15219, 15220, 1534, 1535, 15230, 15245, 1543, 15244
6768, 15220, 15221, 1533, 1534, 15232, 15246, 1542, 15245
6769, 15221, 15222, 1532, 1533, 15234, 15247, 1541, 15246
6770, 15222, 15223, 1531, 1532, 15236, 15248, 1540, 15247
6771, 15223, 15224, 1530, 1531, 15238, 15249, 1539, 15248
6772, 15224, 15225, 1529, 1530, 15240, 15250, 1538, 15249
6773, 15225, 15226, 1528, 1529, 15242, 15251, 1537, 15250
6774, 15226, 2020, 45, 1528, 15243, 2022, 1536, 15251
*ELEMENT, type=CPS8, ELSET=Surface233
6775, 69, 2071, 15252, 2115, 2072, 15274, 15275, 2138
6776, 2115, 15252, 15253, 2114, 15275, 15276, 15277, 2137
6777, 2114, 15253, 15254, 2113, 15277, 15278, 15279, 2136
6778, 2113, 15254, 15255, 2112, 15279, 15280, 15281, 2135
6779, 2112, 15255, 15256, 2111, 15281, 15282, 15283, 2134
6780, 2111, 15256, 15257, 2110, 15283, 15284, 15285, 2133
6781, 2110, 15257, 15258, 2109, 15285, 15286, 15287, 2132
6782, 2109, 15258, 15259, 2108, 15287, 15288, 15289, 2131
6783, 2108, 15259, 15260, 2107, 15289, 15290, 15291, 2130
6784, 2107, 15260, 15261, 2106, 15291, 15292, 15293, 2129
6785, 2106, 15261, 15262, 2105, 15293, 15294, 15295, 2128
6786, 2105, 15262, 15263, 2104, 15295, 15296, 15297, 2127
6787, 2104, 15263, 15264, 2103, 15297, 15298, 15299, 2126
6788, 2103, 15264, 15265, 2102, 15299, 15300, 15301, 2125
6789, 2102, 15265, 15266, 2101, 15301, 15302, 15303, 2124
6790, 2101, 15266, 15267, 2100, 15303, 15304, 15305, 2123
6791, 2100, 15267, 15268, 2099, 15305, 15306, 15307, 2122
6792, 2099, 15268, 15269, 2098, 15307, 15308, 15309, 2121
6793, 2098, 15269, 15270, 2097, 15309, 15310, 15311, 2120
6794, 2097, 15270, 15271, 2096, 15311, 15312, 15313, 2119
6795, 2096, 15271, 15272, 2095, 15313, 15314, 15315, 2118
6796, 2095, 15272, 15273, 2094, 15315, 15316, 15317, 2117
6797, 2094, 15273, 2091, 70, 15317, 15318, 2092, 2116
6798, 2071, 49, 1588, 15252, 2073, 1611, 15319, 15274
6799, 15252, 1588, 1587, 15253, 15319, 1610, 15320, 15276
6800, 15253, 1587, 1586, 15254, 15320, 1609, 15321, 15278
6801, 15254, 1586, 1585, 15255, 15321, 1608, 15322, 15280
6802, 15255, 1585, 1584, 15256, 15322, 1607, 15323, 15282
6803, 15256, 1584, 1583, 15257, 15323, 1606, 15324, 15284
6804, 15257, 1583, 1582, 15258, 15324, 1605, 15325, 15286
6805, 15258, 1582, 1581, 15259, 15325, 1604, 15326, 15288
6806, 15259, 1581, 1580, 15260, 15326, 1603, 15327, 15290
6807, 15260, 1580, 1579, 15261, 15327, 1602, 15328, 15292
6808, 15261, 1579, 1578, 15262, 15328, 1601, 15329, 15294
6809, 15262, 1578, 1577, 15263, 15329, 1600, 15330, 15296
6810, 15263, 1577, 1576, 15264, 15330, 1599, 15331, 15298
6811, 15264, 1576, 1575, 15265, 15331, 1598, 15332, 15300
6812, 15265, 1575, 1574, 15266, 15332, 1597, 15333, 15302
6813, 15266, 1574, 1573, 15267, 15333, 1596, 15334, 15304
6814, 15267, 1573, 1572, 15268, 15334, 1595, 15335, 15306
6815, 15268, 1572, 1571, 15269, 15335, 1594, 15336, 15308
6816, 15269, 1571, 1570, 15270, 15336, 1593, 15337, 15310
6817, 15270, 1570, 1569, 15271, 15337, 1592, 15338, 15312
6818, 15271, 1569, 1568, 15272, 15338, 1591, 15339, 15314
6819, 15272, 1568, 1567, 15273, 15339, 1590, 15340, 15316
6820, 15273, 1567, 51, 2091, 15340, 1589, 2093, 15318
*ELEMENT, type=CPS8, ELSET=Surface234
6821, 70, 2091, 15341, 2146, 2092, 15349, 15350, 2155
6822, 2146, 15341, 15342, 2145, 15350, 15351, 15352, 2154
6823, 2145, 15342, 15343, 2144, 15352, 15353, 15354, 2153
6824, 2144, 15343, 15344, 2143, 15354, 15355, 15356, 2152
6825, 2143, 15344, 15345, 2142, 15356, 15357, 15358, 2151
6826, 2142, 15345, 15346, 2141, 15358, 15359, 15360, 2150
6827, 2141, 15346, 15347, 2140, 15360, 15361, 15362, 2149
6828, 2140, 15347, 15348, 2139, 15362, 15363, 15364, 2148
6829, 2139, 15348, 2023, 68, 15364, 15365, 2024, 2147
6830, 2091, 51, 1664, 15341, 2093, 1673, 15366, 15349
6831, 15341, 1664, 1663, 15342, 15366, 1672, 15367, 15351
6832, 15342, 1663, 1662, 15343, 15367, 1671, 15368, 15353
6833, 15343, 1662, 1661, 15344, 15368, 1670, 15369, 15355
6834, 15344, 1661, 1660, 15345, 15369, 1669, 15370, 15357
6835, 15345, 1660, 1659, 15346, 15370, 1668, 15371, 15359
6836, 15346, 1659, 1658, 15347, 15371, 1667, 15372, 15361
6837, 15347, 1658, 1657, 15348, 15372, 1666, 15373, 15363
6838, 15348, 1657, 47, 2023, 15373, 1665, 2025, 15365
*ELEMENT, type=CPS8, ELSET=Surface235
6839, 68, 2026, 15374, 2139, 2048, 15550, 15551, 2147
6840, 2139, 15374, 15375, 2140, 15551, 15552, 15553, 2148
6841, 2140, 15375, 15376, 2141, 15553, 15554, 15555, 2149
6842, 2141, 15376, 15377, 2142, 15555, 15556, 15557, 2150
6843, 2142, 15377, 15378, 2143, 15557, 15558, 15559, 2151
6844, 2143, 15378, 15379, 2144, 15559, 15560, 15561, 2152
6845, 2144, 15379, 15380, 2145, 15561, 15562, 15563, 2153
6846, 2145, 15380, 15381, 2146, 15563, 15564, 15565, 2154
6847, 2146, 15381, 2094, 70, 15565, 15566, 2116, 2155
6848, 2026, 2027, 15382, 15374, 2049, 15567, 15568, 15550
6849, 15374, 15382, 15383, 15375, 15568, 15569, 15570, 15552
6850, 15375, 15383, 15384, 15376, 15570, 15571, 15572, 15554
6851, 15376, 15384, 15385, 15377, 15572, 15573, 15574, 15556
6852, 15377, 15385, 15386, 15378, 15574, 15575, 15576, 15558
6853, 15378, 15386, 15387, 15379, 15576, 15577, 15578, 15560
6854, 15379, 15387, 15388, 15380, 15578, 15579, 15580, 15562
6855, 15380, 15388, 15389, 15381, 15580, 15581, 15582, 15564
6856, 15381, 15389, 2095, 2094, 15582, 15583, 2117, 15566
6857, 2027, 2028, 15390, 15382, 2050, 15584, 15585, 15567
6858, 15382, 15390, 15391, 15383, 15585, 15586, 15587, 15569
6859, 15383, 15391, 15392, 15384, 15587, 15588, 15589, 15571
6860, 15384, 15392, 15393, 15385, 15589, 15590, 15591, 15573
6861, 15385, 15393, 15394, 15386, 15591, 15592, 15593, 15575
6862, 15386, 15394, 15395, 15387, 15593, 15594, 15595, 15577
6863, 15387, 15395, 15396, 15388, 15595, 15596, 15597, 15579
6864, 15388, 15396, 15397, 15389, 15597, 15598, 15599, 15581
6865, 15389, 15397, 2096, 2095, 15599, 15600, 2118, 15583
6866, 2028, 2029, 15398, 15390, 2051, 15601, 15602, 15584
6867, 15390, 15398, 15399, 15391, 15602, 15603, 15604, 15586
6868, 15391, 15399, 15400, 15392, 15604, 15605, 15606, 15588
6869, 15392, 15400, 15401, 15393, 15606, 15607, 15608, 15590
6870, 15393, 15401, 15402, 15394, 15608, 15609, 15610, 15592
6871, 15394, 15402, 15403, 15395, 15610, 15611, 15612, 15594
6872, 15395, 15403, 15404, 15396, 15612, 15613, 15614, 15596
6873, 15396, 15404, 15405, 15397, 15614, 15615, 15616, 15598
6874, 15397, 15405, 2097, 2096, 15616, 15617, 2119, 15600
6875, 2029, 2030, 15406, 15398, 2052, 15618, 15619, 15601
6876, 15398, 15406, 15407, 15399, 15619, 15620, 15621, 15603
6877, 15399, 15407, 15408, 15400, 15621, 15622, 15623, 15605
6878, 15400, 15408, 15409, 15401, 15623, 15624, 15625, 15607
6879, 15401, 15409, 15410, 15402, 15625, 15626, 15627, 15609
6880, 15402, 15410, 15411, 15403, 15627, 15628, 15629, 15611
6881, 15403, 15411, 15412, 15404, 15629, 15630, 15631, 15613
6882, 15404, 15412, 15413, 15405, 15631, 15632, 15633, 15615
6883, 15405, 15413, 2098, 2097, 15633, 15634, 2120, 15617
6884, 2030, 2031, 15414, 15406, 2053, 15635, 15636, 15618
6885, 15406, 15414, 15415, 15407, 15636, 15637, 15638, 15620
6886, 15407, 15415, 15416, 15408, 15638, 15639, 15640, 15622
6887, 15408, 15416, 15417, 15409, 15640, 15641, 15642, 15624
6888, 15409, 15417, 15418, 15410, 15642, 15643, 15644, 15626
6889, 15410, 15418, 15419, 15411, 15644, 15645, 15646, 15628
6890, 15411, 15419, 15420, 15412, 15646, 15647, 15648, 15630
6891, 15412, 15420, 15421, 15413, 15648, 15649, 15650, 15632
6892, 15413, 15421, 2099, 2098, 15650, 15651, 2121, 15634
6893, 2031, 2032, 15422, 15414, 2054, 15652, 15653, 15635
6894, 15414, 15422, 15423, 15415, 15653, 15654, 15655, 15637
6895, 15415, 15423, 15424, 15416, 15655, 15656, 15657, 15639
6896, 15416, 15424, 15425, 15417, 15657, 15658, 15659, 15641
6897, 15417, 15425, 15426, 15418, 15659, 15660, 15661, 15643
6898, 15418, 15426, 15427, 15419, 15661, 15662, 15663, 15645
6899, 15419, 15427, 15428, 15420, 15663, 15664, 15665, 15647
6900, 15420, 15428, 15429, 15421, 15665, 15666, 15667, 15649
6901, 15421, 15429, 2100, 2099, 15667, 15668, 2122, 15651
6902, 2032, 2033, 15430, 15422, 2055, 15669, 15670, 15652
6903, 15422, 15430, 15431, 15423, 15670, 15671, 15672, 15654
6904, 15423, 15431, 15432, 15424, 15672, 15673, 15674, 15656
6905, 15424, 15432, 15433, 15425, 15674, 15675, 15676, 15658
6906, 15425, 15433, 15434, 15426, 15676, 15677, 15678, 15660
6907, 15426, 15434, 15435, 15427, 15678, 15679, 15680, 15662
6908, 15427, 15435, 15436, 15428, 15680, 15681, 15682, 15664
6909, 15428, 15436, 15437, 15429, 15682, 15683, 15684, 15666
6910, 15429, 15437, 2101, 2100, 15684, 15685, 2123, 15668
6911, 2033, 2034, 15438, 15430, 2056, 15686, 15687, 15669
6912, 15430, 15438, 15439, 15431, 15687, 15688, 15689, 15671
6913, 15431, 15439, 15440, 15432, 15689, 15690, 15691, 15673
6914, 15432, 15440, 15441, 15433, 15691, 15692, 15693, 15675
6915, 15433, 15441, 15442, 15434, 15693, 15694, 15695, 15677
6916, 15434, 15442, 15443, 15435, 15695, 15696, 15697, 15679
6917, 15435, 15443, 15444, 15436, 15697, 15698, 15699, 15681
6918, 15436, 15444, 15445, 15437, 15699, 15700, 15701, 15683
6919, 15437, 15445, 2102, 2101, 15701, 15702, 2124, 15685
6920, 2034, 2035, 15446, 15438, 2057, 15703, 15704, 15686
6921, 15438, 15446, 15447, 15439, 15704, 15705, 15706, 15688
6922, 15439, 15447, 15448, 15440, 15706, 15707, 15708, 15690
6923, 15440, 15448, 15449, 15441, 15708, 15709, 15710, 15692
6924, 15441, 15449, 15450, 15442, 15710, 15711, 15712, 15694
6925, 15442, 15450, 15451, 15443, 15712, 15713, 15714, 15696
6926, 15443, 15451, 15452, 15444, 15714, 15715, 15716, 15698
6927, 15444, 15452, 15453, 15445, 15716, 15717, 15718, 15700
6928, 15445, 15453, 2103, 2102, 15718, 15719, 2125, 15702
6929, 2035, 2036, 15454, 15446, 2058, 15720, 15721, 15703
6930, 15446, 15454, 15455, 15447, 15721, 15722, 15723, 15705
6931, 15447, 15455, 15456, 15448, 15723, 15724, 15725, 15707
6932, 15448, 15456, 15457, 15449, 15725, 15726, 15727, 15709
6933, 15449, 15457, 15458, 15450, 15727, 15728, 15729, 15711
6934, 15450, 15458, 15459, 15451, 15729, 15730, 15731, 15713
6935, 15451, 15459, 15460, 15452, 15731, 15732, 15733, 15715
6936, 15452, 15460, 15461, 15453, 15733, 15734, 15735, 15717
6937, 15453, 15461, 2104, 2103, 15735, 15736, 2126, 15719
6938, 2036, 2037, 15462, 15454, 2059, 15737, 15738, 15720
6939, 15454, 15462, 15463, 15455, 15738, 15739, 15740, 15722
6940, 15455, 15463, 15464, 15456, 15740, 15741, 15742, 15724
6941, 15456, 15464, 15465, 15457, 15742, 15743, 15744, 15726
6942, 15457, 15465, 15466, 15458, 15744, 15745, 15746, 15728
6943, 15458, 15466, 15467, 15459, 15746, 15747, 15748, 15730
6944, 15459, 15467, 15468, 15460, 15748, 15749, 15750, 15732
6945, 15460, 15468, 15469, 15461, 15750, 15751, 15752, 15734
6946, 15461, 15469, 2105, 2104, 15752, 15753, 2127, 15736
6947, 2037, 2038, 15470, 15462, 2060, 15754, 15755, 15737
6948, 15462, 15470, 15471, 15463, 15755, 15756, 15757, 15739
6949, 15463, 15471, 15472, 15464, 15757, 15758, 15759, 15741
6950, 15464, 15472, 15473, 15465, 15759, 15760, 15761, 15743
6951, 15465, 15473, 15474, 15466, 15761, 15762, 15763, 15745
6952, 15466, 15474, 15475, 15467, 15763, 15764, 15765, 15747
6953, 15467, 15475, 15476, 15468, 15765, 15766, 15767, 15749
6954, 15468, 15476, 15477, 15469, 15767, 15768, 15769, 15751
6955, 15469, 15477, 2106, 2105, 15769, 15770, 2128, 15753
6956, 2038, 2039, 15478, 15470, 2061, 15771, 15772, 15754
6957, 15470, 15478, 15479, 15471, 15772, 15773, 15774, 15756
6958, 15471, 15479, 15480, 15472, 15774, 15775, 15776, 15758
6959, 15472, 15480, 15481, 15473, 15776, 15777, 15778, 15760
6960, 15473, 15481, 15482, 15474, 15778, 15779, 15780, 15762
6961, 15474, 15482, 15483, 15475, 15780, 15781, 15782, 15764
6962, 15475, 15483, 15484, 15476, 15782, 15783, 15784, 15766
6963, 15476, 15484, 15485, 15477, 15784, 15785, 15786, 15768
6964, 15477, 15485, 2107, 2106, 15786, 15787, 2129, 15770
6965, 2039, 2040, 15486, 15478, 2062, 15788, 15789, 15771
6966, 15478, 15486, 15487, 15479, 15789, 15790, 15791, 15773
6967, 15479, 15487, 15488, 15480, 15791, 15792, 15793, 15775
6968, 15480, 15488, 15489, 15481, 15793, 15794, 15795, 15777
6969, 15481, 15489, 15490, 15482, 15795, 15796, 15797, 15779
6970, 15482, 15490, 15491, 15483, 15797, 15798, 15799, 15781
6971, 15483, 15491, 15492, 15484, 15799, 15800, 15801, 15783
6972, 15484, 15492, 15493, 15485, 15801, 15802, 15803, 15785
6973, 15485, 15493, 2108, 2107, 15803, 15804, 2130, 15787
6974, 2040, 2041, 15494, 15486, 2063, 15805, 15806, 15788
6975, 15486, 15494, 15495, 15487, 15806, 15807, 15808, 15790
6976, 15487, 15495, 15496, 15488, 15808, 15809, 15810, 15792
6977, 15488, 15496, 15497, 15489, 15810, 15811, 15812, 15794
6978, 15489, 15497, 15498, 15490, 15812, 15813, 15814, 15796
6979, 15490, 15498, 15499, 15491, 15814, 15815, 15816, 15798
6980, 15491, 15499, 15500, 15492, 15816, 15817, 15818, 15800
6981, 15492, 15500, 15501, 15493, 15818, 15819, 15820, 15802
6982, 15493, 15501, 2109, 2108, 15820, 15821, 2131, 15804
