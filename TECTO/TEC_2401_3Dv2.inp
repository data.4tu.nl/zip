15261, 0.56521739130435, 1.425, 0.5
15262, 0.52173913043478, 1.425, 0.5
15263, 0.47826086956522, 1.425, 0.5
15264, 0.43478260869565, 1.425, 0.5
15265, 0.39130434782609, 1.425, 0.5
15266, 0.34782608695652, 1.425, 0.5
15267, 0.30434782608696, 1.425, 0.5
15268, 0.26086956521739, 1.425, 0.5
15269, 0.21739130434783, 1.425, 0.5
15270, 0.17391304347826, 1.425, 0.5
15271, 0.1304347826087, 1.425, 0.5
15272, 0.08695652173913, 1.425, 0.5
15273, 0.043478260869565, 1.425, 0.5
15274, 0.97826086956522, 1.425, 0.5
15275, 0.95652173913043, 1.4125, 0.5
15276, 0.93478260869565, 1.425, 0.5
15277, 0.91304347826087, 1.4125, 0.5
15278, 0.89130434782609, 1.425, 0.5
15279, 0.8695652173913, 1.4125, 0.5
15280, 0.84782608695652, 1.425, 0.5
15281, 0.82608695652174, 1.4125, 0.5
15282, 0.80434782608696, 1.425, 0.5
15283, 0.78260869565217, 1.4125, 0.5
15284, 0.76086956521739, 1.425, 0.5
15285, 0.73913043478261, 1.4125, 0.5
15286, 0.71739130434783, 1.425, 0.5
15287, 0.69565217391304, 1.4125, 0.5
15288, 0.67391304347826, 1.425, 0.5
15289, 0.65217391304348, 1.4125, 0.5
15290, 0.6304347826087, 1.425, 0.5
15291, 0.60869565217391, 1.4125, 0.5
15292, 0.58695652173913, 1.425, 0.5
15293, 0.56521739130435, 1.4125, 0.5
15294, 0.54347826086957, 1.425, 0.5
15295, 0.52173913043478, 1.4125, 0.5
15296, 0.5, 1.425, 0.5
15297, 0.47826086956522, 1.4125, 0.5
15298, 0.45652173913043, 1.425, 0.5
15299, 0.43478260869565, 1.4125, 0.5
15300, 0.41304347826087, 1.425, 0.5
15301, 0.39130434782609, 1.4125, 0.5
15302, 0.3695652173913, 1.425, 0.5
15303, 0.34782608695652, 1.4125, 0.5
15304, 0.32608695652174, 1.425, 0.5
15305, 0.30434782608696, 1.4125, 0.5
15306, 0.28260869565217, 1.425, 0.5
15307, 0.26086956521739, 1.4125, 0.5
15308, 0.23913043478261, 1.425, 0.5
15309, 0.21739130434783, 1.4125, 0.5
15310, 0.19565217391304, 1.425, 0.5
15311, 0.17391304347826, 1.4125, 0.5
15312, 0.15217391304348, 1.425, 0.5
15313, 0.1304347826087, 1.4125, 0.5
15314, 0.10869565217391, 1.425, 0.5
15315, 0.08695652173913, 1.4125, 0.5
15316, 0.065217391304348, 1.425, 0.5
15317, 0.043478260869565, 1.4125, 0.5
15318, 0.021739130434783, 1.425, 0.5
15319, 0.95652173913043, 1.4375, 0.5
15320, 0.91304347826087, 1.4375, 0.5
15321, 0.8695652173913, 1.4375, 0.5
15322, 0.82608695652174, 1.4375, 0.5
15323, 0.78260869565217, 1.4375, 0.5
15324, 0.73913043478261, 1.4375, 0.5
15325, 0.69565217391304, 1.4375, 0.5
15326, 0.65217391304348, 1.4375, 0.5
15327, 0.60869565217391, 1.4375, 0.5
15328, 0.56521739130435, 1.4375, 0.5
15329, 0.52173913043478, 1.4375, 0.5
15330, 0.47826086956522, 1.4375, 0.5
15331, 0.43478260869565, 1.4375, 0.5
15332, 0.39130434782609, 1.4375, 0.5
15333, 0.34782608695652, 1.4375, 0.5
15334, 0.30434782608696, 1.4375, 0.5
15335, 0.26086956521739, 1.4375, 0.5
15336, 0.21739130434783, 1.4375, 0.5
15337, 0.17391304347826, 1.4375, 0.5
15338, 0.1304347826087, 1.4375, 0.5
15339, 0.08695652173913, 1.4375, 0.5
15340, 0.043478260869565, 1.4375, 0.5
15341, 0, 1.425, 0.44444444444444
15342, 0, 1.425, 0.38888888888889
15343, 0, 1.425, 0.33333333333333
15344, 0, 1.425, 0.27777777777778
15345, 0, 1.425, 0.22222222222222
15346, 0, 1.425, 0.16666666666667
15347, 0, 1.425, 0.11111111111111
15348, 0, 1.425, 0.055555555555556
15349, 0, 1.425, 0.47222222222222
15350, 0, 1.4125, 0.44444444444444
15351, 0, 1.425, 0.41666666666667
15352, 0, 1.4125, 0.38888888888889
15353, 0, 1.425, 0.36111111111111
15354, 0, 1.4125, 0.33333333333333
15355, 0, 1.425, 0.30555555555556
15356, 0, 1.4125, 0.27777777777778
15357, 0, 1.425, 0.25
15358, 0, 1.4125, 0.22222222222222
15359, 0, 1.425, 0.19444444444444
15360, 0, 1.4125, 0.16666666666667
15361, 0, 1.425, 0.13888888888889
15362, 0, 1.4125, 0.11111111111111
15363, 0, 1.425, 0.083333333333333
15364, 0, 1.4125, 0.055555555555556
15365, 0, 1.425, 0.027777777777778
15366, 0, 1.4375, 0.44444444444444
15367, 0, 1.4375, 0.38888888888889
15368, 0, 1.4375, 0.33333333333333
15369, 0, 1.4375, 0.27777777777778
15370, 0, 1.4375, 0.22222222222222
15371, 0, 1.4375, 0.16666666666667
15372, 0, 1.4375, 0.11111111111111
15373, 0, 1.4375, 0.055555555555556
15374, 0.043478260869565, 1.4, 0.055555555555556
15375, 0.043478260869565, 1.4, 0.11111111111111
15376, 0.043478260869565, 1.4, 0.16666666666667
15377, 0.043478260869565, 1.4, 0.22222222222222
15378, 0.043478260869565, 1.4, 0.27777777777778
15379, 0.043478260869565, 1.4, 0.33333333333333
15380, 0.043478260869565, 1.4, 0.38888888888889
15381, 0.043478260869565, 1.4, 0.44444444444444
15382, 0.08695652173913, 1.4, 0.055555555555556
15383, 0.08695652173913, 1.4, 0.11111111111111
15384, 0.08695652173913, 1.4, 0.16666666666667
15385, 0.08695652173913, 1.4, 0.22222222222222
15386, 0.08695652173913, 1.4, 0.27777777777778
15387, 0.08695652173913, 1.4, 0.33333333333333
15388, 0.08695652173913, 1.4, 0.38888888888889
15389, 0.08695652173913, 1.4, 0.44444444444444
15390, 0.1304347826087, 1.4, 0.055555555555556
15391, 0.1304347826087, 1.4, 0.11111111111111
15392, 0.1304347826087, 1.4, 0.16666666666667
15393, 0.1304347826087, 1.4, 0.22222222222222
15394, 0.1304347826087, 1.4, 0.27777777777778
15395, 0.1304347826087, 1.4, 0.33333333333333
15396, 0.1304347826087, 1.4, 0.38888888888889
15397, 0.1304347826087, 1.4, 0.44444444444444
15398, 0.17391304347826, 1.4, 0.055555555555556
15399, 0.17391304347826, 1.4, 0.11111111111111
15400, 0.17391304347826, 1.4, 0.16666666666667
15401, 0.17391304347826, 1.4, 0.22222222222222
15402, 0.17391304347826, 1.4, 0.27777777777778
15403, 0.17391304347826, 1.4, 0.33333333333333
15404, 0.17391304347826, 1.4, 0.38888888888889
15405, 0.17391304347826, 1.4, 0.44444444444444
15406, 0.21739130434783, 1.4, 0.055555555555556
15407, 0.21739130434783, 1.4, 0.11111111111111
15408, 0.21739130434783, 1.4, 0.16666666666667
15409, 0.21739130434783, 1.4, 0.22222222222222
15410, 0.21739130434783, 1.4, 0.27777777777778
15411, 0.21739130434783, 1.4, 0.33333333333333
15412, 0.21739130434783, 1.4, 0.38888888888889
15413, 0.21739130434783, 1.4, 0.44444444444444
15414, 0.26086956521739, 1.4, 0.055555555555556
15415, 0.26086956521739, 1.4, 0.11111111111111
15416, 0.26086956521739, 1.4, 0.16666666666667
15417, 0.26086956521739, 1.4, 0.22222222222222
15418, 0.26086956521739, 1.4, 0.27777777777778
15419, 0.26086956521739, 1.4, 0.33333333333333
15420, 0.26086956521739, 1.4, 0.38888888888889
15421, 0.26086956521739, 1.4, 0.44444444444444
15422, 0.30434782608696, 1.4, 0.055555555555556
15423, 0.30434782608696, 1.4, 0.11111111111111
15424, 0.30434782608696, 1.4, 0.16666666666667
15425, 0.30434782608696, 1.4, 0.22222222222222
15426, 0.30434782608696, 1.4, 0.27777777777778
15427, 0.30434782608696, 1.4, 0.33333333333333
15428, 0.30434782608696, 1.4, 0.38888888888889
15429, 0.30434782608696, 1.4, 0.44444444444444
15430, 0.34782608695652, 1.4, 0.055555555555556
15431, 0.34782608695652, 1.4, 0.11111111111111
15432, 0.34782608695652, 1.4, 0.16666666666667
15433, 0.34782608695652, 1.4, 0.22222222222222
15434, 0.34782608695652, 1.4, 0.27777777777778
15435, 0.34782608695652, 1.4, 0.33333333333333
15436, 0.34782608695652, 1.4, 0.38888888888889
15437, 0.34782608695652, 1.4, 0.44444444444444
15438, 0.39130434782609, 1.4, 0.055555555555556
15439, 0.39130434782609, 1.4, 0.11111111111111
15440, 0.39130434782609, 1.4, 0.16666666666667
15441, 0.39130434782609, 1.4, 0.22222222222222
15442, 0.39130434782609, 1.4, 0.27777777777778
15443, 0.39130434782609, 1.4, 0.33333333333333
15444, 0.39130434782609, 1.4, 0.38888888888889
15445, 0.39130434782609, 1.4, 0.44444444444444
15446, 0.43478260869565, 1.4, 0.055555555555556
15447, 0.43478260869565, 1.4, 0.11111111111111
15448, 0.43478260869565, 1.4, 0.16666666666667
15449, 0.43478260869565, 1.4, 0.22222222222222
15450, 0.43478260869565, 1.4, 0.27777777777778
15451, 0.43478260869565, 1.4, 0.33333333333333
15452, 0.43478260869565, 1.4, 0.38888888888889
15453, 0.43478260869565, 1.4, 0.44444444444444
15454, 0.47826086956522, 1.4, 0.055555555555556
15455, 0.47826086956522, 1.4, 0.11111111111111
15456, 0.47826086956522, 1.4, 0.16666666666667
15457, 0.47826086956522, 1.4, 0.22222222222222
15458, 0.47826086956522, 1.4, 0.27777777777778
15459, 0.47826086956522, 1.4, 0.33333333333333
15460, 0.47826086956522, 1.4, 0.38888888888889
15461, 0.47826086956522, 1.4, 0.44444444444444
15462, 0.52173913043478, 1.4, 0.055555555555556
15463, 0.52173913043478, 1.4, 0.11111111111111
15464, 0.52173913043478, 1.4, 0.16666666666667
15465, 0.52173913043478, 1.4, 0.22222222222222
15466, 0.52173913043478, 1.4, 0.27777777777778
15467, 0.52173913043478, 1.4, 0.33333333333333
15468, 0.52173913043478, 1.4, 0.38888888888889
15469, 0.52173913043478, 1.4, 0.44444444444444
15470, 0.56521739130435, 1.4, 0.055555555555556
15471, 0.56521739130435, 1.4, 0.11111111111111
15472, 0.56521739130435, 1.4, 0.16666666666667
15473, 0.56521739130435, 1.4, 0.22222222222222
15474, 0.56521739130435, 1.4, 0.27777777777778
15475, 0.56521739130435, 1.4, 0.33333333333333
15476, 0.56521739130435, 1.4, 0.38888888888889
15477, 0.56521739130435, 1.4, 0.44444444444444
15478, 0.60869565217391, 1.4, 0.055555555555556
15479, 0.60869565217391, 1.4, 0.11111111111111
15480, 0.60869565217391, 1.4, 0.16666666666667
15481, 0.60869565217391, 1.4, 0.22222222222222
15482, 0.60869565217391, 1.4, 0.27777777777778
15483, 0.60869565217391, 1.4, 0.33333333333333
15484, 0.60869565217391, 1.4, 0.38888888888889
15485, 0.60869565217391, 1.4, 0.44444444444444
15486, 0.65217391304348, 1.4, 0.055555555555556
15487, 0.65217391304348, 1.4, 0.11111111111111
15488, 0.65217391304348, 1.4, 0.16666666666667
15489, 0.65217391304348, 1.4, 0.22222222222222
15490, 0.65217391304348, 1.4, 0.27777777777778
15491, 0.65217391304348, 1.4, 0.33333333333333
15492, 0.65217391304348, 1.4, 0.38888888888889
15493, 0.65217391304348, 1.4, 0.44444444444444
15494, 0.69565217391304, 1.4, 0.055555555555556
15495, 0.69565217391304, 1.4, 0.11111111111111
15496, 0.69565217391304, 1.4, 0.16666666666667
15497, 0.69565217391304, 1.4, 0.22222222222222
15498, 0.69565217391304, 1.4, 0.27777777777778
15499, 0.69565217391304, 1.4, 0.33333333333333
15500, 0.69565217391304, 1.4, 0.38888888888889
15501, 0.69565217391304, 1.4, 0.44444444444444
15502, 0.73913043478261, 1.4, 0.055555555555556
15503, 0.73913043478261, 1.4, 0.11111111111111
15504, 0.73913043478261, 1.4, 0.16666666666667
15505, 0.73913043478261, 1.4, 0.22222222222222
15506, 0.73913043478261, 1.4, 0.27777777777778
15507, 0.73913043478261, 1.4, 0.33333333333333
15508, 0.73913043478261, 1.4, 0.38888888888889
15509, 0.73913043478261, 1.4, 0.44444444444444
15510, 0.78260869565217, 1.4, 0.055555555555556
15511, 0.78260869565217, 1.4, 0.11111111111111
15512, 0.78260869565217, 1.4, 0.16666666666667
15513, 0.78260869565217, 1.4, 0.22222222222222
15514, 0.78260869565217, 1.4, 0.27777777777778
15515, 0.78260869565217, 1.4, 0.33333333333333
15516, 0.78260869565217, 1.4, 0.38888888888889
15517, 0.78260869565217, 1.4, 0.44444444444444
15518, 0.82608695652174, 1.4, 0.055555555555556
15519, 0.82608695652174, 1.4, 0.11111111111111
15520, 0.82608695652174, 1.4, 0.16666666666667
15521, 0.82608695652174, 1.4, 0.22222222222222
15522, 0.82608695652174, 1.4, 0.27777777777778
15523, 0.82608695652174, 1.4, 0.33333333333333
15524, 0.82608695652174, 1.4, 0.38888888888889
15525, 0.82608695652174, 1.4, 0.44444444444444
15526, 0.8695652173913, 1.4, 0.055555555555556
15527, 0.8695652173913, 1.4, 0.11111111111111
15528, 0.8695652173913, 1.4, 0.16666666666667
15529, 0.8695652173913, 1.4, 0.22222222222222
15530, 0.8695652173913, 1.4, 0.27777777777778
15531, 0.8695652173913, 1.4, 0.33333333333333
15532, 0.8695652173913, 1.4, 0.38888888888889
15533, 0.8695652173913, 1.4, 0.44444444444444
15534, 0.91304347826087, 1.4, 0.055555555555556
15535, 0.91304347826087, 1.4, 0.11111111111111
15536, 0.91304347826087, 1.4, 0.16666666666667
15537, 0.91304347826087, 1.4, 0.22222222222222
15538, 0.91304347826087, 1.4, 0.27777777777778
15539, 0.91304347826087, 1.4, 0.33333333333333
15540, 0.91304347826087, 1.4, 0.38888888888889
15541, 0.91304347826087, 1.4, 0.44444444444444
15542, 0.95652173913043, 1.4, 0.055555555555556
15543, 0.95652173913043, 1.4, 0.11111111111111
15544, 0.95652173913043, 1.4, 0.16666666666667
15545, 0.95652173913043, 1.4, 0.22222222222222
15546, 0.95652173913043, 1.4, 0.27777777777778
15547, 0.95652173913043, 1.4, 0.33333333333333
15548, 0.95652173913043, 1.4, 0.38888888888889
15549, 0.95652173913043, 1.4, 0.44444444444444
15550, 0.043478260869565, 1.4, 0.027777777777778
15551, 0.021739130434783, 1.4, 0.055555555555556
15552, 0.043478260869565, 1.4, 0.083333333333333
15553, 0.021739130434783, 1.4, 0.11111111111111
15554, 0.043478260869565, 1.4, 0.13888888888889
15555, 0.021739130434783, 1.4, 0.16666666666667
15556, 0.043478260869565, 1.4, 0.19444444444444
15557, 0.021739130434783, 1.4, 0.22222222222222
15558, 0.043478260869565, 1.4, 0.25
15559, 0.021739130434783, 1.4, 0.27777777777778
15560, 0.043478260869565, 1.4, 0.30555555555556
15561, 0.021739130434783, 1.4, 0.33333333333333
15562, 0.043478260869565, 1.4, 0.36111111111111
15563, 0.021739130434783, 1.4, 0.38888888888889
15564, 0.043478260869565, 1.4, 0.41666666666667
15565, 0.021739130434783, 1.4, 0.44444444444444
15566, 0.043478260869565, 1.4, 0.47222222222222
15567, 0.08695652173913, 1.4, 0.027777777777778
15568, 0.065217391304348, 1.4, 0.055555555555556
15569, 0.08695652173913, 1.4, 0.083333333333333
15570, 0.065217391304348, 1.4, 0.11111111111111
15571, 0.08695652173913, 1.4, 0.13888888888889
15572, 0.065217391304348, 1.4, 0.16666666666667
15573, 0.08695652173913, 1.4, 0.19444444444444
15574, 0.065217391304348, 1.4, 0.22222222222222
15575, 0.08695652173913, 1.4, 0.25
15576, 0.065217391304348, 1.4, 0.27777777777778
15577, 0.08695652173913, 1.4, 0.30555555555556
15578, 0.065217391304348, 1.4, 0.33333333333333
15579, 0.08695652173913, 1.4, 0.36111111111111
15580, 0.065217391304348, 1.4, 0.38888888888889
15581, 0.08695652173913, 1.4, 0.41666666666667
15582, 0.065217391304348, 1.4, 0.44444444444444
15583, 0.08695652173913, 1.4, 0.47222222222222
15584, 0.1304347826087, 1.4, 0.027777777777778
15585, 0.10869565217391, 1.4, 0.055555555555556
15586, 0.1304347826087, 1.4, 0.083333333333333
15587, 0.10869565217391, 1.4, 0.11111111111111
15588, 0.1304347826087, 1.4, 0.13888888888889
15589, 0.10869565217391, 1.4, 0.16666666666667
15590, 0.1304347826087, 1.4, 0.19444444444444
15591, 0.10869565217391, 1.4, 0.22222222222222
15592, 0.1304347826087, 1.4, 0.25
15593, 0.10869565217391, 1.4, 0.27777777777778
15594, 0.1304347826087, 1.4, 0.30555555555556
15595, 0.10869565217391, 1.4, 0.33333333333333
15596, 0.1304347826087, 1.4, 0.36111111111111
15597, 0.10869565217391, 1.4, 0.38888888888889
15598, 0.1304347826087, 1.4, 0.41666666666667
15599, 0.10869565217391, 1.4, 0.44444444444444
15600, 0.1304347826087, 1.4, 0.47222222222222
15601, 0.17391304347826, 1.4, 0.027777777777778
15602, 0.15217391304348, 1.4, 0.055555555555556
15603, 0.17391304347826, 1.4, 0.083333333333333
15604, 0.15217391304348, 1.4, 0.11111111111111
15605, 0.17391304347826, 1.4, 0.13888888888889
15606, 0.15217391304348, 1.4, 0.16666666666667
15607, 0.17391304347826, 1.4, 0.19444444444444
15608, 0.15217391304348, 1.4, 0.22222222222222
15609, 0.17391304347826, 1.4, 0.25
15610, 0.15217391304348, 1.4, 0.27777777777778
15611, 0.17391304347826, 1.4, 0.30555555555556
15612, 0.15217391304348, 1.4, 0.33333333333333
15613, 0.17391304347826, 1.4, 0.36111111111111
15614, 0.15217391304348, 1.4, 0.38888888888889
15615, 0.17391304347826, 1.4, 0.41666666666667
15616, 0.15217391304348, 1.4, 0.44444444444444
15617, 0.17391304347826, 1.4, 0.47222222222222
15618, 0.21739130434783, 1.4, 0.027777777777778
15619, 0.19565217391304, 1.4, 0.055555555555556
15620, 0.21739130434783, 1.4, 0.083333333333333
15621, 0.19565217391304, 1.4, 0.11111111111111
15622, 0.21739130434783, 1.4, 0.13888888888889
15623, 0.19565217391304, 1.4, 0.16666666666667
15624, 0.21739130434783, 1.4, 0.19444444444444
15625, 0.19565217391304, 1.4, 0.22222222222222
15626, 0.21739130434783, 1.4, 0.25
15627, 0.19565217391304, 1.4, 0.27777777777778
15628, 0.21739130434783, 1.4, 0.30555555555556
15629, 0.19565217391304, 1.4, 0.33333333333333
15630, 0.21739130434783, 1.4, 0.36111111111111
15631, 0.19565217391304, 1.4, 0.38888888888889
15632, 0.21739130434783, 1.4, 0.41666666666667
15633, 0.19565217391304, 1.4, 0.44444444444444
15634, 0.21739130434783, 1.4, 0.47222222222222
15635, 0.26086956521739, 1.4, 0.027777777777778
15636, 0.23913043478261, 1.4, 0.055555555555556
15637, 0.26086956521739, 1.4, 0.083333333333333
15638, 0.23913043478261, 1.4, 0.11111111111111
15639, 0.26086956521739, 1.4, 0.13888888888889
15640, 0.23913043478261, 1.4, 0.16666666666667
15641, 0.26086956521739, 1.4, 0.19444444444444
15642, 0.23913043478261, 1.4, 0.22222222222222
15643, 0.26086956521739, 1.4, 0.25
15644, 0.23913043478261, 1.4, 0.27777777777778
15645, 0.26086956521739, 1.4, 0.30555555555556
15646, 0.23913043478261, 1.4, 0.33333333333333
15647, 0.26086956521739, 1.4, 0.36111111111111
15648, 0.23913043478261, 1.4, 0.38888888888889
15649, 0.26086956521739, 1.4, 0.41666666666667
15650, 0.23913043478261, 1.4, 0.44444444444444
15651, 0.26086956521739, 1.4, 0.47222222222222
15652, 0.30434782608696, 1.4, 0.027777777777778
15653, 0.28260869565217, 1.4, 0.055555555555556
15654, 0.30434782608696, 1.4, 0.083333333333333
15655, 0.28260869565217, 1.4, 0.11111111111111
15656, 0.30434782608696, 1.4, 0.13888888888889
15657, 0.28260869565217, 1.4, 0.16666666666667
15658, 0.30434782608696, 1.4, 0.19444444444444
15659, 0.28260869565217, 1.4, 0.22222222222222
15660, 0.30434782608696, 1.4, 0.25
15661, 0.28260869565217, 1.4, 0.27777777777778
15662, 0.30434782608696, 1.4, 0.30555555555556
15663, 0.28260869565217, 1.4, 0.33333333333333
15664, 0.30434782608696, 1.4, 0.36111111111111
15665, 0.28260869565217, 1.4, 0.38888888888889
15666, 0.30434782608696, 1.4, 0.41666666666667
15667, 0.28260869565217, 1.4, 0.44444444444444
15668, 0.30434782608696, 1.4, 0.47222222222222
15669, 0.34782608695652, 1.4, 0.027777777777778
15670, 0.32608695652174, 1.4, 0.055555555555556
15671, 0.34782608695652, 1.4, 0.083333333333333
15672, 0.32608695652174, 1.4, 0.11111111111111
15673, 0.34782608695652, 1.4, 0.13888888888889
15674, 0.32608695652174, 1.4, 0.16666666666667
15675, 0.34782608695652, 1.4, 0.19444444444444
15676, 0.32608695652174, 1.4, 0.22222222222222
15677, 0.34782608695652, 1.4, 0.25
15678, 0.32608695652174, 1.4, 0.27777777777778
15679, 0.34782608695652, 1.4, 0.30555555555556
15680, 0.32608695652174, 1.4, 0.33333333333333
15681, 0.34782608695652, 1.4, 0.36111111111111
15682, 0.32608695652174, 1.4, 0.38888888888889
15683, 0.34782608695652, 1.4, 0.41666666666667
15684, 0.32608695652174, 1.4, 0.44444444444444
15685, 0.34782608695652, 1.4, 0.47222222222222
15686, 0.39130434782609, 1.4, 0.027777777777778
15687, 0.3695652173913, 1.4, 0.055555555555556
15688, 0.39130434782609, 1.4, 0.083333333333333
15689, 0.3695652173913, 1.4, 0.11111111111111
15690, 0.39130434782609, 1.4, 0.13888888888889
15691, 0.3695652173913, 1.4, 0.16666666666667
15692, 0.39130434782609, 1.4, 0.19444444444444
15693, 0.3695652173913, 1.4, 0.22222222222222
15694, 0.39130434782609, 1.4, 0.25
15695, 0.3695652173913, 1.4, 0.27777777777778
15696, 0.39130434782609, 1.4, 0.30555555555556
15697, 0.3695652173913, 1.4, 0.33333333333333
15698, 0.39130434782609, 1.4, 0.36111111111111
15699, 0.3695652173913, 1.4, 0.38888888888889
15700, 0.39130434782609, 1.4, 0.41666666666667
15701, 0.3695652173913, 1.4, 0.44444444444444
15702, 0.39130434782609, 1.4, 0.47222222222222
15703, 0.43478260869565, 1.4, 0.027777777777778
15704, 0.41304347826087, 1.4, 0.055555555555556
15705, 0.43478260869565, 1.4, 0.083333333333333
15706, 0.41304347826087, 1.4, 0.11111111111111
15707, 0.43478260869565, 1.4, 0.13888888888889
15708, 0.41304347826087, 1.4, 0.16666666666667
15709, 0.43478260869565, 1.4, 0.19444444444444
15710, 0.41304347826087, 1.4, 0.22222222222222
15711, 0.43478260869565, 1.4, 0.25
15712, 0.41304347826087, 1.4, 0.27777777777778
15713, 0.43478260869565, 1.4, 0.30555555555556
15714, 0.41304347826087, 1.4, 0.33333333333333
15715, 0.43478260869565, 1.4, 0.36111111111111
15716, 0.41304347826087, 1.4, 0.38888888888889
15717, 0.43478260869565, 1.4, 0.41666666666667
15718, 0.41304347826087, 1.4, 0.44444444444444
15719, 0.43478260869565, 1.4, 0.47222222222222
15720, 0.47826086956522, 1.4, 0.027777777777778
15721, 0.45652173913043, 1.4, 0.055555555555556
15722, 0.47826086956522, 1.4, 0.083333333333333
15723, 0.45652173913043, 1.4, 0.11111111111111
15724, 0.47826086956522, 1.4, 0.13888888888889
15725, 0.45652173913043, 1.4, 0.16666666666667
15726, 0.47826086956522, 1.4, 0.19444444444444
15727, 0.45652173913043, 1.4, 0.22222222222222
15728, 0.47826086956522, 1.4, 0.25
15729, 0.45652173913043, 1.4, 0.27777777777778
15730, 0.47826086956522, 1.4, 0.30555555555556
15731, 0.45652173913043, 1.4, 0.33333333333333
15732, 0.47826086956522, 1.4, 0.36111111111111
15733, 0.45652173913043, 1.4, 0.38888888888889
15734, 0.47826086956522, 1.4, 0.41666666666667
15735, 0.45652173913043, 1.4, 0.44444444444444
15736, 0.47826086956522, 1.4, 0.47222222222222
15737, 0.52173913043478, 1.4, 0.027777777777778
15738, 0.5, 1.4, 0.055555555555556
15739, 0.52173913043478, 1.4, 0.083333333333333
15740, 0.5, 1.4, 0.11111111111111
15741, 0.52173913043478, 1.4, 0.13888888888889
15742, 0.5, 1.4, 0.16666666666667
15743, 0.52173913043478, 1.4, 0.19444444444444
15744, 0.5, 1.4, 0.22222222222222
15745, 0.52173913043478, 1.4, 0.25
15746, 0.5, 1.4, 0.27777777777778
15747, 0.52173913043478, 1.4, 0.30555555555556
15748, 0.5, 1.4, 0.33333333333333
15749, 0.52173913043478, 1.4, 0.36111111111111
15750, 0.5, 1.4, 0.38888888888889
15751, 0.52173913043478, 1.4, 0.41666666666667
15752, 0.5, 1.4, 0.44444444444444
15753, 0.52173913043478, 1.4, 0.47222222222222
15754, 0.56521739130435, 1.4, 0.027777777777778
15755, 0.54347826086957, 1.4, 0.055555555555556
15756, 0.56521739130435, 1.4, 0.083333333333333
15757, 0.54347826086957, 1.4, 0.11111111111111
15758, 0.56521739130435, 1.4, 0.13888888888889
15759, 0.54347826086957, 1.4, 0.16666666666667
15760, 0.56521739130435, 1.4, 0.19444444444444
15761, 0.54347826086957, 1.4, 0.22222222222222
15762, 0.56521739130435, 1.4, 0.25
15763, 0.54347826086957, 1.4, 0.27777777777778
15764, 0.56521739130435, 1.4, 0.30555555555556
15765, 0.54347826086957, 1.4, 0.33333333333333
15766, 0.56521739130435, 1.4, 0.36111111111111
15767, 0.54347826086957, 1.4, 0.38888888888889
15768, 0.56521739130435, 1.4, 0.41666666666667
15769, 0.54347826086957, 1.4, 0.44444444444444
15770, 0.56521739130435, 1.4, 0.47222222222222
15771, 0.60869565217391, 1.4, 0.027777777777778
15772, 0.58695652173913, 1.4, 0.055555555555556
15773, 0.60869565217391, 1.4, 0.083333333333333
15774, 0.58695652173913, 1.4, 0.11111111111111
15775, 0.60869565217391, 1.4, 0.13888888888889
15776, 0.58695652173913, 1.4, 0.16666666666667
15777, 0.60869565217391, 1.4, 0.19444444444444
15778, 0.58695652173913, 1.4, 0.22222222222222
15779, 0.60869565217391, 1.4, 0.25
15780, 0.58695652173913, 1.4, 0.27777777777778
15781, 0.60869565217391, 1.4, 0.30555555555556
15782, 0.58695652173913, 1.4, 0.33333333333333
15783, 0.60869565217391, 1.4, 0.36111111111111
15784, 0.58695652173913, 1.4, 0.38888888888889
15785, 0.60869565217391, 1.4, 0.41666666666667
15786, 0.58695652173913, 1.4, 0.44444444444444
15787, 0.60869565217391, 1.4, 0.47222222222222
15788, 0.65217391304348, 1.4, 0.027777777777778
15789, 0.6304347826087, 1.4, 0.055555555555556
15790, 0.65217391304348, 1.4, 0.083333333333333
15791, 0.6304347826087, 1.4, 0.11111111111111
15792, 0.65217391304348, 1.4, 0.13888888888889
15793, 0.6304347826087, 1.4, 0.16666666666667
15794, 0.65217391304348, 1.4, 0.19444444444444
15795, 0.6304347826087, 1.4, 0.22222222222222
15796, 0.65217391304348, 1.4, 0.25
15797, 0.6304347826087, 1.4, 0.27777777777778
15798, 0.65217391304348, 1.4, 0.30555555555556
15799, 0.6304347826087, 1.4, 0.33333333333333
15800, 0.65217391304348, 1.4, 0.36111111111111
15801, 0.6304347826087, 1.4, 0.38888888888889
15802, 0.65217391304348, 1.4, 0.41666666666667
15803, 0.6304347826087, 1.4, 0.44444444444444
15804, 0.65217391304348, 1.4, 0.47222222222222
15805, 0.69565217391304, 1.4, 0.027777777777778
15806, 0.67391304347826, 1.4, 0.055555555555556
15807, 0.69565217391304, 1.4, 0.083333333333333
15808, 0.67391304347826, 1.4, 0.11111111111111
15809, 0.69565217391304, 1.4, 0.13888888888889
15810, 0.67391304347826, 1.4, 0.16666666666667
15811, 0.69565217391304, 1.4, 0.19444444444444
15812, 0.67391304347826, 1.4, 0.22222222222222
15813, 0.69565217391304, 1.4, 0.25
15814, 0.67391304347826, 1.4, 0.27777777777778
15815, 0.69565217391304, 1.4, 0.30555555555556
15816, 0.67391304347826, 1.4, 0.33333333333333
15817, 0.69565217391304, 1.4, 0.36111111111111
15818, 0.67391304347826, 1.4, 0.38888888888889
15819, 0.69565217391304, 1.4, 0.41666666666667
15820, 0.67391304347826, 1.4, 0.44444444444444
15821, 0.69565217391304, 1.4, 0.47222222222222
15822, 0.73913043478261, 1.4, 0.027777777777778
15823, 0.71739130434783, 1.4, 0.055555555555556
15824, 0.73913043478261, 1.4, 0.083333333333333
15825, 0.71739130434783, 1.4, 0.11111111111111
15826, 0.73913043478261, 1.4, 0.13888888888889
15827, 0.71739130434783, 1.4, 0.16666666666667
15828, 0.73913043478261, 1.4, 0.19444444444444
15829, 0.71739130434783, 1.4, 0.22222222222222
15830, 0.73913043478261, 1.4, 0.25
15831, 0.71739130434783, 1.4, 0.27777777777778
15832, 0.73913043478261, 1.4, 0.30555555555556
15833, 0.71739130434783, 1.4, 0.33333333333333
15834, 0.73913043478261, 1.4, 0.36111111111111
15835, 0.71739130434783, 1.4, 0.38888888888889
15836, 0.73913043478261, 1.4, 0.41666666666667
15837, 0.71739130434783, 1.4, 0.44444444444444
15838, 0.73913043478261, 1.4, 0.47222222222222
15839, 0.78260869565217, 1.4, 0.027777777777778
15840, 0.76086956521739, 1.4, 0.055555555555556
15841, 0.78260869565217, 1.4, 0.083333333333333
15842, 0.76086956521739, 1.4, 0.11111111111111
15843, 0.78260869565217, 1.4, 0.13888888888889
15844, 0.76086956521739, 1.4, 0.16666666666667
15845, 0.78260869565217, 1.4, 0.19444444444444
15846, 0.76086956521739, 1.4, 0.22222222222222
15847, 0.78260869565217, 1.4, 0.25
15848, 0.76086956521739, 1.4, 0.27777777777778
15849, 0.78260869565217, 1.4, 0.30555555555556
15850, 0.76086956521739, 1.4, 0.33333333333333
15851, 0.78260869565217, 1.4, 0.36111111111111
15852, 0.76086956521739, 1.4, 0.38888888888889
15853, 0.78260869565217, 1.4, 0.41666666666667
15854, 0.76086956521739, 1.4, 0.44444444444444
15855, 0.78260869565217, 1.4, 0.47222222222222
15856, 0.82608695652174, 1.4, 0.027777777777778
15857, 0.80434782608696, 1.4, 0.055555555555556
15858, 0.82608695652174, 1.4, 0.083333333333333
15859, 0.80434782608696, 1.4, 0.11111111111111
15860, 0.82608695652174, 1.4, 0.13888888888889
15861, 0.80434782608696, 1.4, 0.16666666666667
15862, 0.82608695652174, 1.4, 0.19444444444444
15863, 0.80434782608696, 1.4, 0.22222222222222
15864, 0.82608695652174, 1.4, 0.25
15865, 0.80434782608696, 1.4, 0.27777777777778
15866, 0.82608695652174, 1.4, 0.30555555555556
15867, 0.80434782608696, 1.4, 0.33333333333333
15868, 0.82608695652174, 1.4, 0.36111111111111
15869, 0.80434782608696, 1.4, 0.38888888888889
15870, 0.82608695652174, 1.4, 0.41666666666667
15871, 0.80434782608696, 1.4, 0.44444444444444
15872, 0.82608695652174, 1.4, 0.47222222222222
15873, 0.8695652173913, 1.4, 0.027777777777778
15874, 0.84782608695652, 1.4, 0.055555555555556
15875, 0.8695652173913, 1.4, 0.083333333333333
15876, 0.84782608695652, 1.4, 0.11111111111111
15877, 0.8695652173913, 1.4, 0.13888888888889
15878, 0.84782608695652, 1.4, 0.16666666666667
15879, 0.8695652173913, 1.4, 0.19444444444444
15880, 0.84782608695652, 1.4, 0.22222222222222
15881, 0.8695652173913, 1.4, 0.25
15882, 0.84782608695652, 1.4, 0.27777777777778
15883, 0.8695652173913, 1.4, 0.30555555555556
15884, 0.84782608695652, 1.4, 0.33333333333333
15885, 0.8695652173913, 1.4, 0.36111111111111
15886, 0.84782608695652, 1.4, 0.38888888888889
15887, 0.8695652173913, 1.4, 0.41666666666667
15888, 0.84782608695652, 1.4, 0.44444444444444
15889, 0.8695652173913, 1.4, 0.47222222222222
15890, 0.91304347826087, 1.4, 0.027777777777778
15891, 0.89130434782609, 1.4, 0.055555555555556
15892, 0.91304347826087, 1.4, 0.083333333333333
15893, 0.89130434782609, 1.4, 0.11111111111111
15894, 0.91304347826087, 1.4, 0.13888888888889
15895, 0.89130434782609, 1.4, 0.16666666666667
15896, 0.91304347826087, 1.4, 0.19444444444444
15897, 0.89130434782609, 1.4, 0.22222222222222
15898, 0.91304347826087, 1.4, 0.25
15899, 0.89130434782609, 1.4, 0.27777777777778
15900, 0.91304347826087, 1.4, 0.30555555555556
15901, 0.89130434782609, 1.4, 0.33333333333333
15902, 0.91304347826087, 1.4, 0.36111111111111
15903, 0.89130434782609, 1.4, 0.38888888888889
15904, 0.91304347826087, 1.4, 0.41666666666667
15905, 0.89130434782609, 1.4, 0.44444444444444
15906, 0.91304347826087, 1.4, 0.47222222222222
15907, 0.95652173913043, 1.4, 0.027777777777778
15908, 0.93478260869565, 1.4, 0.055555555555556
15909, 0.95652173913043, 1.4, 0.083333333333333
15910, 0.93478260869565, 1.4, 0.11111111111111
15911, 0.95652173913043, 1.4, 0.13888888888889
15912, 0.93478260869565, 1.4, 0.16666666666667
15913, 0.95652173913043, 1.4, 0.19444444444444
15914, 0.93478260869565, 1.4, 0.22222222222222
15915, 0.95652173913043, 1.4, 0.25
15916, 0.93478260869565, 1.4, 0.27777777777778
15917, 0.95652173913043, 1.4, 0.30555555555556
15918, 0.93478260869565, 1.4, 0.33333333333333
15919, 0.95652173913043, 1.4, 0.36111111111111
15920, 0.93478260869565, 1.4, 0.38888888888889
15921, 0.95652173913043, 1.4, 0.41666666666667
15922, 0.93478260869565, 1.4, 0.44444444444444
15923, 0.95652173913043, 1.4, 0.47222222222222
15924, 0.97826086956522, 1.4, 0.055555555555556
15925, 0.97826086956522, 1.4, 0.11111111111111
15926, 0.97826086956522, 1.4, 0.16666666666667
15927, 0.97826086956522, 1.4, 0.22222222222222
15928, 0.97826086956522, 1.4, 0.27777777777778
15929, 0.97826086956522, 1.4, 0.33333333333333
15930, 0.97826086956522, 1.4, 0.38888888888889
15931, 0.97826086956522, 1.4, 0.44444444444444
15932, 1.2434782608696, 1.425, 0.5
15933, 1.2869565217391, 1.425, 0.5
15934, 1.3304347826087, 1.425, 0.5
15935, 1.3739130434783, 1.425, 0.5
15936, 1.4173913043478, 1.425, 0.5
15937, 1.4608695652174, 1.425, 0.5
15938, 1.504347826087, 1.425, 0.5
15939, 1.5478260869565, 1.425, 0.5
15940, 1.5913043478261, 1.425, 0.5
15941, 1.6347826086957, 1.425, 0.5
15942, 1.6782608695652, 1.425, 0.5
15943, 1.7217391304348, 1.425, 0.5
15944, 1.7652173913043, 1.425, 0.5
15945, 1.8086956521739, 1.425, 0.5
15946, 1.8521739130435, 1.425, 0.5
15947, 1.895652173913, 1.425, 0.5
15948, 1.9391304347826, 1.425, 0.5
15949, 1.9826086956522, 1.425, 0.5
15950, 2.0260869565217, 1.425, 0.5
15951, 2.0695652173913, 1.425, 0.5
15952, 2.1130434782609, 1.425, 0.5
15953, 2.1565217391304, 1.425, 0.5
15954, 1.2217391304348, 1.425, 0.5
15955, 1.2434782608696, 1.4375, 0.5
15956, 1.2652173913043, 1.425, 0.5
15957, 1.2869565217391, 1.4375, 0.5
15958, 1.3086956521739, 1.425, 0.5
15959, 1.3304347826087, 1.4375, 0.5
15960, 1.3521739130435, 1.425, 0.5
15961, 1.3739130434783, 1.4375, 0.5
15962, 1.395652173913, 1.425, 0.5
15963, 1.4173913043478, 1.4375, 0.5
15964, 1.4391304347826, 1.425, 0.5
15965, 1.4608695652174, 1.4375, 0.5
15966, 1.4826086956522, 1.425, 0.5
15967, 1.504347826087, 1.4375, 0.5
15968, 1.5260869565217, 1.425, 0.5
15969, 1.5478260869565, 1.4375, 0.5
15970, 1.5695652173913, 1.425, 0.5
15971, 1.5913043478261, 1.4375, 0.5
15972, 1.6130434782609, 1.425, 0.5
15973, 1.6347826086957, 1.4375, 0.5
15974, 1.6565217391304, 1.425, 0.5
15975, 1.6782608695652, 1.4375, 0.5
15976, 1.7, 1.425, 0.5
15977, 1.7217391304348, 1.4375, 0.5
15978, 1.7434782608696, 1.425, 0.5
15979, 1.7652173913043, 1.4375, 0.5
15980, 1.7869565217391, 1.425, 0.5
15981, 1.8086956521739, 1.4375, 0.5
15982, 1.8304347826087, 1.425, 0.5
15983, 1.8521739130435, 1.4375, 0.5
15984, 1.8739130434783, 1.425, 0.5
15985, 1.895652173913, 1.4375, 0.5
15986, 1.9173913043478, 1.425, 0.5
15987, 1.9391304347826, 1.4375, 0.5
15988, 1.9608695652174, 1.425, 0.5
15989, 1.9826086956522, 1.4375, 0.5
15990, 2.004347826087, 1.425, 0.5
15991, 2.0260869565217, 1.4375, 0.5
15992, 2.0478260869565, 1.425, 0.5
15993, 2.0695652173913, 1.4375, 0.5
15994, 2.0913043478261, 1.425, 0.5
15995, 2.1130434782609, 1.4375, 0.5
15996, 2.1347826086957, 1.425, 0.5
15997, 2.1565217391304, 1.4375, 0.5
15998, 2.1782608695652, 1.425, 0.5
15999, 1.2434782608696, 1.4125, 0.5
16000, 1.2869565217391, 1.4125, 0.5
16001, 1.3304347826087, 1.4125, 0.5
16002, 1.3739130434783, 1.4125, 0.5
16003, 1.4173913043478, 1.4125, 0.5
16004, 1.4608695652174, 1.4125, 0.5
16005, 1.504347826087, 1.4125, 0.5
16006, 1.5478260869565, 1.4125, 0.5
16007, 1.5913043478261, 1.4125, 0.5
16008, 1.6347826086957, 1.4125, 0.5
16009, 1.6782608695652, 1.4125, 0.5
16010, 1.7217391304348, 1.4125, 0.5
16011, 1.7652173913043, 1.4125, 0.5
16012, 1.8086956521739, 1.4125, 0.5
16013, 1.8521739130435, 1.4125, 0.5
16014, 1.895652173913, 1.4125, 0.5
16015, 1.9391304347826, 1.4125, 0.5
16016, 1.9826086956522, 1.4125, 0.5
16017, 2.0260869565217, 1.4125, 0.5
16018, 2.0695652173913, 1.4125, 0.5
16019, 2.1130434782609, 1.4125, 0.5
16020, 2.1565217391304, 1.4125, 0.5
16021, 1.2434782608696, 1.425, 0
16022, 1.2869565217391, 1.425, 0
16023, 1.3304347826087, 1.425, 0
16024, 1.3739130434783, 1.425, 0
16025, 1.4173913043478, 1.425, 0
16026, 1.4608695652174, 1.425, 0
16027, 1.504347826087, 1.425, 0
16028, 1.5478260869565, 1.425, 0
16029, 1.5913043478261, 1.425, 0
16030, 1.6347826086957, 1.425, 0
16031, 1.6782608695652, 1.425, 0
16032, 1.7217391304348, 1.425, 0
16033, 1.7652173913043, 1.425, 0
16034, 1.8086956521739, 1.425, 0
16035, 1.8521739130435, 1.425, 0
16036, 1.895652173913, 1.425, 0
16037, 1.9391304347826, 1.425, 0
16038, 1.9826086956522, 1.425, 0
16039, 2.0260869565217, 1.425, 0
16040, 2.0695652173913, 1.425, 0
16041, 2.1130434782609, 1.425, 0
16042, 2.1565217391304, 1.425, 0
16043, 1.2434782608696, 1.4375, 0
16044, 1.2217391304348, 1.425, 0
16045, 1.2869565217391, 1.4375, 0
16046, 1.2652173913043, 1.425, 0
16047, 1.3304347826087, 1.4375, 0
16048, 1.3086956521739, 1.425, 0
16049, 1.3739130434783, 1.4375, 0
16050, 1.3521739130435, 1.425, 0
16051, 1.4173913043478, 1.4375, 0
16052, 1.395652173913, 1.425, 0
16053, 1.4608695652174, 1.4375, 0
16054, 1.4391304347826, 1.425, 0
16055, 1.504347826087, 1.4375, 0
16056, 1.4826086956522, 1.425, 0
16057, 1.5478260869565, 1.4375, 0
16058, 1.5260869565217, 1.425, 0
16059, 1.5913043478261, 1.4375, 0
16060, 1.5695652173913, 1.425, 0
16061, 1.6347826086957, 1.4375, 0
16062, 1.6130434782609, 1.425, 0
16063, 1.6782608695652, 1.4375, 0
16064, 1.6565217391304, 1.425, 0
16065, 1.7217391304348, 1.4375, 0
16066, 1.7, 1.425, 0
16067, 1.7652173913043, 1.4375, 0
16068, 1.7434782608696, 1.425, 0
16069, 1.8086956521739, 1.4375, 0
16070, 1.7869565217391, 1.425, 0
16071, 1.8521739130435, 1.4375, 0
16072, 1.8304347826087, 1.425, 0
16073, 1.895652173913, 1.4375, 0
16074, 1.8739130434783, 1.425, 0
16075, 1.9391304347826, 1.4375, 0
16076, 1.9173913043478, 1.425, 0
16077, 1.9826086956522, 1.4375, 0
16078, 1.9608695652174, 1.425, 0
16079, 2.0260869565217, 1.4375, 0
16080, 2.004347826087, 1.425, 0
16081, 2.0695652173913, 1.4375, 0
16082, 2.0478260869565, 1.425, 0
16083, 2.1130434782609, 1.4375, 0
16084, 2.0913043478261, 1.425, 0
16085, 2.1565217391304, 1.4375, 0
16086, 2.1347826086957, 1.425, 0
16087, 2.1782608695652, 1.425, 0
16088, 1.2434782608696, 1.4125, 0
16089, 1.2869565217391, 1.4125, 0
16090, 1.3304347826087, 1.4125, 0
16091, 1.3739130434783, 1.4125, 0
16092, 1.4173913043478, 1.4125, 0
16093, 1.4608695652174, 1.4125, 0
16094, 1.504347826087, 1.4125, 0
16095, 1.5478260869565, 1.4125, 0
16096, 1.5913043478261, 1.4125, 0
16097, 1.6347826086957, 1.4125, 0
16098, 1.6782608695652, 1.4125, 0
16099, 1.7217391304348, 1.4125, 0
16100, 1.7652173913043, 1.4125, 0
16101, 1.8086956521739, 1.4125, 0
16102, 1.8521739130435, 1.4125, 0
16103, 1.895652173913, 1.4125, 0
16104, 1.9391304347826, 1.4125, 0
16105, 1.9826086956522, 1.4125, 0
16106, 2.0260869565217, 1.4125, 0
16107, 2.0695652173913, 1.4125, 0
16108, 2.1130434782609, 1.4125, 0
16109, 2.1565217391304, 1.4125, 0
16110, 1.2, 1.425, 0.44444444444444
16111, 1.2, 1.425, 0.38888888888889
16112, 1.2, 1.425, 0.33333333333333
16113, 1.2, 1.425, 0.27777777777778
16114, 1.2, 1.425, 0.22222222222222
16115, 1.2, 1.425, 0.16666666666667
16116, 1.2, 1.425, 0.11111111111111
16117, 1.2, 1.425, 0.055555555555556
16118, 1.2, 1.4375, 0.44444444444444
16119, 1.2, 1.425, 0.47222222222222
16120, 1.2, 1.4375, 0.38888888888889
16121, 1.2, 1.425, 0.41666666666667
16122, 1.2, 1.4375, 0.33333333333333
16123, 1.2, 1.425, 0.36111111111111
16124, 1.2, 1.4375, 0.27777777777778
16125, 1.2, 1.425, 0.30555555555556
16126, 1.2, 1.4375, 0.22222222222222
16127, 1.2, 1.425, 0.25
16128, 1.2, 1.4375, 0.16666666666667
16129, 1.2, 1.425, 0.19444444444444
16130, 1.2, 1.4375, 0.11111111111111
16131, 1.2, 1.425, 0.13888888888889
16132, 1.2, 1.4375, 0.055555555555556
16133, 1.2, 1.425, 0.083333333333333
16134, 1.2, 1.425, 0.027777777777778
16135, 1.2, 1.4125, 0.44444444444444
16136, 1.2, 1.4125, 0.38888888888889
16137, 1.2, 1.4125, 0.33333333333333
16138, 1.2, 1.4125, 0.27777777777778
16139, 1.2, 1.4125, 0.22222222222222
16140, 1.2, 1.4125, 0.16666666666667
16141, 1.2, 1.4125, 0.11111111111111
16142, 1.2, 1.4125, 0.055555555555556
16143, 2.2, 1.425, 0.44444444444444
16144, 2.2, 1.425, 0.38888888888889
16145, 2.2, 1.425, 0.33333333333333
16146, 2.2, 1.425, 0.27777777777778
16147, 2.2, 1.425, 0.22222222222222
16148, 2.2, 1.425, 0.16666666666667
16149, 2.2, 1.425, 0.11111111111111
16150, 2.2, 1.425, 0.055555555555556
16151, 2.2, 1.425, 0.47222222222222
16152, 2.2, 1.4375, 0.44444444444444
16153, 2.2, 1.425, 0.41666666666667
16154, 2.2, 1.4375, 0.38888888888889
16155, 2.2, 1.425, 0.36111111111111
16156, 2.2, 1.4375, 0.33333333333333
16157, 2.2, 1.425, 0.30555555555556
16158, 2.2, 1.4375, 0.27777777777778
16159, 2.2, 1.425, 0.25
16160, 2.2, 1.4375, 0.22222222222222
16161, 2.2, 1.425, 0.19444444444444
16162, 2.2, 1.4375, 0.16666666666667
16163, 2.2, 1.425, 0.13888888888889
16164, 2.2, 1.4375, 0.11111111111111
16165, 2.2, 1.425, 0.083333333333333
16166, 2.2, 1.4375, 0.055555555555556
16167, 2.2, 1.425, 0.027777777777778
16168, 2.2, 1.4125, 0.44444444444444
16169, 2.2, 1.4125, 0.38888888888889
16170, 2.2, 1.4125, 0.33333333333333
16171, 2.2, 1.4125, 0.27777777777778
16172, 2.2, 1.4125, 0.22222222222222
16173, 2.2, 1.4125, 0.16666666666667
16174, 2.2, 1.4125, 0.11111111111111
16175, 2.2, 1.4125, 0.055555555555556
16176, 1.2434782608696, 1.45, 0.44444444444444
16177, 1.2434782608696, 1.45, 0.38888888888889
16178, 1.2434782608696, 1.45, 0.33333333333333
16179, 1.2434782608696, 1.45, 0.27777777777778
16180, 1.2434782608696, 1.45, 0.22222222222222
16181, 1.2434782608696, 1.45, 0.16666666666667
16182, 1.2434782608696, 1.45, 0.11111111111111
16183, 1.2434782608696, 1.45, 0.055555555555556
16184, 1.2869565217391, 1.45, 0.44444444444444
16185, 1.2869565217391, 1.45, 0.38888888888889
16186, 1.2869565217391, 1.45, 0.33333333333333
16187, 1.2869565217391, 1.45, 0.27777777777778
16188, 1.2869565217391, 1.45, 0.22222222222222
16189, 1.2869565217391, 1.45, 0.16666666666667
16190, 1.2869565217391, 1.45, 0.11111111111111
16191, 1.2869565217391, 1.45, 0.055555555555556
16192, 1.3304347826087, 1.45, 0.44444444444444
16193, 1.3304347826087, 1.45, 0.38888888888889
16194, 1.3304347826087, 1.45, 0.33333333333333
16195, 1.3304347826087, 1.45, 0.27777777777778
16196, 1.3304347826087, 1.45, 0.22222222222222
16197, 1.3304347826087, 1.45, 0.16666666666667
16198, 1.3304347826087, 1.45, 0.11111111111111
16199, 1.3304347826087, 1.45, 0.055555555555556
16200, 1.3739130434783, 1.45, 0.44444444444444
16201, 1.3739130434783, 1.45, 0.38888888888889
16202, 1.3739130434783, 1.45, 0.33333333333333
16203, 1.3739130434783, 1.45, 0.27777777777778
16204, 1.3739130434783, 1.45, 0.22222222222222
16205, 1.3739130434783, 1.45, 0.16666666666667
16206, 1.3739130434783, 1.45, 0.11111111111111
16207, 1.3739130434783, 1.45, 0.055555555555556
16208, 1.4173913043478, 1.45, 0.44444444444444
16209, 1.4173913043478, 1.45, 0.38888888888889
16210, 1.4173913043478, 1.45, 0.33333333333333
16211, 1.4173913043478, 1.45, 0.27777777777778
16212, 1.4173913043478, 1.45, 0.22222222222222
16213, 1.4173913043478, 1.45, 0.16666666666667
16214, 1.4173913043478, 1.45, 0.11111111111111
16215, 1.4173913043478, 1.45, 0.055555555555556
16216, 1.4608695652174, 1.45, 0.44444444444444
16217, 1.4608695652174, 1.45, 0.38888888888889
16218, 1.4608695652174, 1.45, 0.33333333333333
16219, 1.4608695652174, 1.45, 0.27777777777778
16220, 1.4608695652174, 1.45, 0.22222222222222
16221, 1.4608695652174, 1.45, 0.16666666666667
16222, 1.4608695652174, 1.45, 0.11111111111111
16223, 1.4608695652174, 1.45, 0.055555555555556
16224, 1.504347826087, 1.45, 0.44444444444444
16225, 1.504347826087, 1.45, 0.38888888888889
16226, 1.504347826087, 1.45, 0.33333333333333
16227, 1.504347826087, 1.45, 0.27777777777778
16228, 1.504347826087, 1.45, 0.22222222222222
16229, 1.504347826087, 1.45, 0.16666666666667
16230, 1.504347826087, 1.45, 0.11111111111111
16231, 1.504347826087, 1.45, 0.055555555555556
16232, 1.5478260869565, 1.45, 0.44444444444444
16233, 1.5478260869565, 1.45, 0.38888888888889
16234, 1.5478260869565, 1.45, 0.33333333333333
16235, 1.5478260869565, 1.45, 0.27777777777778
16236, 1.5478260869565, 1.45, 0.22222222222222
16237, 1.5478260869565, 1.45, 0.16666666666667
16238, 1.5478260869565, 1.45, 0.11111111111111
16239, 1.5478260869565, 1.45, 0.055555555555556
16240, 1.5913043478261, 1.45, 0.44444444444444
16241, 1.5913043478261, 1.45, 0.38888888888889
16242, 1.5913043478261, 1.45, 0.33333333333333
16243, 1.5913043478261, 1.45, 0.27777777777778
16244, 1.5913043478261, 1.45, 0.22222222222222
16245, 1.5913043478261, 1.45, 0.16666666666667
16246, 1.5913043478261, 1.45, 0.11111111111111
16247, 1.5913043478261, 1.45, 0.055555555555556
16248, 1.6347826086957, 1.45, 0.44444444444444
16249, 1.6347826086957, 1.45, 0.38888888888889
16250, 1.6347826086957, 1.45, 0.33333333333333
16251, 1.6347826086957, 1.45, 0.27777777777778
16252, 1.6347826086957, 1.45, 0.22222222222222
16253, 1.6347826086957, 1.45, 0.16666666666667
16254, 1.6347826086957, 1.45, 0.11111111111111
16255, 1.6347826086957, 1.45, 0.055555555555556
16256, 1.6782608695652, 1.45, 0.44444444444444
16257, 1.6782608695652, 1.45, 0.38888888888889
16258, 1.6782608695652, 1.45, 0.33333333333333
16259, 1.6782608695652, 1.45, 0.27777777777778
16260, 1.6782608695652, 1.45, 0.22222222222222
16261, 1.6782608695652, 1.45, 0.16666666666667
16262, 1.6782608695652, 1.45, 0.11111111111111
16263, 1.6782608695652, 1.45, 0.055555555555556
16264, 1.7217391304348, 1.45, 0.44444444444444
16265, 1.7217391304348, 1.45, 0.38888888888889
16266, 1.7217391304348, 1.45, 0.33333333333333
16267, 1.7217391304348, 1.45, 0.27777777777778
16268, 1.7217391304348, 1.45, 0.22222222222222
16269, 1.7217391304348, 1.45, 0.16666666666667
16270, 1.7217391304348, 1.45, 0.11111111111111
16271, 1.7217391304348, 1.45, 0.055555555555556
16272, 1.7652173913043, 1.45, 0.44444444444444
16273, 1.7652173913043, 1.45, 0.38888888888889
16274, 1.7652173913043, 1.45, 0.33333333333333
16275, 1.7652173913043, 1.45, 0.27777777777778
16276, 1.7652173913043, 1.45, 0.22222222222222
16277, 1.7652173913043, 1.45, 0.16666666666667
16278, 1.7652173913043, 1.45, 0.11111111111111
16279, 1.7652173913043, 1.45, 0.055555555555556
16280, 1.8086956521739, 1.45, 0.44444444444444
16281, 1.8086956521739, 1.45, 0.38888888888889
16282, 1.8086956521739, 1.45, 0.33333333333333
16283, 1.8086956521739, 1.45, 0.27777777777778
16284, 1.8086956521739, 1.45, 0.22222222222222
16285, 1.8086956521739, 1.45, 0.16666666666667
16286, 1.8086956521739, 1.45, 0.11111111111111
16287, 1.8086956521739, 1.45, 0.055555555555556
16288, 1.8521739130435, 1.45, 0.44444444444444
16289, 1.8521739130435, 1.45, 0.38888888888889
16290, 1.8521739130435, 1.45, 0.33333333333333
16291, 1.8521739130435, 1.45, 0.27777777777778
16292, 1.8521739130435, 1.45, 0.22222222222222
16293, 1.8521739130435, 1.45, 0.16666666666667
16294, 1.8521739130435, 1.45, 0.11111111111111
16295, 1.8521739130435, 1.45, 0.055555555555556
16296, 1.895652173913, 1.45, 0.44444444444444
16297, 1.895652173913, 1.45, 0.38888888888889
16298, 1.895652173913, 1.45, 0.33333333333333
16299, 1.895652173913, 1.45, 0.27777777777778
16300, 1.895652173913, 1.45, 0.22222222222222
16301, 1.895652173913, 1.45, 0.16666666666667
16302, 1.895652173913, 1.45, 0.11111111111111
16303, 1.895652173913, 1.45, 0.055555555555556
16304, 1.9391304347826, 1.45, 0.44444444444444
16305, 1.9391304347826, 1.45, 0.38888888888889
16306, 1.9391304347826, 1.45, 0.33333333333333
16307, 1.9391304347826, 1.45, 0.27777777777778
16308, 1.9391304347826, 1.45, 0.22222222222222
16309, 1.9391304347826, 1.45, 0.16666666666667
16310, 1.9391304347826, 1.45, 0.11111111111111
16311, 1.9391304347826, 1.45, 0.055555555555556
16312, 1.9826086956522, 1.45, 0.44444444444444
16313, 1.9826086956522, 1.45, 0.38888888888889
16314, 1.9826086956522, 1.45, 0.33333333333333
16315, 1.9826086956522, 1.45, 0.27777777777778
16316, 1.9826086956522, 1.45, 0.22222222222222
16317, 1.9826086956522, 1.45, 0.16666666666667
16318, 1.9826086956522, 1.45, 0.11111111111111
16319, 1.9826086956522, 1.45, 0.055555555555556
16320, 2.0260869565217, 1.45, 0.44444444444444
16321, 2.0260869565217, 1.45, 0.38888888888889
16322, 2.0260869565217, 1.45, 0.33333333333333
16323, 2.0260869565217, 1.45, 0.27777777777778
16324, 2.0260869565217, 1.45, 0.22222222222222
16325, 2.0260869565217, 1.45, 0.16666666666667
16326, 2.0260869565217, 1.45, 0.11111111111111
16327, 2.0260869565217, 1.45, 0.055555555555556
16328, 2.0695652173913, 1.45, 0.44444444444444
16329, 2.0695652173913, 1.45, 0.38888888888889
16330, 2.0695652173913, 1.45, 0.33333333333333
16331, 2.0695652173913, 1.45, 0.27777777777778
16332, 2.0695652173913, 1.45, 0.22222222222222
16333, 2.0695652173913, 1.45, 0.16666666666667
16334, 2.0695652173913, 1.45, 0.11111111111111
16335, 2.0695652173913, 1.45, 0.055555555555556
16336, 2.1130434782609, 1.45, 0.44444444444444
16337, 2.1130434782609, 1.45, 0.38888888888889
16338, 2.1130434782609, 1.45, 0.33333333333333
16339, 2.1130434782609, 1.45, 0.27777777777778
16340, 2.1130434782609, 1.45, 0.22222222222222
16341, 2.1130434782609, 1.45, 0.16666666666667
16342, 2.1130434782609, 1.45, 0.11111111111111
16343, 2.1130434782609, 1.45, 0.055555555555556
16344, 2.1565217391304, 1.45, 0.44444444444444
16345, 2.1565217391304, 1.45, 0.38888888888889
16346, 2.1565217391304, 1.45, 0.33333333333333
16347, 2.1565217391304, 1.45, 0.27777777777778
16348, 2.1565217391304, 1.45, 0.22222222222222
16349, 2.1565217391304, 1.45, 0.16666666666667
16350, 2.1565217391304, 1.45, 0.11111111111111
16351, 2.1565217391304, 1.45, 0.055555555555556
16352, 1.2434782608696, 1.45, 0.47222222222222
16353, 1.2217391304348, 1.45, 0.44444444444444
16354, 1.2434782608696, 1.45, 0.41666666666667
16355, 1.2217391304348, 1.45, 0.38888888888889
16356, 1.2434782608696, 1.45, 0.36111111111111
16357, 1.2217391304348, 1.45, 0.33333333333333
16358, 1.2434782608696, 1.45, 0.30555555555556
16359, 1.2217391304348, 1.45, 0.27777777777778
16360, 1.2434782608696, 1.45, 0.25
16361, 1.2217391304348, 1.45, 0.22222222222222
16362, 1.2434782608696, 1.45, 0.19444444444444
16363, 1.2217391304348, 1.45, 0.16666666666667
16364, 1.2434782608696, 1.45, 0.13888888888889
16365, 1.2217391304348, 1.45, 0.11111111111111
16366, 1.2434782608696, 1.45, 0.083333333333333
16367, 1.2217391304348, 1.45, 0.055555555555556
16368, 1.2434782608696, 1.45, 0.027777777777778
16369, 1.2869565217391, 1.45, 0.47222222222222
16370, 1.2652173913043, 1.45, 0.44444444444444
16371, 1.2869565217391, 1.45, 0.41666666666667
16372, 1.2652173913043, 1.45, 0.38888888888889
16373, 1.2869565217391, 1.45, 0.36111111111111
16374, 1.2652173913043, 1.45, 0.33333333333333
16375, 1.2869565217391, 1.45, 0.30555555555556
16376, 1.2652173913043, 1.45, 0.27777777777778
16377, 1.2869565217391, 1.45, 0.25
16378, 1.2652173913043, 1.45, 0.22222222222222
16379, 1.2869565217391, 1.45, 0.19444444444444
16380, 1.2652173913043, 1.45, 0.16666666666667
16381, 1.2869565217391, 1.45, 0.13888888888889
16382, 1.2652173913043, 1.45, 0.11111111111111
16383, 1.2869565217391, 1.45, 0.083333333333333
16384, 1.2652173913043, 1.45, 0.055555555555556
16385, 1.2869565217391, 1.45, 0.027777777777778
16386, 1.3304347826087, 1.45, 0.47222222222222
16387, 1.3086956521739, 1.45, 0.44444444444444
16388, 1.3304347826087, 1.45, 0.41666666666667
16389, 1.3086956521739, 1.45, 0.38888888888889
16390, 1.3304347826087, 1.45, 0.36111111111111
16391, 1.3086956521739, 1.45, 0.33333333333333
16392, 1.3304347826087, 1.45, 0.30555555555556
16393, 1.3086956521739, 1.45, 0.27777777777778
16394, 1.3304347826087, 1.45, 0.25
16395, 1.3086956521739, 1.45, 0.22222222222222
16396, 1.3304347826087, 1.45, 0.19444444444444
16397, 1.3086956521739, 1.45, 0.16666666666667
16398, 1.3304347826087, 1.45, 0.13888888888889
16399, 1.3086956521739, 1.45, 0.11111111111111
16400, 1.3304347826087, 1.45, 0.083333333333333
16401, 1.3086956521739, 1.45, 0.055555555555556
16402, 1.3304347826087, 1.45, 0.027777777777778
16403, 1.3739130434783, 1.45, 0.47222222222222
16404, 1.3521739130435, 1.45, 0.44444444444444
16405, 1.3739130434783, 1.45, 0.41666666666667
16406, 1.3521739130435, 1.45, 0.38888888888889
16407, 1.3739130434783, 1.45, 0.36111111111111
16408, 1.3521739130435, 1.45, 0.33333333333333
16409, 1.3739130434783, 1.45, 0.30555555555556
16410, 1.3521739130435, 1.45, 0.27777777777778
16411, 1.3739130434783, 1.45, 0.25
16412, 1.3521739130435, 1.45, 0.22222222222222
16413, 1.3739130434783, 1.45, 0.19444444444444
16414, 1.3521739130435, 1.45, 0.16666666666667
16415, 1.3739130434783, 1.45, 0.13888888888889
16416, 1.3521739130435, 1.45, 0.11111111111111
16417, 1.3739130434783, 1.45, 0.083333333333333
16418, 1.3521739130435, 1.45, 0.055555555555556
16419, 1.3739130434783, 1.45, 0.027777777777778
16420, 1.4173913043478, 1.45, 0.47222222222222
16421, 1.395652173913, 1.45, 0.44444444444444
16422, 1.4173913043478, 1.45, 0.41666666666667
16423, 1.395652173913, 1.45, 0.38888888888889
16424, 1.4173913043478, 1.45, 0.36111111111111
16425, 1.395652173913, 1.45, 0.33333333333333
16426, 1.4173913043478, 1.45, 0.30555555555556
16427, 1.395652173913, 1.45, 0.27777777777778
16428, 1.4173913043478, 1.45, 0.25
16429, 1.395652173913, 1.45, 0.22222222222222
16430, 1.4173913043478, 1.45, 0.19444444444444
16431, 1.395652173913, 1.45, 0.16666666666667
16432, 1.4173913043478, 1.45, 0.13888888888889
16433, 1.395652173913, 1.45, 0.11111111111111
16434, 1.4173913043478, 1.45, 0.083333333333333
16435, 1.395652173913, 1.45, 0.055555555555556
16436, 1.4173913043478, 1.45, 0.027777777777778
16437, 1.4608695652174, 1.45, 0.47222222222222
16438, 1.4391304347826, 1.45, 0.44444444444444
16439, 1.4608695652174, 1.45, 0.41666666666667
16440, 1.4391304347826, 1.45, 0.38888888888889
16441, 1.4608695652174, 1.45, 0.36111111111111
16442, 1.4391304347826, 1.45, 0.33333333333333
16443, 1.4608695652174, 1.45, 0.30555555555556
16444, 1.4391304347826, 1.45, 0.27777777777778
16445, 1.4608695652174, 1.45, 0.25
16446, 1.4391304347826, 1.45, 0.22222222222222
16447, 1.4608695652174, 1.45, 0.19444444444444
16448, 1.4391304347826, 1.45, 0.16666666666667
16449, 1.4608695652174, 1.45, 0.13888888888889
16450, 1.4391304347826, 1.45, 0.11111111111111
16451, 1.4608695652174, 1.45, 0.083333333333333
16452, 1.4391304347826, 1.45, 0.055555555555556
16453, 1.4608695652174, 1.45, 0.027777777777778
16454, 1.504347826087, 1.45, 0.47222222222222
16455, 1.4826086956522, 1.45, 0.44444444444444
16456, 1.504347826087, 1.45, 0.41666666666667
16457, 1.4826086956522, 1.45, 0.38888888888889
16458, 1.504347826087, 1.45, 0.36111111111111
16459, 1.4826086956522, 1.45, 0.33333333333333
16460, 1.504347826087, 1.45, 0.30555555555556
16461, 1.4826086956522, 1.45, 0.27777777777778
16462, 1.504347826087, 1.45, 0.25
16463, 1.4826086956522, 1.45, 0.22222222222222
16464, 1.504347826087, 1.45, 0.19444444444444
16465, 1.4826086956522, 1.45, 0.16666666666667
16466, 1.504347826087, 1.45, 0.13888888888889
16467, 1.4826086956522, 1.45, 0.11111111111111
16468, 1.504347826087, 1.45, 0.083333333333333
16469, 1.4826086956522, 1.45, 0.055555555555556
16470, 1.504347826087, 1.45, 0.027777777777778
16471, 1.5478260869565, 1.45, 0.47222222222222
16472, 1.5260869565217, 1.45, 0.44444444444444
16473, 1.5478260869565, 1.45, 0.41666666666667
16474, 1.5260869565217, 1.45, 0.38888888888889
16475, 1.5478260869565, 1.45, 0.36111111111111
16476, 1.5260869565217, 1.45, 0.33333333333333
16477, 1.5478260869565, 1.45, 0.30555555555556
16478, 1.5260869565217, 1.45, 0.27777777777778
16479, 1.5478260869565, 1.45, 0.25
16480, 1.5260869565217, 1.45, 0.22222222222222
16481, 1.5478260869565, 1.45, 0.19444444444444
16482, 1.5260869565217, 1.45, 0.16666666666667
16483, 1.5478260869565, 1.45, 0.13888888888889
16484, 1.5260869565217, 1.45, 0.11111111111111
16485, 1.5478260869565, 1.45, 0.083333333333333
16486, 1.5260869565217, 1.45, 0.055555555555556
16487, 1.5478260869565, 1.45, 0.027777777777778
16488, 1.5913043478261, 1.45, 0.47222222222222
16489, 1.5695652173913, 1.45, 0.44444444444444
16490, 1.5913043478261, 1.45, 0.41666666666667
16491, 1.5695652173913, 1.45, 0.38888888888889
16492, 1.5913043478261, 1.45, 0.36111111111111
16493, 1.5695652173913, 1.45, 0.33333333333333
16494, 1.5913043478261, 1.45, 0.30555555555556
16495, 1.5695652173913, 1.45, 0.27777777777778
16496, 1.5913043478261, 1.45, 0.25
16497, 1.5695652173913, 1.45, 0.22222222222222
16498, 1.5913043478261, 1.45, 0.19444444444444
16499, 1.5695652173913, 1.45, 0.16666666666667
16500, 1.5913043478261, 1.45, 0.13888888888889
16501, 1.5695652173913, 1.45, 0.11111111111111
16502, 1.5913043478261, 1.45, 0.083333333333333
16503, 1.5695652173913, 1.45, 0.055555555555556
16504, 1.5913043478261, 1.45, 0.027777777777778
16505, 1.6347826086957, 1.45, 0.47222222222222
16506, 1.6130434782609, 1.45, 0.44444444444444
16507, 1.6347826086957, 1.45, 0.41666666666667
16508, 1.6130434782609, 1.45, 0.38888888888889
16509, 1.6347826086957, 1.45, 0.36111111111111
16510, 1.6130434782609, 1.45, 0.33333333333333
16511, 1.6347826086957, 1.45, 0.30555555555556
16512, 1.6130434782609, 1.45, 0.27777777777778
16513, 1.6347826086957, 1.45, 0.25
16514, 1.6130434782609, 1.45, 0.22222222222222
16515, 1.6347826086957, 1.45, 0.19444444444444
16516, 1.6130434782609, 1.45, 0.16666666666667
16517, 1.6347826086957, 1.45, 0.13888888888889
16518, 1.6130434782609, 1.45, 0.11111111111111
16519, 1.6347826086957, 1.45, 0.083333333333333
16520, 1.6130434782609, 1.45, 0.055555555555556
16521, 1.6347826086957, 1.45, 0.027777777777778
16522, 1.6782608695652, 1.45, 0.47222222222222
16523, 1.6565217391304, 1.45, 0.44444444444444
16524, 1.6782608695652, 1.45, 0.41666666666667
16525, 1.6565217391304, 1.45, 0.38888888888889
16526, 1.6782608695652, 1.45, 0.36111111111111
16527, 1.6565217391304, 1.45, 0.33333333333333
16528, 1.6782608695652, 1.45, 0.30555555555556
16529, 1.6565217391304, 1.45, 0.27777777777778
16530, 1.6782608695652, 1.45, 0.25
16531, 1.6565217391304, 1.45, 0.22222222222222
16532, 1.6782608695652, 1.45, 0.19444444444444
16533, 1.6565217391304, 1.45, 0.16666666666667
16534, 1.6782608695652, 1.45, 0.13888888888889
16535, 1.6565217391304, 1.45, 0.11111111111111
16536, 1.6782608695652, 1.45, 0.083333333333333
16537, 1.6565217391304, 1.45, 0.055555555555556
16538, 1.6782608695652, 1.45, 0.027777777777778
16539, 1.7217391304348, 1.45, 0.47222222222222
16540, 1.7, 1.45, 0.44444444444444
16541, 1.7217391304348, 1.45, 0.41666666666667
16542, 1.7, 1.45, 0.38888888888889
16543, 1.7217391304348, 1.45, 0.36111111111111
16544, 1.7, 1.45, 0.33333333333333
16545, 1.7217391304348, 1.45, 0.30555555555556
16546, 1.7, 1.45, 0.27777777777778
16547, 1.7217391304348, 1.45, 0.25
16548, 1.7, 1.45, 0.22222222222222
16549, 1.7217391304348, 1.45, 0.19444444444444
16550, 1.7, 1.45, 0.16666666666667
16551, 1.7217391304348, 1.45, 0.13888888888889
16552, 1.7, 1.45, 0.11111111111111
16553, 1.7217391304348, 1.45, 0.083333333333333
16554, 1.7, 1.45, 0.055555555555556
16555, 1.7217391304348, 1.45, 0.027777777777778
16556, 1.7652173913043, 1.45, 0.47222222222222
16557, 1.7434782608696, 1.45, 0.44444444444444
16558, 1.7652173913043, 1.45, 0.41666666666667
16559, 1.7434782608696, 1.45, 0.38888888888889
16560, 1.7652173913043, 1.45, 0.36111111111111
16561, 1.7434782608696, 1.45, 0.33333333333333
16562, 1.7652173913043, 1.45, 0.30555555555556
16563, 1.7434782608696, 1.45, 0.27777777777778
16564, 1.7652173913043, 1.45, 0.25
16565, 1.7434782608696, 1.45, 0.22222222222222
16566, 1.7652173913043, 1.45, 0.19444444444444
16567, 1.7434782608696, 1.45, 0.16666666666667
16568, 1.7652173913043, 1.45, 0.13888888888889
16569, 1.7434782608696, 1.45, 0.11111111111111
16570, 1.7652173913043, 1.45, 0.083333333333333
16571, 1.7434782608696, 1.45, 0.055555555555556
16572, 1.7652173913043, 1.45, 0.027777777777778
16573, 1.8086956521739, 1.45, 0.47222222222222
16574, 1.7869565217391, 1.45, 0.44444444444444
16575, 1.8086956521739, 1.45, 0.41666666666667
16576, 1.7869565217391, 1.45, 0.38888888888889
16577, 1.8086956521739, 1.45, 0.36111111111111
16578, 1.7869565217391, 1.45, 0.33333333333333
16579, 1.8086956521739, 1.45, 0.30555555555556
16580, 1.7869565217391, 1.45, 0.27777777777778
16581, 1.8086956521739, 1.45, 0.25
16582, 1.7869565217391, 1.45, 0.22222222222222
16583, 1.8086956521739, 1.45, 0.19444444444444
16584, 1.7869565217391, 1.45, 0.16666666666667
16585, 1.8086956521739, 1.45, 0.13888888888889
16586, 1.7869565217391, 1.45, 0.11111111111111
16587, 1.8086956521739, 1.45, 0.083333333333333
16588, 1.7869565217391, 1.45, 0.055555555555556
16589, 1.8086956521739, 1.45, 0.027777777777778
16590, 1.8521739130435, 1.45, 0.47222222222222
16591, 1.8304347826087, 1.45, 0.44444444444444
16592, 1.8521739130435, 1.45, 0.41666666666667
16593, 1.8304347826087, 1.45, 0.38888888888889
16594, 1.8521739130435, 1.45, 0.36111111111111
16595, 1.8304347826087, 1.45, 0.33333333333333
16596, 1.8521739130435, 1.45, 0.30555555555556
16597, 1.8304347826087, 1.45, 0.27777777777778
16598, 1.8521739130435, 1.45, 0.25
16599, 1.8304347826087, 1.45, 0.22222222222222
16600, 1.8521739130435, 1.45, 0.19444444444444
16601, 1.8304347826087, 1.45, 0.16666666666667
16602, 1.8521739130435, 1.45, 0.13888888888889
16603, 1.8304347826087, 1.45, 0.11111111111111
16604, 1.8521739130435, 1.45, 0.083333333333333
16605, 1.8304347826087, 1.45, 0.055555555555556
16606, 1.8521739130435, 1.45, 0.027777777777778
16607, 1.895652173913, 1.45, 0.47222222222222
16608, 1.8739130434783, 1.45, 0.44444444444444
16609, 1.895652173913, 1.45, 0.41666666666667
16610, 1.8739130434783, 1.45, 0.38888888888889
16611, 1.895652173913, 1.45, 0.36111111111111
16612, 1.8739130434783, 1.45, 0.33333333333333
16613, 1.895652173913, 1.45, 0.30555555555556
16614, 1.8739130434783, 1.45, 0.27777777777778
16615, 1.895652173913, 1.45, 0.25
16616, 1.8739130434783, 1.45, 0.22222222222222
16617, 1.895652173913, 1.45, 0.19444444444444
16618, 1.8739130434783, 1.45, 0.16666666666667
16619, 1.895652173913, 1.45, 0.13888888888889
16620, 1.8739130434783, 1.45, 0.11111111111111
16621, 1.895652173913, 1.45, 0.083333333333333
16622, 1.8739130434783, 1.45, 0.055555555555556
16623, 1.895652173913, 1.45, 0.027777777777778
16624, 1.9391304347826, 1.45, 0.47222222222222
16625, 1.9173913043478, 1.45, 0.44444444444444
16626, 1.9391304347826, 1.45, 0.41666666666667
16627, 1.9173913043478, 1.45, 0.38888888888889
16628, 1.9391304347826, 1.45, 0.36111111111111
16629, 1.9173913043478, 1.45, 0.33333333333333
16630, 1.9391304347826, 1.45, 0.30555555555556
16631, 1.9173913043478, 1.45, 0.27777777777778
16632, 1.9391304347826, 1.45, 0.25
16633, 1.9173913043478, 1.45, 0.22222222222222
16634, 1.9391304347826, 1.45, 0.19444444444444
16635, 1.9173913043478, 1.45, 0.16666666666667
16636, 1.9391304347826, 1.45, 0.13888888888889
16637, 1.9173913043478, 1.45, 0.11111111111111
16638, 1.9391304347826, 1.45, 0.083333333333333
16639, 1.9173913043478, 1.45, 0.055555555555556
16640, 1.9391304347826, 1.45, 0.027777777777778
16641, 1.9826086956522, 1.45, 0.47222222222222
16642, 1.9608695652174, 1.45, 0.44444444444444
16643, 1.9826086956522, 1.45, 0.41666666666667
16644, 1.9608695652174, 1.45, 0.38888888888889
16645, 1.9826086956522, 1.45, 0.36111111111111
16646, 1.9608695652174, 1.45, 0.33333333333333
16647, 1.9826086956522, 1.45, 0.30555555555556
16648, 1.9608695652174, 1.45, 0.27777777777778
16649, 1.9826086956522, 1.45, 0.25
16650, 1.9608695652174, 1.45, 0.22222222222222
16651, 1.9826086956522, 1.45, 0.19444444444444
16652, 1.9608695652174, 1.45, 0.16666666666667
16653, 1.9826086956522, 1.45, 0.13888888888889
16654, 1.9608695652174, 1.45, 0.11111111111111
16655, 1.9826086956522, 1.45, 0.083333333333333
16656, 1.9608695652174, 1.45, 0.055555555555556
16657, 1.9826086956522, 1.45, 0.027777777777778
16658, 2.0260869565217, 1.45, 0.47222222222222
16659, 2.004347826087, 1.45, 0.44444444444444
16660, 2.0260869565217, 1.45, 0.41666666666667
16661, 2.004347826087, 1.45, 0.38888888888889
16662, 2.0260869565217, 1.45, 0.36111111111111
16663, 2.004347826087, 1.45, 0.33333333333333
16664, 2.0260869565217, 1.45, 0.30555555555556
16665, 2.004347826087, 1.45, 0.27777777777778
16666, 2.0260869565217, 1.45, 0.25
16667, 2.004347826087, 1.45, 0.22222222222222
16668, 2.0260869565217, 1.45, 0.19444444444444
16669, 2.004347826087, 1.45, 0.16666666666667
16670, 2.0260869565217, 1.45, 0.13888888888889
16671, 2.004347826087, 1.45, 0.11111111111111
16672, 2.0260869565217, 1.45, 0.083333333333333
16673, 2.004347826087, 1.45, 0.055555555555556
16674, 2.0260869565217, 1.45, 0.027777777777778
16675, 2.0695652173913, 1.45, 0.47222222222222
16676, 2.0478260869565, 1.45, 0.44444444444444
16677, 2.0695652173913, 1.45, 0.41666666666667
16678, 2.0478260869565, 1.45, 0.38888888888889
16679, 2.0695652173913, 1.45, 0.36111111111111
16680, 2.0478260869565, 1.45, 0.33333333333333
16681, 2.0695652173913, 1.45, 0.30555555555556
16682, 2.0478260869565, 1.45, 0.27777777777778
16683, 2.0695652173913, 1.45, 0.25
16684, 2.0478260869565, 1.45, 0.22222222222222
16685, 2.0695652173913, 1.45, 0.19444444444444
16686, 2.0478260869565, 1.45, 0.16666666666667
16687, 2.0695652173913, 1.45, 0.13888888888889
16688, 2.0478260869565, 1.45, 0.11111111111111
16689, 2.0695652173913, 1.45, 0.083333333333333
16690, 2.0478260869565, 1.45, 0.055555555555556
16691, 2.0695652173913, 1.45, 0.027777777777778
16692, 2.1130434782609, 1.45, 0.47222222222222
16693, 2.0913043478261, 1.45, 0.44444444444444
16694, 2.1130434782609, 1.45, 0.41666666666667
16695, 2.0913043478261, 1.45, 0.38888888888889
16696, 2.1130434782609, 1.45, 0.36111111111111
16697, 2.0913043478261, 1.45, 0.33333333333333
16698, 2.1130434782609, 1.45, 0.30555555555556
16699, 2.0913043478261, 1.45, 0.27777777777778
16700, 2.1130434782609, 1.45, 0.25
16701, 2.0913043478261, 1.45, 0.22222222222222
16702, 2.1130434782609, 1.45, 0.19444444444444
16703, 2.0913043478261, 1.45, 0.16666666666667
16704, 2.1130434782609, 1.45, 0.13888888888889
16705, 2.0913043478261, 1.45, 0.11111111111111
16706, 2.1130434782609, 1.45, 0.083333333333333
16707, 2.0913043478261, 1.45, 0.055555555555556
16708, 2.1130434782609, 1.45, 0.027777777777778
16709, 2.1565217391304, 1.45, 0.47222222222222
16710, 2.1347826086957, 1.45, 0.44444444444444
16711, 2.1565217391304, 1.45, 0.41666666666667
16712, 2.1347826086957, 1.45, 0.38888888888889
16713, 2.1565217391304, 1.45, 0.36111111111111
16714, 2.1347826086957, 1.45, 0.33333333333333
16715, 2.1565217391304, 1.45, 0.30555555555556
16716, 2.1347826086957, 1.45, 0.27777777777778
16717, 2.1565217391304, 1.45, 0.25
16718, 2.1347826086957, 1.45, 0.22222222222222
16719, 2.1565217391304, 1.45, 0.19444444444444
16720, 2.1347826086957, 1.45, 0.16666666666667
16721, 2.1565217391304, 1.45, 0.13888888888889
16722, 2.1347826086957, 1.45, 0.11111111111111
16723, 2.1565217391304, 1.45, 0.083333333333333
16724, 2.1347826086957, 1.45, 0.055555555555556
16725, 2.1565217391304, 1.45, 0.027777777777778
16726, 2.1782608695652, 1.45, 0.44444444444444
16727, 2.1782608695652, 1.45, 0.38888888888889
16728, 2.1782608695652, 1.45, 0.33333333333333
16729, 2.1782608695652, 1.45, 0.27777777777778
16730, 2.1782608695652, 1.45, 0.22222222222222
16731, 2.1782608695652, 1.45, 0.16666666666667
16732, 2.1782608695652, 1.45, 0.11111111111111
16733, 2.1782608695652, 1.45, 0.055555555555556
16734, 1.2434782608696, 1.4, 0.44444444444444
16735, 1.2434782608696, 1.4, 0.38888888888889
16736, 1.2434782608696, 1.4, 0.33333333333333
16737, 1.2434782608696, 1.4, 0.27777777777778
16738, 1.2434782608696, 1.4, 0.22222222222222
16739, 1.2434782608696, 1.4, 0.16666666666667
16740, 1.2434782608696, 1.4, 0.11111111111111
16741, 1.2434782608696, 1.4, 0.055555555555556
16742, 1.2869565217391, 1.4, 0.44444444444444
16743, 1.2869565217391, 1.4, 0.38888888888889
16744, 1.2869565217391, 1.4, 0.33333333333333
16745, 1.2869565217391, 1.4, 0.27777777777778
16746, 1.2869565217391, 1.4, 0.22222222222222
16747, 1.2869565217391, 1.4, 0.16666666666667
16748, 1.2869565217391, 1.4, 0.11111111111111
16749, 1.2869565217391, 1.4, 0.055555555555556
16750, 1.3304347826087, 1.4, 0.44444444444444
16751, 1.3304347826087, 1.4, 0.38888888888889
16752, 1.3304347826087, 1.4, 0.33333333333333
16753, 1.3304347826087, 1.4, 0.27777777777778
16754, 1.3304347826087, 1.4, 0.22222222222222
16755, 1.3304347826087, 1.4, 0.16666666666667
16756, 1.3304347826087, 1.4, 0.11111111111111
16757, 1.3304347826087, 1.4, 0.055555555555556
16758, 1.3739130434783, 1.4, 0.44444444444444
16759, 1.3739130434783, 1.4, 0.38888888888889
16760, 1.3739130434783, 1.4, 0.33333333333333
16761, 1.3739130434783, 1.4, 0.27777777777778
16762, 1.3739130434783, 1.4, 0.22222222222222
16763, 1.3739130434783, 1.4, 0.16666666666667
16764, 1.3739130434783, 1.4, 0.11111111111111
16765, 1.3739130434783, 1.4, 0.055555555555556
16766, 1.4173913043478, 1.4, 0.44444444444444
16767, 1.4173913043478, 1.4, 0.38888888888889
16768, 1.4173913043478, 1.4, 0.33333333333333
16769, 1.4173913043478, 1.4, 0.27777777777778
16770, 1.4173913043478, 1.4, 0.22222222222222
16771, 1.4173913043478, 1.4, 0.16666666666667
16772, 1.4173913043478, 1.4, 0.11111111111111
16773, 1.4173913043478, 1.4, 0.055555555555556
16774, 1.4608695652174, 1.4, 0.44444444444444
16775, 1.4608695652174, 1.4, 0.38888888888889
16776, 1.4608695652174, 1.4, 0.33333333333333
16777, 1.4608695652174, 1.4, 0.27777777777778
16778, 1.4608695652174, 1.4, 0.22222222222222
16779, 1.4608695652174, 1.4, 0.16666666666667
16780, 1.4608695652174, 1.4, 0.11111111111111
16781, 1.4608695652174, 1.4, 0.055555555555556
16782, 1.504347826087, 1.4, 0.44444444444444
16783, 1.504347826087, 1.4, 0.38888888888889
16784, 1.504347826087, 1.4, 0.33333333333333
16785, 1.504347826087, 1.4, 0.27777777777778
16786, 1.504347826087, 1.4, 0.22222222222222
16787, 1.504347826087, 1.4, 0.16666666666667
16788, 1.504347826087, 1.4, 0.11111111111111
16789, 1.504347826087, 1.4, 0.055555555555556
16790, 1.5478260869565, 1.4, 0.44444444444444
16791, 1.5478260869565, 1.4, 0.38888888888889
16792, 1.5478260869565, 1.4, 0.33333333333333
16793, 1.5478260869565, 1.4, 0.27777777777778
16794, 1.5478260869565, 1.4, 0.22222222222222
16795, 1.5478260869565, 1.4, 0.16666666666667
16796, 1.5478260869565, 1.4, 0.11111111111111
16797, 1.5478260869565, 1.4, 0.055555555555556
16798, 1.5913043478261, 1.4, 0.44444444444444
16799, 1.5913043478261, 1.4, 0.38888888888889
16800, 1.5913043478261, 1.4, 0.33333333333333
16801, 1.5913043478261, 1.4, 0.27777777777778
16802, 1.5913043478261, 1.4, 0.22222222222222
16803, 1.5913043478261, 1.4, 0.16666666666667
16804, 1.5913043478261, 1.4, 0.11111111111111
16805, 1.5913043478261, 1.4, 0.055555555555556
16806, 1.6347826086957, 1.4, 0.44444444444444
16807, 1.6347826086957, 1.4, 0.38888888888889
16808, 1.6347826086957, 1.4, 0.33333333333333
16809, 1.6347826086957, 1.4, 0.27777777777778
16810, 1.6347826086957, 1.4, 0.22222222222222
16811, 1.6347826086957, 1.4, 0.16666666666667
16812, 1.6347826086957, 1.4, 0.11111111111111
16813, 1.6347826086957, 1.4, 0.055555555555556
16814, 1.6782608695652, 1.4, 0.44444444444444
16815, 1.6782608695652, 1.4, 0.38888888888889
16816, 1.6782608695652, 1.4, 0.33333333333333
16817, 1.6782608695652, 1.4, 0.27777777777778
16818, 1.6782608695652, 1.4, 0.22222222222222
16819, 1.6782608695652, 1.4, 0.16666666666667
16820, 1.6782608695652, 1.4, 0.11111111111111
16821, 1.6782608695652, 1.4, 0.055555555555556
16822, 1.7217391304348, 1.4, 0.44444444444444
16823, 1.7217391304348, 1.4, 0.38888888888889
16824, 1.7217391304348, 1.4, 0.33333333333333
16825, 1.7217391304348, 1.4, 0.27777777777778
16826, 1.7217391304348, 1.4, 0.22222222222222
16827, 1.7217391304348, 1.4, 0.16666666666667
16828, 1.7217391304348, 1.4, 0.11111111111111
16829, 1.7217391304348, 1.4, 0.055555555555556
16830, 1.7652173913043, 1.4, 0.44444444444444
16831, 1.7652173913043, 1.4, 0.38888888888889
16832, 1.7652173913043, 1.4, 0.33333333333333
16833, 1.7652173913043, 1.4, 0.27777777777778
16834, 1.7652173913043, 1.4, 0.22222222222222
16835, 1.7652173913043, 1.4, 0.16666666666667
16836, 1.7652173913043, 1.4, 0.11111111111111
16837, 1.7652173913043, 1.4, 0.055555555555556
16838, 1.8086956521739, 1.4, 0.44444444444444
16839, 1.8086956521739, 1.4, 0.38888888888889
16840, 1.8086956521739, 1.4, 0.33333333333333
16841, 1.8086956521739, 1.4, 0.27777777777778
16842, 1.8086956521739, 1.4, 0.22222222222222
16843, 1.8086956521739, 1.4, 0.16666666666667
16844, 1.8086956521739, 1.4, 0.11111111111111
16845, 1.8086956521739, 1.4, 0.055555555555556
16846, 1.8521739130435, 1.4, 0.44444444444444
16847, 1.8521739130435, 1.4, 0.38888888888889
16848, 1.8521739130435, 1.4, 0.33333333333333
16849, 1.8521739130435, 1.4, 0.27777777777778
16850, 1.8521739130435, 1.4, 0.22222222222222
16851, 1.8521739130435, 1.4, 0.16666666666667
16852, 1.8521739130435, 1.4, 0.11111111111111
16853, 1.8521739130435, 1.4, 0.055555555555556
16854, 1.895652173913, 1.4, 0.44444444444444
16855, 1.895652173913, 1.4, 0.38888888888889
16856, 1.895652173913, 1.4, 0.33333333333333
16857, 1.895652173913, 1.4, 0.27777777777778
16858, 1.895652173913, 1.4, 0.22222222222222
16859, 1.895652173913, 1.4, 0.16666666666667
16860, 1.895652173913, 1.4, 0.11111111111111
16861, 1.895652173913, 1.4, 0.055555555555556
16862, 1.9391304347826, 1.4, 0.44444444444444
16863, 1.9391304347826, 1.4, 0.38888888888889
16864, 1.9391304347826, 1.4, 0.33333333333333
16865, 1.9391304347826, 1.4, 0.27777777777778
16866, 1.9391304347826, 1.4, 0.22222222222222
16867, 1.9391304347826, 1.4, 0.16666666666667
16868, 1.9391304347826, 1.4, 0.11111111111111
16869, 1.9391304347826, 1.4, 0.055555555555556
16870, 1.9826086956522, 1.4, 0.44444444444444
16871, 1.9826086956522, 1.4, 0.38888888888889
16872, 1.9826086956522, 1.4, 0.33333333333333
16873, 1.9826086956522, 1.4, 0.27777777777778
16874, 1.9826086956522, 1.4, 0.22222222222222
16875, 1.9826086956522, 1.4, 0.16666666666667
16876, 1.9826086956522, 1.4, 0.11111111111111
16877, 1.9826086956522, 1.4, 0.055555555555556
16878, 2.0260869565217, 1.4, 0.44444444444444
16879, 2.0260869565217, 1.4, 0.38888888888889
16880, 2.0260869565217, 1.4, 0.33333333333333
16881, 2.0260869565217, 1.4, 0.27777777777778
16882, 2.0260869565217, 1.4, 0.22222222222222
16883, 2.0260869565217, 1.4, 0.16666666666667
16884, 2.0260869565217, 1.4, 0.11111111111111
16885, 2.0260869565217, 1.4, 0.055555555555556
16886, 2.0695652173913, 1.4, 0.44444444444444
16887, 2.0695652173913, 1.4, 0.38888888888889
16888, 2.0695652173913, 1.4, 0.33333333333333
16889, 2.0695652173913, 1.4, 0.27777777777778
16890, 2.0695652173913, 1.4, 0.22222222222222
16891, 2.0695652173913, 1.4, 0.16666666666667
16892, 2.0695652173913, 1.4, 0.11111111111111
16893, 2.0695652173913, 1.4, 0.055555555555556
16894, 2.1130434782609, 1.4, 0.44444444444444
16895, 2.1130434782609, 1.4, 0.38888888888889
16896, 2.1130434782609, 1.4, 0.33333333333333
16897, 2.1130434782609, 1.4, 0.27777777777778
16898, 2.1130434782609, 1.4, 0.22222222222222
16899, 2.1130434782609, 1.4, 0.16666666666667
16900, 2.1130434782609, 1.4, 0.11111111111111
16901, 2.1130434782609, 1.4, 0.055555555555556
16902, 2.1565217391304, 1.4, 0.44444444444444
16903, 2.1565217391304, 1.4, 0.38888888888889
16904, 2.1565217391304, 1.4, 0.33333333333333
16905, 2.1565217391304, 1.4, 0.27777777777778
16906, 2.1565217391304, 1.4, 0.22222222222222
16907, 2.1565217391304, 1.4, 0.16666666666667
16908, 2.1565217391304, 1.4, 0.11111111111111
16909, 2.1565217391304, 1.4, 0.055555555555556
16910, 1.2217391304348, 1.4, 0.44444444444444
16911, 1.2434782608696, 1.4, 0.47222222222222
16912, 1.2217391304348, 1.4, 0.38888888888889
16913, 1.2434782608696, 1.4, 0.41666666666667
16914, 1.2217391304348, 1.4, 0.33333333333333
16915, 1.2434782608696, 1.4, 0.36111111111111
16916, 1.2217391304348, 1.4, 0.27777777777778
16917, 1.2434782608696, 1.4, 0.30555555555556
16918, 1.2217391304348, 1.4, 0.22222222222222
16919, 1.2434782608696, 1.4, 0.25
16920, 1.2217391304348, 1.4, 0.16666666666667
16921, 1.2434782608696, 1.4, 0.19444444444444
16922, 1.2217391304348, 1.4, 0.11111111111111
16923, 1.2434782608696, 1.4, 0.13888888888889
16924, 1.2217391304348, 1.4, 0.055555555555556
16925, 1.2434782608696, 1.4, 0.083333333333333
16926, 1.2434782608696, 1.4, 0.027777777777778
16927, 1.2652173913043, 1.4, 0.44444444444444
16928, 1.2869565217391, 1.4, 0.47222222222222
16929, 1.2652173913043, 1.4, 0.38888888888889
16930, 1.2869565217391, 1.4, 0.41666666666667
16931, 1.2652173913043, 1.4, 0.33333333333333
16932, 1.2869565217391, 1.4, 0.36111111111111
16933, 1.2652173913043, 1.4, 0.27777777777778
16934, 1.2869565217391, 1.4, 0.30555555555556
16935, 1.2652173913043, 1.4, 0.22222222222222
16936, 1.2869565217391, 1.4, 0.25
16937, 1.2652173913043, 1.4, 0.16666666666667
16938, 1.2869565217391, 1.4, 0.19444444444444
16939, 1.2652173913043, 1.4, 0.11111111111111
16940, 1.2869565217391, 1.4, 0.13888888888889
16941, 1.2652173913043, 1.4, 0.055555555555556
16942, 1.2869565217391, 1.4, 0.083333333333333
16943, 1.2869565217391, 1.4, 0.027777777777778
16944, 1.3086956521739, 1.4, 0.44444444444444
16945, 1.3304347826087, 1.4, 0.47222222222222
16946, 1.3086956521739, 1.4, 0.38888888888889
16947, 1.3304347826087, 1.4, 0.41666666666667
16948, 1.3086956521739, 1.4, 0.33333333333333
16949, 1.3304347826087, 1.4, 0.36111111111111
16950, 1.3086956521739, 1.4, 0.27777777777778
16951, 1.3304347826087, 1.4, 0.30555555555556
16952, 1.3086956521739, 1.4, 0.22222222222222
16953, 1.3304347826087, 1.4, 0.25
16954, 1.3086956521739, 1.4, 0.16666666666667
16955, 1.3304347826087, 1.4, 0.19444444444444
16956, 1.3086956521739, 1.4, 0.11111111111111
16957, 1.3304347826087, 1.4, 0.13888888888889
16958, 1.3086956521739, 1.4, 0.055555555555556
16959, 1.3304347826087, 1.4, 0.083333333333333
16960, 1.3304347826087, 1.4, 0.027777777777778
16961, 1.3521739130435, 1.4, 0.44444444444444
16962, 1.3739130434783, 1.4, 0.47222222222222
16963, 1.3521739130435, 1.4, 0.38888888888889
16964, 1.3739130434783, 1.4, 0.41666666666667
16965, 1.3521739130435, 1.4, 0.33333333333333
16966, 1.3739130434783, 1.4, 0.36111111111111
16967, 1.3521739130435, 1.4, 0.27777777777778
16968, 1.3739130434783, 1.4, 0.30555555555556
16969, 1.3521739130435, 1.4, 0.22222222222222
16970, 1.3739130434783, 1.4, 0.25
16971, 1.3521739130435, 1.4, 0.16666666666667
16972, 1.3739130434783, 1.4, 0.19444444444444
16973, 1.3521739130435, 1.4, 0.11111111111111
16974, 1.3739130434783, 1.4, 0.13888888888889
16975, 1.3521739130435, 1.4, 0.055555555555556
16976, 1.3739130434783, 1.4, 0.083333333333333
16977, 1.3739130434783, 1.4, 0.027777777777778
16978, 1.395652173913, 1.4, 0.44444444444444
16979, 1.4173913043478, 1.4, 0.47222222222222
16980, 1.395652173913, 1.4, 0.38888888888889
16981, 1.4173913043478, 1.4, 0.41666666666667
16982, 1.395652173913, 1.4, 0.33333333333333
16983, 1.4173913043478, 1.4, 0.36111111111111
16984, 1.395652173913, 1.4, 0.27777777777778
16985, 1.4173913043478, 1.4, 0.30555555555556
16986, 1.395652173913, 1.4, 0.22222222222222
16987, 1.4173913043478, 1.4, 0.25
16988, 1.395652173913, 1.4, 0.16666666666667
16989, 1.4173913043478, 1.4, 0.19444444444444
16990, 1.395652173913, 1.4, 0.11111111111111
16991, 1.4173913043478, 1.4, 0.13888888888889
16992, 1.395652173913, 1.4, 0.055555555555556
16993, 1.4173913043478, 1.4, 0.083333333333333
16994, 1.4173913043478, 1.4, 0.027777777777778
16995, 1.4391304347826, 1.4, 0.44444444444444
16996, 1.4608695652174, 1.4, 0.47222222222222
16997, 1.4391304347826, 1.4, 0.38888888888889
16998, 1.4608695652174, 1.4, 0.41666666666667
16999, 1.4391304347826, 1.4, 0.33333333333333
17000, 1.4608695652174, 1.4, 0.36111111111111
17001, 1.4391304347826, 1.4, 0.27777777777778
17002, 1.4608695652174, 1.4, 0.30555555555556
17003, 1.4391304347826, 1.4, 0.22222222222222
17004, 1.4608695652174, 1.4, 0.25
17005, 1.4391304347826, 1.4, 0.16666666666667
17006, 1.4608695652174, 1.4, 0.19444444444444
17007, 1.4391304347826, 1.4, 0.11111111111111
17008, 1.4608695652174, 1.4, 0.13888888888889
17009, 1.4391304347826, 1.4, 0.055555555555556
17010, 1.4608695652174, 1.4, 0.083333333333333
17011, 1.4608695652174, 1.4, 0.027777777777778
17012, 1.4826086956522, 1.4, 0.44444444444444
17013, 1.504347826087, 1.4, 0.47222222222222
17014, 1.4826086956522, 1.4, 0.38888888888889
17015, 1.504347826087, 1.4, 0.41666666666667
17016, 1.4826086956522, 1.4, 0.33333333333333
17017, 1.504347826087, 1.4, 0.36111111111111
17018, 1.4826086956522, 1.4, 0.27777777777778
17019, 1.504347826087, 1.4, 0.30555555555556
17020, 1.4826086956522, 1.4, 0.22222222222222
17021, 1.504347826087, 1.4, 0.25
17022, 1.4826086956522, 1.4, 0.16666666666667
17023, 1.504347826087, 1.4, 0.19444444444444
17024, 1.4826086956522, 1.4, 0.11111111111111
17025, 1.504347826087, 1.4, 0.13888888888889
17026, 1.4826086956522, 1.4, 0.055555555555556
17027, 1.504347826087, 1.4, 0.083333333333333
17028, 1.504347826087, 1.4, 0.027777777777778
17029, 1.5260869565217, 1.4, 0.44444444444444
17030, 1.5478260869565, 1.4, 0.47222222222222
17031, 1.5260869565217, 1.4, 0.38888888888889
17032, 1.5478260869565, 1.4, 0.41666666666667
17033, 1.5260869565217, 1.4, 0.33333333333333
17034, 1.5478260869565, 1.4, 0.36111111111111
17035, 1.5260869565217, 1.4, 0.27777777777778
17036, 1.5478260869565, 1.4, 0.30555555555556
17037, 1.5260869565217, 1.4, 0.22222222222222
17038, 1.5478260869565, 1.4, 0.25
17039, 1.5260869565217, 1.4, 0.16666666666667
17040, 1.5478260869565, 1.4, 0.19444444444444
17041, 1.5260869565217, 1.4, 0.11111111111111
17042, 1.5478260869565, 1.4, 0.13888888888889
17043, 1.5260869565217, 1.4, 0.055555555555556
17044, 1.5478260869565, 1.4, 0.083333333333333
17045, 1.5478260869565, 1.4, 0.027777777777778
17046, 1.5695652173913, 1.4, 0.44444444444444
17047, 1.5913043478261, 1.4, 0.47222222222222
17048, 1.5695652173913, 1.4, 0.38888888888889
17049, 1.5913043478261, 1.4, 0.41666666666667
17050, 1.5695652173913, 1.4, 0.33333333333333
17051, 1.5913043478261, 1.4, 0.36111111111111
17052, 1.5695652173913, 1.4, 0.27777777777778
17053, 1.5913043478261, 1.4, 0.30555555555556
17054, 1.5695652173913, 1.4, 0.22222222222222
17055, 1.5913043478261, 1.4, 0.25
17056, 1.5695652173913, 1.4, 0.16666666666667
17057, 1.5913043478261, 1.4, 0.19444444444444
17058, 1.5695652173913, 1.4, 0.11111111111111
17059, 1.5913043478261, 1.4, 0.13888888888889
17060, 1.5695652173913, 1.4, 0.055555555555556
17061, 1.5913043478261, 1.4, 0.083333333333333
17062, 1.5913043478261, 1.4, 0.027777777777778
17063, 1.6130434782609, 1.4, 0.44444444444444
17064, 1.6347826086957, 1.4, 0.47222222222222
17065, 1.6130434782609, 1.4, 0.38888888888889
17066, 1.6347826086957, 1.4, 0.41666666666667
17067, 1.6130434782609, 1.4, 0.33333333333333
17068, 1.6347826086957, 1.4, 0.36111111111111
17069, 1.6130434782609, 1.4, 0.27777777777778
17070, 1.6347826086957, 1.4, 0.30555555555556
17071, 1.6130434782609, 1.4, 0.22222222222222
17072, 1.6347826086957, 1.4, 0.25
17073, 1.6130434782609, 1.4, 0.16666666666667
17074, 1.6347826086957, 1.4, 0.19444444444444
17075, 1.6130434782609, 1.4, 0.11111111111111
17076, 1.6347826086957, 1.4, 0.13888888888889
17077, 1.6130434782609, 1.4, 0.055555555555556
17078, 1.6347826086957, 1.4, 0.083333333333333
17079, 1.6347826086957, 1.4, 0.027777777777778
17080, 1.6565217391304, 1.4, 0.44444444444444
17081, 1.6782608695652, 1.4, 0.47222222222222
17082, 1.6565217391304, 1.4, 0.38888888888889
17083, 1.6782608695652, 1.4, 0.41666666666667
17084, 1.6565217391304, 1.4, 0.33333333333333
17085, 1.6782608695652, 1.4, 0.36111111111111
17086, 1.6565217391304, 1.4, 0.27777777777778
17087, 1.6782608695652, 1.4, 0.30555555555556
17088, 1.6565217391304, 1.4, 0.22222222222222
17089, 1.6782608695652, 1.4, 0.25
17090, 1.6565217391304, 1.4, 0.16666666666667
17091, 1.6782608695652, 1.4, 0.19444444444444
17092, 1.6565217391304, 1.4, 0.11111111111111
17093, 1.6782608695652, 1.4, 0.13888888888889
17094, 1.6565217391304, 1.4, 0.055555555555556
17095, 1.6782608695652, 1.4, 0.083333333333333
17096, 1.6782608695652, 1.4, 0.027777777777778
17097, 1.7, 1.4, 0.44444444444444
17098, 1.7217391304348, 1.4, 0.47222222222222
17099, 1.7, 1.4, 0.38888888888889
17100, 1.7217391304348, 1.4, 0.41666666666667
17101, 1.7, 1.4, 0.33333333333333
17102, 1.7217391304348, 1.4, 0.36111111111111
17103, 1.7, 1.4, 0.27777777777778
17104, 1.7217391304348, 1.4, 0.30555555555556
17105, 1.7, 1.4, 0.22222222222222
17106, 1.7217391304348, 1.4, 0.25
17107, 1.7, 1.4, 0.16666666666667
17108, 1.7217391304348, 1.4, 0.19444444444444
17109, 1.7, 1.4, 0.11111111111111
17110, 1.7217391304348, 1.4, 0.13888888888889
17111, 1.7, 1.4, 0.055555555555556
17112, 1.7217391304348, 1.4, 0.083333333333333
17113, 1.7217391304348, 1.4, 0.027777777777778
17114, 1.7434782608696, 1.4, 0.44444444444444
17115, 1.7652173913043, 1.4, 0.47222222222222
17116, 1.7434782608696, 1.4, 0.38888888888889
17117, 1.7652173913043, 1.4, 0.41666666666667
17118, 1.7434782608696, 1.4, 0.33333333333333
17119, 1.7652173913043, 1.4, 0.36111111111111
17120, 1.7434782608696, 1.4, 0.27777777777778
17121, 1.7652173913043, 1.4, 0.30555555555556
17122, 1.7434782608696, 1.4, 0.22222222222222
17123, 1.7652173913043, 1.4, 0.25
17124, 1.7434782608696, 1.4, 0.16666666666667
17125, 1.7652173913043, 1.4, 0.19444444444444
17126, 1.7434782608696, 1.4, 0.11111111111111
17127, 1.7652173913043, 1.4, 0.13888888888889
17128, 1.7434782608696, 1.4, 0.055555555555556
17129, 1.7652173913043, 1.4, 0.083333333333333
17130, 1.7652173913043, 1.4, 0.027777777777778
17131, 1.7869565217391, 1.4, 0.44444444444444
17132, 1.8086956521739, 1.4, 0.47222222222222
17133, 1.7869565217391, 1.4, 0.38888888888889
17134, 1.8086956521739, 1.4, 0.41666666666667
17135, 1.7869565217391, 1.4, 0.33333333333333
17136, 1.8086956521739, 1.4, 0.36111111111111
17137, 1.7869565217391, 1.4, 0.27777777777778
17138, 1.8086956521739, 1.4, 0.30555555555556
17139, 1.7869565217391, 1.4, 0.22222222222222
17140, 1.8086956521739, 1.4, 0.25
17141, 1.7869565217391, 1.4, 0.16666666666667
17142, 1.8086956521739, 1.4, 0.19444444444444
17143, 1.7869565217391, 1.4, 0.11111111111111
17144, 1.8086956521739, 1.4, 0.13888888888889
17145, 1.7869565217391, 1.4, 0.055555555555556
17146, 1.8086956521739, 1.4, 0.083333333333333
17147, 1.8086956521739, 1.4, 0.027777777777778
17148, 1.8304347826087, 1.4, 0.44444444444444
17149, 1.8521739130435, 1.4, 0.47222222222222
17150, 1.8304347826087, 1.4, 0.38888888888889
17151, 1.8521739130435, 1.4, 0.41666666666667
17152, 1.8304347826087, 1.4, 0.33333333333333
17153, 1.8521739130435, 1.4, 0.36111111111111
17154, 1.8304347826087, 1.4, 0.27777777777778
17155, 1.8521739130435, 1.4, 0.30555555555556
17156, 1.8304347826087, 1.4, 0.22222222222222
17157, 1.8521739130435, 1.4, 0.25
17158, 1.8304347826087, 1.4, 0.16666666666667
17159, 1.8521739130435, 1.4, 0.19444444444444
17160, 1.8304347826087, 1.4, 0.11111111111111
17161, 1.8521739130435, 1.4, 0.13888888888889
17162, 1.8304347826087, 1.4, 0.055555555555556
17163, 1.8521739130435, 1.4, 0.083333333333333
17164, 1.8521739130435, 1.4, 0.027777777777778
17165, 1.8739130434783, 1.4, 0.44444444444444
17166, 1.895652173913, 1.4, 0.47222222222222
17167, 1.8739130434783, 1.4, 0.38888888888889
17168, 1.895652173913, 1.4, 0.41666666666667
17169, 1.8739130434783, 1.4, 0.33333333333333
17170, 1.895652173913, 1.4, 0.36111111111111
17171, 1.8739130434783, 1.4, 0.27777777777778
17172, 1.895652173913, 1.4, 0.30555555555556
17173, 1.8739130434783, 1.4, 0.22222222222222
17174, 1.895652173913, 1.4, 0.25
17175, 1.8739130434783, 1.4, 0.16666666666667
17176, 1.895652173913, 1.4, 0.19444444444444
17177, 1.8739130434783, 1.4, 0.11111111111111
17178, 1.895652173913, 1.4, 0.13888888888889
17179, 1.8739130434783, 1.4, 0.055555555555556
17180, 1.895652173913, 1.4, 0.083333333333333
17181, 1.895652173913, 1.4, 0.027777777777778
17182, 1.9173913043478, 1.4, 0.44444444444444
17183, 1.9391304347826, 1.4, 0.47222222222222
17184, 1.9173913043478, 1.4, 0.38888888888889
17185, 1.9391304347826, 1.4, 0.41666666666667
17186, 1.9173913043478, 1.4, 0.33333333333333
17187, 1.9391304347826, 1.4, 0.36111111111111
17188, 1.9173913043478, 1.4, 0.27777777777778
17189, 1.9391304347826, 1.4, 0.30555555555556
17190, 1.9173913043478, 1.4, 0.22222222222222
17191, 1.9391304347826, 1.4, 0.25
17192, 1.9173913043478, 1.4, 0.16666666666667
17193, 1.9391304347826, 1.4, 0.19444444444444
17194, 1.9173913043478, 1.4, 0.11111111111111
17195, 1.9391304347826, 1.4, 0.13888888888889
17196, 1.9173913043478, 1.4, 0.055555555555556
17197, 1.9391304347826, 1.4, 0.083333333333333
17198, 1.9391304347826, 1.4, 0.027777777777778
17199, 1.9608695652174, 1.4, 0.44444444444444
17200, 1.9826086956522, 1.4, 0.47222222222222
17201, 1.9608695652174, 1.4, 0.38888888888889
17202, 1.9826086956522, 1.4, 0.41666666666667
17203, 1.9608695652174, 1.4, 0.33333333333333
17204, 1.9826086956522, 1.4, 0.36111111111111
17205, 1.9608695652174, 1.4, 0.27777777777778
17206, 1.9826086956522, 1.4, 0.30555555555556
17207, 1.9608695652174, 1.4, 0.22222222222222
17208, 1.9826086956522, 1.4, 0.25
17209, 1.9608695652174, 1.4, 0.16666666666667
17210, 1.9826086956522, 1.4, 0.19444444444444
17211, 1.9608695652174, 1.4, 0.11111111111111
17212, 1.9826086956522, 1.4, 0.13888888888889
17213, 1.9608695652174, 1.4, 0.055555555555556
17214, 1.9826086956522, 1.4, 0.083333333333333
17215, 1.9826086956522, 1.4, 0.027777777777778
17216, 2.004347826087, 1.4, 0.44444444444444
17217, 2.0260869565217, 1.4, 0.47222222222222
17218, 2.004347826087, 1.4, 0.38888888888889
17219, 2.0260869565217, 1.4, 0.41666666666667
17220, 2.004347826087, 1.4, 0.33333333333333
17221, 2.0260869565217, 1.4, 0.36111111111111
17222, 2.004347826087, 1.4, 0.27777777777778
17223, 2.0260869565217, 1.4, 0.30555555555556
17224, 2.004347826087, 1.4, 0.22222222222222
17225, 2.0260869565217, 1.4, 0.25
17226, 2.004347826087, 1.4, 0.16666666666667
17227, 2.0260869565217, 1.4, 0.19444444444444
17228, 2.004347826087, 1.4, 0.11111111111111
17229, 2.0260869565217, 1.4, 0.13888888888889
17230, 2.004347826087, 1.4, 0.055555555555556
17231, 2.0260869565217, 1.4, 0.083333333333333
17232, 2.0260869565217, 1.4, 0.027777777777778
17233, 2.0478260869565, 1.4, 0.44444444444444
17234, 2.0695652173913, 1.4, 0.47222222222222
17235, 2.0478260869565, 1.4, 0.38888888888889
17236, 2.0695652173913, 1.4, 0.41666666666667
17237, 2.0478260869565, 1.4, 0.33333333333333
17238, 2.0695652173913, 1.4, 0.36111111111111
17239, 2.0478260869565, 1.4, 0.27777777777778
17240, 2.0695652173913, 1.4, 0.30555555555556
17241, 2.0478260869565, 1.4, 0.22222222222222
17242, 2.0695652173913, 1.4, 0.25
17243, 2.0478260869565, 1.4, 0.16666666666667
17244, 2.0695652173913, 1.4, 0.19444444444444
17245, 2.0478260869565, 1.4, 0.11111111111111
17246, 2.0695652173913, 1.4, 0.13888888888889
17247, 2.0478260869565, 1.4, 0.055555555555556
17248, 2.0695652173913, 1.4, 0.083333333333333
17249, 2.0695652173913, 1.4, 0.027777777777778
17250, 2.0913043478261, 1.4, 0.44444444444444
17251, 2.1130434782609, 1.4, 0.47222222222222
17252, 2.0913043478261, 1.4, 0.38888888888889
17253, 2.1130434782609, 1.4, 0.41666666666667
17254, 2.0913043478261, 1.4, 0.33333333333333
17255, 2.1130434782609, 1.4, 0.36111111111111
17256, 2.0913043478261, 1.4, 0.27777777777778
17257, 2.1130434782609, 1.4, 0.30555555555556
17258, 2.0913043478261, 1.4, 0.22222222222222
17259, 2.1130434782609, 1.4, 0.25
17260, 2.0913043478261, 1.4, 0.16666666666667
17261, 2.1130434782609, 1.4, 0.19444444444444
17262, 2.0913043478261, 1.4, 0.11111111111111
17263, 2.1130434782609, 1.4, 0.13888888888889
17264, 2.0913043478261, 1.4, 0.055555555555556
17265, 2.1130434782609, 1.4, 0.083333333333333
17266, 2.1130434782609, 1.4, 0.027777777777778
17267, 2.1347826086957, 1.4, 0.44444444444444
17268, 2.1565217391304, 1.4, 0.47222222222222
17269, 2.1347826086957, 1.4, 0.38888888888889
17270, 2.1565217391304, 1.4, 0.41666666666667
17271, 2.1347826086957, 1.4, 0.33333333333333
17272, 2.1565217391304, 1.4, 0.36111111111111
17273, 2.1347826086957, 1.4, 0.27777777777778
17274, 2.1565217391304, 1.4, 0.30555555555556
17275, 2.1347826086957, 1.4, 0.22222222222222
17276, 2.1565217391304, 1.4, 0.25
17277, 2.1347826086957, 1.4, 0.16666666666667
17278, 2.1565217391304, 1.4, 0.19444444444444
17279, 2.1347826086957, 1.4, 0.11111111111111
17280, 2.1565217391304, 1.4, 0.13888888888889
17281, 2.1347826086957, 1.4, 0.055555555555556
17282, 2.1565217391304, 1.4, 0.083333333333333
17283, 2.1565217391304, 1.4, 0.027777777777778
17284, 2.1782608695652, 1.4, 0.44444444444444
17285, 2.1782608695652, 1.4, 0.38888888888889
17286, 2.1782608695652, 1.4, 0.33333333333333
17287, 2.1782608695652, 1.4, 0.27777777777778
17288, 2.1782608695652, 1.4, 0.22222222222222
17289, 2.1782608695652, 1.4, 0.16666666666667
17290, 2.1782608695652, 1.4, 0.11111111111111
17291, 2.1782608695652, 1.4, 0.055555555555556
17292, 1.2434782608696, 1.4833333333333, 0.5
17293, 1.2434782608696, 1.5166666666667, 0.5
17294, 1.2869565217391, 1.4833333333333, 0.5
17295, 1.2869565217391, 1.5166666666667, 0.5
17296, 1.3304347826087, 1.4833333333333, 0.5
17297, 1.3304347826087, 1.5166666666667, 0.5
17298, 1.3739130434783, 1.4833333333333, 0.5
17299, 1.3739130434783, 1.5166666666667, 0.5
17300, 1.4173913043478, 1.4833333333333, 0.5
17301, 1.4173913043478, 1.5166666666667, 0.5
17302, 1.4608695652174, 1.4833333333333, 0.5
17303, 1.4608695652174, 1.5166666666667, 0.5
17304, 1.504347826087, 1.4833333333333, 0.5
17305, 1.504347826087, 1.5166666666667, 0.5
17306, 1.5478260869565, 1.4833333333333, 0.5
17307, 1.5478260869565, 1.5166666666667, 0.5
17308, 1.5913043478261, 1.4833333333333, 0.5
17309, 1.5913043478261, 1.5166666666667, 0.5
17310, 1.6347826086957, 1.4833333333333, 0.5
17311, 1.6347826086957, 1.5166666666667, 0.5
17312, 1.6782608695652, 1.4833333333333, 0.5
17313, 1.6782608695652, 1.5166666666667, 0.5
17314, 1.7217391304348, 1.4833333333333, 0.5
17315, 1.7217391304348, 1.5166666666667, 0.5
17316, 1.7652173913043, 1.4833333333333, 0.5
17317, 1.7652173913043, 1.5166666666667, 0.5
17318, 1.8086956521739, 1.4833333333333, 0.5
17319, 1.8086956521739, 1.5166666666667, 0.5
17320, 1.8521739130435, 1.4833333333333, 0.5
17321, 1.8521739130435, 1.5166666666667, 0.5
17322, 1.895652173913, 1.4833333333333, 0.5
17323, 1.895652173913, 1.5166666666667, 0.5
17324, 1.9391304347826, 1.4833333333333, 0.5
17325, 1.9391304347826, 1.5166666666667, 0.5
17326, 1.9826086956522, 1.4833333333333, 0.5
17327, 1.9826086956522, 1.5166666666667, 0.5
17328, 2.0260869565217, 1.4833333333333, 0.5
17329, 2.0260869565217, 1.5166666666667, 0.5
17330, 2.0695652173913, 1.4833333333333, 0.5
17331, 2.0695652173913, 1.5166666666667, 0.5
17332, 2.1130434782609, 1.4833333333333, 0.5
17333, 2.1130434782609, 1.5166666666667, 0.5
17334, 2.1565217391304, 1.4833333333333, 0.5
17335, 2.1565217391304, 1.5166666666667, 0.5
17336, 1.2434782608696, 1.4666666666667, 0.5
17337, 1.2217391304348, 1.4833333333333, 0.5
17338, 1.2434782608696, 1.5, 0.5
17339, 1.2217391304348, 1.5166666666667, 0.5
17340, 1.2434782608696, 1.5333333333333, 0.5
17341, 1.2869565217391, 1.4666666666667, 0.5
17342, 1.2652173913043, 1.4833333333333, 0.5
17343, 1.2869565217391, 1.5, 0.5
17344, 1.2652173913043, 1.5166666666667, 0.5
17345, 1.2869565217391, 1.5333333333333, 0.5
17346, 1.3304347826087, 1.4666666666667, 0.5
17347, 1.3086956521739, 1.4833333333333, 0.5
17348, 1.3304347826087, 1.5, 0.5
17349, 1.3086956521739, 1.5166666666667, 0.5
17350, 1.3304347826087, 1.5333333333333, 0.5
17351, 1.3739130434783, 1.4666666666667, 0.5
17352, 1.3521739130435, 1.4833333333333, 0.5
17353, 1.3739130434783, 1.5, 0.5
17354, 1.3521739130435, 1.5166666666667, 0.5
17355, 1.3739130434783, 1.5333333333333, 0.5
17356, 1.4173913043478, 1.4666666666667, 0.5
17357, 1.395652173913, 1.4833333333333, 0.5
17358, 1.4173913043478, 1.5, 0.5
17359, 1.395652173913, 1.5166666666667, 0.5
17360, 1.4173913043478, 1.5333333333333, 0.5
17361, 1.4608695652174, 1.4666666666667, 0.5
17362, 1.4391304347826, 1.4833333333333, 0.5
17363, 1.4608695652174, 1.5, 0.5
17364, 1.4391304347826, 1.5166666666667, 0.5
17365, 1.4608695652174, 1.5333333333333, 0.5
17366, 1.504347826087, 1.4666666666667, 0.5
17367, 1.4826086956522, 1.4833333333333, 0.5
17368, 1.504347826087, 1.5, 0.5
17369, 1.4826086956522, 1.5166666666667, 0.5
17370, 1.504347826087, 1.5333333333333, 0.5
17371, 1.5478260869565, 1.4666666666667, 0.5
17372, 1.5260869565217, 1.4833333333333, 0.5
17373, 1.5478260869565, 1.5, 0.5
17374, 1.5260869565217, 1.5166666666667, 0.5
17375, 1.5478260869565, 1.5333333333333, 0.5
17376, 1.5913043478261, 1.4666666666667, 0.5
17377, 1.5695652173913, 1.4833333333333, 0.5
17378, 1.5913043478261, 1.5, 0.5
17379, 1.5695652173913, 1.5166666666667, 0.5
17380, 1.5913043478261, 1.5333333333333, 0.5
17381, 1.6347826086957, 1.4666666666667, 0.5
17382, 1.6130434782609, 1.4833333333333, 0.5
17383, 1.6347826086957, 1.5, 0.5
17384, 1.6130434782609, 1.5166666666667, 0.5
17385, 1.6347826086957, 1.5333333333333, 0.5
17386, 1.6782608695652, 1.4666666666667, 0.5
17387, 1.6565217391304, 1.4833333333333, 0.5
17388, 1.6782608695652, 1.5, 0.5
17389, 1.6565217391304, 1.5166666666667, 0.5
17390, 1.6782608695652, 1.5333333333333, 0.5
17391, 1.7217391304348, 1.4666666666667, 0.5
17392, 1.7, 1.4833333333333, 0.5
17393, 1.7217391304348, 1.5, 0.5
17394, 1.7, 1.5166666666667, 0.5
17395, 1.7217391304348, 1.5333333333333, 0.5
17396, 1.7652173913043, 1.4666666666667, 0.5
17397, 1.7434782608696, 1.4833333333333, 0.5
17398, 1.7652173913043, 1.5, 0.5
17399, 1.7434782608696, 1.5166666666667, 0.5
17400, 1.7652173913043, 1.5333333333333, 0.5
17401, 1.8086956521739, 1.4666666666667, 0.5
17402, 1.7869565217391, 1.4833333333333, 0.5
17403, 1.8086956521739, 1.5, 0.5
17404, 1.7869565217391, 1.5166666666667, 0.5
17405, 1.8086956521739, 1.5333333333333, 0.5
17406, 1.8521739130435, 1.4666666666667, 0.5
17407, 1.8304347826087, 1.4833333333333, 0.5
17408, 1.8521739130435, 1.5, 0.5
17409, 1.8304347826087, 1.5166666666667, 0.5
17410, 1.8521739130435, 1.5333333333333, 0.5
17411, 1.895652173913, 1.4666666666667, 0.5
17412, 1.8739130434783, 1.4833333333333, 0.5
17413, 1.895652173913, 1.5, 0.5
17414, 1.8739130434783, 1.5166666666667, 0.5
17415, 1.895652173913, 1.5333333333333, 0.5
17416, 1.9391304347826, 1.4666666666667, 0.5
17417, 1.9173913043478, 1.4833333333333, 0.5
17418, 1.9391304347826, 1.5, 0.5
17419, 1.9173913043478, 1.5166666666667, 0.5
17420, 1.9391304347826, 1.5333333333333, 0.5
17421, 1.9826086956522, 1.4666666666667, 0.5
17422, 1.9608695652174, 1.4833333333333, 0.5
17423, 1.9826086956522, 1.5, 0.5
17424, 1.9608695652174, 1.5166666666667, 0.5
17425, 1.9826086956522, 1.5333333333333, 0.5
17426, 2.0260869565217, 1.4666666666667, 0.5
17427, 2.004347826087, 1.4833333333333, 0.5
17428, 2.0260869565217, 1.5, 0.5
17429, 2.004347826087, 1.5166666666667, 0.5
17430, 2.0260869565217, 1.5333333333333, 0.5
17431, 2.0695652173913, 1.4666666666667, 0.5
17432, 2.0478260869565, 1.4833333333333, 0.5
17433, 2.0695652173913, 1.5, 0.5
17434, 2.0478260869565, 1.5166666666667, 0.5
17435, 2.0695652173913, 1.5333333333333, 0.5
17436, 2.1130434782609, 1.4666666666667, 0.5
17437, 2.0913043478261, 1.4833333333333, 0.5
17438, 2.1130434782609, 1.5, 0.5
17439, 2.0913043478261, 1.5166666666667, 0.5
17440, 2.1130434782609, 1.5333333333333, 0.5
17441, 2.1565217391304, 1.4666666666667, 0.5
17442, 2.1347826086957, 1.4833333333333, 0.5
17443, 2.1565217391304, 1.5, 0.5
17444, 2.1347826086957, 1.5166666666667, 0.5
17445, 2.1565217391304, 1.5333333333333, 0.5
17446, 2.1782608695652, 1.4833333333333, 0.5
17447, 2.1782608695652, 1.5166666666667, 0.5
17448, 1.2434782608696, 1.4833333333333, 0
17449, 1.2434782608696, 1.5166666666667, 0
17450, 1.2869565217391, 1.4833333333333, 0
17451, 1.2869565217391, 1.5166666666667, 0
17452, 1.3304347826087, 1.4833333333333, 0
17453, 1.3304347826087, 1.5166666666667, 0
17454, 1.3739130434783, 1.4833333333333, 0
17455, 1.3739130434783, 1.5166666666667, 0
17456, 1.4173913043478, 1.4833333333333, 0
17457, 1.4173913043478, 1.5166666666667, 0
17458, 1.4608695652174, 1.4833333333333, 0
17459, 1.4608695652174, 1.5166666666667, 0
17460, 1.504347826087, 1.4833333333333, 0
17461, 1.504347826087, 1.5166666666667, 0
17462, 1.5478260869565, 1.4833333333333, 0
17463, 1.5478260869565, 1.5166666666667, 0
17464, 1.5913043478261, 1.4833333333333, 0
17465, 1.5913043478261, 1.5166666666667, 0
17466, 1.6347826086957, 1.4833333333333, 0
17467, 1.6347826086957, 1.5166666666667, 0
17468, 1.6782608695652, 1.4833333333333, 0
17469, 1.6782608695652, 1.5166666666667, 0
17470, 1.7217391304348, 1.4833333333333, 0
17471, 1.7217391304348, 1.5166666666667, 0
17472, 1.7652173913043, 1.4833333333333, 0
17473, 1.7652173913043, 1.5166666666667, 0
17474, 1.8086956521739, 1.4833333333333, 0
17475, 1.8086956521739, 1.5166666666667, 0
17476, 1.8521739130435, 1.4833333333333, 0
17477, 1.8521739130435, 1.5166666666667, 0
17478, 1.895652173913, 1.4833333333333, 0
17479, 1.895652173913, 1.5166666666667, 0
17480, 1.9391304347826, 1.4833333333333, 0
17481, 1.9391304347826, 1.5166666666667, 0
17482, 1.9826086956522, 1.4833333333333, 0
17483, 1.9826086956522, 1.5166666666667, 0
17484, 2.0260869565217, 1.4833333333333, 0
17485, 2.0260869565217, 1.5166666666667, 0
17486, 2.0695652173913, 1.4833333333333, 0
17487, 2.0695652173913, 1.5166666666667, 0
17488, 2.1130434782609, 1.4833333333333, 0
17489, 2.1130434782609, 1.5166666666667, 0
17490, 2.1565217391304, 1.4833333333333, 0
17491, 2.1565217391304, 1.5166666666667, 0
17492, 1.2217391304348, 1.4833333333333, 0
17493, 1.2434782608696, 1.4666666666667, 0
17494, 1.2217391304348, 1.5166666666667, 0
17495, 1.2434782608696, 1.5, 0
17496, 1.2434782608696, 1.5333333333333, 0
17497, 1.2652173913043, 1.4833333333333, 0
17498, 1.2869565217391, 1.4666666666667, 0
17499, 1.2652173913043, 1.5166666666667, 0
17500, 1.2869565217391, 1.5, 0
17501, 1.2869565217391, 1.5333333333333, 0
17502, 1.3086956521739, 1.4833333333333, 0
17503, 1.3304347826087, 1.4666666666667, 0
17504, 1.3086956521739, 1.5166666666667, 0
17505, 1.3304347826087, 1.5, 0
17506, 1.3304347826087, 1.5333333333333, 0
17507, 1.3521739130435, 1.4833333333333, 0
17508, 1.3739130434783, 1.4666666666667, 0
17509, 1.3521739130435, 1.5166666666667, 0
17510, 1.3739130434783, 1.5, 0
17511, 1.3739130434783, 1.5333333333333, 0
17512, 1.395652173913, 1.4833333333333, 0
17513, 1.4173913043478, 1.4666666666667, 0
17514, 1.395652173913, 1.5166666666667, 0
17515, 1.4173913043478, 1.5, 0
17516, 1.4173913043478, 1.5333333333333, 0
17517, 1.4391304347826, 1.4833333333333, 0
17518, 1.4608695652174, 1.4666666666667, 0
17519, 1.4391304347826, 1.5166666666667, 0
17520, 1.4608695652174, 1.5, 0
17521, 1.4608695652174, 1.5333333333333, 0
17522, 1.4826086956522, 1.4833333333333, 0
17523, 1.504347826087, 1.4666666666667, 0
17524, 1.4826086956522, 1.5166666666667, 0
17525, 1.504347826087, 1.5, 0
17526, 1.504347826087, 1.5333333333333, 0
17527, 1.5260869565217, 1.4833333333333, 0
17528, 1.5478260869565, 1.4666666666667, 0
17529, 1.5260869565217, 1.5166666666667, 0
17530, 1.5478260869565, 1.5, 0
17531, 1.5478260869565, 1.5333333333333, 0
17532, 1.5695652173913, 1.4833333333333, 0
