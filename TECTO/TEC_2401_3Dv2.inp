72344, 2.0260869565217, 0.67173913043478, 0.027777777777778
72345, 2.0695652173913, 0.67173913043478, 0.47222222222222
72346, 2.0478260869565, 0.67173913043478, 0.44444444444444
72347, 2.0695652173913, 0.69782608695652, 0.44444444444444
72348, 2.0695652173913, 0.67173913043478, 0.41666666666667
72349, 2.0478260869565, 0.67173913043478, 0.38888888888889
72350, 2.0695652173913, 0.69782608695652, 0.38888888888889
72351, 2.0695652173913, 0.67173913043478, 0.36111111111111
72352, 2.0478260869565, 0.67173913043478, 0.33333333333333
72353, 2.0695652173913, 0.69782608695652, 0.33333333333333
72354, 2.0695652173913, 0.67173913043478, 0.30555555555556
72355, 2.0478260869565, 0.67173913043478, 0.27777777777778
72356, 2.0695652173913, 0.69782608695652, 0.27777777777778
72357, 2.0695652173913, 0.67173913043478, 0.25
72358, 2.0478260869565, 0.67173913043478, 0.22222222222222
72359, 2.0695652173913, 0.69782608695652, 0.22222222222222
72360, 2.0695652173913, 0.67173913043478, 0.19444444444444
72361, 2.0478260869565, 0.67173913043478, 0.16666666666667
72362, 2.0695652173913, 0.69782608695652, 0.16666666666667
72363, 2.0695652173913, 0.67173913043478, 0.13888888888889
72364, 2.0478260869565, 0.67173913043478, 0.11111111111111
72365, 2.0695652173913, 0.69782608695652, 0.11111111111111
72366, 2.0695652173913, 0.67173913043478, 0.083333333333333
72367, 2.0478260869565, 0.67173913043478, 0.055555555555556
72368, 2.0695652173913, 0.69782608695652, 0.055555555555556
72369, 2.0695652173913, 0.67173913043478, 0.027777777777778
72370, 2.1130434782609, 0.67173913043478, 0.47222222222222
72371, 2.0913043478261, 0.67173913043478, 0.44444444444444
72372, 2.1130434782609, 0.69782608695652, 0.44444444444444
72373, 2.1130434782609, 0.67173913043478, 0.41666666666667
72374, 2.0913043478261, 0.67173913043478, 0.38888888888889
72375, 2.1130434782609, 0.69782608695652, 0.38888888888889
72376, 2.1130434782609, 0.67173913043478, 0.36111111111111
72377, 2.0913043478261, 0.67173913043478, 0.33333333333333
72378, 2.1130434782609, 0.69782608695652, 0.33333333333333
72379, 2.1130434782609, 0.67173913043478, 0.30555555555556
72380, 2.0913043478261, 0.67173913043478, 0.27777777777778
72381, 2.1130434782609, 0.69782608695652, 0.27777777777778
72382, 2.1130434782609, 0.67173913043478, 0.25
72383, 2.0913043478261, 0.67173913043478, 0.22222222222222
72384, 2.1130434782609, 0.69782608695652, 0.22222222222222
72385, 2.1130434782609, 0.67173913043478, 0.19444444444444
72386, 2.0913043478261, 0.67173913043478, 0.16666666666667
72387, 2.1130434782609, 0.69782608695652, 0.16666666666667
72388, 2.1130434782609, 0.67173913043478, 0.13888888888889
72389, 2.0913043478261, 0.67173913043478, 0.11111111111111
72390, 2.1130434782609, 0.69782608695652, 0.11111111111111
72391, 2.1130434782609, 0.67173913043478, 0.083333333333333
72392, 2.0913043478261, 0.67173913043478, 0.055555555555556
72393, 2.1130434782609, 0.69782608695652, 0.055555555555556
72394, 2.1130434782609, 0.67173913043478, 0.027777777777778
72395, 2.1565217391304, 0.67173913043478, 0.47222222222222
72396, 2.1347826086957, 0.67173913043478, 0.44444444444444
72397, 2.1565217391304, 0.69782608695652, 0.44444444444444
72398, 2.1565217391304, 0.67173913043478, 0.41666666666667
72399, 2.1347826086957, 0.67173913043478, 0.38888888888889
72400, 2.1565217391304, 0.69782608695652, 0.38888888888889
72401, 2.1565217391304, 0.67173913043478, 0.36111111111111
72402, 2.1347826086957, 0.67173913043478, 0.33333333333333
72403, 2.1565217391304, 0.69782608695652, 0.33333333333333
72404, 2.1565217391304, 0.67173913043478, 0.30555555555556
72405, 2.1347826086957, 0.67173913043478, 0.27777777777778
72406, 2.1565217391304, 0.69782608695652, 0.27777777777778
72407, 2.1565217391304, 0.67173913043478, 0.25
72408, 2.1347826086957, 0.67173913043478, 0.22222222222222
72409, 2.1565217391304, 0.69782608695652, 0.22222222222222
72410, 2.1565217391304, 0.67173913043478, 0.19444444444444
72411, 2.1347826086957, 0.67173913043478, 0.16666666666667
72412, 2.1565217391304, 0.69782608695652, 0.16666666666667
72413, 2.1565217391304, 0.67173913043478, 0.13888888888889
72414, 2.1347826086957, 0.67173913043478, 0.11111111111111
72415, 2.1565217391304, 0.69782608695652, 0.11111111111111
72416, 2.1565217391304, 0.67173913043478, 0.083333333333333
72417, 2.1347826086957, 0.67173913043478, 0.055555555555556
72418, 2.1565217391304, 0.69782608695652, 0.055555555555556
72419, 2.1565217391304, 0.67173913043478, 0.027777777777778
72420, 2.1782608695652, 0.67173913043478, 0.44444444444444
72421, 2.1782608695652, 0.67173913043478, 0.38888888888889
72422, 2.1782608695652, 0.67173913043478, 0.33333333333333
72423, 2.1782608695652, 0.67173913043478, 0.27777777777778
72424, 2.1782608695652, 0.67173913043478, 0.22222222222222
72425, 2.1782608695652, 0.67173913043478, 0.16666666666667
72426, 2.1782608695652, 0.67173913043478, 0.11111111111111
72427, 2.1782608695652, 0.67173913043478, 0.055555555555556
72428, 1.2434782608696, 0.61956521739131, 0.47222222222222
72429, 1.2217391304348, 0.61956521739131, 0.44444444444444
72430, 1.2434782608696, 0.64565217391304, 0.44444444444444
72431, 1.2434782608696, 0.61956521739131, 0.41666666666667
72432, 1.2217391304348, 0.61956521739131, 0.38888888888889
72433, 1.2434782608696, 0.64565217391304, 0.38888888888889
72434, 1.2434782608696, 0.61956521739131, 0.36111111111111
72435, 1.2217391304348, 0.61956521739131, 0.33333333333333
72436, 1.2434782608696, 0.64565217391304, 0.33333333333333
72437, 1.2434782608696, 0.61956521739131, 0.30555555555556
72438, 1.2217391304348, 0.61956521739131, 0.27777777777778
72439, 1.2434782608696, 0.64565217391304, 0.27777777777778
72440, 1.2434782608696, 0.61956521739131, 0.25
72441, 1.2217391304348, 0.61956521739131, 0.22222222222222
72442, 1.2434782608696, 0.64565217391304, 0.22222222222222
72443, 1.2434782608696, 0.61956521739131, 0.19444444444444
72444, 1.2217391304348, 0.61956521739131, 0.16666666666667
72445, 1.2434782608696, 0.64565217391304, 0.16666666666667
72446, 1.2434782608696, 0.61956521739131, 0.13888888888889
72447, 1.2217391304348, 0.61956521739131, 0.11111111111111
72448, 1.2434782608696, 0.64565217391304, 0.11111111111111
72449, 1.2434782608696, 0.61956521739131, 0.083333333333333
72450, 1.2217391304348, 0.61956521739131, 0.055555555555556
72451, 1.2434782608696, 0.64565217391304, 0.055555555555556
72452, 1.2434782608696, 0.61956521739131, 0.027777777777778
72453, 1.2869565217391, 0.61956521739131, 0.47222222222222
72454, 1.2652173913043, 0.61956521739131, 0.44444444444444
72455, 1.2869565217391, 0.64565217391304, 0.44444444444444
72456, 1.2869565217391, 0.61956521739131, 0.41666666666667
72457, 1.2652173913043, 0.61956521739131, 0.38888888888889
72458, 1.2869565217391, 0.64565217391304, 0.38888888888889
72459, 1.2869565217391, 0.61956521739131, 0.36111111111111
72460, 1.2652173913043, 0.61956521739131, 0.33333333333333
72461, 1.2869565217391, 0.64565217391304, 0.33333333333333
72462, 1.2869565217391, 0.61956521739131, 0.30555555555556
72463, 1.2652173913043, 0.61956521739131, 0.27777777777778
72464, 1.2869565217391, 0.64565217391304, 0.27777777777778
72465, 1.2869565217391, 0.61956521739131, 0.25
72466, 1.2652173913043, 0.61956521739131, 0.22222222222222
72467, 1.2869565217391, 0.64565217391304, 0.22222222222222
72468, 1.2869565217391, 0.61956521739131, 0.19444444444444
72469, 1.2652173913043, 0.61956521739131, 0.16666666666667
72470, 1.2869565217391, 0.64565217391304, 0.16666666666667
72471, 1.2869565217391, 0.61956521739131, 0.13888888888889
72472, 1.2652173913043, 0.61956521739131, 0.11111111111111
72473, 1.2869565217391, 0.64565217391304, 0.11111111111111
72474, 1.2869565217391, 0.61956521739131, 0.083333333333333
72475, 1.2652173913043, 0.61956521739131, 0.055555555555556
72476, 1.2869565217391, 0.64565217391304, 0.055555555555556
72477, 1.2869565217391, 0.61956521739131, 0.027777777777778
72478, 1.3304347826087, 0.61956521739131, 0.47222222222222
72479, 1.3086956521739, 0.61956521739131, 0.44444444444444
72480, 1.3304347826087, 0.64565217391304, 0.44444444444444
72481, 1.3304347826087, 0.61956521739131, 0.41666666666667
72482, 1.3086956521739, 0.61956521739131, 0.38888888888889
72483, 1.3304347826087, 0.64565217391304, 0.38888888888889
72484, 1.3304347826087, 0.61956521739131, 0.36111111111111
72485, 1.3086956521739, 0.61956521739131, 0.33333333333333
72486, 1.3304347826087, 0.64565217391304, 0.33333333333333
72487, 1.3304347826087, 0.61956521739131, 0.30555555555556
72488, 1.3086956521739, 0.61956521739131, 0.27777777777778
72489, 1.3304347826087, 0.64565217391304, 0.27777777777778
72490, 1.3304347826087, 0.61956521739131, 0.25
72491, 1.3086956521739, 0.61956521739131, 0.22222222222222
72492, 1.3304347826087, 0.64565217391304, 0.22222222222222
72493, 1.3304347826087, 0.61956521739131, 0.19444444444444
72494, 1.3086956521739, 0.61956521739131, 0.16666666666667
72495, 1.3304347826087, 0.64565217391304, 0.16666666666667
72496, 1.3304347826087, 0.61956521739131, 0.13888888888889
72497, 1.3086956521739, 0.61956521739131, 0.11111111111111
72498, 1.3304347826087, 0.64565217391304, 0.11111111111111
72499, 1.3304347826087, 0.61956521739131, 0.083333333333333
72500, 1.3086956521739, 0.61956521739131, 0.055555555555556
72501, 1.3304347826087, 0.64565217391304, 0.055555555555556
72502, 1.3304347826087, 0.61956521739131, 0.027777777777778
72503, 1.3739130434783, 0.61956521739131, 0.47222222222222
72504, 1.3521739130435, 0.61956521739131, 0.44444444444444
72505, 1.3739130434783, 0.64565217391304, 0.44444444444444
72506, 1.3739130434783, 0.61956521739131, 0.41666666666667
72507, 1.3521739130435, 0.61956521739131, 0.38888888888889
72508, 1.3739130434783, 0.64565217391304, 0.38888888888889
72509, 1.3739130434783, 0.61956521739131, 0.36111111111111
72510, 1.3521739130435, 0.61956521739131, 0.33333333333333
72511, 1.3739130434783, 0.64565217391304, 0.33333333333333
72512, 1.3739130434783, 0.61956521739131, 0.30555555555556
72513, 1.3521739130435, 0.61956521739131, 0.27777777777778
72514, 1.3739130434783, 0.64565217391304, 0.27777777777778
72515, 1.3739130434783, 0.61956521739131, 0.25
72516, 1.3521739130435, 0.61956521739131, 0.22222222222222
72517, 1.3739130434783, 0.64565217391304, 0.22222222222222
72518, 1.3739130434783, 0.61956521739131, 0.19444444444444
72519, 1.3521739130435, 0.61956521739131, 0.16666666666667
72520, 1.3739130434783, 0.64565217391304, 0.16666666666667
72521, 1.3739130434783, 0.61956521739131, 0.13888888888889
72522, 1.3521739130435, 0.61956521739131, 0.11111111111111
72523, 1.3739130434783, 0.64565217391304, 0.11111111111111
72524, 1.3739130434783, 0.61956521739131, 0.083333333333333
72525, 1.3521739130435, 0.61956521739131, 0.055555555555556
72526, 1.3739130434783, 0.64565217391304, 0.055555555555556
72527, 1.3739130434783, 0.61956521739131, 0.027777777777778
72528, 1.4173913043478, 0.61956521739131, 0.47222222222222
72529, 1.395652173913, 0.61956521739131, 0.44444444444444
72530, 1.4173913043478, 0.64565217391304, 0.44444444444444
72531, 1.4173913043478, 0.61956521739131, 0.41666666666667
72532, 1.395652173913, 0.61956521739131, 0.38888888888889
72533, 1.4173913043478, 0.64565217391304, 0.38888888888889
72534, 1.4173913043478, 0.61956521739131, 0.36111111111111
72535, 1.395652173913, 0.61956521739131, 0.33333333333333
72536, 1.4173913043478, 0.64565217391304, 0.33333333333333
72537, 1.4173913043478, 0.61956521739131, 0.30555555555556
72538, 1.395652173913, 0.61956521739131, 0.27777777777778
72539, 1.4173913043478, 0.64565217391304, 0.27777777777778
72540, 1.4173913043478, 0.61956521739131, 0.25
72541, 1.395652173913, 0.61956521739131, 0.22222222222222
72542, 1.4173913043478, 0.64565217391304, 0.22222222222222
72543, 1.4173913043478, 0.61956521739131, 0.19444444444444
72544, 1.395652173913, 0.61956521739131, 0.16666666666667
72545, 1.4173913043478, 0.64565217391304, 0.16666666666667
72546, 1.4173913043478, 0.61956521739131, 0.13888888888889
72547, 1.395652173913, 0.61956521739131, 0.11111111111111
72548, 1.4173913043478, 0.64565217391304, 0.11111111111111
72549, 1.4173913043478, 0.61956521739131, 0.083333333333333
72550, 1.395652173913, 0.61956521739131, 0.055555555555556
72551, 1.4173913043478, 0.64565217391304, 0.055555555555556
72552, 1.4173913043478, 0.61956521739131, 0.027777777777778
72553, 1.4608695652174, 0.61956521739131, 0.47222222222222
72554, 1.4391304347826, 0.61956521739131, 0.44444444444444
72555, 1.4608695652174, 0.64565217391304, 0.44444444444444
72556, 1.4608695652174, 0.61956521739131, 0.41666666666667
72557, 1.4391304347826, 0.61956521739131, 0.38888888888889
72558, 1.4608695652174, 0.64565217391304, 0.38888888888889
72559, 1.4608695652174, 0.61956521739131, 0.36111111111111
72560, 1.4391304347826, 0.61956521739131, 0.33333333333333
72561, 1.4608695652174, 0.64565217391304, 0.33333333333333
72562, 1.4608695652174, 0.6195652173913, 0.30555555555556
72563, 1.4391304347826, 0.6195652173913, 0.27777777777778
72564, 1.4608695652174, 0.64565217391304, 0.27777777777778
72565, 1.4608695652174, 0.6195652173913, 0.25
72566, 1.4391304347826, 0.61956521739131, 0.22222222222222
72567, 1.4608695652174, 0.64565217391304, 0.22222222222222
72568, 1.4608695652174, 0.6195652173913, 0.19444444444444
72569, 1.4391304347826, 0.6195652173913, 0.16666666666667
72570, 1.4608695652174, 0.64565217391304, 0.16666666666667
72571, 1.4608695652174, 0.6195652173913, 0.13888888888889
72572, 1.4391304347826, 0.61956521739131, 0.11111111111111
72573, 1.4608695652174, 0.64565217391304, 0.11111111111111
72574, 1.4608695652174, 0.61956521739131, 0.083333333333333
72575, 1.4391304347826, 0.61956521739131, 0.055555555555556
72576, 1.4608695652174, 0.64565217391304, 0.055555555555556
72577, 1.4608695652174, 0.61956521739131, 0.027777777777778
72578, 1.504347826087, 0.61956521739131, 0.47222222222222
72579, 1.4826086956522, 0.61956521739131, 0.44444444444444
72580, 1.504347826087, 0.64565217391304, 0.44444444444444
72581, 1.504347826087, 0.6195652173913, 0.41666666666667
72582, 1.4826086956522, 0.6195652173913, 0.38888888888889
72583, 1.504347826087, 0.64565217391304, 0.38888888888889
72584, 1.504347826087, 0.6195652173913, 0.36111111111111
72585, 1.4826086956522, 0.61956521739131, 0.33333333333333
72586, 1.504347826087, 0.64565217391304, 0.33333333333333
72587, 1.504347826087, 0.6195652173913, 0.30555555555556
72588, 1.4826086956522, 0.6195652173913, 0.27777777777778
72589, 1.504347826087, 0.64565217391304, 0.27777777777778
72590, 1.504347826087, 0.6195652173913, 0.25
72591, 1.4826086956522, 0.6195652173913, 0.22222222222222
72592, 1.504347826087, 0.64565217391304, 0.22222222222222
72593, 1.504347826087, 0.6195652173913, 0.19444444444444
72594, 1.4826086956522, 0.6195652173913, 0.16666666666667
72595, 1.504347826087, 0.64565217391304, 0.16666666666667
72596, 1.504347826087, 0.6195652173913, 0.13888888888889
72597, 1.4826086956522, 0.6195652173913, 0.11111111111111
72598, 1.504347826087, 0.64565217391304, 0.11111111111111
72599, 1.504347826087, 0.6195652173913, 0.083333333333333
72600, 1.4826086956522, 0.6195652173913, 0.055555555555556
72601, 1.504347826087, 0.64565217391304, 0.055555555555556
72602, 1.504347826087, 0.6195652173913, 0.027777777777778
72603, 1.5478260869565, 0.61956521739131, 0.47222222222222
72604, 1.5260869565217, 0.61956521739131, 0.44444444444444
72605, 1.5478260869565, 0.64565217391304, 0.44444444444444
72606, 1.5478260869565, 0.61956521739131, 0.41666666666667
72607, 1.5260869565217, 0.6195652173913, 0.38888888888889
72608, 1.5478260869565, 0.64565217391304, 0.38888888888889
72609, 1.5478260869565, 0.61956521739131, 0.36111111111111
72610, 1.5260869565217, 0.61956521739131, 0.33333333333333
72611, 1.5478260869565, 0.64565217391304, 0.33333333333333
72612, 1.5478260869565, 0.61956521739131, 0.30555555555556
72613, 1.5260869565217, 0.6195652173913, 0.27777777777778
72614, 1.5478260869565, 0.64565217391304, 0.27777777777778
72615, 1.5478260869565, 0.61956521739131, 0.25
72616, 1.5260869565217, 0.6195652173913, 0.22222222222222
72617, 1.5478260869565, 0.64565217391304, 0.22222222222222
72618, 1.5478260869565, 0.61956521739131, 0.19444444444444
72619, 1.5260869565217, 0.6195652173913, 0.16666666666667
72620, 1.5478260869565, 0.64565217391304, 0.16666666666667
72621, 1.5478260869565, 0.61956521739131, 0.13888888888889
72622, 1.5260869565217, 0.6195652173913, 0.11111111111111
72623, 1.5478260869565, 0.64565217391304, 0.11111111111111
72624, 1.5478260869565, 0.61956521739131, 0.083333333333333
72625, 1.5260869565217, 0.6195652173913, 0.055555555555556
72626, 1.5478260869565, 0.64565217391304, 0.055555555555556
72627, 1.5478260869565, 0.61956521739131, 0.027777777777778
72628, 1.5913043478261, 0.61956521739131, 0.47222222222222
72629, 1.5695652173913, 0.61956521739131, 0.44444444444444
72630, 1.5913043478261, 0.64565217391304, 0.44444444444444
72631, 1.5913043478261, 0.61956521739131, 0.41666666666667
72632, 1.5695652173913, 0.61956521739131, 0.38888888888889
72633, 1.5913043478261, 0.64565217391304, 0.38888888888889
72634, 1.5913043478261, 0.61956521739131, 0.36111111111111
72635, 1.5695652173913, 0.61956521739131, 0.33333333333333
72636, 1.5913043478261, 0.64565217391304, 0.33333333333333
72637, 1.5913043478261, 0.6195652173913, 0.30555555555556
72638, 1.5695652173913, 0.6195652173913, 0.27777777777778
72639, 1.5913043478261, 0.64565217391304, 0.27777777777778
72640, 1.5913043478261, 0.6195652173913, 0.25
72641, 1.5695652173913, 0.61956521739131, 0.22222222222222
72642, 1.5913043478261, 0.64565217391304, 0.22222222222222
72643, 1.5913043478261, 0.6195652173913, 0.19444444444444
72644, 1.5695652173913, 0.6195652173913, 0.16666666666667
72645, 1.5913043478261, 0.64565217391304, 0.16666666666667
72646, 1.5913043478261, 0.6195652173913, 0.13888888888889
72647, 1.5695652173913, 0.61956521739131, 0.11111111111111
72648, 1.5913043478261, 0.64565217391304, 0.11111111111111
72649, 1.5913043478261, 0.6195652173913, 0.083333333333333
72650, 1.5695652173913, 0.61956521739131, 0.055555555555556
72651, 1.5913043478261, 0.64565217391304, 0.055555555555556
72652, 1.5913043478261, 0.61956521739131, 0.027777777777778
72653, 1.6347826086957, 0.61956521739131, 0.47222222222222
72654, 1.6130434782609, 0.61956521739131, 0.44444444444444
72655, 1.6347826086957, 0.64565217391304, 0.44444444444444
72656, 1.6347826086957, 0.61956521739131, 0.41666666666667
72657, 1.6130434782609, 0.61956521739131, 0.38888888888889
72658, 1.6347826086957, 0.64565217391304, 0.38888888888889
72659, 1.6347826086957, 0.61956521739131, 0.36111111111111
72660, 1.6130434782609, 0.61956521739131, 0.33333333333333
72661, 1.6347826086957, 0.64565217391304, 0.33333333333333
72662, 1.6347826086957, 0.61956521739131, 0.30555555555556
72663, 1.6130434782609, 0.6195652173913, 0.27777777777778
72664, 1.6347826086957, 0.64565217391304, 0.27777777777778
72665, 1.6347826086957, 0.61956521739131, 0.25
72666, 1.6130434782609, 0.61956521739131, 0.22222222222222
72667, 1.6347826086957, 0.64565217391304, 0.22222222222222
72668, 1.6347826086957, 0.61956521739131, 0.19444444444444
72669, 1.6130434782609, 0.6195652173913, 0.16666666666667
72670, 1.6347826086957, 0.64565217391304, 0.16666666666667
72671, 1.6347826086957, 0.61956521739131, 0.13888888888889
72672, 1.6130434782609, 0.61956521739131, 0.11111111111111
72673, 1.6347826086957, 0.64565217391304, 0.11111111111111
72674, 1.6347826086957, 0.61956521739131, 0.083333333333333
72675, 1.6130434782609, 0.61956521739131, 0.055555555555556
72676, 1.6347826086957, 0.64565217391304, 0.055555555555556
72677, 1.6347826086957, 0.61956521739131, 0.027777777777778
72678, 1.6782608695652, 0.61956521739131, 0.47222222222222
72679, 1.6565217391304, 0.61956521739131, 0.44444444444444
72680, 1.6782608695652, 0.64565217391304, 0.44444444444444
72681, 1.6782608695652, 0.61956521739131, 0.41666666666667
72682, 1.6565217391304, 0.61956521739131, 0.38888888888889
72683, 1.6782608695652, 0.64565217391304, 0.38888888888889
72684, 1.6782608695652, 0.61956521739131, 0.36111111111111
72685, 1.6565217391304, 0.61956521739131, 0.33333333333333
72686, 1.6782608695652, 0.64565217391304, 0.33333333333333
72687, 1.6782608695652, 0.61956521739131, 0.30555555555556
72688, 1.6565217391304, 0.61956521739131, 0.27777777777778
72689, 1.6782608695652, 0.64565217391304, 0.27777777777778
72690, 1.6782608695652, 0.61956521739131, 0.25
72691, 1.6565217391304, 0.61956521739131, 0.22222222222222
72692, 1.6782608695652, 0.64565217391304, 0.22222222222222
72693, 1.6782608695652, 0.61956521739131, 0.19444444444444
72694, 1.6565217391304, 0.61956521739131, 0.16666666666667
72695, 1.6782608695652, 0.64565217391304, 0.16666666666667
72696, 1.6782608695652, 0.61956521739131, 0.13888888888889
72697, 1.6565217391304, 0.61956521739131, 0.11111111111111
72698, 1.6782608695652, 0.64565217391304, 0.11111111111111
72699, 1.6782608695652, 0.61956521739131, 0.083333333333333
72700, 1.6565217391304, 0.61956521739131, 0.055555555555556
72701, 1.6782608695652, 0.64565217391304, 0.055555555555556
72702, 1.6782608695652, 0.61956521739131, 0.027777777777778
72703, 1.7217391304348, 0.61956521739131, 0.47222222222222
72704, 1.7, 0.61956521739131, 0.44444444444444
72705, 1.7217391304348, 0.64565217391304, 0.44444444444444
72706, 1.7217391304348, 0.61956521739131, 0.41666666666667
72707, 1.7, 0.61956521739131, 0.38888888888889
72708, 1.7217391304348, 0.64565217391304, 0.38888888888889
72709, 1.7217391304348, 0.61956521739131, 0.36111111111111
72710, 1.7, 0.61956521739131, 0.33333333333333
72711, 1.7217391304348, 0.64565217391304, 0.33333333333333
72712, 1.7217391304348, 0.61956521739131, 0.30555555555556
72713, 1.7, 0.6195652173913, 0.27777777777778
72714, 1.7217391304348, 0.64565217391304, 0.27777777777778
72715, 1.7217391304348, 0.61956521739131, 0.25
72716, 1.7, 0.61956521739131, 0.22222222222222
72717, 1.7217391304348, 0.64565217391304, 0.22222222222222
72718, 1.7217391304348, 0.61956521739131, 0.19444444444444
72719, 1.7, 0.61956521739131, 0.16666666666667
72720, 1.7217391304348, 0.64565217391304, 0.16666666666667
72721, 1.7217391304348, 0.61956521739131, 0.13888888888889
72722, 1.7, 0.61956521739131, 0.11111111111111
72723, 1.7217391304348, 0.64565217391304, 0.11111111111111
72724, 1.7217391304348, 0.61956521739131, 0.083333333333333
72725, 1.7, 0.61956521739131, 0.055555555555556
72726, 1.7217391304348, 0.64565217391304, 0.055555555555556
72727, 1.7217391304348, 0.61956521739131, 0.027777777777778
72728, 1.7652173913043, 0.61956521739131, 0.47222222222222
72729, 1.7434782608696, 0.61956521739131, 0.44444444444444
72730, 1.7652173913043, 0.64565217391304, 0.44444444444444
72731, 1.7652173913043, 0.61956521739131, 0.41666666666667
72732, 1.7434782608696, 0.61956521739131, 0.38888888888889
72733, 1.7652173913043, 0.64565217391304, 0.38888888888889
72734, 1.7652173913043, 0.61956521739131, 0.36111111111111
72735, 1.7434782608696, 0.61956521739131, 0.33333333333333
72736, 1.7652173913043, 0.64565217391304, 0.33333333333333
72737, 1.7652173913043, 0.61956521739131, 0.30555555555556
72738, 1.7434782608696, 0.61956521739131, 0.27777777777778
72739, 1.7652173913043, 0.64565217391304, 0.27777777777778
72740, 1.7652173913043, 0.61956521739131, 0.25
72741, 1.7434782608696, 0.61956521739131, 0.22222222222222
72742, 1.7652173913043, 0.64565217391304, 0.22222222222222
72743, 1.7652173913043, 0.61956521739131, 0.19444444444444
72744, 1.7434782608696, 0.61956521739131, 0.16666666666667
72745, 1.7652173913043, 0.64565217391304, 0.16666666666667
72746, 1.7652173913043, 0.61956521739131, 0.13888888888889
72747, 1.7434782608696, 0.61956521739131, 0.11111111111111
72748, 1.7652173913043, 0.64565217391304, 0.11111111111111
72749, 1.7652173913043, 0.61956521739131, 0.083333333333333
72750, 1.7434782608696, 0.61956521739131, 0.055555555555556
72751, 1.7652173913043, 0.64565217391304, 0.055555555555556
72752, 1.7652173913043, 0.61956521739131, 0.027777777777778
72753, 1.8086956521739, 0.61956521739131, 0.47222222222222
72754, 1.7869565217391, 0.61956521739131, 0.44444444444444
72755, 1.8086956521739, 0.64565217391304, 0.44444444444444
72756, 1.8086956521739, 0.61956521739131, 0.41666666666667
72757, 1.7869565217391, 0.61956521739131, 0.38888888888889
72758, 1.8086956521739, 0.64565217391304, 0.38888888888889
72759, 1.8086956521739, 0.61956521739131, 0.36111111111111
72760, 1.7869565217391, 0.61956521739131, 0.33333333333333
72761, 1.8086956521739, 0.64565217391304, 0.33333333333333
72762, 1.8086956521739, 0.61956521739131, 0.30555555555556
72763, 1.7869565217391, 0.61956521739131, 0.27777777777778
72764, 1.8086956521739, 0.64565217391304, 0.27777777777778
72765, 1.8086956521739, 0.61956521739131, 0.25
72766, 1.7869565217391, 0.61956521739131, 0.22222222222222
72767, 1.8086956521739, 0.64565217391304, 0.22222222222222
72768, 1.8086956521739, 0.61956521739131, 0.19444444444444
72769, 1.7869565217391, 0.6195652173913, 0.16666666666667
72770, 1.8086956521739, 0.64565217391304, 0.16666666666667
72771, 1.8086956521739, 0.61956521739131, 0.13888888888889
72772, 1.7869565217391, 0.61956521739131, 0.11111111111111
72773, 1.8086956521739, 0.64565217391304, 0.11111111111111
72774, 1.8086956521739, 0.61956521739131, 0.083333333333333
72775, 1.7869565217391, 0.61956521739131, 0.055555555555556
72776, 1.8086956521739, 0.64565217391304, 0.055555555555556
72777, 1.8086956521739, 0.61956521739131, 0.027777777777778
72778, 1.8521739130435, 0.61956521739131, 0.47222222222222
72779, 1.8304347826087, 0.61956521739131, 0.44444444444444
72780, 1.8521739130435, 0.64565217391304, 0.44444444444444
72781, 1.8521739130435, 0.61956521739131, 0.41666666666667
72782, 1.8304347826087, 0.61956521739131, 0.38888888888889
72783, 1.8521739130435, 0.64565217391304, 0.38888888888889
72784, 1.8521739130435, 0.61956521739131, 0.36111111111111
72785, 1.8304347826087, 0.61956521739131, 0.33333333333333
72786, 1.8521739130435, 0.64565217391304, 0.33333333333333
72787, 1.8521739130435, 0.61956521739131, 0.30555555555556
72788, 1.8304347826087, 0.61956521739131, 0.27777777777778
72789, 1.8521739130435, 0.64565217391304, 0.27777777777778
72790, 1.8521739130435, 0.61956521739131, 0.25
72791, 1.8304347826087, 0.61956521739131, 0.22222222222222
72792, 1.8521739130435, 0.64565217391304, 0.22222222222222
72793, 1.8521739130435, 0.61956521739131, 0.19444444444444
72794, 1.8304347826087, 0.6195652173913, 0.16666666666667
72795, 1.8521739130435, 0.64565217391304, 0.16666666666667
72796, 1.8521739130435, 0.61956521739131, 0.13888888888889
72797, 1.8304347826087, 0.61956521739131, 0.11111111111111
72798, 1.8521739130435, 0.64565217391304, 0.11111111111111
72799, 1.8521739130435, 0.61956521739131, 0.083333333333333
72800, 1.8304347826087, 0.61956521739131, 0.055555555555556
72801, 1.8521739130435, 0.64565217391304, 0.055555555555556
72802, 1.8521739130435, 0.61956521739131, 0.027777777777778
72803, 1.895652173913, 0.61956521739131, 0.47222222222222
72804, 1.8739130434783, 0.61956521739131, 0.44444444444444
72805, 1.895652173913, 0.64565217391304, 0.44444444444444
72806, 1.895652173913, 0.61956521739131, 0.41666666666667
72807, 1.8739130434783, 0.61956521739131, 0.38888888888889
72808, 1.895652173913, 0.64565217391304, 0.38888888888889
72809, 1.895652173913, 0.61956521739131, 0.36111111111111
72810, 1.8739130434783, 0.61956521739131, 0.33333333333333
72811, 1.895652173913, 0.64565217391304, 0.33333333333333
72812, 1.895652173913, 0.61956521739131, 0.30555555555556
72813, 1.8739130434783, 0.61956521739131, 0.27777777777778
72814, 1.895652173913, 0.64565217391304, 0.27777777777778
72815, 1.895652173913, 0.61956521739131, 0.25
72816, 1.8739130434783, 0.61956521739131, 0.22222222222222
72817, 1.895652173913, 0.64565217391304, 0.22222222222222
72818, 1.895652173913, 0.61956521739131, 0.19444444444444
72819, 1.8739130434783, 0.61956521739131, 0.16666666666667
72820, 1.895652173913, 0.64565217391304, 0.16666666666667
72821, 1.895652173913, 0.61956521739131, 0.13888888888889
72822, 1.8739130434783, 0.61956521739131, 0.11111111111111
72823, 1.895652173913, 0.64565217391304, 0.11111111111111
72824, 1.895652173913, 0.61956521739131, 0.083333333333333
72825, 1.8739130434783, 0.61956521739131, 0.055555555555556
72826, 1.895652173913, 0.64565217391304, 0.055555555555556
72827, 1.895652173913, 0.61956521739131, 0.027777777777778
72828, 1.9391304347826, 0.61956521739131, 0.47222222222222
72829, 1.9173913043478, 0.61956521739131, 0.44444444444444
72830, 1.9391304347826, 0.64565217391304, 0.44444444444444
72831, 1.9391304347826, 0.61956521739131, 0.41666666666667
72832, 1.9173913043478, 0.61956521739131, 0.38888888888889
72833, 1.9391304347826, 0.64565217391304, 0.38888888888889
72834, 1.9391304347826, 0.61956521739131, 0.36111111111111
72835, 1.9173913043478, 0.61956521739131, 0.33333333333333
72836, 1.9391304347826, 0.64565217391304, 0.33333333333333
72837, 1.9391304347826, 0.61956521739131, 0.30555555555556
72838, 1.9173913043478, 0.61956521739131, 0.27777777777778
72839, 1.9391304347826, 0.64565217391304, 0.27777777777778
72840, 1.9391304347826, 0.61956521739131, 0.25
72841, 1.9173913043478, 0.61956521739131, 0.22222222222222
72842, 1.9391304347826, 0.64565217391304, 0.22222222222222
72843, 1.9391304347826, 0.61956521739131, 0.19444444444444
72844, 1.9173913043478, 0.61956521739131, 0.16666666666667
72845, 1.9391304347826, 0.64565217391304, 0.16666666666667
72846, 1.9391304347826, 0.61956521739131, 0.13888888888889
72847, 1.9173913043478, 0.61956521739131, 0.11111111111111
72848, 1.9391304347826, 0.64565217391304, 0.11111111111111
72849, 1.9391304347826, 0.61956521739131, 0.083333333333333
72850, 1.9173913043478, 0.61956521739131, 0.055555555555556
72851, 1.9391304347826, 0.64565217391304, 0.055555555555556
72852, 1.9391304347826, 0.61956521739131, 0.027777777777778
72853, 1.9826086956522, 0.61956521739131, 0.47222222222222
72854, 1.9608695652174, 0.61956521739131, 0.44444444444444
72855, 1.9826086956522, 0.64565217391304, 0.44444444444444
72856, 1.9826086956522, 0.61956521739131, 0.41666666666667
72857, 1.9608695652174, 0.61956521739131, 0.38888888888889
72858, 1.9826086956522, 0.64565217391304, 0.38888888888889
72859, 1.9826086956522, 0.61956521739131, 0.36111111111111
72860, 1.9608695652174, 0.61956521739131, 0.33333333333333
72861, 1.9826086956522, 0.64565217391304, 0.33333333333333
72862, 1.9826086956522, 0.61956521739131, 0.30555555555556
72863, 1.9608695652174, 0.61956521739131, 0.27777777777778
72864, 1.9826086956522, 0.64565217391304, 0.27777777777778
72865, 1.9826086956522, 0.61956521739131, 0.25
72866, 1.9608695652174, 0.61956521739131, 0.22222222222222
72867, 1.9826086956522, 0.64565217391304, 0.22222222222222
72868, 1.9826086956522, 0.61956521739131, 0.19444444444444
72869, 1.9608695652174, 0.61956521739131, 0.16666666666667
72870, 1.9826086956522, 0.64565217391304, 0.16666666666667
72871, 1.9826086956522, 0.61956521739131, 0.13888888888889
72872, 1.9608695652174, 0.61956521739131, 0.11111111111111
72873, 1.9826086956522, 0.64565217391304, 0.11111111111111
72874, 1.9826086956522, 0.61956521739131, 0.083333333333333
72875, 1.9608695652174, 0.61956521739131, 0.055555555555556
72876, 1.9826086956522, 0.64565217391304, 0.055555555555556
72877, 1.9826086956522, 0.61956521739131, 0.027777777777778
72878, 2.0260869565217, 0.61956521739131, 0.47222222222222
72879, 2.004347826087, 0.61956521739131, 0.44444444444444
72880, 2.0260869565217, 0.64565217391304, 0.44444444444444
72881, 2.0260869565217, 0.61956521739131, 0.41666666666667
72882, 2.004347826087, 0.61956521739131, 0.38888888888889
72883, 2.0260869565217, 0.64565217391304, 0.38888888888889
72884, 2.0260869565217, 0.61956521739131, 0.36111111111111
72885, 2.004347826087, 0.61956521739131, 0.33333333333333
72886, 2.0260869565217, 0.64565217391304, 0.33333333333333
72887, 2.0260869565217, 0.6195652173913, 0.30555555555556
72888, 2.004347826087, 0.61956521739131, 0.27777777777778
72889, 2.0260869565217, 0.64565217391304, 0.27777777777778
72890, 2.0260869565217, 0.61956521739131, 0.25
72891, 2.004347826087, 0.61956521739131, 0.22222222222222
72892, 2.0260869565217, 0.64565217391304, 0.22222222222222
72893, 2.0260869565217, 0.6195652173913, 0.19444444444444
72894, 2.004347826087, 0.6195652173913, 0.16666666666667
72895, 2.0260869565217, 0.64565217391304, 0.16666666666667
72896, 2.0260869565217, 0.6195652173913, 0.13888888888889
72897, 2.004347826087, 0.61956521739131, 0.11111111111111
72898, 2.0260869565217, 0.64565217391304, 0.11111111111111
72899, 2.0260869565217, 0.61956521739131, 0.083333333333333
72900, 2.004347826087, 0.61956521739131, 0.055555555555556
72901, 2.0260869565217, 0.64565217391304, 0.055555555555556
72902, 2.0260869565217, 0.61956521739131, 0.027777777777778
72903, 2.0695652173913, 0.61956521739131, 0.47222222222222
72904, 2.0478260869565, 0.61956521739131, 0.44444444444444
72905, 2.0695652173913, 0.64565217391304, 0.44444444444444
72906, 2.0695652173913, 0.61956521739131, 0.41666666666667
72907, 2.0478260869565, 0.61956521739131, 0.38888888888889
72908, 2.0695652173913, 0.64565217391304, 0.38888888888889
72909, 2.0695652173913, 0.61956521739131, 0.36111111111111
72910, 2.0478260869565, 0.61956521739131, 0.33333333333333
72911, 2.0695652173913, 0.64565217391304, 0.33333333333333
72912, 2.0695652173913, 0.61956521739131, 0.30555555555556
72913, 2.0478260869565, 0.6195652173913, 0.27777777777778
72914, 2.0695652173913, 0.64565217391304, 0.27777777777778
72915, 2.0695652173913, 0.61956521739131, 0.25
72916, 2.0478260869565, 0.61956521739131, 0.22222222222222
72917, 2.0695652173913, 0.64565217391304, 0.22222222222222
72918, 2.0695652173913, 0.61956521739131, 0.19444444444444
72919, 2.0478260869565, 0.6195652173913, 0.16666666666667
72920, 2.0695652173913, 0.64565217391304, 0.16666666666667
72921, 2.0695652173913, 0.61956521739131, 0.13888888888889
72922, 2.0478260869565, 0.61956521739131, 0.11111111111111
72923, 2.0695652173913, 0.64565217391304, 0.11111111111111
72924, 2.0695652173913, 0.61956521739131, 0.083333333333333
72925, 2.0478260869565, 0.61956521739131, 0.055555555555556
72926, 2.0695652173913, 0.64565217391304, 0.055555555555556
72927, 2.0695652173913, 0.61956521739131, 0.027777777777778
72928, 2.1130434782609, 0.61956521739131, 0.47222222222222
72929, 2.0913043478261, 0.61956521739131, 0.44444444444444
72930, 2.1130434782609, 0.64565217391304, 0.44444444444444
72931, 2.1130434782609, 0.61956521739131, 0.41666666666667
72932, 2.0913043478261, 0.61956521739131, 0.38888888888889
72933, 2.1130434782609, 0.64565217391304, 0.38888888888889
72934, 2.1130434782609, 0.61956521739131, 0.36111111111111
72935, 2.0913043478261, 0.61956521739131, 0.33333333333333
72936, 2.1130434782609, 0.64565217391304, 0.33333333333333
72937, 2.1130434782609, 0.61956521739131, 0.30555555555556
72938, 2.0913043478261, 0.61956521739131, 0.27777777777778
72939, 2.1130434782609, 0.64565217391304, 0.27777777777778
72940, 2.1130434782609, 0.61956521739131, 0.25
72941, 2.0913043478261, 0.61956521739131, 0.22222222222222
72942, 2.1130434782609, 0.64565217391304, 0.22222222222222
72943, 2.1130434782609, 0.61956521739131, 0.19444444444444
72944, 2.0913043478261, 0.6195652173913, 0.16666666666667
72945, 2.1130434782609, 0.64565217391304, 0.16666666666667
72946, 2.1130434782609, 0.61956521739131, 0.13888888888889
72947, 2.0913043478261, 0.61956521739131, 0.11111111111111
72948, 2.1130434782609, 0.64565217391304, 0.11111111111111
72949, 2.1130434782609, 0.61956521739131, 0.083333333333333
72950, 2.0913043478261, 0.61956521739131, 0.055555555555556
72951, 2.1130434782609, 0.64565217391304, 0.055555555555556
72952, 2.1130434782609, 0.61956521739131, 0.027777777777778
72953, 2.1565217391304, 0.61956521739131, 0.47222222222222
72954, 2.1347826086957, 0.61956521739131, 0.44444444444444
72955, 2.1565217391304, 0.64565217391304, 0.44444444444444
72956, 2.1565217391304, 0.61956521739131, 0.41666666666667
72957, 2.1347826086957, 0.61956521739131, 0.38888888888889
72958, 2.1565217391304, 0.64565217391304, 0.38888888888889
72959, 2.1565217391304, 0.61956521739131, 0.36111111111111
72960, 2.1347826086957, 0.61956521739131, 0.33333333333333
72961, 2.1565217391304, 0.64565217391304, 0.33333333333333
72962, 2.1565217391304, 0.61956521739131, 0.30555555555556
72963, 2.1347826086957, 0.61956521739131, 0.27777777777778
72964, 2.1565217391304, 0.64565217391304, 0.27777777777778
72965, 2.1565217391304, 0.61956521739131, 0.25
72966, 2.1347826086957, 0.61956521739131, 0.22222222222222
72967, 2.1565217391304, 0.64565217391304, 0.22222222222222
72968, 2.1565217391304, 0.61956521739131, 0.19444444444444
72969, 2.1347826086957, 0.61956521739131, 0.16666666666667
72970, 2.1565217391304, 0.64565217391304, 0.16666666666667
72971, 2.1565217391304, 0.61956521739131, 0.13888888888889
72972, 2.1347826086957, 0.61956521739131, 0.11111111111111
72973, 2.1565217391304, 0.64565217391304, 0.11111111111111
72974, 2.1565217391304, 0.61956521739131, 0.083333333333333
72975, 2.1347826086957, 0.61956521739131, 0.055555555555556
72976, 2.1565217391304, 0.64565217391304, 0.055555555555556
72977, 2.1565217391304, 0.61956521739131, 0.027777777777778
72978, 2.1782608695652, 0.61956521739131, 0.44444444444444
72979, 2.1782608695652, 0.61956521739131, 0.38888888888889
72980, 2.1782608695652, 0.61956521739131, 0.33333333333333
72981, 2.1782608695652, 0.61956521739131, 0.27777777777778
72982, 2.1782608695652, 0.61956521739131, 0.22222222222222
72983, 2.1782608695652, 0.61956521739131, 0.16666666666667
72984, 2.1782608695652, 0.61956521739131, 0.11111111111111
72985, 2.1782608695652, 0.61956521739131, 0.055555555555556
72986, 1.2434782608696, 0.56739130434783, 0.47222222222222
72987, 1.2217391304348, 0.56739130434783, 0.44444444444444
72988, 1.2434782608696, 0.59347826086957, 0.44444444444444
72989, 1.2434782608696, 0.56739130434783, 0.41666666666667
72990, 1.2217391304348, 0.56739130434783, 0.38888888888889
72991, 1.2434782608696, 0.59347826086957, 0.38888888888889
72992, 1.2434782608696, 0.56739130434783, 0.36111111111111
72993, 1.2217391304348, 0.56739130434783, 0.33333333333333
72994, 1.2434782608696, 0.59347826086957, 0.33333333333333
72995, 1.2434782608696, 0.56739130434783, 0.30555555555556
72996, 1.2217391304348, 0.56739130434783, 0.27777777777778
72997, 1.2434782608696, 0.59347826086957, 0.27777777777778
72998, 1.2434782608696, 0.56739130434783, 0.25
72999, 1.2217391304348, 0.56739130434783, 0.22222222222222
73000, 1.2434782608696, 0.59347826086957, 0.22222222222222
73001, 1.2434782608696, 0.56739130434783, 0.19444444444444
73002, 1.2217391304348, 0.56739130434783, 0.16666666666667
73003, 1.2434782608696, 0.59347826086957, 0.16666666666667
73004, 1.2434782608696, 0.56739130434783, 0.13888888888889
73005, 1.2217391304348, 0.56739130434783, 0.11111111111111
73006, 1.2434782608696, 0.59347826086957, 0.11111111111111
73007, 1.2434782608696, 0.56739130434783, 0.083333333333333
73008, 1.2217391304348, 0.56739130434783, 0.055555555555556
73009, 1.2434782608696, 0.59347826086957, 0.055555555555556
73010, 1.2434782608696, 0.56739130434783, 0.027777777777778
73011, 1.2869565217391, 0.56739130434783, 0.47222222222222
73012, 1.2652173913043, 0.56739130434783, 0.44444444444444
73013, 1.2869565217391, 0.59347826086957, 0.44444444444444
73014, 1.2869565217391, 0.56739130434783, 0.41666666666667
73015, 1.2652173913043, 0.56739130434783, 0.38888888888889
73016, 1.2869565217391, 0.59347826086957, 0.38888888888889
73017, 1.2869565217391, 0.56739130434783, 0.36111111111111
73018, 1.2652173913043, 0.56739130434783, 0.33333333333333
73019, 1.2869565217391, 0.59347826086957, 0.33333333333333
73020, 1.2869565217391, 0.56739130434783, 0.30555555555556
73021, 1.2652173913043, 0.56739130434783, 0.27777777777778
73022, 1.2869565217391, 0.59347826086957, 0.27777777777778
73023, 1.2869565217391, 0.56739130434783, 0.25
73024, 1.2652173913043, 0.56739130434783, 0.22222222222222
73025, 1.2869565217391, 0.59347826086957, 0.22222222222222
73026, 1.2869565217391, 0.56739130434783, 0.19444444444444
73027, 1.2652173913043, 0.56739130434783, 0.16666666666667
73028, 1.2869565217391, 0.59347826086957, 0.16666666666667
73029, 1.2869565217391, 0.56739130434783, 0.13888888888889
73030, 1.2652173913043, 0.56739130434783, 0.11111111111111
73031, 1.2869565217391, 0.59347826086957, 0.11111111111111
73032, 1.2869565217391, 0.56739130434783, 0.083333333333333
73033, 1.2652173913043, 0.56739130434783, 0.055555555555556
73034, 1.2869565217391, 0.59347826086957, 0.055555555555556
73035, 1.2869565217391, 0.56739130434783, 0.027777777777778
73036, 1.3304347826087, 0.56739130434783, 0.47222222222222
73037, 1.3086956521739, 0.56739130434783, 0.44444444444444
73038, 1.3304347826087, 0.59347826086957, 0.44444444444444
73039, 1.3304347826087, 0.56739130434783, 0.41666666666667
73040, 1.3086956521739, 0.56739130434783, 0.38888888888889
73041, 1.3304347826087, 0.59347826086957, 0.38888888888889
73042, 1.3304347826087, 0.56739130434783, 0.36111111111111
73043, 1.3086956521739, 0.56739130434783, 0.33333333333333
73044, 1.3304347826087, 0.59347826086957, 0.33333333333333
73045, 1.3304347826087, 0.56739130434783, 0.30555555555556
73046, 1.3086956521739, 0.56739130434783, 0.27777777777778
73047, 1.3304347826087, 0.59347826086957, 0.27777777777778
73048, 1.3304347826087, 0.56739130434783, 0.25
73049, 1.3086956521739, 0.56739130434783, 0.22222222222222
73050, 1.3304347826087, 0.59347826086957, 0.22222222222222
73051, 1.3304347826087, 0.56739130434783, 0.19444444444444
73052, 1.3086956521739, 0.56739130434783, 0.16666666666667
73053, 1.3304347826087, 0.59347826086957, 0.16666666666667
73054, 1.3304347826087, 0.56739130434783, 0.13888888888889
73055, 1.3086956521739, 0.56739130434783, 0.11111111111111
73056, 1.3304347826087, 0.59347826086957, 0.11111111111111
73057, 1.3304347826087, 0.56739130434783, 0.083333333333333
73058, 1.3086956521739, 0.56739130434783, 0.055555555555556
73059, 1.3304347826087, 0.59347826086957, 0.055555555555556
73060, 1.3304347826087, 0.56739130434783, 0.027777777777778
73061, 1.3739130434783, 0.56739130434783, 0.47222222222222
73062, 1.3521739130435, 0.56739130434783, 0.44444444444444
73063, 1.3739130434783, 0.59347826086957, 0.44444444444444
73064, 1.3739130434783, 0.56739130434783, 0.41666666666667
73065, 1.3521739130435, 0.56739130434783, 0.38888888888889
73066, 1.3739130434783, 0.59347826086957, 0.38888888888889
73067, 1.3739130434783, 0.56739130434783, 0.36111111111111
73068, 1.3521739130435, 0.56739130434783, 0.33333333333333
73069, 1.3739130434783, 0.59347826086957, 0.33333333333333
73070, 1.3739130434783, 0.56739130434783, 0.30555555555556
73071, 1.3521739130435, 0.56739130434783, 0.27777777777778
73072, 1.3739130434783, 0.59347826086957, 0.27777777777778
73073, 1.3739130434783, 0.56739130434783, 0.25
73074, 1.3521739130435, 0.56739130434783, 0.22222222222222
73075, 1.3739130434783, 0.59347826086957, 0.22222222222222
73076, 1.3739130434783, 0.56739130434783, 0.19444444444444
73077, 1.3521739130435, 0.56739130434783, 0.16666666666667
73078, 1.3739130434783, 0.59347826086957, 0.16666666666667
73079, 1.3739130434783, 0.56739130434783, 0.13888888888889
73080, 1.3521739130435, 0.56739130434783, 0.11111111111111
73081, 1.3739130434783, 0.59347826086957, 0.11111111111111
73082, 1.3739130434783, 0.56739130434783, 0.083333333333333
73083, 1.3521739130435, 0.56739130434783, 0.055555555555556
73084, 1.3739130434783, 0.59347826086957, 0.055555555555556
73085, 1.3739130434783, 0.56739130434783, 0.027777777777778
73086, 1.4173913043478, 0.56739130434783, 0.47222222222222
73087, 1.395652173913, 0.56739130434783, 0.44444444444444
73088, 1.4173913043478, 0.59347826086957, 0.44444444444444
73089, 1.4173913043478, 0.56739130434783, 0.41666666666667
73090, 1.395652173913, 0.56739130434783, 0.38888888888889
73091, 1.4173913043478, 0.59347826086957, 0.38888888888889
73092, 1.4173913043478, 0.56739130434783, 0.36111111111111
73093, 1.395652173913, 0.56739130434783, 0.33333333333333
73094, 1.4173913043478, 0.59347826086957, 0.33333333333333
73095, 1.4173913043478, 0.56739130434783, 0.30555555555556
73096, 1.395652173913, 0.56739130434783, 0.27777777777778
73097, 1.4173913043478, 0.59347826086957, 0.27777777777778
73098, 1.4173913043478, 0.56739130434783, 0.25
73099, 1.395652173913, 0.56739130434783, 0.22222222222222
73100, 1.4173913043478, 0.59347826086957, 0.22222222222222
73101, 1.4173913043478, 0.56739130434783, 0.19444444444444
73102, 1.395652173913, 0.56739130434783, 0.16666666666667
73103, 1.4173913043478, 0.59347826086957, 0.16666666666667
73104, 1.4173913043478, 0.56739130434783, 0.13888888888889
73105, 1.395652173913, 0.56739130434783, 0.11111111111111
73106, 1.4173913043478, 0.59347826086957, 0.11111111111111
73107, 1.4173913043478, 0.56739130434783, 0.083333333333333
73108, 1.395652173913, 0.56739130434783, 0.055555555555556
73109, 1.4173913043478, 0.59347826086957, 0.055555555555556
73110, 1.4173913043478, 0.56739130434783, 0.027777777777778
73111, 1.4608695652174, 0.56739130434783, 0.47222222222222
73112, 1.4391304347826, 0.56739130434783, 0.44444444444444
73113, 1.4608695652174, 0.59347826086957, 0.44444444444444
73114, 1.4608695652174, 0.56739130434783, 0.41666666666667
73115, 1.4391304347826, 0.56739130434783, 0.38888888888889
73116, 1.4608695652174, 0.59347826086957, 0.38888888888889
73117, 1.4608695652174, 0.56739130434783, 0.36111111111111
73118, 1.4391304347826, 0.56739130434783, 0.33333333333333
73119, 1.4608695652174, 0.59347826086957, 0.33333333333333
73120, 1.4608695652174, 0.56739130434783, 0.30555555555556
73121, 1.4391304347826, 0.56739130434783, 0.27777777777778
73122, 1.4608695652174, 0.59347826086957, 0.27777777777778
73123, 1.4608695652174, 0.56739130434783, 0.25
73124, 1.4391304347826, 0.56739130434783, 0.22222222222222
73125, 1.4608695652174, 0.59347826086957, 0.22222222222222
73126, 1.4608695652174, 0.56739130434783, 0.19444444444444
73127, 1.4391304347826, 0.56739130434783, 0.16666666666667
73128, 1.4608695652174, 0.59347826086957, 0.16666666666667
73129, 1.4608695652174, 0.56739130434783, 0.13888888888889
73130, 1.4391304347826, 0.56739130434783, 0.11111111111111
73131, 1.4608695652174, 0.59347826086957, 0.11111111111111
73132, 1.4608695652174, 0.56739130434783, 0.083333333333333
73133, 1.4391304347826, 0.56739130434783, 0.055555555555556
73134, 1.4608695652174, 0.59347826086957, 0.055555555555556
73135, 1.4608695652174, 0.56739130434783, 0.027777777777778
73136, 1.504347826087, 0.56739130434783, 0.47222222222222
73137, 1.4826086956522, 0.56739130434783, 0.44444444444444
73138, 1.504347826087, 0.59347826086957, 0.44444444444444
73139, 1.504347826087, 0.56739130434783, 0.41666666666667
73140, 1.4826086956522, 0.56739130434783, 0.38888888888889
73141, 1.504347826087, 0.59347826086957, 0.38888888888889
73142, 1.504347826087, 0.56739130434783, 0.36111111111111
73143, 1.4826086956522, 0.56739130434783, 0.33333333333333
73144, 1.504347826087, 0.59347826086957, 0.33333333333333
73145, 1.504347826087, 0.56739130434783, 0.30555555555556
73146, 1.4826086956522, 0.56739130434783, 0.27777777777778
73147, 1.504347826087, 0.59347826086957, 0.27777777777778
73148, 1.504347826087, 0.56739130434783, 0.25
73149, 1.4826086956522, 0.56739130434783, 0.22222222222222
73150, 1.504347826087, 0.59347826086957, 0.22222222222222
73151, 1.504347826087, 0.56739130434783, 0.19444444444444
73152, 1.4826086956522, 0.56739130434783, 0.16666666666667
73153, 1.504347826087, 0.59347826086957, 0.16666666666667
73154, 1.504347826087, 0.56739130434783, 0.13888888888889
73155, 1.4826086956522, 0.56739130434783, 0.11111111111111
73156, 1.504347826087, 0.59347826086957, 0.11111111111111
73157, 1.504347826087, 0.56739130434783, 0.083333333333333
73158, 1.4826086956522, 0.56739130434783, 0.055555555555556
73159, 1.504347826087, 0.59347826086957, 0.055555555555556
73160, 1.504347826087, 0.56739130434783, 0.027777777777778
73161, 1.5478260869565, 0.56739130434783, 0.47222222222222
73162, 1.5260869565217, 0.56739130434783, 0.44444444444444
73163, 1.5478260869565, 0.59347826086957, 0.44444444444444
73164, 1.5478260869565, 0.56739130434783, 0.41666666666667
73165, 1.5260869565217, 0.56739130434783, 0.38888888888889
73166, 1.5478260869565, 0.59347826086957, 0.38888888888889
73167, 1.5478260869565, 0.56739130434783, 0.36111111111111
73168, 1.5260869565217, 0.56739130434783, 0.33333333333333
73169, 1.5478260869565, 0.59347826086957, 0.33333333333333
73170, 1.5478260869565, 0.56739130434783, 0.30555555555556
73171, 1.5260869565217, 0.56739130434783, 0.27777777777778
73172, 1.5478260869565, 0.59347826086957, 0.27777777777778
73173, 1.5478260869565, 0.56739130434783, 0.25
73174, 1.5260869565217, 0.56739130434783, 0.22222222222222
73175, 1.5478260869565, 0.59347826086957, 0.22222222222222
73176, 1.5478260869565, 0.56739130434783, 0.19444444444444
73177, 1.5260869565217, 0.56739130434783, 0.16666666666667
73178, 1.5478260869565, 0.59347826086957, 0.16666666666667
73179, 1.5478260869565, 0.56739130434783, 0.13888888888889
73180, 1.5260869565217, 0.56739130434783, 0.11111111111111
73181, 1.5478260869565, 0.59347826086957, 0.11111111111111
73182, 1.5478260869565, 0.56739130434783, 0.083333333333333
73183, 1.5260869565217, 0.56739130434783, 0.055555555555556
73184, 1.5478260869565, 0.59347826086957, 0.055555555555556
73185, 1.5478260869565, 0.56739130434783, 0.027777777777778
73186, 1.5913043478261, 0.56739130434783, 0.47222222222222
73187, 1.5695652173913, 0.56739130434783, 0.44444444444444
73188, 1.5913043478261, 0.59347826086957, 0.44444444444444
73189, 1.5913043478261, 0.56739130434783, 0.41666666666667
73190, 1.5695652173913, 0.56739130434783, 0.38888888888889
73191, 1.5913043478261, 0.59347826086957, 0.38888888888889
73192, 1.5913043478261, 0.56739130434783, 0.36111111111111
73193, 1.5695652173913, 0.56739130434783, 0.33333333333333
73194, 1.5913043478261, 0.59347826086957, 0.33333333333333
73195, 1.5913043478261, 0.56739130434783, 0.30555555555556
73196, 1.5695652173913, 0.56739130434783, 0.27777777777778
73197, 1.5913043478261, 0.59347826086957, 0.27777777777778
73198, 1.5913043478261, 0.56739130434783, 0.25
73199, 1.5695652173913, 0.56739130434783, 0.22222222222222
73200, 1.5913043478261, 0.59347826086957, 0.22222222222222
73201, 1.5913043478261, 0.56739130434783, 0.19444444444444
73202, 1.5695652173913, 0.56739130434783, 0.16666666666667
73203, 1.5913043478261, 0.59347826086957, 0.16666666666667
73204, 1.5913043478261, 0.56739130434783, 0.13888888888889
73205, 1.5695652173913, 0.56739130434783, 0.11111111111111
73206, 1.5913043478261, 0.59347826086957, 0.11111111111111
73207, 1.5913043478261, 0.56739130434783, 0.083333333333333
73208, 1.5695652173913, 0.56739130434783, 0.055555555555556
73209, 1.5913043478261, 0.59347826086957, 0.055555555555556
73210, 1.5913043478261, 0.56739130434783, 0.027777777777778
73211, 1.6347826086957, 0.56739130434783, 0.47222222222222
73212, 1.6130434782609, 0.56739130434783, 0.44444444444444
73213, 1.6347826086957, 0.59347826086957, 0.44444444444444
73214, 1.6347826086957, 0.56739130434783, 0.41666666666667
73215, 1.6130434782609, 0.56739130434783, 0.38888888888889
73216, 1.6347826086957, 0.59347826086957, 0.38888888888889
73217, 1.6347826086957, 0.56739130434783, 0.36111111111111
73218, 1.6130434782609, 0.56739130434783, 0.33333333333333
73219, 1.6347826086957, 0.59347826086957, 0.33333333333333
73220, 1.6347826086957, 0.56739130434783, 0.30555555555556
73221, 1.6130434782609, 0.56739130434783, 0.27777777777778
73222, 1.6347826086957, 0.59347826086957, 0.27777777777778
73223, 1.6347826086957, 0.56739130434783, 0.25
73224, 1.6130434782609, 0.56739130434783, 0.22222222222222
73225, 1.6347826086957, 0.59347826086957, 0.22222222222222
73226, 1.6347826086957, 0.56739130434783, 0.19444444444444
73227, 1.6130434782609, 0.56739130434783, 0.16666666666667
73228, 1.6347826086957, 0.59347826086957, 0.16666666666667
73229, 1.6347826086957, 0.56739130434783, 0.13888888888889
73230, 1.6130434782609, 0.56739130434783, 0.11111111111111
73231, 1.6347826086957, 0.59347826086957, 0.11111111111111
73232, 1.6347826086957, 0.56739130434783, 0.083333333333333
73233, 1.6130434782609, 0.56739130434783, 0.055555555555556
73234, 1.6347826086957, 0.59347826086957, 0.055555555555556
73235, 1.6347826086957, 0.56739130434783, 0.027777777777778
73236, 1.6782608695652, 0.56739130434783, 0.47222222222222
73237, 1.6565217391304, 0.56739130434783, 0.44444444444444
73238, 1.6782608695652, 0.59347826086957, 0.44444444444444
73239, 1.6782608695652, 0.56739130434783, 0.41666666666667
73240, 1.6565217391304, 0.56739130434783, 0.38888888888889
73241, 1.6782608695652, 0.59347826086957, 0.38888888888889
73242, 1.6782608695652, 0.56739130434783, 0.36111111111111
73243, 1.6565217391304, 0.56739130434783, 0.33333333333333
73244, 1.6782608695652, 0.59347826086957, 0.33333333333333
73245, 1.6782608695652, 0.56739130434783, 0.30555555555556
73246, 1.6565217391304, 0.56739130434783, 0.27777777777778
73247, 1.6782608695652, 0.59347826086957, 0.27777777777778
73248, 1.6782608695652, 0.56739130434783, 0.25
73249, 1.6565217391304, 0.56739130434783, 0.22222222222222
73250, 1.6782608695652, 0.59347826086957, 0.22222222222222
73251, 1.6782608695652, 0.56739130434783, 0.19444444444444
73252, 1.6565217391304, 0.56739130434783, 0.16666666666667
73253, 1.6782608695652, 0.59347826086957, 0.16666666666667
73254, 1.6782608695652, 0.56739130434783, 0.13888888888889
73255, 1.6565217391304, 0.56739130434783, 0.11111111111111
73256, 1.6782608695652, 0.59347826086957, 0.11111111111111
73257, 1.6782608695652, 0.56739130434783, 0.083333333333333
73258, 1.6565217391304, 0.56739130434783, 0.055555555555556
73259, 1.6782608695652, 0.59347826086957, 0.055555555555556
73260, 1.6782608695652, 0.56739130434783, 0.027777777777778
73261, 1.7217391304348, 0.56739130434783, 0.47222222222222
73262, 1.7, 0.56739130434783, 0.44444444444444
73263, 1.7217391304348, 0.59347826086957, 0.44444444444444
73264, 1.7217391304348, 0.56739130434783, 0.41666666666667
73265, 1.7, 0.56739130434783, 0.38888888888889
73266, 1.7217391304348, 0.59347826086957, 0.38888888888889
73267, 1.7217391304348, 0.56739130434783, 0.36111111111111
73268, 1.7, 0.56739130434783, 0.33333333333333
73269, 1.7217391304348, 0.59347826086957, 0.33333333333333
73270, 1.7217391304348, 0.56739130434783, 0.30555555555556
73271, 1.7, 0.56739130434783, 0.27777777777778
73272, 1.7217391304348, 0.59347826086957, 0.27777777777778
73273, 1.7217391304348, 0.56739130434783, 0.25
73274, 1.7, 0.56739130434783, 0.22222222222222
73275, 1.7217391304348, 0.59347826086957, 0.22222222222222
73276, 1.7217391304348, 0.56739130434783, 0.19444444444444
73277, 1.7, 0.56739130434783, 0.16666666666667
73278, 1.7217391304348, 0.59347826086957, 0.16666666666667
73279, 1.7217391304348, 0.56739130434783, 0.13888888888889
73280, 1.7, 0.56739130434783, 0.11111111111111
73281, 1.7217391304348, 0.59347826086957, 0.11111111111111
73282, 1.7217391304348, 0.56739130434783, 0.083333333333333
73283, 1.7, 0.56739130434783, 0.055555555555556
73284, 1.7217391304348, 0.59347826086957, 0.055555555555556
73285, 1.7217391304348, 0.56739130434783, 0.027777777777778
73286, 1.7652173913043, 0.56739130434783, 0.47222222222222
73287, 1.7434782608696, 0.56739130434783, 0.44444444444444
73288, 1.7652173913043, 0.59347826086957, 0.44444444444444
73289, 1.7652173913043, 0.56739130434783, 0.41666666666667
73290, 1.7434782608696, 0.56739130434783, 0.38888888888889
73291, 1.7652173913043, 0.59347826086957, 0.38888888888889
73292, 1.7652173913043, 0.56739130434783, 0.36111111111111
73293, 1.7434782608696, 0.56739130434783, 0.33333333333333
73294, 1.7652173913043, 0.59347826086957, 0.33333333333333
73295, 1.7652173913043, 0.56739130434783, 0.30555555555556
73296, 1.7434782608696, 0.56739130434783, 0.27777777777778
73297, 1.7652173913043, 0.59347826086957, 0.27777777777778
73298, 1.7652173913043, 0.56739130434783, 0.25
73299, 1.7434782608696, 0.56739130434783, 0.22222222222222
73300, 1.7652173913043, 0.59347826086957, 0.22222222222222
73301, 1.7652173913043, 0.56739130434783, 0.19444444444444
73302, 1.7434782608696, 0.56739130434783, 0.16666666666667
73303, 1.7652173913043, 0.59347826086957, 0.16666666666667
73304, 1.7652173913043, 0.56739130434783, 0.13888888888889
73305, 1.7434782608696, 0.56739130434783, 0.11111111111111
73306, 1.7652173913043, 0.59347826086957, 0.11111111111111
73307, 1.7652173913043, 0.56739130434783, 0.083333333333333
73308, 1.7434782608696, 0.56739130434783, 0.055555555555556
73309, 1.7652173913043, 0.59347826086957, 0.055555555555556
73310, 1.7652173913043, 0.56739130434783, 0.027777777777778
73311, 1.8086956521739, 0.56739130434783, 0.47222222222222
73312, 1.7869565217391, 0.56739130434783, 0.44444444444444
73313, 1.8086956521739, 0.59347826086957, 0.44444444444444
73314, 1.8086956521739, 0.56739130434783, 0.41666666666667
73315, 1.7869565217391, 0.56739130434783, 0.38888888888889
73316, 1.8086956521739, 0.59347826086957, 0.38888888888889
73317, 1.8086956521739, 0.56739130434783, 0.36111111111111
73318, 1.7869565217391, 0.56739130434783, 0.33333333333333
73319, 1.8086956521739, 0.59347826086957, 0.33333333333333
73320, 1.8086956521739, 0.56739130434783, 0.30555555555556
73321, 1.7869565217391, 0.56739130434783, 0.27777777777778
73322, 1.8086956521739, 0.59347826086957, 0.27777777777778
73323, 1.8086956521739, 0.56739130434783, 0.25
73324, 1.7869565217391, 0.56739130434783, 0.22222222222222
73325, 1.8086956521739, 0.59347826086957, 0.22222222222222
73326, 1.8086956521739, 0.56739130434783, 0.19444444444444
73327, 1.7869565217391, 0.56739130434783, 0.16666666666667
73328, 1.8086956521739, 0.59347826086957, 0.16666666666667
73329, 1.8086956521739, 0.56739130434783, 0.13888888888889
73330, 1.7869565217391, 0.56739130434783, 0.11111111111111
73331, 1.8086956521739, 0.59347826086957, 0.11111111111111
73332, 1.8086956521739, 0.56739130434783, 0.083333333333333
73333, 1.7869565217391, 0.56739130434783, 0.055555555555556
73334, 1.8086956521739, 0.59347826086957, 0.055555555555556
73335, 1.8086956521739, 0.56739130434783, 0.027777777777778
73336, 1.8521739130435, 0.56739130434783, 0.47222222222222
73337, 1.8304347826087, 0.56739130434783, 0.44444444444444
73338, 1.8521739130435, 0.59347826086957, 0.44444444444444
73339, 1.8521739130435, 0.56739130434783, 0.41666666666667
73340, 1.8304347826087, 0.56739130434783, 0.38888888888889
73341, 1.8521739130435, 0.59347826086957, 0.38888888888889
73342, 1.8521739130435, 0.56739130434783, 0.36111111111111
73343, 1.8304347826087, 0.56739130434783, 0.33333333333333
73344, 1.8521739130435, 0.59347826086957, 0.33333333333333
73345, 1.8521739130435, 0.56739130434783, 0.30555555555556
73346, 1.8304347826087, 0.56739130434783, 0.27777777777778
73347, 1.8521739130435, 0.59347826086957, 0.27777777777778
73348, 1.8521739130435, 0.56739130434783, 0.25
73349, 1.8304347826087, 0.56739130434783, 0.22222222222222
73350, 1.8521739130435, 0.59347826086957, 0.22222222222222
73351, 1.8521739130435, 0.56739130434783, 0.19444444444444
73352, 1.8304347826087, 0.56739130434783, 0.16666666666667
73353, 1.8521739130435, 0.59347826086957, 0.16666666666667
73354, 1.8521739130435, 0.56739130434783, 0.13888888888889
73355, 1.8304347826087, 0.56739130434783, 0.11111111111111
73356, 1.8521739130435, 0.59347826086957, 0.11111111111111
73357, 1.8521739130435, 0.56739130434783, 0.083333333333333
73358, 1.8304347826087, 0.56739130434783, 0.055555555555556
73359, 1.8521739130435, 0.59347826086957, 0.055555555555556
73360, 1.8521739130435, 0.56739130434783, 0.027777777777778
73361, 1.895652173913, 0.56739130434783, 0.47222222222222
73362, 1.8739130434783, 0.56739130434783, 0.44444444444444
73363, 1.895652173913, 0.59347826086957, 0.44444444444444
73364, 1.895652173913, 0.56739130434783, 0.41666666666667
73365, 1.8739130434783, 0.56739130434783, 0.38888888888889
73366, 1.895652173913, 0.59347826086957, 0.38888888888889
73367, 1.895652173913, 0.56739130434783, 0.36111111111111
73368, 1.8739130434783, 0.56739130434783, 0.33333333333333
73369, 1.895652173913, 0.59347826086957, 0.33333333333333
73370, 1.895652173913, 0.56739130434783, 0.30555555555556
73371, 1.8739130434783, 0.56739130434783, 0.27777777777778
73372, 1.895652173913, 0.59347826086957, 0.27777777777778
73373, 1.895652173913, 0.56739130434783, 0.25
73374, 1.8739130434783, 0.56739130434783, 0.22222222222222
73375, 1.895652173913, 0.59347826086957, 0.22222222222222
73376, 1.895652173913, 0.56739130434783, 0.19444444444444
73377, 1.8739130434783, 0.56739130434783, 0.16666666666667
73378, 1.895652173913, 0.59347826086957, 0.16666666666667
73379, 1.895652173913, 0.56739130434783, 0.13888888888889
73380, 1.8739130434783, 0.56739130434783, 0.11111111111111
73381, 1.895652173913, 0.59347826086957, 0.11111111111111
73382, 1.895652173913, 0.56739130434783, 0.083333333333333
73383, 1.8739130434783, 0.56739130434783, 0.055555555555556
73384, 1.895652173913, 0.59347826086957, 0.055555555555556
73385, 1.895652173913, 0.56739130434783, 0.027777777777778
73386, 1.9391304347826, 0.56739130434783, 0.47222222222222
73387, 1.9173913043478, 0.56739130434783, 0.44444444444444
73388, 1.9391304347826, 0.59347826086957, 0.44444444444444
73389, 1.9391304347826, 0.56739130434783, 0.41666666666667
73390, 1.9173913043478, 0.56739130434783, 0.38888888888889
73391, 1.9391304347826, 0.59347826086957, 0.38888888888889
73392, 1.9391304347826, 0.56739130434783, 0.36111111111111
73393, 1.9173913043478, 0.56739130434783, 0.33333333333333
73394, 1.9391304347826, 0.59347826086957, 0.33333333333333
73395, 1.9391304347826, 0.56739130434783, 0.30555555555556
73396, 1.9173913043478, 0.56739130434783, 0.27777777777778
73397, 1.9391304347826, 0.59347826086957, 0.27777777777778
73398, 1.9391304347826, 0.56739130434783, 0.25
73399, 1.9173913043478, 0.56739130434783, 0.22222222222222
73400, 1.9391304347826, 0.59347826086957, 0.22222222222222
73401, 1.9391304347826, 0.56739130434783, 0.19444444444444
73402, 1.9173913043478, 0.56739130434783, 0.16666666666667
73403, 1.9391304347826, 0.59347826086957, 0.16666666666667
73404, 1.9391304347826, 0.56739130434783, 0.13888888888889
73405, 1.9173913043478, 0.56739130434783, 0.11111111111111
73406, 1.9391304347826, 0.59347826086957, 0.11111111111111
73407, 1.9391304347826, 0.56739130434783, 0.083333333333333
73408, 1.9173913043478, 0.56739130434783, 0.055555555555556
73409, 1.9391304347826, 0.59347826086957, 0.055555555555556
73410, 1.9391304347826, 0.56739130434783, 0.027777777777778
73411, 1.9826086956522, 0.56739130434783, 0.47222222222222
73412, 1.9608695652174, 0.56739130434783, 0.44444444444444
73413, 1.9826086956522, 0.59347826086957, 0.44444444444444
73414, 1.9826086956522, 0.56739130434783, 0.41666666666667
73415, 1.9608695652174, 0.56739130434783, 0.38888888888889
73416, 1.9826086956522, 0.59347826086957, 0.38888888888889
73417, 1.9826086956522, 0.56739130434783, 0.36111111111111
73418, 1.9608695652174, 0.56739130434783, 0.33333333333333
73419, 1.9826086956522, 0.59347826086957, 0.33333333333333
73420, 1.9826086956522, 0.56739130434783, 0.30555555555556
73421, 1.9608695652174, 0.56739130434783, 0.27777777777778
73422, 1.9826086956522, 0.59347826086957, 0.27777777777778
73423, 1.9826086956522, 0.56739130434783, 0.25
73424, 1.9608695652174, 0.56739130434783, 0.22222222222222
73425, 1.9826086956522, 0.59347826086957, 0.22222222222222
73426, 1.9826086956522, 0.56739130434783, 0.19444444444444
73427, 1.9608695652174, 0.56739130434783, 0.16666666666667
73428, 1.9826086956522, 0.59347826086957, 0.16666666666667
73429, 1.9826086956522, 0.56739130434783, 0.13888888888889
73430, 1.9608695652174, 0.56739130434783, 0.11111111111111
73431, 1.9826086956522, 0.59347826086957, 0.11111111111111
73432, 1.9826086956522, 0.56739130434783, 0.083333333333333
73433, 1.9608695652174, 0.56739130434783, 0.055555555555556
73434, 1.9826086956522, 0.59347826086957, 0.055555555555556
73435, 1.9826086956522, 0.56739130434783, 0.027777777777778
73436, 2.0260869565217, 0.56739130434783, 0.47222222222222
73437, 2.004347826087, 0.56739130434783, 0.44444444444444
73438, 2.0260869565217, 0.59347826086957, 0.44444444444444
73439, 2.0260869565217, 0.56739130434783, 0.41666666666667
73440, 2.004347826087, 0.56739130434783, 0.38888888888889
73441, 2.0260869565217, 0.59347826086957, 0.38888888888889
73442, 2.0260869565217, 0.56739130434783, 0.36111111111111
73443, 2.004347826087, 0.56739130434783, 0.33333333333333
73444, 2.0260869565217, 0.59347826086957, 0.33333333333333
73445, 2.0260869565217, 0.56739130434783, 0.30555555555556
73446, 2.004347826087, 0.56739130434783, 0.27777777777778
73447, 2.0260869565217, 0.59347826086957, 0.27777777777778
73448, 2.0260869565217, 0.56739130434783, 0.25
73449, 2.004347826087, 0.56739130434783, 0.22222222222222
73450, 2.0260869565217, 0.59347826086957, 0.22222222222222
73451, 2.0260869565217, 0.56739130434783, 0.19444444444444
73452, 2.004347826087, 0.56739130434783, 0.16666666666667
73453, 2.0260869565217, 0.59347826086957, 0.16666666666667
73454, 2.0260869565217, 0.56739130434783, 0.13888888888889
73455, 2.004347826087, 0.56739130434783, 0.11111111111111
73456, 2.0260869565217, 0.59347826086957, 0.11111111111111
73457, 2.0260869565217, 0.56739130434783, 0.083333333333333
73458, 2.004347826087, 0.56739130434783, 0.055555555555556
73459, 2.0260869565217, 0.59347826086957, 0.055555555555556
73460, 2.0260869565217, 0.56739130434783, 0.027777777777778
73461, 2.0695652173913, 0.56739130434783, 0.47222222222222
73462, 2.0478260869565, 0.56739130434783, 0.44444444444444
73463, 2.0695652173913, 0.59347826086957, 0.44444444444444
73464, 2.0695652173913, 0.56739130434783, 0.41666666666667
73465, 2.0478260869565, 0.56739130434783, 0.38888888888889
73466, 2.0695652173913, 0.59347826086957, 0.38888888888889
73467, 2.0695652173913, 0.56739130434783, 0.36111111111111
73468, 2.0478260869565, 0.56739130434783, 0.33333333333333
73469, 2.0695652173913, 0.59347826086957, 0.33333333333333
73470, 2.0695652173913, 0.56739130434783, 0.30555555555556
73471, 2.0478260869565, 0.56739130434783, 0.27777777777778
73472, 2.0695652173913, 0.59347826086957, 0.27777777777778
73473, 2.0695652173913, 0.56739130434783, 0.25
73474, 2.0478260869565, 0.56739130434783, 0.22222222222222
73475, 2.0695652173913, 0.59347826086957, 0.22222222222222
73476, 2.0695652173913, 0.56739130434783, 0.19444444444444
73477, 2.0478260869565, 0.56739130434783, 0.16666666666667
73478, 2.0695652173913, 0.59347826086957, 0.16666666666667
73479, 2.0695652173913, 0.56739130434783, 0.13888888888889
73480, 2.0478260869565, 0.56739130434783, 0.11111111111111
73481, 2.0695652173913, 0.59347826086957, 0.11111111111111
73482, 2.0695652173913, 0.56739130434783, 0.083333333333333
73483, 2.0478260869565, 0.56739130434783, 0.055555555555556
73484, 2.0695652173913, 0.59347826086957, 0.055555555555556
73485, 2.0695652173913, 0.56739130434783, 0.027777777777778
73486, 2.1130434782609, 0.56739130434783, 0.47222222222222
73487, 2.0913043478261, 0.56739130434783, 0.44444444444444
73488, 2.1130434782609, 0.59347826086957, 0.44444444444444
73489, 2.1130434782609, 0.56739130434783, 0.41666666666667
73490, 2.0913043478261, 0.56739130434783, 0.38888888888889
73491, 2.1130434782609, 0.59347826086957, 0.38888888888889
73492, 2.1130434782609, 0.56739130434783, 0.36111111111111
73493, 2.0913043478261, 0.56739130434783, 0.33333333333333
73494, 2.1130434782609, 0.59347826086957, 0.33333333333333
73495, 2.1130434782609, 0.56739130434783, 0.30555555555556
73496, 2.0913043478261, 0.56739130434783, 0.27777777777778
73497, 2.1130434782609, 0.59347826086957, 0.27777777777778
73498, 2.1130434782609, 0.56739130434783, 0.25
73499, 2.0913043478261, 0.56739130434783, 0.22222222222222
73500, 2.1130434782609, 0.59347826086957, 0.22222222222222
73501, 2.1130434782609, 0.56739130434783, 0.19444444444444
73502, 2.0913043478261, 0.56739130434783, 0.16666666666667
73503, 2.1130434782609, 0.59347826086957, 0.16666666666667
73504, 2.1130434782609, 0.56739130434783, 0.13888888888889
73505, 2.0913043478261, 0.56739130434783, 0.11111111111111
73506, 2.1130434782609, 0.59347826086957, 0.11111111111111
73507, 2.1130434782609, 0.56739130434783, 0.083333333333333
73508, 2.0913043478261, 0.56739130434783, 0.055555555555556
73509, 2.1130434782609, 0.59347826086957, 0.055555555555556
73510, 2.1130434782609, 0.56739130434783, 0.027777777777778
73511, 2.1565217391304, 0.56739130434783, 0.47222222222222
73512, 2.1347826086957, 0.56739130434783, 0.44444444444444
73513, 2.1565217391304, 0.59347826086957, 0.44444444444444
73514, 2.1565217391304, 0.56739130434783, 0.41666666666667
73515, 2.1347826086957, 0.56739130434783, 0.38888888888889
73516, 2.1565217391304, 0.59347826086957, 0.38888888888889
73517, 2.1565217391304, 0.56739130434783, 0.36111111111111
73518, 2.1347826086957, 0.56739130434783, 0.33333333333333
73519, 2.1565217391304, 0.59347826086957, 0.33333333333333
73520, 2.1565217391304, 0.56739130434783, 0.30555555555556
73521, 2.1347826086957, 0.56739130434783, 0.27777777777778
73522, 2.1565217391304, 0.59347826086957, 0.27777777777778
73523, 2.1565217391304, 0.56739130434783, 0.25
73524, 2.1347826086957, 0.56739130434783, 0.22222222222222
73525, 2.1565217391304, 0.59347826086957, 0.22222222222222
73526, 2.1565217391304, 0.56739130434783, 0.19444444444444
73527, 2.1347826086957, 0.56739130434783, 0.16666666666667
73528, 2.1565217391304, 0.59347826086957, 0.16666666666667
73529, 2.1565217391304, 0.56739130434783, 0.13888888888889
73530, 2.1347826086957, 0.56739130434783, 0.11111111111111
73531, 2.1565217391304, 0.59347826086957, 0.11111111111111
73532, 2.1565217391304, 0.56739130434783, 0.083333333333333
73533, 2.1347826086957, 0.56739130434783, 0.055555555555556
73534, 2.1565217391304, 0.59347826086957, 0.055555555555556
73535, 2.1565217391304, 0.56739130434783, 0.027777777777778
73536, 2.1782608695652, 0.56739130434783, 0.44444444444444
73537, 2.1782608695652, 0.56739130434783, 0.38888888888889
73538, 2.1782608695652, 0.56739130434783, 0.33333333333333
73539, 2.1782608695652, 0.56739130434783, 0.27777777777778
73540, 2.1782608695652, 0.56739130434783, 0.22222222222222
73541, 2.1782608695652, 0.56739130434783, 0.16666666666667
73542, 2.1782608695652, 0.56739130434783, 0.11111111111111
73543, 2.1782608695652, 0.56739130434783, 0.055555555555556
73544, 1.2434782608696, 0.51521739130435, 0.47222222222222
73545, 1.2217391304348, 0.51521739130435, 0.44444444444444
73546, 1.2434782608696, 0.54130434782609, 0.44444444444444
73547, 1.2434782608696, 0.51521739130435, 0.41666666666667
73548, 1.2217391304348, 0.51521739130435, 0.38888888888889
73549, 1.2434782608696, 0.54130434782609, 0.38888888888889
73550, 1.2434782608696, 0.51521739130435, 0.36111111111111
73551, 1.2217391304348, 0.51521739130435, 0.33333333333333
73552, 1.2434782608696, 0.54130434782609, 0.33333333333333
73553, 1.2434782608696, 0.51521739130435, 0.30555555555556
73554, 1.2217391304348, 0.51521739130435, 0.27777777777778
73555, 1.2434782608696, 0.54130434782609, 0.27777777777778
73556, 1.2434782608696, 0.51521739130435, 0.25
73557, 1.2217391304348, 0.51521739130435, 0.22222222222222
73558, 1.2434782608696, 0.54130434782609, 0.22222222222222
73559, 1.2434782608696, 0.51521739130435, 0.19444444444444
73560, 1.2217391304348, 0.51521739130435, 0.16666666666667
73561, 1.2434782608696, 0.54130434782609, 0.16666666666667
73562, 1.2434782608696, 0.51521739130435, 0.13888888888889
73563, 1.2217391304348, 0.51521739130435, 0.11111111111111
73564, 1.2434782608696, 0.54130434782609, 0.11111111111111
73565, 1.2434782608696, 0.51521739130435, 0.083333333333333
73566, 1.2217391304348, 0.51521739130435, 0.055555555555556
73567, 1.2434782608696, 0.54130434782609, 0.055555555555556
73568, 1.2434782608696, 0.51521739130435, 0.027777777777778
73569, 1.2869565217391, 0.51521739130435, 0.47222222222222
73570, 1.2652173913043, 0.51521739130435, 0.44444444444444
73571, 1.2869565217391, 0.54130434782609, 0.44444444444444
73572, 1.2869565217391, 0.51521739130435, 0.41666666666667
73573, 1.2652173913043, 0.51521739130435, 0.38888888888889
73574, 1.2869565217391, 0.54130434782609, 0.38888888888889
73575, 1.2869565217391, 0.51521739130435, 0.36111111111111
73576, 1.2652173913043, 0.51521739130435, 0.33333333333333
73577, 1.2869565217391, 0.54130434782609, 0.33333333333333
73578, 1.2869565217391, 0.51521739130435, 0.30555555555556
73579, 1.2652173913043, 0.51521739130435, 0.27777777777778
73580, 1.2869565217391, 0.54130434782609, 0.27777777777778
73581, 1.2869565217391, 0.51521739130435, 0.25
73582, 1.2652173913043, 0.51521739130435, 0.22222222222222
73583, 1.2869565217391, 0.54130434782609, 0.22222222222222
73584, 1.2869565217391, 0.51521739130435, 0.19444444444444
73585, 1.2652173913043, 0.51521739130435, 0.16666666666667
73586, 1.2869565217391, 0.54130434782609, 0.16666666666667
73587, 1.2869565217391, 0.51521739130435, 0.13888888888889
73588, 1.2652173913043, 0.51521739130435, 0.11111111111111
73589, 1.2869565217391, 0.54130434782609, 0.11111111111111
73590, 1.2869565217391, 0.51521739130435, 0.083333333333333
73591, 1.2652173913043, 0.51521739130435, 0.055555555555556
73592, 1.2869565217391, 0.54130434782609, 0.055555555555556
73593, 1.2869565217391, 0.51521739130435, 0.027777777777778
73594, 1.3304347826087, 0.51521739130435, 0.47222222222222
73595, 1.3086956521739, 0.51521739130435, 0.44444444444444
73596, 1.3304347826087, 0.54130434782609, 0.44444444444444
73597, 1.3304347826087, 0.51521739130435, 0.41666666666667
73598, 1.3086956521739, 0.51521739130435, 0.38888888888889
73599, 1.3304347826087, 0.54130434782609, 0.38888888888889
73600, 1.3304347826087, 0.51521739130435, 0.36111111111111
73601, 1.3086956521739, 0.51521739130435, 0.33333333333333
73602, 1.3304347826087, 0.54130434782609, 0.33333333333333
73603, 1.3304347826087, 0.51521739130435, 0.30555555555556
73604, 1.3086956521739, 0.51521739130435, 0.27777777777778
73605, 1.3304347826087, 0.54130434782609, 0.27777777777778
73606, 1.3304347826087, 0.51521739130435, 0.25
73607, 1.3086956521739, 0.51521739130435, 0.22222222222222
73608, 1.3304347826087, 0.54130434782609, 0.22222222222222
73609, 1.3304347826087, 0.51521739130435, 0.19444444444444
73610, 1.3086956521739, 0.51521739130435, 0.16666666666667
73611, 1.3304347826087, 0.54130434782609, 0.16666666666667
73612, 1.3304347826087, 0.51521739130435, 0.13888888888889
73613, 1.3086956521739, 0.51521739130435, 0.11111111111111
73614, 1.3304347826087, 0.54130434782609, 0.11111111111111
73615, 1.3304347826087, 0.51521739130435, 0.083333333333333
73616, 1.3086956521739, 0.51521739130435, 0.055555555555556
73617, 1.3304347826087, 0.54130434782609, 0.055555555555556
73618, 1.3304347826087, 0.51521739130435, 0.027777777777778
73619, 1.3739130434783, 0.51521739130435, 0.47222222222222
73620, 1.3521739130435, 0.51521739130435, 0.44444444444444
73621, 1.3739130434783, 0.54130434782609, 0.44444444444444
73622, 1.3739130434783, 0.51521739130435, 0.41666666666667
73623, 1.3521739130435, 0.51521739130435, 0.38888888888889
73624, 1.3739130434783, 0.54130434782609, 0.38888888888889
73625, 1.3739130434783, 0.51521739130435, 0.36111111111111
73626, 1.3521739130435, 0.51521739130435, 0.33333333333333
73627, 1.3739130434783, 0.54130434782609, 0.33333333333333
73628, 1.3739130434783, 0.51521739130435, 0.30555555555556
73629, 1.3521739130435, 0.51521739130435, 0.27777777777778
73630, 1.3739130434783, 0.54130434782609, 0.27777777777778
73631, 1.3739130434783, 0.51521739130435, 0.25
73632, 1.3521739130435, 0.51521739130435, 0.22222222222222
73633, 1.3739130434783, 0.54130434782609, 0.22222222222222
73634, 1.3739130434783, 0.51521739130435, 0.19444444444444
73635, 1.3521739130435, 0.51521739130435, 0.16666666666667
73636, 1.3739130434783, 0.54130434782609, 0.16666666666667
73637, 1.3739130434783, 0.51521739130435, 0.13888888888889
73638, 1.3521739130435, 0.51521739130435, 0.11111111111111
73639, 1.3739130434783, 0.54130434782609, 0.11111111111111
73640, 1.3739130434783, 0.51521739130435, 0.083333333333333
73641, 1.3521739130435, 0.51521739130435, 0.055555555555556
73642, 1.3739130434783, 0.54130434782609, 0.055555555555556
73643, 1.3739130434783, 0.51521739130435, 0.027777777777778
73644, 1.4173913043478, 0.51521739130435, 0.47222222222222
73645, 1.395652173913, 0.51521739130435, 0.44444444444444
73646, 1.4173913043478, 0.54130434782609, 0.44444444444444
73647, 1.4173913043478, 0.51521739130435, 0.41666666666667
73648, 1.395652173913, 0.51521739130435, 0.38888888888889
73649, 1.4173913043478, 0.54130434782609, 0.38888888888889
73650, 1.4173913043478, 0.51521739130435, 0.36111111111111
73651, 1.395652173913, 0.51521739130435, 0.33333333333333
73652, 1.4173913043478, 0.54130434782609, 0.33333333333333
73653, 1.4173913043478, 0.51521739130435, 0.30555555555556
73654, 1.395652173913, 0.51521739130435, 0.27777777777778
73655, 1.4173913043478, 0.54130434782609, 0.27777777777778
73656, 1.4173913043478, 0.51521739130435, 0.25
73657, 1.395652173913, 0.51521739130435, 0.22222222222222
73658, 1.4173913043478, 0.54130434782609, 0.22222222222222
73659, 1.4173913043478, 0.51521739130435, 0.19444444444444
73660, 1.395652173913, 0.51521739130435, 0.16666666666667
73661, 1.4173913043478, 0.54130434782609, 0.16666666666667
73662, 1.4173913043478, 0.51521739130435, 0.13888888888889
73663, 1.395652173913, 0.51521739130435, 0.11111111111111
73664, 1.4173913043478, 0.54130434782609, 0.11111111111111
73665, 1.4173913043478, 0.51521739130435, 0.083333333333333
73666, 1.395652173913, 0.51521739130435, 0.055555555555556
73667, 1.4173913043478, 0.54130434782609, 0.055555555555556
73668, 1.4173913043478, 0.51521739130435, 0.027777777777778
73669, 1.4608695652174, 0.51521739130435, 0.47222222222222
73670, 1.4391304347826, 0.51521739130435, 0.44444444444444
73671, 1.4608695652174, 0.54130434782609, 0.44444444444444
73672, 1.4608695652174, 0.51521739130435, 0.41666666666667
73673, 1.4391304347826, 0.51521739130435, 0.38888888888889
73674, 1.4608695652174, 0.54130434782609, 0.38888888888889
73675, 1.4608695652174, 0.51521739130435, 0.36111111111111
73676, 1.4391304347826, 0.51521739130435, 0.33333333333333
73677, 1.4608695652174, 0.54130434782609, 0.33333333333333
73678, 1.4608695652174, 0.51521739130435, 0.30555555555556
73679, 1.4391304347826, 0.51521739130435, 0.27777777777778
73680, 1.4608695652174, 0.54130434782609, 0.27777777777778
73681, 1.4608695652174, 0.51521739130435, 0.25
73682, 1.4391304347826, 0.51521739130435, 0.22222222222222
73683, 1.4608695652174, 0.54130434782609, 0.22222222222222
73684, 1.4608695652174, 0.51521739130435, 0.19444444444444
73685, 1.4391304347826, 0.51521739130435, 0.16666666666667
73686, 1.4608695652174, 0.54130434782609, 0.16666666666667
73687, 1.4608695652174, 0.51521739130435, 0.13888888888889
73688, 1.4391304347826, 0.51521739130435, 0.11111111111111
73689, 1.4608695652174, 0.54130434782609, 0.11111111111111
73690, 1.4608695652174, 0.51521739130435, 0.083333333333333
73691, 1.4391304347826, 0.51521739130435, 0.055555555555556
73692, 1.4608695652174, 0.54130434782609, 0.055555555555556
73693, 1.4608695652174, 0.51521739130435, 0.027777777777778
73694, 1.504347826087, 0.51521739130435, 0.47222222222222
73695, 1.4826086956522, 0.51521739130435, 0.44444444444444
73696, 1.504347826087, 0.54130434782609, 0.44444444444444
73697, 1.504347826087, 0.51521739130435, 0.41666666666667
73698, 1.4826086956522, 0.51521739130435, 0.38888888888889
73699, 1.504347826087, 0.54130434782609, 0.38888888888889
73700, 1.504347826087, 0.51521739130435, 0.36111111111111
73701, 1.4826086956522, 0.51521739130435, 0.33333333333333
73702, 1.504347826087, 0.54130434782609, 0.33333333333333
73703, 1.504347826087, 0.51521739130435, 0.30555555555556
73704, 1.4826086956522, 0.51521739130435, 0.27777777777778
73705, 1.504347826087, 0.54130434782609, 0.27777777777778
73706, 1.504347826087, 0.51521739130435, 0.25
73707, 1.4826086956522, 0.51521739130435, 0.22222222222222
73708, 1.504347826087, 0.54130434782609, 0.22222222222222
73709, 1.504347826087, 0.51521739130435, 0.19444444444444
73710, 1.4826086956522, 0.51521739130435, 0.16666666666667
73711, 1.504347826087, 0.54130434782609, 0.16666666666667
73712, 1.504347826087, 0.51521739130435, 0.13888888888889
73713, 1.4826086956522, 0.51521739130435, 0.11111111111111
73714, 1.504347826087, 0.54130434782609, 0.11111111111111
73715, 1.504347826087, 0.51521739130435, 0.083333333333333
73716, 1.4826086956522, 0.51521739130435, 0.055555555555556
73717, 1.504347826087, 0.54130434782609, 0.055555555555556
73718, 1.504347826087, 0.51521739130435, 0.027777777777778
73719, 1.5478260869565, 0.51521739130435, 0.47222222222222
73720, 1.5260869565217, 0.51521739130435, 0.44444444444444
73721, 1.5478260869565, 0.54130434782609, 0.44444444444444
73722, 1.5478260869565, 0.51521739130435, 0.41666666666667
73723, 1.5260869565217, 0.51521739130435, 0.38888888888889
73724, 1.5478260869565, 0.54130434782609, 0.38888888888889
73725, 1.5478260869565, 0.51521739130435, 0.36111111111111
73726, 1.5260869565217, 0.51521739130435, 0.33333333333333
73727, 1.5478260869565, 0.54130434782609, 0.33333333333333
73728, 1.5478260869565, 0.51521739130435, 0.30555555555556
73729, 1.5260869565217, 0.51521739130435, 0.27777777777778
73730, 1.5478260869565, 0.54130434782609, 0.27777777777778
73731, 1.5478260869565, 0.51521739130435, 0.25
73732, 1.5260869565217, 0.51521739130435, 0.22222222222222
73733, 1.5478260869565, 0.54130434782609, 0.22222222222222
73734, 1.5478260869565, 0.51521739130435, 0.19444444444444
73735, 1.5260869565217, 0.51521739130435, 0.16666666666667
73736, 1.5478260869565, 0.54130434782609, 0.16666666666667
73737, 1.5478260869565, 0.51521739130435, 0.13888888888889
73738, 1.5260869565217, 0.51521739130435, 0.11111111111111
73739, 1.5478260869565, 0.54130434782609, 0.11111111111111
73740, 1.5478260869565, 0.51521739130435, 0.083333333333333
73741, 1.5260869565217, 0.51521739130435, 0.055555555555556
73742, 1.5478260869565, 0.54130434782609, 0.055555555555556
73743, 1.5478260869565, 0.51521739130435, 0.027777777777778
73744, 1.5913043478261, 0.51521739130435, 0.47222222222222
73745, 1.5695652173913, 0.51521739130435, 0.44444444444444
73746, 1.5913043478261, 0.54130434782609, 0.44444444444444
73747, 1.5913043478261, 0.51521739130435, 0.41666666666667
73748, 1.5695652173913, 0.51521739130435, 0.38888888888889
73749, 1.5913043478261, 0.54130434782609, 0.38888888888889
73750, 1.5913043478261, 0.51521739130435, 0.36111111111111
73751, 1.5695652173913, 0.51521739130435, 0.33333333333333
73752, 1.5913043478261, 0.54130434782609, 0.33333333333333
73753, 1.5913043478261, 0.51521739130435, 0.30555555555556
73754, 1.5695652173913, 0.51521739130435, 0.27777777777778
73755, 1.5913043478261, 0.54130434782609, 0.27777777777778
73756, 1.5913043478261, 0.51521739130435, 0.25
73757, 1.5695652173913, 0.51521739130435, 0.22222222222222
73758, 1.5913043478261, 0.54130434782609, 0.22222222222222
73759, 1.5913043478261, 0.51521739130435, 0.19444444444444
73760, 1.5695652173913, 0.51521739130435, 0.16666666666667
73761, 1.5913043478261, 0.54130434782609, 0.16666666666667
73762, 1.5913043478261, 0.51521739130435, 0.13888888888889
73763, 1.5695652173913, 0.51521739130435, 0.11111111111111
73764, 1.5913043478261, 0.54130434782609, 0.11111111111111
73765, 1.5913043478261, 0.51521739130435, 0.083333333333333
73766, 1.5695652173913, 0.51521739130435, 0.055555555555556
73767, 1.5913043478261, 0.54130434782609, 0.055555555555556
73768, 1.5913043478261, 0.51521739130435, 0.027777777777778
73769, 1.6347826086957, 0.51521739130435, 0.47222222222222
73770, 1.6130434782609, 0.51521739130435, 0.44444444444444
73771, 1.6347826086957, 0.54130434782609, 0.44444444444444
73772, 1.6347826086957, 0.51521739130435, 0.41666666666667
73773, 1.6130434782609, 0.51521739130435, 0.38888888888889
73774, 1.6347826086957, 0.54130434782609, 0.38888888888889
73775, 1.6347826086957, 0.51521739130435, 0.36111111111111
73776, 1.6130434782609, 0.51521739130435, 0.33333333333333
73777, 1.6347826086957, 0.54130434782609, 0.33333333333333
73778, 1.6347826086957, 0.51521739130435, 0.30555555555556
73779, 1.6130434782609, 0.51521739130435, 0.27777777777778
73780, 1.6347826086957, 0.54130434782609, 0.27777777777778
73781, 1.6347826086957, 0.51521739130435, 0.25
73782, 1.6130434782609, 0.51521739130435, 0.22222222222222
73783, 1.6347826086957, 0.54130434782609, 0.22222222222222
73784, 1.6347826086957, 0.51521739130435, 0.19444444444444
73785, 1.6130434782609, 0.51521739130435, 0.16666666666667
73786, 1.6347826086957, 0.54130434782609, 0.16666666666667
73787, 1.6347826086957, 0.51521739130435, 0.13888888888889
73788, 1.6130434782609, 0.51521739130435, 0.11111111111111
73789, 1.6347826086957, 0.54130434782609, 0.11111111111111
73790, 1.6347826086957, 0.51521739130435, 0.083333333333333
73791, 1.6130434782609, 0.51521739130435, 0.055555555555556
73792, 1.6347826086957, 0.54130434782609, 0.055555555555556
73793, 1.6347826086957, 0.51521739130435, 0.027777777777778
73794, 1.6782608695652, 0.51521739130435, 0.47222222222222
73795, 1.6565217391304, 0.51521739130435, 0.44444444444444
73796, 1.6782608695652, 0.54130434782609, 0.44444444444444
73797, 1.6782608695652, 0.51521739130435, 0.41666666666667
73798, 1.6565217391304, 0.51521739130435, 0.38888888888889
73799, 1.6782608695652, 0.54130434782609, 0.38888888888889
73800, 1.6782608695652, 0.51521739130435, 0.36111111111111
73801, 1.6565217391304, 0.51521739130435, 0.33333333333333
73802, 1.6782608695652, 0.54130434782609, 0.33333333333333
73803, 1.6782608695652, 0.51521739130435, 0.30555555555556
73804, 1.6565217391304, 0.51521739130435, 0.27777777777778
73805, 1.6782608695652, 0.54130434782609, 0.27777777777778
73806, 1.6782608695652, 0.51521739130435, 0.25
73807, 1.6565217391304, 0.51521739130435, 0.22222222222222
73808, 1.6782608695652, 0.54130434782609, 0.22222222222222
73809, 1.6782608695652, 0.51521739130435, 0.19444444444444
73810, 1.6565217391304, 0.51521739130435, 0.16666666666667
73811, 1.6782608695652, 0.54130434782609, 0.16666666666667
73812, 1.6782608695652, 0.51521739130435, 0.13888888888889
73813, 1.6565217391304, 0.51521739130435, 0.11111111111111
73814, 1.6782608695652, 0.54130434782609, 0.11111111111111
73815, 1.6782608695652, 0.51521739130435, 0.083333333333333
73816, 1.6565217391304, 0.51521739130435, 0.055555555555556
73817, 1.6782608695652, 0.54130434782609, 0.055555555555556
73818, 1.6782608695652, 0.51521739130435, 0.027777777777778
73819, 1.7217391304348, 0.51521739130435, 0.47222222222222
73820, 1.7, 0.51521739130435, 0.44444444444444
73821, 1.7217391304348, 0.54130434782609, 0.44444444444444
73822, 1.7217391304348, 0.51521739130435, 0.41666666666667
73823, 1.7, 0.51521739130435, 0.38888888888889
73824, 1.7217391304348, 0.54130434782609, 0.38888888888889
73825, 1.7217391304348, 0.51521739130435, 0.36111111111111
73826, 1.7, 0.51521739130435, 0.33333333333333
73827, 1.7217391304348, 0.54130434782609, 0.33333333333333
73828, 1.7217391304348, 0.51521739130435, 0.30555555555556
73829, 1.7, 0.51521739130435, 0.27777777777778
73830, 1.7217391304348, 0.54130434782609, 0.27777777777778
73831, 1.7217391304348, 0.51521739130435, 0.25
73832, 1.7, 0.51521739130435, 0.22222222222222
73833, 1.7217391304348, 0.54130434782609, 0.22222222222222
73834, 1.7217391304348, 0.51521739130435, 0.19444444444444
73835, 1.7, 0.51521739130435, 0.16666666666667
73836, 1.7217391304348, 0.54130434782609, 0.16666666666667
73837, 1.7217391304348, 0.51521739130435, 0.13888888888889
73838, 1.7, 0.51521739130435, 0.11111111111111
73839, 1.7217391304348, 0.54130434782609, 0.11111111111111
73840, 1.7217391304348, 0.51521739130435, 0.083333333333333
73841, 1.7, 0.51521739130435, 0.055555555555556
73842, 1.7217391304348, 0.54130434782609, 0.055555555555556
73843, 1.7217391304348, 0.51521739130435, 0.027777777777778
73844, 1.7652173913043, 0.51521739130435, 0.47222222222222
73845, 1.7434782608696, 0.51521739130435, 0.44444444444444
73846, 1.7652173913043, 0.54130434782609, 0.44444444444444
73847, 1.7652173913043, 0.51521739130435, 0.41666666666667
73848, 1.7434782608696, 0.51521739130435, 0.38888888888889
73849, 1.7652173913043, 0.54130434782609, 0.38888888888889
73850, 1.7652173913043, 0.51521739130435, 0.36111111111111
73851, 1.7434782608696, 0.51521739130435, 0.33333333333333
73852, 1.7652173913043, 0.54130434782609, 0.33333333333333
73853, 1.7652173913043, 0.51521739130435, 0.30555555555556
73854, 1.7434782608696, 0.51521739130435, 0.27777777777778
73855, 1.7652173913043, 0.54130434782609, 0.27777777777778
73856, 1.7652173913043, 0.51521739130435, 0.25
73857, 1.7434782608696, 0.51521739130435, 0.22222222222222
73858, 1.7652173913043, 0.54130434782609, 0.22222222222222
73859, 1.7652173913043, 0.51521739130435, 0.19444444444444
73860, 1.7434782608696, 0.51521739130435, 0.16666666666667
73861, 1.7652173913043, 0.54130434782609, 0.16666666666667
73862, 1.7652173913043, 0.51521739130435, 0.13888888888889
73863, 1.7434782608696, 0.51521739130435, 0.11111111111111
73864, 1.7652173913043, 0.54130434782609, 0.11111111111111
73865, 1.7652173913043, 0.51521739130435, 0.083333333333333
73866, 1.7434782608696, 0.51521739130435, 0.055555555555556
73867, 1.7652173913043, 0.54130434782609, 0.055555555555556
73868, 1.7652173913043, 0.51521739130435, 0.027777777777778
73869, 1.8086956521739, 0.51521739130435, 0.47222222222222
73870, 1.7869565217391, 0.51521739130435, 0.44444444444444
73871, 1.8086956521739, 0.54130434782609, 0.44444444444444
73872, 1.8086956521739, 0.51521739130435, 0.41666666666667
73873, 1.7869565217391, 0.51521739130435, 0.38888888888889
73874, 1.8086956521739, 0.54130434782609, 0.38888888888889
73875, 1.8086956521739, 0.51521739130435, 0.36111111111111
73876, 1.7869565217391, 0.51521739130435, 0.33333333333333
73877, 1.8086956521739, 0.54130434782609, 0.33333333333333
73878, 1.8086956521739, 0.51521739130435, 0.30555555555556
73879, 1.7869565217391, 0.51521739130435, 0.27777777777778
73880, 1.8086956521739, 0.54130434782609, 0.27777777777778
73881, 1.8086956521739, 0.51521739130435, 0.25
73882, 1.7869565217391, 0.51521739130435, 0.22222222222222
73883, 1.8086956521739, 0.54130434782609, 0.22222222222222
73884, 1.8086956521739, 0.51521739130435, 0.19444444444444
73885, 1.7869565217391, 0.51521739130435, 0.16666666666667
73886, 1.8086956521739, 0.54130434782609, 0.16666666666667
73887, 1.8086956521739, 0.51521739130435, 0.13888888888889
73888, 1.7869565217391, 0.51521739130435, 0.11111111111111
73889, 1.8086956521739, 0.54130434782609, 0.11111111111111
73890, 1.8086956521739, 0.51521739130435, 0.083333333333333
73891, 1.7869565217391, 0.51521739130435, 0.055555555555556
73892, 1.8086956521739, 0.54130434782609, 0.055555555555556
73893, 1.8086956521739, 0.51521739130435, 0.027777777777778
73894, 1.8521739130435, 0.51521739130435, 0.47222222222222
73895, 1.8304347826087, 0.51521739130435, 0.44444444444444
73896, 1.8521739130435, 0.54130434782609, 0.44444444444444
73897, 1.8521739130435, 0.51521739130435, 0.41666666666667
73898, 1.8304347826087, 0.51521739130435, 0.38888888888889
73899, 1.8521739130435, 0.54130434782609, 0.38888888888889
73900, 1.8521739130435, 0.51521739130435, 0.36111111111111
73901, 1.8304347826087, 0.51521739130435, 0.33333333333333
73902, 1.8521739130435, 0.54130434782609, 0.33333333333333
73903, 1.8521739130435, 0.51521739130435, 0.30555555555556
73904, 1.8304347826087, 0.51521739130435, 0.27777777777778
73905, 1.8521739130435, 0.54130434782609, 0.27777777777778
73906, 1.8521739130435, 0.51521739130435, 0.25
73907, 1.8304347826087, 0.51521739130435, 0.22222222222222
73908, 1.8521739130435, 0.54130434782609, 0.22222222222222
73909, 1.8521739130435, 0.51521739130435, 0.19444444444444
73910, 1.8304347826087, 0.51521739130435, 0.16666666666667
73911, 1.8521739130435, 0.54130434782609, 0.16666666666667
73912, 1.8521739130435, 0.51521739130435, 0.13888888888889
73913, 1.8304347826087, 0.51521739130435, 0.11111111111111
73914, 1.8521739130435, 0.54130434782609, 0.11111111111111
73915, 1.8521739130435, 0.51521739130435, 0.083333333333333
73916, 1.8304347826087, 0.51521739130435, 0.055555555555556
73917, 1.8521739130435, 0.54130434782609, 0.055555555555556
73918, 1.8521739130435, 0.51521739130435, 0.027777777777778
73919, 1.895652173913, 0.51521739130435, 0.47222222222222
73920, 1.8739130434783, 0.51521739130435, 0.44444444444444
73921, 1.895652173913, 0.54130434782609, 0.44444444444444
73922, 1.895652173913, 0.51521739130435, 0.41666666666667
73923, 1.8739130434783, 0.51521739130435, 0.38888888888889
73924, 1.895652173913, 0.54130434782609, 0.38888888888889
73925, 1.895652173913, 0.51521739130435, 0.36111111111111
73926, 1.8739130434783, 0.51521739130435, 0.33333333333333
73927, 1.895652173913, 0.54130434782609, 0.33333333333333
73928, 1.895652173913, 0.51521739130435, 0.30555555555556
73929, 1.8739130434783, 0.51521739130435, 0.27777777777778
73930, 1.895652173913, 0.54130434782609, 0.27777777777778
73931, 1.895652173913, 0.51521739130435, 0.25
73932, 1.8739130434783, 0.51521739130435, 0.22222222222222
73933, 1.895652173913, 0.54130434782609, 0.22222222222222
73934, 1.895652173913, 0.51521739130435, 0.19444444444444
73935, 1.8739130434783, 0.51521739130435, 0.16666666666667
73936, 1.895652173913, 0.54130434782609, 0.16666666666667
73937, 1.895652173913, 0.51521739130435, 0.13888888888889
73938, 1.8739130434783, 0.51521739130435, 0.11111111111111
73939, 1.895652173913, 0.54130434782609, 0.11111111111111
73940, 1.895652173913, 0.51521739130435, 0.083333333333333
73941, 1.8739130434783, 0.51521739130435, 0.055555555555556
73942, 1.895652173913, 0.54130434782609, 0.055555555555556
73943, 1.895652173913, 0.51521739130435, 0.027777777777778
73944, 1.9391304347826, 0.51521739130435, 0.47222222222222
73945, 1.9173913043478, 0.51521739130435, 0.44444444444444
73946, 1.9391304347826, 0.54130434782609, 0.44444444444444
73947, 1.9391304347826, 0.51521739130435, 0.41666666666667
73948, 1.9173913043478, 0.51521739130435, 0.38888888888889
73949, 1.9391304347826, 0.54130434782609, 0.38888888888889
73950, 1.9391304347826, 0.51521739130435, 0.36111111111111
73951, 1.9173913043478, 0.51521739130435, 0.33333333333333
73952, 1.9391304347826, 0.54130434782609, 0.33333333333333
73953, 1.9391304347826, 0.51521739130435, 0.30555555555556
73954, 1.9173913043478, 0.51521739130435, 0.27777777777778
73955, 1.9391304347826, 0.54130434782609, 0.27777777777778
73956, 1.9391304347826, 0.51521739130435, 0.25
73957, 1.9173913043478, 0.51521739130435, 0.22222222222222
73958, 1.9391304347826, 0.54130434782609, 0.22222222222222
73959, 1.9391304347826, 0.51521739130435, 0.19444444444444
73960, 1.9173913043478, 0.51521739130435, 0.16666666666667
73961, 1.9391304347826, 0.54130434782609, 0.16666666666667
73962, 1.9391304347826, 0.51521739130435, 0.13888888888889
73963, 1.9173913043478, 0.51521739130435, 0.11111111111111
73964, 1.9391304347826, 0.54130434782609, 0.11111111111111
73965, 1.9391304347826, 0.51521739130435, 0.083333333333333
73966, 1.9173913043478, 0.51521739130435, 0.055555555555556
73967, 1.9391304347826, 0.54130434782609, 0.055555555555556
73968, 1.9391304347826, 0.51521739130435, 0.027777777777778
73969, 1.9826086956522, 0.51521739130435, 0.47222222222222
73970, 1.9608695652174, 0.51521739130435, 0.44444444444444
73971, 1.9826086956522, 0.54130434782609, 0.44444444444444
73972, 1.9826086956522, 0.51521739130435, 0.41666666666667
73973, 1.9608695652174, 0.51521739130435, 0.38888888888889
73974, 1.9826086956522, 0.54130434782609, 0.38888888888889
73975, 1.9826086956522, 0.51521739130435, 0.36111111111111
73976, 1.9608695652174, 0.51521739130435, 0.33333333333333
73977, 1.9826086956522, 0.54130434782609, 0.33333333333333
73978, 1.9826086956522, 0.51521739130435, 0.30555555555556
73979, 1.9608695652174, 0.51521739130435, 0.27777777777778
73980, 1.9826086956522, 0.54130434782609, 0.27777777777778
73981, 1.9826086956522, 0.51521739130435, 0.25
73982, 1.9608695652174, 0.51521739130435, 0.22222222222222
73983, 1.9826086956522, 0.54130434782609, 0.22222222222222
73984, 1.9826086956522, 0.51521739130435, 0.19444444444444
73985, 1.9608695652174, 0.51521739130435, 0.16666666666667
73986, 1.9826086956522, 0.54130434782609, 0.16666666666667
73987, 1.9826086956522, 0.51521739130435, 0.13888888888889
73988, 1.9608695652174, 0.51521739130435, 0.11111111111111
73989, 1.9826086956522, 0.54130434782609, 0.11111111111111
73990, 1.9826086956522, 0.51521739130435, 0.083333333333333
73991, 1.9608695652174, 0.51521739130435, 0.055555555555556
73992, 1.9826086956522, 0.54130434782609, 0.055555555555556
73993, 1.9826086956522, 0.51521739130435, 0.027777777777778
73994, 2.0260869565217, 0.51521739130435, 0.47222222222222
73995, 2.004347826087, 0.51521739130435, 0.44444444444444
73996, 2.0260869565217, 0.54130434782609, 0.44444444444444
73997, 2.0260869565217, 0.51521739130435, 0.41666666666667
73998, 2.004347826087, 0.51521739130435, 0.38888888888889
73999, 2.0260869565217, 0.54130434782609, 0.38888888888889
74000, 2.0260869565217, 0.51521739130435, 0.36111111111111
74001, 2.004347826087, 0.51521739130435, 0.33333333333333
74002, 2.0260869565217, 0.54130434782609, 0.33333333333333
74003, 2.0260869565217, 0.51521739130435, 0.30555555555556
74004, 2.004347826087, 0.51521739130435, 0.27777777777778
74005, 2.0260869565217, 0.54130434782609, 0.27777777777778
74006, 2.0260869565217, 0.51521739130435, 0.25
74007, 2.004347826087, 0.51521739130435, 0.22222222222222
74008, 2.0260869565217, 0.54130434782609, 0.22222222222222
74009, 2.0260869565217, 0.51521739130435, 0.19444444444444
74010, 2.004347826087, 0.51521739130435, 0.16666666666667
74011, 2.0260869565217, 0.54130434782609, 0.16666666666667
74012, 2.0260869565217, 0.51521739130435, 0.13888888888889
74013, 2.004347826087, 0.51521739130435, 0.11111111111111
74014, 2.0260869565217, 0.54130434782609, 0.11111111111111
74015, 2.0260869565217, 0.51521739130435, 0.083333333333333
74016, 2.004347826087, 0.51521739130435, 0.055555555555556
74017, 2.0260869565217, 0.54130434782609, 0.055555555555556
74018, 2.0260869565217, 0.51521739130435, 0.027777777777778
74019, 2.0695652173913, 0.51521739130435, 0.47222222222222
74020, 2.0478260869565, 0.51521739130435, 0.44444444444444
74021, 2.0695652173913, 0.54130434782609, 0.44444444444444
74022, 2.0695652173913, 0.51521739130435, 0.41666666666667
74023, 2.0478260869565, 0.51521739130435, 0.38888888888889
74024, 2.0695652173913, 0.54130434782609, 0.38888888888889
74025, 2.0695652173913, 0.51521739130435, 0.36111111111111
74026, 2.0478260869565, 0.51521739130435, 0.33333333333333
74027, 2.0695652173913, 0.54130434782609, 0.33333333333333
74028, 2.0695652173913, 0.51521739130435, 0.30555555555556
74029, 2.0478260869565, 0.51521739130435, 0.27777777777778
74030, 2.0695652173913, 0.54130434782609, 0.27777777777778
74031, 2.0695652173913, 0.51521739130435, 0.25
74032, 2.0478260869565, 0.51521739130435, 0.22222222222222
74033, 2.0695652173913, 0.54130434782609, 0.22222222222222
74034, 2.0695652173913, 0.51521739130435, 0.19444444444444
74035, 2.0478260869565, 0.51521739130435, 0.16666666666667
74036, 2.0695652173913, 0.54130434782609, 0.16666666666667
74037, 2.0695652173913, 0.51521739130435, 0.13888888888889
74038, 2.0478260869565, 0.51521739130435, 0.11111111111111
74039, 2.0695652173913, 0.54130434782609, 0.11111111111111
74040, 2.0695652173913, 0.51521739130435, 0.083333333333333
74041, 2.0478260869565, 0.51521739130435, 0.055555555555556
74042, 2.0695652173913, 0.54130434782609, 0.055555555555556
74043, 2.0695652173913, 0.51521739130435, 0.027777777777778
74044, 2.1130434782609, 0.51521739130435, 0.47222222222222
74045, 2.0913043478261, 0.51521739130435, 0.44444444444444
74046, 2.1130434782609, 0.54130434782609, 0.44444444444444
74047, 2.1130434782609, 0.51521739130435, 0.41666666666667
74048, 2.0913043478261, 0.51521739130435, 0.38888888888889
74049, 2.1130434782609, 0.54130434782609, 0.38888888888889
74050, 2.1130434782609, 0.51521739130435, 0.36111111111111
74051, 2.0913043478261, 0.51521739130435, 0.33333333333333
74052, 2.1130434782609, 0.54130434782609, 0.33333333333333
74053, 2.1130434782609, 0.51521739130435, 0.30555555555556
74054, 2.0913043478261, 0.51521739130435, 0.27777777777778
74055, 2.1130434782609, 0.54130434782609, 0.27777777777778
