11940, 28657, 28665, 28666, 28658, 29027, 29028, 29029, 29011
11941, 28658, 28666, 28667, 28659, 29029, 29030, 29031, 29013
11942, 28659, 28667, 3337, 3336, 29031, 29032, 3359, 29015
11943, 3202, 3203, 28668, 28660, 3225, 29033, 29034, 29016
11944, 28660, 28668, 28669, 28661, 29034, 29035, 29036, 29018
11945, 28661, 28669, 28670, 28662, 29036, 29037, 29038, 29020
11946, 28662, 28670, 28671, 28663, 29038, 29039, 29040, 29022
11947, 28663, 28671, 28672, 28664, 29040, 29041, 29042, 29024
11948, 28664, 28672, 28673, 28665, 29042, 29043, 29044, 29026
11949, 28665, 28673, 28674, 28666, 29044, 29045, 29046, 29028
11950, 28666, 28674, 28675, 28667, 29046, 29047, 29048, 29030
11951, 28667, 28675, 3338, 3337, 29048, 29049, 3360, 29032
11952, 3203, 6, 359, 28668, 3226, 368, 29050, 29033
11953, 28668, 359, 358, 28669, 29050, 367, 29051, 29035
11954, 28669, 358, 357, 28670, 29051, 366, 29052, 29037
11955, 28670, 357, 356, 28671, 29052, 365, 29053, 29039
11956, 28671, 356, 355, 28672, 29053, 364, 29054, 29041
11957, 28672, 355, 354, 28673, 29054, 363, 29055, 29043
11958, 28673, 354, 353, 28674, 29055, 362, 29056, 29045
11959, 28674, 353, 352, 28675, 29056, 361, 29057, 29047
11960, 28675, 352, 8, 3338, 29057, 360, 3361, 29049
*ELEMENT, type=CPS8, ELSET=Surface269
11961, 93, 3227, 29058, 3414, 3249, 29234, 29235, 3423
11962, 3414, 29058, 29059, 3413, 29235, 29236, 29237, 3422
11963, 3413, 29059, 29060, 3412, 29237, 29238, 29239, 3421
11964, 3412, 29060, 29061, 3411, 29239, 29240, 29241, 3420
11965, 3411, 29061, 29062, 3410, 29241, 29242, 29243, 3419
11966, 3410, 29062, 29063, 3409, 29243, 29244, 29245, 3418
11967, 3409, 29063, 29064, 3408, 29245, 29246, 29247, 3417
11968, 3408, 29064, 29065, 3407, 29247, 29248, 29249, 3416
11969, 3407, 29065, 3362, 95, 29249, 29250, 3384, 3415
11970, 3227, 3228, 29066, 29058, 3250, 29251, 29252, 29234
11971, 29058, 29066, 29067, 29059, 29252, 29253, 29254, 29236
11972, 29059, 29067, 29068, 29060, 29254, 29255, 29256, 29238
11973, 29060, 29068, 29069, 29061, 29256, 29257, 29258, 29240
11974, 29061, 29069, 29070, 29062, 29258, 29259, 29260, 29242
11975, 29062, 29070, 29071, 29063, 29260, 29261, 29262, 29244
11976, 29063, 29071, 29072, 29064, 29262, 29263, 29264, 29246
11977, 29064, 29072, 29073, 29065, 29264, 29265, 29266, 29248
11978, 29065, 29073, 3363, 3362, 29266, 29267, 3385, 29250
11979, 3228, 3229, 29074, 29066, 3251, 29268, 29269, 29251
11980, 29066, 29074, 29075, 29067, 29269, 29270, 29271, 29253
11981, 29067, 29075, 29076, 29068, 29271, 29272, 29273, 29255
11982, 29068, 29076, 29077, 29069, 29273, 29274, 29275, 29257
11983, 29069, 29077, 29078, 29070, 29275, 29276, 29277, 29259
11984, 29070, 29078, 29079, 29071, 29277, 29278, 29279, 29261
11985, 29071, 29079, 29080, 29072, 29279, 29280, 29281, 29263
11986, 29072, 29080, 29081, 29073, 29281, 29282, 29283, 29265
11987, 29073, 29081, 3364, 3363, 29283, 29284, 3386, 29267
11988, 3229, 3230, 29082, 29074, 3252, 29285, 29286, 29268
11989, 29074, 29082, 29083, 29075, 29286, 29287, 29288, 29270
11990, 29075, 29083, 29084, 29076, 29288, 29289, 29290, 29272
11991, 29076, 29084, 29085, 29077, 29290, 29291, 29292, 29274
11992, 29077, 29085, 29086, 29078, 29292, 29293, 29294, 29276
11993, 29078, 29086, 29087, 29079, 29294, 29295, 29296, 29278
11994, 29079, 29087, 29088, 29080, 29296, 29297, 29298, 29280
11995, 29080, 29088, 29089, 29081, 29298, 29299, 29300, 29282
11996, 29081, 29089, 3365, 3364, 29300, 29301, 3387, 29284
11997, 3230, 3231, 29090, 29082, 3253, 29302, 29303, 29285
11998, 29082, 29090, 29091, 29083, 29303, 29304, 29305, 29287
11999, 29083, 29091, 29092, 29084, 29305, 29306, 29307, 29289
12000, 29084, 29092, 29093, 29085, 29307, 29308, 29309, 29291
12001, 29085, 29093, 29094, 29086, 29309, 29310, 29311, 29293
12002, 29086, 29094, 29095, 29087, 29311, 29312, 29313, 29295
12003, 29087, 29095, 29096, 29088, 29313, 29314, 29315, 29297
12004, 29088, 29096, 29097, 29089, 29315, 29316, 29317, 29299
12005, 29089, 29097, 3366, 3365, 29317, 29318, 3388, 29301
12006, 3231, 3232, 29098, 29090, 3254, 29319, 29320, 29302
12007, 29090, 29098, 29099, 29091, 29320, 29321, 29322, 29304
12008, 29091, 29099, 29100, 29092, 29322, 29323, 29324, 29306
12009, 29092, 29100, 29101, 29093, 29324, 29325, 29326, 29308
12010, 29093, 29101, 29102, 29094, 29326, 29327, 29328, 29310
12011, 29094, 29102, 29103, 29095, 29328, 29329, 29330, 29312
12012, 29095, 29103, 29104, 29096, 29330, 29331, 29332, 29314
12013, 29096, 29104, 29105, 29097, 29332, 29333, 29334, 29316
12014, 29097, 29105, 3367, 3366, 29334, 29335, 3389, 29318
12015, 3232, 3233, 29106, 29098, 3255, 29336, 29337, 29319
12016, 29098, 29106, 29107, 29099, 29337, 29338, 29339, 29321
12017, 29099, 29107, 29108, 29100, 29339, 29340, 29341, 29323
12018, 29100, 29108, 29109, 29101, 29341, 29342, 29343, 29325
12019, 29101, 29109, 29110, 29102, 29343, 29344, 29345, 29327
12020, 29102, 29110, 29111, 29103, 29345, 29346, 29347, 29329
12021, 29103, 29111, 29112, 29104, 29347, 29348, 29349, 29331
12022, 29104, 29112, 29113, 29105, 29349, 29350, 29351, 29333
12023, 29105, 29113, 3368, 3367, 29351, 29352, 3390, 29335
12024, 3233, 3234, 29114, 29106, 3256, 29353, 29354, 29336
12025, 29106, 29114, 29115, 29107, 29354, 29355, 29356, 29338
12026, 29107, 29115, 29116, 29108, 29356, 29357, 29358, 29340
12027, 29108, 29116, 29117, 29109, 29358, 29359, 29360, 29342
12028, 29109, 29117, 29118, 29110, 29360, 29361, 29362, 29344
12029, 29110, 29118, 29119, 29111, 29362, 29363, 29364, 29346
12030, 29111, 29119, 29120, 29112, 29364, 29365, 29366, 29348
12031, 29112, 29120, 29121, 29113, 29366, 29367, 29368, 29350
12032, 29113, 29121, 3369, 3368, 29368, 29369, 3391, 29352
12033, 3234, 3235, 29122, 29114, 3257, 29370, 29371, 29353
12034, 29114, 29122, 29123, 29115, 29371, 29372, 29373, 29355
12035, 29115, 29123, 29124, 29116, 29373, 29374, 29375, 29357
12036, 29116, 29124, 29125, 29117, 29375, 29376, 29377, 29359
12037, 29117, 29125, 29126, 29118, 29377, 29378, 29379, 29361
12038, 29118, 29126, 29127, 29119, 29379, 29380, 29381, 29363
12039, 29119, 29127, 29128, 29120, 29381, 29382, 29383, 29365
12040, 29120, 29128, 29129, 29121, 29383, 29384, 29385, 29367
12041, 29121, 29129, 3370, 3369, 29385, 29386, 3392, 29369
12042, 3235, 3236, 29130, 29122, 3258, 29387, 29388, 29370
12043, 29122, 29130, 29131, 29123, 29388, 29389, 29390, 29372
12044, 29123, 29131, 29132, 29124, 29390, 29391, 29392, 29374
12045, 29124, 29132, 29133, 29125, 29392, 29393, 29394, 29376
12046, 29125, 29133, 29134, 29126, 29394, 29395, 29396, 29378
12047, 29126, 29134, 29135, 29127, 29396, 29397, 29398, 29380
12048, 29127, 29135, 29136, 29128, 29398, 29399, 29400, 29382
12049, 29128, 29136, 29137, 29129, 29400, 29401, 29402, 29384
12050, 29129, 29137, 3371, 3370, 29402, 29403, 3393, 29386
12051, 3236, 3237, 29138, 29130, 3259, 29404, 29405, 29387
12052, 29130, 29138, 29139, 29131, 29405, 29406, 29407, 29389
12053, 29131, 29139, 29140, 29132, 29407, 29408, 29409, 29391
12054, 29132, 29140, 29141, 29133, 29409, 29410, 29411, 29393
12055, 29133, 29141, 29142, 29134, 29411, 29412, 29413, 29395
12056, 29134, 29142, 29143, 29135, 29413, 29414, 29415, 29397
12057, 29135, 29143, 29144, 29136, 29415, 29416, 29417, 29399
12058, 29136, 29144, 29145, 29137, 29417, 29418, 29419, 29401
12059, 29137, 29145, 3372, 3371, 29419, 29420, 3394, 29403
12060, 3237, 3238, 29146, 29138, 3260, 29421, 29422, 29404
12061, 29138, 29146, 29147, 29139, 29422, 29423, 29424, 29406
12062, 29139, 29147, 29148, 29140, 29424, 29425, 29426, 29408
12063, 29140, 29148, 29149, 29141, 29426, 29427, 29428, 29410
12064, 29141, 29149, 29150, 29142, 29428, 29429, 29430, 29412
12065, 29142, 29150, 29151, 29143, 29430, 29431, 29432, 29414
12066, 29143, 29151, 29152, 29144, 29432, 29433, 29434, 29416
12067, 29144, 29152, 29153, 29145, 29434, 29435, 29436, 29418
12068, 29145, 29153, 3373, 3372, 29436, 29437, 3395, 29420
12069, 3238, 3239, 29154, 29146, 3261, 29438, 29439, 29421
12070, 29146, 29154, 29155, 29147, 29439, 29440, 29441, 29423
12071, 29147, 29155, 29156, 29148, 29441, 29442, 29443, 29425
12072, 29148, 29156, 29157, 29149, 29443, 29444, 29445, 29427
12073, 29149, 29157, 29158, 29150, 29445, 29446, 29447, 29429
12074, 29150, 29158, 29159, 29151, 29447, 29448, 29449, 29431
12075, 29151, 29159, 29160, 29152, 29449, 29450, 29451, 29433
12076, 29152, 29160, 29161, 29153, 29451, 29452, 29453, 29435
12077, 29153, 29161, 3374, 3373, 29453, 29454, 3396, 29437
12078, 3239, 3240, 29162, 29154, 3262, 29455, 29456, 29438
12079, 29154, 29162, 29163, 29155, 29456, 29457, 29458, 29440
12080, 29155, 29163, 29164, 29156, 29458, 29459, 29460, 29442
12081, 29156, 29164, 29165, 29157, 29460, 29461, 29462, 29444
12082, 29157, 29165, 29166, 29158, 29462, 29463, 29464, 29446
12083, 29158, 29166, 29167, 29159, 29464, 29465, 29466, 29448
12084, 29159, 29167, 29168, 29160, 29466, 29467, 29468, 29450
12085, 29160, 29168, 29169, 29161, 29468, 29469, 29470, 29452
12086, 29161, 29169, 3375, 3374, 29470, 29471, 3397, 29454
12087, 3240, 3241, 29170, 29162, 3263, 29472, 29473, 29455
12088, 29162, 29170, 29171, 29163, 29473, 29474, 29475, 29457
12089, 29163, 29171, 29172, 29164, 29475, 29476, 29477, 29459
12090, 29164, 29172, 29173, 29165, 29477, 29478, 29479, 29461
12091, 29165, 29173, 29174, 29166, 29479, 29480, 29481, 29463
12092, 29166, 29174, 29175, 29167, 29481, 29482, 29483, 29465
12093, 29167, 29175, 29176, 29168, 29483, 29484, 29485, 29467
12094, 29168, 29176, 29177, 29169, 29485, 29486, 29487, 29469
12095, 29169, 29177, 3376, 3375, 29487, 29488, 3398, 29471
12096, 3241, 3242, 29178, 29170, 3264, 29489, 29490, 29472
12097, 29170, 29178, 29179, 29171, 29490, 29491, 29492, 29474
12098, 29171, 29179, 29180, 29172, 29492, 29493, 29494, 29476
12099, 29172, 29180, 29181, 29173, 29494, 29495, 29496, 29478
12100, 29173, 29181, 29182, 29174, 29496, 29497, 29498, 29480
12101, 29174, 29182, 29183, 29175, 29498, 29499, 29500, 29482
12102, 29175, 29183, 29184, 29176, 29500, 29501, 29502, 29484
12103, 29176, 29184, 29185, 29177, 29502, 29503, 29504, 29486
12104, 29177, 29185, 3377, 3376, 29504, 29505, 3399, 29488
12105, 3242, 3243, 29186, 29178, 3265, 29506, 29507, 29489
12106, 29178, 29186, 29187, 29179, 29507, 29508, 29509, 29491
12107, 29179, 29187, 29188, 29180, 29509, 29510, 29511, 29493
12108, 29180, 29188, 29189, 29181, 29511, 29512, 29513, 29495
12109, 29181, 29189, 29190, 29182, 29513, 29514, 29515, 29497
12110, 29182, 29190, 29191, 29183, 29515, 29516, 29517, 29499
12111, 29183, 29191, 29192, 29184, 29517, 29518, 29519, 29501
12112, 29184, 29192, 29193, 29185, 29519, 29520, 29521, 29503
12113, 29185, 29193, 3378, 3377, 29521, 29522, 3400, 29505
12114, 3243, 3244, 29194, 29186, 3266, 29523, 29524, 29506
12115, 29186, 29194, 29195, 29187, 29524, 29525, 29526, 29508
12116, 29187, 29195, 29196, 29188, 29526, 29527, 29528, 29510
12117, 29188, 29196, 29197, 29189, 29528, 29529, 29530, 29512
12118, 29189, 29197, 29198, 29190, 29530, 29531, 29532, 29514
12119, 29190, 29198, 29199, 29191, 29532, 29533, 29534, 29516
12120, 29191, 29199, 29200, 29192, 29534, 29535, 29536, 29518
12121, 29192, 29200, 29201, 29193, 29536, 29537, 29538, 29520
12122, 29193, 29201, 3379, 3378, 29538, 29539, 3401, 29522
12123, 3244, 3245, 29202, 29194, 3267, 29540, 29541, 29523
12124, 29194, 29202, 29203, 29195, 29541, 29542, 29543, 29525
12125, 29195, 29203, 29204, 29196, 29543, 29544, 29545, 29527
12126, 29196, 29204, 29205, 29197, 29545, 29546, 29547, 29529
12127, 29197, 29205, 29206, 29198, 29547, 29548, 29549, 29531
12128, 29198, 29206, 29207, 29199, 29549, 29550, 29551, 29533
12129, 29199, 29207, 29208, 29200, 29551, 29552, 29553, 29535
12130, 29200, 29208, 29209, 29201, 29553, 29554, 29555, 29537
12131, 29201, 29209, 3380, 3379, 29555, 29556, 3402, 29539
12132, 3245, 3246, 29210, 29202, 3268, 29557, 29558, 29540
12133, 29202, 29210, 29211, 29203, 29558, 29559, 29560, 29542
12134, 29203, 29211, 29212, 29204, 29560, 29561, 29562, 29544
12135, 29204, 29212, 29213, 29205, 29562, 29563, 29564, 29546
12136, 29205, 29213, 29214, 29206, 29564, 29565, 29566, 29548
12137, 29206, 29214, 29215, 29207, 29566, 29567, 29568, 29550
12138, 29207, 29215, 29216, 29208, 29568, 29569, 29570, 29552
12139, 29208, 29216, 29217, 29209, 29570, 29571, 29572, 29554
12140, 29209, 29217, 3381, 3380, 29572, 29573, 3403, 29556
12141, 3246, 3247, 29218, 29210, 3269, 29574, 29575, 29557
12142, 29210, 29218, 29219, 29211, 29575, 29576, 29577, 29559
12143, 29211, 29219, 29220, 29212, 29577, 29578, 29579, 29561
12144, 29212, 29220, 29221, 29213, 29579, 29580, 29581, 29563
12145, 29213, 29221, 29222, 29214, 29581, 29582, 29583, 29565
12146, 29214, 29222, 29223, 29215, 29583, 29584, 29585, 29567
12147, 29215, 29223, 29224, 29216, 29585, 29586, 29587, 29569
12148, 29216, 29224, 29225, 29217, 29587, 29588, 29589, 29571
12149, 29217, 29225, 3382, 3381, 29589, 29590, 3404, 29573
12150, 3247, 3248, 29226, 29218, 3270, 29591, 29592, 29574
12151, 29218, 29226, 29227, 29219, 29592, 29593, 29594, 29576
12152, 29219, 29227, 29228, 29220, 29594, 29595, 29596, 29578
12153, 29220, 29228, 29229, 29221, 29596, 29597, 29598, 29580
12154, 29221, 29229, 29230, 29222, 29598, 29599, 29600, 29582
12155, 29222, 29230, 29231, 29223, 29600, 29601, 29602, 29584
12156, 29223, 29231, 29232, 29224, 29602, 29603, 29604, 29586
12157, 29224, 29232, 29233, 29225, 29604, 29605, 29606, 29588
12158, 29225, 29233, 3383, 3382, 29606, 29607, 3405, 29590
12159, 3248, 94, 3431, 29226, 3271, 3440, 29608, 29591
12160, 29226, 3431, 3430, 29227, 29608, 3439, 29609, 29593
12161, 29227, 3430, 3429, 29228, 29609, 3438, 29610, 29595
12162, 29228, 3429, 3428, 29229, 29610, 3437, 29611, 29597
12163, 29229, 3428, 3427, 29230, 29611, 3436, 29612, 29599
12164, 29230, 3427, 3426, 29231, 29612, 3435, 29613, 29601
12165, 29231, 3426, 3425, 29232, 29613, 3434, 29614, 29603
12166, 29232, 3425, 3424, 29233, 29614, 3433, 29615, 29605
12167, 29233, 3424, 96, 3383, 29615, 3432, 3406, 29607
*ELEMENT, type=CPS8, ELSET=Surface270
12168, 5, 3441, 29616, 245, 3442, 29638, 29639, 267
12169, 245, 29616, 29617, 246, 29639, 29640, 29641, 268
12170, 246, 29617, 29618, 247, 29641, 29642, 29643, 269
12171, 247, 29618, 29619, 248, 29643, 29644, 29645, 270
12172, 248, 29619, 29620, 249, 29645, 29646, 29647, 271
12173, 249, 29620, 29621, 250, 29647, 29648, 29649, 272
12174, 250, 29621, 29622, 251, 29649, 29650, 29651, 273
12175, 251, 29622, 29623, 252, 29651, 29652, 29653, 274
12176, 252, 29623, 29624, 253, 29653, 29654, 29655, 275
12177, 253, 29624, 29625, 254, 29655, 29656, 29657, 276
12178, 254, 29625, 29626, 255, 29657, 29658, 29659, 277
12179, 255, 29626, 29627, 256, 29659, 29660, 29661, 278
12180, 256, 29627, 29628, 257, 29661, 29662, 29663, 279
12181, 257, 29628, 29629, 258, 29663, 29664, 29665, 280
12182, 258, 29629, 29630, 259, 29665, 29666, 29667, 281
12183, 259, 29630, 29631, 260, 29667, 29668, 29669, 282
12184, 260, 29631, 29632, 261, 29669, 29670, 29671, 283
12185, 261, 29632, 29633, 262, 29671, 29672, 29673, 284
12186, 262, 29633, 29634, 263, 29673, 29674, 29675, 285
12187, 263, 29634, 29635, 264, 29675, 29676, 29677, 286
12188, 264, 29635, 29636, 265, 29677, 29678, 29679, 287
12189, 265, 29636, 29637, 266, 29679, 29680, 29681, 288
12190, 266, 29637, 3444, 6, 29681, 29682, 3445, 289
12191, 3441, 97, 3447, 29616, 3443, 3469, 29683, 29638
12192, 29616, 3447, 3448, 29617, 29683, 3470, 29684, 29640
12193, 29617, 3448, 3449, 29618, 29684, 3471, 29685, 29642
12194, 29618, 3449, 3450, 29619, 29685, 3472, 29686, 29644
12195, 29619, 3450, 3451, 29620, 29686, 3473, 29687, 29646
12196, 29620, 3451, 3452, 29621, 29687, 3474, 29688, 29648
12197, 29621, 3452, 3453, 29622, 29688, 3475, 29689, 29650
12198, 29622, 3453, 3454, 29623, 29689, 3476, 29690, 29652
12199, 29623, 3454, 3455, 29624, 29690, 3477, 29691, 29654
12200, 29624, 3455, 3456, 29625, 29691, 3478, 29692, 29656
12201, 29625, 3456, 3457, 29626, 29692, 3479, 29693, 29658
12202, 29626, 3457, 3458, 29627, 29693, 3480, 29694, 29660
12203, 29627, 3458, 3459, 29628, 29694, 3481, 29695, 29662
12204, 29628, 3459, 3460, 29629, 29695, 3482, 29696, 29664
12205, 29629, 3460, 3461, 29630, 29696, 3483, 29697, 29666
12206, 29630, 3461, 3462, 29631, 29697, 3484, 29698, 29668
12207, 29631, 3462, 3463, 29632, 29698, 3485, 29699, 29670
12208, 29632, 3463, 3464, 29633, 29699, 3486, 29700, 29672
12209, 29633, 3464, 3465, 29634, 29700, 3487, 29701, 29674
12210, 29634, 3465, 3466, 29635, 29701, 3488, 29702, 29676
12211, 29635, 3466, 3467, 29636, 29702, 3489, 29703, 29678
12212, 29636, 3467, 3468, 29637, 29703, 3490, 29704, 29680
12213, 29637, 3468, 98, 3444, 29704, 3491, 3446, 29682
*ELEMENT, type=CPS8, ELSET=Surface271
12214, 7, 290, 29705, 3492, 312, 29727, 29728, 3493
12215, 290, 291, 29706, 29705, 313, 29729, 29730, 29727
12216, 291, 292, 29707, 29706, 314, 29731, 29732, 29729
12217, 292, 293, 29708, 29707, 315, 29733, 29734, 29731
12218, 293, 294, 29709, 29708, 316, 29735, 29736, 29733
12219, 294, 295, 29710, 29709, 317, 29737, 29738, 29735
12220, 295, 296, 29711, 29710, 318, 29739, 29740, 29737
12221, 296, 297, 29712, 29711, 319, 29741, 29742, 29739
12222, 297, 298, 29713, 29712, 320, 29743, 29744, 29741
12223, 298, 299, 29714, 29713, 321, 29745, 29746, 29743
12224, 299, 300, 29715, 29714, 322, 29747, 29748, 29745
12225, 300, 301, 29716, 29715, 323, 29749, 29750, 29747
12226, 301, 302, 29717, 29716, 324, 29751, 29752, 29749
12227, 302, 303, 29718, 29717, 325, 29753, 29754, 29751
12228, 303, 304, 29719, 29718, 326, 29755, 29756, 29753
12229, 304, 305, 29720, 29719, 327, 29757, 29758, 29755
12230, 305, 306, 29721, 29720, 328, 29759, 29760, 29757
12231, 306, 307, 29722, 29721, 329, 29761, 29762, 29759
12232, 307, 308, 29723, 29722, 330, 29763, 29764, 29761
12233, 308, 309, 29724, 29723, 331, 29765, 29766, 29763
12234, 309, 310, 29725, 29724, 332, 29767, 29768, 29765
12235, 310, 311, 29726, 29725, 333, 29769, 29770, 29767
12236, 311, 8, 3495, 29726, 334, 3496, 29771, 29769
12237, 3492, 29705, 3498, 99, 29728, 29772, 3520, 3494
12238, 29705, 29706, 3499, 3498, 29730, 29773, 3521, 29772
12239, 29706, 29707, 3500, 3499, 29732, 29774, 3522, 29773
12240, 29707, 29708, 3501, 3500, 29734, 29775, 3523, 29774
12241, 29708, 29709, 3502, 3501, 29736, 29776, 3524, 29775
12242, 29709, 29710, 3503, 3502, 29738, 29777, 3525, 29776
12243, 29710, 29711, 3504, 3503, 29740, 29778, 3526, 29777
12244, 29711, 29712, 3505, 3504, 29742, 29779, 3527, 29778
12245, 29712, 29713, 3506, 3505, 29744, 29780, 3528, 29779
12246, 29713, 29714, 3507, 3506, 29746, 29781, 3529, 29780
12247, 29714, 29715, 3508, 3507, 29748, 29782, 3530, 29781
12248, 29715, 29716, 3509, 3508, 29750, 29783, 3531, 29782
12249, 29716, 29717, 3510, 3509, 29752, 29784, 3532, 29783
12250, 29717, 29718, 3511, 3510, 29754, 29785, 3533, 29784
12251, 29718, 29719, 3512, 3511, 29756, 29786, 3534, 29785
12252, 29719, 29720, 3513, 3512, 29758, 29787, 3535, 29786
12253, 29720, 29721, 3514, 3513, 29760, 29788, 3536, 29787
12254, 29721, 29722, 3515, 3514, 29762, 29789, 3537, 29788
12255, 29722, 29723, 3516, 3515, 29764, 29790, 3538, 29789
12256, 29723, 29724, 3517, 3516, 29766, 29791, 3539, 29790
12257, 29724, 29725, 3518, 3517, 29768, 29792, 3540, 29791
12258, 29725, 29726, 3519, 3518, 29770, 29793, 3541, 29792
12259, 29726, 3495, 100, 3519, 29771, 3497, 3542, 29793
*ELEMENT, type=CPS8, ELSET=Surface272
12260, 5, 342, 29794, 3441, 351, 29802, 29803, 3442
12261, 342, 341, 29795, 29794, 350, 29804, 29805, 29802
12262, 341, 340, 29796, 29795, 349, 29806, 29807, 29804
12263, 340, 339, 29797, 29796, 348, 29808, 29809, 29806
12264, 339, 338, 29798, 29797, 347, 29810, 29811, 29808
12265, 338, 337, 29799, 29798, 346, 29812, 29813, 29810
12266, 337, 336, 29800, 29799, 345, 29814, 29815, 29812
12267, 336, 335, 29801, 29800, 344, 29816, 29817, 29814
12268, 335, 7, 3492, 29801, 343, 3493, 29818, 29816
12269, 3441, 29794, 3550, 97, 29803, 29819, 3559, 3443
12270, 29794, 29795, 3549, 3550, 29805, 29820, 3558, 29819
12271, 29795, 29796, 3548, 3549, 29807, 29821, 3557, 29820
12272, 29796, 29797, 3547, 3548, 29809, 29822, 3556, 29821
12273, 29797, 29798, 3546, 3547, 29811, 29823, 3555, 29822
12274, 29798, 29799, 3545, 3546, 29813, 29824, 3554, 29823
12275, 29799, 29800, 3544, 3545, 29815, 29825, 3553, 29824
12276, 29800, 29801, 3543, 3544, 29817, 29826, 3552, 29825
12277, 29801, 3492, 99, 3543, 29818, 3494, 3551, 29826
*ELEMENT, type=CPS8, ELSET=Surface273
12278, 6, 3444, 29827, 359, 3445, 29835, 29836, 368
12279, 359, 29827, 29828, 358, 29836, 29837, 29838, 367
12280, 358, 29828, 29829, 357, 29838, 29839, 29840, 366
12281, 357, 29829, 29830, 356, 29840, 29841, 29842, 365
12282, 356, 29830, 29831, 355, 29842, 29843, 29844, 364
12283, 355, 29831, 29832, 354, 29844, 29845, 29846, 363
12284, 354, 29832, 29833, 353, 29846, 29847, 29848, 362
12285, 353, 29833, 29834, 352, 29848, 29849, 29850, 361
12286, 352, 29834, 3495, 8, 29850, 29851, 3496, 360
12287, 3444, 98, 3567, 29827, 3446, 3576, 29852, 29835
12288, 29827, 3567, 3566, 29828, 29852, 3575, 29853, 29837
12289, 29828, 3566, 3565, 29829, 29853, 3574, 29854, 29839
12290, 29829, 3565, 3564, 29830, 29854, 3573, 29855, 29841
12291, 29830, 3564, 3563, 29831, 29855, 3572, 29856, 29843
12292, 29831, 3563, 3562, 29832, 29856, 3571, 29857, 29845
12293, 29832, 3562, 3561, 29833, 29857, 3570, 29858, 29847
12294, 29833, 3561, 3560, 29834, 29858, 3569, 29859, 29849
12295, 29834, 3560, 100, 3495, 29859, 3568, 3497, 29851
*ELEMENT, type=CPS8, ELSET=Surface274
12296, 97, 3550, 29860, 3447, 3559, 30036, 30037, 3469
12297, 3550, 3549, 29861, 29860, 3558, 30038, 30039, 30036
12298, 3549, 3548, 29862, 29861, 3557, 30040, 30041, 30038
12299, 3548, 3547, 29863, 29862, 3556, 30042, 30043, 30040
12300, 3547, 3546, 29864, 29863, 3555, 30044, 30045, 30042
12301, 3546, 3545, 29865, 29864, 3554, 30046, 30047, 30044
12302, 3545, 3544, 29866, 29865, 3553, 30048, 30049, 30046
12303, 3544, 3543, 29867, 29866, 3552, 30050, 30051, 30048
12304, 3543, 99, 3498, 29867, 3551, 3520, 30052, 30050
12305, 3447, 29860, 29868, 3448, 30037, 30053, 30054, 3470
12306, 29860, 29861, 29869, 29868, 30039, 30055, 30056, 30053
12307, 29861, 29862, 29870, 29869, 30041, 30057, 30058, 30055
12308, 29862, 29863, 29871, 29870, 30043, 30059, 30060, 30057
12309, 29863, 29864, 29872, 29871, 30045, 30061, 30062, 30059
12310, 29864, 29865, 29873, 29872, 30047, 30063, 30064, 30061
12311, 29865, 29866, 29874, 29873, 30049, 30065, 30066, 30063
12312, 29866, 29867, 29875, 29874, 30051, 30067, 30068, 30065
12313, 29867, 3498, 3499, 29875, 30052, 3521, 30069, 30067
12314, 3448, 29868, 29876, 3449, 30054, 30070, 30071, 3471
12315, 29868, 29869, 29877, 29876, 30056, 30072, 30073, 30070
12316, 29869, 29870, 29878, 29877, 30058, 30074, 30075, 30072
12317, 29870, 29871, 29879, 29878, 30060, 30076, 30077, 30074
12318, 29871, 29872, 29880, 29879, 30062, 30078, 30079, 30076
12319, 29872, 29873, 29881, 29880, 30064, 30080, 30081, 30078
12320, 29873, 29874, 29882, 29881, 30066, 30082, 30083, 30080
12321, 29874, 29875, 29883, 29882, 30068, 30084, 30085, 30082
12322, 29875, 3499, 3500, 29883, 30069, 3522, 30086, 30084
12323, 3449, 29876, 29884, 3450, 30071, 30087, 30088, 3472
12324, 29876, 29877, 29885, 29884, 30073, 30089, 30090, 30087
12325, 29877, 29878, 29886, 29885, 30075, 30091, 30092, 30089
12326, 29878, 29879, 29887, 29886, 30077, 30093, 30094, 30091
12327, 29879, 29880, 29888, 29887, 30079, 30095, 30096, 30093
12328, 29880, 29881, 29889, 29888, 30081, 30097, 30098, 30095
12329, 29881, 29882, 29890, 29889, 30083, 30099, 30100, 30097
12330, 29882, 29883, 29891, 29890, 30085, 30101, 30102, 30099
12331, 29883, 3500, 3501, 29891, 30086, 3523, 30103, 30101
12332, 3450, 29884, 29892, 3451, 30088, 30104, 30105, 3473
12333, 29884, 29885, 29893, 29892, 30090, 30106, 30107, 30104
12334, 29885, 29886, 29894, 29893, 30092, 30108, 30109, 30106
12335, 29886, 29887, 29895, 29894, 30094, 30110, 30111, 30108
12336, 29887, 29888, 29896, 29895, 30096, 30112, 30113, 30110
12337, 29888, 29889, 29897, 29896, 30098, 30114, 30115, 30112
12338, 29889, 29890, 29898, 29897, 30100, 30116, 30117, 30114
12339, 29890, 29891, 29899, 29898, 30102, 30118, 30119, 30116
12340, 29891, 3501, 3502, 29899, 30103, 3524, 30120, 30118
12341, 3451, 29892, 29900, 3452, 30105, 30121, 30122, 3474
12342, 29892, 29893, 29901, 29900, 30107, 30123, 30124, 30121
12343, 29893, 29894, 29902, 29901, 30109, 30125, 30126, 30123
12344, 29894, 29895, 29903, 29902, 30111, 30127, 30128, 30125
12345, 29895, 29896, 29904, 29903, 30113, 30129, 30130, 30127
12346, 29896, 29897, 29905, 29904, 30115, 30131, 30132, 30129
12347, 29897, 29898, 29906, 29905, 30117, 30133, 30134, 30131
12348, 29898, 29899, 29907, 29906, 30119, 30135, 30136, 30133
12349, 29899, 3502, 3503, 29907, 30120, 3525, 30137, 30135
12350, 3452, 29900, 29908, 3453, 30122, 30138, 30139, 3475
12351, 29900, 29901, 29909, 29908, 30124, 30140, 30141, 30138
12352, 29901, 29902, 29910, 29909, 30126, 30142, 30143, 30140
12353, 29902, 29903, 29911, 29910, 30128, 30144, 30145, 30142
12354, 29903, 29904, 29912, 29911, 30130, 30146, 30147, 30144
12355, 29904, 29905, 29913, 29912, 30132, 30148, 30149, 30146
12356, 29905, 29906, 29914, 29913, 30134, 30150, 30151, 30148
12357, 29906, 29907, 29915, 29914, 30136, 30152, 30153, 30150
12358, 29907, 3503, 3504, 29915, 30137, 3526, 30154, 30152
12359, 3453, 29908, 29916, 3454, 30139, 30155, 30156, 3476
12360, 29908, 29909, 29917, 29916, 30141, 30157, 30158, 30155
12361, 29909, 29910, 29918, 29917, 30143, 30159, 30160, 30157
12362, 29910, 29911, 29919, 29918, 30145, 30161, 30162, 30159
12363, 29911, 29912, 29920, 29919, 30147, 30163, 30164, 30161
12364, 29912, 29913, 29921, 29920, 30149, 30165, 30166, 30163
12365, 29913, 29914, 29922, 29921, 30151, 30167, 30168, 30165
12366, 29914, 29915, 29923, 29922, 30153, 30169, 30170, 30167
12367, 29915, 3504, 3505, 29923, 30154, 3527, 30171, 30169
12368, 3454, 29916, 29924, 3455, 30156, 30172, 30173, 3477
12369, 29916, 29917, 29925, 29924, 30158, 30174, 30175, 30172
12370, 29917, 29918, 29926, 29925, 30160, 30176, 30177, 30174
12371, 29918, 29919, 29927, 29926, 30162, 30178, 30179, 30176
12372, 29919, 29920, 29928, 29927, 30164, 30180, 30181, 30178
12373, 29920, 29921, 29929, 29928, 30166, 30182, 30183, 30180
12374, 29921, 29922, 29930, 29929, 30168, 30184, 30185, 30182
12375, 29922, 29923, 29931, 29930, 30170, 30186, 30187, 30184
12376, 29923, 3505, 3506, 29931, 30171, 3528, 30188, 30186
12377, 3455, 29924, 29932, 3456, 30173, 30189, 30190, 3478
12378, 29924, 29925, 29933, 29932, 30175, 30191, 30192, 30189
12379, 29925, 29926, 29934, 29933, 30177, 30193, 30194, 30191
12380, 29926, 29927, 29935, 29934, 30179, 30195, 30196, 30193
12381, 29927, 29928, 29936, 29935, 30181, 30197, 30198, 30195
12382, 29928, 29929, 29937, 29936, 30183, 30199, 30200, 30197
12383, 29929, 29930, 29938, 29937, 30185, 30201, 30202, 30199
12384, 29930, 29931, 29939, 29938, 30187, 30203, 30204, 30201
12385, 29931, 3506, 3507, 29939, 30188, 3529, 30205, 30203
12386, 3456, 29932, 29940, 3457, 30190, 30206, 30207, 3479
12387, 29932, 29933, 29941, 29940, 30192, 30208, 30209, 30206
12388, 29933, 29934, 29942, 29941, 30194, 30210, 30211, 30208
12389, 29934, 29935, 29943, 29942, 30196, 30212, 30213, 30210
12390, 29935, 29936, 29944, 29943, 30198, 30214, 30215, 30212
12391, 29936, 29937, 29945, 29944, 30200, 30216, 30217, 30214
12392, 29937, 29938, 29946, 29945, 30202, 30218, 30219, 30216
12393, 29938, 29939, 29947, 29946, 30204, 30220, 30221, 30218
12394, 29939, 3507, 3508, 29947, 30205, 3530, 30222, 30220
12395, 3457, 29940, 29948, 3458, 30207, 30223, 30224, 3480
12396, 29940, 29941, 29949, 29948, 30209, 30225, 30226, 30223
12397, 29941, 29942, 29950, 29949, 30211, 30227, 30228, 30225
12398, 29942, 29943, 29951, 29950, 30213, 30229, 30230, 30227
12399, 29943, 29944, 29952, 29951, 30215, 30231, 30232, 30229
12400, 29944, 29945, 29953, 29952, 30217, 30233, 30234, 30231
12401, 29945, 29946, 29954, 29953, 30219, 30235, 30236, 30233
12402, 29946, 29947, 29955, 29954, 30221, 30237, 30238, 30235
12403, 29947, 3508, 3509, 29955, 30222, 3531, 30239, 30237
12404, 3458, 29948, 29956, 3459, 30224, 30240, 30241, 3481
12405, 29948, 29949, 29957, 29956, 30226, 30242, 30243, 30240
12406, 29949, 29950, 29958, 29957, 30228, 30244, 30245, 30242
12407, 29950, 29951, 29959, 29958, 30230, 30246, 30247, 30244
12408, 29951, 29952, 29960, 29959, 30232, 30248, 30249, 30246
12409, 29952, 29953, 29961, 29960, 30234, 30250, 30251, 30248
12410, 29953, 29954, 29962, 29961, 30236, 30252, 30253, 30250
12411, 29954, 29955, 29963, 29962, 30238, 30254, 30255, 30252
12412, 29955, 3509, 3510, 29963, 30239, 3532, 30256, 30254
12413, 3459, 29956, 29964, 3460, 30241, 30257, 30258, 3482
12414, 29956, 29957, 29965, 29964, 30243, 30259, 30260, 30257
12415, 29957, 29958, 29966, 29965, 30245, 30261, 30262, 30259
12416, 29958, 29959, 29967, 29966, 30247, 30263, 30264, 30261
12417, 29959, 29960, 29968, 29967, 30249, 30265, 30266, 30263
12418, 29960, 29961, 29969, 29968, 30251, 30267, 30268, 30265
12419, 29961, 29962, 29970, 29969, 30253, 30269, 30270, 30267
12420, 29962, 29963, 29971, 29970, 30255, 30271, 30272, 30269
12421, 29963, 3510, 3511, 29971, 30256, 3533, 30273, 30271
12422, 3460, 29964, 29972, 3461, 30258, 30274, 30275, 3483
12423, 29964, 29965, 29973, 29972, 30260, 30276, 30277, 30274
12424, 29965, 29966, 29974, 29973, 30262, 30278, 30279, 30276
12425, 29966, 29967, 29975, 29974, 30264, 30280, 30281, 30278
12426, 29967, 29968, 29976, 29975, 30266, 30282, 30283, 30280
12427, 29968, 29969, 29977, 29976, 30268, 30284, 30285, 30282
12428, 29969, 29970, 29978, 29977, 30270, 30286, 30287, 30284
12429, 29970, 29971, 29979, 29978, 30272, 30288, 30289, 30286
12430, 29971, 3511, 3512, 29979, 30273, 3534, 30290, 30288
12431, 3461, 29972, 29980, 3462, 30275, 30291, 30292, 3484
12432, 29972, 29973, 29981, 29980, 30277, 30293, 30294, 30291
12433, 29973, 29974, 29982, 29981, 30279, 30295, 30296, 30293
12434, 29974, 29975, 29983, 29982, 30281, 30297, 30298, 30295
12435, 29975, 29976, 29984, 29983, 30283, 30299, 30300, 30297
12436, 29976, 29977, 29985, 29984, 30285, 30301, 30302, 30299
12437, 29977, 29978, 29986, 29985, 30287, 30303, 30304, 30301
12438, 29978, 29979, 29987, 29986, 30289, 30305, 30306, 30303
12439, 29979, 3512, 3513, 29987, 30290, 3535, 30307, 30305
12440, 3462, 29980, 29988, 3463, 30292, 30308, 30309, 3485
12441, 29980, 29981, 29989, 29988, 30294, 30310, 30311, 30308
12442, 29981, 29982, 29990, 29989, 30296, 30312, 30313, 30310
12443, 29982, 29983, 29991, 29990, 30298, 30314, 30315, 30312
12444, 29983, 29984, 29992, 29991, 30300, 30316, 30317, 30314
12445, 29984, 29985, 29993, 29992, 30302, 30318, 30319, 30316
12446, 29985, 29986, 29994, 29993, 30304, 30320, 30321, 30318
12447, 29986, 29987, 29995, 29994, 30306, 30322, 30323, 30320
12448, 29987, 3513, 3514, 29995, 30307, 3536, 30324, 30322
12449, 3463, 29988, 29996, 3464, 30309, 30325, 30326, 3486
12450, 29988, 29989, 29997, 29996, 30311, 30327, 30328, 30325
12451, 29989, 29990, 29998, 29997, 30313, 30329, 30330, 30327
12452, 29990, 29991, 29999, 29998, 30315, 30331, 30332, 30329
12453, 29991, 29992, 30000, 29999, 30317, 30333, 30334, 30331
12454, 29992, 29993, 30001, 30000, 30319, 30335, 30336, 30333
12455, 29993, 29994, 30002, 30001, 30321, 30337, 30338, 30335
12456, 29994, 29995, 30003, 30002, 30323, 30339, 30340, 30337
12457, 29995, 3514, 3515, 30003, 30324, 3537, 30341, 30339
12458, 3464, 29996, 30004, 3465, 30326, 30342, 30343, 3487
12459, 29996, 29997, 30005, 30004, 30328, 30344, 30345, 30342
12460, 29997, 29998, 30006, 30005, 30330, 30346, 30347, 30344
12461, 29998, 29999, 30007, 30006, 30332, 30348, 30349, 30346
12462, 29999, 30000, 30008, 30007, 30334, 30350, 30351, 30348
12463, 30000, 30001, 30009, 30008, 30336, 30352, 30353, 30350
12464, 30001, 30002, 30010, 30009, 30338, 30354, 30355, 30352
12465, 30002, 30003, 30011, 30010, 30340, 30356, 30357, 30354
12466, 30003, 3515, 3516, 30011, 30341, 3538, 30358, 30356
12467, 3465, 30004, 30012, 3466, 30343, 30359, 30360, 3488
12468, 30004, 30005, 30013, 30012, 30345, 30361, 30362, 30359
12469, 30005, 30006, 30014, 30013, 30347, 30363, 30364, 30361
12470, 30006, 30007, 30015, 30014, 30349, 30365, 30366, 30363
12471, 30007, 30008, 30016, 30015, 30351, 30367, 30368, 30365
12472, 30008, 30009, 30017, 30016, 30353, 30369, 30370, 30367
12473, 30009, 30010, 30018, 30017, 30355, 30371, 30372, 30369
12474, 30010, 30011, 30019, 30018, 30357, 30373, 30374, 30371
12475, 30011, 3516, 3517, 30019, 30358, 3539, 30375, 30373
12476, 3466, 30012, 30020, 3467, 30360, 30376, 30377, 3489
12477, 30012, 30013, 30021, 30020, 30362, 30378, 30379, 30376
12478, 30013, 30014, 30022, 30021, 30364, 30380, 30381, 30378
12479, 30014, 30015, 30023, 30022, 30366, 30382, 30383, 30380
12480, 30015, 30016, 30024, 30023, 30368, 30384, 30385, 30382
12481, 30016, 30017, 30025, 30024, 30370, 30386, 30387, 30384
12482, 30017, 30018, 30026, 30025, 30372, 30388, 30389, 30386
12483, 30018, 30019, 30027, 30026, 30374, 30390, 30391, 30388
12484, 30019, 3517, 3518, 30027, 30375, 3540, 30392, 30390
12485, 3467, 30020, 30028, 3468, 30377, 30393, 30394, 3490
12486, 30020, 30021, 30029, 30028, 30379, 30395, 30396, 30393
12487, 30021, 30022, 30030, 30029, 30381, 30397, 30398, 30395
12488, 30022, 30023, 30031, 30030, 30383, 30399, 30400, 30397
12489, 30023, 30024, 30032, 30031, 30385, 30401, 30402, 30399
12490, 30024, 30025, 30033, 30032, 30387, 30403, 30404, 30401
12491, 30025, 30026, 30034, 30033, 30389, 30405, 30406, 30403
12492, 30026, 30027, 30035, 30034, 30391, 30407, 30408, 30405
12493, 30027, 3518, 3519, 30035, 30392, 3541, 30409, 30407
12494, 3468, 30028, 3567, 98, 30394, 30410, 3576, 3491
12495, 30028, 30029, 3566, 3567, 30396, 30411, 3575, 30410
12496, 30029, 30030, 3565, 3566, 30398, 30412, 3574, 30411
12497, 30030, 30031, 3564, 3565, 30400, 30413, 3573, 30412
12498, 30031, 30032, 3563, 3564, 30402, 30414, 3572, 30413
12499, 30032, 30033, 3562, 3563, 30404, 30415, 3571, 30414
12500, 30033, 30034, 3561, 3562, 30406, 30416, 3570, 30415
12501, 30034, 30035, 3560, 3561, 30408, 30417, 3569, 30416
12502, 30035, 3519, 100, 3560, 30409, 3542, 3568, 30417
*ELEMENT, type=CPS8, ELSET=Surface275
12503, 35, 1196, 30418, 3577, 1218, 30440, 30441, 3578
12504, 1196, 1197, 30419, 30418, 1219, 30442, 30443, 30440
12505, 1197, 1198, 30420, 30419, 1220, 30444, 30445, 30442
12506, 1198, 1199, 30421, 30420, 1221, 30446, 30447, 30444
12507, 1199, 1200, 30422, 30421, 1222, 30448, 30449, 30446
12508, 1200, 1201, 30423, 30422, 1223, 30450, 30451, 30448
12509, 1201, 1202, 30424, 30423, 1224, 30452, 30453, 30450
12510, 1202, 1203, 30425, 30424, 1225, 30454, 30455, 30452
12511, 1203, 1204, 30426, 30425, 1226, 30456, 30457, 30454
12512, 1204, 1205, 30427, 30426, 1227, 30458, 30459, 30456
12513, 1205, 1206, 30428, 30427, 1228, 30460, 30461, 30458
12514, 1206, 1207, 30429, 30428, 1229, 30462, 30463, 30460
12515, 1207, 1208, 30430, 30429, 1230, 30464, 30465, 30462
12516, 1208, 1209, 30431, 30430, 1231, 30466, 30467, 30464
12517, 1209, 1210, 30432, 30431, 1232, 30468, 30469, 30466
12518, 1210, 1211, 30433, 30432, 1233, 30470, 30471, 30468
12519, 1211, 1212, 30434, 30433, 1234, 30472, 30473, 30470
12520, 1212, 1213, 30435, 30434, 1235, 30474, 30475, 30472
12521, 1213, 1214, 30436, 30435, 1236, 30476, 30477, 30474
12522, 1214, 1215, 30437, 30436, 1237, 30478, 30479, 30476
12523, 1215, 1216, 30438, 30437, 1238, 30480, 30481, 30478
12524, 1216, 1217, 30439, 30438, 1239, 30482, 30483, 30480
12525, 1217, 36, 3580, 30439, 1240, 3581, 30484, 30482
12526, 3577, 30418, 3447, 97, 30441, 30485, 3469, 3579
12527, 30418, 30419, 3448, 3447, 30443, 30486, 3470, 30485
12528, 30419, 30420, 3449, 3448, 30445, 30487, 3471, 30486
12529, 30420, 30421, 3450, 3449, 30447, 30488, 3472, 30487
12530, 30421, 30422, 3451, 3450, 30449, 30489, 3473, 30488
12531, 30422, 30423, 3452, 3451, 30451, 30490, 3474, 30489
12532, 30423, 30424, 3453, 3452, 30453, 30491, 3475, 30490
12533, 30424, 30425, 3454, 3453, 30455, 30492, 3476, 30491
12534, 30425, 30426, 3455, 3454, 30457, 30493, 3477, 30492
12535, 30426, 30427, 3456, 3455, 30459, 30494, 3478, 30493
12536, 30427, 30428, 3457, 3456, 30461, 30495, 3479, 30494
12537, 30428, 30429, 3458, 3457, 30463, 30496, 3480, 30495
12538, 30429, 30430, 3459, 3458, 30465, 30497, 3481, 30496
12539, 30430, 30431, 3460, 3459, 30467, 30498, 3482, 30497
12540, 30431, 30432, 3461, 3460, 30469, 30499, 3483, 30498
12541, 30432, 30433, 3462, 3461, 30471, 30500, 3484, 30499
12542, 30433, 30434, 3463, 3462, 30473, 30501, 3485, 30500
12543, 30434, 30435, 3464, 3463, 30475, 30502, 3486, 30501
12544, 30435, 30436, 3465, 3464, 30477, 30503, 3487, 30502
12545, 30436, 30437, 3466, 3465, 30479, 30504, 3488, 30503
12546, 30437, 30438, 3467, 3466, 30481, 30505, 3489, 30504
12547, 30438, 30439, 3468, 3467, 30483, 30506, 3490, 30505
12548, 30439, 3580, 98, 3468, 30484, 3582, 3491, 30506
*ELEMENT, type=CPS8, ELSET=Surface276
12549, 37, 3583, 30507, 1251, 3584, 30529, 30530, 1273
12550, 1251, 30507, 30508, 1252, 30530, 30531, 30532, 1274
12551, 1252, 30508, 30509, 1253, 30532, 30533, 30534, 1275
12552, 1253, 30509, 30510, 1254, 30534, 30535, 30536, 1276
12553, 1254, 30510, 30511, 1255, 30536, 30537, 30538, 1277
12554, 1255, 30511, 30512, 1256, 30538, 30539, 30540, 1278
12555, 1256, 30512, 30513, 1257, 30540, 30541, 30542, 1279
12556, 1257, 30513, 30514, 1258, 30542, 30543, 30544, 1280
12557, 1258, 30514, 30515, 1259, 30544, 30545, 30546, 1281
12558, 1259, 30515, 30516, 1260, 30546, 30547, 30548, 1282
12559, 1260, 30516, 30517, 1261, 30548, 30549, 30550, 1283
12560, 1261, 30517, 30518, 1262, 30550, 30551, 30552, 1284
12561, 1262, 30518, 30519, 1263, 30552, 30553, 30554, 1285
12562, 1263, 30519, 30520, 1264, 30554, 30555, 30556, 1286
12563, 1264, 30520, 30521, 1265, 30556, 30557, 30558, 1287
12564, 1265, 30521, 30522, 1266, 30558, 30559, 30560, 1288
12565, 1266, 30522, 30523, 1267, 30560, 30561, 30562, 1289
12566, 1267, 30523, 30524, 1268, 30562, 30563, 30564, 1290
12567, 1268, 30524, 30525, 1269, 30564, 30565, 30566, 1291
12568, 1269, 30525, 30526, 1270, 30566, 30567, 30568, 1292
12569, 1270, 30526, 30527, 1271, 30568, 30569, 30570, 1293
12570, 1271, 30527, 30528, 1272, 30570, 30571, 30572, 1294
12571, 1272, 30528, 3586, 38, 30572, 30573, 3587, 1295
12572, 3583, 99, 3498, 30507, 3585, 3520, 30574, 30529
12573, 30507, 3498, 3499, 30508, 30574, 3521, 30575, 30531
12574, 30508, 3499, 3500, 30509, 30575, 3522, 30576, 30533
12575, 30509, 3500, 3501, 30510, 30576, 3523, 30577, 30535
12576, 30510, 3501, 3502, 30511, 30577, 3524, 30578, 30537
12577, 30511, 3502, 3503, 30512, 30578, 3525, 30579, 30539
12578, 30512, 3503, 3504, 30513, 30579, 3526, 30580, 30541
12579, 30513, 3504, 3505, 30514, 30580, 3527, 30581, 30543
12580, 30514, 3505, 3506, 30515, 30581, 3528, 30582, 30545
12581, 30515, 3506, 3507, 30516, 30582, 3529, 30583, 30547
12582, 30516, 3507, 3508, 30517, 30583, 3530, 30584, 30549
12583, 30517, 3508, 3509, 30518, 30584, 3531, 30585, 30551
12584, 30518, 3509, 3510, 30519, 30585, 3532, 30586, 30553
12585, 30519, 3510, 3511, 30520, 30586, 3533, 30587, 30555
12586, 30520, 3511, 3512, 30521, 30587, 3534, 30588, 30557
12587, 30521, 3512, 3513, 30522, 30588, 3535, 30589, 30559
12588, 30522, 3513, 3514, 30523, 30589, 3536, 30590, 30561
12589, 30523, 3514, 3515, 30524, 30590, 3537, 30591, 30563
12590, 30524, 3515, 3516, 30525, 30591, 3538, 30592, 30565
12591, 30525, 3516, 3517, 30526, 30592, 3539, 30593, 30567
12592, 30526, 3517, 3518, 30527, 30593, 3540, 30594, 30569
12593, 30527, 3518, 3519, 30528, 30594, 3541, 30595, 30571
12594, 30528, 3519, 100, 3586, 30595, 3542, 3588, 30573
*ELEMENT, type=CPS8, ELSET=Surface277
12595, 35, 3577, 30596, 1303, 3578, 30604, 30605, 1312
12596, 1303, 30596, 30597, 1302, 30605, 30606, 30607, 1311
12597, 1302, 30597, 30598, 1301, 30607, 30608, 30609, 1310
12598, 1301, 30598, 30599, 1300, 30609, 30610, 30611, 1309
12599, 1300, 30599, 30600, 1299, 30611, 30612, 30613, 1308
12600, 1299, 30600, 30601, 1298, 30613, 30614, 30615, 1307
12601, 1298, 30601, 30602, 1297, 30615, 30616, 30617, 1306
12602, 1297, 30602, 30603, 1296, 30617, 30618, 30619, 1305
12603, 1296, 30603, 3583, 37, 30619, 30620, 3584, 1304
12604, 3577, 97, 3550, 30596, 3579, 3559, 30621, 30604
12605, 30596, 3550, 3549, 30597, 30621, 3558, 30622, 30606
12606, 30597, 3549, 3548, 30598, 30622, 3557, 30623, 30608
12607, 30598, 3548, 3547, 30599, 30623, 3556, 30624, 30610
12608, 30599, 3547, 3546, 30600, 30624, 3555, 30625, 30612
12609, 30600, 3546, 3545, 30601, 30625, 3554, 30626, 30614
12610, 30601, 3545, 3544, 30602, 30626, 3553, 30627, 30616
12611, 30602, 3544, 3543, 30603, 30627, 3552, 30628, 30618
12612, 30603, 3543, 99, 3583, 30628, 3551, 3585, 30620
*ELEMENT, type=CPS8, ELSET=Surface278
12613, 36, 1320, 30629, 3580, 1329, 30637, 30638, 3581
12614, 1320, 1319, 30630, 30629, 1328, 30639, 30640, 30637
12615, 1319, 1318, 30631, 30630, 1327, 30641, 30642, 30639
12616, 1318, 1317, 30632, 30631, 1326, 30643, 30644, 30641
12617, 1317, 1316, 30633, 30632, 1325, 30645, 30646, 30643
12618, 1316, 1315, 30634, 30633, 1324, 30647, 30648, 30645
12619, 1315, 1314, 30635, 30634, 1323, 30649, 30650, 30647
12620, 1314, 1313, 30636, 30635, 1322, 30651, 30652, 30649
12621, 1313, 38, 3586, 30636, 1321, 3587, 30653, 30651
12622, 3580, 30629, 3567, 98, 30638, 30654, 3576, 3582
12623, 30629, 30630, 3566, 3567, 30640, 30655, 3575, 30654
12624, 30630, 30631, 3565, 3566, 30642, 30656, 3574, 30655
12625, 30631, 30632, 3564, 3565, 30644, 30657, 3573, 30656
12626, 30632, 30633, 3563, 3564, 30646, 30658, 3572, 30657
12627, 30633, 30634, 3562, 3563, 30648, 30659, 3571, 30658
12628, 30634, 30635, 3561, 3562, 30650, 30660, 3570, 30659
12629, 30635, 30636, 3560, 3561, 30652, 30661, 3569, 30660
12630, 30636, 3586, 100, 3560, 30653, 3588, 3568, 30661
*ELEMENT, type=CPS8, ELSET=Surface279
12631, 24, 692, 30662, 3589, 715, 30684, 30685, 3590
12632, 692, 691, 30663, 30662, 714, 30686, 30687, 30684
12633, 691, 690, 30664, 30663, 713, 30688, 30689, 30686
12634, 690, 689, 30665, 30664, 712, 30690, 30691, 30688
12635, 689, 688, 30666, 30665, 711, 30692, 30693, 30690
12636, 688, 687, 30667, 30666, 710, 30694, 30695, 30692
12637, 687, 686, 30668, 30667, 709, 30696, 30697, 30694
12638, 686, 685, 30669, 30668, 708, 30698, 30699, 30696
12639, 685, 684, 30670, 30669, 707, 30700, 30701, 30698
12640, 684, 683, 30671, 30670, 706, 30702, 30703, 30700
12641, 683, 682, 30672, 30671, 705, 30704, 30705, 30702
12642, 682, 681, 30673, 30672, 704, 30706, 30707, 30704
12643, 681, 680, 30674, 30673, 703, 30708, 30709, 30706
12644, 680, 679, 30675, 30674, 702, 30710, 30711, 30708
12645, 679, 678, 30676, 30675, 701, 30712, 30713, 30710
12646, 678, 677, 30677, 30676, 700, 30714, 30715, 30712
12647, 677, 676, 30678, 30677, 699, 30716, 30717, 30714
12648, 676, 675, 30679, 30678, 698, 30718, 30719, 30716
12649, 675, 674, 30680, 30679, 697, 30720, 30721, 30718
12650, 674, 673, 30681, 30680, 696, 30722, 30723, 30720
12651, 673, 672, 30682, 30681, 695, 30724, 30725, 30722
12652, 672, 671, 30683, 30682, 694, 30726, 30727, 30724
12653, 671, 15, 3592, 30683, 693, 3593, 30728, 30726
12654, 3589, 30662, 2724, 85, 30685, 30729, 2747, 3591
12655, 30662, 30663, 2723, 2724, 30687, 30730, 2746, 30729
12656, 30663, 30664, 2722, 2723, 30689, 30731, 2745, 30730
12657, 30664, 30665, 2721, 2722, 30691, 30732, 2744, 30731
12658, 30665, 30666, 2720, 2721, 30693, 30733, 2743, 30732
12659, 30666, 30667, 2719, 2720, 30695, 30734, 2742, 30733
12660, 30667, 30668, 2718, 2719, 30697, 30735, 2741, 30734
12661, 30668, 30669, 2717, 2718, 30699, 30736, 2740, 30735
12662, 30669, 30670, 2716, 2717, 30701, 30737, 2739, 30736
12663, 30670, 30671, 2715, 2716, 30703, 30738, 2738, 30737
12664, 30671, 30672, 2714, 2715, 30705, 30739, 2737, 30738
12665, 30672, 30673, 2713, 2714, 30707, 30740, 2736, 30739
12666, 30673, 30674, 2712, 2713, 30709, 30741, 2735, 30740
12667, 30674, 30675, 2711, 2712, 30711, 30742, 2734, 30741
12668, 30675, 30676, 2710, 2711, 30713, 30743, 2733, 30742
12669, 30676, 30677, 2709, 2710, 30715, 30744, 2732, 30743
12670, 30677, 30678, 2708, 2709, 30717, 30745, 2731, 30744
12671, 30678, 30679, 2707, 2708, 30719, 30746, 2730, 30745
12672, 30679, 30680, 2706, 2707, 30721, 30747, 2729, 30746
12673, 30680, 30681, 2705, 2706, 30723, 30748, 2728, 30747
12674, 30681, 30682, 2704, 2705, 30725, 30749, 2727, 30748
12675, 30682, 30683, 2703, 2704, 30727, 30750, 2726, 30749
12676, 30683, 3592, 86, 2703, 30728, 3594, 2725, 30750
*ELEMENT, type=CPS8, ELSET=Surface280
12677, 23, 566, 30751, 3595, 575, 30759, 30760, 3596
12678, 566, 565, 30752, 30751, 574, 30761, 30762, 30759
12679, 565, 564, 30753, 30752, 573, 30763, 30764, 30761
12680, 564, 563, 30754, 30753, 572, 30765, 30766, 30763
12681, 563, 562, 30755, 30754, 571, 30767, 30768, 30765
12682, 562, 561, 30756, 30755, 570, 30769, 30770, 30767
12683, 561, 560, 30757, 30756, 569, 30771, 30772, 30769
12684, 560, 559, 30758, 30757, 568, 30773, 30774, 30771
12685, 559, 24, 3589, 30758, 567, 3590, 30775, 30773
12686, 3595, 30751, 2758, 87, 30760, 30776, 2767, 3597
12687, 30751, 30752, 2757, 2758, 30762, 30777, 2766, 30776
12688, 30752, 30753, 2756, 2757, 30764, 30778, 2765, 30777
12689, 30753, 30754, 2755, 2756, 30766, 30779, 2764, 30778
12690, 30754, 30755, 2754, 2755, 30768, 30780, 2763, 30779
12691, 30755, 30756, 2753, 2754, 30770, 30781, 2762, 30780
12692, 30756, 30757, 2752, 2753, 30772, 30782, 2761, 30781
12693, 30757, 30758, 2751, 2752, 30774, 30783, 2760, 30782
12694, 30758, 3589, 85, 2751, 30775, 3591, 2759, 30783
*ELEMENT, type=CPS8, ELSET=Surface281
12695, 23, 3595, 30784, 737, 3596, 30806, 30807, 760
12696, 737, 30784, 30785, 736, 30807, 30808, 30809, 759
12697, 736, 30785, 30786, 735, 30809, 30810, 30811, 758
12698, 735, 30786, 30787, 734, 30811, 30812, 30813, 757
12699, 734, 30787, 30788, 733, 30813, 30814, 30815, 756
12700, 733, 30788, 30789, 732, 30815, 30816, 30817, 755
12701, 732, 30789, 30790, 731, 30817, 30818, 30819, 754
12702, 731, 30790, 30791, 730, 30819, 30820, 30821, 753
12703, 730, 30791, 30792, 729, 30821, 30822, 30823, 752
12704, 729, 30792, 30793, 728, 30823, 30824, 30825, 751
12705, 728, 30793, 30794, 727, 30825, 30826, 30827, 750
12706, 727, 30794, 30795, 726, 30827, 30828, 30829, 749
12707, 726, 30795, 30796, 725, 30829, 30830, 30831, 748
12708, 725, 30796, 30797, 724, 30831, 30832, 30833, 747
12709, 724, 30797, 30798, 723, 30833, 30834, 30835, 746
12710, 723, 30798, 30799, 722, 30835, 30836, 30837, 745
12711, 722, 30799, 30800, 721, 30837, 30838, 30839, 744
12712, 721, 30800, 30801, 720, 30839, 30840, 30841, 743
12713, 720, 30801, 30802, 719, 30841, 30842, 30843, 742
12714, 719, 30802, 30803, 718, 30843, 30844, 30845, 741
12715, 718, 30803, 30804, 717, 30845, 30846, 30847, 740
12716, 717, 30804, 30805, 716, 30847, 30848, 30849, 739
12717, 716, 30805, 3598, 9, 30849, 30850, 3599, 738
12718, 3595, 87, 2792, 30784, 3597, 2815, 30851, 30806
12719, 30784, 2792, 2791, 30785, 30851, 2814, 30852, 30808
12720, 30785, 2791, 2790, 30786, 30852, 2813, 30853, 30810
12721, 30786, 2790, 2789, 30787, 30853, 2812, 30854, 30812
12722, 30787, 2789, 2788, 30788, 30854, 2811, 30855, 30814
12723, 30788, 2788, 2787, 30789, 30855, 2810, 30856, 30816
12724, 30789, 2787, 2786, 30790, 30856, 2809, 30857, 30818
12725, 30790, 2786, 2785, 30791, 30857, 2808, 30858, 30820
12726, 30791, 2785, 2784, 30792, 30858, 2807, 30859, 30822
12727, 30792, 2784, 2783, 30793, 30859, 2806, 30860, 30824
12728, 30793, 2783, 2782, 30794, 30860, 2805, 30861, 30826
12729, 30794, 2782, 2781, 30795, 30861, 2804, 30862, 30828
12730, 30795, 2781, 2780, 30796, 30862, 2803, 30863, 30830
12731, 30796, 2780, 2779, 30797, 30863, 2802, 30864, 30832
12732, 30797, 2779, 2778, 30798, 30864, 2801, 30865, 30834
12733, 30798, 2778, 2777, 30799, 30865, 2800, 30866, 30836
12734, 30799, 2777, 2776, 30800, 30866, 2799, 30867, 30838
12735, 30800, 2776, 2775, 30801, 30867, 2798, 30868, 30840
12736, 30801, 2775, 2774, 30802, 30868, 2797, 30869, 30842
12737, 30802, 2774, 2773, 30803, 30869, 2796, 30870, 30844
12738, 30803, 2773, 2772, 30804, 30870, 2795, 30871, 30846
12739, 30804, 2772, 2771, 30805, 30871, 2794, 30872, 30848
12740, 30805, 2771, 88, 3598, 30872, 2793, 3600, 30850
*ELEMENT, type=CPS8, ELSET=Surface282
12741, 9, 3598, 30873, 432, 3599, 30881, 30882, 441
12742, 432, 30873, 30874, 431, 30882, 30883, 30884, 440
12743, 431, 30874, 30875, 430, 30884, 30885, 30886, 439
12744, 430, 30875, 30876, 429, 30886, 30887, 30888, 438
12745, 429, 30876, 30877, 428, 30888, 30889, 30890, 437
12746, 428, 30877, 30878, 427, 30890, 30891, 30892, 436
12747, 427, 30878, 30879, 426, 30892, 30893, 30894, 435
12748, 426, 30879, 30880, 425, 30894, 30895, 30896, 434
12749, 425, 30880, 3592, 15, 30896, 30897, 3593, 433
12750, 3598, 88, 2823, 30873, 3600, 2832, 30898, 30881
12751, 30873, 2823, 2822, 30874, 30898, 2831, 30899, 30883
12752, 30874, 2822, 2821, 30875, 30899, 2830, 30900, 30885
12753, 30875, 2821, 2820, 30876, 30900, 2829, 30901, 30887
12754, 30876, 2820, 2819, 30877, 30901, 2828, 30902, 30889
12755, 30877, 2819, 2818, 30878, 30902, 2827, 30903, 30891
12756, 30878, 2818, 2817, 30879, 30903, 2826, 30904, 30893
12757, 30879, 2817, 2816, 30880, 30904, 2825, 30905, 30895
12758, 30880, 2816, 86, 3592, 30905, 2824, 3594, 30897
*ELEMENT, type=CPS8, ELSET=Surface283
12759, 3, 3601, 30906, 2968, 3602, 30928, 30929, 2990
12760, 2968, 30906, 30907, 2969, 30929, 30930, 30931, 2991
12761, 2969, 30907, 30908, 2970, 30931, 30932, 30933, 2992
12762, 2970, 30908, 30909, 2971, 30933, 30934, 30935, 2993
12763, 2971, 30909, 30910, 2972, 30935, 30936, 30937, 2994
12764, 2972, 30910, 30911, 2973, 30937, 30938, 30939, 2995
12765, 2973, 30911, 30912, 2974, 30939, 30940, 30941, 2996
12766, 2974, 30912, 30913, 2975, 30941, 30942, 30943, 2997
12767, 2975, 30913, 30914, 2976, 30943, 30944, 30945, 2998
12768, 2976, 30914, 30915, 2977, 30945, 30946, 30947, 2999
12769, 2977, 30915, 30916, 2978, 30947, 30948, 30949, 3000
12770, 2978, 30916, 30917, 2979, 30949, 30950, 30951, 3001
12771, 2979, 30917, 30918, 2980, 30951, 30952, 30953, 3002
12772, 2980, 30918, 30919, 2981, 30953, 30954, 30955, 3003
12773, 2981, 30919, 30920, 2982, 30955, 30956, 30957, 3004
12774, 2982, 30920, 30921, 2983, 30957, 30958, 30959, 3005
12775, 2983, 30921, 30922, 2984, 30959, 30960, 30961, 3006
12776, 2984, 30922, 30923, 2985, 30961, 30962, 30963, 3007
12777, 2985, 30923, 30924, 2986, 30963, 30964, 30965, 3008
12778, 2986, 30924, 30925, 2987, 30965, 30966, 30967, 3009
12779, 2987, 30925, 30926, 2988, 30967, 30968, 30969, 3010
12780, 2988, 30926, 30927, 2989, 30969, 30970, 30971, 3011
12781, 2989, 30927, 3604, 91, 30971, 30972, 3605, 3012
12782, 3601, 101, 3607, 30906, 3603, 3629, 30973, 30928
12783, 30906, 3607, 3608, 30907, 30973, 3630, 30974, 30930
12784, 30907, 3608, 3609, 30908, 30974, 3631, 30975, 30932
12785, 30908, 3609, 3610, 30909, 30975, 3632, 30976, 30934
12786, 30909, 3610, 3611, 30910, 30976, 3633, 30977, 30936
12787, 30910, 3611, 3612, 30911, 30977, 3634, 30978, 30938
12788, 30911, 3612, 3613, 30912, 30978, 3635, 30979, 30940
12789, 30912, 3613, 3614, 30913, 30979, 3636, 30980, 30942
12790, 30913, 3614, 3615, 30914, 30980, 3637, 30981, 30944
12791, 30914, 3615, 3616, 30915, 30981, 3638, 30982, 30946
12792, 30915, 3616, 3617, 30916, 30982, 3639, 30983, 30948
12793, 30916, 3617, 3618, 30917, 30983, 3640, 30984, 30950
12794, 30917, 3618, 3619, 30918, 30984, 3641, 30985, 30952
12795, 30918, 3619, 3620, 30919, 30985, 3642, 30986, 30954
12796, 30919, 3620, 3621, 30920, 30986, 3643, 30987, 30956
12797, 30920, 3621, 3622, 30921, 30987, 3644, 30988, 30958
12798, 30921, 3622, 3623, 30922, 30988, 3645, 30989, 30960
12799, 30922, 3623, 3624, 30923, 30989, 3646, 30990, 30962
12800, 30923, 3624, 3625, 30924, 30990, 3647, 30991, 30964
12801, 30924, 3625, 3626, 30925, 30991, 3648, 30992, 30966
12802, 30925, 3626, 3627, 30926, 30992, 3649, 30993, 30968
12803, 30926, 3627, 3628, 30927, 30993, 3650, 30994, 30970
12804, 30927, 3628, 102, 3604, 30994, 3651, 3606, 30972
*ELEMENT, type=CPS8, ELSET=Surface284
12805, 1, 2833, 30995, 3652, 2855, 31017, 31018, 3653
12806, 2833, 2834, 30996, 30995, 2856, 31019, 31020, 31017
12807, 2834, 2835, 30997, 30996, 2857, 31021, 31022, 31019
12808, 2835, 2836, 30998, 30997, 2858, 31023, 31024, 31021
12809, 2836, 2837, 30999, 30998, 2859, 31025, 31026, 31023
12810, 2837, 2838, 31000, 30999, 2860, 31027, 31028, 31025
12811, 2838, 2839, 31001, 31000, 2861, 31029, 31030, 31027
12812, 2839, 2840, 31002, 31001, 2862, 31031, 31032, 31029
12813, 2840, 2841, 31003, 31002, 2863, 31033, 31034, 31031
12814, 2841, 2842, 31004, 31003, 2864, 31035, 31036, 31033
12815, 2842, 2843, 31005, 31004, 2865, 31037, 31038, 31035
12816, 2843, 2844, 31006, 31005, 2866, 31039, 31040, 31037
12817, 2844, 2845, 31007, 31006, 2867, 31041, 31042, 31039
12818, 2845, 2846, 31008, 31007, 2868, 31043, 31044, 31041
12819, 2846, 2847, 31009, 31008, 2869, 31045, 31046, 31043
12820, 2847, 2848, 31010, 31009, 2870, 31047, 31048, 31045
12821, 2848, 2849, 31011, 31010, 2871, 31049, 31050, 31047
12822, 2849, 2850, 31012, 31011, 2872, 31051, 31052, 31049
12823, 2850, 2851, 31013, 31012, 2873, 31053, 31054, 31051
12824, 2851, 2852, 31014, 31013, 2874, 31055, 31056, 31053
12825, 2852, 2853, 31015, 31014, 2875, 31057, 31058, 31055
12826, 2853, 2854, 31016, 31015, 2876, 31059, 31060, 31057
12827, 2854, 89, 3655, 31016, 2877, 3656, 31061, 31059
12828, 3652, 30995, 3658, 103, 31018, 31062, 3680, 3654
12829, 30995, 30996, 3659, 3658, 31020, 31063, 3681, 31062
12830, 30996, 30997, 3660, 3659, 31022, 31064, 3682, 31063
12831, 30997, 30998, 3661, 3660, 31024, 31065, 3683, 31064
12832, 30998, 30999, 3662, 3661, 31026, 31066, 3684, 31065
12833, 30999, 31000, 3663, 3662, 31028, 31067, 3685, 31066
12834, 31000, 31001, 3664, 3663, 31030, 31068, 3686, 31067
12835, 31001, 31002, 3665, 3664, 31032, 31069, 3687, 31068
12836, 31002, 31003, 3666, 3665, 31034, 31070, 3688, 31069
12837, 31003, 31004, 3667, 3666, 31036, 31071, 3689, 31070
12838, 31004, 31005, 3668, 3667, 31038, 31072, 3690, 31071
12839, 31005, 31006, 3669, 3668, 31040, 31073, 3691, 31072
12840, 31006, 31007, 3670, 3669, 31042, 31074, 3692, 31073
12841, 31007, 31008, 3671, 3670, 31044, 31075, 3693, 31074
12842, 31008, 31009, 3672, 3671, 31046, 31076, 3694, 31075
12843, 31009, 31010, 3673, 3672, 31048, 31077, 3695, 31076
12844, 31010, 31011, 3674, 3673, 31050, 31078, 3696, 31077
12845, 31011, 31012, 3675, 3674, 31052, 31079, 3697, 31078
12846, 31012, 31013, 3676, 3675, 31054, 31080, 3698, 31079
12847, 31013, 31014, 3677, 3676, 31056, 31081, 3699, 31080
12848, 31014, 31015, 3678, 3677, 31058, 31082, 3700, 31081
12849, 31015, 31016, 3679, 3678, 31060, 31083, 3701, 31082
12850, 31016, 3655, 104, 3679, 31061, 3657, 3702, 31083
*ELEMENT, type=CPS8, ELSET=Surface285
12851, 3, 173, 31084, 3601, 182, 31092, 31093, 3602
12852, 173, 172, 31085, 31084, 181, 31094, 31095, 31092
12853, 172, 171, 31086, 31085, 180, 31096, 31097, 31094
12854, 171, 170, 31087, 31086, 179, 31098, 31099, 31096
12855, 170, 169, 31088, 31087, 178, 31100, 31101, 31098
12856, 169, 168, 31089, 31088, 177, 31102, 31103, 31100
12857, 168, 167, 31090, 31089, 176, 31104, 31105, 31102
12858, 167, 166, 31091, 31090, 175, 31106, 31107, 31104
12859, 166, 1, 3652, 31091, 174, 3653, 31108, 31106
12860, 3601, 31084, 3710, 101, 31093, 31109, 3719, 3603
12861, 31084, 31085, 3709, 3710, 31095, 31110, 3718, 31109
12862, 31085, 31086, 3708, 3709, 31097, 31111, 3717, 31110
12863, 31086, 31087, 3707, 3708, 31099, 31112, 3716, 31111
12864, 31087, 31088, 3706, 3707, 31101, 31113, 3715, 31112
12865, 31088, 31089, 3705, 3706, 31103, 31114, 3714, 31113
12866, 31089, 31090, 3704, 3705, 31105, 31115, 3713, 31114
12867, 31090, 31091, 3703, 3704, 31107, 31116, 3712, 31115
12868, 31091, 3652, 103, 3703, 31108, 3654, 3711, 31116
*ELEMENT, type=CPS8, ELSET=Surface286
12869, 91, 3604, 31117, 3020, 3605, 31125, 31126, 3029
12870, 3020, 31117, 31118, 3019, 31126, 31127, 31128, 3028
12871, 3019, 31118, 31119, 3018, 31128, 31129, 31130, 3027
12872, 3018, 31119, 31120, 3017, 31130, 31131, 31132, 3026
12873, 3017, 31120, 31121, 3016, 31132, 31133, 31134, 3025
12874, 3016, 31121, 31122, 3015, 31134, 31135, 31136, 3024
12875, 3015, 31122, 31123, 3014, 31136, 31137, 31138, 3023
12876, 3014, 31123, 31124, 3013, 31138, 31139, 31140, 3022
12877, 3013, 31124, 3655, 89, 31140, 31141, 3656, 3021
12878, 3604, 102, 3727, 31117, 3606, 3736, 31142, 31125
12879, 31117, 3727, 3726, 31118, 31142, 3735, 31143, 31127
12880, 31118, 3726, 3725, 31119, 31143, 3734, 31144, 31129
12881, 31119, 3725, 3724, 31120, 31144, 3733, 31145, 31131
12882, 31120, 3724, 3723, 31121, 31145, 3732, 31146, 31133
12883, 31121, 3723, 3722, 31122, 31146, 3731, 31147, 31135
12884, 31122, 3722, 3721, 31123, 31147, 3730, 31148, 31137
12885, 31123, 3721, 3720, 31124, 31148, 3729, 31149, 31139
12886, 31124, 3720, 104, 3655, 31149, 3728, 3657, 31141
*ELEMENT, type=CPS8, ELSET=Surface287
12887, 101, 3710, 31150, 3607, 3719, 31326, 31327, 3629
12888, 3710, 3709, 31151, 31150, 3718, 31328, 31329, 31326
12889, 3709, 3708, 31152, 31151, 3717, 31330, 31331, 31328
12890, 3708, 3707, 31153, 31152, 3716, 31332, 31333, 31330
12891, 3707, 3706, 31154, 31153, 3715, 31334, 31335, 31332
12892, 3706, 3705, 31155, 31154, 3714, 31336, 31337, 31334
12893, 3705, 3704, 31156, 31155, 3713, 31338, 31339, 31336
12894, 3704, 3703, 31157, 31156, 3712, 31340, 31341, 31338
12895, 3703, 103, 3658, 31157, 3711, 3680, 31342, 31340
12896, 3607, 31150, 31158, 3608, 31327, 31343, 31344, 3630
12897, 31150, 31151, 31159, 31158, 31329, 31345, 31346, 31343
12898, 31151, 31152, 31160, 31159, 31331, 31347, 31348, 31345
12899, 31152, 31153, 31161, 31160, 31333, 31349, 31350, 31347
12900, 31153, 31154, 31162, 31161, 31335, 31351, 31352, 31349
12901, 31154, 31155, 31163, 31162, 31337, 31353, 31354, 31351
12902, 31155, 31156, 31164, 31163, 31339, 31355, 31356, 31353
12903, 31156, 31157, 31165, 31164, 31341, 31357, 31358, 31355
12904, 31157, 3658, 3659, 31165, 31342, 3681, 31359, 31357
12905, 3608, 31158, 31166, 3609, 31344, 31360, 31361, 3631
12906, 31158, 31159, 31167, 31166, 31346, 31362, 31363, 31360
12907, 31159, 31160, 31168, 31167, 31348, 31364, 31365, 31362
12908, 31160, 31161, 31169, 31168, 31350, 31366, 31367, 31364
12909, 31161, 31162, 31170, 31169, 31352, 31368, 31369, 31366
12910, 31162, 31163, 31171, 31170, 31354, 31370, 31371, 31368
12911, 31163, 31164, 31172, 31171, 31356, 31372, 31373, 31370
12912, 31164, 31165, 31173, 31172, 31358, 31374, 31375, 31372
12913, 31165, 3659, 3660, 31173, 31359, 3682, 31376, 31374
12914, 3609, 31166, 31174, 3610, 31361, 31377, 31378, 3632
12915, 31166, 31167, 31175, 31174, 31363, 31379, 31380, 31377
12916, 31167, 31168, 31176, 31175, 31365, 31381, 31382, 31379
12917, 31168, 31169, 31177, 31176, 31367, 31383, 31384, 31381
12918, 31169, 31170, 31178, 31177, 31369, 31385, 31386, 31383
12919, 31170, 31171, 31179, 31178, 31371, 31387, 31388, 31385
12920, 31171, 31172, 31180, 31179, 31373, 31389, 31390, 31387
12921, 31172, 31173, 31181, 31180, 31375, 31391, 31392, 31389
12922, 31173, 3660, 3661, 31181, 31376, 3683, 31393, 31391
12923, 3610, 31174, 31182, 3611, 31378, 31394, 31395, 3633
12924, 31174, 31175, 31183, 31182, 31380, 31396, 31397, 31394
12925, 31175, 31176, 31184, 31183, 31382, 31398, 31399, 31396
12926, 31176, 31177, 31185, 31184, 31384, 31400, 31401, 31398
12927, 31177, 31178, 31186, 31185, 31386, 31402, 31403, 31400
12928, 31178, 31179, 31187, 31186, 31388, 31404, 31405, 31402
12929, 31179, 31180, 31188, 31187, 31390, 31406, 31407, 31404
12930, 31180, 31181, 31189, 31188, 31392, 31408, 31409, 31406
12931, 31181, 3661, 3662, 31189, 31393, 3684, 31410, 31408
12932, 3611, 31182, 31190, 3612, 31395, 31411, 31412, 3634
12933, 31182, 31183, 31191, 31190, 31397, 31413, 31414, 31411
12934, 31183, 31184, 31192, 31191, 31399, 31415, 31416, 31413
12935, 31184, 31185, 31193, 31192, 31401, 31417, 31418, 31415
12936, 31185, 31186, 31194, 31193, 31403, 31419, 31420, 31417
12937, 31186, 31187, 31195, 31194, 31405, 31421, 31422, 31419
12938, 31187, 31188, 31196, 31195, 31407, 31423, 31424, 31421
12939, 31188, 31189, 31197, 31196, 31409, 31425, 31426, 31423
12940, 31189, 3662, 3663, 31197, 31410, 3685, 31427, 31425
12941, 3612, 31190, 31198, 3613, 31412, 31428, 31429, 3635
12942, 31190, 31191, 31199, 31198, 31414, 31430, 31431, 31428
12943, 31191, 31192, 31200, 31199, 31416, 31432, 31433, 31430
12944, 31192, 31193, 31201, 31200, 31418, 31434, 31435, 31432
12945, 31193, 31194, 31202, 31201, 31420, 31436, 31437, 31434
12946, 31194, 31195, 31203, 31202, 31422, 31438, 31439, 31436
12947, 31195, 31196, 31204, 31203, 31424, 31440, 31441, 31438
12948, 31196, 31197, 31205, 31204, 31426, 31442, 31443, 31440
12949, 31197, 3663, 3664, 31205, 31427, 3686, 31444, 31442
12950, 3613, 31198, 31206, 3614, 31429, 31445, 31446, 3636
12951, 31198, 31199, 31207, 31206, 31431, 31447, 31448, 31445
12952, 31199, 31200, 31208, 31207, 31433, 31449, 31450, 31447
12953, 31200, 31201, 31209, 31208, 31435, 31451, 31452, 31449
12954, 31201, 31202, 31210, 31209, 31437, 31453, 31454, 31451
12955, 31202, 31203, 31211, 31210, 31439, 31455, 31456, 31453
12956, 31203, 31204, 31212, 31211, 31441, 31457, 31458, 31455
12957, 31204, 31205, 31213, 31212, 31443, 31459, 31460, 31457
12958, 31205, 3664, 3665, 31213, 31444, 3687, 31461, 31459
12959, 3614, 31206, 31214, 3615, 31446, 31462, 31463, 3637
12960, 31206, 31207, 31215, 31214, 31448, 31464, 31465, 31462
12961, 31207, 31208, 31216, 31215, 31450, 31466, 31467, 31464
12962, 31208, 31209, 31217, 31216, 31452, 31468, 31469, 31466
12963, 31209, 31210, 31218, 31217, 31454, 31470, 31471, 31468
12964, 31210, 31211, 31219, 31218, 31456, 31472, 31473, 31470
12965, 31211, 31212, 31220, 31219, 31458, 31474, 31475, 31472
12966, 31212, 31213, 31221, 31220, 31460, 31476, 31477, 31474
12967, 31213, 3665, 3666, 31221, 31461, 3688, 31478, 31476
12968, 3615, 31214, 31222, 3616, 31463, 31479, 31480, 3638
12969, 31214, 31215, 31223, 31222, 31465, 31481, 31482, 31479
12970, 31215, 31216, 31224, 31223, 31467, 31483, 31484, 31481
12971, 31216, 31217, 31225, 31224, 31469, 31485, 31486, 31483
12972, 31217, 31218, 31226, 31225, 31471, 31487, 31488, 31485
12973, 31218, 31219, 31227, 31226, 31473, 31489, 31490, 31487
12974, 31219, 31220, 31228, 31227, 31475, 31491, 31492, 31489
12975, 31220, 31221, 31229, 31228, 31477, 31493, 31494, 31491
12976, 31221, 3666, 3667, 31229, 31478, 3689, 31495, 31493
12977, 3616, 31222, 31230, 3617, 31480, 31496, 31497, 3639
12978, 31222, 31223, 31231, 31230, 31482, 31498, 31499, 31496
12979, 31223, 31224, 31232, 31231, 31484, 31500, 31501, 31498
12980, 31224, 31225, 31233, 31232, 31486, 31502, 31503, 31500
12981, 31225, 31226, 31234, 31233, 31488, 31504, 31505, 31502
12982, 31226, 31227, 31235, 31234, 31490, 31506, 31507, 31504
12983, 31227, 31228, 31236, 31235, 31492, 31508, 31509, 31506
12984, 31228, 31229, 31237, 31236, 31494, 31510, 31511, 31508
12985, 31229, 3667, 3668, 31237, 31495, 3690, 31512, 31510
12986, 3617, 31230, 31238, 3618, 31497, 31513, 31514, 3640
12987, 31230, 31231, 31239, 31238, 31499, 31515, 31516, 31513
12988, 31231, 31232, 31240, 31239, 31501, 31517, 31518, 31515
12989, 31232, 31233, 31241, 31240, 31503, 31519, 31520, 31517
12990, 31233, 31234, 31242, 31241, 31505, 31521, 31522, 31519
12991, 31234, 31235, 31243, 31242, 31507, 31523, 31524, 31521
12992, 31235, 31236, 31244, 31243, 31509, 31525, 31526, 31523
12993, 31236, 31237, 31245, 31244, 31511, 31527, 31528, 31525
12994, 31237, 3668, 3669, 31245, 31512, 3691, 31529, 31527
12995, 3618, 31238, 31246, 3619, 31514, 31530, 31531, 3641
12996, 31238, 31239, 31247, 31246, 31516, 31532, 31533, 31530
12997, 31239, 31240, 31248, 31247, 31518, 31534, 31535, 31532
12998, 31240, 31241, 31249, 31248, 31520, 31536, 31537, 31534
12999, 31241, 31242, 31250, 31249, 31522, 31538, 31539, 31536
13000, 31242, 31243, 31251, 31250, 31524, 31540, 31541, 31538
13001, 31243, 31244, 31252, 31251, 31526, 31542, 31543, 31540
13002, 31244, 31245, 31253, 31252, 31528, 31544, 31545, 31542
13003, 31245, 3669, 3670, 31253, 31529, 3692, 31546, 31544
13004, 3619, 31246, 31254, 3620, 31531, 31547, 31548, 3642
13005, 31246, 31247, 31255, 31254, 31533, 31549, 31550, 31547
13006, 31247, 31248, 31256, 31255, 31535, 31551, 31552, 31549
13007, 31248, 31249, 31257, 31256, 31537, 31553, 31554, 31551
13008, 31249, 31250, 31258, 31257, 31539, 31555, 31556, 31553
13009, 31250, 31251, 31259, 31258, 31541, 31557, 31558, 31555
13010, 31251, 31252, 31260, 31259, 31543, 31559, 31560, 31557
13011, 31252, 31253, 31261, 31260, 31545, 31561, 31562, 31559
13012, 31253, 3670, 3671, 31261, 31546, 3693, 31563, 31561
13013, 3620, 31254, 31262, 3621, 31548, 31564, 31565, 3643
13014, 31254, 31255, 31263, 31262, 31550, 31566, 31567, 31564
13015, 31255, 31256, 31264, 31263, 31552, 31568, 31569, 31566
13016, 31256, 31257, 31265, 31264, 31554, 31570, 31571, 31568
13017, 31257, 31258, 31266, 31265, 31556, 31572, 31573, 31570
13018, 31258, 31259, 31267, 31266, 31558, 31574, 31575, 31572
13019, 31259, 31260, 31268, 31267, 31560, 31576, 31577, 31574
13020, 31260, 31261, 31269, 31268, 31562, 31578, 31579, 31576
13021, 31261, 3671, 3672, 31269, 31563, 3694, 31580, 31578
13022, 3621, 31262, 31270, 3622, 31565, 31581, 31582, 3644
13023, 31262, 31263, 31271, 31270, 31567, 31583, 31584, 31581
13024, 31263, 31264, 31272, 31271, 31569, 31585, 31586, 31583
13025, 31264, 31265, 31273, 31272, 31571, 31587, 31588, 31585
13026, 31265, 31266, 31274, 31273, 31573, 31589, 31590, 31587
13027, 31266, 31267, 31275, 31274, 31575, 31591, 31592, 31589
13028, 31267, 31268, 31276, 31275, 31577, 31593, 31594, 31591
13029, 31268, 31269, 31277, 31276, 31579, 31595, 31596, 31593
13030, 31269, 3672, 3673, 31277, 31580, 3695, 31597, 31595
13031, 3622, 31270, 31278, 3623, 31582, 31598, 31599, 3645
13032, 31270, 31271, 31279, 31278, 31584, 31600, 31601, 31598
13033, 31271, 31272, 31280, 31279, 31586, 31602, 31603, 31600
13034, 31272, 31273, 31281, 31280, 31588, 31604, 31605, 31602
13035, 31273, 31274, 31282, 31281, 31590, 31606, 31607, 31604
13036, 31274, 31275, 31283, 31282, 31592, 31608, 31609, 31606
13037, 31275, 31276, 31284, 31283, 31594, 31610, 31611, 31608
13038, 31276, 31277, 31285, 31284, 31596, 31612, 31613, 31610
13039, 31277, 3673, 3674, 31285, 31597, 3696, 31614, 31612
13040, 3623, 31278, 31286, 3624, 31599, 31615, 31616, 3646
13041, 31278, 31279, 31287, 31286, 31601, 31617, 31618, 31615
13042, 31279, 31280, 31288, 31287, 31603, 31619, 31620, 31617
13043, 31280, 31281, 31289, 31288, 31605, 31621, 31622, 31619
13044, 31281, 31282, 31290, 31289, 31607, 31623, 31624, 31621
13045, 31282, 31283, 31291, 31290, 31609, 31625, 31626, 31623
13046, 31283, 31284, 31292, 31291, 31611, 31627, 31628, 31625
13047, 31284, 31285, 31293, 31292, 31613, 31629, 31630, 31627
13048, 31285, 3674, 3675, 31293, 31614, 3697, 31631, 31629
13049, 3624, 31286, 31294, 3625, 31616, 31632, 31633, 3647
13050, 31286, 31287, 31295, 31294, 31618, 31634, 31635, 31632
13051, 31287, 31288, 31296, 31295, 31620, 31636, 31637, 31634
13052, 31288, 31289, 31297, 31296, 31622, 31638, 31639, 31636
13053, 31289, 31290, 31298, 31297, 31624, 31640, 31641, 31638
13054, 31290, 31291, 31299, 31298, 31626, 31642, 31643, 31640
13055, 31291, 31292, 31300, 31299, 31628, 31644, 31645, 31642
13056, 31292, 31293, 31301, 31300, 31630, 31646, 31647, 31644
13057, 31293, 3675, 3676, 31301, 31631, 3698, 31648, 31646
13058, 3625, 31294, 31302, 3626, 31633, 31649, 31650, 3648
13059, 31294, 31295, 31303, 31302, 31635, 31651, 31652, 31649
13060, 31295, 31296, 31304, 31303, 31637, 31653, 31654, 31651
13061, 31296, 31297, 31305, 31304, 31639, 31655, 31656, 31653
13062, 31297, 31298, 31306, 31305, 31641, 31657, 31658, 31655
13063, 31298, 31299, 31307, 31306, 31643, 31659, 31660, 31657
13064, 31299, 31300, 31308, 31307, 31645, 31661, 31662, 31659
13065, 31300, 31301, 31309, 31308, 31647, 31663, 31664, 31661
13066, 31301, 3676, 3677, 31309, 31648, 3699, 31665, 31663
13067, 3626, 31302, 31310, 3627, 31650, 31666, 31667, 3649
13068, 31302, 31303, 31311, 31310, 31652, 31668, 31669, 31666
13069, 31303, 31304, 31312, 31311, 31654, 31670, 31671, 31668
13070, 31304, 31305, 31313, 31312, 31656, 31672, 31673, 31670
13071, 31305, 31306, 31314, 31313, 31658, 31674, 31675, 31672
13072, 31306, 31307, 31315, 31314, 31660, 31676, 31677, 31674
13073, 31307, 31308, 31316, 31315, 31662, 31678, 31679, 31676
13074, 31308, 31309, 31317, 31316, 31664, 31680, 31681, 31678
13075, 31309, 3677, 3678, 31317, 31665, 3700, 31682, 31680
13076, 3627, 31310, 31318, 3628, 31667, 31683, 31684, 3650
13077, 31310, 31311, 31319, 31318, 31669, 31685, 31686, 31683
13078, 31311, 31312, 31320, 31319, 31671, 31687, 31688, 31685
13079, 31312, 31313, 31321, 31320, 31673, 31689, 31690, 31687
13080, 31313, 31314, 31322, 31321, 31675, 31691, 31692, 31689
13081, 31314, 31315, 31323, 31322, 31677, 31693, 31694, 31691
13082, 31315, 31316, 31324, 31323, 31679, 31695, 31696, 31693
13083, 31316, 31317, 31325, 31324, 31681, 31697, 31698, 31695
13084, 31317, 3678, 3679, 31325, 31682, 3701, 31699, 31697
13085, 3628, 31318, 3727, 102, 31684, 31700, 3736, 3651
13086, 31318, 31319, 3726, 3727, 31686, 31701, 3735, 31700
13087, 31319, 31320, 3725, 3726, 31688, 31702, 3734, 31701
13088, 31320, 31321, 3724, 3725, 31690, 31703, 3733, 31702
13089, 31321, 31322, 3723, 3724, 31692, 31704, 3732, 31703
13090, 31322, 31323, 3722, 3723, 31694, 31705, 3731, 31704
13091, 31323, 31324, 3721, 3722, 31696, 31706, 3730, 31705
13092, 31324, 31325, 3720, 3721, 31698, 31707, 3729, 31706
13093, 31325, 3679, 104, 3720, 31699, 3702, 3728, 31707
*ELEMENT, type=CPS8, ELSET=Surface288
13094, 93, 3737, 31708, 3137, 3738, 31730, 31731, 3159
13095, 3137, 31708, 31709, 3138, 31731, 31732, 31733, 3160
13096, 3138, 31709, 31710, 3139, 31733, 31734, 31735, 3161
13097, 3139, 31710, 31711, 3140, 31735, 31736, 31737, 3162
13098, 3140, 31711, 31712, 3141, 31737, 31738, 31739, 3163
13099, 3141, 31712, 31713, 3142, 31739, 31740, 31741, 3164
13100, 3142, 31713, 31714, 3143, 31741, 31742, 31743, 3165
13101, 3143, 31714, 31715, 3144, 31743, 31744, 31745, 3166
13102, 3144, 31715, 31716, 3145, 31745, 31746, 31747, 3167
13103, 3145, 31716, 31717, 3146, 31747, 31748, 31749, 3168
13104, 3146, 31717, 31718, 3147, 31749, 31750, 31751, 3169
13105, 3147, 31718, 31719, 3148, 31751, 31752, 31753, 3170
13106, 3148, 31719, 31720, 3149, 31753, 31754, 31755, 3171
13107, 3149, 31720, 31721, 3150, 31755, 31756, 31757, 3172
13108, 3150, 31721, 31722, 3151, 31757, 31758, 31759, 3173
13109, 3151, 31722, 31723, 3152, 31759, 31760, 31761, 3174
13110, 3152, 31723, 31724, 3153, 31761, 31762, 31763, 3175
13111, 3153, 31724, 31725, 3154, 31763, 31764, 31765, 3176
13112, 3154, 31725, 31726, 3155, 31765, 31766, 31767, 3177
13113, 3155, 31726, 31727, 3156, 31767, 31768, 31769, 3178
13114, 3156, 31727, 31728, 3157, 31769, 31770, 31771, 3179
13115, 3157, 31728, 31729, 3158, 31771, 31772, 31773, 3180
13116, 3158, 31729, 3740, 5, 31773, 31774, 3741, 3181
13117, 3737, 105, 3743, 31708, 3739, 3765, 31775, 31730
13118, 31708, 3743, 3744, 31709, 31775, 3766, 31776, 31732
13119, 31709, 3744, 3745, 31710, 31776, 3767, 31777, 31734
13120, 31710, 3745, 3746, 31711, 31777, 3768, 31778, 31736
13121, 31711, 3746, 3747, 31712, 31778, 3769, 31779, 31738
13122, 31712, 3747, 3748, 31713, 31779, 3770, 31780, 31740
13123, 31713, 3748, 3749, 31714, 31780, 3771, 31781, 31742
13124, 31714, 3749, 3750, 31715, 31781, 3772, 31782, 31744
13125, 31715, 3750, 3751, 31716, 31782, 3773, 31783, 31746
13126, 31716, 3751, 3752, 31717, 31783, 3774, 31784, 31748
13127, 31717, 3752, 3753, 31718, 31784, 3775, 31785, 31750
13128, 31718, 3753, 3754, 31719, 31785, 3776, 31786, 31752
13129, 31719, 3754, 3755, 31720, 31786, 3777, 31787, 31754
13130, 31720, 3755, 3756, 31721, 31787, 3778, 31788, 31756
13131, 31721, 3756, 3757, 31722, 31788, 3779, 31789, 31758
13132, 31722, 3757, 3758, 31723, 31789, 3780, 31790, 31760
13133, 31723, 3758, 3759, 31724, 31790, 3781, 31791, 31762
13134, 31724, 3759, 3760, 31725, 31791, 3782, 31792, 31764
13135, 31725, 3760, 3761, 31726, 31792, 3783, 31793, 31766
13136, 31726, 3761, 3762, 31727, 31793, 3784, 31794, 31768
13137, 31727, 3762, 3763, 31728, 31794, 3785, 31795, 31770
13138, 31728, 3763, 3764, 31729, 31795, 3786, 31796, 31772
13139, 31729, 3764, 106, 3740, 31796, 3787, 3742, 31774
*ELEMENT, type=CPS8, ELSET=Surface289
13140, 95, 3272, 31797, 3788, 3294, 31819, 31820, 3789
13141, 3272, 3273, 31798, 31797, 3295, 31821, 31822, 31819
13142, 3273, 3274, 31799, 31798, 3296, 31823, 31824, 31821
13143, 3274, 3275, 31800, 31799, 3297, 31825, 31826, 31823
13144, 3275, 3276, 31801, 31800, 3298, 31827, 31828, 31825
13145, 3276, 3277, 31802, 31801, 3299, 31829, 31830, 31827
13146, 3277, 3278, 31803, 31802, 3300, 31831, 31832, 31829
13147, 3278, 3279, 31804, 31803, 3301, 31833, 31834, 31831
13148, 3279, 3280, 31805, 31804, 3302, 31835, 31836, 31833
13149, 3280, 3281, 31806, 31805, 3303, 31837, 31838, 31835
13150, 3281, 3282, 31807, 31806, 3304, 31839, 31840, 31837
13151, 3282, 3283, 31808, 31807, 3305, 31841, 31842, 31839
13152, 3283, 3284, 31809, 31808, 3306, 31843, 31844, 31841
13153, 3284, 3285, 31810, 31809, 3307, 31845, 31846, 31843
13154, 3285, 3286, 31811, 31810, 3308, 31847, 31848, 31845
13155, 3286, 3287, 31812, 31811, 3309, 31849, 31850, 31847
13156, 3287, 3288, 31813, 31812, 3310, 31851, 31852, 31849
13157, 3288, 3289, 31814, 31813, 3311, 31853, 31854, 31851
13158, 3289, 3290, 31815, 31814, 3312, 31855, 31856, 31853
13159, 3290, 3291, 31816, 31815, 3313, 31857, 31858, 31855
13160, 3291, 3292, 31817, 31816, 3314, 31859, 31860, 31857
13161, 3292, 3293, 31818, 31817, 3315, 31861, 31862, 31859
13162, 3293, 7, 3791, 31818, 3316, 3792, 31863, 31861
13163, 3788, 31797, 3794, 107, 31820, 31864, 3816, 3790
13164, 31797, 31798, 3795, 3794, 31822, 31865, 3817, 31864
13165, 31798, 31799, 3796, 3795, 31824, 31866, 3818, 31865
13166, 31799, 31800, 3797, 3796, 31826, 31867, 3819, 31866
13167, 31800, 31801, 3798, 3797, 31828, 31868, 3820, 31867
13168, 31801, 31802, 3799, 3798, 31830, 31869, 3821, 31868
13169, 31802, 31803, 3800, 3799, 31832, 31870, 3822, 31869
13170, 31803, 31804, 3801, 3800, 31834, 31871, 3823, 31870
13171, 31804, 31805, 3802, 3801, 31836, 31872, 3824, 31871
13172, 31805, 31806, 3803, 3802, 31838, 31873, 3825, 31872
13173, 31806, 31807, 3804, 3803, 31840, 31874, 3826, 31873
13174, 31807, 31808, 3805, 3804, 31842, 31875, 3827, 31874
13175, 31808, 31809, 3806, 3805, 31844, 31876, 3828, 31875
13176, 31809, 31810, 3807, 3806, 31846, 31877, 3829, 31876
13177, 31810, 31811, 3808, 3807, 31848, 31878, 3830, 31877
13178, 31811, 31812, 3809, 3808, 31850, 31879, 3831, 31878
13179, 31812, 31813, 3810, 3809, 31852, 31880, 3832, 31879
13180, 31813, 31814, 3811, 3810, 31854, 31881, 3833, 31880
13181, 31814, 31815, 3812, 3811, 31856, 31882, 3834, 31881
13182, 31815, 31816, 3813, 3812, 31858, 31883, 3835, 31882
13183, 31816, 31817, 3814, 3813, 31860, 31884, 3836, 31883
13184, 31817, 31818, 3815, 3814, 31862, 31885, 3837, 31884
13185, 31818, 3791, 108, 3815, 31863, 3793, 3838, 31885
*ELEMENT, type=CPS8, ELSET=Surface290
13186, 93, 3414, 31886, 3737, 3423, 31894, 31895, 3738
13187, 3414, 3413, 31887, 31886, 3422, 31896, 31897, 31894
13188, 3413, 3412, 31888, 31887, 3421, 31898, 31899, 31896
13189, 3412, 3411, 31889, 31888, 3420, 31900, 31901, 31898
13190, 3411, 3410, 31890, 31889, 3419, 31902, 31903, 31900
13191, 3410, 3409, 31891, 31890, 3418, 31904, 31905, 31902
13192, 3409, 3408, 31892, 31891, 3417, 31906, 31907, 31904
13193, 3408, 3407, 31893, 31892, 3416, 31908, 31909, 31906
13194, 3407, 95, 3788, 31893, 3415, 3789, 31910, 31908
13195, 3737, 31886, 3846, 105, 31895, 31911, 3855, 3739
13196, 31886, 31887, 3845, 3846, 31897, 31912, 3854, 31911
13197, 31887, 31888, 3844, 3845, 31899, 31913, 3853, 31912
13198, 31888, 31889, 3843, 3844, 31901, 31914, 3852, 31913
13199, 31889, 31890, 3842, 3843, 31903, 31915, 3851, 31914
13200, 31890, 31891, 3841, 3842, 31905, 31916, 3850, 31915
13201, 31891, 31892, 3840, 3841, 31907, 31917, 3849, 31916
13202, 31892, 31893, 3839, 3840, 31909, 31918, 3848, 31917
13203, 31893, 3788, 107, 3839, 31910, 3790, 3847, 31918
*ELEMENT, type=CPS8, ELSET=Surface291
13204, 5, 3740, 31919, 342, 3741, 31927, 31928, 351
13205, 342, 31919, 31920, 341, 31928, 31929, 31930, 350
13206, 341, 31920, 31921, 340, 31930, 31931, 31932, 349
13207, 340, 31921, 31922, 339, 31932, 31933, 31934, 348
13208, 339, 31922, 31923, 338, 31934, 31935, 31936, 347
13209, 338, 31923, 31924, 337, 31936, 31937, 31938, 346
13210, 337, 31924, 31925, 336, 31938, 31939, 31940, 345
13211, 336, 31925, 31926, 335, 31940, 31941, 31942, 344
13212, 335, 31926, 3791, 7, 31942, 31943, 3792, 343
13213, 3740, 106, 3863, 31919, 3742, 3872, 31944, 31927
13214, 31919, 3863, 3862, 31920, 31944, 3871, 31945, 31929
13215, 31920, 3862, 3861, 31921, 31945, 3870, 31946, 31931
13216, 31921, 3861, 3860, 31922, 31946, 3869, 31947, 31933
13217, 31922, 3860, 3859, 31923, 31947, 3868, 31948, 31935
13218, 31923, 3859, 3858, 31924, 31948, 3867, 31949, 31937
13219, 31924, 3858, 3857, 31925, 31949, 3866, 31950, 31939
13220, 31925, 3857, 3856, 31926, 31950, 3865, 31951, 31941
13221, 31926, 3856, 108, 3791, 31951, 3864, 3793, 31943
*ELEMENT, type=CPS8, ELSET=Surface292
13222, 105, 3846, 31952, 3743, 3855, 32128, 32129, 3765
13223, 3846, 3845, 31953, 31952, 3854, 32130, 32131, 32128
13224, 3845, 3844, 31954, 31953, 3853, 32132, 32133, 32130
13225, 3844, 3843, 31955, 31954, 3852, 32134, 32135, 32132
13226, 3843, 3842, 31956, 31955, 3851, 32136, 32137, 32134
13227, 3842, 3841, 31957, 31956, 3850, 32138, 32139, 32136
13228, 3841, 3840, 31958, 31957, 3849, 32140, 32141, 32138
13229, 3840, 3839, 31959, 31958, 3848, 32142, 32143, 32140
13230, 3839, 107, 3794, 31959, 3847, 3816, 32144, 32142
13231, 3743, 31952, 31960, 3744, 32129, 32145, 32146, 3766
13232, 31952, 31953, 31961, 31960, 32131, 32147, 32148, 32145
13233, 31953, 31954, 31962, 31961, 32133, 32149, 32150, 32147
13234, 31954, 31955, 31963, 31962, 32135, 32151, 32152, 32149
13235, 31955, 31956, 31964, 31963, 32137, 32153, 32154, 32151
13236, 31956, 31957, 31965, 31964, 32139, 32155, 32156, 32153
13237, 31957, 31958, 31966, 31965, 32141, 32157, 32158, 32155
13238, 31958, 31959, 31967, 31966, 32143, 32159, 32160, 32157
13239, 31959, 3794, 3795, 31967, 32144, 3817, 32161, 32159
13240, 3744, 31960, 31968, 3745, 32146, 32162, 32163, 3767
13241, 31960, 31961, 31969, 31968, 32148, 32164, 32165, 32162
13242, 31961, 31962, 31970, 31969, 32150, 32166, 32167, 32164
13243, 31962, 31963, 31971, 31970, 32152, 32168, 32169, 32166
13244, 31963, 31964, 31972, 31971, 32154, 32170, 32171, 32168
13245, 31964, 31965, 31973, 31972, 32156, 32172, 32173, 32170
13246, 31965, 31966, 31974, 31973, 32158, 32174, 32175, 32172
13247, 31966, 31967, 31975, 31974, 32160, 32176, 32177, 32174
13248, 31967, 3795, 3796, 31975, 32161, 3818, 32178, 32176
13249, 3745, 31968, 31976, 3746, 32163, 32179, 32180, 3768
13250, 31968, 31969, 31977, 31976, 32165, 32181, 32182, 32179
13251, 31969, 31970, 31978, 31977, 32167, 32183, 32184, 32181
13252, 31970, 31971, 31979, 31978, 32169, 32185, 32186, 32183
13253, 31971, 31972, 31980, 31979, 32171, 32187, 32188, 32185
13254, 31972, 31973, 31981, 31980, 32173, 32189, 32190, 32187
13255, 31973, 31974, 31982, 31981, 32175, 32191, 32192, 32189
13256, 31974, 31975, 31983, 31982, 32177, 32193, 32194, 32191
13257, 31975, 3796, 3797, 31983, 32178, 3819, 32195, 32193
13258, 3746, 31976, 31984, 3747, 32180, 32196, 32197, 3769
13259, 31976, 31977, 31985, 31984, 32182, 32198, 32199, 32196
13260, 31977, 31978, 31986, 31985, 32184, 32200, 32201, 32198
13261, 31978, 31979, 31987, 31986, 32186, 32202, 32203, 32200
13262, 31979, 31980, 31988, 31987, 32188, 32204, 32205, 32202
13263, 31980, 31981, 31989, 31988, 32190, 32206, 32207, 32204
13264, 31981, 31982, 31990, 31989, 32192, 32208, 32209, 32206
13265, 31982, 31983, 31991, 31990, 32194, 32210, 32211, 32208
13266, 31983, 3797, 3798, 31991, 32195, 3820, 32212, 32210
13267, 3747, 31984, 31992, 3748, 32197, 32213, 32214, 3770
13268, 31984, 31985, 31993, 31992, 32199, 32215, 32216, 32213
13269, 31985, 31986, 31994, 31993, 32201, 32217, 32218, 32215
13270, 31986, 31987, 31995, 31994, 32203, 32219, 32220, 32217
13271, 31987, 31988, 31996, 31995, 32205, 32221, 32222, 32219
13272, 31988, 31989, 31997, 31996, 32207, 32223, 32224, 32221
13273, 31989, 31990, 31998, 31997, 32209, 32225, 32226, 32223
13274, 31990, 31991, 31999, 31998, 32211, 32227, 32228, 32225
13275, 31991, 3798, 3799, 31999, 32212, 3821, 32229, 32227
13276, 3748, 31992, 32000, 3749, 32214, 32230, 32231, 3771
13277, 31992, 31993, 32001, 32000, 32216, 32232, 32233, 32230
13278, 31993, 31994, 32002, 32001, 32218, 32234, 32235, 32232
13279, 31994, 31995, 32003, 32002, 32220, 32236, 32237, 32234
13280, 31995, 31996, 32004, 32003, 32222, 32238, 32239, 32236
13281, 31996, 31997, 32005, 32004, 32224, 32240, 32241, 32238
13282, 31997, 31998, 32006, 32005, 32226, 32242, 32243, 32240
13283, 31998, 31999, 32007, 32006, 32228, 32244, 32245, 32242
13284, 31999, 3799, 3800, 32007, 32229, 3822, 32246, 32244
13285, 3749, 32000, 32008, 3750, 32231, 32247, 32248, 3772
13286, 32000, 32001, 32009, 32008, 32233, 32249, 32250, 32247
13287, 32001, 32002, 32010, 32009, 32235, 32251, 32252, 32249
13288, 32002, 32003, 32011, 32010, 32237, 32253, 32254, 32251
13289, 32003, 32004, 32012, 32011, 32239, 32255, 32256, 32253
13290, 32004, 32005, 32013, 32012, 32241, 32257, 32258, 32255
13291, 32005, 32006, 32014, 32013, 32243, 32259, 32260, 32257
13292, 32006, 32007, 32015, 32014, 32245, 32261, 32262, 32259
13293, 32007, 3800, 3801, 32015, 32246, 3823, 32263, 32261
13294, 3750, 32008, 32016, 3751, 32248, 32264, 32265, 3773
13295, 32008, 32009, 32017, 32016, 32250, 32266, 32267, 32264
13296, 32009, 32010, 32018, 32017, 32252, 32268, 32269, 32266
13297, 32010, 32011, 32019, 32018, 32254, 32270, 32271, 32268
13298, 32011, 32012, 32020, 32019, 32256, 32272, 32273, 32270
13299, 32012, 32013, 32021, 32020, 32258, 32274, 32275, 32272
13300, 32013, 32014, 32022, 32021, 32260, 32276, 32277, 32274
13301, 32014, 32015, 32023, 32022, 32262, 32278, 32279, 32276
13302, 32015, 3801, 3802, 32023, 32263, 3824, 32280, 32278
13303, 3751, 32016, 32024, 3752, 32265, 32281, 32282, 3774
13304, 32016, 32017, 32025, 32024, 32267, 32283, 32284, 32281
13305, 32017, 32018, 32026, 32025, 32269, 32285, 32286, 32283
13306, 32018, 32019, 32027, 32026, 32271, 32287, 32288, 32285
13307, 32019, 32020, 32028, 32027, 32273, 32289, 32290, 32287
13308, 32020, 32021, 32029, 32028, 32275, 32291, 32292, 32289
13309, 32021, 32022, 32030, 32029, 32277, 32293, 32294, 32291
13310, 32022, 32023, 32031, 32030, 32279, 32295, 32296, 32293
13311, 32023, 3802, 3803, 32031, 32280, 3825, 32297, 32295
13312, 3752, 32024, 32032, 3753, 32282, 32298, 32299, 3775
13313, 32024, 32025, 32033, 32032, 32284, 32300, 32301, 32298
13314, 32025, 32026, 32034, 32033, 32286, 32302, 32303, 32300
13315, 32026, 32027, 32035, 32034, 32288, 32304, 32305, 32302
13316, 32027, 32028, 32036, 32035, 32290, 32306, 32307, 32304
13317, 32028, 32029, 32037, 32036, 32292, 32308, 32309, 32306
13318, 32029, 32030, 32038, 32037, 32294, 32310, 32311, 32308
13319, 32030, 32031, 32039, 32038, 32296, 32312, 32313, 32310
13320, 32031, 3803, 3804, 32039, 32297, 3826, 32314, 32312
13321, 3753, 32032, 32040, 3754, 32299, 32315, 32316, 3776
13322, 32032, 32033, 32041, 32040, 32301, 32317, 32318, 32315
13323, 32033, 32034, 32042, 32041, 32303, 32319, 32320, 32317
13324, 32034, 32035, 32043, 32042, 32305, 32321, 32322, 32319
13325, 32035, 32036, 32044, 32043, 32307, 32323, 32324, 32321
13326, 32036, 32037, 32045, 32044, 32309, 32325, 32326, 32323
13327, 32037, 32038, 32046, 32045, 32311, 32327, 32328, 32325
13328, 32038, 32039, 32047, 32046, 32313, 32329, 32330, 32327
13329, 32039, 3804, 3805, 32047, 32314, 3827, 32331, 32329
13330, 3754, 32040, 32048, 3755, 32316, 32332, 32333, 3777
13331, 32040, 32041, 32049, 32048, 32318, 32334, 32335, 32332
13332, 32041, 32042, 32050, 32049, 32320, 32336, 32337, 32334
13333, 32042, 32043, 32051, 32050, 32322, 32338, 32339, 32336
13334, 32043, 32044, 32052, 32051, 32324, 32340, 32341, 32338
13335, 32044, 32045, 32053, 32052, 32326, 32342, 32343, 32340
13336, 32045, 32046, 32054, 32053, 32328, 32344, 32345, 32342
13337, 32046, 32047, 32055, 32054, 32330, 32346, 32347, 32344
13338, 32047, 3805, 3806, 32055, 32331, 3828, 32348, 32346
13339, 3755, 32048, 32056, 3756, 32333, 32349, 32350, 3778
13340, 32048, 32049, 32057, 32056, 32335, 32351, 32352, 32349
13341, 32049, 32050, 32058, 32057, 32337, 32353, 32354, 32351
13342, 32050, 32051, 32059, 32058, 32339, 32355, 32356, 32353
13343, 32051, 32052, 32060, 32059, 32341, 32357, 32358, 32355
13344, 32052, 32053, 32061, 32060, 32343, 32359, 32360, 32357
13345, 32053, 32054, 32062, 32061, 32345, 32361, 32362, 32359
13346, 32054, 32055, 32063, 32062, 32347, 32363, 32364, 32361
13347, 32055, 3806, 3807, 32063, 32348, 3829, 32365, 32363
13348, 3756, 32056, 32064, 3757, 32350, 32366, 32367, 3779
13349, 32056, 32057, 32065, 32064, 32352, 32368, 32369, 32366
13350, 32057, 32058, 32066, 32065, 32354, 32370, 32371, 32368
13351, 32058, 32059, 32067, 32066, 32356, 32372, 32373, 32370
13352, 32059, 32060, 32068, 32067, 32358, 32374, 32375, 32372
13353, 32060, 32061, 32069, 32068, 32360, 32376, 32377, 32374
13354, 32061, 32062, 32070, 32069, 32362, 32378, 32379, 32376
13355, 32062, 32063, 32071, 32070, 32364, 32380, 32381, 32378
13356, 32063, 3807, 3808, 32071, 32365, 3830, 32382, 32380
13357, 3757, 32064, 32072, 3758, 32367, 32383, 32384, 3780
13358, 32064, 32065, 32073, 32072, 32369, 32385, 32386, 32383
13359, 32065, 32066, 32074, 32073, 32371, 32387, 32388, 32385
13360, 32066, 32067, 32075, 32074, 32373, 32389, 32390, 32387
13361, 32067, 32068, 32076, 32075, 32375, 32391, 32392, 32389
13362, 32068, 32069, 32077, 32076, 32377, 32393, 32394, 32391
13363, 32069, 32070, 32078, 32077, 32379, 32395, 32396, 32393
13364, 32070, 32071, 32079, 32078, 32381, 32397, 32398, 32395
13365, 32071, 3808, 3809, 32079, 32382, 3831, 32399, 32397
13366, 3758, 32072, 32080, 3759, 32384, 32400, 32401, 3781
13367, 32072, 32073, 32081, 32080, 32386, 32402, 32403, 32400
13368, 32073, 32074, 32082, 32081, 32388, 32404, 32405, 32402
13369, 32074, 32075, 32083, 32082, 32390, 32406, 32407, 32404
13370, 32075, 32076, 32084, 32083, 32392, 32408, 32409, 32406
13371, 32076, 32077, 32085, 32084, 32394, 32410, 32411, 32408
13372, 32077, 32078, 32086, 32085, 32396, 32412, 32413, 32410
13373, 32078, 32079, 32087, 32086, 32398, 32414, 32415, 32412
13374, 32079, 3809, 3810, 32087, 32399, 3832, 32416, 32414
13375, 3759, 32080, 32088, 3760, 32401, 32417, 32418, 3782
13376, 32080, 32081, 32089, 32088, 32403, 32419, 32420, 32417
13377, 32081, 32082, 32090, 32089, 32405, 32421, 32422, 32419
13378, 32082, 32083, 32091, 32090, 32407, 32423, 32424, 32421
13379, 32083, 32084, 32092, 32091, 32409, 32425, 32426, 32423
13380, 32084, 32085, 32093, 32092, 32411, 32427, 32428, 32425
13381, 32085, 32086, 32094, 32093, 32413, 32429, 32430, 32427
13382, 32086, 32087, 32095, 32094, 32415, 32431, 32432, 32429
13383, 32087, 3810, 3811, 32095, 32416, 3833, 32433, 32431
13384, 3760, 32088, 32096, 3761, 32418, 32434, 32435, 3783
13385, 32088, 32089, 32097, 32096, 32420, 32436, 32437, 32434
13386, 32089, 32090, 32098, 32097, 32422, 32438, 32439, 32436
13387, 32090, 32091, 32099, 32098, 32424, 32440, 32441, 32438
13388, 32091, 32092, 32100, 32099, 32426, 32442, 32443, 32440
13389, 32092, 32093, 32101, 32100, 32428, 32444, 32445, 32442
13390, 32093, 32094, 32102, 32101, 32430, 32446, 32447, 32444
13391, 32094, 32095, 32103, 32102, 32432, 32448, 32449, 32446
13392, 32095, 3811, 3812, 32103, 32433, 3834, 32450, 32448
13393, 3761, 32096, 32104, 3762, 32435, 32451, 32452, 3784
13394, 32096, 32097, 32105, 32104, 32437, 32453, 32454, 32451
13395, 32097, 32098, 32106, 32105, 32439, 32455, 32456, 32453
13396, 32098, 32099, 32107, 32106, 32441, 32457, 32458, 32455
13397, 32099, 32100, 32108, 32107, 32443, 32459, 32460, 32457
13398, 32100, 32101, 32109, 32108, 32445, 32461, 32462, 32459
13399, 32101, 32102, 32110, 32109, 32447, 32463, 32464, 32461
13400, 32102, 32103, 32111, 32110, 32449, 32465, 32466, 32463
13401, 32103, 3812, 3813, 32111, 32450, 3835, 32467, 32465
13402, 3762, 32104, 32112, 3763, 32452, 32468, 32469, 3785
13403, 32104, 32105, 32113, 32112, 32454, 32470, 32471, 32468
13404, 32105, 32106, 32114, 32113, 32456, 32472, 32473, 32470
13405, 32106, 32107, 32115, 32114, 32458, 32474, 32475, 32472
13406, 32107, 32108, 32116, 32115, 32460, 32476, 32477, 32474
13407, 32108, 32109, 32117, 32116, 32462, 32478, 32479, 32476
13408, 32109, 32110, 32118, 32117, 32464, 32480, 32481, 32478
13409, 32110, 32111, 32119, 32118, 32466, 32482, 32483, 32480
13410, 32111, 3813, 3814, 32119, 32467, 3836, 32484, 32482
13411, 3763, 32112, 32120, 3764, 32469, 32485, 32486, 3786
13412, 32112, 32113, 32121, 32120, 32471, 32487, 32488, 32485
13413, 32113, 32114, 32122, 32121, 32473, 32489, 32490, 32487
13414, 32114, 32115, 32123, 32122, 32475, 32491, 32492, 32489
13415, 32115, 32116, 32124, 32123, 32477, 32493, 32494, 32491
13416, 32116, 32117, 32125, 32124, 32479, 32495, 32496, 32493
13417, 32117, 32118, 32126, 32125, 32481, 32497, 32498, 32495
13418, 32118, 32119, 32127, 32126, 32483, 32499, 32500, 32497
13419, 32119, 3814, 3815, 32127, 32484, 3837, 32501, 32499
13420, 3764, 32120, 3863, 106, 32486, 32502, 3872, 3787
13421, 32120, 32121, 3862, 3863, 32488, 32503, 3871, 32502
13422, 32121, 32122, 3861, 3862, 32490, 32504, 3870, 32503
13423, 32122, 32123, 3860, 3861, 32492, 32505, 3869, 32504
13424, 32123, 32124, 3859, 3860, 32494, 32506, 3868, 32505
13425, 32124, 32125, 3858, 3859, 32496, 32507, 3867, 32506
13426, 32125, 32126, 3857, 3858, 32498, 32508, 3866, 32507
13427, 32126, 32127, 3856, 3857, 32500, 32509, 3865, 32508
13428, 32127, 3815, 108, 3856, 32501, 3838, 3864, 32509
*ELEMENT, type=CPS8, ELSET=Surface293
13429, 67, 3873, 32510, 2047, 3874, 32532, 32533, 2070
13430, 2047, 32510, 32511, 2046, 32533, 32534, 32535, 2069
13431, 2046, 32511, 32512, 2045, 32535, 32536, 32537, 2068
13432, 2045, 32512, 32513, 2044, 32537, 32538, 32539, 2067
13433, 2044, 32513, 32514, 2043, 32539, 32540, 32541, 2066
13434, 2043, 32514, 32515, 2042, 32541, 32542, 32543, 2065
13435, 2042, 32515, 32516, 2041, 32543, 32544, 32545, 2064
13436, 2041, 32516, 32517, 2040, 32545, 32546, 32547, 2063
13437, 2040, 32517, 32518, 2039, 32547, 32548, 32549, 2062
13438, 2039, 32518, 32519, 2038, 32549, 32550, 32551, 2061
13439, 2038, 32519, 32520, 2037, 32551, 32552, 32553, 2060
13440, 2037, 32520, 32521, 2036, 32553, 32554, 32555, 2059
13441, 2036, 32521, 32522, 2035, 32555, 32556, 32557, 2058
13442, 2035, 32522, 32523, 2034, 32557, 32558, 32559, 2057
13443, 2034, 32523, 32524, 2033, 32559, 32560, 32561, 2056
13444, 2033, 32524, 32525, 2032, 32561, 32562, 32563, 2055
13445, 2032, 32525, 32526, 2031, 32563, 32564, 32565, 2054
13446, 2031, 32526, 32527, 2030, 32565, 32566, 32567, 2053
13447, 2030, 32527, 32528, 2029, 32567, 32568, 32569, 2052
13448, 2029, 32528, 32529, 2028, 32569, 32570, 32571, 2051
13449, 2028, 32529, 32530, 2027, 32571, 32572, 32573, 2050
13450, 2027, 32530, 32531, 2026, 32573, 32574, 32575, 2049
13451, 2026, 32531, 3876, 68, 32575, 32576, 3877, 2048
13452, 3873, 89, 2944, 32510, 3875, 2967, 32577, 32532
13453, 32510, 2944, 2943, 32511, 32577, 2966, 32578, 32534
13454, 32511, 2943, 2942, 32512, 32578, 2965, 32579, 32536
13455, 32512, 2942, 2941, 32513, 32579, 2964, 32580, 32538
13456, 32513, 2941, 2940, 32514, 32580, 2963, 32581, 32540
13457, 32514, 2940, 2939, 32515, 32581, 2962, 32582, 32542
13458, 32515, 2939, 2938, 32516, 32582, 2961, 32583, 32544
13459, 32516, 2938, 2937, 32517, 32583, 2960, 32584, 32546
13460, 32517, 2937, 2936, 32518, 32584, 2959, 32585, 32548
13461, 32518, 2936, 2935, 32519, 32585, 2958, 32586, 32550
13462, 32519, 2935, 2934, 32520, 32586, 2957, 32587, 32552
13463, 32520, 2934, 2933, 32521, 32587, 2956, 32588, 32554
13464, 32521, 2933, 2932, 32522, 32588, 2955, 32589, 32556
13465, 32522, 2932, 2931, 32523, 32589, 2954, 32590, 32558
13466, 32523, 2931, 2930, 32524, 32590, 2953, 32591, 32560
13467, 32524, 2930, 2929, 32525, 32591, 2952, 32592, 32562
13468, 32525, 2929, 2928, 32526, 32592, 2951, 32593, 32564
13469, 32526, 2928, 2927, 32527, 32593, 2950, 32594, 32566
13470, 32527, 2927, 2926, 32528, 32594, 2949, 32595, 32568
13471, 32528, 2926, 2925, 32529, 32595, 2948, 32596, 32570
13472, 32529, 2925, 2924, 32530, 32596, 2947, 32597, 32572
13473, 32530, 2924, 2923, 32531, 32597, 2946, 32598, 32574
13474, 32531, 2923, 90, 3876, 32598, 2945, 3878, 32576
*ELEMENT, type=CPS8, ELSET=Surface294
13475, 69, 3879, 32599, 2081, 3880, 32607, 32608, 2090
13476, 2081, 32599, 32600, 2080, 32608, 32609, 32610, 2089
13477, 2080, 32600, 32601, 2079, 32610, 32611, 32612, 2088
13478, 2079, 32601, 32602, 2078, 32612, 32613, 32614, 2087
13479, 2078, 32602, 32603, 2077, 32614, 32615, 32616, 2086
13480, 2077, 32603, 32604, 2076, 32616, 32617, 32618, 2085
13481, 2076, 32604, 32605, 2075, 32618, 32619, 32620, 2084
13482, 2075, 32605, 32606, 2074, 32620, 32621, 32622, 2083
13483, 2074, 32606, 3873, 67, 32622, 32623, 3874, 2082
13484, 3879, 91, 3020, 32599, 3881, 3029, 32624, 32607
13485, 32599, 3020, 3019, 32600, 32624, 3028, 32625, 32609
13486, 32600, 3019, 3018, 32601, 32625, 3027, 32626, 32611
13487, 32601, 3018, 3017, 32602, 32626, 3026, 32627, 32613
13488, 32602, 3017, 3016, 32603, 32627, 3025, 32628, 32615
13489, 32603, 3016, 3015, 32604, 32628, 3024, 32629, 32617
13490, 32604, 3015, 3014, 32605, 32629, 3023, 32630, 32619
13491, 32605, 3014, 3013, 32606, 32630, 3022, 32631, 32621
13492, 32606, 3013, 89, 3873, 32631, 3021, 3875, 32623
*ELEMENT, type=CPS8, ELSET=Surface295
13493, 69, 2115, 32632, 3879, 2138, 32654, 32655, 3880
13494, 2115, 2114, 32633, 32632, 2137, 32656, 32657, 32654
13495, 2114, 2113, 32634, 32633, 2136, 32658, 32659, 32656
13496, 2113, 2112, 32635, 32634, 2135, 32660, 32661, 32658
13497, 2112, 2111, 32636, 32635, 2134, 32662, 32663, 32660
13498, 2111, 2110, 32637, 32636, 2133, 32664, 32665, 32662
13499, 2110, 2109, 32638, 32637, 2132, 32666, 32667, 32664
13500, 2109, 2108, 32639, 32638, 2131, 32668, 32669, 32666
13501, 2108, 2107, 32640, 32639, 2130, 32670, 32671, 32668
13502, 2107, 2106, 32641, 32640, 2129, 32672, 32673, 32670
13503, 2106, 2105, 32642, 32641, 2128, 32674, 32675, 32672
13504, 2105, 2104, 32643, 32642, 2127, 32676, 32677, 32674
13505, 2104, 2103, 32644, 32643, 2126, 32678, 32679, 32676
13506, 2103, 2102, 32645, 32644, 2125, 32680, 32681, 32678
13507, 2102, 2101, 32646, 32645, 2124, 32682, 32683, 32680
13508, 2101, 2100, 32647, 32646, 2123, 32684, 32685, 32682
13509, 2100, 2099, 32648, 32647, 2122, 32686, 32687, 32684
13510, 2099, 2098, 32649, 32648, 2121, 32688, 32689, 32686
13511, 2098, 2097, 32650, 32649, 2120, 32690, 32691, 32688
13512, 2097, 2096, 32651, 32650, 2119, 32692, 32693, 32690
13513, 2096, 2095, 32652, 32651, 2118, 32694, 32695, 32692
13514, 2095, 2094, 32653, 32652, 2117, 32696, 32697, 32694
13515, 2094, 70, 3882, 32653, 2116, 3883, 32698, 32696
13516, 3879, 32632, 3096, 91, 32655, 32699, 3119, 3881
13517, 32632, 32633, 3095, 3096, 32657, 32700, 3118, 32699
13518, 32633, 32634, 3094, 3095, 32659, 32701, 3117, 32700
13519, 32634, 32635, 3093, 3094, 32661, 32702, 3116, 32701
13520, 32635, 32636, 3092, 3093, 32663, 32703, 3115, 32702
13521, 32636, 32637, 3091, 3092, 32665, 32704, 3114, 32703
13522, 32637, 32638, 3090, 3091, 32667, 32705, 3113, 32704
13523, 32638, 32639, 3089, 3090, 32669, 32706, 3112, 32705
13524, 32639, 32640, 3088, 3089, 32671, 32707, 3111, 32706
13525, 32640, 32641, 3087, 3088, 32673, 32708, 3110, 32707
13526, 32641, 32642, 3086, 3087, 32675, 32709, 3109, 32708
13527, 32642, 32643, 3085, 3086, 32677, 32710, 3108, 32709
13528, 32643, 32644, 3084, 3085, 32679, 32711, 3107, 32710
13529, 32644, 32645, 3083, 3084, 32681, 32712, 3106, 32711
13530, 32645, 32646, 3082, 3083, 32683, 32713, 3105, 32712
13531, 32646, 32647, 3081, 3082, 32685, 32714, 3104, 32713
13532, 32647, 32648, 3080, 3081, 32687, 32715, 3103, 32714
13533, 32648, 32649, 3079, 3080, 32689, 32716, 3102, 32715
13534, 32649, 32650, 3078, 3079, 32691, 32717, 3101, 32716
13535, 32650, 32651, 3077, 3078, 32693, 32718, 3100, 32717
13536, 32651, 32652, 3076, 3077, 32695, 32719, 3099, 32718
13537, 32652, 32653, 3075, 3076, 32697, 32720, 3098, 32719
13538, 32653, 3882, 92, 3075, 32698, 3884, 3097, 32720
*ELEMENT, type=CPS8, ELSET=Surface296
13539, 70, 2146, 32721, 3882, 2155, 32729, 32730, 3883
13540, 2146, 2145, 32722, 32721, 2154, 32731, 32732, 32729
13541, 2145, 2144, 32723, 32722, 2153, 32733, 32734, 32731
13542, 2144, 2143, 32724, 32723, 2152, 32735, 32736, 32733
13543, 2143, 2142, 32725, 32724, 2151, 32737, 32738, 32735
13544, 2142, 2141, 32726, 32725, 2150, 32739, 32740, 32737
13545, 2141, 2140, 32727, 32726, 2149, 32741, 32742, 32739
13546, 2140, 2139, 32728, 32727, 2148, 32743, 32744, 32741
13547, 2139, 68, 3876, 32728, 2147, 3877, 32745, 32743
13548, 3882, 32721, 3127, 92, 32730, 32746, 3136, 3884
13549, 32721, 32722, 3126, 3127, 32732, 32747, 3135, 32746
13550, 32722, 32723, 3125, 3126, 32734, 32748, 3134, 32747
13551, 32723, 32724, 3124, 3125, 32736, 32749, 3133, 32748
13552, 32724, 32725, 3123, 3124, 32738, 32750, 3132, 32749
13553, 32725, 32726, 3122, 3123, 32740, 32751, 3131, 32750
13554, 32726, 32727, 3121, 3122, 32742, 32752, 3130, 32751
13555, 32727, 32728, 3120, 3121, 32744, 32753, 3129, 32752
13556, 32728, 3876, 90, 3120, 32745, 3878, 3128, 32753
*ELEMENT, type=CPS8, ELSET=Surface297
13557, 71, 3885, 32754, 2207, 3886, 32776, 32777, 2229
13558, 2207, 32754, 32755, 2208, 32777, 32778, 32779, 2230
13559, 2208, 32755, 32756, 2209, 32779, 32780, 32781, 2231
13560, 2209, 32756, 32757, 2210, 32781, 32782, 32783, 2232
13561, 2210, 32757, 32758, 2211, 32783, 32784, 32785, 2233
13562, 2211, 32758, 32759, 2212, 32785, 32786, 32787, 2234
13563, 2212, 32759, 32760, 2213, 32787, 32788, 32789, 2235
13564, 2213, 32760, 32761, 2214, 32789, 32790, 32791, 2236
13565, 2214, 32761, 32762, 2215, 32791, 32792, 32793, 2237
13566, 2215, 32762, 32763, 2216, 32793, 32794, 32795, 2238
13567, 2216, 32763, 32764, 2217, 32795, 32796, 32797, 2239
13568, 2217, 32764, 32765, 2218, 32797, 32798, 32799, 2240
13569, 2218, 32765, 32766, 2219, 32799, 32800, 32801, 2241
13570, 2219, 32766, 32767, 2220, 32801, 32802, 32803, 2242
13571, 2220, 32767, 32768, 2221, 32803, 32804, 32805, 2243
13572, 2221, 32768, 32769, 2222, 32805, 32806, 32807, 2244
13573, 2222, 32769, 32770, 2223, 32807, 32808, 32809, 2245
13574, 2223, 32770, 32771, 2224, 32809, 32810, 32811, 2246
13575, 2224, 32771, 32772, 2225, 32811, 32812, 32813, 2247
13576, 2225, 32772, 32773, 2226, 32813, 32814, 32815, 2248
13577, 2226, 32773, 32774, 2227, 32815, 32816, 32817, 2249
13578, 2227, 32774, 32775, 2228, 32817, 32818, 32819, 2250
13579, 2228, 32775, 3888, 73, 32819, 32820, 3889, 2251
13580, 3885, 93, 3227, 32754, 3887, 3249, 32821, 32776
13581, 32754, 3227, 3228, 32755, 32821, 3250, 32822, 32778
13582, 32755, 3228, 3229, 32756, 32822, 3251, 32823, 32780
13583, 32756, 3229, 3230, 32757, 32823, 3252, 32824, 32782
13584, 32757, 3230, 3231, 32758, 32824, 3253, 32825, 32784
13585, 32758, 3231, 3232, 32759, 32825, 3254, 32826, 32786
13586, 32759, 3232, 3233, 32760, 32826, 3255, 32827, 32788
13587, 32760, 3233, 3234, 32761, 32827, 3256, 32828, 32790
13588, 32761, 3234, 3235, 32762, 32828, 3257, 32829, 32792
13589, 32762, 3235, 3236, 32763, 32829, 3258, 32830, 32794
13590, 32763, 3236, 3237, 32764, 32830, 3259, 32831, 32796
13591, 32764, 3237, 3238, 32765, 32831, 3260, 32832, 32798
13592, 32765, 3238, 3239, 32766, 32832, 3261, 32833, 32800
13593, 32766, 3239, 3240, 32767, 32833, 3262, 32834, 32802
13594, 32767, 3240, 3241, 32768, 32834, 3263, 32835, 32804
13595, 32768, 3241, 3242, 32769, 32835, 3264, 32836, 32806
13596, 32769, 3242, 3243, 32770, 32836, 3265, 32837, 32808
13597, 32770, 3243, 3244, 32771, 32837, 3266, 32838, 32810
13598, 32771, 3244, 3245, 32772, 32838, 3267, 32839, 32812
13599, 32772, 3245, 3246, 32773, 32839, 3268, 32840, 32814
13600, 32773, 3246, 3247, 32774, 32840, 3269, 32841, 32816
