10310, 24408, 24409, 24417, 24416, 24605, 24621, 24622, 24619
10311, 24409, 24410, 24418, 24417, 24607, 24623, 24624, 24621
10312, 24410, 24411, 24419, 24418, 24609, 24625, 24626, 24623
10313, 24411, 24412, 24420, 24419, 24611, 24627, 24628, 24625
10314, 24412, 24413, 24421, 24420, 24613, 24629, 24630, 24627
10315, 24413, 24414, 24422, 24421, 24615, 24631, 24632, 24629
10316, 24414, 24415, 24423, 24422, 24617, 24633, 24634, 24631
10317, 24415, 3077, 3078, 24423, 24618, 3100, 24635, 24633
10318, 2926, 24416, 24424, 2927, 24620, 24636, 24637, 2949
10319, 24416, 24417, 24425, 24424, 24622, 24638, 24639, 24636
10320, 24417, 24418, 24426, 24425, 24624, 24640, 24641, 24638
10321, 24418, 24419, 24427, 24426, 24626, 24642, 24643, 24640
10322, 24419, 24420, 24428, 24427, 24628, 24644, 24645, 24642
10323, 24420, 24421, 24429, 24428, 24630, 24646, 24647, 24644
10324, 24421, 24422, 24430, 24429, 24632, 24648, 24649, 24646
10325, 24422, 24423, 24431, 24430, 24634, 24650, 24651, 24648
10326, 24423, 3078, 3079, 24431, 24635, 3101, 24652, 24650
10327, 2927, 24424, 24432, 2928, 24637, 24653, 24654, 2950
10328, 24424, 24425, 24433, 24432, 24639, 24655, 24656, 24653
10329, 24425, 24426, 24434, 24433, 24641, 24657, 24658, 24655
10330, 24426, 24427, 24435, 24434, 24643, 24659, 24660, 24657
10331, 24427, 24428, 24436, 24435, 24645, 24661, 24662, 24659
10332, 24428, 24429, 24437, 24436, 24647, 24663, 24664, 24661
10333, 24429, 24430, 24438, 24437, 24649, 24665, 24666, 24663
10334, 24430, 24431, 24439, 24438, 24651, 24667, 24668, 24665
10335, 24431, 3079, 3080, 24439, 24652, 3102, 24669, 24667
10336, 2928, 24432, 24440, 2929, 24654, 24670, 24671, 2951
10337, 24432, 24433, 24441, 24440, 24656, 24672, 24673, 24670
10338, 24433, 24434, 24442, 24441, 24658, 24674, 24675, 24672
10339, 24434, 24435, 24443, 24442, 24660, 24676, 24677, 24674
10340, 24435, 24436, 24444, 24443, 24662, 24678, 24679, 24676
10341, 24436, 24437, 24445, 24444, 24664, 24680, 24681, 24678
10342, 24437, 24438, 24446, 24445, 24666, 24682, 24683, 24680
10343, 24438, 24439, 24447, 24446, 24668, 24684, 24685, 24682
10344, 24439, 3080, 3081, 24447, 24669, 3103, 24686, 24684
10345, 2929, 24440, 24448, 2930, 24671, 24687, 24688, 2952
10346, 24440, 24441, 24449, 24448, 24673, 24689, 24690, 24687
10347, 24441, 24442, 24450, 24449, 24675, 24691, 24692, 24689
10348, 24442, 24443, 24451, 24450, 24677, 24693, 24694, 24691
10349, 24443, 24444, 24452, 24451, 24679, 24695, 24696, 24693
10350, 24444, 24445, 24453, 24452, 24681, 24697, 24698, 24695
10351, 24445, 24446, 24454, 24453, 24683, 24699, 24700, 24697
10352, 24446, 24447, 24455, 24454, 24685, 24701, 24702, 24699
10353, 24447, 3081, 3082, 24455, 24686, 3104, 24703, 24701
10354, 2930, 24448, 24456, 2931, 24688, 24704, 24705, 2953
10355, 24448, 24449, 24457, 24456, 24690, 24706, 24707, 24704
10356, 24449, 24450, 24458, 24457, 24692, 24708, 24709, 24706
10357, 24450, 24451, 24459, 24458, 24694, 24710, 24711, 24708
10358, 24451, 24452, 24460, 24459, 24696, 24712, 24713, 24710
10359, 24452, 24453, 24461, 24460, 24698, 24714, 24715, 24712
10360, 24453, 24454, 24462, 24461, 24700, 24716, 24717, 24714
10361, 24454, 24455, 24463, 24462, 24702, 24718, 24719, 24716
10362, 24455, 3082, 3083, 24463, 24703, 3105, 24720, 24718
10363, 2931, 24456, 24464, 2932, 24705, 24721, 24722, 2954
10364, 24456, 24457, 24465, 24464, 24707, 24723, 24724, 24721
10365, 24457, 24458, 24466, 24465, 24709, 24725, 24726, 24723
10366, 24458, 24459, 24467, 24466, 24711, 24727, 24728, 24725
10367, 24459, 24460, 24468, 24467, 24713, 24729, 24730, 24727
10368, 24460, 24461, 24469, 24468, 24715, 24731, 24732, 24729
10369, 24461, 24462, 24470, 24469, 24717, 24733, 24734, 24731
10370, 24462, 24463, 24471, 24470, 24719, 24735, 24736, 24733
10371, 24463, 3083, 3084, 24471, 24720, 3106, 24737, 24735
10372, 2932, 24464, 24472, 2933, 24722, 24738, 24739, 2955
10373, 24464, 24465, 24473, 24472, 24724, 24740, 24741, 24738
10374, 24465, 24466, 24474, 24473, 24726, 24742, 24743, 24740
10375, 24466, 24467, 24475, 24474, 24728, 24744, 24745, 24742
10376, 24467, 24468, 24476, 24475, 24730, 24746, 24747, 24744
10377, 24468, 24469, 24477, 24476, 24732, 24748, 24749, 24746
10378, 24469, 24470, 24478, 24477, 24734, 24750, 24751, 24748
10379, 24470, 24471, 24479, 24478, 24736, 24752, 24753, 24750
10380, 24471, 3084, 3085, 24479, 24737, 3107, 24754, 24752
10381, 2933, 24472, 24480, 2934, 24739, 24755, 24756, 2956
10382, 24472, 24473, 24481, 24480, 24741, 24757, 24758, 24755
10383, 24473, 24474, 24482, 24481, 24743, 24759, 24760, 24757
10384, 24474, 24475, 24483, 24482, 24745, 24761, 24762, 24759
10385, 24475, 24476, 24484, 24483, 24747, 24763, 24764, 24761
10386, 24476, 24477, 24485, 24484, 24749, 24765, 24766, 24763
10387, 24477, 24478, 24486, 24485, 24751, 24767, 24768, 24765
10388, 24478, 24479, 24487, 24486, 24753, 24769, 24770, 24767
10389, 24479, 3085, 3086, 24487, 24754, 3108, 24771, 24769
10390, 2934, 24480, 24488, 2935, 24756, 24772, 24773, 2957
10391, 24480, 24481, 24489, 24488, 24758, 24774, 24775, 24772
10392, 24481, 24482, 24490, 24489, 24760, 24776, 24777, 24774
10393, 24482, 24483, 24491, 24490, 24762, 24778, 24779, 24776
10394, 24483, 24484, 24492, 24491, 24764, 24780, 24781, 24778
10395, 24484, 24485, 24493, 24492, 24766, 24782, 24783, 24780
10396, 24485, 24486, 24494, 24493, 24768, 24784, 24785, 24782
10397, 24486, 24487, 24495, 24494, 24770, 24786, 24787, 24784
10398, 24487, 3086, 3087, 24495, 24771, 3109, 24788, 24786
10399, 2935, 24488, 24496, 2936, 24773, 24789, 24790, 2958
10400, 24488, 24489, 24497, 24496, 24775, 24791, 24792, 24789
10401, 24489, 24490, 24498, 24497, 24777, 24793, 24794, 24791
10402, 24490, 24491, 24499, 24498, 24779, 24795, 24796, 24793
10403, 24491, 24492, 24500, 24499, 24781, 24797, 24798, 24795
10404, 24492, 24493, 24501, 24500, 24783, 24799, 24800, 24797
10405, 24493, 24494, 24502, 24501, 24785, 24801, 24802, 24799
10406, 24494, 24495, 24503, 24502, 24787, 24803, 24804, 24801
10407, 24495, 3087, 3088, 24503, 24788, 3110, 24805, 24803
10408, 2936, 24496, 24504, 2937, 24790, 24806, 24807, 2959
10409, 24496, 24497, 24505, 24504, 24792, 24808, 24809, 24806
10410, 24497, 24498, 24506, 24505, 24794, 24810, 24811, 24808
10411, 24498, 24499, 24507, 24506, 24796, 24812, 24813, 24810
10412, 24499, 24500, 24508, 24507, 24798, 24814, 24815, 24812
10413, 24500, 24501, 24509, 24508, 24800, 24816, 24817, 24814
10414, 24501, 24502, 24510, 24509, 24802, 24818, 24819, 24816
10415, 24502, 24503, 24511, 24510, 24804, 24820, 24821, 24818
10416, 24503, 3088, 3089, 24511, 24805, 3111, 24822, 24820
10417, 2937, 24504, 24512, 2938, 24807, 24823, 24824, 2960
10418, 24504, 24505, 24513, 24512, 24809, 24825, 24826, 24823
10419, 24505, 24506, 24514, 24513, 24811, 24827, 24828, 24825
10420, 24506, 24507, 24515, 24514, 24813, 24829, 24830, 24827
10421, 24507, 24508, 24516, 24515, 24815, 24831, 24832, 24829
10422, 24508, 24509, 24517, 24516, 24817, 24833, 24834, 24831
10423, 24509, 24510, 24518, 24517, 24819, 24835, 24836, 24833
10424, 24510, 24511, 24519, 24518, 24821, 24837, 24838, 24835
10425, 24511, 3089, 3090, 24519, 24822, 3112, 24839, 24837
10426, 2938, 24512, 24520, 2939, 24824, 24840, 24841, 2961
10427, 24512, 24513, 24521, 24520, 24826, 24842, 24843, 24840
10428, 24513, 24514, 24522, 24521, 24828, 24844, 24845, 24842
10429, 24514, 24515, 24523, 24522, 24830, 24846, 24847, 24844
10430, 24515, 24516, 24524, 24523, 24832, 24848, 24849, 24846
10431, 24516, 24517, 24525, 24524, 24834, 24850, 24851, 24848
10432, 24517, 24518, 24526, 24525, 24836, 24852, 24853, 24850
10433, 24518, 24519, 24527, 24526, 24838, 24854, 24855, 24852
10434, 24519, 3090, 3091, 24527, 24839, 3113, 24856, 24854
10435, 2939, 24520, 24528, 2940, 24841, 24857, 24858, 2962
10436, 24520, 24521, 24529, 24528, 24843, 24859, 24860, 24857
10437, 24521, 24522, 24530, 24529, 24845, 24861, 24862, 24859
10438, 24522, 24523, 24531, 24530, 24847, 24863, 24864, 24861
10439, 24523, 24524, 24532, 24531, 24849, 24865, 24866, 24863
10440, 24524, 24525, 24533, 24532, 24851, 24867, 24868, 24865
10441, 24525, 24526, 24534, 24533, 24853, 24869, 24870, 24867
10442, 24526, 24527, 24535, 24534, 24855, 24871, 24872, 24869
10443, 24527, 3091, 3092, 24535, 24856, 3114, 24873, 24871
10444, 2940, 24528, 24536, 2941, 24858, 24874, 24875, 2963
10445, 24528, 24529, 24537, 24536, 24860, 24876, 24877, 24874
10446, 24529, 24530, 24538, 24537, 24862, 24878, 24879, 24876
10447, 24530, 24531, 24539, 24538, 24864, 24880, 24881, 24878
10448, 24531, 24532, 24540, 24539, 24866, 24882, 24883, 24880
10449, 24532, 24533, 24541, 24540, 24868, 24884, 24885, 24882
10450, 24533, 24534, 24542, 24541, 24870, 24886, 24887, 24884
10451, 24534, 24535, 24543, 24542, 24872, 24888, 24889, 24886
10452, 24535, 3092, 3093, 24543, 24873, 3115, 24890, 24888
10453, 2941, 24536, 24544, 2942, 24875, 24891, 24892, 2964
10454, 24536, 24537, 24545, 24544, 24877, 24893, 24894, 24891
10455, 24537, 24538, 24546, 24545, 24879, 24895, 24896, 24893
10456, 24538, 24539, 24547, 24546, 24881, 24897, 24898, 24895
10457, 24539, 24540, 24548, 24547, 24883, 24899, 24900, 24897
10458, 24540, 24541, 24549, 24548, 24885, 24901, 24902, 24899
10459, 24541, 24542, 24550, 24549, 24887, 24903, 24904, 24901
10460, 24542, 24543, 24551, 24550, 24889, 24905, 24906, 24903
10461, 24543, 3093, 3094, 24551, 24890, 3116, 24907, 24905
10462, 2942, 24544, 24552, 2943, 24892, 24908, 24909, 2965
10463, 24544, 24545, 24553, 24552, 24894, 24910, 24911, 24908
10464, 24545, 24546, 24554, 24553, 24896, 24912, 24913, 24910
10465, 24546, 24547, 24555, 24554, 24898, 24914, 24915, 24912
10466, 24547, 24548, 24556, 24555, 24900, 24916, 24917, 24914
10467, 24548, 24549, 24557, 24556, 24902, 24918, 24919, 24916
10468, 24549, 24550, 24558, 24557, 24904, 24920, 24921, 24918
10469, 24550, 24551, 24559, 24558, 24906, 24922, 24923, 24920
10470, 24551, 3094, 3095, 24559, 24907, 3117, 24924, 24922
10471, 2943, 24552, 24560, 2944, 24909, 24925, 24926, 2966
10472, 24552, 24553, 24561, 24560, 24911, 24927, 24928, 24925
10473, 24553, 24554, 24562, 24561, 24913, 24929, 24930, 24927
10474, 24554, 24555, 24563, 24562, 24915, 24931, 24932, 24929
10475, 24555, 24556, 24564, 24563, 24917, 24933, 24934, 24931
10476, 24556, 24557, 24565, 24564, 24919, 24935, 24936, 24933
10477, 24557, 24558, 24566, 24565, 24921, 24937, 24938, 24935
10478, 24558, 24559, 24567, 24566, 24923, 24939, 24940, 24937
10479, 24559, 3095, 3096, 24567, 24924, 3118, 24941, 24939
10480, 2944, 24560, 3013, 89, 24926, 24942, 3021, 2967
10481, 24560, 24561, 3014, 3013, 24928, 24943, 3022, 24942
10482, 24561, 24562, 3015, 3014, 24930, 24944, 3023, 24943
10483, 24562, 24563, 3016, 3015, 24932, 24945, 3024, 24944
10484, 24563, 24564, 3017, 3016, 24934, 24946, 3025, 24945
10485, 24564, 24565, 3018, 3017, 24936, 24947, 3026, 24946
10486, 24565, 24566, 3019, 3018, 24938, 24948, 3027, 24947
10487, 24566, 24567, 3020, 3019, 24940, 24949, 3028, 24948
10488, 24567, 3096, 91, 3020, 24941, 3119, 3029, 24949
*ELEMENT, type=CPS8, ELSET=Surface265
10489, 93, 3137, 24950, 3227, 3159, 25434, 25435, 3249
10490, 3227, 24950, 24951, 3228, 25435, 25436, 25437, 3250
10491, 3228, 24951, 24952, 3229, 25437, 25438, 25439, 3251
10492, 3229, 24952, 24953, 3230, 25439, 25440, 25441, 3252
10493, 3230, 24953, 24954, 3231, 25441, 25442, 25443, 3253
10494, 3231, 24954, 24955, 3232, 25443, 25444, 25445, 3254
10495, 3232, 24955, 24956, 3233, 25445, 25446, 25447, 3255
10496, 3233, 24956, 24957, 3234, 25447, 25448, 25449, 3256
10497, 3234, 24957, 24958, 3235, 25449, 25450, 25451, 3257
10498, 3235, 24958, 24959, 3236, 25451, 25452, 25453, 3258
10499, 3236, 24959, 24960, 3237, 25453, 25454, 25455, 3259
10500, 3237, 24960, 24961, 3238, 25455, 25456, 25457, 3260
10501, 3238, 24961, 24962, 3239, 25457, 25458, 25459, 3261
10502, 3239, 24962, 24963, 3240, 25459, 25460, 25461, 3262
10503, 3240, 24963, 24964, 3241, 25461, 25462, 25463, 3263
10504, 3241, 24964, 24965, 3242, 25463, 25464, 25465, 3264
10505, 3242, 24965, 24966, 3243, 25465, 25466, 25467, 3265
10506, 3243, 24966, 24967, 3244, 25467, 25468, 25469, 3266
10507, 3244, 24967, 24968, 3245, 25469, 25470, 25471, 3267
10508, 3245, 24968, 24969, 3246, 25471, 25472, 25473, 3268
10509, 3246, 24969, 24970, 3247, 25473, 25474, 25475, 3269
10510, 3247, 24970, 24971, 3248, 25475, 25476, 25477, 3270
10511, 3248, 24971, 3182, 94, 25477, 25478, 3204, 3271
10512, 3137, 3138, 24972, 24950, 3160, 25479, 25480, 25434
10513, 24950, 24972, 24973, 24951, 25480, 25481, 25482, 25436
10514, 24951, 24973, 24974, 24952, 25482, 25483, 25484, 25438
10515, 24952, 24974, 24975, 24953, 25484, 25485, 25486, 25440
10516, 24953, 24975, 24976, 24954, 25486, 25487, 25488, 25442
10517, 24954, 24976, 24977, 24955, 25488, 25489, 25490, 25444
10518, 24955, 24977, 24978, 24956, 25490, 25491, 25492, 25446
10519, 24956, 24978, 24979, 24957, 25492, 25493, 25494, 25448
10520, 24957, 24979, 24980, 24958, 25494, 25495, 25496, 25450
10521, 24958, 24980, 24981, 24959, 25496, 25497, 25498, 25452
10522, 24959, 24981, 24982, 24960, 25498, 25499, 25500, 25454
10523, 24960, 24982, 24983, 24961, 25500, 25501, 25502, 25456
10524, 24961, 24983, 24984, 24962, 25502, 25503, 25504, 25458
10525, 24962, 24984, 24985, 24963, 25504, 25505, 25506, 25460
10526, 24963, 24985, 24986, 24964, 25506, 25507, 25508, 25462
10527, 24964, 24986, 24987, 24965, 25508, 25509, 25510, 25464
10528, 24965, 24987, 24988, 24966, 25510, 25511, 25512, 25466
10529, 24966, 24988, 24989, 24967, 25512, 25513, 25514, 25468
10530, 24967, 24989, 24990, 24968, 25514, 25515, 25516, 25470
10531, 24968, 24990, 24991, 24969, 25516, 25517, 25518, 25472
10532, 24969, 24991, 24992, 24970, 25518, 25519, 25520, 25474
10533, 24970, 24992, 24993, 24971, 25520, 25521, 25522, 25476
10534, 24971, 24993, 3183, 3182, 25522, 25523, 3205, 25478
10535, 3138, 3139, 24994, 24972, 3161, 25524, 25525, 25479
10536, 24972, 24994, 24995, 24973, 25525, 25526, 25527, 25481
10537, 24973, 24995, 24996, 24974, 25527, 25528, 25529, 25483
10538, 24974, 24996, 24997, 24975, 25529, 25530, 25531, 25485
10539, 24975, 24997, 24998, 24976, 25531, 25532, 25533, 25487
10540, 24976, 24998, 24999, 24977, 25533, 25534, 25535, 25489
10541, 24977, 24999, 25000, 24978, 25535, 25536, 25537, 25491
10542, 24978, 25000, 25001, 24979, 25537, 25538, 25539, 25493
10543, 24979, 25001, 25002, 24980, 25539, 25540, 25541, 25495
10544, 24980, 25002, 25003, 24981, 25541, 25542, 25543, 25497
10545, 24981, 25003, 25004, 24982, 25543, 25544, 25545, 25499
10546, 24982, 25004, 25005, 24983, 25545, 25546, 25547, 25501
10547, 24983, 25005, 25006, 24984, 25547, 25548, 25549, 25503
10548, 24984, 25006, 25007, 24985, 25549, 25550, 25551, 25505
10549, 24985, 25007, 25008, 24986, 25551, 25552, 25553, 25507
10550, 24986, 25008, 25009, 24987, 25553, 25554, 25555, 25509
10551, 24987, 25009, 25010, 24988, 25555, 25556, 25557, 25511
10552, 24988, 25010, 25011, 24989, 25557, 25558, 25559, 25513
10553, 24989, 25011, 25012, 24990, 25559, 25560, 25561, 25515
10554, 24990, 25012, 25013, 24991, 25561, 25562, 25563, 25517
10555, 24991, 25013, 25014, 24992, 25563, 25564, 25565, 25519
10556, 24992, 25014, 25015, 24993, 25565, 25566, 25567, 25521
10557, 24993, 25015, 3184, 3183, 25567, 25568, 3206, 25523
10558, 3139, 3140, 25016, 24994, 3162, 25569, 25570, 25524
10559, 24994, 25016, 25017, 24995, 25570, 25571, 25572, 25526
10560, 24995, 25017, 25018, 24996, 25572, 25573, 25574, 25528
10561, 24996, 25018, 25019, 24997, 25574, 25575, 25576, 25530
10562, 24997, 25019, 25020, 24998, 25576, 25577, 25578, 25532
10563, 24998, 25020, 25021, 24999, 25578, 25579, 25580, 25534
10564, 24999, 25021, 25022, 25000, 25580, 25581, 25582, 25536
10565, 25000, 25022, 25023, 25001, 25582, 25583, 25584, 25538
10566, 25001, 25023, 25024, 25002, 25584, 25585, 25586, 25540
10567, 25002, 25024, 25025, 25003, 25586, 25587, 25588, 25542
10568, 25003, 25025, 25026, 25004, 25588, 25589, 25590, 25544
10569, 25004, 25026, 25027, 25005, 25590, 25591, 25592, 25546
10570, 25005, 25027, 25028, 25006, 25592, 25593, 25594, 25548
10571, 25006, 25028, 25029, 25007, 25594, 25595, 25596, 25550
10572, 25007, 25029, 25030, 25008, 25596, 25597, 25598, 25552
10573, 25008, 25030, 25031, 25009, 25598, 25599, 25600, 25554
10574, 25009, 25031, 25032, 25010, 25600, 25601, 25602, 25556
10575, 25010, 25032, 25033, 25011, 25602, 25603, 25604, 25558
10576, 25011, 25033, 25034, 25012, 25604, 25605, 25606, 25560
10577, 25012, 25034, 25035, 25013, 25606, 25607, 25608, 25562
10578, 25013, 25035, 25036, 25014, 25608, 25609, 25610, 25564
10579, 25014, 25036, 25037, 25015, 25610, 25611, 25612, 25566
10580, 25015, 25037, 3185, 3184, 25612, 25613, 3207, 25568
10581, 3140, 3141, 25038, 25016, 3163, 25614, 25615, 25569
10582, 25016, 25038, 25039, 25017, 25615, 25616, 25617, 25571
10583, 25017, 25039, 25040, 25018, 25617, 25618, 25619, 25573
10584, 25018, 25040, 25041, 25019, 25619, 25620, 25621, 25575
10585, 25019, 25041, 25042, 25020, 25621, 25622, 25623, 25577
10586, 25020, 25042, 25043, 25021, 25623, 25624, 25625, 25579
10587, 25021, 25043, 25044, 25022, 25625, 25626, 25627, 25581
10588, 25022, 25044, 25045, 25023, 25627, 25628, 25629, 25583
10589, 25023, 25045, 25046, 25024, 25629, 25630, 25631, 25585
10590, 25024, 25046, 25047, 25025, 25631, 25632, 25633, 25587
10591, 25025, 25047, 25048, 25026, 25633, 25634, 25635, 25589
10592, 25026, 25048, 25049, 25027, 25635, 25636, 25637, 25591
10593, 25027, 25049, 25050, 25028, 25637, 25638, 25639, 25593
10594, 25028, 25050, 25051, 25029, 25639, 25640, 25641, 25595
10595, 25029, 25051, 25052, 25030, 25641, 25642, 25643, 25597
10596, 25030, 25052, 25053, 25031, 25643, 25644, 25645, 25599
10597, 25031, 25053, 25054, 25032, 25645, 25646, 25647, 25601
10598, 25032, 25054, 25055, 25033, 25647, 25648, 25649, 25603
10599, 25033, 25055, 25056, 25034, 25649, 25650, 25651, 25605
10600, 25034, 25056, 25057, 25035, 25651, 25652, 25653, 25607
10601, 25035, 25057, 25058, 25036, 25653, 25654, 25655, 25609
10602, 25036, 25058, 25059, 25037, 25655, 25656, 25657, 25611
10603, 25037, 25059, 3186, 3185, 25657, 25658, 3208, 25613
10604, 3141, 3142, 25060, 25038, 3164, 25659, 25660, 25614
10605, 25038, 25060, 25061, 25039, 25660, 25661, 25662, 25616
10606, 25039, 25061, 25062, 25040, 25662, 25663, 25664, 25618
10607, 25040, 25062, 25063, 25041, 25664, 25665, 25666, 25620
10608, 25041, 25063, 25064, 25042, 25666, 25667, 25668, 25622
10609, 25042, 25064, 25065, 25043, 25668, 25669, 25670, 25624
10610, 25043, 25065, 25066, 25044, 25670, 25671, 25672, 25626
10611, 25044, 25066, 25067, 25045, 25672, 25673, 25674, 25628
10612, 25045, 25067, 25068, 25046, 25674, 25675, 25676, 25630
10613, 25046, 25068, 25069, 25047, 25676, 25677, 25678, 25632
10614, 25047, 25069, 25070, 25048, 25678, 25679, 25680, 25634
10615, 25048, 25070, 25071, 25049, 25680, 25681, 25682, 25636
10616, 25049, 25071, 25072, 25050, 25682, 25683, 25684, 25638
10617, 25050, 25072, 25073, 25051, 25684, 25685, 25686, 25640
10618, 25051, 25073, 25074, 25052, 25686, 25687, 25688, 25642
10619, 25052, 25074, 25075, 25053, 25688, 25689, 25690, 25644
10620, 25053, 25075, 25076, 25054, 25690, 25691, 25692, 25646
10621, 25054, 25076, 25077, 25055, 25692, 25693, 25694, 25648
10622, 25055, 25077, 25078, 25056, 25694, 25695, 25696, 25650
10623, 25056, 25078, 25079, 25057, 25696, 25697, 25698, 25652
10624, 25057, 25079, 25080, 25058, 25698, 25699, 25700, 25654
10625, 25058, 25080, 25081, 25059, 25700, 25701, 25702, 25656
10626, 25059, 25081, 3187, 3186, 25702, 25703, 3209, 25658
10627, 3142, 3143, 25082, 25060, 3165, 25704, 25705, 25659
10628, 25060, 25082, 25083, 25061, 25705, 25706, 25707, 25661
10629, 25061, 25083, 25084, 25062, 25707, 25708, 25709, 25663
10630, 25062, 25084, 25085, 25063, 25709, 25710, 25711, 25665
10631, 25063, 25085, 25086, 25064, 25711, 25712, 25713, 25667
10632, 25064, 25086, 25087, 25065, 25713, 25714, 25715, 25669
10633, 25065, 25087, 25088, 25066, 25715, 25716, 25717, 25671
10634, 25066, 25088, 25089, 25067, 25717, 25718, 25719, 25673
10635, 25067, 25089, 25090, 25068, 25719, 25720, 25721, 25675
10636, 25068, 25090, 25091, 25069, 25721, 25722, 25723, 25677
10637, 25069, 25091, 25092, 25070, 25723, 25724, 25725, 25679
10638, 25070, 25092, 25093, 25071, 25725, 25726, 25727, 25681
10639, 25071, 25093, 25094, 25072, 25727, 25728, 25729, 25683
10640, 25072, 25094, 25095, 25073, 25729, 25730, 25731, 25685
10641, 25073, 25095, 25096, 25074, 25731, 25732, 25733, 25687
10642, 25074, 25096, 25097, 25075, 25733, 25734, 25735, 25689
10643, 25075, 25097, 25098, 25076, 25735, 25736, 25737, 25691
10644, 25076, 25098, 25099, 25077, 25737, 25738, 25739, 25693
10645, 25077, 25099, 25100, 25078, 25739, 25740, 25741, 25695
10646, 25078, 25100, 25101, 25079, 25741, 25742, 25743, 25697
10647, 25079, 25101, 25102, 25080, 25743, 25744, 25745, 25699
10648, 25080, 25102, 25103, 25081, 25745, 25746, 25747, 25701
10649, 25081, 25103, 3188, 3187, 25747, 25748, 3210, 25703
10650, 3143, 3144, 25104, 25082, 3166, 25749, 25750, 25704
10651, 25082, 25104, 25105, 25083, 25750, 25751, 25752, 25706
10652, 25083, 25105, 25106, 25084, 25752, 25753, 25754, 25708
10653, 25084, 25106, 25107, 25085, 25754, 25755, 25756, 25710
10654, 25085, 25107, 25108, 25086, 25756, 25757, 25758, 25712
10655, 25086, 25108, 25109, 25087, 25758, 25759, 25760, 25714
10656, 25087, 25109, 25110, 25088, 25760, 25761, 25762, 25716
10657, 25088, 25110, 25111, 25089, 25762, 25763, 25764, 25718
10658, 25089, 25111, 25112, 25090, 25764, 25765, 25766, 25720
10659, 25090, 25112, 25113, 25091, 25766, 25767, 25768, 25722
10660, 25091, 25113, 25114, 25092, 25768, 25769, 25770, 25724
10661, 25092, 25114, 25115, 25093, 25770, 25771, 25772, 25726
10662, 25093, 25115, 25116, 25094, 25772, 25773, 25774, 25728
10663, 25094, 25116, 25117, 25095, 25774, 25775, 25776, 25730
10664, 25095, 25117, 25118, 25096, 25776, 25777, 25778, 25732
10665, 25096, 25118, 25119, 25097, 25778, 25779, 25780, 25734
10666, 25097, 25119, 25120, 25098, 25780, 25781, 25782, 25736
10667, 25098, 25120, 25121, 25099, 25782, 25783, 25784, 25738
10668, 25099, 25121, 25122, 25100, 25784, 25785, 25786, 25740
10669, 25100, 25122, 25123, 25101, 25786, 25787, 25788, 25742
10670, 25101, 25123, 25124, 25102, 25788, 25789, 25790, 25744
10671, 25102, 25124, 25125, 25103, 25790, 25791, 25792, 25746
10672, 25103, 25125, 3189, 3188, 25792, 25793, 3211, 25748
10673, 3144, 3145, 25126, 25104, 3167, 25794, 25795, 25749
10674, 25104, 25126, 25127, 25105, 25795, 25796, 25797, 25751
10675, 25105, 25127, 25128, 25106, 25797, 25798, 25799, 25753
10676, 25106, 25128, 25129, 25107, 25799, 25800, 25801, 25755
10677, 25107, 25129, 25130, 25108, 25801, 25802, 25803, 25757
10678, 25108, 25130, 25131, 25109, 25803, 25804, 25805, 25759
10679, 25109, 25131, 25132, 25110, 25805, 25806, 25807, 25761
10680, 25110, 25132, 25133, 25111, 25807, 25808, 25809, 25763
10681, 25111, 25133, 25134, 25112, 25809, 25810, 25811, 25765
10682, 25112, 25134, 25135, 25113, 25811, 25812, 25813, 25767
10683, 25113, 25135, 25136, 25114, 25813, 25814, 25815, 25769
10684, 25114, 25136, 25137, 25115, 25815, 25816, 25817, 25771
10685, 25115, 25137, 25138, 25116, 25817, 25818, 25819, 25773
10686, 25116, 25138, 25139, 25117, 25819, 25820, 25821, 25775
10687, 25117, 25139, 25140, 25118, 25821, 25822, 25823, 25777
10688, 25118, 25140, 25141, 25119, 25823, 25824, 25825, 25779
10689, 25119, 25141, 25142, 25120, 25825, 25826, 25827, 25781
10690, 25120, 25142, 25143, 25121, 25827, 25828, 25829, 25783
10691, 25121, 25143, 25144, 25122, 25829, 25830, 25831, 25785
10692, 25122, 25144, 25145, 25123, 25831, 25832, 25833, 25787
10693, 25123, 25145, 25146, 25124, 25833, 25834, 25835, 25789
10694, 25124, 25146, 25147, 25125, 25835, 25836, 25837, 25791
10695, 25125, 25147, 3190, 3189, 25837, 25838, 3212, 25793
10696, 3145, 3146, 25148, 25126, 3168, 25839, 25840, 25794
10697, 25126, 25148, 25149, 25127, 25840, 25841, 25842, 25796
10698, 25127, 25149, 25150, 25128, 25842, 25843, 25844, 25798
10699, 25128, 25150, 25151, 25129, 25844, 25845, 25846, 25800
10700, 25129, 25151, 25152, 25130, 25846, 25847, 25848, 25802
10701, 25130, 25152, 25153, 25131, 25848, 25849, 25850, 25804
10702, 25131, 25153, 25154, 25132, 25850, 25851, 25852, 25806
10703, 25132, 25154, 25155, 25133, 25852, 25853, 25854, 25808
10704, 25133, 25155, 25156, 25134, 25854, 25855, 25856, 25810
10705, 25134, 25156, 25157, 25135, 25856, 25857, 25858, 25812
10706, 25135, 25157, 25158, 25136, 25858, 25859, 25860, 25814
10707, 25136, 25158, 25159, 25137, 25860, 25861, 25862, 25816
10708, 25137, 25159, 25160, 25138, 25862, 25863, 25864, 25818
10709, 25138, 25160, 25161, 25139, 25864, 25865, 25866, 25820
10710, 25139, 25161, 25162, 25140, 25866, 25867, 25868, 25822
10711, 25140, 25162, 25163, 25141, 25868, 25869, 25870, 25824
10712, 25141, 25163, 25164, 25142, 25870, 25871, 25872, 25826
10713, 25142, 25164, 25165, 25143, 25872, 25873, 25874, 25828
10714, 25143, 25165, 25166, 25144, 25874, 25875, 25876, 25830
10715, 25144, 25166, 25167, 25145, 25876, 25877, 25878, 25832
10716, 25145, 25167, 25168, 25146, 25878, 25879, 25880, 25834
10717, 25146, 25168, 25169, 25147, 25880, 25881, 25882, 25836
10718, 25147, 25169, 3191, 3190, 25882, 25883, 3213, 25838
10719, 3146, 3147, 25170, 25148, 3169, 25884, 25885, 25839
10720, 25148, 25170, 25171, 25149, 25885, 25886, 25887, 25841
10721, 25149, 25171, 25172, 25150, 25887, 25888, 25889, 25843
10722, 25150, 25172, 25173, 25151, 25889, 25890, 25891, 25845
10723, 25151, 25173, 25174, 25152, 25891, 25892, 25893, 25847
10724, 25152, 25174, 25175, 25153, 25893, 25894, 25895, 25849
10725, 25153, 25175, 25176, 25154, 25895, 25896, 25897, 25851
10726, 25154, 25176, 25177, 25155, 25897, 25898, 25899, 25853
10727, 25155, 25177, 25178, 25156, 25899, 25900, 25901, 25855
10728, 25156, 25178, 25179, 25157, 25901, 25902, 25903, 25857
10729, 25157, 25179, 25180, 25158, 25903, 25904, 25905, 25859
10730, 25158, 25180, 25181, 25159, 25905, 25906, 25907, 25861
10731, 25159, 25181, 25182, 25160, 25907, 25908, 25909, 25863
10732, 25160, 25182, 25183, 25161, 25909, 25910, 25911, 25865
10733, 25161, 25183, 25184, 25162, 25911, 25912, 25913, 25867
10734, 25162, 25184, 25185, 25163, 25913, 25914, 25915, 25869
10735, 25163, 25185, 25186, 25164, 25915, 25916, 25917, 25871
10736, 25164, 25186, 25187, 25165, 25917, 25918, 25919, 25873
10737, 25165, 25187, 25188, 25166, 25919, 25920, 25921, 25875
10738, 25166, 25188, 25189, 25167, 25921, 25922, 25923, 25877
10739, 25167, 25189, 25190, 25168, 25923, 25924, 25925, 25879
10740, 25168, 25190, 25191, 25169, 25925, 25926, 25927, 25881
10741, 25169, 25191, 3192, 3191, 25927, 25928, 3214, 25883
10742, 3147, 3148, 25192, 25170, 3170, 25929, 25930, 25884
10743, 25170, 25192, 25193, 25171, 25930, 25931, 25932, 25886
10744, 25171, 25193, 25194, 25172, 25932, 25933, 25934, 25888
10745, 25172, 25194, 25195, 25173, 25934, 25935, 25936, 25890
10746, 25173, 25195, 25196, 25174, 25936, 25937, 25938, 25892
10747, 25174, 25196, 25197, 25175, 25938, 25939, 25940, 25894
10748, 25175, 25197, 25198, 25176, 25940, 25941, 25942, 25896
10749, 25176, 25198, 25199, 25177, 25942, 25943, 25944, 25898
10750, 25177, 25199, 25200, 25178, 25944, 25945, 25946, 25900
10751, 25178, 25200, 25201, 25179, 25946, 25947, 25948, 25902
10752, 25179, 25201, 25202, 25180, 25948, 25949, 25950, 25904
10753, 25180, 25202, 25203, 25181, 25950, 25951, 25952, 25906
10754, 25181, 25203, 25204, 25182, 25952, 25953, 25954, 25908
10755, 25182, 25204, 25205, 25183, 25954, 25955, 25956, 25910
10756, 25183, 25205, 25206, 25184, 25956, 25957, 25958, 25912
10757, 25184, 25206, 25207, 25185, 25958, 25959, 25960, 25914
10758, 25185, 25207, 25208, 25186, 25960, 25961, 25962, 25916
10759, 25186, 25208, 25209, 25187, 25962, 25963, 25964, 25918
10760, 25187, 25209, 25210, 25188, 25964, 25965, 25966, 25920
10761, 25188, 25210, 25211, 25189, 25966, 25967, 25968, 25922
10762, 25189, 25211, 25212, 25190, 25968, 25969, 25970, 25924
10763, 25190, 25212, 25213, 25191, 25970, 25971, 25972, 25926
10764, 25191, 25213, 3193, 3192, 25972, 25973, 3215, 25928
10765, 3148, 3149, 25214, 25192, 3171, 25974, 25975, 25929
10766, 25192, 25214, 25215, 25193, 25975, 25976, 25977, 25931
10767, 25193, 25215, 25216, 25194, 25977, 25978, 25979, 25933
10768, 25194, 25216, 25217, 25195, 25979, 25980, 25981, 25935
10769, 25195, 25217, 25218, 25196, 25981, 25982, 25983, 25937
10770, 25196, 25218, 25219, 25197, 25983, 25984, 25985, 25939
10771, 25197, 25219, 25220, 25198, 25985, 25986, 25987, 25941
10772, 25198, 25220, 25221, 25199, 25987, 25988, 25989, 25943
10773, 25199, 25221, 25222, 25200, 25989, 25990, 25991, 25945
10774, 25200, 25222, 25223, 25201, 25991, 25992, 25993, 25947
10775, 25201, 25223, 25224, 25202, 25993, 25994, 25995, 25949
10776, 25202, 25224, 25225, 25203, 25995, 25996, 25997, 25951
10777, 25203, 25225, 25226, 25204, 25997, 25998, 25999, 25953
10778, 25204, 25226, 25227, 25205, 25999, 26000, 26001, 25955
10779, 25205, 25227, 25228, 25206, 26001, 26002, 26003, 25957
10780, 25206, 25228, 25229, 25207, 26003, 26004, 26005, 25959
10781, 25207, 25229, 25230, 25208, 26005, 26006, 26007, 25961
10782, 25208, 25230, 25231, 25209, 26007, 26008, 26009, 25963
10783, 25209, 25231, 25232, 25210, 26009, 26010, 26011, 25965
10784, 25210, 25232, 25233, 25211, 26011, 26012, 26013, 25967
10785, 25211, 25233, 25234, 25212, 26013, 26014, 26015, 25969
10786, 25212, 25234, 25235, 25213, 26015, 26016, 26017, 25971
10787, 25213, 25235, 3194, 3193, 26017, 26018, 3216, 25973
10788, 3149, 3150, 25236, 25214, 3172, 26019, 26020, 25974
10789, 25214, 25236, 25237, 25215, 26020, 26021, 26022, 25976
10790, 25215, 25237, 25238, 25216, 26022, 26023, 26024, 25978
10791, 25216, 25238, 25239, 25217, 26024, 26025, 26026, 25980
10792, 25217, 25239, 25240, 25218, 26026, 26027, 26028, 25982
10793, 25218, 25240, 25241, 25219, 26028, 26029, 26030, 25984
10794, 25219, 25241, 25242, 25220, 26030, 26031, 26032, 25986
10795, 25220, 25242, 25243, 25221, 26032, 26033, 26034, 25988
10796, 25221, 25243, 25244, 25222, 26034, 26035, 26036, 25990
10797, 25222, 25244, 25245, 25223, 26036, 26037, 26038, 25992
10798, 25223, 25245, 25246, 25224, 26038, 26039, 26040, 25994
10799, 25224, 25246, 25247, 25225, 26040, 26041, 26042, 25996
10800, 25225, 25247, 25248, 25226, 26042, 26043, 26044, 25998
10801, 25226, 25248, 25249, 25227, 26044, 26045, 26046, 26000
10802, 25227, 25249, 25250, 25228, 26046, 26047, 26048, 26002
10803, 25228, 25250, 25251, 25229, 26048, 26049, 26050, 26004
10804, 25229, 25251, 25252, 25230, 26050, 26051, 26052, 26006
10805, 25230, 25252, 25253, 25231, 26052, 26053, 26054, 26008
10806, 25231, 25253, 25254, 25232, 26054, 26055, 26056, 26010
10807, 25232, 25254, 25255, 25233, 26056, 26057, 26058, 26012
10808, 25233, 25255, 25256, 25234, 26058, 26059, 26060, 26014
10809, 25234, 25256, 25257, 25235, 26060, 26061, 26062, 26016
10810, 25235, 25257, 3195, 3194, 26062, 26063, 3217, 26018
10811, 3150, 3151, 25258, 25236, 3173, 26064, 26065, 26019
10812, 25236, 25258, 25259, 25237, 26065, 26066, 26067, 26021
10813, 25237, 25259, 25260, 25238, 26067, 26068, 26069, 26023
10814, 25238, 25260, 25261, 25239, 26069, 26070, 26071, 26025
10815, 25239, 25261, 25262, 25240, 26071, 26072, 26073, 26027
10816, 25240, 25262, 25263, 25241, 26073, 26074, 26075, 26029
10817, 25241, 25263, 25264, 25242, 26075, 26076, 26077, 26031
10818, 25242, 25264, 25265, 25243, 26077, 26078, 26079, 26033
10819, 25243, 25265, 25266, 25244, 26079, 26080, 26081, 26035
10820, 25244, 25266, 25267, 25245, 26081, 26082, 26083, 26037
10821, 25245, 25267, 25268, 25246, 26083, 26084, 26085, 26039
10822, 25246, 25268, 25269, 25247, 26085, 26086, 26087, 26041
10823, 25247, 25269, 25270, 25248, 26087, 26088, 26089, 26043
10824, 25248, 25270, 25271, 25249, 26089, 26090, 26091, 26045
10825, 25249, 25271, 25272, 25250, 26091, 26092, 26093, 26047
10826, 25250, 25272, 25273, 25251, 26093, 26094, 26095, 26049
10827, 25251, 25273, 25274, 25252, 26095, 26096, 26097, 26051
10828, 25252, 25274, 25275, 25253, 26097, 26098, 26099, 26053
10829, 25253, 25275, 25276, 25254, 26099, 26100, 26101, 26055
10830, 25254, 25276, 25277, 25255, 26101, 26102, 26103, 26057
10831, 25255, 25277, 25278, 25256, 26103, 26104, 26105, 26059
10832, 25256, 25278, 25279, 25257, 26105, 26106, 26107, 26061
10833, 25257, 25279, 3196, 3195, 26107, 26108, 3218, 26063
10834, 3151, 3152, 25280, 25258, 3174, 26109, 26110, 26064
10835, 25258, 25280, 25281, 25259, 26110, 26111, 26112, 26066
10836, 25259, 25281, 25282, 25260, 26112, 26113, 26114, 26068
10837, 25260, 25282, 25283, 25261, 26114, 26115, 26116, 26070
10838, 25261, 25283, 25284, 25262, 26116, 26117, 26118, 26072
10839, 25262, 25284, 25285, 25263, 26118, 26119, 26120, 26074
10840, 25263, 25285, 25286, 25264, 26120, 26121, 26122, 26076
10841, 25264, 25286, 25287, 25265, 26122, 26123, 26124, 26078
10842, 25265, 25287, 25288, 25266, 26124, 26125, 26126, 26080
10843, 25266, 25288, 25289, 25267, 26126, 26127, 26128, 26082
10844, 25267, 25289, 25290, 25268, 26128, 26129, 26130, 26084
10845, 25268, 25290, 25291, 25269, 26130, 26131, 26132, 26086
10846, 25269, 25291, 25292, 25270, 26132, 26133, 26134, 26088
10847, 25270, 25292, 25293, 25271, 26134, 26135, 26136, 26090
10848, 25271, 25293, 25294, 25272, 26136, 26137, 26138, 26092
10849, 25272, 25294, 25295, 25273, 26138, 26139, 26140, 26094
10850, 25273, 25295, 25296, 25274, 26140, 26141, 26142, 26096
10851, 25274, 25296, 25297, 25275, 26142, 26143, 26144, 26098
10852, 25275, 25297, 25298, 25276, 26144, 26145, 26146, 26100
10853, 25276, 25298, 25299, 25277, 26146, 26147, 26148, 26102
10854, 25277, 25299, 25300, 25278, 26148, 26149, 26150, 26104
10855, 25278, 25300, 25301, 25279, 26150, 26151, 26152, 26106
10856, 25279, 25301, 3197, 3196, 26152, 26153, 3219, 26108
10857, 3152, 3153, 25302, 25280, 3175, 26154, 26155, 26109
10858, 25280, 25302, 25303, 25281, 26155, 26156, 26157, 26111
10859, 25281, 25303, 25304, 25282, 26157, 26158, 26159, 26113
10860, 25282, 25304, 25305, 25283, 26159, 26160, 26161, 26115
10861, 25283, 25305, 25306, 25284, 26161, 26162, 26163, 26117
10862, 25284, 25306, 25307, 25285, 26163, 26164, 26165, 26119
10863, 25285, 25307, 25308, 25286, 26165, 26166, 26167, 26121
10864, 25286, 25308, 25309, 25287, 26167, 26168, 26169, 26123
10865, 25287, 25309, 25310, 25288, 26169, 26170, 26171, 26125
10866, 25288, 25310, 25311, 25289, 26171, 26172, 26173, 26127
10867, 25289, 25311, 25312, 25290, 26173, 26174, 26175, 26129
10868, 25290, 25312, 25313, 25291, 26175, 26176, 26177, 26131
10869, 25291, 25313, 25314, 25292, 26177, 26178, 26179, 26133
10870, 25292, 25314, 25315, 25293, 26179, 26180, 26181, 26135
10871, 25293, 25315, 25316, 25294, 26181, 26182, 26183, 26137
10872, 25294, 25316, 25317, 25295, 26183, 26184, 26185, 26139
10873, 25295, 25317, 25318, 25296, 26185, 26186, 26187, 26141
10874, 25296, 25318, 25319, 25297, 26187, 26188, 26189, 26143
10875, 25297, 25319, 25320, 25298, 26189, 26190, 26191, 26145
10876, 25298, 25320, 25321, 25299, 26191, 26192, 26193, 26147
10877, 25299, 25321, 25322, 25300, 26193, 26194, 26195, 26149
10878, 25300, 25322, 25323, 25301, 26195, 26196, 26197, 26151
10879, 25301, 25323, 3198, 3197, 26197, 26198, 3220, 26153
10880, 3153, 3154, 25324, 25302, 3176, 26199, 26200, 26154
10881, 25302, 25324, 25325, 25303, 26200, 26201, 26202, 26156
10882, 25303, 25325, 25326, 25304, 26202, 26203, 26204, 26158
10883, 25304, 25326, 25327, 25305, 26204, 26205, 26206, 26160
10884, 25305, 25327, 25328, 25306, 26206, 26207, 26208, 26162
10885, 25306, 25328, 25329, 25307, 26208, 26209, 26210, 26164
10886, 25307, 25329, 25330, 25308, 26210, 26211, 26212, 26166
10887, 25308, 25330, 25331, 25309, 26212, 26213, 26214, 26168
10888, 25309, 25331, 25332, 25310, 26214, 26215, 26216, 26170
10889, 25310, 25332, 25333, 25311, 26216, 26217, 26218, 26172
10890, 25311, 25333, 25334, 25312, 26218, 26219, 26220, 26174
10891, 25312, 25334, 25335, 25313, 26220, 26221, 26222, 26176
10892, 25313, 25335, 25336, 25314, 26222, 26223, 26224, 26178
10893, 25314, 25336, 25337, 25315, 26224, 26225, 26226, 26180
10894, 25315, 25337, 25338, 25316, 26226, 26227, 26228, 26182
10895, 25316, 25338, 25339, 25317, 26228, 26229, 26230, 26184
10896, 25317, 25339, 25340, 25318, 26230, 26231, 26232, 26186
10897, 25318, 25340, 25341, 25319, 26232, 26233, 26234, 26188
10898, 25319, 25341, 25342, 25320, 26234, 26235, 26236, 26190
10899, 25320, 25342, 25343, 25321, 26236, 26237, 26238, 26192
10900, 25321, 25343, 25344, 25322, 26238, 26239, 26240, 26194
10901, 25322, 25344, 25345, 25323, 26240, 26241, 26242, 26196
10902, 25323, 25345, 3199, 3198, 26242, 26243, 3221, 26198
10903, 3154, 3155, 25346, 25324, 3177, 26244, 26245, 26199
10904, 25324, 25346, 25347, 25325, 26245, 26246, 26247, 26201
10905, 25325, 25347, 25348, 25326, 26247, 26248, 26249, 26203
10906, 25326, 25348, 25349, 25327, 26249, 26250, 26251, 26205
10907, 25327, 25349, 25350, 25328, 26251, 26252, 26253, 26207
10908, 25328, 25350, 25351, 25329, 26253, 26254, 26255, 26209
10909, 25329, 25351, 25352, 25330, 26255, 26256, 26257, 26211
10910, 25330, 25352, 25353, 25331, 26257, 26258, 26259, 26213
10911, 25331, 25353, 25354, 25332, 26259, 26260, 26261, 26215
10912, 25332, 25354, 25355, 25333, 26261, 26262, 26263, 26217
10913, 25333, 25355, 25356, 25334, 26263, 26264, 26265, 26219
10914, 25334, 25356, 25357, 25335, 26265, 26266, 26267, 26221
10915, 25335, 25357, 25358, 25336, 26267, 26268, 26269, 26223
10916, 25336, 25358, 25359, 25337, 26269, 26270, 26271, 26225
10917, 25337, 25359, 25360, 25338, 26271, 26272, 26273, 26227
10918, 25338, 25360, 25361, 25339, 26273, 26274, 26275, 26229
10919, 25339, 25361, 25362, 25340, 26275, 26276, 26277, 26231
10920, 25340, 25362, 25363, 25341, 26277, 26278, 26279, 26233
10921, 25341, 25363, 25364, 25342, 26279, 26280, 26281, 26235
10922, 25342, 25364, 25365, 25343, 26281, 26282, 26283, 26237
10923, 25343, 25365, 25366, 25344, 26283, 26284, 26285, 26239
10924, 25344, 25366, 25367, 25345, 26285, 26286, 26287, 26241
10925, 25345, 25367, 3200, 3199, 26287, 26288, 3222, 26243
10926, 3155, 3156, 25368, 25346, 3178, 26289, 26290, 26244
10927, 25346, 25368, 25369, 25347, 26290, 26291, 26292, 26246
10928, 25347, 25369, 25370, 25348, 26292, 26293, 26294, 26248
10929, 25348, 25370, 25371, 25349, 26294, 26295, 26296, 26250
10930, 25349, 25371, 25372, 25350, 26296, 26297, 26298, 26252
10931, 25350, 25372, 25373, 25351, 26298, 26299, 26300, 26254
10932, 25351, 25373, 25374, 25352, 26300, 26301, 26302, 26256
10933, 25352, 25374, 25375, 25353, 26302, 26303, 26304, 26258
10934, 25353, 25375, 25376, 25354, 26304, 26305, 26306, 26260
10935, 25354, 25376, 25377, 25355, 26306, 26307, 26308, 26262
10936, 25355, 25377, 25378, 25356, 26308, 26309, 26310, 26264
10937, 25356, 25378, 25379, 25357, 26310, 26311, 26312, 26266
10938, 25357, 25379, 25380, 25358, 26312, 26313, 26314, 26268
10939, 25358, 25380, 25381, 25359, 26314, 26315, 26316, 26270
10940, 25359, 25381, 25382, 25360, 26316, 26317, 26318, 26272
10941, 25360, 25382, 25383, 25361, 26318, 26319, 26320, 26274
10942, 25361, 25383, 25384, 25362, 26320, 26321, 26322, 26276
10943, 25362, 25384, 25385, 25363, 26322, 26323, 26324, 26278
10944, 25363, 25385, 25386, 25364, 26324, 26325, 26326, 26280
10945, 25364, 25386, 25387, 25365, 26326, 26327, 26328, 26282
10946, 25365, 25387, 25388, 25366, 26328, 26329, 26330, 26284
10947, 25366, 25388, 25389, 25367, 26330, 26331, 26332, 26286
10948, 25367, 25389, 3201, 3200, 26332, 26333, 3223, 26288
10949, 3156, 3157, 25390, 25368, 3179, 26334, 26335, 26289
10950, 25368, 25390, 25391, 25369, 26335, 26336, 26337, 26291
10951, 25369, 25391, 25392, 25370, 26337, 26338, 26339, 26293
10952, 25370, 25392, 25393, 25371, 26339, 26340, 26341, 26295
10953, 25371, 25393, 25394, 25372, 26341, 26342, 26343, 26297
10954, 25372, 25394, 25395, 25373, 26343, 26344, 26345, 26299
10955, 25373, 25395, 25396, 25374, 26345, 26346, 26347, 26301
10956, 25374, 25396, 25397, 25375, 26347, 26348, 26349, 26303
10957, 25375, 25397, 25398, 25376, 26349, 26350, 26351, 26305
10958, 25376, 25398, 25399, 25377, 26351, 26352, 26353, 26307
10959, 25377, 25399, 25400, 25378, 26353, 26354, 26355, 26309
10960, 25378, 25400, 25401, 25379, 26355, 26356, 26357, 26311
10961, 25379, 25401, 25402, 25380, 26357, 26358, 26359, 26313
10962, 25380, 25402, 25403, 25381, 26359, 26360, 26361, 26315
10963, 25381, 25403, 25404, 25382, 26361, 26362, 26363, 26317
10964, 25382, 25404, 25405, 25383, 26363, 26364, 26365, 26319
10965, 25383, 25405, 25406, 25384, 26365, 26366, 26367, 26321
10966, 25384, 25406, 25407, 25385, 26367, 26368, 26369, 26323
10967, 25385, 25407, 25408, 25386, 26369, 26370, 26371, 26325
10968, 25386, 25408, 25409, 25387, 26371, 26372, 26373, 26327
10969, 25387, 25409, 25410, 25388, 26373, 26374, 26375, 26329
10970, 25388, 25410, 25411, 25389, 26375, 26376, 26377, 26331
10971, 25389, 25411, 3202, 3201, 26377, 26378, 3224, 26333
10972, 3157, 3158, 25412, 25390, 3180, 26379, 26380, 26334
10973, 25390, 25412, 25413, 25391, 26380, 26381, 26382, 26336
10974, 25391, 25413, 25414, 25392, 26382, 26383, 26384, 26338
10975, 25392, 25414, 25415, 25393, 26384, 26385, 26386, 26340
10976, 25393, 25415, 25416, 25394, 26386, 26387, 26388, 26342
10977, 25394, 25416, 25417, 25395, 26388, 26389, 26390, 26344
10978, 25395, 25417, 25418, 25396, 26390, 26391, 26392, 26346
10979, 25396, 25418, 25419, 25397, 26392, 26393, 26394, 26348
10980, 25397, 25419, 25420, 25398, 26394, 26395, 26396, 26350
10981, 25398, 25420, 25421, 25399, 26396, 26397, 26398, 26352
10982, 25399, 25421, 25422, 25400, 26398, 26399, 26400, 26354
10983, 25400, 25422, 25423, 25401, 26400, 26401, 26402, 26356
10984, 25401, 25423, 25424, 25402, 26402, 26403, 26404, 26358
10985, 25402, 25424, 25425, 25403, 26404, 26405, 26406, 26360
10986, 25403, 25425, 25426, 25404, 26406, 26407, 26408, 26362
10987, 25404, 25426, 25427, 25405, 26408, 26409, 26410, 26364
10988, 25405, 25427, 25428, 25406, 26410, 26411, 26412, 26366
10989, 25406, 25428, 25429, 25407, 26412, 26413, 26414, 26368
10990, 25407, 25429, 25430, 25408, 26414, 26415, 26416, 26370
10991, 25408, 25430, 25431, 25409, 26416, 26417, 26418, 26372
10992, 25409, 25431, 25432, 25410, 26418, 26419, 26420, 26374
10993, 25410, 25432, 25433, 25411, 26420, 26421, 26422, 26376
10994, 25411, 25433, 3203, 3202, 26422, 26423, 3225, 26378
10995, 3158, 5, 245, 25412, 3181, 267, 26424, 26379
10996, 25412, 245, 246, 25413, 26424, 268, 26425, 26381
10997, 25413, 246, 247, 25414, 26425, 269, 26426, 26383
10998, 25414, 247, 248, 25415, 26426, 270, 26427, 26385
10999, 25415, 248, 249, 25416, 26427, 271, 26428, 26387
11000, 25416, 249, 250, 25417, 26428, 272, 26429, 26389
11001, 25417, 250, 251, 25418, 26429, 273, 26430, 26391
11002, 25418, 251, 252, 25419, 26430, 274, 26431, 26393
11003, 25419, 252, 253, 25420, 26431, 275, 26432, 26395
11004, 25420, 253, 254, 25421, 26432, 276, 26433, 26397
11005, 25421, 254, 255, 25422, 26433, 277, 26434, 26399
11006, 25422, 255, 256, 25423, 26434, 278, 26435, 26401
11007, 25423, 256, 257, 25424, 26435, 279, 26436, 26403
11008, 25424, 257, 258, 25425, 26436, 280, 26437, 26405
11009, 25425, 258, 259, 25426, 26437, 281, 26438, 26407
11010, 25426, 259, 260, 25427, 26438, 282, 26439, 26409
11011, 25427, 260, 261, 25428, 26439, 283, 26440, 26411
11012, 25428, 261, 262, 25429, 26440, 284, 26441, 26413
11013, 25429, 262, 263, 25430, 26441, 285, 26442, 26415
11014, 25430, 263, 264, 25431, 26442, 286, 26443, 26417
11015, 25431, 264, 265, 25432, 26443, 287, 26444, 26419
11016, 25432, 265, 266, 25433, 26444, 288, 26445, 26421
11017, 25433, 266, 6, 3203, 26445, 289, 3226, 26423
*ELEMENT, type=CPS8, ELSET=Surface266
11018, 95, 3362, 26446, 3272, 3384, 26930, 26931, 3294
11019, 3362, 3363, 26447, 26446, 3385, 26932, 26933, 26930
11020, 3363, 3364, 26448, 26447, 3386, 26934, 26935, 26932
11021, 3364, 3365, 26449, 26448, 3387, 26936, 26937, 26934
11022, 3365, 3366, 26450, 26449, 3388, 26938, 26939, 26936
11023, 3366, 3367, 26451, 26450, 3389, 26940, 26941, 26938
11024, 3367, 3368, 26452, 26451, 3390, 26942, 26943, 26940
11025, 3368, 3369, 26453, 26452, 3391, 26944, 26945, 26942
11026, 3369, 3370, 26454, 26453, 3392, 26946, 26947, 26944
11027, 3370, 3371, 26455, 26454, 3393, 26948, 26949, 26946
11028, 3371, 3372, 26456, 26455, 3394, 26950, 26951, 26948
11029, 3372, 3373, 26457, 26456, 3395, 26952, 26953, 26950
11030, 3373, 3374, 26458, 26457, 3396, 26954, 26955, 26952
11031, 3374, 3375, 26459, 26458, 3397, 26956, 26957, 26954
11032, 3375, 3376, 26460, 26459, 3398, 26958, 26959, 26956
11033, 3376, 3377, 26461, 26460, 3399, 26960, 26961, 26958
11034, 3377, 3378, 26462, 26461, 3400, 26962, 26963, 26960
11035, 3378, 3379, 26463, 26462, 3401, 26964, 26965, 26962
11036, 3379, 3380, 26464, 26463, 3402, 26966, 26967, 26964
11037, 3380, 3381, 26465, 26464, 3403, 26968, 26969, 26966
11038, 3381, 3382, 26466, 26465, 3404, 26970, 26971, 26968
11039, 3382, 3383, 26467, 26466, 3405, 26972, 26973, 26970
11040, 3383, 96, 3317, 26467, 3406, 3339, 26974, 26972
11041, 3272, 26446, 26468, 3273, 26931, 26975, 26976, 3295
11042, 26446, 26447, 26469, 26468, 26933, 26977, 26978, 26975
11043, 26447, 26448, 26470, 26469, 26935, 26979, 26980, 26977
11044, 26448, 26449, 26471, 26470, 26937, 26981, 26982, 26979
11045, 26449, 26450, 26472, 26471, 26939, 26983, 26984, 26981
11046, 26450, 26451, 26473, 26472, 26941, 26985, 26986, 26983
11047, 26451, 26452, 26474, 26473, 26943, 26987, 26988, 26985
11048, 26452, 26453, 26475, 26474, 26945, 26989, 26990, 26987
11049, 26453, 26454, 26476, 26475, 26947, 26991, 26992, 26989
11050, 26454, 26455, 26477, 26476, 26949, 26993, 26994, 26991
11051, 26455, 26456, 26478, 26477, 26951, 26995, 26996, 26993
11052, 26456, 26457, 26479, 26478, 26953, 26997, 26998, 26995
11053, 26457, 26458, 26480, 26479, 26955, 26999, 27000, 26997
11054, 26458, 26459, 26481, 26480, 26957, 27001, 27002, 26999
11055, 26459, 26460, 26482, 26481, 26959, 27003, 27004, 27001
11056, 26460, 26461, 26483, 26482, 26961, 27005, 27006, 27003
11057, 26461, 26462, 26484, 26483, 26963, 27007, 27008, 27005
11058, 26462, 26463, 26485, 26484, 26965, 27009, 27010, 27007
11059, 26463, 26464, 26486, 26485, 26967, 27011, 27012, 27009
11060, 26464, 26465, 26487, 26486, 26969, 27013, 27014, 27011
11061, 26465, 26466, 26488, 26487, 26971, 27015, 27016, 27013
11062, 26466, 26467, 26489, 26488, 26973, 27017, 27018, 27015
11063, 26467, 3317, 3318, 26489, 26974, 3340, 27019, 27017
11064, 3273, 26468, 26490, 3274, 26976, 27020, 27021, 3296
11065, 26468, 26469, 26491, 26490, 26978, 27022, 27023, 27020
11066, 26469, 26470, 26492, 26491, 26980, 27024, 27025, 27022
11067, 26470, 26471, 26493, 26492, 26982, 27026, 27027, 27024
11068, 26471, 26472, 26494, 26493, 26984, 27028, 27029, 27026
11069, 26472, 26473, 26495, 26494, 26986, 27030, 27031, 27028
11070, 26473, 26474, 26496, 26495, 26988, 27032, 27033, 27030
11071, 26474, 26475, 26497, 26496, 26990, 27034, 27035, 27032
11072, 26475, 26476, 26498, 26497, 26992, 27036, 27037, 27034
11073, 26476, 26477, 26499, 26498, 26994, 27038, 27039, 27036
11074, 26477, 26478, 26500, 26499, 26996, 27040, 27041, 27038
11075, 26478, 26479, 26501, 26500, 26998, 27042, 27043, 27040
11076, 26479, 26480, 26502, 26501, 27000, 27044, 27045, 27042
11077, 26480, 26481, 26503, 26502, 27002, 27046, 27047, 27044
11078, 26481, 26482, 26504, 26503, 27004, 27048, 27049, 27046
11079, 26482, 26483, 26505, 26504, 27006, 27050, 27051, 27048
11080, 26483, 26484, 26506, 26505, 27008, 27052, 27053, 27050
11081, 26484, 26485, 26507, 26506, 27010, 27054, 27055, 27052
11082, 26485, 26486, 26508, 26507, 27012, 27056, 27057, 27054
11083, 26486, 26487, 26509, 26508, 27014, 27058, 27059, 27056
11084, 26487, 26488, 26510, 26509, 27016, 27060, 27061, 27058
11085, 26488, 26489, 26511, 26510, 27018, 27062, 27063, 27060
11086, 26489, 3318, 3319, 26511, 27019, 3341, 27064, 27062
11087, 3274, 26490, 26512, 3275, 27021, 27065, 27066, 3297
11088, 26490, 26491, 26513, 26512, 27023, 27067, 27068, 27065
11089, 26491, 26492, 26514, 26513, 27025, 27069, 27070, 27067
11090, 26492, 26493, 26515, 26514, 27027, 27071, 27072, 27069
11091, 26493, 26494, 26516, 26515, 27029, 27073, 27074, 27071
11092, 26494, 26495, 26517, 26516, 27031, 27075, 27076, 27073
11093, 26495, 26496, 26518, 26517, 27033, 27077, 27078, 27075
11094, 26496, 26497, 26519, 26518, 27035, 27079, 27080, 27077
11095, 26497, 26498, 26520, 26519, 27037, 27081, 27082, 27079
11096, 26498, 26499, 26521, 26520, 27039, 27083, 27084, 27081
11097, 26499, 26500, 26522, 26521, 27041, 27085, 27086, 27083
11098, 26500, 26501, 26523, 26522, 27043, 27087, 27088, 27085
11099, 26501, 26502, 26524, 26523, 27045, 27089, 27090, 27087
11100, 26502, 26503, 26525, 26524, 27047, 27091, 27092, 27089
11101, 26503, 26504, 26526, 26525, 27049, 27093, 27094, 27091
11102, 26504, 26505, 26527, 26526, 27051, 27095, 27096, 27093
11103, 26505, 26506, 26528, 26527, 27053, 27097, 27098, 27095
11104, 26506, 26507, 26529, 26528, 27055, 27099, 27100, 27097
11105, 26507, 26508, 26530, 26529, 27057, 27101, 27102, 27099
11106, 26508, 26509, 26531, 26530, 27059, 27103, 27104, 27101
11107, 26509, 26510, 26532, 26531, 27061, 27105, 27106, 27103
11108, 26510, 26511, 26533, 26532, 27063, 27107, 27108, 27105
11109, 26511, 3319, 3320, 26533, 27064, 3342, 27109, 27107
11110, 3275, 26512, 26534, 3276, 27066, 27110, 27111, 3298
11111, 26512, 26513, 26535, 26534, 27068, 27112, 27113, 27110
11112, 26513, 26514, 26536, 26535, 27070, 27114, 27115, 27112
11113, 26514, 26515, 26537, 26536, 27072, 27116, 27117, 27114
11114, 26515, 26516, 26538, 26537, 27074, 27118, 27119, 27116
11115, 26516, 26517, 26539, 26538, 27076, 27120, 27121, 27118
11116, 26517, 26518, 26540, 26539, 27078, 27122, 27123, 27120
11117, 26518, 26519, 26541, 26540, 27080, 27124, 27125, 27122
11118, 26519, 26520, 26542, 26541, 27082, 27126, 27127, 27124
11119, 26520, 26521, 26543, 26542, 27084, 27128, 27129, 27126
11120, 26521, 26522, 26544, 26543, 27086, 27130, 27131, 27128
11121, 26522, 26523, 26545, 26544, 27088, 27132, 27133, 27130
11122, 26523, 26524, 26546, 26545, 27090, 27134, 27135, 27132
11123, 26524, 26525, 26547, 26546, 27092, 27136, 27137, 27134
11124, 26525, 26526, 26548, 26547, 27094, 27138, 27139, 27136
11125, 26526, 26527, 26549, 26548, 27096, 27140, 27141, 27138
11126, 26527, 26528, 26550, 26549, 27098, 27142, 27143, 27140
11127, 26528, 26529, 26551, 26550, 27100, 27144, 27145, 27142
11128, 26529, 26530, 26552, 26551, 27102, 27146, 27147, 27144
11129, 26530, 26531, 26553, 26552, 27104, 27148, 27149, 27146
11130, 26531, 26532, 26554, 26553, 27106, 27150, 27151, 27148
11131, 26532, 26533, 26555, 26554, 27108, 27152, 27153, 27150
11132, 26533, 3320, 3321, 26555, 27109, 3343, 27154, 27152
11133, 3276, 26534, 26556, 3277, 27111, 27155, 27156, 3299
11134, 26534, 26535, 26557, 26556, 27113, 27157, 27158, 27155
11135, 26535, 26536, 26558, 26557, 27115, 27159, 27160, 27157
11136, 26536, 26537, 26559, 26558, 27117, 27161, 27162, 27159
11137, 26537, 26538, 26560, 26559, 27119, 27163, 27164, 27161
11138, 26538, 26539, 26561, 26560, 27121, 27165, 27166, 27163
11139, 26539, 26540, 26562, 26561, 27123, 27167, 27168, 27165
11140, 26540, 26541, 26563, 26562, 27125, 27169, 27170, 27167
11141, 26541, 26542, 26564, 26563, 27127, 27171, 27172, 27169
11142, 26542, 26543, 26565, 26564, 27129, 27173, 27174, 27171
11143, 26543, 26544, 26566, 26565, 27131, 27175, 27176, 27173
11144, 26544, 26545, 26567, 26566, 27133, 27177, 27178, 27175
11145, 26545, 26546, 26568, 26567, 27135, 27179, 27180, 27177
11146, 26546, 26547, 26569, 26568, 27137, 27181, 27182, 27179
11147, 26547, 26548, 26570, 26569, 27139, 27183, 27184, 27181
11148, 26548, 26549, 26571, 26570, 27141, 27185, 27186, 27183
11149, 26549, 26550, 26572, 26571, 27143, 27187, 27188, 27185
11150, 26550, 26551, 26573, 26572, 27145, 27189, 27190, 27187
11151, 26551, 26552, 26574, 26573, 27147, 27191, 27192, 27189
11152, 26552, 26553, 26575, 26574, 27149, 27193, 27194, 27191
11153, 26553, 26554, 26576, 26575, 27151, 27195, 27196, 27193
11154, 26554, 26555, 26577, 26576, 27153, 27197, 27198, 27195
11155, 26555, 3321, 3322, 26577, 27154, 3344, 27199, 27197
11156, 3277, 26556, 26578, 3278, 27156, 27200, 27201, 3300
11157, 26556, 26557, 26579, 26578, 27158, 27202, 27203, 27200
11158, 26557, 26558, 26580, 26579, 27160, 27204, 27205, 27202
11159, 26558, 26559, 26581, 26580, 27162, 27206, 27207, 27204
11160, 26559, 26560, 26582, 26581, 27164, 27208, 27209, 27206
11161, 26560, 26561, 26583, 26582, 27166, 27210, 27211, 27208
11162, 26561, 26562, 26584, 26583, 27168, 27212, 27213, 27210
11163, 26562, 26563, 26585, 26584, 27170, 27214, 27215, 27212
11164, 26563, 26564, 26586, 26585, 27172, 27216, 27217, 27214
11165, 26564, 26565, 26587, 26586, 27174, 27218, 27219, 27216
11166, 26565, 26566, 26588, 26587, 27176, 27220, 27221, 27218
11167, 26566, 26567, 26589, 26588, 27178, 27222, 27223, 27220
11168, 26567, 26568, 26590, 26589, 27180, 27224, 27225, 27222
11169, 26568, 26569, 26591, 26590, 27182, 27226, 27227, 27224
11170, 26569, 26570, 26592, 26591, 27184, 27228, 27229, 27226
11171, 26570, 26571, 26593, 26592, 27186, 27230, 27231, 27228
11172, 26571, 26572, 26594, 26593, 27188, 27232, 27233, 27230
11173, 26572, 26573, 26595, 26594, 27190, 27234, 27235, 27232
11174, 26573, 26574, 26596, 26595, 27192, 27236, 27237, 27234
11175, 26574, 26575, 26597, 26596, 27194, 27238, 27239, 27236
11176, 26575, 26576, 26598, 26597, 27196, 27240, 27241, 27238
11177, 26576, 26577, 26599, 26598, 27198, 27242, 27243, 27240
11178, 26577, 3322, 3323, 26599, 27199, 3345, 27244, 27242
11179, 3278, 26578, 26600, 3279, 27201, 27245, 27246, 3301
11180, 26578, 26579, 26601, 26600, 27203, 27247, 27248, 27245
11181, 26579, 26580, 26602, 26601, 27205, 27249, 27250, 27247
11182, 26580, 26581, 26603, 26602, 27207, 27251, 27252, 27249
11183, 26581, 26582, 26604, 26603, 27209, 27253, 27254, 27251
11184, 26582, 26583, 26605, 26604, 27211, 27255, 27256, 27253
11185, 26583, 26584, 26606, 26605, 27213, 27257, 27258, 27255
11186, 26584, 26585, 26607, 26606, 27215, 27259, 27260, 27257
11187, 26585, 26586, 26608, 26607, 27217, 27261, 27262, 27259
11188, 26586, 26587, 26609, 26608, 27219, 27263, 27264, 27261
11189, 26587, 26588, 26610, 26609, 27221, 27265, 27266, 27263
11190, 26588, 26589, 26611, 26610, 27223, 27267, 27268, 27265
11191, 26589, 26590, 26612, 26611, 27225, 27269, 27270, 27267
11192, 26590, 26591, 26613, 26612, 27227, 27271, 27272, 27269
11193, 26591, 26592, 26614, 26613, 27229, 27273, 27274, 27271
11194, 26592, 26593, 26615, 26614, 27231, 27275, 27276, 27273
11195, 26593, 26594, 26616, 26615, 27233, 27277, 27278, 27275
11196, 26594, 26595, 26617, 26616, 27235, 27279, 27280, 27277
11197, 26595, 26596, 26618, 26617, 27237, 27281, 27282, 27279
11198, 26596, 26597, 26619, 26618, 27239, 27283, 27284, 27281
11199, 26597, 26598, 26620, 26619, 27241, 27285, 27286, 27283
11200, 26598, 26599, 26621, 26620, 27243, 27287, 27288, 27285
11201, 26599, 3323, 3324, 26621, 27244, 3346, 27289, 27287
11202, 3279, 26600, 26622, 3280, 27246, 27290, 27291, 3302
11203, 26600, 26601, 26623, 26622, 27248, 27292, 27293, 27290
11204, 26601, 26602, 26624, 26623, 27250, 27294, 27295, 27292
11205, 26602, 26603, 26625, 26624, 27252, 27296, 27297, 27294
11206, 26603, 26604, 26626, 26625, 27254, 27298, 27299, 27296
11207, 26604, 26605, 26627, 26626, 27256, 27300, 27301, 27298
11208, 26605, 26606, 26628, 26627, 27258, 27302, 27303, 27300
11209, 26606, 26607, 26629, 26628, 27260, 27304, 27305, 27302
11210, 26607, 26608, 26630, 26629, 27262, 27306, 27307, 27304
11211, 26608, 26609, 26631, 26630, 27264, 27308, 27309, 27306
11212, 26609, 26610, 26632, 26631, 27266, 27310, 27311, 27308
11213, 26610, 26611, 26633, 26632, 27268, 27312, 27313, 27310
11214, 26611, 26612, 26634, 26633, 27270, 27314, 27315, 27312
11215, 26612, 26613, 26635, 26634, 27272, 27316, 27317, 27314
11216, 26613, 26614, 26636, 26635, 27274, 27318, 27319, 27316
11217, 26614, 26615, 26637, 26636, 27276, 27320, 27321, 27318
11218, 26615, 26616, 26638, 26637, 27278, 27322, 27323, 27320
11219, 26616, 26617, 26639, 26638, 27280, 27324, 27325, 27322
11220, 26617, 26618, 26640, 26639, 27282, 27326, 27327, 27324
11221, 26618, 26619, 26641, 26640, 27284, 27328, 27329, 27326
11222, 26619, 26620, 26642, 26641, 27286, 27330, 27331, 27328
11223, 26620, 26621, 26643, 26642, 27288, 27332, 27333, 27330
11224, 26621, 3324, 3325, 26643, 27289, 3347, 27334, 27332
11225, 3280, 26622, 26644, 3281, 27291, 27335, 27336, 3303
11226, 26622, 26623, 26645, 26644, 27293, 27337, 27338, 27335
11227, 26623, 26624, 26646, 26645, 27295, 27339, 27340, 27337
11228, 26624, 26625, 26647, 26646, 27297, 27341, 27342, 27339
11229, 26625, 26626, 26648, 26647, 27299, 27343, 27344, 27341
11230, 26626, 26627, 26649, 26648, 27301, 27345, 27346, 27343
11231, 26627, 26628, 26650, 26649, 27303, 27347, 27348, 27345
11232, 26628, 26629, 26651, 26650, 27305, 27349, 27350, 27347
11233, 26629, 26630, 26652, 26651, 27307, 27351, 27352, 27349
11234, 26630, 26631, 26653, 26652, 27309, 27353, 27354, 27351
11235, 26631, 26632, 26654, 26653, 27311, 27355, 27356, 27353
11236, 26632, 26633, 26655, 26654, 27313, 27357, 27358, 27355
11237, 26633, 26634, 26656, 26655, 27315, 27359, 27360, 27357
11238, 26634, 26635, 26657, 26656, 27317, 27361, 27362, 27359
11239, 26635, 26636, 26658, 26657, 27319, 27363, 27364, 27361
11240, 26636, 26637, 26659, 26658, 27321, 27365, 27366, 27363
11241, 26637, 26638, 26660, 26659, 27323, 27367, 27368, 27365
11242, 26638, 26639, 26661, 26660, 27325, 27369, 27370, 27367
11243, 26639, 26640, 26662, 26661, 27327, 27371, 27372, 27369
11244, 26640, 26641, 26663, 26662, 27329, 27373, 27374, 27371
11245, 26641, 26642, 26664, 26663, 27331, 27375, 27376, 27373
11246, 26642, 26643, 26665, 26664, 27333, 27377, 27378, 27375
11247, 26643, 3325, 3326, 26665, 27334, 3348, 27379, 27377
11248, 3281, 26644, 26666, 3282, 27336, 27380, 27381, 3304
11249, 26644, 26645, 26667, 26666, 27338, 27382, 27383, 27380
11250, 26645, 26646, 26668, 26667, 27340, 27384, 27385, 27382
11251, 26646, 26647, 26669, 26668, 27342, 27386, 27387, 27384
11252, 26647, 26648, 26670, 26669, 27344, 27388, 27389, 27386
11253, 26648, 26649, 26671, 26670, 27346, 27390, 27391, 27388
11254, 26649, 26650, 26672, 26671, 27348, 27392, 27393, 27390
11255, 26650, 26651, 26673, 26672, 27350, 27394, 27395, 27392
11256, 26651, 26652, 26674, 26673, 27352, 27396, 27397, 27394
11257, 26652, 26653, 26675, 26674, 27354, 27398, 27399, 27396
11258, 26653, 26654, 26676, 26675, 27356, 27400, 27401, 27398
11259, 26654, 26655, 26677, 26676, 27358, 27402, 27403, 27400
11260, 26655, 26656, 26678, 26677, 27360, 27404, 27405, 27402
11261, 26656, 26657, 26679, 26678, 27362, 27406, 27407, 27404
11262, 26657, 26658, 26680, 26679, 27364, 27408, 27409, 27406
11263, 26658, 26659, 26681, 26680, 27366, 27410, 27411, 27408
11264, 26659, 26660, 26682, 26681, 27368, 27412, 27413, 27410
11265, 26660, 26661, 26683, 26682, 27370, 27414, 27415, 27412
11266, 26661, 26662, 26684, 26683, 27372, 27416, 27417, 27414
11267, 26662, 26663, 26685, 26684, 27374, 27418, 27419, 27416
11268, 26663, 26664, 26686, 26685, 27376, 27420, 27421, 27418
11269, 26664, 26665, 26687, 26686, 27378, 27422, 27423, 27420
11270, 26665, 3326, 3327, 26687, 27379, 3349, 27424, 27422
11271, 3282, 26666, 26688, 3283, 27381, 27425, 27426, 3305
11272, 26666, 26667, 26689, 26688, 27383, 27427, 27428, 27425
11273, 26667, 26668, 26690, 26689, 27385, 27429, 27430, 27427
11274, 26668, 26669, 26691, 26690, 27387, 27431, 27432, 27429
11275, 26669, 26670, 26692, 26691, 27389, 27433, 27434, 27431
11276, 26670, 26671, 26693, 26692, 27391, 27435, 27436, 27433
11277, 26671, 26672, 26694, 26693, 27393, 27437, 27438, 27435
11278, 26672, 26673, 26695, 26694, 27395, 27439, 27440, 27437
11279, 26673, 26674, 26696, 26695, 27397, 27441, 27442, 27439
11280, 26674, 26675, 26697, 26696, 27399, 27443, 27444, 27441
11281, 26675, 26676, 26698, 26697, 27401, 27445, 27446, 27443
11282, 26676, 26677, 26699, 26698, 27403, 27447, 27448, 27445
11283, 26677, 26678, 26700, 26699, 27405, 27449, 27450, 27447
11284, 26678, 26679, 26701, 26700, 27407, 27451, 27452, 27449
11285, 26679, 26680, 26702, 26701, 27409, 27453, 27454, 27451
11286, 26680, 26681, 26703, 26702, 27411, 27455, 27456, 27453
11287, 26681, 26682, 26704, 26703, 27413, 27457, 27458, 27455
11288, 26682, 26683, 26705, 26704, 27415, 27459, 27460, 27457
11289, 26683, 26684, 26706, 26705, 27417, 27461, 27462, 27459
11290, 26684, 26685, 26707, 26706, 27419, 27463, 27464, 27461
11291, 26685, 26686, 26708, 26707, 27421, 27465, 27466, 27463
11292, 26686, 26687, 26709, 26708, 27423, 27467, 27468, 27465
11293, 26687, 3327, 3328, 26709, 27424, 3350, 27469, 27467
11294, 3283, 26688, 26710, 3284, 27426, 27470, 27471, 3306
11295, 26688, 26689, 26711, 26710, 27428, 27472, 27473, 27470
11296, 26689, 26690, 26712, 26711, 27430, 27474, 27475, 27472
11297, 26690, 26691, 26713, 26712, 27432, 27476, 27477, 27474
11298, 26691, 26692, 26714, 26713, 27434, 27478, 27479, 27476
11299, 26692, 26693, 26715, 26714, 27436, 27480, 27481, 27478
11300, 26693, 26694, 26716, 26715, 27438, 27482, 27483, 27480
11301, 26694, 26695, 26717, 26716, 27440, 27484, 27485, 27482
11302, 26695, 26696, 26718, 26717, 27442, 27486, 27487, 27484
11303, 26696, 26697, 26719, 26718, 27444, 27488, 27489, 27486
11304, 26697, 26698, 26720, 26719, 27446, 27490, 27491, 27488
11305, 26698, 26699, 26721, 26720, 27448, 27492, 27493, 27490
11306, 26699, 26700, 26722, 26721, 27450, 27494, 27495, 27492
11307, 26700, 26701, 26723, 26722, 27452, 27496, 27497, 27494
11308, 26701, 26702, 26724, 26723, 27454, 27498, 27499, 27496
11309, 26702, 26703, 26725, 26724, 27456, 27500, 27501, 27498
11310, 26703, 26704, 26726, 26725, 27458, 27502, 27503, 27500
11311, 26704, 26705, 26727, 26726, 27460, 27504, 27505, 27502
11312, 26705, 26706, 26728, 26727, 27462, 27506, 27507, 27504
11313, 26706, 26707, 26729, 26728, 27464, 27508, 27509, 27506
11314, 26707, 26708, 26730, 26729, 27466, 27510, 27511, 27508
11315, 26708, 26709, 26731, 26730, 27468, 27512, 27513, 27510
11316, 26709, 3328, 3329, 26731, 27469, 3351, 27514, 27512
11317, 3284, 26710, 26732, 3285, 27471, 27515, 27516, 3307
11318, 26710, 26711, 26733, 26732, 27473, 27517, 27518, 27515
11319, 26711, 26712, 26734, 26733, 27475, 27519, 27520, 27517
11320, 26712, 26713, 26735, 26734, 27477, 27521, 27522, 27519
11321, 26713, 26714, 26736, 26735, 27479, 27523, 27524, 27521
11322, 26714, 26715, 26737, 26736, 27481, 27525, 27526, 27523
11323, 26715, 26716, 26738, 26737, 27483, 27527, 27528, 27525
11324, 26716, 26717, 26739, 26738, 27485, 27529, 27530, 27527
11325, 26717, 26718, 26740, 26739, 27487, 27531, 27532, 27529
11326, 26718, 26719, 26741, 26740, 27489, 27533, 27534, 27531
11327, 26719, 26720, 26742, 26741, 27491, 27535, 27536, 27533
11328, 26720, 26721, 26743, 26742, 27493, 27537, 27538, 27535
11329, 26721, 26722, 26744, 26743, 27495, 27539, 27540, 27537
11330, 26722, 26723, 26745, 26744, 27497, 27541, 27542, 27539
11331, 26723, 26724, 26746, 26745, 27499, 27543, 27544, 27541
11332, 26724, 26725, 26747, 26746, 27501, 27545, 27546, 27543
11333, 26725, 26726, 26748, 26747, 27503, 27547, 27548, 27545
11334, 26726, 26727, 26749, 26748, 27505, 27549, 27550, 27547
11335, 26727, 26728, 26750, 26749, 27507, 27551, 27552, 27549
11336, 26728, 26729, 26751, 26750, 27509, 27553, 27554, 27551
11337, 26729, 26730, 26752, 26751, 27511, 27555, 27556, 27553
11338, 26730, 26731, 26753, 26752, 27513, 27557, 27558, 27555
11339, 26731, 3329, 3330, 26753, 27514, 3352, 27559, 27557
11340, 3285, 26732, 26754, 3286, 27516, 27560, 27561, 3308
11341, 26732, 26733, 26755, 26754, 27518, 27562, 27563, 27560
11342, 26733, 26734, 26756, 26755, 27520, 27564, 27565, 27562
11343, 26734, 26735, 26757, 26756, 27522, 27566, 27567, 27564
11344, 26735, 26736, 26758, 26757, 27524, 27568, 27569, 27566
11345, 26736, 26737, 26759, 26758, 27526, 27570, 27571, 27568
11346, 26737, 26738, 26760, 26759, 27528, 27572, 27573, 27570
11347, 26738, 26739, 26761, 26760, 27530, 27574, 27575, 27572
11348, 26739, 26740, 26762, 26761, 27532, 27576, 27577, 27574
11349, 26740, 26741, 26763, 26762, 27534, 27578, 27579, 27576
11350, 26741, 26742, 26764, 26763, 27536, 27580, 27581, 27578
11351, 26742, 26743, 26765, 26764, 27538, 27582, 27583, 27580
11352, 26743, 26744, 26766, 26765, 27540, 27584, 27585, 27582
11353, 26744, 26745, 26767, 26766, 27542, 27586, 27587, 27584
11354, 26745, 26746, 26768, 26767, 27544, 27588, 27589, 27586
11355, 26746, 26747, 26769, 26768, 27546, 27590, 27591, 27588
11356, 26747, 26748, 26770, 26769, 27548, 27592, 27593, 27590
11357, 26748, 26749, 26771, 26770, 27550, 27594, 27595, 27592
11358, 26749, 26750, 26772, 26771, 27552, 27596, 27597, 27594
11359, 26750, 26751, 26773, 26772, 27554, 27598, 27599, 27596
11360, 26751, 26752, 26774, 26773, 27556, 27600, 27601, 27598
11361, 26752, 26753, 26775, 26774, 27558, 27602, 27603, 27600
11362, 26753, 3330, 3331, 26775, 27559, 3353, 27604, 27602
11363, 3286, 26754, 26776, 3287, 27561, 27605, 27606, 3309
11364, 26754, 26755, 26777, 26776, 27563, 27607, 27608, 27605
11365, 26755, 26756, 26778, 26777, 27565, 27609, 27610, 27607
11366, 26756, 26757, 26779, 26778, 27567, 27611, 27612, 27609
11367, 26757, 26758, 26780, 26779, 27569, 27613, 27614, 27611
11368, 26758, 26759, 26781, 26780, 27571, 27615, 27616, 27613
11369, 26759, 26760, 26782, 26781, 27573, 27617, 27618, 27615
11370, 26760, 26761, 26783, 26782, 27575, 27619, 27620, 27617
11371, 26761, 26762, 26784, 26783, 27577, 27621, 27622, 27619
11372, 26762, 26763, 26785, 26784, 27579, 27623, 27624, 27621
11373, 26763, 26764, 26786, 26785, 27581, 27625, 27626, 27623
11374, 26764, 26765, 26787, 26786, 27583, 27627, 27628, 27625
11375, 26765, 26766, 26788, 26787, 27585, 27629, 27630, 27627
11376, 26766, 26767, 26789, 26788, 27587, 27631, 27632, 27629
11377, 26767, 26768, 26790, 26789, 27589, 27633, 27634, 27631
11378, 26768, 26769, 26791, 26790, 27591, 27635, 27636, 27633
11379, 26769, 26770, 26792, 26791, 27593, 27637, 27638, 27635
11380, 26770, 26771, 26793, 26792, 27595, 27639, 27640, 27637
11381, 26771, 26772, 26794, 26793, 27597, 27641, 27642, 27639
11382, 26772, 26773, 26795, 26794, 27599, 27643, 27644, 27641
11383, 26773, 26774, 26796, 26795, 27601, 27645, 27646, 27643
11384, 26774, 26775, 26797, 26796, 27603, 27647, 27648, 27645
11385, 26775, 3331, 3332, 26797, 27604, 3354, 27649, 27647
11386, 3287, 26776, 26798, 3288, 27606, 27650, 27651, 3310
11387, 26776, 26777, 26799, 26798, 27608, 27652, 27653, 27650
11388, 26777, 26778, 26800, 26799, 27610, 27654, 27655, 27652
11389, 26778, 26779, 26801, 26800, 27612, 27656, 27657, 27654
11390, 26779, 26780, 26802, 26801, 27614, 27658, 27659, 27656
11391, 26780, 26781, 26803, 26802, 27616, 27660, 27661, 27658
11392, 26781, 26782, 26804, 26803, 27618, 27662, 27663, 27660
11393, 26782, 26783, 26805, 26804, 27620, 27664, 27665, 27662
11394, 26783, 26784, 26806, 26805, 27622, 27666, 27667, 27664
11395, 26784, 26785, 26807, 26806, 27624, 27668, 27669, 27666
11396, 26785, 26786, 26808, 26807, 27626, 27670, 27671, 27668
11397, 26786, 26787, 26809, 26808, 27628, 27672, 27673, 27670
11398, 26787, 26788, 26810, 26809, 27630, 27674, 27675, 27672
11399, 26788, 26789, 26811, 26810, 27632, 27676, 27677, 27674
11400, 26789, 26790, 26812, 26811, 27634, 27678, 27679, 27676
11401, 26790, 26791, 26813, 26812, 27636, 27680, 27681, 27678
11402, 26791, 26792, 26814, 26813, 27638, 27682, 27683, 27680
11403, 26792, 26793, 26815, 26814, 27640, 27684, 27685, 27682
11404, 26793, 26794, 26816, 26815, 27642, 27686, 27687, 27684
11405, 26794, 26795, 26817, 26816, 27644, 27688, 27689, 27686
11406, 26795, 26796, 26818, 26817, 27646, 27690, 27691, 27688
11407, 26796, 26797, 26819, 26818, 27648, 27692, 27693, 27690
11408, 26797, 3332, 3333, 26819, 27649, 3355, 27694, 27692
11409, 3288, 26798, 26820, 3289, 27651, 27695, 27696, 3311
11410, 26798, 26799, 26821, 26820, 27653, 27697, 27698, 27695
11411, 26799, 26800, 26822, 26821, 27655, 27699, 27700, 27697
11412, 26800, 26801, 26823, 26822, 27657, 27701, 27702, 27699
11413, 26801, 26802, 26824, 26823, 27659, 27703, 27704, 27701
11414, 26802, 26803, 26825, 26824, 27661, 27705, 27706, 27703
11415, 26803, 26804, 26826, 26825, 27663, 27707, 27708, 27705
11416, 26804, 26805, 26827, 26826, 27665, 27709, 27710, 27707
11417, 26805, 26806, 26828, 26827, 27667, 27711, 27712, 27709
11418, 26806, 26807, 26829, 26828, 27669, 27713, 27714, 27711
11419, 26807, 26808, 26830, 26829, 27671, 27715, 27716, 27713
11420, 26808, 26809, 26831, 26830, 27673, 27717, 27718, 27715
11421, 26809, 26810, 26832, 26831, 27675, 27719, 27720, 27717
11422, 26810, 26811, 26833, 26832, 27677, 27721, 27722, 27719
11423, 26811, 26812, 26834, 26833, 27679, 27723, 27724, 27721
11424, 26812, 26813, 26835, 26834, 27681, 27725, 27726, 27723
11425, 26813, 26814, 26836, 26835, 27683, 27727, 27728, 27725
11426, 26814, 26815, 26837, 26836, 27685, 27729, 27730, 27727
11427, 26815, 26816, 26838, 26837, 27687, 27731, 27732, 27729
11428, 26816, 26817, 26839, 26838, 27689, 27733, 27734, 27731
11429, 26817, 26818, 26840, 26839, 27691, 27735, 27736, 27733
11430, 26818, 26819, 26841, 26840, 27693, 27737, 27738, 27735
11431, 26819, 3333, 3334, 26841, 27694, 3356, 27739, 27737
11432, 3289, 26820, 26842, 3290, 27696, 27740, 27741, 3312
11433, 26820, 26821, 26843, 26842, 27698, 27742, 27743, 27740
11434, 26821, 26822, 26844, 26843, 27700, 27744, 27745, 27742
11435, 26822, 26823, 26845, 26844, 27702, 27746, 27747, 27744
11436, 26823, 26824, 26846, 26845, 27704, 27748, 27749, 27746
11437, 26824, 26825, 26847, 26846, 27706, 27750, 27751, 27748
11438, 26825, 26826, 26848, 26847, 27708, 27752, 27753, 27750
11439, 26826, 26827, 26849, 26848, 27710, 27754, 27755, 27752
11440, 26827, 26828, 26850, 26849, 27712, 27756, 27757, 27754
11441, 26828, 26829, 26851, 26850, 27714, 27758, 27759, 27756
11442, 26829, 26830, 26852, 26851, 27716, 27760, 27761, 27758
11443, 26830, 26831, 26853, 26852, 27718, 27762, 27763, 27760
11444, 26831, 26832, 26854, 26853, 27720, 27764, 27765, 27762
11445, 26832, 26833, 26855, 26854, 27722, 27766, 27767, 27764
11446, 26833, 26834, 26856, 26855, 27724, 27768, 27769, 27766
11447, 26834, 26835, 26857, 26856, 27726, 27770, 27771, 27768
11448, 26835, 26836, 26858, 26857, 27728, 27772, 27773, 27770
11449, 26836, 26837, 26859, 26858, 27730, 27774, 27775, 27772
11450, 26837, 26838, 26860, 26859, 27732, 27776, 27777, 27774
11451, 26838, 26839, 26861, 26860, 27734, 27778, 27779, 27776
11452, 26839, 26840, 26862, 26861, 27736, 27780, 27781, 27778
11453, 26840, 26841, 26863, 26862, 27738, 27782, 27783, 27780
11454, 26841, 3334, 3335, 26863, 27739, 3357, 27784, 27782
11455, 3290, 26842, 26864, 3291, 27741, 27785, 27786, 3313
11456, 26842, 26843, 26865, 26864, 27743, 27787, 27788, 27785
11457, 26843, 26844, 26866, 26865, 27745, 27789, 27790, 27787
11458, 26844, 26845, 26867, 26866, 27747, 27791, 27792, 27789
11459, 26845, 26846, 26868, 26867, 27749, 27793, 27794, 27791
11460, 26846, 26847, 26869, 26868, 27751, 27795, 27796, 27793
11461, 26847, 26848, 26870, 26869, 27753, 27797, 27798, 27795
11462, 26848, 26849, 26871, 26870, 27755, 27799, 27800, 27797
11463, 26849, 26850, 26872, 26871, 27757, 27801, 27802, 27799
11464, 26850, 26851, 26873, 26872, 27759, 27803, 27804, 27801
11465, 26851, 26852, 26874, 26873, 27761, 27805, 27806, 27803
11466, 26852, 26853, 26875, 26874, 27763, 27807, 27808, 27805
11467, 26853, 26854, 26876, 26875, 27765, 27809, 27810, 27807
11468, 26854, 26855, 26877, 26876, 27767, 27811, 27812, 27809
11469, 26855, 26856, 26878, 26877, 27769, 27813, 27814, 27811
11470, 26856, 26857, 26879, 26878, 27771, 27815, 27816, 27813
11471, 26857, 26858, 26880, 26879, 27773, 27817, 27818, 27815
11472, 26858, 26859, 26881, 26880, 27775, 27819, 27820, 27817
11473, 26859, 26860, 26882, 26881, 27777, 27821, 27822, 27819
11474, 26860, 26861, 26883, 26882, 27779, 27823, 27824, 27821
11475, 26861, 26862, 26884, 26883, 27781, 27825, 27826, 27823
11476, 26862, 26863, 26885, 26884, 27783, 27827, 27828, 27825
11477, 26863, 3335, 3336, 26885, 27784, 3358, 27829, 27827
11478, 3291, 26864, 26886, 3292, 27786, 27830, 27831, 3314
11479, 26864, 26865, 26887, 26886, 27788, 27832, 27833, 27830
11480, 26865, 26866, 26888, 26887, 27790, 27834, 27835, 27832
11481, 26866, 26867, 26889, 26888, 27792, 27836, 27837, 27834
11482, 26867, 26868, 26890, 26889, 27794, 27838, 27839, 27836
11483, 26868, 26869, 26891, 26890, 27796, 27840, 27841, 27838
11484, 26869, 26870, 26892, 26891, 27798, 27842, 27843, 27840
11485, 26870, 26871, 26893, 26892, 27800, 27844, 27845, 27842
11486, 26871, 26872, 26894, 26893, 27802, 27846, 27847, 27844
11487, 26872, 26873, 26895, 26894, 27804, 27848, 27849, 27846
11488, 26873, 26874, 26896, 26895, 27806, 27850, 27851, 27848
11489, 26874, 26875, 26897, 26896, 27808, 27852, 27853, 27850
11490, 26875, 26876, 26898, 26897, 27810, 27854, 27855, 27852
11491, 26876, 26877, 26899, 26898, 27812, 27856, 27857, 27854
11492, 26877, 26878, 26900, 26899, 27814, 27858, 27859, 27856
11493, 26878, 26879, 26901, 26900, 27816, 27860, 27861, 27858
11494, 26879, 26880, 26902, 26901, 27818, 27862, 27863, 27860
11495, 26880, 26881, 26903, 26902, 27820, 27864, 27865, 27862
11496, 26881, 26882, 26904, 26903, 27822, 27866, 27867, 27864
11497, 26882, 26883, 26905, 26904, 27824, 27868, 27869, 27866
11498, 26883, 26884, 26906, 26905, 27826, 27870, 27871, 27868
11499, 26884, 26885, 26907, 26906, 27828, 27872, 27873, 27870
11500, 26885, 3336, 3337, 26907, 27829, 3359, 27874, 27872
11501, 3292, 26886, 26908, 3293, 27831, 27875, 27876, 3315
11502, 26886, 26887, 26909, 26908, 27833, 27877, 27878, 27875
11503, 26887, 26888, 26910, 26909, 27835, 27879, 27880, 27877
11504, 26888, 26889, 26911, 26910, 27837, 27881, 27882, 27879
11505, 26889, 26890, 26912, 26911, 27839, 27883, 27884, 27881
11506, 26890, 26891, 26913, 26912, 27841, 27885, 27886, 27883
11507, 26891, 26892, 26914, 26913, 27843, 27887, 27888, 27885
11508, 26892, 26893, 26915, 26914, 27845, 27889, 27890, 27887
11509, 26893, 26894, 26916, 26915, 27847, 27891, 27892, 27889
11510, 26894, 26895, 26917, 26916, 27849, 27893, 27894, 27891
11511, 26895, 26896, 26918, 26917, 27851, 27895, 27896, 27893
11512, 26896, 26897, 26919, 26918, 27853, 27897, 27898, 27895
11513, 26897, 26898, 26920, 26919, 27855, 27899, 27900, 27897
11514, 26898, 26899, 26921, 26920, 27857, 27901, 27902, 27899
11515, 26899, 26900, 26922, 26921, 27859, 27903, 27904, 27901
11516, 26900, 26901, 26923, 26922, 27861, 27905, 27906, 27903
11517, 26901, 26902, 26924, 26923, 27863, 27907, 27908, 27905
11518, 26902, 26903, 26925, 26924, 27865, 27909, 27910, 27907
11519, 26903, 26904, 26926, 26925, 27867, 27911, 27912, 27909
11520, 26904, 26905, 26927, 26926, 27869, 27913, 27914, 27911
11521, 26905, 26906, 26928, 26927, 27871, 27915, 27916, 27913
11522, 26906, 26907, 26929, 26928, 27873, 27917, 27918, 27915
11523, 26907, 3337, 3338, 26929, 27874, 3360, 27919, 27917
11524, 3293, 26908, 290, 7, 27876, 27920, 312, 3316
11525, 26908, 26909, 291, 290, 27878, 27921, 313, 27920
11526, 26909, 26910, 292, 291, 27880, 27922, 314, 27921
11527, 26910, 26911, 293, 292, 27882, 27923, 315, 27922
11528, 26911, 26912, 294, 293, 27884, 27924, 316, 27923
11529, 26912, 26913, 295, 294, 27886, 27925, 317, 27924
11530, 26913, 26914, 296, 295, 27888, 27926, 318, 27925
11531, 26914, 26915, 297, 296, 27890, 27927, 319, 27926
11532, 26915, 26916, 298, 297, 27892, 27928, 320, 27927
11533, 26916, 26917, 299, 298, 27894, 27929, 321, 27928
11534, 26917, 26918, 300, 299, 27896, 27930, 322, 27929
11535, 26918, 26919, 301, 300, 27898, 27931, 323, 27930
11536, 26919, 26920, 302, 301, 27900, 27932, 324, 27931
11537, 26920, 26921, 303, 302, 27902, 27933, 325, 27932
11538, 26921, 26922, 304, 303, 27904, 27934, 326, 27933
11539, 26922, 26923, 305, 304, 27906, 27935, 327, 27934
11540, 26923, 26924, 306, 305, 27908, 27936, 328, 27935
11541, 26924, 26925, 307, 306, 27910, 27937, 329, 27936
11542, 26925, 26926, 308, 307, 27912, 27938, 330, 27937
11543, 26926, 26927, 309, 308, 27914, 27939, 331, 27938
11544, 26927, 26928, 310, 309, 27916, 27940, 332, 27939
11545, 26928, 26929, 311, 310, 27918, 27941, 333, 27940
11546, 26929, 3338, 8, 311, 27919, 3361, 334, 27941
*ELEMENT, type=CPS8, ELSET=Surface267
11547, 93, 3414, 27942, 3137, 3423, 28118, 28119, 3159
11548, 3414, 3413, 27943, 27942, 3422, 28120, 28121, 28118
11549, 3413, 3412, 27944, 27943, 3421, 28122, 28123, 28120
11550, 3412, 3411, 27945, 27944, 3420, 28124, 28125, 28122
11551, 3411, 3410, 27946, 27945, 3419, 28126, 28127, 28124
11552, 3410, 3409, 27947, 27946, 3418, 28128, 28129, 28126
11553, 3409, 3408, 27948, 27947, 3417, 28130, 28131, 28128
11554, 3408, 3407, 27949, 27948, 3416, 28132, 28133, 28130
11555, 3407, 95, 3272, 27949, 3415, 3294, 28134, 28132
11556, 3137, 27942, 27950, 3138, 28119, 28135, 28136, 3160
11557, 27942, 27943, 27951, 27950, 28121, 28137, 28138, 28135
11558, 27943, 27944, 27952, 27951, 28123, 28139, 28140, 28137
11559, 27944, 27945, 27953, 27952, 28125, 28141, 28142, 28139
11560, 27945, 27946, 27954, 27953, 28127, 28143, 28144, 28141
11561, 27946, 27947, 27955, 27954, 28129, 28145, 28146, 28143
11562, 27947, 27948, 27956, 27955, 28131, 28147, 28148, 28145
11563, 27948, 27949, 27957, 27956, 28133, 28149, 28150, 28147
11564, 27949, 3272, 3273, 27957, 28134, 3295, 28151, 28149
11565, 3138, 27950, 27958, 3139, 28136, 28152, 28153, 3161
11566, 27950, 27951, 27959, 27958, 28138, 28154, 28155, 28152
11567, 27951, 27952, 27960, 27959, 28140, 28156, 28157, 28154
11568, 27952, 27953, 27961, 27960, 28142, 28158, 28159, 28156
11569, 27953, 27954, 27962, 27961, 28144, 28160, 28161, 28158
11570, 27954, 27955, 27963, 27962, 28146, 28162, 28163, 28160
11571, 27955, 27956, 27964, 27963, 28148, 28164, 28165, 28162
11572, 27956, 27957, 27965, 27964, 28150, 28166, 28167, 28164
11573, 27957, 3273, 3274, 27965, 28151, 3296, 28168, 28166
11574, 3139, 27958, 27966, 3140, 28153, 28169, 28170, 3162
11575, 27958, 27959, 27967, 27966, 28155, 28171, 28172, 28169
11576, 27959, 27960, 27968, 27967, 28157, 28173, 28174, 28171
11577, 27960, 27961, 27969, 27968, 28159, 28175, 28176, 28173
11578, 27961, 27962, 27970, 27969, 28161, 28177, 28178, 28175
11579, 27962, 27963, 27971, 27970, 28163, 28179, 28180, 28177
11580, 27963, 27964, 27972, 27971, 28165, 28181, 28182, 28179
11581, 27964, 27965, 27973, 27972, 28167, 28183, 28184, 28181
11582, 27965, 3274, 3275, 27973, 28168, 3297, 28185, 28183
11583, 3140, 27966, 27974, 3141, 28170, 28186, 28187, 3163
11584, 27966, 27967, 27975, 27974, 28172, 28188, 28189, 28186
11585, 27967, 27968, 27976, 27975, 28174, 28190, 28191, 28188
11586, 27968, 27969, 27977, 27976, 28176, 28192, 28193, 28190
11587, 27969, 27970, 27978, 27977, 28178, 28194, 28195, 28192
11588, 27970, 27971, 27979, 27978, 28180, 28196, 28197, 28194
11589, 27971, 27972, 27980, 27979, 28182, 28198, 28199, 28196
11590, 27972, 27973, 27981, 27980, 28184, 28200, 28201, 28198
11591, 27973, 3275, 3276, 27981, 28185, 3298, 28202, 28200
11592, 3141, 27974, 27982, 3142, 28187, 28203, 28204, 3164
11593, 27974, 27975, 27983, 27982, 28189, 28205, 28206, 28203
11594, 27975, 27976, 27984, 27983, 28191, 28207, 28208, 28205
11595, 27976, 27977, 27985, 27984, 28193, 28209, 28210, 28207
11596, 27977, 27978, 27986, 27985, 28195, 28211, 28212, 28209
11597, 27978, 27979, 27987, 27986, 28197, 28213, 28214, 28211
11598, 27979, 27980, 27988, 27987, 28199, 28215, 28216, 28213
11599, 27980, 27981, 27989, 27988, 28201, 28217, 28218, 28215
11600, 27981, 3276, 3277, 27989, 28202, 3299, 28219, 28217
11601, 3142, 27982, 27990, 3143, 28204, 28220, 28221, 3165
11602, 27982, 27983, 27991, 27990, 28206, 28222, 28223, 28220
11603, 27983, 27984, 27992, 27991, 28208, 28224, 28225, 28222
11604, 27984, 27985, 27993, 27992, 28210, 28226, 28227, 28224
11605, 27985, 27986, 27994, 27993, 28212, 28228, 28229, 28226
11606, 27986, 27987, 27995, 27994, 28214, 28230, 28231, 28228
11607, 27987, 27988, 27996, 27995, 28216, 28232, 28233, 28230
11608, 27988, 27989, 27997, 27996, 28218, 28234, 28235, 28232
11609, 27989, 3277, 3278, 27997, 28219, 3300, 28236, 28234
11610, 3143, 27990, 27998, 3144, 28221, 28237, 28238, 3166
11611, 27990, 27991, 27999, 27998, 28223, 28239, 28240, 28237
11612, 27991, 27992, 28000, 27999, 28225, 28241, 28242, 28239
11613, 27992, 27993, 28001, 28000, 28227, 28243, 28244, 28241
11614, 27993, 27994, 28002, 28001, 28229, 28245, 28246, 28243
11615, 27994, 27995, 28003, 28002, 28231, 28247, 28248, 28245
11616, 27995, 27996, 28004, 28003, 28233, 28249, 28250, 28247
11617, 27996, 27997, 28005, 28004, 28235, 28251, 28252, 28249
11618, 27997, 3278, 3279, 28005, 28236, 3301, 28253, 28251
11619, 3144, 27998, 28006, 3145, 28238, 28254, 28255, 3167
11620, 27998, 27999, 28007, 28006, 28240, 28256, 28257, 28254
11621, 27999, 28000, 28008, 28007, 28242, 28258, 28259, 28256
11622, 28000, 28001, 28009, 28008, 28244, 28260, 28261, 28258
11623, 28001, 28002, 28010, 28009, 28246, 28262, 28263, 28260
11624, 28002, 28003, 28011, 28010, 28248, 28264, 28265, 28262
11625, 28003, 28004, 28012, 28011, 28250, 28266, 28267, 28264
11626, 28004, 28005, 28013, 28012, 28252, 28268, 28269, 28266
11627, 28005, 3279, 3280, 28013, 28253, 3302, 28270, 28268
11628, 3145, 28006, 28014, 3146, 28255, 28271, 28272, 3168
11629, 28006, 28007, 28015, 28014, 28257, 28273, 28274, 28271
11630, 28007, 28008, 28016, 28015, 28259, 28275, 28276, 28273
11631, 28008, 28009, 28017, 28016, 28261, 28277, 28278, 28275
11632, 28009, 28010, 28018, 28017, 28263, 28279, 28280, 28277
11633, 28010, 28011, 28019, 28018, 28265, 28281, 28282, 28279
11634, 28011, 28012, 28020, 28019, 28267, 28283, 28284, 28281
11635, 28012, 28013, 28021, 28020, 28269, 28285, 28286, 28283
11636, 28013, 3280, 3281, 28021, 28270, 3303, 28287, 28285
11637, 3146, 28014, 28022, 3147, 28272, 28288, 28289, 3169
11638, 28014, 28015, 28023, 28022, 28274, 28290, 28291, 28288
11639, 28015, 28016, 28024, 28023, 28276, 28292, 28293, 28290
11640, 28016, 28017, 28025, 28024, 28278, 28294, 28295, 28292
11641, 28017, 28018, 28026, 28025, 28280, 28296, 28297, 28294
11642, 28018, 28019, 28027, 28026, 28282, 28298, 28299, 28296
11643, 28019, 28020, 28028, 28027, 28284, 28300, 28301, 28298
11644, 28020, 28021, 28029, 28028, 28286, 28302, 28303, 28300
11645, 28021, 3281, 3282, 28029, 28287, 3304, 28304, 28302
11646, 3147, 28022, 28030, 3148, 28289, 28305, 28306, 3170
11647, 28022, 28023, 28031, 28030, 28291, 28307, 28308, 28305
11648, 28023, 28024, 28032, 28031, 28293, 28309, 28310, 28307
11649, 28024, 28025, 28033, 28032, 28295, 28311, 28312, 28309
11650, 28025, 28026, 28034, 28033, 28297, 28313, 28314, 28311
11651, 28026, 28027, 28035, 28034, 28299, 28315, 28316, 28313
11652, 28027, 28028, 28036, 28035, 28301, 28317, 28318, 28315
11653, 28028, 28029, 28037, 28036, 28303, 28319, 28320, 28317
11654, 28029, 3282, 3283, 28037, 28304, 3305, 28321, 28319
11655, 3148, 28030, 28038, 3149, 28306, 28322, 28323, 3171
11656, 28030, 28031, 28039, 28038, 28308, 28324, 28325, 28322
11657, 28031, 28032, 28040, 28039, 28310, 28326, 28327, 28324
11658, 28032, 28033, 28041, 28040, 28312, 28328, 28329, 28326
11659, 28033, 28034, 28042, 28041, 28314, 28330, 28331, 28328
11660, 28034, 28035, 28043, 28042, 28316, 28332, 28333, 28330
11661, 28035, 28036, 28044, 28043, 28318, 28334, 28335, 28332
11662, 28036, 28037, 28045, 28044, 28320, 28336, 28337, 28334
11663, 28037, 3283, 3284, 28045, 28321, 3306, 28338, 28336
11664, 3149, 28038, 28046, 3150, 28323, 28339, 28340, 3172
11665, 28038, 28039, 28047, 28046, 28325, 28341, 28342, 28339
11666, 28039, 28040, 28048, 28047, 28327, 28343, 28344, 28341
11667, 28040, 28041, 28049, 28048, 28329, 28345, 28346, 28343
11668, 28041, 28042, 28050, 28049, 28331, 28347, 28348, 28345
11669, 28042, 28043, 28051, 28050, 28333, 28349, 28350, 28347
11670, 28043, 28044, 28052, 28051, 28335, 28351, 28352, 28349
11671, 28044, 28045, 28053, 28052, 28337, 28353, 28354, 28351
11672, 28045, 3284, 3285, 28053, 28338, 3307, 28355, 28353
11673, 3150, 28046, 28054, 3151, 28340, 28356, 28357, 3173
11674, 28046, 28047, 28055, 28054, 28342, 28358, 28359, 28356
11675, 28047, 28048, 28056, 28055, 28344, 28360, 28361, 28358
11676, 28048, 28049, 28057, 28056, 28346, 28362, 28363, 28360
11677, 28049, 28050, 28058, 28057, 28348, 28364, 28365, 28362
11678, 28050, 28051, 28059, 28058, 28350, 28366, 28367, 28364
11679, 28051, 28052, 28060, 28059, 28352, 28368, 28369, 28366
11680, 28052, 28053, 28061, 28060, 28354, 28370, 28371, 28368
11681, 28053, 3285, 3286, 28061, 28355, 3308, 28372, 28370
11682, 3151, 28054, 28062, 3152, 28357, 28373, 28374, 3174
11683, 28054, 28055, 28063, 28062, 28359, 28375, 28376, 28373
11684, 28055, 28056, 28064, 28063, 28361, 28377, 28378, 28375
11685, 28056, 28057, 28065, 28064, 28363, 28379, 28380, 28377
11686, 28057, 28058, 28066, 28065, 28365, 28381, 28382, 28379
11687, 28058, 28059, 28067, 28066, 28367, 28383, 28384, 28381
11688, 28059, 28060, 28068, 28067, 28369, 28385, 28386, 28383
11689, 28060, 28061, 28069, 28068, 28371, 28387, 28388, 28385
11690, 28061, 3286, 3287, 28069, 28372, 3309, 28389, 28387
11691, 3152, 28062, 28070, 3153, 28374, 28390, 28391, 3175
11692, 28062, 28063, 28071, 28070, 28376, 28392, 28393, 28390
11693, 28063, 28064, 28072, 28071, 28378, 28394, 28395, 28392
11694, 28064, 28065, 28073, 28072, 28380, 28396, 28397, 28394
11695, 28065, 28066, 28074, 28073, 28382, 28398, 28399, 28396
11696, 28066, 28067, 28075, 28074, 28384, 28400, 28401, 28398
11697, 28067, 28068, 28076, 28075, 28386, 28402, 28403, 28400
11698, 28068, 28069, 28077, 28076, 28388, 28404, 28405, 28402
11699, 28069, 3287, 3288, 28077, 28389, 3310, 28406, 28404
11700, 3153, 28070, 28078, 3154, 28391, 28407, 28408, 3176
11701, 28070, 28071, 28079, 28078, 28393, 28409, 28410, 28407
11702, 28071, 28072, 28080, 28079, 28395, 28411, 28412, 28409
11703, 28072, 28073, 28081, 28080, 28397, 28413, 28414, 28411
11704, 28073, 28074, 28082, 28081, 28399, 28415, 28416, 28413
11705, 28074, 28075, 28083, 28082, 28401, 28417, 28418, 28415
11706, 28075, 28076, 28084, 28083, 28403, 28419, 28420, 28417
11707, 28076, 28077, 28085, 28084, 28405, 28421, 28422, 28419
11708, 28077, 3288, 3289, 28085, 28406, 3311, 28423, 28421
11709, 3154, 28078, 28086, 3155, 28408, 28424, 28425, 3177
11710, 28078, 28079, 28087, 28086, 28410, 28426, 28427, 28424
11711, 28079, 28080, 28088, 28087, 28412, 28428, 28429, 28426
11712, 28080, 28081, 28089, 28088, 28414, 28430, 28431, 28428
11713, 28081, 28082, 28090, 28089, 28416, 28432, 28433, 28430
11714, 28082, 28083, 28091, 28090, 28418, 28434, 28435, 28432
11715, 28083, 28084, 28092, 28091, 28420, 28436, 28437, 28434
11716, 28084, 28085, 28093, 28092, 28422, 28438, 28439, 28436
11717, 28085, 3289, 3290, 28093, 28423, 3312, 28440, 28438
11718, 3155, 28086, 28094, 3156, 28425, 28441, 28442, 3178
11719, 28086, 28087, 28095, 28094, 28427, 28443, 28444, 28441
11720, 28087, 28088, 28096, 28095, 28429, 28445, 28446, 28443
11721, 28088, 28089, 28097, 28096, 28431, 28447, 28448, 28445
11722, 28089, 28090, 28098, 28097, 28433, 28449, 28450, 28447
11723, 28090, 28091, 28099, 28098, 28435, 28451, 28452, 28449
11724, 28091, 28092, 28100, 28099, 28437, 28453, 28454, 28451
11725, 28092, 28093, 28101, 28100, 28439, 28455, 28456, 28453
11726, 28093, 3290, 3291, 28101, 28440, 3313, 28457, 28455
11727, 3156, 28094, 28102, 3157, 28442, 28458, 28459, 3179
11728, 28094, 28095, 28103, 28102, 28444, 28460, 28461, 28458
11729, 28095, 28096, 28104, 28103, 28446, 28462, 28463, 28460
11730, 28096, 28097, 28105, 28104, 28448, 28464, 28465, 28462
11731, 28097, 28098, 28106, 28105, 28450, 28466, 28467, 28464
11732, 28098, 28099, 28107, 28106, 28452, 28468, 28469, 28466
11733, 28099, 28100, 28108, 28107, 28454, 28470, 28471, 28468
11734, 28100, 28101, 28109, 28108, 28456, 28472, 28473, 28470
11735, 28101, 3291, 3292, 28109, 28457, 3314, 28474, 28472
11736, 3157, 28102, 28110, 3158, 28459, 28475, 28476, 3180
11737, 28102, 28103, 28111, 28110, 28461, 28477, 28478, 28475
11738, 28103, 28104, 28112, 28111, 28463, 28479, 28480, 28477
11739, 28104, 28105, 28113, 28112, 28465, 28481, 28482, 28479
11740, 28105, 28106, 28114, 28113, 28467, 28483, 28484, 28481
11741, 28106, 28107, 28115, 28114, 28469, 28485, 28486, 28483
11742, 28107, 28108, 28116, 28115, 28471, 28487, 28488, 28485
11743, 28108, 28109, 28117, 28116, 28473, 28489, 28490, 28487
11744, 28109, 3292, 3293, 28117, 28474, 3315, 28491, 28489
11745, 3158, 28110, 342, 5, 28476, 28492, 351, 3181
11746, 28110, 28111, 341, 342, 28478, 28493, 350, 28492
11747, 28111, 28112, 340, 341, 28480, 28494, 349, 28493
11748, 28112, 28113, 339, 340, 28482, 28495, 348, 28494
11749, 28113, 28114, 338, 339, 28484, 28496, 347, 28495
11750, 28114, 28115, 337, 338, 28486, 28497, 346, 28496
11751, 28115, 28116, 336, 337, 28488, 28498, 345, 28497
11752, 28116, 28117, 335, 336, 28490, 28499, 344, 28498
11753, 28117, 3293, 7, 335, 28491, 3316, 343, 28499
*ELEMENT, type=CPS8, ELSET=Surface268
11754, 94, 3182, 28500, 3431, 3204, 28676, 28677, 3440
11755, 3431, 28500, 28501, 3430, 28677, 28678, 28679, 3439
11756, 3430, 28501, 28502, 3429, 28679, 28680, 28681, 3438
11757, 3429, 28502, 28503, 3428, 28681, 28682, 28683, 3437
11758, 3428, 28503, 28504, 3427, 28683, 28684, 28685, 3436
11759, 3427, 28504, 28505, 3426, 28685, 28686, 28687, 3435
11760, 3426, 28505, 28506, 3425, 28687, 28688, 28689, 3434
11761, 3425, 28506, 28507, 3424, 28689, 28690, 28691, 3433
11762, 3424, 28507, 3317, 96, 28691, 28692, 3339, 3432
11763, 3182, 3183, 28508, 28500, 3205, 28693, 28694, 28676
11764, 28500, 28508, 28509, 28501, 28694, 28695, 28696, 28678
11765, 28501, 28509, 28510, 28502, 28696, 28697, 28698, 28680
11766, 28502, 28510, 28511, 28503, 28698, 28699, 28700, 28682
11767, 28503, 28511, 28512, 28504, 28700, 28701, 28702, 28684
11768, 28504, 28512, 28513, 28505, 28702, 28703, 28704, 28686
11769, 28505, 28513, 28514, 28506, 28704, 28705, 28706, 28688
11770, 28506, 28514, 28515, 28507, 28706, 28707, 28708, 28690
11771, 28507, 28515, 3318, 3317, 28708, 28709, 3340, 28692
11772, 3183, 3184, 28516, 28508, 3206, 28710, 28711, 28693
11773, 28508, 28516, 28517, 28509, 28711, 28712, 28713, 28695
11774, 28509, 28517, 28518, 28510, 28713, 28714, 28715, 28697
11775, 28510, 28518, 28519, 28511, 28715, 28716, 28717, 28699
11776, 28511, 28519, 28520, 28512, 28717, 28718, 28719, 28701
11777, 28512, 28520, 28521, 28513, 28719, 28720, 28721, 28703
11778, 28513, 28521, 28522, 28514, 28721, 28722, 28723, 28705
11779, 28514, 28522, 28523, 28515, 28723, 28724, 28725, 28707
11780, 28515, 28523, 3319, 3318, 28725, 28726, 3341, 28709
11781, 3184, 3185, 28524, 28516, 3207, 28727, 28728, 28710
11782, 28516, 28524, 28525, 28517, 28728, 28729, 28730, 28712
11783, 28517, 28525, 28526, 28518, 28730, 28731, 28732, 28714
11784, 28518, 28526, 28527, 28519, 28732, 28733, 28734, 28716
11785, 28519, 28527, 28528, 28520, 28734, 28735, 28736, 28718
11786, 28520, 28528, 28529, 28521, 28736, 28737, 28738, 28720
11787, 28521, 28529, 28530, 28522, 28738, 28739, 28740, 28722
11788, 28522, 28530, 28531, 28523, 28740, 28741, 28742, 28724
11789, 28523, 28531, 3320, 3319, 28742, 28743, 3342, 28726
11790, 3185, 3186, 28532, 28524, 3208, 28744, 28745, 28727
11791, 28524, 28532, 28533, 28525, 28745, 28746, 28747, 28729
11792, 28525, 28533, 28534, 28526, 28747, 28748, 28749, 28731
11793, 28526, 28534, 28535, 28527, 28749, 28750, 28751, 28733
11794, 28527, 28535, 28536, 28528, 28751, 28752, 28753, 28735
11795, 28528, 28536, 28537, 28529, 28753, 28754, 28755, 28737
11796, 28529, 28537, 28538, 28530, 28755, 28756, 28757, 28739
11797, 28530, 28538, 28539, 28531, 28757, 28758, 28759, 28741
11798, 28531, 28539, 3321, 3320, 28759, 28760, 3343, 28743
11799, 3186, 3187, 28540, 28532, 3209, 28761, 28762, 28744
11800, 28532, 28540, 28541, 28533, 28762, 28763, 28764, 28746
11801, 28533, 28541, 28542, 28534, 28764, 28765, 28766, 28748
11802, 28534, 28542, 28543, 28535, 28766, 28767, 28768, 28750
11803, 28535, 28543, 28544, 28536, 28768, 28769, 28770, 28752
11804, 28536, 28544, 28545, 28537, 28770, 28771, 28772, 28754
11805, 28537, 28545, 28546, 28538, 28772, 28773, 28774, 28756
11806, 28538, 28546, 28547, 28539, 28774, 28775, 28776, 28758
11807, 28539, 28547, 3322, 3321, 28776, 28777, 3344, 28760
11808, 3187, 3188, 28548, 28540, 3210, 28778, 28779, 28761
11809, 28540, 28548, 28549, 28541, 28779, 28780, 28781, 28763
11810, 28541, 28549, 28550, 28542, 28781, 28782, 28783, 28765
11811, 28542, 28550, 28551, 28543, 28783, 28784, 28785, 28767
11812, 28543, 28551, 28552, 28544, 28785, 28786, 28787, 28769
11813, 28544, 28552, 28553, 28545, 28787, 28788, 28789, 28771
11814, 28545, 28553, 28554, 28546, 28789, 28790, 28791, 28773
11815, 28546, 28554, 28555, 28547, 28791, 28792, 28793, 28775
11816, 28547, 28555, 3323, 3322, 28793, 28794, 3345, 28777
11817, 3188, 3189, 28556, 28548, 3211, 28795, 28796, 28778
11818, 28548, 28556, 28557, 28549, 28796, 28797, 28798, 28780
11819, 28549, 28557, 28558, 28550, 28798, 28799, 28800, 28782
11820, 28550, 28558, 28559, 28551, 28800, 28801, 28802, 28784
11821, 28551, 28559, 28560, 28552, 28802, 28803, 28804, 28786
11822, 28552, 28560, 28561, 28553, 28804, 28805, 28806, 28788
11823, 28553, 28561, 28562, 28554, 28806, 28807, 28808, 28790
11824, 28554, 28562, 28563, 28555, 28808, 28809, 28810, 28792
11825, 28555, 28563, 3324, 3323, 28810, 28811, 3346, 28794
11826, 3189, 3190, 28564, 28556, 3212, 28812, 28813, 28795
11827, 28556, 28564, 28565, 28557, 28813, 28814, 28815, 28797
11828, 28557, 28565, 28566, 28558, 28815, 28816, 28817, 28799
11829, 28558, 28566, 28567, 28559, 28817, 28818, 28819, 28801
11830, 28559, 28567, 28568, 28560, 28819, 28820, 28821, 28803
11831, 28560, 28568, 28569, 28561, 28821, 28822, 28823, 28805
11832, 28561, 28569, 28570, 28562, 28823, 28824, 28825, 28807
11833, 28562, 28570, 28571, 28563, 28825, 28826, 28827, 28809
11834, 28563, 28571, 3325, 3324, 28827, 28828, 3347, 28811
11835, 3190, 3191, 28572, 28564, 3213, 28829, 28830, 28812
11836, 28564, 28572, 28573, 28565, 28830, 28831, 28832, 28814
11837, 28565, 28573, 28574, 28566, 28832, 28833, 28834, 28816
11838, 28566, 28574, 28575, 28567, 28834, 28835, 28836, 28818
11839, 28567, 28575, 28576, 28568, 28836, 28837, 28838, 28820
11840, 28568, 28576, 28577, 28569, 28838, 28839, 28840, 28822
11841, 28569, 28577, 28578, 28570, 28840, 28841, 28842, 28824
11842, 28570, 28578, 28579, 28571, 28842, 28843, 28844, 28826
11843, 28571, 28579, 3326, 3325, 28844, 28845, 3348, 28828
11844, 3191, 3192, 28580, 28572, 3214, 28846, 28847, 28829
11845, 28572, 28580, 28581, 28573, 28847, 28848, 28849, 28831
11846, 28573, 28581, 28582, 28574, 28849, 28850, 28851, 28833
11847, 28574, 28582, 28583, 28575, 28851, 28852, 28853, 28835
11848, 28575, 28583, 28584, 28576, 28853, 28854, 28855, 28837
11849, 28576, 28584, 28585, 28577, 28855, 28856, 28857, 28839
11850, 28577, 28585, 28586, 28578, 28857, 28858, 28859, 28841
11851, 28578, 28586, 28587, 28579, 28859, 28860, 28861, 28843
11852, 28579, 28587, 3327, 3326, 28861, 28862, 3349, 28845
11853, 3192, 3193, 28588, 28580, 3215, 28863, 28864, 28846
11854, 28580, 28588, 28589, 28581, 28864, 28865, 28866, 28848
11855, 28581, 28589, 28590, 28582, 28866, 28867, 28868, 28850
11856, 28582, 28590, 28591, 28583, 28868, 28869, 28870, 28852
11857, 28583, 28591, 28592, 28584, 28870, 28871, 28872, 28854
11858, 28584, 28592, 28593, 28585, 28872, 28873, 28874, 28856
11859, 28585, 28593, 28594, 28586, 28874, 28875, 28876, 28858
11860, 28586, 28594, 28595, 28587, 28876, 28877, 28878, 28860
11861, 28587, 28595, 3328, 3327, 28878, 28879, 3350, 28862
11862, 3193, 3194, 28596, 28588, 3216, 28880, 28881, 28863
11863, 28588, 28596, 28597, 28589, 28881, 28882, 28883, 28865
11864, 28589, 28597, 28598, 28590, 28883, 28884, 28885, 28867
11865, 28590, 28598, 28599, 28591, 28885, 28886, 28887, 28869
11866, 28591, 28599, 28600, 28592, 28887, 28888, 28889, 28871
11867, 28592, 28600, 28601, 28593, 28889, 28890, 28891, 28873
11868, 28593, 28601, 28602, 28594, 28891, 28892, 28893, 28875
11869, 28594, 28602, 28603, 28595, 28893, 28894, 28895, 28877
11870, 28595, 28603, 3329, 3328, 28895, 28896, 3351, 28879
11871, 3194, 3195, 28604, 28596, 3217, 28897, 28898, 28880
11872, 28596, 28604, 28605, 28597, 28898, 28899, 28900, 28882
11873, 28597, 28605, 28606, 28598, 28900, 28901, 28902, 28884
11874, 28598, 28606, 28607, 28599, 28902, 28903, 28904, 28886
11875, 28599, 28607, 28608, 28600, 28904, 28905, 28906, 28888
11876, 28600, 28608, 28609, 28601, 28906, 28907, 28908, 28890
11877, 28601, 28609, 28610, 28602, 28908, 28909, 28910, 28892
11878, 28602, 28610, 28611, 28603, 28910, 28911, 28912, 28894
11879, 28603, 28611, 3330, 3329, 28912, 28913, 3352, 28896
11880, 3195, 3196, 28612, 28604, 3218, 28914, 28915, 28897
11881, 28604, 28612, 28613, 28605, 28915, 28916, 28917, 28899
11882, 28605, 28613, 28614, 28606, 28917, 28918, 28919, 28901
11883, 28606, 28614, 28615, 28607, 28919, 28920, 28921, 28903
11884, 28607, 28615, 28616, 28608, 28921, 28922, 28923, 28905
11885, 28608, 28616, 28617, 28609, 28923, 28924, 28925, 28907
11886, 28609, 28617, 28618, 28610, 28925, 28926, 28927, 28909
11887, 28610, 28618, 28619, 28611, 28927, 28928, 28929, 28911
11888, 28611, 28619, 3331, 3330, 28929, 28930, 3353, 28913
11889, 3196, 3197, 28620, 28612, 3219, 28931, 28932, 28914
11890, 28612, 28620, 28621, 28613, 28932, 28933, 28934, 28916
11891, 28613, 28621, 28622, 28614, 28934, 28935, 28936, 28918
11892, 28614, 28622, 28623, 28615, 28936, 28937, 28938, 28920
11893, 28615, 28623, 28624, 28616, 28938, 28939, 28940, 28922
11894, 28616, 28624, 28625, 28617, 28940, 28941, 28942, 28924
11895, 28617, 28625, 28626, 28618, 28942, 28943, 28944, 28926
11896, 28618, 28626, 28627, 28619, 28944, 28945, 28946, 28928
11897, 28619, 28627, 3332, 3331, 28946, 28947, 3354, 28930
11898, 3197, 3198, 28628, 28620, 3220, 28948, 28949, 28931
11899, 28620, 28628, 28629, 28621, 28949, 28950, 28951, 28933
11900, 28621, 28629, 28630, 28622, 28951, 28952, 28953, 28935
11901, 28622, 28630, 28631, 28623, 28953, 28954, 28955, 28937
11902, 28623, 28631, 28632, 28624, 28955, 28956, 28957, 28939
11903, 28624, 28632, 28633, 28625, 28957, 28958, 28959, 28941
11904, 28625, 28633, 28634, 28626, 28959, 28960, 28961, 28943
11905, 28626, 28634, 28635, 28627, 28961, 28962, 28963, 28945
11906, 28627, 28635, 3333, 3332, 28963, 28964, 3355, 28947
11907, 3198, 3199, 28636, 28628, 3221, 28965, 28966, 28948
11908, 28628, 28636, 28637, 28629, 28966, 28967, 28968, 28950
11909, 28629, 28637, 28638, 28630, 28968, 28969, 28970, 28952
11910, 28630, 28638, 28639, 28631, 28970, 28971, 28972, 28954
11911, 28631, 28639, 28640, 28632, 28972, 28973, 28974, 28956
11912, 28632, 28640, 28641, 28633, 28974, 28975, 28976, 28958
11913, 28633, 28641, 28642, 28634, 28976, 28977, 28978, 28960
11914, 28634, 28642, 28643, 28635, 28978, 28979, 28980, 28962
11915, 28635, 28643, 3334, 3333, 28980, 28981, 3356, 28964
11916, 3199, 3200, 28644, 28636, 3222, 28982, 28983, 28965
11917, 28636, 28644, 28645, 28637, 28983, 28984, 28985, 28967
11918, 28637, 28645, 28646, 28638, 28985, 28986, 28987, 28969
11919, 28638, 28646, 28647, 28639, 28987, 28988, 28989, 28971
11920, 28639, 28647, 28648, 28640, 28989, 28990, 28991, 28973
11921, 28640, 28648, 28649, 28641, 28991, 28992, 28993, 28975
11922, 28641, 28649, 28650, 28642, 28993, 28994, 28995, 28977
11923, 28642, 28650, 28651, 28643, 28995, 28996, 28997, 28979
11924, 28643, 28651, 3335, 3334, 28997, 28998, 3357, 28981
11925, 3200, 3201, 28652, 28644, 3223, 28999, 29000, 28982
11926, 28644, 28652, 28653, 28645, 29000, 29001, 29002, 28984
11927, 28645, 28653, 28654, 28646, 29002, 29003, 29004, 28986
11928, 28646, 28654, 28655, 28647, 29004, 29005, 29006, 28988
11929, 28647, 28655, 28656, 28648, 29006, 29007, 29008, 28990
11930, 28648, 28656, 28657, 28649, 29008, 29009, 29010, 28992
11931, 28649, 28657, 28658, 28650, 29010, 29011, 29012, 28994
11932, 28650, 28658, 28659, 28651, 29012, 29013, 29014, 28996
11933, 28651, 28659, 3336, 3335, 29014, 29015, 3358, 28998
11934, 3201, 3202, 28660, 28652, 3224, 29016, 29017, 28999
11935, 28652, 28660, 28661, 28653, 29017, 29018, 29019, 29001
11936, 28653, 28661, 28662, 28654, 29019, 29020, 29021, 29003
11937, 28654, 28662, 28663, 28655, 29021, 29022, 29023, 29005
11938, 28655, 28663, 28664, 28656, 29023, 29024, 29025, 29007
11939, 28656, 28664, 28665, 28657, 29025, 29026, 29027, 29009
