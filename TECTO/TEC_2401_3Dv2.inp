8658, 19766, 19774, 19775, 19767, 20005, 20006, 20007, 19989
8659, 19767, 19775, 19776, 19768, 20007, 20008, 20009, 19991
8660, 19768, 19776, 19777, 19769, 20009, 20010, 20011, 19993
8661, 19769, 19777, 19778, 19770, 20011, 20012, 20013, 19995
8662, 19770, 19778, 19779, 19771, 20013, 20014, 20015, 19997
8663, 19771, 19779, 19780, 19772, 20015, 20016, 20017, 19999
8664, 19772, 19780, 19781, 19773, 20017, 20018, 20019, 20001
8665, 19773, 19781, 2777, 2776, 20019, 20020, 2799, 20003
8666, 2709, 2710, 19782, 19774, 2732, 20021, 20022, 20004
8667, 19774, 19782, 19783, 19775, 20022, 20023, 20024, 20006
8668, 19775, 19783, 19784, 19776, 20024, 20025, 20026, 20008
8669, 19776, 19784, 19785, 19777, 20026, 20027, 20028, 20010
8670, 19777, 19785, 19786, 19778, 20028, 20029, 20030, 20012
8671, 19778, 19786, 19787, 19779, 20030, 20031, 20032, 20014
8672, 19779, 19787, 19788, 19780, 20032, 20033, 20034, 20016
8673, 19780, 19788, 19789, 19781, 20034, 20035, 20036, 20018
8674, 19781, 19789, 2778, 2777, 20036, 20037, 2800, 20020
8675, 2710, 2711, 19790, 19782, 2733, 20038, 20039, 20021
8676, 19782, 19790, 19791, 19783, 20039, 20040, 20041, 20023
8677, 19783, 19791, 19792, 19784, 20041, 20042, 20043, 20025
8678, 19784, 19792, 19793, 19785, 20043, 20044, 20045, 20027
8679, 19785, 19793, 19794, 19786, 20045, 20046, 20047, 20029
8680, 19786, 19794, 19795, 19787, 20047, 20048, 20049, 20031
8681, 19787, 19795, 19796, 19788, 20049, 20050, 20051, 20033
8682, 19788, 19796, 19797, 19789, 20051, 20052, 20053, 20035
8683, 19789, 19797, 2779, 2778, 20053, 20054, 2801, 20037
8684, 2711, 2712, 19798, 19790, 2734, 20055, 20056, 20038
8685, 19790, 19798, 19799, 19791, 20056, 20057, 20058, 20040
8686, 19791, 19799, 19800, 19792, 20058, 20059, 20060, 20042
8687, 19792, 19800, 19801, 19793, 20060, 20061, 20062, 20044
8688, 19793, 19801, 19802, 19794, 20062, 20063, 20064, 20046
8689, 19794, 19802, 19803, 19795, 20064, 20065, 20066, 20048
8690, 19795, 19803, 19804, 19796, 20066, 20067, 20068, 20050
8691, 19796, 19804, 19805, 19797, 20068, 20069, 20070, 20052
8692, 19797, 19805, 2780, 2779, 20070, 20071, 2802, 20054
8693, 2712, 2713, 19806, 19798, 2735, 20072, 20073, 20055
8694, 19798, 19806, 19807, 19799, 20073, 20074, 20075, 20057
8695, 19799, 19807, 19808, 19800, 20075, 20076, 20077, 20059
8696, 19800, 19808, 19809, 19801, 20077, 20078, 20079, 20061
8697, 19801, 19809, 19810, 19802, 20079, 20080, 20081, 20063
8698, 19802, 19810, 19811, 19803, 20081, 20082, 20083, 20065
8699, 19803, 19811, 19812, 19804, 20083, 20084, 20085, 20067
8700, 19804, 19812, 19813, 19805, 20085, 20086, 20087, 20069
8701, 19805, 19813, 2781, 2780, 20087, 20088, 2803, 20071
8702, 2713, 2714, 19814, 19806, 2736, 20089, 20090, 20072
8703, 19806, 19814, 19815, 19807, 20090, 20091, 20092, 20074
8704, 19807, 19815, 19816, 19808, 20092, 20093, 20094, 20076
8705, 19808, 19816, 19817, 19809, 20094, 20095, 20096, 20078
8706, 19809, 19817, 19818, 19810, 20096, 20097, 20098, 20080
8707, 19810, 19818, 19819, 19811, 20098, 20099, 20100, 20082
8708, 19811, 19819, 19820, 19812, 20100, 20101, 20102, 20084
8709, 19812, 19820, 19821, 19813, 20102, 20103, 20104, 20086
8710, 19813, 19821, 2782, 2781, 20104, 20105, 2804, 20088
8711, 2714, 2715, 19822, 19814, 2737, 20106, 20107, 20089
8712, 19814, 19822, 19823, 19815, 20107, 20108, 20109, 20091
8713, 19815, 19823, 19824, 19816, 20109, 20110, 20111, 20093
8714, 19816, 19824, 19825, 19817, 20111, 20112, 20113, 20095
8715, 19817, 19825, 19826, 19818, 20113, 20114, 20115, 20097
8716, 19818, 19826, 19827, 19819, 20115, 20116, 20117, 20099
8717, 19819, 19827, 19828, 19820, 20117, 20118, 20119, 20101
8718, 19820, 19828, 19829, 19821, 20119, 20120, 20121, 20103
8719, 19821, 19829, 2783, 2782, 20121, 20122, 2805, 20105
8720, 2715, 2716, 19830, 19822, 2738, 20123, 20124, 20106
8721, 19822, 19830, 19831, 19823, 20124, 20125, 20126, 20108
8722, 19823, 19831, 19832, 19824, 20126, 20127, 20128, 20110
8723, 19824, 19832, 19833, 19825, 20128, 20129, 20130, 20112
8724, 19825, 19833, 19834, 19826, 20130, 20131, 20132, 20114
8725, 19826, 19834, 19835, 19827, 20132, 20133, 20134, 20116
8726, 19827, 19835, 19836, 19828, 20134, 20135, 20136, 20118
8727, 19828, 19836, 19837, 19829, 20136, 20137, 20138, 20120
8728, 19829, 19837, 2784, 2783, 20138, 20139, 2806, 20122
8729, 2716, 2717, 19838, 19830, 2739, 20140, 20141, 20123
8730, 19830, 19838, 19839, 19831, 20141, 20142, 20143, 20125
8731, 19831, 19839, 19840, 19832, 20143, 20144, 20145, 20127
8732, 19832, 19840, 19841, 19833, 20145, 20146, 20147, 20129
8733, 19833, 19841, 19842, 19834, 20147, 20148, 20149, 20131
8734, 19834, 19842, 19843, 19835, 20149, 20150, 20151, 20133
8735, 19835, 19843, 19844, 19836, 20151, 20152, 20153, 20135
8736, 19836, 19844, 19845, 19837, 20153, 20154, 20155, 20137
8737, 19837, 19845, 2785, 2784, 20155, 20156, 2807, 20139
8738, 2717, 2718, 19846, 19838, 2740, 20157, 20158, 20140
8739, 19838, 19846, 19847, 19839, 20158, 20159, 20160, 20142
8740, 19839, 19847, 19848, 19840, 20160, 20161, 20162, 20144
8741, 19840, 19848, 19849, 19841, 20162, 20163, 20164, 20146
8742, 19841, 19849, 19850, 19842, 20164, 20165, 20166, 20148
8743, 19842, 19850, 19851, 19843, 20166, 20167, 20168, 20150
8744, 19843, 19851, 19852, 19844, 20168, 20169, 20170, 20152
8745, 19844, 19852, 19853, 19845, 20170, 20171, 20172, 20154
8746, 19845, 19853, 2786, 2785, 20172, 20173, 2808, 20156
8747, 2718, 2719, 19854, 19846, 2741, 20174, 20175, 20157
8748, 19846, 19854, 19855, 19847, 20175, 20176, 20177, 20159
8749, 19847, 19855, 19856, 19848, 20177, 20178, 20179, 20161
8750, 19848, 19856, 19857, 19849, 20179, 20180, 20181, 20163
8751, 19849, 19857, 19858, 19850, 20181, 20182, 20183, 20165
8752, 19850, 19858, 19859, 19851, 20183, 20184, 20185, 20167
8753, 19851, 19859, 19860, 19852, 20185, 20186, 20187, 20169
8754, 19852, 19860, 19861, 19853, 20187, 20188, 20189, 20171
8755, 19853, 19861, 2787, 2786, 20189, 20190, 2809, 20173
8756, 2719, 2720, 19862, 19854, 2742, 20191, 20192, 20174
8757, 19854, 19862, 19863, 19855, 20192, 20193, 20194, 20176
8758, 19855, 19863, 19864, 19856, 20194, 20195, 20196, 20178
8759, 19856, 19864, 19865, 19857, 20196, 20197, 20198, 20180
8760, 19857, 19865, 19866, 19858, 20198, 20199, 20200, 20182
8761, 19858, 19866, 19867, 19859, 20200, 20201, 20202, 20184
8762, 19859, 19867, 19868, 19860, 20202, 20203, 20204, 20186
8763, 19860, 19868, 19869, 19861, 20204, 20205, 20206, 20188
8764, 19861, 19869, 2788, 2787, 20206, 20207, 2810, 20190
8765, 2720, 2721, 19870, 19862, 2743, 20208, 20209, 20191
8766, 19862, 19870, 19871, 19863, 20209, 20210, 20211, 20193
8767, 19863, 19871, 19872, 19864, 20211, 20212, 20213, 20195
8768, 19864, 19872, 19873, 19865, 20213, 20214, 20215, 20197
8769, 19865, 19873, 19874, 19866, 20215, 20216, 20217, 20199
8770, 19866, 19874, 19875, 19867, 20217, 20218, 20219, 20201
8771, 19867, 19875, 19876, 19868, 20219, 20220, 20221, 20203
8772, 19868, 19876, 19877, 19869, 20221, 20222, 20223, 20205
8773, 19869, 19877, 2789, 2788, 20223, 20224, 2811, 20207
8774, 2721, 2722, 19878, 19870, 2744, 20225, 20226, 20208
8775, 19870, 19878, 19879, 19871, 20226, 20227, 20228, 20210
8776, 19871, 19879, 19880, 19872, 20228, 20229, 20230, 20212
8777, 19872, 19880, 19881, 19873, 20230, 20231, 20232, 20214
8778, 19873, 19881, 19882, 19874, 20232, 20233, 20234, 20216
8779, 19874, 19882, 19883, 19875, 20234, 20235, 20236, 20218
8780, 19875, 19883, 19884, 19876, 20236, 20237, 20238, 20220
8781, 19876, 19884, 19885, 19877, 20238, 20239, 20240, 20222
8782, 19877, 19885, 2790, 2789, 20240, 20241, 2812, 20224
8783, 2722, 2723, 19886, 19878, 2745, 20242, 20243, 20225
8784, 19878, 19886, 19887, 19879, 20243, 20244, 20245, 20227
8785, 19879, 19887, 19888, 19880, 20245, 20246, 20247, 20229
8786, 19880, 19888, 19889, 19881, 20247, 20248, 20249, 20231
8787, 19881, 19889, 19890, 19882, 20249, 20250, 20251, 20233
8788, 19882, 19890, 19891, 19883, 20251, 20252, 20253, 20235
8789, 19883, 19891, 19892, 19884, 20253, 20254, 20255, 20237
8790, 19884, 19892, 19893, 19885, 20255, 20256, 20257, 20239
8791, 19885, 19893, 2791, 2790, 20257, 20258, 2813, 20241
8792, 2723, 2724, 19894, 19886, 2746, 20259, 20260, 20242
8793, 19886, 19894, 19895, 19887, 20260, 20261, 20262, 20244
8794, 19887, 19895, 19896, 19888, 20262, 20263, 20264, 20246
8795, 19888, 19896, 19897, 19889, 20264, 20265, 20266, 20248
8796, 19889, 19897, 19898, 19890, 20266, 20267, 20268, 20250
8797, 19890, 19898, 19899, 19891, 20268, 20269, 20270, 20252
8798, 19891, 19899, 19900, 19892, 20270, 20271, 20272, 20254
8799, 19892, 19900, 19901, 19893, 20272, 20273, 20274, 20256
8800, 19893, 19901, 2792, 2791, 20274, 20275, 2814, 20258
8801, 2724, 85, 2751, 19894, 2747, 2759, 20276, 20259
8802, 19894, 2751, 2752, 19895, 20276, 2760, 20277, 20261
8803, 19895, 2752, 2753, 19896, 20277, 2761, 20278, 20263
8804, 19896, 2753, 2754, 19897, 20278, 2762, 20279, 20265
8805, 19897, 2754, 2755, 19898, 20279, 2763, 20280, 20267
8806, 19898, 2755, 2756, 19899, 20280, 2764, 20281, 20269
8807, 19899, 2756, 2757, 19900, 20281, 2765, 20282, 20271
8808, 19900, 2757, 2758, 19901, 20282, 2766, 20283, 20273
8809, 19901, 2758, 87, 2792, 20283, 2767, 2815, 20275
*ELEMENT, type=CPS8, ELSET=Surface260
8810, 1, 142, 20284, 2833, 165, 20768, 20769, 2855
8811, 142, 141, 20285, 20284, 164, 20770, 20771, 20768
8812, 141, 140, 20286, 20285, 163, 20772, 20773, 20770
8813, 140, 139, 20287, 20286, 162, 20774, 20775, 20772
8814, 139, 138, 20288, 20287, 161, 20776, 20777, 20774
8815, 138, 137, 20289, 20288, 160, 20778, 20779, 20776
8816, 137, 136, 20290, 20289, 159, 20780, 20781, 20778
8817, 136, 135, 20291, 20290, 158, 20782, 20783, 20780
8818, 135, 134, 20292, 20291, 157, 20784, 20785, 20782
8819, 134, 133, 20293, 20292, 156, 20786, 20787, 20784
8820, 133, 132, 20294, 20293, 155, 20788, 20789, 20786
8821, 132, 131, 20295, 20294, 154, 20790, 20791, 20788
8822, 131, 130, 20296, 20295, 153, 20792, 20793, 20790
8823, 130, 129, 20297, 20296, 152, 20794, 20795, 20792
8824, 129, 128, 20298, 20297, 151, 20796, 20797, 20794
8825, 128, 127, 20299, 20298, 150, 20798, 20799, 20796
8826, 127, 126, 20300, 20299, 149, 20800, 20801, 20798
8827, 126, 125, 20301, 20300, 148, 20802, 20803, 20800
8828, 125, 124, 20302, 20301, 147, 20804, 20805, 20802
8829, 124, 123, 20303, 20302, 146, 20806, 20807, 20804
8830, 123, 122, 20304, 20303, 145, 20808, 20809, 20806
8831, 122, 121, 20305, 20304, 144, 20810, 20811, 20808
8832, 121, 2, 2878, 20305, 143, 2900, 20812, 20810
8833, 2833, 20284, 20306, 2834, 20769, 20813, 20814, 2856
8834, 20284, 20285, 20307, 20306, 20771, 20815, 20816, 20813
8835, 20285, 20286, 20308, 20307, 20773, 20817, 20818, 20815
8836, 20286, 20287, 20309, 20308, 20775, 20819, 20820, 20817
8837, 20287, 20288, 20310, 20309, 20777, 20821, 20822, 20819
8838, 20288, 20289, 20311, 20310, 20779, 20823, 20824, 20821
8839, 20289, 20290, 20312, 20311, 20781, 20825, 20826, 20823
8840, 20290, 20291, 20313, 20312, 20783, 20827, 20828, 20825
8841, 20291, 20292, 20314, 20313, 20785, 20829, 20830, 20827
8842, 20292, 20293, 20315, 20314, 20787, 20831, 20832, 20829
8843, 20293, 20294, 20316, 20315, 20789, 20833, 20834, 20831
8844, 20294, 20295, 20317, 20316, 20791, 20835, 20836, 20833
8845, 20295, 20296, 20318, 20317, 20793, 20837, 20838, 20835
8846, 20296, 20297, 20319, 20318, 20795, 20839, 20840, 20837
8847, 20297, 20298, 20320, 20319, 20797, 20841, 20842, 20839
8848, 20298, 20299, 20321, 20320, 20799, 20843, 20844, 20841
8849, 20299, 20300, 20322, 20321, 20801, 20845, 20846, 20843
8850, 20300, 20301, 20323, 20322, 20803, 20847, 20848, 20845
8851, 20301, 20302, 20324, 20323, 20805, 20849, 20850, 20847
8852, 20302, 20303, 20325, 20324, 20807, 20851, 20852, 20849
8853, 20303, 20304, 20326, 20325, 20809, 20853, 20854, 20851
8854, 20304, 20305, 20327, 20326, 20811, 20855, 20856, 20853
8855, 20305, 2878, 2879, 20327, 20812, 2901, 20857, 20855
8856, 2834, 20306, 20328, 2835, 20814, 20858, 20859, 2857
8857, 20306, 20307, 20329, 20328, 20816, 20860, 20861, 20858
8858, 20307, 20308, 20330, 20329, 20818, 20862, 20863, 20860
8859, 20308, 20309, 20331, 20330, 20820, 20864, 20865, 20862
8860, 20309, 20310, 20332, 20331, 20822, 20866, 20867, 20864
8861, 20310, 20311, 20333, 20332, 20824, 20868, 20869, 20866
8862, 20311, 20312, 20334, 20333, 20826, 20870, 20871, 20868
8863, 20312, 20313, 20335, 20334, 20828, 20872, 20873, 20870
8864, 20313, 20314, 20336, 20335, 20830, 20874, 20875, 20872
8865, 20314, 20315, 20337, 20336, 20832, 20876, 20877, 20874
8866, 20315, 20316, 20338, 20337, 20834, 20878, 20879, 20876
8867, 20316, 20317, 20339, 20338, 20836, 20880, 20881, 20878
8868, 20317, 20318, 20340, 20339, 20838, 20882, 20883, 20880
8869, 20318, 20319, 20341, 20340, 20840, 20884, 20885, 20882
8870, 20319, 20320, 20342, 20341, 20842, 20886, 20887, 20884
8871, 20320, 20321, 20343, 20342, 20844, 20888, 20889, 20886
8872, 20321, 20322, 20344, 20343, 20846, 20890, 20891, 20888
8873, 20322, 20323, 20345, 20344, 20848, 20892, 20893, 20890
8874, 20323, 20324, 20346, 20345, 20850, 20894, 20895, 20892
8875, 20324, 20325, 20347, 20346, 20852, 20896, 20897, 20894
8876, 20325, 20326, 20348, 20347, 20854, 20898, 20899, 20896
8877, 20326, 20327, 20349, 20348, 20856, 20900, 20901, 20898
8878, 20327, 2879, 2880, 20349, 20857, 2902, 20902, 20900
8879, 2835, 20328, 20350, 2836, 20859, 20903, 20904, 2858
8880, 20328, 20329, 20351, 20350, 20861, 20905, 20906, 20903
8881, 20329, 20330, 20352, 20351, 20863, 20907, 20908, 20905
8882, 20330, 20331, 20353, 20352, 20865, 20909, 20910, 20907
8883, 20331, 20332, 20354, 20353, 20867, 20911, 20912, 20909
8884, 20332, 20333, 20355, 20354, 20869, 20913, 20914, 20911
8885, 20333, 20334, 20356, 20355, 20871, 20915, 20916, 20913
8886, 20334, 20335, 20357, 20356, 20873, 20917, 20918, 20915
8887, 20335, 20336, 20358, 20357, 20875, 20919, 20920, 20917
8888, 20336, 20337, 20359, 20358, 20877, 20921, 20922, 20919
8889, 20337, 20338, 20360, 20359, 20879, 20923, 20924, 20921
8890, 20338, 20339, 20361, 20360, 20881, 20925, 20926, 20923
8891, 20339, 20340, 20362, 20361, 20883, 20927, 20928, 20925
8892, 20340, 20341, 20363, 20362, 20885, 20929, 20930, 20927
8893, 20341, 20342, 20364, 20363, 20887, 20931, 20932, 20929
8894, 20342, 20343, 20365, 20364, 20889, 20933, 20934, 20931
8895, 20343, 20344, 20366, 20365, 20891, 20935, 20936, 20933
8896, 20344, 20345, 20367, 20366, 20893, 20937, 20938, 20935
8897, 20345, 20346, 20368, 20367, 20895, 20939, 20940, 20937
8898, 20346, 20347, 20369, 20368, 20897, 20941, 20942, 20939
8899, 20347, 20348, 20370, 20369, 20899, 20943, 20944, 20941
8900, 20348, 20349, 20371, 20370, 20901, 20945, 20946, 20943
8901, 20349, 2880, 2881, 20371, 20902, 2903, 20947, 20945
8902, 2836, 20350, 20372, 2837, 20904, 20948, 20949, 2859
8903, 20350, 20351, 20373, 20372, 20906, 20950, 20951, 20948
8904, 20351, 20352, 20374, 20373, 20908, 20952, 20953, 20950
8905, 20352, 20353, 20375, 20374, 20910, 20954, 20955, 20952
8906, 20353, 20354, 20376, 20375, 20912, 20956, 20957, 20954
8907, 20354, 20355, 20377, 20376, 20914, 20958, 20959, 20956
8908, 20355, 20356, 20378, 20377, 20916, 20960, 20961, 20958
8909, 20356, 20357, 20379, 20378, 20918, 20962, 20963, 20960
8910, 20357, 20358, 20380, 20379, 20920, 20964, 20965, 20962
8911, 20358, 20359, 20381, 20380, 20922, 20966, 20967, 20964
8912, 20359, 20360, 20382, 20381, 20924, 20968, 20969, 20966
8913, 20360, 20361, 20383, 20382, 20926, 20970, 20971, 20968
8914, 20361, 20362, 20384, 20383, 20928, 20972, 20973, 20970
8915, 20362, 20363, 20385, 20384, 20930, 20974, 20975, 20972
8916, 20363, 20364, 20386, 20385, 20932, 20976, 20977, 20974
8917, 20364, 20365, 20387, 20386, 20934, 20978, 20979, 20976
8918, 20365, 20366, 20388, 20387, 20936, 20980, 20981, 20978
8919, 20366, 20367, 20389, 20388, 20938, 20982, 20983, 20980
8920, 20367, 20368, 20390, 20389, 20940, 20984, 20985, 20982
8921, 20368, 20369, 20391, 20390, 20942, 20986, 20987, 20984
8922, 20369, 20370, 20392, 20391, 20944, 20988, 20989, 20986
8923, 20370, 20371, 20393, 20392, 20946, 20990, 20991, 20988
8924, 20371, 2881, 2882, 20393, 20947, 2904, 20992, 20990
8925, 2837, 20372, 20394, 2838, 20949, 20993, 20994, 2860
8926, 20372, 20373, 20395, 20394, 20951, 20995, 20996, 20993
8927, 20373, 20374, 20396, 20395, 20953, 20997, 20998, 20995
8928, 20374, 20375, 20397, 20396, 20955, 20999, 21000, 20997
8929, 20375, 20376, 20398, 20397, 20957, 21001, 21002, 20999
8930, 20376, 20377, 20399, 20398, 20959, 21003, 21004, 21001
8931, 20377, 20378, 20400, 20399, 20961, 21005, 21006, 21003
8932, 20378, 20379, 20401, 20400, 20963, 21007, 21008, 21005
8933, 20379, 20380, 20402, 20401, 20965, 21009, 21010, 21007
8934, 20380, 20381, 20403, 20402, 20967, 21011, 21012, 21009
8935, 20381, 20382, 20404, 20403, 20969, 21013, 21014, 21011
8936, 20382, 20383, 20405, 20404, 20971, 21015, 21016, 21013
8937, 20383, 20384, 20406, 20405, 20973, 21017, 21018, 21015
8938, 20384, 20385, 20407, 20406, 20975, 21019, 21020, 21017
8939, 20385, 20386, 20408, 20407, 20977, 21021, 21022, 21019
8940, 20386, 20387, 20409, 20408, 20979, 21023, 21024, 21021
8941, 20387, 20388, 20410, 20409, 20981, 21025, 21026, 21023
8942, 20388, 20389, 20411, 20410, 20983, 21027, 21028, 21025
8943, 20389, 20390, 20412, 20411, 20985, 21029, 21030, 21027
8944, 20390, 20391, 20413, 20412, 20987, 21031, 21032, 21029
8945, 20391, 20392, 20414, 20413, 20989, 21033, 21034, 21031
8946, 20392, 20393, 20415, 20414, 20991, 21035, 21036, 21033
8947, 20393, 2882, 2883, 20415, 20992, 2905, 21037, 21035
8948, 2838, 20394, 20416, 2839, 20994, 21038, 21039, 2861
8949, 20394, 20395, 20417, 20416, 20996, 21040, 21041, 21038
8950, 20395, 20396, 20418, 20417, 20998, 21042, 21043, 21040
8951, 20396, 20397, 20419, 20418, 21000, 21044, 21045, 21042
8952, 20397, 20398, 20420, 20419, 21002, 21046, 21047, 21044
8953, 20398, 20399, 20421, 20420, 21004, 21048, 21049, 21046
8954, 20399, 20400, 20422, 20421, 21006, 21050, 21051, 21048
8955, 20400, 20401, 20423, 20422, 21008, 21052, 21053, 21050
8956, 20401, 20402, 20424, 20423, 21010, 21054, 21055, 21052
8957, 20402, 20403, 20425, 20424, 21012, 21056, 21057, 21054
8958, 20403, 20404, 20426, 20425, 21014, 21058, 21059, 21056
8959, 20404, 20405, 20427, 20426, 21016, 21060, 21061, 21058
8960, 20405, 20406, 20428, 20427, 21018, 21062, 21063, 21060
8961, 20406, 20407, 20429, 20428, 21020, 21064, 21065, 21062
8962, 20407, 20408, 20430, 20429, 21022, 21066, 21067, 21064
8963, 20408, 20409, 20431, 20430, 21024, 21068, 21069, 21066
8964, 20409, 20410, 20432, 20431, 21026, 21070, 21071, 21068
8965, 20410, 20411, 20433, 20432, 21028, 21072, 21073, 21070
8966, 20411, 20412, 20434, 20433, 21030, 21074, 21075, 21072
8967, 20412, 20413, 20435, 20434, 21032, 21076, 21077, 21074
8968, 20413, 20414, 20436, 20435, 21034, 21078, 21079, 21076
8969, 20414, 20415, 20437, 20436, 21036, 21080, 21081, 21078
8970, 20415, 2883, 2884, 20437, 21037, 2906, 21082, 21080
8971, 2839, 20416, 20438, 2840, 21039, 21083, 21084, 2862
8972, 20416, 20417, 20439, 20438, 21041, 21085, 21086, 21083
8973, 20417, 20418, 20440, 20439, 21043, 21087, 21088, 21085
8974, 20418, 20419, 20441, 20440, 21045, 21089, 21090, 21087
8975, 20419, 20420, 20442, 20441, 21047, 21091, 21092, 21089
8976, 20420, 20421, 20443, 20442, 21049, 21093, 21094, 21091
8977, 20421, 20422, 20444, 20443, 21051, 21095, 21096, 21093
8978, 20422, 20423, 20445, 20444, 21053, 21097, 21098, 21095
8979, 20423, 20424, 20446, 20445, 21055, 21099, 21100, 21097
8980, 20424, 20425, 20447, 20446, 21057, 21101, 21102, 21099
8981, 20425, 20426, 20448, 20447, 21059, 21103, 21104, 21101
8982, 20426, 20427, 20449, 20448, 21061, 21105, 21106, 21103
8983, 20427, 20428, 20450, 20449, 21063, 21107, 21108, 21105
8984, 20428, 20429, 20451, 20450, 21065, 21109, 21110, 21107
8985, 20429, 20430, 20452, 20451, 21067, 21111, 21112, 21109
8986, 20430, 20431, 20453, 20452, 21069, 21113, 21114, 21111
8987, 20431, 20432, 20454, 20453, 21071, 21115, 21116, 21113
8988, 20432, 20433, 20455, 20454, 21073, 21117, 21118, 21115
8989, 20433, 20434, 20456, 20455, 21075, 21119, 21120, 21117
8990, 20434, 20435, 20457, 20456, 21077, 21121, 21122, 21119
8991, 20435, 20436, 20458, 20457, 21079, 21123, 21124, 21121
8992, 20436, 20437, 20459, 20458, 21081, 21125, 21126, 21123
8993, 20437, 2884, 2885, 20459, 21082, 2907, 21127, 21125
8994, 2840, 20438, 20460, 2841, 21084, 21128, 21129, 2863
8995, 20438, 20439, 20461, 20460, 21086, 21130, 21131, 21128
8996, 20439, 20440, 20462, 20461, 21088, 21132, 21133, 21130
8997, 20440, 20441, 20463, 20462, 21090, 21134, 21135, 21132
8998, 20441, 20442, 20464, 20463, 21092, 21136, 21137, 21134
8999, 20442, 20443, 20465, 20464, 21094, 21138, 21139, 21136
9000, 20443, 20444, 20466, 20465, 21096, 21140, 21141, 21138
9001, 20444, 20445, 20467, 20466, 21098, 21142, 21143, 21140
9002, 20445, 20446, 20468, 20467, 21100, 21144, 21145, 21142
9003, 20446, 20447, 20469, 20468, 21102, 21146, 21147, 21144
9004, 20447, 20448, 20470, 20469, 21104, 21148, 21149, 21146
9005, 20448, 20449, 20471, 20470, 21106, 21150, 21151, 21148
9006, 20449, 20450, 20472, 20471, 21108, 21152, 21153, 21150
9007, 20450, 20451, 20473, 20472, 21110, 21154, 21155, 21152
9008, 20451, 20452, 20474, 20473, 21112, 21156, 21157, 21154
9009, 20452, 20453, 20475, 20474, 21114, 21158, 21159, 21156
9010, 20453, 20454, 20476, 20475, 21116, 21160, 21161, 21158
9011, 20454, 20455, 20477, 20476, 21118, 21162, 21163, 21160
9012, 20455, 20456, 20478, 20477, 21120, 21164, 21165, 21162
9013, 20456, 20457, 20479, 20478, 21122, 21166, 21167, 21164
9014, 20457, 20458, 20480, 20479, 21124, 21168, 21169, 21166
9015, 20458, 20459, 20481, 20480, 21126, 21170, 21171, 21168
9016, 20459, 2885, 2886, 20481, 21127, 2908, 21172, 21170
9017, 2841, 20460, 20482, 2842, 21129, 21173, 21174, 2864
9018, 20460, 20461, 20483, 20482, 21131, 21175, 21176, 21173
9019, 20461, 20462, 20484, 20483, 21133, 21177, 21178, 21175
9020, 20462, 20463, 20485, 20484, 21135, 21179, 21180, 21177
9021, 20463, 20464, 20486, 20485, 21137, 21181, 21182, 21179
9022, 20464, 20465, 20487, 20486, 21139, 21183, 21184, 21181
9023, 20465, 20466, 20488, 20487, 21141, 21185, 21186, 21183
9024, 20466, 20467, 20489, 20488, 21143, 21187, 21188, 21185
9025, 20467, 20468, 20490, 20489, 21145, 21189, 21190, 21187
9026, 20468, 20469, 20491, 20490, 21147, 21191, 21192, 21189
9027, 20469, 20470, 20492, 20491, 21149, 21193, 21194, 21191
9028, 20470, 20471, 20493, 20492, 21151, 21195, 21196, 21193
9029, 20471, 20472, 20494, 20493, 21153, 21197, 21198, 21195
9030, 20472, 20473, 20495, 20494, 21155, 21199, 21200, 21197
9031, 20473, 20474, 20496, 20495, 21157, 21201, 21202, 21199
9032, 20474, 20475, 20497, 20496, 21159, 21203, 21204, 21201
9033, 20475, 20476, 20498, 20497, 21161, 21205, 21206, 21203
9034, 20476, 20477, 20499, 20498, 21163, 21207, 21208, 21205
9035, 20477, 20478, 20500, 20499, 21165, 21209, 21210, 21207
9036, 20478, 20479, 20501, 20500, 21167, 21211, 21212, 21209
9037, 20479, 20480, 20502, 20501, 21169, 21213, 21214, 21211
9038, 20480, 20481, 20503, 20502, 21171, 21215, 21216, 21213
9039, 20481, 2886, 2887, 20503, 21172, 2909, 21217, 21215
9040, 2842, 20482, 20504, 2843, 21174, 21218, 21219, 2865
9041, 20482, 20483, 20505, 20504, 21176, 21220, 21221, 21218
9042, 20483, 20484, 20506, 20505, 21178, 21222, 21223, 21220
9043, 20484, 20485, 20507, 20506, 21180, 21224, 21225, 21222
9044, 20485, 20486, 20508, 20507, 21182, 21226, 21227, 21224
9045, 20486, 20487, 20509, 20508, 21184, 21228, 21229, 21226
9046, 20487, 20488, 20510, 20509, 21186, 21230, 21231, 21228
9047, 20488, 20489, 20511, 20510, 21188, 21232, 21233, 21230
9048, 20489, 20490, 20512, 20511, 21190, 21234, 21235, 21232
9049, 20490, 20491, 20513, 20512, 21192, 21236, 21237, 21234
9050, 20491, 20492, 20514, 20513, 21194, 21238, 21239, 21236
9051, 20492, 20493, 20515, 20514, 21196, 21240, 21241, 21238
9052, 20493, 20494, 20516, 20515, 21198, 21242, 21243, 21240
9053, 20494, 20495, 20517, 20516, 21200, 21244, 21245, 21242
9054, 20495, 20496, 20518, 20517, 21202, 21246, 21247, 21244
9055, 20496, 20497, 20519, 20518, 21204, 21248, 21249, 21246
9056, 20497, 20498, 20520, 20519, 21206, 21250, 21251, 21248
9057, 20498, 20499, 20521, 20520, 21208, 21252, 21253, 21250
9058, 20499, 20500, 20522, 20521, 21210, 21254, 21255, 21252
9059, 20500, 20501, 20523, 20522, 21212, 21256, 21257, 21254
9060, 20501, 20502, 20524, 20523, 21214, 21258, 21259, 21256
9061, 20502, 20503, 20525, 20524, 21216, 21260, 21261, 21258
9062, 20503, 2887, 2888, 20525, 21217, 2910, 21262, 21260
9063, 2843, 20504, 20526, 2844, 21219, 21263, 21264, 2866
9064, 20504, 20505, 20527, 20526, 21221, 21265, 21266, 21263
9065, 20505, 20506, 20528, 20527, 21223, 21267, 21268, 21265
9066, 20506, 20507, 20529, 20528, 21225, 21269, 21270, 21267
9067, 20507, 20508, 20530, 20529, 21227, 21271, 21272, 21269
9068, 20508, 20509, 20531, 20530, 21229, 21273, 21274, 21271
9069, 20509, 20510, 20532, 20531, 21231, 21275, 21276, 21273
9070, 20510, 20511, 20533, 20532, 21233, 21277, 21278, 21275
9071, 20511, 20512, 20534, 20533, 21235, 21279, 21280, 21277
9072, 20512, 20513, 20535, 20534, 21237, 21281, 21282, 21279
9073, 20513, 20514, 20536, 20535, 21239, 21283, 21284, 21281
9074, 20514, 20515, 20537, 20536, 21241, 21285, 21286, 21283
9075, 20515, 20516, 20538, 20537, 21243, 21287, 21288, 21285
9076, 20516, 20517, 20539, 20538, 21245, 21289, 21290, 21287
9077, 20517, 20518, 20540, 20539, 21247, 21291, 21292, 21289
9078, 20518, 20519, 20541, 20540, 21249, 21293, 21294, 21291
9079, 20519, 20520, 20542, 20541, 21251, 21295, 21296, 21293
9080, 20520, 20521, 20543, 20542, 21253, 21297, 21298, 21295
9081, 20521, 20522, 20544, 20543, 21255, 21299, 21300, 21297
9082, 20522, 20523, 20545, 20544, 21257, 21301, 21302, 21299
9083, 20523, 20524, 20546, 20545, 21259, 21303, 21304, 21301
9084, 20524, 20525, 20547, 20546, 21261, 21305, 21306, 21303
9085, 20525, 2888, 2889, 20547, 21262, 2911, 21307, 21305
9086, 2844, 20526, 20548, 2845, 21264, 21308, 21309, 2867
9087, 20526, 20527, 20549, 20548, 21266, 21310, 21311, 21308
9088, 20527, 20528, 20550, 20549, 21268, 21312, 21313, 21310
9089, 20528, 20529, 20551, 20550, 21270, 21314, 21315, 21312
9090, 20529, 20530, 20552, 20551, 21272, 21316, 21317, 21314
9091, 20530, 20531, 20553, 20552, 21274, 21318, 21319, 21316
9092, 20531, 20532, 20554, 20553, 21276, 21320, 21321, 21318
9093, 20532, 20533, 20555, 20554, 21278, 21322, 21323, 21320
9094, 20533, 20534, 20556, 20555, 21280, 21324, 21325, 21322
9095, 20534, 20535, 20557, 20556, 21282, 21326, 21327, 21324
9096, 20535, 20536, 20558, 20557, 21284, 21328, 21329, 21326
9097, 20536, 20537, 20559, 20558, 21286, 21330, 21331, 21328
9098, 20537, 20538, 20560, 20559, 21288, 21332, 21333, 21330
9099, 20538, 20539, 20561, 20560, 21290, 21334, 21335, 21332
9100, 20539, 20540, 20562, 20561, 21292, 21336, 21337, 21334
9101, 20540, 20541, 20563, 20562, 21294, 21338, 21339, 21336
9102, 20541, 20542, 20564, 20563, 21296, 21340, 21341, 21338
9103, 20542, 20543, 20565, 20564, 21298, 21342, 21343, 21340
9104, 20543, 20544, 20566, 20565, 21300, 21344, 21345, 21342
9105, 20544, 20545, 20567, 20566, 21302, 21346, 21347, 21344
9106, 20545, 20546, 20568, 20567, 21304, 21348, 21349, 21346
9107, 20546, 20547, 20569, 20568, 21306, 21350, 21351, 21348
9108, 20547, 2889, 2890, 20569, 21307, 2912, 21352, 21350
9109, 2845, 20548, 20570, 2846, 21309, 21353, 21354, 2868
9110, 20548, 20549, 20571, 20570, 21311, 21355, 21356, 21353
9111, 20549, 20550, 20572, 20571, 21313, 21357, 21358, 21355
9112, 20550, 20551, 20573, 20572, 21315, 21359, 21360, 21357
9113, 20551, 20552, 20574, 20573, 21317, 21361, 21362, 21359
9114, 20552, 20553, 20575, 20574, 21319, 21363, 21364, 21361
9115, 20553, 20554, 20576, 20575, 21321, 21365, 21366, 21363
9116, 20554, 20555, 20577, 20576, 21323, 21367, 21368, 21365
9117, 20555, 20556, 20578, 20577, 21325, 21369, 21370, 21367
9118, 20556, 20557, 20579, 20578, 21327, 21371, 21372, 21369
9119, 20557, 20558, 20580, 20579, 21329, 21373, 21374, 21371
9120, 20558, 20559, 20581, 20580, 21331, 21375, 21376, 21373
9121, 20559, 20560, 20582, 20581, 21333, 21377, 21378, 21375
9122, 20560, 20561, 20583, 20582, 21335, 21379, 21380, 21377
9123, 20561, 20562, 20584, 20583, 21337, 21381, 21382, 21379
9124, 20562, 20563, 20585, 20584, 21339, 21383, 21384, 21381
9125, 20563, 20564, 20586, 20585, 21341, 21385, 21386, 21383
9126, 20564, 20565, 20587, 20586, 21343, 21387, 21388, 21385
9127, 20565, 20566, 20588, 20587, 21345, 21389, 21390, 21387
9128, 20566, 20567, 20589, 20588, 21347, 21391, 21392, 21389
9129, 20567, 20568, 20590, 20589, 21349, 21393, 21394, 21391
9130, 20568, 20569, 20591, 20590, 21351, 21395, 21396, 21393
9131, 20569, 2890, 2891, 20591, 21352, 2913, 21397, 21395
9132, 2846, 20570, 20592, 2847, 21354, 21398, 21399, 2869
9133, 20570, 20571, 20593, 20592, 21356, 21400, 21401, 21398
9134, 20571, 20572, 20594, 20593, 21358, 21402, 21403, 21400
9135, 20572, 20573, 20595, 20594, 21360, 21404, 21405, 21402
9136, 20573, 20574, 20596, 20595, 21362, 21406, 21407, 21404
9137, 20574, 20575, 20597, 20596, 21364, 21408, 21409, 21406
9138, 20575, 20576, 20598, 20597, 21366, 21410, 21411, 21408
9139, 20576, 20577, 20599, 20598, 21368, 21412, 21413, 21410
9140, 20577, 20578, 20600, 20599, 21370, 21414, 21415, 21412
9141, 20578, 20579, 20601, 20600, 21372, 21416, 21417, 21414
9142, 20579, 20580, 20602, 20601, 21374, 21418, 21419, 21416
9143, 20580, 20581, 20603, 20602, 21376, 21420, 21421, 21418
9144, 20581, 20582, 20604, 20603, 21378, 21422, 21423, 21420
9145, 20582, 20583, 20605, 20604, 21380, 21424, 21425, 21422
9146, 20583, 20584, 20606, 20605, 21382, 21426, 21427, 21424
9147, 20584, 20585, 20607, 20606, 21384, 21428, 21429, 21426
9148, 20585, 20586, 20608, 20607, 21386, 21430, 21431, 21428
9149, 20586, 20587, 20609, 20608, 21388, 21432, 21433, 21430
9150, 20587, 20588, 20610, 20609, 21390, 21434, 21435, 21432
9151, 20588, 20589, 20611, 20610, 21392, 21436, 21437, 21434
9152, 20589, 20590, 20612, 20611, 21394, 21438, 21439, 21436
9153, 20590, 20591, 20613, 20612, 21396, 21440, 21441, 21438
9154, 20591, 2891, 2892, 20613, 21397, 2914, 21442, 21440
9155, 2847, 20592, 20614, 2848, 21399, 21443, 21444, 2870
9156, 20592, 20593, 20615, 20614, 21401, 21445, 21446, 21443
9157, 20593, 20594, 20616, 20615, 21403, 21447, 21448, 21445
9158, 20594, 20595, 20617, 20616, 21405, 21449, 21450, 21447
9159, 20595, 20596, 20618, 20617, 21407, 21451, 21452, 21449
9160, 20596, 20597, 20619, 20618, 21409, 21453, 21454, 21451
9161, 20597, 20598, 20620, 20619, 21411, 21455, 21456, 21453
9162, 20598, 20599, 20621, 20620, 21413, 21457, 21458, 21455
9163, 20599, 20600, 20622, 20621, 21415, 21459, 21460, 21457
9164, 20600, 20601, 20623, 20622, 21417, 21461, 21462, 21459
9165, 20601, 20602, 20624, 20623, 21419, 21463, 21464, 21461
9166, 20602, 20603, 20625, 20624, 21421, 21465, 21466, 21463
9167, 20603, 20604, 20626, 20625, 21423, 21467, 21468, 21465
9168, 20604, 20605, 20627, 20626, 21425, 21469, 21470, 21467
9169, 20605, 20606, 20628, 20627, 21427, 21471, 21472, 21469
9170, 20606, 20607, 20629, 20628, 21429, 21473, 21474, 21471
9171, 20607, 20608, 20630, 20629, 21431, 21475, 21476, 21473
9172, 20608, 20609, 20631, 20630, 21433, 21477, 21478, 21475
9173, 20609, 20610, 20632, 20631, 21435, 21479, 21480, 21477
9174, 20610, 20611, 20633, 20632, 21437, 21481, 21482, 21479
9175, 20611, 20612, 20634, 20633, 21439, 21483, 21484, 21481
9176, 20612, 20613, 20635, 20634, 21441, 21485, 21486, 21483
9177, 20613, 2892, 2893, 20635, 21442, 2915, 21487, 21485
9178, 2848, 20614, 20636, 2849, 21444, 21488, 21489, 2871
9179, 20614, 20615, 20637, 20636, 21446, 21490, 21491, 21488
9180, 20615, 20616, 20638, 20637, 21448, 21492, 21493, 21490
9181, 20616, 20617, 20639, 20638, 21450, 21494, 21495, 21492
9182, 20617, 20618, 20640, 20639, 21452, 21496, 21497, 21494
9183, 20618, 20619, 20641, 20640, 21454, 21498, 21499, 21496
9184, 20619, 20620, 20642, 20641, 21456, 21500, 21501, 21498
9185, 20620, 20621, 20643, 20642, 21458, 21502, 21503, 21500
9186, 20621, 20622, 20644, 20643, 21460, 21504, 21505, 21502
9187, 20622, 20623, 20645, 20644, 21462, 21506, 21507, 21504
9188, 20623, 20624, 20646, 20645, 21464, 21508, 21509, 21506
9189, 20624, 20625, 20647, 20646, 21466, 21510, 21511, 21508
9190, 20625, 20626, 20648, 20647, 21468, 21512, 21513, 21510
9191, 20626, 20627, 20649, 20648, 21470, 21514, 21515, 21512
9192, 20627, 20628, 20650, 20649, 21472, 21516, 21517, 21514
9193, 20628, 20629, 20651, 20650, 21474, 21518, 21519, 21516
9194, 20629, 20630, 20652, 20651, 21476, 21520, 21521, 21518
9195, 20630, 20631, 20653, 20652, 21478, 21522, 21523, 21520
9196, 20631, 20632, 20654, 20653, 21480, 21524, 21525, 21522
9197, 20632, 20633, 20655, 20654, 21482, 21526, 21527, 21524
9198, 20633, 20634, 20656, 20655, 21484, 21528, 21529, 21526
9199, 20634, 20635, 20657, 20656, 21486, 21530, 21531, 21528
9200, 20635, 2893, 2894, 20657, 21487, 2916, 21532, 21530
9201, 2849, 20636, 20658, 2850, 21489, 21533, 21534, 2872
9202, 20636, 20637, 20659, 20658, 21491, 21535, 21536, 21533
9203, 20637, 20638, 20660, 20659, 21493, 21537, 21538, 21535
9204, 20638, 20639, 20661, 20660, 21495, 21539, 21540, 21537
9205, 20639, 20640, 20662, 20661, 21497, 21541, 21542, 21539
9206, 20640, 20641, 20663, 20662, 21499, 21543, 21544, 21541
9207, 20641, 20642, 20664, 20663, 21501, 21545, 21546, 21543
9208, 20642, 20643, 20665, 20664, 21503, 21547, 21548, 21545
9209, 20643, 20644, 20666, 20665, 21505, 21549, 21550, 21547
9210, 20644, 20645, 20667, 20666, 21507, 21551, 21552, 21549
9211, 20645, 20646, 20668, 20667, 21509, 21553, 21554, 21551
9212, 20646, 20647, 20669, 20668, 21511, 21555, 21556, 21553
9213, 20647, 20648, 20670, 20669, 21513, 21557, 21558, 21555
9214, 20648, 20649, 20671, 20670, 21515, 21559, 21560, 21557
9215, 20649, 20650, 20672, 20671, 21517, 21561, 21562, 21559
9216, 20650, 20651, 20673, 20672, 21519, 21563, 21564, 21561
9217, 20651, 20652, 20674, 20673, 21521, 21565, 21566, 21563
9218, 20652, 20653, 20675, 20674, 21523, 21567, 21568, 21565
9219, 20653, 20654, 20676, 20675, 21525, 21569, 21570, 21567
9220, 20654, 20655, 20677, 20676, 21527, 21571, 21572, 21569
9221, 20655, 20656, 20678, 20677, 21529, 21573, 21574, 21571
9222, 20656, 20657, 20679, 20678, 21531, 21575, 21576, 21573
9223, 20657, 2894, 2895, 20679, 21532, 2917, 21577, 21575
9224, 2850, 20658, 20680, 2851, 21534, 21578, 21579, 2873
9225, 20658, 20659, 20681, 20680, 21536, 21580, 21581, 21578
9226, 20659, 20660, 20682, 20681, 21538, 21582, 21583, 21580
9227, 20660, 20661, 20683, 20682, 21540, 21584, 21585, 21582
9228, 20661, 20662, 20684, 20683, 21542, 21586, 21587, 21584
9229, 20662, 20663, 20685, 20684, 21544, 21588, 21589, 21586
9230, 20663, 20664, 20686, 20685, 21546, 21590, 21591, 21588
9231, 20664, 20665, 20687, 20686, 21548, 21592, 21593, 21590
9232, 20665, 20666, 20688, 20687, 21550, 21594, 21595, 21592
9233, 20666, 20667, 20689, 20688, 21552, 21596, 21597, 21594
9234, 20667, 20668, 20690, 20689, 21554, 21598, 21599, 21596
9235, 20668, 20669, 20691, 20690, 21556, 21600, 21601, 21598
9236, 20669, 20670, 20692, 20691, 21558, 21602, 21603, 21600
9237, 20670, 20671, 20693, 20692, 21560, 21604, 21605, 21602
9238, 20671, 20672, 20694, 20693, 21562, 21606, 21607, 21604
9239, 20672, 20673, 20695, 20694, 21564, 21608, 21609, 21606
9240, 20673, 20674, 20696, 20695, 21566, 21610, 21611, 21608
9241, 20674, 20675, 20697, 20696, 21568, 21612, 21613, 21610
9242, 20675, 20676, 20698, 20697, 21570, 21614, 21615, 21612
9243, 20676, 20677, 20699, 20698, 21572, 21616, 21617, 21614
9244, 20677, 20678, 20700, 20699, 21574, 21618, 21619, 21616
9245, 20678, 20679, 20701, 20700, 21576, 21620, 21621, 21618
9246, 20679, 2895, 2896, 20701, 21577, 2918, 21622, 21620
9247, 2851, 20680, 20702, 2852, 21579, 21623, 21624, 2874
9248, 20680, 20681, 20703, 20702, 21581, 21625, 21626, 21623
9249, 20681, 20682, 20704, 20703, 21583, 21627, 21628, 21625
9250, 20682, 20683, 20705, 20704, 21585, 21629, 21630, 21627
9251, 20683, 20684, 20706, 20705, 21587, 21631, 21632, 21629
9252, 20684, 20685, 20707, 20706, 21589, 21633, 21634, 21631
9253, 20685, 20686, 20708, 20707, 21591, 21635, 21636, 21633
9254, 20686, 20687, 20709, 20708, 21593, 21637, 21638, 21635
9255, 20687, 20688, 20710, 20709, 21595, 21639, 21640, 21637
9256, 20688, 20689, 20711, 20710, 21597, 21641, 21642, 21639
9257, 20689, 20690, 20712, 20711, 21599, 21643, 21644, 21641
9258, 20690, 20691, 20713, 20712, 21601, 21645, 21646, 21643
9259, 20691, 20692, 20714, 20713, 21603, 21647, 21648, 21645
9260, 20692, 20693, 20715, 20714, 21605, 21649, 21650, 21647
9261, 20693, 20694, 20716, 20715, 21607, 21651, 21652, 21649
9262, 20694, 20695, 20717, 20716, 21609, 21653, 21654, 21651
9263, 20695, 20696, 20718, 20717, 21611, 21655, 21656, 21653
9264, 20696, 20697, 20719, 20718, 21613, 21657, 21658, 21655
9265, 20697, 20698, 20720, 20719, 21615, 21659, 21660, 21657
9266, 20698, 20699, 20721, 20720, 21617, 21661, 21662, 21659
9267, 20699, 20700, 20722, 20721, 21619, 21663, 21664, 21661
9268, 20700, 20701, 20723, 20722, 21621, 21665, 21666, 21663
9269, 20701, 2896, 2897, 20723, 21622, 2919, 21667, 21665
9270, 2852, 20702, 20724, 2853, 21624, 21668, 21669, 2875
9271, 20702, 20703, 20725, 20724, 21626, 21670, 21671, 21668
9272, 20703, 20704, 20726, 20725, 21628, 21672, 21673, 21670
9273, 20704, 20705, 20727, 20726, 21630, 21674, 21675, 21672
9274, 20705, 20706, 20728, 20727, 21632, 21676, 21677, 21674
9275, 20706, 20707, 20729, 20728, 21634, 21678, 21679, 21676
9276, 20707, 20708, 20730, 20729, 21636, 21680, 21681, 21678
9277, 20708, 20709, 20731, 20730, 21638, 21682, 21683, 21680
9278, 20709, 20710, 20732, 20731, 21640, 21684, 21685, 21682
9279, 20710, 20711, 20733, 20732, 21642, 21686, 21687, 21684
9280, 20711, 20712, 20734, 20733, 21644, 21688, 21689, 21686
9281, 20712, 20713, 20735, 20734, 21646, 21690, 21691, 21688
9282, 20713, 20714, 20736, 20735, 21648, 21692, 21693, 21690
9283, 20714, 20715, 20737, 20736, 21650, 21694, 21695, 21692
9284, 20715, 20716, 20738, 20737, 21652, 21696, 21697, 21694
9285, 20716, 20717, 20739, 20738, 21654, 21698, 21699, 21696
9286, 20717, 20718, 20740, 20739, 21656, 21700, 21701, 21698
9287, 20718, 20719, 20741, 20740, 21658, 21702, 21703, 21700
9288, 20719, 20720, 20742, 20741, 21660, 21704, 21705, 21702
9289, 20720, 20721, 20743, 20742, 21662, 21706, 21707, 21704
9290, 20721, 20722, 20744, 20743, 21664, 21708, 21709, 21706
9291, 20722, 20723, 20745, 20744, 21666, 21710, 21711, 21708
9292, 20723, 2897, 2898, 20745, 21667, 2920, 21712, 21710
9293, 2853, 20724, 20746, 2854, 21669, 21713, 21714, 2876
9294, 20724, 20725, 20747, 20746, 21671, 21715, 21716, 21713
9295, 20725, 20726, 20748, 20747, 21673, 21717, 21718, 21715
9296, 20726, 20727, 20749, 20748, 21675, 21719, 21720, 21717
9297, 20727, 20728, 20750, 20749, 21677, 21721, 21722, 21719
9298, 20728, 20729, 20751, 20750, 21679, 21723, 21724, 21721
9299, 20729, 20730, 20752, 20751, 21681, 21725, 21726, 21723
9300, 20730, 20731, 20753, 20752, 21683, 21727, 21728, 21725
9301, 20731, 20732, 20754, 20753, 21685, 21729, 21730, 21727
9302, 20732, 20733, 20755, 20754, 21687, 21731, 21732, 21729
9303, 20733, 20734, 20756, 20755, 21689, 21733, 21734, 21731
9304, 20734, 20735, 20757, 20756, 21691, 21735, 21736, 21733
9305, 20735, 20736, 20758, 20757, 21693, 21737, 21738, 21735
9306, 20736, 20737, 20759, 20758, 21695, 21739, 21740, 21737
9307, 20737, 20738, 20760, 20759, 21697, 21741, 21742, 21739
9308, 20738, 20739, 20761, 20760, 21699, 21743, 21744, 21741
9309, 20739, 20740, 20762, 20761, 21701, 21745, 21746, 21743
9310, 20740, 20741, 20763, 20762, 21703, 21747, 21748, 21745
9311, 20741, 20742, 20764, 20763, 21705, 21749, 21750, 21747
9312, 20742, 20743, 20765, 20764, 21707, 21751, 21752, 21749
9313, 20743, 20744, 20766, 20765, 21709, 21753, 21754, 21751
9314, 20744, 20745, 20767, 20766, 21711, 21755, 21756, 21753
9315, 20745, 2898, 2899, 20767, 21712, 2921, 21757, 21755
9316, 2854, 20746, 2944, 89, 21714, 21758, 2967, 2877
9317, 20746, 20747, 2943, 2944, 21716, 21759, 2966, 21758
9318, 20747, 20748, 2942, 2943, 21718, 21760, 2965, 21759
9319, 20748, 20749, 2941, 2942, 21720, 21761, 2964, 21760
9320, 20749, 20750, 2940, 2941, 21722, 21762, 2963, 21761
9321, 20750, 20751, 2939, 2940, 21724, 21763, 2962, 21762
9322, 20751, 20752, 2938, 2939, 21726, 21764, 2961, 21763
9323, 20752, 20753, 2937, 2938, 21728, 21765, 2960, 21764
9324, 20753, 20754, 2936, 2937, 21730, 21766, 2959, 21765
9325, 20754, 20755, 2935, 2936, 21732, 21767, 2958, 21766
9326, 20755, 20756, 2934, 2935, 21734, 21768, 2957, 21767
9327, 20756, 20757, 2933, 2934, 21736, 21769, 2956, 21768
9328, 20757, 20758, 2932, 2933, 21738, 21770, 2955, 21769
9329, 20758, 20759, 2931, 2932, 21740, 21771, 2954, 21770
9330, 20759, 20760, 2930, 2931, 21742, 21772, 2953, 21771
9331, 20760, 20761, 2929, 2930, 21744, 21773, 2952, 21772
9332, 20761, 20762, 2928, 2929, 21746, 21774, 2951, 21773
9333, 20762, 20763, 2927, 2928, 21748, 21775, 2950, 21774
9334, 20763, 20764, 2926, 2927, 21750, 21776, 2949, 21775
9335, 20764, 20765, 2925, 2926, 21752, 21777, 2948, 21776
9336, 20765, 20766, 2924, 2925, 21754, 21778, 2947, 21777
9337, 20766, 20767, 2923, 2924, 21756, 21779, 2946, 21778
9338, 20767, 2899, 90, 2923, 21757, 2922, 2945, 21779
*ELEMENT, type=CPS8, ELSET=Surface261
9339, 3, 173, 21780, 2968, 182, 21956, 21957, 2990
9340, 173, 172, 21781, 21780, 181, 21958, 21959, 21956
9341, 172, 171, 21782, 21781, 180, 21960, 21961, 21958
9342, 171, 170, 21783, 21782, 179, 21962, 21963, 21960
9343, 170, 169, 21784, 21783, 178, 21964, 21965, 21962
9344, 169, 168, 21785, 21784, 177, 21966, 21967, 21964
9345, 168, 167, 21786, 21785, 176, 21968, 21969, 21966
9346, 167, 166, 21787, 21786, 175, 21970, 21971, 21968
9347, 166, 1, 2833, 21787, 174, 2855, 21972, 21970
9348, 2968, 21780, 21788, 2969, 21957, 21973, 21974, 2991
9349, 21780, 21781, 21789, 21788, 21959, 21975, 21976, 21973
9350, 21781, 21782, 21790, 21789, 21961, 21977, 21978, 21975
9351, 21782, 21783, 21791, 21790, 21963, 21979, 21980, 21977
9352, 21783, 21784, 21792, 21791, 21965, 21981, 21982, 21979
9353, 21784, 21785, 21793, 21792, 21967, 21983, 21984, 21981
9354, 21785, 21786, 21794, 21793, 21969, 21985, 21986, 21983
9355, 21786, 21787, 21795, 21794, 21971, 21987, 21988, 21985
9356, 21787, 2833, 2834, 21795, 21972, 2856, 21989, 21987
9357, 2969, 21788, 21796, 2970, 21974, 21990, 21991, 2992
9358, 21788, 21789, 21797, 21796, 21976, 21992, 21993, 21990
9359, 21789, 21790, 21798, 21797, 21978, 21994, 21995, 21992
9360, 21790, 21791, 21799, 21798, 21980, 21996, 21997, 21994
9361, 21791, 21792, 21800, 21799, 21982, 21998, 21999, 21996
9362, 21792, 21793, 21801, 21800, 21984, 22000, 22001, 21998
9363, 21793, 21794, 21802, 21801, 21986, 22002, 22003, 22000
9364, 21794, 21795, 21803, 21802, 21988, 22004, 22005, 22002
9365, 21795, 2834, 2835, 21803, 21989, 2857, 22006, 22004
9366, 2970, 21796, 21804, 2971, 21991, 22007, 22008, 2993
9367, 21796, 21797, 21805, 21804, 21993, 22009, 22010, 22007
9368, 21797, 21798, 21806, 21805, 21995, 22011, 22012, 22009
9369, 21798, 21799, 21807, 21806, 21997, 22013, 22014, 22011
9370, 21799, 21800, 21808, 21807, 21999, 22015, 22016, 22013
9371, 21800, 21801, 21809, 21808, 22001, 22017, 22018, 22015
9372, 21801, 21802, 21810, 21809, 22003, 22019, 22020, 22017
9373, 21802, 21803, 21811, 21810, 22005, 22021, 22022, 22019
9374, 21803, 2835, 2836, 21811, 22006, 2858, 22023, 22021
9375, 2971, 21804, 21812, 2972, 22008, 22024, 22025, 2994
9376, 21804, 21805, 21813, 21812, 22010, 22026, 22027, 22024
9377, 21805, 21806, 21814, 21813, 22012, 22028, 22029, 22026
9378, 21806, 21807, 21815, 21814, 22014, 22030, 22031, 22028
9379, 21807, 21808, 21816, 21815, 22016, 22032, 22033, 22030
9380, 21808, 21809, 21817, 21816, 22018, 22034, 22035, 22032
9381, 21809, 21810, 21818, 21817, 22020, 22036, 22037, 22034
9382, 21810, 21811, 21819, 21818, 22022, 22038, 22039, 22036
9383, 21811, 2836, 2837, 21819, 22023, 2859, 22040, 22038
9384, 2972, 21812, 21820, 2973, 22025, 22041, 22042, 2995
9385, 21812, 21813, 21821, 21820, 22027, 22043, 22044, 22041
9386, 21813, 21814, 21822, 21821, 22029, 22045, 22046, 22043
9387, 21814, 21815, 21823, 21822, 22031, 22047, 22048, 22045
9388, 21815, 21816, 21824, 21823, 22033, 22049, 22050, 22047
9389, 21816, 21817, 21825, 21824, 22035, 22051, 22052, 22049
9390, 21817, 21818, 21826, 21825, 22037, 22053, 22054, 22051
9391, 21818, 21819, 21827, 21826, 22039, 22055, 22056, 22053
9392, 21819, 2837, 2838, 21827, 22040, 2860, 22057, 22055
9393, 2973, 21820, 21828, 2974, 22042, 22058, 22059, 2996
9394, 21820, 21821, 21829, 21828, 22044, 22060, 22061, 22058
9395, 21821, 21822, 21830, 21829, 22046, 22062, 22063, 22060
9396, 21822, 21823, 21831, 21830, 22048, 22064, 22065, 22062
9397, 21823, 21824, 21832, 21831, 22050, 22066, 22067, 22064
9398, 21824, 21825, 21833, 21832, 22052, 22068, 22069, 22066
9399, 21825, 21826, 21834, 21833, 22054, 22070, 22071, 22068
9400, 21826, 21827, 21835, 21834, 22056, 22072, 22073, 22070
9401, 21827, 2838, 2839, 21835, 22057, 2861, 22074, 22072
9402, 2974, 21828, 21836, 2975, 22059, 22075, 22076, 2997
9403, 21828, 21829, 21837, 21836, 22061, 22077, 22078, 22075
9404, 21829, 21830, 21838, 21837, 22063, 22079, 22080, 22077
9405, 21830, 21831, 21839, 21838, 22065, 22081, 22082, 22079
9406, 21831, 21832, 21840, 21839, 22067, 22083, 22084, 22081
9407, 21832, 21833, 21841, 21840, 22069, 22085, 22086, 22083
9408, 21833, 21834, 21842, 21841, 22071, 22087, 22088, 22085
9409, 21834, 21835, 21843, 21842, 22073, 22089, 22090, 22087
9410, 21835, 2839, 2840, 21843, 22074, 2862, 22091, 22089
9411, 2975, 21836, 21844, 2976, 22076, 22092, 22093, 2998
9412, 21836, 21837, 21845, 21844, 22078, 22094, 22095, 22092
9413, 21837, 21838, 21846, 21845, 22080, 22096, 22097, 22094
9414, 21838, 21839, 21847, 21846, 22082, 22098, 22099, 22096
9415, 21839, 21840, 21848, 21847, 22084, 22100, 22101, 22098
9416, 21840, 21841, 21849, 21848, 22086, 22102, 22103, 22100
9417, 21841, 21842, 21850, 21849, 22088, 22104, 22105, 22102
9418, 21842, 21843, 21851, 21850, 22090, 22106, 22107, 22104
9419, 21843, 2840, 2841, 21851, 22091, 2863, 22108, 22106
9420, 2976, 21844, 21852, 2977, 22093, 22109, 22110, 2999
9421, 21844, 21845, 21853, 21852, 22095, 22111, 22112, 22109
9422, 21845, 21846, 21854, 21853, 22097, 22113, 22114, 22111
9423, 21846, 21847, 21855, 21854, 22099, 22115, 22116, 22113
9424, 21847, 21848, 21856, 21855, 22101, 22117, 22118, 22115
9425, 21848, 21849, 21857, 21856, 22103, 22119, 22120, 22117
9426, 21849, 21850, 21858, 21857, 22105, 22121, 22122, 22119
9427, 21850, 21851, 21859, 21858, 22107, 22123, 22124, 22121
9428, 21851, 2841, 2842, 21859, 22108, 2864, 22125, 22123
9429, 2977, 21852, 21860, 2978, 22110, 22126, 22127, 3000
9430, 21852, 21853, 21861, 21860, 22112, 22128, 22129, 22126
9431, 21853, 21854, 21862, 21861, 22114, 22130, 22131, 22128
9432, 21854, 21855, 21863, 21862, 22116, 22132, 22133, 22130
9433, 21855, 21856, 21864, 21863, 22118, 22134, 22135, 22132
9434, 21856, 21857, 21865, 21864, 22120, 22136, 22137, 22134
9435, 21857, 21858, 21866, 21865, 22122, 22138, 22139, 22136
9436, 21858, 21859, 21867, 21866, 22124, 22140, 22141, 22138
9437, 21859, 2842, 2843, 21867, 22125, 2865, 22142, 22140
9438, 2978, 21860, 21868, 2979, 22127, 22143, 22144, 3001
9439, 21860, 21861, 21869, 21868, 22129, 22145, 22146, 22143
9440, 21861, 21862, 21870, 21869, 22131, 22147, 22148, 22145
9441, 21862, 21863, 21871, 21870, 22133, 22149, 22150, 22147
9442, 21863, 21864, 21872, 21871, 22135, 22151, 22152, 22149
9443, 21864, 21865, 21873, 21872, 22137, 22153, 22154, 22151
9444, 21865, 21866, 21874, 21873, 22139, 22155, 22156, 22153
9445, 21866, 21867, 21875, 21874, 22141, 22157, 22158, 22155
9446, 21867, 2843, 2844, 21875, 22142, 2866, 22159, 22157
9447, 2979, 21868, 21876, 2980, 22144, 22160, 22161, 3002
9448, 21868, 21869, 21877, 21876, 22146, 22162, 22163, 22160
9449, 21869, 21870, 21878, 21877, 22148, 22164, 22165, 22162
9450, 21870, 21871, 21879, 21878, 22150, 22166, 22167, 22164
9451, 21871, 21872, 21880, 21879, 22152, 22168, 22169, 22166
9452, 21872, 21873, 21881, 21880, 22154, 22170, 22171, 22168
9453, 21873, 21874, 21882, 21881, 22156, 22172, 22173, 22170
9454, 21874, 21875, 21883, 21882, 22158, 22174, 22175, 22172
9455, 21875, 2844, 2845, 21883, 22159, 2867, 22176, 22174
9456, 2980, 21876, 21884, 2981, 22161, 22177, 22178, 3003
9457, 21876, 21877, 21885, 21884, 22163, 22179, 22180, 22177
9458, 21877, 21878, 21886, 21885, 22165, 22181, 22182, 22179
9459, 21878, 21879, 21887, 21886, 22167, 22183, 22184, 22181
9460, 21879, 21880, 21888, 21887, 22169, 22185, 22186, 22183
9461, 21880, 21881, 21889, 21888, 22171, 22187, 22188, 22185
9462, 21881, 21882, 21890, 21889, 22173, 22189, 22190, 22187
9463, 21882, 21883, 21891, 21890, 22175, 22191, 22192, 22189
9464, 21883, 2845, 2846, 21891, 22176, 2868, 22193, 22191
9465, 2981, 21884, 21892, 2982, 22178, 22194, 22195, 3004
9466, 21884, 21885, 21893, 21892, 22180, 22196, 22197, 22194
9467, 21885, 21886, 21894, 21893, 22182, 22198, 22199, 22196
9468, 21886, 21887, 21895, 21894, 22184, 22200, 22201, 22198
9469, 21887, 21888, 21896, 21895, 22186, 22202, 22203, 22200
9470, 21888, 21889, 21897, 21896, 22188, 22204, 22205, 22202
9471, 21889, 21890, 21898, 21897, 22190, 22206, 22207, 22204
9472, 21890, 21891, 21899, 21898, 22192, 22208, 22209, 22206
9473, 21891, 2846, 2847, 21899, 22193, 2869, 22210, 22208
9474, 2982, 21892, 21900, 2983, 22195, 22211, 22212, 3005
9475, 21892, 21893, 21901, 21900, 22197, 22213, 22214, 22211
9476, 21893, 21894, 21902, 21901, 22199, 22215, 22216, 22213
9477, 21894, 21895, 21903, 21902, 22201, 22217, 22218, 22215
9478, 21895, 21896, 21904, 21903, 22203, 22219, 22220, 22217
9479, 21896, 21897, 21905, 21904, 22205, 22221, 22222, 22219
9480, 21897, 21898, 21906, 21905, 22207, 22223, 22224, 22221
9481, 21898, 21899, 21907, 21906, 22209, 22225, 22226, 22223
9482, 21899, 2847, 2848, 21907, 22210, 2870, 22227, 22225
9483, 2983, 21900, 21908, 2984, 22212, 22228, 22229, 3006
9484, 21900, 21901, 21909, 21908, 22214, 22230, 22231, 22228
9485, 21901, 21902, 21910, 21909, 22216, 22232, 22233, 22230
9486, 21902, 21903, 21911, 21910, 22218, 22234, 22235, 22232
9487, 21903, 21904, 21912, 21911, 22220, 22236, 22237, 22234
9488, 21904, 21905, 21913, 21912, 22222, 22238, 22239, 22236
9489, 21905, 21906, 21914, 21913, 22224, 22240, 22241, 22238
9490, 21906, 21907, 21915, 21914, 22226, 22242, 22243, 22240
9491, 21907, 2848, 2849, 21915, 22227, 2871, 22244, 22242
9492, 2984, 21908, 21916, 2985, 22229, 22245, 22246, 3007
9493, 21908, 21909, 21917, 21916, 22231, 22247, 22248, 22245
9494, 21909, 21910, 21918, 21917, 22233, 22249, 22250, 22247
9495, 21910, 21911, 21919, 21918, 22235, 22251, 22252, 22249
9496, 21911, 21912, 21920, 21919, 22237, 22253, 22254, 22251
9497, 21912, 21913, 21921, 21920, 22239, 22255, 22256, 22253
9498, 21913, 21914, 21922, 21921, 22241, 22257, 22258, 22255
9499, 21914, 21915, 21923, 21922, 22243, 22259, 22260, 22257
9500, 21915, 2849, 2850, 21923, 22244, 2872, 22261, 22259
9501, 2985, 21916, 21924, 2986, 22246, 22262, 22263, 3008
9502, 21916, 21917, 21925, 21924, 22248, 22264, 22265, 22262
9503, 21917, 21918, 21926, 21925, 22250, 22266, 22267, 22264
9504, 21918, 21919, 21927, 21926, 22252, 22268, 22269, 22266
9505, 21919, 21920, 21928, 21927, 22254, 22270, 22271, 22268
9506, 21920, 21921, 21929, 21928, 22256, 22272, 22273, 22270
9507, 21921, 21922, 21930, 21929, 22258, 22274, 22275, 22272
9508, 21922, 21923, 21931, 21930, 22260, 22276, 22277, 22274
9509, 21923, 2850, 2851, 21931, 22261, 2873, 22278, 22276
9510, 2986, 21924, 21932, 2987, 22263, 22279, 22280, 3009
9511, 21924, 21925, 21933, 21932, 22265, 22281, 22282, 22279
9512, 21925, 21926, 21934, 21933, 22267, 22283, 22284, 22281
9513, 21926, 21927, 21935, 21934, 22269, 22285, 22286, 22283
9514, 21927, 21928, 21936, 21935, 22271, 22287, 22288, 22285
9515, 21928, 21929, 21937, 21936, 22273, 22289, 22290, 22287
9516, 21929, 21930, 21938, 21937, 22275, 22291, 22292, 22289
9517, 21930, 21931, 21939, 21938, 22277, 22293, 22294, 22291
9518, 21931, 2851, 2852, 21939, 22278, 2874, 22295, 22293
9519, 2987, 21932, 21940, 2988, 22280, 22296, 22297, 3010
9520, 21932, 21933, 21941, 21940, 22282, 22298, 22299, 22296
9521, 21933, 21934, 21942, 21941, 22284, 22300, 22301, 22298
9522, 21934, 21935, 21943, 21942, 22286, 22302, 22303, 22300
9523, 21935, 21936, 21944, 21943, 22288, 22304, 22305, 22302
9524, 21936, 21937, 21945, 21944, 22290, 22306, 22307, 22304
9525, 21937, 21938, 21946, 21945, 22292, 22308, 22309, 22306
9526, 21938, 21939, 21947, 21946, 22294, 22310, 22311, 22308
9527, 21939, 2852, 2853, 21947, 22295, 2875, 22312, 22310
9528, 2988, 21940, 21948, 2989, 22297, 22313, 22314, 3011
9529, 21940, 21941, 21949, 21948, 22299, 22315, 22316, 22313
9530, 21941, 21942, 21950, 21949, 22301, 22317, 22318, 22315
9531, 21942, 21943, 21951, 21950, 22303, 22319, 22320, 22317
9532, 21943, 21944, 21952, 21951, 22305, 22321, 22322, 22319
9533, 21944, 21945, 21953, 21952, 22307, 22323, 22324, 22321
9534, 21945, 21946, 21954, 21953, 22309, 22325, 22326, 22323
9535, 21946, 21947, 21955, 21954, 22311, 22327, 22328, 22325
9536, 21947, 2853, 2854, 21955, 22312, 2876, 22329, 22327
9537, 2989, 21948, 3020, 91, 22314, 22330, 3029, 3012
9538, 21948, 21949, 3019, 3020, 22316, 22331, 3028, 22330
9539, 21949, 21950, 3018, 3019, 22318, 22332, 3027, 22331
9540, 21950, 21951, 3017, 3018, 22320, 22333, 3026, 22332
9541, 21951, 21952, 3016, 3017, 22322, 22334, 3025, 22333
9542, 21952, 21953, 3015, 3016, 22324, 22335, 3024, 22334
9543, 21953, 21954, 3014, 3015, 22326, 22336, 3023, 22335
9544, 21954, 21955, 3013, 3014, 22328, 22337, 3022, 22336
9545, 21955, 2854, 89, 3013, 22329, 2877, 3021, 22337
*ELEMENT, type=CPS8, ELSET=Surface262
9546, 3, 2968, 22338, 204, 2990, 22822, 22823, 227
9547, 204, 22338, 22339, 203, 22823, 22824, 22825, 226
9548, 203, 22339, 22340, 202, 22825, 22826, 22827, 225
9549, 202, 22340, 22341, 201, 22827, 22828, 22829, 224
9550, 201, 22341, 22342, 200, 22829, 22830, 22831, 223
9551, 200, 22342, 22343, 199, 22831, 22832, 22833, 222
9552, 199, 22343, 22344, 198, 22833, 22834, 22835, 221
9553, 198, 22344, 22345, 197, 22835, 22836, 22837, 220
9554, 197, 22345, 22346, 196, 22837, 22838, 22839, 219
9555, 196, 22346, 22347, 195, 22839, 22840, 22841, 218
9556, 195, 22347, 22348, 194, 22841, 22842, 22843, 217
9557, 194, 22348, 22349, 193, 22843, 22844, 22845, 216
9558, 193, 22349, 22350, 192, 22845, 22846, 22847, 215
9559, 192, 22350, 22351, 191, 22847, 22848, 22849, 214
9560, 191, 22351, 22352, 190, 22849, 22850, 22851, 213
9561, 190, 22352, 22353, 189, 22851, 22852, 22853, 212
9562, 189, 22353, 22354, 188, 22853, 22854, 22855, 211
9563, 188, 22354, 22355, 187, 22855, 22856, 22857, 210
9564, 187, 22355, 22356, 186, 22857, 22858, 22859, 209
9565, 186, 22356, 22357, 185, 22859, 22860, 22861, 208
9566, 185, 22357, 22358, 184, 22861, 22862, 22863, 207
9567, 184, 22358, 22359, 183, 22863, 22864, 22865, 206
9568, 183, 22359, 3030, 4, 22865, 22866, 3052, 205
9569, 2968, 2969, 22360, 22338, 2991, 22867, 22868, 22822
9570, 22338, 22360, 22361, 22339, 22868, 22869, 22870, 22824
9571, 22339, 22361, 22362, 22340, 22870, 22871, 22872, 22826
9572, 22340, 22362, 22363, 22341, 22872, 22873, 22874, 22828
9573, 22341, 22363, 22364, 22342, 22874, 22875, 22876, 22830
9574, 22342, 22364, 22365, 22343, 22876, 22877, 22878, 22832
9575, 22343, 22365, 22366, 22344, 22878, 22879, 22880, 22834
9576, 22344, 22366, 22367, 22345, 22880, 22881, 22882, 22836
9577, 22345, 22367, 22368, 22346, 22882, 22883, 22884, 22838
9578, 22346, 22368, 22369, 22347, 22884, 22885, 22886, 22840
9579, 22347, 22369, 22370, 22348, 22886, 22887, 22888, 22842
9580, 22348, 22370, 22371, 22349, 22888, 22889, 22890, 22844
9581, 22349, 22371, 22372, 22350, 22890, 22891, 22892, 22846
9582, 22350, 22372, 22373, 22351, 22892, 22893, 22894, 22848
9583, 22351, 22373, 22374, 22352, 22894, 22895, 22896, 22850
9584, 22352, 22374, 22375, 22353, 22896, 22897, 22898, 22852
9585, 22353, 22375, 22376, 22354, 22898, 22899, 22900, 22854
9586, 22354, 22376, 22377, 22355, 22900, 22901, 22902, 22856
9587, 22355, 22377, 22378, 22356, 22902, 22903, 22904, 22858
9588, 22356, 22378, 22379, 22357, 22904, 22905, 22906, 22860
9589, 22357, 22379, 22380, 22358, 22906, 22907, 22908, 22862
9590, 22358, 22380, 22381, 22359, 22908, 22909, 22910, 22864
9591, 22359, 22381, 3031, 3030, 22910, 22911, 3053, 22866
9592, 2969, 2970, 22382, 22360, 2992, 22912, 22913, 22867
9593, 22360, 22382, 22383, 22361, 22913, 22914, 22915, 22869
9594, 22361, 22383, 22384, 22362, 22915, 22916, 22917, 22871
9595, 22362, 22384, 22385, 22363, 22917, 22918, 22919, 22873
9596, 22363, 22385, 22386, 22364, 22919, 22920, 22921, 22875
9597, 22364, 22386, 22387, 22365, 22921, 22922, 22923, 22877
9598, 22365, 22387, 22388, 22366, 22923, 22924, 22925, 22879
9599, 22366, 22388, 22389, 22367, 22925, 22926, 22927, 22881
9600, 22367, 22389, 22390, 22368, 22927, 22928, 22929, 22883
9601, 22368, 22390, 22391, 22369, 22929, 22930, 22931, 22885
9602, 22369, 22391, 22392, 22370, 22931, 22932, 22933, 22887
9603, 22370, 22392, 22393, 22371, 22933, 22934, 22935, 22889
9604, 22371, 22393, 22394, 22372, 22935, 22936, 22937, 22891
9605, 22372, 22394, 22395, 22373, 22937, 22938, 22939, 22893
9606, 22373, 22395, 22396, 22374, 22939, 22940, 22941, 22895
9607, 22374, 22396, 22397, 22375, 22941, 22942, 22943, 22897
9608, 22375, 22397, 22398, 22376, 22943, 22944, 22945, 22899
9609, 22376, 22398, 22399, 22377, 22945, 22946, 22947, 22901
9610, 22377, 22399, 22400, 22378, 22947, 22948, 22949, 22903
9611, 22378, 22400, 22401, 22379, 22949, 22950, 22951, 22905
9612, 22379, 22401, 22402, 22380, 22951, 22952, 22953, 22907
9613, 22380, 22402, 22403, 22381, 22953, 22954, 22955, 22909
9614, 22381, 22403, 3032, 3031, 22955, 22956, 3054, 22911
9615, 2970, 2971, 22404, 22382, 2993, 22957, 22958, 22912
9616, 22382, 22404, 22405, 22383, 22958, 22959, 22960, 22914
9617, 22383, 22405, 22406, 22384, 22960, 22961, 22962, 22916
9618, 22384, 22406, 22407, 22385, 22962, 22963, 22964, 22918
9619, 22385, 22407, 22408, 22386, 22964, 22965, 22966, 22920
9620, 22386, 22408, 22409, 22387, 22966, 22967, 22968, 22922
9621, 22387, 22409, 22410, 22388, 22968, 22969, 22970, 22924
9622, 22388, 22410, 22411, 22389, 22970, 22971, 22972, 22926
9623, 22389, 22411, 22412, 22390, 22972, 22973, 22974, 22928
9624, 22390, 22412, 22413, 22391, 22974, 22975, 22976, 22930
9625, 22391, 22413, 22414, 22392, 22976, 22977, 22978, 22932
9626, 22392, 22414, 22415, 22393, 22978, 22979, 22980, 22934
9627, 22393, 22415, 22416, 22394, 22980, 22981, 22982, 22936
9628, 22394, 22416, 22417, 22395, 22982, 22983, 22984, 22938
9629, 22395, 22417, 22418, 22396, 22984, 22985, 22986, 22940
9630, 22396, 22418, 22419, 22397, 22986, 22987, 22988, 22942
9631, 22397, 22419, 22420, 22398, 22988, 22989, 22990, 22944
9632, 22398, 22420, 22421, 22399, 22990, 22991, 22992, 22946
9633, 22399, 22421, 22422, 22400, 22992, 22993, 22994, 22948
9634, 22400, 22422, 22423, 22401, 22994, 22995, 22996, 22950
9635, 22401, 22423, 22424, 22402, 22996, 22997, 22998, 22952
9636, 22402, 22424, 22425, 22403, 22998, 22999, 23000, 22954
9637, 22403, 22425, 3033, 3032, 23000, 23001, 3055, 22956
9638, 2971, 2972, 22426, 22404, 2994, 23002, 23003, 22957
9639, 22404, 22426, 22427, 22405, 23003, 23004, 23005, 22959
9640, 22405, 22427, 22428, 22406, 23005, 23006, 23007, 22961
9641, 22406, 22428, 22429, 22407, 23007, 23008, 23009, 22963
9642, 22407, 22429, 22430, 22408, 23009, 23010, 23011, 22965
9643, 22408, 22430, 22431, 22409, 23011, 23012, 23013, 22967
9644, 22409, 22431, 22432, 22410, 23013, 23014, 23015, 22969
9645, 22410, 22432, 22433, 22411, 23015, 23016, 23017, 22971
9646, 22411, 22433, 22434, 22412, 23017, 23018, 23019, 22973
9647, 22412, 22434, 22435, 22413, 23019, 23020, 23021, 22975
9648, 22413, 22435, 22436, 22414, 23021, 23022, 23023, 22977
9649, 22414, 22436, 22437, 22415, 23023, 23024, 23025, 22979
9650, 22415, 22437, 22438, 22416, 23025, 23026, 23027, 22981
9651, 22416, 22438, 22439, 22417, 23027, 23028, 23029, 22983
9652, 22417, 22439, 22440, 22418, 23029, 23030, 23031, 22985
9653, 22418, 22440, 22441, 22419, 23031, 23032, 23033, 22987
9654, 22419, 22441, 22442, 22420, 23033, 23034, 23035, 22989
9655, 22420, 22442, 22443, 22421, 23035, 23036, 23037, 22991
9656, 22421, 22443, 22444, 22422, 23037, 23038, 23039, 22993
9657, 22422, 22444, 22445, 22423, 23039, 23040, 23041, 22995
9658, 22423, 22445, 22446, 22424, 23041, 23042, 23043, 22997
9659, 22424, 22446, 22447, 22425, 23043, 23044, 23045, 22999
9660, 22425, 22447, 3034, 3033, 23045, 23046, 3056, 23001
9661, 2972, 2973, 22448, 22426, 2995, 23047, 23048, 23002
9662, 22426, 22448, 22449, 22427, 23048, 23049, 23050, 23004
9663, 22427, 22449, 22450, 22428, 23050, 23051, 23052, 23006
9664, 22428, 22450, 22451, 22429, 23052, 23053, 23054, 23008
9665, 22429, 22451, 22452, 22430, 23054, 23055, 23056, 23010
9666, 22430, 22452, 22453, 22431, 23056, 23057, 23058, 23012
9667, 22431, 22453, 22454, 22432, 23058, 23059, 23060, 23014
9668, 22432, 22454, 22455, 22433, 23060, 23061, 23062, 23016
9669, 22433, 22455, 22456, 22434, 23062, 23063, 23064, 23018
9670, 22434, 22456, 22457, 22435, 23064, 23065, 23066, 23020
9671, 22435, 22457, 22458, 22436, 23066, 23067, 23068, 23022
9672, 22436, 22458, 22459, 22437, 23068, 23069, 23070, 23024
9673, 22437, 22459, 22460, 22438, 23070, 23071, 23072, 23026
9674, 22438, 22460, 22461, 22439, 23072, 23073, 23074, 23028
9675, 22439, 22461, 22462, 22440, 23074, 23075, 23076, 23030
9676, 22440, 22462, 22463, 22441, 23076, 23077, 23078, 23032
9677, 22441, 22463, 22464, 22442, 23078, 23079, 23080, 23034
9678, 22442, 22464, 22465, 22443, 23080, 23081, 23082, 23036
9679, 22443, 22465, 22466, 22444, 23082, 23083, 23084, 23038
9680, 22444, 22466, 22467, 22445, 23084, 23085, 23086, 23040
9681, 22445, 22467, 22468, 22446, 23086, 23087, 23088, 23042
9682, 22446, 22468, 22469, 22447, 23088, 23089, 23090, 23044
9683, 22447, 22469, 3035, 3034, 23090, 23091, 3057, 23046
9684, 2973, 2974, 22470, 22448, 2996, 23092, 23093, 23047
9685, 22448, 22470, 22471, 22449, 23093, 23094, 23095, 23049
9686, 22449, 22471, 22472, 22450, 23095, 23096, 23097, 23051
9687, 22450, 22472, 22473, 22451, 23097, 23098, 23099, 23053
9688, 22451, 22473, 22474, 22452, 23099, 23100, 23101, 23055
9689, 22452, 22474, 22475, 22453, 23101, 23102, 23103, 23057
9690, 22453, 22475, 22476, 22454, 23103, 23104, 23105, 23059
9691, 22454, 22476, 22477, 22455, 23105, 23106, 23107, 23061
9692, 22455, 22477, 22478, 22456, 23107, 23108, 23109, 23063
9693, 22456, 22478, 22479, 22457, 23109, 23110, 23111, 23065
9694, 22457, 22479, 22480, 22458, 23111, 23112, 23113, 23067
9695, 22458, 22480, 22481, 22459, 23113, 23114, 23115, 23069
9696, 22459, 22481, 22482, 22460, 23115, 23116, 23117, 23071
9697, 22460, 22482, 22483, 22461, 23117, 23118, 23119, 23073
9698, 22461, 22483, 22484, 22462, 23119, 23120, 23121, 23075
9699, 22462, 22484, 22485, 22463, 23121, 23122, 23123, 23077
9700, 22463, 22485, 22486, 22464, 23123, 23124, 23125, 23079
9701, 22464, 22486, 22487, 22465, 23125, 23126, 23127, 23081
9702, 22465, 22487, 22488, 22466, 23127, 23128, 23129, 23083
9703, 22466, 22488, 22489, 22467, 23129, 23130, 23131, 23085
9704, 22467, 22489, 22490, 22468, 23131, 23132, 23133, 23087
9705, 22468, 22490, 22491, 22469, 23133, 23134, 23135, 23089
9706, 22469, 22491, 3036, 3035, 23135, 23136, 3058, 23091
9707, 2974, 2975, 22492, 22470, 2997, 23137, 23138, 23092
9708, 22470, 22492, 22493, 22471, 23138, 23139, 23140, 23094
9709, 22471, 22493, 22494, 22472, 23140, 23141, 23142, 23096
9710, 22472, 22494, 22495, 22473, 23142, 23143, 23144, 23098
9711, 22473, 22495, 22496, 22474, 23144, 23145, 23146, 23100
9712, 22474, 22496, 22497, 22475, 23146, 23147, 23148, 23102
9713, 22475, 22497, 22498, 22476, 23148, 23149, 23150, 23104
9714, 22476, 22498, 22499, 22477, 23150, 23151, 23152, 23106
9715, 22477, 22499, 22500, 22478, 23152, 23153, 23154, 23108
9716, 22478, 22500, 22501, 22479, 23154, 23155, 23156, 23110
9717, 22479, 22501, 22502, 22480, 23156, 23157, 23158, 23112
9718, 22480, 22502, 22503, 22481, 23158, 23159, 23160, 23114
9719, 22481, 22503, 22504, 22482, 23160, 23161, 23162, 23116
9720, 22482, 22504, 22505, 22483, 23162, 23163, 23164, 23118
9721, 22483, 22505, 22506, 22484, 23164, 23165, 23166, 23120
9722, 22484, 22506, 22507, 22485, 23166, 23167, 23168, 23122
9723, 22485, 22507, 22508, 22486, 23168, 23169, 23170, 23124
9724, 22486, 22508, 22509, 22487, 23170, 23171, 23172, 23126
9725, 22487, 22509, 22510, 22488, 23172, 23173, 23174, 23128
9726, 22488, 22510, 22511, 22489, 23174, 23175, 23176, 23130
9727, 22489, 22511, 22512, 22490, 23176, 23177, 23178, 23132
9728, 22490, 22512, 22513, 22491, 23178, 23179, 23180, 23134
9729, 22491, 22513, 3037, 3036, 23180, 23181, 3059, 23136
9730, 2975, 2976, 22514, 22492, 2998, 23182, 23183, 23137
9731, 22492, 22514, 22515, 22493, 23183, 23184, 23185, 23139
9732, 22493, 22515, 22516, 22494, 23185, 23186, 23187, 23141
9733, 22494, 22516, 22517, 22495, 23187, 23188, 23189, 23143
9734, 22495, 22517, 22518, 22496, 23189, 23190, 23191, 23145
9735, 22496, 22518, 22519, 22497, 23191, 23192, 23193, 23147
9736, 22497, 22519, 22520, 22498, 23193, 23194, 23195, 23149
9737, 22498, 22520, 22521, 22499, 23195, 23196, 23197, 23151
9738, 22499, 22521, 22522, 22500, 23197, 23198, 23199, 23153
9739, 22500, 22522, 22523, 22501, 23199, 23200, 23201, 23155
9740, 22501, 22523, 22524, 22502, 23201, 23202, 23203, 23157
9741, 22502, 22524, 22525, 22503, 23203, 23204, 23205, 23159
9742, 22503, 22525, 22526, 22504, 23205, 23206, 23207, 23161
9743, 22504, 22526, 22527, 22505, 23207, 23208, 23209, 23163
9744, 22505, 22527, 22528, 22506, 23209, 23210, 23211, 23165
9745, 22506, 22528, 22529, 22507, 23211, 23212, 23213, 23167
9746, 22507, 22529, 22530, 22508, 23213, 23214, 23215, 23169
9747, 22508, 22530, 22531, 22509, 23215, 23216, 23217, 23171
9748, 22509, 22531, 22532, 22510, 23217, 23218, 23219, 23173
9749, 22510, 22532, 22533, 22511, 23219, 23220, 23221, 23175
9750, 22511, 22533, 22534, 22512, 23221, 23222, 23223, 23177
9751, 22512, 22534, 22535, 22513, 23223, 23224, 23225, 23179
9752, 22513, 22535, 3038, 3037, 23225, 23226, 3060, 23181
9753, 2976, 2977, 22536, 22514, 2999, 23227, 23228, 23182
9754, 22514, 22536, 22537, 22515, 23228, 23229, 23230, 23184
9755, 22515, 22537, 22538, 22516, 23230, 23231, 23232, 23186
9756, 22516, 22538, 22539, 22517, 23232, 23233, 23234, 23188
9757, 22517, 22539, 22540, 22518, 23234, 23235, 23236, 23190
9758, 22518, 22540, 22541, 22519, 23236, 23237, 23238, 23192
9759, 22519, 22541, 22542, 22520, 23238, 23239, 23240, 23194
9760, 22520, 22542, 22543, 22521, 23240, 23241, 23242, 23196
9761, 22521, 22543, 22544, 22522, 23242, 23243, 23244, 23198
9762, 22522, 22544, 22545, 22523, 23244, 23245, 23246, 23200
9763, 22523, 22545, 22546, 22524, 23246, 23247, 23248, 23202
9764, 22524, 22546, 22547, 22525, 23248, 23249, 23250, 23204
9765, 22525, 22547, 22548, 22526, 23250, 23251, 23252, 23206
9766, 22526, 22548, 22549, 22527, 23252, 23253, 23254, 23208
9767, 22527, 22549, 22550, 22528, 23254, 23255, 23256, 23210
9768, 22528, 22550, 22551, 22529, 23256, 23257, 23258, 23212
9769, 22529, 22551, 22552, 22530, 23258, 23259, 23260, 23214
9770, 22530, 22552, 22553, 22531, 23260, 23261, 23262, 23216
9771, 22531, 22553, 22554, 22532, 23262, 23263, 23264, 23218
9772, 22532, 22554, 22555, 22533, 23264, 23265, 23266, 23220
9773, 22533, 22555, 22556, 22534, 23266, 23267, 23268, 23222
9774, 22534, 22556, 22557, 22535, 23268, 23269, 23270, 23224
9775, 22535, 22557, 3039, 3038, 23270, 23271, 3061, 23226
9776, 2977, 2978, 22558, 22536, 3000, 23272, 23273, 23227
9777, 22536, 22558, 22559, 22537, 23273, 23274, 23275, 23229
9778, 22537, 22559, 22560, 22538, 23275, 23276, 23277, 23231
9779, 22538, 22560, 22561, 22539, 23277, 23278, 23279, 23233
9780, 22539, 22561, 22562, 22540, 23279, 23280, 23281, 23235
9781, 22540, 22562, 22563, 22541, 23281, 23282, 23283, 23237
9782, 22541, 22563, 22564, 22542, 23283, 23284, 23285, 23239
9783, 22542, 22564, 22565, 22543, 23285, 23286, 23287, 23241
9784, 22543, 22565, 22566, 22544, 23287, 23288, 23289, 23243
9785, 22544, 22566, 22567, 22545, 23289, 23290, 23291, 23245
9786, 22545, 22567, 22568, 22546, 23291, 23292, 23293, 23247
9787, 22546, 22568, 22569, 22547, 23293, 23294, 23295, 23249
9788, 22547, 22569, 22570, 22548, 23295, 23296, 23297, 23251
9789, 22548, 22570, 22571, 22549, 23297, 23298, 23299, 23253
9790, 22549, 22571, 22572, 22550, 23299, 23300, 23301, 23255
9791, 22550, 22572, 22573, 22551, 23301, 23302, 23303, 23257
9792, 22551, 22573, 22574, 22552, 23303, 23304, 23305, 23259
9793, 22552, 22574, 22575, 22553, 23305, 23306, 23307, 23261
9794, 22553, 22575, 22576, 22554, 23307, 23308, 23309, 23263
9795, 22554, 22576, 22577, 22555, 23309, 23310, 23311, 23265
9796, 22555, 22577, 22578, 22556, 23311, 23312, 23313, 23267
9797, 22556, 22578, 22579, 22557, 23313, 23314, 23315, 23269
9798, 22557, 22579, 3040, 3039, 23315, 23316, 3062, 23271
9799, 2978, 2979, 22580, 22558, 3001, 23317, 23318, 23272
9800, 22558, 22580, 22581, 22559, 23318, 23319, 23320, 23274
9801, 22559, 22581, 22582, 22560, 23320, 23321, 23322, 23276
9802, 22560, 22582, 22583, 22561, 23322, 23323, 23324, 23278
9803, 22561, 22583, 22584, 22562, 23324, 23325, 23326, 23280
9804, 22562, 22584, 22585, 22563, 23326, 23327, 23328, 23282
9805, 22563, 22585, 22586, 22564, 23328, 23329, 23330, 23284
9806, 22564, 22586, 22587, 22565, 23330, 23331, 23332, 23286
9807, 22565, 22587, 22588, 22566, 23332, 23333, 23334, 23288
9808, 22566, 22588, 22589, 22567, 23334, 23335, 23336, 23290
9809, 22567, 22589, 22590, 22568, 23336, 23337, 23338, 23292
9810, 22568, 22590, 22591, 22569, 23338, 23339, 23340, 23294
9811, 22569, 22591, 22592, 22570, 23340, 23341, 23342, 23296
9812, 22570, 22592, 22593, 22571, 23342, 23343, 23344, 23298
9813, 22571, 22593, 22594, 22572, 23344, 23345, 23346, 23300
9814, 22572, 22594, 22595, 22573, 23346, 23347, 23348, 23302
9815, 22573, 22595, 22596, 22574, 23348, 23349, 23350, 23304
9816, 22574, 22596, 22597, 22575, 23350, 23351, 23352, 23306
9817, 22575, 22597, 22598, 22576, 23352, 23353, 23354, 23308
9818, 22576, 22598, 22599, 22577, 23354, 23355, 23356, 23310
9819, 22577, 22599, 22600, 22578, 23356, 23357, 23358, 23312
9820, 22578, 22600, 22601, 22579, 23358, 23359, 23360, 23314
9821, 22579, 22601, 3041, 3040, 23360, 23361, 3063, 23316
9822, 2979, 2980, 22602, 22580, 3002, 23362, 23363, 23317
9823, 22580, 22602, 22603, 22581, 23363, 23364, 23365, 23319
9824, 22581, 22603, 22604, 22582, 23365, 23366, 23367, 23321
9825, 22582, 22604, 22605, 22583, 23367, 23368, 23369, 23323
9826, 22583, 22605, 22606, 22584, 23369, 23370, 23371, 23325
9827, 22584, 22606, 22607, 22585, 23371, 23372, 23373, 23327
9828, 22585, 22607, 22608, 22586, 23373, 23374, 23375, 23329
9829, 22586, 22608, 22609, 22587, 23375, 23376, 23377, 23331
9830, 22587, 22609, 22610, 22588, 23377, 23378, 23379, 23333
9831, 22588, 22610, 22611, 22589, 23379, 23380, 23381, 23335
9832, 22589, 22611, 22612, 22590, 23381, 23382, 23383, 23337
9833, 22590, 22612, 22613, 22591, 23383, 23384, 23385, 23339
9834, 22591, 22613, 22614, 22592, 23385, 23386, 23387, 23341
9835, 22592, 22614, 22615, 22593, 23387, 23388, 23389, 23343
9836, 22593, 22615, 22616, 22594, 23389, 23390, 23391, 23345
9837, 22594, 22616, 22617, 22595, 23391, 23392, 23393, 23347
9838, 22595, 22617, 22618, 22596, 23393, 23394, 23395, 23349
9839, 22596, 22618, 22619, 22597, 23395, 23396, 23397, 23351
9840, 22597, 22619, 22620, 22598, 23397, 23398, 23399, 23353
9841, 22598, 22620, 22621, 22599, 23399, 23400, 23401, 23355
9842, 22599, 22621, 22622, 22600, 23401, 23402, 23403, 23357
9843, 22600, 22622, 22623, 22601, 23403, 23404, 23405, 23359
9844, 22601, 22623, 3042, 3041, 23405, 23406, 3064, 23361
9845, 2980, 2981, 22624, 22602, 3003, 23407, 23408, 23362
9846, 22602, 22624, 22625, 22603, 23408, 23409, 23410, 23364
9847, 22603, 22625, 22626, 22604, 23410, 23411, 23412, 23366
9848, 22604, 22626, 22627, 22605, 23412, 23413, 23414, 23368
9849, 22605, 22627, 22628, 22606, 23414, 23415, 23416, 23370
9850, 22606, 22628, 22629, 22607, 23416, 23417, 23418, 23372
9851, 22607, 22629, 22630, 22608, 23418, 23419, 23420, 23374
9852, 22608, 22630, 22631, 22609, 23420, 23421, 23422, 23376
9853, 22609, 22631, 22632, 22610, 23422, 23423, 23424, 23378
9854, 22610, 22632, 22633, 22611, 23424, 23425, 23426, 23380
9855, 22611, 22633, 22634, 22612, 23426, 23427, 23428, 23382
9856, 22612, 22634, 22635, 22613, 23428, 23429, 23430, 23384
9857, 22613, 22635, 22636, 22614, 23430, 23431, 23432, 23386
9858, 22614, 22636, 22637, 22615, 23432, 23433, 23434, 23388
9859, 22615, 22637, 22638, 22616, 23434, 23435, 23436, 23390
9860, 22616, 22638, 22639, 22617, 23436, 23437, 23438, 23392
9861, 22617, 22639, 22640, 22618, 23438, 23439, 23440, 23394
9862, 22618, 22640, 22641, 22619, 23440, 23441, 23442, 23396
9863, 22619, 22641, 22642, 22620, 23442, 23443, 23444, 23398
9864, 22620, 22642, 22643, 22621, 23444, 23445, 23446, 23400
9865, 22621, 22643, 22644, 22622, 23446, 23447, 23448, 23402
9866, 22622, 22644, 22645, 22623, 23448, 23449, 23450, 23404
9867, 22623, 22645, 3043, 3042, 23450, 23451, 3065, 23406
9868, 2981, 2982, 22646, 22624, 3004, 23452, 23453, 23407
9869, 22624, 22646, 22647, 22625, 23453, 23454, 23455, 23409
9870, 22625, 22647, 22648, 22626, 23455, 23456, 23457, 23411
9871, 22626, 22648, 22649, 22627, 23457, 23458, 23459, 23413
9872, 22627, 22649, 22650, 22628, 23459, 23460, 23461, 23415
9873, 22628, 22650, 22651, 22629, 23461, 23462, 23463, 23417
9874, 22629, 22651, 22652, 22630, 23463, 23464, 23465, 23419
9875, 22630, 22652, 22653, 22631, 23465, 23466, 23467, 23421
9876, 22631, 22653, 22654, 22632, 23467, 23468, 23469, 23423
9877, 22632, 22654, 22655, 22633, 23469, 23470, 23471, 23425
9878, 22633, 22655, 22656, 22634, 23471, 23472, 23473, 23427
9879, 22634, 22656, 22657, 22635, 23473, 23474, 23475, 23429
9880, 22635, 22657, 22658, 22636, 23475, 23476, 23477, 23431
9881, 22636, 22658, 22659, 22637, 23477, 23478, 23479, 23433
9882, 22637, 22659, 22660, 22638, 23479, 23480, 23481, 23435
9883, 22638, 22660, 22661, 22639, 23481, 23482, 23483, 23437
9884, 22639, 22661, 22662, 22640, 23483, 23484, 23485, 23439
9885, 22640, 22662, 22663, 22641, 23485, 23486, 23487, 23441
9886, 22641, 22663, 22664, 22642, 23487, 23488, 23489, 23443
9887, 22642, 22664, 22665, 22643, 23489, 23490, 23491, 23445
9888, 22643, 22665, 22666, 22644, 23491, 23492, 23493, 23447
9889, 22644, 22666, 22667, 22645, 23493, 23494, 23495, 23449
9890, 22645, 22667, 3044, 3043, 23495, 23496, 3066, 23451
9891, 2982, 2983, 22668, 22646, 3005, 23497, 23498, 23452
9892, 22646, 22668, 22669, 22647, 23498, 23499, 23500, 23454
9893, 22647, 22669, 22670, 22648, 23500, 23501, 23502, 23456
9894, 22648, 22670, 22671, 22649, 23502, 23503, 23504, 23458
9895, 22649, 22671, 22672, 22650, 23504, 23505, 23506, 23460
9896, 22650, 22672, 22673, 22651, 23506, 23507, 23508, 23462
9897, 22651, 22673, 22674, 22652, 23508, 23509, 23510, 23464
9898, 22652, 22674, 22675, 22653, 23510, 23511, 23512, 23466
9899, 22653, 22675, 22676, 22654, 23512, 23513, 23514, 23468
9900, 22654, 22676, 22677, 22655, 23514, 23515, 23516, 23470
9901, 22655, 22677, 22678, 22656, 23516, 23517, 23518, 23472
9902, 22656, 22678, 22679, 22657, 23518, 23519, 23520, 23474
9903, 22657, 22679, 22680, 22658, 23520, 23521, 23522, 23476
9904, 22658, 22680, 22681, 22659, 23522, 23523, 23524, 23478
9905, 22659, 22681, 22682, 22660, 23524, 23525, 23526, 23480
9906, 22660, 22682, 22683, 22661, 23526, 23527, 23528, 23482
9907, 22661, 22683, 22684, 22662, 23528, 23529, 23530, 23484
9908, 22662, 22684, 22685, 22663, 23530, 23531, 23532, 23486
9909, 22663, 22685, 22686, 22664, 23532, 23533, 23534, 23488
9910, 22664, 22686, 22687, 22665, 23534, 23535, 23536, 23490
9911, 22665, 22687, 22688, 22666, 23536, 23537, 23538, 23492
9912, 22666, 22688, 22689, 22667, 23538, 23539, 23540, 23494
9913, 22667, 22689, 3045, 3044, 23540, 23541, 3067, 23496
9914, 2983, 2984, 22690, 22668, 3006, 23542, 23543, 23497
9915, 22668, 22690, 22691, 22669, 23543, 23544, 23545, 23499
9916, 22669, 22691, 22692, 22670, 23545, 23546, 23547, 23501
9917, 22670, 22692, 22693, 22671, 23547, 23548, 23549, 23503
9918, 22671, 22693, 22694, 22672, 23549, 23550, 23551, 23505
9919, 22672, 22694, 22695, 22673, 23551, 23552, 23553, 23507
9920, 22673, 22695, 22696, 22674, 23553, 23554, 23555, 23509
9921, 22674, 22696, 22697, 22675, 23555, 23556, 23557, 23511
9922, 22675, 22697, 22698, 22676, 23557, 23558, 23559, 23513
9923, 22676, 22698, 22699, 22677, 23559, 23560, 23561, 23515
9924, 22677, 22699, 22700, 22678, 23561, 23562, 23563, 23517
9925, 22678, 22700, 22701, 22679, 23563, 23564, 23565, 23519
9926, 22679, 22701, 22702, 22680, 23565, 23566, 23567, 23521
9927, 22680, 22702, 22703, 22681, 23567, 23568, 23569, 23523
9928, 22681, 22703, 22704, 22682, 23569, 23570, 23571, 23525
9929, 22682, 22704, 22705, 22683, 23571, 23572, 23573, 23527
9930, 22683, 22705, 22706, 22684, 23573, 23574, 23575, 23529
9931, 22684, 22706, 22707, 22685, 23575, 23576, 23577, 23531
9932, 22685, 22707, 22708, 22686, 23577, 23578, 23579, 23533
9933, 22686, 22708, 22709, 22687, 23579, 23580, 23581, 23535
9934, 22687, 22709, 22710, 22688, 23581, 23582, 23583, 23537
9935, 22688, 22710, 22711, 22689, 23583, 23584, 23585, 23539
9936, 22689, 22711, 3046, 3045, 23585, 23586, 3068, 23541
9937, 2984, 2985, 22712, 22690, 3007, 23587, 23588, 23542
9938, 22690, 22712, 22713, 22691, 23588, 23589, 23590, 23544
9939, 22691, 22713, 22714, 22692, 23590, 23591, 23592, 23546
9940, 22692, 22714, 22715, 22693, 23592, 23593, 23594, 23548
9941, 22693, 22715, 22716, 22694, 23594, 23595, 23596, 23550
9942, 22694, 22716, 22717, 22695, 23596, 23597, 23598, 23552
9943, 22695, 22717, 22718, 22696, 23598, 23599, 23600, 23554
9944, 22696, 22718, 22719, 22697, 23600, 23601, 23602, 23556
9945, 22697, 22719, 22720, 22698, 23602, 23603, 23604, 23558
9946, 22698, 22720, 22721, 22699, 23604, 23605, 23606, 23560
9947, 22699, 22721, 22722, 22700, 23606, 23607, 23608, 23562
9948, 22700, 22722, 22723, 22701, 23608, 23609, 23610, 23564
9949, 22701, 22723, 22724, 22702, 23610, 23611, 23612, 23566
9950, 22702, 22724, 22725, 22703, 23612, 23613, 23614, 23568
9951, 22703, 22725, 22726, 22704, 23614, 23615, 23616, 23570
9952, 22704, 22726, 22727, 22705, 23616, 23617, 23618, 23572
9953, 22705, 22727, 22728, 22706, 23618, 23619, 23620, 23574
9954, 22706, 22728, 22729, 22707, 23620, 23621, 23622, 23576
9955, 22707, 22729, 22730, 22708, 23622, 23623, 23624, 23578
9956, 22708, 22730, 22731, 22709, 23624, 23625, 23626, 23580
9957, 22709, 22731, 22732, 22710, 23626, 23627, 23628, 23582
9958, 22710, 22732, 22733, 22711, 23628, 23629, 23630, 23584
9959, 22711, 22733, 3047, 3046, 23630, 23631, 3069, 23586
9960, 2985, 2986, 22734, 22712, 3008, 23632, 23633, 23587
9961, 22712, 22734, 22735, 22713, 23633, 23634, 23635, 23589
9962, 22713, 22735, 22736, 22714, 23635, 23636, 23637, 23591
9963, 22714, 22736, 22737, 22715, 23637, 23638, 23639, 23593
9964, 22715, 22737, 22738, 22716, 23639, 23640, 23641, 23595
9965, 22716, 22738, 22739, 22717, 23641, 23642, 23643, 23597
9966, 22717, 22739, 22740, 22718, 23643, 23644, 23645, 23599
9967, 22718, 22740, 22741, 22719, 23645, 23646, 23647, 23601
9968, 22719, 22741, 22742, 22720, 23647, 23648, 23649, 23603
9969, 22720, 22742, 22743, 22721, 23649, 23650, 23651, 23605
9970, 22721, 22743, 22744, 22722, 23651, 23652, 23653, 23607
9971, 22722, 22744, 22745, 22723, 23653, 23654, 23655, 23609
9972, 22723, 22745, 22746, 22724, 23655, 23656, 23657, 23611
9973, 22724, 22746, 22747, 22725, 23657, 23658, 23659, 23613
9974, 22725, 22747, 22748, 22726, 23659, 23660, 23661, 23615
9975, 22726, 22748, 22749, 22727, 23661, 23662, 23663, 23617
9976, 22727, 22749, 22750, 22728, 23663, 23664, 23665, 23619
9977, 22728, 22750, 22751, 22729, 23665, 23666, 23667, 23621
9978, 22729, 22751, 22752, 22730, 23667, 23668, 23669, 23623
9979, 22730, 22752, 22753, 22731, 23669, 23670, 23671, 23625
9980, 22731, 22753, 22754, 22732, 23671, 23672, 23673, 23627
9981, 22732, 22754, 22755, 22733, 23673, 23674, 23675, 23629
9982, 22733, 22755, 3048, 3047, 23675, 23676, 3070, 23631
9983, 2986, 2987, 22756, 22734, 3009, 23677, 23678, 23632
9984, 22734, 22756, 22757, 22735, 23678, 23679, 23680, 23634
9985, 22735, 22757, 22758, 22736, 23680, 23681, 23682, 23636
9986, 22736, 22758, 22759, 22737, 23682, 23683, 23684, 23638
9987, 22737, 22759, 22760, 22738, 23684, 23685, 23686, 23640
9988, 22738, 22760, 22761, 22739, 23686, 23687, 23688, 23642
9989, 22739, 22761, 22762, 22740, 23688, 23689, 23690, 23644
9990, 22740, 22762, 22763, 22741, 23690, 23691, 23692, 23646
9991, 22741, 22763, 22764, 22742, 23692, 23693, 23694, 23648
9992, 22742, 22764, 22765, 22743, 23694, 23695, 23696, 23650
9993, 22743, 22765, 22766, 22744, 23696, 23697, 23698, 23652
9994, 22744, 22766, 22767, 22745, 23698, 23699, 23700, 23654
9995, 22745, 22767, 22768, 22746, 23700, 23701, 23702, 23656
9996, 22746, 22768, 22769, 22747, 23702, 23703, 23704, 23658
9997, 22747, 22769, 22770, 22748, 23704, 23705, 23706, 23660
9998, 22748, 22770, 22771, 22749, 23706, 23707, 23708, 23662
9999, 22749, 22771, 22772, 22750, 23708, 23709, 23710, 23664
10000, 22750, 22772, 22773, 22751, 23710, 23711, 23712, 23666
10001, 22751, 22773, 22774, 22752, 23712, 23713, 23714, 23668
10002, 22752, 22774, 22775, 22753, 23714, 23715, 23716, 23670
10003, 22753, 22775, 22776, 22754, 23716, 23717, 23718, 23672
10004, 22754, 22776, 22777, 22755, 23718, 23719, 23720, 23674
10005, 22755, 22777, 3049, 3048, 23720, 23721, 3071, 23676
10006, 2987, 2988, 22778, 22756, 3010, 23722, 23723, 23677
10007, 22756, 22778, 22779, 22757, 23723, 23724, 23725, 23679
10008, 22757, 22779, 22780, 22758, 23725, 23726, 23727, 23681
10009, 22758, 22780, 22781, 22759, 23727, 23728, 23729, 23683
10010, 22759, 22781, 22782, 22760, 23729, 23730, 23731, 23685
10011, 22760, 22782, 22783, 22761, 23731, 23732, 23733, 23687
10012, 22761, 22783, 22784, 22762, 23733, 23734, 23735, 23689
10013, 22762, 22784, 22785, 22763, 23735, 23736, 23737, 23691
10014, 22763, 22785, 22786, 22764, 23737, 23738, 23739, 23693
10015, 22764, 22786, 22787, 22765, 23739, 23740, 23741, 23695
10016, 22765, 22787, 22788, 22766, 23741, 23742, 23743, 23697
10017, 22766, 22788, 22789, 22767, 23743, 23744, 23745, 23699
10018, 22767, 22789, 22790, 22768, 23745, 23746, 23747, 23701
10019, 22768, 22790, 22791, 22769, 23747, 23748, 23749, 23703
10020, 22769, 22791, 22792, 22770, 23749, 23750, 23751, 23705
10021, 22770, 22792, 22793, 22771, 23751, 23752, 23753, 23707
10022, 22771, 22793, 22794, 22772, 23753, 23754, 23755, 23709
10023, 22772, 22794, 22795, 22773, 23755, 23756, 23757, 23711
10024, 22773, 22795, 22796, 22774, 23757, 23758, 23759, 23713
10025, 22774, 22796, 22797, 22775, 23759, 23760, 23761, 23715
10026, 22775, 22797, 22798, 22776, 23761, 23762, 23763, 23717
10027, 22776, 22798, 22799, 22777, 23763, 23764, 23765, 23719
10028, 22777, 22799, 3050, 3049, 23765, 23766, 3072, 23721
10029, 2988, 2989, 22800, 22778, 3011, 23767, 23768, 23722
10030, 22778, 22800, 22801, 22779, 23768, 23769, 23770, 23724
10031, 22779, 22801, 22802, 22780, 23770, 23771, 23772, 23726
10032, 22780, 22802, 22803, 22781, 23772, 23773, 23774, 23728
10033, 22781, 22803, 22804, 22782, 23774, 23775, 23776, 23730
10034, 22782, 22804, 22805, 22783, 23776, 23777, 23778, 23732
10035, 22783, 22805, 22806, 22784, 23778, 23779, 23780, 23734
10036, 22784, 22806, 22807, 22785, 23780, 23781, 23782, 23736
10037, 22785, 22807, 22808, 22786, 23782, 23783, 23784, 23738
10038, 22786, 22808, 22809, 22787, 23784, 23785, 23786, 23740
10039, 22787, 22809, 22810, 22788, 23786, 23787, 23788, 23742
10040, 22788, 22810, 22811, 22789, 23788, 23789, 23790, 23744
10041, 22789, 22811, 22812, 22790, 23790, 23791, 23792, 23746
10042, 22790, 22812, 22813, 22791, 23792, 23793, 23794, 23748
10043, 22791, 22813, 22814, 22792, 23794, 23795, 23796, 23750
10044, 22792, 22814, 22815, 22793, 23796, 23797, 23798, 23752
10045, 22793, 22815, 22816, 22794, 23798, 23799, 23800, 23754
10046, 22794, 22816, 22817, 22795, 23800, 23801, 23802, 23756
10047, 22795, 22817, 22818, 22796, 23802, 23803, 23804, 23758
10048, 22796, 22818, 22819, 22797, 23804, 23805, 23806, 23760
10049, 22797, 22819, 22820, 22798, 23806, 23807, 23808, 23762
10050, 22798, 22820, 22821, 22799, 23808, 23809, 23810, 23764
10051, 22799, 22821, 3051, 3050, 23810, 23811, 3073, 23766
10052, 2989, 91, 3096, 22800, 3012, 3119, 23812, 23767
10053, 22800, 3096, 3095, 22801, 23812, 3118, 23813, 23769
10054, 22801, 3095, 3094, 22802, 23813, 3117, 23814, 23771
10055, 22802, 3094, 3093, 22803, 23814, 3116, 23815, 23773
10056, 22803, 3093, 3092, 22804, 23815, 3115, 23816, 23775
10057, 22804, 3092, 3091, 22805, 23816, 3114, 23817, 23777
10058, 22805, 3091, 3090, 22806, 23817, 3113, 23818, 23779
10059, 22806, 3090, 3089, 22807, 23818, 3112, 23819, 23781
10060, 22807, 3089, 3088, 22808, 23819, 3111, 23820, 23783
10061, 22808, 3088, 3087, 22809, 23820, 3110, 23821, 23785
10062, 22809, 3087, 3086, 22810, 23821, 3109, 23822, 23787
10063, 22810, 3086, 3085, 22811, 23822, 3108, 23823, 23789
10064, 22811, 3085, 3084, 22812, 23823, 3107, 23824, 23791
10065, 22812, 3084, 3083, 22813, 23824, 3106, 23825, 23793
10066, 22813, 3083, 3082, 22814, 23825, 3105, 23826, 23795
10067, 22814, 3082, 3081, 22815, 23826, 3104, 23827, 23797
10068, 22815, 3081, 3080, 22816, 23827, 3103, 23828, 23799
10069, 22816, 3080, 3079, 22817, 23828, 3102, 23829, 23801
10070, 22817, 3079, 3078, 22818, 23829, 3101, 23830, 23803
10071, 22818, 3078, 3077, 22819, 23830, 3100, 23831, 23805
10072, 22819, 3077, 3076, 22820, 23831, 3099, 23832, 23807
10073, 22820, 3076, 3075, 22821, 23832, 3098, 23833, 23809
10074, 22821, 3075, 92, 3051, 23833, 3097, 3074, 23811
*ELEMENT, type=CPS8, ELSET=Surface263
10075, 4, 3030, 23834, 235, 3052, 24010, 24011, 244
10076, 235, 23834, 23835, 234, 24011, 24012, 24013, 243
10077, 234, 23835, 23836, 233, 24013, 24014, 24015, 242
10078, 233, 23836, 23837, 232, 24015, 24016, 24017, 241
10079, 232, 23837, 23838, 231, 24017, 24018, 24019, 240
10080, 231, 23838, 23839, 230, 24019, 24020, 24021, 239
10081, 230, 23839, 23840, 229, 24021, 24022, 24023, 238
10082, 229, 23840, 23841, 228, 24023, 24024, 24025, 237
10083, 228, 23841, 2878, 2, 24025, 24026, 2900, 236
10084, 3030, 3031, 23842, 23834, 3053, 24027, 24028, 24010
10085, 23834, 23842, 23843, 23835, 24028, 24029, 24030, 24012
10086, 23835, 23843, 23844, 23836, 24030, 24031, 24032, 24014
10087, 23836, 23844, 23845, 23837, 24032, 24033, 24034, 24016
10088, 23837, 23845, 23846, 23838, 24034, 24035, 24036, 24018
10089, 23838, 23846, 23847, 23839, 24036, 24037, 24038, 24020
10090, 23839, 23847, 23848, 23840, 24038, 24039, 24040, 24022
10091, 23840, 23848, 23849, 23841, 24040, 24041, 24042, 24024
10092, 23841, 23849, 2879, 2878, 24042, 24043, 2901, 24026
10093, 3031, 3032, 23850, 23842, 3054, 24044, 24045, 24027
10094, 23842, 23850, 23851, 23843, 24045, 24046, 24047, 24029
10095, 23843, 23851, 23852, 23844, 24047, 24048, 24049, 24031
10096, 23844, 23852, 23853, 23845, 24049, 24050, 24051, 24033
10097, 23845, 23853, 23854, 23846, 24051, 24052, 24053, 24035
10098, 23846, 23854, 23855, 23847, 24053, 24054, 24055, 24037
10099, 23847, 23855, 23856, 23848, 24055, 24056, 24057, 24039
10100, 23848, 23856, 23857, 23849, 24057, 24058, 24059, 24041
10101, 23849, 23857, 2880, 2879, 24059, 24060, 2902, 24043
10102, 3032, 3033, 23858, 23850, 3055, 24061, 24062, 24044
10103, 23850, 23858, 23859, 23851, 24062, 24063, 24064, 24046
10104, 23851, 23859, 23860, 23852, 24064, 24065, 24066, 24048
10105, 23852, 23860, 23861, 23853, 24066, 24067, 24068, 24050
10106, 23853, 23861, 23862, 23854, 24068, 24069, 24070, 24052
10107, 23854, 23862, 23863, 23855, 24070, 24071, 24072, 24054
10108, 23855, 23863, 23864, 23856, 24072, 24073, 24074, 24056
10109, 23856, 23864, 23865, 23857, 24074, 24075, 24076, 24058
10110, 23857, 23865, 2881, 2880, 24076, 24077, 2903, 24060
10111, 3033, 3034, 23866, 23858, 3056, 24078, 24079, 24061
10112, 23858, 23866, 23867, 23859, 24079, 24080, 24081, 24063
10113, 23859, 23867, 23868, 23860, 24081, 24082, 24083, 24065
10114, 23860, 23868, 23869, 23861, 24083, 24084, 24085, 24067
10115, 23861, 23869, 23870, 23862, 24085, 24086, 24087, 24069
10116, 23862, 23870, 23871, 23863, 24087, 24088, 24089, 24071
10117, 23863, 23871, 23872, 23864, 24089, 24090, 24091, 24073
10118, 23864, 23872, 23873, 23865, 24091, 24092, 24093, 24075
10119, 23865, 23873, 2882, 2881, 24093, 24094, 2904, 24077
10120, 3034, 3035, 23874, 23866, 3057, 24095, 24096, 24078
10121, 23866, 23874, 23875, 23867, 24096, 24097, 24098, 24080
10122, 23867, 23875, 23876, 23868, 24098, 24099, 24100, 24082
10123, 23868, 23876, 23877, 23869, 24100, 24101, 24102, 24084
10124, 23869, 23877, 23878, 23870, 24102, 24103, 24104, 24086
10125, 23870, 23878, 23879, 23871, 24104, 24105, 24106, 24088
10126, 23871, 23879, 23880, 23872, 24106, 24107, 24108, 24090
10127, 23872, 23880, 23881, 23873, 24108, 24109, 24110, 24092
10128, 23873, 23881, 2883, 2882, 24110, 24111, 2905, 24094
10129, 3035, 3036, 23882, 23874, 3058, 24112, 24113, 24095
10130, 23874, 23882, 23883, 23875, 24113, 24114, 24115, 24097
10131, 23875, 23883, 23884, 23876, 24115, 24116, 24117, 24099
10132, 23876, 23884, 23885, 23877, 24117, 24118, 24119, 24101
10133, 23877, 23885, 23886, 23878, 24119, 24120, 24121, 24103
10134, 23878, 23886, 23887, 23879, 24121, 24122, 24123, 24105
10135, 23879, 23887, 23888, 23880, 24123, 24124, 24125, 24107
10136, 23880, 23888, 23889, 23881, 24125, 24126, 24127, 24109
10137, 23881, 23889, 2884, 2883, 24127, 24128, 2906, 24111
10138, 3036, 3037, 23890, 23882, 3059, 24129, 24130, 24112
10139, 23882, 23890, 23891, 23883, 24130, 24131, 24132, 24114
10140, 23883, 23891, 23892, 23884, 24132, 24133, 24134, 24116
10141, 23884, 23892, 23893, 23885, 24134, 24135, 24136, 24118
10142, 23885, 23893, 23894, 23886, 24136, 24137, 24138, 24120
10143, 23886, 23894, 23895, 23887, 24138, 24139, 24140, 24122
10144, 23887, 23895, 23896, 23888, 24140, 24141, 24142, 24124
10145, 23888, 23896, 23897, 23889, 24142, 24143, 24144, 24126
10146, 23889, 23897, 2885, 2884, 24144, 24145, 2907, 24128
10147, 3037, 3038, 23898, 23890, 3060, 24146, 24147, 24129
10148, 23890, 23898, 23899, 23891, 24147, 24148, 24149, 24131
10149, 23891, 23899, 23900, 23892, 24149, 24150, 24151, 24133
10150, 23892, 23900, 23901, 23893, 24151, 24152, 24153, 24135
10151, 23893, 23901, 23902, 23894, 24153, 24154, 24155, 24137
10152, 23894, 23902, 23903, 23895, 24155, 24156, 24157, 24139
10153, 23895, 23903, 23904, 23896, 24157, 24158, 24159, 24141
10154, 23896, 23904, 23905, 23897, 24159, 24160, 24161, 24143
10155, 23897, 23905, 2886, 2885, 24161, 24162, 2908, 24145
10156, 3038, 3039, 23906, 23898, 3061, 24163, 24164, 24146
10157, 23898, 23906, 23907, 23899, 24164, 24165, 24166, 24148
10158, 23899, 23907, 23908, 23900, 24166, 24167, 24168, 24150
10159, 23900, 23908, 23909, 23901, 24168, 24169, 24170, 24152
10160, 23901, 23909, 23910, 23902, 24170, 24171, 24172, 24154
10161, 23902, 23910, 23911, 23903, 24172, 24173, 24174, 24156
10162, 23903, 23911, 23912, 23904, 24174, 24175, 24176, 24158
10163, 23904, 23912, 23913, 23905, 24176, 24177, 24178, 24160
10164, 23905, 23913, 2887, 2886, 24178, 24179, 2909, 24162
10165, 3039, 3040, 23914, 23906, 3062, 24180, 24181, 24163
10166, 23906, 23914, 23915, 23907, 24181, 24182, 24183, 24165
10167, 23907, 23915, 23916, 23908, 24183, 24184, 24185, 24167
10168, 23908, 23916, 23917, 23909, 24185, 24186, 24187, 24169
10169, 23909, 23917, 23918, 23910, 24187, 24188, 24189, 24171
10170, 23910, 23918, 23919, 23911, 24189, 24190, 24191, 24173
10171, 23911, 23919, 23920, 23912, 24191, 24192, 24193, 24175
10172, 23912, 23920, 23921, 23913, 24193, 24194, 24195, 24177
10173, 23913, 23921, 2888, 2887, 24195, 24196, 2910, 24179
10174, 3040, 3041, 23922, 23914, 3063, 24197, 24198, 24180
10175, 23914, 23922, 23923, 23915, 24198, 24199, 24200, 24182
10176, 23915, 23923, 23924, 23916, 24200, 24201, 24202, 24184
10177, 23916, 23924, 23925, 23917, 24202, 24203, 24204, 24186
10178, 23917, 23925, 23926, 23918, 24204, 24205, 24206, 24188
10179, 23918, 23926, 23927, 23919, 24206, 24207, 24208, 24190
10180, 23919, 23927, 23928, 23920, 24208, 24209, 24210, 24192
10181, 23920, 23928, 23929, 23921, 24210, 24211, 24212, 24194
10182, 23921, 23929, 2889, 2888, 24212, 24213, 2911, 24196
10183, 3041, 3042, 23930, 23922, 3064, 24214, 24215, 24197
10184, 23922, 23930, 23931, 23923, 24215, 24216, 24217, 24199
10185, 23923, 23931, 23932, 23924, 24217, 24218, 24219, 24201
10186, 23924, 23932, 23933, 23925, 24219, 24220, 24221, 24203
10187, 23925, 23933, 23934, 23926, 24221, 24222, 24223, 24205
10188, 23926, 23934, 23935, 23927, 24223, 24224, 24225, 24207
10189, 23927, 23935, 23936, 23928, 24225, 24226, 24227, 24209
10190, 23928, 23936, 23937, 23929, 24227, 24228, 24229, 24211
10191, 23929, 23937, 2890, 2889, 24229, 24230, 2912, 24213
10192, 3042, 3043, 23938, 23930, 3065, 24231, 24232, 24214
10193, 23930, 23938, 23939, 23931, 24232, 24233, 24234, 24216
10194, 23931, 23939, 23940, 23932, 24234, 24235, 24236, 24218
10195, 23932, 23940, 23941, 23933, 24236, 24237, 24238, 24220
10196, 23933, 23941, 23942, 23934, 24238, 24239, 24240, 24222
10197, 23934, 23942, 23943, 23935, 24240, 24241, 24242, 24224
10198, 23935, 23943, 23944, 23936, 24242, 24243, 24244, 24226
10199, 23936, 23944, 23945, 23937, 24244, 24245, 24246, 24228
10200, 23937, 23945, 2891, 2890, 24246, 24247, 2913, 24230
10201, 3043, 3044, 23946, 23938, 3066, 24248, 24249, 24231
10202, 23938, 23946, 23947, 23939, 24249, 24250, 24251, 24233
10203, 23939, 23947, 23948, 23940, 24251, 24252, 24253, 24235
10204, 23940, 23948, 23949, 23941, 24253, 24254, 24255, 24237
10205, 23941, 23949, 23950, 23942, 24255, 24256, 24257, 24239
10206, 23942, 23950, 23951, 23943, 24257, 24258, 24259, 24241
10207, 23943, 23951, 23952, 23944, 24259, 24260, 24261, 24243
10208, 23944, 23952, 23953, 23945, 24261, 24262, 24263, 24245
10209, 23945, 23953, 2892, 2891, 24263, 24264, 2914, 24247
10210, 3044, 3045, 23954, 23946, 3067, 24265, 24266, 24248
10211, 23946, 23954, 23955, 23947, 24266, 24267, 24268, 24250
10212, 23947, 23955, 23956, 23948, 24268, 24269, 24270, 24252
10213, 23948, 23956, 23957, 23949, 24270, 24271, 24272, 24254
10214, 23949, 23957, 23958, 23950, 24272, 24273, 24274, 24256
10215, 23950, 23958, 23959, 23951, 24274, 24275, 24276, 24258
10216, 23951, 23959, 23960, 23952, 24276, 24277, 24278, 24260
10217, 23952, 23960, 23961, 23953, 24278, 24279, 24280, 24262
10218, 23953, 23961, 2893, 2892, 24280, 24281, 2915, 24264
10219, 3045, 3046, 23962, 23954, 3068, 24282, 24283, 24265
10220, 23954, 23962, 23963, 23955, 24283, 24284, 24285, 24267
10221, 23955, 23963, 23964, 23956, 24285, 24286, 24287, 24269
10222, 23956, 23964, 23965, 23957, 24287, 24288, 24289, 24271
10223, 23957, 23965, 23966, 23958, 24289, 24290, 24291, 24273
10224, 23958, 23966, 23967, 23959, 24291, 24292, 24293, 24275
10225, 23959, 23967, 23968, 23960, 24293, 24294, 24295, 24277
10226, 23960, 23968, 23969, 23961, 24295, 24296, 24297, 24279
10227, 23961, 23969, 2894, 2893, 24297, 24298, 2916, 24281
10228, 3046, 3047, 23970, 23962, 3069, 24299, 24300, 24282
10229, 23962, 23970, 23971, 23963, 24300, 24301, 24302, 24284
10230, 23963, 23971, 23972, 23964, 24302, 24303, 24304, 24286
10231, 23964, 23972, 23973, 23965, 24304, 24305, 24306, 24288
10232, 23965, 23973, 23974, 23966, 24306, 24307, 24308, 24290
10233, 23966, 23974, 23975, 23967, 24308, 24309, 24310, 24292
10234, 23967, 23975, 23976, 23968, 24310, 24311, 24312, 24294
10235, 23968, 23976, 23977, 23969, 24312, 24313, 24314, 24296
10236, 23969, 23977, 2895, 2894, 24314, 24315, 2917, 24298
10237, 3047, 3048, 23978, 23970, 3070, 24316, 24317, 24299
10238, 23970, 23978, 23979, 23971, 24317, 24318, 24319, 24301
10239, 23971, 23979, 23980, 23972, 24319, 24320, 24321, 24303
10240, 23972, 23980, 23981, 23973, 24321, 24322, 24323, 24305
10241, 23973, 23981, 23982, 23974, 24323, 24324, 24325, 24307
10242, 23974, 23982, 23983, 23975, 24325, 24326, 24327, 24309
10243, 23975, 23983, 23984, 23976, 24327, 24328, 24329, 24311
10244, 23976, 23984, 23985, 23977, 24329, 24330, 24331, 24313
10245, 23977, 23985, 2896, 2895, 24331, 24332, 2918, 24315
10246, 3048, 3049, 23986, 23978, 3071, 24333, 24334, 24316
10247, 23978, 23986, 23987, 23979, 24334, 24335, 24336, 24318
10248, 23979, 23987, 23988, 23980, 24336, 24337, 24338, 24320
10249, 23980, 23988, 23989, 23981, 24338, 24339, 24340, 24322
10250, 23981, 23989, 23990, 23982, 24340, 24341, 24342, 24324
10251, 23982, 23990, 23991, 23983, 24342, 24343, 24344, 24326
10252, 23983, 23991, 23992, 23984, 24344, 24345, 24346, 24328
10253, 23984, 23992, 23993, 23985, 24346, 24347, 24348, 24330
10254, 23985, 23993, 2897, 2896, 24348, 24349, 2919, 24332
10255, 3049, 3050, 23994, 23986, 3072, 24350, 24351, 24333
10256, 23986, 23994, 23995, 23987, 24351, 24352, 24353, 24335
10257, 23987, 23995, 23996, 23988, 24353, 24354, 24355, 24337
10258, 23988, 23996, 23997, 23989, 24355, 24356, 24357, 24339
10259, 23989, 23997, 23998, 23990, 24357, 24358, 24359, 24341
10260, 23990, 23998, 23999, 23991, 24359, 24360, 24361, 24343
10261, 23991, 23999, 24000, 23992, 24361, 24362, 24363, 24345
10262, 23992, 24000, 24001, 23993, 24363, 24364, 24365, 24347
10263, 23993, 24001, 2898, 2897, 24365, 24366, 2920, 24349
10264, 3050, 3051, 24002, 23994, 3073, 24367, 24368, 24350
10265, 23994, 24002, 24003, 23995, 24368, 24369, 24370, 24352
10266, 23995, 24003, 24004, 23996, 24370, 24371, 24372, 24354
10267, 23996, 24004, 24005, 23997, 24372, 24373, 24374, 24356
10268, 23997, 24005, 24006, 23998, 24374, 24375, 24376, 24358
10269, 23998, 24006, 24007, 23999, 24376, 24377, 24378, 24360
10270, 23999, 24007, 24008, 24000, 24378, 24379, 24380, 24362
10271, 24000, 24008, 24009, 24001, 24380, 24381, 24382, 24364
10272, 24001, 24009, 2899, 2898, 24382, 24383, 2921, 24366
10273, 3051, 92, 3127, 24002, 3074, 3136, 24384, 24367
10274, 24002, 3127, 3126, 24003, 24384, 3135, 24385, 24369
10275, 24003, 3126, 3125, 24004, 24385, 3134, 24386, 24371
10276, 24004, 3125, 3124, 24005, 24386, 3133, 24387, 24373
10277, 24005, 3124, 3123, 24006, 24387, 3132, 24388, 24375
10278, 24006, 3123, 3122, 24007, 24388, 3131, 24389, 24377
10279, 24007, 3122, 3121, 24008, 24389, 3130, 24390, 24379
10280, 24008, 3121, 3120, 24009, 24390, 3129, 24391, 24381
10281, 24009, 3120, 90, 2899, 24391, 3128, 2922, 24383
*ELEMENT, type=CPS8, ELSET=Surface264
10282, 90, 3120, 24392, 2923, 3128, 24568, 24569, 2945
10283, 3120, 3121, 24393, 24392, 3129, 24570, 24571, 24568
10284, 3121, 3122, 24394, 24393, 3130, 24572, 24573, 24570
10285, 3122, 3123, 24395, 24394, 3131, 24574, 24575, 24572
10286, 3123, 3124, 24396, 24395, 3132, 24576, 24577, 24574
10287, 3124, 3125, 24397, 24396, 3133, 24578, 24579, 24576
10288, 3125, 3126, 24398, 24397, 3134, 24580, 24581, 24578
10289, 3126, 3127, 24399, 24398, 3135, 24582, 24583, 24580
10290, 3127, 92, 3075, 24399, 3136, 3097, 24584, 24582
10291, 2923, 24392, 24400, 2924, 24569, 24585, 24586, 2946
10292, 24392, 24393, 24401, 24400, 24571, 24587, 24588, 24585
10293, 24393, 24394, 24402, 24401, 24573, 24589, 24590, 24587
10294, 24394, 24395, 24403, 24402, 24575, 24591, 24592, 24589
10295, 24395, 24396, 24404, 24403, 24577, 24593, 24594, 24591
10296, 24396, 24397, 24405, 24404, 24579, 24595, 24596, 24593
10297, 24397, 24398, 24406, 24405, 24581, 24597, 24598, 24595
10298, 24398, 24399, 24407, 24406, 24583, 24599, 24600, 24597
10299, 24399, 3075, 3076, 24407, 24584, 3098, 24601, 24599
10300, 2924, 24400, 24408, 2925, 24586, 24602, 24603, 2947
10301, 24400, 24401, 24409, 24408, 24588, 24604, 24605, 24602
10302, 24401, 24402, 24410, 24409, 24590, 24606, 24607, 24604
10303, 24402, 24403, 24411, 24410, 24592, 24608, 24609, 24606
10304, 24403, 24404, 24412, 24411, 24594, 24610, 24611, 24608
10305, 24404, 24405, 24413, 24412, 24596, 24612, 24613, 24610
10306, 24405, 24406, 24414, 24413, 24598, 24614, 24615, 24612
10307, 24406, 24407, 24415, 24414, 24600, 24616, 24617, 24614
10308, 24407, 3076, 3077, 24415, 24601, 3099, 24618, 24616
10309, 2925, 24408, 24416, 2926, 24603, 24619, 24620, 2948
