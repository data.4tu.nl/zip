3499, 7140, 679, 680, 7141, 7252, 702, 7253, 7217
3500, 7141, 680, 681, 7142, 7253, 703, 7254, 7219
3501, 7142, 681, 682, 7143, 7254, 704, 7255, 7221
3502, 7143, 682, 683, 7144, 7255, 705, 7256, 7223
3503, 7144, 683, 684, 7145, 7256, 706, 7257, 7225
3504, 7145, 684, 685, 7146, 7257, 707, 7258, 7227
3505, 7146, 685, 686, 7147, 7258, 708, 7259, 7229
3506, 7147, 686, 687, 7148, 7259, 709, 7260, 7231
3507, 7148, 687, 688, 7149, 7260, 710, 7261, 7233
3508, 7149, 688, 689, 7150, 7261, 711, 7262, 7235
3509, 7150, 689, 690, 7151, 7262, 712, 7263, 7237
3510, 7151, 690, 691, 7152, 7263, 713, 7264, 7239
3511, 7152, 691, 692, 7153, 7264, 714, 7265, 7241
3512, 7153, 692, 24, 577, 7265, 715, 580, 7243
*ELEMENT, type=CPS8, ELSET=Surface177
3513, 11, 626, 7266, 375, 648, 7310, 7311, 377
3514, 626, 627, 7267, 7266, 649, 7312, 7313, 7310
3515, 627, 628, 7268, 7267, 650, 7314, 7315, 7312
3516, 628, 629, 7269, 7268, 651, 7316, 7317, 7314
3517, 629, 630, 7270, 7269, 652, 7318, 7319, 7316
3518, 630, 631, 7271, 7270, 653, 7320, 7321, 7318
3519, 631, 632, 7272, 7271, 654, 7322, 7323, 7320
3520, 632, 633, 7273, 7272, 655, 7324, 7325, 7322
3521, 633, 634, 7274, 7273, 656, 7326, 7327, 7324
3522, 634, 635, 7275, 7274, 657, 7328, 7329, 7326
3523, 635, 636, 7276, 7275, 658, 7330, 7331, 7328
3524, 636, 637, 7277, 7276, 659, 7332, 7333, 7330
3525, 637, 638, 7278, 7277, 660, 7334, 7335, 7332
3526, 638, 639, 7279, 7278, 661, 7336, 7337, 7334
3527, 639, 640, 7280, 7279, 662, 7338, 7339, 7336
3528, 640, 641, 7281, 7280, 663, 7340, 7341, 7338
3529, 641, 642, 7282, 7281, 664, 7342, 7343, 7340
3530, 642, 643, 7283, 7282, 665, 7344, 7345, 7342
3531, 643, 644, 7284, 7283, 666, 7346, 7347, 7344
3532, 644, 645, 7285, 7284, 667, 7348, 7349, 7346
3533, 645, 646, 7286, 7285, 668, 7350, 7351, 7348
3534, 646, 647, 7287, 7286, 669, 7352, 7353, 7350
3535, 647, 21, 554, 7287, 670, 556, 7354, 7352
3536, 375, 7266, 7288, 376, 7311, 7355, 7356, 378
3537, 7266, 7267, 7289, 7288, 7313, 7357, 7358, 7355
3538, 7267, 7268, 7290, 7289, 7315, 7359, 7360, 7357
3539, 7268, 7269, 7291, 7290, 7317, 7361, 7362, 7359
3540, 7269, 7270, 7292, 7291, 7319, 7363, 7364, 7361
3541, 7270, 7271, 7293, 7292, 7321, 7365, 7366, 7363
3542, 7271, 7272, 7294, 7293, 7323, 7367, 7368, 7365
3543, 7272, 7273, 7295, 7294, 7325, 7369, 7370, 7367
3544, 7273, 7274, 7296, 7295, 7327, 7371, 7372, 7369
3545, 7274, 7275, 7297, 7296, 7329, 7373, 7374, 7371
3546, 7275, 7276, 7298, 7297, 7331, 7375, 7376, 7373
3547, 7276, 7277, 7299, 7298, 7333, 7377, 7378, 7375
3548, 7277, 7278, 7300, 7299, 7335, 7379, 7380, 7377
3549, 7278, 7279, 7301, 7300, 7337, 7381, 7382, 7379
3550, 7279, 7280, 7302, 7301, 7339, 7383, 7384, 7381
3551, 7280, 7281, 7303, 7302, 7341, 7385, 7386, 7383
3552, 7281, 7282, 7304, 7303, 7343, 7387, 7388, 7385
3553, 7282, 7283, 7305, 7304, 7345, 7389, 7390, 7387
3554, 7283, 7284, 7306, 7305, 7347, 7391, 7392, 7389
3555, 7284, 7285, 7307, 7306, 7349, 7393, 7394, 7391
3556, 7285, 7286, 7308, 7307, 7351, 7395, 7396, 7393
3557, 7286, 7287, 7309, 7308, 7353, 7397, 7398, 7395
3558, 7287, 554, 555, 7309, 7354, 557, 7399, 7397
3559, 376, 7288, 716, 9, 7356, 7400, 738, 379
3560, 7288, 7289, 717, 716, 7358, 7401, 739, 7400
3561, 7289, 7290, 718, 717, 7360, 7402, 740, 7401
3562, 7290, 7291, 719, 718, 7362, 7403, 741, 7402
3563, 7291, 7292, 720, 719, 7364, 7404, 742, 7403
3564, 7292, 7293, 721, 720, 7366, 7405, 743, 7404
3565, 7293, 7294, 722, 721, 7368, 7406, 744, 7405
3566, 7294, 7295, 723, 722, 7370, 7407, 745, 7406
3567, 7295, 7296, 724, 723, 7372, 7408, 746, 7407
3568, 7296, 7297, 725, 724, 7374, 7409, 747, 7408
3569, 7297, 7298, 726, 725, 7376, 7410, 748, 7409
3570, 7298, 7299, 727, 726, 7378, 7411, 749, 7410
3571, 7299, 7300, 728, 727, 7380, 7412, 750, 7411
3572, 7300, 7301, 729, 728, 7382, 7413, 751, 7412
3573, 7301, 7302, 730, 729, 7384, 7414, 752, 7413
3574, 7302, 7303, 731, 730, 7386, 7415, 753, 7414
3575, 7303, 7304, 732, 731, 7388, 7416, 754, 7415
3576, 7304, 7305, 733, 732, 7390, 7417, 755, 7416
3577, 7305, 7306, 734, 733, 7392, 7418, 756, 7417
3578, 7306, 7307, 735, 734, 7394, 7419, 757, 7418
3579, 7307, 7308, 736, 735, 7396, 7420, 758, 7419
3580, 7308, 7309, 737, 736, 7398, 7421, 759, 7420
3581, 7309, 555, 23, 737, 7399, 558, 760, 7421
*ELEMENT, type=CPS8, ELSET=Surface178
3582, 22, 761, 7422, 602, 764, 7488, 7489, 625
3583, 602, 7422, 7423, 601, 7489, 7490, 7491, 624
3584, 601, 7423, 7424, 600, 7491, 7492, 7493, 623
3585, 600, 7424, 7425, 599, 7493, 7494, 7495, 622
3586, 599, 7425, 7426, 598, 7495, 7496, 7497, 621
3587, 598, 7426, 7427, 597, 7497, 7498, 7499, 620
3588, 597, 7427, 7428, 596, 7499, 7500, 7501, 619
3589, 596, 7428, 7429, 595, 7501, 7502, 7503, 618
3590, 595, 7429, 7430, 594, 7503, 7504, 7505, 617
3591, 594, 7430, 7431, 593, 7505, 7506, 7507, 616
3592, 593, 7431, 7432, 592, 7507, 7508, 7509, 615
3593, 592, 7432, 7433, 591, 7509, 7510, 7511, 614
3594, 591, 7433, 7434, 590, 7511, 7512, 7513, 613
3595, 590, 7434, 7435, 589, 7513, 7514, 7515, 612
3596, 589, 7435, 7436, 588, 7515, 7516, 7517, 611
3597, 588, 7436, 7437, 587, 7517, 7518, 7519, 610
3598, 587, 7437, 7438, 586, 7519, 7520, 7521, 609
3599, 586, 7438, 7439, 585, 7521, 7522, 7523, 608
3600, 585, 7439, 7440, 584, 7523, 7524, 7525, 607
3601, 584, 7440, 7441, 583, 7525, 7526, 7527, 606
3602, 583, 7441, 7442, 582, 7527, 7528, 7529, 605
3603, 582, 7442, 7443, 581, 7529, 7530, 7531, 604
3604, 581, 7443, 486, 13, 7531, 7532, 489, 603
3605, 761, 762, 7444, 7422, 765, 7533, 7534, 7488
3606, 7422, 7444, 7445, 7423, 7534, 7535, 7536, 7490
3607, 7423, 7445, 7446, 7424, 7536, 7537, 7538, 7492
3608, 7424, 7446, 7447, 7425, 7538, 7539, 7540, 7494
3609, 7425, 7447, 7448, 7426, 7540, 7541, 7542, 7496
3610, 7426, 7448, 7449, 7427, 7542, 7543, 7544, 7498
3611, 7427, 7449, 7450, 7428, 7544, 7545, 7546, 7500
3612, 7428, 7450, 7451, 7429, 7546, 7547, 7548, 7502
3613, 7429, 7451, 7452, 7430, 7548, 7549, 7550, 7504
3614, 7430, 7452, 7453, 7431, 7550, 7551, 7552, 7506
3615, 7431, 7453, 7454, 7432, 7552, 7553, 7554, 7508
3616, 7432, 7454, 7455, 7433, 7554, 7555, 7556, 7510
3617, 7433, 7455, 7456, 7434, 7556, 7557, 7558, 7512
3618, 7434, 7456, 7457, 7435, 7558, 7559, 7560, 7514
3619, 7435, 7457, 7458, 7436, 7560, 7561, 7562, 7516
3620, 7436, 7458, 7459, 7437, 7562, 7563, 7564, 7518
3621, 7437, 7459, 7460, 7438, 7564, 7565, 7566, 7520
3622, 7438, 7460, 7461, 7439, 7566, 7567, 7568, 7522
3623, 7439, 7461, 7462, 7440, 7568, 7569, 7570, 7524
3624, 7440, 7462, 7463, 7441, 7570, 7571, 7572, 7526
3625, 7441, 7463, 7464, 7442, 7572, 7573, 7574, 7528
3626, 7442, 7464, 7465, 7443, 7574, 7575, 7576, 7530
3627, 7443, 7465, 487, 486, 7576, 7577, 490, 7532
3628, 762, 763, 7466, 7444, 766, 7578, 7579, 7533
3629, 7444, 7466, 7467, 7445, 7579, 7580, 7581, 7535
3630, 7445, 7467, 7468, 7446, 7581, 7582, 7583, 7537
3631, 7446, 7468, 7469, 7447, 7583, 7584, 7585, 7539
3632, 7447, 7469, 7470, 7448, 7585, 7586, 7587, 7541
3633, 7448, 7470, 7471, 7449, 7587, 7588, 7589, 7543
3634, 7449, 7471, 7472, 7450, 7589, 7590, 7591, 7545
3635, 7450, 7472, 7473, 7451, 7591, 7592, 7593, 7547
3636, 7451, 7473, 7474, 7452, 7593, 7594, 7595, 7549
3637, 7452, 7474, 7475, 7453, 7595, 7596, 7597, 7551
3638, 7453, 7475, 7476, 7454, 7597, 7598, 7599, 7553
3639, 7454, 7476, 7477, 7455, 7599, 7600, 7601, 7555
3640, 7455, 7477, 7478, 7456, 7601, 7602, 7603, 7557
3641, 7456, 7478, 7479, 7457, 7603, 7604, 7605, 7559
3642, 7457, 7479, 7480, 7458, 7605, 7606, 7607, 7561
3643, 7458, 7480, 7481, 7459, 7607, 7608, 7609, 7563
3644, 7459, 7481, 7482, 7460, 7609, 7610, 7611, 7565
3645, 7460, 7482, 7483, 7461, 7611, 7612, 7613, 7567
3646, 7461, 7483, 7484, 7462, 7613, 7614, 7615, 7569
3647, 7462, 7484, 7485, 7463, 7615, 7616, 7617, 7571
3648, 7463, 7485, 7486, 7464, 7617, 7618, 7619, 7573
3649, 7464, 7486, 7487, 7465, 7619, 7620, 7621, 7575
3650, 7465, 7487, 488, 487, 7621, 7622, 491, 7577
3651, 763, 25, 789, 7466, 767, 812, 7623, 7578
3652, 7466, 789, 788, 7467, 7623, 811, 7624, 7580
3653, 7467, 788, 787, 7468, 7624, 810, 7625, 7582
3654, 7468, 787, 786, 7469, 7625, 809, 7626, 7584
3655, 7469, 786, 785, 7470, 7626, 808, 7627, 7586
3656, 7470, 785, 784, 7471, 7627, 807, 7628, 7588
3657, 7471, 784, 783, 7472, 7628, 806, 7629, 7590
3658, 7472, 783, 782, 7473, 7629, 805, 7630, 7592
3659, 7473, 782, 781, 7474, 7630, 804, 7631, 7594
3660, 7474, 781, 780, 7475, 7631, 803, 7632, 7596
3661, 7475, 780, 779, 7476, 7632, 802, 7633, 7598
3662, 7476, 779, 778, 7477, 7633, 801, 7634, 7600
3663, 7477, 778, 777, 7478, 7634, 800, 7635, 7602
3664, 7478, 777, 776, 7479, 7635, 799, 7636, 7604
3665, 7479, 776, 775, 7480, 7636, 798, 7637, 7606
3666, 7480, 775, 774, 7481, 7637, 797, 7638, 7608
3667, 7481, 774, 773, 7482, 7638, 796, 7639, 7610
3668, 7482, 773, 772, 7483, 7639, 795, 7640, 7612
3669, 7483, 772, 771, 7484, 7640, 794, 7641, 7614
3670, 7484, 771, 770, 7485, 7641, 793, 7642, 7616
3671, 7485, 770, 769, 7486, 7642, 792, 7643, 7618
3672, 7486, 769, 768, 7487, 7643, 791, 7644, 7620
3673, 7487, 768, 19, 488, 7644, 790, 492, 7622
*ELEMENT, type=CPS8, ELSET=Surface179
3674, 21, 813, 7645, 544, 816, 7669, 7670, 553
3675, 544, 7645, 7646, 543, 7670, 7671, 7672, 552
3676, 543, 7646, 7647, 542, 7672, 7673, 7674, 551
3677, 542, 7647, 7648, 541, 7674, 7675, 7676, 550
3678, 541, 7648, 7649, 540, 7676, 7677, 7678, 549
3679, 540, 7649, 7650, 539, 7678, 7679, 7680, 548
3680, 539, 7650, 7651, 538, 7680, 7681, 7682, 547
3681, 538, 7651, 7652, 537, 7682, 7683, 7684, 546
3682, 537, 7652, 761, 22, 7684, 7685, 764, 545
3683, 813, 814, 7653, 7645, 817, 7686, 7687, 7669
3684, 7645, 7653, 7654, 7646, 7687, 7688, 7689, 7671
3685, 7646, 7654, 7655, 7647, 7689, 7690, 7691, 7673
3686, 7647, 7655, 7656, 7648, 7691, 7692, 7693, 7675
3687, 7648, 7656, 7657, 7649, 7693, 7694, 7695, 7677
3688, 7649, 7657, 7658, 7650, 7695, 7696, 7697, 7679
3689, 7650, 7658, 7659, 7651, 7697, 7698, 7699, 7681
3690, 7651, 7659, 7660, 7652, 7699, 7700, 7701, 7683
3691, 7652, 7660, 762, 761, 7701, 7702, 765, 7685
3692, 814, 815, 7661, 7653, 818, 7703, 7704, 7686
3693, 7653, 7661, 7662, 7654, 7704, 7705, 7706, 7688
3694, 7654, 7662, 7663, 7655, 7706, 7707, 7708, 7690
3695, 7655, 7663, 7664, 7656, 7708, 7709, 7710, 7692
3696, 7656, 7664, 7665, 7657, 7710, 7711, 7712, 7694
3697, 7657, 7665, 7666, 7658, 7712, 7713, 7714, 7696
3698, 7658, 7666, 7667, 7659, 7714, 7715, 7716, 7698
3699, 7659, 7667, 7668, 7660, 7716, 7717, 7718, 7700
3700, 7660, 7668, 763, 762, 7718, 7719, 766, 7702
3701, 815, 26, 827, 7661, 819, 836, 7720, 7703
3702, 7661, 827, 826, 7662, 7720, 835, 7721, 7705
3703, 7662, 826, 825, 7663, 7721, 834, 7722, 7707
3704, 7663, 825, 824, 7664, 7722, 833, 7723, 7709
3705, 7664, 824, 823, 7665, 7723, 832, 7724, 7711
3706, 7665, 823, 822, 7666, 7724, 831, 7725, 7713
3707, 7666, 822, 821, 7667, 7725, 830, 7726, 7715
3708, 7667, 821, 820, 7668, 7726, 829, 7727, 7717
3709, 7668, 820, 25, 763, 7727, 828, 767, 7719
*ELEMENT, type=CPS8, ELSET=Surface180
3710, 21, 647, 7728, 813, 670, 7794, 7795, 816
3711, 647, 646, 7729, 7728, 669, 7796, 7797, 7794
3712, 646, 645, 7730, 7729, 668, 7798, 7799, 7796
3713, 645, 644, 7731, 7730, 667, 7800, 7801, 7798
3714, 644, 643, 7732, 7731, 666, 7802, 7803, 7800
3715, 643, 642, 7733, 7732, 665, 7804, 7805, 7802
3716, 642, 641, 7734, 7733, 664, 7806, 7807, 7804
3717, 641, 640, 7735, 7734, 663, 7808, 7809, 7806
3718, 640, 639, 7736, 7735, 662, 7810, 7811, 7808
3719, 639, 638, 7737, 7736, 661, 7812, 7813, 7810
3720, 638, 637, 7738, 7737, 660, 7814, 7815, 7812
3721, 637, 636, 7739, 7738, 659, 7816, 7817, 7814
3722, 636, 635, 7740, 7739, 658, 7818, 7819, 7816
3723, 635, 634, 7741, 7740, 657, 7820, 7821, 7818
3724, 634, 633, 7742, 7741, 656, 7822, 7823, 7820
3725, 633, 632, 7743, 7742, 655, 7824, 7825, 7822
3726, 632, 631, 7744, 7743, 654, 7826, 7827, 7824
3727, 631, 630, 7745, 7744, 653, 7828, 7829, 7826
3728, 630, 629, 7746, 7745, 652, 7830, 7831, 7828
3729, 629, 628, 7747, 7746, 651, 7832, 7833, 7830
3730, 628, 627, 7748, 7747, 650, 7834, 7835, 7832
3731, 627, 626, 7749, 7748, 649, 7836, 7837, 7834
3732, 626, 11, 469, 7749, 648, 472, 7838, 7836
3733, 813, 7728, 7750, 814, 7795, 7839, 7840, 817
3734, 7728, 7729, 7751, 7750, 7797, 7841, 7842, 7839
3735, 7729, 7730, 7752, 7751, 7799, 7843, 7844, 7841
3736, 7730, 7731, 7753, 7752, 7801, 7845, 7846, 7843
3737, 7731, 7732, 7754, 7753, 7803, 7847, 7848, 7845
3738, 7732, 7733, 7755, 7754, 7805, 7849, 7850, 7847
3739, 7733, 7734, 7756, 7755, 7807, 7851, 7852, 7849
3740, 7734, 7735, 7757, 7756, 7809, 7853, 7854, 7851
3741, 7735, 7736, 7758, 7757, 7811, 7855, 7856, 7853
3742, 7736, 7737, 7759, 7758, 7813, 7857, 7858, 7855
3743, 7737, 7738, 7760, 7759, 7815, 7859, 7860, 7857
3744, 7738, 7739, 7761, 7760, 7817, 7861, 7862, 7859
3745, 7739, 7740, 7762, 7761, 7819, 7863, 7864, 7861
3746, 7740, 7741, 7763, 7762, 7821, 7865, 7866, 7863
3747, 7741, 7742, 7764, 7763, 7823, 7867, 7868, 7865
3748, 7742, 7743, 7765, 7764, 7825, 7869, 7870, 7867
3749, 7743, 7744, 7766, 7765, 7827, 7871, 7872, 7869
3750, 7744, 7745, 7767, 7766, 7829, 7873, 7874, 7871
3751, 7745, 7746, 7768, 7767, 7831, 7875, 7876, 7873
3752, 7746, 7747, 7769, 7768, 7833, 7877, 7878, 7875
3753, 7747, 7748, 7770, 7769, 7835, 7879, 7880, 7877
3754, 7748, 7749, 7771, 7770, 7837, 7881, 7882, 7879
3755, 7749, 469, 470, 7771, 7838, 473, 7883, 7881
3756, 814, 7750, 7772, 815, 7840, 7884, 7885, 818
3757, 7750, 7751, 7773, 7772, 7842, 7886, 7887, 7884
3758, 7751, 7752, 7774, 7773, 7844, 7888, 7889, 7886
3759, 7752, 7753, 7775, 7774, 7846, 7890, 7891, 7888
3760, 7753, 7754, 7776, 7775, 7848, 7892, 7893, 7890
3761, 7754, 7755, 7777, 7776, 7850, 7894, 7895, 7892
3762, 7755, 7756, 7778, 7777, 7852, 7896, 7897, 7894
3763, 7756, 7757, 7779, 7778, 7854, 7898, 7899, 7896
3764, 7757, 7758, 7780, 7779, 7856, 7900, 7901, 7898
3765, 7758, 7759, 7781, 7780, 7858, 7902, 7903, 7900
3766, 7759, 7760, 7782, 7781, 7860, 7904, 7905, 7902
3767, 7760, 7761, 7783, 7782, 7862, 7906, 7907, 7904
3768, 7761, 7762, 7784, 7783, 7864, 7908, 7909, 7906
3769, 7762, 7763, 7785, 7784, 7866, 7910, 7911, 7908
3770, 7763, 7764, 7786, 7785, 7868, 7912, 7913, 7910
3771, 7764, 7765, 7787, 7786, 7870, 7914, 7915, 7912
3772, 7765, 7766, 7788, 7787, 7872, 7916, 7917, 7914
3773, 7766, 7767, 7789, 7788, 7874, 7918, 7919, 7916
3774, 7767, 7768, 7790, 7789, 7876, 7920, 7921, 7918
3775, 7768, 7769, 7791, 7790, 7878, 7922, 7923, 7920
3776, 7769, 7770, 7792, 7791, 7880, 7924, 7925, 7922
3777, 7770, 7771, 7793, 7792, 7882, 7926, 7927, 7924
3778, 7771, 470, 471, 7793, 7883, 474, 7928, 7926
3779, 815, 7772, 858, 26, 7885, 7929, 881, 819
3780, 7772, 7773, 857, 858, 7887, 7930, 880, 7929
3781, 7773, 7774, 856, 857, 7889, 7931, 879, 7930
3782, 7774, 7775, 855, 856, 7891, 7932, 878, 7931
3783, 7775, 7776, 854, 855, 7893, 7933, 877, 7932
3784, 7776, 7777, 853, 854, 7895, 7934, 876, 7933
3785, 7777, 7778, 852, 853, 7897, 7935, 875, 7934
3786, 7778, 7779, 851, 852, 7899, 7936, 874, 7935
3787, 7779, 7780, 850, 851, 7901, 7937, 873, 7936
3788, 7780, 7781, 849, 850, 7903, 7938, 872, 7937
3789, 7781, 7782, 848, 849, 7905, 7939, 871, 7938
3790, 7782, 7783, 847, 848, 7907, 7940, 870, 7939
3791, 7783, 7784, 846, 847, 7909, 7941, 869, 7940
3792, 7784, 7785, 845, 846, 7911, 7942, 868, 7941
3793, 7785, 7786, 844, 845, 7913, 7943, 867, 7942
3794, 7786, 7787, 843, 844, 7915, 7944, 866, 7943
3795, 7787, 7788, 842, 843, 7917, 7945, 865, 7944
3796, 7788, 7789, 841, 842, 7919, 7946, 864, 7945
3797, 7789, 7790, 840, 841, 7921, 7947, 863, 7946
3798, 7790, 7791, 839, 840, 7923, 7948, 862, 7947
3799, 7791, 7792, 838, 839, 7925, 7949, 861, 7948
3800, 7792, 7793, 837, 838, 7927, 7950, 860, 7949
3801, 7793, 471, 17, 837, 7928, 475, 859, 7950
*ELEMENT, type=CPS8, ELSET=Surface181
3802, 19, 768, 7951, 503, 790, 8127, 8128, 511
3803, 503, 7951, 7952, 504, 8128, 8129, 8130, 512
3804, 504, 7952, 7953, 505, 8130, 8131, 8132, 513
3805, 505, 7953, 7954, 506, 8132, 8133, 8134, 514
3806, 506, 7954, 7955, 507, 8134, 8135, 8136, 515
3807, 507, 7955, 7956, 508, 8136, 8137, 8138, 516
3808, 508, 7956, 7957, 509, 8138, 8139, 8140, 517
3809, 509, 7957, 7958, 510, 8140, 8141, 8142, 518
3810, 510, 7958, 837, 17, 8142, 8143, 859, 519
3811, 768, 769, 7959, 7951, 791, 8144, 8145, 8127
3812, 7951, 7959, 7960, 7952, 8145, 8146, 8147, 8129
3813, 7952, 7960, 7961, 7953, 8147, 8148, 8149, 8131
3814, 7953, 7961, 7962, 7954, 8149, 8150, 8151, 8133
3815, 7954, 7962, 7963, 7955, 8151, 8152, 8153, 8135
3816, 7955, 7963, 7964, 7956, 8153, 8154, 8155, 8137
3817, 7956, 7964, 7965, 7957, 8155, 8156, 8157, 8139
3818, 7957, 7965, 7966, 7958, 8157, 8158, 8159, 8141
3819, 7958, 7966, 838, 837, 8159, 8160, 860, 8143
3820, 769, 770, 7967, 7959, 792, 8161, 8162, 8144
3821, 7959, 7967, 7968, 7960, 8162, 8163, 8164, 8146
3822, 7960, 7968, 7969, 7961, 8164, 8165, 8166, 8148
3823, 7961, 7969, 7970, 7962, 8166, 8167, 8168, 8150
3824, 7962, 7970, 7971, 7963, 8168, 8169, 8170, 8152
3825, 7963, 7971, 7972, 7964, 8170, 8171, 8172, 8154
3826, 7964, 7972, 7973, 7965, 8172, 8173, 8174, 8156
3827, 7965, 7973, 7974, 7966, 8174, 8175, 8176, 8158
3828, 7966, 7974, 839, 838, 8176, 8177, 861, 8160
3829, 770, 771, 7975, 7967, 793, 8178, 8179, 8161
3830, 7967, 7975, 7976, 7968, 8179, 8180, 8181, 8163
3831, 7968, 7976, 7977, 7969, 8181, 8182, 8183, 8165
3832, 7969, 7977, 7978, 7970, 8183, 8184, 8185, 8167
3833, 7970, 7978, 7979, 7971, 8185, 8186, 8187, 8169
3834, 7971, 7979, 7980, 7972, 8187, 8188, 8189, 8171
3835, 7972, 7980, 7981, 7973, 8189, 8190, 8191, 8173
3836, 7973, 7981, 7982, 7974, 8191, 8192, 8193, 8175
3837, 7974, 7982, 840, 839, 8193, 8194, 862, 8177
3838, 771, 772, 7983, 7975, 794, 8195, 8196, 8178
3839, 7975, 7983, 7984, 7976, 8196, 8197, 8198, 8180
3840, 7976, 7984, 7985, 7977, 8198, 8199, 8200, 8182
3841, 7977, 7985, 7986, 7978, 8200, 8201, 8202, 8184
3842, 7978, 7986, 7987, 7979, 8202, 8203, 8204, 8186
3843, 7979, 7987, 7988, 7980, 8204, 8205, 8206, 8188
3844, 7980, 7988, 7989, 7981, 8206, 8207, 8208, 8190
3845, 7981, 7989, 7990, 7982, 8208, 8209, 8210, 8192
3846, 7982, 7990, 841, 840, 8210, 8211, 863, 8194
3847, 772, 773, 7991, 7983, 795, 8212, 8213, 8195
3848, 7983, 7991, 7992, 7984, 8213, 8214, 8215, 8197
3849, 7984, 7992, 7993, 7985, 8215, 8216, 8217, 8199
3850, 7985, 7993, 7994, 7986, 8217, 8218, 8219, 8201
3851, 7986, 7994, 7995, 7987, 8219, 8220, 8221, 8203
3852, 7987, 7995, 7996, 7988, 8221, 8222, 8223, 8205
3853, 7988, 7996, 7997, 7989, 8223, 8224, 8225, 8207
3854, 7989, 7997, 7998, 7990, 8225, 8226, 8227, 8209
3855, 7990, 7998, 842, 841, 8227, 8228, 864, 8211
3856, 773, 774, 7999, 7991, 796, 8229, 8230, 8212
3857, 7991, 7999, 8000, 7992, 8230, 8231, 8232, 8214
3858, 7992, 8000, 8001, 7993, 8232, 8233, 8234, 8216
3859, 7993, 8001, 8002, 7994, 8234, 8235, 8236, 8218
3860, 7994, 8002, 8003, 7995, 8236, 8237, 8238, 8220
3861, 7995, 8003, 8004, 7996, 8238, 8239, 8240, 8222
3862, 7996, 8004, 8005, 7997, 8240, 8241, 8242, 8224
3863, 7997, 8005, 8006, 7998, 8242, 8243, 8244, 8226
3864, 7998, 8006, 843, 842, 8244, 8245, 865, 8228
3865, 774, 775, 8007, 7999, 797, 8246, 8247, 8229
3866, 7999, 8007, 8008, 8000, 8247, 8248, 8249, 8231
3867, 8000, 8008, 8009, 8001, 8249, 8250, 8251, 8233
3868, 8001, 8009, 8010, 8002, 8251, 8252, 8253, 8235
3869, 8002, 8010, 8011, 8003, 8253, 8254, 8255, 8237
3870, 8003, 8011, 8012, 8004, 8255, 8256, 8257, 8239
3871, 8004, 8012, 8013, 8005, 8257, 8258, 8259, 8241
3872, 8005, 8013, 8014, 8006, 8259, 8260, 8261, 8243
3873, 8006, 8014, 844, 843, 8261, 8262, 866, 8245
3874, 775, 776, 8015, 8007, 798, 8263, 8264, 8246
3875, 8007, 8015, 8016, 8008, 8264, 8265, 8266, 8248
3876, 8008, 8016, 8017, 8009, 8266, 8267, 8268, 8250
3877, 8009, 8017, 8018, 8010, 8268, 8269, 8270, 8252
3878, 8010, 8018, 8019, 8011, 8270, 8271, 8272, 8254
3879, 8011, 8019, 8020, 8012, 8272, 8273, 8274, 8256
3880, 8012, 8020, 8021, 8013, 8274, 8275, 8276, 8258
3881, 8013, 8021, 8022, 8014, 8276, 8277, 8278, 8260
3882, 8014, 8022, 845, 844, 8278, 8279, 867, 8262
3883, 776, 777, 8023, 8015, 799, 8280, 8281, 8263
3884, 8015, 8023, 8024, 8016, 8281, 8282, 8283, 8265
3885, 8016, 8024, 8025, 8017, 8283, 8284, 8285, 8267
3886, 8017, 8025, 8026, 8018, 8285, 8286, 8287, 8269
3887, 8018, 8026, 8027, 8019, 8287, 8288, 8289, 8271
3888, 8019, 8027, 8028, 8020, 8289, 8290, 8291, 8273
3889, 8020, 8028, 8029, 8021, 8291, 8292, 8293, 8275
3890, 8021, 8029, 8030, 8022, 8293, 8294, 8295, 8277
3891, 8022, 8030, 846, 845, 8295, 8296, 868, 8279
3892, 777, 778, 8031, 8023, 800, 8297, 8298, 8280
3893, 8023, 8031, 8032, 8024, 8298, 8299, 8300, 8282
3894, 8024, 8032, 8033, 8025, 8300, 8301, 8302, 8284
3895, 8025, 8033, 8034, 8026, 8302, 8303, 8304, 8286
3896, 8026, 8034, 8035, 8027, 8304, 8305, 8306, 8288
3897, 8027, 8035, 8036, 8028, 8306, 8307, 8308, 8290
3898, 8028, 8036, 8037, 8029, 8308, 8309, 8310, 8292
3899, 8029, 8037, 8038, 8030, 8310, 8311, 8312, 8294
3900, 8030, 8038, 847, 846, 8312, 8313, 869, 8296
3901, 778, 779, 8039, 8031, 801, 8314, 8315, 8297
3902, 8031, 8039, 8040, 8032, 8315, 8316, 8317, 8299
3903, 8032, 8040, 8041, 8033, 8317, 8318, 8319, 8301
3904, 8033, 8041, 8042, 8034, 8319, 8320, 8321, 8303
3905, 8034, 8042, 8043, 8035, 8321, 8322, 8323, 8305
3906, 8035, 8043, 8044, 8036, 8323, 8324, 8325, 8307
3907, 8036, 8044, 8045, 8037, 8325, 8326, 8327, 8309
3908, 8037, 8045, 8046, 8038, 8327, 8328, 8329, 8311
3909, 8038, 8046, 848, 847, 8329, 8330, 870, 8313
3910, 779, 780, 8047, 8039, 802, 8331, 8332, 8314
3911, 8039, 8047, 8048, 8040, 8332, 8333, 8334, 8316
3912, 8040, 8048, 8049, 8041, 8334, 8335, 8336, 8318
3913, 8041, 8049, 8050, 8042, 8336, 8337, 8338, 8320
3914, 8042, 8050, 8051, 8043, 8338, 8339, 8340, 8322
3915, 8043, 8051, 8052, 8044, 8340, 8341, 8342, 8324
3916, 8044, 8052, 8053, 8045, 8342, 8343, 8344, 8326
3917, 8045, 8053, 8054, 8046, 8344, 8345, 8346, 8328
3918, 8046, 8054, 849, 848, 8346, 8347, 871, 8330
3919, 780, 781, 8055, 8047, 803, 8348, 8349, 8331
3920, 8047, 8055, 8056, 8048, 8349, 8350, 8351, 8333
3921, 8048, 8056, 8057, 8049, 8351, 8352, 8353, 8335
3922, 8049, 8057, 8058, 8050, 8353, 8354, 8355, 8337
3923, 8050, 8058, 8059, 8051, 8355, 8356, 8357, 8339
3924, 8051, 8059, 8060, 8052, 8357, 8358, 8359, 8341
3925, 8052, 8060, 8061, 8053, 8359, 8360, 8361, 8343
3926, 8053, 8061, 8062, 8054, 8361, 8362, 8363, 8345
3927, 8054, 8062, 850, 849, 8363, 8364, 872, 8347
3928, 781, 782, 8063, 8055, 804, 8365, 8366, 8348
3929, 8055, 8063, 8064, 8056, 8366, 8367, 8368, 8350
3930, 8056, 8064, 8065, 8057, 8368, 8369, 8370, 8352
3931, 8057, 8065, 8066, 8058, 8370, 8371, 8372, 8354
3932, 8058, 8066, 8067, 8059, 8372, 8373, 8374, 8356
3933, 8059, 8067, 8068, 8060, 8374, 8375, 8376, 8358
3934, 8060, 8068, 8069, 8061, 8376, 8377, 8378, 8360
3935, 8061, 8069, 8070, 8062, 8378, 8379, 8380, 8362
3936, 8062, 8070, 851, 850, 8380, 8381, 873, 8364
3937, 782, 783, 8071, 8063, 805, 8382, 8383, 8365
3938, 8063, 8071, 8072, 8064, 8383, 8384, 8385, 8367
3939, 8064, 8072, 8073, 8065, 8385, 8386, 8387, 8369
3940, 8065, 8073, 8074, 8066, 8387, 8388, 8389, 8371
3941, 8066, 8074, 8075, 8067, 8389, 8390, 8391, 8373
3942, 8067, 8075, 8076, 8068, 8391, 8392, 8393, 8375
3943, 8068, 8076, 8077, 8069, 8393, 8394, 8395, 8377
3944, 8069, 8077, 8078, 8070, 8395, 8396, 8397, 8379
3945, 8070, 8078, 852, 851, 8397, 8398, 874, 8381
3946, 783, 784, 8079, 8071, 806, 8399, 8400, 8382
3947, 8071, 8079, 8080, 8072, 8400, 8401, 8402, 8384
3948, 8072, 8080, 8081, 8073, 8402, 8403, 8404, 8386
3949, 8073, 8081, 8082, 8074, 8404, 8405, 8406, 8388
3950, 8074, 8082, 8083, 8075, 8406, 8407, 8408, 8390
3951, 8075, 8083, 8084, 8076, 8408, 8409, 8410, 8392
3952, 8076, 8084, 8085, 8077, 8410, 8411, 8412, 8394
3953, 8077, 8085, 8086, 8078, 8412, 8413, 8414, 8396
3954, 8078, 8086, 853, 852, 8414, 8415, 875, 8398
3955, 784, 785, 8087, 8079, 807, 8416, 8417, 8399
3956, 8079, 8087, 8088, 8080, 8417, 8418, 8419, 8401
3957, 8080, 8088, 8089, 8081, 8419, 8420, 8421, 8403
3958, 8081, 8089, 8090, 8082, 8421, 8422, 8423, 8405
3959, 8082, 8090, 8091, 8083, 8423, 8424, 8425, 8407
3960, 8083, 8091, 8092, 8084, 8425, 8426, 8427, 8409
3961, 8084, 8092, 8093, 8085, 8427, 8428, 8429, 8411
3962, 8085, 8093, 8094, 8086, 8429, 8430, 8431, 8413
3963, 8086, 8094, 854, 853, 8431, 8432, 876, 8415
3964, 785, 786, 8095, 8087, 808, 8433, 8434, 8416
3965, 8087, 8095, 8096, 8088, 8434, 8435, 8436, 8418
3966, 8088, 8096, 8097, 8089, 8436, 8437, 8438, 8420
3967, 8089, 8097, 8098, 8090, 8438, 8439, 8440, 8422
3968, 8090, 8098, 8099, 8091, 8440, 8441, 8442, 8424
3969, 8091, 8099, 8100, 8092, 8442, 8443, 8444, 8426
3970, 8092, 8100, 8101, 8093, 8444, 8445, 8446, 8428
3971, 8093, 8101, 8102, 8094, 8446, 8447, 8448, 8430
3972, 8094, 8102, 855, 854, 8448, 8449, 877, 8432
3973, 786, 787, 8103, 8095, 809, 8450, 8451, 8433
3974, 8095, 8103, 8104, 8096, 8451, 8452, 8453, 8435
3975, 8096, 8104, 8105, 8097, 8453, 8454, 8455, 8437
3976, 8097, 8105, 8106, 8098, 8455, 8456, 8457, 8439
3977, 8098, 8106, 8107, 8099, 8457, 8458, 8459, 8441
3978, 8099, 8107, 8108, 8100, 8459, 8460, 8461, 8443
3979, 8100, 8108, 8109, 8101, 8461, 8462, 8463, 8445
3980, 8101, 8109, 8110, 8102, 8463, 8464, 8465, 8447
3981, 8102, 8110, 856, 855, 8465, 8466, 878, 8449
3982, 787, 788, 8111, 8103, 810, 8467, 8468, 8450
3983, 8103, 8111, 8112, 8104, 8468, 8469, 8470, 8452
3984, 8104, 8112, 8113, 8105, 8470, 8471, 8472, 8454
3985, 8105, 8113, 8114, 8106, 8472, 8473, 8474, 8456
3986, 8106, 8114, 8115, 8107, 8474, 8475, 8476, 8458
3987, 8107, 8115, 8116, 8108, 8476, 8477, 8478, 8460
3988, 8108, 8116, 8117, 8109, 8478, 8479, 8480, 8462
3989, 8109, 8117, 8118, 8110, 8480, 8481, 8482, 8464
3990, 8110, 8118, 857, 856, 8482, 8483, 879, 8466
3991, 788, 789, 8119, 8111, 811, 8484, 8485, 8467
3992, 8111, 8119, 8120, 8112, 8485, 8486, 8487, 8469
3993, 8112, 8120, 8121, 8113, 8487, 8488, 8489, 8471
3994, 8113, 8121, 8122, 8114, 8489, 8490, 8491, 8473
3995, 8114, 8122, 8123, 8115, 8491, 8492, 8493, 8475
3996, 8115, 8123, 8124, 8116, 8493, 8494, 8495, 8477
3997, 8116, 8124, 8125, 8117, 8495, 8496, 8497, 8479
3998, 8117, 8125, 8126, 8118, 8497, 8498, 8499, 8481
3999, 8118, 8126, 858, 857, 8499, 8500, 880, 8483
4000, 789, 25, 820, 8119, 812, 828, 8501, 8484
4001, 8119, 820, 821, 8120, 8501, 829, 8502, 8486
4002, 8120, 821, 822, 8121, 8502, 830, 8503, 8488
4003, 8121, 822, 823, 8122, 8503, 831, 8504, 8490
4004, 8122, 823, 824, 8123, 8504, 832, 8505, 8492
4005, 8123, 824, 825, 8124, 8505, 833, 8506, 8494
4006, 8124, 825, 826, 8125, 8506, 834, 8507, 8496
4007, 8125, 826, 827, 8126, 8507, 835, 8508, 8498
4008, 8126, 827, 26, 858, 8508, 836, 881, 8500
*ELEMENT, type=CPS8, ELSET=Surface182
4009, 21, 813, 8509, 882, 816, 8518, 8519, 885
4010, 813, 814, 8510, 8509, 817, 8520, 8521, 8518
4011, 814, 815, 8511, 8510, 818, 8522, 8523, 8520
4012, 815, 26, 889, 8511, 819, 892, 8524, 8522
4013, 882, 8509, 8512, 883, 8519, 8525, 8526, 886
4014, 8509, 8510, 8513, 8512, 8521, 8527, 8528, 8525
4015, 8510, 8511, 8514, 8513, 8523, 8529, 8530, 8527
4016, 8511, 889, 890, 8514, 8524, 893, 8531, 8529
4017, 883, 8512, 8515, 884, 8526, 8532, 8533, 887
4018, 8512, 8513, 8516, 8515, 8528, 8534, 8535, 8532
4019, 8513, 8514, 8517, 8516, 8530, 8536, 8537, 8534
4020, 8514, 890, 891, 8517, 8531, 894, 8538, 8536
4021, 884, 8515, 896, 27, 8533, 8539, 899, 888
4022, 8515, 8516, 897, 896, 8535, 8540, 900, 8539
4023, 8516, 8517, 898, 897, 8537, 8541, 901, 8540
4024, 8517, 891, 28, 898, 8538, 895, 902, 8541
*ELEMENT, type=CPS8, ELSET=Surface183
4025, 22, 903, 8542, 761, 906, 8551, 8552, 764
4026, 761, 8542, 8543, 762, 8552, 8553, 8554, 765
4027, 762, 8543, 8544, 763, 8554, 8555, 8556, 766
4028, 763, 8544, 910, 25, 8556, 8557, 913, 767
4029, 903, 904, 8545, 8542, 907, 8558, 8559, 8551
4030, 8542, 8545, 8546, 8543, 8559, 8560, 8561, 8553
4031, 8543, 8546, 8547, 8544, 8561, 8562, 8563, 8555
4032, 8544, 8547, 911, 910, 8563, 8564, 914, 8557
4033, 904, 905, 8548, 8545, 908, 8565, 8566, 8558
4034, 8545, 8548, 8549, 8546, 8566, 8567, 8568, 8560
4035, 8546, 8549, 8550, 8547, 8568, 8569, 8570, 8562
4036, 8547, 8550, 912, 911, 8570, 8571, 915, 8564
4037, 905, 29, 917, 8548, 909, 920, 8572, 8565
4038, 8548, 917, 918, 8549, 8572, 921, 8573, 8567
4039, 8549, 918, 919, 8550, 8573, 922, 8574, 8569
4040, 8550, 919, 30, 912, 8574, 923, 916, 8571
*ELEMENT, type=CPS8, ELSET=Surface184
4041, 21, 882, 8575, 544, 885, 8599, 8600, 553
4042, 544, 8575, 8576, 543, 8600, 8601, 8602, 552
4043, 543, 8576, 8577, 542, 8602, 8603, 8604, 551
4044, 542, 8577, 8578, 541, 8604, 8605, 8606, 550
4045, 541, 8578, 8579, 540, 8606, 8607, 8608, 549
4046, 540, 8579, 8580, 539, 8608, 8609, 8610, 548
4047, 539, 8580, 8581, 538, 8610, 8611, 8612, 547
4048, 538, 8581, 8582, 537, 8612, 8613, 8614, 546
4049, 537, 8582, 903, 22, 8614, 8615, 906, 545
4050, 882, 883, 8583, 8575, 886, 8616, 8617, 8599
4051, 8575, 8583, 8584, 8576, 8617, 8618, 8619, 8601
4052, 8576, 8584, 8585, 8577, 8619, 8620, 8621, 8603
4053, 8577, 8585, 8586, 8578, 8621, 8622, 8623, 8605
4054, 8578, 8586, 8587, 8579, 8623, 8624, 8625, 8607
4055, 8579, 8587, 8588, 8580, 8625, 8626, 8627, 8609
4056, 8580, 8588, 8589, 8581, 8627, 8628, 8629, 8611
4057, 8581, 8589, 8590, 8582, 8629, 8630, 8631, 8613
4058, 8582, 8590, 904, 903, 8631, 8632, 907, 8615
4059, 883, 884, 8591, 8583, 887, 8633, 8634, 8616
4060, 8583, 8591, 8592, 8584, 8634, 8635, 8636, 8618
4061, 8584, 8592, 8593, 8585, 8636, 8637, 8638, 8620
4062, 8585, 8593, 8594, 8586, 8638, 8639, 8640, 8622
4063, 8586, 8594, 8595, 8587, 8640, 8641, 8642, 8624
4064, 8587, 8595, 8596, 8588, 8642, 8643, 8644, 8626
4065, 8588, 8596, 8597, 8589, 8644, 8645, 8646, 8628
4066, 8589, 8597, 8598, 8590, 8646, 8647, 8648, 8630
4067, 8590, 8598, 905, 904, 8648, 8649, 908, 8632
4068, 884, 27, 931, 8591, 888, 940, 8650, 8633
4069, 8591, 931, 930, 8592, 8650, 939, 8651, 8635
4070, 8592, 930, 929, 8593, 8651, 938, 8652, 8637
4071, 8593, 929, 928, 8594, 8652, 937, 8653, 8639
4072, 8594, 928, 927, 8595, 8653, 936, 8654, 8641
4073, 8595, 927, 926, 8596, 8654, 935, 8655, 8643
4074, 8596, 926, 925, 8597, 8655, 934, 8656, 8645
4075, 8597, 925, 924, 8598, 8656, 933, 8657, 8647
4076, 8598, 924, 29, 905, 8657, 932, 909, 8649
*ELEMENT, type=CPS8, ELSET=Surface185
4077, 26, 827, 8658, 889, 836, 8682, 8683, 892
4078, 827, 826, 8659, 8658, 835, 8684, 8685, 8682
4079, 826, 825, 8660, 8659, 834, 8686, 8687, 8684
4080, 825, 824, 8661, 8660, 833, 8688, 8689, 8686
4081, 824, 823, 8662, 8661, 832, 8690, 8691, 8688
4082, 823, 822, 8663, 8662, 831, 8692, 8693, 8690
4083, 822, 821, 8664, 8663, 830, 8694, 8695, 8692
4084, 821, 820, 8665, 8664, 829, 8696, 8697, 8694
4085, 820, 25, 910, 8665, 828, 913, 8698, 8696
4086, 889, 8658, 8666, 890, 8683, 8699, 8700, 893
4087, 8658, 8659, 8667, 8666, 8685, 8701, 8702, 8699
4088, 8659, 8660, 8668, 8667, 8687, 8703, 8704, 8701
4089, 8660, 8661, 8669, 8668, 8689, 8705, 8706, 8703
4090, 8661, 8662, 8670, 8669, 8691, 8707, 8708, 8705
4091, 8662, 8663, 8671, 8670, 8693, 8709, 8710, 8707
4092, 8663, 8664, 8672, 8671, 8695, 8711, 8712, 8709
4093, 8664, 8665, 8673, 8672, 8697, 8713, 8714, 8711
4094, 8665, 910, 911, 8673, 8698, 914, 8715, 8713
4095, 890, 8666, 8674, 891, 8700, 8716, 8717, 894
4096, 8666, 8667, 8675, 8674, 8702, 8718, 8719, 8716
4097, 8667, 8668, 8676, 8675, 8704, 8720, 8721, 8718
4098, 8668, 8669, 8677, 8676, 8706, 8722, 8723, 8720
4099, 8669, 8670, 8678, 8677, 8708, 8724, 8725, 8722
4100, 8670, 8671, 8679, 8678, 8710, 8726, 8727, 8724
4101, 8671, 8672, 8680, 8679, 8712, 8728, 8729, 8726
4102, 8672, 8673, 8681, 8680, 8714, 8730, 8731, 8728
4103, 8673, 911, 912, 8681, 8715, 915, 8732, 8730
4104, 891, 8674, 948, 28, 8717, 8733, 957, 895
4105, 8674, 8675, 947, 948, 8719, 8734, 956, 8733
4106, 8675, 8676, 946, 947, 8721, 8735, 955, 8734
4107, 8676, 8677, 945, 946, 8723, 8736, 954, 8735
4108, 8677, 8678, 944, 945, 8725, 8737, 953, 8736
4109, 8678, 8679, 943, 944, 8727, 8738, 952, 8737
4110, 8679, 8680, 942, 943, 8729, 8739, 951, 8738
4111, 8680, 8681, 941, 942, 8731, 8740, 950, 8739
4112, 8681, 912, 30, 941, 8732, 916, 949, 8740
*ELEMENT, type=CPS8, ELSET=Surface186
4113, 27, 896, 8741, 931, 899, 8765, 8766, 940
4114, 931, 8741, 8742, 930, 8766, 8767, 8768, 939
4115, 930, 8742, 8743, 929, 8768, 8769, 8770, 938
4116, 929, 8743, 8744, 928, 8770, 8771, 8772, 937
4117, 928, 8744, 8745, 927, 8772, 8773, 8774, 936
4118, 927, 8745, 8746, 926, 8774, 8775, 8776, 935
4119, 926, 8746, 8747, 925, 8776, 8777, 8778, 934
4120, 925, 8747, 8748, 924, 8778, 8779, 8780, 933
4121, 924, 8748, 917, 29, 8780, 8781, 920, 932
4122, 896, 897, 8749, 8741, 900, 8782, 8783, 8765
4123, 8741, 8749, 8750, 8742, 8783, 8784, 8785, 8767
4124, 8742, 8750, 8751, 8743, 8785, 8786, 8787, 8769
4125, 8743, 8751, 8752, 8744, 8787, 8788, 8789, 8771
4126, 8744, 8752, 8753, 8745, 8789, 8790, 8791, 8773
4127, 8745, 8753, 8754, 8746, 8791, 8792, 8793, 8775
4128, 8746, 8754, 8755, 8747, 8793, 8794, 8795, 8777
4129, 8747, 8755, 8756, 8748, 8795, 8796, 8797, 8779
4130, 8748, 8756, 918, 917, 8797, 8798, 921, 8781
4131, 897, 898, 8757, 8749, 901, 8799, 8800, 8782
4132, 8749, 8757, 8758, 8750, 8800, 8801, 8802, 8784
4133, 8750, 8758, 8759, 8751, 8802, 8803, 8804, 8786
4134, 8751, 8759, 8760, 8752, 8804, 8805, 8806, 8788
4135, 8752, 8760, 8761, 8753, 8806, 8807, 8808, 8790
4136, 8753, 8761, 8762, 8754, 8808, 8809, 8810, 8792
4137, 8754, 8762, 8763, 8755, 8810, 8811, 8812, 8794
4138, 8755, 8763, 8764, 8756, 8812, 8813, 8814, 8796
4139, 8756, 8764, 919, 918, 8814, 8815, 922, 8798
4140, 898, 28, 948, 8757, 902, 957, 8816, 8799
4141, 8757, 948, 947, 8758, 8816, 956, 8817, 8801
4142, 8758, 947, 946, 8759, 8817, 955, 8818, 8803
4143, 8759, 946, 945, 8760, 8818, 954, 8819, 8805
4144, 8760, 945, 944, 8761, 8819, 953, 8820, 8807
4145, 8761, 944, 943, 8762, 8820, 952, 8821, 8809
4146, 8762, 943, 942, 8763, 8821, 951, 8822, 8811
4147, 8763, 942, 941, 8764, 8822, 950, 8823, 8813
4148, 8764, 941, 30, 919, 8823, 949, 923, 8815
*ELEMENT, type=CPS8, ELSET=Surface187
4149, 27, 896, 8824, 965, 899, 8890, 8891, 987
4150, 965, 8824, 8825, 966, 8891, 8892, 8893, 988
4151, 966, 8825, 8826, 967, 8893, 8894, 8895, 989
4152, 967, 8826, 8827, 968, 8895, 8896, 8897, 990
4153, 968, 8827, 8828, 969, 8897, 8898, 8899, 991
4154, 969, 8828, 8829, 970, 8899, 8900, 8901, 992
4155, 970, 8829, 8830, 971, 8901, 8902, 8903, 993
4156, 971, 8830, 8831, 972, 8903, 8904, 8905, 994
4157, 972, 8831, 8832, 973, 8905, 8906, 8907, 995
4158, 973, 8832, 8833, 974, 8907, 8908, 8909, 996
4159, 974, 8833, 8834, 975, 8909, 8910, 8911, 997
4160, 975, 8834, 8835, 976, 8911, 8912, 8913, 998
4161, 976, 8835, 8836, 977, 8913, 8914, 8915, 999
4162, 977, 8836, 8837, 978, 8915, 8916, 8917, 1000
4163, 978, 8837, 8838, 979, 8917, 8918, 8919, 1001
4164, 979, 8838, 8839, 980, 8919, 8920, 8921, 1002
4165, 980, 8839, 8840, 981, 8921, 8922, 8923, 1003
4166, 981, 8840, 8841, 982, 8923, 8924, 8925, 1004
4167, 982, 8841, 8842, 983, 8925, 8926, 8927, 1005
4168, 983, 8842, 8843, 984, 8927, 8928, 8929, 1006
4169, 984, 8843, 8844, 985, 8929, 8930, 8931, 1007
4170, 985, 8844, 8845, 986, 8931, 8932, 8933, 1008
4171, 986, 8845, 958, 31, 8933, 8934, 961, 1009
4172, 896, 897, 8846, 8824, 900, 8935, 8936, 8890
4173, 8824, 8846, 8847, 8825, 8936, 8937, 8938, 8892
4174, 8825, 8847, 8848, 8826, 8938, 8939, 8940, 8894
4175, 8826, 8848, 8849, 8827, 8940, 8941, 8942, 8896
4176, 8827, 8849, 8850, 8828, 8942, 8943, 8944, 8898
4177, 8828, 8850, 8851, 8829, 8944, 8945, 8946, 8900
4178, 8829, 8851, 8852, 8830, 8946, 8947, 8948, 8902
4179, 8830, 8852, 8853, 8831, 8948, 8949, 8950, 8904
4180, 8831, 8853, 8854, 8832, 8950, 8951, 8952, 8906
4181, 8832, 8854, 8855, 8833, 8952, 8953, 8954, 8908
4182, 8833, 8855, 8856, 8834, 8954, 8955, 8956, 8910
4183, 8834, 8856, 8857, 8835, 8956, 8957, 8958, 8912
4184, 8835, 8857, 8858, 8836, 8958, 8959, 8960, 8914
4185, 8836, 8858, 8859, 8837, 8960, 8961, 8962, 8916
4186, 8837, 8859, 8860, 8838, 8962, 8963, 8964, 8918
4187, 8838, 8860, 8861, 8839, 8964, 8965, 8966, 8920
4188, 8839, 8861, 8862, 8840, 8966, 8967, 8968, 8922
4189, 8840, 8862, 8863, 8841, 8968, 8969, 8970, 8924
4190, 8841, 8863, 8864, 8842, 8970, 8971, 8972, 8926
4191, 8842, 8864, 8865, 8843, 8972, 8973, 8974, 8928
4192, 8843, 8865, 8866, 8844, 8974, 8975, 8976, 8930
4193, 8844, 8866, 8867, 8845, 8976, 8977, 8978, 8932
4194, 8845, 8867, 959, 958, 8978, 8979, 962, 8934
4195, 897, 898, 8868, 8846, 901, 8980, 8981, 8935
4196, 8846, 8868, 8869, 8847, 8981, 8982, 8983, 8937
4197, 8847, 8869, 8870, 8848, 8983, 8984, 8985, 8939
4198, 8848, 8870, 8871, 8849, 8985, 8986, 8987, 8941
4199, 8849, 8871, 8872, 8850, 8987, 8988, 8989, 8943
4200, 8850, 8872, 8873, 8851, 8989, 8990, 8991, 8945
4201, 8851, 8873, 8874, 8852, 8991, 8992, 8993, 8947
4202, 8852, 8874, 8875, 8853, 8993, 8994, 8995, 8949
4203, 8853, 8875, 8876, 8854, 8995, 8996, 8997, 8951
4204, 8854, 8876, 8877, 8855, 8997, 8998, 8999, 8953
4205, 8855, 8877, 8878, 8856, 8999, 9000, 9001, 8955
4206, 8856, 8878, 8879, 8857, 9001, 9002, 9003, 8957
4207, 8857, 8879, 8880, 8858, 9003, 9004, 9005, 8959
4208, 8858, 8880, 8881, 8859, 9005, 9006, 9007, 8961
4209, 8859, 8881, 8882, 8860, 9007, 9008, 9009, 8963
4210, 8860, 8882, 8883, 8861, 9009, 9010, 9011, 8965
4211, 8861, 8883, 8884, 8862, 9011, 9012, 9013, 8967
4212, 8862, 8884, 8885, 8863, 9013, 9014, 9015, 8969
4213, 8863, 8885, 8886, 8864, 9015, 9016, 9017, 8971
4214, 8864, 8886, 8887, 8865, 9017, 9018, 9019, 8973
4215, 8865, 8887, 8888, 8866, 9019, 9020, 9021, 8975
4216, 8866, 8888, 8889, 8867, 9021, 9022, 9023, 8977
4217, 8867, 8889, 960, 959, 9023, 9024, 963, 8979
4218, 898, 28, 1010, 8868, 902, 1032, 9025, 8980
4219, 8868, 1010, 1011, 8869, 9025, 1033, 9026, 8982
4220, 8869, 1011, 1012, 8870, 9026, 1034, 9027, 8984
4221, 8870, 1012, 1013, 8871, 9027, 1035, 9028, 8986
4222, 8871, 1013, 1014, 8872, 9028, 1036, 9029, 8988
4223, 8872, 1014, 1015, 8873, 9029, 1037, 9030, 8990
4224, 8873, 1015, 1016, 8874, 9030, 1038, 9031, 8992
4225, 8874, 1016, 1017, 8875, 9031, 1039, 9032, 8994
4226, 8875, 1017, 1018, 8876, 9032, 1040, 9033, 8996
4227, 8876, 1018, 1019, 8877, 9033, 1041, 9034, 8998
4228, 8877, 1019, 1020, 8878, 9034, 1042, 9035, 9000
4229, 8878, 1020, 1021, 8879, 9035, 1043, 9036, 9002
4230, 8879, 1021, 1022, 8880, 9036, 1044, 9037, 9004
4231, 8880, 1022, 1023, 8881, 9037, 1045, 9038, 9006
4232, 8881, 1023, 1024, 8882, 9038, 1046, 9039, 9008
4233, 8882, 1024, 1025, 8883, 9039, 1047, 9040, 9010
4234, 8883, 1025, 1026, 8884, 9040, 1048, 9041, 9012
4235, 8884, 1026, 1027, 8885, 9041, 1049, 9042, 9014
4236, 8885, 1027, 1028, 8886, 9042, 1050, 9043, 9016
4237, 8886, 1028, 1029, 8887, 9043, 1051, 9044, 9018
4238, 8887, 1029, 1030, 8888, 9044, 1052, 9045, 9020
4239, 8888, 1030, 1031, 8889, 9045, 1053, 9046, 9022
4240, 8889, 1031, 32, 960, 9046, 1054, 964, 9024
*ELEMENT, type=CPS8, ELSET=Surface188
4241, 29, 1062, 9047, 917, 1084, 9113, 9114, 920
4242, 1062, 1063, 9048, 9047, 1085, 9115, 9116, 9113
4243, 1063, 1064, 9049, 9048, 1086, 9117, 9118, 9115
4244, 1064, 1065, 9050, 9049, 1087, 9119, 9120, 9117
4245, 1065, 1066, 9051, 9050, 1088, 9121, 9122, 9119
4246, 1066, 1067, 9052, 9051, 1089, 9123, 9124, 9121
4247, 1067, 1068, 9053, 9052, 1090, 9125, 9126, 9123
4248, 1068, 1069, 9054, 9053, 1091, 9127, 9128, 9125
4249, 1069, 1070, 9055, 9054, 1092, 9129, 9130, 9127
4250, 1070, 1071, 9056, 9055, 1093, 9131, 9132, 9129
4251, 1071, 1072, 9057, 9056, 1094, 9133, 9134, 9131
4252, 1072, 1073, 9058, 9057, 1095, 9135, 9136, 9133
4253, 1073, 1074, 9059, 9058, 1096, 9137, 9138, 9135
4254, 1074, 1075, 9060, 9059, 1097, 9139, 9140, 9137
4255, 1075, 1076, 9061, 9060, 1098, 9141, 9142, 9139
4256, 1076, 1077, 9062, 9061, 1099, 9143, 9144, 9141
4257, 1077, 1078, 9063, 9062, 1100, 9145, 9146, 9143
4258, 1078, 1079, 9064, 9063, 1101, 9147, 9148, 9145
4259, 1079, 1080, 9065, 9064, 1102, 9149, 9150, 9147
4260, 1080, 1081, 9066, 9065, 1103, 9151, 9152, 9149
4261, 1081, 1082, 9067, 9066, 1104, 9153, 9154, 9151
4262, 1082, 1083, 9068, 9067, 1105, 9155, 9156, 9153
4263, 1083, 33, 1055, 9068, 1106, 1058, 9157, 9155
4264, 917, 9047, 9069, 918, 9114, 9158, 9159, 921
4265, 9047, 9048, 9070, 9069, 9116, 9160, 9161, 9158
4266, 9048, 9049, 9071, 9070, 9118, 9162, 9163, 9160
4267, 9049, 9050, 9072, 9071, 9120, 9164, 9165, 9162
4268, 9050, 9051, 9073, 9072, 9122, 9166, 9167, 9164
4269, 9051, 9052, 9074, 9073, 9124, 9168, 9169, 9166
4270, 9052, 9053, 9075, 9074, 9126, 9170, 9171, 9168
4271, 9053, 9054, 9076, 9075, 9128, 9172, 9173, 9170
4272, 9054, 9055, 9077, 9076, 9130, 9174, 9175, 9172
4273, 9055, 9056, 9078, 9077, 9132, 9176, 9177, 9174
4274, 9056, 9057, 9079, 9078, 9134, 9178, 9179, 9176
4275, 9057, 9058, 9080, 9079, 9136, 9180, 9181, 9178
4276, 9058, 9059, 9081, 9080, 9138, 9182, 9183, 9180
4277, 9059, 9060, 9082, 9081, 9140, 9184, 9185, 9182
4278, 9060, 9061, 9083, 9082, 9142, 9186, 9187, 9184
4279, 9061, 9062, 9084, 9083, 9144, 9188, 9189, 9186
4280, 9062, 9063, 9085, 9084, 9146, 9190, 9191, 9188
4281, 9063, 9064, 9086, 9085, 9148, 9192, 9193, 9190
4282, 9064, 9065, 9087, 9086, 9150, 9194, 9195, 9192
4283, 9065, 9066, 9088, 9087, 9152, 9196, 9197, 9194
4284, 9066, 9067, 9089, 9088, 9154, 9198, 9199, 9196
4285, 9067, 9068, 9090, 9089, 9156, 9200, 9201, 9198
4286, 9068, 1055, 1056, 9090, 9157, 1059, 9202, 9200
4287, 918, 9069, 9091, 919, 9159, 9203, 9204, 922
4288, 9069, 9070, 9092, 9091, 9161, 9205, 9206, 9203
4289, 9070, 9071, 9093, 9092, 9163, 9207, 9208, 9205
4290, 9071, 9072, 9094, 9093, 9165, 9209, 9210, 9207
4291, 9072, 9073, 9095, 9094, 9167, 9211, 9212, 9209
4292, 9073, 9074, 9096, 9095, 9169, 9213, 9214, 9211
4293, 9074, 9075, 9097, 9096, 9171, 9215, 9216, 9213
4294, 9075, 9076, 9098, 9097, 9173, 9217, 9218, 9215
4295, 9076, 9077, 9099, 9098, 9175, 9219, 9220, 9217
4296, 9077, 9078, 9100, 9099, 9177, 9221, 9222, 9219
4297, 9078, 9079, 9101, 9100, 9179, 9223, 9224, 9221
4298, 9079, 9080, 9102, 9101, 9181, 9225, 9226, 9223
4299, 9080, 9081, 9103, 9102, 9183, 9227, 9228, 9225
4300, 9081, 9082, 9104, 9103, 9185, 9229, 9230, 9227
4301, 9082, 9083, 9105, 9104, 9187, 9231, 9232, 9229
4302, 9083, 9084, 9106, 9105, 9189, 9233, 9234, 9231
4303, 9084, 9085, 9107, 9106, 9191, 9235, 9236, 9233
4304, 9085, 9086, 9108, 9107, 9193, 9237, 9238, 9235
4305, 9086, 9087, 9109, 9108, 9195, 9239, 9240, 9237
4306, 9087, 9088, 9110, 9109, 9197, 9241, 9242, 9239
4307, 9088, 9089, 9111, 9110, 9199, 9243, 9244, 9241
4308, 9089, 9090, 9112, 9111, 9201, 9245, 9246, 9243
4309, 9090, 1056, 1057, 9112, 9202, 1060, 9247, 9245
4310, 919, 9091, 1107, 30, 9204, 9248, 1129, 923
4311, 9091, 9092, 1108, 1107, 9206, 9249, 1130, 9248
4312, 9092, 9093, 1109, 1108, 9208, 9250, 1131, 9249
4313, 9093, 9094, 1110, 1109, 9210, 9251, 1132, 9250
4314, 9094, 9095, 1111, 1110, 9212, 9252, 1133, 9251
4315, 9095, 9096, 1112, 1111, 9214, 9253, 1134, 9252
4316, 9096, 9097, 1113, 1112, 9216, 9254, 1135, 9253
4317, 9097, 9098, 1114, 1113, 9218, 9255, 1136, 9254
4318, 9098, 9099, 1115, 1114, 9220, 9256, 1137, 9255
4319, 9099, 9100, 1116, 1115, 9222, 9257, 1138, 9256
4320, 9100, 9101, 1117, 1116, 9224, 9258, 1139, 9257
4321, 9101, 9102, 1118, 1117, 9226, 9259, 1140, 9258
4322, 9102, 9103, 1119, 1118, 9228, 9260, 1141, 9259
4323, 9103, 9104, 1120, 1119, 9230, 9261, 1142, 9260
4324, 9104, 9105, 1121, 1120, 9232, 9262, 1143, 9261
4325, 9105, 9106, 1122, 1121, 9234, 9263, 1144, 9262
4326, 9106, 9107, 1123, 1122, 9236, 9264, 1145, 9263
4327, 9107, 9108, 1124, 1123, 9238, 9265, 1146, 9264
4328, 9108, 9109, 1125, 1124, 9240, 9266, 1147, 9265
4329, 9109, 9110, 1126, 1125, 9242, 9267, 1148, 9266
4330, 9110, 9111, 1127, 1126, 9244, 9268, 1149, 9267
4331, 9111, 9112, 1128, 1127, 9246, 9269, 1150, 9268
4332, 9112, 1057, 34, 1128, 9247, 1061, 1151, 9269
*ELEMENT, type=CPS8, ELSET=Surface189
4333, 31, 958, 9270, 1159, 961, 9294, 9295, 1168
4334, 1159, 9270, 9271, 1158, 9295, 9296, 9297, 1167
4335, 1158, 9271, 9272, 1157, 9297, 9298, 9299, 1166
4336, 1157, 9272, 9273, 1156, 9299, 9300, 9301, 1165
4337, 1156, 9273, 9274, 1155, 9301, 9302, 9303, 1164
4338, 1155, 9274, 9275, 1154, 9303, 9304, 9305, 1163
4339, 1154, 9275, 9276, 1153, 9305, 9306, 9307, 1162
4340, 1153, 9276, 9277, 1152, 9307, 9308, 9309, 1161
4341, 1152, 9277, 1055, 33, 9309, 9310, 1058, 1160
4342, 958, 959, 9278, 9270, 962, 9311, 9312, 9294
4343, 9270, 9278, 9279, 9271, 9312, 9313, 9314, 9296
4344, 9271, 9279, 9280, 9272, 9314, 9315, 9316, 9298
4345, 9272, 9280, 9281, 9273, 9316, 9317, 9318, 9300
4346, 9273, 9281, 9282, 9274, 9318, 9319, 9320, 9302
4347, 9274, 9282, 9283, 9275, 9320, 9321, 9322, 9304
4348, 9275, 9283, 9284, 9276, 9322, 9323, 9324, 9306
4349, 9276, 9284, 9285, 9277, 9324, 9325, 9326, 9308
4350, 9277, 9285, 1056, 1055, 9326, 9327, 1059, 9310
4351, 959, 960, 9286, 9278, 963, 9328, 9329, 9311
4352, 9278, 9286, 9287, 9279, 9329, 9330, 9331, 9313
4353, 9279, 9287, 9288, 9280, 9331, 9332, 9333, 9315
4354, 9280, 9288, 9289, 9281, 9333, 9334, 9335, 9317
4355, 9281, 9289, 9290, 9282, 9335, 9336, 9337, 9319
4356, 9282, 9290, 9291, 9283, 9337, 9338, 9339, 9321
4357, 9283, 9291, 9292, 9284, 9339, 9340, 9341, 9323
4358, 9284, 9292, 9293, 9285, 9341, 9342, 9343, 9325
4359, 9285, 9293, 1057, 1056, 9343, 9344, 1060, 9327
4360, 960, 32, 1176, 9286, 964, 1185, 9345, 9328
4361, 9286, 1176, 1175, 9287, 9345, 1184, 9346, 9330
4362, 9287, 1175, 1174, 9288, 9346, 1183, 9347, 9332
4363, 9288, 1174, 1173, 9289, 9347, 1182, 9348, 9334
4364, 9289, 1173, 1172, 9290, 9348, 1181, 9349, 9336
4365, 9290, 1172, 1171, 9291, 9349, 1180, 9350, 9338
4366, 9291, 1171, 1170, 9292, 9350, 1179, 9351, 9340
4367, 9292, 1170, 1169, 9293, 9351, 1178, 9352, 9342
4368, 9293, 1169, 34, 1057, 9352, 1177, 1061, 9344
*ELEMENT, type=CPS8, ELSET=Surface190
4369, 27, 965, 9353, 931, 987, 9529, 9530, 940
4370, 931, 9353, 9354, 930, 9530, 9531, 9532, 939
4371, 930, 9354, 9355, 929, 9532, 9533, 9534, 938
4372, 929, 9355, 9356, 928, 9534, 9535, 9536, 937
4373, 928, 9356, 9357, 927, 9536, 9537, 9538, 936
4374, 927, 9357, 9358, 926, 9538, 9539, 9540, 935
4375, 926, 9358, 9359, 925, 9540, 9541, 9542, 934
4376, 925, 9359, 9360, 924, 9542, 9543, 9544, 933
4377, 924, 9360, 1062, 29, 9544, 9545, 1084, 932
4378, 965, 966, 9361, 9353, 988, 9546, 9547, 9529
4379, 9353, 9361, 9362, 9354, 9547, 9548, 9549, 9531
4380, 9354, 9362, 9363, 9355, 9549, 9550, 9551, 9533
4381, 9355, 9363, 9364, 9356, 9551, 9552, 9553, 9535
4382, 9356, 9364, 9365, 9357, 9553, 9554, 9555, 9537
4383, 9357, 9365, 9366, 9358, 9555, 9556, 9557, 9539
4384, 9358, 9366, 9367, 9359, 9557, 9558, 9559, 9541
4385, 9359, 9367, 9368, 9360, 9559, 9560, 9561, 9543
4386, 9360, 9368, 1063, 1062, 9561, 9562, 1085, 9545
4387, 966, 967, 9369, 9361, 989, 9563, 9564, 9546
4388, 9361, 9369, 9370, 9362, 9564, 9565, 9566, 9548
4389, 9362, 9370, 9371, 9363, 9566, 9567, 9568, 9550
4390, 9363, 9371, 9372, 9364, 9568, 9569, 9570, 9552
4391, 9364, 9372, 9373, 9365, 9570, 9571, 9572, 9554
4392, 9365, 9373, 9374, 9366, 9572, 9573, 9574, 9556
4393, 9366, 9374, 9375, 9367, 9574, 9575, 9576, 9558
4394, 9367, 9375, 9376, 9368, 9576, 9577, 9578, 9560
4395, 9368, 9376, 1064, 1063, 9578, 9579, 1086, 9562
4396, 967, 968, 9377, 9369, 990, 9580, 9581, 9563
4397, 9369, 9377, 9378, 9370, 9581, 9582, 9583, 9565
4398, 9370, 9378, 9379, 9371, 9583, 9584, 9585, 9567
4399, 9371, 9379, 9380, 9372, 9585, 9586, 9587, 9569
4400, 9372, 9380, 9381, 9373, 9587, 9588, 9589, 9571
4401, 9373, 9381, 9382, 9374, 9589, 9590, 9591, 9573
4402, 9374, 9382, 9383, 9375, 9591, 9592, 9593, 9575
4403, 9375, 9383, 9384, 9376, 9593, 9594, 9595, 9577
4404, 9376, 9384, 1065, 1064, 9595, 9596, 1087, 9579
4405, 968, 969, 9385, 9377, 991, 9597, 9598, 9580
4406, 9377, 9385, 9386, 9378, 9598, 9599, 9600, 9582
4407, 9378, 9386, 9387, 9379, 9600, 9601, 9602, 9584
4408, 9379, 9387, 9388, 9380, 9602, 9603, 9604, 9586
4409, 9380, 9388, 9389, 9381, 9604, 9605, 9606, 9588
4410, 9381, 9389, 9390, 9382, 9606, 9607, 9608, 9590
4411, 9382, 9390, 9391, 9383, 9608, 9609, 9610, 9592
4412, 9383, 9391, 9392, 9384, 9610, 9611, 9612, 9594
4413, 9384, 9392, 1066, 1065, 9612, 9613, 1088, 9596
4414, 969, 970, 9393, 9385, 992, 9614, 9615, 9597
4415, 9385, 9393, 9394, 9386, 9615, 9616, 9617, 9599
4416, 9386, 9394, 9395, 9387, 9617, 9618, 9619, 9601
4417, 9387, 9395, 9396, 9388, 9619, 9620, 9621, 9603
4418, 9388, 9396, 9397, 9389, 9621, 9622, 9623, 9605
4419, 9389, 9397, 9398, 9390, 9623, 9624, 9625, 9607
4420, 9390, 9398, 9399, 9391, 9625, 9626, 9627, 9609
4421, 9391, 9399, 9400, 9392, 9627, 9628, 9629, 9611
4422, 9392, 9400, 1067, 1066, 9629, 9630, 1089, 9613
4423, 970, 971, 9401, 9393, 993, 9631, 9632, 9614
4424, 9393, 9401, 9402, 9394, 9632, 9633, 9634, 9616
4425, 9394, 9402, 9403, 9395, 9634, 9635, 9636, 9618
4426, 9395, 9403, 9404, 9396, 9636, 9637, 9638, 9620
4427, 9396, 9404, 9405, 9397, 9638, 9639, 9640, 9622
4428, 9397, 9405, 9406, 9398, 9640, 9641, 9642, 9624
4429, 9398, 9406, 9407, 9399, 9642, 9643, 9644, 9626
4430, 9399, 9407, 9408, 9400, 9644, 9645, 9646, 9628
4431, 9400, 9408, 1068, 1067, 9646, 9647, 1090, 9630
4432, 971, 972, 9409, 9401, 994, 9648, 9649, 9631
4433, 9401, 9409, 9410, 9402, 9649, 9650, 9651, 9633
4434, 9402, 9410, 9411, 9403, 9651, 9652, 9653, 9635
4435, 9403, 9411, 9412, 9404, 9653, 9654, 9655, 9637
4436, 9404, 9412, 9413, 9405, 9655, 9656, 9657, 9639
4437, 9405, 9413, 9414, 9406, 9657, 9658, 9659, 9641
4438, 9406, 9414, 9415, 9407, 9659, 9660, 9661, 9643
4439, 9407, 9415, 9416, 9408, 9661, 9662, 9663, 9645
4440, 9408, 9416, 1069, 1068, 9663, 9664, 1091, 9647
4441, 972, 973, 9417, 9409, 995, 9665, 9666, 9648
4442, 9409, 9417, 9418, 9410, 9666, 9667, 9668, 9650
4443, 9410, 9418, 9419, 9411, 9668, 9669, 9670, 9652
4444, 9411, 9419, 9420, 9412, 9670, 9671, 9672, 9654
4445, 9412, 9420, 9421, 9413, 9672, 9673, 9674, 9656
4446, 9413, 9421, 9422, 9414, 9674, 9675, 9676, 9658
4447, 9414, 9422, 9423, 9415, 9676, 9677, 9678, 9660
4448, 9415, 9423, 9424, 9416, 9678, 9679, 9680, 9662
4449, 9416, 9424, 1070, 1069, 9680, 9681, 1092, 9664
4450, 973, 974, 9425, 9417, 996, 9682, 9683, 9665
4451, 9417, 9425, 9426, 9418, 9683, 9684, 9685, 9667
4452, 9418, 9426, 9427, 9419, 9685, 9686, 9687, 9669
4453, 9419, 9427, 9428, 9420, 9687, 9688, 9689, 9671
4454, 9420, 9428, 9429, 9421, 9689, 9690, 9691, 9673
4455, 9421, 9429, 9430, 9422, 9691, 9692, 9693, 9675
4456, 9422, 9430, 9431, 9423, 9693, 9694, 9695, 9677
4457, 9423, 9431, 9432, 9424, 9695, 9696, 9697, 9679
4458, 9424, 9432, 1071, 1070, 9697, 9698, 1093, 9681
4459, 974, 975, 9433, 9425, 997, 9699, 9700, 9682
4460, 9425, 9433, 9434, 9426, 9700, 9701, 9702, 9684
4461, 9426, 9434, 9435, 9427, 9702, 9703, 9704, 9686
4462, 9427, 9435, 9436, 9428, 9704, 9705, 9706, 9688
4463, 9428, 9436, 9437, 9429, 9706, 9707, 9708, 9690
4464, 9429, 9437, 9438, 9430, 9708, 9709, 9710, 9692
4465, 9430, 9438, 9439, 9431, 9710, 9711, 9712, 9694
4466, 9431, 9439, 9440, 9432, 9712, 9713, 9714, 9696
4467, 9432, 9440, 1072, 1071, 9714, 9715, 1094, 9698
4468, 975, 976, 9441, 9433, 998, 9716, 9717, 9699
4469, 9433, 9441, 9442, 9434, 9717, 9718, 9719, 9701
4470, 9434, 9442, 9443, 9435, 9719, 9720, 9721, 9703
4471, 9435, 9443, 9444, 9436, 9721, 9722, 9723, 9705
4472, 9436, 9444, 9445, 9437, 9723, 9724, 9725, 9707
4473, 9437, 9445, 9446, 9438, 9725, 9726, 9727, 9709
4474, 9438, 9446, 9447, 9439, 9727, 9728, 9729, 9711
4475, 9439, 9447, 9448, 9440, 9729, 9730, 9731, 9713
4476, 9440, 9448, 1073, 1072, 9731, 9732, 1095, 9715
4477, 976, 977, 9449, 9441, 999, 9733, 9734, 9716
4478, 9441, 9449, 9450, 9442, 9734, 9735, 9736, 9718
4479, 9442, 9450, 9451, 9443, 9736, 9737, 9738, 9720
4480, 9443, 9451, 9452, 9444, 9738, 9739, 9740, 9722
4481, 9444, 9452, 9453, 9445, 9740, 9741, 9742, 9724
4482, 9445, 9453, 9454, 9446, 9742, 9743, 9744, 9726
4483, 9446, 9454, 9455, 9447, 9744, 9745, 9746, 9728
4484, 9447, 9455, 9456, 9448, 9746, 9747, 9748, 9730
4485, 9448, 9456, 1074, 1073, 9748, 9749, 1096, 9732
4486, 977, 978, 9457, 9449, 1000, 9750, 9751, 9733
4487, 9449, 9457, 9458, 9450, 9751, 9752, 9753, 9735
4488, 9450, 9458, 9459, 9451, 9753, 9754, 9755, 9737
4489, 9451, 9459, 9460, 9452, 9755, 9756, 9757, 9739
4490, 9452, 9460, 9461, 9453, 9757, 9758, 9759, 9741
4491, 9453, 9461, 9462, 9454, 9759, 9760, 9761, 9743
4492, 9454, 9462, 9463, 9455, 9761, 9762, 9763, 9745
4493, 9455, 9463, 9464, 9456, 9763, 9764, 9765, 9747
4494, 9456, 9464, 1075, 1074, 9765, 9766, 1097, 9749
4495, 978, 979, 9465, 9457, 1001, 9767, 9768, 9750
4496, 9457, 9465, 9466, 9458, 9768, 9769, 9770, 9752
4497, 9458, 9466, 9467, 9459, 9770, 9771, 9772, 9754
4498, 9459, 9467, 9468, 9460, 9772, 9773, 9774, 9756
4499, 9460, 9468, 9469, 9461, 9774, 9775, 9776, 9758
4500, 9461, 9469, 9470, 9462, 9776, 9777, 9778, 9760
4501, 9462, 9470, 9471, 9463, 9778, 9779, 9780, 9762
4502, 9463, 9471, 9472, 9464, 9780, 9781, 9782, 9764
4503, 9464, 9472, 1076, 1075, 9782, 9783, 1098, 9766
4504, 979, 980, 9473, 9465, 1002, 9784, 9785, 9767
4505, 9465, 9473, 9474, 9466, 9785, 9786, 9787, 9769
4506, 9466, 9474, 9475, 9467, 9787, 9788, 9789, 9771
4507, 9467, 9475, 9476, 9468, 9789, 9790, 9791, 9773
4508, 9468, 9476, 9477, 9469, 9791, 9792, 9793, 9775
4509, 9469, 9477, 9478, 9470, 9793, 9794, 9795, 9777
4510, 9470, 9478, 9479, 9471, 9795, 9796, 9797, 9779
4511, 9471, 9479, 9480, 9472, 9797, 9798, 9799, 9781
4512, 9472, 9480, 1077, 1076, 9799, 9800, 1099, 9783
4513, 980, 981, 9481, 9473, 1003, 9801, 9802, 9784
4514, 9473, 9481, 9482, 9474, 9802, 9803, 9804, 9786
4515, 9474, 9482, 9483, 9475, 9804, 9805, 9806, 9788
4516, 9475, 9483, 9484, 9476, 9806, 9807, 9808, 9790
4517, 9476, 9484, 9485, 9477, 9808, 9809, 9810, 9792
4518, 9477, 9485, 9486, 9478, 9810, 9811, 9812, 9794
4519, 9478, 9486, 9487, 9479, 9812, 9813, 9814, 9796
4520, 9479, 9487, 9488, 9480, 9814, 9815, 9816, 9798
4521, 9480, 9488, 1078, 1077, 9816, 9817, 1100, 9800
4522, 981, 982, 9489, 9481, 1004, 9818, 9819, 9801
4523, 9481, 9489, 9490, 9482, 9819, 9820, 9821, 9803
4524, 9482, 9490, 9491, 9483, 9821, 9822, 9823, 9805
4525, 9483, 9491, 9492, 9484, 9823, 9824, 9825, 9807
4526, 9484, 9492, 9493, 9485, 9825, 9826, 9827, 9809
4527, 9485, 9493, 9494, 9486, 9827, 9828, 9829, 9811
4528, 9486, 9494, 9495, 9487, 9829, 9830, 9831, 9813
4529, 9487, 9495, 9496, 9488, 9831, 9832, 9833, 9815
4530, 9488, 9496, 1079, 1078, 9833, 9834, 1101, 9817
4531, 982, 983, 9497, 9489, 1005, 9835, 9836, 9818
4532, 9489, 9497, 9498, 9490, 9836, 9837, 9838, 9820
4533, 9490, 9498, 9499, 9491, 9838, 9839, 9840, 9822
4534, 9491, 9499, 9500, 9492, 9840, 9841, 9842, 9824
4535, 9492, 9500, 9501, 9493, 9842, 9843, 9844, 9826
4536, 9493, 9501, 9502, 9494, 9844, 9845, 9846, 9828
4537, 9494, 9502, 9503, 9495, 9846, 9847, 9848, 9830
4538, 9495, 9503, 9504, 9496, 9848, 9849, 9850, 9832
4539, 9496, 9504, 1080, 1079, 9850, 9851, 1102, 9834
4540, 983, 984, 9505, 9497, 1006, 9852, 9853, 9835
4541, 9497, 9505, 9506, 9498, 9853, 9854, 9855, 9837
4542, 9498, 9506, 9507, 9499, 9855, 9856, 9857, 9839
4543, 9499, 9507, 9508, 9500, 9857, 9858, 9859, 9841
4544, 9500, 9508, 9509, 9501, 9859, 9860, 9861, 9843
4545, 9501, 9509, 9510, 9502, 9861, 9862, 9863, 9845
4546, 9502, 9510, 9511, 9503, 9863, 9864, 9865, 9847
4547, 9503, 9511, 9512, 9504, 9865, 9866, 9867, 9849
4548, 9504, 9512, 1081, 1080, 9867, 9868, 1103, 9851
4549, 984, 985, 9513, 9505, 1007, 9869, 9870, 9852
4550, 9505, 9513, 9514, 9506, 9870, 9871, 9872, 9854
4551, 9506, 9514, 9515, 9507, 9872, 9873, 9874, 9856
4552, 9507, 9515, 9516, 9508, 9874, 9875, 9876, 9858
4553, 9508, 9516, 9517, 9509, 9876, 9877, 9878, 9860
4554, 9509, 9517, 9518, 9510, 9878, 9879, 9880, 9862
4555, 9510, 9518, 9519, 9511, 9880, 9881, 9882, 9864
4556, 9511, 9519, 9520, 9512, 9882, 9883, 9884, 9866
4557, 9512, 9520, 1082, 1081, 9884, 9885, 1104, 9868
4558, 985, 986, 9521, 9513, 1008, 9886, 9887, 9869
4559, 9513, 9521, 9522, 9514, 9887, 9888, 9889, 9871
4560, 9514, 9522, 9523, 9515, 9889, 9890, 9891, 9873
4561, 9515, 9523, 9524, 9516, 9891, 9892, 9893, 9875
4562, 9516, 9524, 9525, 9517, 9893, 9894, 9895, 9877
4563, 9517, 9525, 9526, 9518, 9895, 9896, 9897, 9879
4564, 9518, 9526, 9527, 9519, 9897, 9898, 9899, 9881
4565, 9519, 9527, 9528, 9520, 9899, 9900, 9901, 9883
4566, 9520, 9528, 1083, 1082, 9901, 9902, 1105, 9885
4567, 986, 31, 1159, 9521, 1009, 1168, 9903, 9886
4568, 9521, 1159, 1158, 9522, 9903, 1167, 9904, 9888
4569, 9522, 1158, 1157, 9523, 9904, 1166, 9905, 9890
4570, 9523, 1157, 1156, 9524, 9905, 1165, 9906, 9892
4571, 9524, 1156, 1155, 9525, 9906, 1164, 9907, 9894
4572, 9525, 1155, 1154, 9526, 9907, 1163, 9908, 9896
4573, 9526, 1154, 1153, 9527, 9908, 1162, 9909, 9898
4574, 9527, 1153, 1152, 9528, 9909, 1161, 9910, 9900
4575, 9528, 1152, 33, 1083, 9910, 1160, 1106, 9902
*ELEMENT, type=CPS8, ELSET=Surface191
4576, 28, 948, 9911, 1010, 957, 10087, 10088, 1032
4577, 948, 947, 9912, 9911, 956, 10089, 10090, 10087
4578, 947, 946, 9913, 9912, 955, 10091, 10092, 10089
4579, 946, 945, 9914, 9913, 954, 10093, 10094, 10091
4580, 945, 944, 9915, 9914, 953, 10095, 10096, 10093
4581, 944, 943, 9916, 9915, 952, 10097, 10098, 10095
4582, 943, 942, 9917, 9916, 951, 10099, 10100, 10097
4583, 942, 941, 9918, 9917, 950, 10101, 10102, 10099
4584, 941, 30, 1107, 9918, 949, 1129, 10103, 10101
4585, 1010, 9911, 9919, 1011, 10088, 10104, 10105, 1033
4586, 9911, 9912, 9920, 9919, 10090, 10106, 10107, 10104
4587, 9912, 9913, 9921, 9920, 10092, 10108, 10109, 10106
4588, 9913, 9914, 9922, 9921, 10094, 10110, 10111, 10108
4589, 9914, 9915, 9923, 9922, 10096, 10112, 10113, 10110
4590, 9915, 9916, 9924, 9923, 10098, 10114, 10115, 10112
4591, 9916, 9917, 9925, 9924, 10100, 10116, 10117, 10114
4592, 9917, 9918, 9926, 9925, 10102, 10118, 10119, 10116
4593, 9918, 1107, 1108, 9926, 10103, 1130, 10120, 10118
4594, 1011, 9919, 9927, 1012, 10105, 10121, 10122, 1034
4595, 9919, 9920, 9928, 9927, 10107, 10123, 10124, 10121
4596, 9920, 9921, 9929, 9928, 10109, 10125, 10126, 10123
4597, 9921, 9922, 9930, 9929, 10111, 10127, 10128, 10125
4598, 9922, 9923, 9931, 9930, 10113, 10129, 10130, 10127
4599, 9923, 9924, 9932, 9931, 10115, 10131, 10132, 10129
4600, 9924, 9925, 9933, 9932, 10117, 10133, 10134, 10131
4601, 9925, 9926, 9934, 9933, 10119, 10135, 10136, 10133
4602, 9926, 1108, 1109, 9934, 10120, 1131, 10137, 10135
4603, 1012, 9927, 9935, 1013, 10122, 10138, 10139, 1035
4604, 9927, 9928, 9936, 9935, 10124, 10140, 10141, 10138
4605, 9928, 9929, 9937, 9936, 10126, 10142, 10143, 10140
4606, 9929, 9930, 9938, 9937, 10128, 10144, 10145, 10142
4607, 9930, 9931, 9939, 9938, 10130, 10146, 10147, 10144
4608, 9931, 9932, 9940, 9939, 10132, 10148, 10149, 10146
4609, 9932, 9933, 9941, 9940, 10134, 10150, 10151, 10148
4610, 9933, 9934, 9942, 9941, 10136, 10152, 10153, 10150
4611, 9934, 1109, 1110, 9942, 10137, 1132, 10154, 10152
4612, 1013, 9935, 9943, 1014, 10139, 10155, 10156, 1036
4613, 9935, 9936, 9944, 9943, 10141, 10157, 10158, 10155
4614, 9936, 9937, 9945, 9944, 10143, 10159, 10160, 10157
4615, 9937, 9938, 9946, 9945, 10145, 10161, 10162, 10159
4616, 9938, 9939, 9947, 9946, 10147, 10163, 10164, 10161
4617, 9939, 9940, 9948, 9947, 10149, 10165, 10166, 10163
4618, 9940, 9941, 9949, 9948, 10151, 10167, 10168, 10165
4619, 9941, 9942, 9950, 9949, 10153, 10169, 10170, 10167
4620, 9942, 1110, 1111, 9950, 10154, 1133, 10171, 10169
4621, 1014, 9943, 9951, 1015, 10156, 10172, 10173, 1037
4622, 9943, 9944, 9952, 9951, 10158, 10174, 10175, 10172
4623, 9944, 9945, 9953, 9952, 10160, 10176, 10177, 10174
4624, 9945, 9946, 9954, 9953, 10162, 10178, 10179, 10176
4625, 9946, 9947, 9955, 9954, 10164, 10180, 10181, 10178
4626, 9947, 9948, 9956, 9955, 10166, 10182, 10183, 10180
4627, 9948, 9949, 9957, 9956, 10168, 10184, 10185, 10182
4628, 9949, 9950, 9958, 9957, 10170, 10186, 10187, 10184
4629, 9950, 1111, 1112, 9958, 10171, 1134, 10188, 10186
4630, 1015, 9951, 9959, 1016, 10173, 10189, 10190, 1038
4631, 9951, 9952, 9960, 9959, 10175, 10191, 10192, 10189
4632, 9952, 9953, 9961, 9960, 10177, 10193, 10194, 10191
4633, 9953, 9954, 9962, 9961, 10179, 10195, 10196, 10193
4634, 9954, 9955, 9963, 9962, 10181, 10197, 10198, 10195
4635, 9955, 9956, 9964, 9963, 10183, 10199, 10200, 10197
4636, 9956, 9957, 9965, 9964, 10185, 10201, 10202, 10199
4637, 9957, 9958, 9966, 9965, 10187, 10203, 10204, 10201
4638, 9958, 1112, 1113, 9966, 10188, 1135, 10205, 10203
4639, 1016, 9959, 9967, 1017, 10190, 10206, 10207, 1039
4640, 9959, 9960, 9968, 9967, 10192, 10208, 10209, 10206
4641, 9960, 9961, 9969, 9968, 10194, 10210, 10211, 10208
4642, 9961, 9962, 9970, 9969, 10196, 10212, 10213, 10210
4643, 9962, 9963, 9971, 9970, 10198, 10214, 10215, 10212
4644, 9963, 9964, 9972, 9971, 10200, 10216, 10217, 10214
4645, 9964, 9965, 9973, 9972, 10202, 10218, 10219, 10216
4646, 9965, 9966, 9974, 9973, 10204, 10220, 10221, 10218
4647, 9966, 1113, 1114, 9974, 10205, 1136, 10222, 10220
4648, 1017, 9967, 9975, 1018, 10207, 10223, 10224, 1040
4649, 9967, 9968, 9976, 9975, 10209, 10225, 10226, 10223
4650, 9968, 9969, 9977, 9976, 10211, 10227, 10228, 10225
4651, 9969, 9970, 9978, 9977, 10213, 10229, 10230, 10227
4652, 9970, 9971, 9979, 9978, 10215, 10231, 10232, 10229
4653, 9971, 9972, 9980, 9979, 10217, 10233, 10234, 10231
4654, 9972, 9973, 9981, 9980, 10219, 10235, 10236, 10233
4655, 9973, 9974, 9982, 9981, 10221, 10237, 10238, 10235
4656, 9974, 1114, 1115, 9982, 10222, 1137, 10239, 10237
4657, 1018, 9975, 9983, 1019, 10224, 10240, 10241, 1041
4658, 9975, 9976, 9984, 9983, 10226, 10242, 10243, 10240
4659, 9976, 9977, 9985, 9984, 10228, 10244, 10245, 10242
4660, 9977, 9978, 9986, 9985, 10230, 10246, 10247, 10244
4661, 9978, 9979, 9987, 9986, 10232, 10248, 10249, 10246
4662, 9979, 9980, 9988, 9987, 10234, 10250, 10251, 10248
4663, 9980, 9981, 9989, 9988, 10236, 10252, 10253, 10250
4664, 9981, 9982, 9990, 9989, 10238, 10254, 10255, 10252
4665, 9982, 1115, 1116, 9990, 10239, 1138, 10256, 10254
4666, 1019, 9983, 9991, 1020, 10241, 10257, 10258, 1042
4667, 9983, 9984, 9992, 9991, 10243, 10259, 10260, 10257
4668, 9984, 9985, 9993, 9992, 10245, 10261, 10262, 10259
4669, 9985, 9986, 9994, 9993, 10247, 10263, 10264, 10261
4670, 9986, 9987, 9995, 9994, 10249, 10265, 10266, 10263
4671, 9987, 9988, 9996, 9995, 10251, 10267, 10268, 10265
4672, 9988, 9989, 9997, 9996, 10253, 10269, 10270, 10267
4673, 9989, 9990, 9998, 9997, 10255, 10271, 10272, 10269
4674, 9990, 1116, 1117, 9998, 10256, 1139, 10273, 10271
4675, 1020, 9991, 9999, 1021, 10258, 10274, 10275, 1043
4676, 9991, 9992, 10000, 9999, 10260, 10276, 10277, 10274
4677, 9992, 9993, 10001, 10000, 10262, 10278, 10279, 10276
4678, 9993, 9994, 10002, 10001, 10264, 10280, 10281, 10278
4679, 9994, 9995, 10003, 10002, 10266, 10282, 10283, 10280
4680, 9995, 9996, 10004, 10003, 10268, 10284, 10285, 10282
4681, 9996, 9997, 10005, 10004, 10270, 10286, 10287, 10284
4682, 9997, 9998, 10006, 10005, 10272, 10288, 10289, 10286
4683, 9998, 1117, 1118, 10006, 10273, 1140, 10290, 10288
4684, 1021, 9999, 10007, 1022, 10275, 10291, 10292, 1044
4685, 9999, 10000, 10008, 10007, 10277, 10293, 10294, 10291
4686, 10000, 10001, 10009, 10008, 10279, 10295, 10296, 10293
4687, 10001, 10002, 10010, 10009, 10281, 10297, 10298, 10295
4688, 10002, 10003, 10011, 10010, 10283, 10299, 10300, 10297
4689, 10003, 10004, 10012, 10011, 10285, 10301, 10302, 10299
4690, 10004, 10005, 10013, 10012, 10287, 10303, 10304, 10301
4691, 10005, 10006, 10014, 10013, 10289, 10305, 10306, 10303
4692, 10006, 1118, 1119, 10014, 10290, 1141, 10307, 10305
4693, 1022, 10007, 10015, 1023, 10292, 10308, 10309, 1045
4694, 10007, 10008, 10016, 10015, 10294, 10310, 10311, 10308
4695, 10008, 10009, 10017, 10016, 10296, 10312, 10313, 10310
4696, 10009, 10010, 10018, 10017, 10298, 10314, 10315, 10312
4697, 10010, 10011, 10019, 10018, 10300, 10316, 10317, 10314
4698, 10011, 10012, 10020, 10019, 10302, 10318, 10319, 10316
4699, 10012, 10013, 10021, 10020, 10304, 10320, 10321, 10318
4700, 10013, 10014, 10022, 10021, 10306, 10322, 10323, 10320
4701, 10014, 1119, 1120, 10022, 10307, 1142, 10324, 10322
4702, 1023, 10015, 10023, 1024, 10309, 10325, 10326, 1046
4703, 10015, 10016, 10024, 10023, 10311, 10327, 10328, 10325
4704, 10016, 10017, 10025, 10024, 10313, 10329, 10330, 10327
4705, 10017, 10018, 10026, 10025, 10315, 10331, 10332, 10329
4706, 10018, 10019, 10027, 10026, 10317, 10333, 10334, 10331
4707, 10019, 10020, 10028, 10027, 10319, 10335, 10336, 10333
4708, 10020, 10021, 10029, 10028, 10321, 10337, 10338, 10335
4709, 10021, 10022, 10030, 10029, 10323, 10339, 10340, 10337
4710, 10022, 1120, 1121, 10030, 10324, 1143, 10341, 10339
4711, 1024, 10023, 10031, 1025, 10326, 10342, 10343, 1047
4712, 10023, 10024, 10032, 10031, 10328, 10344, 10345, 10342
4713, 10024, 10025, 10033, 10032, 10330, 10346, 10347, 10344
4714, 10025, 10026, 10034, 10033, 10332, 10348, 10349, 10346
4715, 10026, 10027, 10035, 10034, 10334, 10350, 10351, 10348
4716, 10027, 10028, 10036, 10035, 10336, 10352, 10353, 10350
4717, 10028, 10029, 10037, 10036, 10338, 10354, 10355, 10352
4718, 10029, 10030, 10038, 10037, 10340, 10356, 10357, 10354
4719, 10030, 1121, 1122, 10038, 10341, 1144, 10358, 10356
4720, 1025, 10031, 10039, 1026, 10343, 10359, 10360, 1048
4721, 10031, 10032, 10040, 10039, 10345, 10361, 10362, 10359
4722, 10032, 10033, 10041, 10040, 10347, 10363, 10364, 10361
4723, 10033, 10034, 10042, 10041, 10349, 10365, 10366, 10363
4724, 10034, 10035, 10043, 10042, 10351, 10367, 10368, 10365
4725, 10035, 10036, 10044, 10043, 10353, 10369, 10370, 10367
4726, 10036, 10037, 10045, 10044, 10355, 10371, 10372, 10369
4727, 10037, 10038, 10046, 10045, 10357, 10373, 10374, 10371
4728, 10038, 1122, 1123, 10046, 10358, 1145, 10375, 10373
4729, 1026, 10039, 10047, 1027, 10360, 10376, 10377, 1049
4730, 10039, 10040, 10048, 10047, 10362, 10378, 10379, 10376
4731, 10040, 10041, 10049, 10048, 10364, 10380, 10381, 10378
4732, 10041, 10042, 10050, 10049, 10366, 10382, 10383, 10380
4733, 10042, 10043, 10051, 10050, 10368, 10384, 10385, 10382
4734, 10043, 10044, 10052, 10051, 10370, 10386, 10387, 10384
4735, 10044, 10045, 10053, 10052, 10372, 10388, 10389, 10386
4736, 10045, 10046, 10054, 10053, 10374, 10390, 10391, 10388
4737, 10046, 1123, 1124, 10054, 10375, 1146, 10392, 10390
4738, 1027, 10047, 10055, 1028, 10377, 10393, 10394, 1050
4739, 10047, 10048, 10056, 10055, 10379, 10395, 10396, 10393
4740, 10048, 10049, 10057, 10056, 10381, 10397, 10398, 10395
4741, 10049, 10050, 10058, 10057, 10383, 10399, 10400, 10397
4742, 10050, 10051, 10059, 10058, 10385, 10401, 10402, 10399
4743, 10051, 10052, 10060, 10059, 10387, 10403, 10404, 10401
4744, 10052, 10053, 10061, 10060, 10389, 10405, 10406, 10403
4745, 10053, 10054, 10062, 10061, 10391, 10407, 10408, 10405
4746, 10054, 1124, 1125, 10062, 10392, 1147, 10409, 10407
4747, 1028, 10055, 10063, 1029, 10394, 10410, 10411, 1051
4748, 10055, 10056, 10064, 10063, 10396, 10412, 10413, 10410
4749, 10056, 10057, 10065, 10064, 10398, 10414, 10415, 10412
4750, 10057, 10058, 10066, 10065, 10400, 10416, 10417, 10414
4751, 10058, 10059, 10067, 10066, 10402, 10418, 10419, 10416
4752, 10059, 10060, 10068, 10067, 10404, 10420, 10421, 10418
4753, 10060, 10061, 10069, 10068, 10406, 10422, 10423, 10420
4754, 10061, 10062, 10070, 10069, 10408, 10424, 10425, 10422
4755, 10062, 1125, 1126, 10070, 10409, 1148, 10426, 10424
4756, 1029, 10063, 10071, 1030, 10411, 10427, 10428, 1052
4757, 10063, 10064, 10072, 10071, 10413, 10429, 10430, 10427
4758, 10064, 10065, 10073, 10072, 10415, 10431, 10432, 10429
4759, 10065, 10066, 10074, 10073, 10417, 10433, 10434, 10431
4760, 10066, 10067, 10075, 10074, 10419, 10435, 10436, 10433
4761, 10067, 10068, 10076, 10075, 10421, 10437, 10438, 10435
4762, 10068, 10069, 10077, 10076, 10423, 10439, 10440, 10437
4763, 10069, 10070, 10078, 10077, 10425, 10441, 10442, 10439
4764, 10070, 1126, 1127, 10078, 10426, 1149, 10443, 10441
4765, 1030, 10071, 10079, 1031, 10428, 10444, 10445, 1053
4766, 10071, 10072, 10080, 10079, 10430, 10446, 10447, 10444
4767, 10072, 10073, 10081, 10080, 10432, 10448, 10449, 10446
4768, 10073, 10074, 10082, 10081, 10434, 10450, 10451, 10448
4769, 10074, 10075, 10083, 10082, 10436, 10452, 10453, 10450
4770, 10075, 10076, 10084, 10083, 10438, 10454, 10455, 10452
4771, 10076, 10077, 10085, 10084, 10440, 10456, 10457, 10454
4772, 10077, 10078, 10086, 10085, 10442, 10458, 10459, 10456
4773, 10078, 1127, 1128, 10086, 10443, 1150, 10460, 10458
4774, 1031, 10079, 1176, 32, 10445, 10461, 1185, 1054
4775, 10079, 10080, 1175, 1176, 10447, 10462, 1184, 10461
4776, 10080, 10081, 1174, 1175, 10449, 10463, 1183, 10462
4777, 10081, 10082, 1173, 1174, 10451, 10464, 1182, 10463
4778, 10082, 10083, 1172, 1173, 10453, 10465, 1181, 10464
4779, 10083, 10084, 1171, 1172, 10455, 10466, 1180, 10465
4780, 10084, 10085, 1170, 1171, 10457, 10467, 1179, 10466
4781, 10085, 10086, 1169, 1170, 10459, 10468, 1178, 10467
4782, 10086, 1128, 34, 1169, 10460, 1151, 1177, 10468
*ELEMENT, type=CPS8, ELSET=Surface192
4783, 35, 1186, 10469, 1196, 1188, 10513, 10514, 1218
4784, 1196, 10469, 10470, 1197, 10514, 10515, 10516, 1219
4785, 1197, 10470, 10471, 1198, 10516, 10517, 10518, 1220
4786, 1198, 10471, 10472, 1199, 10518, 10519, 10520, 1221
4787, 1199, 10472, 10473, 1200, 10520, 10521, 10522, 1222
4788, 1200, 10473, 10474, 1201, 10522, 10523, 10524, 1223
4789, 1201, 10474, 10475, 1202, 10524, 10525, 10526, 1224
4790, 1202, 10475, 10476, 1203, 10526, 10527, 10528, 1225
4791, 1203, 10476, 10477, 1204, 10528, 10529, 10530, 1226
4792, 1204, 10477, 10478, 1205, 10530, 10531, 10532, 1227
4793, 1205, 10478, 10479, 1206, 10532, 10533, 10534, 1228
4794, 1206, 10479, 10480, 1207, 10534, 10535, 10536, 1229
4795, 1207, 10480, 10481, 1208, 10536, 10537, 10538, 1230
4796, 1208, 10481, 10482, 1209, 10538, 10539, 10540, 1231
4797, 1209, 10482, 10483, 1210, 10540, 10541, 10542, 1232
4798, 1210, 10483, 10484, 1211, 10542, 10543, 10544, 1233
4799, 1211, 10484, 10485, 1212, 10544, 10545, 10546, 1234
4800, 1212, 10485, 10486, 1213, 10546, 10547, 10548, 1235
4801, 1213, 10486, 10487, 1214, 10548, 10549, 10550, 1236
4802, 1214, 10487, 10488, 1215, 10550, 10551, 10552, 1237
4803, 1215, 10488, 10489, 1216, 10552, 10553, 10554, 1238
4804, 1216, 10489, 10490, 1217, 10554, 10555, 10556, 1239
4805, 1217, 10490, 1191, 36, 10556, 10557, 1193, 1240
4806, 1186, 1187, 10491, 10469, 1189, 10558, 10559, 10513
4807, 10469, 10491, 10492, 10470, 10559, 10560, 10561, 10515
4808, 10470, 10492, 10493, 10471, 10561, 10562, 10563, 10517
4809, 10471, 10493, 10494, 10472, 10563, 10564, 10565, 10519
4810, 10472, 10494, 10495, 10473, 10565, 10566, 10567, 10521
4811, 10473, 10495, 10496, 10474, 10567, 10568, 10569, 10523
4812, 10474, 10496, 10497, 10475, 10569, 10570, 10571, 10525
4813, 10475, 10497, 10498, 10476, 10571, 10572, 10573, 10527
4814, 10476, 10498, 10499, 10477, 10573, 10574, 10575, 10529
4815, 10477, 10499, 10500, 10478, 10575, 10576, 10577, 10531
4816, 10478, 10500, 10501, 10479, 10577, 10578, 10579, 10533
4817, 10479, 10501, 10502, 10480, 10579, 10580, 10581, 10535
4818, 10480, 10502, 10503, 10481, 10581, 10582, 10583, 10537
4819, 10481, 10503, 10504, 10482, 10583, 10584, 10585, 10539
4820, 10482, 10504, 10505, 10483, 10585, 10586, 10587, 10541
4821, 10483, 10505, 10506, 10484, 10587, 10588, 10589, 10543
4822, 10484, 10506, 10507, 10485, 10589, 10590, 10591, 10545
4823, 10485, 10507, 10508, 10486, 10591, 10592, 10593, 10547
4824, 10486, 10508, 10509, 10487, 10593, 10594, 10595, 10549
4825, 10487, 10509, 10510, 10488, 10595, 10596, 10597, 10551
4826, 10488, 10510, 10511, 10489, 10597, 10598, 10599, 10553
4827, 10489, 10511, 10512, 10490, 10599, 10600, 10601, 10555
4828, 10490, 10512, 1192, 1191, 10601, 10602, 1194, 10557
4829, 1187, 27, 965, 10491, 1190, 987, 10603, 10558
4830, 10491, 965, 966, 10492, 10603, 988, 10604, 10560
4831, 10492, 966, 967, 10493, 10604, 989, 10605, 10562
4832, 10493, 967, 968, 10494, 10605, 990, 10606, 10564
4833, 10494, 968, 969, 10495, 10606, 991, 10607, 10566
4834, 10495, 969, 970, 10496, 10607, 992, 10608, 10568
4835, 10496, 970, 971, 10497, 10608, 993, 10609, 10570
4836, 10497, 971, 972, 10498, 10609, 994, 10610, 10572
4837, 10498, 972, 973, 10499, 10610, 995, 10611, 10574
4838, 10499, 973, 974, 10500, 10611, 996, 10612, 10576
4839, 10500, 974, 975, 10501, 10612, 997, 10613, 10578
4840, 10501, 975, 976, 10502, 10613, 998, 10614, 10580
4841, 10502, 976, 977, 10503, 10614, 999, 10615, 10582
4842, 10503, 977, 978, 10504, 10615, 1000, 10616, 10584
4843, 10504, 978, 979, 10505, 10616, 1001, 10617, 10586
4844, 10505, 979, 980, 10506, 10617, 1002, 10618, 10588
4845, 10506, 980, 981, 10507, 10618, 1003, 10619, 10590
4846, 10507, 981, 982, 10508, 10619, 1004, 10620, 10592
4847, 10508, 982, 983, 10509, 10620, 1005, 10621, 10594
4848, 10509, 983, 984, 10510, 10621, 1006, 10622, 10596
4849, 10510, 984, 985, 10511, 10622, 1007, 10623, 10598
4850, 10511, 985, 986, 10512, 10623, 1008, 10624, 10600
4851, 10512, 986, 31, 1192, 10624, 1009, 1195, 10602
*ELEMENT, type=CPS8, ELSET=Surface193
4852, 37, 1251, 10625, 1241, 1273, 10669, 10670, 1243
4853, 1251, 1252, 10626, 10625, 1274, 10671, 10672, 10669
4854, 1252, 1253, 10627, 10626, 1275, 10673, 10674, 10671
4855, 1253, 1254, 10628, 10627, 1276, 10675, 10676, 10673
4856, 1254, 1255, 10629, 10628, 1277, 10677, 10678, 10675
4857, 1255, 1256, 10630, 10629, 1278, 10679, 10680, 10677
4858, 1256, 1257, 10631, 10630, 1279, 10681, 10682, 10679
4859, 1257, 1258, 10632, 10631, 1280, 10683, 10684, 10681
4860, 1258, 1259, 10633, 10632, 1281, 10685, 10686, 10683
4861, 1259, 1260, 10634, 10633, 1282, 10687, 10688, 10685
4862, 1260, 1261, 10635, 10634, 1283, 10689, 10690, 10687
4863, 1261, 1262, 10636, 10635, 1284, 10691, 10692, 10689
4864, 1262, 1263, 10637, 10636, 1285, 10693, 10694, 10691
4865, 1263, 1264, 10638, 10637, 1286, 10695, 10696, 10693
4866, 1264, 1265, 10639, 10638, 1287, 10697, 10698, 10695
4867, 1265, 1266, 10640, 10639, 1288, 10699, 10700, 10697
4868, 1266, 1267, 10641, 10640, 1289, 10701, 10702, 10699
4869, 1267, 1268, 10642, 10641, 1290, 10703, 10704, 10701
4870, 1268, 1269, 10643, 10642, 1291, 10705, 10706, 10703
4871, 1269, 1270, 10644, 10643, 1292, 10707, 10708, 10705
4872, 1270, 1271, 10645, 10644, 1293, 10709, 10710, 10707
4873, 1271, 1272, 10646, 10645, 1294, 10711, 10712, 10709
4874, 1272, 38, 1246, 10646, 1295, 1248, 10713, 10711
4875, 1241, 10625, 10647, 1242, 10670, 10714, 10715, 1244
4876, 10625, 10626, 10648, 10647, 10672, 10716, 10717, 10714
4877, 10626, 10627, 10649, 10648, 10674, 10718, 10719, 10716
4878, 10627, 10628, 10650, 10649, 10676, 10720, 10721, 10718
4879, 10628, 10629, 10651, 10650, 10678, 10722, 10723, 10720
4880, 10629, 10630, 10652, 10651, 10680, 10724, 10725, 10722
4881, 10630, 10631, 10653, 10652, 10682, 10726, 10727, 10724
4882, 10631, 10632, 10654, 10653, 10684, 10728, 10729, 10726
4883, 10632, 10633, 10655, 10654, 10686, 10730, 10731, 10728
4884, 10633, 10634, 10656, 10655, 10688, 10732, 10733, 10730
4885, 10634, 10635, 10657, 10656, 10690, 10734, 10735, 10732
4886, 10635, 10636, 10658, 10657, 10692, 10736, 10737, 10734
4887, 10636, 10637, 10659, 10658, 10694, 10738, 10739, 10736
4888, 10637, 10638, 10660, 10659, 10696, 10740, 10741, 10738
4889, 10638, 10639, 10661, 10660, 10698, 10742, 10743, 10740
4890, 10639, 10640, 10662, 10661, 10700, 10744, 10745, 10742
4891, 10640, 10641, 10663, 10662, 10702, 10746, 10747, 10744
4892, 10641, 10642, 10664, 10663, 10704, 10748, 10749, 10746
4893, 10642, 10643, 10665, 10664, 10706, 10750, 10751, 10748
4894, 10643, 10644, 10666, 10665, 10708, 10752, 10753, 10750
4895, 10644, 10645, 10667, 10666, 10710, 10754, 10755, 10752
4896, 10645, 10646, 10668, 10667, 10712, 10756, 10757, 10754
4897, 10646, 1246, 1247, 10668, 10713, 1249, 10758, 10756
4898, 1242, 10647, 1062, 29, 10715, 10759, 1084, 1245
4899, 10647, 10648, 1063, 1062, 10717, 10760, 1085, 10759
4900, 10648, 10649, 1064, 1063, 10719, 10761, 1086, 10760
4901, 10649, 10650, 1065, 1064, 10721, 10762, 1087, 10761
4902, 10650, 10651, 1066, 1065, 10723, 10763, 1088, 10762
4903, 10651, 10652, 1067, 1066, 10725, 10764, 1089, 10763
4904, 10652, 10653, 1068, 1067, 10727, 10765, 1090, 10764
4905, 10653, 10654, 1069, 1068, 10729, 10766, 1091, 10765
4906, 10654, 10655, 1070, 1069, 10731, 10767, 1092, 10766
4907, 10655, 10656, 1071, 1070, 10733, 10768, 1093, 10767
4908, 10656, 10657, 1072, 1071, 10735, 10769, 1094, 10768
4909, 10657, 10658, 1073, 1072, 10737, 10770, 1095, 10769
4910, 10658, 10659, 1074, 1073, 10739, 10771, 1096, 10770
4911, 10659, 10660, 1075, 1074, 10741, 10772, 1097, 10771
4912, 10660, 10661, 1076, 1075, 10743, 10773, 1098, 10772
4913, 10661, 10662, 1077, 1076, 10745, 10774, 1099, 10773
4914, 10662, 10663, 1078, 1077, 10747, 10775, 1100, 10774
4915, 10663, 10664, 1079, 1078, 10749, 10776, 1101, 10775
4916, 10664, 10665, 1080, 1079, 10751, 10777, 1102, 10776
4917, 10665, 10666, 1081, 1080, 10753, 10778, 1103, 10777
4918, 10666, 10667, 1082, 1081, 10755, 10779, 1104, 10778
4919, 10667, 10668, 1083, 1082, 10757, 10780, 1105, 10779
4920, 10668, 1247, 33, 1083, 10758, 1250, 1106, 10780
*ELEMENT, type=CPS8, ELSET=Surface194
4921, 35, 1303, 10781, 1186, 1312, 10797, 10798, 1188
4922, 1303, 1302, 10782, 10781, 1311, 10799, 10800, 10797
4923, 1302, 1301, 10783, 10782, 1310, 10801, 10802, 10799
4924, 1301, 1300, 10784, 10783, 1309, 10803, 10804, 10801
4925, 1300, 1299, 10785, 10784, 1308, 10805, 10806, 10803
4926, 1299, 1298, 10786, 10785, 1307, 10807, 10808, 10805
4927, 1298, 1297, 10787, 10786, 1306, 10809, 10810, 10807
4928, 1297, 1296, 10788, 10787, 1305, 10811, 10812, 10809
4929, 1296, 37, 1241, 10788, 1304, 1243, 10813, 10811
4930, 1186, 10781, 10789, 1187, 10798, 10814, 10815, 1189
4931, 10781, 10782, 10790, 10789, 10800, 10816, 10817, 10814
4932, 10782, 10783, 10791, 10790, 10802, 10818, 10819, 10816
4933, 10783, 10784, 10792, 10791, 10804, 10820, 10821, 10818
4934, 10784, 10785, 10793, 10792, 10806, 10822, 10823, 10820
4935, 10785, 10786, 10794, 10793, 10808, 10824, 10825, 10822
4936, 10786, 10787, 10795, 10794, 10810, 10826, 10827, 10824
4937, 10787, 10788, 10796, 10795, 10812, 10828, 10829, 10826
4938, 10788, 1241, 1242, 10796, 10813, 1244, 10830, 10828
4939, 1187, 10789, 931, 27, 10815, 10831, 940, 1190
4940, 10789, 10790, 930, 931, 10817, 10832, 939, 10831
4941, 10790, 10791, 929, 930, 10819, 10833, 938, 10832
4942, 10791, 10792, 928, 929, 10821, 10834, 937, 10833
4943, 10792, 10793, 927, 928, 10823, 10835, 936, 10834
4944, 10793, 10794, 926, 927, 10825, 10836, 935, 10835
4945, 10794, 10795, 925, 926, 10827, 10837, 934, 10836
4946, 10795, 10796, 924, 925, 10829, 10838, 933, 10837
4947, 10796, 1242, 29, 924, 10830, 1245, 932, 10838
*ELEMENT, type=CPS8, ELSET=Surface195
4948, 36, 1191, 10839, 1320, 1193, 10855, 10856, 1329
4949, 1320, 10839, 10840, 1319, 10856, 10857, 10858, 1328
4950, 1319, 10840, 10841, 1318, 10858, 10859, 10860, 1327
4951, 1318, 10841, 10842, 1317, 10860, 10861, 10862, 1326
4952, 1317, 10842, 10843, 1316, 10862, 10863, 10864, 1325
4953, 1316, 10843, 10844, 1315, 10864, 10865, 10866, 1324
4954, 1315, 10844, 10845, 1314, 10866, 10867, 10868, 1323
4955, 1314, 10845, 10846, 1313, 10868, 10869, 10870, 1322
4956, 1313, 10846, 1246, 38, 10870, 10871, 1248, 1321
4957, 1191, 1192, 10847, 10839, 1194, 10872, 10873, 10855
4958, 10839, 10847, 10848, 10840, 10873, 10874, 10875, 10857
4959, 10840, 10848, 10849, 10841, 10875, 10876, 10877, 10859
4960, 10841, 10849, 10850, 10842, 10877, 10878, 10879, 10861
4961, 10842, 10850, 10851, 10843, 10879, 10880, 10881, 10863
4962, 10843, 10851, 10852, 10844, 10881, 10882, 10883, 10865
4963, 10844, 10852, 10853, 10845, 10883, 10884, 10885, 10867
4964, 10845, 10853, 10854, 10846, 10885, 10886, 10887, 10869
4965, 10846, 10854, 1247, 1246, 10887, 10888, 1249, 10871
4966, 1192, 31, 1159, 10847, 1195, 1168, 10889, 10872
4967, 10847, 1159, 1158, 10848, 10889, 1167, 10890, 10874
4968, 10848, 1158, 1157, 10849, 10890, 1166, 10891, 10876
4969, 10849, 1157, 1156, 10850, 10891, 1165, 10892, 10878
4970, 10850, 1156, 1155, 10851, 10892, 1164, 10893, 10880
4971, 10851, 1155, 1154, 10852, 10893, 1163, 10894, 10882
4972, 10852, 1154, 1153, 10853, 10894, 1162, 10895, 10884
4973, 10853, 1153, 1152, 10854, 10895, 1161, 10896, 10886
4974, 10854, 1152, 33, 1247, 10896, 1160, 1250, 10888
*ELEMENT, type=CPS8, ELSET=Surface196
4975, 35, 1196, 10897, 1303, 1218, 11073, 11074, 1312
4976, 1303, 10897, 10898, 1302, 11074, 11075, 11076, 1311
4977, 1302, 10898, 10899, 1301, 11076, 11077, 11078, 1310
4978, 1301, 10899, 10900, 1300, 11078, 11079, 11080, 1309
4979, 1300, 10900, 10901, 1299, 11080, 11081, 11082, 1308
4980, 1299, 10901, 10902, 1298, 11082, 11083, 11084, 1307
4981, 1298, 10902, 10903, 1297, 11084, 11085, 11086, 1306
4982, 1297, 10903, 10904, 1296, 11086, 11087, 11088, 1305
4983, 1296, 10904, 1251, 37, 11088, 11089, 1273, 1304
4984, 1196, 1197, 10905, 10897, 1219, 11090, 11091, 11073
4985, 10897, 10905, 10906, 10898, 11091, 11092, 11093, 11075
4986, 10898, 10906, 10907, 10899, 11093, 11094, 11095, 11077
4987, 10899, 10907, 10908, 10900, 11095, 11096, 11097, 11079
4988, 10900, 10908, 10909, 10901, 11097, 11098, 11099, 11081
4989, 10901, 10909, 10910, 10902, 11099, 11100, 11101, 11083
4990, 10902, 10910, 10911, 10903, 11101, 11102, 11103, 11085
4991, 10903, 10911, 10912, 10904, 11103, 11104, 11105, 11087
4992, 10904, 10912, 1252, 1251, 11105, 11106, 1274, 11089
4993, 1197, 1198, 10913, 10905, 1220, 11107, 11108, 11090
4994, 10905, 10913, 10914, 10906, 11108, 11109, 11110, 11092
4995, 10906, 10914, 10915, 10907, 11110, 11111, 11112, 11094
4996, 10907, 10915, 10916, 10908, 11112, 11113, 11114, 11096
4997, 10908, 10916, 10917, 10909, 11114, 11115, 11116, 11098
4998, 10909, 10917, 10918, 10910, 11116, 11117, 11118, 11100
4999, 10910, 10918, 10919, 10911, 11118, 11119, 11120, 11102
5000, 10911, 10919, 10920, 10912, 11120, 11121, 11122, 11104
5001, 10912, 10920, 1253, 1252, 11122, 11123, 1275, 11106
5002, 1198, 1199, 10921, 10913, 1221, 11124, 11125, 11107
5003, 10913, 10921, 10922, 10914, 11125, 11126, 11127, 11109
5004, 10914, 10922, 10923, 10915, 11127, 11128, 11129, 11111
5005, 10915, 10923, 10924, 10916, 11129, 11130, 11131, 11113
5006, 10916, 10924, 10925, 10917, 11131, 11132, 11133, 11115
5007, 10917, 10925, 10926, 10918, 11133, 11134, 11135, 11117
5008, 10918, 10926, 10927, 10919, 11135, 11136, 11137, 11119
5009, 10919, 10927, 10928, 10920, 11137, 11138, 11139, 11121
5010, 10920, 10928, 1254, 1253, 11139, 11140, 1276, 11123
5011, 1199, 1200, 10929, 10921, 1222, 11141, 11142, 11124
5012, 10921, 10929, 10930, 10922, 11142, 11143, 11144, 11126
5013, 10922, 10930, 10931, 10923, 11144, 11145, 11146, 11128
5014, 10923, 10931, 10932, 10924, 11146, 11147, 11148, 11130
5015, 10924, 10932, 10933, 10925, 11148, 11149, 11150, 11132
5016, 10925, 10933, 10934, 10926, 11150, 11151, 11152, 11134
5017, 10926, 10934, 10935, 10927, 11152, 11153, 11154, 11136
5018, 10927, 10935, 10936, 10928, 11154, 11155, 11156, 11138
5019, 10928, 10936, 1255, 1254, 11156, 11157, 1277, 11140
5020, 1200, 1201, 10937, 10929, 1223, 11158, 11159, 11141
5021, 10929, 10937, 10938, 10930, 11159, 11160, 11161, 11143
5022, 10930, 10938, 10939, 10931, 11161, 11162, 11163, 11145
5023, 10931, 10939, 10940, 10932, 11163, 11164, 11165, 11147
5024, 10932, 10940, 10941, 10933, 11165, 11166, 11167, 11149
5025, 10933, 10941, 10942, 10934, 11167, 11168, 11169, 11151
5026, 10934, 10942, 10943, 10935, 11169, 11170, 11171, 11153
5027, 10935, 10943, 10944, 10936, 11171, 11172, 11173, 11155
5028, 10936, 10944, 1256, 1255, 11173, 11174, 1278, 11157
5029, 1201, 1202, 10945, 10937, 1224, 11175, 11176, 11158
5030, 10937, 10945, 10946, 10938, 11176, 11177, 11178, 11160
5031, 10938, 10946, 10947, 10939, 11178, 11179, 11180, 11162
5032, 10939, 10947, 10948, 10940, 11180, 11181, 11182, 11164
5033, 10940, 10948, 10949, 10941, 11182, 11183, 11184, 11166
5034, 10941, 10949, 10950, 10942, 11184, 11185, 11186, 11168
5035, 10942, 10950, 10951, 10943, 11186, 11187, 11188, 11170
5036, 10943, 10951, 10952, 10944, 11188, 11189, 11190, 11172
5037, 10944, 10952, 1257, 1256, 11190, 11191, 1279, 11174
5038, 1202, 1203, 10953, 10945, 1225, 11192, 11193, 11175
5039, 10945, 10953, 10954, 10946, 11193, 11194, 11195, 11177
5040, 10946, 10954, 10955, 10947, 11195, 11196, 11197, 11179
5041, 10947, 10955, 10956, 10948, 11197, 11198, 11199, 11181
5042, 10948, 10956, 10957, 10949, 11199, 11200, 11201, 11183
5043, 10949, 10957, 10958, 10950, 11201, 11202, 11203, 11185
5044, 10950, 10958, 10959, 10951, 11203, 11204, 11205, 11187
5045, 10951, 10959, 10960, 10952, 11205, 11206, 11207, 11189
5046, 10952, 10960, 1258, 1257, 11207, 11208, 1280, 11191
5047, 1203, 1204, 10961, 10953, 1226, 11209, 11210, 11192
5048, 10953, 10961, 10962, 10954, 11210, 11211, 11212, 11194
5049, 10954, 10962, 10963, 10955, 11212, 11213, 11214, 11196
5050, 10955, 10963, 10964, 10956, 11214, 11215, 11216, 11198
5051, 10956, 10964, 10965, 10957, 11216, 11217, 11218, 11200
5052, 10957, 10965, 10966, 10958, 11218, 11219, 11220, 11202
5053, 10958, 10966, 10967, 10959, 11220, 11221, 11222, 11204
5054, 10959, 10967, 10968, 10960, 11222, 11223, 11224, 11206
5055, 10960, 10968, 1259, 1258, 11224, 11225, 1281, 11208
5056, 1204, 1205, 10969, 10961, 1227, 11226, 11227, 11209
5057, 10961, 10969, 10970, 10962, 11227, 11228, 11229, 11211
5058, 10962, 10970, 10971, 10963, 11229, 11230, 11231, 11213
5059, 10963, 10971, 10972, 10964, 11231, 11232, 11233, 11215
5060, 10964, 10972, 10973, 10965, 11233, 11234, 11235, 11217
5061, 10965, 10973, 10974, 10966, 11235, 11236, 11237, 11219
5062, 10966, 10974, 10975, 10967, 11237, 11238, 11239, 11221
5063, 10967, 10975, 10976, 10968, 11239, 11240, 11241, 11223
5064, 10968, 10976, 1260, 1259, 11241, 11242, 1282, 11225
5065, 1205, 1206, 10977, 10969, 1228, 11243, 11244, 11226
5066, 10969, 10977, 10978, 10970, 11244, 11245, 11246, 11228
5067, 10970, 10978, 10979, 10971, 11246, 11247, 11248, 11230
5068, 10971, 10979, 10980, 10972, 11248, 11249, 11250, 11232
5069, 10972, 10980, 10981, 10973, 11250, 11251, 11252, 11234
5070, 10973, 10981, 10982, 10974, 11252, 11253, 11254, 11236
5071, 10974, 10982, 10983, 10975, 11254, 11255, 11256, 11238
5072, 10975, 10983, 10984, 10976, 11256, 11257, 11258, 11240
5073, 10976, 10984, 1261, 1260, 11258, 11259, 1283, 11242
5074, 1206, 1207, 10985, 10977, 1229, 11260, 11261, 11243
5075, 10977, 10985, 10986, 10978, 11261, 11262, 11263, 11245
5076, 10978, 10986, 10987, 10979, 11263, 11264, 11265, 11247
5077, 10979, 10987, 10988, 10980, 11265, 11266, 11267, 11249
5078, 10980, 10988, 10989, 10981, 11267, 11268, 11269, 11251
5079, 10981, 10989, 10990, 10982, 11269, 11270, 11271, 11253
5080, 10982, 10990, 10991, 10983, 11271, 11272, 11273, 11255
5081, 10983, 10991, 10992, 10984, 11273, 11274, 11275, 11257
5082, 10984, 10992, 1262, 1261, 11275, 11276, 1284, 11259
5083, 1207, 1208, 10993, 10985, 1230, 11277, 11278, 11260
5084, 10985, 10993, 10994, 10986, 11278, 11279, 11280, 11262
5085, 10986, 10994, 10995, 10987, 11280, 11281, 11282, 11264
5086, 10987, 10995, 10996, 10988, 11282, 11283, 11284, 11266
5087, 10988, 10996, 10997, 10989, 11284, 11285, 11286, 11268
5088, 10989, 10997, 10998, 10990, 11286, 11287, 11288, 11270
5089, 10990, 10998, 10999, 10991, 11288, 11289, 11290, 11272
5090, 10991, 10999, 11000, 10992, 11290, 11291, 11292, 11274
5091, 10992, 11000, 1263, 1262, 11292, 11293, 1285, 11276
5092, 1208, 1209, 11001, 10993, 1231, 11294, 11295, 11277
5093, 10993, 11001, 11002, 10994, 11295, 11296, 11297, 11279
5094, 10994, 11002, 11003, 10995, 11297, 11298, 11299, 11281
5095, 10995, 11003, 11004, 10996, 11299, 11300, 11301, 11283
5096, 10996, 11004, 11005, 10997, 11301, 11302, 11303, 11285
5097, 10997, 11005, 11006, 10998, 11303, 11304, 11305, 11287
5098, 10998, 11006, 11007, 10999, 11305, 11306, 11307, 11289
5099, 10999, 11007, 11008, 11000, 11307, 11308, 11309, 11291
5100, 11000, 11008, 1264, 1263, 11309, 11310, 1286, 11293
5101, 1209, 1210, 11009, 11001, 1232, 11311, 11312, 11294
5102, 11001, 11009, 11010, 11002, 11312, 11313, 11314, 11296
5103, 11002, 11010, 11011, 11003, 11314, 11315, 11316, 11298
5104, 11003, 11011, 11012, 11004, 11316, 11317, 11318, 11300
5105, 11004, 11012, 11013, 11005, 11318, 11319, 11320, 11302
5106, 11005, 11013, 11014, 11006, 11320, 11321, 11322, 11304
5107, 11006, 11014, 11015, 11007, 11322, 11323, 11324, 11306
5108, 11007, 11015, 11016, 11008, 11324, 11325, 11326, 11308
5109, 11008, 11016, 1265, 1264, 11326, 11327, 1287, 11310
5110, 1210, 1211, 11017, 11009, 1233, 11328, 11329, 11311
5111, 11009, 11017, 11018, 11010, 11329, 11330, 11331, 11313
5112, 11010, 11018, 11019, 11011, 11331, 11332, 11333, 11315
5113, 11011, 11019, 11020, 11012, 11333, 11334, 11335, 11317
5114, 11012, 11020, 11021, 11013, 11335, 11336, 11337, 11319
5115, 11013, 11021, 11022, 11014, 11337, 11338, 11339, 11321
5116, 11014, 11022, 11023, 11015, 11339, 11340, 11341, 11323
5117, 11015, 11023, 11024, 11016, 11341, 11342, 11343, 11325
5118, 11016, 11024, 1266, 1265, 11343, 11344, 1288, 11327
5119, 1211, 1212, 11025, 11017, 1234, 11345, 11346, 11328
5120, 11017, 11025, 11026, 11018, 11346, 11347, 11348, 11330
5121, 11018, 11026, 11027, 11019, 11348, 11349, 11350, 11332
5122, 11019, 11027, 11028, 11020, 11350, 11351, 11352, 11334
5123, 11020, 11028, 11029, 11021, 11352, 11353, 11354, 11336
5124, 11021, 11029, 11030, 11022, 11354, 11355, 11356, 11338
5125, 11022, 11030, 11031, 11023, 11356, 11357, 11358, 11340
5126, 11023, 11031, 11032, 11024, 11358, 11359, 11360, 11342
5127, 11024, 11032, 1267, 1266, 11360, 11361, 1289, 11344
5128, 1212, 1213, 11033, 11025, 1235, 11362, 11363, 11345
5129, 11025, 11033, 11034, 11026, 11363, 11364, 11365, 11347
5130, 11026, 11034, 11035, 11027, 11365, 11366, 11367, 11349
5131, 11027, 11035, 11036, 11028, 11367, 11368, 11369, 11351
5132, 11028, 11036, 11037, 11029, 11369, 11370, 11371, 11353
5133, 11029, 11037, 11038, 11030, 11371, 11372, 11373, 11355
5134, 11030, 11038, 11039, 11031, 11373, 11374, 11375, 11357
5135, 11031, 11039, 11040, 11032, 11375, 11376, 11377, 11359
5136, 11032, 11040, 1268, 1267, 11377, 11378, 1290, 11361
5137, 1213, 1214, 11041, 11033, 1236, 11379, 11380, 11362
5138, 11033, 11041, 11042, 11034, 11380, 11381, 11382, 11364
5139, 11034, 11042, 11043, 11035, 11382, 11383, 11384, 11366
5140, 11035, 11043, 11044, 11036, 11384, 11385, 11386, 11368
5141, 11036, 11044, 11045, 11037, 11386, 11387, 11388, 11370
5142, 11037, 11045, 11046, 11038, 11388, 11389, 11390, 11372
5143, 11038, 11046, 11047, 11039, 11390, 11391, 11392, 11374
5144, 11039, 11047, 11048, 11040, 11392, 11393, 11394, 11376
5145, 11040, 11048, 1269, 1268, 11394, 11395, 1291, 11378
5146, 1214, 1215, 11049, 11041, 1237, 11396, 11397, 11379
5147, 11041, 11049, 11050, 11042, 11397, 11398, 11399, 11381
5148, 11042, 11050, 11051, 11043, 11399, 11400, 11401, 11383
5149, 11043, 11051, 11052, 11044, 11401, 11402, 11403, 11385
5150, 11044, 11052, 11053, 11045, 11403, 11404, 11405, 11387
5151, 11045, 11053, 11054, 11046, 11405, 11406, 11407, 11389
5152, 11046, 11054, 11055, 11047, 11407, 11408, 11409, 11391
5153, 11047, 11055, 11056, 11048, 11409, 11410, 11411, 11393
5154, 11048, 11056, 1270, 1269, 11411, 11412, 1292, 11395
5155, 1215, 1216, 11057, 11049, 1238, 11413, 11414, 11396
5156, 11049, 11057, 11058, 11050, 11414, 11415, 11416, 11398
5157, 11050, 11058, 11059, 11051, 11416, 11417, 11418, 11400
5158, 11051, 11059, 11060, 11052, 11418, 11419, 11420, 11402
5159, 11052, 11060, 11061, 11053, 11420, 11421, 11422, 11404
5160, 11053, 11061, 11062, 11054, 11422, 11423, 11424, 11406
5161, 11054, 11062, 11063, 11055, 11424, 11425, 11426, 11408
5162, 11055, 11063, 11064, 11056, 11426, 11427, 11428, 11410
5163, 11056, 11064, 1271, 1270, 11428, 11429, 1293, 11412
5164, 1216, 1217, 11065, 11057, 1239, 11430, 11431, 11413
5165, 11057, 11065, 11066, 11058, 11431, 11432, 11433, 11415
5166, 11058, 11066, 11067, 11059, 11433, 11434, 11435, 11417
5167, 11059, 11067, 11068, 11060, 11435, 11436, 11437, 11419
5168, 11060, 11068, 11069, 11061, 11437, 11438, 11439, 11421
5169, 11061, 11069, 11070, 11062, 11439, 11440, 11441, 11423
5170, 11062, 11070, 11071, 11063, 11441, 11442, 11443, 11425
5171, 11063, 11071, 11072, 11064, 11443, 11444, 11445, 11427
5172, 11064, 11072, 1272, 1271, 11445, 11446, 1294, 11429
5173, 1217, 36, 1320, 11065, 1240, 1329, 11447, 11430
5174, 11065, 1320, 1319, 11066, 11447, 1328, 11448, 11432
5175, 11066, 1319, 1318, 11067, 11448, 1327, 11449, 11434
5176, 11067, 1318, 1317, 11068, 11449, 1326, 11450, 11436
5177, 11068, 1317, 1316, 11069, 11450, 1325, 11451, 11438
5178, 11069, 1316, 1315, 11070, 11451, 1324, 11452, 11440
5179, 11070, 1315, 1314, 11071, 11452, 1323, 11453, 11442
5180, 11071, 1314, 1313, 11072, 11453, 1322, 11454, 11444
5181, 11072, 1313, 38, 1272, 11454, 1321, 1295, 11446
*ELEMENT, type=CPS8, ELSET=Surface197
5182, 36, 1191, 11455, 1330, 1193, 11457, 11458, 1331
5183, 1191, 1192, 11456, 11455, 1194, 11459, 11460, 11457
5184, 1192, 31, 1333, 11456, 1195, 1334, 11461, 11459
5185, 1330, 11455, 1336, 39, 11458, 11462, 1338, 1332
5186, 11455, 11456, 1337, 1336, 11460, 11463, 1339, 11462
5187, 11456, 1333, 40, 1337, 11461, 1335, 1340, 11463
*ELEMENT, type=CPS8, ELSET=Surface198
5188, 38, 1341, 11464, 1246, 1342, 11466, 11467, 1248
5189, 1246, 11464, 11465, 1247, 11467, 11468, 11469, 1249
5190, 1247, 11465, 1344, 33, 11469, 11470, 1345, 1250
5191, 1341, 41, 1347, 11464, 1343, 1349, 11471, 11466
5192, 11464, 1347, 1348, 11465, 11471, 1350, 11472, 11468
5193, 11465, 1348, 42, 1344, 11472, 1351, 1346, 11470
*ELEMENT, type=CPS8, ELSET=Surface199
5194, 36, 1330, 11473, 1320, 1331, 11481, 11482, 1329
5195, 1320, 11473, 11474, 1319, 11482, 11483, 11484, 1328
5196, 1319, 11474, 11475, 1318, 11484, 11485, 11486, 1327
5197, 1318, 11475, 11476, 1317, 11486, 11487, 11488, 1326
5198, 1317, 11476, 11477, 1316, 11488, 11489, 11490, 1325
5199, 1316, 11477, 11478, 1315, 11490, 11491, 11492, 1324
5200, 1315, 11478, 11479, 1314, 11492, 11493, 11494, 1323
5201, 1314, 11479, 11480, 1313, 11494, 11495, 11496, 1322
5202, 1313, 11480, 1341, 38, 11496, 11497, 1342, 1321
5203, 1330, 39, 1359, 11473, 1332, 1368, 11498, 11481
5204, 11473, 1359, 1358, 11474, 11498, 1367, 11499, 11483
5205, 11474, 1358, 1357, 11475, 11499, 1366, 11500, 11485
5206, 11475, 1357, 1356, 11476, 11500, 1365, 11501, 11487
5207, 11476, 1356, 1355, 11477, 11501, 1364, 11502, 11489
5208, 11477, 1355, 1354, 11478, 11502, 1363, 11503, 11491
5209, 11478, 1354, 1353, 11479, 11503, 1362, 11504, 11493
5210, 11479, 1353, 1352, 11480, 11504, 1361, 11505, 11495
5211, 11480, 1352, 41, 1341, 11505, 1360, 1343, 11497
*ELEMENT, type=CPS8, ELSET=Surface200
5212, 31, 1159, 11506, 1333, 1168, 11514, 11515, 1334
5213, 1159, 1158, 11507, 11506, 1167, 11516, 11517, 11514
5214, 1158, 1157, 11508, 11507, 1166, 11518, 11519, 11516
5215, 1157, 1156, 11509, 11508, 1165, 11520, 11521, 11518
5216, 1156, 1155, 11510, 11509, 1164, 11522, 11523, 11520
5217, 1155, 1154, 11511, 11510, 1163, 11524, 11525, 11522
5218, 1154, 1153, 11512, 11511, 1162, 11526, 11527, 11524
5219, 1153, 1152, 11513, 11512, 1161, 11528, 11529, 11526
5220, 1152, 33, 1344, 11513, 1160, 1345, 11530, 11528
5221, 1333, 11506, 1376, 40, 11515, 11531, 1385, 1335
5222, 11506, 11507, 1375, 1376, 11517, 11532, 1384, 11531
5223, 11507, 11508, 1374, 1375, 11519, 11533, 1383, 11532
5224, 11508, 11509, 1373, 1374, 11521, 11534, 1382, 11533
5225, 11509, 11510, 1372, 1373, 11523, 11535, 1381, 11534
5226, 11510, 11511, 1371, 1372, 11525, 11536, 1380, 11535
5227, 11511, 11512, 1370, 1371, 11527, 11537, 1379, 11536
5228, 11512, 11513, 1369, 1370, 11529, 11538, 1378, 11537
5229, 11513, 1344, 42, 1369, 11530, 1346, 1377, 11538
*ELEMENT, type=CPS8, ELSET=Surface201
5230, 39, 1336, 11539, 1359, 1338, 11555, 11556, 1368
5231, 1359, 11539, 11540, 1358, 11556, 11557, 11558, 1367
5232, 1358, 11540, 11541, 1357, 11558, 11559, 11560, 1366
5233, 1357, 11541, 11542, 1356, 11560, 11561, 11562, 1365
5234, 1356, 11542, 11543, 1355, 11562, 11563, 11564, 1364
5235, 1355, 11543, 11544, 1354, 11564, 11565, 11566, 1363
5236, 1354, 11544, 11545, 1353, 11566, 11567, 11568, 1362
5237, 1353, 11545, 11546, 1352, 11568, 11569, 11570, 1361
5238, 1352, 11546, 1347, 41, 11570, 11571, 1349, 1360
5239, 1336, 1337, 11547, 11539, 1339, 11572, 11573, 11555
5240, 11539, 11547, 11548, 11540, 11573, 11574, 11575, 11557
5241, 11540, 11548, 11549, 11541, 11575, 11576, 11577, 11559
5242, 11541, 11549, 11550, 11542, 11577, 11578, 11579, 11561
5243, 11542, 11550, 11551, 11543, 11579, 11580, 11581, 11563
5244, 11543, 11551, 11552, 11544, 11581, 11582, 11583, 11565
5245, 11544, 11552, 11553, 11545, 11583, 11584, 11585, 11567
5246, 11545, 11553, 11554, 11546, 11585, 11586, 11587, 11569
5247, 11546, 11554, 1348, 1347, 11587, 11588, 1350, 11571
5248, 1337, 40, 1376, 11547, 1340, 1385, 11589, 11572
5249, 11547, 1376, 1375, 11548, 11589, 1384, 11590, 11574
5250, 11548, 1375, 1374, 11549, 11590, 1383, 11591, 11576
5251, 11549, 1374, 1373, 11550, 11591, 1382, 11592, 11578
5252, 11550, 1373, 1372, 11551, 11592, 1381, 11593, 11580
5253, 11551, 1372, 1371, 11552, 11593, 1380, 11594, 11582
5254, 11552, 1371, 1370, 11553, 11594, 1379, 11595, 11584
5255, 11553, 1370, 1369, 11554, 11595, 1378, 11596, 11586
5256, 11554, 1369, 42, 1348, 11596, 1377, 1351, 11588
*ELEMENT, type=CPS8, ELSET=Surface202
5257, 31, 958, 11597, 1333, 961, 11600, 11601, 1334
5258, 1333, 11597, 1386, 40, 11601, 11602, 1389, 1335
5259, 958, 959, 11598, 11597, 962, 11603, 11604, 11600
5260, 11597, 11598, 1387, 1386, 11604, 11605, 1390, 11602
5261, 959, 960, 11599, 11598, 963, 11606, 11607, 11603
5262, 11598, 11599, 1388, 1387, 11607, 11608, 1391, 11605
5263, 960, 32, 1393, 11599, 964, 1394, 11609, 11606
5264, 11599, 1393, 43, 1388, 11609, 1395, 1392, 11608
*ELEMENT, type=CPS8, ELSET=Surface203
5265, 33, 1344, 11610, 1055, 1345, 11613, 11614, 1058
5266, 1344, 42, 1396, 11610, 1346, 1399, 11615, 11613
5267, 1055, 11610, 11611, 1056, 11614, 11616, 11617, 1059
5268, 11610, 1396, 1397, 11611, 11615, 1400, 11618, 11616
5269, 1056, 11611, 11612, 1057, 11617, 11619, 11620, 1060
5270, 11611, 1397, 1398, 11612, 11618, 1401, 11621, 11619
5271, 1057, 11612, 1403, 34, 11620, 11622, 1404, 1061
5272, 11612, 1398, 44, 1403, 11621, 1402, 1405, 11622
*ELEMENT, type=CPS8, ELSET=Surface204
5273, 40, 1386, 11623, 1376, 1389, 11647, 11648, 1385
5274, 1376, 11623, 11624, 1375, 11648, 11649, 11650, 1384
5275, 1375, 11624, 11625, 1374, 11650, 11651, 11652, 1383
5276, 1374, 11625, 11626, 1373, 11652, 11653, 11654, 1382
5277, 1373, 11626, 11627, 1372, 11654, 11655, 11656, 1381
5278, 1372, 11627, 11628, 1371, 11656, 11657, 11658, 1380
5279, 1371, 11628, 11629, 1370, 11658, 11659, 11660, 1379
5280, 1370, 11629, 11630, 1369, 11660, 11661, 11662, 1378
5281, 1369, 11630, 1396, 42, 11662, 11663, 1399, 1377
5282, 1386, 1387, 11631, 11623, 1390, 11664, 11665, 11647
5283, 11623, 11631, 11632, 11624, 11665, 11666, 11667, 11649
5284, 11624, 11632, 11633, 11625, 11667, 11668, 11669, 11651
5285, 11625, 11633, 11634, 11626, 11669, 11670, 11671, 11653
5286, 11626, 11634, 11635, 11627, 11671, 11672, 11673, 11655
5287, 11627, 11635, 11636, 11628, 11673, 11674, 11675, 11657
5288, 11628, 11636, 11637, 11629, 11675, 11676, 11677, 11659
5289, 11629, 11637, 11638, 11630, 11677, 11678, 11679, 11661
5290, 11630, 11638, 1397, 1396, 11679, 11680, 1400, 11663
5291, 1387, 1388, 11639, 11631, 1391, 11681, 11682, 11664
5292, 11631, 11639, 11640, 11632, 11682, 11683, 11684, 11666
5293, 11632, 11640, 11641, 11633, 11684, 11685, 11686, 11668
5294, 11633, 11641, 11642, 11634, 11686, 11687, 11688, 11670
5295, 11634, 11642, 11643, 11635, 11688, 11689, 11690, 11672
5296, 11635, 11643, 11644, 11636, 11690, 11691, 11692, 11674
5297, 11636, 11644, 11645, 11637, 11692, 11693, 11694, 11676
5298, 11637, 11645, 11646, 11638, 11694, 11695, 11696, 11678
5299, 11638, 11646, 1398, 1397, 11696, 11697, 1401, 11680
5300, 1388, 43, 1413, 11639, 1392, 1422, 11698, 11681
5301, 11639, 1413, 1412, 11640, 11698, 1421, 11699, 11683
5302, 11640, 1412, 1411, 11641, 11699, 1420, 11700, 11685
5303, 11641, 1411, 1410, 11642, 11700, 1419, 11701, 11687
5304, 11642, 1410, 1409, 11643, 11701, 1418, 11702, 11689
5305, 11643, 1409, 1408, 11644, 11702, 1417, 11703, 11691
5306, 11644, 1408, 1407, 11645, 11703, 1416, 11704, 11693
5307, 11645, 1407, 1406, 11646, 11704, 1415, 11705, 11695
5308, 11646, 1406, 44, 1398, 11705, 1414, 1402, 11697
*ELEMENT, type=CPS8, ELSET=Surface205
5309, 32, 1176, 11706, 1393, 1185, 11714, 11715, 1394
5310, 1176, 1175, 11707, 11706, 1184, 11716, 11717, 11714
5311, 1175, 1174, 11708, 11707, 1183, 11718, 11719, 11716
