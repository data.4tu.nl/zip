12752, 0.17391304347826, 1.55, 0.22222222222222
12753, 0.17391304347826, 1.55, 0.27777777777778
12754, 0.17391304347826, 1.55, 0.33333333333333
12755, 0.17391304347826, 1.55, 0.38888888888889
12756, 0.17391304347826, 1.55, 0.44444444444444
12757, 0.21739130434783, 1.55, 0.055555555555556
12758, 0.21739130434783, 1.55, 0.11111111111111
12759, 0.21739130434783, 1.55, 0.16666666666667
12760, 0.21739130434783, 1.55, 0.22222222222222
12761, 0.21739130434783, 1.55, 0.27777777777778
12762, 0.21739130434783, 1.55, 0.33333333333333
12763, 0.21739130434783, 1.55, 0.38888888888889
12764, 0.21739130434783, 1.55, 0.44444444444444
12765, 0.26086956521739, 1.55, 0.055555555555556
12766, 0.26086956521739, 1.55, 0.11111111111111
12767, 0.26086956521739, 1.55, 0.16666666666667
12768, 0.26086956521739, 1.55, 0.22222222222222
12769, 0.26086956521739, 1.55, 0.27777777777778
12770, 0.26086956521739, 1.55, 0.33333333333333
12771, 0.26086956521739, 1.55, 0.38888888888889
12772, 0.26086956521739, 1.55, 0.44444444444444
12773, 0.30434782608696, 1.55, 0.055555555555556
12774, 0.30434782608696, 1.55, 0.11111111111111
12775, 0.30434782608696, 1.55, 0.16666666666667
12776, 0.30434782608696, 1.55, 0.22222222222222
12777, 0.30434782608696, 1.55, 0.27777777777778
12778, 0.30434782608696, 1.55, 0.33333333333333
12779, 0.30434782608696, 1.55, 0.38888888888889
12780, 0.30434782608696, 1.55, 0.44444444444444
12781, 0.34782608695652, 1.55, 0.055555555555556
12782, 0.34782608695652, 1.55, 0.11111111111111
12783, 0.34782608695652, 1.55, 0.16666666666667
12784, 0.34782608695652, 1.55, 0.22222222222222
12785, 0.34782608695652, 1.55, 0.27777777777778
12786, 0.34782608695652, 1.55, 0.33333333333333
12787, 0.34782608695652, 1.55, 0.38888888888889
12788, 0.34782608695652, 1.55, 0.44444444444444
12789, 0.39130434782609, 1.55, 0.055555555555556
12790, 0.39130434782609, 1.55, 0.11111111111111
12791, 0.39130434782609, 1.55, 0.16666666666667
12792, 0.39130434782609, 1.55, 0.22222222222222
12793, 0.39130434782609, 1.55, 0.27777777777778
12794, 0.39130434782609, 1.55, 0.33333333333333
12795, 0.39130434782609, 1.55, 0.38888888888889
12796, 0.39130434782609, 1.55, 0.44444444444444
12797, 0.43478260869565, 1.55, 0.055555555555556
12798, 0.43478260869565, 1.55, 0.11111111111111
12799, 0.43478260869565, 1.55, 0.16666666666667
12800, 0.43478260869565, 1.55, 0.22222222222222
12801, 0.43478260869565, 1.55, 0.27777777777778
12802, 0.43478260869565, 1.55, 0.33333333333333
12803, 0.43478260869565, 1.55, 0.38888888888889
12804, 0.43478260869565, 1.55, 0.44444444444444
12805, 0.47826086956522, 1.55, 0.055555555555556
12806, 0.47826086956522, 1.55, 0.11111111111111
12807, 0.47826086956522, 1.55, 0.16666666666667
12808, 0.47826086956522, 1.55, 0.22222222222222
12809, 0.47826086956522, 1.55, 0.27777777777778
12810, 0.47826086956522, 1.55, 0.33333333333333
12811, 0.47826086956522, 1.55, 0.38888888888889
12812, 0.47826086956522, 1.55, 0.44444444444444
12813, 0.52173913043478, 1.55, 0.055555555555556
12814, 0.52173913043478, 1.55, 0.11111111111111
12815, 0.52173913043478, 1.55, 0.16666666666667
12816, 0.52173913043478, 1.55, 0.22222222222222
12817, 0.52173913043478, 1.55, 0.27777777777778
12818, 0.52173913043478, 1.55, 0.33333333333333
12819, 0.52173913043478, 1.55, 0.38888888888889
12820, 0.52173913043478, 1.55, 0.44444444444444
12821, 0.56521739130435, 1.55, 0.055555555555556
12822, 0.56521739130435, 1.55, 0.11111111111111
12823, 0.56521739130435, 1.55, 0.16666666666667
12824, 0.56521739130435, 1.55, 0.22222222222222
12825, 0.56521739130435, 1.55, 0.27777777777778
12826, 0.56521739130435, 1.55, 0.33333333333333
12827, 0.56521739130435, 1.55, 0.38888888888889
12828, 0.56521739130435, 1.55, 0.44444444444444
12829, 0.60869565217391, 1.55, 0.055555555555556
12830, 0.60869565217391, 1.55, 0.11111111111111
12831, 0.60869565217391, 1.55, 0.16666666666667
12832, 0.60869565217391, 1.55, 0.22222222222222
12833, 0.60869565217391, 1.55, 0.27777777777778
12834, 0.60869565217391, 1.55, 0.33333333333333
12835, 0.60869565217391, 1.55, 0.38888888888889
12836, 0.60869565217391, 1.55, 0.44444444444444
12837, 0.65217391304348, 1.55, 0.055555555555556
12838, 0.65217391304348, 1.55, 0.11111111111111
12839, 0.65217391304348, 1.55, 0.16666666666667
12840, 0.65217391304348, 1.55, 0.22222222222222
12841, 0.65217391304348, 1.55, 0.27777777777778
12842, 0.65217391304348, 1.55, 0.33333333333333
12843, 0.65217391304348, 1.55, 0.38888888888889
12844, 0.65217391304348, 1.55, 0.44444444444444
12845, 0.69565217391304, 1.55, 0.055555555555556
12846, 0.69565217391304, 1.55, 0.11111111111111
12847, 0.69565217391304, 1.55, 0.16666666666667
12848, 0.69565217391304, 1.55, 0.22222222222222
12849, 0.69565217391304, 1.55, 0.27777777777778
12850, 0.69565217391304, 1.55, 0.33333333333333
12851, 0.69565217391304, 1.55, 0.38888888888889
12852, 0.69565217391304, 1.55, 0.44444444444444
12853, 0.73913043478261, 1.55, 0.055555555555556
12854, 0.73913043478261, 1.55, 0.11111111111111
12855, 0.73913043478261, 1.55, 0.16666666666667
12856, 0.73913043478261, 1.55, 0.22222222222222
12857, 0.73913043478261, 1.55, 0.27777777777778
12858, 0.73913043478261, 1.55, 0.33333333333333
12859, 0.73913043478261, 1.55, 0.38888888888889
12860, 0.73913043478261, 1.55, 0.44444444444444
12861, 0.78260869565217, 1.55, 0.055555555555556
12862, 0.78260869565217, 1.55, 0.11111111111111
12863, 0.78260869565217, 1.55, 0.16666666666667
12864, 0.78260869565217, 1.55, 0.22222222222222
12865, 0.78260869565217, 1.55, 0.27777777777778
12866, 0.78260869565217, 1.55, 0.33333333333333
12867, 0.78260869565217, 1.55, 0.38888888888889
12868, 0.78260869565217, 1.55, 0.44444444444444
12869, 0.82608695652174, 1.55, 0.055555555555556
12870, 0.82608695652174, 1.55, 0.11111111111111
12871, 0.82608695652174, 1.55, 0.16666666666667
12872, 0.82608695652174, 1.55, 0.22222222222222
12873, 0.82608695652174, 1.55, 0.27777777777778
12874, 0.82608695652174, 1.55, 0.33333333333333
12875, 0.82608695652174, 1.55, 0.38888888888889
12876, 0.82608695652174, 1.55, 0.44444444444444
12877, 0.8695652173913, 1.55, 0.055555555555556
12878, 0.8695652173913, 1.55, 0.11111111111111
12879, 0.8695652173913, 1.55, 0.16666666666667
12880, 0.8695652173913, 1.55, 0.22222222222222
12881, 0.8695652173913, 1.55, 0.27777777777778
12882, 0.8695652173913, 1.55, 0.33333333333333
12883, 0.8695652173913, 1.55, 0.38888888888889
12884, 0.8695652173913, 1.55, 0.44444444444444
12885, 0.91304347826087, 1.55, 0.055555555555556
12886, 0.91304347826087, 1.55, 0.11111111111111
12887, 0.91304347826087, 1.55, 0.16666666666667
12888, 0.91304347826087, 1.55, 0.22222222222222
12889, 0.91304347826087, 1.55, 0.27777777777778
12890, 0.91304347826087, 1.55, 0.33333333333333
12891, 0.91304347826087, 1.55, 0.38888888888889
12892, 0.91304347826087, 1.55, 0.44444444444444
12893, 0.95652173913043, 1.55, 0.055555555555556
12894, 0.95652173913043, 1.55, 0.11111111111111
12895, 0.95652173913043, 1.55, 0.16666666666667
12896, 0.95652173913043, 1.55, 0.22222222222222
12897, 0.95652173913043, 1.55, 0.27777777777778
12898, 0.95652173913043, 1.55, 0.33333333333333
12899, 0.95652173913043, 1.55, 0.38888888888889
12900, 0.95652173913043, 1.55, 0.44444444444444
12901, 0.021739130434783, 1.55, 0.055555555555556
12902, 0.043478260869565, 1.55, 0.027777777777778
12903, 0.021739130434783, 1.55, 0.11111111111111
12904, 0.043478260869565, 1.55, 0.083333333333333
12905, 0.021739130434783, 1.55, 0.16666666666667
12906, 0.043478260869565, 1.55, 0.13888888888889
12907, 0.021739130434783, 1.55, 0.22222222222222
12908, 0.043478260869565, 1.55, 0.19444444444444
12909, 0.021739130434783, 1.55, 0.27777777777778
12910, 0.043478260869565, 1.55, 0.25
12911, 0.021739130434783, 1.55, 0.33333333333333
12912, 0.043478260869565, 1.55, 0.30555555555556
12913, 0.021739130434783, 1.55, 0.38888888888889
12914, 0.043478260869565, 1.55, 0.36111111111111
12915, 0.021739130434783, 1.55, 0.44444444444444
12916, 0.043478260869565, 1.55, 0.41666666666667
12917, 0.043478260869565, 1.55, 0.47222222222222
12918, 0.065217391304348, 1.55, 0.055555555555556
12919, 0.08695652173913, 1.55, 0.027777777777778
12920, 0.065217391304348, 1.55, 0.11111111111111
12921, 0.08695652173913, 1.55, 0.083333333333333
12922, 0.065217391304348, 1.55, 0.16666666666667
12923, 0.08695652173913, 1.55, 0.13888888888889
12924, 0.065217391304348, 1.55, 0.22222222222222
12925, 0.08695652173913, 1.55, 0.19444444444444
12926, 0.065217391304348, 1.55, 0.27777777777778
12927, 0.08695652173913, 1.55, 0.25
12928, 0.065217391304348, 1.55, 0.33333333333333
12929, 0.08695652173913, 1.55, 0.30555555555556
12930, 0.065217391304348, 1.55, 0.38888888888889
12931, 0.08695652173913, 1.55, 0.36111111111111
12932, 0.065217391304348, 1.55, 0.44444444444444
12933, 0.08695652173913, 1.55, 0.41666666666667
12934, 0.08695652173913, 1.55, 0.47222222222222
12935, 0.10869565217391, 1.55, 0.055555555555556
12936, 0.1304347826087, 1.55, 0.027777777777778
12937, 0.10869565217391, 1.55, 0.11111111111111
12938, 0.1304347826087, 1.55, 0.083333333333333
12939, 0.10869565217391, 1.55, 0.16666666666667
12940, 0.1304347826087, 1.55, 0.13888888888889
12941, 0.10869565217391, 1.55, 0.22222222222222
12942, 0.1304347826087, 1.55, 0.19444444444444
12943, 0.10869565217391, 1.55, 0.27777777777778
12944, 0.1304347826087, 1.55, 0.25
12945, 0.10869565217391, 1.55, 0.33333333333333
12946, 0.1304347826087, 1.55, 0.30555555555556
12947, 0.10869565217391, 1.55, 0.38888888888889
12948, 0.1304347826087, 1.55, 0.36111111111111
12949, 0.10869565217391, 1.55, 0.44444444444444
12950, 0.1304347826087, 1.55, 0.41666666666667
12951, 0.1304347826087, 1.55, 0.47222222222222
12952, 0.15217391304348, 1.55, 0.055555555555556
12953, 0.17391304347826, 1.55, 0.027777777777778
12954, 0.15217391304348, 1.55, 0.11111111111111
12955, 0.17391304347826, 1.55, 0.083333333333333
12956, 0.15217391304348, 1.55, 0.16666666666667
12957, 0.17391304347826, 1.55, 0.13888888888889
12958, 0.15217391304348, 1.55, 0.22222222222222
12959, 0.17391304347826, 1.55, 0.19444444444444
12960, 0.15217391304348, 1.55, 0.27777777777778
12961, 0.17391304347826, 1.55, 0.25
12962, 0.15217391304348, 1.55, 0.33333333333333
12963, 0.17391304347826, 1.55, 0.30555555555556
12964, 0.15217391304348, 1.55, 0.38888888888889
12965, 0.17391304347826, 1.55, 0.36111111111111
12966, 0.15217391304348, 1.55, 0.44444444444444
12967, 0.17391304347826, 1.55, 0.41666666666667
12968, 0.17391304347826, 1.55, 0.47222222222222
12969, 0.19565217391304, 1.55, 0.055555555555556
12970, 0.21739130434783, 1.55, 0.027777777777778
12971, 0.19565217391304, 1.55, 0.11111111111111
12972, 0.21739130434783, 1.55, 0.083333333333333
12973, 0.19565217391304, 1.55, 0.16666666666667
12974, 0.21739130434783, 1.55, 0.13888888888889
12975, 0.19565217391304, 1.55, 0.22222222222222
12976, 0.21739130434783, 1.55, 0.19444444444444
12977, 0.19565217391304, 1.55, 0.27777777777778
12978, 0.21739130434783, 1.55, 0.25
12979, 0.19565217391304, 1.55, 0.33333333333333
12980, 0.21739130434783, 1.55, 0.30555555555556
12981, 0.19565217391304, 1.55, 0.38888888888889
12982, 0.21739130434783, 1.55, 0.36111111111111
12983, 0.19565217391304, 1.55, 0.44444444444444
12984, 0.21739130434783, 1.55, 0.41666666666667
12985, 0.21739130434783, 1.55, 0.47222222222222
12986, 0.23913043478261, 1.55, 0.055555555555556
12987, 0.26086956521739, 1.55, 0.027777777777778
12988, 0.23913043478261, 1.55, 0.11111111111111
12989, 0.26086956521739, 1.55, 0.083333333333333
12990, 0.23913043478261, 1.55, 0.16666666666667
12991, 0.26086956521739, 1.55, 0.13888888888889
12992, 0.23913043478261, 1.55, 0.22222222222222
12993, 0.26086956521739, 1.55, 0.19444444444444
12994, 0.23913043478261, 1.55, 0.27777777777778
12995, 0.26086956521739, 1.55, 0.25
12996, 0.23913043478261, 1.55, 0.33333333333333
12997, 0.26086956521739, 1.55, 0.30555555555556
12998, 0.23913043478261, 1.55, 0.38888888888889
12999, 0.26086956521739, 1.55, 0.36111111111111
13000, 0.23913043478261, 1.55, 0.44444444444444
13001, 0.26086956521739, 1.55, 0.41666666666667
13002, 0.26086956521739, 1.55, 0.47222222222222
13003, 0.28260869565217, 1.55, 0.055555555555556
13004, 0.30434782608696, 1.55, 0.027777777777778
13005, 0.28260869565217, 1.55, 0.11111111111111
13006, 0.30434782608696, 1.55, 0.083333333333333
13007, 0.28260869565217, 1.55, 0.16666666666667
13008, 0.30434782608696, 1.55, 0.13888888888889
13009, 0.28260869565217, 1.55, 0.22222222222222
13010, 0.30434782608696, 1.55, 0.19444444444444
13011, 0.28260869565217, 1.55, 0.27777777777778
13012, 0.30434782608696, 1.55, 0.25
13013, 0.28260869565217, 1.55, 0.33333333333333
13014, 0.30434782608696, 1.55, 0.30555555555556
13015, 0.28260869565217, 1.55, 0.38888888888889
13016, 0.30434782608696, 1.55, 0.36111111111111
13017, 0.28260869565217, 1.55, 0.44444444444444
13018, 0.30434782608696, 1.55, 0.41666666666667
13019, 0.30434782608696, 1.55, 0.47222222222222
13020, 0.32608695652174, 1.55, 0.055555555555556
13021, 0.34782608695652, 1.55, 0.027777777777778
13022, 0.32608695652174, 1.55, 0.11111111111111
13023, 0.34782608695652, 1.55, 0.083333333333333
13024, 0.32608695652174, 1.55, 0.16666666666667
13025, 0.34782608695652, 1.55, 0.13888888888889
13026, 0.32608695652174, 1.55, 0.22222222222222
13027, 0.34782608695652, 1.55, 0.19444444444444
13028, 0.32608695652174, 1.55, 0.27777777777778
13029, 0.34782608695652, 1.55, 0.25
13030, 0.32608695652174, 1.55, 0.33333333333333
13031, 0.34782608695652, 1.55, 0.30555555555556
13032, 0.32608695652174, 1.55, 0.38888888888889
13033, 0.34782608695652, 1.55, 0.36111111111111
13034, 0.32608695652174, 1.55, 0.44444444444444
13035, 0.34782608695652, 1.55, 0.41666666666667
13036, 0.34782608695652, 1.55, 0.47222222222222
13037, 0.3695652173913, 1.55, 0.055555555555556
13038, 0.39130434782609, 1.55, 0.027777777777778
13039, 0.3695652173913, 1.55, 0.11111111111111
13040, 0.39130434782609, 1.55, 0.083333333333333
13041, 0.3695652173913, 1.55, 0.16666666666667
13042, 0.39130434782609, 1.55, 0.13888888888889
13043, 0.3695652173913, 1.55, 0.22222222222222
13044, 0.39130434782609, 1.55, 0.19444444444444
13045, 0.3695652173913, 1.55, 0.27777777777778
13046, 0.39130434782609, 1.55, 0.25
13047, 0.3695652173913, 1.55, 0.33333333333333
13048, 0.39130434782609, 1.55, 0.30555555555556
13049, 0.3695652173913, 1.55, 0.38888888888889
13050, 0.39130434782609, 1.55, 0.36111111111111
13051, 0.3695652173913, 1.55, 0.44444444444444
13052, 0.39130434782609, 1.55, 0.41666666666667
13053, 0.39130434782609, 1.55, 0.47222222222222
13054, 0.41304347826087, 1.55, 0.055555555555556
13055, 0.43478260869565, 1.55, 0.027777777777778
13056, 0.41304347826087, 1.55, 0.11111111111111
13057, 0.43478260869565, 1.55, 0.083333333333333
13058, 0.41304347826087, 1.55, 0.16666666666667
13059, 0.43478260869565, 1.55, 0.13888888888889
13060, 0.41304347826087, 1.55, 0.22222222222222
13061, 0.43478260869565, 1.55, 0.19444444444444
13062, 0.41304347826087, 1.55, 0.27777777777778
13063, 0.43478260869565, 1.55, 0.25
13064, 0.41304347826087, 1.55, 0.33333333333333
13065, 0.43478260869565, 1.55, 0.30555555555556
13066, 0.41304347826087, 1.55, 0.38888888888889
13067, 0.43478260869565, 1.55, 0.36111111111111
13068, 0.41304347826087, 1.55, 0.44444444444444
13069, 0.43478260869565, 1.55, 0.41666666666667
13070, 0.43478260869565, 1.55, 0.47222222222222
13071, 0.45652173913043, 1.55, 0.055555555555556
13072, 0.47826086956522, 1.55, 0.027777777777778
13073, 0.45652173913043, 1.55, 0.11111111111111
13074, 0.47826086956522, 1.55, 0.083333333333333
13075, 0.45652173913043, 1.55, 0.16666666666667
13076, 0.47826086956522, 1.55, 0.13888888888889
13077, 0.45652173913043, 1.55, 0.22222222222222
13078, 0.47826086956522, 1.55, 0.19444444444444
13079, 0.45652173913043, 1.55, 0.27777777777778
13080, 0.47826086956522, 1.55, 0.25
13081, 0.45652173913043, 1.55, 0.33333333333333
13082, 0.47826086956522, 1.55, 0.30555555555556
13083, 0.45652173913043, 1.55, 0.38888888888889
13084, 0.47826086956522, 1.55, 0.36111111111111
13085, 0.45652173913043, 1.55, 0.44444444444444
13086, 0.47826086956522, 1.55, 0.41666666666667
13087, 0.47826086956522, 1.55, 0.47222222222222
13088, 0.5, 1.55, 0.055555555555556
13089, 0.52173913043478, 1.55, 0.027777777777778
13090, 0.5, 1.55, 0.11111111111111
13091, 0.52173913043478, 1.55, 0.083333333333333
13092, 0.5, 1.55, 0.16666666666667
13093, 0.52173913043478, 1.55, 0.13888888888889
13094, 0.5, 1.55, 0.22222222222222
13095, 0.52173913043478, 1.55, 0.19444444444444
13096, 0.5, 1.55, 0.27777777777778
13097, 0.52173913043478, 1.55, 0.25
13098, 0.5, 1.55, 0.33333333333333
13099, 0.52173913043478, 1.55, 0.30555555555556
13100, 0.5, 1.55, 0.38888888888889
13101, 0.52173913043478, 1.55, 0.36111111111111
13102, 0.5, 1.55, 0.44444444444444
13103, 0.52173913043478, 1.55, 0.41666666666667
13104, 0.52173913043478, 1.55, 0.47222222222222
13105, 0.54347826086957, 1.55, 0.055555555555556
13106, 0.56521739130435, 1.55, 0.027777777777778
13107, 0.54347826086957, 1.55, 0.11111111111111
13108, 0.56521739130435, 1.55, 0.083333333333333
13109, 0.54347826086957, 1.55, 0.16666666666667
13110, 0.56521739130435, 1.55, 0.13888888888889
13111, 0.54347826086957, 1.55, 0.22222222222222
13112, 0.56521739130435, 1.55, 0.19444444444444
13113, 0.54347826086957, 1.55, 0.27777777777778
13114, 0.56521739130435, 1.55, 0.25
13115, 0.54347826086957, 1.55, 0.33333333333333
13116, 0.56521739130435, 1.55, 0.30555555555556
13117, 0.54347826086957, 1.55, 0.38888888888889
13118, 0.56521739130435, 1.55, 0.36111111111111
13119, 0.54347826086957, 1.55, 0.44444444444444
13120, 0.56521739130435, 1.55, 0.41666666666667
13121, 0.56521739130435, 1.55, 0.47222222222222
13122, 0.58695652173913, 1.55, 0.055555555555556
13123, 0.60869565217391, 1.55, 0.027777777777778
13124, 0.58695652173913, 1.55, 0.11111111111111
13125, 0.60869565217391, 1.55, 0.083333333333333
13126, 0.58695652173913, 1.55, 0.16666666666667
13127, 0.60869565217391, 1.55, 0.13888888888889
13128, 0.58695652173913, 1.55, 0.22222222222222
13129, 0.60869565217391, 1.55, 0.19444444444444
13130, 0.58695652173913, 1.55, 0.27777777777778
13131, 0.60869565217391, 1.55, 0.25
13132, 0.58695652173913, 1.55, 0.33333333333333
13133, 0.60869565217391, 1.55, 0.30555555555556
13134, 0.58695652173913, 1.55, 0.38888888888889
13135, 0.60869565217391, 1.55, 0.36111111111111
13136, 0.58695652173913, 1.55, 0.44444444444444
13137, 0.60869565217391, 1.55, 0.41666666666667
13138, 0.60869565217391, 1.55, 0.47222222222222
13139, 0.6304347826087, 1.55, 0.055555555555556
13140, 0.65217391304348, 1.55, 0.027777777777778
13141, 0.6304347826087, 1.55, 0.11111111111111
13142, 0.65217391304348, 1.55, 0.083333333333333
13143, 0.6304347826087, 1.55, 0.16666666666667
13144, 0.65217391304348, 1.55, 0.13888888888889
13145, 0.6304347826087, 1.55, 0.22222222222222
13146, 0.65217391304348, 1.55, 0.19444444444444
13147, 0.6304347826087, 1.55, 0.27777777777778
13148, 0.65217391304348, 1.55, 0.25
13149, 0.6304347826087, 1.55, 0.33333333333333
13150, 0.65217391304348, 1.55, 0.30555555555556
13151, 0.6304347826087, 1.55, 0.38888888888889
13152, 0.65217391304348, 1.55, 0.36111111111111
13153, 0.6304347826087, 1.55, 0.44444444444444
13154, 0.65217391304348, 1.55, 0.41666666666667
13155, 0.65217391304348, 1.55, 0.47222222222222
13156, 0.67391304347826, 1.55, 0.055555555555556
13157, 0.69565217391304, 1.55, 0.027777777777778
13158, 0.67391304347826, 1.55, 0.11111111111111
13159, 0.69565217391304, 1.55, 0.083333333333333
13160, 0.67391304347826, 1.55, 0.16666666666667
13161, 0.69565217391304, 1.55, 0.13888888888889
13162, 0.67391304347826, 1.55, 0.22222222222222
13163, 0.69565217391304, 1.55, 0.19444444444444
13164, 0.67391304347826, 1.55, 0.27777777777778
13165, 0.69565217391304, 1.55, 0.25
13166, 0.67391304347826, 1.55, 0.33333333333333
13167, 0.69565217391304, 1.55, 0.30555555555556
13168, 0.67391304347826, 1.55, 0.38888888888889
13169, 0.69565217391304, 1.55, 0.36111111111111
13170, 0.67391304347826, 1.55, 0.44444444444444
13171, 0.69565217391304, 1.55, 0.41666666666667
13172, 0.69565217391304, 1.55, 0.47222222222222
13173, 0.71739130434783, 1.55, 0.055555555555556
13174, 0.73913043478261, 1.55, 0.027777777777778
13175, 0.71739130434783, 1.55, 0.11111111111111
13176, 0.73913043478261, 1.55, 0.083333333333333
13177, 0.71739130434783, 1.55, 0.16666666666667
13178, 0.73913043478261, 1.55, 0.13888888888889
13179, 0.71739130434783, 1.55, 0.22222222222222
13180, 0.73913043478261, 1.55, 0.19444444444444
13181, 0.71739130434783, 1.55, 0.27777777777778
13182, 0.73913043478261, 1.55, 0.25
13183, 0.71739130434783, 1.55, 0.33333333333333
13184, 0.73913043478261, 1.55, 0.30555555555556
13185, 0.71739130434783, 1.55, 0.38888888888889
13186, 0.73913043478261, 1.55, 0.36111111111111
13187, 0.71739130434783, 1.55, 0.44444444444444
13188, 0.73913043478261, 1.55, 0.41666666666667
13189, 0.73913043478261, 1.55, 0.47222222222222
13190, 0.76086956521739, 1.55, 0.055555555555556
13191, 0.78260869565217, 1.55, 0.027777777777778
13192, 0.76086956521739, 1.55, 0.11111111111111
13193, 0.78260869565217, 1.55, 0.083333333333333
13194, 0.76086956521739, 1.55, 0.16666666666667
13195, 0.78260869565217, 1.55, 0.13888888888889
13196, 0.76086956521739, 1.55, 0.22222222222222
13197, 0.78260869565217, 1.55, 0.19444444444444
13198, 0.76086956521739, 1.55, 0.27777777777778
13199, 0.78260869565217, 1.55, 0.25
13200, 0.76086956521739, 1.55, 0.33333333333333
13201, 0.78260869565217, 1.55, 0.30555555555556
13202, 0.76086956521739, 1.55, 0.38888888888889
13203, 0.78260869565217, 1.55, 0.36111111111111
13204, 0.76086956521739, 1.55, 0.44444444444444
13205, 0.78260869565217, 1.55, 0.41666666666667
13206, 0.78260869565217, 1.55, 0.47222222222222
13207, 0.80434782608696, 1.55, 0.055555555555556
13208, 0.82608695652174, 1.55, 0.027777777777778
13209, 0.80434782608696, 1.55, 0.11111111111111
13210, 0.82608695652174, 1.55, 0.083333333333333
13211, 0.80434782608696, 1.55, 0.16666666666667
13212, 0.82608695652174, 1.55, 0.13888888888889
13213, 0.80434782608696, 1.55, 0.22222222222222
13214, 0.82608695652174, 1.55, 0.19444444444444
13215, 0.80434782608696, 1.55, 0.27777777777778
13216, 0.82608695652174, 1.55, 0.25
13217, 0.80434782608696, 1.55, 0.33333333333333
13218, 0.82608695652174, 1.55, 0.30555555555556
13219, 0.80434782608696, 1.55, 0.38888888888889
13220, 0.82608695652174, 1.55, 0.36111111111111
13221, 0.80434782608696, 1.55, 0.44444444444444
13222, 0.82608695652174, 1.55, 0.41666666666667
13223, 0.82608695652174, 1.55, 0.47222222222222
13224, 0.84782608695652, 1.55, 0.055555555555556
13225, 0.8695652173913, 1.55, 0.027777777777778
13226, 0.84782608695652, 1.55, 0.11111111111111
13227, 0.8695652173913, 1.55, 0.083333333333333
13228, 0.84782608695652, 1.55, 0.16666666666667
13229, 0.8695652173913, 1.55, 0.13888888888889
13230, 0.84782608695652, 1.55, 0.22222222222222
13231, 0.8695652173913, 1.55, 0.19444444444444
13232, 0.84782608695652, 1.55, 0.27777777777778
13233, 0.8695652173913, 1.55, 0.25
13234, 0.84782608695652, 1.55, 0.33333333333333
13235, 0.8695652173913, 1.55, 0.30555555555556
13236, 0.84782608695652, 1.55, 0.38888888888889
13237, 0.8695652173913, 1.55, 0.36111111111111
13238, 0.84782608695652, 1.55, 0.44444444444444
13239, 0.8695652173913, 1.55, 0.41666666666667
13240, 0.8695652173913, 1.55, 0.47222222222222
13241, 0.89130434782609, 1.55, 0.055555555555556
13242, 0.91304347826087, 1.55, 0.027777777777778
13243, 0.89130434782609, 1.55, 0.11111111111111
13244, 0.91304347826087, 1.55, 0.083333333333333
13245, 0.89130434782609, 1.55, 0.16666666666667
13246, 0.91304347826087, 1.55, 0.13888888888889
13247, 0.89130434782609, 1.55, 0.22222222222222
13248, 0.91304347826087, 1.55, 0.19444444444444
13249, 0.89130434782609, 1.55, 0.27777777777778
13250, 0.91304347826087, 1.55, 0.25
13251, 0.89130434782609, 1.55, 0.33333333333333
13252, 0.91304347826087, 1.55, 0.30555555555556
13253, 0.89130434782609, 1.55, 0.38888888888889
13254, 0.91304347826087, 1.55, 0.36111111111111
13255, 0.89130434782609, 1.55, 0.44444444444444
13256, 0.91304347826087, 1.55, 0.41666666666667
13257, 0.91304347826087, 1.55, 0.47222222222222
13258, 0.93478260869565, 1.55, 0.055555555555556
13259, 0.95652173913043, 1.55, 0.027777777777778
13260, 0.93478260869565, 1.55, 0.11111111111111
13261, 0.95652173913043, 1.55, 0.083333333333333
13262, 0.93478260869565, 1.55, 0.16666666666667
13263, 0.95652173913043, 1.55, 0.13888888888889
13264, 0.93478260869565, 1.55, 0.22222222222222
13265, 0.95652173913043, 1.55, 0.19444444444444
13266, 0.93478260869565, 1.55, 0.27777777777778
13267, 0.95652173913043, 1.55, 0.25
13268, 0.93478260869565, 1.55, 0.33333333333333
13269, 0.95652173913043, 1.55, 0.30555555555556
13270, 0.93478260869565, 1.55, 0.38888888888889
13271, 0.95652173913043, 1.55, 0.36111111111111
13272, 0.93478260869565, 1.55, 0.44444444444444
13273, 0.95652173913043, 1.55, 0.41666666666667
13274, 0.95652173913043, 1.55, 0.47222222222222
13275, 0.97826086956522, 1.55, 0.055555555555556
13276, 0.97826086956522, 1.55, 0.11111111111111
13277, 0.97826086956522, 1.55, 0.16666666666667
13278, 0.97826086956522, 1.55, 0.22222222222222
13279, 0.97826086956522, 1.55, 0.27777777777778
13280, 0.97826086956522, 1.55, 0.33333333333333
13281, 0.97826086956522, 1.55, 0.38888888888889
13282, 0.97826086956522, 1.55, 0.44444444444444
13283, 1.05, 1.4833333333333, 0.5
13284, 1.05, 1.5166666666667, 0.5
13285, 1.1, 1.4833333333333, 0.5
13286, 1.1, 1.5166666666667, 0.5
13287, 1.15, 1.4833333333333, 0.5
13288, 1.15, 1.5166666666667, 0.5
13289, 1.05, 1.4666666666667, 0.5
13290, 1.025, 1.4833333333333, 0.5
13291, 1.05, 1.5, 0.5
13292, 1.025, 1.5166666666667, 0.5
13293, 1.05, 1.5333333333333, 0.5
13294, 1.1, 1.4666666666667, 0.5
13295, 1.075, 1.4833333333333, 0.5
13296, 1.1, 1.5, 0.5
13297, 1.075, 1.5166666666667, 0.5
13298, 1.1, 1.5333333333333, 0.5
13299, 1.15, 1.4666666666667, 0.5
13300, 1.125, 1.4833333333333, 0.5
13301, 1.15, 1.5, 0.5
13302, 1.125, 1.5166666666667, 0.5
13303, 1.15, 1.5333333333333, 0.5
13304, 1.175, 1.4833333333333, 0.5
13305, 1.175, 1.5166666666667, 0.5
13306, 1.05, 1.4833333333333, 0
13307, 1.05, 1.5166666666667, 0
13308, 1.1, 1.4833333333333, 0
13309, 1.1, 1.5166666666667, 0
13310, 1.15, 1.4833333333333, 0
13311, 1.15, 1.5166666666667, 0
13312, 1.025, 1.4833333333333, 0
13313, 1.05, 1.4666666666667, 0
13314, 1.025, 1.5166666666667, 0
13315, 1.05, 1.5, 0
13316, 1.05, 1.5333333333333, 0
13317, 1.075, 1.4833333333333, 0
13318, 1.1, 1.4666666666667, 0
13319, 1.075, 1.5166666666667, 0
13320, 1.1, 1.5, 0
13321, 1.1, 1.5333333333333, 0
13322, 1.125, 1.4833333333333, 0
13323, 1.15, 1.4666666666667, 0
13324, 1.125, 1.5166666666667, 0
13325, 1.15, 1.5, 0
13326, 1.15, 1.5333333333333, 0
13327, 1.175, 1.4833333333333, 0
13328, 1.175, 1.5166666666667, 0
13329, 1.05, 1.45, 0.44444444444444
13330, 1.05, 1.45, 0.38888888888889
13331, 1.05, 1.45, 0.33333333333333
13332, 1.05, 1.45, 0.27777777777778
13333, 1.05, 1.45, 0.22222222222222
13334, 1.05, 1.45, 0.16666666666667
13335, 1.05, 1.45, 0.11111111111111
13336, 1.05, 1.45, 0.055555555555556
13337, 1.1, 1.45, 0.44444444444444
13338, 1.1, 1.45, 0.38888888888889
13339, 1.1, 1.45, 0.33333333333333
13340, 1.1, 1.45, 0.27777777777778
13341, 1.1, 1.45, 0.22222222222222
13342, 1.1, 1.45, 0.16666666666667
13343, 1.1, 1.45, 0.11111111111111
13344, 1.1, 1.45, 0.055555555555556
13345, 1.15, 1.45, 0.44444444444444
13346, 1.15, 1.45, 0.38888888888889
13347, 1.15, 1.45, 0.33333333333333
13348, 1.15, 1.45, 0.27777777777778
13349, 1.15, 1.45, 0.22222222222222
13350, 1.15, 1.45, 0.16666666666667
13351, 1.15, 1.45, 0.11111111111111
13352, 1.15, 1.45, 0.055555555555556
13353, 1.025, 1.45, 0.44444444444444
13354, 1.05, 1.45, 0.47222222222222
13355, 1.025, 1.45, 0.38888888888889
13356, 1.05, 1.45, 0.41666666666667
13357, 1.025, 1.45, 0.33333333333333
13358, 1.05, 1.45, 0.36111111111111
13359, 1.025, 1.45, 0.27777777777778
13360, 1.05, 1.45, 0.30555555555556
13361, 1.025, 1.45, 0.22222222222222
13362, 1.05, 1.45, 0.25
13363, 1.025, 1.45, 0.16666666666667
13364, 1.05, 1.45, 0.19444444444444
13365, 1.025, 1.45, 0.11111111111111
13366, 1.05, 1.45, 0.13888888888889
13367, 1.025, 1.45, 0.055555555555556
13368, 1.05, 1.45, 0.083333333333333
13369, 1.05, 1.45, 0.027777777777778
13370, 1.075, 1.45, 0.44444444444444
13371, 1.1, 1.45, 0.47222222222222
13372, 1.075, 1.45, 0.38888888888889
13373, 1.1, 1.45, 0.41666666666667
13374, 1.075, 1.45, 0.33333333333333
13375, 1.1, 1.45, 0.36111111111111
13376, 1.075, 1.45, 0.27777777777778
13377, 1.1, 1.45, 0.30555555555556
13378, 1.075, 1.45, 0.22222222222222
13379, 1.1, 1.45, 0.25
13380, 1.075, 1.45, 0.16666666666667
13381, 1.1, 1.45, 0.19444444444444
13382, 1.075, 1.45, 0.11111111111111
13383, 1.1, 1.45, 0.13888888888889
13384, 1.075, 1.45, 0.055555555555556
13385, 1.1, 1.45, 0.083333333333333
13386, 1.1, 1.45, 0.027777777777778
13387, 1.125, 1.45, 0.44444444444444
13388, 1.15, 1.45, 0.47222222222222
13389, 1.125, 1.45, 0.38888888888889
13390, 1.15, 1.45, 0.41666666666667
13391, 1.125, 1.45, 0.33333333333333
13392, 1.15, 1.45, 0.36111111111111
13393, 1.125, 1.45, 0.27777777777778
13394, 1.15, 1.45, 0.30555555555556
13395, 1.125, 1.45, 0.22222222222222
13396, 1.15, 1.45, 0.25
13397, 1.125, 1.45, 0.16666666666667
13398, 1.15, 1.45, 0.19444444444444
13399, 1.125, 1.45, 0.11111111111111
13400, 1.15, 1.45, 0.13888888888889
13401, 1.125, 1.45, 0.055555555555556
13402, 1.15, 1.45, 0.083333333333333
13403, 1.15, 1.45, 0.027777777777778
13404, 1.175, 1.45, 0.44444444444444
13405, 1.175, 1.45, 0.38888888888889
13406, 1.175, 1.45, 0.33333333333333
13407, 1.175, 1.45, 0.27777777777778
13408, 1.175, 1.45, 0.22222222222222
13409, 1.175, 1.45, 0.16666666666667
13410, 1.175, 1.45, 0.11111111111111
13411, 1.175, 1.45, 0.055555555555556
13412, 1.05, 1.55, 0.44444444444444
13413, 1.05, 1.55, 0.38888888888889
13414, 1.05, 1.55, 0.33333333333333
13415, 1.05, 1.55, 0.27777777777778
13416, 1.05, 1.55, 0.22222222222222
13417, 1.05, 1.55, 0.16666666666667
13418, 1.05, 1.55, 0.11111111111111
13419, 1.05, 1.55, 0.055555555555556
13420, 1.1, 1.55, 0.44444444444444
13421, 1.1, 1.55, 0.38888888888889
13422, 1.1, 1.55, 0.33333333333333
13423, 1.1, 1.55, 0.27777777777778
13424, 1.1, 1.55, 0.22222222222222
13425, 1.1, 1.55, 0.16666666666667
13426, 1.1, 1.55, 0.11111111111111
13427, 1.1, 1.55, 0.055555555555556
13428, 1.15, 1.55, 0.44444444444444
13429, 1.15, 1.55, 0.38888888888889
13430, 1.15, 1.55, 0.33333333333333
13431, 1.15, 1.55, 0.27777777777778
13432, 1.15, 1.55, 0.22222222222222
13433, 1.15, 1.55, 0.16666666666667
13434, 1.15, 1.55, 0.11111111111111
13435, 1.15, 1.55, 0.055555555555556
13436, 1.05, 1.55, 0.47222222222222
13437, 1.025, 1.55, 0.44444444444444
13438, 1.05, 1.55, 0.41666666666667
13439, 1.025, 1.55, 0.38888888888889
13440, 1.05, 1.55, 0.36111111111111
13441, 1.025, 1.55, 0.33333333333333
13442, 1.05, 1.55, 0.30555555555556
13443, 1.025, 1.55, 0.27777777777778
13444, 1.05, 1.55, 0.25
13445, 1.025, 1.55, 0.22222222222222
13446, 1.05, 1.55, 0.19444444444444
13447, 1.025, 1.55, 0.16666666666667
13448, 1.05, 1.55, 0.13888888888889
13449, 1.025, 1.55, 0.11111111111111
13450, 1.05, 1.55, 0.083333333333333
13451, 1.025, 1.55, 0.055555555555556
13452, 1.05, 1.55, 0.027777777777778
13453, 1.1, 1.55, 0.47222222222222
13454, 1.075, 1.55, 0.44444444444444
13455, 1.1, 1.55, 0.41666666666667
13456, 1.075, 1.55, 0.38888888888889
13457, 1.1, 1.55, 0.36111111111111
13458, 1.075, 1.55, 0.33333333333333
13459, 1.1, 1.55, 0.30555555555556
13460, 1.075, 1.55, 0.27777777777778
13461, 1.1, 1.55, 0.25
13462, 1.075, 1.55, 0.22222222222222
13463, 1.1, 1.55, 0.19444444444444
13464, 1.075, 1.55, 0.16666666666667
13465, 1.1, 1.55, 0.13888888888889
13466, 1.075, 1.55, 0.11111111111111
13467, 1.1, 1.55, 0.083333333333333
13468, 1.075, 1.55, 0.055555555555556
13469, 1.1, 1.55, 0.027777777777778
13470, 1.15, 1.55, 0.47222222222222
13471, 1.125, 1.55, 0.44444444444444
13472, 1.15, 1.55, 0.41666666666667
13473, 1.125, 1.55, 0.38888888888889
13474, 1.15, 1.55, 0.36111111111111
13475, 1.125, 1.55, 0.33333333333333
13476, 1.15, 1.55, 0.30555555555556
13477, 1.125, 1.55, 0.27777777777778
13478, 1.15, 1.55, 0.25
13479, 1.125, 1.55, 0.22222222222222
13480, 1.15, 1.55, 0.19444444444444
13481, 1.125, 1.55, 0.16666666666667
13482, 1.15, 1.55, 0.13888888888889
13483, 1.125, 1.55, 0.11111111111111
13484, 1.15, 1.55, 0.083333333333333
13485, 1.125, 1.55, 0.055555555555556
13486, 1.15, 1.55, 0.027777777777778
13487, 1.175, 1.55, 0.44444444444444
13488, 1.175, 1.55, 0.38888888888889
13489, 1.175, 1.55, 0.33333333333333
13490, 1.175, 1.55, 0.27777777777778
13491, 1.175, 1.55, 0.22222222222222
13492, 1.175, 1.55, 0.16666666666667
13493, 1.175, 1.55, 0.11111111111111
13494, 1.175, 1.55, 0.055555555555556
13495, 1.2, 1.4833333333333, 0.44444444444444
13496, 1.2, 1.4833333333333, 0.38888888888889
13497, 1.2, 1.4833333333333, 0.33333333333333
13498, 1.2, 1.4833333333333, 0.27777777777778
13499, 1.2, 1.4833333333333, 0.22222222222222
13500, 1.2, 1.4833333333333, 0.16666666666667
13501, 1.2, 1.4833333333333, 0.11111111111111
13502, 1.2, 1.4833333333333, 0.055555555555556
13503, 1.2, 1.5166666666667, 0.44444444444444
13504, 1.2, 1.5166666666667, 0.38888888888889
13505, 1.2, 1.5166666666667, 0.33333333333333
13506, 1.2, 1.5166666666667, 0.27777777777778
13507, 1.2, 1.5166666666667, 0.22222222222222
13508, 1.2, 1.5166666666667, 0.16666666666667
13509, 1.2, 1.5166666666667, 0.11111111111111
13510, 1.2, 1.5166666666667, 0.055555555555556
13511, 1.2, 1.4666666666667, 0.44444444444444
13512, 1.2, 1.4833333333333, 0.47222222222222
13513, 1.2, 1.4666666666667, 0.38888888888889
13514, 1.2, 1.4833333333333, 0.41666666666667
13515, 1.2, 1.4666666666667, 0.33333333333333
13516, 1.2, 1.4833333333333, 0.36111111111111
13517, 1.2, 1.4666666666667, 0.27777777777778
13518, 1.2, 1.4833333333333, 0.30555555555556
13519, 1.2, 1.4666666666667, 0.22222222222222
13520, 1.2, 1.4833333333333, 0.25
13521, 1.2, 1.4666666666667, 0.16666666666667
13522, 1.2, 1.4833333333333, 0.19444444444444
13523, 1.2, 1.4666666666667, 0.11111111111111
13524, 1.2, 1.4833333333333, 0.13888888888889
13525, 1.2, 1.4666666666667, 0.055555555555556
13526, 1.2, 1.4833333333333, 0.083333333333333
13527, 1.2, 1.4833333333333, 0.027777777777778
13528, 1.2, 1.5, 0.44444444444444
13529, 1.2, 1.5166666666667, 0.47222222222222
13530, 1.2, 1.5, 0.38888888888889
13531, 1.2, 1.5166666666667, 0.41666666666667
13532, 1.2, 1.5, 0.33333333333333
13533, 1.2, 1.5166666666667, 0.36111111111111
13534, 1.2, 1.5, 0.27777777777778
13535, 1.2, 1.5166666666667, 0.30555555555556
13536, 1.2, 1.5, 0.22222222222222
13537, 1.2, 1.5166666666667, 0.25
13538, 1.2, 1.5, 0.16666666666667
13539, 1.2, 1.5166666666667, 0.19444444444444
13540, 1.2, 1.5, 0.11111111111111
13541, 1.2, 1.5166666666667, 0.13888888888889
13542, 1.2, 1.5, 0.055555555555556
13543, 1.2, 1.5166666666667, 0.083333333333333
13544, 1.2, 1.5166666666667, 0.027777777777778
13545, 1.2, 1.5333333333333, 0.44444444444444
13546, 1.2, 1.5333333333333, 0.38888888888889
13547, 1.2, 1.5333333333333, 0.33333333333333
13548, 1.2, 1.5333333333333, 0.27777777777778
13549, 1.2, 1.5333333333333, 0.22222222222222
13550, 1.2, 1.5333333333333, 0.16666666666667
13551, 1.2, 1.5333333333333, 0.11111111111111
13552, 1.2, 1.5333333333333, 0.055555555555556
13553, 1.05, 1.6, 0.5
13554, 1.1, 1.6, 0.5
13555, 1.15, 1.6, 0.5
13556, 1.05, 1.65, 0.5
13557, 1.1, 1.65, 0.5
13558, 1.15, 1.65, 0.5
13559, 1.05, 1.7, 0.5
13560, 1.1, 1.7, 0.5
13561, 1.15, 1.7, 0.5
13562, 1.05, 1.575, 0.5
13563, 1.025, 1.6, 0.5
13564, 1.1, 1.575, 0.5
13565, 1.075, 1.6, 0.5
13566, 1.15, 1.575, 0.5
13567, 1.125, 1.6, 0.5
13568, 1.175, 1.6, 0.5
13569, 1.05, 1.625, 0.5
13570, 1.025, 1.65, 0.5
13571, 1.1, 1.625, 0.5
13572, 1.075, 1.65, 0.5
13573, 1.15, 1.625, 0.5
13574, 1.125, 1.65, 0.5
13575, 1.175, 1.65, 0.5
13576, 1.05, 1.675, 0.5
13577, 1.025, 1.7, 0.5
13578, 1.1, 1.675, 0.5
13579, 1.075, 1.7, 0.5
13580, 1.15, 1.675, 0.5
13581, 1.125, 1.7, 0.5
13582, 1.175, 1.7, 0.5
13583, 1.05, 1.725, 0.5
13584, 1.1, 1.725, 0.5
13585, 1.15, 1.725, 0.5
13586, 1.05, 1.6, 0
13587, 1.1, 1.6, 0
13588, 1.15, 1.6, 0
13589, 1.05, 1.65, 0
13590, 1.1, 1.65, 0
13591, 1.15, 1.65, 0
13592, 1.05, 1.7, 0
13593, 1.1, 1.7, 0
13594, 1.15, 1.7, 0
13595, 1.025, 1.6, 0
13596, 1.05, 1.575, 0
13597, 1.075, 1.6, 0
13598, 1.1, 1.575, 0
13599, 1.125, 1.6, 0
13600, 1.15, 1.575, 0
13601, 1.175, 1.6, 0
13602, 1.025, 1.65, 0
13603, 1.05, 1.625, 0
13604, 1.075, 1.65, 0
13605, 1.1, 1.625, 0
13606, 1.125, 1.65, 0
13607, 1.15, 1.625, 0
13608, 1.175, 1.65, 0
13609, 1.025, 1.7, 0
13610, 1.05, 1.675, 0
13611, 1.075, 1.7, 0
13612, 1.1, 1.675, 0
13613, 1.125, 1.7, 0
13614, 1.15, 1.675, 0
13615, 1.175, 1.7, 0
13616, 1.05, 1.725, 0
13617, 1.1, 1.725, 0
13618, 1.15, 1.725, 0
13619, 1, 1.6, 0.44444444444444
13620, 1, 1.6, 0.38888888888889
13621, 1, 1.6, 0.33333333333333
13622, 1, 1.6, 0.27777777777778
13623, 1, 1.6, 0.22222222222222
13624, 1, 1.6, 0.16666666666667
13625, 1, 1.6, 0.11111111111111
13626, 1, 1.6, 0.055555555555556
13627, 1, 1.65, 0.44444444444444
13628, 1, 1.65, 0.38888888888889
13629, 1, 1.65, 0.33333333333333
13630, 1, 1.65, 0.27777777777778
13631, 1, 1.65, 0.22222222222222
13632, 1, 1.65, 0.16666666666667
13633, 1, 1.65, 0.11111111111111
13634, 1, 1.65, 0.055555555555556
13635, 1, 1.7, 0.44444444444444
13636, 1, 1.7, 0.38888888888889
13637, 1, 1.7, 0.33333333333333
13638, 1, 1.7, 0.27777777777778
13639, 1, 1.7, 0.22222222222222
13640, 1, 1.7, 0.16666666666667
13641, 1, 1.7, 0.11111111111111
13642, 1, 1.7, 0.055555555555556
13643, 1, 1.6, 0.47222222222222
13644, 1, 1.575, 0.44444444444444
13645, 1, 1.6, 0.41666666666667
13646, 1, 1.575, 0.38888888888889
13647, 1, 1.6, 0.36111111111111
13648, 1, 1.575, 0.33333333333333
13649, 1, 1.6, 0.30555555555556
13650, 1, 1.575, 0.27777777777778
13651, 1, 1.6, 0.25
13652, 1, 1.575, 0.22222222222222
13653, 1, 1.6, 0.19444444444444
13654, 1, 1.575, 0.16666666666667
13655, 1, 1.6, 0.13888888888889
13656, 1, 1.575, 0.11111111111111
13657, 1, 1.6, 0.083333333333333
13658, 1, 1.575, 0.055555555555556
13659, 1, 1.6, 0.027777777777778
13660, 1, 1.65, 0.47222222222222
13661, 1, 1.625, 0.44444444444444
13662, 1, 1.65, 0.41666666666667
13663, 1, 1.625, 0.38888888888889
13664, 1, 1.65, 0.36111111111111
13665, 1, 1.625, 0.33333333333333
13666, 1, 1.65, 0.30555555555556
13667, 1, 1.625, 0.27777777777778
13668, 1, 1.65, 0.25
13669, 1, 1.625, 0.22222222222222
13670, 1, 1.65, 0.19444444444444
13671, 1, 1.625, 0.16666666666667
13672, 1, 1.65, 0.13888888888889
13673, 1, 1.625, 0.11111111111111
13674, 1, 1.65, 0.083333333333333
13675, 1, 1.625, 0.055555555555556
13676, 1, 1.65, 0.027777777777778
13677, 1, 1.7, 0.47222222222222
13678, 1, 1.675, 0.44444444444444
13679, 1, 1.7, 0.41666666666667
13680, 1, 1.675, 0.38888888888889
13681, 1, 1.7, 0.36111111111111
13682, 1, 1.675, 0.33333333333333
13683, 1, 1.7, 0.30555555555556
13684, 1, 1.675, 0.27777777777778
13685, 1, 1.7, 0.25
13686, 1, 1.675, 0.22222222222222
13687, 1, 1.7, 0.19444444444444
13688, 1, 1.675, 0.16666666666667
13689, 1, 1.7, 0.13888888888889
13690, 1, 1.675, 0.11111111111111
13691, 1, 1.7, 0.083333333333333
13692, 1, 1.675, 0.055555555555556
13693, 1, 1.7, 0.027777777777778
13694, 1, 1.725, 0.44444444444444
13695, 1, 1.725, 0.38888888888889
13696, 1, 1.725, 0.33333333333333
13697, 1, 1.725, 0.27777777777778
13698, 1, 1.725, 0.22222222222222
13699, 1, 1.725, 0.16666666666667
13700, 1, 1.725, 0.11111111111111
13701, 1, 1.725, 0.055555555555556
13702, 1.2, 1.6, 0.44444444444444
13703, 1.2, 1.6, 0.38888888888889
13704, 1.2, 1.6, 0.33333333333333
13705, 1.2, 1.6, 0.27777777777778
13706, 1.2, 1.6, 0.22222222222222
13707, 1.2, 1.6, 0.16666666666667
13708, 1.2, 1.6, 0.11111111111111
13709, 1.2, 1.6, 0.055555555555556
13710, 1.2, 1.65, 0.44444444444444
13711, 1.2, 1.65, 0.38888888888889
13712, 1.2, 1.65, 0.33333333333333
13713, 1.2, 1.65, 0.27777777777778
13714, 1.2, 1.65, 0.22222222222222
13715, 1.2, 1.65, 0.16666666666667
13716, 1.2, 1.65, 0.11111111111111
13717, 1.2, 1.65, 0.055555555555556
13718, 1.2, 1.7, 0.44444444444444
13719, 1.2, 1.7, 0.38888888888889
13720, 1.2, 1.7, 0.33333333333333
13721, 1.2, 1.7, 0.27777777777778
13722, 1.2, 1.7, 0.22222222222222
13723, 1.2, 1.7, 0.16666666666667
13724, 1.2, 1.7, 0.11111111111111
13725, 1.2, 1.7, 0.055555555555556
13726, 1.2, 1.575, 0.44444444444444
13727, 1.2, 1.6, 0.47222222222222
13728, 1.2, 1.575, 0.38888888888889
13729, 1.2, 1.6, 0.41666666666667
13730, 1.2, 1.575, 0.33333333333333
13731, 1.2, 1.6, 0.36111111111111
13732, 1.2, 1.575, 0.27777777777778
13733, 1.2, 1.6, 0.30555555555556
13734, 1.2, 1.575, 0.22222222222222
13735, 1.2, 1.6, 0.25
13736, 1.2, 1.575, 0.16666666666667
13737, 1.2, 1.6, 0.19444444444444
13738, 1.2, 1.575, 0.11111111111111
13739, 1.2, 1.6, 0.13888888888889
13740, 1.2, 1.575, 0.055555555555556
13741, 1.2, 1.6, 0.083333333333333
13742, 1.2, 1.6, 0.027777777777778
13743, 1.2, 1.625, 0.44444444444444
13744, 1.2, 1.65, 0.47222222222222
13745, 1.2, 1.625, 0.38888888888889
13746, 1.2, 1.65, 0.41666666666667
13747, 1.2, 1.625, 0.33333333333333
13748, 1.2, 1.65, 0.36111111111111
13749, 1.2, 1.625, 0.27777777777778
13750, 1.2, 1.65, 0.30555555555556
13751, 1.2, 1.625, 0.22222222222222
13752, 1.2, 1.65, 0.25
13753, 1.2, 1.625, 0.16666666666667
13754, 1.2, 1.65, 0.19444444444444
13755, 1.2, 1.625, 0.11111111111111
13756, 1.2, 1.65, 0.13888888888889
13757, 1.2, 1.625, 0.055555555555556
13758, 1.2, 1.65, 0.083333333333333
13759, 1.2, 1.65, 0.027777777777778
13760, 1.2, 1.675, 0.44444444444444
13761, 1.2, 1.7, 0.47222222222222
13762, 1.2, 1.675, 0.38888888888889
13763, 1.2, 1.7, 0.41666666666667
13764, 1.2, 1.675, 0.33333333333333
13765, 1.2, 1.7, 0.36111111111111
13766, 1.2, 1.675, 0.27777777777778
13767, 1.2, 1.7, 0.30555555555556
13768, 1.2, 1.675, 0.22222222222222
13769, 1.2, 1.7, 0.25
13770, 1.2, 1.675, 0.16666666666667
13771, 1.2, 1.7, 0.19444444444444
13772, 1.2, 1.675, 0.11111111111111
13773, 1.2, 1.7, 0.13888888888889
13774, 1.2, 1.675, 0.055555555555556
13775, 1.2, 1.7, 0.083333333333333
13776, 1.2, 1.7, 0.027777777777778
13777, 1.2, 1.725, 0.44444444444444
13778, 1.2, 1.725, 0.38888888888889
13779, 1.2, 1.725, 0.33333333333333
13780, 1.2, 1.725, 0.27777777777778
13781, 1.2, 1.725, 0.22222222222222
13782, 1.2, 1.725, 0.16666666666667
13783, 1.2, 1.725, 0.11111111111111
13784, 1.2, 1.725, 0.055555555555556
13785, 1.05, 1.75, 0.44444444444444
13786, 1.05, 1.75, 0.38888888888889
13787, 1.05, 1.75, 0.33333333333333
13788, 1.05, 1.75, 0.27777777777778
13789, 1.05, 1.75, 0.22222222222222
13790, 1.05, 1.75, 0.16666666666667
13791, 1.05, 1.75, 0.11111111111111
13792, 1.05, 1.75, 0.055555555555556
13793, 1.1, 1.75, 0.44444444444444
13794, 1.1, 1.75, 0.38888888888889
13795, 1.1, 1.75, 0.33333333333333
13796, 1.1, 1.75, 0.27777777777778
13797, 1.1, 1.75, 0.22222222222222
13798, 1.1, 1.75, 0.16666666666667
13799, 1.1, 1.75, 0.11111111111111
13800, 1.1, 1.75, 0.055555555555556
13801, 1.15, 1.75, 0.44444444444444
13802, 1.15, 1.75, 0.38888888888889
13803, 1.15, 1.75, 0.33333333333333
13804, 1.15, 1.75, 0.27777777777778
13805, 1.15, 1.75, 0.22222222222222
13806, 1.15, 1.75, 0.16666666666667
13807, 1.15, 1.75, 0.11111111111111
13808, 1.15, 1.75, 0.055555555555556
13809, 1.05, 1.75, 0.47222222222222
13810, 1.025, 1.75, 0.44444444444444
13811, 1.05, 1.75, 0.41666666666667
13812, 1.025, 1.75, 0.38888888888889
13813, 1.05, 1.75, 0.36111111111111
13814, 1.025, 1.75, 0.33333333333333
13815, 1.05, 1.75, 0.30555555555556
13816, 1.025, 1.75, 0.27777777777778
13817, 1.05, 1.75, 0.25
13818, 1.025, 1.75, 0.22222222222222
13819, 1.05, 1.75, 0.19444444444444
13820, 1.025, 1.75, 0.16666666666667
13821, 1.05, 1.75, 0.13888888888889
13822, 1.025, 1.75, 0.11111111111111
13823, 1.05, 1.75, 0.083333333333333
13824, 1.025, 1.75, 0.055555555555556
13825, 1.05, 1.75, 0.027777777777778
13826, 1.1, 1.75, 0.47222222222222
13827, 1.075, 1.75, 0.44444444444444
13828, 1.1, 1.75, 0.41666666666667
13829, 1.075, 1.75, 0.38888888888889
13830, 1.1, 1.75, 0.36111111111111
13831, 1.075, 1.75, 0.33333333333333
13832, 1.1, 1.75, 0.30555555555556
13833, 1.075, 1.75, 0.27777777777778
13834, 1.1, 1.75, 0.25
13835, 1.075, 1.75, 0.22222222222222
13836, 1.1, 1.75, 0.19444444444444
13837, 1.075, 1.75, 0.16666666666667
13838, 1.1, 1.75, 0.13888888888889
13839, 1.075, 1.75, 0.11111111111111
13840, 1.1, 1.75, 0.083333333333333
13841, 1.075, 1.75, 0.055555555555556
13842, 1.1, 1.75, 0.027777777777778
13843, 1.15, 1.75, 0.47222222222222
13844, 1.125, 1.75, 0.44444444444444
13845, 1.15, 1.75, 0.41666666666667
13846, 1.125, 1.75, 0.38888888888889
13847, 1.15, 1.75, 0.36111111111111
13848, 1.125, 1.75, 0.33333333333333
13849, 1.15, 1.75, 0.30555555555556
13850, 1.125, 1.75, 0.27777777777778
13851, 1.15, 1.75, 0.25
13852, 1.125, 1.75, 0.22222222222222
13853, 1.15, 1.75, 0.19444444444444
13854, 1.125, 1.75, 0.16666666666667
13855, 1.15, 1.75, 0.13888888888889
13856, 1.125, 1.75, 0.11111111111111
13857, 1.15, 1.75, 0.083333333333333
13858, 1.125, 1.75, 0.055555555555556
13859, 1.15, 1.75, 0.027777777777778
13860, 1.175, 1.75, 0.44444444444444
13861, 1.175, 1.75, 0.38888888888889
13862, 1.175, 1.75, 0.33333333333333
13863, 1.175, 1.75, 0.27777777777778
13864, 1.175, 1.75, 0.22222222222222
13865, 1.175, 1.75, 0.16666666666667
13866, 1.175, 1.75, 0.11111111111111
13867, 1.175, 1.75, 0.055555555555556
13868, 0.95652173913043, 1.6, 0
13869, 0.91304347826087, 1.6, 0
13870, 0.8695652173913, 1.6, 0
13871, 0.82608695652174, 1.6, 0
13872, 0.78260869565217, 1.6, 0
13873, 0.73913043478261, 1.6, 0
13874, 0.69565217391304, 1.6, 0
13875, 0.65217391304348, 1.6, 0
13876, 0.60869565217391, 1.6, 0
13877, 0.56521739130435, 1.6, 0
13878, 0.52173913043478, 1.6, 0
13879, 0.47826086956522, 1.6, 0
13880, 0.43478260869565, 1.6, 0
13881, 0.39130434782609, 1.6, 0
13882, 0.34782608695652, 1.6, 0
13883, 0.30434782608696, 1.6, 0
13884, 0.26086956521739, 1.6, 0
13885, 0.21739130434783, 1.6, 0
13886, 0.17391304347826, 1.6, 0
13887, 0.1304347826087, 1.6, 0
13888, 0.08695652173913, 1.6, 0
13889, 0.043478260869565, 1.6, 0
13890, 0.95652173913043, 1.65, 0
13891, 0.91304347826087, 1.65, 0
13892, 0.8695652173913, 1.65, 0
13893, 0.82608695652174, 1.65, 0
13894, 0.78260869565217, 1.65, 0
13895, 0.73913043478261, 1.65, 0
13896, 0.69565217391304, 1.65, 0
13897, 0.65217391304348, 1.65, 0
13898, 0.60869565217391, 1.65, 0
13899, 0.56521739130435, 1.65, 0
13900, 0.52173913043478, 1.65, 0
13901, 0.47826086956522, 1.65, 0
13902, 0.43478260869565, 1.65, 0
13903, 0.39130434782609, 1.65, 0
13904, 0.34782608695652, 1.65, 0
13905, 0.30434782608696, 1.65, 0
13906, 0.26086956521739, 1.65, 0
13907, 0.21739130434783, 1.65, 0
13908, 0.17391304347826, 1.65, 0
13909, 0.1304347826087, 1.65, 0
13910, 0.08695652173913, 1.65, 0
13911, 0.043478260869565, 1.65, 0
13912, 0.95652173913043, 1.7, 0
13913, 0.91304347826087, 1.7, 0
13914, 0.8695652173913, 1.7, 0
13915, 0.82608695652174, 1.7, 0
13916, 0.78260869565217, 1.7, 0
13917, 0.73913043478261, 1.7, 0
13918, 0.69565217391304, 1.7, 0
13919, 0.65217391304348, 1.7, 0
13920, 0.60869565217391, 1.7, 0
13921, 0.56521739130435, 1.7, 0
13922, 0.52173913043478, 1.7, 0
13923, 0.47826086956522, 1.7, 0
13924, 0.43478260869565, 1.7, 0
13925, 0.39130434782609, 1.7, 0
13926, 0.34782608695652, 1.7, 0
13927, 0.30434782608696, 1.7, 0
13928, 0.26086956521739, 1.7, 0
13929, 0.21739130434783, 1.7, 0
13930, 0.17391304347826, 1.7, 0
13931, 0.1304347826087, 1.7, 0
13932, 0.08695652173913, 1.7, 0
13933, 0.043478260869565, 1.7, 0
13934, 0.95652173913043, 1.575, 0
13935, 0.97826086956522, 1.6, 0
13936, 0.91304347826087, 1.575, 0
13937, 0.93478260869565, 1.6, 0
13938, 0.8695652173913, 1.575, 0
13939, 0.89130434782609, 1.6, 0
13940, 0.82608695652174, 1.575, 0
13941, 0.84782608695652, 1.6, 0
13942, 0.78260869565217, 1.575, 0
13943, 0.80434782608696, 1.6, 0
13944, 0.73913043478261, 1.575, 0
13945, 0.76086956521739, 1.6, 0
13946, 0.69565217391304, 1.575, 0
13947, 0.71739130434783, 1.6, 0
13948, 0.65217391304348, 1.575, 0
13949, 0.67391304347826, 1.6, 0
13950, 0.60869565217391, 1.575, 0
13951, 0.6304347826087, 1.6, 0
13952, 0.56521739130435, 1.575, 0
13953, 0.58695652173913, 1.6, 0
13954, 0.52173913043478, 1.575, 0
13955, 0.54347826086957, 1.6, 0
13956, 0.47826086956522, 1.575, 0
13957, 0.5, 1.6, 0
13958, 0.43478260869565, 1.575, 0
13959, 0.45652173913043, 1.6, 0
13960, 0.39130434782609, 1.575, 0
13961, 0.41304347826087, 1.6, 0
13962, 0.34782608695652, 1.575, 0
13963, 0.3695652173913, 1.6, 0
13964, 0.30434782608696, 1.575, 0
13965, 0.32608695652174, 1.6, 0
13966, 0.26086956521739, 1.575, 0
13967, 0.28260869565217, 1.6, 0
13968, 0.21739130434783, 1.575, 0
13969, 0.23913043478261, 1.6, 0
13970, 0.17391304347826, 1.575, 0
13971, 0.19565217391304, 1.6, 0
13972, 0.1304347826087, 1.575, 0
13973, 0.15217391304348, 1.6, 0
13974, 0.08695652173913, 1.575, 0
13975, 0.10869565217391, 1.6, 0
13976, 0.043478260869565, 1.575, 0
13977, 0.065217391304348, 1.6, 0
13978, 0.021739130434783, 1.6, 0
13979, 0.95652173913043, 1.625, 0
13980, 0.97826086956522, 1.65, 0
13981, 0.91304347826087, 1.625, 0
13982, 0.93478260869565, 1.65, 0
13983, 0.8695652173913, 1.625, 0
13984, 0.89130434782609, 1.65, 0
13985, 0.82608695652174, 1.625, 0
13986, 0.84782608695652, 1.65, 0
13987, 0.78260869565217, 1.625, 0
13988, 0.80434782608696, 1.65, 0
13989, 0.73913043478261, 1.625, 0
13990, 0.76086956521739, 1.65, 0
13991, 0.69565217391304, 1.625, 0
13992, 0.71739130434783, 1.65, 0
13993, 0.65217391304348, 1.625, 0
13994, 0.67391304347826, 1.65, 0
13995, 0.60869565217391, 1.625, 0
13996, 0.6304347826087, 1.65, 0
13997, 0.56521739130435, 1.625, 0
13998, 0.58695652173913, 1.65, 0
13999, 0.52173913043478, 1.625, 0
14000, 0.54347826086957, 1.65, 0
14001, 0.47826086956522, 1.625, 0
14002, 0.5, 1.65, 0
14003, 0.43478260869565, 1.625, 0
14004, 0.45652173913043, 1.65, 0
14005, 0.39130434782609, 1.625, 0
14006, 0.41304347826087, 1.65, 0
14007, 0.34782608695652, 1.625, 0
14008, 0.3695652173913, 1.65, 0
14009, 0.30434782608696, 1.625, 0
14010, 0.32608695652174, 1.65, 0
14011, 0.26086956521739, 1.625, 0
14012, 0.28260869565217, 1.65, 0
14013, 0.21739130434783, 1.625, 0
14014, 0.23913043478261, 1.65, 0
14015, 0.17391304347826, 1.625, 0
14016, 0.19565217391304, 1.65, 0
14017, 0.1304347826087, 1.625, 0
14018, 0.15217391304348, 1.65, 0
14019, 0.08695652173913, 1.625, 0
14020, 0.10869565217391, 1.65, 0
14021, 0.043478260869565, 1.625, 0
14022, 0.065217391304348, 1.65, 0
14023, 0.021739130434783, 1.65, 0
14024, 0.95652173913043, 1.675, 0
14025, 0.97826086956522, 1.7, 0
14026, 0.91304347826087, 1.675, 0
14027, 0.93478260869565, 1.7, 0
14028, 0.8695652173913, 1.675, 0
14029, 0.89130434782609, 1.7, 0
14030, 0.82608695652174, 1.675, 0
14031, 0.84782608695652, 1.7, 0
14032, 0.78260869565217, 1.675, 0
14033, 0.80434782608696, 1.7, 0
14034, 0.73913043478261, 1.675, 0
14035, 0.76086956521739, 1.7, 0
14036, 0.69565217391304, 1.675, 0
14037, 0.71739130434783, 1.7, 0
14038, 0.65217391304348, 1.675, 0
14039, 0.67391304347826, 1.7, 0
14040, 0.60869565217391, 1.675, 0
14041, 0.6304347826087, 1.7, 0
14042, 0.56521739130435, 1.675, 0
14043, 0.58695652173913, 1.7, 0
14044, 0.52173913043478, 1.675, 0
14045, 0.54347826086957, 1.7, 0
14046, 0.47826086956522, 1.675, 0
14047, 0.5, 1.7, 0
14048, 0.43478260869565, 1.675, 0
14049, 0.45652173913043, 1.7, 0
14050, 0.39130434782609, 1.675, 0
14051, 0.41304347826087, 1.7, 0
14052, 0.34782608695652, 1.675, 0
14053, 0.3695652173913, 1.7, 0
14054, 0.30434782608696, 1.675, 0
14055, 0.32608695652174, 1.7, 0
14056, 0.26086956521739, 1.675, 0
14057, 0.28260869565217, 1.7, 0
14058, 0.21739130434783, 1.675, 0
14059, 0.23913043478261, 1.7, 0
14060, 0.17391304347826, 1.675, 0
14061, 0.19565217391304, 1.7, 0
14062, 0.1304347826087, 1.675, 0
14063, 0.15217391304348, 1.7, 0
14064, 0.08695652173913, 1.675, 0
14065, 0.10869565217391, 1.7, 0
14066, 0.043478260869565, 1.675, 0
14067, 0.065217391304348, 1.7, 0
14068, 0.021739130434783, 1.7, 0
14069, 0.95652173913043, 1.725, 0
14070, 0.91304347826087, 1.725, 0
14071, 0.8695652173913, 1.725, 0
14072, 0.82608695652174, 1.725, 0
14073, 0.78260869565217, 1.725, 0
14074, 0.73913043478261, 1.725, 0
14075, 0.69565217391304, 1.725, 0
14076, 0.65217391304348, 1.725, 0
14077, 0.60869565217391, 1.725, 0
14078, 0.56521739130435, 1.725, 0
14079, 0.52173913043478, 1.725, 0
14080, 0.47826086956522, 1.725, 0
14081, 0.43478260869565, 1.725, 0
14082, 0.39130434782609, 1.725, 0
14083, 0.34782608695652, 1.725, 0
14084, 0.30434782608696, 1.725, 0
14085, 0.26086956521739, 1.725, 0
14086, 0.21739130434783, 1.725, 0
14087, 0.17391304347826, 1.725, 0
14088, 0.1304347826087, 1.725, 0
14089, 0.08695652173913, 1.725, 0
14090, 0.043478260869565, 1.725, 0
14091, 0.95652173913043, 1.6, 0.5
14092, 0.91304347826087, 1.6, 0.5
14093, 0.8695652173913, 1.6, 0.5
14094, 0.82608695652174, 1.6, 0.5
14095, 0.78260869565217, 1.6, 0.5
14096, 0.73913043478261, 1.6, 0.5
14097, 0.69565217391304, 1.6, 0.5
14098, 0.65217391304348, 1.6, 0.5
14099, 0.60869565217391, 1.6, 0.5
14100, 0.56521739130435, 1.6, 0.5
14101, 0.52173913043478, 1.6, 0.5
14102, 0.47826086956522, 1.6, 0.5
14103, 0.43478260869565, 1.6, 0.5
14104, 0.39130434782609, 1.6, 0.5
14105, 0.34782608695652, 1.6, 0.5
14106, 0.30434782608696, 1.6, 0.5
14107, 0.26086956521739, 1.6, 0.5
14108, 0.21739130434783, 1.6, 0.5
14109, 0.17391304347826, 1.6, 0.5
14110, 0.1304347826087, 1.6, 0.5
14111, 0.08695652173913, 1.6, 0.5
14112, 0.043478260869565, 1.6, 0.5
14113, 0.95652173913043, 1.65, 0.5
14114, 0.91304347826087, 1.65, 0.5
14115, 0.8695652173913, 1.65, 0.5
14116, 0.82608695652174, 1.65, 0.5
14117, 0.78260869565217, 1.65, 0.5
14118, 0.73913043478261, 1.65, 0.5
14119, 0.69565217391304, 1.65, 0.5
14120, 0.65217391304348, 1.65, 0.5
14121, 0.60869565217391, 1.65, 0.5
14122, 0.56521739130435, 1.65, 0.5
14123, 0.52173913043478, 1.65, 0.5
14124, 0.47826086956522, 1.65, 0.5
14125, 0.43478260869565, 1.65, 0.5
14126, 0.39130434782609, 1.65, 0.5
14127, 0.34782608695652, 1.65, 0.5
14128, 0.30434782608696, 1.65, 0.5
14129, 0.26086956521739, 1.65, 0.5
14130, 0.21739130434783, 1.65, 0.5
14131, 0.17391304347826, 1.65, 0.5
14132, 0.1304347826087, 1.65, 0.5
14133, 0.08695652173913, 1.65, 0.5
14134, 0.043478260869565, 1.65, 0.5
14135, 0.95652173913043, 1.7, 0.5
14136, 0.91304347826087, 1.7, 0.5
14137, 0.8695652173913, 1.7, 0.5
14138, 0.82608695652174, 1.7, 0.5
14139, 0.78260869565217, 1.7, 0.5
14140, 0.73913043478261, 1.7, 0.5
14141, 0.69565217391304, 1.7, 0.5
14142, 0.65217391304348, 1.7, 0.5
14143, 0.60869565217391, 1.7, 0.5
14144, 0.56521739130435, 1.7, 0.5
14145, 0.52173913043478, 1.7, 0.5
14146, 0.47826086956522, 1.7, 0.5
14147, 0.43478260869565, 1.7, 0.5
14148, 0.39130434782609, 1.7, 0.5
14149, 0.34782608695652, 1.7, 0.5
14150, 0.30434782608696, 1.7, 0.5
14151, 0.26086956521739, 1.7, 0.5
14152, 0.21739130434783, 1.7, 0.5
14153, 0.17391304347826, 1.7, 0.5
14154, 0.1304347826087, 1.7, 0.5
14155, 0.08695652173913, 1.7, 0.5
14156, 0.043478260869565, 1.7, 0.5
14157, 0.97826086956522, 1.6, 0.5
14158, 0.95652173913043, 1.575, 0.5
14159, 0.93478260869565, 1.6, 0.5
14160, 0.91304347826087, 1.575, 0.5
14161, 0.89130434782609, 1.6, 0.5
14162, 0.8695652173913, 1.575, 0.5
14163, 0.84782608695652, 1.6, 0.5
14164, 0.82608695652174, 1.575, 0.5
14165, 0.80434782608696, 1.6, 0.5
14166, 0.78260869565217, 1.575, 0.5
14167, 0.76086956521739, 1.6, 0.5
14168, 0.73913043478261, 1.575, 0.5
14169, 0.71739130434783, 1.6, 0.5
14170, 0.69565217391304, 1.575, 0.5
14171, 0.67391304347826, 1.6, 0.5
14172, 0.65217391304348, 1.575, 0.5
14173, 0.6304347826087, 1.6, 0.5
14174, 0.60869565217391, 1.575, 0.5
14175, 0.58695652173913, 1.6, 0.5
14176, 0.56521739130435, 1.575, 0.5
14177, 0.54347826086957, 1.6, 0.5
14178, 0.52173913043478, 1.575, 0.5
14179, 0.5, 1.6, 0.5
14180, 0.47826086956522, 1.575, 0.5
14181, 0.45652173913043, 1.6, 0.5
14182, 0.43478260869565, 1.575, 0.5
14183, 0.41304347826087, 1.6, 0.5
14184, 0.39130434782609, 1.575, 0.5
14185, 0.3695652173913, 1.6, 0.5
14186, 0.34782608695652, 1.575, 0.5
14187, 0.32608695652174, 1.6, 0.5
14188, 0.30434782608696, 1.575, 0.5
14189, 0.28260869565217, 1.6, 0.5
14190, 0.26086956521739, 1.575, 0.5
14191, 0.23913043478261, 1.6, 0.5
14192, 0.21739130434783, 1.575, 0.5
14193, 0.19565217391304, 1.6, 0.5
14194, 0.17391304347826, 1.575, 0.5
14195, 0.15217391304348, 1.6, 0.5
14196, 0.1304347826087, 1.575, 0.5
14197, 0.10869565217391, 1.6, 0.5
14198, 0.08695652173913, 1.575, 0.5
14199, 0.065217391304348, 1.6, 0.5
14200, 0.043478260869565, 1.575, 0.5
14201, 0.021739130434783, 1.6, 0.5
14202, 0.97826086956522, 1.65, 0.5
14203, 0.95652173913043, 1.625, 0.5
14204, 0.93478260869565, 1.65, 0.5
14205, 0.91304347826087, 1.625, 0.5
14206, 0.89130434782609, 1.65, 0.5
14207, 0.8695652173913, 1.625, 0.5
14208, 0.84782608695652, 1.65, 0.5
14209, 0.82608695652174, 1.625, 0.5
14210, 0.80434782608696, 1.65, 0.5
14211, 0.78260869565217, 1.625, 0.5
14212, 0.76086956521739, 1.65, 0.5
14213, 0.73913043478261, 1.625, 0.5
14214, 0.71739130434783, 1.65, 0.5
14215, 0.69565217391304, 1.625, 0.5
14216, 0.67391304347826, 1.65, 0.5
14217, 0.65217391304348, 1.625, 0.5
14218, 0.6304347826087, 1.65, 0.5
14219, 0.60869565217391, 1.625, 0.5
14220, 0.58695652173913, 1.65, 0.5
14221, 0.56521739130435, 1.625, 0.5
14222, 0.54347826086957, 1.65, 0.5
14223, 0.52173913043478, 1.625, 0.5
14224, 0.5, 1.65, 0.5
14225, 0.47826086956522, 1.625, 0.5
14226, 0.45652173913043, 1.65, 0.5
14227, 0.43478260869565, 1.625, 0.5
14228, 0.41304347826087, 1.65, 0.5
14229, 0.39130434782609, 1.625, 0.5
14230, 0.3695652173913, 1.65, 0.5
14231, 0.34782608695652, 1.625, 0.5
14232, 0.32608695652174, 1.65, 0.5
14233, 0.30434782608696, 1.625, 0.5
14234, 0.28260869565217, 1.65, 0.5
14235, 0.26086956521739, 1.625, 0.5
14236, 0.23913043478261, 1.65, 0.5
14237, 0.21739130434783, 1.625, 0.5
14238, 0.19565217391304, 1.65, 0.5
14239, 0.17391304347826, 1.625, 0.5
14240, 0.15217391304348, 1.65, 0.5
14241, 0.1304347826087, 1.625, 0.5
14242, 0.10869565217391, 1.65, 0.5
14243, 0.08695652173913, 1.625, 0.5
14244, 0.065217391304348, 1.65, 0.5
14245, 0.043478260869565, 1.625, 0.5
14246, 0.021739130434783, 1.65, 0.5
14247, 0.97826086956522, 1.7, 0.5
14248, 0.95652173913043, 1.675, 0.5
14249, 0.93478260869565, 1.7, 0.5
14250, 0.91304347826087, 1.675, 0.5
14251, 0.89130434782609, 1.7, 0.5
14252, 0.8695652173913, 1.675, 0.5
14253, 0.84782608695652, 1.7, 0.5
14254, 0.82608695652174, 1.675, 0.5
14255, 0.80434782608696, 1.7, 0.5
14256, 0.78260869565217, 1.675, 0.5
14257, 0.76086956521739, 1.7, 0.5
14258, 0.73913043478261, 1.675, 0.5
14259, 0.71739130434783, 1.7, 0.5
14260, 0.69565217391304, 1.675, 0.5
14261, 0.67391304347826, 1.7, 0.5
14262, 0.65217391304348, 1.675, 0.5
14263, 0.6304347826087, 1.7, 0.5
14264, 0.60869565217391, 1.675, 0.5
14265, 0.58695652173913, 1.7, 0.5
14266, 0.56521739130435, 1.675, 0.5
14267, 0.54347826086957, 1.7, 0.5
14268, 0.52173913043478, 1.675, 0.5
14269, 0.5, 1.7, 0.5
14270, 0.47826086956522, 1.675, 0.5
14271, 0.45652173913043, 1.7, 0.5
14272, 0.43478260869565, 1.675, 0.5
14273, 0.41304347826087, 1.7, 0.5
14274, 0.39130434782609, 1.675, 0.5
14275, 0.3695652173913, 1.7, 0.5
14276, 0.34782608695652, 1.675, 0.5
14277, 0.32608695652174, 1.7, 0.5
14278, 0.30434782608696, 1.675, 0.5
14279, 0.28260869565217, 1.7, 0.5
14280, 0.26086956521739, 1.675, 0.5
14281, 0.23913043478261, 1.7, 0.5
14282, 0.21739130434783, 1.675, 0.5
14283, 0.19565217391304, 1.7, 0.5
14284, 0.17391304347826, 1.675, 0.5
14285, 0.15217391304348, 1.7, 0.5
14286, 0.1304347826087, 1.675, 0.5
14287, 0.10869565217391, 1.7, 0.5
14288, 0.08695652173913, 1.675, 0.5
14289, 0.065217391304348, 1.7, 0.5
14290, 0.043478260869565, 1.675, 0.5
14291, 0.021739130434783, 1.7, 0.5
14292, 0.95652173913043, 1.725, 0.5
14293, 0.91304347826087, 1.725, 0.5
14294, 0.8695652173913, 1.725, 0.5
14295, 0.82608695652174, 1.725, 0.5
14296, 0.78260869565217, 1.725, 0.5
14297, 0.73913043478261, 1.725, 0.5
14298, 0.69565217391304, 1.725, 0.5
14299, 0.65217391304348, 1.725, 0.5
14300, 0.60869565217391, 1.725, 0.5
14301, 0.56521739130435, 1.725, 0.5
14302, 0.52173913043478, 1.725, 0.5
14303, 0.47826086956522, 1.725, 0.5
14304, 0.43478260869565, 1.725, 0.5
14305, 0.39130434782609, 1.725, 0.5
14306, 0.34782608695652, 1.725, 0.5
14307, 0.30434782608696, 1.725, 0.5
14308, 0.26086956521739, 1.725, 0.5
14309, 0.21739130434783, 1.725, 0.5
14310, 0.17391304347826, 1.725, 0.5
14311, 0.1304347826087, 1.725, 0.5
14312, 0.08695652173913, 1.725, 0.5
14313, 0.043478260869565, 1.725, 0.5
14314, 0, 1.6, 0.44444444444444
14315, 0, 1.6, 0.38888888888889
14316, 0, 1.6, 0.33333333333333
14317, 0, 1.6, 0.27777777777778
14318, 0, 1.6, 0.22222222222222
14319, 0, 1.6, 0.16666666666667
14320, 0, 1.6, 0.11111111111111
14321, 0, 1.6, 0.055555555555556
14322, 0, 1.65, 0.44444444444444
14323, 0, 1.65, 0.38888888888889
14324, 0, 1.65, 0.33333333333333
14325, 0, 1.65, 0.27777777777778
14326, 0, 1.65, 0.22222222222222
14327, 0, 1.65, 0.16666666666667
14328, 0, 1.65, 0.11111111111111
14329, 0, 1.65, 0.055555555555556
14330, 0, 1.7, 0.44444444444444
14331, 0, 1.7, 0.38888888888889
14332, 0, 1.7, 0.33333333333333
14333, 0, 1.7, 0.27777777777778
14334, 0, 1.7, 0.22222222222222
14335, 0, 1.7, 0.16666666666667
14336, 0, 1.7, 0.11111111111111
14337, 0, 1.7, 0.055555555555556
14338, 0, 1.6, 0.47222222222222
14339, 0, 1.575, 0.44444444444444
14340, 0, 1.6, 0.41666666666667
14341, 0, 1.575, 0.38888888888889
14342, 0, 1.6, 0.36111111111111
14343, 0, 1.575, 0.33333333333333
14344, 0, 1.6, 0.30555555555556
14345, 0, 1.575, 0.27777777777778
14346, 0, 1.6, 0.25
14347, 0, 1.575, 0.22222222222222
14348, 0, 1.6, 0.19444444444444
14349, 0, 1.575, 0.16666666666667
14350, 0, 1.6, 0.13888888888889
14351, 0, 1.575, 0.11111111111111
14352, 0, 1.6, 0.083333333333333
14353, 0, 1.575, 0.055555555555556
14354, 0, 1.6, 0.027777777777778
14355, 0, 1.65, 0.47222222222222
14356, 0, 1.625, 0.44444444444444
14357, 0, 1.65, 0.41666666666667
14358, 0, 1.625, 0.38888888888889
14359, 0, 1.65, 0.36111111111111
14360, 0, 1.625, 0.33333333333333
14361, 0, 1.65, 0.30555555555556
14362, 0, 1.625, 0.27777777777778
14363, 0, 1.65, 0.25
14364, 0, 1.625, 0.22222222222222
14365, 0, 1.65, 0.19444444444444
14366, 0, 1.625, 0.16666666666667
14367, 0, 1.65, 0.13888888888889
14368, 0, 1.625, 0.11111111111111
14369, 0, 1.65, 0.083333333333333
14370, 0, 1.625, 0.055555555555556
14371, 0, 1.65, 0.027777777777778
14372, 0, 1.7, 0.47222222222222
14373, 0, 1.675, 0.44444444444444
14374, 0, 1.7, 0.41666666666667
14375, 0, 1.675, 0.38888888888889
14376, 0, 1.7, 0.36111111111111
14377, 0, 1.675, 0.33333333333333
14378, 0, 1.7, 0.30555555555556
14379, 0, 1.675, 0.27777777777778
14380, 0, 1.7, 0.25
14381, 0, 1.675, 0.22222222222222
14382, 0, 1.7, 0.19444444444444
14383, 0, 1.675, 0.16666666666667
14384, 0, 1.7, 0.13888888888889
14385, 0, 1.675, 0.11111111111111
14386, 0, 1.7, 0.083333333333333
14387, 0, 1.675, 0.055555555555556
14388, 0, 1.7, 0.027777777777778
14389, 0, 1.725, 0.44444444444444
14390, 0, 1.725, 0.38888888888889
14391, 0, 1.725, 0.33333333333333
14392, 0, 1.725, 0.27777777777778
14393, 0, 1.725, 0.22222222222222
14394, 0, 1.725, 0.16666666666667
14395, 0, 1.725, 0.11111111111111
14396, 0, 1.725, 0.055555555555556
14397, 0.043478260869565, 1.75, 0.055555555555556
14398, 0.043478260869565, 1.75, 0.11111111111111
14399, 0.043478260869565, 1.75, 0.16666666666667
14400, 0.043478260869565, 1.75, 0.22222222222222
14401, 0.043478260869565, 1.75, 0.27777777777778
14402, 0.043478260869565, 1.75, 0.33333333333333
14403, 0.043478260869565, 1.75, 0.38888888888889
14404, 0.043478260869565, 1.75, 0.44444444444444
14405, 0.08695652173913, 1.75, 0.055555555555556
14406, 0.08695652173913, 1.75, 0.11111111111111
14407, 0.08695652173913, 1.75, 0.16666666666667
14408, 0.08695652173913, 1.75, 0.22222222222222
14409, 0.08695652173913, 1.75, 0.27777777777778
14410, 0.08695652173913, 1.75, 0.33333333333333
14411, 0.08695652173913, 1.75, 0.38888888888889
14412, 0.08695652173913, 1.75, 0.44444444444444
14413, 0.1304347826087, 1.75, 0.055555555555556
14414, 0.1304347826087, 1.75, 0.11111111111111
14415, 0.1304347826087, 1.75, 0.16666666666667
14416, 0.1304347826087, 1.75, 0.22222222222222
14417, 0.1304347826087, 1.75, 0.27777777777778
14418, 0.1304347826087, 1.75, 0.33333333333333
14419, 0.1304347826087, 1.75, 0.38888888888889
14420, 0.1304347826087, 1.75, 0.44444444444444
14421, 0.17391304347826, 1.75, 0.055555555555556
14422, 0.17391304347826, 1.75, 0.11111111111111
14423, 0.17391304347826, 1.75, 0.16666666666667
14424, 0.17391304347826, 1.75, 0.22222222222222
14425, 0.17391304347826, 1.75, 0.27777777777778
14426, 0.17391304347826, 1.75, 0.33333333333333
14427, 0.17391304347826, 1.75, 0.38888888888889
14428, 0.17391304347826, 1.75, 0.44444444444444
14429, 0.21739130434783, 1.75, 0.055555555555556
14430, 0.21739130434783, 1.75, 0.11111111111111
14431, 0.21739130434783, 1.75, 0.16666666666667
14432, 0.21739130434783, 1.75, 0.22222222222222
14433, 0.21739130434783, 1.75, 0.27777777777778
14434, 0.21739130434783, 1.75, 0.33333333333333
14435, 0.21739130434783, 1.75, 0.38888888888889
14436, 0.21739130434783, 1.75, 0.44444444444444
14437, 0.26086956521739, 1.75, 0.055555555555556
14438, 0.26086956521739, 1.75, 0.11111111111111
14439, 0.26086956521739, 1.75, 0.16666666666667
14440, 0.26086956521739, 1.75, 0.22222222222222
14441, 0.26086956521739, 1.75, 0.27777777777778
14442, 0.26086956521739, 1.75, 0.33333333333333
14443, 0.26086956521739, 1.75, 0.38888888888889
14444, 0.26086956521739, 1.75, 0.44444444444444
14445, 0.30434782608696, 1.75, 0.055555555555556
14446, 0.30434782608696, 1.75, 0.11111111111111
14447, 0.30434782608696, 1.75, 0.16666666666667
14448, 0.30434782608696, 1.75, 0.22222222222222
14449, 0.30434782608696, 1.75, 0.27777777777778
14450, 0.30434782608696, 1.75, 0.33333333333333
14451, 0.30434782608696, 1.75, 0.38888888888889
14452, 0.30434782608696, 1.75, 0.44444444444444
14453, 0.34782608695652, 1.75, 0.055555555555556
14454, 0.34782608695652, 1.75, 0.11111111111111
14455, 0.34782608695652, 1.75, 0.16666666666667
14456, 0.34782608695652, 1.75, 0.22222222222222
14457, 0.34782608695652, 1.75, 0.27777777777778
14458, 0.34782608695652, 1.75, 0.33333333333333
14459, 0.34782608695652, 1.75, 0.38888888888889
14460, 0.34782608695652, 1.75, 0.44444444444444
14461, 0.39130434782609, 1.75, 0.055555555555556
14462, 0.39130434782609, 1.75, 0.11111111111111
14463, 0.39130434782609, 1.75, 0.16666666666667
14464, 0.39130434782609, 1.75, 0.22222222222222
14465, 0.39130434782609, 1.75, 0.27777777777778
14466, 0.39130434782609, 1.75, 0.33333333333333
14467, 0.39130434782609, 1.75, 0.38888888888889
14468, 0.39130434782609, 1.75, 0.44444444444444
14469, 0.43478260869565, 1.75, 0.055555555555556
14470, 0.43478260869565, 1.75, 0.11111111111111
14471, 0.43478260869565, 1.75, 0.16666666666667
14472, 0.43478260869565, 1.75, 0.22222222222222
14473, 0.43478260869565, 1.75, 0.27777777777778
14474, 0.43478260869565, 1.75, 0.33333333333333
14475, 0.43478260869565, 1.75, 0.38888888888889
14476, 0.43478260869565, 1.75, 0.44444444444444
14477, 0.47826086956522, 1.75, 0.055555555555556
14478, 0.47826086956522, 1.75, 0.11111111111111
14479, 0.47826086956522, 1.75, 0.16666666666667
14480, 0.47826086956522, 1.75, 0.22222222222222
14481, 0.47826086956522, 1.75, 0.27777777777778
14482, 0.47826086956522, 1.75, 0.33333333333333
14483, 0.47826086956522, 1.75, 0.38888888888889
14484, 0.47826086956522, 1.75, 0.44444444444444
14485, 0.52173913043478, 1.75, 0.055555555555556
14486, 0.52173913043478, 1.75, 0.11111111111111
14487, 0.52173913043478, 1.75, 0.16666666666667
14488, 0.52173913043478, 1.75, 0.22222222222222
14489, 0.52173913043478, 1.75, 0.27777777777778
14490, 0.52173913043478, 1.75, 0.33333333333333
14491, 0.52173913043478, 1.75, 0.38888888888889
14492, 0.52173913043478, 1.75, 0.44444444444444
14493, 0.56521739130435, 1.75, 0.055555555555556
14494, 0.56521739130435, 1.75, 0.11111111111111
14495, 0.56521739130435, 1.75, 0.16666666666667
14496, 0.56521739130435, 1.75, 0.22222222222222
14497, 0.56521739130435, 1.75, 0.27777777777778
14498, 0.56521739130435, 1.75, 0.33333333333333
14499, 0.56521739130435, 1.75, 0.38888888888889
14500, 0.56521739130435, 1.75, 0.44444444444444
14501, 0.60869565217391, 1.75, 0.055555555555556
14502, 0.60869565217391, 1.75, 0.11111111111111
14503, 0.60869565217391, 1.75, 0.16666666666667
14504, 0.60869565217391, 1.75, 0.22222222222222
14505, 0.60869565217391, 1.75, 0.27777777777778
14506, 0.60869565217391, 1.75, 0.33333333333333
14507, 0.60869565217391, 1.75, 0.38888888888889
14508, 0.60869565217391, 1.75, 0.44444444444444
14509, 0.65217391304348, 1.75, 0.055555555555556
14510, 0.65217391304348, 1.75, 0.11111111111111
14511, 0.65217391304348, 1.75, 0.16666666666667
14512, 0.65217391304348, 1.75, 0.22222222222222
14513, 0.65217391304348, 1.75, 0.27777777777778
14514, 0.65217391304348, 1.75, 0.33333333333333
14515, 0.65217391304348, 1.75, 0.38888888888889
14516, 0.65217391304348, 1.75, 0.44444444444444
14517, 0.69565217391304, 1.75, 0.055555555555556
14518, 0.69565217391304, 1.75, 0.11111111111111
14519, 0.69565217391304, 1.75, 0.16666666666667
14520, 0.69565217391304, 1.75, 0.22222222222222
14521, 0.69565217391304, 1.75, 0.27777777777778
14522, 0.69565217391304, 1.75, 0.33333333333333
14523, 0.69565217391304, 1.75, 0.38888888888889
14524, 0.69565217391304, 1.75, 0.44444444444444
14525, 0.73913043478261, 1.75, 0.055555555555556
14526, 0.73913043478261, 1.75, 0.11111111111111
14527, 0.73913043478261, 1.75, 0.16666666666667
14528, 0.73913043478261, 1.75, 0.22222222222222
14529, 0.73913043478261, 1.75, 0.27777777777778
14530, 0.73913043478261, 1.75, 0.33333333333333
14531, 0.73913043478261, 1.75, 0.38888888888889
14532, 0.73913043478261, 1.75, 0.44444444444444
14533, 0.78260869565217, 1.75, 0.055555555555556
14534, 0.78260869565217, 1.75, 0.11111111111111
14535, 0.78260869565217, 1.75, 0.16666666666667
14536, 0.78260869565217, 1.75, 0.22222222222222
14537, 0.78260869565217, 1.75, 0.27777777777778
14538, 0.78260869565217, 1.75, 0.33333333333333
14539, 0.78260869565217, 1.75, 0.38888888888889
14540, 0.78260869565217, 1.75, 0.44444444444444
14541, 0.82608695652174, 1.75, 0.055555555555556
14542, 0.82608695652174, 1.75, 0.11111111111111
14543, 0.82608695652174, 1.75, 0.16666666666667
14544, 0.82608695652174, 1.75, 0.22222222222222
14545, 0.82608695652174, 1.75, 0.27777777777778
14546, 0.82608695652174, 1.75, 0.33333333333333
14547, 0.82608695652174, 1.75, 0.38888888888889
14548, 0.82608695652174, 1.75, 0.44444444444444
14549, 0.8695652173913, 1.75, 0.055555555555556
14550, 0.8695652173913, 1.75, 0.11111111111111
14551, 0.8695652173913, 1.75, 0.16666666666667
14552, 0.8695652173913, 1.75, 0.22222222222222
14553, 0.8695652173913, 1.75, 0.27777777777778
14554, 0.8695652173913, 1.75, 0.33333333333333
14555, 0.8695652173913, 1.75, 0.38888888888889
14556, 0.8695652173913, 1.75, 0.44444444444444
14557, 0.91304347826087, 1.75, 0.055555555555556
14558, 0.91304347826087, 1.75, 0.11111111111111
14559, 0.91304347826087, 1.75, 0.16666666666667
14560, 0.91304347826087, 1.75, 0.22222222222222
14561, 0.91304347826087, 1.75, 0.27777777777778
14562, 0.91304347826087, 1.75, 0.33333333333333
14563, 0.91304347826087, 1.75, 0.38888888888889
14564, 0.91304347826087, 1.75, 0.44444444444444
14565, 0.95652173913043, 1.75, 0.055555555555556
14566, 0.95652173913043, 1.75, 0.11111111111111
14567, 0.95652173913043, 1.75, 0.16666666666667
14568, 0.95652173913043, 1.75, 0.22222222222222
14569, 0.95652173913043, 1.75, 0.27777777777778
14570, 0.95652173913043, 1.75, 0.33333333333333
14571, 0.95652173913043, 1.75, 0.38888888888889
14572, 0.95652173913043, 1.75, 0.44444444444444
14573, 0.021739130434783, 1.75, 0.055555555555556
14574, 0.043478260869565, 1.75, 0.027777777777778
14575, 0.021739130434783, 1.75, 0.11111111111111
14576, 0.043478260869565, 1.75, 0.083333333333333
14577, 0.021739130434783, 1.75, 0.16666666666667
14578, 0.043478260869565, 1.75, 0.13888888888889
14579, 0.021739130434783, 1.75, 0.22222222222222
14580, 0.043478260869565, 1.75, 0.19444444444444
14581, 0.021739130434783, 1.75, 0.27777777777778
14582, 0.043478260869565, 1.75, 0.25
14583, 0.021739130434783, 1.75, 0.33333333333333
14584, 0.043478260869565, 1.75, 0.30555555555556
14585, 0.021739130434783, 1.75, 0.38888888888889
14586, 0.043478260869565, 1.75, 0.36111111111111
14587, 0.021739130434783, 1.75, 0.44444444444444
14588, 0.043478260869565, 1.75, 0.41666666666667
14589, 0.043478260869565, 1.75, 0.47222222222222
14590, 0.065217391304348, 1.75, 0.055555555555556
14591, 0.08695652173913, 1.75, 0.027777777777778
14592, 0.065217391304348, 1.75, 0.11111111111111
14593, 0.08695652173913, 1.75, 0.083333333333333
14594, 0.065217391304348, 1.75, 0.16666666666667
14595, 0.08695652173913, 1.75, 0.13888888888889
14596, 0.065217391304348, 1.75, 0.22222222222222
14597, 0.08695652173913, 1.75, 0.19444444444444
14598, 0.065217391304348, 1.75, 0.27777777777778
14599, 0.08695652173913, 1.75, 0.25
14600, 0.065217391304348, 1.75, 0.33333333333333
14601, 0.08695652173913, 1.75, 0.30555555555556
14602, 0.065217391304348, 1.75, 0.38888888888889
14603, 0.08695652173913, 1.75, 0.36111111111111
14604, 0.065217391304348, 1.75, 0.44444444444444
14605, 0.08695652173913, 1.75, 0.41666666666667
14606, 0.08695652173913, 1.75, 0.47222222222222
14607, 0.10869565217391, 1.75, 0.055555555555556
14608, 0.1304347826087, 1.75, 0.027777777777778
14609, 0.10869565217391, 1.75, 0.11111111111111
14610, 0.1304347826087, 1.75, 0.083333333333333
14611, 0.10869565217391, 1.75, 0.16666666666667
14612, 0.1304347826087, 1.75, 0.13888888888889
14613, 0.10869565217391, 1.75, 0.22222222222222
14614, 0.1304347826087, 1.75, 0.19444444444444
14615, 0.10869565217391, 1.75, 0.27777777777778
14616, 0.1304347826087, 1.75, 0.25
14617, 0.10869565217391, 1.75, 0.33333333333333
14618, 0.1304347826087, 1.75, 0.30555555555556
14619, 0.10869565217391, 1.75, 0.38888888888889
14620, 0.1304347826087, 1.75, 0.36111111111111
14621, 0.10869565217391, 1.75, 0.44444444444444
14622, 0.1304347826087, 1.75, 0.41666666666667
14623, 0.1304347826087, 1.75, 0.47222222222222
14624, 0.15217391304348, 1.75, 0.055555555555556
14625, 0.17391304347826, 1.75, 0.027777777777778
14626, 0.15217391304348, 1.75, 0.11111111111111
14627, 0.17391304347826, 1.75, 0.083333333333333
14628, 0.15217391304348, 1.75, 0.16666666666667
14629, 0.17391304347826, 1.75, 0.13888888888889
14630, 0.15217391304348, 1.75, 0.22222222222222
14631, 0.17391304347826, 1.75, 0.19444444444444
14632, 0.15217391304348, 1.75, 0.27777777777778
14633, 0.17391304347826, 1.75, 0.25
14634, 0.15217391304348, 1.75, 0.33333333333333
14635, 0.17391304347826, 1.75, 0.30555555555556
14636, 0.15217391304348, 1.75, 0.38888888888889
14637, 0.17391304347826, 1.75, 0.36111111111111
14638, 0.15217391304348, 1.75, 0.44444444444444
14639, 0.17391304347826, 1.75, 0.41666666666667
14640, 0.17391304347826, 1.75, 0.47222222222222
14641, 0.19565217391304, 1.75, 0.055555555555556
14642, 0.21739130434783, 1.75, 0.027777777777778
14643, 0.19565217391304, 1.75, 0.11111111111111
14644, 0.21739130434783, 1.75, 0.083333333333333
14645, 0.19565217391304, 1.75, 0.16666666666667
14646, 0.21739130434783, 1.75, 0.13888888888889
14647, 0.19565217391304, 1.75, 0.22222222222222
14648, 0.21739130434783, 1.75, 0.19444444444444
14649, 0.19565217391304, 1.75, 0.27777777777778
14650, 0.21739130434783, 1.75, 0.25
14651, 0.19565217391304, 1.75, 0.33333333333333
14652, 0.21739130434783, 1.75, 0.30555555555556
14653, 0.19565217391304, 1.75, 0.38888888888889
14654, 0.21739130434783, 1.75, 0.36111111111111
14655, 0.19565217391304, 1.75, 0.44444444444444
14656, 0.21739130434783, 1.75, 0.41666666666667
14657, 0.21739130434783, 1.75, 0.47222222222222
14658, 0.23913043478261, 1.75, 0.055555555555556
14659, 0.26086956521739, 1.75, 0.027777777777778
14660, 0.23913043478261, 1.75, 0.11111111111111
14661, 0.26086956521739, 1.75, 0.083333333333333
14662, 0.23913043478261, 1.75, 0.16666666666667
14663, 0.26086956521739, 1.75, 0.13888888888889
14664, 0.23913043478261, 1.75, 0.22222222222222
14665, 0.26086956521739, 1.75, 0.19444444444444
14666, 0.23913043478261, 1.75, 0.27777777777778
14667, 0.26086956521739, 1.75, 0.25
14668, 0.23913043478261, 1.75, 0.33333333333333
14669, 0.26086956521739, 1.75, 0.30555555555556
14670, 0.23913043478261, 1.75, 0.38888888888889
14671, 0.26086956521739, 1.75, 0.36111111111111
14672, 0.23913043478261, 1.75, 0.44444444444444
14673, 0.26086956521739, 1.75, 0.41666666666667
14674, 0.26086956521739, 1.75, 0.47222222222222
14675, 0.28260869565217, 1.75, 0.055555555555556
14676, 0.30434782608696, 1.75, 0.027777777777778
14677, 0.28260869565217, 1.75, 0.11111111111111
14678, 0.30434782608696, 1.75, 0.083333333333333
14679, 0.28260869565217, 1.75, 0.16666666666667
14680, 0.30434782608696, 1.75, 0.13888888888889
14681, 0.28260869565217, 1.75, 0.22222222222222
14682, 0.30434782608696, 1.75, 0.19444444444444
14683, 0.28260869565217, 1.75, 0.27777777777778
14684, 0.30434782608696, 1.75, 0.25
14685, 0.28260869565217, 1.75, 0.33333333333333
14686, 0.30434782608696, 1.75, 0.30555555555556
14687, 0.28260869565217, 1.75, 0.38888888888889
14688, 0.30434782608696, 1.75, 0.36111111111111
14689, 0.28260869565217, 1.75, 0.44444444444444
14690, 0.30434782608696, 1.75, 0.41666666666667
14691, 0.30434782608696, 1.75, 0.47222222222222
14692, 0.32608695652174, 1.75, 0.055555555555556
14693, 0.34782608695652, 1.75, 0.027777777777778
14694, 0.32608695652174, 1.75, 0.11111111111111
14695, 0.34782608695652, 1.75, 0.083333333333333
14696, 0.32608695652174, 1.75, 0.16666666666667
14697, 0.34782608695652, 1.75, 0.13888888888889
14698, 0.32608695652174, 1.75, 0.22222222222222
14699, 0.34782608695652, 1.75, 0.19444444444444
14700, 0.32608695652174, 1.75, 0.27777777777778
14701, 0.34782608695652, 1.75, 0.25
14702, 0.32608695652174, 1.75, 0.33333333333333
14703, 0.34782608695652, 1.75, 0.30555555555556
14704, 0.32608695652174, 1.75, 0.38888888888889
14705, 0.34782608695652, 1.75, 0.36111111111111
14706, 0.32608695652174, 1.75, 0.44444444444444
14707, 0.34782608695652, 1.75, 0.41666666666667
14708, 0.34782608695652, 1.75, 0.47222222222222
14709, 0.3695652173913, 1.75, 0.055555555555556
14710, 0.39130434782609, 1.75, 0.027777777777778
14711, 0.3695652173913, 1.75, 0.11111111111111
14712, 0.39130434782609, 1.75, 0.083333333333333
14713, 0.3695652173913, 1.75, 0.16666666666667
14714, 0.39130434782609, 1.75, 0.13888888888889
14715, 0.3695652173913, 1.75, 0.22222222222222
14716, 0.39130434782609, 1.75, 0.19444444444444
14717, 0.3695652173913, 1.75, 0.27777777777778
14718, 0.39130434782609, 1.75, 0.25
14719, 0.3695652173913, 1.75, 0.33333333333333
14720, 0.39130434782609, 1.75, 0.30555555555556
14721, 0.3695652173913, 1.75, 0.38888888888889
14722, 0.39130434782609, 1.75, 0.36111111111111
14723, 0.3695652173913, 1.75, 0.44444444444444
14724, 0.39130434782609, 1.75, 0.41666666666667
14725, 0.39130434782609, 1.75, 0.47222222222222
14726, 0.41304347826087, 1.75, 0.055555555555556
14727, 0.43478260869565, 1.75, 0.027777777777778
14728, 0.41304347826087, 1.75, 0.11111111111111
14729, 0.43478260869565, 1.75, 0.083333333333333
14730, 0.41304347826087, 1.75, 0.16666666666667
14731, 0.43478260869565, 1.75, 0.13888888888889
14732, 0.41304347826087, 1.75, 0.22222222222222
14733, 0.43478260869565, 1.75, 0.19444444444444
14734, 0.41304347826087, 1.75, 0.27777777777778
14735, 0.43478260869565, 1.75, 0.25
14736, 0.41304347826087, 1.75, 0.33333333333333
14737, 0.43478260869565, 1.75, 0.30555555555556
14738, 0.41304347826087, 1.75, 0.38888888888889
14739, 0.43478260869565, 1.75, 0.36111111111111
14740, 0.41304347826087, 1.75, 0.44444444444444
14741, 0.43478260869565, 1.75, 0.41666666666667
14742, 0.43478260869565, 1.75, 0.47222222222222
14743, 0.45652173913043, 1.75, 0.055555555555556
14744, 0.47826086956522, 1.75, 0.027777777777778
14745, 0.45652173913043, 1.75, 0.11111111111111
14746, 0.47826086956522, 1.75, 0.083333333333333
14747, 0.45652173913043, 1.75, 0.16666666666667
14748, 0.47826086956522, 1.75, 0.13888888888889
14749, 0.45652173913043, 1.75, 0.22222222222222
14750, 0.47826086956522, 1.75, 0.19444444444444
14751, 0.45652173913043, 1.75, 0.27777777777778
14752, 0.47826086956522, 1.75, 0.25
14753, 0.45652173913043, 1.75, 0.33333333333333
14754, 0.47826086956522, 1.75, 0.30555555555556
14755, 0.45652173913043, 1.75, 0.38888888888889
14756, 0.47826086956522, 1.75, 0.36111111111111
14757, 0.45652173913043, 1.75, 0.44444444444444
14758, 0.47826086956522, 1.75, 0.41666666666667
14759, 0.47826086956522, 1.75, 0.47222222222222
14760, 0.5, 1.75, 0.055555555555556
14761, 0.52173913043478, 1.75, 0.027777777777778
14762, 0.5, 1.75, 0.11111111111111
14763, 0.52173913043478, 1.75, 0.083333333333333
14764, 0.5, 1.75, 0.16666666666667
14765, 0.52173913043478, 1.75, 0.13888888888889
14766, 0.5, 1.75, 0.22222222222222
14767, 0.52173913043478, 1.75, 0.19444444444444
14768, 0.5, 1.75, 0.27777777777778
14769, 0.52173913043478, 1.75, 0.25
14770, 0.5, 1.75, 0.33333333333333
14771, 0.52173913043478, 1.75, 0.30555555555556
14772, 0.5, 1.75, 0.38888888888889
14773, 0.52173913043478, 1.75, 0.36111111111111
14774, 0.5, 1.75, 0.44444444444444
14775, 0.52173913043478, 1.75, 0.41666666666667
14776, 0.52173913043478, 1.75, 0.47222222222222
14777, 0.54347826086957, 1.75, 0.055555555555556
14778, 0.56521739130435, 1.75, 0.027777777777778
14779, 0.54347826086957, 1.75, 0.11111111111111
14780, 0.56521739130435, 1.75, 0.083333333333333
14781, 0.54347826086957, 1.75, 0.16666666666667
14782, 0.56521739130435, 1.75, 0.13888888888889
14783, 0.54347826086957, 1.75, 0.22222222222222
14784, 0.56521739130435, 1.75, 0.19444444444444
14785, 0.54347826086957, 1.75, 0.27777777777778
14786, 0.56521739130435, 1.75, 0.25
14787, 0.54347826086957, 1.75, 0.33333333333333
14788, 0.56521739130435, 1.75, 0.30555555555556
14789, 0.54347826086957, 1.75, 0.38888888888889
14790, 0.56521739130435, 1.75, 0.36111111111111
14791, 0.54347826086957, 1.75, 0.44444444444444
14792, 0.56521739130435, 1.75, 0.41666666666667
14793, 0.56521739130435, 1.75, 0.47222222222222
14794, 0.58695652173913, 1.75, 0.055555555555556
14795, 0.60869565217391, 1.75, 0.027777777777778
14796, 0.58695652173913, 1.75, 0.11111111111111
14797, 0.60869565217391, 1.75, 0.083333333333333
14798, 0.58695652173913, 1.75, 0.16666666666667
14799, 0.60869565217391, 1.75, 0.13888888888889
14800, 0.58695652173913, 1.75, 0.22222222222222
14801, 0.60869565217391, 1.75, 0.19444444444444
14802, 0.58695652173913, 1.75, 0.27777777777778
14803, 0.60869565217391, 1.75, 0.25
14804, 0.58695652173913, 1.75, 0.33333333333333
14805, 0.60869565217391, 1.75, 0.30555555555556
14806, 0.58695652173913, 1.75, 0.38888888888889
14807, 0.60869565217391, 1.75, 0.36111111111111
14808, 0.58695652173913, 1.75, 0.44444444444444
14809, 0.60869565217391, 1.75, 0.41666666666667
14810, 0.60869565217391, 1.75, 0.47222222222222
14811, 0.6304347826087, 1.75, 0.055555555555556
14812, 0.65217391304348, 1.75, 0.027777777777778
14813, 0.6304347826087, 1.75, 0.11111111111111
14814, 0.65217391304348, 1.75, 0.083333333333333
14815, 0.6304347826087, 1.75, 0.16666666666667
14816, 0.65217391304348, 1.75, 0.13888888888889
14817, 0.6304347826087, 1.75, 0.22222222222222
14818, 0.65217391304348, 1.75, 0.19444444444444
14819, 0.6304347826087, 1.75, 0.27777777777778
14820, 0.65217391304348, 1.75, 0.25
14821, 0.6304347826087, 1.75, 0.33333333333333
14822, 0.65217391304348, 1.75, 0.30555555555556
14823, 0.6304347826087, 1.75, 0.38888888888889
14824, 0.65217391304348, 1.75, 0.36111111111111
14825, 0.6304347826087, 1.75, 0.44444444444444
14826, 0.65217391304348, 1.75, 0.41666666666667
14827, 0.65217391304348, 1.75, 0.47222222222222
14828, 0.67391304347826, 1.75, 0.055555555555556
14829, 0.69565217391304, 1.75, 0.027777777777778
14830, 0.67391304347826, 1.75, 0.11111111111111
14831, 0.69565217391304, 1.75, 0.083333333333333
14832, 0.67391304347826, 1.75, 0.16666666666667
14833, 0.69565217391304, 1.75, 0.13888888888889
14834, 0.67391304347826, 1.75, 0.22222222222222
14835, 0.69565217391304, 1.75, 0.19444444444444
14836, 0.67391304347826, 1.75, 0.27777777777778
14837, 0.69565217391304, 1.75, 0.25
14838, 0.67391304347826, 1.75, 0.33333333333333
14839, 0.69565217391304, 1.75, 0.30555555555556
14840, 0.67391304347826, 1.75, 0.38888888888889
14841, 0.69565217391304, 1.75, 0.36111111111111
14842, 0.67391304347826, 1.75, 0.44444444444444
14843, 0.69565217391304, 1.75, 0.41666666666667
14844, 0.69565217391304, 1.75, 0.47222222222222
14845, 0.71739130434783, 1.75, 0.055555555555556
14846, 0.73913043478261, 1.75, 0.027777777777778
14847, 0.71739130434783, 1.75, 0.11111111111111
14848, 0.73913043478261, 1.75, 0.083333333333333
14849, 0.71739130434783, 1.75, 0.16666666666667
14850, 0.73913043478261, 1.75, 0.13888888888889
14851, 0.71739130434783, 1.75, 0.22222222222222
14852, 0.73913043478261, 1.75, 0.19444444444444
14853, 0.71739130434783, 1.75, 0.27777777777778
14854, 0.73913043478261, 1.75, 0.25
14855, 0.71739130434783, 1.75, 0.33333333333333
14856, 0.73913043478261, 1.75, 0.30555555555556
14857, 0.71739130434783, 1.75, 0.38888888888889
14858, 0.73913043478261, 1.75, 0.36111111111111
14859, 0.71739130434783, 1.75, 0.44444444444444
14860, 0.73913043478261, 1.75, 0.41666666666667
14861, 0.73913043478261, 1.75, 0.47222222222222
14862, 0.76086956521739, 1.75, 0.055555555555556
14863, 0.78260869565217, 1.75, 0.027777777777778
14864, 0.76086956521739, 1.75, 0.11111111111111
14865, 0.78260869565217, 1.75, 0.083333333333333
14866, 0.76086956521739, 1.75, 0.16666666666667
14867, 0.78260869565217, 1.75, 0.13888888888889
14868, 0.76086956521739, 1.75, 0.22222222222222
14869, 0.78260869565217, 1.75, 0.19444444444444
14870, 0.76086956521739, 1.75, 0.27777777777778
14871, 0.78260869565217, 1.75, 0.25
14872, 0.76086956521739, 1.75, 0.33333333333333
14873, 0.78260869565217, 1.75, 0.30555555555556
14874, 0.76086956521739, 1.75, 0.38888888888889
14875, 0.78260869565217, 1.75, 0.36111111111111
14876, 0.76086956521739, 1.75, 0.44444444444444
14877, 0.78260869565217, 1.75, 0.41666666666667
14878, 0.78260869565217, 1.75, 0.47222222222222
14879, 0.80434782608696, 1.75, 0.055555555555556
14880, 0.82608695652174, 1.75, 0.027777777777778
14881, 0.80434782608696, 1.75, 0.11111111111111
14882, 0.82608695652174, 1.75, 0.083333333333333
14883, 0.80434782608696, 1.75, 0.16666666666667
14884, 0.82608695652174, 1.75, 0.13888888888889
14885, 0.80434782608696, 1.75, 0.22222222222222
14886, 0.82608695652174, 1.75, 0.19444444444444
14887, 0.80434782608696, 1.75, 0.27777777777778
14888, 0.82608695652174, 1.75, 0.25
14889, 0.80434782608696, 1.75, 0.33333333333333
14890, 0.82608695652174, 1.75, 0.30555555555556
14891, 0.80434782608696, 1.75, 0.38888888888889
14892, 0.82608695652174, 1.75, 0.36111111111111
14893, 0.80434782608696, 1.75, 0.44444444444444
14894, 0.82608695652174, 1.75, 0.41666666666667
14895, 0.82608695652174, 1.75, 0.47222222222222
14896, 0.84782608695652, 1.75, 0.055555555555556
14897, 0.8695652173913, 1.75, 0.027777777777778
14898, 0.84782608695652, 1.75, 0.11111111111111
14899, 0.8695652173913, 1.75, 0.083333333333333
14900, 0.84782608695652, 1.75, 0.16666666666667
14901, 0.8695652173913, 1.75, 0.13888888888889
14902, 0.84782608695652, 1.75, 0.22222222222222
14903, 0.8695652173913, 1.75, 0.19444444444444
14904, 0.84782608695652, 1.75, 0.27777777777778
14905, 0.8695652173913, 1.75, 0.25
14906, 0.84782608695652, 1.75, 0.33333333333333
14907, 0.8695652173913, 1.75, 0.30555555555556
14908, 0.84782608695652, 1.75, 0.38888888888889
14909, 0.8695652173913, 1.75, 0.36111111111111
14910, 0.84782608695652, 1.75, 0.44444444444444
14911, 0.8695652173913, 1.75, 0.41666666666667
14912, 0.8695652173913, 1.75, 0.47222222222222
14913, 0.89130434782609, 1.75, 0.055555555555556
14914, 0.91304347826087, 1.75, 0.027777777777778
14915, 0.89130434782609, 1.75, 0.11111111111111
14916, 0.91304347826087, 1.75, 0.083333333333333
14917, 0.89130434782609, 1.75, 0.16666666666667
14918, 0.91304347826087, 1.75, 0.13888888888889
14919, 0.89130434782609, 1.75, 0.22222222222222
14920, 0.91304347826087, 1.75, 0.19444444444444
14921, 0.89130434782609, 1.75, 0.27777777777778
14922, 0.91304347826087, 1.75, 0.25
14923, 0.89130434782609, 1.75, 0.33333333333333
14924, 0.91304347826087, 1.75, 0.30555555555556
14925, 0.89130434782609, 1.75, 0.38888888888889
14926, 0.91304347826087, 1.75, 0.36111111111111
14927, 0.89130434782609, 1.75, 0.44444444444444
14928, 0.91304347826087, 1.75, 0.41666666666667
14929, 0.91304347826087, 1.75, 0.47222222222222
14930, 0.93478260869565, 1.75, 0.055555555555556
14931, 0.95652173913043, 1.75, 0.027777777777778
14932, 0.93478260869565, 1.75, 0.11111111111111
14933, 0.95652173913043, 1.75, 0.083333333333333
14934, 0.93478260869565, 1.75, 0.16666666666667
14935, 0.95652173913043, 1.75, 0.13888888888889
14936, 0.93478260869565, 1.75, 0.22222222222222
14937, 0.95652173913043, 1.75, 0.19444444444444
14938, 0.93478260869565, 1.75, 0.27777777777778
14939, 0.95652173913043, 1.75, 0.25
14940, 0.93478260869565, 1.75, 0.33333333333333
14941, 0.95652173913043, 1.75, 0.30555555555556
14942, 0.93478260869565, 1.75, 0.38888888888889
14943, 0.95652173913043, 1.75, 0.36111111111111
14944, 0.93478260869565, 1.75, 0.44444444444444
14945, 0.95652173913043, 1.75, 0.41666666666667
14946, 0.95652173913043, 1.75, 0.47222222222222
14947, 0.97826086956522, 1.75, 0.055555555555556
14948, 0.97826086956522, 1.75, 0.11111111111111
14949, 0.97826086956522, 1.75, 0.16666666666667
14950, 0.97826086956522, 1.75, 0.22222222222222
14951, 0.97826086956522, 1.75, 0.27777777777778
14952, 0.97826086956522, 1.75, 0.33333333333333
14953, 0.97826086956522, 1.75, 0.38888888888889
14954, 0.97826086956522, 1.75, 0.44444444444444
14955, -0.05, 1.6, 0.5
14956, -0.05, 1.65, 0.5
14957, -0.05, 1.7, 0.5
14958, -0.025, 1.6, 0.5
14959, -0.05, 1.575, 0.5
14960, -0.025, 1.65, 0.5
14961, -0.05, 1.625, 0.5
14962, -0.025, 1.7, 0.5
14963, -0.05, 1.675, 0.5
14964, -0.05, 1.725, 0.5
14965, -0.075, 1.6, 0.5
14966, -0.075, 1.65, 0.5
14967, -0.075, 1.7, 0.5
14968, -0.05, 1.6, 0
14969, -0.05, 1.65, 0
14970, -0.05, 1.7, 0
14971, -0.05, 1.575, 0
14972, -0.025, 1.6, 0
14973, -0.05, 1.625, 0
14974, -0.025, 1.65, 0
14975, -0.05, 1.675, 0
14976, -0.025, 1.7, 0
14977, -0.05, 1.725, 0
14978, -0.075, 1.6, 0
14979, -0.075, 1.65, 0
14980, -0.075, 1.7, 0
14981, -0.05, 1.55, 0.44444444444444
14982, -0.05, 1.55, 0.38888888888889
14983, -0.05, 1.55, 0.33333333333333
14984, -0.05, 1.55, 0.27777777777778
14985, -0.05, 1.55, 0.22222222222222
14986, -0.05, 1.55, 0.16666666666667
14987, -0.05, 1.55, 0.11111111111111
14988, -0.05, 1.55, 0.055555555555556
14989, -0.05, 1.55, 0.47222222222222
14990, -0.025, 1.55, 0.44444444444444
14991, -0.05, 1.55, 0.41666666666667
14992, -0.025, 1.55, 0.38888888888889
14993, -0.05, 1.55, 0.36111111111111
14994, -0.025, 1.55, 0.33333333333333
14995, -0.05, 1.55, 0.30555555555556
14996, -0.025, 1.55, 0.27777777777778
14997, -0.05, 1.55, 0.25
14998, -0.025, 1.55, 0.22222222222222
14999, -0.05, 1.55, 0.19444444444444
15000, -0.025, 1.55, 0.16666666666667
15001, -0.05, 1.55, 0.13888888888889
15002, -0.025, 1.55, 0.11111111111111
15003, -0.05, 1.55, 0.083333333333333
15004, -0.025, 1.55, 0.055555555555556
15005, -0.05, 1.55, 0.027777777777778
15006, -0.075, 1.55, 0.44444444444444
15007, -0.075, 1.55, 0.38888888888889
15008, -0.075, 1.55, 0.33333333333333
15009, -0.075, 1.55, 0.27777777777778
15010, -0.075, 1.55, 0.22222222222222
15011, -0.075, 1.55, 0.16666666666667
15012, -0.075, 1.55, 0.11111111111111
15013, -0.075, 1.55, 0.055555555555556
15014, -0.05, 1.75, 0.44444444444444
15015, -0.05, 1.75, 0.38888888888889
15016, -0.05, 1.75, 0.33333333333333
15017, -0.05, 1.75, 0.27777777777778
15018, -0.05, 1.75, 0.22222222222222
15019, -0.05, 1.75, 0.16666666666667
15020, -0.05, 1.75, 0.11111111111111
15021, -0.05, 1.75, 0.055555555555556
15022, -0.025, 1.75, 0.44444444444444
15023, -0.05, 1.75, 0.47222222222222
15024, -0.025, 1.75, 0.38888888888889
15025, -0.05, 1.75, 0.41666666666667
15026, -0.025, 1.75, 0.33333333333333
15027, -0.05, 1.75, 0.36111111111111
15028, -0.025, 1.75, 0.27777777777778
15029, -0.05, 1.75, 0.30555555555556
15030, -0.025, 1.75, 0.22222222222222
15031, -0.05, 1.75, 0.25
15032, -0.025, 1.75, 0.16666666666667
15033, -0.05, 1.75, 0.19444444444444
15034, -0.025, 1.75, 0.11111111111111
15035, -0.05, 1.75, 0.13888888888889
15036, -0.025, 1.75, 0.055555555555556
15037, -0.05, 1.75, 0.083333333333333
15038, -0.05, 1.75, 0.027777777777778
15039, -0.075, 1.75, 0.44444444444444
15040, -0.075, 1.75, 0.38888888888889
15041, -0.075, 1.75, 0.33333333333333
15042, -0.075, 1.75, 0.27777777777778
15043, -0.075, 1.75, 0.22222222222222
15044, -0.075, 1.75, 0.16666666666667
15045, -0.075, 1.75, 0.11111111111111
15046, -0.075, 1.75, 0.055555555555556
15047, -0.1, 1.6, 0.44444444444444
15048, -0.1, 1.6, 0.38888888888889
15049, -0.1, 1.6, 0.33333333333333
15050, -0.1, 1.6, 0.27777777777778
15051, -0.1, 1.6, 0.22222222222222
15052, -0.1, 1.6, 0.16666666666667
15053, -0.1, 1.6, 0.11111111111111
15054, -0.1, 1.6, 0.055555555555556
15055, -0.1, 1.65, 0.44444444444444
15056, -0.1, 1.65, 0.38888888888889
15057, -0.1, 1.65, 0.33333333333333
15058, -0.1, 1.65, 0.27777777777778
15059, -0.1, 1.65, 0.22222222222222
15060, -0.1, 1.65, 0.16666666666667
15061, -0.1, 1.65, 0.11111111111111
15062, -0.1, 1.65, 0.055555555555556
15063, -0.1, 1.7, 0.44444444444444
15064, -0.1, 1.7, 0.38888888888889
15065, -0.1, 1.7, 0.33333333333333
15066, -0.1, 1.7, 0.27777777777778
15067, -0.1, 1.7, 0.22222222222222
15068, -0.1, 1.7, 0.16666666666667
15069, -0.1, 1.7, 0.11111111111111
15070, -0.1, 1.7, 0.055555555555556
15071, -0.1, 1.6, 0.47222222222222
15072, -0.1, 1.575, 0.44444444444444
15073, -0.1, 1.6, 0.41666666666667
15074, -0.1, 1.575, 0.38888888888889
15075, -0.1, 1.6, 0.36111111111111
15076, -0.1, 1.575, 0.33333333333333
15077, -0.1, 1.6, 0.30555555555556
15078, -0.1, 1.575, 0.27777777777778
15079, -0.1, 1.6, 0.25
15080, -0.1, 1.575, 0.22222222222222
15081, -0.1, 1.6, 0.19444444444444
15082, -0.1, 1.575, 0.16666666666667
15083, -0.1, 1.6, 0.13888888888889
15084, -0.1, 1.575, 0.11111111111111
15085, -0.1, 1.6, 0.083333333333333
15086, -0.1, 1.575, 0.055555555555556
15087, -0.1, 1.6, 0.027777777777778
15088, -0.1, 1.65, 0.47222222222222
15089, -0.1, 1.625, 0.44444444444444
15090, -0.1, 1.65, 0.41666666666667
15091, -0.1, 1.625, 0.38888888888889
15092, -0.1, 1.65, 0.36111111111111
15093, -0.1, 1.625, 0.33333333333333
15094, -0.1, 1.65, 0.30555555555556
15095, -0.1, 1.625, 0.27777777777778
15096, -0.1, 1.65, 0.25
15097, -0.1, 1.625, 0.22222222222222
15098, -0.1, 1.65, 0.19444444444444
15099, -0.1, 1.625, 0.16666666666667
15100, -0.1, 1.65, 0.13888888888889
15101, -0.1, 1.625, 0.11111111111111
15102, -0.1, 1.65, 0.083333333333333
15103, -0.1, 1.625, 0.055555555555556
15104, -0.1, 1.65, 0.027777777777778
15105, -0.1, 1.7, 0.47222222222222
15106, -0.1, 1.675, 0.44444444444444
15107, -0.1, 1.7, 0.41666666666667
15108, -0.1, 1.675, 0.38888888888889
15109, -0.1, 1.7, 0.36111111111111
15110, -0.1, 1.675, 0.33333333333333
15111, -0.1, 1.7, 0.30555555555556
15112, -0.1, 1.675, 0.27777777777778
15113, -0.1, 1.7, 0.25
15114, -0.1, 1.675, 0.22222222222222
15115, -0.1, 1.7, 0.19444444444444
15116, -0.1, 1.675, 0.16666666666667
15117, -0.1, 1.7, 0.13888888888889
15118, -0.1, 1.675, 0.11111111111111
15119, -0.1, 1.7, 0.083333333333333
15120, -0.1, 1.675, 0.055555555555556
15121, -0.1, 1.7, 0.027777777777778
15122, -0.1, 1.725, 0.44444444444444
15123, -0.1, 1.725, 0.38888888888889
15124, -0.1, 1.725, 0.33333333333333
15125, -0.1, 1.725, 0.27777777777778
15126, -0.1, 1.725, 0.22222222222222
15127, -0.1, 1.725, 0.16666666666667
15128, -0.1, 1.725, 0.11111111111111
15129, -0.1, 1.725, 0.055555555555556
15130, 0.95652173913043, 1.425, 0
15131, 0.91304347826087, 1.425, 0
15132, 0.8695652173913, 1.425, 0
15133, 0.82608695652174, 1.425, 0
15134, 0.78260869565217, 1.425, 0
15135, 0.73913043478261, 1.425, 0
15136, 0.69565217391304, 1.425, 0
15137, 0.65217391304348, 1.425, 0
15138, 0.60869565217391, 1.425, 0
15139, 0.56521739130435, 1.425, 0
15140, 0.52173913043478, 1.425, 0
15141, 0.47826086956522, 1.425, 0
15142, 0.43478260869565, 1.425, 0
15143, 0.39130434782609, 1.425, 0
15144, 0.34782608695652, 1.425, 0
15145, 0.30434782608696, 1.425, 0
15146, 0.26086956521739, 1.425, 0
15147, 0.21739130434783, 1.425, 0
15148, 0.17391304347826, 1.425, 0
15149, 0.1304347826087, 1.425, 0
15150, 0.08695652173913, 1.425, 0
15151, 0.043478260869565, 1.425, 0
15152, 0.95652173913043, 1.4125, 0
15153, 0.97826086956522, 1.425, 0
15154, 0.91304347826087, 1.4125, 0
15155, 0.93478260869565, 1.425, 0
15156, 0.8695652173913, 1.4125, 0
15157, 0.89130434782609, 1.425, 0
15158, 0.82608695652174, 1.4125, 0
15159, 0.84782608695652, 1.425, 0
15160, 0.78260869565217, 1.4125, 0
15161, 0.80434782608696, 1.425, 0
15162, 0.73913043478261, 1.4125, 0
15163, 0.76086956521739, 1.425, 0
15164, 0.69565217391304, 1.4125, 0
15165, 0.71739130434783, 1.425, 0
15166, 0.65217391304348, 1.4125, 0
15167, 0.67391304347826, 1.425, 0
15168, 0.60869565217391, 1.4125, 0
15169, 0.6304347826087, 1.425, 0
15170, 0.56521739130435, 1.4125, 0
15171, 0.58695652173913, 1.425, 0
15172, 0.52173913043478, 1.4125, 0
15173, 0.54347826086957, 1.425, 0
15174, 0.47826086956522, 1.4125, 0
15175, 0.5, 1.425, 0
15176, 0.43478260869565, 1.4125, 0
15177, 0.45652173913043, 1.425, 0
15178, 0.39130434782609, 1.4125, 0
15179, 0.41304347826087, 1.425, 0
15180, 0.34782608695652, 1.4125, 0
15181, 0.3695652173913, 1.425, 0
15182, 0.30434782608696, 1.4125, 0
15183, 0.32608695652174, 1.425, 0
15184, 0.26086956521739, 1.4125, 0
15185, 0.28260869565217, 1.425, 0
15186, 0.21739130434783, 1.4125, 0
15187, 0.23913043478261, 1.425, 0
15188, 0.17391304347826, 1.4125, 0
15189, 0.19565217391304, 1.425, 0
15190, 0.1304347826087, 1.4125, 0
15191, 0.15217391304348, 1.425, 0
15192, 0.08695652173913, 1.4125, 0
15193, 0.10869565217391, 1.425, 0
15194, 0.043478260869565, 1.4125, 0
15195, 0.065217391304348, 1.425, 0
15196, 0.021739130434783, 1.425, 0
15197, 0.95652173913043, 1.4375, 0
15198, 0.91304347826087, 1.4375, 0
15199, 0.8695652173913, 1.4375, 0
15200, 0.82608695652174, 1.4375, 0
15201, 0.78260869565217, 1.4375, 0
15202, 0.73913043478261, 1.4375, 0
15203, 0.69565217391304, 1.4375, 0
15204, 0.65217391304348, 1.4375, 0
15205, 0.60869565217391, 1.4375, 0
15206, 0.56521739130435, 1.4375, 0
15207, 0.52173913043478, 1.4375, 0
15208, 0.47826086956522, 1.4375, 0
15209, 0.43478260869565, 1.4375, 0
15210, 0.39130434782609, 1.4375, 0
15211, 0.34782608695652, 1.4375, 0
15212, 0.30434782608696, 1.4375, 0
15213, 0.26086956521739, 1.4375, 0
15214, 0.21739130434783, 1.4375, 0
15215, 0.17391304347826, 1.4375, 0
15216, 0.1304347826087, 1.4375, 0
15217, 0.08695652173913, 1.4375, 0
15218, 0.043478260869565, 1.4375, 0
15219, 1, 1.425, 0.44444444444444
15220, 1, 1.425, 0.38888888888889
15221, 1, 1.425, 0.33333333333333
15222, 1, 1.425, 0.27777777777778
15223, 1, 1.425, 0.22222222222222
15224, 1, 1.425, 0.16666666666667
15225, 1, 1.425, 0.11111111111111
15226, 1, 1.425, 0.055555555555556
15227, 1, 1.4125, 0.44444444444444
15228, 1, 1.425, 0.47222222222222
15229, 1, 1.4125, 0.38888888888889
15230, 1, 1.425, 0.41666666666667
15231, 1, 1.4125, 0.33333333333333
15232, 1, 1.425, 0.36111111111111
15233, 1, 1.4125, 0.27777777777778
15234, 1, 1.425, 0.30555555555556
15235, 1, 1.4125, 0.22222222222222
15236, 1, 1.425, 0.25
15237, 1, 1.4125, 0.16666666666667
15238, 1, 1.425, 0.19444444444444
15239, 1, 1.4125, 0.11111111111111
15240, 1, 1.425, 0.13888888888889
15241, 1, 1.4125, 0.055555555555556
15242, 1, 1.425, 0.083333333333333
15243, 1, 1.425, 0.027777777777778
15244, 1, 1.4375, 0.44444444444444
15245, 1, 1.4375, 0.38888888888889
15246, 1, 1.4375, 0.33333333333333
15247, 1, 1.4375, 0.27777777777778
15248, 1, 1.4375, 0.22222222222222
15249, 1, 1.4375, 0.16666666666667
15250, 1, 1.4375, 0.11111111111111
15251, 1, 1.4375, 0.055555555555556
15252, 0.95652173913043, 1.425, 0.5
15253, 0.91304347826087, 1.425, 0.5
15254, 0.8695652173913, 1.425, 0.5
15255, 0.82608695652174, 1.425, 0.5
15256, 0.78260869565217, 1.425, 0.5
15257, 0.73913043478261, 1.425, 0.5
15258, 0.69565217391304, 1.425, 0.5
15259, 0.65217391304348, 1.425, 0.5
15260, 0.60869565217391, 1.425, 0.5
