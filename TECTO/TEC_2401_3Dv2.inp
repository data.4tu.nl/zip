47882, 0.19565217391304, 0.56739130434783, 0.44444444444444
47883, 0.17391304347826, 0.54130434782609, 0.44444444444444
47884, 0.17391304347826, 0.56739130434783, 0.47222222222222
47885, 0.1304347826087, 0.56739130434783, 0.027777777777778
47886, 0.15217391304348, 0.56739130434783, 0.055555555555556
47887, 0.1304347826087, 0.54130434782609, 0.055555555555556
47888, 0.1304347826087, 0.56739130434783, 0.083333333333333
47889, 0.15217391304348, 0.56739130434783, 0.11111111111111
47890, 0.1304347826087, 0.54130434782609, 0.11111111111111
47891, 0.1304347826087, 0.56739130434783, 0.13888888888889
47892, 0.15217391304348, 0.56739130434783, 0.16666666666667
47893, 0.1304347826087, 0.54130434782609, 0.16666666666667
47894, 0.1304347826087, 0.56739130434783, 0.19444444444444
47895, 0.15217391304348, 0.56739130434783, 0.22222222222222
47896, 0.1304347826087, 0.54130434782609, 0.22222222222222
47897, 0.1304347826087, 0.56739130434783, 0.25
47898, 0.15217391304348, 0.56739130434783, 0.27777777777778
47899, 0.1304347826087, 0.54130434782609, 0.27777777777778
47900, 0.1304347826087, 0.56739130434783, 0.30555555555556
47901, 0.15217391304348, 0.56739130434783, 0.33333333333333
47902, 0.1304347826087, 0.54130434782609, 0.33333333333333
47903, 0.1304347826087, 0.56739130434783, 0.36111111111111
47904, 0.15217391304348, 0.56739130434783, 0.38888888888889
47905, 0.1304347826087, 0.54130434782609, 0.38888888888889
47906, 0.1304347826087, 0.56739130434783, 0.41666666666667
47907, 0.15217391304348, 0.56739130434783, 0.44444444444444
47908, 0.1304347826087, 0.54130434782609, 0.44444444444444
47909, 0.1304347826087, 0.56739130434783, 0.47222222222222
47910, 0.08695652173913, 0.56739130434783, 0.027777777777778
47911, 0.10869565217391, 0.56739130434783, 0.055555555555556
47912, 0.08695652173913, 0.54130434782609, 0.055555555555556
47913, 0.08695652173913, 0.56739130434783, 0.083333333333333
47914, 0.10869565217391, 0.56739130434783, 0.11111111111111
47915, 0.08695652173913, 0.54130434782609, 0.11111111111111
47916, 0.08695652173913, 0.56739130434783, 0.13888888888889
47917, 0.10869565217391, 0.56739130434783, 0.16666666666667
47918, 0.08695652173913, 0.54130434782609, 0.16666666666667
47919, 0.08695652173913, 0.56739130434783, 0.19444444444444
47920, 0.10869565217391, 0.56739130434783, 0.22222222222222
47921, 0.08695652173913, 0.54130434782609, 0.22222222222222
47922, 0.08695652173913, 0.56739130434783, 0.25
47923, 0.10869565217391, 0.56739130434783, 0.27777777777778
47924, 0.08695652173913, 0.54130434782609, 0.27777777777778
47925, 0.08695652173913, 0.56739130434783, 0.30555555555556
47926, 0.10869565217391, 0.56739130434783, 0.33333333333333
47927, 0.08695652173913, 0.54130434782609, 0.33333333333333
47928, 0.08695652173913, 0.56739130434783, 0.36111111111111
47929, 0.10869565217391, 0.56739130434783, 0.38888888888889
47930, 0.08695652173913, 0.54130434782609, 0.38888888888889
47931, 0.08695652173913, 0.56739130434783, 0.41666666666667
47932, 0.10869565217391, 0.56739130434783, 0.44444444444444
47933, 0.08695652173913, 0.54130434782609, 0.44444444444444
47934, 0.08695652173913, 0.56739130434783, 0.47222222222222
47935, 0.043478260869565, 0.56739130434783, 0.027777777777778
47936, 0.065217391304348, 0.56739130434783, 0.055555555555556
47937, 0.043478260869565, 0.54130434782609, 0.055555555555556
47938, 0.043478260869565, 0.56739130434783, 0.083333333333333
47939, 0.065217391304348, 0.56739130434783, 0.11111111111111
47940, 0.043478260869565, 0.54130434782609, 0.11111111111111
47941, 0.043478260869565, 0.56739130434783, 0.13888888888889
47942, 0.065217391304348, 0.56739130434783, 0.16666666666667
47943, 0.043478260869565, 0.54130434782609, 0.16666666666667
47944, 0.043478260869565, 0.56739130434783, 0.19444444444444
47945, 0.065217391304348, 0.56739130434783, 0.22222222222222
47946, 0.043478260869565, 0.54130434782609, 0.22222222222222
47947, 0.043478260869565, 0.56739130434783, 0.25
47948, 0.065217391304348, 0.56739130434783, 0.27777777777778
47949, 0.043478260869565, 0.54130434782609, 0.27777777777778
47950, 0.043478260869565, 0.56739130434783, 0.30555555555556
47951, 0.065217391304348, 0.56739130434783, 0.33333333333333
47952, 0.043478260869565, 0.54130434782609, 0.33333333333333
47953, 0.043478260869565, 0.56739130434783, 0.36111111111111
47954, 0.065217391304348, 0.56739130434783, 0.38888888888889
47955, 0.043478260869565, 0.54130434782609, 0.38888888888889
47956, 0.043478260869565, 0.56739130434783, 0.41666666666667
47957, 0.065217391304348, 0.56739130434783, 0.44444444444444
47958, 0.043478260869565, 0.54130434782609, 0.44444444444444
47959, 0.043478260869565, 0.56739130434783, 0.47222222222222
47960, 0.021739130434783, 0.56739130434783, 0.055555555555556
47961, 0.021739130434783, 0.56739130434783, 0.11111111111111
47962, 0.021739130434783, 0.56739130434783, 0.16666666666667
47963, 0.021739130434783, 0.56739130434783, 0.22222222222222
47964, 0.021739130434783, 0.56739130434783, 0.27777777777778
47965, 0.021739130434783, 0.56739130434783, 0.33333333333333
47966, 0.021739130434783, 0.56739130434783, 0.38888888888889
47967, 0.021739130434783, 0.56739130434783, 0.44444444444444
47968, 0.95652173913043, 0.6195652173913, 0.027777777777778
47969, 0.97826086956522, 0.6195652173913, 0.055555555555556
47970, 0.95652173913043, 0.59347826086956, 0.055555555555556
47971, 0.95652173913043, 0.6195652173913, 0.083333333333333
47972, 0.97826086956522, 0.6195652173913, 0.11111111111111
47973, 0.95652173913044, 0.59347826086956, 0.11111111111111
47974, 0.95652173913044, 0.6195652173913, 0.13888888888889
47975, 0.97826086956522, 0.6195652173913, 0.16666666666667
47976, 0.95652173913044, 0.59347826086956, 0.16666666666667
47977, 0.95652173913044, 0.6195652173913, 0.19444444444444
47978, 0.97826086956522, 0.6195652173913, 0.22222222222222
47979, 0.95652173913044, 0.59347826086956, 0.22222222222222
47980, 0.95652173913044, 0.6195652173913, 0.25
47981, 0.97826086956522, 0.6195652173913, 0.27777777777778
47982, 0.95652173913044, 0.59347826086956, 0.27777777777778
47983, 0.95652173913044, 0.6195652173913, 0.30555555555556
47984, 0.97826086956522, 0.6195652173913, 0.33333333333333
47985, 0.95652173913044, 0.59347826086956, 0.33333333333333
47986, 0.95652173913044, 0.6195652173913, 0.36111111111111
47987, 0.97826086956522, 0.6195652173913, 0.38888888888889
47988, 0.95652173913044, 0.59347826086956, 0.38888888888889
47989, 0.95652173913044, 0.6195652173913, 0.41666666666667
47990, 0.97826086956522, 0.6195652173913, 0.44444444444444
47991, 0.95652173913044, 0.59347826086956, 0.44444444444444
47992, 0.95652173913043, 0.6195652173913, 0.47222222222222
47993, 0.91304347826087, 0.6195652173913, 0.027777777777778
47994, 0.93478260869565, 0.6195652173913, 0.055555555555556
47995, 0.91304347826087, 0.59347826086956, 0.055555555555556
47996, 0.91304347826087, 0.6195652173913, 0.083333333333333
47997, 0.93478260869565, 0.6195652173913, 0.11111111111111
47998, 0.91304347826087, 0.59347826086956, 0.11111111111111
47999, 0.91304347826087, 0.6195652173913, 0.13888888888889
48000, 0.93478260869565, 0.6195652173913, 0.16666666666667
48001, 0.91304347826087, 0.59347826086956, 0.16666666666667
48002, 0.91304347826087, 0.6195652173913, 0.19444444444444
48003, 0.93478260869565, 0.6195652173913, 0.22222222222222
48004, 0.91304347826087, 0.59347826086956, 0.22222222222222
48005, 0.91304347826087, 0.6195652173913, 0.25
48006, 0.93478260869565, 0.6195652173913, 0.27777777777778
48007, 0.91304347826087, 0.59347826086957, 0.27777777777778
48008, 0.91304347826087, 0.6195652173913, 0.30555555555556
48009, 0.93478260869565, 0.6195652173913, 0.33333333333333
48010, 0.91304347826087, 0.59347826086956, 0.33333333333333
48011, 0.91304347826087, 0.6195652173913, 0.36111111111111
48012, 0.93478260869565, 0.6195652173913, 0.38888888888889
48013, 0.91304347826087, 0.59347826086957, 0.38888888888889
48014, 0.91304347826087, 0.6195652173913, 0.41666666666667
48015, 0.93478260869565, 0.6195652173913, 0.44444444444444
48016, 0.91304347826087, 0.59347826086956, 0.44444444444444
48017, 0.91304347826087, 0.6195652173913, 0.47222222222222
48018, 0.8695652173913, 0.6195652173913, 0.027777777777778
48019, 0.89130434782609, 0.6195652173913, 0.055555555555556
48020, 0.8695652173913, 0.59347826086956, 0.055555555555556
48021, 0.8695652173913, 0.6195652173913, 0.083333333333333
48022, 0.89130434782609, 0.6195652173913, 0.11111111111111
48023, 0.8695652173913, 0.59347826086956, 0.11111111111111
48024, 0.8695652173913, 0.6195652173913, 0.13888888888889
48025, 0.89130434782609, 0.6195652173913, 0.16666666666667
48026, 0.8695652173913, 0.59347826086956, 0.16666666666667
48027, 0.8695652173913, 0.6195652173913, 0.19444444444444
48028, 0.89130434782609, 0.6195652173913, 0.22222222222222
48029, 0.8695652173913, 0.59347826086956, 0.22222222222222
48030, 0.8695652173913, 0.6195652173913, 0.25
48031, 0.89130434782609, 0.6195652173913, 0.27777777777778
48032, 0.8695652173913, 0.59347826086956, 0.27777777777778
48033, 0.8695652173913, 0.6195652173913, 0.30555555555556
48034, 0.89130434782609, 0.6195652173913, 0.33333333333333
48035, 0.8695652173913, 0.59347826086956, 0.33333333333333
48036, 0.8695652173913, 0.6195652173913, 0.36111111111111
48037, 0.89130434782609, 0.6195652173913, 0.38888888888889
48038, 0.8695652173913, 0.59347826086956, 0.38888888888889
48039, 0.8695652173913, 0.6195652173913, 0.41666666666667
48040, 0.89130434782609, 0.6195652173913, 0.44444444444444
48041, 0.8695652173913, 0.59347826086956, 0.44444444444444
48042, 0.8695652173913, 0.6195652173913, 0.47222222222222
48043, 0.82608695652174, 0.6195652173913, 0.027777777777778
48044, 0.84782608695652, 0.6195652173913, 0.055555555555556
48045, 0.82608695652174, 0.59347826086956, 0.055555555555556
48046, 0.82608695652174, 0.6195652173913, 0.083333333333333
48047, 0.84782608695652, 0.6195652173913, 0.11111111111111
48048, 0.82608695652174, 0.59347826086957, 0.11111111111111
48049, 0.82608695652174, 0.6195652173913, 0.13888888888889
48050, 0.84782608695652, 0.6195652173913, 0.16666666666667
48051, 0.82608695652174, 0.59347826086956, 0.16666666666667
48052, 0.82608695652174, 0.6195652173913, 0.19444444444444
48053, 0.84782608695652, 0.6195652173913, 0.22222222222222
48054, 0.82608695652174, 0.59347826086956, 0.22222222222222
48055, 0.82608695652174, 0.6195652173913, 0.25
48056, 0.84782608695652, 0.6195652173913, 0.27777777777778
48057, 0.82608695652174, 0.59347826086956, 0.27777777777778
48058, 0.82608695652174, 0.6195652173913, 0.30555555555556
48059, 0.84782608695652, 0.6195652173913, 0.33333333333333
48060, 0.82608695652174, 0.59347826086956, 0.33333333333333
48061, 0.82608695652174, 0.6195652173913, 0.36111111111111
48062, 0.84782608695652, 0.6195652173913, 0.38888888888889
48063, 0.82608695652174, 0.59347826086957, 0.38888888888889
48064, 0.82608695652174, 0.6195652173913, 0.41666666666667
48065, 0.84782608695652, 0.6195652173913, 0.44444444444444
48066, 0.82608695652174, 0.59347826086956, 0.44444444444444
48067, 0.82608695652174, 0.6195652173913, 0.47222222222222
48068, 0.78260869565217, 0.6195652173913, 0.027777777777778
48069, 0.80434782608696, 0.6195652173913, 0.055555555555556
48070, 0.78260869565217, 0.59347826086956, 0.055555555555556
48071, 0.78260869565217, 0.6195652173913, 0.083333333333333
48072, 0.80434782608696, 0.6195652173913, 0.11111111111111
48073, 0.78260869565217, 0.59347826086956, 0.11111111111111
48074, 0.78260869565217, 0.6195652173913, 0.13888888888889
48075, 0.80434782608696, 0.6195652173913, 0.16666666666667
48076, 0.78260869565217, 0.59347826086956, 0.16666666666667
48077, 0.78260869565217, 0.6195652173913, 0.19444444444444
48078, 0.80434782608696, 0.6195652173913, 0.22222222222222
48079, 0.78260869565217, 0.59347826086957, 0.22222222222222
48080, 0.78260869565217, 0.6195652173913, 0.25
48081, 0.80434782608696, 0.6195652173913, 0.27777777777778
48082, 0.78260869565217, 0.59347826086957, 0.27777777777778
48083, 0.78260869565217, 0.6195652173913, 0.30555555555556
48084, 0.80434782608696, 0.6195652173913, 0.33333333333333
48085, 0.78260869565217, 0.59347826086956, 0.33333333333333
48086, 0.78260869565217, 0.6195652173913, 0.36111111111111
48087, 0.80434782608696, 0.6195652173913, 0.38888888888889
48088, 0.78260869565217, 0.59347826086956, 0.38888888888889
48089, 0.78260869565217, 0.6195652173913, 0.41666666666667
48090, 0.80434782608696, 0.6195652173913, 0.44444444444444
48091, 0.78260869565217, 0.59347826086956, 0.44444444444444
48092, 0.78260869565217, 0.6195652173913, 0.47222222222222
48093, 0.73913043478261, 0.6195652173913, 0.027777777777778
48094, 0.76086956521739, 0.6195652173913, 0.055555555555556
48095, 0.73913043478261, 0.59347826086956, 0.055555555555556
48096, 0.73913043478261, 0.6195652173913, 0.083333333333333
48097, 0.76086956521739, 0.6195652173913, 0.11111111111111
48098, 0.73913043478261, 0.59347826086956, 0.11111111111111
48099, 0.73913043478261, 0.6195652173913, 0.13888888888889
48100, 0.76086956521739, 0.6195652173913, 0.16666666666667
48101, 0.73913043478261, 0.59347826086956, 0.16666666666667
48102, 0.73913043478261, 0.6195652173913, 0.19444444444444
48103, 0.76086956521739, 0.6195652173913, 0.22222222222222
48104, 0.73913043478261, 0.59347826086956, 0.22222222222222
48105, 0.73913043478261, 0.6195652173913, 0.25
48106, 0.76086956521739, 0.6195652173913, 0.27777777777778
48107, 0.73913043478261, 0.59347826086956, 0.27777777777778
48108, 0.73913043478261, 0.6195652173913, 0.30555555555556
48109, 0.76086956521739, 0.6195652173913, 0.33333333333333
48110, 0.73913043478261, 0.59347826086956, 0.33333333333333
48111, 0.73913043478261, 0.6195652173913, 0.36111111111111
48112, 0.76086956521739, 0.6195652173913, 0.38888888888889
48113, 0.73913043478261, 0.59347826086957, 0.38888888888889
48114, 0.73913043478261, 0.6195652173913, 0.41666666666667
48115, 0.76086956521739, 0.6195652173913, 0.44444444444444
48116, 0.73913043478261, 0.59347826086956, 0.44444444444444
48117, 0.73913043478261, 0.6195652173913, 0.47222222222222
48118, 0.69565217391304, 0.6195652173913, 0.027777777777778
48119, 0.71739130434783, 0.6195652173913, 0.055555555555556
48120, 0.69565217391304, 0.59347826086956, 0.055555555555556
48121, 0.69565217391304, 0.6195652173913, 0.083333333333333
48122, 0.71739130434783, 0.6195652173913, 0.11111111111111
48123, 0.69565217391304, 0.59347826086956, 0.11111111111111
48124, 0.69565217391304, 0.6195652173913, 0.13888888888889
48125, 0.71739130434783, 0.6195652173913, 0.16666666666667
48126, 0.69565217391304, 0.59347826086956, 0.16666666666667
48127, 0.69565217391304, 0.6195652173913, 0.19444444444444
48128, 0.71739130434783, 0.6195652173913, 0.22222222222222
48129, 0.69565217391304, 0.59347826086956, 0.22222222222222
48130, 0.69565217391304, 0.6195652173913, 0.25
48131, 0.71739130434783, 0.6195652173913, 0.27777777777778
48132, 0.69565217391304, 0.59347826086956, 0.27777777777778
48133, 0.69565217391304, 0.6195652173913, 0.30555555555556
48134, 0.71739130434783, 0.6195652173913, 0.33333333333333
48135, 0.69565217391304, 0.59347826086956, 0.33333333333333
48136, 0.69565217391304, 0.6195652173913, 0.36111111111111
48137, 0.71739130434783, 0.6195652173913, 0.38888888888889
48138, 0.69565217391304, 0.59347826086956, 0.38888888888889
48139, 0.69565217391304, 0.6195652173913, 0.41666666666667
48140, 0.71739130434783, 0.6195652173913, 0.44444444444444
48141, 0.69565217391304, 0.59347826086956, 0.44444444444444
48142, 0.69565217391304, 0.6195652173913, 0.47222222222222
48143, 0.65217391304348, 0.6195652173913, 0.027777777777778
48144, 0.67391304347826, 0.6195652173913, 0.055555555555556
48145, 0.65217391304348, 0.59347826086956, 0.055555555555556
48146, 0.65217391304348, 0.6195652173913, 0.083333333333333
48147, 0.67391304347826, 0.6195652173913, 0.11111111111111
48148, 0.65217391304348, 0.59347826086956, 0.11111111111111
48149, 0.65217391304348, 0.6195652173913, 0.13888888888889
48150, 0.67391304347826, 0.6195652173913, 0.16666666666667
48151, 0.65217391304348, 0.59347826086956, 0.16666666666667
48152, 0.65217391304348, 0.6195652173913, 0.19444444444444
48153, 0.67391304347826, 0.6195652173913, 0.22222222222222
48154, 0.65217391304348, 0.59347826086956, 0.22222222222222
48155, 0.65217391304348, 0.6195652173913, 0.25
48156, 0.67391304347826, 0.6195652173913, 0.27777777777778
48157, 0.65217391304348, 0.59347826086956, 0.27777777777778
48158, 0.65217391304348, 0.6195652173913, 0.30555555555556
48159, 0.67391304347826, 0.6195652173913, 0.33333333333333
48160, 0.65217391304348, 0.59347826086956, 0.33333333333333
48161, 0.65217391304348, 0.6195652173913, 0.36111111111111
48162, 0.67391304347826, 0.6195652173913, 0.38888888888889
48163, 0.65217391304348, 0.59347826086957, 0.38888888888889
48164, 0.65217391304348, 0.6195652173913, 0.41666666666667
48165, 0.67391304347826, 0.6195652173913, 0.44444444444444
48166, 0.65217391304348, 0.59347826086956, 0.44444444444444
48167, 0.65217391304348, 0.6195652173913, 0.47222222222222
48168, 0.60869565217391, 0.6195652173913, 0.027777777777778
48169, 0.6304347826087, 0.6195652173913, 0.055555555555556
48170, 0.60869565217391, 0.59347826086956, 0.055555555555556
48171, 0.60869565217391, 0.6195652173913, 0.083333333333333
48172, 0.6304347826087, 0.6195652173913, 0.11111111111111
48173, 0.60869565217391, 0.59347826086956, 0.11111111111111
48174, 0.60869565217391, 0.6195652173913, 0.13888888888889
48175, 0.6304347826087, 0.6195652173913, 0.16666666666667
48176, 0.60869565217391, 0.59347826086956, 0.16666666666667
48177, 0.60869565217391, 0.6195652173913, 0.19444444444444
48178, 0.6304347826087, 0.6195652173913, 0.22222222222222
48179, 0.60869565217391, 0.59347826086956, 0.22222222222222
48180, 0.60869565217391, 0.6195652173913, 0.25
48181, 0.6304347826087, 0.6195652173913, 0.27777777777778
48182, 0.60869565217391, 0.59347826086956, 0.27777777777778
48183, 0.60869565217391, 0.6195652173913, 0.30555555555556
48184, 0.6304347826087, 0.6195652173913, 0.33333333333333
48185, 0.60869565217391, 0.59347826086956, 0.33333333333333
48186, 0.60869565217391, 0.6195652173913, 0.36111111111111
48187, 0.6304347826087, 0.6195652173913, 0.38888888888889
48188, 0.60869565217391, 0.59347826086956, 0.38888888888889
48189, 0.60869565217391, 0.6195652173913, 0.41666666666667
48190, 0.6304347826087, 0.6195652173913, 0.44444444444444
48191, 0.60869565217391, 0.59347826086956, 0.44444444444444
48192, 0.60869565217391, 0.6195652173913, 0.47222222222222
48193, 0.56521739130435, 0.6195652173913, 0.027777777777778
48194, 0.58695652173913, 0.6195652173913, 0.055555555555556
48195, 0.56521739130435, 0.59347826086956, 0.055555555555556
48196, 0.56521739130435, 0.6195652173913, 0.083333333333333
48197, 0.58695652173913, 0.6195652173913, 0.11111111111111
48198, 0.56521739130435, 0.59347826086956, 0.11111111111111
48199, 0.56521739130435, 0.6195652173913, 0.13888888888889
48200, 0.58695652173913, 0.6195652173913, 0.16666666666667
48201, 0.56521739130435, 0.59347826086956, 0.16666666666667
48202, 0.56521739130435, 0.6195652173913, 0.19444444444444
48203, 0.58695652173913, 0.6195652173913, 0.22222222222222
48204, 0.56521739130435, 0.59347826086956, 0.22222222222222
48205, 0.56521739130435, 0.6195652173913, 0.25
48206, 0.58695652173913, 0.6195652173913, 0.27777777777778
48207, 0.56521739130435, 0.59347826086956, 0.27777777777778
48208, 0.56521739130435, 0.6195652173913, 0.30555555555556
48209, 0.58695652173913, 0.6195652173913, 0.33333333333333
48210, 0.56521739130435, 0.59347826086956, 0.33333333333333
48211, 0.56521739130435, 0.6195652173913, 0.36111111111111
48212, 0.58695652173913, 0.6195652173913, 0.38888888888889
48213, 0.56521739130435, 0.59347826086957, 0.38888888888889
48214, 0.56521739130435, 0.6195652173913, 0.41666666666667
48215, 0.58695652173913, 0.6195652173913, 0.44444444444444
48216, 0.56521739130435, 0.59347826086956, 0.44444444444444
48217, 0.56521739130435, 0.6195652173913, 0.47222222222222
48218, 0.52173913043478, 0.6195652173913, 0.027777777777778
48219, 0.54347826086957, 0.6195652173913, 0.055555555555556
48220, 0.52173913043478, 0.59347826086956, 0.055555555555556
48221, 0.52173913043478, 0.6195652173913, 0.083333333333333
48222, 0.54347826086957, 0.6195652173913, 0.11111111111111
48223, 0.52173913043478, 0.59347826086956, 0.11111111111111
48224, 0.52173913043478, 0.6195652173913, 0.13888888888889
48225, 0.54347826086957, 0.6195652173913, 0.16666666666667
48226, 0.52173913043478, 0.59347826086956, 0.16666666666667
48227, 0.52173913043478, 0.6195652173913, 0.19444444444444
48228, 0.54347826086956, 0.6195652173913, 0.22222222222222
48229, 0.52173913043478, 0.59347826086956, 0.22222222222222
48230, 0.52173913043478, 0.6195652173913, 0.25
48231, 0.54347826086956, 0.6195652173913, 0.27777777777778
48232, 0.52173913043478, 0.59347826086956, 0.27777777777778
48233, 0.52173913043478, 0.6195652173913, 0.30555555555556
48234, 0.54347826086956, 0.6195652173913, 0.33333333333333
48235, 0.52173913043478, 0.59347826086956, 0.33333333333333
48236, 0.52173913043478, 0.6195652173913, 0.36111111111111
48237, 0.54347826086956, 0.6195652173913, 0.38888888888889
48238, 0.52173913043478, 0.59347826086956, 0.38888888888889
48239, 0.52173913043478, 0.6195652173913, 0.41666666666667
48240, 0.54347826086956, 0.6195652173913, 0.44444444444444
48241, 0.52173913043478, 0.59347826086956, 0.44444444444444
48242, 0.52173913043478, 0.6195652173913, 0.47222222222222
48243, 0.47826086956522, 0.6195652173913, 0.027777777777778
48244, 0.5, 0.6195652173913, 0.055555555555556
48245, 0.47826086956522, 0.59347826086956, 0.055555555555556
48246, 0.47826086956522, 0.6195652173913, 0.083333333333333
48247, 0.5, 0.6195652173913, 0.11111111111111
48248, 0.47826086956522, 0.59347826086956, 0.11111111111111
48249, 0.47826086956522, 0.6195652173913, 0.13888888888889
48250, 0.5, 0.6195652173913, 0.16666666666667
48251, 0.47826086956522, 0.59347826086957, 0.16666666666667
48252, 0.47826086956522, 0.6195652173913, 0.19444444444444
48253, 0.5, 0.6195652173913, 0.22222222222222
48254, 0.47826086956522, 0.59347826086957, 0.22222222222222
48255, 0.47826086956522, 0.6195652173913, 0.25
48256, 0.5, 0.6195652173913, 0.27777777777778
48257, 0.47826086956522, 0.59347826086956, 0.27777777777778
48258, 0.47826086956522, 0.6195652173913, 0.30555555555556
48259, 0.5, 0.6195652173913, 0.33333333333333
48260, 0.47826086956522, 0.59347826086956, 0.33333333333333
48261, 0.47826086956522, 0.6195652173913, 0.36111111111111
48262, 0.5, 0.6195652173913, 0.38888888888889
48263, 0.47826086956522, 0.59347826086956, 0.38888888888889
48264, 0.47826086956522, 0.6195652173913, 0.41666666666667
48265, 0.5, 0.6195652173913, 0.44444444444444
48266, 0.47826086956522, 0.59347826086956, 0.44444444444444
48267, 0.47826086956522, 0.6195652173913, 0.47222222222222
48268, 0.43478260869565, 0.6195652173913, 0.027777777777778
48269, 0.45652173913043, 0.6195652173913, 0.055555555555556
48270, 0.43478260869565, 0.59347826086956, 0.055555555555556
48271, 0.43478260869565, 0.6195652173913, 0.083333333333333
48272, 0.45652173913043, 0.6195652173913, 0.11111111111111
48273, 0.43478260869565, 0.59347826086956, 0.11111111111111
48274, 0.43478260869565, 0.6195652173913, 0.13888888888889
48275, 0.45652173913043, 0.6195652173913, 0.16666666666667
48276, 0.43478260869565, 0.59347826086956, 0.16666666666667
48277, 0.43478260869565, 0.6195652173913, 0.19444444444444
48278, 0.45652173913043, 0.6195652173913, 0.22222222222222
48279, 0.43478260869565, 0.59347826086956, 0.22222222222222
48280, 0.43478260869565, 0.6195652173913, 0.25
48281, 0.45652173913043, 0.6195652173913, 0.27777777777778
48282, 0.43478260869565, 0.59347826086956, 0.27777777777778
48283, 0.43478260869565, 0.6195652173913, 0.30555555555556
48284, 0.45652173913043, 0.6195652173913, 0.33333333333333
48285, 0.43478260869565, 0.59347826086956, 0.33333333333333
48286, 0.43478260869565, 0.6195652173913, 0.36111111111111
48287, 0.45652173913043, 0.6195652173913, 0.38888888888889
48288, 0.43478260869565, 0.59347826086956, 0.38888888888889
48289, 0.43478260869565, 0.6195652173913, 0.41666666666667
48290, 0.45652173913043, 0.6195652173913, 0.44444444444444
48291, 0.43478260869565, 0.59347826086956, 0.44444444444444
48292, 0.43478260869565, 0.6195652173913, 0.47222222222222
48293, 0.39130434782609, 0.6195652173913, 0.027777777777778
48294, 0.41304347826087, 0.6195652173913, 0.055555555555556
48295, 0.39130434782609, 0.59347826086956, 0.055555555555556
48296, 0.39130434782609, 0.6195652173913, 0.083333333333333
48297, 0.41304347826087, 0.6195652173913, 0.11111111111111
48298, 0.39130434782609, 0.59347826086956, 0.11111111111111
48299, 0.39130434782609, 0.6195652173913, 0.13888888888889
48300, 0.41304347826087, 0.6195652173913, 0.16666666666667
48301, 0.39130434782609, 0.59347826086956, 0.16666666666667
48302, 0.39130434782609, 0.6195652173913, 0.19444444444444
48303, 0.41304347826087, 0.6195652173913, 0.22222222222222
48304, 0.39130434782609, 0.59347826086956, 0.22222222222222
48305, 0.39130434782609, 0.6195652173913, 0.25
48306, 0.41304347826087, 0.6195652173913, 0.27777777777778
48307, 0.39130434782609, 0.59347826086956, 0.27777777777778
48308, 0.39130434782609, 0.6195652173913, 0.30555555555556
48309, 0.41304347826087, 0.6195652173913, 0.33333333333333
48310, 0.39130434782609, 0.59347826086956, 0.33333333333333
48311, 0.39130434782609, 0.6195652173913, 0.36111111111111
48312, 0.41304347826087, 0.6195652173913, 0.38888888888889
48313, 0.39130434782609, 0.59347826086956, 0.38888888888889
48314, 0.39130434782609, 0.6195652173913, 0.41666666666667
48315, 0.41304347826087, 0.6195652173913, 0.44444444444444
48316, 0.39130434782609, 0.59347826086956, 0.44444444444444
48317, 0.39130434782609, 0.6195652173913, 0.47222222222222
48318, 0.34782608695652, 0.6195652173913, 0.027777777777778
48319, 0.3695652173913, 0.6195652173913, 0.055555555555556
48320, 0.34782608695652, 0.59347826086956, 0.055555555555556
48321, 0.34782608695652, 0.6195652173913, 0.083333333333333
48322, 0.3695652173913, 0.6195652173913, 0.11111111111111
48323, 0.34782608695652, 0.59347826086956, 0.11111111111111
48324, 0.34782608695652, 0.6195652173913, 0.13888888888889
48325, 0.3695652173913, 0.6195652173913, 0.16666666666667
48326, 0.34782608695652, 0.59347826086956, 0.16666666666667
48327, 0.34782608695652, 0.6195652173913, 0.19444444444444
48328, 0.3695652173913, 0.6195652173913, 0.22222222222222
48329, 0.34782608695652, 0.59347826086956, 0.22222222222222
48330, 0.34782608695652, 0.6195652173913, 0.25
48331, 0.3695652173913, 0.6195652173913, 0.27777777777778
48332, 0.34782608695652, 0.59347826086956, 0.27777777777778
48333, 0.34782608695652, 0.6195652173913, 0.30555555555556
48334, 0.3695652173913, 0.6195652173913, 0.33333333333333
48335, 0.34782608695652, 0.59347826086956, 0.33333333333333
48336, 0.34782608695652, 0.6195652173913, 0.36111111111111
48337, 0.3695652173913, 0.6195652173913, 0.38888888888889
48338, 0.34782608695652, 0.59347826086956, 0.38888888888889
48339, 0.34782608695652, 0.6195652173913, 0.41666666666667
48340, 0.3695652173913, 0.6195652173913, 0.44444444444444
48341, 0.34782608695652, 0.59347826086956, 0.44444444444444
48342, 0.34782608695652, 0.6195652173913, 0.47222222222222
48343, 0.30434782608696, 0.6195652173913, 0.027777777777778
48344, 0.32608695652174, 0.6195652173913, 0.055555555555556
48345, 0.30434782608696, 0.59347826086956, 0.055555555555556
48346, 0.30434782608696, 0.6195652173913, 0.083333333333333
48347, 0.32608695652174, 0.6195652173913, 0.11111111111111
48348, 0.30434782608696, 0.59347826086956, 0.11111111111111
48349, 0.30434782608696, 0.6195652173913, 0.13888888888889
48350, 0.32608695652174, 0.6195652173913, 0.16666666666667
48351, 0.30434782608696, 0.59347826086956, 0.16666666666667
48352, 0.30434782608696, 0.6195652173913, 0.19444444444444
48353, 0.32608695652174, 0.6195652173913, 0.22222222222222
48354, 0.30434782608696, 0.59347826086956, 0.22222222222222
48355, 0.30434782608696, 0.6195652173913, 0.25
48356, 0.32608695652174, 0.6195652173913, 0.27777777777778
48357, 0.30434782608696, 0.59347826086956, 0.27777777777778
48358, 0.30434782608696, 0.6195652173913, 0.30555555555556
48359, 0.32608695652174, 0.6195652173913, 0.33333333333333
48360, 0.30434782608696, 0.59347826086956, 0.33333333333333
48361, 0.30434782608696, 0.6195652173913, 0.36111111111111
48362, 0.32608695652174, 0.6195652173913, 0.38888888888889
48363, 0.30434782608696, 0.59347826086956, 0.38888888888889
48364, 0.30434782608696, 0.6195652173913, 0.41666666666667
48365, 0.32608695652174, 0.6195652173913, 0.44444444444444
48366, 0.30434782608696, 0.59347826086956, 0.44444444444444
48367, 0.30434782608696, 0.6195652173913, 0.47222222222222
48368, 0.26086956521739, 0.6195652173913, 0.027777777777778
48369, 0.28260869565217, 0.6195652173913, 0.055555555555556
48370, 0.26086956521739, 0.59347826086956, 0.055555555555556
48371, 0.26086956521739, 0.6195652173913, 0.083333333333333
48372, 0.28260869565217, 0.6195652173913, 0.11111111111111
48373, 0.26086956521739, 0.59347826086956, 0.11111111111111
48374, 0.26086956521739, 0.6195652173913, 0.13888888888889
48375, 0.28260869565217, 0.6195652173913, 0.16666666666667
48376, 0.26086956521739, 0.59347826086956, 0.16666666666667
48377, 0.26086956521739, 0.6195652173913, 0.19444444444444
48378, 0.28260869565217, 0.6195652173913, 0.22222222222222
48379, 0.26086956521739, 0.59347826086956, 0.22222222222222
48380, 0.26086956521739, 0.6195652173913, 0.25
48381, 0.28260869565217, 0.6195652173913, 0.27777777777778
48382, 0.26086956521739, 0.59347826086956, 0.27777777777778
48383, 0.26086956521739, 0.6195652173913, 0.30555555555556
48384, 0.28260869565217, 0.6195652173913, 0.33333333333333
48385, 0.26086956521739, 0.59347826086956, 0.33333333333333
48386, 0.26086956521739, 0.6195652173913, 0.36111111111111
48387, 0.28260869565217, 0.6195652173913, 0.38888888888889
48388, 0.26086956521739, 0.59347826086956, 0.38888888888889
48389, 0.26086956521739, 0.6195652173913, 0.41666666666667
48390, 0.28260869565217, 0.6195652173913, 0.44444444444444
48391, 0.26086956521739, 0.59347826086956, 0.44444444444444
48392, 0.26086956521739, 0.6195652173913, 0.47222222222222
48393, 0.21739130434783, 0.6195652173913, 0.027777777777778
48394, 0.23913043478261, 0.6195652173913, 0.055555555555556
48395, 0.21739130434783, 0.59347826086956, 0.055555555555556
48396, 0.21739130434783, 0.6195652173913, 0.083333333333333
48397, 0.23913043478261, 0.6195652173913, 0.11111111111111
48398, 0.21739130434783, 0.59347826086956, 0.11111111111111
48399, 0.21739130434783, 0.6195652173913, 0.13888888888889
48400, 0.23913043478261, 0.6195652173913, 0.16666666666667
48401, 0.21739130434783, 0.59347826086956, 0.16666666666667
48402, 0.21739130434783, 0.6195652173913, 0.19444444444444
48403, 0.23913043478261, 0.6195652173913, 0.22222222222222
48404, 0.21739130434783, 0.59347826086956, 0.22222222222222
48405, 0.21739130434783, 0.6195652173913, 0.25
48406, 0.23913043478261, 0.6195652173913, 0.27777777777778
48407, 0.21739130434783, 0.59347826086956, 0.27777777777778
48408, 0.21739130434783, 0.6195652173913, 0.30555555555556
48409, 0.23913043478261, 0.6195652173913, 0.33333333333333
48410, 0.21739130434783, 0.59347826086956, 0.33333333333333
48411, 0.21739130434783, 0.6195652173913, 0.36111111111111
48412, 0.23913043478261, 0.6195652173913, 0.38888888888889
48413, 0.21739130434783, 0.59347826086956, 0.38888888888889
48414, 0.21739130434783, 0.6195652173913, 0.41666666666667
48415, 0.23913043478261, 0.6195652173913, 0.44444444444444
48416, 0.21739130434783, 0.59347826086956, 0.44444444444444
48417, 0.21739130434783, 0.6195652173913, 0.47222222222222
48418, 0.17391304347826, 0.6195652173913, 0.027777777777778
48419, 0.19565217391304, 0.6195652173913, 0.055555555555556
48420, 0.17391304347826, 0.59347826086956, 0.055555555555556
48421, 0.17391304347826, 0.6195652173913, 0.083333333333333
48422, 0.19565217391304, 0.6195652173913, 0.11111111111111
48423, 0.17391304347826, 0.59347826086956, 0.11111111111111
48424, 0.17391304347826, 0.6195652173913, 0.13888888888889
48425, 0.19565217391304, 0.6195652173913, 0.16666666666667
48426, 0.17391304347826, 0.59347826086956, 0.16666666666667
48427, 0.17391304347826, 0.6195652173913, 0.19444444444444
48428, 0.19565217391304, 0.6195652173913, 0.22222222222222
48429, 0.17391304347826, 0.59347826086956, 0.22222222222222
48430, 0.17391304347826, 0.6195652173913, 0.25
48431, 0.19565217391304, 0.6195652173913, 0.27777777777778
48432, 0.17391304347826, 0.59347826086956, 0.27777777777778
48433, 0.17391304347826, 0.6195652173913, 0.30555555555556
48434, 0.19565217391304, 0.6195652173913, 0.33333333333333
48435, 0.17391304347826, 0.59347826086956, 0.33333333333333
48436, 0.17391304347826, 0.6195652173913, 0.36111111111111
48437, 0.19565217391304, 0.6195652173913, 0.38888888888889
48438, 0.17391304347826, 0.59347826086956, 0.38888888888889
48439, 0.17391304347826, 0.6195652173913, 0.41666666666667
48440, 0.19565217391304, 0.6195652173913, 0.44444444444444
48441, 0.17391304347826, 0.59347826086956, 0.44444444444444
48442, 0.17391304347826, 0.6195652173913, 0.47222222222222
48443, 0.1304347826087, 0.6195652173913, 0.027777777777778
48444, 0.15217391304348, 0.6195652173913, 0.055555555555556
48445, 0.1304347826087, 0.59347826086956, 0.055555555555556
48446, 0.1304347826087, 0.6195652173913, 0.083333333333333
48447, 0.15217391304348, 0.6195652173913, 0.11111111111111
48448, 0.1304347826087, 0.59347826086956, 0.11111111111111
48449, 0.1304347826087, 0.6195652173913, 0.13888888888889
48450, 0.15217391304348, 0.6195652173913, 0.16666666666667
48451, 0.1304347826087, 0.59347826086956, 0.16666666666667
48452, 0.1304347826087, 0.6195652173913, 0.19444444444444
48453, 0.15217391304348, 0.6195652173913, 0.22222222222222
48454, 0.1304347826087, 0.59347826086956, 0.22222222222222
48455, 0.1304347826087, 0.6195652173913, 0.25
48456, 0.15217391304348, 0.6195652173913, 0.27777777777778
48457, 0.1304347826087, 0.59347826086956, 0.27777777777778
48458, 0.1304347826087, 0.6195652173913, 0.30555555555556
48459, 0.15217391304348, 0.6195652173913, 0.33333333333333
48460, 0.1304347826087, 0.59347826086956, 0.33333333333333
48461, 0.1304347826087, 0.6195652173913, 0.36111111111111
48462, 0.15217391304348, 0.6195652173913, 0.38888888888889
48463, 0.1304347826087, 0.59347826086956, 0.38888888888889
48464, 0.1304347826087, 0.6195652173913, 0.41666666666667
48465, 0.15217391304348, 0.6195652173913, 0.44444444444444
48466, 0.1304347826087, 0.59347826086956, 0.44444444444444
48467, 0.1304347826087, 0.6195652173913, 0.47222222222222
48468, 0.08695652173913, 0.6195652173913, 0.027777777777778
48469, 0.10869565217391, 0.6195652173913, 0.055555555555556
48470, 0.08695652173913, 0.59347826086956, 0.055555555555556
48471, 0.08695652173913, 0.6195652173913, 0.083333333333333
48472, 0.10869565217391, 0.6195652173913, 0.11111111111111
48473, 0.08695652173913, 0.59347826086956, 0.11111111111111
48474, 0.08695652173913, 0.6195652173913, 0.13888888888889
48475, 0.10869565217391, 0.6195652173913, 0.16666666666667
48476, 0.08695652173913, 0.59347826086956, 0.16666666666667
48477, 0.08695652173913, 0.6195652173913, 0.19444444444444
48478, 0.10869565217391, 0.6195652173913, 0.22222222222222
48479, 0.08695652173913, 0.59347826086956, 0.22222222222222
48480, 0.08695652173913, 0.6195652173913, 0.25
48481, 0.10869565217391, 0.6195652173913, 0.27777777777778
48482, 0.08695652173913, 0.59347826086956, 0.27777777777778
48483, 0.08695652173913, 0.6195652173913, 0.30555555555556
48484, 0.10869565217391, 0.6195652173913, 0.33333333333333
48485, 0.08695652173913, 0.59347826086956, 0.33333333333333
48486, 0.08695652173913, 0.6195652173913, 0.36111111111111
48487, 0.10869565217391, 0.6195652173913, 0.38888888888889
48488, 0.08695652173913, 0.59347826086956, 0.38888888888889
48489, 0.08695652173913, 0.6195652173913, 0.41666666666667
48490, 0.10869565217391, 0.6195652173913, 0.44444444444444
48491, 0.08695652173913, 0.59347826086956, 0.44444444444444
48492, 0.08695652173913, 0.6195652173913, 0.47222222222222
48493, 0.043478260869565, 0.6195652173913, 0.027777777777778
48494, 0.065217391304348, 0.6195652173913, 0.055555555555556
48495, 0.043478260869565, 0.59347826086956, 0.055555555555556
48496, 0.043478260869565, 0.6195652173913, 0.083333333333333
48497, 0.065217391304348, 0.6195652173913, 0.11111111111111
48498, 0.043478260869565, 0.59347826086956, 0.11111111111111
48499, 0.043478260869565, 0.6195652173913, 0.13888888888889
48500, 0.065217391304348, 0.6195652173913, 0.16666666666667
48501, 0.043478260869565, 0.59347826086956, 0.16666666666667
48502, 0.043478260869565, 0.6195652173913, 0.19444444444444
48503, 0.065217391304348, 0.6195652173913, 0.22222222222222
48504, 0.043478260869565, 0.59347826086956, 0.22222222222222
48505, 0.043478260869565, 0.6195652173913, 0.25
48506, 0.065217391304348, 0.6195652173913, 0.27777777777778
48507, 0.043478260869565, 0.59347826086956, 0.27777777777778
48508, 0.043478260869565, 0.6195652173913, 0.30555555555556
48509, 0.065217391304348, 0.6195652173913, 0.33333333333333
48510, 0.043478260869565, 0.59347826086956, 0.33333333333333
48511, 0.043478260869565, 0.6195652173913, 0.36111111111111
48512, 0.065217391304348, 0.6195652173913, 0.38888888888889
48513, 0.043478260869565, 0.59347826086956, 0.38888888888889
48514, 0.043478260869565, 0.6195652173913, 0.41666666666667
48515, 0.065217391304348, 0.6195652173913, 0.44444444444444
48516, 0.043478260869565, 0.59347826086956, 0.44444444444444
48517, 0.043478260869565, 0.6195652173913, 0.47222222222222
48518, 0.021739130434783, 0.6195652173913, 0.055555555555556
48519, 0.021739130434783, 0.6195652173913, 0.11111111111111
48520, 0.021739130434783, 0.6195652173913, 0.16666666666667
48521, 0.021739130434783, 0.6195652173913, 0.22222222222222
48522, 0.021739130434783, 0.6195652173913, 0.27777777777778
48523, 0.021739130434783, 0.6195652173913, 0.33333333333333
48524, 0.021739130434783, 0.6195652173913, 0.38888888888889
48525, 0.021739130434783, 0.6195652173913, 0.44444444444444
48526, 0.95652173913043, 0.67173913043478, 0.027777777777778
48527, 0.97826086956522, 0.67173913043478, 0.055555555555556
48528, 0.95652173913043, 0.64565217391304, 0.055555555555556
48529, 0.95652173913043, 0.67173913043478, 0.083333333333333
48530, 0.97826086956522, 0.67173913043478, 0.11111111111111
48531, 0.95652173913044, 0.64565217391304, 0.11111111111111
48532, 0.95652173913044, 0.67173913043478, 0.13888888888889
48533, 0.97826086956522, 0.67173913043478, 0.16666666666667
48534, 0.95652173913044, 0.64565217391304, 0.16666666666667
48535, 0.95652173913044, 0.67173913043478, 0.19444444444444
48536, 0.97826086956522, 0.67173913043478, 0.22222222222222
48537, 0.95652173913044, 0.64565217391304, 0.22222222222222
48538, 0.95652173913044, 0.67173913043478, 0.25
48539, 0.97826086956522, 0.67173913043478, 0.27777777777778
48540, 0.95652173913044, 0.64565217391304, 0.27777777777778
48541, 0.95652173913044, 0.67173913043478, 0.30555555555556
48542, 0.97826086956522, 0.67173913043478, 0.33333333333333
48543, 0.95652173913044, 0.64565217391304, 0.33333333333333
48544, 0.95652173913044, 0.67173913043478, 0.36111111111111
48545, 0.97826086956522, 0.67173913043478, 0.38888888888889
48546, 0.95652173913044, 0.64565217391304, 0.38888888888889
48547, 0.95652173913044, 0.67173913043478, 0.41666666666667
48548, 0.97826086956522, 0.67173913043478, 0.44444444444444
48549, 0.95652173913044, 0.64565217391304, 0.44444444444444
48550, 0.95652173913043, 0.67173913043478, 0.47222222222222
48551, 0.91304347826087, 0.67173913043478, 0.027777777777778
48552, 0.93478260869565, 0.67173913043478, 0.055555555555556
48553, 0.91304347826087, 0.64565217391304, 0.055555555555556
48554, 0.91304347826087, 0.67173913043478, 0.083333333333333
48555, 0.93478260869565, 0.67173913043478, 0.11111111111111
48556, 0.91304347826087, 0.64565217391304, 0.11111111111111
48557, 0.91304347826087, 0.67173913043478, 0.13888888888889
48558, 0.93478260869565, 0.67173913043478, 0.16666666666667
48559, 0.91304347826087, 0.64565217391304, 0.16666666666667
48560, 0.91304347826087, 0.67173913043478, 0.19444444444444
48561, 0.93478260869565, 0.67173913043478, 0.22222222222222
48562, 0.91304347826087, 0.64565217391304, 0.22222222222222
48563, 0.91304347826087, 0.67173913043478, 0.25
48564, 0.93478260869565, 0.67173913043478, 0.27777777777778
48565, 0.91304347826087, 0.64565217391304, 0.27777777777778
48566, 0.91304347826087, 0.67173913043478, 0.30555555555556
48567, 0.93478260869565, 0.67173913043478, 0.33333333333333
48568, 0.91304347826087, 0.64565217391304, 0.33333333333333
48569, 0.91304347826087, 0.67173913043478, 0.36111111111111
48570, 0.93478260869565, 0.67173913043478, 0.38888888888889
48571, 0.91304347826087, 0.64565217391304, 0.38888888888889
48572, 0.91304347826087, 0.67173913043478, 0.41666666666667
48573, 0.93478260869565, 0.67173913043478, 0.44444444444444
48574, 0.91304347826087, 0.64565217391304, 0.44444444444444
48575, 0.91304347826087, 0.67173913043478, 0.47222222222222
48576, 0.8695652173913, 0.67173913043478, 0.027777777777778
48577, 0.89130434782609, 0.67173913043478, 0.055555555555556
48578, 0.8695652173913, 0.64565217391304, 0.055555555555556
48579, 0.8695652173913, 0.67173913043478, 0.083333333333333
48580, 0.89130434782609, 0.67173913043478, 0.11111111111111
48581, 0.8695652173913, 0.64565217391304, 0.11111111111111
48582, 0.8695652173913, 0.67173913043478, 0.13888888888889
48583, 0.89130434782609, 0.67173913043478, 0.16666666666667
48584, 0.8695652173913, 0.64565217391304, 0.16666666666667
48585, 0.8695652173913, 0.67173913043478, 0.19444444444444
48586, 0.89130434782609, 0.67173913043478, 0.22222222222222
48587, 0.8695652173913, 0.64565217391304, 0.22222222222222
48588, 0.8695652173913, 0.67173913043478, 0.25
48589, 0.89130434782609, 0.67173913043478, 0.27777777777778
48590, 0.8695652173913, 0.64565217391304, 0.27777777777778
48591, 0.8695652173913, 0.67173913043478, 0.30555555555556
48592, 0.89130434782609, 0.67173913043478, 0.33333333333333
48593, 0.8695652173913, 0.64565217391304, 0.33333333333333
48594, 0.8695652173913, 0.67173913043478, 0.36111111111111
48595, 0.89130434782609, 0.67173913043478, 0.38888888888889
48596, 0.8695652173913, 0.64565217391304, 0.38888888888889
48597, 0.8695652173913, 0.67173913043478, 0.41666666666667
48598, 0.89130434782609, 0.67173913043478, 0.44444444444444
48599, 0.8695652173913, 0.64565217391304, 0.44444444444444
48600, 0.8695652173913, 0.67173913043478, 0.47222222222222
48601, 0.82608695652174, 0.67173913043478, 0.027777777777778
48602, 0.84782608695652, 0.67173913043478, 0.055555555555556
48603, 0.82608695652174, 0.64565217391304, 0.055555555555556
48604, 0.82608695652174, 0.67173913043478, 0.083333333333333
48605, 0.84782608695652, 0.67173913043478, 0.11111111111111
48606, 0.82608695652174, 0.64565217391304, 0.11111111111111
48607, 0.82608695652174, 0.67173913043478, 0.13888888888889
48608, 0.84782608695652, 0.67173913043478, 0.16666666666667
48609, 0.82608695652174, 0.64565217391304, 0.16666666666667
48610, 0.82608695652174, 0.67173913043478, 0.19444444444444
48611, 0.84782608695652, 0.67173913043478, 0.22222222222222
48612, 0.82608695652174, 0.64565217391304, 0.22222222222222
48613, 0.82608695652174, 0.67173913043478, 0.25
48614, 0.84782608695652, 0.67173913043478, 0.27777777777778
48615, 0.82608695652174, 0.64565217391304, 0.27777777777778
48616, 0.82608695652174, 0.67173913043478, 0.30555555555556
48617, 0.84782608695652, 0.67173913043478, 0.33333333333333
48618, 0.82608695652174, 0.64565217391304, 0.33333333333333
48619, 0.82608695652174, 0.67173913043478, 0.36111111111111
48620, 0.84782608695652, 0.67173913043478, 0.38888888888889
48621, 0.82608695652174, 0.64565217391304, 0.38888888888889
48622, 0.82608695652174, 0.67173913043478, 0.41666666666667
48623, 0.84782608695652, 0.67173913043478, 0.44444444444444
48624, 0.82608695652174, 0.64565217391304, 0.44444444444444
48625, 0.82608695652174, 0.67173913043478, 0.47222222222222
48626, 0.78260869565217, 0.67173913043478, 0.027777777777778
48627, 0.80434782608696, 0.67173913043478, 0.055555555555556
48628, 0.78260869565217, 0.64565217391304, 0.055555555555556
48629, 0.78260869565217, 0.67173913043478, 0.083333333333333
48630, 0.80434782608696, 0.67173913043478, 0.11111111111111
48631, 0.78260869565217, 0.64565217391304, 0.11111111111111
48632, 0.78260869565217, 0.67173913043478, 0.13888888888889
48633, 0.80434782608696, 0.67173913043478, 0.16666666666667
48634, 0.78260869565217, 0.64565217391304, 0.16666666666667
48635, 0.78260869565217, 0.67173913043478, 0.19444444444444
48636, 0.80434782608696, 0.67173913043478, 0.22222222222222
48637, 0.78260869565217, 0.64565217391304, 0.22222222222222
48638, 0.78260869565217, 0.67173913043478, 0.25
48639, 0.80434782608696, 0.67173913043478, 0.27777777777778
48640, 0.78260869565217, 0.64565217391304, 0.27777777777778
48641, 0.78260869565217, 0.67173913043478, 0.30555555555556
48642, 0.80434782608696, 0.67173913043478, 0.33333333333333
48643, 0.78260869565217, 0.64565217391304, 0.33333333333333
48644, 0.78260869565217, 0.67173913043478, 0.36111111111111
48645, 0.80434782608696, 0.67173913043478, 0.38888888888889
48646, 0.78260869565217, 0.64565217391304, 0.38888888888889
48647, 0.78260869565217, 0.67173913043478, 0.41666666666667
48648, 0.80434782608696, 0.67173913043478, 0.44444444444444
48649, 0.78260869565217, 0.64565217391304, 0.44444444444444
48650, 0.78260869565217, 0.67173913043478, 0.47222222222222
48651, 0.73913043478261, 0.67173913043478, 0.027777777777778
48652, 0.76086956521739, 0.67173913043478, 0.055555555555556
48653, 0.73913043478261, 0.64565217391304, 0.055555555555556
48654, 0.73913043478261, 0.67173913043478, 0.083333333333333
48655, 0.76086956521739, 0.67173913043478, 0.11111111111111
48656, 0.73913043478261, 0.64565217391304, 0.11111111111111
48657, 0.73913043478261, 0.67173913043478, 0.13888888888889
48658, 0.76086956521739, 0.67173913043478, 0.16666666666667
48659, 0.73913043478261, 0.64565217391304, 0.16666666666667
48660, 0.73913043478261, 0.67173913043478, 0.19444444444444
48661, 0.76086956521739, 0.67173913043478, 0.22222222222222
48662, 0.73913043478261, 0.64565217391304, 0.22222222222222
48663, 0.73913043478261, 0.67173913043478, 0.25
48664, 0.76086956521739, 0.67173913043478, 0.27777777777778
48665, 0.73913043478261, 0.64565217391304, 0.27777777777778
48666, 0.73913043478261, 0.67173913043478, 0.30555555555556
48667, 0.76086956521739, 0.67173913043478, 0.33333333333333
48668, 0.73913043478261, 0.64565217391304, 0.33333333333333
48669, 0.73913043478261, 0.67173913043478, 0.36111111111111
48670, 0.76086956521739, 0.67173913043478, 0.38888888888889
48671, 0.73913043478261, 0.64565217391304, 0.38888888888889
48672, 0.73913043478261, 0.67173913043478, 0.41666666666667
48673, 0.76086956521739, 0.67173913043478, 0.44444444444444
48674, 0.73913043478261, 0.64565217391304, 0.44444444444444
48675, 0.73913043478261, 0.67173913043478, 0.47222222222222
48676, 0.69565217391304, 0.67173913043478, 0.027777777777778
48677, 0.71739130434783, 0.67173913043478, 0.055555555555556
48678, 0.69565217391304, 0.64565217391304, 0.055555555555556
48679, 0.69565217391304, 0.67173913043478, 0.083333333333333
48680, 0.71739130434783, 0.67173913043478, 0.11111111111111
48681, 0.69565217391304, 0.64565217391304, 0.11111111111111
48682, 0.69565217391304, 0.67173913043478, 0.13888888888889
48683, 0.71739130434783, 0.67173913043478, 0.16666666666667
48684, 0.69565217391304, 0.64565217391304, 0.16666666666667
48685, 0.69565217391304, 0.67173913043478, 0.19444444444444
48686, 0.71739130434783, 0.67173913043478, 0.22222222222222
48687, 0.69565217391304, 0.64565217391304, 0.22222222222222
48688, 0.69565217391304, 0.67173913043478, 0.25
48689, 0.71739130434783, 0.67173913043478, 0.27777777777778
48690, 0.69565217391304, 0.64565217391304, 0.27777777777778
48691, 0.69565217391304, 0.67173913043478, 0.30555555555556
48692, 0.71739130434783, 0.67173913043478, 0.33333333333333
48693, 0.69565217391304, 0.64565217391304, 0.33333333333333
48694, 0.69565217391304, 0.67173913043478, 0.36111111111111
48695, 0.71739130434783, 0.67173913043478, 0.38888888888889
48696, 0.69565217391304, 0.64565217391304, 0.38888888888889
48697, 0.69565217391304, 0.67173913043478, 0.41666666666667
48698, 0.71739130434783, 0.67173913043478, 0.44444444444444
48699, 0.69565217391304, 0.64565217391304, 0.44444444444444
48700, 0.69565217391304, 0.67173913043478, 0.47222222222222
48701, 0.65217391304348, 0.67173913043478, 0.027777777777778
48702, 0.67391304347826, 0.67173913043478, 0.055555555555556
48703, 0.65217391304348, 0.64565217391304, 0.055555555555556
48704, 0.65217391304348, 0.67173913043478, 0.083333333333333
48705, 0.67391304347826, 0.67173913043478, 0.11111111111111
48706, 0.65217391304348, 0.64565217391304, 0.11111111111111
48707, 0.65217391304348, 0.67173913043478, 0.13888888888889
48708, 0.67391304347826, 0.67173913043478, 0.16666666666667
48709, 0.65217391304348, 0.64565217391304, 0.16666666666667
48710, 0.65217391304348, 0.67173913043478, 0.19444444444444
48711, 0.67391304347826, 0.67173913043478, 0.22222222222222
48712, 0.65217391304348, 0.64565217391304, 0.22222222222222
48713, 0.65217391304348, 0.67173913043478, 0.25
48714, 0.67391304347826, 0.67173913043478, 0.27777777777778
48715, 0.65217391304348, 0.64565217391304, 0.27777777777778
48716, 0.65217391304348, 0.67173913043478, 0.30555555555556
48717, 0.67391304347826, 0.67173913043478, 0.33333333333333
48718, 0.65217391304348, 0.64565217391304, 0.33333333333333
48719, 0.65217391304348, 0.67173913043478, 0.36111111111111
48720, 0.67391304347826, 0.67173913043478, 0.38888888888889
48721, 0.65217391304348, 0.64565217391304, 0.38888888888889
48722, 0.65217391304348, 0.67173913043478, 0.41666666666667
48723, 0.67391304347826, 0.67173913043478, 0.44444444444444
48724, 0.65217391304348, 0.64565217391304, 0.44444444444444
48725, 0.65217391304348, 0.67173913043478, 0.47222222222222
48726, 0.60869565217391, 0.67173913043478, 0.027777777777778
48727, 0.6304347826087, 0.67173913043478, 0.055555555555556
48728, 0.60869565217391, 0.64565217391304, 0.055555555555556
48729, 0.60869565217391, 0.67173913043478, 0.083333333333333
48730, 0.6304347826087, 0.67173913043478, 0.11111111111111
48731, 0.60869565217391, 0.64565217391304, 0.11111111111111
48732, 0.60869565217391, 0.67173913043478, 0.13888888888889
48733, 0.6304347826087, 0.67173913043478, 0.16666666666667
48734, 0.60869565217391, 0.64565217391304, 0.16666666666667
48735, 0.60869565217391, 0.67173913043478, 0.19444444444444
48736, 0.6304347826087, 0.67173913043478, 0.22222222222222
48737, 0.60869565217391, 0.64565217391304, 0.22222222222222
48738, 0.60869565217391, 0.67173913043478, 0.25
48739, 0.6304347826087, 0.67173913043478, 0.27777777777778
48740, 0.60869565217391, 0.64565217391304, 0.27777777777778
48741, 0.60869565217391, 0.67173913043478, 0.30555555555556
48742, 0.6304347826087, 0.67173913043478, 0.33333333333333
48743, 0.60869565217391, 0.64565217391304, 0.33333333333333
48744, 0.60869565217391, 0.67173913043478, 0.36111111111111
48745, 0.6304347826087, 0.67173913043478, 0.38888888888889
48746, 0.60869565217391, 0.64565217391304, 0.38888888888889
48747, 0.60869565217391, 0.67173913043478, 0.41666666666667
48748, 0.6304347826087, 0.67173913043478, 0.44444444444444
48749, 0.60869565217391, 0.64565217391304, 0.44444444444444
48750, 0.60869565217391, 0.67173913043478, 0.47222222222222
48751, 0.56521739130435, 0.67173913043478, 0.027777777777778
48752, 0.58695652173913, 0.67173913043478, 0.055555555555556
48753, 0.56521739130435, 0.64565217391304, 0.055555555555556
48754, 0.56521739130435, 0.67173913043478, 0.083333333333333
48755, 0.58695652173913, 0.67173913043478, 0.11111111111111
48756, 0.56521739130435, 0.64565217391304, 0.11111111111111
48757, 0.56521739130435, 0.67173913043478, 0.13888888888889
48758, 0.58695652173913, 0.67173913043478, 0.16666666666667
48759, 0.56521739130435, 0.64565217391304, 0.16666666666667
48760, 0.56521739130435, 0.67173913043478, 0.19444444444444
48761, 0.58695652173913, 0.67173913043478, 0.22222222222222
48762, 0.56521739130435, 0.64565217391304, 0.22222222222222
48763, 0.56521739130435, 0.67173913043478, 0.25
48764, 0.58695652173913, 0.67173913043478, 0.27777777777778
48765, 0.56521739130435, 0.64565217391304, 0.27777777777778
48766, 0.56521739130435, 0.67173913043478, 0.30555555555556
48767, 0.58695652173913, 0.67173913043478, 0.33333333333333
48768, 0.56521739130435, 0.64565217391304, 0.33333333333333
48769, 0.56521739130435, 0.67173913043478, 0.36111111111111
48770, 0.58695652173913, 0.67173913043478, 0.38888888888889
48771, 0.56521739130435, 0.64565217391304, 0.38888888888889
48772, 0.56521739130435, 0.67173913043478, 0.41666666666667
48773, 0.58695652173913, 0.67173913043478, 0.44444444444444
48774, 0.56521739130435, 0.64565217391304, 0.44444444444444
48775, 0.56521739130435, 0.67173913043478, 0.47222222222222
48776, 0.52173913043478, 0.67173913043478, 0.027777777777778
48777, 0.54347826086957, 0.67173913043478, 0.055555555555556
48778, 0.52173913043478, 0.64565217391304, 0.055555555555556
48779, 0.52173913043478, 0.67173913043478, 0.083333333333333
48780, 0.54347826086957, 0.67173913043478, 0.11111111111111
48781, 0.52173913043478, 0.64565217391304, 0.11111111111111
48782, 0.52173913043478, 0.67173913043478, 0.13888888888889
48783, 0.54347826086957, 0.67173913043478, 0.16666666666667
48784, 0.52173913043478, 0.64565217391304, 0.16666666666667
48785, 0.52173913043478, 0.67173913043478, 0.19444444444444
48786, 0.54347826086956, 0.67173913043478, 0.22222222222222
48787, 0.52173913043478, 0.64565217391304, 0.22222222222222
48788, 0.52173913043478, 0.67173913043478, 0.25
48789, 0.54347826086956, 0.67173913043478, 0.27777777777778
48790, 0.52173913043478, 0.64565217391304, 0.27777777777778
48791, 0.52173913043478, 0.67173913043478, 0.30555555555556
48792, 0.54347826086956, 0.67173913043478, 0.33333333333333
48793, 0.52173913043478, 0.64565217391304, 0.33333333333333
48794, 0.52173913043478, 0.67173913043478, 0.36111111111111
48795, 0.54347826086956, 0.67173913043478, 0.38888888888889
48796, 0.52173913043478, 0.64565217391304, 0.38888888888889
48797, 0.52173913043478, 0.67173913043478, 0.41666666666667
48798, 0.54347826086956, 0.67173913043478, 0.44444444444444
48799, 0.52173913043478, 0.64565217391304, 0.44444444444444
48800, 0.52173913043478, 0.67173913043478, 0.47222222222222
48801, 0.47826086956522, 0.67173913043478, 0.027777777777778
48802, 0.5, 0.67173913043478, 0.055555555555556
48803, 0.47826086956522, 0.64565217391304, 0.055555555555556
48804, 0.47826086956522, 0.67173913043478, 0.083333333333333
48805, 0.5, 0.67173913043478, 0.11111111111111
48806, 0.47826086956522, 0.64565217391304, 0.11111111111111
48807, 0.47826086956522, 0.67173913043478, 0.13888888888889
48808, 0.5, 0.67173913043478, 0.16666666666667
48809, 0.47826086956522, 0.64565217391304, 0.16666666666667
48810, 0.47826086956522, 0.67173913043478, 0.19444444444444
48811, 0.5, 0.67173913043478, 0.22222222222222
48812, 0.47826086956522, 0.64565217391304, 0.22222222222222
48813, 0.47826086956522, 0.67173913043478, 0.25
48814, 0.5, 0.67173913043478, 0.27777777777778
48815, 0.47826086956522, 0.64565217391304, 0.27777777777778
48816, 0.47826086956522, 0.67173913043478, 0.30555555555556
48817, 0.5, 0.67173913043478, 0.33333333333333
48818, 0.47826086956522, 0.64565217391304, 0.33333333333333
48819, 0.47826086956522, 0.67173913043478, 0.36111111111111
48820, 0.5, 0.67173913043478, 0.38888888888889
48821, 0.47826086956522, 0.64565217391304, 0.38888888888889
48822, 0.47826086956522, 0.67173913043478, 0.41666666666667
48823, 0.5, 0.67173913043478, 0.44444444444444
48824, 0.47826086956522, 0.64565217391304, 0.44444444444444
48825, 0.47826086956522, 0.67173913043478, 0.47222222222222
48826, 0.43478260869565, 0.67173913043478, 0.027777777777778
48827, 0.45652173913043, 0.67173913043478, 0.055555555555556
48828, 0.43478260869565, 0.64565217391304, 0.055555555555556
48829, 0.43478260869565, 0.67173913043478, 0.083333333333333
48830, 0.45652173913043, 0.67173913043478, 0.11111111111111
48831, 0.43478260869565, 0.64565217391304, 0.11111111111111
48832, 0.43478260869565, 0.67173913043478, 0.13888888888889
48833, 0.45652173913043, 0.67173913043478, 0.16666666666667
48834, 0.43478260869565, 0.64565217391304, 0.16666666666667
48835, 0.43478260869565, 0.67173913043478, 0.19444444444444
48836, 0.45652173913043, 0.67173913043478, 0.22222222222222
48837, 0.43478260869565, 0.64565217391304, 0.22222222222222
48838, 0.43478260869565, 0.67173913043478, 0.25
48839, 0.45652173913043, 0.67173913043478, 0.27777777777778
48840, 0.43478260869565, 0.64565217391304, 0.27777777777778
48841, 0.43478260869565, 0.67173913043478, 0.30555555555556
48842, 0.45652173913043, 0.67173913043478, 0.33333333333333
48843, 0.43478260869565, 0.64565217391304, 0.33333333333333
48844, 0.43478260869565, 0.67173913043478, 0.36111111111111
48845, 0.45652173913043, 0.67173913043478, 0.38888888888889
48846, 0.43478260869565, 0.64565217391304, 0.38888888888889
48847, 0.43478260869565, 0.67173913043478, 0.41666666666667
48848, 0.45652173913043, 0.67173913043478, 0.44444444444444
48849, 0.43478260869565, 0.64565217391304, 0.44444444444444
48850, 0.43478260869565, 0.67173913043478, 0.47222222222222
48851, 0.39130434782609, 0.67173913043478, 0.027777777777778
48852, 0.41304347826087, 0.67173913043478, 0.055555555555556
48853, 0.39130434782609, 0.64565217391304, 0.055555555555556
48854, 0.39130434782609, 0.67173913043478, 0.083333333333333
48855, 0.41304347826087, 0.67173913043478, 0.11111111111111
48856, 0.39130434782609, 0.64565217391304, 0.11111111111111
48857, 0.39130434782609, 0.67173913043478, 0.13888888888889
48858, 0.41304347826087, 0.67173913043478, 0.16666666666667
48859, 0.39130434782609, 0.64565217391304, 0.16666666666667
48860, 0.39130434782609, 0.67173913043478, 0.19444444444444
48861, 0.41304347826087, 0.67173913043478, 0.22222222222222
48862, 0.39130434782609, 0.64565217391304, 0.22222222222222
48863, 0.39130434782609, 0.67173913043478, 0.25
48864, 0.41304347826087, 0.67173913043478, 0.27777777777778
48865, 0.39130434782609, 0.64565217391304, 0.27777777777778
48866, 0.39130434782609, 0.67173913043478, 0.30555555555556
48867, 0.41304347826087, 0.67173913043478, 0.33333333333333
48868, 0.39130434782609, 0.64565217391304, 0.33333333333333
48869, 0.39130434782609, 0.67173913043478, 0.36111111111111
48870, 0.41304347826087, 0.67173913043478, 0.38888888888889
48871, 0.39130434782609, 0.64565217391304, 0.38888888888889
48872, 0.39130434782609, 0.67173913043478, 0.41666666666667
48873, 0.41304347826087, 0.67173913043478, 0.44444444444444
48874, 0.39130434782609, 0.64565217391304, 0.44444444444444
48875, 0.39130434782609, 0.67173913043478, 0.47222222222222
48876, 0.34782608695652, 0.67173913043478, 0.027777777777778
48877, 0.3695652173913, 0.67173913043478, 0.055555555555556
48878, 0.34782608695652, 0.64565217391304, 0.055555555555556
48879, 0.34782608695652, 0.67173913043478, 0.083333333333333
48880, 0.3695652173913, 0.67173913043478, 0.11111111111111
48881, 0.34782608695652, 0.64565217391304, 0.11111111111111
48882, 0.34782608695652, 0.67173913043478, 0.13888888888889
48883, 0.3695652173913, 0.67173913043478, 0.16666666666667
48884, 0.34782608695652, 0.64565217391304, 0.16666666666667
48885, 0.34782608695652, 0.67173913043478, 0.19444444444444
48886, 0.3695652173913, 0.67173913043478, 0.22222222222222
48887, 0.34782608695652, 0.64565217391304, 0.22222222222222
48888, 0.34782608695652, 0.67173913043478, 0.25
48889, 0.3695652173913, 0.67173913043478, 0.27777777777778
48890, 0.34782608695652, 0.64565217391304, 0.27777777777778
48891, 0.34782608695652, 0.67173913043478, 0.30555555555556
48892, 0.3695652173913, 0.67173913043478, 0.33333333333333
48893, 0.34782608695652, 0.64565217391304, 0.33333333333333
48894, 0.34782608695652, 0.67173913043478, 0.36111111111111
48895, 0.3695652173913, 0.67173913043478, 0.38888888888889
48896, 0.34782608695652, 0.64565217391304, 0.38888888888889
48897, 0.34782608695652, 0.67173913043478, 0.41666666666667
48898, 0.3695652173913, 0.67173913043478, 0.44444444444444
48899, 0.34782608695652, 0.64565217391304, 0.44444444444444
48900, 0.34782608695652, 0.67173913043478, 0.47222222222222
48901, 0.30434782608696, 0.67173913043478, 0.027777777777778
48902, 0.32608695652174, 0.67173913043478, 0.055555555555556
48903, 0.30434782608696, 0.64565217391304, 0.055555555555556
48904, 0.30434782608696, 0.67173913043478, 0.083333333333333
48905, 0.32608695652174, 0.67173913043478, 0.11111111111111
48906, 0.30434782608696, 0.64565217391304, 0.11111111111111
48907, 0.30434782608696, 0.67173913043478, 0.13888888888889
48908, 0.32608695652174, 0.67173913043478, 0.16666666666667
48909, 0.30434782608696, 0.64565217391304, 0.16666666666667
48910, 0.30434782608696, 0.67173913043478, 0.19444444444444
48911, 0.32608695652174, 0.67173913043478, 0.22222222222222
48912, 0.30434782608696, 0.64565217391304, 0.22222222222222
48913, 0.30434782608696, 0.67173913043478, 0.25
48914, 0.32608695652174, 0.67173913043478, 0.27777777777778
48915, 0.30434782608696, 0.64565217391304, 0.27777777777778
48916, 0.30434782608696, 0.67173913043478, 0.30555555555556
48917, 0.32608695652174, 0.67173913043478, 0.33333333333333
48918, 0.30434782608696, 0.64565217391304, 0.33333333333333
48919, 0.30434782608696, 0.67173913043478, 0.36111111111111
48920, 0.32608695652174, 0.67173913043478, 0.38888888888889
48921, 0.30434782608696, 0.64565217391304, 0.38888888888889
48922, 0.30434782608696, 0.67173913043478, 0.41666666666667
48923, 0.32608695652174, 0.67173913043478, 0.44444444444444
48924, 0.30434782608696, 0.64565217391304, 0.44444444444444
48925, 0.30434782608696, 0.67173913043478, 0.47222222222222
48926, 0.26086956521739, 0.67173913043478, 0.027777777777778
48927, 0.28260869565217, 0.67173913043478, 0.055555555555556
48928, 0.26086956521739, 0.64565217391304, 0.055555555555556
48929, 0.26086956521739, 0.67173913043478, 0.083333333333333
48930, 0.28260869565217, 0.67173913043478, 0.11111111111111
48931, 0.26086956521739, 0.64565217391304, 0.11111111111111
48932, 0.26086956521739, 0.67173913043478, 0.13888888888889
48933, 0.28260869565217, 0.67173913043478, 0.16666666666667
48934, 0.26086956521739, 0.64565217391304, 0.16666666666667
48935, 0.26086956521739, 0.67173913043478, 0.19444444444444
48936, 0.28260869565217, 0.67173913043478, 0.22222222222222
48937, 0.26086956521739, 0.64565217391304, 0.22222222222222
48938, 0.26086956521739, 0.67173913043478, 0.25
48939, 0.28260869565217, 0.67173913043478, 0.27777777777778
48940, 0.26086956521739, 0.64565217391304, 0.27777777777778
48941, 0.26086956521739, 0.67173913043478, 0.30555555555556
48942, 0.28260869565217, 0.67173913043478, 0.33333333333333
48943, 0.26086956521739, 0.64565217391304, 0.33333333333333
48944, 0.26086956521739, 0.67173913043478, 0.36111111111111
48945, 0.28260869565217, 0.67173913043478, 0.38888888888889
48946, 0.26086956521739, 0.64565217391304, 0.38888888888889
48947, 0.26086956521739, 0.67173913043478, 0.41666666666667
48948, 0.28260869565217, 0.67173913043478, 0.44444444444444
48949, 0.26086956521739, 0.64565217391304, 0.44444444444444
48950, 0.26086956521739, 0.67173913043478, 0.47222222222222
48951, 0.21739130434783, 0.67173913043478, 0.027777777777778
48952, 0.23913043478261, 0.67173913043478, 0.055555555555556
48953, 0.21739130434783, 0.64565217391304, 0.055555555555556
48954, 0.21739130434783, 0.67173913043478, 0.083333333333333
48955, 0.23913043478261, 0.67173913043478, 0.11111111111111
48956, 0.21739130434783, 0.64565217391304, 0.11111111111111
48957, 0.21739130434783, 0.67173913043478, 0.13888888888889
48958, 0.23913043478261, 0.67173913043478, 0.16666666666667
48959, 0.21739130434783, 0.64565217391304, 0.16666666666667
48960, 0.21739130434783, 0.67173913043478, 0.19444444444444
48961, 0.23913043478261, 0.67173913043478, 0.22222222222222
48962, 0.21739130434783, 0.64565217391304, 0.22222222222222
48963, 0.21739130434783, 0.67173913043478, 0.25
48964, 0.23913043478261, 0.67173913043478, 0.27777777777778
48965, 0.21739130434783, 0.64565217391304, 0.27777777777778
48966, 0.21739130434783, 0.67173913043478, 0.30555555555556
48967, 0.23913043478261, 0.67173913043478, 0.33333333333333
48968, 0.21739130434783, 0.64565217391304, 0.33333333333333
48969, 0.21739130434783, 0.67173913043478, 0.36111111111111
48970, 0.23913043478261, 0.67173913043478, 0.38888888888889
48971, 0.21739130434783, 0.64565217391304, 0.38888888888889
48972, 0.21739130434783, 0.67173913043478, 0.41666666666667
48973, 0.23913043478261, 0.67173913043478, 0.44444444444444
48974, 0.21739130434783, 0.64565217391304, 0.44444444444444
48975, 0.21739130434783, 0.67173913043478, 0.47222222222222
48976, 0.17391304347826, 0.67173913043478, 0.027777777777778
48977, 0.19565217391304, 0.67173913043478, 0.055555555555556
48978, 0.17391304347826, 0.64565217391304, 0.055555555555556
48979, 0.17391304347826, 0.67173913043478, 0.083333333333333
48980, 0.19565217391304, 0.67173913043478, 0.11111111111111
48981, 0.17391304347826, 0.64565217391304, 0.11111111111111
48982, 0.17391304347826, 0.67173913043478, 0.13888888888889
48983, 0.19565217391304, 0.67173913043478, 0.16666666666667
48984, 0.17391304347826, 0.64565217391304, 0.16666666666667
48985, 0.17391304347826, 0.67173913043478, 0.19444444444444
48986, 0.19565217391304, 0.67173913043478, 0.22222222222222
48987, 0.17391304347826, 0.64565217391304, 0.22222222222222
48988, 0.17391304347826, 0.67173913043478, 0.25
48989, 0.19565217391304, 0.67173913043478, 0.27777777777778
48990, 0.17391304347826, 0.64565217391304, 0.27777777777778
48991, 0.17391304347826, 0.67173913043478, 0.30555555555556
48992, 0.19565217391304, 0.67173913043478, 0.33333333333333
48993, 0.17391304347826, 0.64565217391304, 0.33333333333333
48994, 0.17391304347826, 0.67173913043478, 0.36111111111111
48995, 0.19565217391304, 0.67173913043478, 0.38888888888889
48996, 0.17391304347826, 0.64565217391304, 0.38888888888889
48997, 0.17391304347826, 0.67173913043478, 0.41666666666667
48998, 0.19565217391304, 0.67173913043478, 0.44444444444444
48999, 0.17391304347826, 0.64565217391304, 0.44444444444444
49000, 0.17391304347826, 0.67173913043478, 0.47222222222222
49001, 0.1304347826087, 0.67173913043478, 0.027777777777778
49002, 0.15217391304348, 0.67173913043478, 0.055555555555556
49003, 0.1304347826087, 0.64565217391304, 0.055555555555556
49004, 0.1304347826087, 0.67173913043478, 0.083333333333333
49005, 0.15217391304348, 0.67173913043478, 0.11111111111111
49006, 0.1304347826087, 0.64565217391304, 0.11111111111111
49007, 0.1304347826087, 0.67173913043478, 0.13888888888889
49008, 0.15217391304348, 0.67173913043478, 0.16666666666667
49009, 0.1304347826087, 0.64565217391304, 0.16666666666667
49010, 0.1304347826087, 0.67173913043478, 0.19444444444444
49011, 0.15217391304348, 0.67173913043478, 0.22222222222222
49012, 0.1304347826087, 0.64565217391304, 0.22222222222222
49013, 0.1304347826087, 0.67173913043478, 0.25
49014, 0.15217391304348, 0.67173913043478, 0.27777777777778
49015, 0.1304347826087, 0.64565217391304, 0.27777777777778
49016, 0.1304347826087, 0.67173913043478, 0.30555555555556
49017, 0.15217391304348, 0.67173913043478, 0.33333333333333
49018, 0.1304347826087, 0.64565217391304, 0.33333333333333
49019, 0.1304347826087, 0.67173913043478, 0.36111111111111
49020, 0.15217391304348, 0.67173913043478, 0.38888888888889
49021, 0.1304347826087, 0.64565217391304, 0.38888888888889
49022, 0.1304347826087, 0.67173913043478, 0.41666666666667
49023, 0.15217391304348, 0.67173913043478, 0.44444444444444
49024, 0.1304347826087, 0.64565217391304, 0.44444444444444
49025, 0.1304347826087, 0.67173913043478, 0.47222222222222
49026, 0.08695652173913, 0.67173913043478, 0.027777777777778
49027, 0.10869565217391, 0.67173913043478, 0.055555555555556
49028, 0.08695652173913, 0.64565217391304, 0.055555555555556
49029, 0.08695652173913, 0.67173913043478, 0.083333333333333
49030, 0.10869565217391, 0.67173913043478, 0.11111111111111
49031, 0.08695652173913, 0.64565217391304, 0.11111111111111
49032, 0.08695652173913, 0.67173913043478, 0.13888888888889
49033, 0.10869565217391, 0.67173913043478, 0.16666666666667
49034, 0.08695652173913, 0.64565217391304, 0.16666666666667
49035, 0.08695652173913, 0.67173913043478, 0.19444444444444
49036, 0.10869565217391, 0.67173913043478, 0.22222222222222
49037, 0.08695652173913, 0.64565217391304, 0.22222222222222
49038, 0.08695652173913, 0.67173913043478, 0.25
49039, 0.10869565217391, 0.67173913043478, 0.27777777777778
49040, 0.08695652173913, 0.64565217391304, 0.27777777777778
49041, 0.08695652173913, 0.67173913043478, 0.30555555555556
49042, 0.10869565217391, 0.67173913043478, 0.33333333333333
49043, 0.08695652173913, 0.64565217391304, 0.33333333333333
49044, 0.08695652173913, 0.67173913043478, 0.36111111111111
49045, 0.10869565217391, 0.67173913043478, 0.38888888888889
49046, 0.08695652173913, 0.64565217391304, 0.38888888888889
49047, 0.08695652173913, 0.67173913043478, 0.41666666666667
49048, 0.10869565217391, 0.67173913043478, 0.44444444444444
49049, 0.08695652173913, 0.64565217391304, 0.44444444444444
49050, 0.08695652173913, 0.67173913043478, 0.47222222222222
49051, 0.043478260869565, 0.67173913043478, 0.027777777777778
49052, 0.065217391304348, 0.67173913043478, 0.055555555555556
49053, 0.043478260869565, 0.64565217391304, 0.055555555555556
49054, 0.043478260869565, 0.67173913043478, 0.083333333333333
49055, 0.065217391304348, 0.67173913043478, 0.11111111111111
49056, 0.043478260869565, 0.64565217391304, 0.11111111111111
49057, 0.043478260869565, 0.67173913043478, 0.13888888888889
49058, 0.065217391304348, 0.67173913043478, 0.16666666666667
49059, 0.043478260869565, 0.64565217391304, 0.16666666666667
49060, 0.043478260869565, 0.67173913043478, 0.19444444444444
49061, 0.065217391304348, 0.67173913043478, 0.22222222222222
49062, 0.043478260869565, 0.64565217391304, 0.22222222222222
49063, 0.043478260869565, 0.67173913043478, 0.25
49064, 0.065217391304348, 0.67173913043478, 0.27777777777778
49065, 0.043478260869565, 0.64565217391304, 0.27777777777778
49066, 0.043478260869565, 0.67173913043478, 0.30555555555556
49067, 0.065217391304348, 0.67173913043478, 0.33333333333333
49068, 0.043478260869565, 0.64565217391304, 0.33333333333333
49069, 0.043478260869565, 0.67173913043478, 0.36111111111111
49070, 0.065217391304348, 0.67173913043478, 0.38888888888889
49071, 0.043478260869565, 0.64565217391304, 0.38888888888889
49072, 0.043478260869565, 0.67173913043478, 0.41666666666667
49073, 0.065217391304348, 0.67173913043478, 0.44444444444444
49074, 0.043478260869565, 0.64565217391304, 0.44444444444444
49075, 0.043478260869565, 0.67173913043478, 0.47222222222222
49076, 0.021739130434783, 0.67173913043478, 0.055555555555556
49077, 0.021739130434783, 0.67173913043478, 0.11111111111111
49078, 0.021739130434783, 0.67173913043478, 0.16666666666667
49079, 0.021739130434783, 0.67173913043478, 0.22222222222222
49080, 0.021739130434783, 0.67173913043478, 0.27777777777778
49081, 0.021739130434783, 0.67173913043478, 0.33333333333333
49082, 0.021739130434783, 0.67173913043478, 0.38888888888889
49083, 0.021739130434783, 0.67173913043478, 0.44444444444444
49084, 0.95652173913043, 0.72391304347826, 0.027777777777778
49085, 0.97826086956522, 0.72391304347826, 0.055555555555556
49086, 0.95652173913043, 0.69782608695652, 0.055555555555556
49087, 0.95652173913043, 0.72391304347826, 0.083333333333333
49088, 0.97826086956522, 0.72391304347826, 0.11111111111111
49089, 0.95652173913044, 0.69782608695652, 0.11111111111111
49090, 0.95652173913044, 0.72391304347826, 0.13888888888889
49091, 0.97826086956522, 0.72391304347826, 0.16666666666667
49092, 0.95652173913044, 0.69782608695652, 0.16666666666667
49093, 0.95652173913044, 0.72391304347826, 0.19444444444444
49094, 0.97826086956522, 0.72391304347826, 0.22222222222222
49095, 0.95652173913044, 0.69782608695652, 0.22222222222222
49096, 0.95652173913044, 0.72391304347826, 0.25
49097, 0.97826086956522, 0.72391304347826, 0.27777777777778
49098, 0.95652173913044, 0.69782608695652, 0.27777777777778
49099, 0.95652173913044, 0.72391304347826, 0.30555555555556
49100, 0.97826086956522, 0.72391304347826, 0.33333333333333
49101, 0.95652173913044, 0.69782608695652, 0.33333333333333
49102, 0.95652173913044, 0.72391304347826, 0.36111111111111
49103, 0.97826086956522, 0.72391304347826, 0.38888888888889
49104, 0.95652173913044, 0.69782608695652, 0.38888888888889
49105, 0.95652173913044, 0.72391304347826, 0.41666666666667
49106, 0.97826086956522, 0.72391304347826, 0.44444444444444
49107, 0.95652173913044, 0.69782608695652, 0.44444444444444
49108, 0.95652173913043, 0.72391304347826, 0.47222222222222
49109, 0.91304347826087, 0.72391304347826, 0.027777777777778
49110, 0.93478260869565, 0.72391304347826, 0.055555555555556
49111, 0.91304347826087, 0.69782608695652, 0.055555555555556
49112, 0.91304347826087, 0.72391304347826, 0.083333333333333
49113, 0.93478260869565, 0.72391304347826, 0.11111111111111
49114, 0.91304347826087, 0.69782608695652, 0.11111111111111
49115, 0.91304347826087, 0.72391304347826, 0.13888888888889
49116, 0.93478260869565, 0.72391304347826, 0.16666666666667
49117, 0.91304347826087, 0.69782608695652, 0.16666666666667
49118, 0.91304347826087, 0.72391304347826, 0.19444444444444
49119, 0.93478260869565, 0.72391304347826, 0.22222222222222
49120, 0.91304347826087, 0.69782608695652, 0.22222222222222
49121, 0.91304347826087, 0.72391304347826, 0.25
49122, 0.93478260869565, 0.72391304347826, 0.27777777777778
49123, 0.91304347826087, 0.69782608695652, 0.27777777777778
49124, 0.91304347826087, 0.72391304347826, 0.30555555555556
49125, 0.93478260869565, 0.72391304347826, 0.33333333333333
49126, 0.91304347826087, 0.69782608695652, 0.33333333333333
49127, 0.91304347826087, 0.72391304347826, 0.36111111111111
49128, 0.93478260869565, 0.72391304347826, 0.38888888888889
49129, 0.91304347826087, 0.69782608695652, 0.38888888888889
49130, 0.91304347826087, 0.72391304347826, 0.41666666666667
49131, 0.93478260869565, 0.72391304347826, 0.44444444444444
49132, 0.91304347826087, 0.69782608695652, 0.44444444444444
49133, 0.91304347826087, 0.72391304347826, 0.47222222222222
49134, 0.8695652173913, 0.72391304347826, 0.027777777777778
49135, 0.89130434782609, 0.72391304347826, 0.055555555555556
49136, 0.8695652173913, 0.69782608695652, 0.055555555555556
49137, 0.8695652173913, 0.72391304347826, 0.083333333333333
49138, 0.89130434782609, 0.72391304347826, 0.11111111111111
49139, 0.8695652173913, 0.69782608695652, 0.11111111111111
49140, 0.8695652173913, 0.72391304347826, 0.13888888888889
49141, 0.89130434782609, 0.72391304347826, 0.16666666666667
49142, 0.8695652173913, 0.69782608695652, 0.16666666666667
49143, 0.8695652173913, 0.72391304347826, 0.19444444444444
49144, 0.89130434782609, 0.72391304347826, 0.22222222222222
49145, 0.8695652173913, 0.69782608695652, 0.22222222222222
49146, 0.8695652173913, 0.72391304347826, 0.25
49147, 0.89130434782609, 0.72391304347826, 0.27777777777778
49148, 0.8695652173913, 0.69782608695652, 0.27777777777778
49149, 0.8695652173913, 0.72391304347826, 0.30555555555556
49150, 0.89130434782609, 0.72391304347826, 0.33333333333333
49151, 0.8695652173913, 0.69782608695652, 0.33333333333333
49152, 0.8695652173913, 0.72391304347826, 0.36111111111111
49153, 0.89130434782609, 0.72391304347826, 0.38888888888889
49154, 0.8695652173913, 0.69782608695652, 0.38888888888889
49155, 0.8695652173913, 0.72391304347826, 0.41666666666667
49156, 0.89130434782609, 0.72391304347826, 0.44444444444444
49157, 0.8695652173913, 0.69782608695652, 0.44444444444444
49158, 0.8695652173913, 0.72391304347826, 0.47222222222222
49159, 0.82608695652174, 0.72391304347826, 0.027777777777778
49160, 0.84782608695652, 0.72391304347826, 0.055555555555556
49161, 0.82608695652174, 0.69782608695652, 0.055555555555556
49162, 0.82608695652174, 0.72391304347826, 0.083333333333333
49163, 0.84782608695652, 0.72391304347826, 0.11111111111111
49164, 0.82608695652174, 0.69782608695652, 0.11111111111111
49165, 0.82608695652174, 0.72391304347826, 0.13888888888889
49166, 0.84782608695652, 0.72391304347826, 0.16666666666667
49167, 0.82608695652174, 0.69782608695652, 0.16666666666667
49168, 0.82608695652174, 0.72391304347826, 0.19444444444444
49169, 0.84782608695652, 0.72391304347826, 0.22222222222222
49170, 0.82608695652174, 0.69782608695652, 0.22222222222222
49171, 0.82608695652174, 0.72391304347826, 0.25
49172, 0.84782608695652, 0.72391304347826, 0.27777777777778
49173, 0.82608695652174, 0.69782608695652, 0.27777777777778
49174, 0.82608695652174, 0.72391304347826, 0.30555555555556
49175, 0.84782608695652, 0.72391304347826, 0.33333333333333
49176, 0.82608695652174, 0.69782608695652, 0.33333333333333
49177, 0.82608695652174, 0.72391304347826, 0.36111111111111
49178, 0.84782608695652, 0.72391304347826, 0.38888888888889
49179, 0.82608695652174, 0.69782608695652, 0.38888888888889
49180, 0.82608695652174, 0.72391304347826, 0.41666666666667
49181, 0.84782608695652, 0.72391304347826, 0.44444444444444
49182, 0.82608695652174, 0.69782608695652, 0.44444444444444
49183, 0.82608695652174, 0.72391304347826, 0.47222222222222
49184, 0.78260869565217, 0.72391304347826, 0.027777777777778
49185, 0.80434782608696, 0.72391304347826, 0.055555555555556
49186, 0.78260869565217, 0.69782608695652, 0.055555555555556
49187, 0.78260869565217, 0.72391304347826, 0.083333333333333
49188, 0.80434782608696, 0.72391304347826, 0.11111111111111
49189, 0.78260869565217, 0.69782608695652, 0.11111111111111
49190, 0.78260869565217, 0.72391304347826, 0.13888888888889
49191, 0.80434782608696, 0.72391304347826, 0.16666666666667
49192, 0.78260869565217, 0.69782608695652, 0.16666666666667
49193, 0.78260869565217, 0.72391304347826, 0.19444444444444
49194, 0.80434782608696, 0.72391304347826, 0.22222222222222
49195, 0.78260869565217, 0.69782608695652, 0.22222222222222
49196, 0.78260869565217, 0.72391304347826, 0.25
49197, 0.80434782608696, 0.72391304347826, 0.27777777777778
49198, 0.78260869565217, 0.69782608695652, 0.27777777777778
49199, 0.78260869565217, 0.72391304347826, 0.30555555555556
49200, 0.80434782608696, 0.72391304347826, 0.33333333333333
49201, 0.78260869565217, 0.69782608695652, 0.33333333333333
49202, 0.78260869565217, 0.72391304347826, 0.36111111111111
49203, 0.80434782608696, 0.72391304347826, 0.38888888888889
49204, 0.78260869565217, 0.69782608695652, 0.38888888888889
49205, 0.78260869565217, 0.72391304347826, 0.41666666666667
49206, 0.80434782608696, 0.72391304347826, 0.44444444444444
49207, 0.78260869565217, 0.69782608695652, 0.44444444444444
49208, 0.78260869565217, 0.72391304347826, 0.47222222222222
49209, 0.73913043478261, 0.72391304347826, 0.027777777777778
49210, 0.76086956521739, 0.72391304347826, 0.055555555555556
49211, 0.73913043478261, 0.69782608695652, 0.055555555555556
49212, 0.73913043478261, 0.72391304347826, 0.083333333333333
49213, 0.76086956521739, 0.72391304347826, 0.11111111111111
49214, 0.73913043478261, 0.69782608695652, 0.11111111111111
49215, 0.73913043478261, 0.72391304347826, 0.13888888888889
49216, 0.76086956521739, 0.72391304347826, 0.16666666666667
49217, 0.73913043478261, 0.69782608695652, 0.16666666666667
49218, 0.73913043478261, 0.72391304347826, 0.19444444444444
49219, 0.76086956521739, 0.72391304347826, 0.22222222222222
49220, 0.73913043478261, 0.69782608695652, 0.22222222222222
49221, 0.73913043478261, 0.72391304347826, 0.25
49222, 0.76086956521739, 0.72391304347826, 0.27777777777778
49223, 0.73913043478261, 0.69782608695652, 0.27777777777778
49224, 0.73913043478261, 0.72391304347826, 0.30555555555556
49225, 0.76086956521739, 0.72391304347826, 0.33333333333333
49226, 0.73913043478261, 0.69782608695652, 0.33333333333333
49227, 0.73913043478261, 0.72391304347826, 0.36111111111111
49228, 0.76086956521739, 0.72391304347826, 0.38888888888889
49229, 0.73913043478261, 0.69782608695652, 0.38888888888889
49230, 0.73913043478261, 0.72391304347826, 0.41666666666667
49231, 0.76086956521739, 0.72391304347826, 0.44444444444444
49232, 0.73913043478261, 0.69782608695652, 0.44444444444444
49233, 0.73913043478261, 0.72391304347826, 0.47222222222222
49234, 0.69565217391304, 0.72391304347826, 0.027777777777778
49235, 0.71739130434783, 0.72391304347826, 0.055555555555556
49236, 0.69565217391304, 0.69782608695652, 0.055555555555556
49237, 0.69565217391304, 0.72391304347826, 0.083333333333333
49238, 0.71739130434783, 0.72391304347826, 0.11111111111111
49239, 0.69565217391304, 0.69782608695652, 0.11111111111111
49240, 0.69565217391304, 0.72391304347826, 0.13888888888889
49241, 0.71739130434783, 0.72391304347826, 0.16666666666667
49242, 0.69565217391304, 0.69782608695652, 0.16666666666667
49243, 0.69565217391304, 0.72391304347826, 0.19444444444444
49244, 0.71739130434783, 0.72391304347826, 0.22222222222222
49245, 0.69565217391304, 0.69782608695652, 0.22222222222222
49246, 0.69565217391304, 0.72391304347826, 0.25
49247, 0.71739130434783, 0.72391304347826, 0.27777777777778
49248, 0.69565217391304, 0.69782608695652, 0.27777777777778
49249, 0.69565217391304, 0.72391304347826, 0.30555555555556
49250, 0.71739130434783, 0.72391304347826, 0.33333333333333
49251, 0.69565217391304, 0.69782608695652, 0.33333333333333
49252, 0.69565217391304, 0.72391304347826, 0.36111111111111
49253, 0.71739130434783, 0.72391304347826, 0.38888888888889
49254, 0.69565217391304, 0.69782608695652, 0.38888888888889
49255, 0.69565217391304, 0.72391304347826, 0.41666666666667
49256, 0.71739130434783, 0.72391304347826, 0.44444444444444
49257, 0.69565217391304, 0.69782608695652, 0.44444444444444
49258, 0.69565217391304, 0.72391304347826, 0.47222222222222
49259, 0.65217391304348, 0.72391304347826, 0.027777777777778
49260, 0.67391304347826, 0.72391304347826, 0.055555555555556
49261, 0.65217391304348, 0.69782608695652, 0.055555555555556
49262, 0.65217391304348, 0.72391304347826, 0.083333333333333
49263, 0.67391304347826, 0.72391304347826, 0.11111111111111
49264, 0.65217391304348, 0.69782608695652, 0.11111111111111
49265, 0.65217391304348, 0.72391304347826, 0.13888888888889
49266, 0.67391304347826, 0.72391304347826, 0.16666666666667
49267, 0.65217391304348, 0.69782608695652, 0.16666666666667
49268, 0.65217391304348, 0.72391304347826, 0.19444444444444
49269, 0.67391304347826, 0.72391304347826, 0.22222222222222
49270, 0.65217391304348, 0.69782608695652, 0.22222222222222
49271, 0.65217391304348, 0.72391304347826, 0.25
49272, 0.67391304347826, 0.72391304347826, 0.27777777777778
49273, 0.65217391304348, 0.69782608695652, 0.27777777777778
49274, 0.65217391304348, 0.72391304347826, 0.30555555555556
49275, 0.67391304347826, 0.72391304347826, 0.33333333333333
49276, 0.65217391304348, 0.69782608695652, 0.33333333333333
49277, 0.65217391304348, 0.72391304347826, 0.36111111111111
49278, 0.67391304347826, 0.72391304347826, 0.38888888888889
49279, 0.65217391304348, 0.69782608695652, 0.38888888888889
49280, 0.65217391304348, 0.72391304347826, 0.41666666666667
49281, 0.67391304347826, 0.72391304347826, 0.44444444444444
49282, 0.65217391304348, 0.69782608695652, 0.44444444444444
49283, 0.65217391304348, 0.72391304347826, 0.47222222222222
49284, 0.60869565217391, 0.72391304347826, 0.027777777777778
49285, 0.6304347826087, 0.72391304347826, 0.055555555555556
49286, 0.60869565217391, 0.69782608695652, 0.055555555555556
49287, 0.60869565217391, 0.72391304347826, 0.083333333333333
49288, 0.6304347826087, 0.72391304347826, 0.11111111111111
49289, 0.60869565217391, 0.69782608695652, 0.11111111111111
49290, 0.60869565217391, 0.72391304347826, 0.13888888888889
49291, 0.6304347826087, 0.72391304347826, 0.16666666666667
49292, 0.60869565217391, 0.69782608695652, 0.16666666666667
49293, 0.60869565217391, 0.72391304347826, 0.19444444444444
49294, 0.6304347826087, 0.72391304347826, 0.22222222222222
49295, 0.60869565217391, 0.69782608695652, 0.22222222222222
49296, 0.60869565217391, 0.72391304347826, 0.25
49297, 0.6304347826087, 0.72391304347826, 0.27777777777778
49298, 0.60869565217391, 0.69782608695652, 0.27777777777778
49299, 0.60869565217391, 0.72391304347826, 0.30555555555556
49300, 0.6304347826087, 0.72391304347826, 0.33333333333333
49301, 0.60869565217391, 0.69782608695652, 0.33333333333333
49302, 0.60869565217391, 0.72391304347826, 0.36111111111111
49303, 0.6304347826087, 0.72391304347826, 0.38888888888889
49304, 0.60869565217391, 0.69782608695652, 0.38888888888889
49305, 0.60869565217391, 0.72391304347826, 0.41666666666667
49306, 0.6304347826087, 0.72391304347826, 0.44444444444444
49307, 0.60869565217391, 0.69782608695652, 0.44444444444444
49308, 0.60869565217391, 0.72391304347826, 0.47222222222222
49309, 0.56521739130435, 0.72391304347826, 0.027777777777778
49310, 0.58695652173913, 0.72391304347826, 0.055555555555556
49311, 0.56521739130435, 0.69782608695652, 0.055555555555556
49312, 0.56521739130435, 0.72391304347826, 0.083333333333333
49313, 0.58695652173913, 0.72391304347826, 0.11111111111111
49314, 0.56521739130435, 0.69782608695652, 0.11111111111111
49315, 0.56521739130435, 0.72391304347826, 0.13888888888889
49316, 0.58695652173913, 0.72391304347826, 0.16666666666667
49317, 0.56521739130435, 0.69782608695652, 0.16666666666667
49318, 0.56521739130435, 0.72391304347826, 0.19444444444444
49319, 0.58695652173913, 0.72391304347826, 0.22222222222222
49320, 0.56521739130435, 0.69782608695652, 0.22222222222222
49321, 0.56521739130435, 0.72391304347826, 0.25
49322, 0.58695652173913, 0.72391304347826, 0.27777777777778
49323, 0.56521739130435, 0.69782608695652, 0.27777777777778
49324, 0.56521739130435, 0.72391304347826, 0.30555555555556
49325, 0.58695652173913, 0.72391304347826, 0.33333333333333
49326, 0.56521739130435, 0.69782608695652, 0.33333333333333
49327, 0.56521739130435, 0.72391304347826, 0.36111111111111
49328, 0.58695652173913, 0.72391304347826, 0.38888888888889
49329, 0.56521739130435, 0.69782608695652, 0.38888888888889
49330, 0.56521739130435, 0.72391304347826, 0.41666666666667
49331, 0.58695652173913, 0.72391304347826, 0.44444444444444
49332, 0.56521739130435, 0.69782608695652, 0.44444444444444
49333, 0.56521739130435, 0.72391304347826, 0.47222222222222
49334, 0.52173913043478, 0.72391304347826, 0.027777777777778
49335, 0.54347826086957, 0.72391304347826, 0.055555555555556
49336, 0.52173913043478, 0.69782608695652, 0.055555555555556
49337, 0.52173913043478, 0.72391304347826, 0.083333333333333
49338, 0.54347826086957, 0.72391304347826, 0.11111111111111
49339, 0.52173913043478, 0.69782608695652, 0.11111111111111
49340, 0.52173913043478, 0.72391304347826, 0.13888888888889
49341, 0.54347826086957, 0.72391304347826, 0.16666666666667
49342, 0.52173913043478, 0.69782608695652, 0.16666666666667
49343, 0.52173913043478, 0.72391304347826, 0.19444444444444
49344, 0.54347826086956, 0.72391304347826, 0.22222222222222
49345, 0.52173913043478, 0.69782608695652, 0.22222222222222
49346, 0.52173913043478, 0.72391304347826, 0.25
49347, 0.54347826086956, 0.72391304347826, 0.27777777777778
49348, 0.52173913043478, 0.69782608695652, 0.27777777777778
49349, 0.52173913043478, 0.72391304347826, 0.30555555555556
49350, 0.54347826086956, 0.72391304347826, 0.33333333333333
49351, 0.52173913043478, 0.69782608695652, 0.33333333333333
49352, 0.52173913043478, 0.72391304347826, 0.36111111111111
49353, 0.54347826086956, 0.72391304347826, 0.38888888888889
49354, 0.52173913043478, 0.69782608695652, 0.38888888888889
49355, 0.52173913043478, 0.72391304347826, 0.41666666666667
49356, 0.54347826086956, 0.72391304347826, 0.44444444444444
49357, 0.52173913043478, 0.69782608695652, 0.44444444444444
49358, 0.52173913043478, 0.72391304347826, 0.47222222222222
49359, 0.47826086956522, 0.72391304347826, 0.027777777777778
49360, 0.5, 0.72391304347826, 0.055555555555556
49361, 0.47826086956522, 0.69782608695652, 0.055555555555556
49362, 0.47826086956522, 0.72391304347826, 0.083333333333333
49363, 0.5, 0.72391304347826, 0.11111111111111
49364, 0.47826086956522, 0.69782608695652, 0.11111111111111
49365, 0.47826086956522, 0.72391304347826, 0.13888888888889
49366, 0.5, 0.72391304347826, 0.16666666666667
49367, 0.47826086956522, 0.69782608695652, 0.16666666666667
49368, 0.47826086956522, 0.72391304347826, 0.19444444444444
49369, 0.5, 0.72391304347826, 0.22222222222222
49370, 0.47826086956522, 0.69782608695652, 0.22222222222222
49371, 0.47826086956522, 0.72391304347826, 0.25
49372, 0.5, 0.72391304347826, 0.27777777777778
49373, 0.47826086956522, 0.69782608695652, 0.27777777777778
49374, 0.47826086956522, 0.72391304347826, 0.30555555555556
49375, 0.5, 0.72391304347826, 0.33333333333333
49376, 0.47826086956522, 0.69782608695652, 0.33333333333333
49377, 0.47826086956522, 0.72391304347826, 0.36111111111111
49378, 0.5, 0.72391304347826, 0.38888888888889
49379, 0.47826086956522, 0.69782608695652, 0.38888888888889
49380, 0.47826086956522, 0.72391304347826, 0.41666666666667
49381, 0.5, 0.72391304347826, 0.44444444444444
49382, 0.47826086956522, 0.69782608695652, 0.44444444444444
49383, 0.47826086956522, 0.72391304347826, 0.47222222222222
49384, 0.43478260869565, 0.72391304347826, 0.027777777777778
49385, 0.45652173913043, 0.72391304347826, 0.055555555555556
49386, 0.43478260869565, 0.69782608695652, 0.055555555555556
49387, 0.43478260869565, 0.72391304347826, 0.083333333333333
49388, 0.45652173913043, 0.72391304347826, 0.11111111111111
49389, 0.43478260869565, 0.69782608695652, 0.11111111111111
49390, 0.43478260869565, 0.72391304347826, 0.13888888888889
49391, 0.45652173913043, 0.72391304347826, 0.16666666666667
49392, 0.43478260869565, 0.69782608695652, 0.16666666666667
49393, 0.43478260869565, 0.72391304347826, 0.19444444444444
49394, 0.45652173913043, 0.72391304347826, 0.22222222222222
49395, 0.43478260869565, 0.69782608695652, 0.22222222222222
49396, 0.43478260869565, 0.72391304347826, 0.25
49397, 0.45652173913043, 0.72391304347826, 0.27777777777778
49398, 0.43478260869565, 0.69782608695652, 0.27777777777778
49399, 0.43478260869565, 0.72391304347826, 0.30555555555556
49400, 0.45652173913043, 0.72391304347826, 0.33333333333333
49401, 0.43478260869565, 0.69782608695652, 0.33333333333333
49402, 0.43478260869565, 0.72391304347826, 0.36111111111111
49403, 0.45652173913043, 0.72391304347826, 0.38888888888889
49404, 0.43478260869565, 0.69782608695652, 0.38888888888889
49405, 0.43478260869565, 0.72391304347826, 0.41666666666667
49406, 0.45652173913043, 0.72391304347826, 0.44444444444444
49407, 0.43478260869565, 0.69782608695652, 0.44444444444444
49408, 0.43478260869565, 0.72391304347826, 0.47222222222222
49409, 0.39130434782609, 0.72391304347826, 0.027777777777778
49410, 0.41304347826087, 0.72391304347826, 0.055555555555556
49411, 0.39130434782609, 0.69782608695652, 0.055555555555556
49412, 0.39130434782609, 0.72391304347826, 0.083333333333333
49413, 0.41304347826087, 0.72391304347826, 0.11111111111111
49414, 0.39130434782609, 0.69782608695652, 0.11111111111111
49415, 0.39130434782609, 0.72391304347826, 0.13888888888889
49416, 0.41304347826087, 0.72391304347826, 0.16666666666667
49417, 0.39130434782609, 0.69782608695652, 0.16666666666667
49418, 0.39130434782609, 0.72391304347826, 0.19444444444444
49419, 0.41304347826087, 0.72391304347826, 0.22222222222222
49420, 0.39130434782609, 0.69782608695652, 0.22222222222222
49421, 0.39130434782609, 0.72391304347826, 0.25
49422, 0.41304347826087, 0.72391304347826, 0.27777777777778
49423, 0.39130434782609, 0.69782608695652, 0.27777777777778
49424, 0.39130434782609, 0.72391304347826, 0.30555555555556
49425, 0.41304347826087, 0.72391304347826, 0.33333333333333
49426, 0.39130434782609, 0.69782608695652, 0.33333333333333
49427, 0.39130434782609, 0.72391304347826, 0.36111111111111
49428, 0.41304347826087, 0.72391304347826, 0.38888888888889
49429, 0.39130434782609, 0.69782608695652, 0.38888888888889
49430, 0.39130434782609, 0.72391304347826, 0.41666666666667
49431, 0.41304347826087, 0.72391304347826, 0.44444444444444
49432, 0.39130434782609, 0.69782608695652, 0.44444444444444
49433, 0.39130434782609, 0.72391304347826, 0.47222222222222
49434, 0.34782608695652, 0.72391304347826, 0.027777777777778
49435, 0.3695652173913, 0.72391304347826, 0.055555555555556
49436, 0.34782608695652, 0.69782608695652, 0.055555555555556
49437, 0.34782608695652, 0.72391304347826, 0.083333333333333
49438, 0.3695652173913, 0.72391304347826, 0.11111111111111
49439, 0.34782608695652, 0.69782608695652, 0.11111111111111
49440, 0.34782608695652, 0.72391304347826, 0.13888888888889
49441, 0.3695652173913, 0.72391304347826, 0.16666666666667
49442, 0.34782608695652, 0.69782608695652, 0.16666666666667
49443, 0.34782608695652, 0.72391304347826, 0.19444444444444
49444, 0.3695652173913, 0.72391304347826, 0.22222222222222
49445, 0.34782608695652, 0.69782608695652, 0.22222222222222
49446, 0.34782608695652, 0.72391304347826, 0.25
49447, 0.3695652173913, 0.72391304347826, 0.27777777777778
49448, 0.34782608695652, 0.69782608695652, 0.27777777777778
49449, 0.34782608695652, 0.72391304347826, 0.30555555555556
49450, 0.3695652173913, 0.72391304347826, 0.33333333333333
49451, 0.34782608695652, 0.69782608695652, 0.33333333333333
49452, 0.34782608695652, 0.72391304347826, 0.36111111111111
49453, 0.3695652173913, 0.72391304347826, 0.38888888888889
49454, 0.34782608695652, 0.69782608695652, 0.38888888888889
49455, 0.34782608695652, 0.72391304347826, 0.41666666666667
49456, 0.3695652173913, 0.72391304347826, 0.44444444444444
49457, 0.34782608695652, 0.69782608695652, 0.44444444444444
49458, 0.34782608695652, 0.72391304347826, 0.47222222222222
49459, 0.30434782608696, 0.72391304347826, 0.027777777777778
49460, 0.32608695652174, 0.72391304347826, 0.055555555555556
49461, 0.30434782608696, 0.69782608695652, 0.055555555555556
49462, 0.30434782608696, 0.72391304347826, 0.083333333333333
49463, 0.32608695652174, 0.72391304347826, 0.11111111111111
49464, 0.30434782608696, 0.69782608695652, 0.11111111111111
49465, 0.30434782608696, 0.72391304347826, 0.13888888888889
49466, 0.32608695652174, 0.72391304347826, 0.16666666666667
49467, 0.30434782608696, 0.69782608695652, 0.16666666666667
49468, 0.30434782608696, 0.72391304347826, 0.19444444444444
49469, 0.32608695652174, 0.72391304347826, 0.22222222222222
49470, 0.30434782608696, 0.69782608695652, 0.22222222222222
49471, 0.30434782608696, 0.72391304347826, 0.25
49472, 0.32608695652174, 0.72391304347826, 0.27777777777778
49473, 0.30434782608696, 0.69782608695652, 0.27777777777778
49474, 0.30434782608696, 0.72391304347826, 0.30555555555556
49475, 0.32608695652174, 0.72391304347826, 0.33333333333333
49476, 0.30434782608696, 0.69782608695652, 0.33333333333333
49477, 0.30434782608696, 0.72391304347826, 0.36111111111111
49478, 0.32608695652174, 0.72391304347826, 0.38888888888889
49479, 0.30434782608696, 0.69782608695652, 0.38888888888889
49480, 0.30434782608696, 0.72391304347826, 0.41666666666667
49481, 0.32608695652174, 0.72391304347826, 0.44444444444444
49482, 0.30434782608696, 0.69782608695652, 0.44444444444444
49483, 0.30434782608696, 0.72391304347826, 0.47222222222222
49484, 0.26086956521739, 0.72391304347826, 0.027777777777778
49485, 0.28260869565217, 0.72391304347826, 0.055555555555556
49486, 0.26086956521739, 0.69782608695652, 0.055555555555556
49487, 0.26086956521739, 0.72391304347826, 0.083333333333333
49488, 0.28260869565217, 0.72391304347826, 0.11111111111111
49489, 0.26086956521739, 0.69782608695652, 0.11111111111111
49490, 0.26086956521739, 0.72391304347826, 0.13888888888889
49491, 0.28260869565217, 0.72391304347826, 0.16666666666667
49492, 0.26086956521739, 0.69782608695652, 0.16666666666667
49493, 0.26086956521739, 0.72391304347826, 0.19444444444444
49494, 0.28260869565217, 0.72391304347826, 0.22222222222222
49495, 0.26086956521739, 0.69782608695652, 0.22222222222222
49496, 0.26086956521739, 0.72391304347826, 0.25
49497, 0.28260869565217, 0.72391304347826, 0.27777777777778
49498, 0.26086956521739, 0.69782608695652, 0.27777777777778
49499, 0.26086956521739, 0.72391304347826, 0.30555555555556
49500, 0.28260869565217, 0.72391304347826, 0.33333333333333
49501, 0.26086956521739, 0.69782608695652, 0.33333333333333
49502, 0.26086956521739, 0.72391304347826, 0.36111111111111
49503, 0.28260869565217, 0.72391304347826, 0.38888888888889
49504, 0.26086956521739, 0.69782608695652, 0.38888888888889
49505, 0.26086956521739, 0.72391304347826, 0.41666666666667
49506, 0.28260869565217, 0.72391304347826, 0.44444444444444
49507, 0.26086956521739, 0.69782608695652, 0.44444444444444
49508, 0.26086956521739, 0.72391304347826, 0.47222222222222
49509, 0.21739130434783, 0.72391304347826, 0.027777777777778
49510, 0.23913043478261, 0.72391304347826, 0.055555555555556
49511, 0.21739130434783, 0.69782608695652, 0.055555555555556
49512, 0.21739130434783, 0.72391304347826, 0.083333333333333
49513, 0.23913043478261, 0.72391304347826, 0.11111111111111
49514, 0.21739130434783, 0.69782608695652, 0.11111111111111
49515, 0.21739130434783, 0.72391304347826, 0.13888888888889
49516, 0.23913043478261, 0.72391304347826, 0.16666666666667
49517, 0.21739130434783, 0.69782608695652, 0.16666666666667
49518, 0.21739130434783, 0.72391304347826, 0.19444444444444
49519, 0.23913043478261, 0.72391304347826, 0.22222222222222
49520, 0.21739130434783, 0.69782608695652, 0.22222222222222
49521, 0.21739130434783, 0.72391304347826, 0.25
49522, 0.23913043478261, 0.72391304347826, 0.27777777777778
49523, 0.21739130434783, 0.69782608695652, 0.27777777777778
49524, 0.21739130434783, 0.72391304347826, 0.30555555555556
49525, 0.23913043478261, 0.72391304347826, 0.33333333333333
49526, 0.21739130434783, 0.69782608695652, 0.33333333333333
49527, 0.21739130434783, 0.72391304347826, 0.36111111111111
49528, 0.23913043478261, 0.72391304347826, 0.38888888888889
49529, 0.21739130434783, 0.69782608695652, 0.38888888888889
49530, 0.21739130434783, 0.72391304347826, 0.41666666666667
49531, 0.23913043478261, 0.72391304347826, 0.44444444444444
49532, 0.21739130434783, 0.69782608695652, 0.44444444444444
49533, 0.21739130434783, 0.72391304347826, 0.47222222222222
49534, 0.17391304347826, 0.72391304347826, 0.027777777777778
49535, 0.19565217391304, 0.72391304347826, 0.055555555555556
49536, 0.17391304347826, 0.69782608695652, 0.055555555555556
49537, 0.17391304347826, 0.72391304347826, 0.083333333333333
49538, 0.19565217391304, 0.72391304347826, 0.11111111111111
49539, 0.17391304347826, 0.69782608695652, 0.11111111111111
49540, 0.17391304347826, 0.72391304347826, 0.13888888888889
49541, 0.19565217391304, 0.72391304347826, 0.16666666666667
49542, 0.17391304347826, 0.69782608695652, 0.16666666666667
49543, 0.17391304347826, 0.72391304347826, 0.19444444444444
49544, 0.19565217391304, 0.72391304347826, 0.22222222222222
49545, 0.17391304347826, 0.69782608695652, 0.22222222222222
49546, 0.17391304347826, 0.72391304347826, 0.25
49547, 0.19565217391304, 0.72391304347826, 0.27777777777778
49548, 0.17391304347826, 0.69782608695652, 0.27777777777778
49549, 0.17391304347826, 0.72391304347826, 0.30555555555556
49550, 0.19565217391304, 0.72391304347826, 0.33333333333333
49551, 0.17391304347826, 0.69782608695652, 0.33333333333333
49552, 0.17391304347826, 0.72391304347826, 0.36111111111111
49553, 0.19565217391304, 0.72391304347826, 0.38888888888889
49554, 0.17391304347826, 0.69782608695652, 0.38888888888889
49555, 0.17391304347826, 0.72391304347826, 0.41666666666667
49556, 0.19565217391304, 0.72391304347826, 0.44444444444444
49557, 0.17391304347826, 0.69782608695652, 0.44444444444444
49558, 0.17391304347826, 0.72391304347826, 0.47222222222222
49559, 0.1304347826087, 0.72391304347826, 0.027777777777778
49560, 0.15217391304348, 0.72391304347826, 0.055555555555556
49561, 0.1304347826087, 0.69782608695652, 0.055555555555556
49562, 0.1304347826087, 0.72391304347826, 0.083333333333333
49563, 0.15217391304348, 0.72391304347826, 0.11111111111111
49564, 0.1304347826087, 0.69782608695652, 0.11111111111111
49565, 0.1304347826087, 0.72391304347826, 0.13888888888889
49566, 0.15217391304348, 0.72391304347826, 0.16666666666667
49567, 0.1304347826087, 0.69782608695652, 0.16666666666667
49568, 0.1304347826087, 0.72391304347826, 0.19444444444444
