8148, 0.08695652173913, -0.25, 0.13888888888889
8149, 0.065217391304348, -0.25, 0.16666666666667
8150, 0.08695652173913, -0.25, 0.19444444444444
8151, 0.065217391304348, -0.25, 0.22222222222222
8152, 0.08695652173913, -0.25, 0.25
8153, 0.065217391304348, -0.25, 0.27777777777778
8154, 0.08695652173913, -0.25, 0.30555555555556
8155, 0.065217391304348, -0.25, 0.33333333333333
8156, 0.08695652173913, -0.25, 0.36111111111111
8157, 0.065217391304348, -0.25, 0.38888888888889
8158, 0.08695652173913, -0.25, 0.41666666666667
8159, 0.065217391304348, -0.25, 0.44444444444444
8160, 0.08695652173913, -0.25, 0.47222222222222
8161, 0.1304347826087, -0.25, 0.027777777777778
8162, 0.10869565217391, -0.25, 0.055555555555556
8163, 0.1304347826087, -0.25, 0.083333333333333
8164, 0.10869565217391, -0.25, 0.11111111111111
8165, 0.1304347826087, -0.25, 0.13888888888889
8166, 0.10869565217391, -0.25, 0.16666666666667
8167, 0.1304347826087, -0.25, 0.19444444444444
8168, 0.10869565217391, -0.25, 0.22222222222222
8169, 0.1304347826087, -0.25, 0.25
8170, 0.10869565217391, -0.25, 0.27777777777778
8171, 0.1304347826087, -0.25, 0.30555555555556
8172, 0.10869565217391, -0.25, 0.33333333333333
8173, 0.1304347826087, -0.25, 0.36111111111111
8174, 0.10869565217391, -0.25, 0.38888888888889
8175, 0.1304347826087, -0.25, 0.41666666666667
8176, 0.10869565217391, -0.25, 0.44444444444444
8177, 0.1304347826087, -0.25, 0.47222222222222
8178, 0.17391304347826, -0.25, 0.027777777777778
8179, 0.15217391304348, -0.25, 0.055555555555556
8180, 0.17391304347826, -0.25, 0.083333333333333
8181, 0.15217391304348, -0.25, 0.11111111111111
8182, 0.17391304347826, -0.25, 0.13888888888889
8183, 0.15217391304348, -0.25, 0.16666666666667
8184, 0.17391304347826, -0.25, 0.19444444444444
8185, 0.15217391304348, -0.25, 0.22222222222222
8186, 0.17391304347826, -0.25, 0.25
8187, 0.15217391304348, -0.25, 0.27777777777778
8188, 0.17391304347826, -0.25, 0.30555555555556
8189, 0.15217391304348, -0.25, 0.33333333333333
8190, 0.17391304347826, -0.25, 0.36111111111111
8191, 0.15217391304348, -0.25, 0.38888888888889
8192, 0.17391304347826, -0.25, 0.41666666666667
8193, 0.15217391304348, -0.25, 0.44444444444444
8194, 0.17391304347826, -0.25, 0.47222222222222
8195, 0.21739130434783, -0.25, 0.027777777777778
8196, 0.19565217391304, -0.25, 0.055555555555556
8197, 0.21739130434783, -0.25, 0.083333333333333
8198, 0.19565217391304, -0.25, 0.11111111111111
8199, 0.21739130434783, -0.25, 0.13888888888889
8200, 0.19565217391304, -0.25, 0.16666666666667
8201, 0.21739130434783, -0.25, 0.19444444444444
8202, 0.19565217391304, -0.25, 0.22222222222222
8203, 0.21739130434783, -0.25, 0.25
8204, 0.19565217391304, -0.25, 0.27777777777778
8205, 0.21739130434783, -0.25, 0.30555555555556
8206, 0.19565217391304, -0.25, 0.33333333333333
8207, 0.21739130434783, -0.25, 0.36111111111111
8208, 0.19565217391304, -0.25, 0.38888888888889
8209, 0.21739130434783, -0.25, 0.41666666666667
8210, 0.19565217391304, -0.25, 0.44444444444444
8211, 0.21739130434783, -0.25, 0.47222222222222
8212, 0.26086956521739, -0.25, 0.027777777777778
8213, 0.23913043478261, -0.25, 0.055555555555556
8214, 0.26086956521739, -0.25, 0.083333333333333
8215, 0.23913043478261, -0.25, 0.11111111111111
8216, 0.26086956521739, -0.25, 0.13888888888889
8217, 0.23913043478261, -0.25, 0.16666666666667
8218, 0.26086956521739, -0.25, 0.19444444444444
8219, 0.23913043478261, -0.25, 0.22222222222222
8220, 0.26086956521739, -0.25, 0.25
8221, 0.23913043478261, -0.25, 0.27777777777778
8222, 0.26086956521739, -0.25, 0.30555555555556
8223, 0.23913043478261, -0.25, 0.33333333333333
8224, 0.26086956521739, -0.25, 0.36111111111111
8225, 0.23913043478261, -0.25, 0.38888888888889
8226, 0.26086956521739, -0.25, 0.41666666666667
8227, 0.23913043478261, -0.25, 0.44444444444444
8228, 0.26086956521739, -0.25, 0.47222222222222
8229, 0.30434782608696, -0.25, 0.027777777777778
8230, 0.28260869565217, -0.25, 0.055555555555556
8231, 0.30434782608696, -0.25, 0.083333333333333
8232, 0.28260869565217, -0.25, 0.11111111111111
8233, 0.30434782608696, -0.25, 0.13888888888889
8234, 0.28260869565217, -0.25, 0.16666666666667
8235, 0.30434782608696, -0.25, 0.19444444444444
8236, 0.28260869565217, -0.25, 0.22222222222222
8237, 0.30434782608696, -0.25, 0.25
8238, 0.28260869565217, -0.25, 0.27777777777778
8239, 0.30434782608696, -0.25, 0.30555555555556
8240, 0.28260869565217, -0.25, 0.33333333333333
8241, 0.30434782608696, -0.25, 0.36111111111111
8242, 0.28260869565217, -0.25, 0.38888888888889
8243, 0.30434782608696, -0.25, 0.41666666666667
8244, 0.28260869565217, -0.25, 0.44444444444444
8245, 0.30434782608696, -0.25, 0.47222222222222
8246, 0.34782608695652, -0.25, 0.027777777777778
8247, 0.32608695652174, -0.25, 0.055555555555556
8248, 0.34782608695652, -0.25, 0.083333333333333
8249, 0.32608695652174, -0.25, 0.11111111111111
8250, 0.34782608695652, -0.25, 0.13888888888889
8251, 0.32608695652174, -0.25, 0.16666666666667
8252, 0.34782608695652, -0.25, 0.19444444444444
8253, 0.32608695652174, -0.25, 0.22222222222222
8254, 0.34782608695652, -0.25, 0.25
8255, 0.32608695652174, -0.25, 0.27777777777778
8256, 0.34782608695652, -0.25, 0.30555555555556
8257, 0.32608695652174, -0.25, 0.33333333333333
8258, 0.34782608695652, -0.25, 0.36111111111111
8259, 0.32608695652174, -0.25, 0.38888888888889
8260, 0.34782608695652, -0.25, 0.41666666666667
8261, 0.32608695652174, -0.25, 0.44444444444444
8262, 0.34782608695652, -0.25, 0.47222222222222
8263, 0.39130434782609, -0.25, 0.027777777777778
8264, 0.3695652173913, -0.25, 0.055555555555556
8265, 0.39130434782609, -0.25, 0.083333333333333
8266, 0.3695652173913, -0.25, 0.11111111111111
8267, 0.39130434782609, -0.25, 0.13888888888889
8268, 0.3695652173913, -0.25, 0.16666666666667
8269, 0.39130434782609, -0.25, 0.19444444444444
8270, 0.3695652173913, -0.25, 0.22222222222222
8271, 0.39130434782609, -0.25, 0.25
8272, 0.3695652173913, -0.25, 0.27777777777778
8273, 0.39130434782609, -0.25, 0.30555555555556
8274, 0.3695652173913, -0.25, 0.33333333333333
8275, 0.39130434782609, -0.25, 0.36111111111111
8276, 0.3695652173913, -0.25, 0.38888888888889
8277, 0.39130434782609, -0.25, 0.41666666666667
8278, 0.3695652173913, -0.25, 0.44444444444444
8279, 0.39130434782609, -0.25, 0.47222222222222
8280, 0.43478260869565, -0.25, 0.027777777777778
8281, 0.41304347826087, -0.25, 0.055555555555556
8282, 0.43478260869565, -0.25, 0.083333333333333
8283, 0.41304347826087, -0.25, 0.11111111111111
8284, 0.43478260869565, -0.25, 0.13888888888889
8285, 0.41304347826087, -0.25, 0.16666666666667
8286, 0.43478260869565, -0.25, 0.19444444444444
8287, 0.41304347826087, -0.25, 0.22222222222222
8288, 0.43478260869565, -0.25, 0.25
8289, 0.41304347826087, -0.25, 0.27777777777778
8290, 0.43478260869565, -0.25, 0.30555555555556
8291, 0.41304347826087, -0.25, 0.33333333333333
8292, 0.43478260869565, -0.25, 0.36111111111111
8293, 0.41304347826087, -0.25, 0.38888888888889
8294, 0.43478260869565, -0.25, 0.41666666666667
8295, 0.41304347826087, -0.25, 0.44444444444444
8296, 0.43478260869565, -0.25, 0.47222222222222
8297, 0.47826086956522, -0.25, 0.027777777777778
8298, 0.45652173913043, -0.25, 0.055555555555556
8299, 0.47826086956522, -0.25, 0.083333333333333
8300, 0.45652173913043, -0.25, 0.11111111111111
8301, 0.47826086956522, -0.25, 0.13888888888889
8302, 0.45652173913043, -0.25, 0.16666666666667
8303, 0.47826086956522, -0.25, 0.19444444444444
8304, 0.45652173913043, -0.25, 0.22222222222222
8305, 0.47826086956522, -0.25, 0.25
8306, 0.45652173913043, -0.25, 0.27777777777778
8307, 0.47826086956522, -0.25, 0.30555555555556
8308, 0.45652173913043, -0.25, 0.33333333333333
8309, 0.47826086956522, -0.25, 0.36111111111111
8310, 0.45652173913043, -0.25, 0.38888888888889
8311, 0.47826086956522, -0.25, 0.41666666666667
8312, 0.45652173913043, -0.25, 0.44444444444444
8313, 0.47826086956522, -0.25, 0.47222222222222
8314, 0.52173913043478, -0.25, 0.027777777777778
8315, 0.5, -0.25, 0.055555555555556
8316, 0.52173913043478, -0.25, 0.083333333333333
8317, 0.5, -0.25, 0.11111111111111
8318, 0.52173913043478, -0.25, 0.13888888888889
8319, 0.5, -0.25, 0.16666666666667
8320, 0.52173913043478, -0.25, 0.19444444444444
8321, 0.5, -0.25, 0.22222222222222
8322, 0.52173913043478, -0.25, 0.25
8323, 0.5, -0.25, 0.27777777777778
8324, 0.52173913043478, -0.25, 0.30555555555556
8325, 0.5, -0.25, 0.33333333333333
8326, 0.52173913043478, -0.25, 0.36111111111111
8327, 0.5, -0.25, 0.38888888888889
8328, 0.52173913043478, -0.25, 0.41666666666667
8329, 0.5, -0.25, 0.44444444444444
8330, 0.52173913043478, -0.25, 0.47222222222222
8331, 0.56521739130435, -0.25, 0.027777777777778
8332, 0.54347826086957, -0.25, 0.055555555555556
8333, 0.56521739130435, -0.25, 0.083333333333333
8334, 0.54347826086957, -0.25, 0.11111111111111
8335, 0.56521739130435, -0.25, 0.13888888888889
8336, 0.54347826086957, -0.25, 0.16666666666667
8337, 0.56521739130435, -0.25, 0.19444444444444
8338, 0.54347826086957, -0.25, 0.22222222222222
8339, 0.56521739130435, -0.25, 0.25
8340, 0.54347826086957, -0.25, 0.27777777777778
8341, 0.56521739130435, -0.25, 0.30555555555556
8342, 0.54347826086957, -0.25, 0.33333333333333
8343, 0.56521739130435, -0.25, 0.36111111111111
8344, 0.54347826086957, -0.25, 0.38888888888889
8345, 0.56521739130435, -0.25, 0.41666666666667
8346, 0.54347826086957, -0.25, 0.44444444444444
8347, 0.56521739130435, -0.25, 0.47222222222222
8348, 0.60869565217391, -0.25, 0.027777777777778
8349, 0.58695652173913, -0.25, 0.055555555555556
8350, 0.60869565217391, -0.25, 0.083333333333333
8351, 0.58695652173913, -0.25, 0.11111111111111
8352, 0.60869565217391, -0.25, 0.13888888888889
8353, 0.58695652173913, -0.25, 0.16666666666667
8354, 0.60869565217391, -0.25, 0.19444444444444
8355, 0.58695652173913, -0.25, 0.22222222222222
8356, 0.60869565217391, -0.25, 0.25
8357, 0.58695652173913, -0.25, 0.27777777777778
8358, 0.60869565217391, -0.25, 0.30555555555556
8359, 0.58695652173913, -0.25, 0.33333333333333
8360, 0.60869565217391, -0.25, 0.36111111111111
8361, 0.58695652173913, -0.25, 0.38888888888889
8362, 0.60869565217391, -0.25, 0.41666666666667
8363, 0.58695652173913, -0.25, 0.44444444444444
8364, 0.60869565217391, -0.25, 0.47222222222222
8365, 0.65217391304348, -0.25, 0.027777777777778
8366, 0.6304347826087, -0.25, 0.055555555555556
8367, 0.65217391304348, -0.25, 0.083333333333333
8368, 0.6304347826087, -0.25, 0.11111111111111
8369, 0.65217391304348, -0.25, 0.13888888888889
8370, 0.6304347826087, -0.25, 0.16666666666667
8371, 0.65217391304348, -0.25, 0.19444444444444
8372, 0.6304347826087, -0.25, 0.22222222222222
8373, 0.65217391304348, -0.25, 0.25
8374, 0.6304347826087, -0.25, 0.27777777777778
8375, 0.65217391304348, -0.25, 0.30555555555556
8376, 0.6304347826087, -0.25, 0.33333333333333
8377, 0.65217391304348, -0.25, 0.36111111111111
8378, 0.6304347826087, -0.25, 0.38888888888889
8379, 0.65217391304348, -0.25, 0.41666666666667
8380, 0.6304347826087, -0.25, 0.44444444444444
8381, 0.65217391304348, -0.25, 0.47222222222222
8382, 0.69565217391304, -0.25, 0.027777777777778
8383, 0.67391304347826, -0.25, 0.055555555555556
8384, 0.69565217391304, -0.25, 0.083333333333333
8385, 0.67391304347826, -0.25, 0.11111111111111
8386, 0.69565217391304, -0.25, 0.13888888888889
8387, 0.67391304347826, -0.25, 0.16666666666667
8388, 0.69565217391304, -0.25, 0.19444444444444
8389, 0.67391304347826, -0.25, 0.22222222222222
8390, 0.69565217391304, -0.25, 0.25
8391, 0.67391304347826, -0.25, 0.27777777777778
8392, 0.69565217391304, -0.25, 0.30555555555556
8393, 0.67391304347826, -0.25, 0.33333333333333
8394, 0.69565217391304, -0.25, 0.36111111111111
8395, 0.67391304347826, -0.25, 0.38888888888889
8396, 0.69565217391304, -0.25, 0.41666666666667
8397, 0.67391304347826, -0.25, 0.44444444444444
8398, 0.69565217391304, -0.25, 0.47222222222222
8399, 0.73913043478261, -0.25, 0.027777777777778
8400, 0.71739130434783, -0.25, 0.055555555555556
8401, 0.73913043478261, -0.25, 0.083333333333333
8402, 0.71739130434783, -0.25, 0.11111111111111
8403, 0.73913043478261, -0.25, 0.13888888888889
8404, 0.71739130434783, -0.25, 0.16666666666667
8405, 0.73913043478261, -0.25, 0.19444444444444
8406, 0.71739130434783, -0.25, 0.22222222222222
8407, 0.73913043478261, -0.25, 0.25
8408, 0.71739130434783, -0.25, 0.27777777777778
8409, 0.73913043478261, -0.25, 0.30555555555556
8410, 0.71739130434783, -0.25, 0.33333333333333
8411, 0.73913043478261, -0.25, 0.36111111111111
8412, 0.71739130434783, -0.25, 0.38888888888889
8413, 0.73913043478261, -0.25, 0.41666666666667
8414, 0.71739130434783, -0.25, 0.44444444444444
8415, 0.73913043478261, -0.25, 0.47222222222222
8416, 0.78260869565217, -0.25, 0.027777777777778
8417, 0.76086956521739, -0.25, 0.055555555555556
8418, 0.78260869565217, -0.25, 0.083333333333333
8419, 0.76086956521739, -0.25, 0.11111111111111
8420, 0.78260869565217, -0.25, 0.13888888888889
8421, 0.76086956521739, -0.25, 0.16666666666667
8422, 0.78260869565217, -0.25, 0.19444444444444
8423, 0.76086956521739, -0.25, 0.22222222222222
8424, 0.78260869565217, -0.25, 0.25
8425, 0.76086956521739, -0.25, 0.27777777777778
8426, 0.78260869565217, -0.25, 0.30555555555556
8427, 0.76086956521739, -0.25, 0.33333333333333
8428, 0.78260869565217, -0.25, 0.36111111111111
8429, 0.76086956521739, -0.25, 0.38888888888889
8430, 0.78260869565217, -0.25, 0.41666666666667
8431, 0.76086956521739, -0.25, 0.44444444444444
8432, 0.78260869565217, -0.25, 0.47222222222222
8433, 0.82608695652174, -0.25, 0.027777777777778
8434, 0.80434782608696, -0.25, 0.055555555555556
8435, 0.82608695652174, -0.25, 0.083333333333333
8436, 0.80434782608696, -0.25, 0.11111111111111
8437, 0.82608695652174, -0.25, 0.13888888888889
8438, 0.80434782608696, -0.25, 0.16666666666667
8439, 0.82608695652174, -0.25, 0.19444444444444
8440, 0.80434782608696, -0.25, 0.22222222222222
8441, 0.82608695652174, -0.25, 0.25
8442, 0.80434782608696, -0.25, 0.27777777777778
8443, 0.82608695652174, -0.25, 0.30555555555556
8444, 0.80434782608696, -0.25, 0.33333333333333
8445, 0.82608695652174, -0.25, 0.36111111111111
8446, 0.80434782608696, -0.25, 0.38888888888889
8447, 0.82608695652174, -0.25, 0.41666666666667
8448, 0.80434782608696, -0.25, 0.44444444444444
8449, 0.82608695652174, -0.25, 0.47222222222222
8450, 0.8695652173913, -0.25, 0.027777777777778
8451, 0.84782608695652, -0.25, 0.055555555555556
8452, 0.8695652173913, -0.25, 0.083333333333333
8453, 0.84782608695652, -0.25, 0.11111111111111
8454, 0.8695652173913, -0.25, 0.13888888888889
8455, 0.84782608695652, -0.25, 0.16666666666667
8456, 0.8695652173913, -0.25, 0.19444444444444
8457, 0.84782608695652, -0.25, 0.22222222222222
8458, 0.8695652173913, -0.25, 0.25
8459, 0.84782608695652, -0.25, 0.27777777777778
8460, 0.8695652173913, -0.25, 0.30555555555556
8461, 0.84782608695652, -0.25, 0.33333333333333
8462, 0.8695652173913, -0.25, 0.36111111111111
8463, 0.84782608695652, -0.25, 0.38888888888889
8464, 0.8695652173913, -0.25, 0.41666666666667
8465, 0.84782608695652, -0.25, 0.44444444444444
8466, 0.8695652173913, -0.25, 0.47222222222222
8467, 0.91304347826087, -0.25, 0.027777777777778
8468, 0.89130434782609, -0.25, 0.055555555555556
8469, 0.91304347826087, -0.25, 0.083333333333333
8470, 0.89130434782609, -0.25, 0.11111111111111
8471, 0.91304347826087, -0.25, 0.13888888888889
8472, 0.89130434782609, -0.25, 0.16666666666667
8473, 0.91304347826087, -0.25, 0.19444444444444
8474, 0.89130434782609, -0.25, 0.22222222222222
8475, 0.91304347826087, -0.25, 0.25
8476, 0.89130434782609, -0.25, 0.27777777777778
8477, 0.91304347826087, -0.25, 0.30555555555556
8478, 0.89130434782609, -0.25, 0.33333333333333
8479, 0.91304347826087, -0.25, 0.36111111111111
8480, 0.89130434782609, -0.25, 0.38888888888889
8481, 0.91304347826087, -0.25, 0.41666666666667
8482, 0.89130434782609, -0.25, 0.44444444444444
8483, 0.91304347826087, -0.25, 0.47222222222222
8484, 0.95652173913043, -0.25, 0.027777777777778
8485, 0.93478260869565, -0.25, 0.055555555555556
8486, 0.95652173913043, -0.25, 0.083333333333333
8487, 0.93478260869565, -0.25, 0.11111111111111
8488, 0.95652173913043, -0.25, 0.13888888888889
8489, 0.93478260869565, -0.25, 0.16666666666667
8490, 0.95652173913043, -0.25, 0.19444444444444
8491, 0.93478260869565, -0.25, 0.22222222222222
8492, 0.95652173913043, -0.25, 0.25
8493, 0.93478260869565, -0.25, 0.27777777777778
8494, 0.95652173913043, -0.25, 0.30555555555556
8495, 0.93478260869565, -0.25, 0.33333333333333
8496, 0.95652173913043, -0.25, 0.36111111111111
8497, 0.93478260869565, -0.25, 0.38888888888889
8498, 0.95652173913043, -0.25, 0.41666666666667
8499, 0.93478260869565, -0.25, 0.44444444444444
8500, 0.95652173913043, -0.25, 0.47222222222222
8501, 0.97826086956522, -0.25, 0.055555555555556
8502, 0.97826086956522, -0.25, 0.11111111111111
8503, 0.97826086956522, -0.25, 0.16666666666667
8504, 0.97826086956522, -0.25, 0.22222222222222
8505, 0.97826086956522, -0.25, 0.27777777777778
8506, 0.97826086956522, -0.25, 0.33333333333333
8507, 0.97826086956522, -0.25, 0.38888888888889
8508, 0.97826086956522, -0.25, 0.44444444444444
8509, 1.05, -0.1, 0.5
8510, 1.05, -0.15, 0.5
8511, 1.05, -0.2, 0.5
8512, 1.1, -0.1, 0.5
8513, 1.1, -0.15, 0.5
8514, 1.1, -0.2, 0.5
8515, 1.15, -0.1, 0.5
8516, 1.15, -0.15, 0.5
8517, 1.15, -0.2, 0.5
8518, 1.025, -0.1, 0.5
8519, 1.05, -0.075, 0.5
8520, 1.025, -0.15, 0.5
8521, 1.05, -0.125, 0.5
8522, 1.025, -0.2, 0.5
8523, 1.05, -0.175, 0.5
8524, 1.05, -0.225, 0.5
8525, 1.075, -0.1, 0.5
8526, 1.1, -0.075, 0.5
8527, 1.075, -0.15, 0.5
8528, 1.1, -0.125, 0.5
8529, 1.075, -0.2, 0.5
8530, 1.1, -0.175, 0.5
8531, 1.1, -0.225, 0.5
8532, 1.125, -0.1, 0.5
8533, 1.15, -0.075, 0.5
8534, 1.125, -0.15, 0.5
8535, 1.15, -0.125, 0.5
8536, 1.125, -0.2, 0.5
8537, 1.15, -0.175, 0.5
8538, 1.15, -0.225, 0.5
8539, 1.175, -0.1, 0.5
8540, 1.175, -0.15, 0.5
8541, 1.175, -0.2, 0.5
8542, 1.05, -0.1, 0
8543, 1.05, -0.15, 0
8544, 1.05, -0.2, 0
8545, 1.1, -0.1, 0
8546, 1.1, -0.15, 0
8547, 1.1, -0.2, 0
8548, 1.15, -0.1, 0
8549, 1.15, -0.15, 0
8550, 1.15, -0.2, 0
8551, 1.05, -0.075, 0
8552, 1.025, -0.1, 0
8553, 1.05, -0.125, 0
8554, 1.025, -0.15, 0
8555, 1.05, -0.175, 0
8556, 1.025, -0.2, 0
8557, 1.05, -0.225, 0
8558, 1.1, -0.075, 0
8559, 1.075, -0.1, 0
8560, 1.1, -0.125, 0
8561, 1.075, -0.15, 0
8562, 1.1, -0.175, 0
8563, 1.075, -0.2, 0
8564, 1.1, -0.225, 0
8565, 1.15, -0.075, 0
8566, 1.125, -0.1, 0
8567, 1.15, -0.125, 0
8568, 1.125, -0.15, 0
8569, 1.15, -0.175, 0
8570, 1.125, -0.2, 0
8571, 1.15, -0.225, 0
8572, 1.175, -0.1, 0
8573, 1.175, -0.15, 0
8574, 1.175, -0.2, 0
8575, 1.05, -0.05, 0.44444444444444
8576, 1.05, -0.05, 0.38888888888889
8577, 1.05, -0.05, 0.33333333333333
8578, 1.05, -0.05, 0.27777777777778
8579, 1.05, -0.05, 0.22222222222222
8580, 1.05, -0.05, 0.16666666666667
8581, 1.05, -0.05, 0.11111111111111
8582, 1.05, -0.05, 0.055555555555556
8583, 1.1, -0.05, 0.44444444444444
8584, 1.1, -0.05, 0.38888888888889
8585, 1.1, -0.05, 0.33333333333333
8586, 1.1, -0.05, 0.27777777777778
8587, 1.1, -0.05, 0.22222222222222
8588, 1.1, -0.05, 0.16666666666667
8589, 1.1, -0.05, 0.11111111111111
8590, 1.1, -0.05, 0.055555555555556
8591, 1.15, -0.05, 0.44444444444444
8592, 1.15, -0.05, 0.38888888888889
8593, 1.15, -0.05, 0.33333333333333
8594, 1.15, -0.05, 0.27777777777778
8595, 1.15, -0.05, 0.22222222222222
8596, 1.15, -0.05, 0.16666666666667
8597, 1.15, -0.05, 0.11111111111111
8598, 1.15, -0.05, 0.055555555555556
8599, 1.05, -0.05, 0.47222222222222
8600, 1.025, -0.05, 0.44444444444444
8601, 1.05, -0.05, 0.41666666666667
8602, 1.025, -0.05, 0.38888888888889
8603, 1.05, -0.05, 0.36111111111111
8604, 1.025, -0.05, 0.33333333333333
8605, 1.05, -0.05, 0.30555555555556
8606, 1.025, -0.05, 0.27777777777778
8607, 1.05, -0.05, 0.25
8608, 1.025, -0.05, 0.22222222222222
8609, 1.05, -0.05, 0.19444444444444
8610, 1.025, -0.05, 0.16666666666667
8611, 1.05, -0.05, 0.13888888888889
8612, 1.025, -0.05, 0.11111111111111
8613, 1.05, -0.05, 0.083333333333333
8614, 1.025, -0.05, 0.055555555555556
8615, 1.05, -0.05, 0.027777777777778
8616, 1.1, -0.05, 0.47222222222222
8617, 1.075, -0.05, 0.44444444444444
8618, 1.1, -0.05, 0.41666666666667
8619, 1.075, -0.05, 0.38888888888889
8620, 1.1, -0.05, 0.36111111111111
8621, 1.075, -0.05, 0.33333333333333
8622, 1.1, -0.05, 0.30555555555556
8623, 1.075, -0.05, 0.27777777777778
8624, 1.1, -0.05, 0.25
8625, 1.075, -0.05, 0.22222222222222
8626, 1.1, -0.05, 0.19444444444444
8627, 1.075, -0.05, 0.16666666666667
8628, 1.1, -0.05, 0.13888888888889
8629, 1.075, -0.05, 0.11111111111111
8630, 1.1, -0.05, 0.083333333333333
8631, 1.075, -0.05, 0.055555555555556
8632, 1.1, -0.05, 0.027777777777778
8633, 1.15, -0.05, 0.47222222222222
8634, 1.125, -0.05, 0.44444444444444
8635, 1.15, -0.05, 0.41666666666667
8636, 1.125, -0.05, 0.38888888888889
8637, 1.15, -0.05, 0.36111111111111
8638, 1.125, -0.05, 0.33333333333333
8639, 1.15, -0.05, 0.30555555555556
8640, 1.125, -0.05, 0.27777777777778
8641, 1.15, -0.05, 0.25
8642, 1.125, -0.05, 0.22222222222222
8643, 1.15, -0.05, 0.19444444444444
8644, 1.125, -0.05, 0.16666666666667
8645, 1.15, -0.05, 0.13888888888889
8646, 1.125, -0.05, 0.11111111111111
8647, 1.15, -0.05, 0.083333333333333
8648, 1.125, -0.05, 0.055555555555556
8649, 1.15, -0.05, 0.027777777777778
8650, 1.175, -0.05, 0.44444444444444
8651, 1.175, -0.05, 0.38888888888889
8652, 1.175, -0.05, 0.33333333333333
8653, 1.175, -0.05, 0.27777777777778
8654, 1.175, -0.05, 0.22222222222222
8655, 1.175, -0.05, 0.16666666666667
8656, 1.175, -0.05, 0.11111111111111
8657, 1.175, -0.05, 0.055555555555556
8658, 1.05, -0.25, 0.44444444444444
8659, 1.05, -0.25, 0.38888888888889
8660, 1.05, -0.25, 0.33333333333333
8661, 1.05, -0.25, 0.27777777777778
8662, 1.05, -0.25, 0.22222222222222
8663, 1.05, -0.25, 0.16666666666667
8664, 1.05, -0.25, 0.11111111111111
8665, 1.05, -0.25, 0.055555555555556
8666, 1.1, -0.25, 0.44444444444444
8667, 1.1, -0.25, 0.38888888888889
8668, 1.1, -0.25, 0.33333333333333
8669, 1.1, -0.25, 0.27777777777778
8670, 1.1, -0.25, 0.22222222222222
8671, 1.1, -0.25, 0.16666666666667
8672, 1.1, -0.25, 0.11111111111111
8673, 1.1, -0.25, 0.055555555555556
8674, 1.15, -0.25, 0.44444444444444
8675, 1.15, -0.25, 0.38888888888889
8676, 1.15, -0.25, 0.33333333333333
8677, 1.15, -0.25, 0.27777777777778
8678, 1.15, -0.25, 0.22222222222222
8679, 1.15, -0.25, 0.16666666666667
8680, 1.15, -0.25, 0.11111111111111
8681, 1.15, -0.25, 0.055555555555556
8682, 1.025, -0.25, 0.44444444444444
8683, 1.05, -0.25, 0.47222222222222
8684, 1.025, -0.25, 0.38888888888889
8685, 1.05, -0.25, 0.41666666666667
8686, 1.025, -0.25, 0.33333333333333
8687, 1.05, -0.25, 0.36111111111111
8688, 1.025, -0.25, 0.27777777777778
8689, 1.05, -0.25, 0.30555555555556
8690, 1.025, -0.25, 0.22222222222222
8691, 1.05, -0.25, 0.25
8692, 1.025, -0.25, 0.16666666666667
8693, 1.05, -0.25, 0.19444444444444
8694, 1.025, -0.25, 0.11111111111111
8695, 1.05, -0.25, 0.13888888888889
8696, 1.025, -0.25, 0.055555555555556
8697, 1.05, -0.25, 0.083333333333333
8698, 1.05, -0.25, 0.027777777777778
8699, 1.075, -0.25, 0.44444444444444
8700, 1.1, -0.25, 0.47222222222222
8701, 1.075, -0.25, 0.38888888888889
8702, 1.1, -0.25, 0.41666666666667
8703, 1.075, -0.25, 0.33333333333333
8704, 1.1, -0.25, 0.36111111111111
8705, 1.075, -0.25, 0.27777777777778
8706, 1.1, -0.25, 0.30555555555556
8707, 1.075, -0.25, 0.22222222222222
8708, 1.1, -0.25, 0.25
8709, 1.075, -0.25, 0.16666666666667
8710, 1.1, -0.25, 0.19444444444444
8711, 1.075, -0.25, 0.11111111111111
8712, 1.1, -0.25, 0.13888888888889
8713, 1.075, -0.25, 0.055555555555556
8714, 1.1, -0.25, 0.083333333333333
8715, 1.1, -0.25, 0.027777777777778
8716, 1.125, -0.25, 0.44444444444444
8717, 1.15, -0.25, 0.47222222222222
8718, 1.125, -0.25, 0.38888888888889
8719, 1.15, -0.25, 0.41666666666667
8720, 1.125, -0.25, 0.33333333333333
8721, 1.15, -0.25, 0.36111111111111
8722, 1.125, -0.25, 0.27777777777778
8723, 1.15, -0.25, 0.30555555555556
8724, 1.125, -0.25, 0.22222222222222
8725, 1.15, -0.25, 0.25
8726, 1.125, -0.25, 0.16666666666667
8727, 1.15, -0.25, 0.19444444444444
8728, 1.125, -0.25, 0.11111111111111
8729, 1.15, -0.25, 0.13888888888889
8730, 1.125, -0.25, 0.055555555555556
8731, 1.15, -0.25, 0.083333333333333
8732, 1.15, -0.25, 0.027777777777778
8733, 1.175, -0.25, 0.44444444444444
8734, 1.175, -0.25, 0.38888888888889
8735, 1.175, -0.25, 0.33333333333333
8736, 1.175, -0.25, 0.27777777777778
8737, 1.175, -0.25, 0.22222222222222
8738, 1.175, -0.25, 0.16666666666667
8739, 1.175, -0.25, 0.11111111111111
8740, 1.175, -0.25, 0.055555555555556
8741, 1.2, -0.1, 0.44444444444444
8742, 1.2, -0.1, 0.38888888888889
8743, 1.2, -0.1, 0.33333333333333
8744, 1.2, -0.1, 0.27777777777778
8745, 1.2, -0.1, 0.22222222222222
8746, 1.2, -0.1, 0.16666666666667
8747, 1.2, -0.1, 0.11111111111111
8748, 1.2, -0.1, 0.055555555555556
8749, 1.2, -0.15, 0.44444444444444
8750, 1.2, -0.15, 0.38888888888889
8751, 1.2, -0.15, 0.33333333333333
8752, 1.2, -0.15, 0.27777777777778
8753, 1.2, -0.15, 0.22222222222222
8754, 1.2, -0.15, 0.16666666666667
8755, 1.2, -0.15, 0.11111111111111
8756, 1.2, -0.15, 0.055555555555556
8757, 1.2, -0.2, 0.44444444444444
8758, 1.2, -0.2, 0.38888888888889
8759, 1.2, -0.2, 0.33333333333333
8760, 1.2, -0.2, 0.27777777777778
8761, 1.2, -0.2, 0.22222222222222
8762, 1.2, -0.2, 0.16666666666667
8763, 1.2, -0.2, 0.11111111111111
8764, 1.2, -0.2, 0.055555555555556
8765, 1.2, -0.1, 0.47222222222222
8766, 1.2, -0.075, 0.44444444444444
8767, 1.2, -0.1, 0.41666666666667
8768, 1.2, -0.075, 0.38888888888889
8769, 1.2, -0.1, 0.36111111111111
8770, 1.2, -0.075, 0.33333333333333
8771, 1.2, -0.1, 0.30555555555556
8772, 1.2, -0.075, 0.27777777777778
8773, 1.2, -0.1, 0.25
8774, 1.2, -0.075, 0.22222222222222
8775, 1.2, -0.1, 0.19444444444444
8776, 1.2, -0.075, 0.16666666666667
8777, 1.2, -0.1, 0.13888888888889
8778, 1.2, -0.075, 0.11111111111111
8779, 1.2, -0.1, 0.083333333333333
8780, 1.2, -0.075, 0.055555555555556
8781, 1.2, -0.1, 0.027777777777778
8782, 1.2, -0.15, 0.47222222222222
8783, 1.2, -0.125, 0.44444444444444
8784, 1.2, -0.15, 0.41666666666667
8785, 1.2, -0.125, 0.38888888888889
8786, 1.2, -0.15, 0.36111111111111
8787, 1.2, -0.125, 0.33333333333333
8788, 1.2, -0.15, 0.30555555555556
8789, 1.2, -0.125, 0.27777777777778
8790, 1.2, -0.15, 0.25
8791, 1.2, -0.125, 0.22222222222222
8792, 1.2, -0.15, 0.19444444444444
8793, 1.2, -0.125, 0.16666666666667
8794, 1.2, -0.15, 0.13888888888889
8795, 1.2, -0.125, 0.11111111111111
8796, 1.2, -0.15, 0.083333333333333
8797, 1.2, -0.125, 0.055555555555556
8798, 1.2, -0.15, 0.027777777777778
8799, 1.2, -0.2, 0.47222222222222
8800, 1.2, -0.175, 0.44444444444444
8801, 1.2, -0.2, 0.41666666666667
8802, 1.2, -0.175, 0.38888888888889
8803, 1.2, -0.2, 0.36111111111111
8804, 1.2, -0.175, 0.33333333333333
8805, 1.2, -0.2, 0.30555555555556
8806, 1.2, -0.175, 0.27777777777778
8807, 1.2, -0.2, 0.25
8808, 1.2, -0.175, 0.22222222222222
8809, 1.2, -0.2, 0.19444444444444
8810, 1.2, -0.175, 0.16666666666667
8811, 1.2, -0.2, 0.13888888888889
8812, 1.2, -0.175, 0.11111111111111
8813, 1.2, -0.2, 0.083333333333333
8814, 1.2, -0.175, 0.055555555555556
8815, 1.2, -0.2, 0.027777777777778
8816, 1.2, -0.225, 0.44444444444444
8817, 1.2, -0.225, 0.38888888888889
8818, 1.2, -0.225, 0.33333333333333
8819, 1.2, -0.225, 0.27777777777778
8820, 1.2, -0.225, 0.22222222222222
8821, 1.2, -0.225, 0.16666666666667
8822, 1.2, -0.225, 0.11111111111111
8823, 1.2, -0.225, 0.055555555555556
8824, 1.2434782608696, -0.1, 0.5
8825, 1.2869565217391, -0.1, 0.5
8826, 1.3304347826087, -0.1, 0.5
8827, 1.3739130434783, -0.1, 0.5
8828, 1.4173913043478, -0.1, 0.5
8829, 1.4608695652174, -0.1, 0.5
8830, 1.504347826087, -0.1, 0.5
8831, 1.5478260869565, -0.1, 0.5
8832, 1.5913043478261, -0.1, 0.5
8833, 1.6347826086957, -0.1, 0.5
8834, 1.6782608695652, -0.1, 0.5
8835, 1.7217391304348, -0.1, 0.5
8836, 1.7652173913043, -0.1, 0.5
8837, 1.8086956521739, -0.1, 0.5
8838, 1.8521739130435, -0.1, 0.5
8839, 1.895652173913, -0.1, 0.5
8840, 1.9391304347826, -0.1, 0.5
8841, 1.9826086956522, -0.1, 0.5
8842, 2.0260869565217, -0.1, 0.5
8843, 2.0695652173913, -0.1, 0.5
8844, 2.1130434782609, -0.1, 0.5
8845, 2.1565217391304, -0.1, 0.5
8846, 1.2434782608696, -0.15, 0.5
8847, 1.2869565217391, -0.15, 0.5
8848, 1.3304347826087, -0.15, 0.5
8849, 1.3739130434783, -0.15, 0.5
8850, 1.4173913043478, -0.15, 0.5
8851, 1.4608695652174, -0.15, 0.5
8852, 1.504347826087, -0.15, 0.5
8853, 1.5478260869565, -0.15, 0.5
8854, 1.5913043478261, -0.15, 0.5
8855, 1.6347826086957, -0.15, 0.5
8856, 1.6782608695652, -0.15, 0.5
8857, 1.7217391304348, -0.15, 0.5
8858, 1.7652173913043, -0.15, 0.5
8859, 1.8086956521739, -0.15, 0.5
8860, 1.8521739130435, -0.15, 0.5
8861, 1.895652173913, -0.15, 0.5
8862, 1.9391304347826, -0.15, 0.5
8863, 1.9826086956522, -0.15, 0.5
8864, 2.0260869565217, -0.15, 0.5
8865, 2.0695652173913, -0.15, 0.5
8866, 2.1130434782609, -0.15, 0.5
8867, 2.1565217391304, -0.15, 0.5
8868, 1.2434782608696, -0.2, 0.5
8869, 1.2869565217391, -0.2, 0.5
8870, 1.3304347826087, -0.2, 0.5
8871, 1.3739130434783, -0.2, 0.5
8872, 1.4173913043478, -0.2, 0.5
8873, 1.4608695652174, -0.2, 0.5
8874, 1.504347826087, -0.2, 0.5
8875, 1.5478260869565, -0.2, 0.5
8876, 1.5913043478261, -0.2, 0.5
8877, 1.6347826086957, -0.2, 0.5
8878, 1.6782608695652, -0.2, 0.5
8879, 1.7217391304348, -0.2, 0.5
8880, 1.7652173913043, -0.2, 0.5
8881, 1.8086956521739, -0.2, 0.5
8882, 1.8521739130435, -0.2, 0.5
8883, 1.895652173913, -0.2, 0.5
8884, 1.9391304347826, -0.2, 0.5
8885, 1.9826086956522, -0.2, 0.5
8886, 2.0260869565217, -0.2, 0.5
8887, 2.0695652173913, -0.2, 0.5
8888, 2.1130434782609, -0.2, 0.5
8889, 2.1565217391304, -0.2, 0.5
8890, 1.2217391304348, -0.1, 0.5
8891, 1.2434782608696, -0.075, 0.5
8892, 1.2652173913043, -0.1, 0.5
8893, 1.2869565217391, -0.075, 0.5
8894, 1.3086956521739, -0.1, 0.5
8895, 1.3304347826087, -0.075, 0.5
8896, 1.3521739130435, -0.1, 0.5
8897, 1.3739130434783, -0.075, 0.5
8898, 1.395652173913, -0.1, 0.5
8899, 1.4173913043478, -0.075, 0.5
8900, 1.4391304347826, -0.1, 0.5
8901, 1.4608695652174, -0.075, 0.5
8902, 1.4826086956522, -0.1, 0.5
8903, 1.504347826087, -0.075, 0.5
8904, 1.5260869565217, -0.1, 0.5
8905, 1.5478260869565, -0.075, 0.5
8906, 1.5695652173913, -0.1, 0.5
8907, 1.5913043478261, -0.075, 0.5
8908, 1.6130434782609, -0.1, 0.5
8909, 1.6347826086957, -0.075, 0.5
8910, 1.6565217391304, -0.1, 0.5
8911, 1.6782608695652, -0.075, 0.5
8912, 1.7, -0.1, 0.5
8913, 1.7217391304348, -0.075, 0.5
8914, 1.7434782608696, -0.1, 0.5
8915, 1.7652173913043, -0.075, 0.5
8916, 1.7869565217391, -0.1, 0.5
8917, 1.8086956521739, -0.075, 0.5
8918, 1.8304347826087, -0.1, 0.5
8919, 1.8521739130435, -0.075, 0.5
8920, 1.8739130434783, -0.1, 0.5
8921, 1.895652173913, -0.075, 0.5
8922, 1.9173913043478, -0.1, 0.5
8923, 1.9391304347826, -0.075, 0.5
8924, 1.9608695652174, -0.1, 0.5
8925, 1.9826086956522, -0.075, 0.5
8926, 2.004347826087, -0.1, 0.5
8927, 2.0260869565217, -0.075, 0.5
8928, 2.0478260869565, -0.1, 0.5
8929, 2.0695652173913, -0.075, 0.5
8930, 2.0913043478261, -0.1, 0.5
8931, 2.1130434782609, -0.075, 0.5
8932, 2.1347826086957, -0.1, 0.5
8933, 2.1565217391304, -0.075, 0.5
8934, 2.1782608695652, -0.1, 0.5
8935, 1.2217391304348, -0.15, 0.5
8936, 1.2434782608696, -0.125, 0.5
8937, 1.2652173913043, -0.15, 0.5
8938, 1.2869565217391, -0.125, 0.5
8939, 1.3086956521739, -0.15, 0.5
8940, 1.3304347826087, -0.125, 0.5
8941, 1.3521739130435, -0.15, 0.5
8942, 1.3739130434783, -0.125, 0.5
8943, 1.395652173913, -0.15, 0.5
8944, 1.4173913043478, -0.125, 0.5
8945, 1.4391304347826, -0.15, 0.5
8946, 1.4608695652174, -0.125, 0.5
8947, 1.4826086956522, -0.15, 0.5
8948, 1.504347826087, -0.125, 0.5
8949, 1.5260869565217, -0.15, 0.5
8950, 1.5478260869565, -0.125, 0.5
8951, 1.5695652173913, -0.15, 0.5
8952, 1.5913043478261, -0.125, 0.5
8953, 1.6130434782609, -0.15, 0.5
8954, 1.6347826086957, -0.125, 0.5
8955, 1.6565217391304, -0.15, 0.5
8956, 1.6782608695652, -0.125, 0.5
8957, 1.7, -0.15, 0.5
8958, 1.7217391304348, -0.125, 0.5
8959, 1.7434782608696, -0.15, 0.5
8960, 1.7652173913043, -0.125, 0.5
8961, 1.7869565217391, -0.15, 0.5
8962, 1.8086956521739, -0.125, 0.5
8963, 1.8304347826087, -0.15, 0.5
8964, 1.8521739130435, -0.125, 0.5
8965, 1.8739130434783, -0.15, 0.5
8966, 1.895652173913, -0.125, 0.5
8967, 1.9173913043478, -0.15, 0.5
8968, 1.9391304347826, -0.125, 0.5
8969, 1.9608695652174, -0.15, 0.5
8970, 1.9826086956522, -0.125, 0.5
8971, 2.004347826087, -0.15, 0.5
8972, 2.0260869565217, -0.125, 0.5
8973, 2.0478260869565, -0.15, 0.5
8974, 2.0695652173913, -0.125, 0.5
8975, 2.0913043478261, -0.15, 0.5
8976, 2.1130434782609, -0.125, 0.5
8977, 2.1347826086957, -0.15, 0.5
8978, 2.1565217391304, -0.125, 0.5
8979, 2.1782608695652, -0.15, 0.5
8980, 1.2217391304348, -0.2, 0.5
8981, 1.2434782608696, -0.175, 0.5
8982, 1.2652173913043, -0.2, 0.5
8983, 1.2869565217391, -0.175, 0.5
8984, 1.3086956521739, -0.2, 0.5
8985, 1.3304347826087, -0.175, 0.5
8986, 1.3521739130435, -0.2, 0.5
8987, 1.3739130434783, -0.175, 0.5
8988, 1.395652173913, -0.2, 0.5
8989, 1.4173913043478, -0.175, 0.5
8990, 1.4391304347826, -0.2, 0.5
8991, 1.4608695652174, -0.175, 0.5
8992, 1.4826086956522, -0.2, 0.5
8993, 1.504347826087, -0.175, 0.5
8994, 1.5260869565217, -0.2, 0.5
8995, 1.5478260869565, -0.175, 0.5
8996, 1.5695652173913, -0.2, 0.5
8997, 1.5913043478261, -0.175, 0.5
8998, 1.6130434782609, -0.2, 0.5
8999, 1.6347826086957, -0.175, 0.5
9000, 1.6565217391304, -0.2, 0.5
9001, 1.6782608695652, -0.175, 0.5
9002, 1.7, -0.2, 0.5
9003, 1.7217391304348, -0.175, 0.5
9004, 1.7434782608696, -0.2, 0.5
9005, 1.7652173913043, -0.175, 0.5
9006, 1.7869565217391, -0.2, 0.5
9007, 1.8086956521739, -0.175, 0.5
9008, 1.8304347826087, -0.2, 0.5
9009, 1.8521739130435, -0.175, 0.5
9010, 1.8739130434783, -0.2, 0.5
9011, 1.895652173913, -0.175, 0.5
9012, 1.9173913043478, -0.2, 0.5
9013, 1.9391304347826, -0.175, 0.5
9014, 1.9608695652174, -0.2, 0.5
9015, 1.9826086956522, -0.175, 0.5
9016, 2.004347826087, -0.2, 0.5
9017, 2.0260869565217, -0.175, 0.5
9018, 2.0478260869565, -0.2, 0.5
9019, 2.0695652173913, -0.175, 0.5
9020, 2.0913043478261, -0.2, 0.5
9021, 2.1130434782609, -0.175, 0.5
9022, 2.1347826086957, -0.2, 0.5
9023, 2.1565217391304, -0.175, 0.5
9024, 2.1782608695652, -0.2, 0.5
9025, 1.2434782608696, -0.225, 0.5
9026, 1.2869565217391, -0.225, 0.5
9027, 1.3304347826087, -0.225, 0.5
9028, 1.3739130434783, -0.225, 0.5
9029, 1.4173913043478, -0.225, 0.5
9030, 1.4608695652174, -0.225, 0.5
9031, 1.504347826087, -0.225, 0.5
9032, 1.5478260869565, -0.225, 0.5
9033, 1.5913043478261, -0.225, 0.5
9034, 1.6347826086957, -0.225, 0.5
9035, 1.6782608695652, -0.225, 0.5
9036, 1.7217391304348, -0.225, 0.5
9037, 1.7652173913043, -0.225, 0.5
9038, 1.8086956521739, -0.225, 0.5
9039, 1.8521739130435, -0.225, 0.5
9040, 1.895652173913, -0.225, 0.5
9041, 1.9391304347826, -0.225, 0.5
9042, 1.9826086956522, -0.225, 0.5
9043, 2.0260869565217, -0.225, 0.5
9044, 2.0695652173913, -0.225, 0.5
9045, 2.1130434782609, -0.225, 0.5
9046, 2.1565217391304, -0.225, 0.5
9047, 1.2434782608696, -0.1, 0
9048, 1.2869565217391, -0.1, 0
9049, 1.3304347826087, -0.1, 0
9050, 1.3739130434783, -0.1, 0
9051, 1.4173913043478, -0.1, 0
9052, 1.4608695652174, -0.1, 0
9053, 1.504347826087, -0.1, 0
9054, 1.5478260869565, -0.1, 0
9055, 1.5913043478261, -0.1, 0
9056, 1.6347826086957, -0.1, 0
9057, 1.6782608695652, -0.1, 0
9058, 1.7217391304348, -0.1, 0
9059, 1.7652173913043, -0.1, 0
9060, 1.8086956521739, -0.1, 0
9061, 1.8521739130435, -0.1, 0
9062, 1.895652173913, -0.1, 0
9063, 1.9391304347826, -0.1, 0
9064, 1.9826086956522, -0.1, 0
9065, 2.0260869565217, -0.1, 0
9066, 2.0695652173913, -0.1, 0
9067, 2.1130434782609, -0.1, 0
9068, 2.1565217391304, -0.1, 0
9069, 1.2434782608696, -0.15, 0
9070, 1.2869565217391, -0.15, 0
9071, 1.3304347826087, -0.15, 0
9072, 1.3739130434783, -0.15, 0
9073, 1.4173913043478, -0.15, 0
9074, 1.4608695652174, -0.15, 0
9075, 1.504347826087, -0.15, 0
9076, 1.5478260869565, -0.15, 0
9077, 1.5913043478261, -0.15, 0
9078, 1.6347826086957, -0.15, 0
9079, 1.6782608695652, -0.15, 0
9080, 1.7217391304348, -0.15, 0
9081, 1.7652173913043, -0.15, 0
9082, 1.8086956521739, -0.15, 0
9083, 1.8521739130435, -0.15, 0
9084, 1.895652173913, -0.15, 0
9085, 1.9391304347826, -0.15, 0
9086, 1.9826086956522, -0.15, 0
9087, 2.0260869565217, -0.15, 0
9088, 2.0695652173913, -0.15, 0
9089, 2.1130434782609, -0.15, 0
9090, 2.1565217391304, -0.15, 0
9091, 1.2434782608696, -0.2, 0
9092, 1.2869565217391, -0.2, 0
9093, 1.3304347826087, -0.2, 0
9094, 1.3739130434783, -0.2, 0
9095, 1.4173913043478, -0.2, 0
9096, 1.4608695652174, -0.2, 0
9097, 1.504347826087, -0.2, 0
9098, 1.5478260869565, -0.2, 0
9099, 1.5913043478261, -0.2, 0
9100, 1.6347826086957, -0.2, 0
9101, 1.6782608695652, -0.2, 0
9102, 1.7217391304348, -0.2, 0
9103, 1.7652173913043, -0.2, 0
9104, 1.8086956521739, -0.2, 0
9105, 1.8521739130435, -0.2, 0
9106, 1.895652173913, -0.2, 0
9107, 1.9391304347826, -0.2, 0
9108, 1.9826086956522, -0.2, 0
9109, 2.0260869565217, -0.2, 0
9110, 2.0695652173913, -0.2, 0
9111, 2.1130434782609, -0.2, 0
9112, 2.1565217391304, -0.2, 0
9113, 1.2434782608696, -0.075, 0
9114, 1.2217391304348, -0.1, 0
9115, 1.2869565217391, -0.075, 0
9116, 1.2652173913043, -0.1, 0
9117, 1.3304347826087, -0.075, 0
9118, 1.3086956521739, -0.1, 0
9119, 1.3739130434783, -0.075, 0
9120, 1.3521739130435, -0.1, 0
9121, 1.4173913043478, -0.075, 0
9122, 1.395652173913, -0.1, 0
9123, 1.4608695652174, -0.075, 0
9124, 1.4391304347826, -0.1, 0
9125, 1.504347826087, -0.075, 0
9126, 1.4826086956522, -0.1, 0
9127, 1.5478260869565, -0.075, 0
9128, 1.5260869565217, -0.1, 0
9129, 1.5913043478261, -0.075, 0
9130, 1.5695652173913, -0.1, 0
9131, 1.6347826086957, -0.075, 0
9132, 1.6130434782609, -0.1, 0
9133, 1.6782608695652, -0.075, 0
9134, 1.6565217391304, -0.1, 0
9135, 1.7217391304348, -0.075, 0
9136, 1.7, -0.1, 0
9137, 1.7652173913043, -0.075, 0
9138, 1.7434782608696, -0.1, 0
9139, 1.8086956521739, -0.075, 0
9140, 1.7869565217391, -0.1, 0
9141, 1.8521739130435, -0.075, 0
9142, 1.8304347826087, -0.1, 0
9143, 1.895652173913, -0.075, 0
9144, 1.8739130434783, -0.1, 0
9145, 1.9391304347826, -0.075, 0
9146, 1.9173913043478, -0.1, 0
9147, 1.9826086956522, -0.075, 0
9148, 1.9608695652174, -0.1, 0
9149, 2.0260869565217, -0.075, 0
9150, 2.004347826087, -0.1, 0
9151, 2.0695652173913, -0.075, 0
9152, 2.0478260869565, -0.1, 0
9153, 2.1130434782609, -0.075, 0
9154, 2.0913043478261, -0.1, 0
9155, 2.1565217391304, -0.075, 0
9156, 2.1347826086957, -0.1, 0
9157, 2.1782608695652, -0.1, 0
9158, 1.2434782608696, -0.125, 0
9159, 1.2217391304348, -0.15, 0
9160, 1.2869565217391, -0.125, 0
9161, 1.2652173913043, -0.15, 0
9162, 1.3304347826087, -0.125, 0
9163, 1.3086956521739, -0.15, 0
9164, 1.3739130434783, -0.125, 0
9165, 1.3521739130435, -0.15, 0
9166, 1.4173913043478, -0.125, 0
9167, 1.395652173913, -0.15, 0
9168, 1.4608695652174, -0.125, 0
9169, 1.4391304347826, -0.15, 0
9170, 1.504347826087, -0.125, 0
9171, 1.4826086956522, -0.15, 0
9172, 1.5478260869565, -0.125, 0
9173, 1.5260869565217, -0.15, 0
9174, 1.5913043478261, -0.125, 0
9175, 1.5695652173913, -0.15, 0
9176, 1.6347826086957, -0.125, 0
9177, 1.6130434782609, -0.15, 0
9178, 1.6782608695652, -0.125, 0
9179, 1.6565217391304, -0.15, 0
9180, 1.7217391304348, -0.125, 0
9181, 1.7, -0.15, 0
9182, 1.7652173913043, -0.125, 0
9183, 1.7434782608696, -0.15, 0
9184, 1.8086956521739, -0.125, 0
9185, 1.7869565217391, -0.15, 0
9186, 1.8521739130435, -0.125, 0
9187, 1.8304347826087, -0.15, 0
9188, 1.895652173913, -0.125, 0
9189, 1.8739130434783, -0.15, 0
9190, 1.9391304347826, -0.125, 0
9191, 1.9173913043478, -0.15, 0
9192, 1.9826086956522, -0.125, 0
9193, 1.9608695652174, -0.15, 0
9194, 2.0260869565217, -0.125, 0
9195, 2.004347826087, -0.15, 0
9196, 2.0695652173913, -0.125, 0
9197, 2.0478260869565, -0.15, 0
9198, 2.1130434782609, -0.125, 0
9199, 2.0913043478261, -0.15, 0
9200, 2.1565217391304, -0.125, 0
9201, 2.1347826086957, -0.15, 0
9202, 2.1782608695652, -0.15, 0
9203, 1.2434782608696, -0.175, 0
9204, 1.2217391304348, -0.2, 0
9205, 1.2869565217391, -0.175, 0
9206, 1.2652173913043, -0.2, 0
9207, 1.3304347826087, -0.175, 0
9208, 1.3086956521739, -0.2, 0
9209, 1.3739130434783, -0.175, 0
9210, 1.3521739130435, -0.2, 0
9211, 1.4173913043478, -0.175, 0
9212, 1.395652173913, -0.2, 0
9213, 1.4608695652174, -0.175, 0
9214, 1.4391304347826, -0.2, 0
9215, 1.504347826087, -0.175, 0
9216, 1.4826086956522, -0.2, 0
9217, 1.5478260869565, -0.175, 0
9218, 1.5260869565217, -0.2, 0
9219, 1.5913043478261, -0.175, 0
9220, 1.5695652173913, -0.2, 0
9221, 1.6347826086957, -0.175, 0
9222, 1.6130434782609, -0.2, 0
9223, 1.6782608695652, -0.175, 0
9224, 1.6565217391304, -0.2, 0
9225, 1.7217391304348, -0.175, 0
9226, 1.7, -0.2, 0
9227, 1.7652173913043, -0.175, 0
9228, 1.7434782608696, -0.2, 0
9229, 1.8086956521739, -0.175, 0
9230, 1.7869565217391, -0.2, 0
9231, 1.8521739130435, -0.175, 0
9232, 1.8304347826087, -0.2, 0
9233, 1.895652173913, -0.175, 0
9234, 1.8739130434783, -0.2, 0
9235, 1.9391304347826, -0.175, 0
9236, 1.9173913043478, -0.2, 0
9237, 1.9826086956522, -0.175, 0
9238, 1.9608695652174, -0.2, 0
9239, 2.0260869565217, -0.175, 0
9240, 2.004347826087, -0.2, 0
9241, 2.0695652173913, -0.175, 0
9242, 2.0478260869565, -0.2, 0
9243, 2.1130434782609, -0.175, 0
9244, 2.0913043478261, -0.2, 0
9245, 2.1565217391304, -0.175, 0
9246, 2.1347826086957, -0.2, 0
9247, 2.1782608695652, -0.2, 0
9248, 1.2434782608696, -0.225, 0
9249, 1.2869565217391, -0.225, 0
9250, 1.3304347826087, -0.225, 0
9251, 1.3739130434783, -0.225, 0
9252, 1.4173913043478, -0.225, 0
9253, 1.4608695652174, -0.225, 0
9254, 1.504347826087, -0.225, 0
9255, 1.5478260869565, -0.225, 0
9256, 1.5913043478261, -0.225, 0
9257, 1.6347826086957, -0.225, 0
9258, 1.6782608695652, -0.225, 0
9259, 1.7217391304348, -0.225, 0
9260, 1.7652173913043, -0.225, 0
9261, 1.8086956521739, -0.225, 0
9262, 1.8521739130435, -0.225, 0
9263, 1.895652173913, -0.225, 0
9264, 1.9391304347826, -0.225, 0
9265, 1.9826086956522, -0.225, 0
9266, 2.0260869565217, -0.225, 0
9267, 2.0695652173913, -0.225, 0
9268, 2.1130434782609, -0.225, 0
9269, 2.1565217391304, -0.225, 0
9270, 2.2, -0.1, 0.44444444444444
9271, 2.2, -0.1, 0.38888888888889
9272, 2.2, -0.1, 0.33333333333333
9273, 2.2, -0.1, 0.27777777777778
9274, 2.2, -0.1, 0.22222222222222
9275, 2.2, -0.1, 0.16666666666667
9276, 2.2, -0.1, 0.11111111111111
9277, 2.2, -0.1, 0.055555555555556
9278, 2.2, -0.15, 0.44444444444444
9279, 2.2, -0.15, 0.38888888888889
9280, 2.2, -0.15, 0.33333333333333
9281, 2.2, -0.15, 0.27777777777778
9282, 2.2, -0.15, 0.22222222222222
9283, 2.2, -0.15, 0.16666666666667
9284, 2.2, -0.15, 0.11111111111111
9285, 2.2, -0.15, 0.055555555555556
9286, 2.2, -0.2, 0.44444444444444
9287, 2.2, -0.2, 0.38888888888889
9288, 2.2, -0.2, 0.33333333333333
9289, 2.2, -0.2, 0.27777777777778
9290, 2.2, -0.2, 0.22222222222222
9291, 2.2, -0.2, 0.16666666666667
9292, 2.2, -0.2, 0.11111111111111
9293, 2.2, -0.2, 0.055555555555556
9294, 2.2, -0.1, 0.47222222222222
9295, 2.2, -0.075, 0.44444444444444
9296, 2.2, -0.1, 0.41666666666667
9297, 2.2, -0.075, 0.38888888888889
9298, 2.2, -0.1, 0.36111111111111
9299, 2.2, -0.075, 0.33333333333333
9300, 2.2, -0.1, 0.30555555555556
9301, 2.2, -0.075, 0.27777777777778
9302, 2.2, -0.1, 0.25
9303, 2.2, -0.075, 0.22222222222222
9304, 2.2, -0.1, 0.19444444444444
9305, 2.2, -0.075, 0.16666666666667
9306, 2.2, -0.1, 0.13888888888889
9307, 2.2, -0.075, 0.11111111111111
9308, 2.2, -0.1, 0.083333333333333
9309, 2.2, -0.075, 0.055555555555556
9310, 2.2, -0.1, 0.027777777777778
9311, 2.2, -0.15, 0.47222222222222
9312, 2.2, -0.125, 0.44444444444444
9313, 2.2, -0.15, 0.41666666666667
9314, 2.2, -0.125, 0.38888888888889
9315, 2.2, -0.15, 0.36111111111111
9316, 2.2, -0.125, 0.33333333333333
9317, 2.2, -0.15, 0.30555555555556
9318, 2.2, -0.125, 0.27777777777778
9319, 2.2, -0.15, 0.25
9320, 2.2, -0.125, 0.22222222222222
9321, 2.2, -0.15, 0.19444444444444
9322, 2.2, -0.125, 0.16666666666667
9323, 2.2, -0.15, 0.13888888888889
9324, 2.2, -0.125, 0.11111111111111
9325, 2.2, -0.15, 0.083333333333333
9326, 2.2, -0.125, 0.055555555555556
9327, 2.2, -0.15, 0.027777777777778
9328, 2.2, -0.2, 0.47222222222222
9329, 2.2, -0.175, 0.44444444444444
9330, 2.2, -0.2, 0.41666666666667
9331, 2.2, -0.175, 0.38888888888889
9332, 2.2, -0.2, 0.36111111111111
9333, 2.2, -0.175, 0.33333333333333
9334, 2.2, -0.2, 0.30555555555556
9335, 2.2, -0.175, 0.27777777777778
9336, 2.2, -0.2, 0.25
9337, 2.2, -0.175, 0.22222222222222
9338, 2.2, -0.2, 0.19444444444444
9339, 2.2, -0.175, 0.16666666666667
9340, 2.2, -0.2, 0.13888888888889
9341, 2.2, -0.175, 0.11111111111111
9342, 2.2, -0.2, 0.083333333333333
9343, 2.2, -0.175, 0.055555555555556
9344, 2.2, -0.2, 0.027777777777778
9345, 2.2, -0.225, 0.44444444444444
9346, 2.2, -0.225, 0.38888888888889
9347, 2.2, -0.225, 0.33333333333333
9348, 2.2, -0.225, 0.27777777777778
9349, 2.2, -0.225, 0.22222222222222
9350, 2.2, -0.225, 0.16666666666667
9351, 2.2, -0.225, 0.11111111111111
9352, 2.2, -0.225, 0.055555555555556
9353, 1.2434782608696, -0.05, 0.44444444444444
9354, 1.2434782608696, -0.05, 0.38888888888889
9355, 1.2434782608696, -0.05, 0.33333333333333
9356, 1.2434782608696, -0.05, 0.27777777777778
9357, 1.2434782608696, -0.05, 0.22222222222222
9358, 1.2434782608696, -0.05, 0.16666666666667
9359, 1.2434782608696, -0.05, 0.11111111111111
9360, 1.2434782608696, -0.05, 0.055555555555556
9361, 1.2869565217391, -0.05, 0.44444444444444
9362, 1.2869565217391, -0.05, 0.38888888888889
9363, 1.2869565217391, -0.05, 0.33333333333333
9364, 1.2869565217391, -0.05, 0.27777777777778
9365, 1.2869565217391, -0.05, 0.22222222222222
9366, 1.2869565217391, -0.05, 0.16666666666667
9367, 1.2869565217391, -0.05, 0.11111111111111
9368, 1.2869565217391, -0.05, 0.055555555555556
9369, 1.3304347826087, -0.05, 0.44444444444444
9370, 1.3304347826087, -0.05, 0.38888888888889
9371, 1.3304347826087, -0.05, 0.33333333333333
9372, 1.3304347826087, -0.05, 0.27777777777778
9373, 1.3304347826087, -0.05, 0.22222222222222
9374, 1.3304347826087, -0.05, 0.16666666666667
9375, 1.3304347826087, -0.05, 0.11111111111111
9376, 1.3304347826087, -0.05, 0.055555555555556
9377, 1.3739130434783, -0.05, 0.44444444444444
9378, 1.3739130434783, -0.05, 0.38888888888889
9379, 1.3739130434783, -0.05, 0.33333333333333
9380, 1.3739130434783, -0.05, 0.27777777777778
9381, 1.3739130434783, -0.05, 0.22222222222222
9382, 1.3739130434783, -0.05, 0.16666666666667
9383, 1.3739130434783, -0.05, 0.11111111111111
9384, 1.3739130434783, -0.05, 0.055555555555556
9385, 1.4173913043478, -0.05, 0.44444444444444
9386, 1.4173913043478, -0.05, 0.38888888888889
9387, 1.4173913043478, -0.05, 0.33333333333333
9388, 1.4173913043478, -0.05, 0.27777777777778
9389, 1.4173913043478, -0.05, 0.22222222222222
9390, 1.4173913043478, -0.05, 0.16666666666667
9391, 1.4173913043478, -0.05, 0.11111111111111
9392, 1.4173913043478, -0.05, 0.055555555555556
9393, 1.4608695652174, -0.05, 0.44444444444444
9394, 1.4608695652174, -0.05, 0.38888888888889
9395, 1.4608695652174, -0.05, 0.33333333333333
9396, 1.4608695652174, -0.05, 0.27777777777778
9397, 1.4608695652174, -0.05, 0.22222222222222
9398, 1.4608695652174, -0.05, 0.16666666666667
9399, 1.4608695652174, -0.05, 0.11111111111111
9400, 1.4608695652174, -0.05, 0.055555555555556
9401, 1.504347826087, -0.05, 0.44444444444444
9402, 1.504347826087, -0.05, 0.38888888888889
9403, 1.504347826087, -0.05, 0.33333333333333
9404, 1.504347826087, -0.05, 0.27777777777778
9405, 1.504347826087, -0.05, 0.22222222222222
9406, 1.504347826087, -0.05, 0.16666666666667
9407, 1.504347826087, -0.05, 0.11111111111111
9408, 1.504347826087, -0.05, 0.055555555555556
9409, 1.5478260869565, -0.05, 0.44444444444444
9410, 1.5478260869565, -0.05, 0.38888888888889
9411, 1.5478260869565, -0.05, 0.33333333333333
9412, 1.5478260869565, -0.05, 0.27777777777778
9413, 1.5478260869565, -0.05, 0.22222222222222
9414, 1.5478260869565, -0.05, 0.16666666666667
9415, 1.5478260869565, -0.05, 0.11111111111111
9416, 1.5478260869565, -0.05, 0.055555555555556
9417, 1.5913043478261, -0.05, 0.44444444444444
9418, 1.5913043478261, -0.05, 0.38888888888889
9419, 1.5913043478261, -0.05, 0.33333333333333
9420, 1.5913043478261, -0.05, 0.27777777777778
9421, 1.5913043478261, -0.05, 0.22222222222222
9422, 1.5913043478261, -0.05, 0.16666666666667
9423, 1.5913043478261, -0.05, 0.11111111111111
9424, 1.5913043478261, -0.05, 0.055555555555556
9425, 1.6347826086957, -0.05, 0.44444444444444
9426, 1.6347826086957, -0.05, 0.38888888888889
9427, 1.6347826086957, -0.05, 0.33333333333333
9428, 1.6347826086957, -0.05, 0.27777777777778
9429, 1.6347826086957, -0.05, 0.22222222222222
9430, 1.6347826086957, -0.05, 0.16666666666667
9431, 1.6347826086957, -0.05, 0.11111111111111
9432, 1.6347826086957, -0.05, 0.055555555555556
9433, 1.6782608695652, -0.05, 0.44444444444444
9434, 1.6782608695652, -0.05, 0.38888888888889
9435, 1.6782608695652, -0.05, 0.33333333333333
9436, 1.6782608695652, -0.05, 0.27777777777778
9437, 1.6782608695652, -0.05, 0.22222222222222
9438, 1.6782608695652, -0.05, 0.16666666666667
9439, 1.6782608695652, -0.05, 0.11111111111111
9440, 1.6782608695652, -0.05, 0.055555555555556
9441, 1.7217391304348, -0.05, 0.44444444444444
9442, 1.7217391304348, -0.05, 0.38888888888889
9443, 1.7217391304348, -0.05, 0.33333333333333
9444, 1.7217391304348, -0.05, 0.27777777777778
9445, 1.7217391304348, -0.05, 0.22222222222222
9446, 1.7217391304348, -0.05, 0.16666666666667
9447, 1.7217391304348, -0.05, 0.11111111111111
9448, 1.7217391304348, -0.05, 0.055555555555556
9449, 1.7652173913043, -0.05, 0.44444444444444
9450, 1.7652173913043, -0.05, 0.38888888888889
9451, 1.7652173913043, -0.05, 0.33333333333333
9452, 1.7652173913043, -0.05, 0.27777777777778
9453, 1.7652173913043, -0.05, 0.22222222222222
9454, 1.7652173913043, -0.05, 0.16666666666667
9455, 1.7652173913043, -0.05, 0.11111111111111
9456, 1.7652173913043, -0.05, 0.055555555555556
9457, 1.8086956521739, -0.05, 0.44444444444444
9458, 1.8086956521739, -0.05, 0.38888888888889
9459, 1.8086956521739, -0.05, 0.33333333333333
9460, 1.8086956521739, -0.05, 0.27777777777778
9461, 1.8086956521739, -0.05, 0.22222222222222
9462, 1.8086956521739, -0.05, 0.16666666666667
9463, 1.8086956521739, -0.05, 0.11111111111111
9464, 1.8086956521739, -0.05, 0.055555555555556
9465, 1.8521739130435, -0.05, 0.44444444444444
9466, 1.8521739130435, -0.05, 0.38888888888889
9467, 1.8521739130435, -0.05, 0.33333333333333
9468, 1.8521739130435, -0.05, 0.27777777777778
9469, 1.8521739130435, -0.05, 0.22222222222222
9470, 1.8521739130435, -0.05, 0.16666666666667
9471, 1.8521739130435, -0.05, 0.11111111111111
9472, 1.8521739130435, -0.05, 0.055555555555556
9473, 1.895652173913, -0.05, 0.44444444444444
9474, 1.895652173913, -0.05, 0.38888888888889
9475, 1.895652173913, -0.05, 0.33333333333333
9476, 1.895652173913, -0.05, 0.27777777777778
9477, 1.895652173913, -0.05, 0.22222222222222
9478, 1.895652173913, -0.05, 0.16666666666667
9479, 1.895652173913, -0.05, 0.11111111111111
9480, 1.895652173913, -0.05, 0.055555555555556
9481, 1.9391304347826, -0.05, 0.44444444444444
9482, 1.9391304347826, -0.05, 0.38888888888889
9483, 1.9391304347826, -0.05, 0.33333333333333
9484, 1.9391304347826, -0.05, 0.27777777777778
9485, 1.9391304347826, -0.05, 0.22222222222222
9486, 1.9391304347826, -0.05, 0.16666666666667
9487, 1.9391304347826, -0.05, 0.11111111111111
9488, 1.9391304347826, -0.05, 0.055555555555556
9489, 1.9826086956522, -0.05, 0.44444444444444
9490, 1.9826086956522, -0.05, 0.38888888888889
9491, 1.9826086956522, -0.05, 0.33333333333333
9492, 1.9826086956522, -0.05, 0.27777777777778
9493, 1.9826086956522, -0.05, 0.22222222222222
9494, 1.9826086956522, -0.05, 0.16666666666667
9495, 1.9826086956522, -0.05, 0.11111111111111
9496, 1.9826086956522, -0.05, 0.055555555555556
9497, 2.0260869565217, -0.05, 0.44444444444444
9498, 2.0260869565217, -0.05, 0.38888888888889
9499, 2.0260869565217, -0.05, 0.33333333333333
9500, 2.0260869565217, -0.05, 0.27777777777778
9501, 2.0260869565217, -0.05, 0.22222222222222
9502, 2.0260869565217, -0.05, 0.16666666666667
9503, 2.0260869565217, -0.05, 0.11111111111111
9504, 2.0260869565217, -0.05, 0.055555555555556
9505, 2.0695652173913, -0.05, 0.44444444444444
9506, 2.0695652173913, -0.05, 0.38888888888889
9507, 2.0695652173913, -0.05, 0.33333333333333
9508, 2.0695652173913, -0.05, 0.27777777777778
9509, 2.0695652173913, -0.05, 0.22222222222222
9510, 2.0695652173913, -0.05, 0.16666666666667
9511, 2.0695652173913, -0.05, 0.11111111111111
9512, 2.0695652173913, -0.05, 0.055555555555556
9513, 2.1130434782609, -0.05, 0.44444444444444
9514, 2.1130434782609, -0.05, 0.38888888888889
9515, 2.1130434782609, -0.05, 0.33333333333333
9516, 2.1130434782609, -0.05, 0.27777777777778
9517, 2.1130434782609, -0.05, 0.22222222222222
9518, 2.1130434782609, -0.05, 0.16666666666667
9519, 2.1130434782609, -0.05, 0.11111111111111
9520, 2.1130434782609, -0.05, 0.055555555555556
9521, 2.1565217391304, -0.05, 0.44444444444444
9522, 2.1565217391304, -0.05, 0.38888888888889
9523, 2.1565217391304, -0.05, 0.33333333333333
9524, 2.1565217391304, -0.05, 0.27777777777778
9525, 2.1565217391304, -0.05, 0.22222222222222
9526, 2.1565217391304, -0.05, 0.16666666666667
9527, 2.1565217391304, -0.05, 0.11111111111111
9528, 2.1565217391304, -0.05, 0.055555555555556
9529, 1.2434782608696, -0.05, 0.47222222222222
9530, 1.2217391304348, -0.05, 0.44444444444444
9531, 1.2434782608696, -0.05, 0.41666666666667
9532, 1.2217391304348, -0.05, 0.38888888888889
9533, 1.2434782608696, -0.05, 0.36111111111111
9534, 1.2217391304348, -0.05, 0.33333333333333
9535, 1.2434782608696, -0.05, 0.30555555555556
9536, 1.2217391304348, -0.05, 0.27777777777778
9537, 1.2434782608696, -0.05, 0.25
9538, 1.2217391304348, -0.05, 0.22222222222222
9539, 1.2434782608696, -0.05, 0.19444444444444
9540, 1.2217391304348, -0.05, 0.16666666666667
9541, 1.2434782608696, -0.05, 0.13888888888889
9542, 1.2217391304348, -0.05, 0.11111111111111
9543, 1.2434782608696, -0.05, 0.083333333333333
9544, 1.2217391304348, -0.05, 0.055555555555556
9545, 1.2434782608696, -0.05, 0.027777777777778
9546, 1.2869565217391, -0.05, 0.47222222222222
9547, 1.2652173913043, -0.05, 0.44444444444444
9548, 1.2869565217391, -0.05, 0.41666666666667
9549, 1.2652173913043, -0.05, 0.38888888888889
9550, 1.2869565217391, -0.05, 0.36111111111111
9551, 1.2652173913043, -0.05, 0.33333333333333
9552, 1.2869565217391, -0.05, 0.30555555555556
9553, 1.2652173913043, -0.05, 0.27777777777778
9554, 1.2869565217391, -0.05, 0.25
9555, 1.2652173913043, -0.05, 0.22222222222222
9556, 1.2869565217391, -0.05, 0.19444444444444
9557, 1.2652173913043, -0.05, 0.16666666666667
9558, 1.2869565217391, -0.05, 0.13888888888889
9559, 1.2652173913043, -0.05, 0.11111111111111
9560, 1.2869565217391, -0.05, 0.083333333333333
9561, 1.2652173913043, -0.05, 0.055555555555556
9562, 1.2869565217391, -0.05, 0.027777777777778
9563, 1.3304347826087, -0.05, 0.47222222222222
9564, 1.3086956521739, -0.05, 0.44444444444444
9565, 1.3304347826087, -0.05, 0.41666666666667
9566, 1.3086956521739, -0.05, 0.38888888888889
9567, 1.3304347826087, -0.05, 0.36111111111111
9568, 1.3086956521739, -0.05, 0.33333333333333
9569, 1.3304347826087, -0.05, 0.30555555555556
9570, 1.3086956521739, -0.05, 0.27777777777778
9571, 1.3304347826087, -0.05, 0.25
9572, 1.3086956521739, -0.05, 0.22222222222222
9573, 1.3304347826087, -0.05, 0.19444444444444
9574, 1.3086956521739, -0.05, 0.16666666666667
9575, 1.3304347826087, -0.05, 0.13888888888889
9576, 1.3086956521739, -0.05, 0.11111111111111
9577, 1.3304347826087, -0.05, 0.083333333333333
9578, 1.3086956521739, -0.05, 0.055555555555556
9579, 1.3304347826087, -0.05, 0.027777777777778
9580, 1.3739130434783, -0.05, 0.47222222222222
9581, 1.3521739130435, -0.05, 0.44444444444444
9582, 1.3739130434783, -0.05, 0.41666666666667
9583, 1.3521739130435, -0.05, 0.38888888888889
9584, 1.3739130434783, -0.05, 0.36111111111111
9585, 1.3521739130435, -0.05, 0.33333333333333
9586, 1.3739130434783, -0.05, 0.30555555555556
9587, 1.3521739130435, -0.05, 0.27777777777778
9588, 1.3739130434783, -0.05, 0.25
9589, 1.3521739130435, -0.05, 0.22222222222222
9590, 1.3739130434783, -0.05, 0.19444444444444
9591, 1.3521739130435, -0.05, 0.16666666666667
9592, 1.3739130434783, -0.05, 0.13888888888889
9593, 1.3521739130435, -0.05, 0.11111111111111
9594, 1.3739130434783, -0.05, 0.083333333333333
9595, 1.3521739130435, -0.05, 0.055555555555556
9596, 1.3739130434783, -0.05, 0.027777777777778
9597, 1.4173913043478, -0.05, 0.47222222222222
9598, 1.395652173913, -0.05, 0.44444444444444
9599, 1.4173913043478, -0.05, 0.41666666666667
9600, 1.395652173913, -0.05, 0.38888888888889
9601, 1.4173913043478, -0.05, 0.36111111111111
9602, 1.395652173913, -0.05, 0.33333333333333
9603, 1.4173913043478, -0.05, 0.30555555555556
9604, 1.395652173913, -0.05, 0.27777777777778
9605, 1.4173913043478, -0.05, 0.25
9606, 1.395652173913, -0.05, 0.22222222222222
9607, 1.4173913043478, -0.05, 0.19444444444444
9608, 1.395652173913, -0.05, 0.16666666666667
9609, 1.4173913043478, -0.05, 0.13888888888889
9610, 1.395652173913, -0.05, 0.11111111111111
9611, 1.4173913043478, -0.05, 0.083333333333333
9612, 1.395652173913, -0.05, 0.055555555555556
9613, 1.4173913043478, -0.05, 0.027777777777778
9614, 1.4608695652174, -0.05, 0.47222222222222
9615, 1.4391304347826, -0.05, 0.44444444444444
9616, 1.4608695652174, -0.05, 0.41666666666667
9617, 1.4391304347826, -0.05, 0.38888888888889
9618, 1.4608695652174, -0.05, 0.36111111111111
9619, 1.4391304347826, -0.05, 0.33333333333333
9620, 1.4608695652174, -0.05, 0.30555555555556
9621, 1.4391304347826, -0.05, 0.27777777777778
9622, 1.4608695652174, -0.05, 0.25
9623, 1.4391304347826, -0.05, 0.22222222222222
9624, 1.4608695652174, -0.05, 0.19444444444444
9625, 1.4391304347826, -0.05, 0.16666666666667
9626, 1.4608695652174, -0.05, 0.13888888888889
9627, 1.4391304347826, -0.05, 0.11111111111111
9628, 1.4608695652174, -0.05, 0.083333333333333
9629, 1.4391304347826, -0.05, 0.055555555555556
9630, 1.4608695652174, -0.05, 0.027777777777778
9631, 1.504347826087, -0.05, 0.47222222222222
9632, 1.4826086956522, -0.05, 0.44444444444444
9633, 1.504347826087, -0.05, 0.41666666666667
9634, 1.4826086956522, -0.05, 0.38888888888889
9635, 1.504347826087, -0.05, 0.36111111111111
9636, 1.4826086956522, -0.05, 0.33333333333333
9637, 1.504347826087, -0.05, 0.30555555555556
9638, 1.4826086956522, -0.05, 0.27777777777778
9639, 1.504347826087, -0.05, 0.25
9640, 1.4826086956522, -0.05, 0.22222222222222
9641, 1.504347826087, -0.05, 0.19444444444444
9642, 1.4826086956522, -0.05, 0.16666666666667
9643, 1.504347826087, -0.05, 0.13888888888889
9644, 1.4826086956522, -0.05, 0.11111111111111
9645, 1.504347826087, -0.05, 0.083333333333333
9646, 1.4826086956522, -0.05, 0.055555555555556
9647, 1.504347826087, -0.05, 0.027777777777778
9648, 1.5478260869565, -0.05, 0.47222222222222
9649, 1.5260869565217, -0.05, 0.44444444444444
9650, 1.5478260869565, -0.05, 0.41666666666667
9651, 1.5260869565217, -0.05, 0.38888888888889
9652, 1.5478260869565, -0.05, 0.36111111111111
9653, 1.5260869565217, -0.05, 0.33333333333333
9654, 1.5478260869565, -0.05, 0.30555555555556
9655, 1.5260869565217, -0.05, 0.27777777777778
9656, 1.5478260869565, -0.05, 0.25
9657, 1.5260869565217, -0.05, 0.22222222222222
9658, 1.5478260869565, -0.05, 0.19444444444444
9659, 1.5260869565217, -0.05, 0.16666666666667
9660, 1.5478260869565, -0.05, 0.13888888888889
9661, 1.5260869565217, -0.05, 0.11111111111111
9662, 1.5478260869565, -0.05, 0.083333333333333
9663, 1.5260869565217, -0.05, 0.055555555555556
9664, 1.5478260869565, -0.05, 0.027777777777778
9665, 1.5913043478261, -0.05, 0.47222222222222
9666, 1.5695652173913, -0.05, 0.44444444444444
9667, 1.5913043478261, -0.05, 0.41666666666667
9668, 1.5695652173913, -0.05, 0.38888888888889
9669, 1.5913043478261, -0.05, 0.36111111111111
9670, 1.5695652173913, -0.05, 0.33333333333333
9671, 1.5913043478261, -0.05, 0.30555555555556
9672, 1.5695652173913, -0.05, 0.27777777777778
9673, 1.5913043478261, -0.05, 0.25
9674, 1.5695652173913, -0.05, 0.22222222222222
9675, 1.5913043478261, -0.05, 0.19444444444444
9676, 1.5695652173913, -0.05, 0.16666666666667
9677, 1.5913043478261, -0.05, 0.13888888888889
9678, 1.5695652173913, -0.05, 0.11111111111111
9679, 1.5913043478261, -0.05, 0.083333333333333
9680, 1.5695652173913, -0.05, 0.055555555555556
9681, 1.5913043478261, -0.05, 0.027777777777778
9682, 1.6347826086957, -0.05, 0.47222222222222
9683, 1.6130434782609, -0.05, 0.44444444444444
9684, 1.6347826086957, -0.05, 0.41666666666667
9685, 1.6130434782609, -0.05, 0.38888888888889
9686, 1.6347826086957, -0.05, 0.36111111111111
9687, 1.6130434782609, -0.05, 0.33333333333333
9688, 1.6347826086957, -0.05, 0.30555555555556
9689, 1.6130434782609, -0.05, 0.27777777777778
9690, 1.6347826086957, -0.05, 0.25
9691, 1.6130434782609, -0.05, 0.22222222222222
9692, 1.6347826086957, -0.05, 0.19444444444444
9693, 1.6130434782609, -0.05, 0.16666666666667
9694, 1.6347826086957, -0.05, 0.13888888888889
9695, 1.6130434782609, -0.05, 0.11111111111111
9696, 1.6347826086957, -0.05, 0.083333333333333
9697, 1.6130434782609, -0.05, 0.055555555555556
9698, 1.6347826086957, -0.05, 0.027777777777778
9699, 1.6782608695652, -0.05, 0.47222222222222
9700, 1.6565217391304, -0.05, 0.44444444444444
9701, 1.6782608695652, -0.05, 0.41666666666667
9702, 1.6565217391304, -0.05, 0.38888888888889
9703, 1.6782608695652, -0.05, 0.36111111111111
9704, 1.6565217391304, -0.05, 0.33333333333333
9705, 1.6782608695652, -0.05, 0.30555555555556
9706, 1.6565217391304, -0.05, 0.27777777777778
9707, 1.6782608695652, -0.05, 0.25
9708, 1.6565217391304, -0.05, 0.22222222222222
9709, 1.6782608695652, -0.05, 0.19444444444444
9710, 1.6565217391304, -0.05, 0.16666666666667
9711, 1.6782608695652, -0.05, 0.13888888888889
9712, 1.6565217391304, -0.05, 0.11111111111111
9713, 1.6782608695652, -0.05, 0.083333333333333
9714, 1.6565217391304, -0.05, 0.055555555555556
9715, 1.6782608695652, -0.05, 0.027777777777778
9716, 1.7217391304348, -0.05, 0.47222222222222
9717, 1.7, -0.05, 0.44444444444444
9718, 1.7217391304348, -0.05, 0.41666666666667
9719, 1.7, -0.05, 0.38888888888889
9720, 1.7217391304348, -0.05, 0.36111111111111
9721, 1.7, -0.05, 0.33333333333333
9722, 1.7217391304348, -0.05, 0.30555555555556
9723, 1.7, -0.05, 0.27777777777778
9724, 1.7217391304348, -0.05, 0.25
9725, 1.7, -0.05, 0.22222222222222
9726, 1.7217391304348, -0.05, 0.19444444444444
9727, 1.7, -0.05, 0.16666666666667
9728, 1.7217391304348, -0.05, 0.13888888888889
9729, 1.7, -0.05, 0.11111111111111
9730, 1.7217391304348, -0.05, 0.083333333333333
9731, 1.7, -0.05, 0.055555555555556
9732, 1.7217391304348, -0.05, 0.027777777777778
9733, 1.7652173913043, -0.05, 0.47222222222222
9734, 1.7434782608696, -0.05, 0.44444444444444
9735, 1.7652173913043, -0.05, 0.41666666666667
9736, 1.7434782608696, -0.05, 0.38888888888889
9737, 1.7652173913043, -0.05, 0.36111111111111
9738, 1.7434782608696, -0.05, 0.33333333333333
9739, 1.7652173913043, -0.05, 0.30555555555556
9740, 1.7434782608696, -0.05, 0.27777777777778
9741, 1.7652173913043, -0.05, 0.25
9742, 1.7434782608696, -0.05, 0.22222222222222
9743, 1.7652173913043, -0.05, 0.19444444444444
9744, 1.7434782608696, -0.05, 0.16666666666667
9745, 1.7652173913043, -0.05, 0.13888888888889
9746, 1.7434782608696, -0.05, 0.11111111111111
9747, 1.7652173913043, -0.05, 0.083333333333333
9748, 1.7434782608696, -0.05, 0.055555555555556
9749, 1.7652173913043, -0.05, 0.027777777777778
9750, 1.8086956521739, -0.05, 0.47222222222222
9751, 1.7869565217391, -0.05, 0.44444444444444
9752, 1.8086956521739, -0.05, 0.41666666666667
9753, 1.7869565217391, -0.05, 0.38888888888889
9754, 1.8086956521739, -0.05, 0.36111111111111
9755, 1.7869565217391, -0.05, 0.33333333333333
9756, 1.8086956521739, -0.05, 0.30555555555556
9757, 1.7869565217391, -0.05, 0.27777777777778
9758, 1.8086956521739, -0.05, 0.25
9759, 1.7869565217391, -0.05, 0.22222222222222
9760, 1.8086956521739, -0.05, 0.19444444444444
9761, 1.7869565217391, -0.05, 0.16666666666667
9762, 1.8086956521739, -0.05, 0.13888888888889
9763, 1.7869565217391, -0.05, 0.11111111111111
9764, 1.8086956521739, -0.05, 0.083333333333333
9765, 1.7869565217391, -0.05, 0.055555555555556
9766, 1.8086956521739, -0.05, 0.027777777777778
9767, 1.8521739130435, -0.05, 0.47222222222222
9768, 1.8304347826087, -0.05, 0.44444444444444
9769, 1.8521739130435, -0.05, 0.41666666666667
9770, 1.8304347826087, -0.05, 0.38888888888889
9771, 1.8521739130435, -0.05, 0.36111111111111
9772, 1.8304347826087, -0.05, 0.33333333333333
9773, 1.8521739130435, -0.05, 0.30555555555556
9774, 1.8304347826087, -0.05, 0.27777777777778
9775, 1.8521739130435, -0.05, 0.25
9776, 1.8304347826087, -0.05, 0.22222222222222
9777, 1.8521739130435, -0.05, 0.19444444444444
9778, 1.8304347826087, -0.05, 0.16666666666667
9779, 1.8521739130435, -0.05, 0.13888888888889
9780, 1.8304347826087, -0.05, 0.11111111111111
9781, 1.8521739130435, -0.05, 0.083333333333333
9782, 1.8304347826087, -0.05, 0.055555555555556
9783, 1.8521739130435, -0.05, 0.027777777777778
9784, 1.895652173913, -0.05, 0.47222222222222
9785, 1.8739130434783, -0.05, 0.44444444444444
9786, 1.895652173913, -0.05, 0.41666666666667
9787, 1.8739130434783, -0.05, 0.38888888888889
9788, 1.895652173913, -0.05, 0.36111111111111
9789, 1.8739130434783, -0.05, 0.33333333333333
9790, 1.895652173913, -0.05, 0.30555555555556
9791, 1.8739130434783, -0.05, 0.27777777777778
9792, 1.895652173913, -0.05, 0.25
9793, 1.8739130434783, -0.05, 0.22222222222222
9794, 1.895652173913, -0.05, 0.19444444444444
9795, 1.8739130434783, -0.05, 0.16666666666667
9796, 1.895652173913, -0.05, 0.13888888888889
9797, 1.8739130434783, -0.05, 0.11111111111111
9798, 1.895652173913, -0.05, 0.083333333333333
9799, 1.8739130434783, -0.05, 0.055555555555556
9800, 1.895652173913, -0.05, 0.027777777777778
9801, 1.9391304347826, -0.05, 0.47222222222222
9802, 1.9173913043478, -0.05, 0.44444444444444
9803, 1.9391304347826, -0.05, 0.41666666666667
9804, 1.9173913043478, -0.05, 0.38888888888889
9805, 1.9391304347826, -0.05, 0.36111111111111
9806, 1.9173913043478, -0.05, 0.33333333333333
9807, 1.9391304347826, -0.05, 0.30555555555556
9808, 1.9173913043478, -0.05, 0.27777777777778
9809, 1.9391304347826, -0.05, 0.25
9810, 1.9173913043478, -0.05, 0.22222222222222
9811, 1.9391304347826, -0.05, 0.19444444444444
9812, 1.9173913043478, -0.05, 0.16666666666667
9813, 1.9391304347826, -0.05, 0.13888888888889
9814, 1.9173913043478, -0.05, 0.11111111111111
9815, 1.9391304347826, -0.05, 0.083333333333333
9816, 1.9173913043478, -0.05, 0.055555555555556
9817, 1.9391304347826, -0.05, 0.027777777777778
9818, 1.9826086956522, -0.05, 0.47222222222222
9819, 1.9608695652174, -0.05, 0.44444444444444
9820, 1.9826086956522, -0.05, 0.41666666666667
9821, 1.9608695652174, -0.05, 0.38888888888889
9822, 1.9826086956522, -0.05, 0.36111111111111
9823, 1.9608695652174, -0.05, 0.33333333333333
9824, 1.9826086956522, -0.05, 0.30555555555556
9825, 1.9608695652174, -0.05, 0.27777777777778
9826, 1.9826086956522, -0.05, 0.25
9827, 1.9608695652174, -0.05, 0.22222222222222
9828, 1.9826086956522, -0.05, 0.19444444444444
9829, 1.9608695652174, -0.05, 0.16666666666667
9830, 1.9826086956522, -0.05, 0.13888888888889
9831, 1.9608695652174, -0.05, 0.11111111111111
9832, 1.9826086956522, -0.05, 0.083333333333333
9833, 1.9608695652174, -0.05, 0.055555555555556
9834, 1.9826086956522, -0.05, 0.027777777777778
9835, 2.0260869565217, -0.05, 0.47222222222222
9836, 2.004347826087, -0.05, 0.44444444444444
9837, 2.0260869565217, -0.05, 0.41666666666667
9838, 2.004347826087, -0.05, 0.38888888888889
9839, 2.0260869565217, -0.05, 0.36111111111111
9840, 2.004347826087, -0.05, 0.33333333333333
9841, 2.0260869565217, -0.05, 0.30555555555556
9842, 2.004347826087, -0.05, 0.27777777777778
9843, 2.0260869565217, -0.05, 0.25
9844, 2.004347826087, -0.05, 0.22222222222222
9845, 2.0260869565217, -0.05, 0.19444444444444
9846, 2.004347826087, -0.05, 0.16666666666667
9847, 2.0260869565217, -0.05, 0.13888888888889
9848, 2.004347826087, -0.05, 0.11111111111111
9849, 2.0260869565217, -0.05, 0.083333333333333
9850, 2.004347826087, -0.05, 0.055555555555556
9851, 2.0260869565217, -0.05, 0.027777777777778
9852, 2.0695652173913, -0.05, 0.47222222222222
9853, 2.0478260869565, -0.05, 0.44444444444444
9854, 2.0695652173913, -0.05, 0.41666666666667
9855, 2.0478260869565, -0.05, 0.38888888888889
9856, 2.0695652173913, -0.05, 0.36111111111111
9857, 2.0478260869565, -0.05, 0.33333333333333
9858, 2.0695652173913, -0.05, 0.30555555555556
9859, 2.0478260869565, -0.05, 0.27777777777778
9860, 2.0695652173913, -0.05, 0.25
9861, 2.0478260869565, -0.05, 0.22222222222222
9862, 2.0695652173913, -0.05, 0.19444444444444
9863, 2.0478260869565, -0.05, 0.16666666666667
9864, 2.0695652173913, -0.05, 0.13888888888889
9865, 2.0478260869565, -0.05, 0.11111111111111
9866, 2.0695652173913, -0.05, 0.083333333333333
9867, 2.0478260869565, -0.05, 0.055555555555556
9868, 2.0695652173913, -0.05, 0.027777777777778
9869, 2.1130434782609, -0.05, 0.47222222222222
9870, 2.0913043478261, -0.05, 0.44444444444444
9871, 2.1130434782609, -0.05, 0.41666666666667
9872, 2.0913043478261, -0.05, 0.38888888888889
9873, 2.1130434782609, -0.05, 0.36111111111111
9874, 2.0913043478261, -0.05, 0.33333333333333
9875, 2.1130434782609, -0.05, 0.30555555555556
9876, 2.0913043478261, -0.05, 0.27777777777778
9877, 2.1130434782609, -0.05, 0.25
9878, 2.0913043478261, -0.05, 0.22222222222222
9879, 2.1130434782609, -0.05, 0.19444444444444
9880, 2.0913043478261, -0.05, 0.16666666666667
9881, 2.1130434782609, -0.05, 0.13888888888889
9882, 2.0913043478261, -0.05, 0.11111111111111
9883, 2.1130434782609, -0.05, 0.083333333333333
9884, 2.0913043478261, -0.05, 0.055555555555556
9885, 2.1130434782609, -0.05, 0.027777777777778
9886, 2.1565217391304, -0.05, 0.47222222222222
9887, 2.1347826086957, -0.05, 0.44444444444444
9888, 2.1565217391304, -0.05, 0.41666666666667
9889, 2.1347826086957, -0.05, 0.38888888888889
9890, 2.1565217391304, -0.05, 0.36111111111111
9891, 2.1347826086957, -0.05, 0.33333333333333
9892, 2.1565217391304, -0.05, 0.30555555555556
9893, 2.1347826086957, -0.05, 0.27777777777778
9894, 2.1565217391304, -0.05, 0.25
9895, 2.1347826086957, -0.05, 0.22222222222222
9896, 2.1565217391304, -0.05, 0.19444444444444
9897, 2.1347826086957, -0.05, 0.16666666666667
9898, 2.1565217391304, -0.05, 0.13888888888889
9899, 2.1347826086957, -0.05, 0.11111111111111
9900, 2.1565217391304, -0.05, 0.083333333333333
9901, 2.1347826086957, -0.05, 0.055555555555556
9902, 2.1565217391304, -0.05, 0.027777777777778
9903, 2.1782608695652, -0.05, 0.44444444444444
9904, 2.1782608695652, -0.05, 0.38888888888889
9905, 2.1782608695652, -0.05, 0.33333333333333
9906, 2.1782608695652, -0.05, 0.27777777777778
9907, 2.1782608695652, -0.05, 0.22222222222222
9908, 2.1782608695652, -0.05, 0.16666666666667
9909, 2.1782608695652, -0.05, 0.11111111111111
9910, 2.1782608695652, -0.05, 0.055555555555556
9911, 1.2434782608696, -0.25, 0.44444444444444
9912, 1.2434782608696, -0.25, 0.38888888888889
9913, 1.2434782608696, -0.25, 0.33333333333333
9914, 1.2434782608696, -0.25, 0.27777777777778
9915, 1.2434782608696, -0.25, 0.22222222222222
9916, 1.2434782608696, -0.25, 0.16666666666667
9917, 1.2434782608696, -0.25, 0.11111111111111
9918, 1.2434782608696, -0.25, 0.055555555555556
9919, 1.2869565217391, -0.25, 0.44444444444444
9920, 1.2869565217391, -0.25, 0.38888888888889
9921, 1.2869565217391, -0.25, 0.33333333333333
9922, 1.2869565217391, -0.25, 0.27777777777778
9923, 1.2869565217391, -0.25, 0.22222222222222
9924, 1.2869565217391, -0.25, 0.16666666666667
9925, 1.2869565217391, -0.25, 0.11111111111111
9926, 1.2869565217391, -0.25, 0.055555555555556
9927, 1.3304347826087, -0.25, 0.44444444444444
9928, 1.3304347826087, -0.25, 0.38888888888889
9929, 1.3304347826087, -0.25, 0.33333333333333
9930, 1.3304347826087, -0.25, 0.27777777777778
9931, 1.3304347826087, -0.25, 0.22222222222222
9932, 1.3304347826087, -0.25, 0.16666666666667
9933, 1.3304347826087, -0.25, 0.11111111111111
9934, 1.3304347826087, -0.25, 0.055555555555556
9935, 1.3739130434783, -0.25, 0.44444444444444
9936, 1.3739130434783, -0.25, 0.38888888888889
9937, 1.3739130434783, -0.25, 0.33333333333333
9938, 1.3739130434783, -0.25, 0.27777777777778
9939, 1.3739130434783, -0.25, 0.22222222222222
9940, 1.3739130434783, -0.25, 0.16666666666667
9941, 1.3739130434783, -0.25, 0.11111111111111
9942, 1.3739130434783, -0.25, 0.055555555555556
9943, 1.4173913043478, -0.25, 0.44444444444444
9944, 1.4173913043478, -0.25, 0.38888888888889
9945, 1.4173913043478, -0.25, 0.33333333333333
9946, 1.4173913043478, -0.25, 0.27777777777778
9947, 1.4173913043478, -0.25, 0.22222222222222
9948, 1.4173913043478, -0.25, 0.16666666666667
9949, 1.4173913043478, -0.25, 0.11111111111111
9950, 1.4173913043478, -0.25, 0.055555555555556
9951, 1.4608695652174, -0.25, 0.44444444444444
9952, 1.4608695652174, -0.25, 0.38888888888889
9953, 1.4608695652174, -0.25, 0.33333333333333
9954, 1.4608695652174, -0.25, 0.27777777777778
9955, 1.4608695652174, -0.25, 0.22222222222222
9956, 1.4608695652174, -0.25, 0.16666666666667
9957, 1.4608695652174, -0.25, 0.11111111111111
9958, 1.4608695652174, -0.25, 0.055555555555556
9959, 1.504347826087, -0.25, 0.44444444444444
9960, 1.504347826087, -0.25, 0.38888888888889
9961, 1.504347826087, -0.25, 0.33333333333333
9962, 1.504347826087, -0.25, 0.27777777777778
9963, 1.504347826087, -0.25, 0.22222222222222
9964, 1.504347826087, -0.25, 0.16666666666667
9965, 1.504347826087, -0.25, 0.11111111111111
9966, 1.504347826087, -0.25, 0.055555555555556
9967, 1.5478260869565, -0.25, 0.44444444444444
9968, 1.5478260869565, -0.25, 0.38888888888889
9969, 1.5478260869565, -0.25, 0.33333333333333
9970, 1.5478260869565, -0.25, 0.27777777777778
9971, 1.5478260869565, -0.25, 0.22222222222222
9972, 1.5478260869565, -0.25, 0.16666666666667
9973, 1.5478260869565, -0.25, 0.11111111111111
9974, 1.5478260869565, -0.25, 0.055555555555556
9975, 1.5913043478261, -0.25, 0.44444444444444
9976, 1.5913043478261, -0.25, 0.38888888888889
9977, 1.5913043478261, -0.25, 0.33333333333333
9978, 1.5913043478261, -0.25, 0.27777777777778
9979, 1.5913043478261, -0.25, 0.22222222222222
9980, 1.5913043478261, -0.25, 0.16666666666667
9981, 1.5913043478261, -0.25, 0.11111111111111
9982, 1.5913043478261, -0.25, 0.055555555555556
9983, 1.6347826086957, -0.25, 0.44444444444444
9984, 1.6347826086957, -0.25, 0.38888888888889
9985, 1.6347826086957, -0.25, 0.33333333333333
9986, 1.6347826086957, -0.25, 0.27777777777778
9987, 1.6347826086957, -0.25, 0.22222222222222
9988, 1.6347826086957, -0.25, 0.16666666666667
9989, 1.6347826086957, -0.25, 0.11111111111111
9990, 1.6347826086957, -0.25, 0.055555555555556
9991, 1.6782608695652, -0.25, 0.44444444444444
9992, 1.6782608695652, -0.25, 0.38888888888889
9993, 1.6782608695652, -0.25, 0.33333333333333
9994, 1.6782608695652, -0.25, 0.27777777777778
9995, 1.6782608695652, -0.25, 0.22222222222222
9996, 1.6782608695652, -0.25, 0.16666666666667
9997, 1.6782608695652, -0.25, 0.11111111111111
9998, 1.6782608695652, -0.25, 0.055555555555556
9999, 1.7217391304348, -0.25, 0.44444444444444
10000, 1.7217391304348, -0.25, 0.38888888888889
10001, 1.7217391304348, -0.25, 0.33333333333333
10002, 1.7217391304348, -0.25, 0.27777777777778
10003, 1.7217391304348, -0.25, 0.22222222222222
10004, 1.7217391304348, -0.25, 0.16666666666667
10005, 1.7217391304348, -0.25, 0.11111111111111
10006, 1.7217391304348, -0.25, 0.055555555555556
10007, 1.7652173913043, -0.25, 0.44444444444444
10008, 1.7652173913043, -0.25, 0.38888888888889
10009, 1.7652173913043, -0.25, 0.33333333333333
10010, 1.7652173913043, -0.25, 0.27777777777778
10011, 1.7652173913043, -0.25, 0.22222222222222
10012, 1.7652173913043, -0.25, 0.16666666666667
10013, 1.7652173913043, -0.25, 0.11111111111111
10014, 1.7652173913043, -0.25, 0.055555555555556
10015, 1.8086956521739, -0.25, 0.44444444444444
10016, 1.8086956521739, -0.25, 0.38888888888889
10017, 1.8086956521739, -0.25, 0.33333333333333
10018, 1.8086956521739, -0.25, 0.27777777777778
10019, 1.8086956521739, -0.25, 0.22222222222222
10020, 1.8086956521739, -0.25, 0.16666666666667
10021, 1.8086956521739, -0.25, 0.11111111111111
10022, 1.8086956521739, -0.25, 0.055555555555556
10023, 1.8521739130435, -0.25, 0.44444444444444
10024, 1.8521739130435, -0.25, 0.38888888888889
10025, 1.8521739130435, -0.25, 0.33333333333333
10026, 1.8521739130435, -0.25, 0.27777777777778
10027, 1.8521739130435, -0.25, 0.22222222222222
10028, 1.8521739130435, -0.25, 0.16666666666667
10029, 1.8521739130435, -0.25, 0.11111111111111
10030, 1.8521739130435, -0.25, 0.055555555555556
10031, 1.895652173913, -0.25, 0.44444444444444
10032, 1.895652173913, -0.25, 0.38888888888889
10033, 1.895652173913, -0.25, 0.33333333333333
10034, 1.895652173913, -0.25, 0.27777777777778
10035, 1.895652173913, -0.25, 0.22222222222222
10036, 1.895652173913, -0.25, 0.16666666666667
10037, 1.895652173913, -0.25, 0.11111111111111
10038, 1.895652173913, -0.25, 0.055555555555556
10039, 1.9391304347826, -0.25, 0.44444444444444
10040, 1.9391304347826, -0.25, 0.38888888888889
10041, 1.9391304347826, -0.25, 0.33333333333333
10042, 1.9391304347826, -0.25, 0.27777777777778
10043, 1.9391304347826, -0.25, 0.22222222222222
10044, 1.9391304347826, -0.25, 0.16666666666667
10045, 1.9391304347826, -0.25, 0.11111111111111
10046, 1.9391304347826, -0.25, 0.055555555555556
10047, 1.9826086956522, -0.25, 0.44444444444444
10048, 1.9826086956522, -0.25, 0.38888888888889
10049, 1.9826086956522, -0.25, 0.33333333333333
10050, 1.9826086956522, -0.25, 0.27777777777778
10051, 1.9826086956522, -0.25, 0.22222222222222
10052, 1.9826086956522, -0.25, 0.16666666666667
10053, 1.9826086956522, -0.25, 0.11111111111111
10054, 1.9826086956522, -0.25, 0.055555555555556
10055, 2.0260869565217, -0.25, 0.44444444444444
10056, 2.0260869565217, -0.25, 0.38888888888889
10057, 2.0260869565217, -0.25, 0.33333333333333
10058, 2.0260869565217, -0.25, 0.27777777777778
10059, 2.0260869565217, -0.25, 0.22222222222222
10060, 2.0260869565217, -0.25, 0.16666666666667
10061, 2.0260869565217, -0.25, 0.11111111111111
10062, 2.0260869565217, -0.25, 0.055555555555556
10063, 2.0695652173913, -0.25, 0.44444444444444
10064, 2.0695652173913, -0.25, 0.38888888888889
10065, 2.0695652173913, -0.25, 0.33333333333333
10066, 2.0695652173913, -0.25, 0.27777777777778
10067, 2.0695652173913, -0.25, 0.22222222222222
10068, 2.0695652173913, -0.25, 0.16666666666667
10069, 2.0695652173913, -0.25, 0.11111111111111
10070, 2.0695652173913, -0.25, 0.055555555555556
10071, 2.1130434782609, -0.25, 0.44444444444444
10072, 2.1130434782609, -0.25, 0.38888888888889
10073, 2.1130434782609, -0.25, 0.33333333333333
10074, 2.1130434782609, -0.25, 0.27777777777778
10075, 2.1130434782609, -0.25, 0.22222222222222
10076, 2.1130434782609, -0.25, 0.16666666666667
10077, 2.1130434782609, -0.25, 0.11111111111111
10078, 2.1130434782609, -0.25, 0.055555555555556
10079, 2.1565217391304, -0.25, 0.44444444444444
10080, 2.1565217391304, -0.25, 0.38888888888889
10081, 2.1565217391304, -0.25, 0.33333333333333
10082, 2.1565217391304, -0.25, 0.27777777777778
10083, 2.1565217391304, -0.25, 0.22222222222222
10084, 2.1565217391304, -0.25, 0.16666666666667
10085, 2.1565217391304, -0.25, 0.11111111111111
10086, 2.1565217391304, -0.25, 0.055555555555556
10087, 1.2217391304348, -0.25, 0.44444444444444
10088, 1.2434782608696, -0.25, 0.47222222222222
10089, 1.2217391304348, -0.25, 0.38888888888889
10090, 1.2434782608696, -0.25, 0.41666666666667
10091, 1.2217391304348, -0.25, 0.33333333333333
10092, 1.2434782608696, -0.25, 0.36111111111111
10093, 1.2217391304348, -0.25, 0.27777777777778
10094, 1.2434782608696, -0.25, 0.30555555555556
10095, 1.2217391304348, -0.25, 0.22222222222222
10096, 1.2434782608696, -0.25, 0.25
10097, 1.2217391304348, -0.25, 0.16666666666667
10098, 1.2434782608696, -0.25, 0.19444444444444
10099, 1.2217391304348, -0.25, 0.11111111111111
10100, 1.2434782608696, -0.25, 0.13888888888889
10101, 1.2217391304348, -0.25, 0.055555555555556
10102, 1.2434782608696, -0.25, 0.083333333333333
10103, 1.2434782608696, -0.25, 0.027777777777778
10104, 1.2652173913043, -0.25, 0.44444444444444
10105, 1.2869565217391, -0.25, 0.47222222222222
10106, 1.2652173913043, -0.25, 0.38888888888889
10107, 1.2869565217391, -0.25, 0.41666666666667
10108, 1.2652173913043, -0.25, 0.33333333333333
10109, 1.2869565217391, -0.25, 0.36111111111111
10110, 1.2652173913043, -0.25, 0.27777777777778
10111, 1.2869565217391, -0.25, 0.30555555555556
10112, 1.2652173913043, -0.25, 0.22222222222222
10113, 1.2869565217391, -0.25, 0.25
10114, 1.2652173913043, -0.25, 0.16666666666667
10115, 1.2869565217391, -0.25, 0.19444444444444
10116, 1.2652173913043, -0.25, 0.11111111111111
10117, 1.2869565217391, -0.25, 0.13888888888889
10118, 1.2652173913043, -0.25, 0.055555555555556
10119, 1.2869565217391, -0.25, 0.083333333333333
10120, 1.2869565217391, -0.25, 0.027777777777778
10121, 1.3086956521739, -0.25, 0.44444444444444
10122, 1.3304347826087, -0.25, 0.47222222222222
10123, 1.3086956521739, -0.25, 0.38888888888889
10124, 1.3304347826087, -0.25, 0.41666666666667
10125, 1.3086956521739, -0.25, 0.33333333333333
10126, 1.3304347826087, -0.25, 0.36111111111111
10127, 1.3086956521739, -0.25, 0.27777777777778
10128, 1.3304347826087, -0.25, 0.30555555555556
10129, 1.3086956521739, -0.25, 0.22222222222222
10130, 1.3304347826087, -0.25, 0.25
10131, 1.3086956521739, -0.25, 0.16666666666667
10132, 1.3304347826087, -0.25, 0.19444444444444
10133, 1.3086956521739, -0.25, 0.11111111111111
10134, 1.3304347826087, -0.25, 0.13888888888889
10135, 1.3086956521739, -0.25, 0.055555555555556
10136, 1.3304347826087, -0.25, 0.083333333333333
10137, 1.3304347826087, -0.25, 0.027777777777778
10138, 1.3521739130435, -0.25, 0.44444444444444
10139, 1.3739130434783, -0.25, 0.47222222222222
10140, 1.3521739130435, -0.25, 0.38888888888889
10141, 1.3739130434783, -0.25, 0.41666666666667
10142, 1.3521739130435, -0.25, 0.33333333333333
10143, 1.3739130434783, -0.25, 0.36111111111111
10144, 1.3521739130435, -0.25, 0.27777777777778
10145, 1.3739130434783, -0.25, 0.30555555555556
10146, 1.3521739130435, -0.25, 0.22222222222222
10147, 1.3739130434783, -0.25, 0.25
10148, 1.3521739130435, -0.25, 0.16666666666667
10149, 1.3739130434783, -0.25, 0.19444444444444
10150, 1.3521739130435, -0.25, 0.11111111111111
10151, 1.3739130434783, -0.25, 0.13888888888889
10152, 1.3521739130435, -0.25, 0.055555555555556
10153, 1.3739130434783, -0.25, 0.083333333333333
10154, 1.3739130434783, -0.25, 0.027777777777778
10155, 1.395652173913, -0.25, 0.44444444444444
10156, 1.4173913043478, -0.25, 0.47222222222222
10157, 1.395652173913, -0.25, 0.38888888888889
10158, 1.4173913043478, -0.25, 0.41666666666667
10159, 1.395652173913, -0.25, 0.33333333333333
10160, 1.4173913043478, -0.25, 0.36111111111111
10161, 1.395652173913, -0.25, 0.27777777777778
10162, 1.4173913043478, -0.25, 0.30555555555556
10163, 1.395652173913, -0.25, 0.22222222222222
10164, 1.4173913043478, -0.25, 0.25
10165, 1.395652173913, -0.25, 0.16666666666667
10166, 1.4173913043478, -0.25, 0.19444444444444
10167, 1.395652173913, -0.25, 0.11111111111111
10168, 1.4173913043478, -0.25, 0.13888888888889
10169, 1.395652173913, -0.25, 0.055555555555556
10170, 1.4173913043478, -0.25, 0.083333333333333
10171, 1.4173913043478, -0.25, 0.027777777777778
10172, 1.4391304347826, -0.25, 0.44444444444444
10173, 1.4608695652174, -0.25, 0.47222222222222
10174, 1.4391304347826, -0.25, 0.38888888888889
10175, 1.4608695652174, -0.25, 0.41666666666667
10176, 1.4391304347826, -0.25, 0.33333333333333
10177, 1.4608695652174, -0.25, 0.36111111111111
10178, 1.4391304347826, -0.25, 0.27777777777778
10179, 1.4608695652174, -0.25, 0.30555555555556
10180, 1.4391304347826, -0.25, 0.22222222222222
10181, 1.4608695652174, -0.25, 0.25
10182, 1.4391304347826, -0.25, 0.16666666666667
10183, 1.4608695652174, -0.25, 0.19444444444444
10184, 1.4391304347826, -0.25, 0.11111111111111
10185, 1.4608695652174, -0.25, 0.13888888888889
10186, 1.4391304347826, -0.25, 0.055555555555556
10187, 1.4608695652174, -0.25, 0.083333333333333
10188, 1.4608695652174, -0.25, 0.027777777777778
10189, 1.4826086956522, -0.25, 0.44444444444444
10190, 1.504347826087, -0.25, 0.47222222222222
10191, 1.4826086956522, -0.25, 0.38888888888889
10192, 1.504347826087, -0.25, 0.41666666666667
10193, 1.4826086956522, -0.25, 0.33333333333333
10194, 1.504347826087, -0.25, 0.36111111111111
10195, 1.4826086956522, -0.25, 0.27777777777778
10196, 1.504347826087, -0.25, 0.30555555555556
10197, 1.4826086956522, -0.25, 0.22222222222222
10198, 1.504347826087, -0.25, 0.25
10199, 1.4826086956522, -0.25, 0.16666666666667
10200, 1.504347826087, -0.25, 0.19444444444444
10201, 1.4826086956522, -0.25, 0.11111111111111
10202, 1.504347826087, -0.25, 0.13888888888889
10203, 1.4826086956522, -0.25, 0.055555555555556
10204, 1.504347826087, -0.25, 0.083333333333333
10205, 1.504347826087, -0.25, 0.027777777777778
10206, 1.5260869565217, -0.25, 0.44444444444444
10207, 1.5478260869565, -0.25, 0.47222222222222
10208, 1.5260869565217, -0.25, 0.38888888888889
10209, 1.5478260869565, -0.25, 0.41666666666667
10210, 1.5260869565217, -0.25, 0.33333333333333
10211, 1.5478260869565, -0.25, 0.36111111111111
10212, 1.5260869565217, -0.25, 0.27777777777778
10213, 1.5478260869565, -0.25, 0.30555555555556
10214, 1.5260869565217, -0.25, 0.22222222222222
10215, 1.5478260869565, -0.25, 0.25
10216, 1.5260869565217, -0.25, 0.16666666666667
10217, 1.5478260869565, -0.25, 0.19444444444444
10218, 1.5260869565217, -0.25, 0.11111111111111
10219, 1.5478260869565, -0.25, 0.13888888888889
10220, 1.5260869565217, -0.25, 0.055555555555556
10221, 1.5478260869565, -0.25, 0.083333333333333
10222, 1.5478260869565, -0.25, 0.027777777777778
10223, 1.5695652173913, -0.25, 0.44444444444444
10224, 1.5913043478261, -0.25, 0.47222222222222
10225, 1.5695652173913, -0.25, 0.38888888888889
10226, 1.5913043478261, -0.25, 0.41666666666667
10227, 1.5695652173913, -0.25, 0.33333333333333
10228, 1.5913043478261, -0.25, 0.36111111111111
10229, 1.5695652173913, -0.25, 0.27777777777778
10230, 1.5913043478261, -0.25, 0.30555555555556
10231, 1.5695652173913, -0.25, 0.22222222222222
10232, 1.5913043478261, -0.25, 0.25
10233, 1.5695652173913, -0.25, 0.16666666666667
10234, 1.5913043478261, -0.25, 0.19444444444444
10235, 1.5695652173913, -0.25, 0.11111111111111
10236, 1.5913043478261, -0.25, 0.13888888888889
10237, 1.5695652173913, -0.25, 0.055555555555556
10238, 1.5913043478261, -0.25, 0.083333333333333
10239, 1.5913043478261, -0.25, 0.027777777777778
10240, 1.6130434782609, -0.25, 0.44444444444444
10241, 1.6347826086957, -0.25, 0.47222222222222
10242, 1.6130434782609, -0.25, 0.38888888888889
10243, 1.6347826086957, -0.25, 0.41666666666667
10244, 1.6130434782609, -0.25, 0.33333333333333
10245, 1.6347826086957, -0.25, 0.36111111111111
10246, 1.6130434782609, -0.25, 0.27777777777778
10247, 1.6347826086957, -0.25, 0.30555555555556
10248, 1.6130434782609, -0.25, 0.22222222222222
10249, 1.6347826086957, -0.25, 0.25
10250, 1.6130434782609, -0.25, 0.16666666666667
10251, 1.6347826086957, -0.25, 0.19444444444444
10252, 1.6130434782609, -0.25, 0.11111111111111
10253, 1.6347826086957, -0.25, 0.13888888888889
10254, 1.6130434782609, -0.25, 0.055555555555556
10255, 1.6347826086957, -0.25, 0.083333333333333
10256, 1.6347826086957, -0.25, 0.027777777777778
10257, 1.6565217391304, -0.25, 0.44444444444444
10258, 1.6782608695652, -0.25, 0.47222222222222
10259, 1.6565217391304, -0.25, 0.38888888888889
10260, 1.6782608695652, -0.25, 0.41666666666667
10261, 1.6565217391304, -0.25, 0.33333333333333
10262, 1.6782608695652, -0.25, 0.36111111111111
10263, 1.6565217391304, -0.25, 0.27777777777778
10264, 1.6782608695652, -0.25, 0.30555555555556
10265, 1.6565217391304, -0.25, 0.22222222222222
10266, 1.6782608695652, -0.25, 0.25
10267, 1.6565217391304, -0.25, 0.16666666666667
10268, 1.6782608695652, -0.25, 0.19444444444444
10269, 1.6565217391304, -0.25, 0.11111111111111
10270, 1.6782608695652, -0.25, 0.13888888888889
10271, 1.6565217391304, -0.25, 0.055555555555556
10272, 1.6782608695652, -0.25, 0.083333333333333
10273, 1.6782608695652, -0.25, 0.027777777777778
10274, 1.7, -0.25, 0.44444444444444
10275, 1.7217391304348, -0.25, 0.47222222222222
10276, 1.7, -0.25, 0.38888888888889
10277, 1.7217391304348, -0.25, 0.41666666666667
10278, 1.7, -0.25, 0.33333333333333
10279, 1.7217391304348, -0.25, 0.36111111111111
10280, 1.7, -0.25, 0.27777777777778
10281, 1.7217391304348, -0.25, 0.30555555555556
10282, 1.7, -0.25, 0.22222222222222
10283, 1.7217391304348, -0.25, 0.25
10284, 1.7, -0.25, 0.16666666666667
10285, 1.7217391304348, -0.25, 0.19444444444444
10286, 1.7, -0.25, 0.11111111111111
10287, 1.7217391304348, -0.25, 0.13888888888889
10288, 1.7, -0.25, 0.055555555555556
10289, 1.7217391304348, -0.25, 0.083333333333333
10290, 1.7217391304348, -0.25, 0.027777777777778
10291, 1.7434782608696, -0.25, 0.44444444444444
10292, 1.7652173913043, -0.25, 0.47222222222222
10293, 1.7434782608696, -0.25, 0.38888888888889
10294, 1.7652173913043, -0.25, 0.41666666666667
10295, 1.7434782608696, -0.25, 0.33333333333333
10296, 1.7652173913043, -0.25, 0.36111111111111
10297, 1.7434782608696, -0.25, 0.27777777777778
10298, 1.7652173913043, -0.25, 0.30555555555556
10299, 1.7434782608696, -0.25, 0.22222222222222
10300, 1.7652173913043, -0.25, 0.25
10301, 1.7434782608696, -0.25, 0.16666666666667
10302, 1.7652173913043, -0.25, 0.19444444444444
10303, 1.7434782608696, -0.25, 0.11111111111111
10304, 1.7652173913043, -0.25, 0.13888888888889
10305, 1.7434782608696, -0.25, 0.055555555555556
10306, 1.7652173913043, -0.25, 0.083333333333333
10307, 1.7652173913043, -0.25, 0.027777777777778
10308, 1.7869565217391, -0.25, 0.44444444444444
10309, 1.8086956521739, -0.25, 0.47222222222222
10310, 1.7869565217391, -0.25, 0.38888888888889
10311, 1.8086956521739, -0.25, 0.41666666666667
10312, 1.7869565217391, -0.25, 0.33333333333333
10313, 1.8086956521739, -0.25, 0.36111111111111
10314, 1.7869565217391, -0.25, 0.27777777777778
10315, 1.8086956521739, -0.25, 0.30555555555556
10316, 1.7869565217391, -0.25, 0.22222222222222
10317, 1.8086956521739, -0.25, 0.25
10318, 1.7869565217391, -0.25, 0.16666666666667
10319, 1.8086956521739, -0.25, 0.19444444444444
10320, 1.7869565217391, -0.25, 0.11111111111111
10321, 1.8086956521739, -0.25, 0.13888888888889
10322, 1.7869565217391, -0.25, 0.055555555555556
10323, 1.8086956521739, -0.25, 0.083333333333333
10324, 1.8086956521739, -0.25, 0.027777777777778
10325, 1.8304347826087, -0.25, 0.44444444444444
10326, 1.8521739130435, -0.25, 0.47222222222222
10327, 1.8304347826087, -0.25, 0.38888888888889
10328, 1.8521739130435, -0.25, 0.41666666666667
10329, 1.8304347826087, -0.25, 0.33333333333333
10330, 1.8521739130435, -0.25, 0.36111111111111
10331, 1.8304347826087, -0.25, 0.27777777777778
10332, 1.8521739130435, -0.25, 0.30555555555556
10333, 1.8304347826087, -0.25, 0.22222222222222
10334, 1.8521739130435, -0.25, 0.25
10335, 1.8304347826087, -0.25, 0.16666666666667
10336, 1.8521739130435, -0.25, 0.19444444444444
10337, 1.8304347826087, -0.25, 0.11111111111111
10338, 1.8521739130435, -0.25, 0.13888888888889
10339, 1.8304347826087, -0.25, 0.055555555555556
10340, 1.8521739130435, -0.25, 0.083333333333333
10341, 1.8521739130435, -0.25, 0.027777777777778
10342, 1.8739130434783, -0.25, 0.44444444444444
10343, 1.895652173913, -0.25, 0.47222222222222
10344, 1.8739130434783, -0.25, 0.38888888888889
10345, 1.895652173913, -0.25, 0.41666666666667
10346, 1.8739130434783, -0.25, 0.33333333333333
10347, 1.895652173913, -0.25, 0.36111111111111
10348, 1.8739130434783, -0.25, 0.27777777777778
10349, 1.895652173913, -0.25, 0.30555555555556
10350, 1.8739130434783, -0.25, 0.22222222222222
10351, 1.895652173913, -0.25, 0.25
10352, 1.8739130434783, -0.25, 0.16666666666667
10353, 1.895652173913, -0.25, 0.19444444444444
10354, 1.8739130434783, -0.25, 0.11111111111111
10355, 1.895652173913, -0.25, 0.13888888888889
10356, 1.8739130434783, -0.25, 0.055555555555556
10357, 1.895652173913, -0.25, 0.083333333333333
10358, 1.895652173913, -0.25, 0.027777777777778
10359, 1.9173913043478, -0.25, 0.44444444444444
10360, 1.9391304347826, -0.25, 0.47222222222222
10361, 1.9173913043478, -0.25, 0.38888888888889
10362, 1.9391304347826, -0.25, 0.41666666666667
10363, 1.9173913043478, -0.25, 0.33333333333333
10364, 1.9391304347826, -0.25, 0.36111111111111
10365, 1.9173913043478, -0.25, 0.27777777777778
10366, 1.9391304347826, -0.25, 0.30555555555556
10367, 1.9173913043478, -0.25, 0.22222222222222
10368, 1.9391304347826, -0.25, 0.25
10369, 1.9173913043478, -0.25, 0.16666666666667
10370, 1.9391304347826, -0.25, 0.19444444444444
10371, 1.9173913043478, -0.25, 0.11111111111111
10372, 1.9391304347826, -0.25, 0.13888888888889
10373, 1.9173913043478, -0.25, 0.055555555555556
10374, 1.9391304347826, -0.25, 0.083333333333333
10375, 1.9391304347826, -0.25, 0.027777777777778
10376, 1.9608695652174, -0.25, 0.44444444444444
10377, 1.9826086956522, -0.25, 0.47222222222222
10378, 1.9608695652174, -0.25, 0.38888888888889
10379, 1.9826086956522, -0.25, 0.41666666666667
10380, 1.9608695652174, -0.25, 0.33333333333333
10381, 1.9826086956522, -0.25, 0.36111111111111
10382, 1.9608695652174, -0.25, 0.27777777777778
10383, 1.9826086956522, -0.25, 0.30555555555556
10384, 1.9608695652174, -0.25, 0.22222222222222
10385, 1.9826086956522, -0.25, 0.25
10386, 1.9608695652174, -0.25, 0.16666666666667
10387, 1.9826086956522, -0.25, 0.19444444444444
10388, 1.9608695652174, -0.25, 0.11111111111111
10389, 1.9826086956522, -0.25, 0.13888888888889
10390, 1.9608695652174, -0.25, 0.055555555555556
10391, 1.9826086956522, -0.25, 0.083333333333333
10392, 1.9826086956522, -0.25, 0.027777777777778
10393, 2.004347826087, -0.25, 0.44444444444444
10394, 2.0260869565217, -0.25, 0.47222222222222
10395, 2.004347826087, -0.25, 0.38888888888889
10396, 2.0260869565217, -0.25, 0.41666666666667
10397, 2.004347826087, -0.25, 0.33333333333333
10398, 2.0260869565217, -0.25, 0.36111111111111
10399, 2.004347826087, -0.25, 0.27777777777778
10400, 2.0260869565217, -0.25, 0.30555555555556
10401, 2.004347826087, -0.25, 0.22222222222222
10402, 2.0260869565217, -0.25, 0.25
10403, 2.004347826087, -0.25, 0.16666666666667
10404, 2.0260869565217, -0.25, 0.19444444444444
10405, 2.004347826087, -0.25, 0.11111111111111
10406, 2.0260869565217, -0.25, 0.13888888888889
10407, 2.004347826087, -0.25, 0.055555555555556
10408, 2.0260869565217, -0.25, 0.083333333333333
10409, 2.0260869565217, -0.25, 0.027777777777778
10410, 2.0478260869565, -0.25, 0.44444444444444
10411, 2.0695652173913, -0.25, 0.47222222222222
10412, 2.0478260869565, -0.25, 0.38888888888889
10413, 2.0695652173913, -0.25, 0.41666666666667
10414, 2.0478260869565, -0.25, 0.33333333333333
10415, 2.0695652173913, -0.25, 0.36111111111111
10416, 2.0478260869565, -0.25, 0.27777777777778
10417, 2.0695652173913, -0.25, 0.30555555555556
10418, 2.0478260869565, -0.25, 0.22222222222222
10419, 2.0695652173913, -0.25, 0.25
10420, 2.0478260869565, -0.25, 0.16666666666667
10421, 2.0695652173913, -0.25, 0.19444444444444
10422, 2.0478260869565, -0.25, 0.11111111111111
10423, 2.0695652173913, -0.25, 0.13888888888889
10424, 2.0478260869565, -0.25, 0.055555555555556
10425, 2.0695652173913, -0.25, 0.083333333333333
10426, 2.0695652173913, -0.25, 0.027777777777778
10427, 2.0913043478261, -0.25, 0.44444444444444
10428, 2.1130434782609, -0.25, 0.47222222222222
10429, 2.0913043478261, -0.25, 0.38888888888889
10430, 2.1130434782609, -0.25, 0.41666666666667
10431, 2.0913043478261, -0.25, 0.33333333333333
10432, 2.1130434782609, -0.25, 0.36111111111111
10433, 2.0913043478261, -0.25, 0.27777777777778
10434, 2.1130434782609, -0.25, 0.30555555555556
10435, 2.0913043478261, -0.25, 0.22222222222222
10436, 2.1130434782609, -0.25, 0.25
10437, 2.0913043478261, -0.25, 0.16666666666667
10438, 2.1130434782609, -0.25, 0.19444444444444
10439, 2.0913043478261, -0.25, 0.11111111111111
10440, 2.1130434782609, -0.25, 0.13888888888889
10441, 2.0913043478261, -0.25, 0.055555555555556
10442, 2.1130434782609, -0.25, 0.083333333333333
10443, 2.1130434782609, -0.25, 0.027777777777778
10444, 2.1347826086957, -0.25, 0.44444444444444
10445, 2.1565217391304, -0.25, 0.47222222222222
10446, 2.1347826086957, -0.25, 0.38888888888889
10447, 2.1565217391304, -0.25, 0.41666666666667
10448, 2.1347826086957, -0.25, 0.33333333333333
10449, 2.1565217391304, -0.25, 0.36111111111111
10450, 2.1347826086957, -0.25, 0.27777777777778
10451, 2.1565217391304, -0.25, 0.30555555555556
10452, 2.1347826086957, -0.25, 0.22222222222222
10453, 2.1565217391304, -0.25, 0.25
10454, 2.1347826086957, -0.25, 0.16666666666667
10455, 2.1565217391304, -0.25, 0.19444444444444
10456, 2.1347826086957, -0.25, 0.11111111111111
10457, 2.1565217391304, -0.25, 0.13888888888889
10458, 2.1347826086957, -0.25, 0.055555555555556
10459, 2.1565217391304, -0.25, 0.083333333333333
10460, 2.1565217391304, -0.25, 0.027777777777778
10461, 2.1782608695652, -0.25, 0.44444444444444
10462, 2.1782608695652, -0.25, 0.38888888888889
10463, 2.1782608695652, -0.25, 0.33333333333333
10464, 2.1782608695652, -0.25, 0.27777777777778
10465, 2.1782608695652, -0.25, 0.22222222222222
10466, 2.1782608695652, -0.25, 0.16666666666667
10467, 2.1782608695652, -0.25, 0.11111111111111
10468, 2.1782608695652, -0.25, 0.055555555555556
10469, 1.2434782608696, 0.016666666666667, 0.5
10470, 1.2869565217391, 0.016666666666667, 0.5
10471, 1.3304347826087, 0.016666666666667, 0.5
10472, 1.3739130434783, 0.016666666666667, 0.5
10473, 1.4173913043478, 0.016666666666667, 0.5
10474, 1.4608695652174, 0.016666666666667, 0.5
10475, 1.504347826087, 0.016666666666667, 0.5
10476, 1.5478260869565, 0.016666666666667, 0.5
10477, 1.5913043478261, 0.016666666666667, 0.5
10478, 1.6347826086957, 0.016666666666667, 0.5
10479, 1.6782608695652, 0.016666666666667, 0.5
10480, 1.7217391304348, 0.016666666666667, 0.5
10481, 1.7652173913043, 0.016666666666667, 0.5
10482, 1.8086956521739, 0.016666666666667, 0.5
10483, 1.8521739130435, 0.016666666666667, 0.5
10484, 1.895652173913, 0.016666666666667, 0.5
10485, 1.9391304347826, 0.016666666666667, 0.5
10486, 1.9826086956522, 0.016666666666667, 0.5
10487, 2.0260869565217, 0.016666666666667, 0.5
10488, 2.0695652173913, 0.016666666666667, 0.5
10489, 2.1130434782609, 0.016666666666667, 0.5
10490, 2.1565217391304, 0.016666666666667, 0.5
10491, 1.2434782608696, -0.016666666666667, 0.5
10492, 1.2869565217391, -0.016666666666667, 0.5
10493, 1.3304347826087, -0.016666666666667, 0.5
10494, 1.3739130434783, -0.016666666666667, 0.5
10495, 1.4173913043478, -0.016666666666667, 0.5
10496, 1.4608695652174, -0.016666666666667, 0.5
10497, 1.504347826087, -0.016666666666667, 0.5
10498, 1.5478260869565, -0.016666666666667, 0.5
10499, 1.5913043478261, -0.016666666666667, 0.5
10500, 1.6347826086957, -0.016666666666667, 0.5
10501, 1.6782608695652, -0.016666666666667, 0.5
10502, 1.7217391304348, -0.016666666666667, 0.5
10503, 1.7652173913043, -0.016666666666667, 0.5
10504, 1.8086956521739, -0.016666666666667, 0.5
10505, 1.8521739130435, -0.016666666666667, 0.5
10506, 1.895652173913, -0.016666666666667, 0.5
10507, 1.9391304347826, -0.016666666666667, 0.5
10508, 1.9826086956522, -0.016666666666667, 0.5
10509, 2.0260869565217, -0.016666666666667, 0.5
10510, 2.0695652173913, -0.016666666666667, 0.5
10511, 2.1130434782609, -0.016666666666667, 0.5
10512, 2.1565217391304, -0.016666666666667, 0.5
10513, 1.2217391304348, 0.016666666666667, 0.5
10514, 1.2434782608696, 0.033333333333333, 0.5
10515, 1.2652173913043, 0.016666666666667, 0.5
10516, 1.2869565217391, 0.033333333333333, 0.5
10517, 1.3086956521739, 0.016666666666667, 0.5
10518, 1.3304347826087, 0.033333333333333, 0.5
10519, 1.3521739130435, 0.016666666666667, 0.5
10520, 1.3739130434783, 0.033333333333333, 0.5
10521, 1.395652173913, 0.016666666666667, 0.5
10522, 1.4173913043478, 0.033333333333333, 0.5
10523, 1.4391304347826, 0.016666666666667, 0.5
10524, 1.4608695652174, 0.033333333333333, 0.5
10525, 1.4826086956522, 0.016666666666667, 0.5
10526, 1.504347826087, 0.033333333333333, 0.5
10527, 1.5260869565217, 0.016666666666667, 0.5
10528, 1.5478260869565, 0.033333333333333, 0.5
10529, 1.5695652173913, 0.016666666666667, 0.5
10530, 1.5913043478261, 0.033333333333333, 0.5
