77481, 1.3739130434783, 0.17608695652174, 0.055555555555556
77482, 1.4173913043478, 0.17608695652174, 0.44444444444444
77483, 1.4173913043478, 0.17608695652174, 0.38888888888889
77484, 1.4173913043478, 0.17608695652174, 0.33333333333333
77485, 1.4173913043478, 0.17608695652174, 0.27777777777778
77486, 1.4173913043478, 0.17608695652174, 0.22222222222222
77487, 1.4173913043478, 0.17608695652174, 0.16666666666667
77488, 1.4173913043478, 0.17608695652174, 0.11111111111111
77489, 1.4173913043478, 0.17608695652174, 0.055555555555556
77490, 1.4608695652174, 0.17608695652174, 0.44444444444444
77491, 1.4608695652174, 0.17608695652174, 0.38888888888889
77492, 1.4608695652174, 0.17608695652174, 0.33333333333333
77493, 1.4608695652174, 0.17608695652174, 0.27777777777778
77494, 1.4608695652174, 0.17608695652174, 0.22222222222222
77495, 1.4608695652174, 0.17608695652174, 0.16666666666667
77496, 1.4608695652174, 0.17608695652174, 0.11111111111111
77497, 1.4608695652174, 0.17608695652174, 0.055555555555556
77498, 1.504347826087, 0.17608695652174, 0.44444444444444
77499, 1.504347826087, 0.17608695652174, 0.38888888888889
77500, 1.504347826087, 0.17608695652174, 0.33333333333333
77501, 1.504347826087, 0.17608695652174, 0.27777777777778
77502, 1.504347826087, 0.17608695652174, 0.22222222222222
77503, 1.504347826087, 0.17608695652174, 0.16666666666667
77504, 1.504347826087, 0.17608695652174, 0.11111111111111
77505, 1.504347826087, 0.17608695652174, 0.055555555555556
77506, 1.5478260869565, 0.17608695652174, 0.44444444444444
77507, 1.5478260869565, 0.17608695652174, 0.38888888888889
77508, 1.5478260869565, 0.17608695652174, 0.33333333333333
77509, 1.5478260869565, 0.17608695652174, 0.27777777777778
77510, 1.5478260869565, 0.17608695652174, 0.22222222222222
77511, 1.5478260869565, 0.17608695652174, 0.16666666666667
77512, 1.5478260869565, 0.17608695652174, 0.11111111111111
77513, 1.5478260869565, 0.17608695652174, 0.055555555555556
77514, 1.5913043478261, 0.17608695652174, 0.44444444444444
77515, 1.5913043478261, 0.17608695652174, 0.38888888888889
77516, 1.5913043478261, 0.17608695652174, 0.33333333333333
77517, 1.5913043478261, 0.17608695652174, 0.27777777777778
77518, 1.5913043478261, 0.17608695652174, 0.22222222222222
77519, 1.5913043478261, 0.17608695652174, 0.16666666666667
77520, 1.5913043478261, 0.17608695652174, 0.11111111111111
77521, 1.5913043478261, 0.17608695652174, 0.055555555555556
77522, 1.6347826086957, 0.17608695652174, 0.44444444444444
77523, 1.6347826086957, 0.17608695652174, 0.38888888888889
77524, 1.6347826086957, 0.17608695652174, 0.33333333333333
77525, 1.6347826086957, 0.17608695652174, 0.27777777777778
77526, 1.6347826086957, 0.17608695652174, 0.22222222222222
77527, 1.6347826086957, 0.17608695652174, 0.16666666666667
77528, 1.6347826086957, 0.17608695652174, 0.11111111111111
77529, 1.6347826086957, 0.17608695652174, 0.055555555555556
77530, 1.6782608695652, 0.17608695652174, 0.44444444444444
77531, 1.6782608695652, 0.17608695652174, 0.38888888888889
77532, 1.6782608695652, 0.17608695652174, 0.33333333333333
77533, 1.6782608695652, 0.17608695652174, 0.27777777777778
77534, 1.6782608695652, 0.17608695652174, 0.22222222222222
77535, 1.6782608695652, 0.17608695652174, 0.16666666666667
77536, 1.6782608695652, 0.17608695652174, 0.11111111111111
77537, 1.6782608695652, 0.17608695652174, 0.055555555555556
77538, 1.7217391304348, 0.17608695652174, 0.44444444444444
77539, 1.7217391304348, 0.17608695652174, 0.38888888888889
77540, 1.7217391304348, 0.17608695652174, 0.33333333333333
77541, 1.7217391304348, 0.17608695652174, 0.27777777777778
77542, 1.7217391304348, 0.17608695652174, 0.22222222222222
77543, 1.7217391304348, 0.17608695652174, 0.16666666666667
77544, 1.7217391304348, 0.17608695652174, 0.11111111111111
77545, 1.7217391304348, 0.17608695652174, 0.055555555555556
77546, 1.7652173913043, 0.17608695652174, 0.44444444444444
77547, 1.7652173913043, 0.17608695652174, 0.38888888888889
77548, 1.7652173913043, 0.17608695652174, 0.33333333333333
77549, 1.7652173913043, 0.17608695652174, 0.27777777777778
77550, 1.7652173913043, 0.17608695652174, 0.22222222222222
77551, 1.7652173913043, 0.17608695652174, 0.16666666666667
77552, 1.7652173913043, 0.17608695652174, 0.11111111111111
77553, 1.7652173913043, 0.17608695652174, 0.055555555555556
77554, 1.8086956521739, 0.17608695652174, 0.44444444444444
77555, 1.8086956521739, 0.17608695652174, 0.38888888888889
77556, 1.8086956521739, 0.17608695652174, 0.33333333333333
77557, 1.8086956521739, 0.17608695652174, 0.27777777777778
77558, 1.8086956521739, 0.17608695652174, 0.22222222222222
77559, 1.8086956521739, 0.17608695652174, 0.16666666666667
77560, 1.8086956521739, 0.17608695652174, 0.11111111111111
77561, 1.8086956521739, 0.17608695652174, 0.055555555555556
77562, 1.8521739130435, 0.17608695652174, 0.44444444444444
77563, 1.8521739130435, 0.17608695652174, 0.38888888888889
77564, 1.8521739130435, 0.17608695652174, 0.33333333333333
77565, 1.8521739130435, 0.17608695652174, 0.27777777777778
77566, 1.8521739130435, 0.17608695652174, 0.22222222222222
77567, 1.8521739130435, 0.17608695652174, 0.16666666666667
77568, 1.8521739130435, 0.17608695652174, 0.11111111111111
77569, 1.8521739130435, 0.17608695652174, 0.055555555555556
77570, 1.895652173913, 0.17608695652174, 0.44444444444444
77571, 1.895652173913, 0.17608695652174, 0.38888888888889
77572, 1.895652173913, 0.17608695652174, 0.33333333333333
77573, 1.895652173913, 0.17608695652174, 0.27777777777778
77574, 1.895652173913, 0.17608695652174, 0.22222222222222
77575, 1.895652173913, 0.17608695652174, 0.16666666666667
77576, 1.895652173913, 0.17608695652174, 0.11111111111111
77577, 1.895652173913, 0.17608695652174, 0.055555555555556
77578, 1.9391304347826, 0.17608695652174, 0.44444444444444
77579, 1.9391304347826, 0.17608695652174, 0.38888888888889
77580, 1.9391304347826, 0.17608695652174, 0.33333333333333
77581, 1.9391304347826, 0.17608695652174, 0.27777777777778
77582, 1.9391304347826, 0.17608695652174, 0.22222222222222
77583, 1.9391304347826, 0.17608695652174, 0.16666666666667
77584, 1.9391304347826, 0.17608695652174, 0.11111111111111
77585, 1.9391304347826, 0.17608695652174, 0.055555555555556
77586, 1.9826086956522, 0.17608695652174, 0.44444444444444
77587, 1.9826086956522, 0.17608695652174, 0.38888888888889
77588, 1.9826086956522, 0.17608695652174, 0.33333333333333
77589, 1.9826086956522, 0.17608695652174, 0.27777777777778
77590, 1.9826086956522, 0.17608695652174, 0.22222222222222
77591, 1.9826086956522, 0.17608695652174, 0.16666666666667
77592, 1.9826086956522, 0.17608695652174, 0.11111111111111
77593, 1.9826086956522, 0.17608695652174, 0.055555555555556
77594, 2.0260869565217, 0.17608695652174, 0.44444444444444
77595, 2.0260869565217, 0.17608695652174, 0.38888888888889
77596, 2.0260869565217, 0.17608695652174, 0.33333333333333
77597, 2.0260869565217, 0.17608695652174, 0.27777777777778
77598, 2.0260869565217, 0.17608695652174, 0.22222222222222
77599, 2.0260869565217, 0.17608695652174, 0.16666666666667
77600, 2.0260869565217, 0.17608695652174, 0.11111111111111
77601, 2.0260869565217, 0.17608695652174, 0.055555555555556
77602, 2.0695652173913, 0.17608695652174, 0.44444444444444
77603, 2.0695652173913, 0.17608695652174, 0.38888888888889
77604, 2.0695652173913, 0.17608695652174, 0.33333333333333
77605, 2.0695652173913, 0.17608695652174, 0.27777777777778
77606, 2.0695652173913, 0.17608695652174, 0.22222222222222
77607, 2.0695652173913, 0.17608695652174, 0.16666666666667
77608, 2.0695652173913, 0.17608695652174, 0.11111111111111
77609, 2.0695652173913, 0.17608695652174, 0.055555555555556
77610, 2.1130434782609, 0.17608695652174, 0.44444444444444
77611, 2.1130434782609, 0.17608695652174, 0.38888888888889
77612, 2.1130434782609, 0.17608695652174, 0.33333333333333
77613, 2.1130434782609, 0.17608695652174, 0.27777777777778
77614, 2.1130434782609, 0.17608695652174, 0.22222222222222
77615, 2.1130434782609, 0.17608695652174, 0.16666666666667
77616, 2.1130434782609, 0.17608695652174, 0.11111111111111
77617, 2.1130434782609, 0.17608695652174, 0.055555555555556
77618, 2.1565217391304, 0.17608695652174, 0.44444444444444
77619, 2.1565217391304, 0.17608695652174, 0.38888888888889
77620, 2.1565217391304, 0.17608695652174, 0.33333333333333
77621, 2.1565217391304, 0.17608695652174, 0.27777777777778
77622, 2.1565217391304, 0.17608695652174, 0.22222222222222
77623, 2.1565217391304, 0.17608695652174, 0.16666666666667
77624, 2.1565217391304, 0.17608695652174, 0.11111111111111
77625, 2.1565217391304, 0.17608695652174, 0.055555555555556
77626, 1.2434782608696, 0.125, 0.44444444444444
77627, 1.2434782608696, 0.125, 0.38888888888889
77628, 1.2434782608696, 0.125, 0.33333333333333
77629, 1.2434782608696, 0.125, 0.27777777777778
77630, 1.2434782608696, 0.125, 0.22222222222222
77631, 1.2434782608696, 0.125, 0.16666666666667
77632, 1.2434782608696, 0.125, 0.11111111111111
77633, 1.2434782608696, 0.125, 0.055555555555556
77634, 1.2869565217391, 0.125, 0.44444444444444
77635, 1.2869565217391, 0.125, 0.38888888888889
77636, 1.2869565217391, 0.125, 0.33333333333333
77637, 1.2869565217391, 0.125, 0.27777777777778
77638, 1.2869565217391, 0.125, 0.22222222222222
77639, 1.2869565217391, 0.125, 0.16666666666667
77640, 1.2869565217391, 0.125, 0.11111111111111
77641, 1.2869565217391, 0.125, 0.055555555555556
77642, 1.3304347826087, 0.125, 0.44444444444444
77643, 1.3304347826087, 0.125, 0.38888888888889
77644, 1.3304347826087, 0.125, 0.33333333333333
77645, 1.3304347826087, 0.125, 0.27777777777778
77646, 1.3304347826087, 0.125, 0.22222222222222
77647, 1.3304347826087, 0.125, 0.16666666666667
77648, 1.3304347826087, 0.125, 0.11111111111111
77649, 1.3304347826087, 0.125, 0.055555555555556
77650, 1.3739130434783, 0.125, 0.44444444444444
77651, 1.3739130434783, 0.125, 0.38888888888889
77652, 1.3739130434783, 0.125, 0.33333333333333
77653, 1.3739130434783, 0.125, 0.27777777777778
77654, 1.3739130434783, 0.125, 0.22222222222222
77655, 1.3739130434783, 0.125, 0.16666666666667
77656, 1.3739130434783, 0.125, 0.11111111111111
77657, 1.3739130434783, 0.125, 0.055555555555556
77658, 1.4173913043478, 0.125, 0.44444444444444
77659, 1.4173913043478, 0.125, 0.38888888888889
77660, 1.4173913043478, 0.125, 0.33333333333333
77661, 1.4173913043478, 0.125, 0.27777777777778
77662, 1.4173913043478, 0.125, 0.22222222222222
77663, 1.4173913043478, 0.125, 0.16666666666667
77664, 1.4173913043478, 0.125, 0.11111111111111
77665, 1.4173913043478, 0.125, 0.055555555555556
77666, 1.4608695652174, 0.125, 0.44444444444444
77667, 1.4608695652174, 0.125, 0.38888888888889
77668, 1.4608695652174, 0.125, 0.33333333333333
77669, 1.4608695652174, 0.125, 0.27777777777778
77670, 1.4608695652174, 0.125, 0.22222222222222
77671, 1.4608695652174, 0.125, 0.16666666666667
77672, 1.4608695652174, 0.125, 0.11111111111111
77673, 1.4608695652174, 0.125, 0.055555555555556
77674, 1.504347826087, 0.125, 0.44444444444444
77675, 1.504347826087, 0.125, 0.38888888888889
77676, 1.504347826087, 0.125, 0.33333333333333
77677, 1.504347826087, 0.125, 0.27777777777778
77678, 1.504347826087, 0.125, 0.22222222222222
77679, 1.504347826087, 0.125, 0.16666666666667
77680, 1.504347826087, 0.125, 0.11111111111111
77681, 1.504347826087, 0.125, 0.055555555555556
77682, 1.5478260869565, 0.125, 0.44444444444444
77683, 1.5478260869565, 0.125, 0.38888888888889
77684, 1.5478260869565, 0.125, 0.33333333333333
77685, 1.5478260869565, 0.125, 0.27777777777778
77686, 1.5478260869565, 0.125, 0.22222222222222
77687, 1.5478260869565, 0.125, 0.16666666666667
77688, 1.5478260869565, 0.125, 0.11111111111111
77689, 1.5478260869565, 0.125, 0.055555555555556
77690, 1.5913043478261, 0.125, 0.44444444444444
77691, 1.5913043478261, 0.125, 0.38888888888889
77692, 1.5913043478261, 0.125, 0.33333333333333
77693, 1.5913043478261, 0.125, 0.27777777777778
77694, 1.5913043478261, 0.125, 0.22222222222222
77695, 1.5913043478261, 0.125, 0.16666666666667
77696, 1.5913043478261, 0.125, 0.11111111111111
77697, 1.5913043478261, 0.125, 0.055555555555556
77698, 1.6347826086957, 0.125, 0.44444444444444
77699, 1.6347826086957, 0.125, 0.38888888888889
77700, 1.6347826086957, 0.125, 0.33333333333333
77701, 1.6347826086957, 0.125, 0.27777777777778
77702, 1.6347826086957, 0.125, 0.22222222222222
77703, 1.6347826086957, 0.125, 0.16666666666667
77704, 1.6347826086957, 0.125, 0.11111111111111
77705, 1.6347826086957, 0.125, 0.055555555555556
77706, 1.6782608695652, 0.125, 0.44444444444444
77707, 1.6782608695652, 0.125, 0.38888888888889
77708, 1.6782608695652, 0.125, 0.33333333333333
77709, 1.6782608695652, 0.125, 0.27777777777778
77710, 1.6782608695652, 0.125, 0.22222222222222
77711, 1.6782608695652, 0.125, 0.16666666666667
77712, 1.6782608695652, 0.125, 0.11111111111111
77713, 1.6782608695652, 0.125, 0.055555555555556
77714, 1.7217391304348, 0.125, 0.44444444444444
77715, 1.7217391304348, 0.125, 0.38888888888889
77716, 1.7217391304348, 0.125, 0.33333333333333
77717, 1.7217391304348, 0.125, 0.27777777777778
77718, 1.7217391304348, 0.125, 0.22222222222222
77719, 1.7217391304348, 0.125, 0.16666666666667
77720, 1.7217391304348, 0.125, 0.11111111111111
77721, 1.7217391304348, 0.125, 0.055555555555556
77722, 1.7652173913043, 0.125, 0.44444444444444
77723, 1.7652173913043, 0.125, 0.38888888888889
77724, 1.7652173913043, 0.125, 0.33333333333333
77725, 1.7652173913043, 0.125, 0.27777777777778
77726, 1.7652173913043, 0.125, 0.22222222222222
77727, 1.7652173913043, 0.125, 0.16666666666667
77728, 1.7652173913043, 0.125, 0.11111111111111
77729, 1.7652173913043, 0.125, 0.055555555555556
77730, 1.8086956521739, 0.125, 0.44444444444444
77731, 1.8086956521739, 0.125, 0.38888888888889
77732, 1.8086956521739, 0.125, 0.33333333333333
77733, 1.8086956521739, 0.125, 0.27777777777778
77734, 1.8086956521739, 0.125, 0.22222222222222
77735, 1.8086956521739, 0.125, 0.16666666666667
77736, 1.8086956521739, 0.125, 0.11111111111111
77737, 1.8086956521739, 0.125, 0.055555555555556
77738, 1.8521739130435, 0.125, 0.44444444444444
77739, 1.8521739130435, 0.125, 0.38888888888889
77740, 1.8521739130435, 0.125, 0.33333333333333
77741, 1.8521739130435, 0.125, 0.27777777777778
77742, 1.8521739130435, 0.125, 0.22222222222222
77743, 1.8521739130435, 0.125, 0.16666666666667
77744, 1.8521739130435, 0.125, 0.11111111111111
77745, 1.8521739130435, 0.125, 0.055555555555556
77746, 1.895652173913, 0.125, 0.44444444444444
77747, 1.895652173913, 0.125, 0.38888888888889
77748, 1.895652173913, 0.125, 0.33333333333333
77749, 1.895652173913, 0.125, 0.27777777777778
77750, 1.895652173913, 0.125, 0.22222222222222
77751, 1.895652173913, 0.125, 0.16666666666667
77752, 1.895652173913, 0.125, 0.11111111111111
77753, 1.895652173913, 0.125, 0.055555555555556
77754, 1.9391304347826, 0.125, 0.44444444444444
77755, 1.9391304347826, 0.125, 0.38888888888889
77756, 1.9391304347826, 0.125, 0.33333333333333
77757, 1.9391304347826, 0.125, 0.27777777777778
77758, 1.9391304347826, 0.125, 0.22222222222222
77759, 1.9391304347826, 0.125, 0.16666666666667
77760, 1.9391304347826, 0.125, 0.11111111111111
77761, 1.9391304347826, 0.125, 0.055555555555556
77762, 1.9826086956522, 0.125, 0.44444444444444
77763, 1.9826086956522, 0.125, 0.38888888888889
77764, 1.9826086956522, 0.125, 0.33333333333333
77765, 1.9826086956522, 0.125, 0.27777777777778
77766, 1.9826086956522, 0.125, 0.22222222222222
77767, 1.9826086956522, 0.125, 0.16666666666667
77768, 1.9826086956522, 0.125, 0.11111111111111
77769, 1.9826086956522, 0.125, 0.055555555555556
77770, 2.0260869565217, 0.125, 0.44444444444444
77771, 2.0260869565217, 0.125, 0.38888888888889
77772, 2.0260869565217, 0.125, 0.33333333333333
77773, 2.0260869565217, 0.125, 0.27777777777778
77774, 2.0260869565217, 0.125, 0.22222222222222
77775, 2.0260869565217, 0.125, 0.16666666666667
77776, 2.0260869565217, 0.125, 0.11111111111111
77777, 2.0260869565217, 0.125, 0.055555555555556
77778, 2.0695652173913, 0.125, 0.44444444444444
77779, 2.0695652173913, 0.125, 0.38888888888889
77780, 2.0695652173913, 0.125, 0.33333333333333
77781, 2.0695652173913, 0.125, 0.27777777777778
77782, 2.0695652173913, 0.125, 0.22222222222222
77783, 2.0695652173913, 0.125, 0.16666666666667
77784, 2.0695652173913, 0.125, 0.11111111111111
77785, 2.0695652173913, 0.125, 0.055555555555556
77786, 2.1130434782609, 0.125, 0.44444444444444
77787, 2.1130434782609, 0.125, 0.38888888888889
77788, 2.1130434782609, 0.125, 0.33333333333333
77789, 2.1130434782609, 0.125, 0.27777777777778
77790, 2.1130434782609, 0.125, 0.22222222222222
77791, 2.1130434782609, 0.125, 0.16666666666667
77792, 2.1130434782609, 0.125, 0.11111111111111
77793, 2.1130434782609, 0.125, 0.055555555555556
77794, 2.1565217391304, 0.125, 0.44444444444444
77795, 2.1565217391304, 0.125, 0.38888888888889
77796, 2.1565217391304, 0.125, 0.33333333333333
77797, 2.1565217391304, 0.125, 0.27777777777778
77798, 2.1565217391304, 0.125, 0.22222222222222
77799, 2.1565217391304, 0.125, 0.16666666666667
77800, 2.1565217391304, 0.125, 0.11111111111111
77801, 2.1565217391304, 0.125, 0.055555555555556
77802, 1.2434782608696, 0.125, 0.47222222222222
77803, 1.2217391304348, 0.125, 0.44444444444444
77804, 1.2434782608696, 0.1375, 0.44444444444444
77805, 1.2434782608696, 0.125, 0.41666666666667
77806, 1.2217391304348, 0.125, 0.38888888888889
77807, 1.2434782608696, 0.1375, 0.38888888888889
77808, 1.2434782608696, 0.125, 0.36111111111111
77809, 1.2217391304348, 0.125, 0.33333333333333
77810, 1.2434782608696, 0.1375, 0.33333333333333
77811, 1.2434782608696, 0.125, 0.30555555555556
77812, 1.2217391304348, 0.125, 0.27777777777778
77813, 1.2434782608696, 0.1375, 0.27777777777778
77814, 1.2434782608696, 0.125, 0.25
77815, 1.2217391304348, 0.125, 0.22222222222222
77816, 1.2434782608696, 0.1375, 0.22222222222222
77817, 1.2434782608696, 0.125, 0.19444444444444
77818, 1.2217391304348, 0.125, 0.16666666666667
77819, 1.2434782608696, 0.1375, 0.16666666666667
77820, 1.2434782608696, 0.125, 0.13888888888889
77821, 1.2217391304348, 0.125, 0.11111111111111
77822, 1.2434782608696, 0.1375, 0.11111111111111
77823, 1.2434782608696, 0.125, 0.083333333333333
77824, 1.2217391304348, 0.125, 0.055555555555556
77825, 1.2434782608696, 0.1375, 0.055555555555556
77826, 1.2434782608696, 0.125, 0.027777777777778
77827, 1.2869565217391, 0.125, 0.47222222222222
77828, 1.2652173913043, 0.125, 0.44444444444444
77829, 1.2869565217391, 0.1375, 0.44444444444444
77830, 1.2869565217391, 0.125, 0.41666666666667
77831, 1.2652173913043, 0.125, 0.38888888888889
77832, 1.2869565217391, 0.1375, 0.38888888888889
77833, 1.2869565217391, 0.125, 0.36111111111111
77834, 1.2652173913043, 0.125, 0.33333333333333
77835, 1.2869565217391, 0.1375, 0.33333333333333
77836, 1.2869565217391, 0.125, 0.30555555555556
77837, 1.2652173913043, 0.125, 0.27777777777778
77838, 1.2869565217391, 0.1375, 0.27777777777778
77839, 1.2869565217391, 0.125, 0.25
77840, 1.2652173913043, 0.125, 0.22222222222222
77841, 1.2869565217391, 0.1375, 0.22222222222222
77842, 1.2869565217391, 0.125, 0.19444444444444
77843, 1.2652173913043, 0.125, 0.16666666666667
77844, 1.2869565217391, 0.1375, 0.16666666666667
77845, 1.2869565217391, 0.125, 0.13888888888889
77846, 1.2652173913043, 0.125, 0.11111111111111
77847, 1.2869565217391, 0.1375, 0.11111111111111
77848, 1.2869565217391, 0.125, 0.083333333333333
77849, 1.2652173913043, 0.125, 0.055555555555556
77850, 1.2869565217391, 0.1375, 0.055555555555556
77851, 1.2869565217391, 0.125, 0.027777777777778
77852, 1.3304347826087, 0.125, 0.47222222222222
77853, 1.3086956521739, 0.125, 0.44444444444444
77854, 1.3304347826087, 0.1375, 0.44444444444444
77855, 1.3304347826087, 0.125, 0.41666666666667
77856, 1.3086956521739, 0.125, 0.38888888888889
77857, 1.3304347826087, 0.1375, 0.38888888888889
77858, 1.3304347826087, 0.125, 0.36111111111111
77859, 1.3086956521739, 0.125, 0.33333333333333
77860, 1.3304347826087, 0.1375, 0.33333333333333
77861, 1.3304347826087, 0.125, 0.30555555555556
77862, 1.3086956521739, 0.125, 0.27777777777778
77863, 1.3304347826087, 0.1375, 0.27777777777778
77864, 1.3304347826087, 0.125, 0.25
77865, 1.3086956521739, 0.125, 0.22222222222222
77866, 1.3304347826087, 0.1375, 0.22222222222222
77867, 1.3304347826087, 0.125, 0.19444444444444
77868, 1.3086956521739, 0.125, 0.16666666666667
77869, 1.3304347826087, 0.1375, 0.16666666666667
77870, 1.3304347826087, 0.125, 0.13888888888889
77871, 1.3086956521739, 0.125, 0.11111111111111
77872, 1.3304347826087, 0.1375, 0.11111111111111
77873, 1.3304347826087, 0.125, 0.083333333333333
77874, 1.3086956521739, 0.125, 0.055555555555556
77875, 1.3304347826087, 0.1375, 0.055555555555556
77876, 1.3304347826087, 0.125, 0.027777777777778
77877, 1.3739130434783, 0.125, 0.47222222222222
77878, 1.3521739130435, 0.125, 0.44444444444444
77879, 1.3739130434783, 0.1375, 0.44444444444444
77880, 1.3739130434783, 0.125, 0.41666666666667
77881, 1.3521739130435, 0.125, 0.38888888888889
77882, 1.3739130434783, 0.1375, 0.38888888888889
77883, 1.3739130434783, 0.125, 0.36111111111111
77884, 1.3521739130435, 0.125, 0.33333333333333
77885, 1.3739130434783, 0.1375, 0.33333333333333
77886, 1.3739130434783, 0.125, 0.30555555555556
77887, 1.3521739130435, 0.125, 0.27777777777778
77888, 1.3739130434783, 0.1375, 0.27777777777778
77889, 1.3739130434783, 0.125, 0.25
77890, 1.3521739130435, 0.125, 0.22222222222222
77891, 1.3739130434783, 0.1375, 0.22222222222222
77892, 1.3739130434783, 0.125, 0.19444444444444
77893, 1.3521739130435, 0.125, 0.16666666666667
77894, 1.3739130434783, 0.1375, 0.16666666666667
77895, 1.3739130434783, 0.125, 0.13888888888889
77896, 1.3521739130435, 0.125, 0.11111111111111
77897, 1.3739130434783, 0.1375, 0.11111111111111
77898, 1.3739130434783, 0.125, 0.083333333333333
77899, 1.3521739130435, 0.125, 0.055555555555556
77900, 1.3739130434783, 0.1375, 0.055555555555556
77901, 1.3739130434783, 0.125, 0.027777777777778
77902, 1.4173913043478, 0.125, 0.47222222222222
77903, 1.395652173913, 0.125, 0.44444444444444
77904, 1.4173913043478, 0.1375, 0.44444444444444
77905, 1.4173913043478, 0.125, 0.41666666666667
77906, 1.395652173913, 0.125, 0.38888888888889
77907, 1.4173913043478, 0.1375, 0.38888888888889
77908, 1.4173913043478, 0.125, 0.36111111111111
77909, 1.395652173913, 0.125, 0.33333333333333
77910, 1.4173913043478, 0.1375, 0.33333333333333
77911, 1.4173913043478, 0.125, 0.30555555555556
77912, 1.395652173913, 0.125, 0.27777777777778
77913, 1.4173913043478, 0.1375, 0.27777777777778
77914, 1.4173913043478, 0.125, 0.25
77915, 1.395652173913, 0.125, 0.22222222222222
77916, 1.4173913043478, 0.1375, 0.22222222222222
77917, 1.4173913043478, 0.125, 0.19444444444444
77918, 1.395652173913, 0.125, 0.16666666666667
77919, 1.4173913043478, 0.1375, 0.16666666666667
77920, 1.4173913043478, 0.125, 0.13888888888889
77921, 1.395652173913, 0.125, 0.11111111111111
77922, 1.4173913043478, 0.1375, 0.11111111111111
77923, 1.4173913043478, 0.125, 0.083333333333333
77924, 1.395652173913, 0.125, 0.055555555555556
77925, 1.4173913043478, 0.1375, 0.055555555555556
77926, 1.4173913043478, 0.125, 0.027777777777778
77927, 1.4608695652174, 0.125, 0.47222222222222
77928, 1.4391304347826, 0.125, 0.44444444444444
77929, 1.4608695652174, 0.1375, 0.44444444444444
77930, 1.4608695652174, 0.125, 0.41666666666667
77931, 1.4391304347826, 0.125, 0.38888888888889
77932, 1.4608695652174, 0.1375, 0.38888888888889
77933, 1.4608695652174, 0.125, 0.36111111111111
77934, 1.4391304347826, 0.125, 0.33333333333333
77935, 1.4608695652174, 0.1375, 0.33333333333333
77936, 1.4608695652174, 0.125, 0.30555555555556
77937, 1.4391304347826, 0.125, 0.27777777777778
77938, 1.4608695652174, 0.1375, 0.27777777777778
77939, 1.4608695652174, 0.125, 0.25
77940, 1.4391304347826, 0.125, 0.22222222222222
77941, 1.4608695652174, 0.1375, 0.22222222222222
77942, 1.4608695652174, 0.125, 0.19444444444444
77943, 1.4391304347826, 0.125, 0.16666666666667
77944, 1.4608695652174, 0.1375, 0.16666666666667
77945, 1.4608695652174, 0.125, 0.13888888888889
77946, 1.4391304347826, 0.125, 0.11111111111111
77947, 1.4608695652174, 0.1375, 0.11111111111111
77948, 1.4608695652174, 0.125, 0.083333333333333
77949, 1.4391304347826, 0.125, 0.055555555555556
77950, 1.4608695652174, 0.1375, 0.055555555555556
77951, 1.4608695652174, 0.125, 0.027777777777778
77952, 1.504347826087, 0.125, 0.47222222222222
77953, 1.4826086956522, 0.125, 0.44444444444444
77954, 1.504347826087, 0.1375, 0.44444444444444
77955, 1.504347826087, 0.125, 0.41666666666667
77956, 1.4826086956522, 0.125, 0.38888888888889
77957, 1.504347826087, 0.1375, 0.38888888888889
77958, 1.504347826087, 0.125, 0.36111111111111
77959, 1.4826086956522, 0.125, 0.33333333333333
77960, 1.504347826087, 0.1375, 0.33333333333333
77961, 1.504347826087, 0.125, 0.30555555555556
77962, 1.4826086956522, 0.125, 0.27777777777778
77963, 1.504347826087, 0.1375, 0.27777777777778
77964, 1.504347826087, 0.125, 0.25
77965, 1.4826086956522, 0.125, 0.22222222222222
77966, 1.504347826087, 0.1375, 0.22222222222222
77967, 1.504347826087, 0.125, 0.19444444444444
77968, 1.4826086956522, 0.125, 0.16666666666667
77969, 1.504347826087, 0.1375, 0.16666666666667
77970, 1.504347826087, 0.125, 0.13888888888889
77971, 1.4826086956522, 0.125, 0.11111111111111
77972, 1.504347826087, 0.1375, 0.11111111111111
77973, 1.504347826087, 0.125, 0.083333333333333
77974, 1.4826086956522, 0.125, 0.055555555555556
77975, 1.504347826087, 0.1375, 0.055555555555556
77976, 1.504347826087, 0.125, 0.027777777777778
77977, 1.5478260869565, 0.125, 0.47222222222222
77978, 1.5260869565217, 0.125, 0.44444444444444
77979, 1.5478260869565, 0.1375, 0.44444444444444
77980, 1.5478260869565, 0.125, 0.41666666666667
77981, 1.5260869565217, 0.125, 0.38888888888889
77982, 1.5478260869565, 0.1375, 0.38888888888889
77983, 1.5478260869565, 0.125, 0.36111111111111
77984, 1.5260869565217, 0.125, 0.33333333333333
77985, 1.5478260869565, 0.1375, 0.33333333333333
77986, 1.5478260869565, 0.125, 0.30555555555556
77987, 1.5260869565217, 0.125, 0.27777777777778
77988, 1.5478260869565, 0.1375, 0.27777777777778
77989, 1.5478260869565, 0.125, 0.25
77990, 1.5260869565217, 0.125, 0.22222222222222
77991, 1.5478260869565, 0.1375, 0.22222222222222
77992, 1.5478260869565, 0.125, 0.19444444444444
77993, 1.5260869565217, 0.125, 0.16666666666667
77994, 1.5478260869565, 0.1375, 0.16666666666667
77995, 1.5478260869565, 0.125, 0.13888888888889
77996, 1.5260869565217, 0.125, 0.11111111111111
77997, 1.5478260869565, 0.1375, 0.11111111111111
77998, 1.5478260869565, 0.125, 0.083333333333333
77999, 1.5260869565217, 0.125, 0.055555555555556
78000, 1.5478260869565, 0.1375, 0.055555555555556
78001, 1.5478260869565, 0.125, 0.027777777777778
78002, 1.5913043478261, 0.125, 0.47222222222222
78003, 1.5695652173913, 0.125, 0.44444444444444
78004, 1.5913043478261, 0.1375, 0.44444444444444
78005, 1.5913043478261, 0.125, 0.41666666666667
78006, 1.5695652173913, 0.125, 0.38888888888889
78007, 1.5913043478261, 0.1375, 0.38888888888889
78008, 1.5913043478261, 0.125, 0.36111111111111
78009, 1.5695652173913, 0.125, 0.33333333333333
78010, 1.5913043478261, 0.1375, 0.33333333333333
78011, 1.5913043478261, 0.125, 0.30555555555556
78012, 1.5695652173913, 0.125, 0.27777777777778
78013, 1.5913043478261, 0.1375, 0.27777777777778
78014, 1.5913043478261, 0.125, 0.25
78015, 1.5695652173913, 0.125, 0.22222222222222
78016, 1.5913043478261, 0.1375, 0.22222222222222
78017, 1.5913043478261, 0.125, 0.19444444444444
78018, 1.5695652173913, 0.125, 0.16666666666667
78019, 1.5913043478261, 0.1375, 0.16666666666667
78020, 1.5913043478261, 0.125, 0.13888888888889
78021, 1.5695652173913, 0.125, 0.11111111111111
78022, 1.5913043478261, 0.1375, 0.11111111111111
78023, 1.5913043478261, 0.125, 0.083333333333333
78024, 1.5695652173913, 0.125, 0.055555555555556
78025, 1.5913043478261, 0.1375, 0.055555555555556
78026, 1.5913043478261, 0.125, 0.027777777777778
78027, 1.6347826086957, 0.125, 0.47222222222222
78028, 1.6130434782609, 0.125, 0.44444444444444
78029, 1.6347826086957, 0.1375, 0.44444444444444
78030, 1.6347826086957, 0.125, 0.41666666666667
78031, 1.6130434782609, 0.125, 0.38888888888889
78032, 1.6347826086957, 0.1375, 0.38888888888889
78033, 1.6347826086957, 0.125, 0.36111111111111
78034, 1.6130434782609, 0.125, 0.33333333333333
78035, 1.6347826086957, 0.1375, 0.33333333333333
78036, 1.6347826086957, 0.125, 0.30555555555556
78037, 1.6130434782609, 0.125, 0.27777777777778
78038, 1.6347826086957, 0.1375, 0.27777777777778
78039, 1.6347826086957, 0.125, 0.25
78040, 1.6130434782609, 0.125, 0.22222222222222
78041, 1.6347826086957, 0.1375, 0.22222222222222
78042, 1.6347826086957, 0.125, 0.19444444444444
78043, 1.6130434782609, 0.125, 0.16666666666667
78044, 1.6347826086957, 0.1375, 0.16666666666667
78045, 1.6347826086957, 0.125, 0.13888888888889
78046, 1.6130434782609, 0.125, 0.11111111111111
78047, 1.6347826086957, 0.1375, 0.11111111111111
78048, 1.6347826086957, 0.125, 0.083333333333333
78049, 1.6130434782609, 0.125, 0.055555555555556
78050, 1.6347826086957, 0.1375, 0.055555555555556
78051, 1.6347826086957, 0.125, 0.027777777777778
78052, 1.6782608695652, 0.125, 0.47222222222222
78053, 1.6565217391304, 0.125, 0.44444444444444
78054, 1.6782608695652, 0.1375, 0.44444444444444
78055, 1.6782608695652, 0.125, 0.41666666666667
78056, 1.6565217391304, 0.125, 0.38888888888889
78057, 1.6782608695652, 0.1375, 0.38888888888889
78058, 1.6782608695652, 0.125, 0.36111111111111
78059, 1.6565217391304, 0.125, 0.33333333333333
78060, 1.6782608695652, 0.1375, 0.33333333333333
78061, 1.6782608695652, 0.125, 0.30555555555556
78062, 1.6565217391304, 0.125, 0.27777777777778
78063, 1.6782608695652, 0.1375, 0.27777777777778
78064, 1.6782608695652, 0.125, 0.25
78065, 1.6565217391304, 0.125, 0.22222222222222
78066, 1.6782608695652, 0.1375, 0.22222222222222
78067, 1.6782608695652, 0.125, 0.19444444444444
78068, 1.6565217391304, 0.125, 0.16666666666667
78069, 1.6782608695652, 0.1375, 0.16666666666667
78070, 1.6782608695652, 0.125, 0.13888888888889
78071, 1.6565217391304, 0.125, 0.11111111111111
78072, 1.6782608695652, 0.1375, 0.11111111111111
78073, 1.6782608695652, 0.125, 0.083333333333333
78074, 1.6565217391304, 0.125, 0.055555555555556
78075, 1.6782608695652, 0.1375, 0.055555555555556
78076, 1.6782608695652, 0.125, 0.027777777777778
78077, 1.7217391304348, 0.125, 0.47222222222222
78078, 1.7, 0.125, 0.44444444444444
78079, 1.7217391304348, 0.1375, 0.44444444444444
78080, 1.7217391304348, 0.125, 0.41666666666667
78081, 1.7, 0.125, 0.38888888888889
78082, 1.7217391304348, 0.1375, 0.38888888888889
78083, 1.7217391304348, 0.125, 0.36111111111111
78084, 1.7, 0.125, 0.33333333333333
78085, 1.7217391304348, 0.1375, 0.33333333333333
78086, 1.7217391304348, 0.125, 0.30555555555556
78087, 1.7, 0.125, 0.27777777777778
78088, 1.7217391304348, 0.1375, 0.27777777777778
78089, 1.7217391304348, 0.125, 0.25
78090, 1.7, 0.125, 0.22222222222222
78091, 1.7217391304348, 0.1375, 0.22222222222222
78092, 1.7217391304348, 0.125, 0.19444444444444
78093, 1.7, 0.125, 0.16666666666667
78094, 1.7217391304348, 0.1375, 0.16666666666667
78095, 1.7217391304348, 0.125, 0.13888888888889
78096, 1.7, 0.125, 0.11111111111111
78097, 1.7217391304348, 0.1375, 0.11111111111111
78098, 1.7217391304348, 0.125, 0.083333333333333
78099, 1.7, 0.125, 0.055555555555556
78100, 1.7217391304348, 0.1375, 0.055555555555556
78101, 1.7217391304348, 0.125, 0.027777777777778
78102, 1.7652173913043, 0.125, 0.47222222222222
78103, 1.7434782608696, 0.125, 0.44444444444444
78104, 1.7652173913043, 0.1375, 0.44444444444444
78105, 1.7652173913043, 0.125, 0.41666666666667
78106, 1.7434782608696, 0.125, 0.38888888888889
78107, 1.7652173913043, 0.1375, 0.38888888888889
78108, 1.7652173913043, 0.125, 0.36111111111111
78109, 1.7434782608696, 0.125, 0.33333333333333
78110, 1.7652173913043, 0.1375, 0.33333333333333
78111, 1.7652173913043, 0.125, 0.30555555555556
78112, 1.7434782608696, 0.125, 0.27777777777778
78113, 1.7652173913043, 0.1375, 0.27777777777778
78114, 1.7652173913043, 0.125, 0.25
78115, 1.7434782608696, 0.125, 0.22222222222222
78116, 1.7652173913043, 0.1375, 0.22222222222222
78117, 1.7652173913043, 0.125, 0.19444444444444
78118, 1.7434782608696, 0.125, 0.16666666666667
78119, 1.7652173913043, 0.1375, 0.16666666666667
78120, 1.7652173913043, 0.125, 0.13888888888889
78121, 1.7434782608696, 0.125, 0.11111111111111
78122, 1.7652173913043, 0.1375, 0.11111111111111
78123, 1.7652173913043, 0.125, 0.083333333333333
78124, 1.7434782608696, 0.125, 0.055555555555556
78125, 1.7652173913043, 0.1375, 0.055555555555556
78126, 1.7652173913043, 0.125, 0.027777777777778
78127, 1.8086956521739, 0.125, 0.47222222222222
78128, 1.7869565217391, 0.125, 0.44444444444444
78129, 1.8086956521739, 0.1375, 0.44444444444444
78130, 1.8086956521739, 0.125, 0.41666666666667
78131, 1.7869565217391, 0.125, 0.38888888888889
78132, 1.8086956521739, 0.1375, 0.38888888888889
78133, 1.8086956521739, 0.125, 0.36111111111111
78134, 1.7869565217391, 0.125, 0.33333333333333
78135, 1.8086956521739, 0.1375, 0.33333333333333
78136, 1.8086956521739, 0.125, 0.30555555555556
78137, 1.7869565217391, 0.125, 0.27777777777778
78138, 1.8086956521739, 0.1375, 0.27777777777778
78139, 1.8086956521739, 0.125, 0.25
78140, 1.7869565217391, 0.125, 0.22222222222222
78141, 1.8086956521739, 0.1375, 0.22222222222222
78142, 1.8086956521739, 0.125, 0.19444444444444
78143, 1.7869565217391, 0.125, 0.16666666666667
78144, 1.8086956521739, 0.1375, 0.16666666666667
78145, 1.8086956521739, 0.125, 0.13888888888889
78146, 1.7869565217391, 0.125, 0.11111111111111
78147, 1.8086956521739, 0.1375, 0.11111111111111
78148, 1.8086956521739, 0.125, 0.083333333333333
78149, 1.7869565217391, 0.125, 0.055555555555556
78150, 1.8086956521739, 0.1375, 0.055555555555556
78151, 1.8086956521739, 0.125, 0.027777777777778
78152, 1.8521739130435, 0.125, 0.47222222222222
78153, 1.8304347826087, 0.125, 0.44444444444444
78154, 1.8521739130435, 0.1375, 0.44444444444444
78155, 1.8521739130435, 0.125, 0.41666666666667
78156, 1.8304347826087, 0.125, 0.38888888888889
78157, 1.8521739130435, 0.1375, 0.38888888888889
78158, 1.8521739130435, 0.125, 0.36111111111111
78159, 1.8304347826087, 0.125, 0.33333333333333
78160, 1.8521739130435, 0.1375, 0.33333333333333
78161, 1.8521739130435, 0.125, 0.30555555555556
78162, 1.8304347826087, 0.125, 0.27777777777778
78163, 1.8521739130435, 0.1375, 0.27777777777778
78164, 1.8521739130435, 0.125, 0.25
78165, 1.8304347826087, 0.125, 0.22222222222222
78166, 1.8521739130435, 0.1375, 0.22222222222222
78167, 1.8521739130435, 0.125, 0.19444444444444
78168, 1.8304347826087, 0.125, 0.16666666666667
78169, 1.8521739130435, 0.1375, 0.16666666666667
78170, 1.8521739130435, 0.125, 0.13888888888889
78171, 1.8304347826087, 0.125, 0.11111111111111
78172, 1.8521739130435, 0.1375, 0.11111111111111
78173, 1.8521739130435, 0.125, 0.083333333333333
78174, 1.8304347826087, 0.125, 0.055555555555556
78175, 1.8521739130435, 0.1375, 0.055555555555556
78176, 1.8521739130435, 0.125, 0.027777777777778
78177, 1.895652173913, 0.125, 0.47222222222222
78178, 1.8739130434783, 0.125, 0.44444444444444
78179, 1.895652173913, 0.1375, 0.44444444444444
78180, 1.895652173913, 0.125, 0.41666666666667
78181, 1.8739130434783, 0.125, 0.38888888888889
78182, 1.895652173913, 0.1375, 0.38888888888889
78183, 1.895652173913, 0.125, 0.36111111111111
78184, 1.8739130434783, 0.125, 0.33333333333333
78185, 1.895652173913, 0.1375, 0.33333333333333
78186, 1.895652173913, 0.125, 0.30555555555556
78187, 1.8739130434783, 0.125, 0.27777777777778
78188, 1.895652173913, 0.1375, 0.27777777777778
78189, 1.895652173913, 0.125, 0.25
78190, 1.8739130434783, 0.125, 0.22222222222222
78191, 1.895652173913, 0.1375, 0.22222222222222
78192, 1.895652173913, 0.125, 0.19444444444444
78193, 1.8739130434783, 0.125, 0.16666666666667
78194, 1.895652173913, 0.1375, 0.16666666666667
78195, 1.895652173913, 0.125, 0.13888888888889
78196, 1.8739130434783, 0.125, 0.11111111111111
78197, 1.895652173913, 0.1375, 0.11111111111111
78198, 1.895652173913, 0.125, 0.083333333333333
78199, 1.8739130434783, 0.125, 0.055555555555556
78200, 1.895652173913, 0.1375, 0.055555555555556
78201, 1.895652173913, 0.125, 0.027777777777778
78202, 1.9391304347826, 0.125, 0.47222222222222
78203, 1.9173913043478, 0.125, 0.44444444444444
78204, 1.9391304347826, 0.1375, 0.44444444444444
78205, 1.9391304347826, 0.125, 0.41666666666667
78206, 1.9173913043478, 0.125, 0.38888888888889
78207, 1.9391304347826, 0.1375, 0.38888888888889
78208, 1.9391304347826, 0.125, 0.36111111111111
78209, 1.9173913043478, 0.125, 0.33333333333333
78210, 1.9391304347826, 0.1375, 0.33333333333333
78211, 1.9391304347826, 0.125, 0.30555555555556
78212, 1.9173913043478, 0.125, 0.27777777777778
78213, 1.9391304347826, 0.1375, 0.27777777777778
78214, 1.9391304347826, 0.125, 0.25
78215, 1.9173913043478, 0.125, 0.22222222222222
78216, 1.9391304347826, 0.1375, 0.22222222222222
78217, 1.9391304347826, 0.125, 0.19444444444444
78218, 1.9173913043478, 0.125, 0.16666666666667
78219, 1.9391304347826, 0.1375, 0.16666666666667
78220, 1.9391304347826, 0.125, 0.13888888888889
78221, 1.9173913043478, 0.125, 0.11111111111111
78222, 1.9391304347826, 0.1375, 0.11111111111111
78223, 1.9391304347826, 0.125, 0.083333333333333
78224, 1.9173913043478, 0.125, 0.055555555555556
78225, 1.9391304347826, 0.1375, 0.055555555555556
78226, 1.9391304347826, 0.125, 0.027777777777778
78227, 1.9826086956522, 0.125, 0.47222222222222
78228, 1.9608695652174, 0.125, 0.44444444444444
78229, 1.9826086956522, 0.1375, 0.44444444444444
78230, 1.9826086956522, 0.125, 0.41666666666667
78231, 1.9608695652174, 0.125, 0.38888888888889
78232, 1.9826086956522, 0.1375, 0.38888888888889
78233, 1.9826086956522, 0.125, 0.36111111111111
78234, 1.9608695652174, 0.125, 0.33333333333333
78235, 1.9826086956522, 0.1375, 0.33333333333333
78236, 1.9826086956522, 0.125, 0.30555555555556
78237, 1.9608695652174, 0.125, 0.27777777777778
78238, 1.9826086956522, 0.1375, 0.27777777777778
78239, 1.9826086956522, 0.125, 0.25
78240, 1.9608695652174, 0.125, 0.22222222222222
78241, 1.9826086956522, 0.1375, 0.22222222222222
78242, 1.9826086956522, 0.125, 0.19444444444444
78243, 1.9608695652174, 0.125, 0.16666666666667
78244, 1.9826086956522, 0.1375, 0.16666666666667
78245, 1.9826086956522, 0.125, 0.13888888888889
78246, 1.9608695652174, 0.125, 0.11111111111111
78247, 1.9826086956522, 0.1375, 0.11111111111111
78248, 1.9826086956522, 0.125, 0.083333333333333
78249, 1.9608695652174, 0.125, 0.055555555555556
78250, 1.9826086956522, 0.1375, 0.055555555555556
78251, 1.9826086956522, 0.125, 0.027777777777778
78252, 2.0260869565217, 0.125, 0.47222222222222
78253, 2.004347826087, 0.125, 0.44444444444444
78254, 2.0260869565217, 0.1375, 0.44444444444444
78255, 2.0260869565217, 0.125, 0.41666666666667
78256, 2.004347826087, 0.125, 0.38888888888889
78257, 2.0260869565217, 0.1375, 0.38888888888889
78258, 2.0260869565217, 0.125, 0.36111111111111
78259, 2.004347826087, 0.125, 0.33333333333333
78260, 2.0260869565217, 0.1375, 0.33333333333333
78261, 2.0260869565217, 0.125, 0.30555555555556
78262, 2.004347826087, 0.125, 0.27777777777778
78263, 2.0260869565217, 0.1375, 0.27777777777778
78264, 2.0260869565217, 0.125, 0.25
78265, 2.004347826087, 0.125, 0.22222222222222
78266, 2.0260869565217, 0.1375, 0.22222222222222
78267, 2.0260869565217, 0.125, 0.19444444444444
78268, 2.004347826087, 0.125, 0.16666666666667
78269, 2.0260869565217, 0.1375, 0.16666666666667
78270, 2.0260869565217, 0.125, 0.13888888888889
78271, 2.004347826087, 0.125, 0.11111111111111
78272, 2.0260869565217, 0.1375, 0.11111111111111
78273, 2.0260869565217, 0.125, 0.083333333333333
78274, 2.004347826087, 0.125, 0.055555555555556
78275, 2.0260869565217, 0.1375, 0.055555555555556
78276, 2.0260869565217, 0.125, 0.027777777777778
78277, 2.0695652173913, 0.125, 0.47222222222222
78278, 2.0478260869565, 0.125, 0.44444444444444
78279, 2.0695652173913, 0.1375, 0.44444444444444
78280, 2.0695652173913, 0.125, 0.41666666666667
78281, 2.0478260869565, 0.125, 0.38888888888889
78282, 2.0695652173913, 0.1375, 0.38888888888889
78283, 2.0695652173913, 0.125, 0.36111111111111
78284, 2.0478260869565, 0.125, 0.33333333333333
78285, 2.0695652173913, 0.1375, 0.33333333333333
78286, 2.0695652173913, 0.125, 0.30555555555556
78287, 2.0478260869565, 0.125, 0.27777777777778
78288, 2.0695652173913, 0.1375, 0.27777777777778
78289, 2.0695652173913, 0.125, 0.25
78290, 2.0478260869565, 0.125, 0.22222222222222
78291, 2.0695652173913, 0.1375, 0.22222222222222
78292, 2.0695652173913, 0.125, 0.19444444444444
78293, 2.0478260869565, 0.125, 0.16666666666667
78294, 2.0695652173913, 0.1375, 0.16666666666667
78295, 2.0695652173913, 0.125, 0.13888888888889
78296, 2.0478260869565, 0.125, 0.11111111111111
78297, 2.0695652173913, 0.1375, 0.11111111111111
78298, 2.0695652173913, 0.125, 0.083333333333333
78299, 2.0478260869565, 0.125, 0.055555555555556
78300, 2.0695652173913, 0.1375, 0.055555555555556
78301, 2.0695652173913, 0.125, 0.027777777777778
78302, 2.1130434782609, 0.125, 0.47222222222222
78303, 2.0913043478261, 0.125, 0.44444444444444
78304, 2.1130434782609, 0.1375, 0.44444444444444
78305, 2.1130434782609, 0.125, 0.41666666666667
78306, 2.0913043478261, 0.125, 0.38888888888889
78307, 2.1130434782609, 0.1375, 0.38888888888889
78308, 2.1130434782609, 0.125, 0.36111111111111
78309, 2.0913043478261, 0.125, 0.33333333333333
78310, 2.1130434782609, 0.1375, 0.33333333333333
78311, 2.1130434782609, 0.125, 0.30555555555556
78312, 2.0913043478261, 0.125, 0.27777777777778
78313, 2.1130434782609, 0.1375, 0.27777777777778
78314, 2.1130434782609, 0.125, 0.25
78315, 2.0913043478261, 0.125, 0.22222222222222
78316, 2.1130434782609, 0.1375, 0.22222222222222
78317, 2.1130434782609, 0.125, 0.19444444444444
78318, 2.0913043478261, 0.125, 0.16666666666667
78319, 2.1130434782609, 0.1375, 0.16666666666667
78320, 2.1130434782609, 0.125, 0.13888888888889
78321, 2.0913043478261, 0.125, 0.11111111111111
78322, 2.1130434782609, 0.1375, 0.11111111111111
78323, 2.1130434782609, 0.125, 0.083333333333333
78324, 2.0913043478261, 0.125, 0.055555555555556
78325, 2.1130434782609, 0.1375, 0.055555555555556
78326, 2.1130434782609, 0.125, 0.027777777777778
78327, 2.1565217391304, 0.125, 0.47222222222222
78328, 2.1347826086957, 0.125, 0.44444444444444
78329, 2.1565217391304, 0.1375, 0.44444444444444
78330, 2.1565217391304, 0.125, 0.41666666666667
78331, 2.1347826086957, 0.125, 0.38888888888889
78332, 2.1565217391304, 0.1375, 0.38888888888889
78333, 2.1565217391304, 0.125, 0.36111111111111
78334, 2.1347826086957, 0.125, 0.33333333333333
78335, 2.1565217391304, 0.1375, 0.33333333333333
78336, 2.1565217391304, 0.125, 0.30555555555556
78337, 2.1347826086957, 0.125, 0.27777777777778
78338, 2.1565217391304, 0.1375, 0.27777777777778
78339, 2.1565217391304, 0.125, 0.25
78340, 2.1347826086957, 0.125, 0.22222222222222
78341, 2.1565217391304, 0.1375, 0.22222222222222
78342, 2.1565217391304, 0.125, 0.19444444444444
78343, 2.1347826086957, 0.125, 0.16666666666667
78344, 2.1565217391304, 0.1375, 0.16666666666667
78345, 2.1565217391304, 0.125, 0.13888888888889
78346, 2.1347826086957, 0.125, 0.11111111111111
78347, 2.1565217391304, 0.1375, 0.11111111111111
78348, 2.1565217391304, 0.125, 0.083333333333333
78349, 2.1347826086957, 0.125, 0.055555555555556
78350, 2.1565217391304, 0.1375, 0.055555555555556
78351, 2.1565217391304, 0.125, 0.027777777777778
78352, 2.1782608695652, 0.125, 0.44444444444444
78353, 2.1782608695652, 0.125, 0.38888888888889
78354, 2.1782608695652, 0.125, 0.33333333333333
78355, 2.1782608695652, 0.125, 0.27777777777778
78356, 2.1782608695652, 0.125, 0.22222222222222
78357, 2.1782608695652, 0.125, 0.16666666666667
78358, 2.1782608695652, 0.125, 0.11111111111111
78359, 2.1782608695652, 0.125, 0.055555555555556
78360, 1.2434782608696, 0.1125, 0.44444444444444
78361, 1.2434782608696, 0.1125, 0.38888888888889
78362, 1.2434782608696, 0.1125, 0.33333333333333
78363, 1.2434782608696, 0.1125, 0.27777777777778
78364, 1.2434782608696, 0.1125, 0.22222222222222
78365, 1.2434782608696, 0.1125, 0.16666666666667
78366, 1.2434782608696, 0.1125, 0.11111111111111
78367, 1.2434782608696, 0.1125, 0.055555555555556
78368, 1.2869565217391, 0.1125, 0.44444444444444
78369, 1.2869565217391, 0.1125, 0.38888888888889
78370, 1.2869565217391, 0.1125, 0.33333333333333
78371, 1.2869565217391, 0.1125, 0.27777777777778
78372, 1.2869565217391, 0.1125, 0.22222222222222
78373, 1.2869565217391, 0.1125, 0.16666666666667
78374, 1.2869565217391, 0.1125, 0.11111111111111
78375, 1.2869565217391, 0.1125, 0.055555555555556
78376, 1.3304347826087, 0.1125, 0.44444444444444
78377, 1.3304347826087, 0.1125, 0.38888888888889
78378, 1.3304347826087, 0.1125, 0.33333333333333
78379, 1.3304347826087, 0.1125, 0.27777777777778
78380, 1.3304347826087, 0.1125, 0.22222222222222
78381, 1.3304347826087, 0.1125, 0.16666666666667
78382, 1.3304347826087, 0.1125, 0.11111111111111
78383, 1.3304347826087, 0.1125, 0.055555555555556
78384, 1.3739130434783, 0.1125, 0.44444444444444
78385, 1.3739130434783, 0.1125, 0.38888888888889
78386, 1.3739130434783, 0.1125, 0.33333333333333
78387, 1.3739130434783, 0.1125, 0.27777777777778
78388, 1.3739130434783, 0.1125, 0.22222222222222
78389, 1.3739130434783, 0.1125, 0.16666666666667
78390, 1.3739130434783, 0.1125, 0.11111111111111
78391, 1.3739130434783, 0.1125, 0.055555555555556
78392, 1.4173913043478, 0.1125, 0.44444444444444
78393, 1.4173913043478, 0.1125, 0.38888888888889
78394, 1.4173913043478, 0.1125, 0.33333333333333
78395, 1.4173913043478, 0.1125, 0.27777777777778
78396, 1.4173913043478, 0.1125, 0.22222222222222
78397, 1.4173913043478, 0.1125, 0.16666666666667
78398, 1.4173913043478, 0.1125, 0.11111111111111
78399, 1.4173913043478, 0.1125, 0.055555555555556
78400, 1.4608695652174, 0.1125, 0.44444444444444
78401, 1.4608695652174, 0.1125, 0.38888888888889
78402, 1.4608695652174, 0.1125, 0.33333333333333
78403, 1.4608695652174, 0.1125, 0.27777777777778
78404, 1.4608695652174, 0.1125, 0.22222222222222
78405, 1.4608695652174, 0.1125, 0.16666666666667
78406, 1.4608695652174, 0.1125, 0.11111111111111
78407, 1.4608695652174, 0.1125, 0.055555555555556
78408, 1.504347826087, 0.1125, 0.44444444444444
78409, 1.504347826087, 0.1125, 0.38888888888889
78410, 1.504347826087, 0.1125, 0.33333333333333
78411, 1.504347826087, 0.1125, 0.27777777777778
78412, 1.504347826087, 0.1125, 0.22222222222222
78413, 1.504347826087, 0.1125, 0.16666666666667
78414, 1.504347826087, 0.1125, 0.11111111111111
78415, 1.504347826087, 0.1125, 0.055555555555556
78416, 1.5478260869565, 0.1125, 0.44444444444444
78417, 1.5478260869565, 0.1125, 0.38888888888889
78418, 1.5478260869565, 0.1125, 0.33333333333333
78419, 1.5478260869565, 0.1125, 0.27777777777778
78420, 1.5478260869565, 0.1125, 0.22222222222222
78421, 1.5478260869565, 0.1125, 0.16666666666667
78422, 1.5478260869565, 0.1125, 0.11111111111111
78423, 1.5478260869565, 0.1125, 0.055555555555556
78424, 1.5913043478261, 0.1125, 0.44444444444444
78425, 1.5913043478261, 0.1125, 0.38888888888889
78426, 1.5913043478261, 0.1125, 0.33333333333333
78427, 1.5913043478261, 0.1125, 0.27777777777778
78428, 1.5913043478261, 0.1125, 0.22222222222222
78429, 1.5913043478261, 0.1125, 0.16666666666667
78430, 1.5913043478261, 0.1125, 0.11111111111111
78431, 1.5913043478261, 0.1125, 0.055555555555556
78432, 1.6347826086957, 0.1125, 0.44444444444444
78433, 1.6347826086957, 0.1125, 0.38888888888889
78434, 1.6347826086957, 0.1125, 0.33333333333333
78435, 1.6347826086957, 0.1125, 0.27777777777778
78436, 1.6347826086957, 0.1125, 0.22222222222222
78437, 1.6347826086957, 0.1125, 0.16666666666667
78438, 1.6347826086957, 0.1125, 0.11111111111111
78439, 1.6347826086957, 0.1125, 0.055555555555556
78440, 1.6782608695652, 0.1125, 0.44444444444444
78441, 1.6782608695652, 0.1125, 0.38888888888889
78442, 1.6782608695652, 0.1125, 0.33333333333333
78443, 1.6782608695652, 0.1125, 0.27777777777778
78444, 1.6782608695652, 0.1125, 0.22222222222222
78445, 1.6782608695652, 0.1125, 0.16666666666667
78446, 1.6782608695652, 0.1125, 0.11111111111111
78447, 1.6782608695652, 0.1125, 0.055555555555556
78448, 1.7217391304348, 0.1125, 0.44444444444444
78449, 1.7217391304348, 0.1125, 0.38888888888889
78450, 1.7217391304348, 0.1125, 0.33333333333333
78451, 1.7217391304348, 0.1125, 0.27777777777778
78452, 1.7217391304348, 0.1125, 0.22222222222222
78453, 1.7217391304348, 0.1125, 0.16666666666667
78454, 1.7217391304348, 0.1125, 0.11111111111111
78455, 1.7217391304348, 0.1125, 0.055555555555556
78456, 1.7652173913043, 0.1125, 0.44444444444444
78457, 1.7652173913043, 0.1125, 0.38888888888889
78458, 1.7652173913043, 0.1125, 0.33333333333333
78459, 1.7652173913043, 0.1125, 0.27777777777778
78460, 1.7652173913043, 0.1125, 0.22222222222222
78461, 1.7652173913043, 0.1125, 0.16666666666667
78462, 1.7652173913043, 0.1125, 0.11111111111111
78463, 1.7652173913043, 0.1125, 0.055555555555556
78464, 1.8086956521739, 0.1125, 0.44444444444444
78465, 1.8086956521739, 0.1125, 0.38888888888889
78466, 1.8086956521739, 0.1125, 0.33333333333333
78467, 1.8086956521739, 0.1125, 0.27777777777778
78468, 1.8086956521739, 0.1125, 0.22222222222222
78469, 1.8086956521739, 0.1125, 0.16666666666667
78470, 1.8086956521739, 0.1125, 0.11111111111111
78471, 1.8086956521739, 0.1125, 0.055555555555556
78472, 1.8521739130435, 0.1125, 0.44444444444444
78473, 1.8521739130435, 0.1125, 0.38888888888889
78474, 1.8521739130435, 0.1125, 0.33333333333333
78475, 1.8521739130435, 0.1125, 0.27777777777778
78476, 1.8521739130435, 0.1125, 0.22222222222222
78477, 1.8521739130435, 0.1125, 0.16666666666667
78478, 1.8521739130435, 0.1125, 0.11111111111111
78479, 1.8521739130435, 0.1125, 0.055555555555556
78480, 1.895652173913, 0.1125, 0.44444444444444
78481, 1.895652173913, 0.1125, 0.38888888888889
78482, 1.895652173913, 0.1125, 0.33333333333333
78483, 1.895652173913, 0.1125, 0.27777777777778
78484, 1.895652173913, 0.1125, 0.22222222222222
78485, 1.895652173913, 0.1125, 0.16666666666667
78486, 1.895652173913, 0.1125, 0.11111111111111
78487, 1.895652173913, 0.1125, 0.055555555555556
78488, 1.9391304347826, 0.1125, 0.44444444444444
78489, 1.9391304347826, 0.1125, 0.38888888888889
78490, 1.9391304347826, 0.1125, 0.33333333333333
78491, 1.9391304347826, 0.1125, 0.27777777777778
78492, 1.9391304347826, 0.1125, 0.22222222222222
78493, 1.9391304347826, 0.1125, 0.16666666666667
78494, 1.9391304347826, 0.1125, 0.11111111111111
78495, 1.9391304347826, 0.1125, 0.055555555555556
78496, 1.9826086956522, 0.1125, 0.44444444444444
78497, 1.9826086956522, 0.1125, 0.38888888888889
78498, 1.9826086956522, 0.1125, 0.33333333333333
78499, 1.9826086956522, 0.1125, 0.27777777777778
78500, 1.9826086956522, 0.1125, 0.22222222222222
78501, 1.9826086956522, 0.1125, 0.16666666666667
78502, 1.9826086956522, 0.1125, 0.11111111111111
78503, 1.9826086956522, 0.1125, 0.055555555555556
78504, 2.0260869565217, 0.1125, 0.44444444444444
78505, 2.0260869565217, 0.1125, 0.38888888888889
78506, 2.0260869565217, 0.1125, 0.33333333333333
78507, 2.0260869565217, 0.1125, 0.27777777777778
78508, 2.0260869565217, 0.1125, 0.22222222222222
78509, 2.0260869565217, 0.1125, 0.16666666666667
78510, 2.0260869565217, 0.1125, 0.11111111111111
78511, 2.0260869565217, 0.1125, 0.055555555555556
78512, 2.0695652173913, 0.1125, 0.44444444444444
78513, 2.0695652173913, 0.1125, 0.38888888888889
78514, 2.0695652173913, 0.1125, 0.33333333333333
78515, 2.0695652173913, 0.1125, 0.27777777777778
78516, 2.0695652173913, 0.1125, 0.22222222222222
78517, 2.0695652173913, 0.1125, 0.16666666666667
78518, 2.0695652173913, 0.1125, 0.11111111111111
78519, 2.0695652173913, 0.1125, 0.055555555555556
78520, 2.1130434782609, 0.1125, 0.44444444444444
78521, 2.1130434782609, 0.1125, 0.38888888888889
78522, 2.1130434782609, 0.1125, 0.33333333333333
78523, 2.1130434782609, 0.1125, 0.27777777777778
78524, 2.1130434782609, 0.1125, 0.22222222222222
78525, 2.1130434782609, 0.1125, 0.16666666666667
78526, 2.1130434782609, 0.1125, 0.11111111111111
78527, 2.1130434782609, 0.1125, 0.055555555555556
78528, 2.1565217391304, 0.1125, 0.44444444444444
78529, 2.1565217391304, 0.1125, 0.38888888888889
78530, 2.1565217391304, 0.1125, 0.33333333333333
78531, 2.1565217391304, 0.1125, 0.27777777777778
78532, 2.1565217391304, 0.1125, 0.22222222222222
78533, 2.1565217391304, 0.1125, 0.16666666666667
78534, 2.1565217391304, 0.1125, 0.11111111111111
78535, 2.1565217391304, 0.1125, 0.055555555555556
78536, 1.2434782608696, 0.016666666666667, 0.44444444444444
78537, 1.2434782608696, 0.016666666666667, 0.38888888888889
78538, 1.2434782608696, 0.016666666666667, 0.33333333333333
78539, 1.2434782608696, 0.016666666666667, 0.27777777777778
78540, 1.2434782608696, 0.016666666666667, 0.22222222222222
78541, 1.2434782608696, 0.016666666666667, 0.16666666666667
78542, 1.2434782608696, 0.016666666666667, 0.11111111111111
78543, 1.2434782608696, 0.016666666666667, 0.055555555555556
78544, 1.2869565217391, 0.016666666666667, 0.44444444444444
78545, 1.2869565217391, 0.016666666666667, 0.38888888888889
78546, 1.2869565217391, 0.016666666666667, 0.33333333333333
78547, 1.2869565217391, 0.016666666666667, 0.27777777777778
78548, 1.2869565217391, 0.016666666666667, 0.22222222222222
78549, 1.2869565217391, 0.016666666666667, 0.16666666666667
78550, 1.2869565217391, 0.016666666666667, 0.11111111111111
78551, 1.2869565217391, 0.016666666666667, 0.055555555555556
78552, 1.3304347826087, 0.016666666666667, 0.44444444444444
78553, 1.3304347826087, 0.016666666666667, 0.38888888888889
78554, 1.3304347826087, 0.016666666666667, 0.33333333333333
78555, 1.3304347826087, 0.016666666666667, 0.27777777777778
78556, 1.3304347826087, 0.016666666666667, 0.22222222222222
78557, 1.3304347826087, 0.016666666666667, 0.16666666666667
78558, 1.3304347826087, 0.016666666666667, 0.11111111111111
78559, 1.3304347826087, 0.016666666666667, 0.055555555555556
78560, 1.3739130434783, 0.016666666666667, 0.44444444444444
78561, 1.3739130434783, 0.016666666666667, 0.38888888888889
78562, 1.3739130434783, 0.016666666666667, 0.33333333333333
78563, 1.3739130434783, 0.016666666666667, 0.27777777777778
78564, 1.3739130434783, 0.016666666666667, 0.22222222222222
78565, 1.3739130434783, 0.016666666666667, 0.16666666666667
78566, 1.3739130434783, 0.016666666666667, 0.11111111111111
78567, 1.3739130434783, 0.016666666666667, 0.055555555555556
78568, 1.4173913043478, 0.016666666666667, 0.44444444444444
78569, 1.4173913043478, 0.016666666666667, 0.38888888888889
78570, 1.4173913043478, 0.016666666666667, 0.33333333333333
78571, 1.4173913043478, 0.016666666666667, 0.27777777777778
78572, 1.4173913043478, 0.016666666666667, 0.22222222222222
78573, 1.4173913043478, 0.016666666666667, 0.16666666666667
78574, 1.4173913043478, 0.016666666666667, 0.11111111111111
78575, 1.4173913043478, 0.016666666666667, 0.055555555555556
78576, 1.4608695652174, 0.016666666666667, 0.44444444444444
78577, 1.4608695652174, 0.016666666666667, 0.38888888888889
78578, 1.4608695652174, 0.016666666666667, 0.33333333333333
78579, 1.4608695652174, 0.016666666666667, 0.27777777777778
78580, 1.4608695652174, 0.016666666666667, 0.22222222222222
78581, 1.4608695652174, 0.016666666666667, 0.16666666666667
78582, 1.4608695652174, 0.016666666666667, 0.11111111111111
78583, 1.4608695652174, 0.016666666666667, 0.055555555555556
78584, 1.504347826087, 0.016666666666667, 0.44444444444444
78585, 1.504347826087, 0.016666666666667, 0.38888888888889
78586, 1.504347826087, 0.016666666666667, 0.33333333333333
78587, 1.504347826087, 0.016666666666667, 0.27777777777778
78588, 1.504347826087, 0.016666666666667, 0.22222222222222
78589, 1.504347826087, 0.016666666666667, 0.16666666666667
78590, 1.504347826087, 0.016666666666667, 0.11111111111111
78591, 1.504347826087, 0.016666666666667, 0.055555555555556
78592, 1.5478260869565, 0.016666666666667, 0.44444444444444
78593, 1.5478260869565, 0.016666666666667, 0.38888888888889
78594, 1.5478260869565, 0.016666666666667, 0.33333333333333
78595, 1.5478260869565, 0.016666666666667, 0.27777777777778
78596, 1.5478260869565, 0.016666666666667, 0.22222222222222
78597, 1.5478260869565, 0.016666666666667, 0.16666666666667
78598, 1.5478260869565, 0.016666666666667, 0.11111111111111
78599, 1.5478260869565, 0.016666666666667, 0.055555555555556
78600, 1.5913043478261, 0.016666666666667, 0.44444444444444
78601, 1.5913043478261, 0.016666666666667, 0.38888888888889
78602, 1.5913043478261, 0.016666666666667, 0.33333333333333
78603, 1.5913043478261, 0.016666666666667, 0.27777777777778
78604, 1.5913043478261, 0.016666666666667, 0.22222222222222
78605, 1.5913043478261, 0.016666666666667, 0.16666666666667
78606, 1.5913043478261, 0.016666666666667, 0.11111111111111
78607, 1.5913043478261, 0.016666666666667, 0.055555555555556
78608, 1.6347826086957, 0.016666666666667, 0.44444444444444
78609, 1.6347826086957, 0.016666666666667, 0.38888888888889
78610, 1.6347826086957, 0.016666666666667, 0.33333333333333
78611, 1.6347826086957, 0.016666666666667, 0.27777777777778
78612, 1.6347826086957, 0.016666666666667, 0.22222222222222
78613, 1.6347826086957, 0.016666666666667, 0.16666666666667
78614, 1.6347826086957, 0.016666666666667, 0.11111111111111
78615, 1.6347826086957, 0.016666666666667, 0.055555555555556
78616, 1.6782608695652, 0.016666666666667, 0.44444444444444
78617, 1.6782608695652, 0.016666666666667, 0.38888888888889
78618, 1.6782608695652, 0.016666666666667, 0.33333333333333
78619, 1.6782608695652, 0.016666666666667, 0.27777777777778
78620, 1.6782608695652, 0.016666666666667, 0.22222222222222
78621, 1.6782608695652, 0.016666666666667, 0.16666666666667
78622, 1.6782608695652, 0.016666666666667, 0.11111111111111
78623, 1.6782608695652, 0.016666666666667, 0.055555555555556
78624, 1.7217391304348, 0.016666666666667, 0.44444444444444
78625, 1.7217391304348, 0.016666666666667, 0.38888888888889
78626, 1.7217391304348, 0.016666666666667, 0.33333333333333
78627, 1.7217391304348, 0.016666666666667, 0.27777777777778
78628, 1.7217391304348, 0.016666666666667, 0.22222222222222
78629, 1.7217391304348, 0.016666666666667, 0.16666666666667
78630, 1.7217391304348, 0.016666666666667, 0.11111111111111
78631, 1.7217391304348, 0.016666666666667, 0.055555555555556
78632, 1.7652173913043, 0.016666666666667, 0.44444444444444
78633, 1.7652173913043, 0.016666666666667, 0.38888888888889
78634, 1.7652173913043, 0.016666666666667, 0.33333333333333
78635, 1.7652173913043, 0.016666666666667, 0.27777777777778
78636, 1.7652173913043, 0.016666666666667, 0.22222222222222
78637, 1.7652173913043, 0.016666666666667, 0.16666666666667
78638, 1.7652173913043, 0.016666666666667, 0.11111111111111
78639, 1.7652173913043, 0.016666666666667, 0.055555555555556
78640, 1.8086956521739, 0.016666666666667, 0.44444444444444
78641, 1.8086956521739, 0.016666666666667, 0.38888888888889
78642, 1.8086956521739, 0.016666666666667, 0.33333333333333
78643, 1.8086956521739, 0.016666666666667, 0.27777777777778
78644, 1.8086956521739, 0.016666666666667, 0.22222222222222
78645, 1.8086956521739, 0.016666666666667, 0.16666666666667
78646, 1.8086956521739, 0.016666666666667, 0.11111111111111
78647, 1.8086956521739, 0.016666666666667, 0.055555555555556
78648, 1.8521739130435, 0.016666666666667, 0.44444444444444
78649, 1.8521739130435, 0.016666666666667, 0.38888888888889
78650, 1.8521739130435, 0.016666666666667, 0.33333333333333
78651, 1.8521739130435, 0.016666666666667, 0.27777777777778
78652, 1.8521739130435, 0.016666666666667, 0.22222222222222
78653, 1.8521739130435, 0.016666666666667, 0.16666666666667
78654, 1.8521739130435, 0.016666666666667, 0.11111111111111
78655, 1.8521739130435, 0.016666666666667, 0.055555555555556
78656, 1.895652173913, 0.016666666666667, 0.44444444444444
78657, 1.895652173913, 0.016666666666667, 0.38888888888889
78658, 1.895652173913, 0.016666666666667, 0.33333333333333
78659, 1.895652173913, 0.016666666666667, 0.27777777777778
78660, 1.895652173913, 0.016666666666667, 0.22222222222222
78661, 1.895652173913, 0.016666666666667, 0.16666666666667
78662, 1.895652173913, 0.016666666666667, 0.11111111111111
78663, 1.895652173913, 0.016666666666667, 0.055555555555556
78664, 1.9391304347826, 0.016666666666667, 0.44444444444444
78665, 1.9391304347826, 0.016666666666667, 0.38888888888889
78666, 1.9391304347826, 0.016666666666667, 0.33333333333333
78667, 1.9391304347826, 0.016666666666667, 0.27777777777778
78668, 1.9391304347826, 0.016666666666667, 0.22222222222222
78669, 1.9391304347826, 0.016666666666667, 0.16666666666667
78670, 1.9391304347826, 0.016666666666667, 0.11111111111111
78671, 1.9391304347826, 0.016666666666667, 0.055555555555556
78672, 1.9826086956522, 0.016666666666667, 0.44444444444444
78673, 1.9826086956522, 0.016666666666667, 0.38888888888889
78674, 1.9826086956522, 0.016666666666667, 0.33333333333333
78675, 1.9826086956522, 0.016666666666667, 0.27777777777778
78676, 1.9826086956522, 0.016666666666667, 0.22222222222222
78677, 1.9826086956522, 0.016666666666667, 0.16666666666667
78678, 1.9826086956522, 0.016666666666667, 0.11111111111111
78679, 1.9826086956522, 0.016666666666667, 0.055555555555556
78680, 2.0260869565217, 0.016666666666667, 0.44444444444444
78681, 2.0260869565217, 0.016666666666667, 0.38888888888889
78682, 2.0260869565217, 0.016666666666667, 0.33333333333333
78683, 2.0260869565217, 0.016666666666667, 0.27777777777778
78684, 2.0260869565217, 0.016666666666667, 0.22222222222222
78685, 2.0260869565217, 0.016666666666667, 0.16666666666667
78686, 2.0260869565217, 0.016666666666667, 0.11111111111111
78687, 2.0260869565217, 0.016666666666667, 0.055555555555556
78688, 2.0695652173913, 0.016666666666667, 0.44444444444444
78689, 2.0695652173913, 0.016666666666667, 0.38888888888889
78690, 2.0695652173913, 0.016666666666667, 0.33333333333333
78691, 2.0695652173913, 0.016666666666667, 0.27777777777778
78692, 2.0695652173913, 0.016666666666667, 0.22222222222222
78693, 2.0695652173913, 0.016666666666667, 0.16666666666667
78694, 2.0695652173913, 0.016666666666667, 0.11111111111111
78695, 2.0695652173913, 0.016666666666667, 0.055555555555556
78696, 2.1130434782609, 0.016666666666667, 0.44444444444444
78697, 2.1130434782609, 0.016666666666667, 0.38888888888889
78698, 2.1130434782609, 0.016666666666667, 0.33333333333333
78699, 2.1130434782609, 0.016666666666667, 0.27777777777778
78700, 2.1130434782609, 0.016666666666667, 0.22222222222222
78701, 2.1130434782609, 0.016666666666667, 0.16666666666667
78702, 2.1130434782609, 0.016666666666667, 0.11111111111111
78703, 2.1130434782609, 0.016666666666667, 0.055555555555556
78704, 2.1565217391304, 0.016666666666667, 0.44444444444444
78705, 2.1565217391304, 0.016666666666667, 0.38888888888889
78706, 2.1565217391304, 0.016666666666667, 0.33333333333333
78707, 2.1565217391304, 0.016666666666667, 0.27777777777778
78708, 2.1565217391304, 0.016666666666667, 0.22222222222222
78709, 2.1565217391304, 0.016666666666667, 0.16666666666667
78710, 2.1565217391304, 0.016666666666667, 0.11111111111111
78711, 2.1565217391304, 0.016666666666667, 0.055555555555556
78712, 1.2434782608696, -0.016666666666667, 0.44444444444444
78713, 1.2434782608696, -0.016666666666667, 0.38888888888889
78714, 1.2434782608696, -0.016666666666667, 0.33333333333333
78715, 1.2434782608696, -0.016666666666667, 0.27777777777778
78716, 1.2434782608696, -0.016666666666667, 0.22222222222222
78717, 1.2434782608696, -0.016666666666667, 0.16666666666667
78718, 1.2434782608696, -0.016666666666667, 0.11111111111111
78719, 1.2434782608696, -0.016666666666667, 0.055555555555556
78720, 1.2869565217391, -0.016666666666667, 0.44444444444444
78721, 1.2869565217391, -0.016666666666667, 0.38888888888889
78722, 1.2869565217391, -0.016666666666667, 0.33333333333333
78723, 1.2869565217391, -0.016666666666667, 0.27777777777778
78724, 1.2869565217391, -0.016666666666667, 0.22222222222222
78725, 1.2869565217391, -0.016666666666667, 0.16666666666667
78726, 1.2869565217391, -0.016666666666667, 0.11111111111111
78727, 1.2869565217391, -0.016666666666667, 0.055555555555556
78728, 1.3304347826087, -0.016666666666667, 0.44444444444444
78729, 1.3304347826087, -0.016666666666667, 0.38888888888889
78730, 1.3304347826087, -0.016666666666667, 0.33333333333333
78731, 1.3304347826087, -0.016666666666667, 0.27777777777778
78732, 1.3304347826087, -0.016666666666667, 0.22222222222222
78733, 1.3304347826087, -0.016666666666667, 0.16666666666667
78734, 1.3304347826087, -0.016666666666667, 0.11111111111111
78735, 1.3304347826087, -0.016666666666667, 0.055555555555556
78736, 1.3739130434783, -0.016666666666667, 0.44444444444444
78737, 1.3739130434783, -0.016666666666667, 0.38888888888889
78738, 1.3739130434783, -0.016666666666667, 0.33333333333333
78739, 1.3739130434783, -0.016666666666667, 0.27777777777778
78740, 1.3739130434783, -0.016666666666667, 0.22222222222222
78741, 1.3739130434783, -0.016666666666667, 0.16666666666667
78742, 1.3739130434783, -0.016666666666667, 0.11111111111111
78743, 1.3739130434783, -0.016666666666667, 0.055555555555556
78744, 1.4173913043478, -0.016666666666667, 0.44444444444444
78745, 1.4173913043478, -0.016666666666667, 0.38888888888889
78746, 1.4173913043478, -0.016666666666667, 0.33333333333333
78747, 1.4173913043478, -0.016666666666667, 0.27777777777778
78748, 1.4173913043478, -0.016666666666667, 0.22222222222222
78749, 1.4173913043478, -0.016666666666667, 0.16666666666667
78750, 1.4173913043478, -0.016666666666667, 0.11111111111111
78751, 1.4173913043478, -0.016666666666667, 0.055555555555556
78752, 1.4608695652174, -0.016666666666667, 0.44444444444444
78753, 1.4608695652174, -0.016666666666667, 0.38888888888889
78754, 1.4608695652174, -0.016666666666667, 0.33333333333333
78755, 1.4608695652174, -0.016666666666667, 0.27777777777778
78756, 1.4608695652174, -0.016666666666667, 0.22222222222222
78757, 1.4608695652174, -0.016666666666667, 0.16666666666667
78758, 1.4608695652174, -0.016666666666667, 0.11111111111111
78759, 1.4608695652174, -0.016666666666667, 0.055555555555556
78760, 1.504347826087, -0.016666666666667, 0.44444444444444
78761, 1.504347826087, -0.016666666666667, 0.38888888888889
78762, 1.504347826087, -0.016666666666667, 0.33333333333333
78763, 1.504347826087, -0.016666666666667, 0.27777777777778
78764, 1.504347826087, -0.016666666666667, 0.22222222222222
78765, 1.504347826087, -0.016666666666667, 0.16666666666667
78766, 1.504347826087, -0.016666666666667, 0.11111111111111
78767, 1.504347826087, -0.016666666666667, 0.055555555555556
78768, 1.5478260869565, -0.016666666666667, 0.44444444444444
78769, 1.5478260869565, -0.016666666666667, 0.38888888888889
78770, 1.5478260869565, -0.016666666666667, 0.33333333333333
78771, 1.5478260869565, -0.016666666666667, 0.27777777777778
78772, 1.5478260869565, -0.016666666666667, 0.22222222222222
78773, 1.5478260869565, -0.016666666666667, 0.16666666666667
78774, 1.5478260869565, -0.016666666666667, 0.11111111111111
78775, 1.5478260869565, -0.016666666666667, 0.055555555555556
78776, 1.5913043478261, -0.016666666666667, 0.44444444444444
78777, 1.5913043478261, -0.016666666666667, 0.38888888888889
78778, 1.5913043478261, -0.016666666666667, 0.33333333333333
78779, 1.5913043478261, -0.016666666666667, 0.27777777777778
78780, 1.5913043478261, -0.016666666666667, 0.22222222222222
78781, 1.5913043478261, -0.016666666666667, 0.16666666666667
78782, 1.5913043478261, -0.016666666666667, 0.11111111111111
78783, 1.5913043478261, -0.016666666666667, 0.055555555555556
78784, 1.6347826086957, -0.016666666666667, 0.44444444444444
78785, 1.6347826086957, -0.016666666666667, 0.38888888888889
78786, 1.6347826086957, -0.016666666666667, 0.33333333333333
78787, 1.6347826086957, -0.016666666666667, 0.27777777777778
78788, 1.6347826086957, -0.016666666666667, 0.22222222222222
78789, 1.6347826086957, -0.016666666666667, 0.16666666666667
78790, 1.6347826086957, -0.016666666666667, 0.11111111111111
78791, 1.6347826086957, -0.016666666666667, 0.055555555555556
78792, 1.6782608695652, -0.016666666666667, 0.44444444444444
78793, 1.6782608695652, -0.016666666666667, 0.38888888888889
78794, 1.6782608695652, -0.016666666666667, 0.33333333333333
78795, 1.6782608695652, -0.016666666666667, 0.27777777777778
78796, 1.6782608695652, -0.016666666666667, 0.22222222222222
78797, 1.6782608695652, -0.016666666666667, 0.16666666666667
78798, 1.6782608695652, -0.016666666666667, 0.11111111111111
78799, 1.6782608695652, -0.016666666666667, 0.055555555555556
78800, 1.7217391304348, -0.016666666666667, 0.44444444444444
78801, 1.7217391304348, -0.016666666666667, 0.38888888888889
78802, 1.7217391304348, -0.016666666666667, 0.33333333333333
78803, 1.7217391304348, -0.016666666666667, 0.27777777777778
78804, 1.7217391304348, -0.016666666666667, 0.22222222222222
78805, 1.7217391304348, -0.016666666666667, 0.16666666666667
78806, 1.7217391304348, -0.016666666666667, 0.11111111111111
78807, 1.7217391304348, -0.016666666666667, 0.055555555555556
78808, 1.7652173913043, -0.016666666666667, 0.44444444444444
78809, 1.7652173913043, -0.016666666666667, 0.38888888888889
78810, 1.7652173913043, -0.016666666666667, 0.33333333333333
78811, 1.7652173913043, -0.016666666666667, 0.27777777777778
78812, 1.7652173913043, -0.016666666666667, 0.22222222222222
78813, 1.7652173913043, -0.016666666666667, 0.16666666666667
78814, 1.7652173913043, -0.016666666666667, 0.11111111111111
78815, 1.7652173913043, -0.016666666666667, 0.055555555555556
78816, 1.8086956521739, -0.016666666666667, 0.44444444444444
78817, 1.8086956521739, -0.016666666666667, 0.38888888888889
78818, 1.8086956521739, -0.016666666666667, 0.33333333333333
78819, 1.8086956521739, -0.016666666666667, 0.27777777777778
78820, 1.8086956521739, -0.016666666666667, 0.22222222222222
78821, 1.8086956521739, -0.016666666666667, 0.16666666666667
78822, 1.8086956521739, -0.016666666666667, 0.11111111111111
78823, 1.8086956521739, -0.016666666666667, 0.055555555555556
78824, 1.8521739130435, -0.016666666666667, 0.44444444444444
78825, 1.8521739130435, -0.016666666666667, 0.38888888888889
78826, 1.8521739130435, -0.016666666666667, 0.33333333333333
78827, 1.8521739130435, -0.016666666666667, 0.27777777777778
78828, 1.8521739130435, -0.016666666666667, 0.22222222222222
78829, 1.8521739130435, -0.016666666666667, 0.16666666666667
78830, 1.8521739130435, -0.016666666666667, 0.11111111111111
78831, 1.8521739130435, -0.016666666666667, 0.055555555555556
78832, 1.895652173913, -0.016666666666667, 0.44444444444444
78833, 1.895652173913, -0.016666666666667, 0.38888888888889
78834, 1.895652173913, -0.016666666666667, 0.33333333333333
78835, 1.895652173913, -0.016666666666667, 0.27777777777778
78836, 1.895652173913, -0.016666666666667, 0.22222222222222
78837, 1.895652173913, -0.016666666666667, 0.16666666666667
78838, 1.895652173913, -0.016666666666667, 0.11111111111111
78839, 1.895652173913, -0.016666666666667, 0.055555555555556
78840, 1.9391304347826, -0.016666666666667, 0.44444444444444
78841, 1.9391304347826, -0.016666666666667, 0.38888888888889
78842, 1.9391304347826, -0.016666666666667, 0.33333333333333
78843, 1.9391304347826, -0.016666666666667, 0.27777777777778
78844, 1.9391304347826, -0.016666666666667, 0.22222222222222
78845, 1.9391304347826, -0.016666666666667, 0.16666666666667
78846, 1.9391304347826, -0.016666666666667, 0.11111111111111
78847, 1.9391304347826, -0.016666666666667, 0.055555555555556
78848, 1.9826086956522, -0.016666666666667, 0.44444444444444
78849, 1.9826086956522, -0.016666666666667, 0.38888888888889
78850, 1.9826086956522, -0.016666666666667, 0.33333333333333
78851, 1.9826086956522, -0.016666666666667, 0.27777777777778
78852, 1.9826086956522, -0.016666666666667, 0.22222222222222
78853, 1.9826086956522, -0.016666666666667, 0.16666666666667
78854, 1.9826086956522, -0.016666666666667, 0.11111111111111
78855, 1.9826086956522, -0.016666666666667, 0.055555555555556
78856, 2.0260869565217, -0.016666666666667, 0.44444444444444
78857, 2.0260869565217, -0.016666666666667, 0.38888888888889
78858, 2.0260869565217, -0.016666666666667, 0.33333333333333
78859, 2.0260869565217, -0.016666666666667, 0.27777777777778
78860, 2.0260869565217, -0.016666666666667, 0.22222222222222
78861, 2.0260869565217, -0.016666666666667, 0.16666666666667
78862, 2.0260869565217, -0.016666666666667, 0.11111111111111
78863, 2.0260869565217, -0.016666666666667, 0.055555555555556
78864, 2.0695652173913, -0.016666666666667, 0.44444444444444
78865, 2.0695652173913, -0.016666666666667, 0.38888888888889
78866, 2.0695652173913, -0.016666666666667, 0.33333333333333
78867, 2.0695652173913, -0.016666666666667, 0.27777777777778
78868, 2.0695652173913, -0.016666666666667, 0.22222222222222
78869, 2.0695652173913, -0.016666666666667, 0.16666666666667
78870, 2.0695652173913, -0.016666666666667, 0.11111111111111
78871, 2.0695652173913, -0.016666666666667, 0.055555555555556
78872, 2.1130434782609, -0.016666666666667, 0.44444444444444
78873, 2.1130434782609, -0.016666666666667, 0.38888888888889
78874, 2.1130434782609, -0.016666666666667, 0.33333333333333
78875, 2.1130434782609, -0.016666666666667, 0.27777777777778
78876, 2.1130434782609, -0.016666666666667, 0.22222222222222
78877, 2.1130434782609, -0.016666666666667, 0.16666666666667
78878, 2.1130434782609, -0.016666666666667, 0.11111111111111
78879, 2.1130434782609, -0.016666666666667, 0.055555555555556
78880, 2.1565217391304, -0.016666666666667, 0.44444444444444
78881, 2.1565217391304, -0.016666666666667, 0.38888888888889
78882, 2.1565217391304, -0.016666666666667, 0.33333333333333
78883, 2.1565217391304, -0.016666666666667, 0.27777777777778
78884, 2.1565217391304, -0.016666666666667, 0.22222222222222
78885, 2.1565217391304, -0.016666666666667, 0.16666666666667
78886, 2.1565217391304, -0.016666666666667, 0.11111111111111
78887, 2.1565217391304, -0.016666666666667, 0.055555555555556
78888, 1.2434782608696, 0.016666666666667, 0.47222222222222
78889, 1.2217391304348, 0.016666666666667, 0.44444444444444
78890, 1.2434782608696, 0.033333333333333, 0.44444444444444
78891, 1.2434782608696, 0.016666666666667, 0.41666666666667
78892, 1.2217391304348, 0.016666666666667, 0.38888888888889
78893, 1.2434782608696, 0.033333333333333, 0.38888888888889
78894, 1.2434782608696, 0.016666666666667, 0.36111111111111
78895, 1.2217391304348, 0.016666666666667, 0.33333333333333
78896, 1.2434782608696, 0.033333333333333, 0.33333333333333
78897, 1.2434782608696, 0.016666666666667, 0.30555555555556
78898, 1.2217391304348, 0.016666666666667, 0.27777777777778
78899, 1.2434782608696, 0.033333333333333, 0.27777777777778
78900, 1.2434782608696, 0.016666666666667, 0.25
78901, 1.2217391304348, 0.016666666666667, 0.22222222222222
78902, 1.2434782608696, 0.033333333333333, 0.22222222222222
78903, 1.2434782608696, 0.016666666666667, 0.19444444444444
78904, 1.2217391304348, 0.016666666666667, 0.16666666666667
78905, 1.2434782608696, 0.033333333333333, 0.16666666666667
78906, 1.2434782608696, 0.016666666666667, 0.13888888888889
78907, 1.2217391304348, 0.016666666666667, 0.11111111111111
78908, 1.2434782608696, 0.033333333333333, 0.11111111111111
78909, 1.2434782608696, 0.016666666666667, 0.083333333333333
78910, 1.2217391304348, 0.016666666666667, 0.055555555555556
78911, 1.2434782608696, 0.033333333333333, 0.055555555555556
78912, 1.2434782608696, 0.016666666666667, 0.027777777777778
78913, 1.2869565217391, 0.016666666666667, 0.47222222222222
78914, 1.2652173913043, 0.016666666666667, 0.44444444444444
78915, 1.2869565217391, 0.033333333333333, 0.44444444444444
78916, 1.2869565217391, 0.016666666666667, 0.41666666666667
78917, 1.2652173913043, 0.016666666666667, 0.38888888888889
78918, 1.2869565217391, 0.033333333333333, 0.38888888888889
78919, 1.2869565217391, 0.016666666666667, 0.36111111111111
78920, 1.2652173913043, 0.016666666666667, 0.33333333333333
78921, 1.2869565217391, 0.033333333333333, 0.33333333333333
78922, 1.2869565217391, 0.016666666666667, 0.30555555555556
78923, 1.2652173913043, 0.016666666666667, 0.27777777777778
78924, 1.2869565217391, 0.033333333333333, 0.27777777777778
78925, 1.2869565217391, 0.016666666666667, 0.25
78926, 1.2652173913043, 0.016666666666667, 0.22222222222222
78927, 1.2869565217391, 0.033333333333333, 0.22222222222222
78928, 1.2869565217391, 0.016666666666667, 0.19444444444444
78929, 1.2652173913043, 0.016666666666667, 0.16666666666667
78930, 1.2869565217391, 0.033333333333333, 0.16666666666667
78931, 1.2869565217391, 0.016666666666667, 0.13888888888889
78932, 1.2652173913043, 0.016666666666667, 0.11111111111111
78933, 1.2869565217391, 0.033333333333333, 0.11111111111111
78934, 1.2869565217391, 0.016666666666667, 0.083333333333333
78935, 1.2652173913043, 0.016666666666667, 0.055555555555556
78936, 1.2869565217391, 0.033333333333333, 0.055555555555556
78937, 1.2869565217391, 0.016666666666667, 0.027777777777778
78938, 1.3304347826087, 0.016666666666667, 0.47222222222222
78939, 1.3086956521739, 0.016666666666667, 0.44444444444444
78940, 1.3304347826087, 0.033333333333333, 0.44444444444444
78941, 1.3304347826087, 0.016666666666667, 0.41666666666667
78942, 1.3086956521739, 0.016666666666667, 0.38888888888889
78943, 1.3304347826087, 0.033333333333333, 0.38888888888889
78944, 1.3304347826087, 0.016666666666667, 0.36111111111111
78945, 1.3086956521739, 0.016666666666667, 0.33333333333333
78946, 1.3304347826087, 0.033333333333333, 0.33333333333333
78947, 1.3304347826087, 0.016666666666667, 0.30555555555556
78948, 1.3086956521739, 0.016666666666667, 0.27777777777778
78949, 1.3304347826087, 0.033333333333333, 0.27777777777778
78950, 1.3304347826087, 0.016666666666667, 0.25
78951, 1.3086956521739, 0.016666666666667, 0.22222222222222
78952, 1.3304347826087, 0.033333333333333, 0.22222222222222
78953, 1.3304347826087, 0.016666666666667, 0.19444444444444
78954, 1.3086956521739, 0.016666666666667, 0.16666666666667
78955, 1.3304347826087, 0.033333333333333, 0.16666666666667
78956, 1.3304347826087, 0.016666666666667, 0.13888888888889
78957, 1.3086956521739, 0.016666666666667, 0.11111111111111
78958, 1.3304347826087, 0.033333333333333, 0.11111111111111
78959, 1.3304347826087, 0.016666666666667, 0.083333333333333
78960, 1.3086956521739, 0.016666666666667, 0.055555555555556
78961, 1.3304347826087, 0.033333333333333, 0.055555555555556
78962, 1.3304347826087, 0.016666666666667, 0.027777777777778
78963, 1.3739130434783, 0.016666666666667, 0.47222222222222
78964, 1.3521739130435, 0.016666666666667, 0.44444444444444
78965, 1.3739130434783, 0.033333333333333, 0.44444444444444
78966, 1.3739130434783, 0.016666666666667, 0.41666666666667
78967, 1.3521739130435, 0.016666666666667, 0.38888888888889
78968, 1.3739130434783, 0.033333333333333, 0.38888888888889
78969, 1.3739130434783, 0.016666666666667, 0.36111111111111
78970, 1.3521739130435, 0.016666666666667, 0.33333333333333
78971, 1.3739130434783, 0.033333333333333, 0.33333333333333
78972, 1.3739130434783, 0.016666666666667, 0.30555555555556
78973, 1.3521739130435, 0.016666666666667, 0.27777777777778
78974, 1.3739130434783, 0.033333333333333, 0.27777777777778
78975, 1.3739130434783, 0.016666666666667, 0.25
78976, 1.3521739130435, 0.016666666666667, 0.22222222222222
78977, 1.3739130434783, 0.033333333333333, 0.22222222222222
78978, 1.3739130434783, 0.016666666666667, 0.19444444444444
78979, 1.3521739130435, 0.016666666666667, 0.16666666666667
78980, 1.3739130434783, 0.033333333333333, 0.16666666666667
78981, 1.3739130434783, 0.016666666666667, 0.13888888888889
78982, 1.3521739130435, 0.016666666666667, 0.11111111111111
78983, 1.3739130434783, 0.033333333333333, 0.11111111111111
78984, 1.3739130434783, 0.016666666666667, 0.083333333333333
78985, 1.3521739130435, 0.016666666666667, 0.055555555555556
78986, 1.3739130434783, 0.033333333333333, 0.055555555555556
78987, 1.3739130434783, 0.016666666666667, 0.027777777777778
78988, 1.4173913043478, 0.016666666666667, 0.47222222222222
78989, 1.395652173913, 0.016666666666667, 0.44444444444444
78990, 1.4173913043478, 0.033333333333333, 0.44444444444444
78991, 1.4173913043478, 0.016666666666667, 0.41666666666667
78992, 1.395652173913, 0.016666666666667, 0.38888888888889
78993, 1.4173913043478, 0.033333333333333, 0.38888888888889
78994, 1.4173913043478, 0.016666666666667, 0.36111111111111
78995, 1.395652173913, 0.016666666666667, 0.33333333333333
78996, 1.4173913043478, 0.033333333333333, 0.33333333333333
78997, 1.4173913043478, 0.016666666666667, 0.30555555555556
78998, 1.395652173913, 0.016666666666667, 0.27777777777778
78999, 1.4173913043478, 0.033333333333333, 0.27777777777778
79000, 1.4173913043478, 0.016666666666667, 0.25
79001, 1.395652173913, 0.016666666666667, 0.22222222222222
79002, 1.4173913043478, 0.033333333333333, 0.22222222222222
79003, 1.4173913043478, 0.016666666666667, 0.19444444444444
79004, 1.395652173913, 0.016666666666667, 0.16666666666667
79005, 1.4173913043478, 0.033333333333333, 0.16666666666667
79006, 1.4173913043478, 0.016666666666667, 0.13888888888889
79007, 1.395652173913, 0.016666666666667, 0.11111111111111
79008, 1.4173913043478, 0.033333333333333, 0.11111111111111
79009, 1.4173913043478, 0.016666666666667, 0.083333333333333
79010, 1.395652173913, 0.016666666666667, 0.055555555555556
79011, 1.4173913043478, 0.033333333333333, 0.055555555555556
79012, 1.4173913043478, 0.016666666666667, 0.027777777777778
79013, 1.4608695652174, 0.016666666666667, 0.47222222222222
79014, 1.4391304347826, 0.016666666666667, 0.44444444444444
79015, 1.4608695652174, 0.033333333333333, 0.44444444444444
79016, 1.4608695652174, 0.016666666666667, 0.41666666666667
79017, 1.4391304347826, 0.016666666666667, 0.38888888888889
79018, 1.4608695652174, 0.033333333333333, 0.38888888888889
79019, 1.4608695652174, 0.016666666666667, 0.36111111111111
79020, 1.4391304347826, 0.016666666666667, 0.33333333333333
79021, 1.4608695652174, 0.033333333333333, 0.33333333333333
79022, 1.4608695652174, 0.016666666666667, 0.30555555555556
79023, 1.4391304347826, 0.016666666666667, 0.27777777777778
79024, 1.4608695652174, 0.033333333333333, 0.27777777777778
79025, 1.4608695652174, 0.016666666666667, 0.25
79026, 1.4391304347826, 0.016666666666667, 0.22222222222222
79027, 1.4608695652174, 0.033333333333333, 0.22222222222222
79028, 1.4608695652174, 0.016666666666667, 0.19444444444444
79029, 1.4391304347826, 0.016666666666667, 0.16666666666667
79030, 1.4608695652174, 0.033333333333333, 0.16666666666667
79031, 1.4608695652174, 0.016666666666667, 0.13888888888889
79032, 1.4391304347826, 0.016666666666667, 0.11111111111111
79033, 1.4608695652174, 0.033333333333333, 0.11111111111111
79034, 1.4608695652174, 0.016666666666667, 0.083333333333333
79035, 1.4391304347826, 0.016666666666667, 0.055555555555556
79036, 1.4608695652174, 0.033333333333333, 0.055555555555556
79037, 1.4608695652174, 0.016666666666667, 0.027777777777778
79038, 1.504347826087, 0.016666666666667, 0.47222222222222
79039, 1.4826086956522, 0.016666666666667, 0.44444444444444
79040, 1.504347826087, 0.033333333333333, 0.44444444444444
79041, 1.504347826087, 0.016666666666667, 0.41666666666667
79042, 1.4826086956522, 0.016666666666667, 0.38888888888889
79043, 1.504347826087, 0.033333333333333, 0.38888888888889
79044, 1.504347826087, 0.016666666666667, 0.36111111111111
79045, 1.4826086956522, 0.016666666666667, 0.33333333333333
79046, 1.504347826087, 0.033333333333333, 0.33333333333333
79047, 1.504347826087, 0.016666666666667, 0.30555555555556
79048, 1.4826086956522, 0.016666666666667, 0.27777777777778
79049, 1.504347826087, 0.033333333333333, 0.27777777777778
79050, 1.504347826087, 0.016666666666667, 0.25
79051, 1.4826086956522, 0.016666666666667, 0.22222222222222
79052, 1.504347826087, 0.033333333333333, 0.22222222222222
79053, 1.504347826087, 0.016666666666667, 0.19444444444444
79054, 1.4826086956522, 0.016666666666667, 0.16666666666667
79055, 1.504347826087, 0.033333333333333, 0.16666666666667
79056, 1.504347826087, 0.016666666666667, 0.13888888888889
79057, 1.4826086956522, 0.016666666666667, 0.11111111111111
79058, 1.504347826087, 0.033333333333333, 0.11111111111111
79059, 1.504347826087, 0.016666666666667, 0.083333333333333
79060, 1.4826086956522, 0.016666666666667, 0.055555555555556
79061, 1.504347826087, 0.033333333333333, 0.055555555555556
79062, 1.504347826087, 0.016666666666667, 0.027777777777778
79063, 1.5478260869565, 0.016666666666667, 0.47222222222222
79064, 1.5260869565217, 0.016666666666667, 0.44444444444444
79065, 1.5478260869565, 0.033333333333333, 0.44444444444444
79066, 1.5478260869565, 0.016666666666667, 0.41666666666667
79067, 1.5260869565217, 0.016666666666667, 0.38888888888889
79068, 1.5478260869565, 0.033333333333333, 0.38888888888889
79069, 1.5478260869565, 0.016666666666667, 0.36111111111111
79070, 1.5260869565217, 0.016666666666667, 0.33333333333333
79071, 1.5478260869565, 0.033333333333333, 0.33333333333333
79072, 1.5478260869565, 0.016666666666667, 0.30555555555556
79073, 1.5260869565217, 0.016666666666667, 0.27777777777778
79074, 1.5478260869565, 0.033333333333333, 0.27777777777778
79075, 1.5478260869565, 0.016666666666667, 0.25
79076, 1.5260869565217, 0.016666666666667, 0.22222222222222
79077, 1.5478260869565, 0.033333333333333, 0.22222222222222
79078, 1.5478260869565, 0.016666666666667, 0.19444444444444
79079, 1.5260869565217, 0.016666666666667, 0.16666666666667
79080, 1.5478260869565, 0.033333333333333, 0.16666666666667
79081, 1.5478260869565, 0.016666666666667, 0.13888888888889
79082, 1.5260869565217, 0.016666666666667, 0.11111111111111
79083, 1.5478260869565, 0.033333333333333, 0.11111111111111
79084, 1.5478260869565, 0.016666666666667, 0.083333333333333
79085, 1.5260869565217, 0.016666666666667, 0.055555555555556
79086, 1.5478260869565, 0.033333333333333, 0.055555555555556
79087, 1.5478260869565, 0.016666666666667, 0.027777777777778
79088, 1.5913043478261, 0.016666666666667, 0.47222222222222
79089, 1.5695652173913, 0.016666666666667, 0.44444444444444
79090, 1.5913043478261, 0.033333333333333, 0.44444444444444
79091, 1.5913043478261, 0.016666666666667, 0.41666666666667
79092, 1.5695652173913, 0.016666666666667, 0.38888888888889
79093, 1.5913043478261, 0.033333333333333, 0.38888888888889
79094, 1.5913043478261, 0.016666666666667, 0.36111111111111
79095, 1.5695652173913, 0.016666666666667, 0.33333333333333
79096, 1.5913043478261, 0.033333333333333, 0.33333333333333
79097, 1.5913043478261, 0.016666666666667, 0.30555555555556
79098, 1.5695652173913, 0.016666666666667, 0.27777777777778
79099, 1.5913043478261, 0.033333333333333, 0.27777777777778
79100, 1.5913043478261, 0.016666666666667, 0.25
79101, 1.5695652173913, 0.016666666666667, 0.22222222222222
79102, 1.5913043478261, 0.033333333333333, 0.22222222222222
79103, 1.5913043478261, 0.016666666666667, 0.19444444444444
79104, 1.5695652173913, 0.016666666666667, 0.16666666666667
79105, 1.5913043478261, 0.033333333333333, 0.16666666666667
79106, 1.5913043478261, 0.016666666666667, 0.13888888888889
79107, 1.5695652173913, 0.016666666666667, 0.11111111111111
79108, 1.5913043478261, 0.033333333333333, 0.11111111111111
79109, 1.5913043478261, 0.016666666666667, 0.083333333333333
79110, 1.5695652173913, 0.016666666666667, 0.055555555555556
79111, 1.5913043478261, 0.033333333333333, 0.055555555555556
79112, 1.5913043478261, 0.016666666666667, 0.027777777777778
79113, 1.6347826086957, 0.016666666666667, 0.47222222222222
79114, 1.6130434782609, 0.016666666666667, 0.44444444444444
79115, 1.6347826086957, 0.033333333333333, 0.44444444444444
79116, 1.6347826086957, 0.016666666666667, 0.41666666666667
79117, 1.6130434782609, 0.016666666666667, 0.38888888888889
79118, 1.6347826086957, 0.033333333333333, 0.38888888888889
79119, 1.6347826086957, 0.016666666666667, 0.36111111111111
79120, 1.6130434782609, 0.016666666666667, 0.33333333333333
79121, 1.6347826086957, 0.033333333333333, 0.33333333333333
79122, 1.6347826086957, 0.016666666666667, 0.30555555555556
79123, 1.6130434782609, 0.016666666666667, 0.27777777777778
79124, 1.6347826086957, 0.033333333333333, 0.27777777777778
79125, 1.6347826086957, 0.016666666666667, 0.25
79126, 1.6130434782609, 0.016666666666667, 0.22222222222222
79127, 1.6347826086957, 0.033333333333333, 0.22222222222222
79128, 1.6347826086957, 0.016666666666667, 0.19444444444444
79129, 1.6130434782609, 0.016666666666667, 0.16666666666667
79130, 1.6347826086957, 0.033333333333333, 0.16666666666667
79131, 1.6347826086957, 0.016666666666667, 0.13888888888889
79132, 1.6130434782609, 0.016666666666667, 0.11111111111111
79133, 1.6347826086957, 0.033333333333333, 0.11111111111111
79134, 1.6347826086957, 0.016666666666667, 0.083333333333333
79135, 1.6130434782609, 0.016666666666667, 0.055555555555556
79136, 1.6347826086957, 0.033333333333333, 0.055555555555556
79137, 1.6347826086957, 0.016666666666667, 0.027777777777778
79138, 1.6782608695652, 0.016666666666667, 0.47222222222222
79139, 1.6565217391304, 0.016666666666667, 0.44444444444444
79140, 1.6782608695652, 0.033333333333333, 0.44444444444444
79141, 1.6782608695652, 0.016666666666667, 0.41666666666667
79142, 1.6565217391304, 0.016666666666667, 0.38888888888889
79143, 1.6782608695652, 0.033333333333333, 0.38888888888889
79144, 1.6782608695652, 0.016666666666667, 0.36111111111111
79145, 1.6565217391304, 0.016666666666667, 0.33333333333333
79146, 1.6782608695652, 0.033333333333333, 0.33333333333333
79147, 1.6782608695652, 0.016666666666667, 0.30555555555556
79148, 1.6565217391304, 0.016666666666667, 0.27777777777778
79149, 1.6782608695652, 0.033333333333333, 0.27777777777778
79150, 1.6782608695652, 0.016666666666667, 0.25
79151, 1.6565217391304, 0.016666666666667, 0.22222222222222
79152, 1.6782608695652, 0.033333333333333, 0.22222222222222
79153, 1.6782608695652, 0.016666666666667, 0.19444444444444
79154, 1.6565217391304, 0.016666666666667, 0.16666666666667
79155, 1.6782608695652, 0.033333333333333, 0.16666666666667
79156, 1.6782608695652, 0.016666666666667, 0.13888888888889
79157, 1.6565217391304, 0.016666666666667, 0.11111111111111
79158, 1.6782608695652, 0.033333333333333, 0.11111111111111
79159, 1.6782608695652, 0.016666666666667, 0.083333333333333
79160, 1.6565217391304, 0.016666666666667, 0.055555555555556
79161, 1.6782608695652, 0.033333333333333, 0.055555555555556
79162, 1.6782608695652, 0.016666666666667, 0.027777777777778
79163, 1.7217391304348, 0.016666666666667, 0.47222222222222
79164, 1.7, 0.016666666666667, 0.44444444444444
79165, 1.7217391304348, 0.033333333333333, 0.44444444444444
79166, 1.7217391304348, 0.016666666666667, 0.41666666666667
79167, 1.7, 0.016666666666667, 0.38888888888889
79168, 1.7217391304348, 0.033333333333333, 0.38888888888889
79169, 1.7217391304348, 0.016666666666667, 0.36111111111111
79170, 1.7, 0.016666666666667, 0.33333333333333
79171, 1.7217391304348, 0.033333333333333, 0.33333333333333
79172, 1.7217391304348, 0.016666666666667, 0.30555555555556
79173, 1.7, 0.016666666666667, 0.27777777777778
79174, 1.7217391304348, 0.033333333333333, 0.27777777777778
79175, 1.7217391304348, 0.016666666666667, 0.25
79176, 1.7, 0.016666666666667, 0.22222222222222
79177, 1.7217391304348, 0.033333333333333, 0.22222222222222
79178, 1.7217391304348, 0.016666666666667, 0.19444444444444
79179, 1.7, 0.016666666666667, 0.16666666666667
79180, 1.7217391304348, 0.033333333333333, 0.16666666666667
79181, 1.7217391304348, 0.016666666666667, 0.13888888888889
79182, 1.7, 0.016666666666667, 0.11111111111111
79183, 1.7217391304348, 0.033333333333333, 0.11111111111111
79184, 1.7217391304348, 0.016666666666667, 0.083333333333333
79185, 1.7, 0.016666666666667, 0.055555555555556
79186, 1.7217391304348, 0.033333333333333, 0.055555555555556
79187, 1.7217391304348, 0.016666666666667, 0.027777777777778
79188, 1.7652173913043, 0.016666666666667, 0.47222222222222
79189, 1.7434782608696, 0.016666666666667, 0.44444444444444
79190, 1.7652173913043, 0.033333333333333, 0.44444444444444
79191, 1.7652173913043, 0.016666666666667, 0.41666666666667
79192, 1.7434782608696, 0.016666666666667, 0.38888888888889
79193, 1.7652173913043, 0.033333333333333, 0.38888888888889
79194, 1.7652173913043, 0.016666666666667, 0.36111111111111
79195, 1.7434782608696, 0.016666666666667, 0.33333333333333
79196, 1.7652173913043, 0.033333333333333, 0.33333333333333
79197, 1.7652173913043, 0.016666666666667, 0.30555555555556
79198, 1.7434782608696, 0.016666666666667, 0.27777777777778
79199, 1.7652173913043, 0.033333333333333, 0.27777777777778
79200, 1.7652173913043, 0.016666666666667, 0.25
79201, 1.7434782608696, 0.016666666666667, 0.22222222222222
79202, 1.7652173913043, 0.033333333333333, 0.22222222222222
79203, 1.7652173913043, 0.016666666666667, 0.19444444444444
79204, 1.7434782608696, 0.016666666666667, 0.16666666666667
79205, 1.7652173913043, 0.033333333333333, 0.16666666666667
79206, 1.7652173913043, 0.016666666666667, 0.13888888888889
79207, 1.7434782608696, 0.016666666666667, 0.11111111111111
79208, 1.7652173913043, 0.033333333333333, 0.11111111111111
79209, 1.7652173913043, 0.016666666666667, 0.083333333333333
79210, 1.7434782608696, 0.016666666666667, 0.055555555555556
79211, 1.7652173913043, 0.033333333333333, 0.055555555555556
79212, 1.7652173913043, 0.016666666666667, 0.027777777777778
79213, 1.8086956521739, 0.016666666666667, 0.47222222222222
79214, 1.7869565217391, 0.016666666666667, 0.44444444444444
79215, 1.8086956521739, 0.033333333333333, 0.44444444444444
79216, 1.8086956521739, 0.016666666666667, 0.41666666666667
79217, 1.7869565217391, 0.016666666666667, 0.38888888888889
79218, 1.8086956521739, 0.033333333333333, 0.38888888888889
79219, 1.8086956521739, 0.016666666666667, 0.36111111111111
79220, 1.7869565217391, 0.016666666666667, 0.33333333333333
79221, 1.8086956521739, 0.033333333333333, 0.33333333333333
79222, 1.8086956521739, 0.016666666666667, 0.30555555555556
79223, 1.7869565217391, 0.016666666666667, 0.27777777777778
79224, 1.8086956521739, 0.033333333333333, 0.27777777777778
79225, 1.8086956521739, 0.016666666666667, 0.25
79226, 1.7869565217391, 0.016666666666667, 0.22222222222222
79227, 1.8086956521739, 0.033333333333333, 0.22222222222222
79228, 1.8086956521739, 0.016666666666667, 0.19444444444444
79229, 1.7869565217391, 0.016666666666667, 0.16666666666667
79230, 1.8086956521739, 0.033333333333333, 0.16666666666667
79231, 1.8086956521739, 0.016666666666667, 0.13888888888889
79232, 1.7869565217391, 0.016666666666667, 0.11111111111111
79233, 1.8086956521739, 0.033333333333333, 0.11111111111111
79234, 1.8086956521739, 0.016666666666667, 0.083333333333333
79235, 1.7869565217391, 0.016666666666667, 0.055555555555556
79236, 1.8086956521739, 0.033333333333333, 0.055555555555556
79237, 1.8086956521739, 0.016666666666667, 0.027777777777778
79238, 1.8521739130435, 0.016666666666667, 0.47222222222222
79239, 1.8304347826087, 0.016666666666667, 0.44444444444444
79240, 1.8521739130435, 0.033333333333333, 0.44444444444444
79241, 1.8521739130435, 0.016666666666667, 0.41666666666667
79242, 1.8304347826087, 0.016666666666667, 0.38888888888889
79243, 1.8521739130435, 0.033333333333333, 0.38888888888889
79244, 1.8521739130435, 0.016666666666667, 0.36111111111111
79245, 1.8304347826087, 0.016666666666667, 0.33333333333333
79246, 1.8521739130435, 0.033333333333333, 0.33333333333333
79247, 1.8521739130435, 0.016666666666667, 0.30555555555556
79248, 1.8304347826087, 0.016666666666667, 0.27777777777778
79249, 1.8521739130435, 0.033333333333333, 0.27777777777778
79250, 1.8521739130435, 0.016666666666667, 0.25
79251, 1.8304347826087, 0.016666666666667, 0.22222222222222
79252, 1.8521739130435, 0.033333333333333, 0.22222222222222
79253, 1.8521739130435, 0.016666666666667, 0.19444444444444
79254, 1.8304347826087, 0.016666666666667, 0.16666666666667
79255, 1.8521739130435, 0.033333333333333, 0.16666666666667
79256, 1.8521739130435, 0.016666666666667, 0.13888888888889
79257, 1.8304347826087, 0.016666666666667, 0.11111111111111
79258, 1.8521739130435, 0.033333333333333, 0.11111111111111
79259, 1.8521739130435, 0.016666666666667, 0.083333333333333
79260, 1.8304347826087, 0.016666666666667, 0.055555555555556
79261, 1.8521739130435, 0.033333333333333, 0.055555555555556
79262, 1.8521739130435, 0.016666666666667, 0.027777777777778
79263, 1.895652173913, 0.016666666666667, 0.47222222222222
79264, 1.8739130434783, 0.016666666666667, 0.44444444444444
79265, 1.895652173913, 0.033333333333333, 0.44444444444444
79266, 1.895652173913, 0.016666666666667, 0.41666666666667
79267, 1.8739130434783, 0.016666666666667, 0.38888888888889
79268, 1.895652173913, 0.033333333333333, 0.38888888888889
79269, 1.895652173913, 0.016666666666667, 0.36111111111111
79270, 1.8739130434783, 0.016666666666667, 0.33333333333333
79271, 1.895652173913, 0.033333333333333, 0.33333333333333
79272, 1.895652173913, 0.016666666666667, 0.30555555555556
79273, 1.8739130434783, 0.016666666666667, 0.27777777777778
79274, 1.895652173913, 0.033333333333333, 0.27777777777778
79275, 1.895652173913, 0.016666666666667, 0.25
79276, 1.8739130434783, 0.016666666666667, 0.22222222222222
79277, 1.895652173913, 0.033333333333333, 0.22222222222222
79278, 1.895652173913, 0.016666666666667, 0.19444444444444
79279, 1.8739130434783, 0.016666666666667, 0.16666666666667
79280, 1.895652173913, 0.033333333333333, 0.16666666666667
79281, 1.895652173913, 0.016666666666667, 0.13888888888889
79282, 1.8739130434783, 0.016666666666667, 0.11111111111111
79283, 1.895652173913, 0.033333333333333, 0.11111111111111
79284, 1.895652173913, 0.016666666666667, 0.083333333333333
79285, 1.8739130434783, 0.016666666666667, 0.055555555555556
79286, 1.895652173913, 0.033333333333333, 0.055555555555556
79287, 1.895652173913, 0.016666666666667, 0.027777777777778
79288, 1.9391304347826, 0.016666666666667, 0.47222222222222
79289, 1.9173913043478, 0.016666666666667, 0.44444444444444
79290, 1.9391304347826, 0.033333333333333, 0.44444444444444
79291, 1.9391304347826, 0.016666666666667, 0.41666666666667
79292, 1.9173913043478, 0.016666666666667, 0.38888888888889
79293, 1.9391304347826, 0.033333333333333, 0.38888888888889
79294, 1.9391304347826, 0.016666666666667, 0.36111111111111
79295, 1.9173913043478, 0.016666666666667, 0.33333333333333
79296, 1.9391304347826, 0.033333333333333, 0.33333333333333
79297, 1.9391304347826, 0.016666666666667, 0.30555555555556
79298, 1.9173913043478, 0.016666666666667, 0.27777777777778
79299, 1.9391304347826, 0.033333333333333, 0.27777777777778
79300, 1.9391304347826, 0.016666666666667, 0.25
79301, 1.9173913043478, 0.016666666666667, 0.22222222222222
79302, 1.9391304347826, 0.033333333333333, 0.22222222222222
79303, 1.9391304347826, 0.016666666666667, 0.19444444444444
79304, 1.9173913043478, 0.016666666666667, 0.16666666666667
79305, 1.9391304347826, 0.033333333333333, 0.16666666666667
79306, 1.9391304347826, 0.016666666666667, 0.13888888888889
79307, 1.9173913043478, 0.016666666666667, 0.11111111111111
79308, 1.9391304347826, 0.033333333333333, 0.11111111111111
79309, 1.9391304347826, 0.016666666666667, 0.083333333333333
79310, 1.9173913043478, 0.016666666666667, 0.055555555555556
79311, 1.9391304347826, 0.033333333333333, 0.055555555555556
79312, 1.9391304347826, 0.016666666666667, 0.027777777777778
79313, 1.9826086956522, 0.016666666666667, 0.47222222222222
79314, 1.9608695652174, 0.016666666666667, 0.44444444444444
79315, 1.9826086956522, 0.033333333333333, 0.44444444444444
79316, 1.9826086956522, 0.016666666666667, 0.41666666666667
79317, 1.9608695652174, 0.016666666666667, 0.38888888888889
79318, 1.9826086956522, 0.033333333333333, 0.38888888888889
79319, 1.9826086956522, 0.016666666666667, 0.36111111111111
79320, 1.9608695652174, 0.016666666666667, 0.33333333333333
79321, 1.9826086956522, 0.033333333333333, 0.33333333333333
79322, 1.9826086956522, 0.016666666666667, 0.30555555555556
79323, 1.9608695652174, 0.016666666666667, 0.27777777777778
79324, 1.9826086956522, 0.033333333333333, 0.27777777777778
79325, 1.9826086956522, 0.016666666666667, 0.25
79326, 1.9608695652174, 0.016666666666667, 0.22222222222222
79327, 1.9826086956522, 0.033333333333333, 0.22222222222222
79328, 1.9826086956522, 0.016666666666667, 0.19444444444444
79329, 1.9608695652174, 0.016666666666667, 0.16666666666667
79330, 1.9826086956522, 0.033333333333333, 0.16666666666667
79331, 1.9826086956522, 0.016666666666667, 0.13888888888889
