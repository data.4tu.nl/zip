21466, 56083, 12222, 12214, 56091, 15267, 1573, 1572, 15268, 56817, 12460, 56825, 56554, 15334, 1595, 15335, 
15306, 56531, 12461, 12444, 56556
21467, 15146, 1438, 1437, 15147, 56084, 12207, 12199, 56092, 15213, 1460, 15214, 15187, 56818, 12429, 56826, 
56558, 56532, 12428, 12411, 56557
21468, 56084, 12207, 12199, 56092, 56085, 12208, 12200, 56093, 56818, 12429, 56826, 56558, 56819, 12431, 56827, 
56561, 56535, 12430, 12413, 56560
21469, 56085, 12208, 12200, 56093, 56086, 12209, 12201, 56094, 56819, 12431, 56827, 56561, 56820, 12433, 56828, 
56564, 56538, 12432, 12415, 56563
21470, 56086, 12209, 12201, 56094, 56087, 12210, 12202, 56095, 56820, 12433, 56828, 56564, 56821, 12435, 56829, 
56567, 56541, 12434, 12417, 56566
21471, 56087, 12210, 12202, 56095, 56088, 12211, 12203, 56096, 56821, 12435, 56829, 56567, 56822, 12437, 56830, 
56570, 56544, 12436, 12419, 56569
21472, 56088, 12211, 12203, 56096, 56089, 12212, 12204, 56097, 56822, 12437, 56830, 56570, 56823, 12439, 56831, 
56573, 56547, 12438, 12421, 56572
21473, 56089, 12212, 12204, 56097, 56090, 12213, 12205, 56098, 56823, 12439, 56831, 56573, 56824, 12441, 56832, 
56576, 56550, 12440, 12423, 56575
21474, 56090, 12213, 12205, 56098, 56091, 12214, 12206, 56099, 56824, 12441, 56832, 56576, 56825, 12443, 56833, 
56579, 56553, 12442, 12425, 56578
21475, 56091, 12214, 12206, 56099, 15268, 1572, 1571, 15269, 56825, 12443, 56833, 56579, 15335, 1594, 15336, 
15308, 56556, 12444, 12427, 56581
21476, 15147, 1437, 1436, 15148, 56092, 12199, 12191, 56100, 15214, 1459, 15215, 15189, 56826, 12412, 56834, 
56583, 56557, 12411, 12394, 56582
21477, 56092, 12199, 12191, 56100, 56093, 12200, 12192, 56101, 56826, 12412, 56834, 56583, 56827, 12414, 56835, 
56586, 56560, 12413, 12396, 56585
21478, 56093, 12200, 12192, 56101, 56094, 12201, 12193, 56102, 56827, 12414, 56835, 56586, 56828, 12416, 56836, 
56589, 56563, 12415, 12398, 56588
21479, 56094, 12201, 12193, 56102, 56095, 12202, 12194, 56103, 56828, 12416, 56836, 56589, 56829, 12418, 56837, 
56592, 56566, 12417, 12400, 56591
21480, 56095, 12202, 12194, 56103, 56096, 12203, 12195, 56104, 56829, 12418, 56837, 56592, 56830, 12420, 56838, 
56595, 56569, 12419, 12402, 56594
21481, 56096, 12203, 12195, 56104, 56097, 12204, 12196, 56105, 56830, 12420, 56838, 56595, 56831, 12422, 56839, 
56598, 56572, 12421, 12404, 56597
21482, 56097, 12204, 12196, 56105, 56098, 12205, 12197, 56106, 56831, 12422, 56839, 56598, 56832, 12424, 56840, 
56601, 56575, 12423, 12406, 56600
21483, 56098, 12205, 12197, 56106, 56099, 12206, 12198, 56107, 56832, 12424, 56840, 56601, 56833, 12426, 56841, 
56604, 56578, 12425, 12408, 56603
21484, 56099, 12206, 12198, 56107, 15269, 1571, 1570, 15270, 56833, 12426, 56841, 56604, 15336, 1593, 15337, 
15310, 56581, 12427, 12410, 56606
21485, 15148, 1436, 1435, 15149, 56100, 12191, 12183, 56108, 15215, 1458, 15216, 15191, 56834, 12395, 56842, 
56608, 56582, 12394, 12377, 56607
21486, 56100, 12191, 12183, 56108, 56101, 12192, 12184, 56109, 56834, 12395, 56842, 56608, 56835, 12397, 56843, 
56611, 56585, 12396, 12379, 56610
21487, 56101, 12192, 12184, 56109, 56102, 12193, 12185, 56110, 56835, 12397, 56843, 56611, 56836, 12399, 56844, 
56614, 56588, 12398, 12381, 56613
21488, 56102, 12193, 12185, 56110, 56103, 12194, 12186, 56111, 56836, 12399, 56844, 56614, 56837, 12401, 56845, 
56617, 56591, 12400, 12383, 56616
21489, 56103, 12194, 12186, 56111, 56104, 12195, 12187, 56112, 56837, 12401, 56845, 56617, 56838, 12403, 56846, 
56620, 56594, 12402, 12385, 56619
21490, 56104, 12195, 12187, 56112, 56105, 12196, 12188, 56113, 56838, 12403, 56846, 56620, 56839, 12405, 56847, 
56623, 56597, 12404, 12387, 56622
21491, 56105, 12196, 12188, 56113, 56106, 12197, 12189, 56114, 56839, 12405, 56847, 56623, 56840, 12407, 56848, 
56626, 56600, 12406, 12389, 56625
21492, 56106, 12197, 12189, 56114, 56107, 12198, 12190, 56115, 56840, 12407, 56848, 56626, 56841, 12409, 56849, 
56629, 56603, 12408, 12391, 56628
21493, 56107, 12198, 12190, 56115, 15270, 1570, 1569, 15271, 56841, 12409, 56849, 56629, 15337, 1592, 15338, 
15312, 56606, 12410, 12393, 56631
21494, 15149, 1435, 1434, 15150, 56108, 12183, 12175, 56116, 15216, 1457, 15217, 15193, 56842, 12378, 56850, 
56633, 56607, 12377, 12360, 56632
21495, 56108, 12183, 12175, 56116, 56109, 12184, 12176, 56117, 56842, 12378, 56850, 56633, 56843, 12380, 56851, 
56636, 56610, 12379, 12362, 56635
21496, 56109, 12184, 12176, 56117, 56110, 12185, 12177, 56118, 56843, 12380, 56851, 56636, 56844, 12382, 56852, 
56639, 56613, 12381, 12364, 56638
21497, 56110, 12185, 12177, 56118, 56111, 12186, 12178, 56119, 56844, 12382, 56852, 56639, 56845, 12384, 56853, 
56642, 56616, 12383, 12366, 56641
21498, 56111, 12186, 12178, 56119, 56112, 12187, 12179, 56120, 56845, 12384, 56853, 56642, 56846, 12386, 56854, 
56645, 56619, 12385, 12368, 56644
21499, 56112, 12187, 12179, 56120, 56113, 12188, 12180, 56121, 56846, 12386, 56854, 56645, 56847, 12388, 56855, 
56648, 56622, 12387, 12370, 56647
21500, 56113, 12188, 12180, 56121, 56114, 12189, 12181, 56122, 56847, 12388, 56855, 56648, 56848, 12390, 56856, 
56651, 56625, 12389, 12372, 56650
21501, 56114, 12189, 12181, 56122, 56115, 12190, 12182, 56123, 56848, 12390, 56856, 56651, 56849, 12392, 56857, 
56654, 56628, 12391, 12374, 56653
21502, 56115, 12190, 12182, 56123, 15271, 1569, 1568, 15272, 56849, 12392, 56857, 56654, 15338, 1591, 15339, 
15314, 56631, 12393, 12376, 56656
21503, 15150, 1434, 1433, 15151, 56116, 12175, 12167, 56124, 15217, 1456, 15218, 15195, 56850, 12361, 56858, 
56658, 56632, 12360, 12343, 56657
21504, 56116, 12175, 12167, 56124, 56117, 12176, 12168, 56125, 56850, 12361, 56858, 56658, 56851, 12363, 56859, 
56661, 56635, 12362, 12345, 56660
21505, 56117, 12176, 12168, 56125, 56118, 12177, 12169, 56126, 56851, 12363, 56859, 56661, 56852, 12365, 56860, 
56664, 56638, 12364, 12347, 56663
21506, 56118, 12177, 12169, 56126, 56119, 12178, 12170, 56127, 56852, 12365, 56860, 56664, 56853, 12367, 56861, 
56667, 56641, 12366, 12349, 56666
21507, 56119, 12178, 12170, 56127, 56120, 12179, 12171, 56128, 56853, 12367, 56861, 56667, 56854, 12369, 56862, 
56670, 56644, 12368, 12351, 56669
21508, 56120, 12179, 12171, 56128, 56121, 12180, 12172, 56129, 56854, 12369, 56862, 56670, 56855, 12371, 56863, 
56673, 56647, 12370, 12353, 56672
21509, 56121, 12180, 12172, 56129, 56122, 12181, 12173, 56130, 56855, 12371, 56863, 56673, 56856, 12373, 56864, 
56676, 56650, 12372, 12355, 56675
21510, 56122, 12181, 12173, 56130, 56123, 12182, 12174, 56131, 56856, 12373, 56864, 56676, 56857, 12375, 56865, 
56679, 56653, 12374, 12357, 56678
21511, 56123, 12182, 12174, 56131, 15272, 1568, 1567, 15273, 56857, 12375, 56865, 56679, 15339, 1590, 15340, 
15316, 56656, 12376, 12359, 56681
21512, 15151, 1433, 47, 2023, 56124, 12167, 1657, 15348, 15218, 1455, 2025, 15196, 56858, 12344, 15373, 
56682, 56657, 12343, 1665, 15365
21513, 56124, 12167, 1657, 15348, 56125, 12168, 1658, 15347, 56858, 12344, 15373, 56682, 56859, 12346, 15372, 
56683, 56660, 12345, 1666, 15363
21514, 56125, 12168, 1658, 15347, 56126, 12169, 1659, 15346, 56859, 12346, 15372, 56683, 56860, 12348, 15371, 
56684, 56663, 12347, 1667, 15361
21515, 56126, 12169, 1659, 15346, 56127, 12170, 1660, 15345, 56860, 12348, 15371, 56684, 56861, 12350, 15370, 
56685, 56666, 12349, 1668, 15359
21516, 56127, 12170, 1660, 15345, 56128, 12171, 1661, 15344, 56861, 12350, 15370, 56685, 56862, 12352, 15369, 
56686, 56669, 12351, 1669, 15357
21517, 56128, 12171, 1661, 15344, 56129, 12172, 1662, 15343, 56862, 12352, 15369, 56686, 56863, 12354, 15368, 
56687, 56672, 12353, 1670, 15355
21518, 56129, 12172, 1662, 15343, 56130, 12173, 1663, 15342, 56863, 12354, 15368, 56687, 56864, 12356, 15367, 
56688, 56675, 12355, 1671, 15353
21519, 56130, 12173, 1663, 15342, 56131, 12174, 1664, 15341, 56864, 12356, 15367, 56688, 56865, 12358, 15366, 
56689, 56678, 12357, 1672, 15351
21520, 56131, 12174, 1664, 15341, 15273, 1567, 51, 2091, 56865, 12358, 15366, 56689, 15340, 1589, 2093, 
15318, 56681, 12359, 1673, 15349
*ELEMENT, type=C3D20, ELSET=Volume5
21521, 45, 1423, 11739, 1454, 1528, 11902, 56866, 12335, 1425, 11784, 11783, 1477, 11925, 57219, 57220, 
12717, 1536, 11927, 57218, 12700
21522, 1528, 11902, 56866, 12335, 1529, 11901, 56867, 12336, 11925, 57219, 57220, 12717, 11923, 57222, 57223, 
12718, 1537, 11926, 57221, 12702
21523, 1529, 11901, 56867, 12336, 1530, 11900, 56868, 12337, 11923, 57222, 57223, 12718, 11921, 57225, 57226, 
12719, 1538, 11924, 57224, 12704
21524, 1530, 11900, 56868, 12337, 1531, 11899, 56869, 12338, 11921, 57225, 57226, 12719, 11919, 57228, 57229, 
12720, 1539, 11922, 57227, 12706
21525, 1531, 11899, 56869, 12338, 1532, 11898, 56870, 12339, 11919, 57228, 57229, 12720, 11917, 57231, 57232, 
12721, 1540, 11920, 57230, 12708
21526, 1532, 11898, 56870, 12339, 1533, 11897, 56871, 12340, 11917, 57231, 57232, 12721, 11915, 57234, 57235, 
12722, 1541, 11918, 57233, 12710
21527, 1533, 11897, 56871, 12340, 1534, 11896, 56872, 12341, 11915, 57234, 57235, 12722, 11913, 57237, 57238, 
12723, 1542, 11916, 57236, 12712
21528, 1534, 11896, 56872, 12341, 1535, 11895, 56873, 12342, 11913, 57237, 57238, 12723, 11911, 57240, 57241, 
12724, 1543, 11914, 57239, 12714
21529, 1535, 11895, 56873, 12342, 49, 1523, 11953, 1588, 11911, 57240, 57241, 12724, 1525, 11997, 11998, 
1611, 1544, 11912, 57242, 12716
21530, 1454, 11739, 11740, 1453, 12335, 56866, 56874, 12327, 11783, 11786, 11785, 1476, 57220, 57244, 57245, 
12701, 12700, 57218, 57243, 12683
21531, 12335, 56866, 56874, 12327, 12336, 56867, 56875, 12328, 57220, 57244, 57245, 12701, 57223, 57247, 57248, 
12703, 12702, 57221, 57246, 12685
21532, 12336, 56867, 56875, 12328, 12337, 56868, 56876, 12329, 57223, 57247, 57248, 12703, 57226, 57250, 57251, 
12705, 12704, 57224, 57249, 12687
21533, 12337, 56868, 56876, 12329, 12338, 56869, 56877, 12330, 57226, 57250, 57251, 12705, 57229, 57253, 57254, 
12707, 12706, 57227, 57252, 12689
21534, 12338, 56869, 56877, 12330, 12339, 56870, 56878, 12331, 57229, 57253, 57254, 12707, 57232, 57256, 57257, 
12709, 12708, 57230, 57255, 12691
21535, 12339, 56870, 56878, 12331, 12340, 56871, 56879, 12332, 57232, 57256, 57257, 12709, 57235, 57259, 57260, 
12711, 12710, 57233, 57258, 12693
21536, 12340, 56871, 56879, 12332, 12341, 56872, 56880, 12333, 57235, 57259, 57260, 12711, 57238, 57262, 57263, 
12713, 12712, 57236, 57261, 12695
21537, 12341, 56872, 56880, 12333, 12342, 56873, 56881, 12334, 57238, 57262, 57263, 12713, 57241, 57265, 57266, 
12715, 12714, 57239, 57264, 12697
21538, 12342, 56873, 56881, 12334, 1588, 11953, 11954, 1587, 57241, 57265, 57266, 12715, 11998, 11999, 12000, 
1610, 12716, 57242, 57267, 12699
21539, 1453, 11740, 11741, 1452, 12327, 56874, 56882, 12319, 11785, 11788, 11787, 1475, 57245, 57269, 57270, 
12684, 12683, 57243, 57268, 12666
21540, 12327, 56874, 56882, 12319, 12328, 56875, 56883, 12320, 57245, 57269, 57270, 12684, 57248, 57272, 57273, 
12686, 12685, 57246, 57271, 12668
21541, 12328, 56875, 56883, 12320, 12329, 56876, 56884, 12321, 57248, 57272, 57273, 12686, 57251, 57275, 57276, 
12688, 12687, 57249, 57274, 12670
21542, 12329, 56876, 56884, 12321, 12330, 56877, 56885, 12322, 57251, 57275, 57276, 12688, 57254, 57278, 57279, 
12690, 12689, 57252, 57277, 12672
21543, 12330, 56877, 56885, 12322, 12331, 56878, 56886, 12323, 57254, 57278, 57279, 12690, 57257, 57281, 57282, 
12692, 12691, 57255, 57280, 12674
21544, 12331, 56878, 56886, 12323, 12332, 56879, 56887, 12324, 57257, 57281, 57282, 12692, 57260, 57284, 57285, 
12694, 12693, 57258, 57283, 12676
21545, 12332, 56879, 56887, 12324, 12333, 56880, 56888, 12325, 57260, 57284, 57285, 12694, 57263, 57287, 57288, 
12696, 12695, 57261, 57286, 12678
21546, 12333, 56880, 56888, 12325, 12334, 56881, 56889, 12326, 57263, 57287, 57288, 12696, 57266, 57290, 57291, 
12698, 12697, 57264, 57289, 12680
21547, 12334, 56881, 56889, 12326, 1587, 11954, 11955, 1586, 57266, 57290, 57291, 12698, 12000, 12001, 12002, 
1609, 12699, 57267, 57292, 12682
21548, 1452, 11741, 11742, 1451, 12319, 56882, 56890, 12311, 11787, 11790, 11789, 1474, 57270, 57294, 57295, 
12667, 12666, 57268, 57293, 12649
21549, 12319, 56882, 56890, 12311, 12320, 56883, 56891, 12312, 57270, 57294, 57295, 12667, 57273, 57297, 57298, 
12669, 12668, 57271, 57296, 12651
21550, 12320, 56883, 56891, 12312, 12321, 56884, 56892, 12313, 57273, 57297, 57298, 12669, 57276, 57300, 57301, 
12671, 12670, 57274, 57299, 12653
21551, 12321, 56884, 56892, 12313, 12322, 56885, 56893, 12314, 57276, 57300, 57301, 12671, 57279, 57303, 57304, 
12673, 12672, 57277, 57302, 12655
21552, 12322, 56885, 56893, 12314, 12323, 56886, 56894, 12315, 57279, 57303, 57304, 12673, 57282, 57306, 57307, 
12675, 12674, 57280, 57305, 12657
21553, 12323, 56886, 56894, 12315, 12324, 56887, 56895, 12316, 57282, 57306, 57307, 12675, 57285, 57309, 57310, 
12677, 12676, 57283, 57308, 12659
21554, 12324, 56887, 56895, 12316, 12325, 56888, 56896, 12317, 57285, 57309, 57310, 12677, 57288, 57312, 57313, 
12679, 12678, 57286, 57311, 12661
21555, 12325, 56888, 56896, 12317, 12326, 56889, 56897, 12318, 57288, 57312, 57313, 12679, 57291, 57315, 57316, 
12681, 12680, 57289, 57314, 12663
21556, 12326, 56889, 56897, 12318, 1586, 11955, 11956, 1585, 57291, 57315, 57316, 12681, 12002, 12003, 12004, 
1608, 12682, 57292, 57317, 12665
21557, 1451, 11742, 11743, 1450, 12311, 56890, 56898, 12303, 11789, 11792, 11791, 1473, 57295, 57319, 57320, 
12650, 12649, 57293, 57318, 12632
21558, 12311, 56890, 56898, 12303, 12312, 56891, 56899, 12304, 57295, 57319, 57320, 12650, 57298, 57322, 57323, 
12652, 12651, 57296, 57321, 12634
21559, 12312, 56891, 56899, 12304, 12313, 56892, 56900, 12305, 57298, 57322, 57323, 12652, 57301, 57325, 57326, 
12654, 12653, 57299, 57324, 12636
21560, 12313, 56892, 56900, 12305, 12314, 56893, 56901, 12306, 57301, 57325, 57326, 12654, 57304, 57328, 57329, 
12656, 12655, 57302, 57327, 12638
21561, 12314, 56893, 56901, 12306, 12315, 56894, 56902, 12307, 57304, 57328, 57329, 12656, 57307, 57331, 57332, 
12658, 12657, 57305, 57330, 12640
21562, 12315, 56894, 56902, 12307, 12316, 56895, 56903, 12308, 57307, 57331, 57332, 12658, 57310, 57334, 57335, 
12660, 12659, 57308, 57333, 12642
21563, 12316, 56895, 56903, 12308, 12317, 56896, 56904, 12309, 57310, 57334, 57335, 12660, 57313, 57337, 57338, 
12662, 12661, 57311, 57336, 12644
21564, 12317, 56896, 56904, 12309, 12318, 56897, 56905, 12310, 57313, 57337, 57338, 12662, 57316, 57340, 57341, 
12664, 12663, 57314, 57339, 12646
21565, 12318, 56897, 56905, 12310, 1585, 11956, 11957, 1584, 57316, 57340, 57341, 12664, 12004, 12005, 12006, 
1607, 12665, 57317, 57342, 12648
21566, 1450, 11743, 11744, 1449, 12303, 56898, 56906, 12295, 11791, 11794, 11793, 1472, 57320, 57344, 57345, 
12633, 12632, 57318, 57343, 12615
21567, 12303, 56898, 56906, 12295, 12304, 56899, 56907, 12296, 57320, 57344, 57345, 12633, 57323, 57347, 57348, 
12635, 12634, 57321, 57346, 12617
21568, 12304, 56899, 56907, 12296, 12305, 56900, 56908, 12297, 57323, 57347, 57348, 12635, 57326, 57350, 57351, 
12637, 12636, 57324, 57349, 12619
21569, 12305, 56900, 56908, 12297, 12306, 56901, 56909, 12298, 57326, 57350, 57351, 12637, 57329, 57353, 57354, 
12639, 12638, 57327, 57352, 12621
21570, 12306, 56901, 56909, 12298, 12307, 56902, 56910, 12299, 57329, 57353, 57354, 12639, 57332, 57356, 57357, 
12641, 12640, 57330, 57355, 12623
21571, 12307, 56902, 56910, 12299, 12308, 56903, 56911, 12300, 57332, 57356, 57357, 12641, 57335, 57359, 57360, 
12643, 12642, 57333, 57358, 12625
21572, 12308, 56903, 56911, 12300, 12309, 56904, 56912, 12301, 57335, 57359, 57360, 12643, 57338, 57362, 57363, 
12645, 12644, 57336, 57361, 12627
21573, 12309, 56904, 56912, 12301, 12310, 56905, 56913, 12302, 57338, 57362, 57363, 12645, 57341, 57365, 57366, 
12647, 12646, 57339, 57364, 12629
21574, 12310, 56905, 56913, 12302, 1584, 11957, 11958, 1583, 57341, 57365, 57366, 12647, 12006, 12007, 12008, 
1606, 12648, 57342, 57367, 12631
21575, 1449, 11744, 11745, 1448, 12295, 56906, 56914, 12287, 11793, 11796, 11795, 1471, 57345, 57369, 57370, 
12616, 12615, 57343, 57368, 12598
21576, 12295, 56906, 56914, 12287, 12296, 56907, 56915, 12288, 57345, 57369, 57370, 12616, 57348, 57372, 57373, 
12618, 12617, 57346, 57371, 12600
21577, 12296, 56907, 56915, 12288, 12297, 56908, 56916, 12289, 57348, 57372, 57373, 12618, 57351, 57375, 57376, 
12620, 12619, 57349, 57374, 12602
21578, 12297, 56908, 56916, 12289, 12298, 56909, 56917, 12290, 57351, 57375, 57376, 12620, 57354, 57378, 57379, 
12622, 12621, 57352, 57377, 12604
21579, 12298, 56909, 56917, 12290, 12299, 56910, 56918, 12291, 57354, 57378, 57379, 12622, 57357, 57381, 57382, 
12624, 12623, 57355, 57380, 12606
21580, 12299, 56910, 56918, 12291, 12300, 56911, 56919, 12292, 57357, 57381, 57382, 12624, 57360, 57384, 57385, 
12626, 12625, 57358, 57383, 12608
21581, 12300, 56911, 56919, 12292, 12301, 56912, 56920, 12293, 57360, 57384, 57385, 12626, 57363, 57387, 57388, 
12628, 12627, 57361, 57386, 12610
21582, 12301, 56912, 56920, 12293, 12302, 56913, 56921, 12294, 57363, 57387, 57388, 12628, 57366, 57390, 57391, 
12630, 12629, 57364, 57389, 12612
21583, 12302, 56913, 56921, 12294, 1583, 11958, 11959, 1582, 57366, 57390, 57391, 12630, 12008, 12009, 12010, 
1605, 12631, 57367, 57392, 12614
21584, 1448, 11745, 11746, 1447, 12287, 56914, 56922, 12279, 11795, 11798, 11797, 1470, 57370, 57394, 57395, 
12599, 12598, 57368, 57393, 12581
21585, 12287, 56914, 56922, 12279, 12288, 56915, 56923, 12280, 57370, 57394, 57395, 12599, 57373, 57397, 57398, 
12601, 12600, 57371, 57396, 12583
21586, 12288, 56915, 56923, 12280, 12289, 56916, 56924, 12281, 57373, 57397, 57398, 12601, 57376, 57400, 57401, 
12603, 12602, 57374, 57399, 12585
21587, 12289, 56916, 56924, 12281, 12290, 56917, 56925, 12282, 57376, 57400, 57401, 12603, 57379, 57403, 57404, 
12605, 12604, 57377, 57402, 12587
21588, 12290, 56917, 56925, 12282, 12291, 56918, 56926, 12283, 57379, 57403, 57404, 12605, 57382, 57406, 57407, 
12607, 12606, 57380, 57405, 12589
21589, 12291, 56918, 56926, 12283, 12292, 56919, 56927, 12284, 57382, 57406, 57407, 12607, 57385, 57409, 57410, 
12609, 12608, 57383, 57408, 12591
21590, 12292, 56919, 56927, 12284, 12293, 56920, 56928, 12285, 57385, 57409, 57410, 12609, 57388, 57412, 57413, 
12611, 12610, 57386, 57411, 12593
21591, 12293, 56920, 56928, 12285, 12294, 56921, 56929, 12286, 57388, 57412, 57413, 12611, 57391, 57415, 57416, 
12613, 12612, 57389, 57414, 12595
21592, 12294, 56921, 56929, 12286, 1582, 11959, 11960, 1581, 57391, 57415, 57416, 12613, 12010, 12011, 12012, 
1604, 12614, 57392, 57417, 12597
21593, 1447, 11746, 11747, 1446, 12279, 56922, 56930, 12271, 11797, 11800, 11799, 1469, 57395, 57419, 57420, 
12582, 12581, 57393, 57418, 12564
21594, 12279, 56922, 56930, 12271, 12280, 56923, 56931, 12272, 57395, 57419, 57420, 12582, 57398, 57422, 57423, 
12584, 12583, 57396, 57421, 12566
21595, 12280, 56923, 56931, 12272, 12281, 56924, 56932, 12273, 57398, 57422, 57423, 12584, 57401, 57425, 57426, 
12586, 12585, 57399, 57424, 12568
21596, 12281, 56924, 56932, 12273, 12282, 56925, 56933, 12274, 57401, 57425, 57426, 12586, 57404, 57428, 57429, 
12588, 12587, 57402, 57427, 12570
21597, 12282, 56925, 56933, 12274, 12283, 56926, 56934, 12275, 57404, 57428, 57429, 12588, 57407, 57431, 57432, 
12590, 12589, 57405, 57430, 12572
21598, 12283, 56926, 56934, 12275, 12284, 56927, 56935, 12276, 57407, 57431, 57432, 12590, 57410, 57434, 57435, 
12592, 12591, 57408, 57433, 12574
21599, 12284, 56927, 56935, 12276, 12285, 56928, 56936, 12277, 57410, 57434, 57435, 12592, 57413, 57437, 57438, 
12594, 12593, 57411, 57436, 12576
21600, 12285, 56928, 56936, 12277, 12286, 56929, 56937, 12278, 57413, 57437, 57438, 12594, 57416, 57440, 57441, 
12596, 12595, 57414, 57439, 12578
21601, 12286, 56929, 56937, 12278, 1581, 11960, 11961, 1580, 57416, 57440, 57441, 12596, 12012, 12013, 12014, 
1603, 12597, 57417, 57442, 12580
21602, 1446, 11747, 11748, 1445, 12271, 56930, 56938, 12263, 11799, 11802, 11801, 1468, 57420, 57444, 57445, 
12565, 12564, 57418, 57443, 12547
21603, 12271, 56930, 56938, 12263, 12272, 56931, 56939, 12264, 57420, 57444, 57445, 12565, 57423, 57447, 57448, 
12567, 12566, 57421, 57446, 12549
21604, 12272, 56931, 56939, 12264, 12273, 56932, 56940, 12265, 57423, 57447, 57448, 12567, 57426, 57450, 57451, 
12569, 12568, 57424, 57449, 12551
21605, 12273, 56932, 56940, 12265, 12274, 56933, 56941, 12266, 57426, 57450, 57451, 12569, 57429, 57453, 57454, 
12571, 12570, 57427, 57452, 12553
21606, 12274, 56933, 56941, 12266, 12275, 56934, 56942, 12267, 57429, 57453, 57454, 12571, 57432, 57456, 57457, 
12573, 12572, 57430, 57455, 12555
21607, 12275, 56934, 56942, 12267, 12276, 56935, 56943, 12268, 57432, 57456, 57457, 12573, 57435, 57459, 57460, 
12575, 12574, 57433, 57458, 12557
21608, 12276, 56935, 56943, 12268, 12277, 56936, 56944, 12269, 57435, 57459, 57460, 12575, 57438, 57462, 57463, 
12577, 12576, 57436, 57461, 12559
21609, 12277, 56936, 56944, 12269, 12278, 56937, 56945, 12270, 57438, 57462, 57463, 12577, 57441, 57465, 57466, 
12579, 12578, 57439, 57464, 12561
21610, 12278, 56937, 56945, 12270, 1580, 11961, 11962, 1579, 57441, 57465, 57466, 12579, 12014, 12015, 12016, 
1602, 12580, 57442, 57467, 12563
21611, 1445, 11748, 11749, 1444, 12263, 56938, 56946, 12255, 11801, 11804, 11803, 1467, 57445, 57469, 57470, 
12548, 12547, 57443, 57468, 12530
21612, 12263, 56938, 56946, 12255, 12264, 56939, 56947, 12256, 57445, 57469, 57470, 12548, 57448, 57472, 57473, 
12550, 12549, 57446, 57471, 12532
21613, 12264, 56939, 56947, 12256, 12265, 56940, 56948, 12257, 57448, 57472, 57473, 12550, 57451, 57475, 57476, 
12552, 12551, 57449, 57474, 12534
21614, 12265, 56940, 56948, 12257, 12266, 56941, 56949, 12258, 57451, 57475, 57476, 12552, 57454, 57478, 57479, 
12554, 12553, 57452, 57477, 12536
21615, 12266, 56941, 56949, 12258, 12267, 56942, 56950, 12259, 57454, 57478, 57479, 12554, 57457, 57481, 57482, 
12556, 12555, 57455, 57480, 12538
21616, 12267, 56942, 56950, 12259, 12268, 56943, 56951, 12260, 57457, 57481, 57482, 12556, 57460, 57484, 57485, 
12558, 12557, 57458, 57483, 12540
21617, 12268, 56943, 56951, 12260, 12269, 56944, 56952, 12261, 57460, 57484, 57485, 12558, 57463, 57487, 57488, 
12560, 12559, 57461, 57486, 12542
21618, 12269, 56944, 56952, 12261, 12270, 56945, 56953, 12262, 57463, 57487, 57488, 12560, 57466, 57490, 57491, 
12562, 12561, 57464, 57489, 12544
21619, 12270, 56945, 56953, 12262, 1579, 11962, 11963, 1578, 57466, 57490, 57491, 12562, 12016, 12017, 12018, 
1601, 12563, 57467, 57492, 12546
21620, 1444, 11749, 11750, 1443, 12255, 56946, 56954, 12247, 11803, 11806, 11805, 1466, 57470, 57494, 57495, 
12531, 12530, 57468, 57493, 12513
21621, 12255, 56946, 56954, 12247, 12256, 56947, 56955, 12248, 57470, 57494, 57495, 12531, 57473, 57497, 57498, 
12533, 12532, 57471, 57496, 12515
21622, 12256, 56947, 56955, 12248, 12257, 56948, 56956, 12249, 57473, 57497, 57498, 12533, 57476, 57500, 57501, 
12535, 12534, 57474, 57499, 12517
21623, 12257, 56948, 56956, 12249, 12258, 56949, 56957, 12250, 57476, 57500, 57501, 12535, 57479, 57503, 57504, 
12537, 12536, 57477, 57502, 12519
21624, 12258, 56949, 56957, 12250, 12259, 56950, 56958, 12251, 57479, 57503, 57504, 12537, 57482, 57506, 57507, 
12539, 12538, 57480, 57505, 12521
21625, 12259, 56950, 56958, 12251, 12260, 56951, 56959, 12252, 57482, 57506, 57507, 12539, 57485, 57509, 57510, 
12541, 12540, 57483, 57508, 12523
21626, 12260, 56951, 56959, 12252, 12261, 56952, 56960, 12253, 57485, 57509, 57510, 12541, 57488, 57512, 57513, 
12543, 12542, 57486, 57511, 12525
21627, 12261, 56952, 56960, 12253, 12262, 56953, 56961, 12254, 57488, 57512, 57513, 12543, 57491, 57515, 57516, 
12545, 12544, 57489, 57514, 12527
21628, 12262, 56953, 56961, 12254, 1578, 11963, 11964, 1577, 57491, 57515, 57516, 12545, 12018, 12019, 12020, 
1600, 12546, 57492, 57517, 12529
21629, 1443, 11750, 11751, 1442, 12247, 56954, 56962, 12239, 11805, 11808, 11807, 1465, 57495, 57519, 57520, 
12514, 12513, 57493, 57518, 12496
21630, 12247, 56954, 56962, 12239, 12248, 56955, 56963, 12240, 57495, 57519, 57520, 12514, 57498, 57522, 57523, 
12516, 12515, 57496, 57521, 12498
21631, 12248, 56955, 56963, 12240, 12249, 56956, 56964, 12241, 57498, 57522, 57523, 12516, 57501, 57525, 57526, 
12518, 12517, 57499, 57524, 12500
21632, 12249, 56956, 56964, 12241, 12250, 56957, 56965, 12242, 57501, 57525, 57526, 12518, 57504, 57528, 57529, 
12520, 12519, 57502, 57527, 12502
21633, 12250, 56957, 56965, 12242, 12251, 56958, 56966, 12243, 57504, 57528, 57529, 12520, 57507, 57531, 57532, 
12522, 12521, 57505, 57530, 12504
21634, 12251, 56958, 56966, 12243, 12252, 56959, 56967, 12244, 57507, 57531, 57532, 12522, 57510, 57534, 57535, 
12524, 12523, 57508, 57533, 12506
21635, 12252, 56959, 56967, 12244, 12253, 56960, 56968, 12245, 57510, 57534, 57535, 12524, 57513, 57537, 57538, 
12526, 12525, 57511, 57536, 12508
21636, 12253, 56960, 56968, 12245, 12254, 56961, 56969, 12246, 57513, 57537, 57538, 12526, 57516, 57540, 57541, 
12528, 12527, 57514, 57539, 12510
21637, 12254, 56961, 56969, 12246, 1577, 11964, 11965, 1576, 57516, 57540, 57541, 12528, 12020, 12021, 12022, 
1599, 12529, 57517, 57542, 12512
21638, 1442, 11751, 11752, 1441, 12239, 56962, 56970, 12231, 11807, 11810, 11809, 1464, 57520, 57544, 57545, 
12497, 12496, 57518, 57543, 12479
21639, 12239, 56962, 56970, 12231, 12240, 56963, 56971, 12232, 57520, 57544, 57545, 12497, 57523, 57547, 57548, 
12499, 12498, 57521, 57546, 12481
21640, 12240, 56963, 56971, 12232, 12241, 56964, 56972, 12233, 57523, 57547, 57548, 12499, 57526, 57550, 57551, 
12501, 12500, 57524, 57549, 12483
21641, 12241, 56964, 56972, 12233, 12242, 56965, 56973, 12234, 57526, 57550, 57551, 12501, 57529, 57553, 57554, 
12503, 12502, 57527, 57552, 12485
21642, 12242, 56965, 56973, 12234, 12243, 56966, 56974, 12235, 57529, 57553, 57554, 12503, 57532, 57556, 57557, 
12505, 12504, 57530, 57555, 12487
21643, 12243, 56966, 56974, 12235, 12244, 56967, 56975, 12236, 57532, 57556, 57557, 12505, 57535, 57559, 57560, 
12507, 12506, 57533, 57558, 12489
21644, 12244, 56967, 56975, 12236, 12245, 56968, 56976, 12237, 57535, 57559, 57560, 12507, 57538, 57562, 57563, 
12509, 12508, 57536, 57561, 12491
21645, 12245, 56968, 56976, 12237, 12246, 56969, 56977, 12238, 57538, 57562, 57563, 12509, 57541, 57565, 57566, 
12511, 12510, 57539, 57564, 12493
21646, 12246, 56969, 56977, 12238, 1576, 11965, 11966, 1575, 57541, 57565, 57566, 12511, 12022, 12023, 12024, 
1598, 12512, 57542, 57567, 12495
21647, 1441, 11752, 11753, 1440, 12231, 56970, 56978, 12223, 11809, 11812, 11811, 1463, 57545, 57569, 57570, 
12480, 12479, 57543, 57568, 12462
21648, 12231, 56970, 56978, 12223, 12232, 56971, 56979, 12224, 57545, 57569, 57570, 12480, 57548, 57572, 57573, 
12482, 12481, 57546, 57571, 12464
21649, 12232, 56971, 56979, 12224, 12233, 56972, 56980, 12225, 57548, 57572, 57573, 12482, 57551, 57575, 57576, 
12484, 12483, 57549, 57574, 12466
21650, 12233, 56972, 56980, 12225, 12234, 56973, 56981, 12226, 57551, 57575, 57576, 12484, 57554, 57578, 57579, 
12486, 12485, 57552, 57577, 12468
21651, 12234, 56973, 56981, 12226, 12235, 56974, 56982, 12227, 57554, 57578, 57579, 12486, 57557, 57581, 57582, 
12488, 12487, 57555, 57580, 12470
21652, 12235, 56974, 56982, 12227, 12236, 56975, 56983, 12228, 57557, 57581, 57582, 12488, 57560, 57584, 57585, 
12490, 12489, 57558, 57583, 12472
21653, 12236, 56975, 56983, 12228, 12237, 56976, 56984, 12229, 57560, 57584, 57585, 12490, 57563, 57587, 57588, 
12492, 12491, 57561, 57586, 12474
21654, 12237, 56976, 56984, 12229, 12238, 56977, 56985, 12230, 57563, 57587, 57588, 12492, 57566, 57590, 57591, 
12494, 12493, 57564, 57589, 12476
21655, 12238, 56977, 56985, 12230, 1575, 11966, 11967, 1574, 57566, 57590, 57591, 12494, 12024, 12025, 12026, 
1597, 12495, 57567, 57592, 12478
21656, 1440, 11753, 11754, 1439, 12223, 56978, 56986, 12215, 11811, 11814, 11813, 1462, 57570, 57594, 57595, 
12463, 12462, 57568, 57593, 12445
21657, 12223, 56978, 56986, 12215, 12224, 56979, 56987, 12216, 57570, 57594, 57595, 12463, 57573, 57597, 57598, 
12465, 12464, 57571, 57596, 12447
21658, 12224, 56979, 56987, 12216, 12225, 56980, 56988, 12217, 57573, 57597, 57598, 12465, 57576, 57600, 57601, 
12467, 12466, 57574, 57599, 12449
21659, 12225, 56980, 56988, 12217, 12226, 56981, 56989, 12218, 57576, 57600, 57601, 12467, 57579, 57603, 57604, 
12469, 12468, 57577, 57602, 12451
21660, 12226, 56981, 56989, 12218, 12227, 56982, 56990, 12219, 57579, 57603, 57604, 12469, 57582, 57606, 57607, 
12471, 12470, 57580, 57605, 12453
21661, 12227, 56982, 56990, 12219, 12228, 56983, 56991, 12220, 57582, 57606, 57607, 12471, 57585, 57609, 57610, 
12473, 12472, 57583, 57608, 12455
21662, 12228, 56983, 56991, 12220, 12229, 56984, 56992, 12221, 57585, 57609, 57610, 12473, 57588, 57612, 57613, 
12475, 12474, 57586, 57611, 12457
21663, 12229, 56984, 56992, 12221, 12230, 56985, 56993, 12222, 57588, 57612, 57613, 12475, 57591, 57615, 57616, 
12477, 12476, 57589, 57614, 12459
21664, 12230, 56985, 56993, 12222, 1574, 11967, 11968, 1573, 57591, 57615, 57616, 12477, 12026, 12027, 12028, 
1596, 12478, 57592, 57617, 12461
21665, 1439, 11754, 11755, 1438, 12215, 56986, 56994, 12207, 11813, 11816, 11815, 1461, 57595, 57619, 57620, 
12446, 12445, 57593, 57618, 12428
21666, 12215, 56986, 56994, 12207, 12216, 56987, 56995, 12208, 57595, 57619, 57620, 12446, 57598, 57622, 57623, 
12448, 12447, 57596, 57621, 12430
21667, 12216, 56987, 56995, 12208, 12217, 56988, 56996, 12209, 57598, 57622, 57623, 12448, 57601, 57625, 57626, 
12450, 12449, 57599, 57624, 12432
21668, 12217, 56988, 56996, 12209, 12218, 56989, 56997, 12210, 57601, 57625, 57626, 12450, 57604, 57628, 57629, 
12452, 12451, 57602, 57627, 12434
21669, 12218, 56989, 56997, 12210, 12219, 56990, 56998, 12211, 57604, 57628, 57629, 12452, 57607, 57631, 57632, 
12454, 12453, 57605, 57630, 12436
21670, 12219, 56990, 56998, 12211, 12220, 56991, 56999, 12212, 57607, 57631, 57632, 12454, 57610, 57634, 57635, 
12456, 12455, 57608, 57633, 12438
21671, 12220, 56991, 56999, 12212, 12221, 56992, 57000, 12213, 57610, 57634, 57635, 12456, 57613, 57637, 57638, 
12458, 12457, 57611, 57636, 12440
21672, 12221, 56992, 57000, 12213, 12222, 56993, 57001, 12214, 57613, 57637, 57638, 12458, 57616, 57640, 57641, 
12460, 12459, 57614, 57639, 12442
21673, 12222, 56993, 57001, 12214, 1573, 11968, 11969, 1572, 57616, 57640, 57641, 12460, 12028, 12029, 12030, 
1595, 12461, 57617, 57642, 12444
21674, 1438, 11755, 11756, 1437, 12207, 56994, 57002, 12199, 11815, 11818, 11817, 1460, 57620, 57644, 57645, 
12429, 12428, 57618, 57643, 12411
21675, 12207, 56994, 57002, 12199, 12208, 56995, 57003, 12200, 57620, 57644, 57645, 12429, 57623, 57647, 57648, 
12431, 12430, 57621, 57646, 12413
21676, 12208, 56995, 57003, 12200, 12209, 56996, 57004, 12201, 57623, 57647, 57648, 12431, 57626, 57650, 57651, 
12433, 12432, 57624, 57649, 12415
21677, 12209, 56996, 57004, 12201, 12210, 56997, 57005, 12202, 57626, 57650, 57651, 12433, 57629, 57653, 57654, 
12435, 12434, 57627, 57652, 12417
21678, 12210, 56997, 57005, 12202, 12211, 56998, 57006, 12203, 57629, 57653, 57654, 12435, 57632, 57656, 57657, 
12437, 12436, 57630, 57655, 12419
21679, 12211, 56998, 57006, 12203, 12212, 56999, 57007, 12204, 57632, 57656, 57657, 12437, 57635, 57659, 57660, 
12439, 12438, 57633, 57658, 12421
21680, 12212, 56999, 57007, 12204, 12213, 57000, 57008, 12205, 57635, 57659, 57660, 12439, 57638, 57662, 57663, 
12441, 12440, 57636, 57661, 12423
21681, 12213, 57000, 57008, 12205, 12214, 57001, 57009, 12206, 57638, 57662, 57663, 12441, 57641, 57665, 57666, 
12443, 12442, 57639, 57664, 12425
21682, 12214, 57001, 57009, 12206, 1572, 11969, 11970, 1571, 57641, 57665, 57666, 12443, 12030, 12031, 12032, 
1594, 12444, 57642, 57667, 12427
21683, 1437, 11756, 11757, 1436, 12199, 57002, 57010, 12191, 11817, 11820, 11819, 1459, 57645, 57669, 57670, 
12412, 12411, 57643, 57668, 12394
21684, 12199, 57002, 57010, 12191, 12200, 57003, 57011, 12192, 57645, 57669, 57670, 12412, 57648, 57672, 57673, 
12414, 12413, 57646, 57671, 12396
21685, 12200, 57003, 57011, 12192, 12201, 57004, 57012, 12193, 57648, 57672, 57673, 12414, 57651, 57675, 57676, 
12416, 12415, 57649, 57674, 12398
21686, 12201, 57004, 57012, 12193, 12202, 57005, 57013, 12194, 57651, 57675, 57676, 12416, 57654, 57678, 57679, 
12418, 12417, 57652, 57677, 12400
21687, 12202, 57005, 57013, 12194, 12203, 57006, 57014, 12195, 57654, 57678, 57679, 12418, 57657, 57681, 57682, 
12420, 12419, 57655, 57680, 12402
21688, 12203, 57006, 57014, 12195, 12204, 57007, 57015, 12196, 57657, 57681, 57682, 12420, 57660, 57684, 57685, 
12422, 12421, 57658, 57683, 12404
21689, 12204, 57007, 57015, 12196, 12205, 57008, 57016, 12197, 57660, 57684, 57685, 12422, 57663, 57687, 57688, 
12424, 12423, 57661, 57686, 12406
21690, 12205, 57008, 57016, 12197, 12206, 57009, 57017, 12198, 57663, 57687, 57688, 12424, 57666, 57690, 57691, 
12426, 12425, 57664, 57689, 12408
21691, 12206, 57009, 57017, 12198, 1571, 11970, 11971, 1570, 57666, 57690, 57691, 12426, 12032, 12033, 12034, 
1593, 12427, 57667, 57692, 12410
21692, 1436, 11757, 11758, 1435, 12191, 57010, 57018, 12183, 11819, 11822, 11821, 1458, 57670, 57694, 57695, 
12395, 12394, 57668, 57693, 12377
21693, 12191, 57010, 57018, 12183, 12192, 57011, 57019, 12184, 57670, 57694, 57695, 12395, 57673, 57697, 57698, 
12397, 12396, 57671, 57696, 12379
21694, 12192, 57011, 57019, 12184, 12193, 57012, 57020, 12185, 57673, 57697, 57698, 12397, 57676, 57700, 57701, 
12399, 12398, 57674, 57699, 12381
21695, 12193, 57012, 57020, 12185, 12194, 57013, 57021, 12186, 57676, 57700, 57701, 12399, 57679, 57703, 57704, 
12401, 12400, 57677, 57702, 12383
21696, 12194, 57013, 57021, 12186, 12195, 57014, 57022, 12187, 57679, 57703, 57704, 12401, 57682, 57706, 57707, 
12403, 12402, 57680, 57705, 12385
21697, 12195, 57014, 57022, 12187, 12196, 57015, 57023, 12188, 57682, 57706, 57707, 12403, 57685, 57709, 57710, 
12405, 12404, 57683, 57708, 12387
21698, 12196, 57015, 57023, 12188, 12197, 57016, 57024, 12189, 57685, 57709, 57710, 12405, 57688, 57712, 57713, 
12407, 12406, 57686, 57711, 12389
21699, 12197, 57016, 57024, 12189, 12198, 57017, 57025, 12190, 57688, 57712, 57713, 12407, 57691, 57715, 57716, 
12409, 12408, 57689, 57714, 12391
21700, 12198, 57017, 57025, 12190, 1570, 11971, 11972, 1569, 57691, 57715, 57716, 12409, 12034, 12035, 12036, 
1592, 12410, 57692, 57717, 12393
21701, 1435, 11758, 11759, 1434, 12183, 57018, 57026, 12175, 11821, 11824, 11823, 1457, 57695, 57719, 57720, 
12378, 12377, 57693, 57718, 12360
21702, 12183, 57018, 57026, 12175, 12184, 57019, 57027, 12176, 57695, 57719, 57720, 12378, 57698, 57722, 57723, 
12380, 12379, 57696, 57721, 12362
21703, 12184, 57019, 57027, 12176, 12185, 57020, 57028, 12177, 57698, 57722, 57723, 12380, 57701, 57725, 57726, 
12382, 12381, 57699, 57724, 12364
21704, 12185, 57020, 57028, 12177, 12186, 57021, 57029, 12178, 57701, 57725, 57726, 12382, 57704, 57728, 57729, 
12384, 12383, 57702, 57727, 12366
21705, 12186, 57021, 57029, 12178, 12187, 57022, 57030, 12179, 57704, 57728, 57729, 12384, 57707, 57731, 57732, 
12386, 12385, 57705, 57730, 12368
21706, 12187, 57022, 57030, 12179, 12188, 57023, 57031, 12180, 57707, 57731, 57732, 12386, 57710, 57734, 57735, 
12388, 12387, 57708, 57733, 12370
21707, 12188, 57023, 57031, 12180, 12189, 57024, 57032, 12181, 57710, 57734, 57735, 12388, 57713, 57737, 57738, 
12390, 12389, 57711, 57736, 12372
21708, 12189, 57024, 57032, 12181, 12190, 57025, 57033, 12182, 57713, 57737, 57738, 12390, 57716, 57740, 57741, 
12392, 12391, 57714, 57739, 12374
21709, 12190, 57025, 57033, 12182, 1569, 11972, 11973, 1568, 57716, 57740, 57741, 12392, 12036, 12037, 12038, 
1591, 12393, 57717, 57742, 12376
21710, 1434, 11759, 11760, 1433, 12175, 57026, 57034, 12167, 11823, 11826, 11825, 1456, 57720, 57744, 57745, 
12361, 12360, 57718, 57743, 12343
21711, 12175, 57026, 57034, 12167, 12176, 57027, 57035, 12168, 57720, 57744, 57745, 12361, 57723, 57747, 57748, 
12363, 12362, 57721, 57746, 12345
21712, 12176, 57027, 57035, 12168, 12177, 57028, 57036, 12169, 57723, 57747, 57748, 12363, 57726, 57750, 57751, 
12365, 12364, 57724, 57749, 12347
21713, 12177, 57028, 57036, 12169, 12178, 57029, 57037, 12170, 57726, 57750, 57751, 12365, 57729, 57753, 57754, 
12367, 12366, 57727, 57752, 12349
21714, 12178, 57029, 57037, 12170, 12179, 57030, 57038, 12171, 57729, 57753, 57754, 12367, 57732, 57756, 57757, 
12369, 12368, 57730, 57755, 12351
21715, 12179, 57030, 57038, 12171, 12180, 57031, 57039, 12172, 57732, 57756, 57757, 12369, 57735, 57759, 57760, 
12371, 12370, 57733, 57758, 12353
21716, 12180, 57031, 57039, 12172, 12181, 57032, 57040, 12173, 57735, 57759, 57760, 12371, 57738, 57762, 57763, 
12373, 12372, 57736, 57761, 12355
21717, 12181, 57032, 57040, 12173, 12182, 57033, 57041, 12174, 57738, 57762, 57763, 12373, 57741, 57765, 57766, 
12375, 12374, 57739, 57764, 12357
21718, 12182, 57033, 57041, 12174, 1568, 11973, 11974, 1567, 57741, 57765, 57766, 12375, 12038, 12039, 12040, 
1590, 12376, 57742, 57767, 12359
21719, 1433, 11760, 1428, 47, 12167, 57034, 12116, 1657, 11825, 11827, 1430, 1455, 57745, 57768, 12140, 
12344, 12343, 57743, 12141, 1665
21720, 12167, 57034, 12116, 1657, 12168, 57035, 12115, 1658, 57745, 57768, 12140, 12344, 57748, 57769, 12138, 
12346, 12345, 57746, 12139, 1666
21721, 12168, 57035, 12115, 1658, 12169, 57036, 12114, 1659, 57748, 57769, 12138, 12346, 57751, 57770, 12136, 
12348, 12347, 57749, 12137, 1667
21722, 12169, 57036, 12114, 1659, 12170, 57037, 12113, 1660, 57751, 57770, 12136, 12348, 57754, 57771, 12134, 
12350, 12349, 57752, 12135, 1668
21723, 12170, 57037, 12113, 1660, 12171, 57038, 12112, 1661, 57754, 57771, 12134, 12350, 57757, 57772, 12132, 
12352, 12351, 57755, 12133, 1669
21724, 12171, 57038, 12112, 1661, 12172, 57039, 12111, 1662, 57757, 57772, 12132, 12352, 57760, 57773, 12130, 
12354, 12353, 57758, 12131, 1670
21725, 12172, 57039, 12111, 1662, 12173, 57040, 12110, 1663, 57760, 57773, 12130, 12354, 57763, 57774, 12128, 
12356, 12355, 57761, 12129, 1671
21726, 12173, 57040, 12110, 1663, 12174, 57041, 12109, 1664, 57763, 57774, 12128, 12356, 57766, 57775, 12126, 
12358, 12357, 57764, 12127, 1672
21727, 12174, 57041, 12109, 1664, 1567, 11974, 1562, 51, 57766, 57775, 12126, 12358, 12040, 12041, 1564, 
1589, 12359, 57767, 12125, 1673
21728, 1423, 1424, 11761, 11739, 11902, 11910, 57042, 56866, 1426, 11829, 11828, 11784, 11942, 57777, 57778, 
57219, 11927, 11944, 57776, 57218
21729, 11902, 11910, 57042, 56866, 11901, 11909, 57043, 56867, 11942, 57777, 57778, 57219, 11940, 57780, 57781, 
57222, 11926, 11943, 57779, 57221
21730, 11901, 11909, 57043, 56867, 11900, 11908, 57044, 56868, 11940, 57780, 57781, 57222, 11938, 57783, 57784, 
57225, 11924, 11941, 57782, 57224
21731, 11900, 11908, 57044, 56868, 11899, 11907, 57045, 56869, 11938, 57783, 57784, 57225, 11936, 57786, 57787, 
57228, 11922, 11939, 57785, 57227
21732, 11899, 11907, 57045, 56869, 11898, 11906, 57046, 56870, 11936, 57786, 57787, 57228, 11934, 57789, 57790, 
57231, 11920, 11937, 57788, 57230
21733, 11898, 11906, 57046, 56870, 11897, 11905, 57047, 56871, 11934, 57789, 57790, 57231, 11932, 57792, 57793, 
57234, 11918, 11935, 57791, 57233
21734, 11897, 11905, 57047, 56871, 11896, 11904, 57048, 56872, 11932, 57792, 57793, 57234, 11930, 57795, 57796, 
57237, 11916, 11933, 57794, 57236
21735, 11896, 11904, 57048, 56872, 11895, 11903, 57049, 56873, 11930, 57795, 57796, 57237, 11928, 57798, 57799, 
57240, 11914, 11931, 57797, 57239
21736, 11895, 11903, 57049, 56873, 1523, 1524, 11975, 11953, 11928, 57798, 57799, 57240, 1526, 12042, 12043, 
11997, 11912, 11929, 57800, 57242
21737, 11739, 11761, 11762, 11740, 56866, 57042, 57050, 56874, 11828, 11831, 11830, 11786, 57778, 57802, 57803, 
57244, 57218, 57776, 57801, 57243
21738, 56866, 57042, 57050, 56874, 56867, 57043, 57051, 56875, 57778, 57802, 57803, 57244, 57781, 57805, 57806, 
57247, 57221, 57779, 57804, 57246
21739, 56867, 57043, 57051, 56875, 56868, 57044, 57052, 56876, 57781, 57805, 57806, 57247, 57784, 57808, 57809, 
57250, 57224, 57782, 57807, 57249
21740, 56868, 57044, 57052, 56876, 56869, 57045, 57053, 56877, 57784, 57808, 57809, 57250, 57787, 57811, 57812, 
57253, 57227, 57785, 57810, 57252
21741, 56869, 57045, 57053, 56877, 56870, 57046, 57054, 56878, 57787, 57811, 57812, 57253, 57790, 57814, 57815, 
57256, 57230, 57788, 57813, 57255
21742, 56870, 57046, 57054, 56878, 56871, 57047, 57055, 56879, 57790, 57814, 57815, 57256, 57793, 57817, 57818, 
57259, 57233, 57791, 57816, 57258
21743, 56871, 57047, 57055, 56879, 56872, 57048, 57056, 56880, 57793, 57817, 57818, 57259, 57796, 57820, 57821, 
57262, 57236, 57794, 57819, 57261
21744, 56872, 57048, 57056, 56880, 56873, 57049, 57057, 56881, 57796, 57820, 57821, 57262, 57799, 57823, 57824, 
57265, 57239, 57797, 57822, 57264
21745, 56873, 57049, 57057, 56881, 11953, 11975, 11976, 11954, 57799, 57823, 57824, 57265, 12043, 12044, 12045, 
11999, 57242, 57800, 57825, 57267
21746, 11740, 11762, 11763, 11741, 56874, 57050, 57058, 56882, 11830, 11833, 11832, 11788, 57803, 57827, 57828, 
57269, 57243, 57801, 57826, 57268
21747, 56874, 57050, 57058, 56882, 56875, 57051, 57059, 56883, 57803, 57827, 57828, 57269, 57806, 57830, 57831, 
57272, 57246, 57804, 57829, 57271
21748, 56875, 57051, 57059, 56883, 56876, 57052, 57060, 56884, 57806, 57830, 57831, 57272, 57809, 57833, 57834, 
57275, 57249, 57807, 57832, 57274
21749, 56876, 57052, 57060, 56884, 56877, 57053, 57061, 56885, 57809, 57833, 57834, 57275, 57812, 57836, 57837, 
57278, 57252, 57810, 57835, 57277
21750, 56877, 57053, 57061, 56885, 56878, 57054, 57062, 56886, 57812, 57836, 57837, 57278, 57815, 57839, 57840, 
57281, 57255, 57813, 57838, 57280
21751, 56878, 57054, 57062, 56886, 56879, 57055, 57063, 56887, 57815, 57839, 57840, 57281, 57818, 57842, 57843, 
57284, 57258, 57816, 57841, 57283
21752, 56879, 57055, 57063, 56887, 56880, 57056, 57064, 56888, 57818, 57842, 57843, 57284, 57821, 57845, 57846, 
57287, 57261, 57819, 57844, 57286
21753, 56880, 57056, 57064, 56888, 56881, 57057, 57065, 56889, 57821, 57845, 57846, 57287, 57824, 57848, 57849, 
57290, 57264, 57822, 57847, 57289
21754, 56881, 57057, 57065, 56889, 11954, 11976, 11977, 11955, 57824, 57848, 57849, 57290, 12045, 12046, 12047, 
12001, 57267, 57825, 57850, 57292
21755, 11741, 11763, 11764, 11742, 56882, 57058, 57066, 56890, 11832, 11835, 11834, 11790, 57828, 57852, 57853, 
57294, 57268, 57826, 57851, 57293
21756, 56882, 57058, 57066, 56890, 56883, 57059, 57067, 56891, 57828, 57852, 57853, 57294, 57831, 57855, 57856, 
57297, 57271, 57829, 57854, 57296
21757, 56883, 57059, 57067, 56891, 56884, 57060, 57068, 56892, 57831, 57855, 57856, 57297, 57834, 57858, 57859, 
57300, 57274, 57832, 57857, 57299
21758, 56884, 57060, 57068, 56892, 56885, 57061, 57069, 56893, 57834, 57858, 57859, 57300, 57837, 57861, 57862, 
57303, 57277, 57835, 57860, 57302
21759, 56885, 57061, 57069, 56893, 56886, 57062, 57070, 56894, 57837, 57861, 57862, 57303, 57840, 57864, 57865, 
57306, 57280, 57838, 57863, 57305
21760, 56886, 57062, 57070, 56894, 56887, 57063, 57071, 56895, 57840, 57864, 57865, 57306, 57843, 57867, 57868, 
57309, 57283, 57841, 57866, 57308
21761, 56887, 57063, 57071, 56895, 56888, 57064, 57072, 56896, 57843, 57867, 57868, 57309, 57846, 57870, 57871, 
57312, 57286, 57844, 57869, 57311
21762, 56888, 57064, 57072, 56896, 56889, 57065, 57073, 56897, 57846, 57870, 57871, 57312, 57849, 57873, 57874, 
57315, 57289, 57847, 57872, 57314
21763, 56889, 57065, 57073, 56897, 11955, 11977, 11978, 11956, 57849, 57873, 57874, 57315, 12047, 12048, 12049, 
12003, 57292, 57850, 57875, 57317
21764, 11742, 11764, 11765, 11743, 56890, 57066, 57074, 56898, 11834, 11837, 11836, 11792, 57853, 57877, 57878, 
57319, 57293, 57851, 57876, 57318
21765, 56890, 57066, 57074, 56898, 56891, 57067, 57075, 56899, 57853, 57877, 57878, 57319, 57856, 57880, 57881, 
57322, 57296, 57854, 57879, 57321
21766, 56891, 57067, 57075, 56899, 56892, 57068, 57076, 56900, 57856, 57880, 57881, 57322, 57859, 57883, 57884, 
57325, 57299, 57857, 57882, 57324
21767, 56892, 57068, 57076, 56900, 56893, 57069, 57077, 56901, 57859, 57883, 57884, 57325, 57862, 57886, 57887, 
57328, 57302, 57860, 57885, 57327
21768, 56893, 57069, 57077, 56901, 56894, 57070, 57078, 56902, 57862, 57886, 57887, 57328, 57865, 57889, 57890, 
57331, 57305, 57863, 57888, 57330
21769, 56894, 57070, 57078, 56902, 56895, 57071, 57079, 56903, 57865, 57889, 57890, 57331, 57868, 57892, 57893, 
57334, 57308, 57866, 57891, 57333
21770, 56895, 57071, 57079, 56903, 56896, 57072, 57080, 56904, 57868, 57892, 57893, 57334, 57871, 57895, 57896, 
57337, 57311, 57869, 57894, 57336
21771, 56896, 57072, 57080, 56904, 56897, 57073, 57081, 56905, 57871, 57895, 57896, 57337, 57874, 57898, 57899, 
57340, 57314, 57872, 57897, 57339
21772, 56897, 57073, 57081, 56905, 11956, 11978, 11979, 11957, 57874, 57898, 57899, 57340, 12049, 12050, 12051, 
12005, 57317, 57875, 57900, 57342
21773, 11743, 11765, 11766, 11744, 56898, 57074, 57082, 56906, 11836, 11839, 11838, 11794, 57878, 57902, 57903, 
57344, 57318, 57876, 57901, 57343
21774, 56898, 57074, 57082, 56906, 56899, 57075, 57083, 56907, 57878, 57902, 57903, 57344, 57881, 57905, 57906, 
57347, 57321, 57879, 57904, 57346
21775, 56899, 57075, 57083, 56907, 56900, 57076, 57084, 56908, 57881, 57905, 57906, 57347, 57884, 57908, 57909, 
57350, 57324, 57882, 57907, 57349
21776, 56900, 57076, 57084, 56908, 56901, 57077, 57085, 56909, 57884, 57908, 57909, 57350, 57887, 57911, 57912, 
57353, 57327, 57885, 57910, 57352
21777, 56901, 57077, 57085, 56909, 56902, 57078, 57086, 56910, 57887, 57911, 57912, 57353, 57890, 57914, 57915, 
57356, 57330, 57888, 57913, 57355
21778, 56902, 57078, 57086, 56910, 56903, 57079, 57087, 56911, 57890, 57914, 57915, 57356, 57893, 57917, 57918, 
57359, 57333, 57891, 57916, 57358
21779, 56903, 57079, 57087, 56911, 56904, 57080, 57088, 56912, 57893, 57917, 57918, 57359, 57896, 57920, 57921, 
57362, 57336, 57894, 57919, 57361
21780, 56904, 57080, 57088, 56912, 56905, 57081, 57089, 56913, 57896, 57920, 57921, 57362, 57899, 57923, 57924, 
57365, 57339, 57897, 57922, 57364
21781, 56905, 57081, 57089, 56913, 11957, 11979, 11980, 11958, 57899, 57923, 57924, 57365, 12051, 12052, 12053, 
12007, 57342, 57900, 57925, 57367
21782, 11744, 11766, 11767, 11745, 56906, 57082, 57090, 56914, 11838, 11841, 11840, 11796, 57903, 57927, 57928, 
57369, 57343, 57901, 57926, 57368
21783, 56906, 57082, 57090, 56914, 56907, 57083, 57091, 56915, 57903, 57927, 57928, 57369, 57906, 57930, 57931, 
57372, 57346, 57904, 57929, 57371
21784, 56907, 57083, 57091, 56915, 56908, 57084, 57092, 56916, 57906, 57930, 57931, 57372, 57909, 57933, 57934, 
57375, 57349, 57907, 57932, 57374
21785, 56908, 57084, 57092, 56916, 56909, 57085, 57093, 56917, 57909, 57933, 57934, 57375, 57912, 57936, 57937, 
57378, 57352, 57910, 57935, 57377
21786, 56909, 57085, 57093, 56917, 56910, 57086, 57094, 56918, 57912, 57936, 57937, 57378, 57915, 57939, 57940, 
57381, 57355, 57913, 57938, 57380
21787, 56910, 57086, 57094, 56918, 56911, 57087, 57095, 56919, 57915, 57939, 57940, 57381, 57918, 57942, 57943, 
57384, 57358, 57916, 57941, 57383
21788, 56911, 57087, 57095, 56919, 56912, 57088, 57096, 56920, 57918, 57942, 57943, 57384, 57921, 57945, 57946, 
57387, 57361, 57919, 57944, 57386
21789, 56912, 57088, 57096, 56920, 56913, 57089, 57097, 56921, 57921, 57945, 57946, 57387, 57924, 57948, 57949, 
57390, 57364, 57922, 57947, 57389
21790, 56913, 57089, 57097, 56921, 11958, 11980, 11981, 11959, 57924, 57948, 57949, 57390, 12053, 12054, 12055, 
12009, 57367, 57925, 57950, 57392
21791, 11745, 11767, 11768, 11746, 56914, 57090, 57098, 56922, 11840, 11843, 11842, 11798, 57928, 57952, 57953, 
57394, 57368, 57926, 57951, 57393
21792, 56914, 57090, 57098, 56922, 56915, 57091, 57099, 56923, 57928, 57952, 57953, 57394, 57931, 57955, 57956, 
57397, 57371, 57929, 57954, 57396
21793, 56915, 57091, 57099, 56923, 56916, 57092, 57100, 56924, 57931, 57955, 57956, 57397, 57934, 57958, 57959, 
57400, 57374, 57932, 57957, 57399
21794, 56916, 57092, 57100, 56924, 56917, 57093, 57101, 56925, 57934, 57958, 57959, 57400, 57937, 57961, 57962, 
57403, 57377, 57935, 57960, 57402
21795, 56917, 57093, 57101, 56925, 56918, 57094, 57102, 56926, 57937, 57961, 57962, 57403, 57940, 57964, 57965, 
57406, 57380, 57938, 57963, 57405
21796, 56918, 57094, 57102, 56926, 56919, 57095, 57103, 56927, 57940, 57964, 57965, 57406, 57943, 57967, 57968, 
57409, 57383, 57941, 57966, 57408
21797, 56919, 57095, 57103, 56927, 56920, 57096, 57104, 56928, 57943, 57967, 57968, 57409, 57946, 57970, 57971, 
57412, 57386, 57944, 57969, 57411
21798, 56920, 57096, 57104, 56928, 56921, 57097, 57105, 56929, 57946, 57970, 57971, 57412, 57949, 57973, 57974, 
57415, 57389, 57947, 57972, 57414
21799, 56921, 57097, 57105, 56929, 11959, 11981, 11982, 11960, 57949, 57973, 57974, 57415, 12055, 12056, 12057, 
12011, 57392, 57950, 57975, 57417
21800, 11746, 11768, 11769, 11747, 56922, 57098, 57106, 56930, 11842, 11845, 11844, 11800, 57953, 57977, 57978, 
57419, 57393, 57951, 57976, 57418
21801, 56922, 57098, 57106, 56930, 56923, 57099, 57107, 56931, 57953, 57977, 57978, 57419, 57956, 57980, 57981, 
57422, 57396, 57954, 57979, 57421
21802, 56923, 57099, 57107, 56931, 56924, 57100, 57108, 56932, 57956, 57980, 57981, 57422, 57959, 57983, 57984, 
57425, 57399, 57957, 57982, 57424
21803, 56924, 57100, 57108, 56932, 56925, 57101, 57109, 56933, 57959, 57983, 57984, 57425, 57962, 57986, 57987, 
57428, 57402, 57960, 57985, 57427
21804, 56925, 57101, 57109, 56933, 56926, 57102, 57110, 56934, 57962, 57986, 57987, 57428, 57965, 57989, 57990, 
57431, 57405, 57963, 57988, 57430
21805, 56926, 57102, 57110, 56934, 56927, 57103, 57111, 56935, 57965, 57989, 57990, 57431, 57968, 57992, 57993, 
57434, 57408, 57966, 57991, 57433
21806, 56927, 57103, 57111, 56935, 56928, 57104, 57112, 56936, 57968, 57992, 57993, 57434, 57971, 57995, 57996, 
57437, 57411, 57969, 57994, 57436
21807, 56928, 57104, 57112, 56936, 56929, 57105, 57113, 56937, 57971, 57995, 57996, 57437, 57974, 57998, 57999, 
57440, 57414, 57972, 57997, 57439
21808, 56929, 57105, 57113, 56937, 11960, 11982, 11983, 11961, 57974, 57998, 57999, 57440, 12057, 12058, 12059, 
12013, 57417, 57975, 58000, 57442
21809, 11747, 11769, 11770, 11748, 56930, 57106, 57114, 56938, 11844, 11847, 11846, 11802, 57978, 58002, 58003, 
57444, 57418, 57976, 58001, 57443
21810, 56930, 57106, 57114, 56938, 56931, 57107, 57115, 56939, 57978, 58002, 58003, 57444, 57981, 58005, 58006, 
57447, 57421, 57979, 58004, 57446
21811, 56931, 57107, 57115, 56939, 56932, 57108, 57116, 56940, 57981, 58005, 58006, 57447, 57984, 58008, 58009, 
57450, 57424, 57982, 58007, 57449
21812, 56932, 57108, 57116, 56940, 56933, 57109, 57117, 56941, 57984, 58008, 58009, 57450, 57987, 58011, 58012, 
57453, 57427, 57985, 58010, 57452
21813, 56933, 57109, 57117, 56941, 56934, 57110, 57118, 56942, 57987, 58011, 58012, 57453, 57990, 58014, 58015, 
57456, 57430, 57988, 58013, 57455
21814, 56934, 57110, 57118, 56942, 56935, 57111, 57119, 56943, 57990, 58014, 58015, 57456, 57993, 58017, 58018, 
57459, 57433, 57991, 58016, 57458
21815, 56935, 57111, 57119, 56943, 56936, 57112, 57120, 56944, 57993, 58017, 58018, 57459, 57996, 58020, 58021, 
57462, 57436, 57994, 58019, 57461
21816, 56936, 57112, 57120, 56944, 56937, 57113, 57121, 56945, 57996, 58020, 58021, 57462, 57999, 58023, 58024, 
57465, 57439, 57997, 58022, 57464
21817, 56937, 57113, 57121, 56945, 11961, 11983, 11984, 11962, 57999, 58023, 58024, 57465, 12059, 12060, 12061, 
12015, 57442, 58000, 58025, 57467
21818, 11748, 11770, 11771, 11749, 56938, 57114, 57122, 56946, 11846, 11849, 11848, 11804, 58003, 58027, 58028, 
57469, 57443, 58001, 58026, 57468
21819, 56938, 57114, 57122, 56946, 56939, 57115, 57123, 56947, 58003, 58027, 58028, 57469, 58006, 58030, 58031, 
57472, 57446, 58004, 58029, 57471
21820, 56939, 57115, 57123, 56947, 56940, 57116, 57124, 56948, 58006, 58030, 58031, 57472, 58009, 58033, 58034, 
57475, 57449, 58007, 58032, 57474
21821, 56940, 57116, 57124, 56948, 56941, 57117, 57125, 56949, 58009, 58033, 58034, 57475, 58012, 58036, 58037, 
57478, 57452, 58010, 58035, 57477
21822, 56941, 57117, 57125, 56949, 56942, 57118, 57126, 56950, 58012, 58036, 58037, 57478, 58015, 58039, 58040, 
57481, 57455, 58013, 58038, 57480
21823, 56942, 57118, 57126, 56950, 56943, 57119, 57127, 56951, 58015, 58039, 58040, 57481, 58018, 58042, 58043, 
57484, 57458, 58016, 58041, 57483
21824, 56943, 57119, 57127, 56951, 56944, 57120, 57128, 56952, 58018, 58042, 58043, 57484, 58021, 58045, 58046, 
57487, 57461, 58019, 58044, 57486
21825, 56944, 57120, 57128, 56952, 56945, 57121, 57129, 56953, 58021, 58045, 58046, 57487, 58024, 58048, 58049, 
57490, 57464, 58022, 58047, 57489
21826, 56945, 57121, 57129, 56953, 11962, 11984, 11985, 11963, 58024, 58048, 58049, 57490, 12061, 12062, 12063, 
12017, 57467, 58025, 58050, 57492
21827, 11749, 11771, 11772, 11750, 56946, 57122, 57130, 56954, 11848, 11851, 11850, 11806, 58028, 58052, 58053, 
57494, 57468, 58026, 58051, 57493
21828, 56946, 57122, 57130, 56954, 56947, 57123, 57131, 56955, 58028, 58052, 58053, 57494, 58031, 58055, 58056, 
57497, 57471, 58029, 58054, 57496
21829, 56947, 57123, 57131, 56955, 56948, 57124, 57132, 56956, 58031, 58055, 58056, 57497, 58034, 58058, 58059, 
57500, 57474, 58032, 58057, 57499
21830, 56948, 57124, 57132, 56956, 56949, 57125, 57133, 56957, 58034, 58058, 58059, 57500, 58037, 58061, 58062, 
57503, 57477, 58035, 58060, 57502
21831, 56949, 57125, 57133, 56957, 56950, 57126, 57134, 56958, 58037, 58061, 58062, 57503, 58040, 58064, 58065, 
57506, 57480, 58038, 58063, 57505
21832, 56950, 57126, 57134, 56958, 56951, 57127, 57135, 56959, 58040, 58064, 58065, 57506, 58043, 58067, 58068, 
57509, 57483, 58041, 58066, 57508
21833, 56951, 57127, 57135, 56959, 56952, 57128, 57136, 56960, 58043, 58067, 58068, 57509, 58046, 58070, 58071, 
57512, 57486, 58044, 58069, 57511
21834, 56952, 57128, 57136, 56960, 56953, 57129, 57137, 56961, 58046, 58070, 58071, 57512, 58049, 58073, 58074, 
57515, 57489, 58047, 58072, 57514
21835, 56953, 57129, 57137, 56961, 11963, 11985, 11986, 11964, 58049, 58073, 58074, 57515, 12063, 12064, 12065, 
12019, 57492, 58050, 58075, 57517
21836, 11750, 11772, 11773, 11751, 56954, 57130, 57138, 56962, 11850, 11853, 11852, 11808, 58053, 58077, 58078, 
57519, 57493, 58051, 58076, 57518
21837, 56954, 57130, 57138, 56962, 56955, 57131, 57139, 56963, 58053, 58077, 58078, 57519, 58056, 58080, 58081, 
57522, 57496, 58054, 58079, 57521
21838, 56955, 57131, 57139, 56963, 56956, 57132, 57140, 56964, 58056, 58080, 58081, 57522, 58059, 58083, 58084, 
57525, 57499, 58057, 58082, 57524
21839, 56956, 57132, 57140, 56964, 56957, 57133, 57141, 56965, 58059, 58083, 58084, 57525, 58062, 58086, 58087, 
57528, 57502, 58060, 58085, 57527
21840, 56957, 57133, 57141, 56965, 56958, 57134, 57142, 56966, 58062, 58086, 58087, 57528, 58065, 58089, 58090, 
57531, 57505, 58063, 58088, 57530
21841, 56958, 57134, 57142, 56966, 56959, 57135, 57143, 56967, 58065, 58089, 58090, 57531, 58068, 58092, 58093, 
57534, 57508, 58066, 58091, 57533
21842, 56959, 57135, 57143, 56967, 56960, 57136, 57144, 56968, 58068, 58092, 58093, 57534, 58071, 58095, 58096, 
57537, 57511, 58069, 58094, 57536
21843, 56960, 57136, 57144, 56968, 56961, 57137, 57145, 56969, 58071, 58095, 58096, 57537, 58074, 58098, 58099, 
57540, 57514, 58072, 58097, 57539
21844, 56961, 57137, 57145, 56969, 11964, 11986, 11987, 11965, 58074, 58098, 58099, 57540, 12065, 12066, 12067, 
12021, 57517, 58075, 58100, 57542
21845, 11751, 11773, 11774, 11752, 56962, 57138, 57146, 56970, 11852, 11855, 11854, 11810, 58078, 58102, 58103, 
57544, 57518, 58076, 58101, 57543
21846, 56962, 57138, 57146, 56970, 56963, 57139, 57147, 56971, 58078, 58102, 58103, 57544, 58081, 58105, 58106, 
57547, 57521, 58079, 58104, 57546
21847, 56963, 57139, 57147, 56971, 56964, 57140, 57148, 56972, 58081, 58105, 58106, 57547, 58084, 58108, 58109, 
57550, 57524, 58082, 58107, 57549
21848, 56964, 57140, 57148, 56972, 56965, 57141, 57149, 56973, 58084, 58108, 58109, 57550, 58087, 58111, 58112, 
57553, 57527, 58085, 58110, 57552
21849, 56965, 57141, 57149, 56973, 56966, 57142, 57150, 56974, 58087, 58111, 58112, 57553, 58090, 58114, 58115, 
57556, 57530, 58088, 58113, 57555
21850, 56966, 57142, 57150, 56974, 56967, 57143, 57151, 56975, 58090, 58114, 58115, 57556, 58093, 58117, 58118, 
57559, 57533, 58091, 58116, 57558
21851, 56967, 57143, 57151, 56975, 56968, 57144, 57152, 56976, 58093, 58117, 58118, 57559, 58096, 58120, 58121, 
57562, 57536, 58094, 58119, 57561
21852, 56968, 57144, 57152, 56976, 56969, 57145, 57153, 56977, 58096, 58120, 58121, 57562, 58099, 58123, 58124, 
57565, 57539, 58097, 58122, 57564
21853, 56969, 57145, 57153, 56977, 11965, 11987, 11988, 11966, 58099, 58123, 58124, 57565, 12067, 12068, 12069, 
12023, 57542, 58100, 58125, 57567
21854, 11752, 11774, 11775, 11753, 56970, 57146, 57154, 56978, 11854, 11857, 11856, 11812, 58103, 58127, 58128, 
57569, 57543, 58101, 58126, 57568
21855, 56970, 57146, 57154, 56978, 56971, 57147, 57155, 56979, 58103, 58127, 58128, 57569, 58106, 58130, 58131, 
57572, 57546, 58104, 58129, 57571
21856, 56971, 57147, 57155, 56979, 56972, 57148, 57156, 56980, 58106, 58130, 58131, 57572, 58109, 58133, 58134, 
57575, 57549, 58107, 58132, 57574
21857, 56972, 57148, 57156, 56980, 56973, 57149, 57157, 56981, 58109, 58133, 58134, 57575, 58112, 58136, 58137, 
57578, 57552, 58110, 58135, 57577
21858, 56973, 57149, 57157, 56981, 56974, 57150, 57158, 56982, 58112, 58136, 58137, 57578, 58115, 58139, 58140, 
57581, 57555, 58113, 58138, 57580
21859, 56974, 57150, 57158, 56982, 56975, 57151, 57159, 56983, 58115, 58139, 58140, 57581, 58118, 58142, 58143, 
57584, 57558, 58116, 58141, 57583
21860, 56975, 57151, 57159, 56983, 56976, 57152, 57160, 56984, 58118, 58142, 58143, 57584, 58121, 58145, 58146, 
57587, 57561, 58119, 58144, 57586
21861, 56976, 57152, 57160, 56984, 56977, 57153, 57161, 56985, 58121, 58145, 58146, 57587, 58124, 58148, 58149, 
57590, 57564, 58122, 58147, 57589
21862, 56977, 57153, 57161, 56985, 11966, 11988, 11989, 11967, 58124, 58148, 58149, 57590, 12069, 12070, 12071, 
12025, 57567, 58125, 58150, 57592
21863, 11753, 11775, 11776, 11754, 56978, 57154, 57162, 56986, 11856, 11859, 11858, 11814, 58128, 58152, 58153, 
57594, 57568, 58126, 58151, 57593
21864, 56978, 57154, 57162, 56986, 56979, 57155, 57163, 56987, 58128, 58152, 58153, 57594, 58131, 58155, 58156, 
57597, 57571, 58129, 58154, 57596
21865, 56979, 57155, 57163, 56987, 56980, 57156, 57164, 56988, 58131, 58155, 58156, 57597, 58134, 58158, 58159, 
57600, 57574, 58132, 58157, 57599
21866, 56980, 57156, 57164, 56988, 56981, 57157, 57165, 56989, 58134, 58158, 58159, 57600, 58137, 58161, 58162, 
57603, 57577, 58135, 58160, 57602
21867, 56981, 57157, 57165, 56989, 56982, 57158, 57166, 56990, 58137, 58161, 58162, 57603, 58140, 58164, 58165, 
57606, 57580, 58138, 58163, 57605
21868, 56982, 57158, 57166, 56990, 56983, 57159, 57167, 56991, 58140, 58164, 58165, 57606, 58143, 58167, 58168, 
57609, 57583, 58141, 58166, 57608
21869, 56983, 57159, 57167, 56991, 56984, 57160, 57168, 56992, 58143, 58167, 58168, 57609, 58146, 58170, 58171, 
57612, 57586, 58144, 58169, 57611
21870, 56984, 57160, 57168, 56992, 56985, 57161, 57169, 56993, 58146, 58170, 58171, 57612, 58149, 58173, 58174, 
57615, 57589, 58147, 58172, 57614
21871, 56985, 57161, 57169, 56993, 11967, 11989, 11990, 11968, 58149, 58173, 58174, 57615, 12071, 12072, 12073, 
12027, 57592, 58150, 58175, 57617
21872, 11754, 11776, 11777, 11755, 56986, 57162, 57170, 56994, 11858, 11861, 11860, 11816, 58153, 58177, 58178, 
57619, 57593, 58151, 58176, 57618
21873, 56986, 57162, 57170, 56994, 56987, 57163, 57171, 56995, 58153, 58177, 58178, 57619, 58156, 58180, 58181, 
57622, 57596, 58154, 58179, 57621
21874, 56987, 57163, 57171, 56995, 56988, 57164, 57172, 56996, 58156, 58180, 58181, 57622, 58159, 58183, 58184, 
57625, 57599, 58157, 58182, 57624
21875, 56988, 57164, 57172, 56996, 56989, 57165, 57173, 56997, 58159, 58183, 58184, 57625, 58162, 58186, 58187, 
57628, 57602, 58160, 58185, 57627
21876, 56989, 57165, 57173, 56997, 56990, 57166, 57174, 56998, 58162, 58186, 58187, 57628, 58165, 58189, 58190, 
57631, 57605, 58163, 58188, 57630
21877, 56990, 57166, 57174, 56998, 56991, 57167, 57175, 56999, 58165, 58189, 58190, 57631, 58168, 58192, 58193, 
57634, 57608, 58166, 58191, 57633
21878, 56991, 57167, 57175, 56999, 56992, 57168, 57176, 57000, 58168, 58192, 58193, 57634, 58171, 58195, 58196, 
57637, 57611, 58169, 58194, 57636
21879, 56992, 57168, 57176, 57000, 56993, 57169, 57177, 57001, 58171, 58195, 58196, 57637, 58174, 58198, 58199, 
57640, 57614, 58172, 58197, 57639
21880, 56993, 57169, 57177, 57001, 11968, 11990, 11991, 11969, 58174, 58198, 58199, 57640, 12073, 12074, 12075, 
12029, 57617, 58175, 58200, 57642
21881, 11755, 11777, 11778, 11756, 56994, 57170, 57178, 57002, 11860, 11863, 11862, 11818, 58178, 58202, 58203, 
57644, 57618, 58176, 58201, 57643
21882, 56994, 57170, 57178, 57002, 56995, 57171, 57179, 57003, 58178, 58202, 58203, 57644, 58181, 58205, 58206, 
57647, 57621, 58179, 58204, 57646
21883, 56995, 57171, 57179, 57003, 56996, 57172, 57180, 57004, 58181, 58205, 58206, 57647, 58184, 58208, 58209, 
57650, 57624, 58182, 58207, 57649
21884, 56996, 57172, 57180, 57004, 56997, 57173, 57181, 57005, 58184, 58208, 58209, 57650, 58187, 58211, 58212, 
57653, 57627, 58185, 58210, 57652
21885, 56997, 57173, 57181, 57005, 56998, 57174, 57182, 57006, 58187, 58211, 58212, 57653, 58190, 58214, 58215, 
57656, 57630, 58188, 58213, 57655
21886, 56998, 57174, 57182, 57006, 56999, 57175, 57183, 57007, 58190, 58214, 58215, 57656, 58193, 58217, 58218, 
57659, 57633, 58191, 58216, 57658
21887, 56999, 57175, 57183, 57007, 57000, 57176, 57184, 57008, 58193, 58217, 58218, 57659, 58196, 58220, 58221, 
57662, 57636, 58194, 58219, 57661
21888, 57000, 57176, 57184, 57008, 57001, 57177, 57185, 57009, 58196, 58220, 58221, 57662, 58199, 58223, 58224, 
57665, 57639, 58197, 58222, 57664
21889, 57001, 57177, 57185, 57009, 11969, 11991, 11992, 11970, 58199, 58223, 58224, 57665, 12075, 12076, 12077, 
12031, 57642, 58200, 58225, 57667
21890, 11756, 11778, 11779, 11757, 57002, 57178, 57186, 57010, 11862, 11865, 11864, 11820, 58203, 58227, 58228, 
57669, 57643, 58201, 58226, 57668
21891, 57002, 57178, 57186, 57010, 57003, 57179, 57187, 57011, 58203, 58227, 58228, 57669, 58206, 58230, 58231, 
57672, 57646, 58204, 58229, 57671
21892, 57003, 57179, 57187, 57011, 57004, 57180, 57188, 57012, 58206, 58230, 58231, 57672, 58209, 58233, 58234, 
57675, 57649, 58207, 58232, 57674
21893, 57004, 57180, 57188, 57012, 57005, 57181, 57189, 57013, 58209, 58233, 58234, 57675, 58212, 58236, 58237, 
57678, 57652, 58210, 58235, 57677
21894, 57005, 57181, 57189, 57013, 57006, 57182, 57190, 57014, 58212, 58236, 58237, 57678, 58215, 58239, 58240, 
57681, 57655, 58213, 58238, 57680
21895, 57006, 57182, 57190, 57014, 57007, 57183, 57191, 57015, 58215, 58239, 58240, 57681, 58218, 58242, 58243, 
57684, 57658, 58216, 58241, 57683
21896, 57007, 57183, 57191, 57015, 57008, 57184, 57192, 57016, 58218, 58242, 58243, 57684, 58221, 58245, 58246, 
57687, 57661, 58219, 58244, 57686
21897, 57008, 57184, 57192, 57016, 57009, 57185, 57193, 57017, 58221, 58245, 58246, 57687, 58224, 58248, 58249, 
57690, 57664, 58222, 58247, 57689
21898, 57009, 57185, 57193, 57017, 11970, 11992, 11993, 11971, 58224, 58248, 58249, 57690, 12077, 12078, 12079, 
12033, 57667, 58225, 58250, 57692
21899, 11757, 11779, 11780, 11758, 57010, 57186, 57194, 57018, 11864, 11867, 11866, 11822, 58228, 58252, 58253, 
57694, 57668, 58226, 58251, 57693
21900, 57010, 57186, 57194, 57018, 57011, 57187, 57195, 57019, 58228, 58252, 58253, 57694, 58231, 58255, 58256, 
57697, 57671, 58229, 58254, 57696
21901, 57011, 57187, 57195, 57019, 57012, 57188, 57196, 57020, 58231, 58255, 58256, 57697, 58234, 58258, 58259, 
57700, 57674, 58232, 58257, 57699
21902, 57012, 57188, 57196, 57020, 57013, 57189, 57197, 57021, 58234, 58258, 58259, 57700, 58237, 58261, 58262, 
57703, 57677, 58235, 58260, 57702
21903, 57013, 57189, 57197, 57021, 57014, 57190, 57198, 57022, 58237, 58261, 58262, 57703, 58240, 58264, 58265, 
57706, 57680, 58238, 58263, 57705
21904, 57014, 57190, 57198, 57022, 57015, 57191, 57199, 57023, 58240, 58264, 58265, 57706, 58243, 58267, 58268, 
57709, 57683, 58241, 58266, 57708
21905, 57015, 57191, 57199, 57023, 57016, 57192, 57200, 57024, 58243, 58267, 58268, 57709, 58246, 58270, 58271, 
57712, 57686, 58244, 58269, 57711
21906, 57016, 57192, 57200, 57024, 57017, 57193, 57201, 57025, 58246, 58270, 58271, 57712, 58249, 58273, 58274, 
57715, 57689, 58247, 58272, 57714
21907, 57017, 57193, 57201, 57025, 11971, 11993, 11994, 11972, 58249, 58273, 58274, 57715, 12079, 12080, 12081, 
12035, 57692, 58250, 58275, 57717
21908, 11758, 11780, 11781, 11759, 57018, 57194, 57202, 57026, 11866, 11869, 11868, 11824, 58253, 58277, 58278, 
57719, 57693, 58251, 58276, 57718
21909, 57018, 57194, 57202, 57026, 57019, 57195, 57203, 57027, 58253, 58277, 58278, 57719, 58256, 58280, 58281, 
57722, 57696, 58254, 58279, 57721
21910, 57019, 57195, 57203, 57027, 57020, 57196, 57204, 57028, 58256, 58280, 58281, 57722, 58259, 58283, 58284, 
57725, 57699, 58257, 58282, 57724
21911, 57020, 57196, 57204, 57028, 57021, 57197, 57205, 57029, 58259, 58283, 58284, 57725, 58262, 58286, 58287, 
57728, 57702, 58260, 58285, 57727
21912, 57021, 57197, 57205, 57029, 57022, 57198, 57206, 57030, 58262, 58286, 58287, 57728, 58265, 58289, 58290, 
57731, 57705, 58263, 58288, 57730
21913, 57022, 57198, 57206, 57030, 57023, 57199, 57207, 57031, 58265, 58289, 58290, 57731, 58268, 58292, 58293, 
57734, 57708, 58266, 58291, 57733
21914, 57023, 57199, 57207, 57031, 57024, 57200, 57208, 57032, 58268, 58292, 58293, 57734, 58271, 58295, 58296, 
57737, 57711, 58269, 58294, 57736
21915, 57024, 57200, 57208, 57032, 57025, 57201, 57209, 57033, 58271, 58295, 58296, 57737, 58274, 58298, 58299, 
57740, 57714, 58272, 58297, 57739
21916, 57025, 57201, 57209, 57033, 11972, 11994, 11995, 11973, 58274, 58298, 58299, 57740, 12081, 12082, 12083, 
12037, 57717, 58275, 58300, 57742
21917, 11759, 11781, 11782, 11760, 57026, 57202, 57210, 57034, 11868, 11871, 11870, 11826, 58278, 58302, 58303, 
57744, 57718, 58276, 58301, 57743
21918, 57026, 57202, 57210, 57034, 57027, 57203, 57211, 57035, 58278, 58302, 58303, 57744, 58281, 58305, 58306, 
57747, 57721, 58279, 58304, 57746
21919, 57027, 57203, 57211, 57035, 57028, 57204, 57212, 57036, 58281, 58305, 58306, 57747, 58284, 58308, 58309, 
57750, 57724, 58282, 58307, 57749
21920, 57028, 57204, 57212, 57036, 57029, 57205, 57213, 57037, 58284, 58308, 58309, 57750, 58287, 58311, 58312, 
57753, 57727, 58285, 58310, 57752
21921, 57029, 57205, 57213, 57037, 57030, 57206, 57214, 57038, 58287, 58311, 58312, 57753, 58290, 58314, 58315, 
57756, 57730, 58288, 58313, 57755
21922, 57030, 57206, 57214, 57038, 57031, 57207, 57215, 57039, 58290, 58314, 58315, 57756, 58293, 58317, 58318, 
57759, 57733, 58291, 58316, 57758
21923, 57031, 57207, 57215, 57039, 57032, 57208, 57216, 57040, 58293, 58317, 58318, 57759, 58296, 58320, 58321, 
57762, 57736, 58294, 58319, 57761
21924, 57032, 57208, 57216, 57040, 57033, 57209, 57217, 57041, 58296, 58320, 58321, 57762, 58299, 58323, 58324, 
57765, 57739, 58297, 58322, 57764
21925, 57033, 57209, 57217, 57041, 11973, 11995, 11996, 11974, 58299, 58323, 58324, 57765, 12083, 12084, 12085, 
12039, 57742, 58300, 58325, 57767
21926, 11760, 11782, 1429, 1428, 57034, 57210, 12124, 12116, 11870, 11872, 1431, 11827, 58303, 58326, 12157, 
57768, 57743, 58301, 12158, 12141
21927, 57034, 57210, 12124, 12116, 57035, 57211, 12123, 12115, 58303, 58326, 12157, 57768, 58306, 58327, 12155, 
57769, 57746, 58304, 12156, 12139
21928, 57035, 57211, 12123, 12115, 57036, 57212, 12122, 12114, 58306, 58327, 12155, 57769, 58309, 58328, 12153, 
57770, 57749, 58307, 12154, 12137
21929, 57036, 57212, 12122, 12114, 57037, 57213, 12121, 12113, 58309, 58328, 12153, 57770, 58312, 58329, 12151, 
57771, 57752, 58310, 12152, 12135
21930, 57037, 57213, 12121, 12113, 57038, 57214, 12120, 12112, 58312, 58329, 12151, 57771, 58315, 58330, 12149, 
57772, 57755, 58313, 12150, 12133
21931, 57038, 57214, 12120, 12112, 57039, 57215, 12119, 12111, 58315, 58330, 12149, 57772, 58318, 58331, 12147, 
57773, 57758, 58316, 12148, 12131
21932, 57039, 57215, 12119, 12111, 57040, 57216, 12118, 12110, 58318, 58331, 12147, 57773, 58321, 58332, 12145, 
57774, 57761, 58319, 12146, 12129
21933, 57040, 57216, 12118, 12110, 57041, 57217, 12117, 12109, 58321, 58332, 12145, 57774, 58324, 58333, 12143, 
57775, 57764, 58322, 12144, 12127
21934, 57041, 57217, 12117, 12109, 11974, 11996, 1563, 1562, 58324, 58333, 12143, 57775, 12085, 12086, 1565, 
12041, 57767, 58325, 12142, 12125
21935, 1424, 46, 1499, 11761, 11910, 1545, 12893, 57042, 1427, 1522, 11873, 11829, 11952, 13275, 58334, 
57777, 11944, 1553, 13259, 57776
21936, 11910, 1545, 12893, 57042, 11909, 1546, 12894, 57043, 11952, 13275, 58334, 57777, 11951, 13276, 58335, 
57780, 11943, 1554, 13261, 57779
21937, 11909, 1546, 12894, 57043, 11908, 1547, 12895, 57044, 11951, 13276, 58335, 57780, 11950, 13277, 58336, 
57783, 11941, 1555, 13263, 57782
21938, 11908, 1547, 12895, 57044, 11907, 1548, 12896, 57045, 11950, 13277, 58336, 57783, 11949, 13278, 58337, 
57786, 11939, 1556, 13265, 57785
21939, 11907, 1548, 12896, 57045, 11906, 1549, 12897, 57046, 11949, 13278, 58337, 57786, 11948, 13279, 58338, 
57789, 11937, 1557, 13267, 57788
21940, 11906, 1549, 12897, 57046, 11905, 1550, 12898, 57047, 11948, 13279, 58338, 57789, 11947, 13280, 58339, 
57792, 11935, 1558, 13269, 57791
21941, 11905, 1550, 12898, 57047, 11904, 1551, 12899, 57048, 11947, 13280, 58339, 57792, 11946, 13281, 58340, 
57795, 11933, 1559, 13271, 57794
21942, 11904, 1551, 12899, 57048, 11903, 1552, 12900, 57049, 11946, 13281, 58340, 57795, 11945, 13282, 58341, 
57798, 11931, 1560, 13273, 57797
21943, 11903, 1552, 12900, 57049, 1524, 50, 1633, 11975, 11945, 13282, 58341, 57798, 1527, 1656, 12087, 
12042, 11929, 1561, 13274, 57800
21944, 11761, 1499, 1498, 11762, 57042, 12893, 12885, 57050, 11873, 1521, 11874, 11831, 58334, 13258, 58342, 
57802, 57776, 13259, 13242, 57801
21945, 57042, 12893, 12885, 57050, 57043, 12894, 12886, 57051, 58334, 13258, 58342, 57802, 58335, 13260, 58343, 
57805, 57779, 13261, 13244, 57804
21946, 57043, 12894, 12886, 57051, 57044, 12895, 12887, 57052, 58335, 13260, 58343, 57805, 58336, 13262, 58344, 
57808, 57782, 13263, 13246, 57807
21947, 57044, 12895, 12887, 57052, 57045, 12896, 12888, 57053, 58336, 13262, 58344, 57808, 58337, 13264, 58345, 
57811, 57785, 13265, 13248, 57810
21948, 57045, 12896, 12888, 57053, 57046, 12897, 12889, 57054, 58337, 13264, 58345, 57811, 58338, 13266, 58346, 
57814, 57788, 13267, 13250, 57813
21949, 57046, 12897, 12889, 57054, 57047, 12898, 12890, 57055, 58338, 13266, 58346, 57814, 58339, 13268, 58347, 
57817, 57791, 13269, 13252, 57816
21950, 57047, 12898, 12890, 57055, 57048, 12899, 12891, 57056, 58339, 13268, 58347, 57817, 58340, 13270, 58348, 
57820, 57794, 13271, 13254, 57819
21951, 57048, 12899, 12891, 57056, 57049, 12900, 12892, 57057, 58340, 13270, 58348, 57820, 58341, 13272, 58349, 
57823, 57797, 13273, 13256, 57822
21952, 57049, 12900, 12892, 57057, 11975, 1633, 1632, 11976, 58341, 13272, 58349, 57823, 12087, 1655, 12088, 
12044, 57800, 13274, 13257, 57825
21953, 11762, 1498, 1497, 11763, 57050, 12885, 12877, 57058, 11874, 1520, 11875, 11833, 58342, 13241, 58350, 
57827, 57801, 13242, 13225, 57826
21954, 57050, 12885, 12877, 57058, 57051, 12886, 12878, 57059, 58342, 13241, 58350, 57827, 58343, 13243, 58351, 
57830, 57804, 13244, 13227, 57829
21955, 57051, 12886, 12878, 57059, 57052, 12887, 12879, 57060, 58343, 13243, 58351, 57830, 58344, 13245, 58352, 
57833, 57807, 13246, 13229, 57832
21956, 57052, 12887, 12879, 57060, 57053, 12888, 12880, 57061, 58344, 13245, 58352, 57833, 58345, 13247, 58353, 
57836, 57810, 13248, 13231, 57835
21957, 57053, 12888, 12880, 57061, 57054, 12889, 12881, 57062, 58345, 13247, 58353, 57836, 58346, 13249, 58354, 
57839, 57813, 13250, 13233, 57838
21958, 57054, 12889, 12881, 57062, 57055, 12890, 12882, 57063, 58346, 13249, 58354, 57839, 58347, 13251, 58355, 
57842, 57816, 13252, 13235, 57841
21959, 57055, 12890, 12882, 57063, 57056, 12891, 12883, 57064, 58347, 13251, 58355, 57842, 58348, 13253, 58356, 
57845, 57819, 13254, 13237, 57844
21960, 57056, 12891, 12883, 57064, 57057, 12892, 12884, 57065, 58348, 13253, 58356, 57845, 58349, 13255, 58357, 
57848, 57822, 13256, 13239, 57847
21961, 57057, 12892, 12884, 57065, 11976, 1632, 1631, 11977, 58349, 13255, 58357, 57848, 12088, 1654, 12089, 
12046, 57825, 13257, 13240, 57850
21962, 11763, 1497, 1496, 11764, 57058, 12877, 12869, 57066, 11875, 1519, 11876, 11835, 58350, 13224, 58358, 
57852, 57826, 13225, 13208, 57851
21963, 57058, 12877, 12869, 57066, 57059, 12878, 12870, 57067, 58350, 13224, 58358, 57852, 58351, 13226, 58359, 
57855, 57829, 13227, 13210, 57854
21964, 57059, 12878, 12870, 57067, 57060, 12879, 12871, 57068, 58351, 13226, 58359, 57855, 58352, 13228, 58360, 
57858, 57832, 13229, 13212, 57857
21965, 57060, 12879, 12871, 57068, 57061, 12880, 12872, 57069, 58352, 13228, 58360, 57858, 58353, 13230, 58361, 
57861, 57835, 13231, 13214, 57860
21966, 57061, 12880, 12872, 57069, 57062, 12881, 12873, 57070, 58353, 13230, 58361, 57861, 58354, 13232, 58362, 
57864, 57838, 13233, 13216, 57863
21967, 57062, 12881, 12873, 57070, 57063, 12882, 12874, 57071, 58354, 13232, 58362, 57864, 58355, 13234, 58363, 
57867, 57841, 13235, 13218, 57866
21968, 57063, 12882, 12874, 57071, 57064, 12883, 12875, 57072, 58355, 13234, 58363, 57867, 58356, 13236, 58364, 
57870, 57844, 13237, 13220, 57869
21969, 57064, 12883, 12875, 57072, 57065, 12884, 12876, 57073, 58356, 13236, 58364, 57870, 58357, 13238, 58365, 
57873, 57847, 13239, 13222, 57872
21970, 57065, 12884, 12876, 57073, 11977, 1631, 1630, 11978, 58357, 13238, 58365, 57873, 12089, 1653, 12090, 
12048, 57850, 13240, 13223, 57875
21971, 11764, 1496, 1495, 11765, 57066, 12869, 12861, 57074, 11876, 1518, 11877, 11837, 58358, 13207, 58366, 
57877, 57851, 13208, 13191, 57876
21972, 57066, 12869, 12861, 57074, 57067, 12870, 12862, 57075, 58358, 13207, 58366, 57877, 58359, 13209, 58367, 
57880, 57854, 13210, 13193, 57879
21973, 57067, 12870, 12862, 57075, 57068, 12871, 12863, 57076, 58359, 13209, 58367, 57880, 58360, 13211, 58368, 
57883, 57857, 13212, 13195, 57882
21974, 57068, 12871, 12863, 57076, 57069, 12872, 12864, 57077, 58360, 13211, 58368, 57883, 58361, 13213, 58369, 
57886, 57860, 13214, 13197, 57885
21975, 57069, 12872, 12864, 57077, 57070, 12873, 12865, 57078, 58361, 13213, 58369, 57886, 58362, 13215, 58370, 
57889, 57863, 13216, 13199, 57888
21976, 57070, 12873, 12865, 57078, 57071, 12874, 12866, 57079, 58362, 13215, 58370, 57889, 58363, 13217, 58371, 
57892, 57866, 13218, 13201, 57891
21977, 57071, 12874, 12866, 57079, 57072, 12875, 12867, 57080, 58363, 13217, 58371, 57892, 58364, 13219, 58372, 
57895, 57869, 13220, 13203, 57894
21978, 57072, 12875, 12867, 57080, 57073, 12876, 12868, 57081, 58364, 13219, 58372, 57895, 58365, 13221, 58373, 
57898, 57872, 13222, 13205, 57897
21979, 57073, 12876, 12868, 57081, 11978, 1630, 1629, 11979, 58365, 13221, 58373, 57898, 12090, 1652, 12091, 
12050, 57875, 13223, 13206, 57900
21980, 11765, 1495, 1494, 11766, 57074, 12861, 12853, 57082, 11877, 1517, 11878, 11839, 58366, 13190, 58374, 
57902, 57876, 13191, 13174, 57901
21981, 57074, 12861, 12853, 57082, 57075, 12862, 12854, 57083, 58366, 13190, 58374, 57902, 58367, 13192, 58375, 
57905, 57879, 13193, 13176, 57904
21982, 57075, 12862, 12854, 57083, 57076, 12863, 12855, 57084, 58367, 13192, 58375, 57905, 58368, 13194, 58376, 
57908, 57882, 13195, 13178, 57907
21983, 57076, 12863, 12855, 57084, 57077, 12864, 12856, 57085, 58368, 13194, 58376, 57908, 58369, 13196, 58377, 
57911, 57885, 13197, 13180, 57910
21984, 57077, 12864, 12856, 57085, 57078, 12865, 12857, 57086, 58369, 13196, 58377, 57911, 58370, 13198, 58378, 
57914, 57888, 13199, 13182, 57913
21985, 57078, 12865, 12857, 57086, 57079, 12866, 12858, 57087, 58370, 13198, 58378, 57914, 58371, 13200, 58379, 
57917, 57891, 13201, 13184, 57916
21986, 57079, 12866, 12858, 57087, 57080, 12867, 12859, 57088, 58371, 13200, 58379, 57917, 58372, 13202, 58380, 
57920, 57894, 13203, 13186, 57919
21987, 57080, 12867, 12859, 57088, 57081, 12868, 12860, 57089, 58372, 13202, 58380, 57920, 58373, 13204, 58381, 
57923, 57897, 13205, 13188, 57922
21988, 57081, 12868, 12860, 57089, 11979, 1629, 1628, 11980, 58373, 13204, 58381, 57923, 12091, 1651, 12092, 
12052, 57900, 13206, 13189, 57925
21989, 11766, 1494, 1493, 11767, 57082, 12853, 12845, 57090, 11878, 1516, 11879, 11841, 58374, 13173, 58382, 
57927, 57901, 13174, 13157, 57926
21990, 57082, 12853, 12845, 57090, 57083, 12854, 12846, 57091, 58374, 13173, 58382, 57927, 58375, 13175, 58383, 
57930, 57904, 13176, 13159, 57929
21991, 57083, 12854, 12846, 57091, 57084, 12855, 12847, 57092, 58375, 13175, 58383, 57930, 58376, 13177, 58384, 
57933, 57907, 13178, 13161, 57932
21992, 57084, 12855, 12847, 57092, 57085, 12856, 12848, 57093, 58376, 13177, 58384, 57933, 58377, 13179, 58385, 
57936, 57910, 13180, 13163, 57935
21993, 57085, 12856, 12848, 57093, 57086, 12857, 12849, 57094, 58377, 13179, 58385, 57936, 58378, 13181, 58386, 
57939, 57913, 13182, 13165, 57938
21994, 57086, 12857, 12849, 57094, 57087, 12858, 12850, 57095, 58378, 13181, 58386, 57939, 58379, 13183, 58387, 
57942, 57916, 13184, 13167, 57941
21995, 57087, 12858, 12850, 57095, 57088, 12859, 12851, 57096, 58379, 13183, 58387, 57942, 58380, 13185, 58388, 
57945, 57919, 13186, 13169, 57944
21996, 57088, 12859, 12851, 57096, 57089, 12860, 12852, 57097, 58380, 13185, 58388, 57945, 58381, 13187, 58389, 
57948, 57922, 13188, 13171, 57947
21997, 57089, 12860, 12852, 57097, 11980, 1628, 1627, 11981, 58381, 13187, 58389, 57948, 12092, 1650, 12093, 
12054, 57925, 13189, 13172, 57950
21998, 11767, 1493, 1492, 11768, 57090, 12845, 12837, 57098, 11879, 1515, 11880, 11843, 58382, 13156, 58390, 
57952, 57926, 13157, 13140, 57951
21999, 57090, 12845, 12837, 57098, 57091, 12846, 12838, 57099, 58382, 13156, 58390, 57952, 58383, 13158, 58391, 
57955, 57929, 13159, 13142, 57954
22000, 57091, 12846, 12838, 57099, 57092, 12847, 12839, 57100, 58383, 13158, 58391, 57955, 58384, 13160, 58392, 
57958, 57932, 13161, 13144, 57957
22001, 57092, 12847, 12839, 57100, 57093, 12848, 12840, 57101, 58384, 13160, 58392, 57958, 58385, 13162, 58393, 
57961, 57935, 13163, 13146, 57960
22002, 57093, 12848, 12840, 57101, 57094, 12849, 12841, 57102, 58385, 13162, 58393, 57961, 58386, 13164, 58394, 
57964, 57938, 13165, 13148, 57963
22003, 57094, 12849, 12841, 57102, 57095, 12850, 12842, 57103, 58386, 13164, 58394, 57964, 58387, 13166, 58395, 
57967, 57941, 13167, 13150, 57966
22004, 57095, 12850, 12842, 57103, 57096, 12851, 12843, 57104, 58387, 13166, 58395, 57967, 58388, 13168, 58396, 
57970, 57944, 13169, 13152, 57969
22005, 57096, 12851, 12843, 57104, 57097, 12852, 12844, 57105, 58388, 13168, 58396, 57970, 58389, 13170, 58397, 
57973, 57947, 13171, 13154, 57972
22006, 57097, 12852, 12844, 57105, 11981, 1627, 1626, 11982, 58389, 13170, 58397, 57973, 12093, 1649, 12094, 
12056, 57950, 13172, 13155, 57975
22007, 11768, 1492, 1491, 11769, 57098, 12837, 12829, 57106, 11880, 1514, 11881, 11845, 58390, 13139, 58398, 
57977, 57951, 13140, 13123, 57976
22008, 57098, 12837, 12829, 57106, 57099, 12838, 12830, 57107, 58390, 13139, 58398, 57977, 58391, 13141, 58399, 
57980, 57954, 13142, 13125, 57979
22009, 57099, 12838, 12830, 57107, 57100, 12839, 12831, 57108, 58391, 13141, 58399, 57980, 58392, 13143, 58400, 
57983, 57957, 13144, 13127, 57982
22010, 57100, 12839, 12831, 57108, 57101, 12840, 12832, 57109, 58392, 13143, 58400, 57983, 58393, 13145, 58401, 
57986, 57960, 13146, 13129, 57985
22011, 57101, 12840, 12832, 57109, 57102, 12841, 12833, 57110, 58393, 13145, 58401, 57986, 58394, 13147, 58402, 
57989, 57963, 13148, 13131, 57988
22012, 57102, 12841, 12833, 57110, 57103, 12842, 12834, 57111, 58394, 13147, 58402, 57989, 58395, 13149, 58403, 
57992, 57966, 13150, 13133, 57991
22013, 57103, 12842, 12834, 57111, 57104, 12843, 12835, 57112, 58395, 13149, 58403, 57992, 58396, 13151, 58404, 
57995, 57969, 13152, 13135, 57994
22014, 57104, 12843, 12835, 57112, 57105, 12844, 12836, 57113, 58396, 13151, 58404, 57995, 58397, 13153, 58405, 
57998, 57972, 13154, 13137, 57997
22015, 57105, 12844, 12836, 57113, 11982, 1626, 1625, 11983, 58397, 13153, 58405, 57998, 12094, 1648, 12095, 
12058, 57975, 13155, 13138, 58000
22016, 11769, 1491, 1490, 11770, 57106, 12829, 12821, 57114, 11881, 1513, 11882, 11847, 58398, 13122, 58406, 
58002, 57976, 13123, 13106, 58001
22017, 57106, 12829, 12821, 57114, 57107, 12830, 12822, 57115, 58398, 13122, 58406, 58002, 58399, 13124, 58407, 
58005, 57979, 13125, 13108, 58004
22018, 57107, 12830, 12822, 57115, 57108, 12831, 12823, 57116, 58399, 13124, 58407, 58005, 58400, 13126, 58408, 
58008, 57982, 13127, 13110, 58007
22019, 57108, 12831, 12823, 57116, 57109, 12832, 12824, 57117, 58400, 13126, 58408, 58008, 58401, 13128, 58409, 
58011, 57985, 13129, 13112, 58010
22020, 57109, 12832, 12824, 57117, 57110, 12833, 12825, 57118, 58401, 13128, 58409, 58011, 58402, 13130, 58410, 
58014, 57988, 13131, 13114, 58013
22021, 57110, 12833, 12825, 57118, 57111, 12834, 12826, 57119, 58402, 13130, 58410, 58014, 58403, 13132, 58411, 
58017, 57991, 13133, 13116, 58016
22022, 57111, 12834, 12826, 57119, 57112, 12835, 12827, 57120, 58403, 13132, 58411, 58017, 58404, 13134, 58412, 
58020, 57994, 13135, 13118, 58019
22023, 57112, 12835, 12827, 57120, 57113, 12836, 12828, 57121, 58404, 13134, 58412, 58020, 58405, 13136, 58413, 
58023, 57997, 13137, 13120, 58022
22024, 57113, 12836, 12828, 57121, 11983, 1625, 1624, 11984, 58405, 13136, 58413, 58023, 12095, 1647, 12096, 
12060, 58000, 13138, 13121, 58025
22025, 11770, 1490, 1489, 11771, 57114, 12821, 12813, 57122, 11882, 1512, 11883, 11849, 58406, 13105, 58414, 
58027, 58001, 13106, 13089, 58026
22026, 57114, 12821, 12813, 57122, 57115, 12822, 12814, 57123, 58406, 13105, 58414, 58027, 58407, 13107, 58415, 
58030, 58004, 13108, 13091, 58029
22027, 57115, 12822, 12814, 57123, 57116, 12823, 12815, 57124, 58407, 13107, 58415, 58030, 58408, 13109, 58416, 
58033, 58007, 13110, 13093, 58032
22028, 57116, 12823, 12815, 57124, 57117, 12824, 12816, 57125, 58408, 13109, 58416, 58033, 58409, 13111, 58417, 
58036, 58010, 13112, 13095, 58035
22029, 57117, 12824, 12816, 57125, 57118, 12825, 12817, 57126, 58409, 13111, 58417, 58036, 58410, 13113, 58418, 
58039, 58013, 13114, 13097, 58038
22030, 57118, 12825, 12817, 57126, 57119, 12826, 12818, 57127, 58410, 13113, 58418, 58039, 58411, 13115, 58419, 
58042, 58016, 13116, 13099, 58041
22031, 57119, 12826, 12818, 57127, 57120, 12827, 12819, 57128, 58411, 13115, 58419, 58042, 58412, 13117, 58420, 
58045, 58019, 13118, 13101, 58044
22032, 57120, 12827, 12819, 57128, 57121, 12828, 12820, 57129, 58412, 13117, 58420, 58045, 58413, 13119, 58421, 
58048, 58022, 13120, 13103, 58047
22033, 57121, 12828, 12820, 57129, 11984, 1624, 1623, 11985, 58413, 13119, 58421, 58048, 12096, 1646, 12097, 
12062, 58025, 13121, 13104, 58050
22034, 11771, 1489, 1488, 11772, 57122, 12813, 12805, 57130, 11883, 1511, 11884, 11851, 58414, 13088, 58422, 
58052, 58026, 13089, 13072, 58051
22035, 57122, 12813, 12805, 57130, 57123, 12814, 12806, 57131, 58414, 13088, 58422, 58052, 58415, 13090, 58423, 
58055, 58029, 13091, 13074, 58054
22036, 57123, 12814, 12806, 57131, 57124, 12815, 12807, 57132, 58415, 13090, 58423, 58055, 58416, 13092, 58424, 
58058, 58032, 13093, 13076, 58057
22037, 57124, 12815, 12807, 57132, 57125, 12816, 12808, 57133, 58416, 13092, 58424, 58058, 58417, 13094, 58425, 
58061, 58035, 13095, 13078, 58060
22038, 57125, 12816, 12808, 57133, 57126, 12817, 12809, 57134, 58417, 13094, 58425, 58061, 58418, 13096, 58426, 
58064, 58038, 13097, 13080, 58063
22039, 57126, 12817, 12809, 57134, 57127, 12818, 12810, 57135, 58418, 13096, 58426, 58064, 58419, 13098, 58427, 
58067, 58041, 13099, 13082, 58066
22040, 57127, 12818, 12810, 57135, 57128, 12819, 12811, 57136, 58419, 13098, 58427, 58067, 58420, 13100, 58428, 
58070, 58044, 13101, 13084, 58069
22041, 57128, 12819, 12811, 57136, 57129, 12820, 12812, 57137, 58420, 13100, 58428, 58070, 58421, 13102, 58429, 
58073, 58047, 13103, 13086, 58072
22042, 57129, 12820, 12812, 57137, 11985, 1623, 1622, 11986, 58421, 13102, 58429, 58073, 12097, 1645, 12098, 
12064, 58050, 13104, 13087, 58075
22043, 11772, 1488, 1487, 11773, 57130, 12805, 12797, 57138, 11884, 1510, 11885, 11853, 58422, 13071, 58430, 
58077, 58051, 13072, 13055, 58076
22044, 57130, 12805, 12797, 57138, 57131, 12806, 12798, 57139, 58422, 13071, 58430, 58077, 58423, 13073, 58431, 
58080, 58054, 13074, 13057, 58079
22045, 57131, 12806, 12798, 57139, 57132, 12807, 12799, 57140, 58423, 13073, 58431, 58080, 58424, 13075, 58432, 
58083, 58057, 13076, 13059, 58082
22046, 57132, 12807, 12799, 57140, 57133, 12808, 12800, 57141, 58424, 13075, 58432, 58083, 58425, 13077, 58433, 
58086, 58060, 13078, 13061, 58085
22047, 57133, 12808, 12800, 57141, 57134, 12809, 12801, 57142, 58425, 13077, 58433, 58086, 58426, 13079, 58434, 
58089, 58063, 13080, 13063, 58088
22048, 57134, 12809, 12801, 57142, 57135, 12810, 12802, 57143, 58426, 13079, 58434, 58089, 58427, 13081, 58435, 
58092, 58066, 13082, 13065, 58091
22049, 57135, 12810, 12802, 57143, 57136, 12811, 12803, 57144, 58427, 13081, 58435, 58092, 58428, 13083, 58436, 
58095, 58069, 13084, 13067, 58094
22050, 57136, 12811, 12803, 57144, 57137, 12812, 12804, 57145, 58428, 13083, 58436, 58095, 58429, 13085, 58437, 
58098, 58072, 13086, 13069, 58097
22051, 57137, 12812, 12804, 57145, 11986, 1622, 1621, 11987, 58429, 13085, 58437, 58098, 12098, 1644, 12099, 
12066, 58075, 13087, 13070, 58100
22052, 11773, 1487, 1486, 11774, 57138, 12797, 12789, 57146, 11885, 1509, 11886, 11855, 58430, 13054, 58438, 
58102, 58076, 13055, 13038, 58101
22053, 57138, 12797, 12789, 57146, 57139, 12798, 12790, 57147, 58430, 13054, 58438, 58102, 58431, 13056, 58439, 
58105, 58079, 13057, 13040, 58104
22054, 57139, 12798, 12790, 57147, 57140, 12799, 12791, 57148, 58431, 13056, 58439, 58105, 58432, 13058, 58440, 
58108, 58082, 13059, 13042, 58107
22055, 57140, 12799, 12791, 57148, 57141, 12800, 12792, 57149, 58432, 13058, 58440, 58108, 58433, 13060, 58441, 
58111, 58085, 13061, 13044, 58110
22056, 57141, 12800, 12792, 57149, 57142, 12801, 12793, 57150, 58433, 13060, 58441, 58111, 58434, 13062, 58442, 
58114, 58088, 13063, 13046, 58113
22057, 57142, 12801, 12793, 57150, 57143, 12802, 12794, 57151, 58434, 13062, 58442, 58114, 58435, 13064, 58443, 
58117, 58091, 13065, 13048, 58116
22058, 57143, 12802, 12794, 57151, 57144, 12803, 12795, 57152, 58435, 13064, 58443, 58117, 58436, 13066, 58444, 
58120, 58094, 13067, 13050, 58119
22059, 57144, 12803, 12795, 57152, 57145, 12804, 12796, 57153, 58436, 13066, 58444, 58120, 58437, 13068, 58445, 
58123, 58097, 13069, 13052, 58122
22060, 57145, 12804, 12796, 57153, 11987, 1621, 1620, 11988, 58437, 13068, 58445, 58123, 12099, 1643, 12100, 
12068, 58100, 13070, 13053, 58125
22061, 11774, 1486, 1485, 11775, 57146, 12789, 12781, 57154, 11886, 1508, 11887, 11857, 58438, 13037, 58446, 
58127, 58101, 13038, 13021, 58126
22062, 57146, 12789, 12781, 57154, 57147, 12790, 12782, 57155, 58438, 13037, 58446, 58127, 58439, 13039, 58447, 
58130, 58104, 13040, 13023, 58129
22063, 57147, 12790, 12782, 57155, 57148, 12791, 12783, 57156, 58439, 13039, 58447, 58130, 58440, 13041, 58448, 
58133, 58107, 13042, 13025, 58132
22064, 57148, 12791, 12783, 57156, 57149, 12792, 12784, 57157, 58440, 13041, 58448, 58133, 58441, 13043, 58449, 
58136, 58110, 13044, 13027, 58135
22065, 57149, 12792, 12784, 57157, 57150, 12793, 12785, 57158, 58441, 13043, 58449, 58136, 58442, 13045, 58450, 
58139, 58113, 13046, 13029, 58138
22066, 57150, 12793, 12785, 57158, 57151, 12794, 12786, 57159, 58442, 13045, 58450, 58139, 58443, 13047, 58451, 
58142, 58116, 13048, 13031, 58141
22067, 57151, 12794, 12786, 57159, 57152, 12795, 12787, 57160, 58443, 13047, 58451, 58142, 58444, 13049, 58452, 
58145, 58119, 13050, 13033, 58144
22068, 57152, 12795, 12787, 57160, 57153, 12796, 12788, 57161, 58444, 13049, 58452, 58145, 58445, 13051, 58453, 
58148, 58122, 13052, 13035, 58147
22069, 57153, 12796, 12788, 57161, 11988, 1620, 1619, 11989, 58445, 13051, 58453, 58148, 12100, 1642, 12101, 
12070, 58125, 13053, 13036, 58150
22070, 11775, 1485, 1484, 11776, 57154, 12781, 12773, 57162, 11887, 1507, 11888, 11859, 58446, 13020, 58454, 
58152, 58126, 13021, 13004, 58151
22071, 57154, 12781, 12773, 57162, 57155, 12782, 12774, 57163, 58446, 13020, 58454, 58152, 58447, 13022, 58455, 
58155, 58129, 13023, 13006, 58154
22072, 57155, 12782, 12774, 57163, 57156, 12783, 12775, 57164, 58447, 13022, 58455, 58155, 58448, 13024, 58456, 
58158, 58132, 13025, 13008, 58157
22073, 57156, 12783, 12775, 57164, 57157, 12784, 12776, 57165, 58448, 13024, 58456, 58158, 58449, 13026, 58457, 
58161, 58135, 13027, 13010, 58160
22074, 57157, 12784, 12776, 57165, 57158, 12785, 12777, 57166, 58449, 13026, 58457, 58161, 58450, 13028, 58458, 
58164, 58138, 13029, 13012, 58163
22075, 57158, 12785, 12777, 57166, 57159, 12786, 12778, 57167, 58450, 13028, 58458, 58164, 58451, 13030, 58459, 
58167, 58141, 13031, 13014, 58166
22076, 57159, 12786, 12778, 57167, 57160, 12787, 12779, 57168, 58451, 13030, 58459, 58167, 58452, 13032, 58460, 
58170, 58144, 13033, 13016, 58169
22077, 57160, 12787, 12779, 57168, 57161, 12788, 12780, 57169, 58452, 13032, 58460, 58170, 58453, 13034, 58461, 
58173, 58147, 13035, 13018, 58172
22078, 57161, 12788, 12780, 57169, 11989, 1619, 1618, 11990, 58453, 13034, 58461, 58173, 12101, 1641, 12102, 
12072, 58150, 13036, 13019, 58175
22079, 11776, 1484, 1483, 11777, 57162, 12773, 12765, 57170, 11888, 1506, 11889, 11861, 58454, 13003, 58462, 
58177, 58151, 13004, 12987, 58176
22080, 57162, 12773, 12765, 57170, 57163, 12774, 12766, 57171, 58454, 13003, 58462, 58177, 58455, 13005, 58463, 
58180, 58154, 13006, 12989, 58179
22081, 57163, 12774, 12766, 57171, 57164, 12775, 12767, 57172, 58455, 13005, 58463, 58180, 58456, 13007, 58464, 
58183, 58157, 13008, 12991, 58182
22082, 57164, 12775, 12767, 57172, 57165, 12776, 12768, 57173, 58456, 13007, 58464, 58183, 58457, 13009, 58465, 
58186, 58160, 13010, 12993, 58185
22083, 57165, 12776, 12768, 57173, 57166, 12777, 12769, 57174, 58457, 13009, 58465, 58186, 58458, 13011, 58466, 
58189, 58163, 13012, 12995, 58188
22084, 57166, 12777, 12769, 57174, 57167, 12778, 12770, 57175, 58458, 13011, 58466, 58189, 58459, 13013, 58467, 
58192, 58166, 13014, 12997, 58191
22085, 57167, 12778, 12770, 57175, 57168, 12779, 12771, 57176, 58459, 13013, 58467, 58192, 58460, 13015, 58468, 
58195, 58169, 13016, 12999, 58194
22086, 57168, 12779, 12771, 57176, 57169, 12780, 12772, 57177, 58460, 13015, 58468, 58195, 58461, 13017, 58469, 
58198, 58172, 13018, 13001, 58197
22087, 57169, 12780, 12772, 57177, 11990, 1618, 1617, 11991, 58461, 13017, 58469, 58198, 12102, 1640, 12103, 
12074, 58175, 13019, 13002, 58200
22088, 11777, 1483, 1482, 11778, 57170, 12765, 12757, 57178, 11889, 1505, 11890, 11863, 58462, 12986, 58470, 
58202, 58176, 12987, 12970, 58201
22089, 57170, 12765, 12757, 57178, 57171, 12766, 12758, 57179, 58462, 12986, 58470, 58202, 58463, 12988, 58471, 
58205, 58179, 12989, 12972, 58204
22090, 57171, 12766, 12758, 57179, 57172, 12767, 12759, 57180, 58463, 12988, 58471, 58205, 58464, 12990, 58472, 
58208, 58182, 12991, 12974, 58207
22091, 57172, 12767, 12759, 57180, 57173, 12768, 12760, 57181, 58464, 12990, 58472, 58208, 58465, 12992, 58473, 
58211, 58185, 12993, 12976, 58210
22092, 57173, 12768, 12760, 57181, 57174, 12769, 12761, 57182, 58465, 12992, 58473, 58211, 58466, 12994, 58474, 
58214, 58188, 12995, 12978, 58213
22093, 57174, 12769, 12761, 57182, 57175, 12770, 12762, 57183, 58466, 12994, 58474, 58214, 58467, 12996, 58475, 
58217, 58191, 12997, 12980, 58216
22094, 57175, 12770, 12762, 57183, 57176, 12771, 12763, 57184, 58467, 12996, 58475, 58217, 58468, 12998, 58476, 
58220, 58194, 12999, 12982, 58219
22095, 57176, 12771, 12763, 57184, 57177, 12772, 12764, 57185, 58468, 12998, 58476, 58220, 58469, 13000, 58477, 
58223, 58197, 13001, 12984, 58222
22096, 57177, 12772, 12764, 57185, 11991, 1617, 1616, 11992, 58469, 13000, 58477, 58223, 12103, 1639, 12104, 
12076, 58200, 13002, 12985, 58225
22097, 11778, 1482, 1481, 11779, 57178, 12757, 12749, 57186, 11890, 1504, 11891, 11865, 58470, 12969, 58478, 
58227, 58201, 12970, 12953, 58226
22098, 57178, 12757, 12749, 57186, 57179, 12758, 12750, 57187, 58470, 12969, 58478, 58227, 58471, 12971, 58479, 
58230, 58204, 12972, 12955, 58229
22099, 57179, 12758, 12750, 57187, 57180, 12759, 12751, 57188, 58471, 12971, 58479, 58230, 58472, 12973, 58480, 
58233, 58207, 12974, 12957, 58232
22100, 57180, 12759, 12751, 57188, 57181, 12760, 12752, 57189, 58472, 12973, 58480, 58233, 58473, 12975, 58481, 
58236, 58210, 12976, 12959, 58235
22101, 57181, 12760, 12752, 57189, 57182, 12761, 12753, 57190, 58473, 12975, 58481, 58236, 58474, 12977, 58482, 
58239, 58213, 12978, 12961, 58238
22102, 57182, 12761, 12753, 57190, 57183, 12762, 12754, 57191, 58474, 12977, 58482, 58239, 58475, 12979, 58483, 
58242, 58216, 12980, 12963, 58241
22103, 57183, 12762, 12754, 57191, 57184, 12763, 12755, 57192, 58475, 12979, 58483, 58242, 58476, 12981, 58484, 
58245, 58219, 12982, 12965, 58244
22104, 57184, 12763, 12755, 57192, 57185, 12764, 12756, 57193, 58476, 12981, 58484, 58245, 58477, 12983, 58485, 
58248, 58222, 12984, 12967, 58247
22105, 57185, 12764, 12756, 57193, 11992, 1616, 1615, 11993, 58477, 12983, 58485, 58248, 12104, 1638, 12105, 
12078, 58225, 12985, 12968, 58250
22106, 11779, 1481, 1480, 11780, 57186, 12749, 12741, 57194, 11891, 1503, 11892, 11867, 58478, 12952, 58486, 
58252, 58226, 12953, 12936, 58251
22107, 57186, 12749, 12741, 57194, 57187, 12750, 12742, 57195, 58478, 12952, 58486, 58252, 58479, 12954, 58487, 
58255, 58229, 12955, 12938, 58254
22108, 57187, 12750, 12742, 57195, 57188, 12751, 12743, 57196, 58479, 12954, 58487, 58255, 58480, 12956, 58488, 
58258, 58232, 12957, 12940, 58257
22109, 57188, 12751, 12743, 57196, 57189, 12752, 12744, 57197, 58480, 12956, 58488, 58258, 58481, 12958, 58489, 
58261, 58235, 12959, 12942, 58260
22110, 57189, 12752, 12744, 57197, 57190, 12753, 12745, 57198, 58481, 12958, 58489, 58261, 58482, 12960, 58490, 
58264, 58238, 12961, 12944, 58263
22111, 57190, 12753, 12745, 57198, 57191, 12754, 12746, 57199, 58482, 12960, 58490, 58264, 58483, 12962, 58491, 
58267, 58241, 12963, 12946, 58266
22112, 57191, 12754, 12746, 57199, 57192, 12755, 12747, 57200, 58483, 12962, 58491, 58267, 58484, 12964, 58492, 
58270, 58244, 12965, 12948, 58269
22113, 57192, 12755, 12747, 57200, 57193, 12756, 12748, 57201, 58484, 12964, 58492, 58270, 58485, 12966, 58493, 
58273, 58247, 12967, 12950, 58272
22114, 57193, 12756, 12748, 57201, 11993, 1615, 1614, 11994, 58485, 12966, 58493, 58273, 12105, 1637, 12106, 
12080, 58250, 12968, 12951, 58275
22115, 11780, 1480, 1479, 11781, 57194, 12741, 12733, 57202, 11892, 1502, 11893, 11869, 58486, 12935, 58494, 
58277, 58251, 12936, 12919, 58276
22116, 57194, 12741, 12733, 57202, 57195, 12742, 12734, 57203, 58486, 12935, 58494, 58277, 58487, 12937, 58495, 
58280, 58254, 12938, 12921, 58279
22117, 57195, 12742, 12734, 57203, 57196, 12743, 12735, 57204, 58487, 12937, 58495, 58280, 58488, 12939, 58496, 
58283, 58257, 12940, 12923, 58282
22118, 57196, 12743, 12735, 57204, 57197, 12744, 12736, 57205, 58488, 12939, 58496, 58283, 58489, 12941, 58497, 
58286, 58260, 12942, 12925, 58285
22119, 57197, 12744, 12736, 57205, 57198, 12745, 12737, 57206, 58489, 12941, 58497, 58286, 58490, 12943, 58498, 
58289, 58263, 12944, 12927, 58288
22120, 57198, 12745, 12737, 57206, 57199, 12746, 12738, 57207, 58490, 12943, 58498, 58289, 58491, 12945, 58499, 
58292, 58266, 12946, 12929, 58291
22121, 57199, 12746, 12738, 57207, 57200, 12747, 12739, 57208, 58491, 12945, 58499, 58292, 58492, 12947, 58500, 
58295, 58269, 12948, 12931, 58294
22122, 57200, 12747, 12739, 57208, 57201, 12748, 12740, 57209, 58492, 12947, 58500, 58295, 58493, 12949, 58501, 
58298, 58272, 12950, 12933, 58297
22123, 57201, 12748, 12740, 57209, 11994, 1614, 1613, 11995, 58493, 12949, 58501, 58298, 12106, 1636, 12107, 
12082, 58275, 12951, 12934, 58300
22124, 11781, 1479, 1478, 11782, 57202, 12733, 12725, 57210, 11893, 1501, 11894, 11871, 58494, 12918, 58502, 
58302, 58276, 12919, 12902, 58301
22125, 57202, 12733, 12725, 57210, 57203, 12734, 12726, 57211, 58494, 12918, 58502, 58302, 58495, 12920, 58503, 
58305, 58279, 12921, 12904, 58304
22126, 57203, 12734, 12726, 57211, 57204, 12735, 12727, 57212, 58495, 12920, 58503, 58305, 58496, 12922, 58504, 
58308, 58282, 12923, 12906, 58307
22127, 57204, 12735, 12727, 57212, 57205, 12736, 12728, 57213, 58496, 12922, 58504, 58308, 58497, 12924, 58505, 
58311, 58285, 12925, 12908, 58310
22128, 57205, 12736, 12728, 57213, 57206, 12737, 12729, 57214, 58497, 12924, 58505, 58311, 58498, 12926, 58506, 
58314, 58288, 12927, 12910, 58313
22129, 57206, 12737, 12729, 57214, 57207, 12738, 12730, 57215, 58498, 12926, 58506, 58314, 58499, 12928, 58507, 
58317, 58291, 12929, 12912, 58316
22130, 57207, 12738, 12730, 57215, 57208, 12739, 12731, 57216, 58499, 12928, 58507, 58317, 58500, 12930, 58508, 
58320, 58294, 12931, 12914, 58319
22131, 57208, 12739, 12731, 57216, 57209, 12740, 12732, 57217, 58500, 12930, 58508, 58320, 58501, 12932, 58509, 
58323, 58297, 12933, 12916, 58322
22132, 57209, 12740, 12732, 57217, 11995, 1613, 1612, 11996, 58501, 12932, 58509, 58323, 12107, 1635, 12108, 
12084, 58300, 12934, 12917, 58325
22133, 11782, 1478, 48, 1429, 57210, 12725, 1674, 12124, 11894, 1500, 1432, 11872, 58502, 12901, 12166, 
58326, 58301, 12902, 1682, 12158
22134, 57210, 12725, 1674, 12124, 57211, 12726, 1675, 12123, 58502, 12901, 12166, 58326, 58503, 12903, 12165, 
58327, 58304, 12904, 1683, 12156
22135, 57211, 12726, 1675, 12123, 57212, 12727, 1676, 12122, 58503, 12903, 12165, 58327, 58504, 12905, 12164, 
58328, 58307, 12906, 1684, 12154
22136, 57212, 12727, 1676, 12122, 57213, 12728, 1677, 12121, 58504, 12905, 12164, 58328, 58505, 12907, 12163, 
58329, 58310, 12908, 1685, 12152
22137, 57213, 12728, 1677, 12121, 57214, 12729, 1678, 12120, 58505, 12907, 12163, 58329, 58506, 12909, 12162, 
58330, 58313, 12910, 1686, 12150
22138, 57214, 12729, 1678, 12120, 57215, 12730, 1679, 12119, 58506, 12909, 12162, 58330, 58507, 12911, 12161, 
58331, 58316, 12912, 1687, 12148
22139, 57215, 12730, 1679, 12119, 57216, 12731, 1680, 12118, 58507, 12911, 12161, 58331, 58508, 12913, 12160, 
58332, 58319, 12914, 1688, 12146
22140, 57216, 12731, 1680, 12118, 57217, 12732, 1681, 12117, 58508, 12913, 12160, 58332, 58509, 12915, 12159, 
58333, 58322, 12916, 1689, 12144
22141, 57217, 12732, 1681, 12117, 11996, 1612, 52, 1563, 58509, 12915, 12159, 58333, 12108, 1634, 1566, 
12086, 58325, 12917, 1690, 12142
*ELEMENT, type=C3D20, ELSET=Volume6
22142, 13283, 1691, 49, 1523, 58510, 13329, 1535, 11895, 13289, 1694, 1525, 13290, 58559, 13353, 11911, 
58560, 58558, 13354, 1544, 11912
22143, 58510, 13329, 1535, 11895, 58511, 13330, 1534, 11896, 58559, 13353, 11911, 58560, 58562, 13355, 11913, 
58563, 58561, 13356, 1543, 11914
22144, 58511, 13330, 1534, 11896, 58512, 13331, 1533, 11897, 58562, 13355, 11913, 58563, 58565, 13357, 11915, 
58566, 58564, 13358, 1542, 11916
22145, 58512, 13331, 1533, 11897, 58513, 13332, 1532, 11898, 58565, 13357, 11915, 58566, 58568, 13359, 11917, 
58569, 58567, 13360, 1541, 11918
22146, 58513, 13332, 1532, 11898, 58514, 13333, 1531, 11899, 58568, 13359, 11917, 58569, 58571, 13361, 11919, 
58572, 58570, 13362, 1540, 11920
22147, 58514, 13333, 1531, 11899, 58515, 13334, 1530, 11900, 58571, 13361, 11919, 58572, 58574, 13363, 11921, 
58575, 58573, 13364, 1539, 11922
22148, 58515, 13334, 1530, 11900, 58516, 13335, 1529, 11901, 58574, 13363, 11921, 58575, 58577, 13365, 11923, 
58578, 58576, 13366, 1538, 11924
