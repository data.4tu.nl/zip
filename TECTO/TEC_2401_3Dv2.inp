65393, 1.5695652173913, 1.2978260869565, 0.11111111111111
65394, 1.5913043478261, 1.3239130434783, 0.11111111111111
65395, 1.5913043478261, 1.2978260869565, 0.083333333333333
65396, 1.5695652173913, 1.2978260869565, 0.055555555555556
65397, 1.5913043478261, 1.3239130434783, 0.055555555555556
65398, 1.5913043478261, 1.2978260869565, 0.027777777777778
65399, 1.6347826086957, 1.2978260869565, 0.47222222222222
65400, 1.6130434782609, 1.2978260869565, 0.44444444444444
65401, 1.6347826086957, 1.3239130434783, 0.44444444444444
65402, 1.6347826086957, 1.2978260869565, 0.41666666666667
65403, 1.6130434782609, 1.2978260869565, 0.38888888888889
65404, 1.6347826086957, 1.3239130434783, 0.38888888888889
65405, 1.6347826086957, 1.2978260869565, 0.36111111111111
65406, 1.6130434782609, 1.2978260869565, 0.33333333333333
65407, 1.6347826086957, 1.3239130434783, 0.33333333333333
65408, 1.6347826086957, 1.2978260869565, 0.30555555555556
65409, 1.6130434782609, 1.2978260869565, 0.27777777777778
65410, 1.6347826086957, 1.3239130434783, 0.27777777777778
65411, 1.6347826086957, 1.2978260869565, 0.25
65412, 1.6130434782609, 1.2978260869565, 0.22222222222222
65413, 1.6347826086957, 1.3239130434783, 0.22222222222222
65414, 1.6347826086957, 1.2978260869565, 0.19444444444444
65415, 1.6130434782609, 1.2978260869565, 0.16666666666667
65416, 1.6347826086957, 1.3239130434783, 0.16666666666667
65417, 1.6347826086957, 1.2978260869565, 0.13888888888889
65418, 1.6130434782609, 1.2978260869565, 0.11111111111111
65419, 1.6347826086957, 1.3239130434783, 0.11111111111111
65420, 1.6347826086957, 1.2978260869565, 0.083333333333333
65421, 1.6130434782609, 1.2978260869565, 0.055555555555556
65422, 1.6347826086957, 1.3239130434783, 0.055555555555556
65423, 1.6347826086957, 1.2978260869565, 0.027777777777778
65424, 1.6782608695652, 1.2978260869565, 0.47222222222222
65425, 1.6565217391304, 1.2978260869565, 0.44444444444444
65426, 1.6782608695652, 1.3239130434783, 0.44444444444444
65427, 1.6782608695652, 1.2978260869565, 0.41666666666667
65428, 1.6565217391304, 1.2978260869565, 0.38888888888889
65429, 1.6782608695652, 1.3239130434783, 0.38888888888889
65430, 1.6782608695652, 1.2978260869565, 0.36111111111111
65431, 1.6565217391304, 1.2978260869565, 0.33333333333333
65432, 1.6782608695652, 1.3239130434783, 0.33333333333333
65433, 1.6782608695652, 1.2978260869565, 0.30555555555556
65434, 1.6565217391304, 1.2978260869565, 0.27777777777778
65435, 1.6782608695652, 1.3239130434783, 0.27777777777778
65436, 1.6782608695652, 1.2978260869565, 0.25
65437, 1.6565217391304, 1.2978260869565, 0.22222222222222
65438, 1.6782608695652, 1.3239130434783, 0.22222222222222
65439, 1.6782608695652, 1.2978260869565, 0.19444444444444
65440, 1.6565217391304, 1.2978260869565, 0.16666666666667
65441, 1.6782608695652, 1.3239130434783, 0.16666666666667
65442, 1.6782608695652, 1.2978260869565, 0.13888888888889
65443, 1.6565217391304, 1.2978260869565, 0.11111111111111
65444, 1.6782608695652, 1.3239130434783, 0.11111111111111
65445, 1.6782608695652, 1.2978260869565, 0.083333333333333
65446, 1.6565217391304, 1.2978260869565, 0.055555555555556
65447, 1.6782608695652, 1.3239130434783, 0.055555555555556
65448, 1.6782608695652, 1.2978260869565, 0.027777777777778
65449, 1.7217391304348, 1.2978260869565, 0.47222222222222
65450, 1.7, 1.2978260869565, 0.44444444444444
65451, 1.7217391304348, 1.3239130434783, 0.44444444444444
65452, 1.7217391304348, 1.2978260869565, 0.41666666666667
65453, 1.7, 1.2978260869565, 0.38888888888889
65454, 1.7217391304348, 1.3239130434783, 0.38888888888889
65455, 1.7217391304348, 1.2978260869565, 0.36111111111111
65456, 1.7, 1.2978260869565, 0.33333333333333
65457, 1.7217391304348, 1.3239130434783, 0.33333333333333
65458, 1.7217391304348, 1.2978260869565, 0.30555555555556
65459, 1.7, 1.2978260869565, 0.27777777777778
65460, 1.7217391304348, 1.3239130434783, 0.27777777777778
65461, 1.7217391304348, 1.2978260869565, 0.25
65462, 1.7, 1.2978260869565, 0.22222222222222
65463, 1.7217391304348, 1.3239130434783, 0.22222222222222
65464, 1.7217391304348, 1.2978260869565, 0.19444444444444
65465, 1.7, 1.2978260869565, 0.16666666666667
65466, 1.7217391304348, 1.3239130434783, 0.16666666666667
65467, 1.7217391304348, 1.2978260869565, 0.13888888888889
65468, 1.7, 1.2978260869565, 0.11111111111111
65469, 1.7217391304348, 1.3239130434783, 0.11111111111111
65470, 1.7217391304348, 1.2978260869565, 0.083333333333333
65471, 1.7, 1.2978260869565, 0.055555555555556
65472, 1.7217391304348, 1.3239130434783, 0.055555555555556
65473, 1.7217391304348, 1.2978260869565, 0.027777777777778
65474, 1.7652173913043, 1.2978260869565, 0.47222222222222
65475, 1.7434782608696, 1.2978260869565, 0.44444444444444
65476, 1.7652173913043, 1.3239130434783, 0.44444444444444
65477, 1.7652173913043, 1.2978260869565, 0.41666666666667
65478, 1.7434782608696, 1.2978260869565, 0.38888888888889
65479, 1.7652173913043, 1.3239130434783, 0.38888888888889
65480, 1.7652173913043, 1.2978260869565, 0.36111111111111
65481, 1.7434782608696, 1.2978260869565, 0.33333333333333
65482, 1.7652173913043, 1.3239130434783, 0.33333333333333
65483, 1.7652173913043, 1.2978260869565, 0.30555555555556
65484, 1.7434782608696, 1.2978260869565, 0.27777777777778
65485, 1.7652173913043, 1.3239130434783, 0.27777777777778
65486, 1.7652173913043, 1.2978260869565, 0.25
65487, 1.7434782608696, 1.2978260869565, 0.22222222222222
65488, 1.7652173913043, 1.3239130434783, 0.22222222222222
65489, 1.7652173913043, 1.2978260869565, 0.19444444444444
65490, 1.7434782608696, 1.2978260869565, 0.16666666666667
65491, 1.7652173913043, 1.3239130434783, 0.16666666666667
65492, 1.7652173913043, 1.2978260869565, 0.13888888888889
65493, 1.7434782608696, 1.2978260869565, 0.11111111111111
65494, 1.7652173913043, 1.3239130434783, 0.11111111111111
65495, 1.7652173913043, 1.2978260869565, 0.083333333333333
65496, 1.7434782608696, 1.2978260869565, 0.055555555555556
65497, 1.7652173913043, 1.3239130434783, 0.055555555555556
65498, 1.7652173913043, 1.2978260869565, 0.027777777777778
65499, 1.8086956521739, 1.2978260869565, 0.47222222222222
65500, 1.7869565217391, 1.2978260869565, 0.44444444444444
65501, 1.8086956521739, 1.3239130434783, 0.44444444444444
65502, 1.8086956521739, 1.2978260869565, 0.41666666666667
65503, 1.7869565217391, 1.2978260869565, 0.38888888888889
65504, 1.8086956521739, 1.3239130434783, 0.38888888888889
65505, 1.8086956521739, 1.2978260869565, 0.36111111111111
65506, 1.7869565217391, 1.2978260869565, 0.33333333333333
65507, 1.8086956521739, 1.3239130434783, 0.33333333333333
65508, 1.8086956521739, 1.2978260869565, 0.30555555555556
65509, 1.7869565217391, 1.2978260869565, 0.27777777777778
65510, 1.8086956521739, 1.3239130434783, 0.27777777777778
65511, 1.8086956521739, 1.2978260869565, 0.25
65512, 1.7869565217391, 1.2978260869565, 0.22222222222222
65513, 1.8086956521739, 1.3239130434783, 0.22222222222222
65514, 1.8086956521739, 1.2978260869565, 0.19444444444444
65515, 1.7869565217391, 1.2978260869565, 0.16666666666667
65516, 1.8086956521739, 1.3239130434783, 0.16666666666667
65517, 1.8086956521739, 1.2978260869565, 0.13888888888889
65518, 1.7869565217391, 1.2978260869565, 0.11111111111111
65519, 1.8086956521739, 1.3239130434783, 0.11111111111111
65520, 1.8086956521739, 1.2978260869565, 0.083333333333333
65521, 1.7869565217391, 1.2978260869565, 0.055555555555556
65522, 1.8086956521739, 1.3239130434783, 0.055555555555556
65523, 1.8086956521739, 1.2978260869565, 0.027777777777778
65524, 1.8521739130435, 1.2978260869565, 0.47222222222222
65525, 1.8304347826087, 1.2978260869565, 0.44444444444444
65526, 1.8521739130435, 1.3239130434783, 0.44444444444444
65527, 1.8521739130435, 1.2978260869565, 0.41666666666667
65528, 1.8304347826087, 1.2978260869565, 0.38888888888889
65529, 1.8521739130435, 1.3239130434783, 0.38888888888889
65530, 1.8521739130435, 1.2978260869565, 0.36111111111111
65531, 1.8304347826087, 1.2978260869565, 0.33333333333333
65532, 1.8521739130435, 1.3239130434783, 0.33333333333333
65533, 1.8521739130435, 1.2978260869565, 0.30555555555556
65534, 1.8304347826087, 1.2978260869565, 0.27777777777778
65535, 1.8521739130435, 1.3239130434783, 0.27777777777778
65536, 1.8521739130435, 1.2978260869565, 0.25
65537, 1.8304347826087, 1.2978260869565, 0.22222222222222
65538, 1.8521739130435, 1.3239130434783, 0.22222222222222
65539, 1.8521739130435, 1.2978260869565, 0.19444444444444
65540, 1.8304347826087, 1.2978260869565, 0.16666666666667
65541, 1.8521739130435, 1.3239130434783, 0.16666666666667
65542, 1.8521739130435, 1.2978260869565, 0.13888888888889
65543, 1.8304347826087, 1.2978260869565, 0.11111111111111
65544, 1.8521739130435, 1.3239130434783, 0.11111111111111
65545, 1.8521739130435, 1.2978260869565, 0.083333333333333
65546, 1.8304347826087, 1.2978260869565, 0.055555555555556
65547, 1.8521739130435, 1.3239130434783, 0.055555555555556
65548, 1.8521739130435, 1.2978260869565, 0.027777777777778
65549, 1.895652173913, 1.2978260869565, 0.47222222222222
65550, 1.8739130434783, 1.2978260869565, 0.44444444444444
65551, 1.895652173913, 1.3239130434783, 0.44444444444444
65552, 1.895652173913, 1.2978260869565, 0.41666666666667
65553, 1.8739130434783, 1.2978260869565, 0.38888888888889
65554, 1.895652173913, 1.3239130434783, 0.38888888888889
65555, 1.895652173913, 1.2978260869565, 0.36111111111111
65556, 1.8739130434783, 1.2978260869565, 0.33333333333333
65557, 1.895652173913, 1.3239130434783, 0.33333333333333
65558, 1.895652173913, 1.2978260869565, 0.30555555555556
65559, 1.8739130434783, 1.2978260869565, 0.27777777777778
65560, 1.895652173913, 1.3239130434783, 0.27777777777778
65561, 1.895652173913, 1.2978260869565, 0.25
65562, 1.8739130434783, 1.2978260869565, 0.22222222222222
65563, 1.895652173913, 1.3239130434783, 0.22222222222222
65564, 1.895652173913, 1.2978260869565, 0.19444444444444
65565, 1.8739130434783, 1.2978260869565, 0.16666666666667
65566, 1.895652173913, 1.3239130434783, 0.16666666666667
65567, 1.895652173913, 1.2978260869565, 0.13888888888889
65568, 1.8739130434783, 1.2978260869565, 0.11111111111111
65569, 1.895652173913, 1.3239130434783, 0.11111111111111
65570, 1.895652173913, 1.2978260869565, 0.083333333333333
65571, 1.8739130434783, 1.2978260869565, 0.055555555555556
65572, 1.895652173913, 1.3239130434783, 0.055555555555556
65573, 1.895652173913, 1.2978260869565, 0.027777777777778
65574, 1.9391304347826, 1.2978260869565, 0.47222222222222
65575, 1.9173913043478, 1.2978260869565, 0.44444444444444
65576, 1.9391304347826, 1.3239130434783, 0.44444444444444
65577, 1.9391304347826, 1.2978260869565, 0.41666666666667
65578, 1.9173913043478, 1.2978260869565, 0.38888888888889
65579, 1.9391304347826, 1.3239130434783, 0.38888888888889
65580, 1.9391304347826, 1.2978260869565, 0.36111111111111
65581, 1.9173913043478, 1.2978260869565, 0.33333333333333
65582, 1.9391304347826, 1.3239130434783, 0.33333333333333
65583, 1.9391304347826, 1.2978260869565, 0.30555555555556
65584, 1.9173913043478, 1.2978260869565, 0.27777777777778
65585, 1.9391304347826, 1.3239130434783, 0.27777777777778
65586, 1.9391304347826, 1.2978260869565, 0.25
65587, 1.9173913043478, 1.2978260869565, 0.22222222222222
65588, 1.9391304347826, 1.3239130434783, 0.22222222222222
65589, 1.9391304347826, 1.2978260869565, 0.19444444444444
65590, 1.9173913043478, 1.2978260869565, 0.16666666666667
65591, 1.9391304347826, 1.3239130434783, 0.16666666666667
65592, 1.9391304347826, 1.2978260869565, 0.13888888888889
65593, 1.9173913043478, 1.2978260869565, 0.11111111111111
65594, 1.9391304347826, 1.3239130434783, 0.11111111111111
65595, 1.9391304347826, 1.2978260869565, 0.083333333333333
65596, 1.9173913043478, 1.2978260869565, 0.055555555555556
65597, 1.9391304347826, 1.3239130434783, 0.055555555555556
65598, 1.9391304347826, 1.2978260869565, 0.027777777777778
65599, 1.9826086956522, 1.2978260869565, 0.47222222222222
65600, 1.9608695652174, 1.2978260869565, 0.44444444444444
65601, 1.9826086956522, 1.3239130434783, 0.44444444444444
65602, 1.9826086956522, 1.2978260869565, 0.41666666666667
65603, 1.9608695652174, 1.2978260869565, 0.38888888888889
65604, 1.9826086956522, 1.3239130434783, 0.38888888888889
65605, 1.9826086956522, 1.2978260869565, 0.36111111111111
65606, 1.9608695652174, 1.2978260869565, 0.33333333333333
65607, 1.9826086956522, 1.3239130434783, 0.33333333333333
65608, 1.9826086956522, 1.2978260869565, 0.30555555555556
65609, 1.9608695652174, 1.2978260869565, 0.27777777777778
65610, 1.9826086956522, 1.3239130434783, 0.27777777777778
65611, 1.9826086956522, 1.2978260869565, 0.25
65612, 1.9608695652174, 1.2978260869565, 0.22222222222222
65613, 1.9826086956522, 1.3239130434783, 0.22222222222222
65614, 1.9826086956522, 1.2978260869565, 0.19444444444444
65615, 1.9608695652174, 1.2978260869565, 0.16666666666667
65616, 1.9826086956522, 1.3239130434783, 0.16666666666667
65617, 1.9826086956522, 1.2978260869565, 0.13888888888889
65618, 1.9608695652174, 1.2978260869565, 0.11111111111111
65619, 1.9826086956522, 1.3239130434783, 0.11111111111111
65620, 1.9826086956522, 1.2978260869565, 0.083333333333333
65621, 1.9608695652174, 1.2978260869565, 0.055555555555556
65622, 1.9826086956522, 1.3239130434783, 0.055555555555556
65623, 1.9826086956522, 1.2978260869565, 0.027777777777778
65624, 2.0260869565217, 1.2978260869565, 0.47222222222222
65625, 2.004347826087, 1.2978260869565, 0.44444444444444
65626, 2.0260869565217, 1.3239130434783, 0.44444444444444
65627, 2.0260869565217, 1.2978260869565, 0.41666666666667
65628, 2.004347826087, 1.2978260869565, 0.38888888888889
65629, 2.0260869565217, 1.3239130434783, 0.38888888888889
65630, 2.0260869565217, 1.2978260869565, 0.36111111111111
65631, 2.004347826087, 1.2978260869565, 0.33333333333333
65632, 2.0260869565217, 1.3239130434783, 0.33333333333333
65633, 2.0260869565217, 1.2978260869565, 0.30555555555556
65634, 2.004347826087, 1.2978260869565, 0.27777777777778
65635, 2.0260869565217, 1.3239130434783, 0.27777777777778
65636, 2.0260869565217, 1.2978260869565, 0.25
65637, 2.004347826087, 1.2978260869565, 0.22222222222222
65638, 2.0260869565217, 1.3239130434783, 0.22222222222222
65639, 2.0260869565217, 1.2978260869565, 0.19444444444444
65640, 2.004347826087, 1.2978260869565, 0.16666666666667
65641, 2.0260869565217, 1.3239130434783, 0.16666666666667
65642, 2.0260869565217, 1.2978260869565, 0.13888888888889
65643, 2.004347826087, 1.2978260869565, 0.11111111111111
65644, 2.0260869565217, 1.3239130434783, 0.11111111111111
65645, 2.0260869565217, 1.2978260869565, 0.083333333333333
65646, 2.004347826087, 1.2978260869565, 0.055555555555556
65647, 2.0260869565217, 1.3239130434783, 0.055555555555556
65648, 2.0260869565217, 1.2978260869565, 0.027777777777778
65649, 2.0695652173913, 1.2978260869565, 0.47222222222222
65650, 2.0478260869565, 1.2978260869565, 0.44444444444444
65651, 2.0695652173913, 1.3239130434783, 0.44444444444444
65652, 2.0695652173913, 1.2978260869565, 0.41666666666667
65653, 2.0478260869565, 1.2978260869565, 0.38888888888889
65654, 2.0695652173913, 1.3239130434783, 0.38888888888889
65655, 2.0695652173913, 1.2978260869565, 0.36111111111111
65656, 2.0478260869565, 1.2978260869565, 0.33333333333333
65657, 2.0695652173913, 1.3239130434783, 0.33333333333333
65658, 2.0695652173913, 1.2978260869565, 0.30555555555556
65659, 2.0478260869565, 1.2978260869565, 0.27777777777778
65660, 2.0695652173913, 1.3239130434783, 0.27777777777778
65661, 2.0695652173913, 1.2978260869565, 0.25
65662, 2.0478260869565, 1.2978260869565, 0.22222222222222
65663, 2.0695652173913, 1.3239130434783, 0.22222222222222
65664, 2.0695652173913, 1.2978260869565, 0.19444444444444
65665, 2.0478260869565, 1.2978260869565, 0.16666666666667
65666, 2.0695652173913, 1.3239130434783, 0.16666666666667
65667, 2.0695652173913, 1.2978260869565, 0.13888888888889
65668, 2.0478260869565, 1.2978260869565, 0.11111111111111
65669, 2.0695652173913, 1.3239130434783, 0.11111111111111
65670, 2.0695652173913, 1.2978260869565, 0.083333333333333
65671, 2.0478260869565, 1.2978260869565, 0.055555555555556
65672, 2.0695652173913, 1.3239130434783, 0.055555555555556
65673, 2.0695652173913, 1.2978260869565, 0.027777777777778
65674, 2.1130434782609, 1.2978260869565, 0.47222222222222
65675, 2.0913043478261, 1.2978260869565, 0.44444444444444
65676, 2.1130434782609, 1.3239130434783, 0.44444444444444
65677, 2.1130434782609, 1.2978260869565, 0.41666666666667
65678, 2.0913043478261, 1.2978260869565, 0.38888888888889
65679, 2.1130434782609, 1.3239130434783, 0.38888888888889
65680, 2.1130434782609, 1.2978260869565, 0.36111111111111
65681, 2.0913043478261, 1.2978260869565, 0.33333333333333
65682, 2.1130434782609, 1.3239130434783, 0.33333333333333
65683, 2.1130434782609, 1.2978260869565, 0.30555555555556
65684, 2.0913043478261, 1.2978260869565, 0.27777777777778
65685, 2.1130434782609, 1.3239130434783, 0.27777777777778
65686, 2.1130434782609, 1.2978260869565, 0.25
65687, 2.0913043478261, 1.2978260869565, 0.22222222222222
65688, 2.1130434782609, 1.3239130434783, 0.22222222222222
65689, 2.1130434782609, 1.2978260869565, 0.19444444444444
65690, 2.0913043478261, 1.2978260869565, 0.16666666666667
65691, 2.1130434782609, 1.3239130434783, 0.16666666666667
65692, 2.1130434782609, 1.2978260869565, 0.13888888888889
65693, 2.0913043478261, 1.2978260869565, 0.11111111111111
65694, 2.1130434782609, 1.3239130434783, 0.11111111111111
65695, 2.1130434782609, 1.2978260869565, 0.083333333333333
65696, 2.0913043478261, 1.2978260869565, 0.055555555555556
65697, 2.1130434782609, 1.3239130434783, 0.055555555555556
65698, 2.1130434782609, 1.2978260869565, 0.027777777777778
65699, 2.1565217391304, 1.2978260869565, 0.47222222222222
65700, 2.1347826086957, 1.2978260869565, 0.44444444444444
65701, 2.1565217391304, 1.3239130434783, 0.44444444444444
65702, 2.1565217391304, 1.2978260869565, 0.41666666666667
65703, 2.1347826086957, 1.2978260869565, 0.38888888888889
65704, 2.1565217391304, 1.3239130434783, 0.38888888888889
65705, 2.1565217391304, 1.2978260869565, 0.36111111111111
65706, 2.1347826086957, 1.2978260869565, 0.33333333333333
65707, 2.1565217391304, 1.3239130434783, 0.33333333333333
65708, 2.1565217391304, 1.2978260869565, 0.30555555555556
65709, 2.1347826086957, 1.2978260869565, 0.27777777777778
65710, 2.1565217391304, 1.3239130434783, 0.27777777777778
65711, 2.1565217391304, 1.2978260869565, 0.25
65712, 2.1347826086957, 1.2978260869565, 0.22222222222222
65713, 2.1565217391304, 1.3239130434783, 0.22222222222222
65714, 2.1565217391304, 1.2978260869565, 0.19444444444444
65715, 2.1347826086957, 1.2978260869565, 0.16666666666667
65716, 2.1565217391304, 1.3239130434783, 0.16666666666667
65717, 2.1565217391304, 1.2978260869565, 0.13888888888889
65718, 2.1347826086957, 1.2978260869565, 0.11111111111111
65719, 2.1565217391304, 1.3239130434783, 0.11111111111111
65720, 2.1565217391304, 1.2978260869565, 0.083333333333333
65721, 2.1347826086957, 1.2978260869565, 0.055555555555556
65722, 2.1565217391304, 1.3239130434783, 0.055555555555556
65723, 2.1565217391304, 1.2978260869565, 0.027777777777778
65724, 2.1782608695652, 1.2978260869565, 0.44444444444444
65725, 2.1782608695652, 1.2978260869565, 0.38888888888889
65726, 2.1782608695652, 1.2978260869565, 0.33333333333333
65727, 2.1782608695652, 1.2978260869565, 0.27777777777778
65728, 2.1782608695652, 1.2978260869565, 0.22222222222222
65729, 2.1782608695652, 1.2978260869565, 0.16666666666667
65730, 2.1782608695652, 1.2978260869565, 0.11111111111111
65731, 2.1782608695652, 1.2978260869565, 0.055555555555556
65732, 1.2434782608696, 1.245652173913, 0.47222222222222
65733, 1.2217391304348, 1.245652173913, 0.44444444444444
65734, 1.2434782608696, 1.2717391304348, 0.44444444444444
65735, 1.2434782608696, 1.245652173913, 0.41666666666667
65736, 1.2217391304348, 1.245652173913, 0.38888888888889
65737, 1.2434782608696, 1.2717391304348, 0.38888888888889
65738, 1.2434782608696, 1.245652173913, 0.36111111111111
65739, 1.2217391304348, 1.245652173913, 0.33333333333333
65740, 1.2434782608696, 1.2717391304348, 0.33333333333333
65741, 1.2434782608696, 1.245652173913, 0.30555555555556
65742, 1.2217391304348, 1.245652173913, 0.27777777777778
65743, 1.2434782608696, 1.2717391304348, 0.27777777777778
65744, 1.2434782608696, 1.245652173913, 0.25
65745, 1.2217391304348, 1.245652173913, 0.22222222222222
65746, 1.2434782608696, 1.2717391304348, 0.22222222222222
65747, 1.2434782608696, 1.245652173913, 0.19444444444444
65748, 1.2217391304348, 1.245652173913, 0.16666666666667
65749, 1.2434782608696, 1.2717391304348, 0.16666666666667
65750, 1.2434782608696, 1.245652173913, 0.13888888888889
65751, 1.2217391304348, 1.245652173913, 0.11111111111111
65752, 1.2434782608696, 1.2717391304348, 0.11111111111111
65753, 1.2434782608696, 1.245652173913, 0.083333333333333
65754, 1.2217391304348, 1.245652173913, 0.055555555555556
65755, 1.2434782608696, 1.2717391304348, 0.055555555555556
65756, 1.2434782608696, 1.245652173913, 0.027777777777778
65757, 1.2869565217391, 1.245652173913, 0.47222222222222
65758, 1.2652173913043, 1.245652173913, 0.44444444444444
65759, 1.2869565217391, 1.2717391304348, 0.44444444444444
65760, 1.2869565217391, 1.245652173913, 0.41666666666667
65761, 1.2652173913043, 1.245652173913, 0.38888888888889
65762, 1.2869565217391, 1.2717391304348, 0.38888888888889
65763, 1.2869565217391, 1.245652173913, 0.36111111111111
65764, 1.2652173913043, 1.245652173913, 0.33333333333333
65765, 1.2869565217391, 1.2717391304348, 0.33333333333333
65766, 1.2869565217391, 1.245652173913, 0.30555555555556
65767, 1.2652173913043, 1.245652173913, 0.27777777777778
65768, 1.2869565217391, 1.2717391304348, 0.27777777777778
65769, 1.2869565217391, 1.245652173913, 0.25
65770, 1.2652173913043, 1.245652173913, 0.22222222222222
65771, 1.2869565217391, 1.2717391304348, 0.22222222222222
65772, 1.2869565217391, 1.245652173913, 0.19444444444444
65773, 1.2652173913043, 1.245652173913, 0.16666666666667
65774, 1.2869565217391, 1.2717391304348, 0.16666666666667
65775, 1.2869565217391, 1.245652173913, 0.13888888888889
65776, 1.2652173913043, 1.245652173913, 0.11111111111111
65777, 1.2869565217391, 1.2717391304348, 0.11111111111111
65778, 1.2869565217391, 1.245652173913, 0.083333333333333
65779, 1.2652173913043, 1.245652173913, 0.055555555555556
65780, 1.2869565217391, 1.2717391304348, 0.055555555555556
65781, 1.2869565217391, 1.245652173913, 0.027777777777778
65782, 1.3304347826087, 1.245652173913, 0.47222222222222
65783, 1.3086956521739, 1.245652173913, 0.44444444444444
65784, 1.3304347826087, 1.2717391304348, 0.44444444444444
65785, 1.3304347826087, 1.245652173913, 0.41666666666667
65786, 1.3086956521739, 1.245652173913, 0.38888888888889
65787, 1.3304347826087, 1.2717391304348, 0.38888888888889
65788, 1.3304347826087, 1.245652173913, 0.36111111111111
65789, 1.3086956521739, 1.245652173913, 0.33333333333333
65790, 1.3304347826087, 1.2717391304348, 0.33333333333333
65791, 1.3304347826087, 1.245652173913, 0.30555555555556
65792, 1.3086956521739, 1.245652173913, 0.27777777777778
65793, 1.3304347826087, 1.2717391304348, 0.27777777777778
65794, 1.3304347826087, 1.245652173913, 0.25
65795, 1.3086956521739, 1.245652173913, 0.22222222222222
65796, 1.3304347826087, 1.2717391304348, 0.22222222222222
65797, 1.3304347826087, 1.245652173913, 0.19444444444444
65798, 1.3086956521739, 1.245652173913, 0.16666666666667
65799, 1.3304347826087, 1.2717391304348, 0.16666666666667
65800, 1.3304347826087, 1.245652173913, 0.13888888888889
65801, 1.3086956521739, 1.245652173913, 0.11111111111111
65802, 1.3304347826087, 1.2717391304348, 0.11111111111111
65803, 1.3304347826087, 1.245652173913, 0.083333333333333
65804, 1.3086956521739, 1.245652173913, 0.055555555555556
65805, 1.3304347826087, 1.2717391304348, 0.055555555555556
65806, 1.3304347826087, 1.245652173913, 0.027777777777778
65807, 1.3739130434783, 1.245652173913, 0.47222222222222
65808, 1.3521739130435, 1.245652173913, 0.44444444444444
65809, 1.3739130434783, 1.2717391304348, 0.44444444444444
65810, 1.3739130434783, 1.245652173913, 0.41666666666667
65811, 1.3521739130435, 1.245652173913, 0.38888888888889
65812, 1.3739130434783, 1.2717391304348, 0.38888888888889
65813, 1.3739130434783, 1.245652173913, 0.36111111111111
65814, 1.3521739130435, 1.245652173913, 0.33333333333333
65815, 1.3739130434783, 1.2717391304348, 0.33333333333333
65816, 1.3739130434783, 1.245652173913, 0.30555555555556
65817, 1.3521739130435, 1.245652173913, 0.27777777777778
65818, 1.3739130434783, 1.2717391304348, 0.27777777777778
65819, 1.3739130434783, 1.245652173913, 0.25
65820, 1.3521739130435, 1.245652173913, 0.22222222222222
65821, 1.3739130434783, 1.2717391304348, 0.22222222222222
65822, 1.3739130434783, 1.245652173913, 0.19444444444444
65823, 1.3521739130435, 1.245652173913, 0.16666666666667
65824, 1.3739130434783, 1.2717391304348, 0.16666666666667
65825, 1.3739130434783, 1.245652173913, 0.13888888888889
65826, 1.3521739130435, 1.245652173913, 0.11111111111111
65827, 1.3739130434783, 1.2717391304348, 0.11111111111111
65828, 1.3739130434783, 1.245652173913, 0.083333333333333
65829, 1.3521739130435, 1.245652173913, 0.055555555555556
65830, 1.3739130434783, 1.2717391304348, 0.055555555555556
65831, 1.3739130434783, 1.245652173913, 0.027777777777778
65832, 1.4173913043478, 1.245652173913, 0.47222222222222
65833, 1.395652173913, 1.245652173913, 0.44444444444444
65834, 1.4173913043478, 1.2717391304348, 0.44444444444444
65835, 1.4173913043478, 1.245652173913, 0.41666666666667
65836, 1.395652173913, 1.245652173913, 0.38888888888889
65837, 1.4173913043478, 1.2717391304348, 0.38888888888889
65838, 1.4173913043478, 1.245652173913, 0.36111111111111
65839, 1.395652173913, 1.245652173913, 0.33333333333333
65840, 1.4173913043478, 1.2717391304348, 0.33333333333333
65841, 1.4173913043478, 1.245652173913, 0.30555555555556
65842, 1.395652173913, 1.245652173913, 0.27777777777778
65843, 1.4173913043478, 1.2717391304348, 0.27777777777778
65844, 1.4173913043478, 1.245652173913, 0.25
65845, 1.395652173913, 1.245652173913, 0.22222222222222
65846, 1.4173913043478, 1.2717391304348, 0.22222222222222
65847, 1.4173913043478, 1.245652173913, 0.19444444444444
65848, 1.395652173913, 1.245652173913, 0.16666666666667
65849, 1.4173913043478, 1.2717391304348, 0.16666666666667
65850, 1.4173913043478, 1.245652173913, 0.13888888888889
65851, 1.395652173913, 1.245652173913, 0.11111111111111
65852, 1.4173913043478, 1.2717391304348, 0.11111111111111
65853, 1.4173913043478, 1.245652173913, 0.083333333333333
65854, 1.395652173913, 1.245652173913, 0.055555555555556
65855, 1.4173913043478, 1.2717391304348, 0.055555555555556
65856, 1.4173913043478, 1.245652173913, 0.027777777777778
65857, 1.4608695652174, 1.245652173913, 0.47222222222222
65858, 1.4391304347826, 1.245652173913, 0.44444444444444
65859, 1.4608695652174, 1.2717391304348, 0.44444444444444
65860, 1.4608695652174, 1.245652173913, 0.41666666666667
65861, 1.4391304347826, 1.245652173913, 0.38888888888889
65862, 1.4608695652174, 1.2717391304348, 0.38888888888889
65863, 1.4608695652174, 1.245652173913, 0.36111111111111
65864, 1.4391304347826, 1.245652173913, 0.33333333333333
65865, 1.4608695652174, 1.2717391304348, 0.33333333333333
65866, 1.4608695652174, 1.245652173913, 0.30555555555556
65867, 1.4391304347826, 1.245652173913, 0.27777777777778
65868, 1.4608695652174, 1.2717391304348, 0.27777777777778
65869, 1.4608695652174, 1.245652173913, 0.25
65870, 1.4391304347826, 1.245652173913, 0.22222222222222
65871, 1.4608695652174, 1.2717391304348, 0.22222222222222
65872, 1.4608695652174, 1.245652173913, 0.19444444444444
65873, 1.4391304347826, 1.245652173913, 0.16666666666667
65874, 1.4608695652174, 1.2717391304348, 0.16666666666667
65875, 1.4608695652174, 1.245652173913, 0.13888888888889
65876, 1.4391304347826, 1.245652173913, 0.11111111111111
65877, 1.4608695652174, 1.2717391304348, 0.11111111111111
65878, 1.4608695652174, 1.245652173913, 0.083333333333333
65879, 1.4391304347826, 1.245652173913, 0.055555555555556
65880, 1.4608695652174, 1.2717391304348, 0.055555555555556
65881, 1.4608695652174, 1.245652173913, 0.027777777777778
65882, 1.504347826087, 1.245652173913, 0.47222222222222
65883, 1.4826086956522, 1.245652173913, 0.44444444444444
65884, 1.504347826087, 1.2717391304348, 0.44444444444444
65885, 1.504347826087, 1.245652173913, 0.41666666666667
65886, 1.4826086956522, 1.245652173913, 0.38888888888889
65887, 1.504347826087, 1.2717391304348, 0.38888888888889
65888, 1.504347826087, 1.245652173913, 0.36111111111111
65889, 1.4826086956522, 1.245652173913, 0.33333333333333
65890, 1.504347826087, 1.2717391304348, 0.33333333333333
65891, 1.504347826087, 1.245652173913, 0.30555555555556
65892, 1.4826086956522, 1.245652173913, 0.27777777777778
65893, 1.504347826087, 1.2717391304348, 0.27777777777778
65894, 1.504347826087, 1.245652173913, 0.25
65895, 1.4826086956522, 1.245652173913, 0.22222222222222
65896, 1.504347826087, 1.2717391304348, 0.22222222222222
65897, 1.504347826087, 1.245652173913, 0.19444444444444
65898, 1.4826086956522, 1.245652173913, 0.16666666666667
65899, 1.504347826087, 1.2717391304348, 0.16666666666667
65900, 1.504347826087, 1.245652173913, 0.13888888888889
65901, 1.4826086956522, 1.245652173913, 0.11111111111111
65902, 1.504347826087, 1.2717391304348, 0.11111111111111
65903, 1.504347826087, 1.245652173913, 0.083333333333333
65904, 1.4826086956522, 1.245652173913, 0.055555555555556
65905, 1.504347826087, 1.2717391304348, 0.055555555555556
65906, 1.504347826087, 1.245652173913, 0.027777777777778
65907, 1.5478260869565, 1.245652173913, 0.47222222222222
65908, 1.5260869565217, 1.245652173913, 0.44444444444444
65909, 1.5478260869565, 1.2717391304348, 0.44444444444444
65910, 1.5478260869565, 1.245652173913, 0.41666666666667
65911, 1.5260869565217, 1.245652173913, 0.38888888888889
65912, 1.5478260869565, 1.2717391304348, 0.38888888888889
65913, 1.5478260869565, 1.245652173913, 0.36111111111111
65914, 1.5260869565217, 1.245652173913, 0.33333333333333
65915, 1.5478260869565, 1.2717391304348, 0.33333333333333
65916, 1.5478260869565, 1.245652173913, 0.30555555555556
65917, 1.5260869565217, 1.245652173913, 0.27777777777778
65918, 1.5478260869565, 1.2717391304348, 0.27777777777778
65919, 1.5478260869565, 1.245652173913, 0.25
65920, 1.5260869565217, 1.245652173913, 0.22222222222222
65921, 1.5478260869565, 1.2717391304348, 0.22222222222222
65922, 1.5478260869565, 1.245652173913, 0.19444444444444
65923, 1.5260869565217, 1.245652173913, 0.16666666666667
65924, 1.5478260869565, 1.2717391304348, 0.16666666666667
65925, 1.5478260869565, 1.245652173913, 0.13888888888889
65926, 1.5260869565217, 1.245652173913, 0.11111111111111
65927, 1.5478260869565, 1.2717391304348, 0.11111111111111
65928, 1.5478260869565, 1.245652173913, 0.083333333333333
65929, 1.5260869565217, 1.245652173913, 0.055555555555556
65930, 1.5478260869565, 1.2717391304348, 0.055555555555556
65931, 1.5478260869565, 1.245652173913, 0.027777777777778
65932, 1.5913043478261, 1.245652173913, 0.47222222222222
65933, 1.5695652173913, 1.245652173913, 0.44444444444444
65934, 1.5913043478261, 1.2717391304348, 0.44444444444444
65935, 1.5913043478261, 1.245652173913, 0.41666666666667
65936, 1.5695652173913, 1.245652173913, 0.38888888888889
65937, 1.5913043478261, 1.2717391304348, 0.38888888888889
65938, 1.5913043478261, 1.245652173913, 0.36111111111111
65939, 1.5695652173913, 1.245652173913, 0.33333333333333
65940, 1.5913043478261, 1.2717391304348, 0.33333333333333
65941, 1.5913043478261, 1.245652173913, 0.30555555555556
65942, 1.5695652173913, 1.245652173913, 0.27777777777778
65943, 1.5913043478261, 1.2717391304348, 0.27777777777778
65944, 1.5913043478261, 1.245652173913, 0.25
65945, 1.5695652173913, 1.245652173913, 0.22222222222222
65946, 1.5913043478261, 1.2717391304348, 0.22222222222222
65947, 1.5913043478261, 1.245652173913, 0.19444444444444
65948, 1.5695652173913, 1.245652173913, 0.16666666666667
65949, 1.5913043478261, 1.2717391304348, 0.16666666666667
65950, 1.5913043478261, 1.245652173913, 0.13888888888889
65951, 1.5695652173913, 1.245652173913, 0.11111111111111
65952, 1.5913043478261, 1.2717391304348, 0.11111111111111
65953, 1.5913043478261, 1.245652173913, 0.083333333333333
65954, 1.5695652173913, 1.245652173913, 0.055555555555556
65955, 1.5913043478261, 1.2717391304348, 0.055555555555556
65956, 1.5913043478261, 1.245652173913, 0.027777777777778
65957, 1.6347826086957, 1.245652173913, 0.47222222222222
65958, 1.6130434782609, 1.245652173913, 0.44444444444444
65959, 1.6347826086957, 1.2717391304348, 0.44444444444444
65960, 1.6347826086957, 1.245652173913, 0.41666666666667
65961, 1.6130434782609, 1.245652173913, 0.38888888888889
65962, 1.6347826086957, 1.2717391304348, 0.38888888888889
65963, 1.6347826086957, 1.245652173913, 0.36111111111111
65964, 1.6130434782609, 1.245652173913, 0.33333333333333
65965, 1.6347826086957, 1.2717391304348, 0.33333333333333
65966, 1.6347826086957, 1.245652173913, 0.30555555555556
65967, 1.6130434782609, 1.245652173913, 0.27777777777778
65968, 1.6347826086957, 1.2717391304348, 0.27777777777778
65969, 1.6347826086957, 1.245652173913, 0.25
65970, 1.6130434782609, 1.245652173913, 0.22222222222222
65971, 1.6347826086957, 1.2717391304348, 0.22222222222222
65972, 1.6347826086957, 1.245652173913, 0.19444444444444
65973, 1.6130434782609, 1.245652173913, 0.16666666666667
65974, 1.6347826086957, 1.2717391304348, 0.16666666666667
65975, 1.6347826086957, 1.245652173913, 0.13888888888889
65976, 1.6130434782609, 1.245652173913, 0.11111111111111
65977, 1.6347826086957, 1.2717391304348, 0.11111111111111
65978, 1.6347826086957, 1.245652173913, 0.083333333333333
65979, 1.6130434782609, 1.245652173913, 0.055555555555556
65980, 1.6347826086957, 1.2717391304348, 0.055555555555556
65981, 1.6347826086957, 1.245652173913, 0.027777777777778
65982, 1.6782608695652, 1.245652173913, 0.47222222222222
65983, 1.6565217391304, 1.245652173913, 0.44444444444444
65984, 1.6782608695652, 1.2717391304348, 0.44444444444444
65985, 1.6782608695652, 1.245652173913, 0.41666666666667
65986, 1.6565217391304, 1.245652173913, 0.38888888888889
65987, 1.6782608695652, 1.2717391304348, 0.38888888888889
65988, 1.6782608695652, 1.245652173913, 0.36111111111111
65989, 1.6565217391304, 1.245652173913, 0.33333333333333
65990, 1.6782608695652, 1.2717391304348, 0.33333333333333
65991, 1.6782608695652, 1.245652173913, 0.30555555555556
65992, 1.6565217391304, 1.245652173913, 0.27777777777778
65993, 1.6782608695652, 1.2717391304348, 0.27777777777778
65994, 1.6782608695652, 1.245652173913, 0.25
65995, 1.6565217391304, 1.245652173913, 0.22222222222222
65996, 1.6782608695652, 1.2717391304348, 0.22222222222222
65997, 1.6782608695652, 1.245652173913, 0.19444444444444
65998, 1.6565217391304, 1.245652173913, 0.16666666666667
65999, 1.6782608695652, 1.2717391304348, 0.16666666666667
66000, 1.6782608695652, 1.245652173913, 0.13888888888889
66001, 1.6565217391304, 1.245652173913, 0.11111111111111
66002, 1.6782608695652, 1.2717391304348, 0.11111111111111
66003, 1.6782608695652, 1.245652173913, 0.083333333333333
66004, 1.6565217391304, 1.245652173913, 0.055555555555556
66005, 1.6782608695652, 1.2717391304348, 0.055555555555556
66006, 1.6782608695652, 1.245652173913, 0.027777777777778
66007, 1.7217391304348, 1.245652173913, 0.47222222222222
66008, 1.7, 1.245652173913, 0.44444444444444
66009, 1.7217391304348, 1.2717391304348, 0.44444444444444
66010, 1.7217391304348, 1.245652173913, 0.41666666666667
66011, 1.7, 1.245652173913, 0.38888888888889
66012, 1.7217391304348, 1.2717391304348, 0.38888888888889
66013, 1.7217391304348, 1.245652173913, 0.36111111111111
66014, 1.7, 1.245652173913, 0.33333333333333
66015, 1.7217391304348, 1.2717391304348, 0.33333333333333
66016, 1.7217391304348, 1.245652173913, 0.30555555555556
66017, 1.7, 1.245652173913, 0.27777777777778
66018, 1.7217391304348, 1.2717391304348, 0.27777777777778
66019, 1.7217391304348, 1.245652173913, 0.25
66020, 1.7, 1.245652173913, 0.22222222222222
66021, 1.7217391304348, 1.2717391304348, 0.22222222222222
66022, 1.7217391304348, 1.245652173913, 0.19444444444444
66023, 1.7, 1.245652173913, 0.16666666666667
66024, 1.7217391304348, 1.2717391304348, 0.16666666666667
66025, 1.7217391304348, 1.245652173913, 0.13888888888889
66026, 1.7, 1.245652173913, 0.11111111111111
66027, 1.7217391304348, 1.2717391304348, 0.11111111111111
66028, 1.7217391304348, 1.245652173913, 0.083333333333333
66029, 1.7, 1.245652173913, 0.055555555555556
66030, 1.7217391304348, 1.2717391304348, 0.055555555555556
66031, 1.7217391304348, 1.245652173913, 0.027777777777778
66032, 1.7652173913043, 1.245652173913, 0.47222222222222
66033, 1.7434782608696, 1.245652173913, 0.44444444444444
66034, 1.7652173913043, 1.2717391304348, 0.44444444444444
66035, 1.7652173913043, 1.245652173913, 0.41666666666667
66036, 1.7434782608696, 1.245652173913, 0.38888888888889
66037, 1.7652173913043, 1.2717391304348, 0.38888888888889
66038, 1.7652173913043, 1.245652173913, 0.36111111111111
66039, 1.7434782608696, 1.245652173913, 0.33333333333333
66040, 1.7652173913043, 1.2717391304348, 0.33333333333333
66041, 1.7652173913043, 1.245652173913, 0.30555555555556
66042, 1.7434782608696, 1.245652173913, 0.27777777777778
66043, 1.7652173913043, 1.2717391304348, 0.27777777777778
66044, 1.7652173913043, 1.245652173913, 0.25
66045, 1.7434782608696, 1.245652173913, 0.22222222222222
66046, 1.7652173913043, 1.2717391304348, 0.22222222222222
66047, 1.7652173913043, 1.245652173913, 0.19444444444444
66048, 1.7434782608696, 1.245652173913, 0.16666666666667
66049, 1.7652173913043, 1.2717391304348, 0.16666666666667
66050, 1.7652173913043, 1.245652173913, 0.13888888888889
66051, 1.7434782608696, 1.245652173913, 0.11111111111111
66052, 1.7652173913043, 1.2717391304348, 0.11111111111111
66053, 1.7652173913043, 1.245652173913, 0.083333333333333
66054, 1.7434782608696, 1.245652173913, 0.055555555555556
66055, 1.7652173913043, 1.2717391304348, 0.055555555555556
66056, 1.7652173913043, 1.245652173913, 0.027777777777778
66057, 1.8086956521739, 1.245652173913, 0.47222222222222
66058, 1.7869565217391, 1.245652173913, 0.44444444444444
66059, 1.8086956521739, 1.2717391304348, 0.44444444444444
66060, 1.8086956521739, 1.245652173913, 0.41666666666667
66061, 1.7869565217391, 1.245652173913, 0.38888888888889
66062, 1.8086956521739, 1.2717391304348, 0.38888888888889
66063, 1.8086956521739, 1.245652173913, 0.36111111111111
66064, 1.7869565217391, 1.245652173913, 0.33333333333333
66065, 1.8086956521739, 1.2717391304348, 0.33333333333333
66066, 1.8086956521739, 1.245652173913, 0.30555555555556
66067, 1.7869565217391, 1.245652173913, 0.27777777777778
66068, 1.8086956521739, 1.2717391304348, 0.27777777777778
66069, 1.8086956521739, 1.245652173913, 0.25
66070, 1.7869565217391, 1.245652173913, 0.22222222222222
66071, 1.8086956521739, 1.2717391304348, 0.22222222222222
66072, 1.8086956521739, 1.245652173913, 0.19444444444444
66073, 1.7869565217391, 1.245652173913, 0.16666666666667
66074, 1.8086956521739, 1.2717391304348, 0.16666666666667
66075, 1.8086956521739, 1.245652173913, 0.13888888888889
66076, 1.7869565217391, 1.245652173913, 0.11111111111111
66077, 1.8086956521739, 1.2717391304348, 0.11111111111111
66078, 1.8086956521739, 1.245652173913, 0.083333333333333
66079, 1.7869565217391, 1.245652173913, 0.055555555555556
66080, 1.8086956521739, 1.2717391304348, 0.055555555555556
66081, 1.8086956521739, 1.245652173913, 0.027777777777778
66082, 1.8521739130435, 1.245652173913, 0.47222222222222
66083, 1.8304347826087, 1.245652173913, 0.44444444444444
66084, 1.8521739130435, 1.2717391304348, 0.44444444444444
66085, 1.8521739130435, 1.245652173913, 0.41666666666667
66086, 1.8304347826087, 1.245652173913, 0.38888888888889
66087, 1.8521739130435, 1.2717391304348, 0.38888888888889
66088, 1.8521739130435, 1.245652173913, 0.36111111111111
66089, 1.8304347826087, 1.245652173913, 0.33333333333333
66090, 1.8521739130435, 1.2717391304348, 0.33333333333333
66091, 1.8521739130435, 1.245652173913, 0.30555555555556
66092, 1.8304347826087, 1.245652173913, 0.27777777777778
66093, 1.8521739130435, 1.2717391304348, 0.27777777777778
66094, 1.8521739130435, 1.245652173913, 0.25
66095, 1.8304347826087, 1.245652173913, 0.22222222222222
66096, 1.8521739130435, 1.2717391304348, 0.22222222222222
66097, 1.8521739130435, 1.245652173913, 0.19444444444444
66098, 1.8304347826087, 1.245652173913, 0.16666666666667
66099, 1.8521739130435, 1.2717391304348, 0.16666666666667
66100, 1.8521739130435, 1.245652173913, 0.13888888888889
66101, 1.8304347826087, 1.245652173913, 0.11111111111111
66102, 1.8521739130435, 1.2717391304348, 0.11111111111111
66103, 1.8521739130435, 1.245652173913, 0.083333333333333
66104, 1.8304347826087, 1.245652173913, 0.055555555555556
66105, 1.8521739130435, 1.2717391304348, 0.055555555555556
66106, 1.8521739130435, 1.245652173913, 0.027777777777778
66107, 1.895652173913, 1.245652173913, 0.47222222222222
66108, 1.8739130434783, 1.245652173913, 0.44444444444444
66109, 1.895652173913, 1.2717391304348, 0.44444444444444
66110, 1.895652173913, 1.245652173913, 0.41666666666667
66111, 1.8739130434783, 1.245652173913, 0.38888888888889
66112, 1.895652173913, 1.2717391304348, 0.38888888888889
66113, 1.895652173913, 1.245652173913, 0.36111111111111
66114, 1.8739130434783, 1.245652173913, 0.33333333333333
66115, 1.895652173913, 1.2717391304348, 0.33333333333333
66116, 1.895652173913, 1.245652173913, 0.30555555555556
66117, 1.8739130434783, 1.245652173913, 0.27777777777778
66118, 1.895652173913, 1.2717391304348, 0.27777777777778
66119, 1.895652173913, 1.245652173913, 0.25
66120, 1.8739130434783, 1.245652173913, 0.22222222222222
66121, 1.895652173913, 1.2717391304348, 0.22222222222222
66122, 1.895652173913, 1.245652173913, 0.19444444444444
66123, 1.8739130434783, 1.245652173913, 0.16666666666667
66124, 1.895652173913, 1.2717391304348, 0.16666666666667
66125, 1.895652173913, 1.245652173913, 0.13888888888889
66126, 1.8739130434783, 1.245652173913, 0.11111111111111
66127, 1.895652173913, 1.2717391304348, 0.11111111111111
66128, 1.895652173913, 1.245652173913, 0.083333333333333
66129, 1.8739130434783, 1.245652173913, 0.055555555555556
66130, 1.895652173913, 1.2717391304348, 0.055555555555556
66131, 1.895652173913, 1.245652173913, 0.027777777777778
66132, 1.9391304347826, 1.245652173913, 0.47222222222222
66133, 1.9173913043478, 1.245652173913, 0.44444444444444
66134, 1.9391304347826, 1.2717391304348, 0.44444444444444
66135, 1.9391304347826, 1.245652173913, 0.41666666666667
66136, 1.9173913043478, 1.245652173913, 0.38888888888889
66137, 1.9391304347826, 1.2717391304348, 0.38888888888889
66138, 1.9391304347826, 1.245652173913, 0.36111111111111
66139, 1.9173913043478, 1.245652173913, 0.33333333333333
66140, 1.9391304347826, 1.2717391304348, 0.33333333333333
66141, 1.9391304347826, 1.245652173913, 0.30555555555556
66142, 1.9173913043478, 1.245652173913, 0.27777777777778
66143, 1.9391304347826, 1.2717391304348, 0.27777777777778
66144, 1.9391304347826, 1.245652173913, 0.25
66145, 1.9173913043478, 1.245652173913, 0.22222222222222
66146, 1.9391304347826, 1.2717391304348, 0.22222222222222
66147, 1.9391304347826, 1.245652173913, 0.19444444444444
66148, 1.9173913043478, 1.245652173913, 0.16666666666667
66149, 1.9391304347826, 1.2717391304348, 0.16666666666667
66150, 1.9391304347826, 1.245652173913, 0.13888888888889
66151, 1.9173913043478, 1.245652173913, 0.11111111111111
66152, 1.9391304347826, 1.2717391304348, 0.11111111111111
66153, 1.9391304347826, 1.245652173913, 0.083333333333333
66154, 1.9173913043478, 1.245652173913, 0.055555555555556
66155, 1.9391304347826, 1.2717391304348, 0.055555555555556
66156, 1.9391304347826, 1.245652173913, 0.027777777777778
66157, 1.9826086956522, 1.245652173913, 0.47222222222222
66158, 1.9608695652174, 1.245652173913, 0.44444444444444
66159, 1.9826086956522, 1.2717391304348, 0.44444444444444
66160, 1.9826086956522, 1.245652173913, 0.41666666666667
66161, 1.9608695652174, 1.245652173913, 0.38888888888889
66162, 1.9826086956522, 1.2717391304348, 0.38888888888889
66163, 1.9826086956522, 1.245652173913, 0.36111111111111
66164, 1.9608695652174, 1.245652173913, 0.33333333333333
66165, 1.9826086956522, 1.2717391304348, 0.33333333333333
66166, 1.9826086956522, 1.245652173913, 0.30555555555556
66167, 1.9608695652174, 1.245652173913, 0.27777777777778
66168, 1.9826086956522, 1.2717391304348, 0.27777777777778
66169, 1.9826086956522, 1.245652173913, 0.25
66170, 1.9608695652174, 1.245652173913, 0.22222222222222
66171, 1.9826086956522, 1.2717391304348, 0.22222222222222
66172, 1.9826086956522, 1.245652173913, 0.19444444444444
66173, 1.9608695652174, 1.245652173913, 0.16666666666667
66174, 1.9826086956522, 1.2717391304348, 0.16666666666667
66175, 1.9826086956522, 1.245652173913, 0.13888888888889
66176, 1.9608695652174, 1.245652173913, 0.11111111111111
66177, 1.9826086956522, 1.2717391304348, 0.11111111111111
66178, 1.9826086956522, 1.245652173913, 0.083333333333333
66179, 1.9608695652174, 1.245652173913, 0.055555555555556
66180, 1.9826086956522, 1.2717391304348, 0.055555555555556
66181, 1.9826086956522, 1.245652173913, 0.027777777777778
66182, 2.0260869565217, 1.245652173913, 0.47222222222222
66183, 2.004347826087, 1.245652173913, 0.44444444444444
66184, 2.0260869565217, 1.2717391304348, 0.44444444444444
66185, 2.0260869565217, 1.245652173913, 0.41666666666667
66186, 2.004347826087, 1.245652173913, 0.38888888888889
66187, 2.0260869565217, 1.2717391304348, 0.38888888888889
66188, 2.0260869565217, 1.245652173913, 0.36111111111111
66189, 2.004347826087, 1.245652173913, 0.33333333333333
66190, 2.0260869565217, 1.2717391304348, 0.33333333333333
66191, 2.0260869565217, 1.245652173913, 0.30555555555556
66192, 2.004347826087, 1.245652173913, 0.27777777777778
66193, 2.0260869565217, 1.2717391304348, 0.27777777777778
66194, 2.0260869565217, 1.245652173913, 0.25
66195, 2.004347826087, 1.245652173913, 0.22222222222222
66196, 2.0260869565217, 1.2717391304348, 0.22222222222222
66197, 2.0260869565217, 1.245652173913, 0.19444444444444
66198, 2.004347826087, 1.245652173913, 0.16666666666667
66199, 2.0260869565217, 1.2717391304348, 0.16666666666667
66200, 2.0260869565217, 1.245652173913, 0.13888888888889
66201, 2.004347826087, 1.245652173913, 0.11111111111111
66202, 2.0260869565217, 1.2717391304348, 0.11111111111111
66203, 2.0260869565217, 1.245652173913, 0.083333333333333
66204, 2.004347826087, 1.245652173913, 0.055555555555556
66205, 2.0260869565217, 1.2717391304348, 0.055555555555556
66206, 2.0260869565217, 1.245652173913, 0.027777777777778
66207, 2.0695652173913, 1.245652173913, 0.47222222222222
66208, 2.0478260869565, 1.245652173913, 0.44444444444444
66209, 2.0695652173913, 1.2717391304348, 0.44444444444444
66210, 2.0695652173913, 1.245652173913, 0.41666666666667
66211, 2.0478260869565, 1.245652173913, 0.38888888888889
66212, 2.0695652173913, 1.2717391304348, 0.38888888888889
66213, 2.0695652173913, 1.245652173913, 0.36111111111111
66214, 2.0478260869565, 1.245652173913, 0.33333333333333
66215, 2.0695652173913, 1.2717391304348, 0.33333333333333
66216, 2.0695652173913, 1.245652173913, 0.30555555555556
66217, 2.0478260869565, 1.245652173913, 0.27777777777778
66218, 2.0695652173913, 1.2717391304348, 0.27777777777778
66219, 2.0695652173913, 1.245652173913, 0.25
66220, 2.0478260869565, 1.245652173913, 0.22222222222222
66221, 2.0695652173913, 1.2717391304348, 0.22222222222222
66222, 2.0695652173913, 1.245652173913, 0.19444444444444
66223, 2.0478260869565, 1.245652173913, 0.16666666666667
66224, 2.0695652173913, 1.2717391304348, 0.16666666666667
66225, 2.0695652173913, 1.245652173913, 0.13888888888889
66226, 2.0478260869565, 1.245652173913, 0.11111111111111
66227, 2.0695652173913, 1.2717391304348, 0.11111111111111
66228, 2.0695652173913, 1.245652173913, 0.083333333333333
66229, 2.0478260869565, 1.245652173913, 0.055555555555556
66230, 2.0695652173913, 1.2717391304348, 0.055555555555556
66231, 2.0695652173913, 1.245652173913, 0.027777777777778
66232, 2.1130434782609, 1.245652173913, 0.47222222222222
66233, 2.0913043478261, 1.245652173913, 0.44444444444444
66234, 2.1130434782609, 1.2717391304348, 0.44444444444444
66235, 2.1130434782609, 1.245652173913, 0.41666666666667
66236, 2.0913043478261, 1.245652173913, 0.38888888888889
66237, 2.1130434782609, 1.2717391304348, 0.38888888888889
66238, 2.1130434782609, 1.245652173913, 0.36111111111111
66239, 2.0913043478261, 1.245652173913, 0.33333333333333
66240, 2.1130434782609, 1.2717391304348, 0.33333333333333
66241, 2.1130434782609, 1.245652173913, 0.30555555555556
66242, 2.0913043478261, 1.245652173913, 0.27777777777778
66243, 2.1130434782609, 1.2717391304348, 0.27777777777778
66244, 2.1130434782609, 1.245652173913, 0.25
66245, 2.0913043478261, 1.245652173913, 0.22222222222222
66246, 2.1130434782609, 1.2717391304348, 0.22222222222222
66247, 2.1130434782609, 1.245652173913, 0.19444444444444
66248, 2.0913043478261, 1.245652173913, 0.16666666666667
66249, 2.1130434782609, 1.2717391304348, 0.16666666666667
66250, 2.1130434782609, 1.245652173913, 0.13888888888889
66251, 2.0913043478261, 1.245652173913, 0.11111111111111
66252, 2.1130434782609, 1.2717391304348, 0.11111111111111
66253, 2.1130434782609, 1.245652173913, 0.083333333333333
66254, 2.0913043478261, 1.245652173913, 0.055555555555556
66255, 2.1130434782609, 1.2717391304348, 0.055555555555556
66256, 2.1130434782609, 1.245652173913, 0.027777777777778
66257, 2.1565217391304, 1.245652173913, 0.47222222222222
66258, 2.1347826086957, 1.245652173913, 0.44444444444444
66259, 2.1565217391304, 1.2717391304348, 0.44444444444444
66260, 2.1565217391304, 1.245652173913, 0.41666666666667
66261, 2.1347826086957, 1.245652173913, 0.38888888888889
66262, 2.1565217391304, 1.2717391304348, 0.38888888888889
66263, 2.1565217391304, 1.245652173913, 0.36111111111111
66264, 2.1347826086957, 1.245652173913, 0.33333333333333
66265, 2.1565217391304, 1.2717391304348, 0.33333333333333
66266, 2.1565217391304, 1.245652173913, 0.30555555555556
66267, 2.1347826086957, 1.245652173913, 0.27777777777778
66268, 2.1565217391304, 1.2717391304348, 0.27777777777778
66269, 2.1565217391304, 1.245652173913, 0.25
66270, 2.1347826086957, 1.245652173913, 0.22222222222222
66271, 2.1565217391304, 1.2717391304348, 0.22222222222222
66272, 2.1565217391304, 1.245652173913, 0.19444444444444
66273, 2.1347826086957, 1.245652173913, 0.16666666666667
66274, 2.1565217391304, 1.2717391304348, 0.16666666666667
66275, 2.1565217391304, 1.245652173913, 0.13888888888889
66276, 2.1347826086957, 1.245652173913, 0.11111111111111
66277, 2.1565217391304, 1.2717391304348, 0.11111111111111
66278, 2.1565217391304, 1.245652173913, 0.083333333333333
66279, 2.1347826086957, 1.245652173913, 0.055555555555556
66280, 2.1565217391304, 1.2717391304348, 0.055555555555556
66281, 2.1565217391304, 1.245652173913, 0.027777777777778
66282, 2.1782608695652, 1.245652173913, 0.44444444444444
66283, 2.1782608695652, 1.245652173913, 0.38888888888889
66284, 2.1782608695652, 1.245652173913, 0.33333333333333
66285, 2.1782608695652, 1.245652173913, 0.27777777777778
66286, 2.1782608695652, 1.245652173913, 0.22222222222222
66287, 2.1782608695652, 1.245652173913, 0.16666666666667
66288, 2.1782608695652, 1.245652173913, 0.11111111111111
66289, 2.1782608695652, 1.245652173913, 0.055555555555556
66290, 1.2434782608696, 1.1934782608696, 0.47222222222222
66291, 1.2217391304348, 1.1934782608696, 0.44444444444444
66292, 1.2434782608696, 1.2195652173913, 0.44444444444444
66293, 1.2434782608696, 1.1934782608696, 0.41666666666667
66294, 1.2217391304348, 1.1934782608696, 0.38888888888889
66295, 1.2434782608696, 1.2195652173913, 0.38888888888889
66296, 1.2434782608696, 1.1934782608696, 0.36111111111111
66297, 1.2217391304348, 1.1934782608696, 0.33333333333333
66298, 1.2434782608696, 1.2195652173913, 0.33333333333333
66299, 1.2434782608696, 1.1934782608696, 0.30555555555556
66300, 1.2217391304348, 1.1934782608696, 0.27777777777778
66301, 1.2434782608696, 1.2195652173913, 0.27777777777778
66302, 1.2434782608696, 1.1934782608696, 0.25
66303, 1.2217391304348, 1.1934782608696, 0.22222222222222
66304, 1.2434782608696, 1.2195652173913, 0.22222222222222
66305, 1.2434782608696, 1.1934782608696, 0.19444444444444
66306, 1.2217391304348, 1.1934782608696, 0.16666666666667
66307, 1.2434782608696, 1.2195652173913, 0.16666666666667
66308, 1.2434782608696, 1.1934782608696, 0.13888888888889
66309, 1.2217391304348, 1.1934782608696, 0.11111111111111
66310, 1.2434782608696, 1.2195652173913, 0.11111111111111
66311, 1.2434782608696, 1.1934782608696, 0.083333333333333
66312, 1.2217391304348, 1.1934782608696, 0.055555555555556
66313, 1.2434782608696, 1.2195652173913, 0.055555555555556
66314, 1.2434782608696, 1.1934782608696, 0.027777777777778
66315, 1.2869565217391, 1.1934782608696, 0.47222222222222
66316, 1.2652173913043, 1.1934782608696, 0.44444444444444
66317, 1.2869565217391, 1.2195652173913, 0.44444444444444
66318, 1.2869565217391, 1.1934782608696, 0.41666666666667
66319, 1.2652173913043, 1.1934782608696, 0.38888888888889
66320, 1.2869565217391, 1.2195652173913, 0.38888888888889
66321, 1.2869565217391, 1.1934782608696, 0.36111111111111
66322, 1.2652173913043, 1.1934782608696, 0.33333333333333
66323, 1.2869565217391, 1.2195652173913, 0.33333333333333
66324, 1.2869565217391, 1.1934782608696, 0.30555555555556
66325, 1.2652173913043, 1.1934782608696, 0.27777777777778
66326, 1.2869565217391, 1.2195652173913, 0.27777777777778
66327, 1.2869565217391, 1.1934782608696, 0.25
66328, 1.2652173913043, 1.1934782608696, 0.22222222222222
66329, 1.2869565217391, 1.2195652173913, 0.22222222222222
66330, 1.2869565217391, 1.1934782608696, 0.19444444444444
66331, 1.2652173913043, 1.1934782608696, 0.16666666666667
66332, 1.2869565217391, 1.2195652173913, 0.16666666666667
66333, 1.2869565217391, 1.1934782608696, 0.13888888888889
66334, 1.2652173913043, 1.1934782608696, 0.11111111111111
66335, 1.2869565217391, 1.2195652173913, 0.11111111111111
66336, 1.2869565217391, 1.1934782608696, 0.083333333333333
66337, 1.2652173913043, 1.1934782608696, 0.055555555555556
66338, 1.2869565217391, 1.2195652173913, 0.055555555555556
66339, 1.2869565217391, 1.1934782608696, 0.027777777777778
66340, 1.3304347826087, 1.1934782608696, 0.47222222222222
66341, 1.3086956521739, 1.1934782608696, 0.44444444444444
66342, 1.3304347826087, 1.2195652173913, 0.44444444444444
66343, 1.3304347826087, 1.1934782608696, 0.41666666666667
66344, 1.3086956521739, 1.1934782608696, 0.38888888888889
66345, 1.3304347826087, 1.2195652173913, 0.38888888888889
66346, 1.3304347826087, 1.1934782608696, 0.36111111111111
66347, 1.3086956521739, 1.1934782608696, 0.33333333333333
66348, 1.3304347826087, 1.2195652173913, 0.33333333333333
66349, 1.3304347826087, 1.1934782608696, 0.30555555555556
66350, 1.3086956521739, 1.1934782608696, 0.27777777777778
66351, 1.3304347826087, 1.2195652173913, 0.27777777777778
66352, 1.3304347826087, 1.1934782608696, 0.25
66353, 1.3086956521739, 1.1934782608696, 0.22222222222222
66354, 1.3304347826087, 1.2195652173913, 0.22222222222222
66355, 1.3304347826087, 1.1934782608696, 0.19444444444444
66356, 1.3086956521739, 1.1934782608696, 0.16666666666667
66357, 1.3304347826087, 1.2195652173913, 0.16666666666667
66358, 1.3304347826087, 1.1934782608696, 0.13888888888889
66359, 1.3086956521739, 1.1934782608696, 0.11111111111111
66360, 1.3304347826087, 1.2195652173913, 0.11111111111111
66361, 1.3304347826087, 1.1934782608696, 0.083333333333333
66362, 1.3086956521739, 1.1934782608696, 0.055555555555556
66363, 1.3304347826087, 1.2195652173913, 0.055555555555556
66364, 1.3304347826087, 1.1934782608696, 0.027777777777778
66365, 1.3739130434783, 1.1934782608696, 0.47222222222222
66366, 1.3521739130435, 1.1934782608696, 0.44444444444444
66367, 1.3739130434783, 1.2195652173913, 0.44444444444444
66368, 1.3739130434783, 1.1934782608696, 0.41666666666667
66369, 1.3521739130435, 1.1934782608696, 0.38888888888889
66370, 1.3739130434783, 1.2195652173913, 0.38888888888889
66371, 1.3739130434783, 1.1934782608696, 0.36111111111111
66372, 1.3521739130435, 1.1934782608696, 0.33333333333333
66373, 1.3739130434783, 1.2195652173913, 0.33333333333333
66374, 1.3739130434783, 1.1934782608696, 0.30555555555556
66375, 1.3521739130435, 1.1934782608696, 0.27777777777778
66376, 1.3739130434783, 1.2195652173913, 0.27777777777778
66377, 1.3739130434783, 1.1934782608696, 0.25
66378, 1.3521739130435, 1.1934782608696, 0.22222222222222
66379, 1.3739130434783, 1.2195652173913, 0.22222222222222
66380, 1.3739130434783, 1.1934782608696, 0.19444444444444
66381, 1.3521739130435, 1.1934782608696, 0.16666666666667
66382, 1.3739130434783, 1.2195652173913, 0.16666666666667
66383, 1.3739130434783, 1.1934782608696, 0.13888888888889
66384, 1.3521739130435, 1.1934782608696, 0.11111111111111
66385, 1.3739130434783, 1.2195652173913, 0.11111111111111
66386, 1.3739130434783, 1.1934782608696, 0.083333333333333
66387, 1.3521739130435, 1.1934782608696, 0.055555555555556
66388, 1.3739130434783, 1.2195652173913, 0.055555555555556
66389, 1.3739130434783, 1.1934782608696, 0.027777777777778
66390, 1.4173913043478, 1.1934782608696, 0.47222222222222
66391, 1.395652173913, 1.1934782608696, 0.44444444444444
66392, 1.4173913043478, 1.2195652173913, 0.44444444444444
66393, 1.4173913043478, 1.1934782608696, 0.41666666666667
66394, 1.395652173913, 1.1934782608696, 0.38888888888889
66395, 1.4173913043478, 1.2195652173913, 0.38888888888889
66396, 1.4173913043478, 1.1934782608696, 0.36111111111111
66397, 1.395652173913, 1.1934782608696, 0.33333333333333
66398, 1.4173913043478, 1.2195652173913, 0.33333333333333
66399, 1.4173913043478, 1.1934782608696, 0.30555555555556
66400, 1.395652173913, 1.1934782608696, 0.27777777777778
66401, 1.4173913043478, 1.2195652173913, 0.27777777777778
66402, 1.4173913043478, 1.1934782608696, 0.25
66403, 1.395652173913, 1.1934782608696, 0.22222222222222
66404, 1.4173913043478, 1.2195652173913, 0.22222222222222
66405, 1.4173913043478, 1.1934782608696, 0.19444444444444
66406, 1.395652173913, 1.1934782608696, 0.16666666666667
66407, 1.4173913043478, 1.2195652173913, 0.16666666666667
66408, 1.4173913043478, 1.1934782608696, 0.13888888888889
66409, 1.395652173913, 1.1934782608696, 0.11111111111111
66410, 1.4173913043478, 1.2195652173913, 0.11111111111111
66411, 1.4173913043478, 1.1934782608696, 0.083333333333333
66412, 1.395652173913, 1.1934782608696, 0.055555555555556
66413, 1.4173913043478, 1.2195652173913, 0.055555555555556
66414, 1.4173913043478, 1.1934782608696, 0.027777777777778
66415, 1.4608695652174, 1.1934782608696, 0.47222222222222
66416, 1.4391304347826, 1.1934782608696, 0.44444444444444
66417, 1.4608695652174, 1.2195652173913, 0.44444444444444
66418, 1.4608695652174, 1.1934782608696, 0.41666666666667
66419, 1.4391304347826, 1.1934782608696, 0.38888888888889
66420, 1.4608695652174, 1.2195652173913, 0.38888888888889
66421, 1.4608695652174, 1.1934782608696, 0.36111111111111
66422, 1.4391304347826, 1.1934782608696, 0.33333333333333
66423, 1.4608695652174, 1.2195652173913, 0.33333333333333
66424, 1.4608695652174, 1.1934782608696, 0.30555555555556
66425, 1.4391304347826, 1.1934782608696, 0.27777777777778
66426, 1.4608695652174, 1.2195652173913, 0.27777777777778
66427, 1.4608695652174, 1.1934782608696, 0.25
66428, 1.4391304347826, 1.1934782608696, 0.22222222222222
66429, 1.4608695652174, 1.2195652173913, 0.22222222222222
66430, 1.4608695652174, 1.1934782608696, 0.19444444444444
66431, 1.4391304347826, 1.1934782608696, 0.16666666666667
66432, 1.4608695652174, 1.2195652173913, 0.16666666666667
66433, 1.4608695652174, 1.1934782608696, 0.13888888888889
66434, 1.4391304347826, 1.1934782608696, 0.11111111111111
66435, 1.4608695652174, 1.2195652173913, 0.11111111111111
66436, 1.4608695652174, 1.1934782608696, 0.083333333333333
66437, 1.4391304347826, 1.1934782608696, 0.055555555555556
66438, 1.4608695652174, 1.2195652173913, 0.055555555555556
66439, 1.4608695652174, 1.1934782608696, 0.027777777777778
66440, 1.504347826087, 1.1934782608696, 0.47222222222222
66441, 1.4826086956522, 1.1934782608696, 0.44444444444444
66442, 1.504347826087, 1.2195652173913, 0.44444444444444
66443, 1.504347826087, 1.1934782608696, 0.41666666666667
66444, 1.4826086956522, 1.1934782608696, 0.38888888888889
66445, 1.504347826087, 1.2195652173913, 0.38888888888889
66446, 1.504347826087, 1.1934782608696, 0.36111111111111
66447, 1.4826086956522, 1.1934782608696, 0.33333333333333
66448, 1.504347826087, 1.2195652173913, 0.33333333333333
66449, 1.504347826087, 1.1934782608696, 0.30555555555556
66450, 1.4826086956522, 1.1934782608696, 0.27777777777778
66451, 1.504347826087, 1.2195652173913, 0.27777777777778
66452, 1.504347826087, 1.1934782608696, 0.25
66453, 1.4826086956522, 1.1934782608696, 0.22222222222222
66454, 1.504347826087, 1.2195652173913, 0.22222222222222
66455, 1.504347826087, 1.1934782608696, 0.19444444444444
66456, 1.4826086956522, 1.1934782608696, 0.16666666666667
66457, 1.504347826087, 1.2195652173913, 0.16666666666667
66458, 1.504347826087, 1.1934782608696, 0.13888888888889
66459, 1.4826086956522, 1.1934782608696, 0.11111111111111
66460, 1.504347826087, 1.2195652173913, 0.11111111111111
66461, 1.504347826087, 1.1934782608696, 0.083333333333333
66462, 1.4826086956522, 1.1934782608696, 0.055555555555556
66463, 1.504347826087, 1.2195652173913, 0.055555555555556
66464, 1.504347826087, 1.1934782608696, 0.027777777777778
66465, 1.5478260869565, 1.1934782608696, 0.47222222222222
66466, 1.5260869565217, 1.1934782608696, 0.44444444444444
66467, 1.5478260869565, 1.2195652173913, 0.44444444444444
66468, 1.5478260869565, 1.1934782608696, 0.41666666666667
66469, 1.5260869565217, 1.1934782608696, 0.38888888888889
66470, 1.5478260869565, 1.2195652173913, 0.38888888888889
66471, 1.5478260869565, 1.1934782608696, 0.36111111111111
66472, 1.5260869565217, 1.1934782608696, 0.33333333333333
66473, 1.5478260869565, 1.2195652173913, 0.33333333333333
66474, 1.5478260869565, 1.1934782608696, 0.30555555555556
66475, 1.5260869565217, 1.1934782608696, 0.27777777777778
66476, 1.5478260869565, 1.2195652173913, 0.27777777777778
66477, 1.5478260869565, 1.1934782608696, 0.25
66478, 1.5260869565217, 1.1934782608696, 0.22222222222222
66479, 1.5478260869565, 1.2195652173913, 0.22222222222222
66480, 1.5478260869565, 1.1934782608696, 0.19444444444444
66481, 1.5260869565217, 1.1934782608696, 0.16666666666667
66482, 1.5478260869565, 1.2195652173913, 0.16666666666667
66483, 1.5478260869565, 1.1934782608696, 0.13888888888889
66484, 1.5260869565217, 1.1934782608696, 0.11111111111111
66485, 1.5478260869565, 1.2195652173913, 0.11111111111111
66486, 1.5478260869565, 1.1934782608696, 0.083333333333333
66487, 1.5260869565217, 1.1934782608696, 0.055555555555556
66488, 1.5478260869565, 1.2195652173913, 0.055555555555556
66489, 1.5478260869565, 1.1934782608696, 0.027777777777778
66490, 1.5913043478261, 1.1934782608696, 0.47222222222222
66491, 1.5695652173913, 1.1934782608696, 0.44444444444444
66492, 1.5913043478261, 1.2195652173913, 0.44444444444444
66493, 1.5913043478261, 1.1934782608696, 0.41666666666667
66494, 1.5695652173913, 1.1934782608696, 0.38888888888889
66495, 1.5913043478261, 1.2195652173913, 0.38888888888889
66496, 1.5913043478261, 1.1934782608696, 0.36111111111111
66497, 1.5695652173913, 1.1934782608696, 0.33333333333333
66498, 1.5913043478261, 1.2195652173913, 0.33333333333333
66499, 1.5913043478261, 1.1934782608696, 0.30555555555556
66500, 1.5695652173913, 1.1934782608696, 0.27777777777778
66501, 1.5913043478261, 1.2195652173913, 0.27777777777778
66502, 1.5913043478261, 1.1934782608696, 0.25
66503, 1.5695652173913, 1.1934782608696, 0.22222222222222
66504, 1.5913043478261, 1.2195652173913, 0.22222222222222
66505, 1.5913043478261, 1.1934782608696, 0.19444444444444
66506, 1.5695652173913, 1.1934782608696, 0.16666666666667
66507, 1.5913043478261, 1.2195652173913, 0.16666666666667
66508, 1.5913043478261, 1.1934782608696, 0.13888888888889
66509, 1.5695652173913, 1.1934782608696, 0.11111111111111
66510, 1.5913043478261, 1.2195652173913, 0.11111111111111
66511, 1.5913043478261, 1.1934782608696, 0.083333333333333
66512, 1.5695652173913, 1.1934782608696, 0.055555555555556
66513, 1.5913043478261, 1.2195652173913, 0.055555555555556
66514, 1.5913043478261, 1.1934782608696, 0.027777777777778
66515, 1.6347826086957, 1.1934782608696, 0.47222222222222
66516, 1.6130434782609, 1.1934782608696, 0.44444444444444
66517, 1.6347826086957, 1.2195652173913, 0.44444444444444
66518, 1.6347826086957, 1.1934782608696, 0.41666666666667
66519, 1.6130434782609, 1.1934782608696, 0.38888888888889
66520, 1.6347826086957, 1.2195652173913, 0.38888888888889
66521, 1.6347826086957, 1.1934782608696, 0.36111111111111
66522, 1.6130434782609, 1.1934782608696, 0.33333333333333
66523, 1.6347826086957, 1.2195652173913, 0.33333333333333
66524, 1.6347826086957, 1.1934782608696, 0.30555555555556
66525, 1.6130434782609, 1.1934782608696, 0.27777777777778
66526, 1.6347826086957, 1.2195652173913, 0.27777777777778
66527, 1.6347826086957, 1.1934782608696, 0.25
66528, 1.6130434782609, 1.1934782608696, 0.22222222222222
66529, 1.6347826086957, 1.2195652173913, 0.22222222222222
66530, 1.6347826086957, 1.1934782608696, 0.19444444444444
66531, 1.6130434782609, 1.1934782608696, 0.16666666666667
66532, 1.6347826086957, 1.2195652173913, 0.16666666666667
66533, 1.6347826086957, 1.1934782608696, 0.13888888888889
66534, 1.6130434782609, 1.1934782608696, 0.11111111111111
66535, 1.6347826086957, 1.2195652173913, 0.11111111111111
66536, 1.6347826086957, 1.1934782608696, 0.083333333333333
66537, 1.6130434782609, 1.1934782608696, 0.055555555555556
66538, 1.6347826086957, 1.2195652173913, 0.055555555555556
66539, 1.6347826086957, 1.1934782608696, 0.027777777777778
66540, 1.6782608695652, 1.1934782608696, 0.47222222222222
66541, 1.6565217391304, 1.1934782608696, 0.44444444444444
66542, 1.6782608695652, 1.2195652173913, 0.44444444444444
66543, 1.6782608695652, 1.1934782608696, 0.41666666666667
66544, 1.6565217391304, 1.1934782608696, 0.38888888888889
66545, 1.6782608695652, 1.2195652173913, 0.38888888888889
66546, 1.6782608695652, 1.1934782608696, 0.36111111111111
66547, 1.6565217391304, 1.1934782608696, 0.33333333333333
66548, 1.6782608695652, 1.2195652173913, 0.33333333333333
66549, 1.6782608695652, 1.1934782608696, 0.30555555555556
66550, 1.6565217391304, 1.1934782608696, 0.27777777777778
66551, 1.6782608695652, 1.2195652173913, 0.27777777777778
66552, 1.6782608695652, 1.1934782608696, 0.25
66553, 1.6565217391304, 1.1934782608696, 0.22222222222222
66554, 1.6782608695652, 1.2195652173913, 0.22222222222222
66555, 1.6782608695652, 1.1934782608696, 0.19444444444444
66556, 1.6565217391304, 1.1934782608696, 0.16666666666667
66557, 1.6782608695652, 1.2195652173913, 0.16666666666667
66558, 1.6782608695652, 1.1934782608696, 0.13888888888889
66559, 1.6565217391304, 1.1934782608696, 0.11111111111111
66560, 1.6782608695652, 1.2195652173913, 0.11111111111111
66561, 1.6782608695652, 1.1934782608696, 0.083333333333333
66562, 1.6565217391304, 1.1934782608696, 0.055555555555556
66563, 1.6782608695652, 1.2195652173913, 0.055555555555556
66564, 1.6782608695652, 1.1934782608696, 0.027777777777778
66565, 1.7217391304348, 1.1934782608696, 0.47222222222222
66566, 1.7, 1.1934782608696, 0.44444444444444
66567, 1.7217391304348, 1.2195652173913, 0.44444444444444
66568, 1.7217391304348, 1.1934782608696, 0.41666666666667
66569, 1.7, 1.1934782608696, 0.38888888888889
66570, 1.7217391304348, 1.2195652173913, 0.38888888888889
66571, 1.7217391304348, 1.1934782608696, 0.36111111111111
66572, 1.7, 1.1934782608696, 0.33333333333333
66573, 1.7217391304348, 1.2195652173913, 0.33333333333333
66574, 1.7217391304348, 1.1934782608696, 0.30555555555556
66575, 1.7, 1.1934782608696, 0.27777777777778
66576, 1.7217391304348, 1.2195652173913, 0.27777777777778
66577, 1.7217391304348, 1.1934782608696, 0.25
66578, 1.7, 1.1934782608696, 0.22222222222222
66579, 1.7217391304348, 1.2195652173913, 0.22222222222222
66580, 1.7217391304348, 1.1934782608696, 0.19444444444444
66581, 1.7, 1.1934782608696, 0.16666666666667
66582, 1.7217391304348, 1.2195652173913, 0.16666666666667
66583, 1.7217391304348, 1.1934782608696, 0.13888888888889
66584, 1.7, 1.1934782608696, 0.11111111111111
66585, 1.7217391304348, 1.2195652173913, 0.11111111111111
66586, 1.7217391304348, 1.1934782608696, 0.083333333333333
66587, 1.7, 1.1934782608696, 0.055555555555556
66588, 1.7217391304348, 1.2195652173913, 0.055555555555556
66589, 1.7217391304348, 1.1934782608696, 0.027777777777778
66590, 1.7652173913043, 1.1934782608696, 0.47222222222222
66591, 1.7434782608696, 1.1934782608696, 0.44444444444444
66592, 1.7652173913043, 1.2195652173913, 0.44444444444444
66593, 1.7652173913043, 1.1934782608696, 0.41666666666667
66594, 1.7434782608696, 1.1934782608696, 0.38888888888889
66595, 1.7652173913043, 1.2195652173913, 0.38888888888889
66596, 1.7652173913043, 1.1934782608696, 0.36111111111111
66597, 1.7434782608696, 1.1934782608696, 0.33333333333333
66598, 1.7652173913043, 1.2195652173913, 0.33333333333333
66599, 1.7652173913043, 1.1934782608696, 0.30555555555556
66600, 1.7434782608696, 1.1934782608696, 0.27777777777778
66601, 1.7652173913043, 1.2195652173913, 0.27777777777778
66602, 1.7652173913043, 1.1934782608696, 0.25
66603, 1.7434782608696, 1.1934782608696, 0.22222222222222
66604, 1.7652173913043, 1.2195652173913, 0.22222222222222
66605, 1.7652173913043, 1.1934782608696, 0.19444444444444
66606, 1.7434782608696, 1.1934782608696, 0.16666666666667
66607, 1.7652173913043, 1.2195652173913, 0.16666666666667
66608, 1.7652173913043, 1.1934782608696, 0.13888888888889
66609, 1.7434782608696, 1.1934782608696, 0.11111111111111
66610, 1.7652173913043, 1.2195652173913, 0.11111111111111
66611, 1.7652173913043, 1.1934782608696, 0.083333333333333
66612, 1.7434782608696, 1.1934782608696, 0.055555555555556
66613, 1.7652173913043, 1.2195652173913, 0.055555555555556
66614, 1.7652173913043, 1.1934782608696, 0.027777777777778
66615, 1.8086956521739, 1.1934782608696, 0.47222222222222
66616, 1.7869565217391, 1.1934782608696, 0.44444444444444
66617, 1.8086956521739, 1.2195652173913, 0.44444444444444
66618, 1.8086956521739, 1.1934782608696, 0.41666666666667
66619, 1.7869565217391, 1.1934782608696, 0.38888888888889
66620, 1.8086956521739, 1.2195652173913, 0.38888888888889
66621, 1.8086956521739, 1.1934782608696, 0.36111111111111
66622, 1.7869565217391, 1.1934782608696, 0.33333333333333
66623, 1.8086956521739, 1.2195652173913, 0.33333333333333
66624, 1.8086956521739, 1.1934782608696, 0.30555555555556
66625, 1.7869565217391, 1.1934782608696, 0.27777777777778
66626, 1.8086956521739, 1.2195652173913, 0.27777777777778
66627, 1.8086956521739, 1.1934782608696, 0.25
66628, 1.7869565217391, 1.1934782608696, 0.22222222222222
66629, 1.8086956521739, 1.2195652173913, 0.22222222222222
66630, 1.8086956521739, 1.1934782608696, 0.19444444444444
66631, 1.7869565217391, 1.1934782608696, 0.16666666666667
66632, 1.8086956521739, 1.2195652173913, 0.16666666666667
66633, 1.8086956521739, 1.1934782608696, 0.13888888888889
66634, 1.7869565217391, 1.1934782608696, 0.11111111111111
66635, 1.8086956521739, 1.2195652173913, 0.11111111111111
66636, 1.8086956521739, 1.1934782608696, 0.083333333333333
66637, 1.7869565217391, 1.1934782608696, 0.055555555555556
66638, 1.8086956521739, 1.2195652173913, 0.055555555555556
66639, 1.8086956521739, 1.1934782608696, 0.027777777777778
66640, 1.8521739130435, 1.1934782608696, 0.47222222222222
66641, 1.8304347826087, 1.1934782608696, 0.44444444444444
66642, 1.8521739130435, 1.2195652173913, 0.44444444444444
66643, 1.8521739130435, 1.1934782608696, 0.41666666666667
66644, 1.8304347826087, 1.1934782608696, 0.38888888888889
66645, 1.8521739130435, 1.2195652173913, 0.38888888888889
66646, 1.8521739130435, 1.1934782608696, 0.36111111111111
66647, 1.8304347826087, 1.1934782608696, 0.33333333333333
66648, 1.8521739130435, 1.2195652173913, 0.33333333333333
66649, 1.8521739130435, 1.1934782608696, 0.30555555555556
66650, 1.8304347826087, 1.1934782608696, 0.27777777777778
66651, 1.8521739130435, 1.2195652173913, 0.27777777777778
66652, 1.8521739130435, 1.1934782608696, 0.25
66653, 1.8304347826087, 1.1934782608696, 0.22222222222222
66654, 1.8521739130435, 1.2195652173913, 0.22222222222222
66655, 1.8521739130435, 1.1934782608696, 0.19444444444444
66656, 1.8304347826087, 1.1934782608696, 0.16666666666667
66657, 1.8521739130435, 1.2195652173913, 0.16666666666667
66658, 1.8521739130435, 1.1934782608696, 0.13888888888889
66659, 1.8304347826087, 1.1934782608696, 0.11111111111111
66660, 1.8521739130435, 1.2195652173913, 0.11111111111111
66661, 1.8521739130435, 1.1934782608696, 0.083333333333333
66662, 1.8304347826087, 1.1934782608696, 0.055555555555556
66663, 1.8521739130435, 1.2195652173913, 0.055555555555556
66664, 1.8521739130435, 1.1934782608696, 0.027777777777778
66665, 1.895652173913, 1.1934782608696, 0.47222222222222
66666, 1.8739130434783, 1.1934782608696, 0.44444444444444
66667, 1.895652173913, 1.2195652173913, 0.44444444444444
66668, 1.895652173913, 1.1934782608696, 0.41666666666667
66669, 1.8739130434783, 1.1934782608696, 0.38888888888889
66670, 1.895652173913, 1.2195652173913, 0.38888888888889
66671, 1.895652173913, 1.1934782608696, 0.36111111111111
66672, 1.8739130434783, 1.1934782608696, 0.33333333333333
66673, 1.895652173913, 1.2195652173913, 0.33333333333333
66674, 1.895652173913, 1.1934782608696, 0.30555555555556
66675, 1.8739130434783, 1.1934782608696, 0.27777777777778
66676, 1.895652173913, 1.2195652173913, 0.27777777777778
66677, 1.895652173913, 1.1934782608696, 0.25
66678, 1.8739130434783, 1.1934782608696, 0.22222222222222
66679, 1.895652173913, 1.2195652173913, 0.22222222222222
66680, 1.895652173913, 1.1934782608696, 0.19444444444444
66681, 1.8739130434783, 1.1934782608696, 0.16666666666667
66682, 1.895652173913, 1.2195652173913, 0.16666666666667
66683, 1.895652173913, 1.1934782608696, 0.13888888888889
66684, 1.8739130434783, 1.1934782608696, 0.11111111111111
66685, 1.895652173913, 1.2195652173913, 0.11111111111111
66686, 1.895652173913, 1.1934782608696, 0.083333333333333
66687, 1.8739130434783, 1.1934782608696, 0.055555555555556
66688, 1.895652173913, 1.2195652173913, 0.055555555555556
66689, 1.895652173913, 1.1934782608696, 0.027777777777778
66690, 1.9391304347826, 1.1934782608696, 0.47222222222222
66691, 1.9173913043478, 1.1934782608696, 0.44444444444444
66692, 1.9391304347826, 1.2195652173913, 0.44444444444444
66693, 1.9391304347826, 1.1934782608696, 0.41666666666667
66694, 1.9173913043478, 1.1934782608696, 0.38888888888889
66695, 1.9391304347826, 1.2195652173913, 0.38888888888889
66696, 1.9391304347826, 1.1934782608696, 0.36111111111111
66697, 1.9173913043478, 1.1934782608696, 0.33333333333333
66698, 1.9391304347826, 1.2195652173913, 0.33333333333333
66699, 1.9391304347826, 1.1934782608696, 0.30555555555556
66700, 1.9173913043478, 1.1934782608696, 0.27777777777778
66701, 1.9391304347826, 1.2195652173913, 0.27777777777778
66702, 1.9391304347826, 1.1934782608696, 0.25
66703, 1.9173913043478, 1.1934782608696, 0.22222222222222
66704, 1.9391304347826, 1.2195652173913, 0.22222222222222
66705, 1.9391304347826, 1.1934782608696, 0.19444444444444
66706, 1.9173913043478, 1.1934782608696, 0.16666666666667
66707, 1.9391304347826, 1.2195652173913, 0.16666666666667
66708, 1.9391304347826, 1.1934782608696, 0.13888888888889
66709, 1.9173913043478, 1.1934782608696, 0.11111111111111
66710, 1.9391304347826, 1.2195652173913, 0.11111111111111
66711, 1.9391304347826, 1.1934782608696, 0.083333333333333
66712, 1.9173913043478, 1.1934782608696, 0.055555555555556
66713, 1.9391304347826, 1.2195652173913, 0.055555555555556
66714, 1.9391304347826, 1.1934782608696, 0.027777777777778
66715, 1.9826086956522, 1.1934782608696, 0.47222222222222
66716, 1.9608695652174, 1.1934782608696, 0.44444444444444
66717, 1.9826086956522, 1.2195652173913, 0.44444444444444
66718, 1.9826086956522, 1.1934782608696, 0.41666666666667
66719, 1.9608695652174, 1.1934782608696, 0.38888888888889
66720, 1.9826086956522, 1.2195652173913, 0.38888888888889
66721, 1.9826086956522, 1.1934782608696, 0.36111111111111
66722, 1.9608695652174, 1.1934782608696, 0.33333333333333
66723, 1.9826086956522, 1.2195652173913, 0.33333333333333
66724, 1.9826086956522, 1.1934782608696, 0.30555555555556
66725, 1.9608695652174, 1.1934782608696, 0.27777777777778
66726, 1.9826086956522, 1.2195652173913, 0.27777777777778
66727, 1.9826086956522, 1.1934782608696, 0.25
66728, 1.9608695652174, 1.1934782608696, 0.22222222222222
66729, 1.9826086956522, 1.2195652173913, 0.22222222222222
66730, 1.9826086956522, 1.1934782608696, 0.19444444444444
66731, 1.9608695652174, 1.1934782608696, 0.16666666666667
66732, 1.9826086956522, 1.2195652173913, 0.16666666666667
66733, 1.9826086956522, 1.1934782608696, 0.13888888888889
66734, 1.9608695652174, 1.1934782608696, 0.11111111111111
66735, 1.9826086956522, 1.2195652173913, 0.11111111111111
66736, 1.9826086956522, 1.1934782608696, 0.083333333333333
66737, 1.9608695652174, 1.1934782608696, 0.055555555555556
66738, 1.9826086956522, 1.2195652173913, 0.055555555555556
66739, 1.9826086956522, 1.1934782608696, 0.027777777777778
66740, 2.0260869565217, 1.1934782608696, 0.47222222222222
66741, 2.004347826087, 1.1934782608696, 0.44444444444444
66742, 2.0260869565217, 1.2195652173913, 0.44444444444444
66743, 2.0260869565217, 1.1934782608696, 0.41666666666667
66744, 2.004347826087, 1.1934782608696, 0.38888888888889
66745, 2.0260869565217, 1.2195652173913, 0.38888888888889
66746, 2.0260869565217, 1.1934782608696, 0.36111111111111
66747, 2.004347826087, 1.1934782608696, 0.33333333333333
66748, 2.0260869565217, 1.2195652173913, 0.33333333333333
66749, 2.0260869565217, 1.1934782608696, 0.30555555555556
66750, 2.004347826087, 1.1934782608696, 0.27777777777778
66751, 2.0260869565217, 1.2195652173913, 0.27777777777778
66752, 2.0260869565217, 1.1934782608696, 0.25
66753, 2.004347826087, 1.1934782608696, 0.22222222222222
66754, 2.0260869565217, 1.2195652173913, 0.22222222222222
66755, 2.0260869565217, 1.1934782608696, 0.19444444444444
66756, 2.004347826087, 1.1934782608696, 0.16666666666667
66757, 2.0260869565217, 1.2195652173913, 0.16666666666667
66758, 2.0260869565217, 1.1934782608696, 0.13888888888889
66759, 2.004347826087, 1.1934782608696, 0.11111111111111
66760, 2.0260869565217, 1.2195652173913, 0.11111111111111
66761, 2.0260869565217, 1.1934782608696, 0.083333333333333
66762, 2.004347826087, 1.1934782608696, 0.055555555555556
66763, 2.0260869565217, 1.2195652173913, 0.055555555555556
66764, 2.0260869565217, 1.1934782608696, 0.027777777777778
66765, 2.0695652173913, 1.1934782608696, 0.47222222222222
66766, 2.0478260869565, 1.1934782608696, 0.44444444444444
66767, 2.0695652173913, 1.2195652173913, 0.44444444444444
66768, 2.0695652173913, 1.1934782608696, 0.41666666666667
66769, 2.0478260869565, 1.1934782608696, 0.38888888888889
66770, 2.0695652173913, 1.2195652173913, 0.38888888888889
66771, 2.0695652173913, 1.1934782608696, 0.36111111111111
66772, 2.0478260869565, 1.1934782608696, 0.33333333333333
66773, 2.0695652173913, 1.2195652173913, 0.33333333333333
66774, 2.0695652173913, 1.1934782608696, 0.30555555555556
66775, 2.0478260869565, 1.1934782608696, 0.27777777777778
66776, 2.0695652173913, 1.2195652173913, 0.27777777777778
66777, 2.0695652173913, 1.1934782608696, 0.25
66778, 2.0478260869565, 1.1934782608696, 0.22222222222222
66779, 2.0695652173913, 1.2195652173913, 0.22222222222222
66780, 2.0695652173913, 1.1934782608696, 0.19444444444444
66781, 2.0478260869565, 1.1934782608696, 0.16666666666667
66782, 2.0695652173913, 1.2195652173913, 0.16666666666667
66783, 2.0695652173913, 1.1934782608696, 0.13888888888889
66784, 2.0478260869565, 1.1934782608696, 0.11111111111111
66785, 2.0695652173913, 1.2195652173913, 0.11111111111111
66786, 2.0695652173913, 1.1934782608696, 0.083333333333333
66787, 2.0478260869565, 1.1934782608696, 0.055555555555556
66788, 2.0695652173913, 1.2195652173913, 0.055555555555556
66789, 2.0695652173913, 1.1934782608696, 0.027777777777778
66790, 2.1130434782609, 1.1934782608696, 0.47222222222222
66791, 2.0913043478261, 1.1934782608696, 0.44444444444444
66792, 2.1130434782609, 1.2195652173913, 0.44444444444444
66793, 2.1130434782609, 1.1934782608696, 0.41666666666667
66794, 2.0913043478261, 1.1934782608696, 0.38888888888889
66795, 2.1130434782609, 1.2195652173913, 0.38888888888889
66796, 2.1130434782609, 1.1934782608696, 0.36111111111111
66797, 2.0913043478261, 1.1934782608696, 0.33333333333333
66798, 2.1130434782609, 1.2195652173913, 0.33333333333333
66799, 2.1130434782609, 1.1934782608696, 0.30555555555556
66800, 2.0913043478261, 1.1934782608696, 0.27777777777778
66801, 2.1130434782609, 1.2195652173913, 0.27777777777778
66802, 2.1130434782609, 1.1934782608696, 0.25
66803, 2.0913043478261, 1.1934782608696, 0.22222222222222
66804, 2.1130434782609, 1.2195652173913, 0.22222222222222
66805, 2.1130434782609, 1.1934782608696, 0.19444444444444
66806, 2.0913043478261, 1.1934782608696, 0.16666666666667
66807, 2.1130434782609, 1.2195652173913, 0.16666666666667
66808, 2.1130434782609, 1.1934782608696, 0.13888888888889
66809, 2.0913043478261, 1.1934782608696, 0.11111111111111
66810, 2.1130434782609, 1.2195652173913, 0.11111111111111
66811, 2.1130434782609, 1.1934782608696, 0.083333333333333
66812, 2.0913043478261, 1.1934782608696, 0.055555555555556
66813, 2.1130434782609, 1.2195652173913, 0.055555555555556
66814, 2.1130434782609, 1.1934782608696, 0.027777777777778
66815, 2.1565217391304, 1.1934782608696, 0.47222222222222
66816, 2.1347826086957, 1.1934782608696, 0.44444444444444
66817, 2.1565217391304, 1.2195652173913, 0.44444444444444
66818, 2.1565217391304, 1.1934782608696, 0.41666666666667
66819, 2.1347826086957, 1.1934782608696, 0.38888888888889
66820, 2.1565217391304, 1.2195652173913, 0.38888888888889
66821, 2.1565217391304, 1.1934782608696, 0.36111111111111
66822, 2.1347826086957, 1.1934782608696, 0.33333333333333
66823, 2.1565217391304, 1.2195652173913, 0.33333333333333
66824, 2.1565217391304, 1.1934782608696, 0.30555555555556
66825, 2.1347826086957, 1.1934782608696, 0.27777777777778
66826, 2.1565217391304, 1.2195652173913, 0.27777777777778
66827, 2.1565217391304, 1.1934782608696, 0.25
66828, 2.1347826086957, 1.1934782608696, 0.22222222222222
66829, 2.1565217391304, 1.2195652173913, 0.22222222222222
66830, 2.1565217391304, 1.1934782608696, 0.19444444444444
66831, 2.1347826086957, 1.1934782608696, 0.16666666666667
66832, 2.1565217391304, 1.2195652173913, 0.16666666666667
66833, 2.1565217391304, 1.1934782608696, 0.13888888888889
66834, 2.1347826086957, 1.1934782608696, 0.11111111111111
66835, 2.1565217391304, 1.2195652173913, 0.11111111111111
66836, 2.1565217391304, 1.1934782608696, 0.083333333333333
66837, 2.1347826086957, 1.1934782608696, 0.055555555555556
66838, 2.1565217391304, 1.2195652173913, 0.055555555555556
66839, 2.1565217391304, 1.1934782608696, 0.027777777777778
66840, 2.1782608695652, 1.1934782608696, 0.44444444444444
66841, 2.1782608695652, 1.1934782608696, 0.38888888888889
66842, 2.1782608695652, 1.1934782608696, 0.33333333333333
66843, 2.1782608695652, 1.1934782608696, 0.27777777777778
66844, 2.1782608695652, 1.1934782608696, 0.22222222222222
66845, 2.1782608695652, 1.1934782608696, 0.16666666666667
66846, 2.1782608695652, 1.1934782608696, 0.11111111111111
66847, 2.1782608695652, 1.1934782608696, 0.055555555555556
66848, 1.2434782608696, 1.1413043478261, 0.47222222222222
66849, 1.2217391304348, 1.1413043478261, 0.44444444444444
66850, 1.2434782608696, 1.1673913043478, 0.44444444444444
66851, 1.2434782608696, 1.1413043478261, 0.41666666666667
66852, 1.2217391304348, 1.1413043478261, 0.38888888888889
66853, 1.2434782608696, 1.1673913043478, 0.38888888888889
66854, 1.2434782608696, 1.1413043478261, 0.36111111111111
66855, 1.2217391304348, 1.1413043478261, 0.33333333333333
66856, 1.2434782608696, 1.1673913043478, 0.33333333333333
66857, 1.2434782608696, 1.1413043478261, 0.30555555555556
66858, 1.2217391304348, 1.1413043478261, 0.27777777777778
66859, 1.2434782608696, 1.1673913043478, 0.27777777777778
66860, 1.2434782608696, 1.1413043478261, 0.25
66861, 1.2217391304348, 1.1413043478261, 0.22222222222222
66862, 1.2434782608696, 1.1673913043478, 0.22222222222222
66863, 1.2434782608696, 1.1413043478261, 0.19444444444444
66864, 1.2217391304348, 1.1413043478261, 0.16666666666667
66865, 1.2434782608696, 1.1673913043478, 0.16666666666667
66866, 1.2434782608696, 1.1413043478261, 0.13888888888889
66867, 1.2217391304348, 1.1413043478261, 0.11111111111111
66868, 1.2434782608696, 1.1673913043478, 0.11111111111111
66869, 1.2434782608696, 1.1413043478261, 0.083333333333333
66870, 1.2217391304348, 1.1413043478261, 0.055555555555556
66871, 1.2434782608696, 1.1673913043478, 0.055555555555556
66872, 1.2434782608696, 1.1413043478261, 0.027777777777778
66873, 1.2869565217391, 1.1413043478261, 0.47222222222222
66874, 1.2652173913043, 1.1413043478261, 0.44444444444444
66875, 1.2869565217391, 1.1673913043478, 0.44444444444444
66876, 1.2869565217391, 1.1413043478261, 0.41666666666667
66877, 1.2652173913043, 1.1413043478261, 0.38888888888889
66878, 1.2869565217391, 1.1673913043478, 0.38888888888889
66879, 1.2869565217391, 1.1413043478261, 0.36111111111111
66880, 1.2652173913043, 1.1413043478261, 0.33333333333333
66881, 1.2869565217391, 1.1673913043478, 0.33333333333333
66882, 1.2869565217391, 1.1413043478261, 0.30555555555556
66883, 1.2652173913043, 1.1413043478261, 0.27777777777778
66884, 1.2869565217391, 1.1673913043478, 0.27777777777778
66885, 1.2869565217391, 1.1413043478261, 0.25
66886, 1.2652173913043, 1.1413043478261, 0.22222222222222
66887, 1.2869565217391, 1.1673913043478, 0.22222222222222
66888, 1.2869565217391, 1.1413043478261, 0.19444444444444
66889, 1.2652173913043, 1.1413043478261, 0.16666666666667
66890, 1.2869565217391, 1.1673913043478, 0.16666666666667
66891, 1.2869565217391, 1.1413043478261, 0.13888888888889
66892, 1.2652173913043, 1.1413043478261, 0.11111111111111
66893, 1.2869565217391, 1.1673913043478, 0.11111111111111
66894, 1.2869565217391, 1.1413043478261, 0.083333333333333
66895, 1.2652173913043, 1.1413043478261, 0.055555555555556
66896, 1.2869565217391, 1.1673913043478, 0.055555555555556
66897, 1.2869565217391, 1.1413043478261, 0.027777777777778
66898, 1.3304347826087, 1.1413043478261, 0.47222222222222
66899, 1.3086956521739, 1.1413043478261, 0.44444444444444
66900, 1.3304347826087, 1.1673913043478, 0.44444444444444
66901, 1.3304347826087, 1.1413043478261, 0.41666666666667
66902, 1.3086956521739, 1.1413043478261, 0.38888888888889
66903, 1.3304347826087, 1.1673913043478, 0.38888888888889
66904, 1.3304347826087, 1.1413043478261, 0.36111111111111
66905, 1.3086956521739, 1.1413043478261, 0.33333333333333
66906, 1.3304347826087, 1.1673913043478, 0.33333333333333
66907, 1.3304347826087, 1.1413043478261, 0.30555555555556
66908, 1.3086956521739, 1.1413043478261, 0.27777777777778
66909, 1.3304347826087, 1.1673913043478, 0.27777777777778
66910, 1.3304347826087, 1.1413043478261, 0.25
66911, 1.3086956521739, 1.1413043478261, 0.22222222222222
66912, 1.3304347826087, 1.1673913043478, 0.22222222222222
66913, 1.3304347826087, 1.1413043478261, 0.19444444444444
66914, 1.3086956521739, 1.1413043478261, 0.16666666666667
66915, 1.3304347826087, 1.1673913043478, 0.16666666666667
66916, 1.3304347826087, 1.1413043478261, 0.13888888888889
66917, 1.3086956521739, 1.1413043478261, 0.11111111111111
66918, 1.3304347826087, 1.1673913043478, 0.11111111111111
66919, 1.3304347826087, 1.1413043478261, 0.083333333333333
66920, 1.3086956521739, 1.1413043478261, 0.055555555555556
66921, 1.3304347826087, 1.1673913043478, 0.055555555555556
66922, 1.3304347826087, 1.1413043478261, 0.027777777777778
66923, 1.3739130434783, 1.1413043478261, 0.47222222222222
66924, 1.3521739130435, 1.1413043478261, 0.44444444444444
66925, 1.3739130434783, 1.1673913043478, 0.44444444444444
66926, 1.3739130434783, 1.1413043478261, 0.41666666666667
66927, 1.3521739130435, 1.1413043478261, 0.38888888888889
66928, 1.3739130434783, 1.1673913043478, 0.38888888888889
66929, 1.3739130434783, 1.1413043478261, 0.36111111111111
66930, 1.3521739130435, 1.1413043478261, 0.33333333333333
66931, 1.3739130434783, 1.1673913043478, 0.33333333333333
66932, 1.3739130434783, 1.1413043478261, 0.30555555555556
66933, 1.3521739130435, 1.1413043478261, 0.27777777777778
66934, 1.3739130434783, 1.1673913043478, 0.27777777777778
66935, 1.3739130434783, 1.1413043478261, 0.25
66936, 1.3521739130435, 1.1413043478261, 0.22222222222222
66937, 1.3739130434783, 1.1673913043478, 0.22222222222222
66938, 1.3739130434783, 1.1413043478261, 0.19444444444444
66939, 1.3521739130435, 1.1413043478261, 0.16666666666667
66940, 1.3739130434783, 1.1673913043478, 0.16666666666667
66941, 1.3739130434783, 1.1413043478261, 0.13888888888889
66942, 1.3521739130435, 1.1413043478261, 0.11111111111111
66943, 1.3739130434783, 1.1673913043478, 0.11111111111111
66944, 1.3739130434783, 1.1413043478261, 0.083333333333333
66945, 1.3521739130435, 1.1413043478261, 0.055555555555556
66946, 1.3739130434783, 1.1673913043478, 0.055555555555556
66947, 1.3739130434783, 1.1413043478261, 0.027777777777778
66948, 1.4173913043478, 1.1413043478261, 0.47222222222222
66949, 1.395652173913, 1.1413043478261, 0.44444444444444
66950, 1.4173913043478, 1.1673913043478, 0.44444444444444
66951, 1.4173913043478, 1.1413043478261, 0.41666666666667
66952, 1.395652173913, 1.1413043478261, 0.38888888888889
66953, 1.4173913043478, 1.1673913043478, 0.38888888888889
66954, 1.4173913043478, 1.1413043478261, 0.36111111111111
66955, 1.395652173913, 1.1413043478261, 0.33333333333333
66956, 1.4173913043478, 1.1673913043478, 0.33333333333333
66957, 1.4173913043478, 1.1413043478261, 0.30555555555556
66958, 1.395652173913, 1.1413043478261, 0.27777777777778
66959, 1.4173913043478, 1.1673913043478, 0.27777777777778
66960, 1.4173913043478, 1.1413043478261, 0.25
66961, 1.395652173913, 1.1413043478261, 0.22222222222222
66962, 1.4173913043478, 1.1673913043478, 0.22222222222222
66963, 1.4173913043478, 1.1413043478261, 0.19444444444444
66964, 1.395652173913, 1.1413043478261, 0.16666666666667
66965, 1.4173913043478, 1.1673913043478, 0.16666666666667
66966, 1.4173913043478, 1.1413043478261, 0.13888888888889
66967, 1.395652173913, 1.1413043478261, 0.11111111111111
66968, 1.4173913043478, 1.1673913043478, 0.11111111111111
66969, 1.4173913043478, 1.1413043478261, 0.083333333333333
66970, 1.395652173913, 1.1413043478261, 0.055555555555556
66971, 1.4173913043478, 1.1673913043478, 0.055555555555556
66972, 1.4173913043478, 1.1413043478261, 0.027777777777778
66973, 1.4608695652174, 1.1413043478261, 0.47222222222222
66974, 1.4391304347826, 1.1413043478261, 0.44444444444444
66975, 1.4608695652174, 1.1673913043478, 0.44444444444444
66976, 1.4608695652174, 1.1413043478261, 0.41666666666667
66977, 1.4391304347826, 1.1413043478261, 0.38888888888889
66978, 1.4608695652174, 1.1673913043478, 0.38888888888889
66979, 1.4608695652174, 1.1413043478261, 0.36111111111111
66980, 1.4391304347826, 1.1413043478261, 0.33333333333333
66981, 1.4608695652174, 1.1673913043478, 0.33333333333333
66982, 1.4608695652174, 1.1413043478261, 0.30555555555556
66983, 1.4391304347826, 1.1413043478261, 0.27777777777778
66984, 1.4608695652174, 1.1673913043478, 0.27777777777778
66985, 1.4608695652174, 1.1413043478261, 0.25
66986, 1.4391304347826, 1.1413043478261, 0.22222222222222
66987, 1.4608695652174, 1.1673913043478, 0.22222222222222
66988, 1.4608695652174, 1.1413043478261, 0.19444444444444
66989, 1.4391304347826, 1.1413043478261, 0.16666666666667
66990, 1.4608695652174, 1.1673913043478, 0.16666666666667
66991, 1.4608695652174, 1.1413043478261, 0.13888888888889
66992, 1.4391304347826, 1.1413043478261, 0.11111111111111
66993, 1.4608695652174, 1.1673913043478, 0.11111111111111
66994, 1.4608695652174, 1.1413043478261, 0.083333333333333
66995, 1.4391304347826, 1.1413043478261, 0.055555555555556
66996, 1.4608695652174, 1.1673913043478, 0.055555555555556
66997, 1.4608695652174, 1.1413043478261, 0.027777777777778
66998, 1.504347826087, 1.1413043478261, 0.47222222222222
66999, 1.4826086956522, 1.1413043478261, 0.44444444444444
67000, 1.504347826087, 1.1673913043478, 0.44444444444444
67001, 1.504347826087, 1.1413043478261, 0.41666666666667
67002, 1.4826086956522, 1.1413043478261, 0.38888888888889
67003, 1.504347826087, 1.1673913043478, 0.38888888888889
67004, 1.504347826087, 1.1413043478261, 0.36111111111111
67005, 1.4826086956522, 1.1413043478261, 0.33333333333333
67006, 1.504347826087, 1.1673913043478, 0.33333333333333
67007, 1.504347826087, 1.1413043478261, 0.30555555555556
67008, 1.4826086956522, 1.1413043478261, 0.27777777777778
67009, 1.504347826087, 1.1673913043478, 0.27777777777778
67010, 1.504347826087, 1.1413043478261, 0.25
67011, 1.4826086956522, 1.1413043478261, 0.22222222222222
67012, 1.504347826087, 1.1673913043478, 0.22222222222222
67013, 1.504347826087, 1.1413043478261, 0.19444444444444
67014, 1.4826086956522, 1.1413043478261, 0.16666666666667
67015, 1.504347826087, 1.1673913043478, 0.16666666666667
67016, 1.504347826087, 1.1413043478261, 0.13888888888889
67017, 1.4826086956522, 1.1413043478261, 0.11111111111111
67018, 1.504347826087, 1.1673913043478, 0.11111111111111
67019, 1.504347826087, 1.1413043478261, 0.083333333333333
67020, 1.4826086956522, 1.1413043478261, 0.055555555555556
67021, 1.504347826087, 1.1673913043478, 0.055555555555556
67022, 1.504347826087, 1.1413043478261, 0.027777777777778
67023, 1.5478260869565, 1.1413043478261, 0.47222222222222
67024, 1.5260869565217, 1.1413043478261, 0.44444444444444
67025, 1.5478260869565, 1.1673913043478, 0.44444444444444
67026, 1.5478260869565, 1.1413043478261, 0.41666666666667
67027, 1.5260869565217, 1.1413043478261, 0.38888888888889
67028, 1.5478260869565, 1.1673913043478, 0.38888888888889
67029, 1.5478260869565, 1.1413043478261, 0.36111111111111
67030, 1.5260869565217, 1.1413043478261, 0.33333333333333
67031, 1.5478260869565, 1.1673913043478, 0.33333333333333
67032, 1.5478260869565, 1.1413043478261, 0.30555555555556
67033, 1.5260869565217, 1.1413043478261, 0.27777777777778
67034, 1.5478260869565, 1.1673913043478, 0.27777777777778
67035, 1.5478260869565, 1.1413043478261, 0.25
67036, 1.5260869565217, 1.1413043478261, 0.22222222222222
67037, 1.5478260869565, 1.1673913043478, 0.22222222222222
67038, 1.5478260869565, 1.1413043478261, 0.19444444444444
67039, 1.5260869565217, 1.1413043478261, 0.16666666666667
67040, 1.5478260869565, 1.1673913043478, 0.16666666666667
67041, 1.5478260869565, 1.1413043478261, 0.13888888888889
67042, 1.5260869565217, 1.1413043478261, 0.11111111111111
67043, 1.5478260869565, 1.1673913043478, 0.11111111111111
67044, 1.5478260869565, 1.1413043478261, 0.083333333333333
67045, 1.5260869565217, 1.1413043478261, 0.055555555555556
67046, 1.5478260869565, 1.1673913043478, 0.055555555555556
67047, 1.5478260869565, 1.1413043478261, 0.027777777777778
67048, 1.5913043478261, 1.1413043478261, 0.47222222222222
67049, 1.5695652173913, 1.1413043478261, 0.44444444444444
67050, 1.5913043478261, 1.1673913043478, 0.44444444444444
67051, 1.5913043478261, 1.1413043478261, 0.41666666666667
67052, 1.5695652173913, 1.1413043478261, 0.38888888888889
67053, 1.5913043478261, 1.1673913043478, 0.38888888888889
67054, 1.5913043478261, 1.1413043478261, 0.36111111111111
67055, 1.5695652173913, 1.1413043478261, 0.33333333333333
67056, 1.5913043478261, 1.1673913043478, 0.33333333333333
67057, 1.5913043478261, 1.1413043478261, 0.30555555555556
67058, 1.5695652173913, 1.1413043478261, 0.27777777777778
67059, 1.5913043478261, 1.1673913043478, 0.27777777777778
67060, 1.5913043478261, 1.1413043478261, 0.25
67061, 1.5695652173913, 1.1413043478261, 0.22222222222222
67062, 1.5913043478261, 1.1673913043478, 0.22222222222222
67063, 1.5913043478261, 1.1413043478261, 0.19444444444444
67064, 1.5695652173913, 1.1413043478261, 0.16666666666667
67065, 1.5913043478261, 1.1673913043478, 0.16666666666667
67066, 1.5913043478261, 1.1413043478261, 0.13888888888889
67067, 1.5695652173913, 1.1413043478261, 0.11111111111111
67068, 1.5913043478261, 1.1673913043478, 0.11111111111111
67069, 1.5913043478261, 1.1413043478261, 0.083333333333333
67070, 1.5695652173913, 1.1413043478261, 0.055555555555556
67071, 1.5913043478261, 1.1673913043478, 0.055555555555556
67072, 1.5913043478261, 1.1413043478261, 0.027777777777778
67073, 1.6347826086957, 1.1413043478261, 0.47222222222222
67074, 1.6130434782609, 1.1413043478261, 0.44444444444444
67075, 1.6347826086957, 1.1673913043478, 0.44444444444444
67076, 1.6347826086957, 1.1413043478261, 0.41666666666667
67077, 1.6130434782609, 1.1413043478261, 0.38888888888889
67078, 1.6347826086957, 1.1673913043478, 0.38888888888889
67079, 1.6347826086957, 1.1413043478261, 0.36111111111111
67080, 1.6130434782609, 1.1413043478261, 0.33333333333333
67081, 1.6347826086957, 1.1673913043478, 0.33333333333333
67082, 1.6347826086957, 1.1413043478261, 0.30555555555556
67083, 1.6130434782609, 1.1413043478261, 0.27777777777778
67084, 1.6347826086957, 1.1673913043478, 0.27777777777778
67085, 1.6347826086957, 1.1413043478261, 0.25
67086, 1.6130434782609, 1.1413043478261, 0.22222222222222
67087, 1.6347826086957, 1.1673913043478, 0.22222222222222
67088, 1.6347826086957, 1.1413043478261, 0.19444444444444
67089, 1.6130434782609, 1.1413043478261, 0.16666666666667
67090, 1.6347826086957, 1.1673913043478, 0.16666666666667
67091, 1.6347826086957, 1.1413043478261, 0.13888888888889
67092, 1.6130434782609, 1.1413043478261, 0.11111111111111
67093, 1.6347826086957, 1.1673913043478, 0.11111111111111
67094, 1.6347826086957, 1.1413043478261, 0.083333333333333
67095, 1.6130434782609, 1.1413043478261, 0.055555555555556
67096, 1.6347826086957, 1.1673913043478, 0.055555555555556
67097, 1.6347826086957, 1.1413043478261, 0.027777777777778
67098, 1.6782608695652, 1.1413043478261, 0.47222222222222
67099, 1.6565217391304, 1.1413043478261, 0.44444444444444
67100, 1.6782608695652, 1.1673913043478, 0.44444444444444
67101, 1.6782608695652, 1.1413043478261, 0.41666666666667
67102, 1.6565217391304, 1.1413043478261, 0.38888888888889
67103, 1.6782608695652, 1.1673913043478, 0.38888888888889
67104, 1.6782608695652, 1.1413043478261, 0.36111111111111
67105, 1.6565217391304, 1.1413043478261, 0.33333333333333
67106, 1.6782608695652, 1.1673913043478, 0.33333333333333
67107, 1.6782608695652, 1.1413043478261, 0.30555555555556
67108, 1.6565217391304, 1.1413043478261, 0.27777777777778
67109, 1.6782608695652, 1.1673913043478, 0.27777777777778
67110, 1.6782608695652, 1.1413043478261, 0.25
67111, 1.6565217391304, 1.1413043478261, 0.22222222222222
67112, 1.6782608695652, 1.1673913043478, 0.22222222222222
67113, 1.6782608695652, 1.1413043478261, 0.19444444444444
67114, 1.6565217391304, 1.1413043478261, 0.16666666666667
67115, 1.6782608695652, 1.1673913043478, 0.16666666666667
67116, 1.6782608695652, 1.1413043478261, 0.13888888888889
67117, 1.6565217391304, 1.1413043478261, 0.11111111111111
67118, 1.6782608695652, 1.1673913043478, 0.11111111111111
67119, 1.6782608695652, 1.1413043478261, 0.083333333333333
67120, 1.6565217391304, 1.1413043478261, 0.055555555555556
67121, 1.6782608695652, 1.1673913043478, 0.055555555555556
67122, 1.6782608695652, 1.1413043478261, 0.027777777777778
67123, 1.7217391304348, 1.1413043478261, 0.47222222222222
67124, 1.7, 1.1413043478261, 0.44444444444444
67125, 1.7217391304348, 1.1673913043478, 0.44444444444444
67126, 1.7217391304348, 1.1413043478261, 0.41666666666667
67127, 1.7, 1.1413043478261, 0.38888888888889
67128, 1.7217391304348, 1.1673913043478, 0.38888888888889
67129, 1.7217391304348, 1.1413043478261, 0.36111111111111
67130, 1.7, 1.1413043478261, 0.33333333333333
67131, 1.7217391304348, 1.1673913043478, 0.33333333333333
67132, 1.7217391304348, 1.1413043478261, 0.30555555555556
67133, 1.7, 1.1413043478261, 0.27777777777778
67134, 1.7217391304348, 1.1673913043478, 0.27777777777778
67135, 1.7217391304348, 1.1413043478261, 0.25
67136, 1.7, 1.1413043478261, 0.22222222222222
67137, 1.7217391304348, 1.1673913043478, 0.22222222222222
67138, 1.7217391304348, 1.1413043478261, 0.19444444444444
67139, 1.7, 1.1413043478261, 0.16666666666667
67140, 1.7217391304348, 1.1673913043478, 0.16666666666667
