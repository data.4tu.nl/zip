24399, 0.043478260869565, 1.35, 0.44444444444444
24400, 0.08695652173913, 1.35, 0.055555555555556
24401, 0.08695652173913, 1.35, 0.11111111111111
24402, 0.08695652173913, 1.35, 0.16666666666667
24403, 0.08695652173913, 1.35, 0.22222222222222
24404, 0.08695652173913, 1.35, 0.27777777777778
24405, 0.08695652173913, 1.35, 0.33333333333333
24406, 0.08695652173913, 1.35, 0.38888888888889
24407, 0.08695652173913, 1.35, 0.44444444444444
24408, 0.1304347826087, 1.35, 0.055555555555556
24409, 0.1304347826087, 1.35, 0.11111111111111
24410, 0.1304347826087, 1.35, 0.16666666666667
24411, 0.1304347826087, 1.35, 0.22222222222222
24412, 0.1304347826087, 1.35, 0.27777777777778
24413, 0.1304347826087, 1.35, 0.33333333333333
24414, 0.1304347826087, 1.35, 0.38888888888889
24415, 0.1304347826087, 1.35, 0.44444444444444
24416, 0.17391304347826, 1.35, 0.055555555555556
24417, 0.17391304347826, 1.35, 0.11111111111111
24418, 0.17391304347826, 1.35, 0.16666666666667
24419, 0.17391304347826, 1.35, 0.22222222222222
24420, 0.17391304347826, 1.35, 0.27777777777778
24421, 0.17391304347826, 1.35, 0.33333333333333
24422, 0.17391304347826, 1.35, 0.38888888888889
24423, 0.17391304347826, 1.35, 0.44444444444444
24424, 0.21739130434783, 1.35, 0.055555555555556
24425, 0.21739130434783, 1.35, 0.11111111111111
24426, 0.21739130434783, 1.35, 0.16666666666667
24427, 0.21739130434783, 1.35, 0.22222222222222
24428, 0.21739130434783, 1.35, 0.27777777777778
24429, 0.21739130434783, 1.35, 0.33333333333333
24430, 0.21739130434783, 1.35, 0.38888888888889
24431, 0.21739130434783, 1.35, 0.44444444444444
24432, 0.26086956521739, 1.35, 0.055555555555556
24433, 0.26086956521739, 1.35, 0.11111111111111
24434, 0.26086956521739, 1.35, 0.16666666666667
24435, 0.26086956521739, 1.35, 0.22222222222222
24436, 0.26086956521739, 1.35, 0.27777777777778
24437, 0.26086956521739, 1.35, 0.33333333333333
24438, 0.26086956521739, 1.35, 0.38888888888889
24439, 0.26086956521739, 1.35, 0.44444444444444
24440, 0.30434782608696, 1.35, 0.055555555555556
24441, 0.30434782608696, 1.35, 0.11111111111111
24442, 0.30434782608696, 1.35, 0.16666666666667
24443, 0.30434782608696, 1.35, 0.22222222222222
24444, 0.30434782608696, 1.35, 0.27777777777778
24445, 0.30434782608696, 1.35, 0.33333333333333
24446, 0.30434782608696, 1.35, 0.38888888888889
24447, 0.30434782608696, 1.35, 0.44444444444444
24448, 0.34782608695652, 1.35, 0.055555555555556
24449, 0.34782608695652, 1.35, 0.11111111111111
24450, 0.34782608695652, 1.35, 0.16666666666667
24451, 0.34782608695652, 1.35, 0.22222222222222
24452, 0.34782608695652, 1.35, 0.27777777777778
24453, 0.34782608695652, 1.35, 0.33333333333333
24454, 0.34782608695652, 1.35, 0.38888888888889
24455, 0.34782608695652, 1.35, 0.44444444444444
24456, 0.39130434782609, 1.35, 0.055555555555556
24457, 0.39130434782609, 1.35, 0.11111111111111
24458, 0.39130434782609, 1.35, 0.16666666666667
24459, 0.39130434782609, 1.35, 0.22222222222222
24460, 0.39130434782609, 1.35, 0.27777777777778
24461, 0.39130434782609, 1.35, 0.33333333333333
24462, 0.39130434782609, 1.35, 0.38888888888889
24463, 0.39130434782609, 1.35, 0.44444444444444
24464, 0.43478260869565, 1.35, 0.055555555555556
24465, 0.43478260869565, 1.35, 0.11111111111111
24466, 0.43478260869565, 1.35, 0.16666666666667
24467, 0.43478260869565, 1.35, 0.22222222222222
24468, 0.43478260869565, 1.35, 0.27777777777778
24469, 0.43478260869565, 1.35, 0.33333333333333
24470, 0.43478260869565, 1.35, 0.38888888888889
24471, 0.43478260869565, 1.35, 0.44444444444444
24472, 0.47826086956522, 1.35, 0.055555555555556
24473, 0.47826086956522, 1.35, 0.11111111111111
24474, 0.47826086956522, 1.35, 0.16666666666667
24475, 0.47826086956522, 1.35, 0.22222222222222
24476, 0.47826086956522, 1.35, 0.27777777777778
24477, 0.47826086956522, 1.35, 0.33333333333333
24478, 0.47826086956522, 1.35, 0.38888888888889
24479, 0.47826086956522, 1.35, 0.44444444444444
24480, 0.52173913043478, 1.35, 0.055555555555556
24481, 0.52173913043478, 1.35, 0.11111111111111
24482, 0.52173913043478, 1.35, 0.16666666666667
24483, 0.52173913043478, 1.35, 0.22222222222222
24484, 0.52173913043478, 1.35, 0.27777777777778
24485, 0.52173913043478, 1.35, 0.33333333333333
24486, 0.52173913043478, 1.35, 0.38888888888889
24487, 0.52173913043478, 1.35, 0.44444444444444
24488, 0.56521739130435, 1.35, 0.055555555555556
24489, 0.56521739130435, 1.35, 0.11111111111111
24490, 0.56521739130435, 1.35, 0.16666666666667
24491, 0.56521739130435, 1.35, 0.22222222222222
24492, 0.56521739130435, 1.35, 0.27777777777778
24493, 0.56521739130435, 1.35, 0.33333333333333
24494, 0.56521739130435, 1.35, 0.38888888888889
24495, 0.56521739130435, 1.35, 0.44444444444444
24496, 0.60869565217391, 1.35, 0.055555555555556
24497, 0.60869565217391, 1.35, 0.11111111111111
24498, 0.60869565217391, 1.35, 0.16666666666667
24499, 0.60869565217391, 1.35, 0.22222222222222
24500, 0.60869565217391, 1.35, 0.27777777777778
24501, 0.60869565217391, 1.35, 0.33333333333333
24502, 0.60869565217391, 1.35, 0.38888888888889
24503, 0.60869565217391, 1.35, 0.44444444444444
24504, 0.65217391304348, 1.35, 0.055555555555556
24505, 0.65217391304348, 1.35, 0.11111111111111
24506, 0.65217391304348, 1.35, 0.16666666666667
24507, 0.65217391304348, 1.35, 0.22222222222222
24508, 0.65217391304348, 1.35, 0.27777777777778
24509, 0.65217391304348, 1.35, 0.33333333333333
24510, 0.65217391304348, 1.35, 0.38888888888889
24511, 0.65217391304348, 1.35, 0.44444444444444
24512, 0.69565217391304, 1.35, 0.055555555555556
24513, 0.69565217391304, 1.35, 0.11111111111111
24514, 0.69565217391304, 1.35, 0.16666666666667
24515, 0.69565217391304, 1.35, 0.22222222222222
24516, 0.69565217391304, 1.35, 0.27777777777778
24517, 0.69565217391304, 1.35, 0.33333333333333
24518, 0.69565217391304, 1.35, 0.38888888888889
24519, 0.69565217391304, 1.35, 0.44444444444444
24520, 0.73913043478261, 1.35, 0.055555555555556
24521, 0.73913043478261, 1.35, 0.11111111111111
24522, 0.73913043478261, 1.35, 0.16666666666667
24523, 0.73913043478261, 1.35, 0.22222222222222
24524, 0.73913043478261, 1.35, 0.27777777777778
24525, 0.73913043478261, 1.35, 0.33333333333333
24526, 0.73913043478261, 1.35, 0.38888888888889
24527, 0.73913043478261, 1.35, 0.44444444444444
24528, 0.78260869565217, 1.35, 0.055555555555556
24529, 0.78260869565217, 1.35, 0.11111111111111
24530, 0.78260869565217, 1.35, 0.16666666666667
24531, 0.78260869565217, 1.35, 0.22222222222222
24532, 0.78260869565217, 1.35, 0.27777777777778
24533, 0.78260869565217, 1.35, 0.33333333333333
24534, 0.78260869565217, 1.35, 0.38888888888889
24535, 0.78260869565217, 1.35, 0.44444444444444
24536, 0.82608695652174, 1.35, 0.055555555555556
24537, 0.82608695652174, 1.35, 0.11111111111111
24538, 0.82608695652174, 1.35, 0.16666666666667
24539, 0.82608695652174, 1.35, 0.22222222222222
24540, 0.82608695652174, 1.35, 0.27777777777778
24541, 0.82608695652174, 1.35, 0.33333333333333
24542, 0.82608695652174, 1.35, 0.38888888888889
24543, 0.82608695652174, 1.35, 0.44444444444444
24544, 0.8695652173913, 1.35, 0.055555555555556
24545, 0.8695652173913, 1.35, 0.11111111111111
24546, 0.8695652173913, 1.35, 0.16666666666667
24547, 0.8695652173913, 1.35, 0.22222222222222
24548, 0.8695652173913, 1.35, 0.27777777777778
24549, 0.8695652173913, 1.35, 0.33333333333333
24550, 0.8695652173913, 1.35, 0.38888888888889
24551, 0.8695652173913, 1.35, 0.44444444444444
24552, 0.91304347826087, 1.35, 0.055555555555556
24553, 0.91304347826087, 1.35, 0.11111111111111
24554, 0.91304347826087, 1.35, 0.16666666666667
24555, 0.91304347826087, 1.35, 0.22222222222222
24556, 0.91304347826087, 1.35, 0.27777777777778
24557, 0.91304347826087, 1.35, 0.33333333333333
24558, 0.91304347826087, 1.35, 0.38888888888889
24559, 0.91304347826087, 1.35, 0.44444444444444
24560, 0.95652173913043, 1.35, 0.055555555555556
24561, 0.95652173913043, 1.35, 0.11111111111111
24562, 0.95652173913043, 1.35, 0.16666666666667
24563, 0.95652173913043, 1.35, 0.22222222222222
24564, 0.95652173913043, 1.35, 0.27777777777778
24565, 0.95652173913043, 1.35, 0.33333333333333
24566, 0.95652173913043, 1.35, 0.38888888888889
24567, 0.95652173913043, 1.35, 0.44444444444444
24568, 0.021739130434783, 1.35, 0.055555555555556
24569, 0.043478260869565, 1.35, 0.027777777777778
24570, 0.021739130434783, 1.35, 0.11111111111111
24571, 0.043478260869565, 1.35, 0.083333333333333
24572, 0.021739130434783, 1.35, 0.16666666666667
24573, 0.043478260869565, 1.35, 0.13888888888889
24574, 0.021739130434783, 1.35, 0.22222222222222
24575, 0.043478260869565, 1.35, 0.19444444444444
24576, 0.021739130434783, 1.35, 0.27777777777778
24577, 0.043478260869565, 1.35, 0.25
24578, 0.021739130434783, 1.35, 0.33333333333333
24579, 0.043478260869565, 1.35, 0.30555555555556
24580, 0.021739130434783, 1.35, 0.38888888888889
24581, 0.043478260869565, 1.35, 0.36111111111111
24582, 0.021739130434783, 1.35, 0.44444444444444
24583, 0.043478260869565, 1.35, 0.41666666666667
24584, 0.043478260869565, 1.35, 0.47222222222222
24585, 0.065217391304348, 1.35, 0.055555555555556
24586, 0.08695652173913, 1.35, 0.027777777777778
24587, 0.065217391304348, 1.35, 0.11111111111111
24588, 0.08695652173913, 1.35, 0.083333333333333
24589, 0.065217391304348, 1.35, 0.16666666666667
24590, 0.08695652173913, 1.35, 0.13888888888889
24591, 0.065217391304348, 1.35, 0.22222222222222
24592, 0.08695652173913, 1.35, 0.19444444444444
24593, 0.065217391304348, 1.35, 0.27777777777778
24594, 0.08695652173913, 1.35, 0.25
24595, 0.065217391304348, 1.35, 0.33333333333333
24596, 0.08695652173913, 1.35, 0.30555555555556
24597, 0.065217391304348, 1.35, 0.38888888888889
24598, 0.08695652173913, 1.35, 0.36111111111111
24599, 0.065217391304348, 1.35, 0.44444444444444
24600, 0.08695652173913, 1.35, 0.41666666666667
24601, 0.08695652173913, 1.35, 0.47222222222222
24602, 0.10869565217391, 1.35, 0.055555555555556
24603, 0.1304347826087, 1.35, 0.027777777777778
24604, 0.10869565217391, 1.35, 0.11111111111111
24605, 0.1304347826087, 1.35, 0.083333333333333
24606, 0.10869565217391, 1.35, 0.16666666666667
24607, 0.1304347826087, 1.35, 0.13888888888889
24608, 0.10869565217391, 1.35, 0.22222222222222
24609, 0.1304347826087, 1.35, 0.19444444444444
24610, 0.10869565217391, 1.35, 0.27777777777778
24611, 0.1304347826087, 1.35, 0.25
24612, 0.10869565217391, 1.35, 0.33333333333333
24613, 0.1304347826087, 1.35, 0.30555555555556
24614, 0.10869565217391, 1.35, 0.38888888888889
24615, 0.1304347826087, 1.35, 0.36111111111111
24616, 0.10869565217391, 1.35, 0.44444444444444
24617, 0.1304347826087, 1.35, 0.41666666666667
24618, 0.1304347826087, 1.35, 0.47222222222222
24619, 0.15217391304348, 1.35, 0.055555555555556
24620, 0.17391304347826, 1.35, 0.027777777777778
24621, 0.15217391304348, 1.35, 0.11111111111111
24622, 0.17391304347826, 1.35, 0.083333333333333
24623, 0.15217391304348, 1.35, 0.16666666666667
24624, 0.17391304347826, 1.35, 0.13888888888889
24625, 0.15217391304348, 1.35, 0.22222222222222
24626, 0.17391304347826, 1.35, 0.19444444444444
24627, 0.15217391304348, 1.35, 0.27777777777778
24628, 0.17391304347826, 1.35, 0.25
24629, 0.15217391304348, 1.35, 0.33333333333333
24630, 0.17391304347826, 1.35, 0.30555555555556
24631, 0.15217391304348, 1.35, 0.38888888888889
24632, 0.17391304347826, 1.35, 0.36111111111111
24633, 0.15217391304348, 1.35, 0.44444444444444
24634, 0.17391304347826, 1.35, 0.41666666666667
24635, 0.17391304347826, 1.35, 0.47222222222222
24636, 0.19565217391304, 1.35, 0.055555555555556
24637, 0.21739130434783, 1.35, 0.027777777777778
24638, 0.19565217391304, 1.35, 0.11111111111111
24639, 0.21739130434783, 1.35, 0.083333333333333
24640, 0.19565217391304, 1.35, 0.16666666666667
24641, 0.21739130434783, 1.35, 0.13888888888889
24642, 0.19565217391304, 1.35, 0.22222222222222
24643, 0.21739130434783, 1.35, 0.19444444444444
24644, 0.19565217391304, 1.35, 0.27777777777778
24645, 0.21739130434783, 1.35, 0.25
24646, 0.19565217391304, 1.35, 0.33333333333333
24647, 0.21739130434783, 1.35, 0.30555555555556
24648, 0.19565217391304, 1.35, 0.38888888888889
24649, 0.21739130434783, 1.35, 0.36111111111111
24650, 0.19565217391304, 1.35, 0.44444444444444
24651, 0.21739130434783, 1.35, 0.41666666666667
24652, 0.21739130434783, 1.35, 0.47222222222222
24653, 0.23913043478261, 1.35, 0.055555555555556
24654, 0.26086956521739, 1.35, 0.027777777777778
24655, 0.23913043478261, 1.35, 0.11111111111111
24656, 0.26086956521739, 1.35, 0.083333333333333
24657, 0.23913043478261, 1.35, 0.16666666666667
24658, 0.26086956521739, 1.35, 0.13888888888889
24659, 0.23913043478261, 1.35, 0.22222222222222
24660, 0.26086956521739, 1.35, 0.19444444444444
24661, 0.23913043478261, 1.35, 0.27777777777778
24662, 0.26086956521739, 1.35, 0.25
24663, 0.23913043478261, 1.35, 0.33333333333333
24664, 0.26086956521739, 1.35, 0.30555555555556
24665, 0.23913043478261, 1.35, 0.38888888888889
24666, 0.26086956521739, 1.35, 0.36111111111111
24667, 0.23913043478261, 1.35, 0.44444444444444
24668, 0.26086956521739, 1.35, 0.41666666666667
24669, 0.26086956521739, 1.35, 0.47222222222222
24670, 0.28260869565217, 1.35, 0.055555555555556
24671, 0.30434782608696, 1.35, 0.027777777777778
24672, 0.28260869565217, 1.35, 0.11111111111111
24673, 0.30434782608696, 1.35, 0.083333333333333
24674, 0.28260869565217, 1.35, 0.16666666666667
24675, 0.30434782608696, 1.35, 0.13888888888889
24676, 0.28260869565217, 1.35, 0.22222222222222
24677, 0.30434782608696, 1.35, 0.19444444444444
24678, 0.28260869565217, 1.35, 0.27777777777778
24679, 0.30434782608696, 1.35, 0.25
24680, 0.28260869565217, 1.35, 0.33333333333333
24681, 0.30434782608696, 1.35, 0.30555555555556
24682, 0.28260869565217, 1.35, 0.38888888888889
24683, 0.30434782608696, 1.35, 0.36111111111111
24684, 0.28260869565217, 1.35, 0.44444444444444
24685, 0.30434782608696, 1.35, 0.41666666666667
24686, 0.30434782608696, 1.35, 0.47222222222222
24687, 0.32608695652174, 1.35, 0.055555555555556
24688, 0.34782608695652, 1.35, 0.027777777777778
24689, 0.32608695652174, 1.35, 0.11111111111111
24690, 0.34782608695652, 1.35, 0.083333333333333
24691, 0.32608695652174, 1.35, 0.16666666666667
24692, 0.34782608695652, 1.35, 0.13888888888889
24693, 0.32608695652174, 1.35, 0.22222222222222
24694, 0.34782608695652, 1.35, 0.19444444444444
24695, 0.32608695652174, 1.35, 0.27777777777778
24696, 0.34782608695652, 1.35, 0.25
24697, 0.32608695652174, 1.35, 0.33333333333333
24698, 0.34782608695652, 1.35, 0.30555555555556
24699, 0.32608695652174, 1.35, 0.38888888888889
24700, 0.34782608695652, 1.35, 0.36111111111111
24701, 0.32608695652174, 1.35, 0.44444444444444
24702, 0.34782608695652, 1.35, 0.41666666666667
24703, 0.34782608695652, 1.35, 0.47222222222222
24704, 0.3695652173913, 1.35, 0.055555555555556
24705, 0.39130434782609, 1.35, 0.027777777777778
24706, 0.3695652173913, 1.35, 0.11111111111111
24707, 0.39130434782609, 1.35, 0.083333333333333
24708, 0.3695652173913, 1.35, 0.16666666666667
24709, 0.39130434782609, 1.35, 0.13888888888889
24710, 0.3695652173913, 1.35, 0.22222222222222
24711, 0.39130434782609, 1.35, 0.19444444444444
24712, 0.3695652173913, 1.35, 0.27777777777778
24713, 0.39130434782609, 1.35, 0.25
24714, 0.3695652173913, 1.35, 0.33333333333333
24715, 0.39130434782609, 1.35, 0.30555555555556
24716, 0.3695652173913, 1.35, 0.38888888888889
24717, 0.39130434782609, 1.35, 0.36111111111111
24718, 0.3695652173913, 1.35, 0.44444444444444
24719, 0.39130434782609, 1.35, 0.41666666666667
24720, 0.39130434782609, 1.35, 0.47222222222222
24721, 0.41304347826087, 1.35, 0.055555555555556
24722, 0.43478260869565, 1.35, 0.027777777777778
24723, 0.41304347826087, 1.35, 0.11111111111111
24724, 0.43478260869565, 1.35, 0.083333333333333
24725, 0.41304347826087, 1.35, 0.16666666666667
24726, 0.43478260869565, 1.35, 0.13888888888889
24727, 0.41304347826087, 1.35, 0.22222222222222
24728, 0.43478260869565, 1.35, 0.19444444444444
24729, 0.41304347826087, 1.35, 0.27777777777778
24730, 0.43478260869565, 1.35, 0.25
24731, 0.41304347826087, 1.35, 0.33333333333333
24732, 0.43478260869565, 1.35, 0.30555555555556
24733, 0.41304347826087, 1.35, 0.38888888888889
24734, 0.43478260869565, 1.35, 0.36111111111111
24735, 0.41304347826087, 1.35, 0.44444444444444
24736, 0.43478260869565, 1.35, 0.41666666666667
24737, 0.43478260869565, 1.35, 0.47222222222222
24738, 0.45652173913043, 1.35, 0.055555555555556
24739, 0.47826086956522, 1.35, 0.027777777777778
24740, 0.45652173913043, 1.35, 0.11111111111111
24741, 0.47826086956522, 1.35, 0.083333333333333
24742, 0.45652173913043, 1.35, 0.16666666666667
24743, 0.47826086956522, 1.35, 0.13888888888889
24744, 0.45652173913043, 1.35, 0.22222222222222
24745, 0.47826086956522, 1.35, 0.19444444444444
24746, 0.45652173913043, 1.35, 0.27777777777778
24747, 0.47826086956522, 1.35, 0.25
24748, 0.45652173913043, 1.35, 0.33333333333333
24749, 0.47826086956522, 1.35, 0.30555555555556
24750, 0.45652173913043, 1.35, 0.38888888888889
24751, 0.47826086956522, 1.35, 0.36111111111111
24752, 0.45652173913043, 1.35, 0.44444444444444
24753, 0.47826086956522, 1.35, 0.41666666666667
24754, 0.47826086956522, 1.35, 0.47222222222222
24755, 0.5, 1.35, 0.055555555555556
24756, 0.52173913043478, 1.35, 0.027777777777778
24757, 0.5, 1.35, 0.11111111111111
24758, 0.52173913043478, 1.35, 0.083333333333333
24759, 0.5, 1.35, 0.16666666666667
24760, 0.52173913043478, 1.35, 0.13888888888889
24761, 0.5, 1.35, 0.22222222222222
24762, 0.52173913043478, 1.35, 0.19444444444444
24763, 0.5, 1.35, 0.27777777777778
24764, 0.52173913043478, 1.35, 0.25
24765, 0.5, 1.35, 0.33333333333333
24766, 0.52173913043478, 1.35, 0.30555555555556
24767, 0.5, 1.35, 0.38888888888889
24768, 0.52173913043478, 1.35, 0.36111111111111
24769, 0.5, 1.35, 0.44444444444444
24770, 0.52173913043478, 1.35, 0.41666666666667
24771, 0.52173913043478, 1.35, 0.47222222222222
24772, 0.54347826086957, 1.35, 0.055555555555556
24773, 0.56521739130435, 1.35, 0.027777777777778
24774, 0.54347826086957, 1.35, 0.11111111111111
24775, 0.56521739130435, 1.35, 0.083333333333333
24776, 0.54347826086957, 1.35, 0.16666666666667
24777, 0.56521739130435, 1.35, 0.13888888888889
24778, 0.54347826086957, 1.35, 0.22222222222222
24779, 0.56521739130435, 1.35, 0.19444444444444
24780, 0.54347826086957, 1.35, 0.27777777777778
24781, 0.56521739130435, 1.35, 0.25
24782, 0.54347826086957, 1.35, 0.33333333333333
24783, 0.56521739130435, 1.35, 0.30555555555556
24784, 0.54347826086957, 1.35, 0.38888888888889
24785, 0.56521739130435, 1.35, 0.36111111111111
24786, 0.54347826086957, 1.35, 0.44444444444444
24787, 0.56521739130435, 1.35, 0.41666666666667
24788, 0.56521739130435, 1.35, 0.47222222222222
24789, 0.58695652173913, 1.35, 0.055555555555556
24790, 0.60869565217391, 1.35, 0.027777777777778
24791, 0.58695652173913, 1.35, 0.11111111111111
24792, 0.60869565217391, 1.35, 0.083333333333333
24793, 0.58695652173913, 1.35, 0.16666666666667
24794, 0.60869565217391, 1.35, 0.13888888888889
24795, 0.58695652173913, 1.35, 0.22222222222222
24796, 0.60869565217391, 1.35, 0.19444444444444
24797, 0.58695652173913, 1.35, 0.27777777777778
24798, 0.60869565217391, 1.35, 0.25
24799, 0.58695652173913, 1.35, 0.33333333333333
24800, 0.60869565217391, 1.35, 0.30555555555556
24801, 0.58695652173913, 1.35, 0.38888888888889
24802, 0.60869565217391, 1.35, 0.36111111111111
24803, 0.58695652173913, 1.35, 0.44444444444444
24804, 0.60869565217391, 1.35, 0.41666666666667
24805, 0.60869565217391, 1.35, 0.47222222222222
24806, 0.6304347826087, 1.35, 0.055555555555556
24807, 0.65217391304348, 1.35, 0.027777777777778
24808, 0.6304347826087, 1.35, 0.11111111111111
24809, 0.65217391304348, 1.35, 0.083333333333333
24810, 0.6304347826087, 1.35, 0.16666666666667
24811, 0.65217391304348, 1.35, 0.13888888888889
24812, 0.6304347826087, 1.35, 0.22222222222222
24813, 0.65217391304348, 1.35, 0.19444444444444
24814, 0.6304347826087, 1.35, 0.27777777777778
24815, 0.65217391304348, 1.35, 0.25
24816, 0.6304347826087, 1.35, 0.33333333333333
24817, 0.65217391304348, 1.35, 0.30555555555556
24818, 0.6304347826087, 1.35, 0.38888888888889
24819, 0.65217391304348, 1.35, 0.36111111111111
24820, 0.6304347826087, 1.35, 0.44444444444444
24821, 0.65217391304348, 1.35, 0.41666666666667
24822, 0.65217391304348, 1.35, 0.47222222222222
24823, 0.67391304347826, 1.35, 0.055555555555556
24824, 0.69565217391304, 1.35, 0.027777777777778
24825, 0.67391304347826, 1.35, 0.11111111111111
24826, 0.69565217391304, 1.35, 0.083333333333333
24827, 0.67391304347826, 1.35, 0.16666666666667
24828, 0.69565217391304, 1.35, 0.13888888888889
24829, 0.67391304347826, 1.35, 0.22222222222222
24830, 0.69565217391304, 1.35, 0.19444444444444
24831, 0.67391304347826, 1.35, 0.27777777777778
24832, 0.69565217391304, 1.35, 0.25
24833, 0.67391304347826, 1.35, 0.33333333333333
24834, 0.69565217391304, 1.35, 0.30555555555556
24835, 0.67391304347826, 1.35, 0.38888888888889
24836, 0.69565217391304, 1.35, 0.36111111111111
24837, 0.67391304347826, 1.35, 0.44444444444444
24838, 0.69565217391304, 1.35, 0.41666666666667
24839, 0.69565217391304, 1.35, 0.47222222222222
24840, 0.71739130434783, 1.35, 0.055555555555556
24841, 0.73913043478261, 1.35, 0.027777777777778
24842, 0.71739130434783, 1.35, 0.11111111111111
24843, 0.73913043478261, 1.35, 0.083333333333333
24844, 0.71739130434783, 1.35, 0.16666666666667
24845, 0.73913043478261, 1.35, 0.13888888888889
24846, 0.71739130434783, 1.35, 0.22222222222222
24847, 0.73913043478261, 1.35, 0.19444444444444
24848, 0.71739130434783, 1.35, 0.27777777777778
24849, 0.73913043478261, 1.35, 0.25
24850, 0.71739130434783, 1.35, 0.33333333333333
24851, 0.73913043478261, 1.35, 0.30555555555556
24852, 0.71739130434783, 1.35, 0.38888888888889
24853, 0.73913043478261, 1.35, 0.36111111111111
24854, 0.71739130434783, 1.35, 0.44444444444444
24855, 0.73913043478261, 1.35, 0.41666666666667
24856, 0.73913043478261, 1.35, 0.47222222222222
24857, 0.76086956521739, 1.35, 0.055555555555556
24858, 0.78260869565217, 1.35, 0.027777777777778
24859, 0.76086956521739, 1.35, 0.11111111111111
24860, 0.78260869565217, 1.35, 0.083333333333333
24861, 0.76086956521739, 1.35, 0.16666666666667
24862, 0.78260869565217, 1.35, 0.13888888888889
24863, 0.76086956521739, 1.35, 0.22222222222222
24864, 0.78260869565217, 1.35, 0.19444444444444
24865, 0.76086956521739, 1.35, 0.27777777777778
24866, 0.78260869565217, 1.35, 0.25
24867, 0.76086956521739, 1.35, 0.33333333333333
24868, 0.78260869565217, 1.35, 0.30555555555556
24869, 0.76086956521739, 1.35, 0.38888888888889
24870, 0.78260869565217, 1.35, 0.36111111111111
24871, 0.76086956521739, 1.35, 0.44444444444444
24872, 0.78260869565217, 1.35, 0.41666666666667
24873, 0.78260869565217, 1.35, 0.47222222222222
24874, 0.80434782608696, 1.35, 0.055555555555556
24875, 0.82608695652174, 1.35, 0.027777777777778
24876, 0.80434782608696, 1.35, 0.11111111111111
24877, 0.82608695652174, 1.35, 0.083333333333333
24878, 0.80434782608696, 1.35, 0.16666666666667
24879, 0.82608695652174, 1.35, 0.13888888888889
24880, 0.80434782608696, 1.35, 0.22222222222222
24881, 0.82608695652174, 1.35, 0.19444444444444
24882, 0.80434782608696, 1.35, 0.27777777777778
24883, 0.82608695652174, 1.35, 0.25
24884, 0.80434782608696, 1.35, 0.33333333333333
24885, 0.82608695652174, 1.35, 0.30555555555556
24886, 0.80434782608696, 1.35, 0.38888888888889
24887, 0.82608695652174, 1.35, 0.36111111111111
24888, 0.80434782608696, 1.35, 0.44444444444444
24889, 0.82608695652174, 1.35, 0.41666666666667
24890, 0.82608695652174, 1.35, 0.47222222222222
24891, 0.84782608695652, 1.35, 0.055555555555556
24892, 0.8695652173913, 1.35, 0.027777777777778
24893, 0.84782608695652, 1.35, 0.11111111111111
24894, 0.8695652173913, 1.35, 0.083333333333333
24895, 0.84782608695652, 1.35, 0.16666666666667
24896, 0.8695652173913, 1.35, 0.13888888888889
24897, 0.84782608695652, 1.35, 0.22222222222222
24898, 0.8695652173913, 1.35, 0.19444444444444
24899, 0.84782608695652, 1.35, 0.27777777777778
24900, 0.8695652173913, 1.35, 0.25
24901, 0.84782608695652, 1.35, 0.33333333333333
24902, 0.8695652173913, 1.35, 0.30555555555556
24903, 0.84782608695652, 1.35, 0.38888888888889
24904, 0.8695652173913, 1.35, 0.36111111111111
24905, 0.84782608695652, 1.35, 0.44444444444444
24906, 0.8695652173913, 1.35, 0.41666666666667
24907, 0.8695652173913, 1.35, 0.47222222222222
24908, 0.89130434782609, 1.35, 0.055555555555556
24909, 0.91304347826087, 1.35, 0.027777777777778
24910, 0.89130434782609, 1.35, 0.11111111111111
24911, 0.91304347826087, 1.35, 0.083333333333333
24912, 0.89130434782609, 1.35, 0.16666666666667
24913, 0.91304347826087, 1.35, 0.13888888888889
24914, 0.89130434782609, 1.35, 0.22222222222222
24915, 0.91304347826087, 1.35, 0.19444444444444
24916, 0.89130434782609, 1.35, 0.27777777777778
24917, 0.91304347826087, 1.35, 0.25
24918, 0.89130434782609, 1.35, 0.33333333333333
24919, 0.91304347826087, 1.35, 0.30555555555556
24920, 0.89130434782609, 1.35, 0.38888888888889
24921, 0.91304347826087, 1.35, 0.36111111111111
24922, 0.89130434782609, 1.35, 0.44444444444444
24923, 0.91304347826087, 1.35, 0.41666666666667
24924, 0.91304347826087, 1.35, 0.47222222222222
24925, 0.93478260869565, 1.35, 0.055555555555556
24926, 0.95652173913043, 1.35, 0.027777777777778
24927, 0.93478260869565, 1.35, 0.11111111111111
24928, 0.95652173913043, 1.35, 0.083333333333333
24929, 0.93478260869565, 1.35, 0.16666666666667
24930, 0.95652173913043, 1.35, 0.13888888888889
24931, 0.93478260869565, 1.35, 0.22222222222222
24932, 0.95652173913043, 1.35, 0.19444444444444
24933, 0.93478260869565, 1.35, 0.27777777777778
24934, 0.95652173913043, 1.35, 0.25
24935, 0.93478260869565, 1.35, 0.33333333333333
24936, 0.95652173913043, 1.35, 0.30555555555556
24937, 0.93478260869565, 1.35, 0.38888888888889
24938, 0.95652173913043, 1.35, 0.36111111111111
24939, 0.93478260869565, 1.35, 0.44444444444444
24940, 0.95652173913043, 1.35, 0.41666666666667
24941, 0.95652173913043, 1.35, 0.47222222222222
24942, 0.97826086956522, 1.35, 0.055555555555556
24943, 0.97826086956522, 1.35, 0.11111111111111
24944, 0.97826086956522, 1.35, 0.16666666666667
24945, 0.97826086956522, 1.35, 0.22222222222222
24946, 0.97826086956522, 1.35, 0.27777777777778
24947, 0.97826086956522, 1.35, 0.33333333333333
24948, 0.97826086956522, 1.35, 0.38888888888889
24949, 0.97826086956522, 1.35, 0.44444444444444
24950, 1.2434782608696, 1.2978260869565, 0.5
24951, 1.2869565217391, 1.2978260869565, 0.5
24952, 1.3304347826087, 1.2978260869565, 0.5
24953, 1.3739130434783, 1.2978260869565, 0.5
24954, 1.4173913043478, 1.2978260869565, 0.5
24955, 1.4608695652174, 1.2978260869565, 0.5
24956, 1.504347826087, 1.2978260869565, 0.5
24957, 1.5478260869565, 1.2978260869565, 0.5
24958, 1.5913043478261, 1.2978260869565, 0.5
24959, 1.6347826086957, 1.2978260869565, 0.5
24960, 1.6782608695652, 1.2978260869565, 0.5
24961, 1.7217391304348, 1.2978260869565, 0.5
24962, 1.7652173913043, 1.2978260869565, 0.5
24963, 1.8086956521739, 1.2978260869565, 0.5
24964, 1.8521739130435, 1.2978260869565, 0.5
24965, 1.895652173913, 1.2978260869565, 0.5
24966, 1.9391304347826, 1.2978260869565, 0.5
24967, 1.9826086956522, 1.2978260869565, 0.5
24968, 2.0260869565217, 1.2978260869565, 0.5
24969, 2.0695652173913, 1.2978260869565, 0.5
24970, 2.1130434782609, 1.2978260869565, 0.5
24971, 2.1565217391304, 1.2978260869565, 0.5
24972, 1.2434782608696, 1.245652173913, 0.5
24973, 1.2869565217391, 1.245652173913, 0.5
24974, 1.3304347826087, 1.245652173913, 0.5
24975, 1.3739130434783, 1.245652173913, 0.5
24976, 1.4173913043478, 1.245652173913, 0.5
24977, 1.4608695652174, 1.245652173913, 0.5
24978, 1.504347826087, 1.245652173913, 0.5
24979, 1.5478260869565, 1.245652173913, 0.5
24980, 1.5913043478261, 1.245652173913, 0.5
24981, 1.6347826086957, 1.245652173913, 0.5
24982, 1.6782608695652, 1.245652173913, 0.5
24983, 1.7217391304348, 1.245652173913, 0.5
24984, 1.7652173913043, 1.245652173913, 0.5
24985, 1.8086956521739, 1.245652173913, 0.5
24986, 1.8521739130435, 1.245652173913, 0.5
24987, 1.895652173913, 1.245652173913, 0.5
24988, 1.9391304347826, 1.245652173913, 0.5
24989, 1.9826086956522, 1.245652173913, 0.5
24990, 2.0260869565217, 1.245652173913, 0.5
24991, 2.0695652173913, 1.245652173913, 0.5
24992, 2.1130434782609, 1.245652173913, 0.5
24993, 2.1565217391304, 1.245652173913, 0.5
24994, 1.2434782608696, 1.1934782608696, 0.5
24995, 1.2869565217391, 1.1934782608696, 0.5
24996, 1.3304347826087, 1.1934782608696, 0.5
24997, 1.3739130434783, 1.1934782608696, 0.5
24998, 1.4173913043478, 1.1934782608696, 0.5
24999, 1.4608695652174, 1.1934782608696, 0.5
25000, 1.504347826087, 1.1934782608696, 0.5
25001, 1.5478260869565, 1.1934782608696, 0.5
25002, 1.5913043478261, 1.1934782608696, 0.5
25003, 1.6347826086957, 1.1934782608696, 0.5
25004, 1.6782608695652, 1.1934782608696, 0.5
25005, 1.7217391304348, 1.1934782608696, 0.5
25006, 1.7652173913043, 1.1934782608696, 0.5
25007, 1.8086956521739, 1.1934782608696, 0.5
25008, 1.8521739130435, 1.1934782608696, 0.5
25009, 1.895652173913, 1.1934782608696, 0.5
25010, 1.9391304347826, 1.1934782608696, 0.5
25011, 1.9826086956522, 1.1934782608696, 0.5
25012, 2.0260869565217, 1.1934782608696, 0.5
25013, 2.0695652173913, 1.1934782608696, 0.5
25014, 2.1130434782609, 1.1934782608696, 0.5
25015, 2.1565217391304, 1.1934782608696, 0.5
25016, 1.2434782608696, 1.1413043478261, 0.5
25017, 1.2869565217391, 1.1413043478261, 0.5
25018, 1.3304347826087, 1.1413043478261, 0.5
25019, 1.3739130434783, 1.1413043478261, 0.5
25020, 1.4173913043478, 1.1413043478261, 0.5
25021, 1.4608695652174, 1.1413043478261, 0.5
25022, 1.504347826087, 1.1413043478261, 0.5
25023, 1.5478260869565, 1.1413043478261, 0.5
25024, 1.5913043478261, 1.1413043478261, 0.5
25025, 1.6347826086957, 1.1413043478261, 0.5
25026, 1.6782608695652, 1.1413043478261, 0.5
25027, 1.7217391304348, 1.1413043478261, 0.5
25028, 1.7652173913043, 1.1413043478261, 0.5
25029, 1.8086956521739, 1.1413043478261, 0.5
25030, 1.8521739130435, 1.1413043478261, 0.5
25031, 1.895652173913, 1.1413043478261, 0.5
25032, 1.9391304347826, 1.1413043478261, 0.5
25033, 1.9826086956522, 1.1413043478261, 0.5
25034, 2.0260869565217, 1.1413043478261, 0.5
25035, 2.0695652173913, 1.1413043478261, 0.5
25036, 2.1130434782609, 1.1413043478261, 0.5
25037, 2.1565217391304, 1.1413043478261, 0.5
25038, 1.2434782608696, 1.0891304347826, 0.5
25039, 1.2869565217391, 1.0891304347826, 0.5
25040, 1.3304347826087, 1.0891304347826, 0.5
25041, 1.3739130434783, 1.0891304347826, 0.5
25042, 1.4173913043478, 1.0891304347826, 0.5
25043, 1.4608695652174, 1.0891304347826, 0.5
25044, 1.504347826087, 1.0891304347826, 0.5
25045, 1.5478260869565, 1.0891304347826, 0.5
25046, 1.5913043478261, 1.0891304347826, 0.5
25047, 1.6347826086957, 1.0891304347826, 0.5
25048, 1.6782608695652, 1.0891304347826, 0.5
25049, 1.7217391304348, 1.0891304347826, 0.5
25050, 1.7652173913043, 1.0891304347826, 0.5
25051, 1.8086956521739, 1.0891304347826, 0.5
25052, 1.8521739130435, 1.0891304347826, 0.5
25053, 1.895652173913, 1.0891304347826, 0.5
25054, 1.9391304347826, 1.0891304347826, 0.5
25055, 1.9826086956522, 1.0891304347826, 0.5
25056, 2.0260869565217, 1.0891304347826, 0.5
25057, 2.0695652173913, 1.0891304347826, 0.5
25058, 2.1130434782609, 1.0891304347826, 0.5
25059, 2.1565217391304, 1.0891304347826, 0.5
25060, 1.2434782608696, 1.0369565217391, 0.5
25061, 1.2869565217391, 1.0369565217391, 0.5
25062, 1.3304347826087, 1.0369565217391, 0.5
25063, 1.3739130434783, 1.0369565217391, 0.5
25064, 1.4173913043478, 1.0369565217391, 0.5
25065, 1.4608695652174, 1.0369565217391, 0.5
25066, 1.504347826087, 1.0369565217391, 0.5
25067, 1.5478260869565, 1.0369565217391, 0.5
25068, 1.5913043478261, 1.0369565217391, 0.5
25069, 1.6347826086957, 1.0369565217391, 0.5
25070, 1.6782608695652, 1.0369565217391, 0.5
25071, 1.7217391304348, 1.0369565217391, 0.5
25072, 1.7652173913043, 1.0369565217391, 0.5
25073, 1.8086956521739, 1.0369565217391, 0.5
25074, 1.8521739130435, 1.0369565217391, 0.5
25075, 1.895652173913, 1.0369565217391, 0.5
25076, 1.9391304347826, 1.0369565217391, 0.5
25077, 1.9826086956522, 1.0369565217391, 0.5
25078, 2.0260869565217, 1.0369565217391, 0.5
25079, 2.0695652173913, 1.0369565217391, 0.5
25080, 2.1130434782609, 1.0369565217391, 0.5
25081, 2.1565217391304, 1.0369565217391, 0.5
25082, 1.2434782608696, 0.98478260869565, 0.5
25083, 1.2869565217391, 0.98478260869565, 0.5
25084, 1.3304347826087, 0.98478260869565, 0.5
25085, 1.3739130434783, 0.98478260869565, 0.5
25086, 1.4173913043478, 0.98478260869565, 0.5
25087, 1.4608695652174, 0.98478260869565, 0.5
25088, 1.504347826087, 0.98478260869565, 0.5
25089, 1.5478260869565, 0.98478260869565, 0.5
25090, 1.5913043478261, 0.98478260869565, 0.5
25091, 1.6347826086957, 0.98478260869565, 0.5
25092, 1.6782608695652, 0.98478260869565, 0.5
25093, 1.7217391304348, 0.98478260869565, 0.5
25094, 1.7652173913043, 0.98478260869565, 0.5
25095, 1.8086956521739, 0.98478260869565, 0.5
25096, 1.8521739130435, 0.98478260869565, 0.5
25097, 1.895652173913, 0.98478260869565, 0.5
25098, 1.9391304347826, 0.98478260869565, 0.5
25099, 1.9826086956522, 0.98478260869565, 0.5
25100, 2.0260869565217, 0.98478260869565, 0.5
25101, 2.0695652173913, 0.98478260869565, 0.5
25102, 2.1130434782609, 0.98478260869565, 0.5
25103, 2.1565217391304, 0.98478260869565, 0.5
25104, 1.2434782608696, 0.93260869565217, 0.5
25105, 1.2869565217391, 0.93260869565217, 0.5
25106, 1.3304347826087, 0.93260869565217, 0.5
25107, 1.3739130434783, 0.93260869565217, 0.5
25108, 1.4173913043478, 0.93260869565217, 0.5
25109, 1.4608695652174, 0.93260869565217, 0.5
25110, 1.504347826087, 0.93260869565217, 0.5
25111, 1.5478260869565, 0.93260869565217, 0.5
25112, 1.5913043478261, 0.93260869565217, 0.5
25113, 1.6347826086957, 0.93260869565217, 0.5
25114, 1.6782608695652, 0.93260869565217, 0.5
25115, 1.7217391304348, 0.93260869565217, 0.5
25116, 1.7652173913043, 0.93260869565217, 0.5
25117, 1.8086956521739, 0.93260869565217, 0.5
25118, 1.8521739130435, 0.93260869565217, 0.5
25119, 1.895652173913, 0.93260869565217, 0.5
25120, 1.9391304347826, 0.93260869565217, 0.5
25121, 1.9826086956522, 0.93260869565217, 0.5
25122, 2.0260869565217, 0.93260869565217, 0.5
25123, 2.0695652173913, 0.93260869565217, 0.5
25124, 2.1130434782609, 0.93260869565217, 0.5
25125, 2.1565217391304, 0.93260869565217, 0.5
25126, 1.2434782608696, 0.8804347826087, 0.5
25127, 1.2869565217391, 0.8804347826087, 0.5
25128, 1.3304347826087, 0.8804347826087, 0.5
25129, 1.3739130434783, 0.8804347826087, 0.5
25130, 1.4173913043478, 0.8804347826087, 0.5
25131, 1.4608695652174, 0.8804347826087, 0.5
25132, 1.504347826087, 0.8804347826087, 0.5
25133, 1.5478260869565, 0.8804347826087, 0.5
25134, 1.5913043478261, 0.8804347826087, 0.5
25135, 1.6347826086957, 0.8804347826087, 0.5
25136, 1.6782608695652, 0.8804347826087, 0.5
25137, 1.7217391304348, 0.8804347826087, 0.5
25138, 1.7652173913043, 0.8804347826087, 0.5
25139, 1.8086956521739, 0.8804347826087, 0.5
25140, 1.8521739130435, 0.8804347826087, 0.5
25141, 1.895652173913, 0.8804347826087, 0.5
25142, 1.9391304347826, 0.8804347826087, 0.5
25143, 1.9826086956522, 0.8804347826087, 0.5
25144, 2.0260869565217, 0.8804347826087, 0.5
25145, 2.0695652173913, 0.8804347826087, 0.5
25146, 2.1130434782609, 0.8804347826087, 0.5
25147, 2.1565217391304, 0.8804347826087, 0.5
25148, 1.2434782608696, 0.82826086956522, 0.5
25149, 1.2869565217391, 0.82826086956522, 0.5
25150, 1.3304347826087, 0.82826086956522, 0.5
25151, 1.3739130434783, 0.82826086956522, 0.5
25152, 1.4173913043478, 0.82826086956522, 0.5
25153, 1.4608695652174, 0.82826086956522, 0.5
25154, 1.504347826087, 0.82826086956522, 0.5
25155, 1.5478260869565, 0.82826086956522, 0.5
25156, 1.5913043478261, 0.82826086956522, 0.5
25157, 1.6347826086957, 0.82826086956522, 0.5
25158, 1.6782608695652, 0.82826086956522, 0.5
25159, 1.7217391304348, 0.82826086956522, 0.5
25160, 1.7652173913043, 0.82826086956522, 0.5
25161, 1.8086956521739, 0.82826086956522, 0.5
25162, 1.8521739130435, 0.82826086956522, 0.5
25163, 1.895652173913, 0.82826086956522, 0.5
25164, 1.9391304347826, 0.82826086956522, 0.5
25165, 1.9826086956522, 0.82826086956522, 0.5
25166, 2.0260869565217, 0.82826086956522, 0.5
25167, 2.0695652173913, 0.82826086956522, 0.5
25168, 2.1130434782609, 0.82826086956522, 0.5
25169, 2.1565217391304, 0.82826086956522, 0.5
25170, 1.2434782608696, 0.77608695652174, 0.5
25171, 1.2869565217391, 0.77608695652174, 0.5
25172, 1.3304347826087, 0.77608695652174, 0.5
25173, 1.3739130434783, 0.77608695652174, 0.5
25174, 1.4173913043478, 0.77608695652174, 0.5
25175, 1.4608695652174, 0.77608695652174, 0.5
25176, 1.504347826087, 0.77608695652174, 0.5
25177, 1.5478260869565, 0.77608695652174, 0.5
25178, 1.5913043478261, 0.77608695652174, 0.5
25179, 1.6347826086957, 0.77608695652174, 0.5
25180, 1.6782608695652, 0.77608695652174, 0.5
25181, 1.7217391304348, 0.77608695652174, 0.5
25182, 1.7652173913043, 0.77608695652174, 0.5
25183, 1.8086956521739, 0.77608695652174, 0.5
25184, 1.8521739130435, 0.77608695652174, 0.5
25185, 1.895652173913, 0.77608695652174, 0.5
25186, 1.9391304347826, 0.77608695652174, 0.5
25187, 1.9826086956522, 0.77608695652174, 0.5
25188, 2.0260869565217, 0.77608695652174, 0.5
25189, 2.0695652173913, 0.77608695652174, 0.5
25190, 2.1130434782609, 0.77608695652174, 0.5
25191, 2.1565217391304, 0.77608695652174, 0.5
25192, 1.2434782608696, 0.72391304347826, 0.5
25193, 1.2869565217391, 0.72391304347826, 0.5
25194, 1.3304347826087, 0.72391304347826, 0.5
25195, 1.3739130434783, 0.72391304347826, 0.5
25196, 1.4173913043478, 0.72391304347826, 0.5
25197, 1.4608695652174, 0.72391304347826, 0.5
25198, 1.504347826087, 0.72391304347826, 0.5
25199, 1.5478260869565, 0.72391304347826, 0.5
25200, 1.5913043478261, 0.72391304347826, 0.5
25201, 1.6347826086957, 0.72391304347826, 0.5
25202, 1.6782608695652, 0.72391304347826, 0.5
25203, 1.7217391304348, 0.72391304347826, 0.5
25204, 1.7652173913043, 0.72391304347826, 0.5
25205, 1.8086956521739, 0.72391304347826, 0.5
25206, 1.8521739130435, 0.72391304347826, 0.5
25207, 1.895652173913, 0.72391304347826, 0.5
25208, 1.9391304347826, 0.72391304347826, 0.5
25209, 1.9826086956522, 0.72391304347826, 0.5
25210, 2.0260869565217, 0.72391304347826, 0.5
25211, 2.0695652173913, 0.72391304347826, 0.5
25212, 2.1130434782609, 0.72391304347826, 0.5
25213, 2.1565217391304, 0.72391304347826, 0.5
25214, 1.2434782608696, 0.67173913043478, 0.5
25215, 1.2869565217391, 0.67173913043478, 0.5
25216, 1.3304347826087, 0.67173913043478, 0.5
25217, 1.3739130434783, 0.67173913043478, 0.5
25218, 1.4173913043478, 0.67173913043478, 0.5
25219, 1.4608695652174, 0.67173913043478, 0.5
25220, 1.504347826087, 0.67173913043478, 0.5
25221, 1.5478260869565, 0.67173913043478, 0.5
25222, 1.5913043478261, 0.67173913043478, 0.5
25223, 1.6347826086957, 0.67173913043478, 0.5
25224, 1.6782608695652, 0.67173913043478, 0.5
25225, 1.7217391304348, 0.67173913043478, 0.5
25226, 1.7652173913043, 0.67173913043478, 0.5
25227, 1.8086956521739, 0.67173913043478, 0.5
25228, 1.8521739130435, 0.67173913043478, 0.5
25229, 1.895652173913, 0.67173913043478, 0.5
25230, 1.9391304347826, 0.67173913043478, 0.5
25231, 1.9826086956522, 0.67173913043478, 0.5
25232, 2.0260869565217, 0.67173913043478, 0.5
25233, 2.0695652173913, 0.67173913043478, 0.5
25234, 2.1130434782609, 0.67173913043478, 0.5
25235, 2.1565217391304, 0.67173913043478, 0.5
25236, 1.2434782608696, 0.61956521739131, 0.5
25237, 1.2869565217391, 0.61956521739131, 0.5
25238, 1.3304347826087, 0.61956521739131, 0.5
25239, 1.3739130434783, 0.61956521739131, 0.5
25240, 1.4173913043478, 0.61956521739131, 0.5
25241, 1.4608695652174, 0.61956521739131, 0.5
25242, 1.504347826087, 0.6195652173913, 0.5
25243, 1.5478260869565, 0.61956521739131, 0.5
25244, 1.5913043478261, 0.61956521739131, 0.5
25245, 1.6347826086957, 0.61956521739131, 0.5
25246, 1.6782608695652, 0.61956521739131, 0.5
25247, 1.7217391304348, 0.61956521739131, 0.5
25248, 1.7652173913043, 0.61956521739131, 0.5
25249, 1.8086956521739, 0.61956521739131, 0.5
25250, 1.8521739130435, 0.61956521739131, 0.5
25251, 1.895652173913, 0.61956521739131, 0.5
25252, 1.9391304347826, 0.61956521739131, 0.5
25253, 1.9826086956522, 0.61956521739131, 0.5
25254, 2.0260869565217, 0.61956521739131, 0.5
25255, 2.0695652173913, 0.61956521739131, 0.5
25256, 2.1130434782609, 0.61956521739131, 0.5
25257, 2.1565217391304, 0.61956521739131, 0.5
25258, 1.2434782608696, 0.56739130434783, 0.5
25259, 1.2869565217391, 0.56739130434783, 0.5
25260, 1.3304347826087, 0.56739130434783, 0.5
25261, 1.3739130434783, 0.56739130434783, 0.5
25262, 1.4173913043478, 0.56739130434783, 0.5
25263, 1.4608695652174, 0.56739130434783, 0.5
25264, 1.504347826087, 0.56739130434783, 0.5
25265, 1.5478260869565, 0.56739130434783, 0.5
25266, 1.5913043478261, 0.56739130434783, 0.5
25267, 1.6347826086957, 0.56739130434783, 0.5
25268, 1.6782608695652, 0.56739130434783, 0.5
25269, 1.7217391304348, 0.56739130434783, 0.5
25270, 1.7652173913043, 0.56739130434783, 0.5
25271, 1.8086956521739, 0.56739130434783, 0.5
25272, 1.8521739130435, 0.56739130434783, 0.5
25273, 1.895652173913, 0.56739130434783, 0.5
25274, 1.9391304347826, 0.56739130434783, 0.5
25275, 1.9826086956522, 0.56739130434783, 0.5
25276, 2.0260869565217, 0.56739130434783, 0.5
25277, 2.0695652173913, 0.56739130434783, 0.5
25278, 2.1130434782609, 0.56739130434783, 0.5
25279, 2.1565217391304, 0.56739130434783, 0.5
25280, 1.2434782608696, 0.51521739130435, 0.5
25281, 1.2869565217391, 0.51521739130435, 0.5
25282, 1.3304347826087, 0.51521739130435, 0.5
25283, 1.3739130434783, 0.51521739130435, 0.5
25284, 1.4173913043478, 0.51521739130435, 0.5
25285, 1.4608695652174, 0.51521739130435, 0.5
25286, 1.504347826087, 0.51521739130435, 0.5
25287, 1.5478260869565, 0.51521739130435, 0.5
25288, 1.5913043478261, 0.51521739130435, 0.5
25289, 1.6347826086957, 0.51521739130435, 0.5
25290, 1.6782608695652, 0.51521739130435, 0.5
25291, 1.7217391304348, 0.51521739130435, 0.5
25292, 1.7652173913043, 0.51521739130435, 0.5
25293, 1.8086956521739, 0.51521739130435, 0.5
25294, 1.8521739130435, 0.51521739130435, 0.5
25295, 1.895652173913, 0.51521739130435, 0.5
25296, 1.9391304347826, 0.51521739130435, 0.5
25297, 1.9826086956522, 0.51521739130435, 0.5
25298, 2.0260869565217, 0.51521739130435, 0.5
25299, 2.0695652173913, 0.51521739130435, 0.5
25300, 2.1130434782609, 0.51521739130435, 0.5
25301, 2.1565217391304, 0.51521739130435, 0.5
25302, 1.2434782608696, 0.46304347826087, 0.5
25303, 1.2869565217391, 0.46304347826087, 0.5
25304, 1.3304347826087, 0.46304347826087, 0.5
25305, 1.3739130434783, 0.46304347826087, 0.5
25306, 1.4173913043478, 0.46304347826087, 0.5
25307, 1.4608695652174, 0.46304347826087, 0.5
25308, 1.504347826087, 0.46304347826087, 0.5
25309, 1.5478260869565, 0.46304347826087, 0.5
25310, 1.5913043478261, 0.46304347826087, 0.5
25311, 1.6347826086957, 0.46304347826087, 0.5
25312, 1.6782608695652, 0.46304347826087, 0.5
25313, 1.7217391304348, 0.46304347826087, 0.5
25314, 1.7652173913043, 0.46304347826087, 0.5
25315, 1.8086956521739, 0.46304347826087, 0.5
25316, 1.8521739130435, 0.46304347826087, 0.5
25317, 1.895652173913, 0.46304347826087, 0.5
25318, 1.9391304347826, 0.46304347826087, 0.5
25319, 1.9826086956522, 0.46304347826087, 0.5
25320, 2.0260869565217, 0.46304347826087, 0.5
25321, 2.0695652173913, 0.46304347826087, 0.5
25322, 2.1130434782609, 0.46304347826087, 0.5
25323, 2.1565217391304, 0.46304347826087, 0.5
25324, 1.2434782608696, 0.41086956521739, 0.5
25325, 1.2869565217391, 0.41086956521739, 0.5
25326, 1.3304347826087, 0.41086956521739, 0.5
25327, 1.3739130434783, 0.41086956521739, 0.5
25328, 1.4173913043478, 0.41086956521739, 0.5
25329, 1.4608695652174, 0.41086956521739, 0.5
25330, 1.504347826087, 0.41086956521739, 0.5
25331, 1.5478260869565, 0.41086956521739, 0.5
25332, 1.5913043478261, 0.41086956521739, 0.5
25333, 1.6347826086957, 0.41086956521739, 0.5
25334, 1.6782608695652, 0.41086956521739, 0.5
25335, 1.7217391304348, 0.41086956521739, 0.5
25336, 1.7652173913043, 0.41086956521739, 0.5
25337, 1.8086956521739, 0.41086956521739, 0.5
25338, 1.8521739130435, 0.41086956521739, 0.5
25339, 1.895652173913, 0.41086956521739, 0.5
25340, 1.9391304347826, 0.41086956521739, 0.5
25341, 1.9826086956522, 0.41086956521739, 0.5
25342, 2.0260869565217, 0.41086956521739, 0.5
25343, 2.0695652173913, 0.41086956521739, 0.5
25344, 2.1130434782609, 0.41086956521739, 0.5
25345, 2.1565217391304, 0.41086956521739, 0.5
25346, 1.2434782608696, 0.35869565217391, 0.5
25347, 1.2869565217391, 0.35869565217391, 0.5
25348, 1.3304347826087, 0.35869565217391, 0.5
25349, 1.3739130434783, 0.35869565217391, 0.5
25350, 1.4173913043478, 0.35869565217391, 0.5
25351, 1.4608695652174, 0.35869565217391, 0.5
25352, 1.504347826087, 0.35869565217391, 0.5
25353, 1.5478260869565, 0.35869565217391, 0.5
25354, 1.5913043478261, 0.35869565217391, 0.5
25355, 1.6347826086957, 0.35869565217391, 0.5
25356, 1.6782608695652, 0.35869565217391, 0.5
25357, 1.7217391304348, 0.35869565217391, 0.5
25358, 1.7652173913043, 0.35869565217391, 0.5
25359, 1.8086956521739, 0.35869565217391, 0.5
25360, 1.8521739130435, 0.35869565217391, 0.5
25361, 1.895652173913, 0.35869565217391, 0.5
25362, 1.9391304347826, 0.35869565217391, 0.5
25363, 1.9826086956522, 0.35869565217391, 0.5
25364, 2.0260869565217, 0.35869565217391, 0.5
25365, 2.0695652173913, 0.35869565217391, 0.5
25366, 2.1130434782609, 0.35869565217391, 0.5
25367, 2.1565217391304, 0.35869565217391, 0.5
25368, 1.2434782608696, 0.30652173913044, 0.5
25369, 1.2869565217391, 0.30652173913043, 0.5
25370, 1.3304347826087, 0.30652173913043, 0.5
25371, 1.3739130434783, 0.30652173913044, 0.5
25372, 1.4173913043478, 0.30652173913044, 0.5
25373, 1.4608695652174, 0.30652173913043, 0.5
25374, 1.504347826087, 0.30652173913044, 0.5
25375, 1.5478260869565, 0.30652173913044, 0.5
25376, 1.5913043478261, 0.30652173913044, 0.5
25377, 1.6347826086957, 0.30652173913043, 0.5
25378, 1.6782608695652, 0.30652173913043, 0.5
25379, 1.7217391304348, 0.30652173913043, 0.5
25380, 1.7652173913043, 0.30652173913043, 0.5
25381, 1.8086956521739, 0.30652173913044, 0.5
25382, 1.8521739130435, 0.30652173913043, 0.5
25383, 1.895652173913, 0.30652173913044, 0.5
25384, 1.9391304347826, 0.30652173913043, 0.5
25385, 1.9826086956522, 0.30652173913044, 0.5
25386, 2.0260869565217, 0.30652173913044, 0.5
25387, 2.0695652173913, 0.30652173913043, 0.5
25388, 2.1130434782609, 0.30652173913043, 0.5
25389, 2.1565217391304, 0.30652173913043, 0.5
25390, 1.2434782608696, 0.25434782608696, 0.5
25391, 1.2869565217391, 0.25434782608696, 0.5
25392, 1.3304347826087, 0.25434782608696, 0.5
25393, 1.3739130434783, 0.25434782608696, 0.5
25394, 1.4173913043478, 0.25434782608696, 0.5
25395, 1.4608695652174, 0.25434782608696, 0.5
25396, 1.504347826087, 0.25434782608696, 0.5
25397, 1.5478260869565, 0.25434782608696, 0.5
25398, 1.5913043478261, 0.25434782608696, 0.5
25399, 1.6347826086957, 0.25434782608696, 0.5
25400, 1.6782608695652, 0.25434782608696, 0.5
25401, 1.7217391304348, 0.25434782608696, 0.5
25402, 1.7652173913043, 0.25434782608696, 0.5
25403, 1.8086956521739, 0.25434782608696, 0.5
25404, 1.8521739130435, 0.25434782608696, 0.5
25405, 1.895652173913, 0.25434782608696, 0.5
25406, 1.9391304347826, 0.25434782608696, 0.5
25407, 1.9826086956522, 0.25434782608696, 0.5
25408, 2.0260869565217, 0.25434782608696, 0.5
25409, 2.0695652173913, 0.25434782608696, 0.5
25410, 2.1130434782609, 0.25434782608696, 0.5
25411, 2.1565217391304, 0.25434782608696, 0.5
25412, 1.2434782608696, 0.20217391304348, 0.5
25413, 1.2869565217391, 0.20217391304348, 0.5
25414, 1.3304347826087, 0.20217391304348, 0.5
25415, 1.3739130434783, 0.20217391304348, 0.5
25416, 1.4173913043478, 0.20217391304348, 0.5
25417, 1.4608695652174, 0.20217391304348, 0.5
25418, 1.504347826087, 0.20217391304348, 0.5
25419, 1.5478260869565, 0.20217391304348, 0.5
25420, 1.5913043478261, 0.20217391304348, 0.5
25421, 1.6347826086957, 0.20217391304348, 0.5
25422, 1.6782608695652, 0.20217391304348, 0.5
25423, 1.7217391304348, 0.20217391304348, 0.5
25424, 1.7652173913043, 0.20217391304348, 0.5
25425, 1.8086956521739, 0.20217391304348, 0.5
25426, 1.8521739130435, 0.20217391304348, 0.5
25427, 1.895652173913, 0.20217391304348, 0.5
25428, 1.9391304347826, 0.20217391304348, 0.5
25429, 1.9826086956522, 0.20217391304348, 0.5
25430, 2.0260869565217, 0.20217391304348, 0.5
25431, 2.0695652173913, 0.20217391304348, 0.5
25432, 2.1130434782609, 0.20217391304348, 0.5
25433, 2.1565217391304, 0.20217391304348, 0.5
25434, 1.2217391304348, 1.2978260869565, 0.5
25435, 1.2434782608696, 1.3239130434783, 0.5
25436, 1.2652173913043, 1.2978260869565, 0.5
25437, 1.2869565217391, 1.3239130434783, 0.5
25438, 1.3086956521739, 1.2978260869565, 0.5
25439, 1.3304347826087, 1.3239130434783, 0.5
25440, 1.3521739130435, 1.2978260869565, 0.5
25441, 1.3739130434783, 1.3239130434783, 0.5
25442, 1.395652173913, 1.2978260869565, 0.5
25443, 1.4173913043478, 1.3239130434783, 0.5
25444, 1.4391304347826, 1.2978260869565, 0.5
25445, 1.4608695652174, 1.3239130434783, 0.5
25446, 1.4826086956522, 1.2978260869565, 0.5
25447, 1.504347826087, 1.3239130434783, 0.5
25448, 1.5260869565217, 1.2978260869565, 0.5
25449, 1.5478260869565, 1.3239130434783, 0.5
25450, 1.5695652173913, 1.2978260869565, 0.5
25451, 1.5913043478261, 1.3239130434783, 0.5
25452, 1.6130434782609, 1.2978260869565, 0.5
25453, 1.6347826086957, 1.3239130434783, 0.5
25454, 1.6565217391304, 1.2978260869565, 0.5
25455, 1.6782608695652, 1.3239130434783, 0.5
25456, 1.7, 1.2978260869565, 0.5
25457, 1.7217391304348, 1.3239130434783, 0.5
25458, 1.7434782608696, 1.2978260869565, 0.5
25459, 1.7652173913043, 1.3239130434783, 0.5
25460, 1.7869565217391, 1.2978260869565, 0.5
25461, 1.8086956521739, 1.3239130434783, 0.5
25462, 1.8304347826087, 1.2978260869565, 0.5
25463, 1.8521739130435, 1.3239130434783, 0.5
25464, 1.8739130434783, 1.2978260869565, 0.5
25465, 1.895652173913, 1.3239130434783, 0.5
25466, 1.9173913043478, 1.2978260869565, 0.5
25467, 1.9391304347826, 1.3239130434783, 0.5
25468, 1.9608695652174, 1.2978260869565, 0.5
25469, 1.9826086956522, 1.3239130434783, 0.5
25470, 2.004347826087, 1.2978260869565, 0.5
25471, 2.0260869565217, 1.3239130434783, 0.5
25472, 2.0478260869565, 1.2978260869565, 0.5
25473, 2.0695652173913, 1.3239130434783, 0.5
25474, 2.0913043478261, 1.2978260869565, 0.5
25475, 2.1130434782609, 1.3239130434783, 0.5
25476, 2.1347826086957, 1.2978260869565, 0.5
25477, 2.1565217391304, 1.3239130434783, 0.5
25478, 2.1782608695652, 1.2978260869565, 0.5
25479, 1.2217391304348, 1.245652173913, 0.5
25480, 1.2434782608696, 1.2717391304348, 0.5
25481, 1.2652173913043, 1.245652173913, 0.5
25482, 1.2869565217391, 1.2717391304348, 0.5
25483, 1.3086956521739, 1.245652173913, 0.5
25484, 1.3304347826087, 1.2717391304348, 0.5
25485, 1.3521739130435, 1.245652173913, 0.5
25486, 1.3739130434783, 1.2717391304348, 0.5
25487, 1.395652173913, 1.245652173913, 0.5
25488, 1.4173913043478, 1.2717391304348, 0.5
25489, 1.4391304347826, 1.245652173913, 0.5
25490, 1.4608695652174, 1.2717391304348, 0.5
25491, 1.4826086956522, 1.245652173913, 0.5
25492, 1.504347826087, 1.2717391304348, 0.5
25493, 1.5260869565217, 1.245652173913, 0.5
25494, 1.5478260869565, 1.2717391304348, 0.5
25495, 1.5695652173913, 1.245652173913, 0.5
25496, 1.5913043478261, 1.2717391304348, 0.5
25497, 1.6130434782609, 1.245652173913, 0.5
25498, 1.6347826086957, 1.2717391304348, 0.5
25499, 1.6565217391304, 1.245652173913, 0.5
25500, 1.6782608695652, 1.2717391304348, 0.5
25501, 1.7, 1.245652173913, 0.5
25502, 1.7217391304348, 1.2717391304348, 0.5
25503, 1.7434782608696, 1.245652173913, 0.5
25504, 1.7652173913043, 1.2717391304348, 0.5
25505, 1.7869565217391, 1.245652173913, 0.5
25506, 1.8086956521739, 1.2717391304348, 0.5
25507, 1.8304347826087, 1.245652173913, 0.5
25508, 1.8521739130435, 1.2717391304348, 0.5
25509, 1.8739130434783, 1.245652173913, 0.5
25510, 1.895652173913, 1.2717391304348, 0.5
25511, 1.9173913043478, 1.245652173913, 0.5
25512, 1.9391304347826, 1.2717391304348, 0.5
25513, 1.9608695652174, 1.245652173913, 0.5
25514, 1.9826086956522, 1.2717391304348, 0.5
25515, 2.004347826087, 1.245652173913, 0.5
25516, 2.0260869565217, 1.2717391304348, 0.5
25517, 2.0478260869565, 1.245652173913, 0.5
25518, 2.0695652173913, 1.2717391304348, 0.5
25519, 2.0913043478261, 1.245652173913, 0.5
25520, 2.1130434782609, 1.2717391304348, 0.5
25521, 2.1347826086957, 1.245652173913, 0.5
25522, 2.1565217391304, 1.2717391304348, 0.5
25523, 2.1782608695652, 1.245652173913, 0.5
25524, 1.2217391304348, 1.1934782608696, 0.5
25525, 1.2434782608696, 1.2195652173913, 0.5
25526, 1.2652173913043, 1.1934782608696, 0.5
25527, 1.2869565217391, 1.2195652173913, 0.5
25528, 1.3086956521739, 1.1934782608696, 0.5
25529, 1.3304347826087, 1.2195652173913, 0.5
25530, 1.3521739130435, 1.1934782608696, 0.5
25531, 1.3739130434783, 1.2195652173913, 0.5
25532, 1.395652173913, 1.1934782608696, 0.5
25533, 1.4173913043478, 1.2195652173913, 0.5
25534, 1.4391304347826, 1.1934782608696, 0.5
25535, 1.4608695652174, 1.2195652173913, 0.5
25536, 1.4826086956522, 1.1934782608696, 0.5
25537, 1.504347826087, 1.2195652173913, 0.5
25538, 1.5260869565217, 1.1934782608696, 0.5
25539, 1.5478260869565, 1.2195652173913, 0.5
25540, 1.5695652173913, 1.1934782608696, 0.5
25541, 1.5913043478261, 1.2195652173913, 0.5
25542, 1.6130434782609, 1.1934782608696, 0.5
25543, 1.6347826086957, 1.2195652173913, 0.5
25544, 1.6565217391304, 1.1934782608696, 0.5
25545, 1.6782608695652, 1.2195652173913, 0.5
25546, 1.7, 1.1934782608696, 0.5
25547, 1.7217391304348, 1.2195652173913, 0.5
25548, 1.7434782608696, 1.1934782608696, 0.5
25549, 1.7652173913043, 1.2195652173913, 0.5
25550, 1.7869565217391, 1.1934782608696, 0.5
25551, 1.8086956521739, 1.2195652173913, 0.5
25552, 1.8304347826087, 1.1934782608696, 0.5
25553, 1.8521739130435, 1.2195652173913, 0.5
25554, 1.8739130434783, 1.1934782608696, 0.5
25555, 1.895652173913, 1.2195652173913, 0.5
25556, 1.9173913043478, 1.1934782608696, 0.5
25557, 1.9391304347826, 1.2195652173913, 0.5
25558, 1.9608695652174, 1.1934782608696, 0.5
25559, 1.9826086956522, 1.2195652173913, 0.5
25560, 2.004347826087, 1.1934782608696, 0.5
25561, 2.0260869565217, 1.2195652173913, 0.5
25562, 2.0478260869565, 1.1934782608696, 0.5
25563, 2.0695652173913, 1.2195652173913, 0.5
25564, 2.0913043478261, 1.1934782608696, 0.5
25565, 2.1130434782609, 1.2195652173913, 0.5
25566, 2.1347826086957, 1.1934782608696, 0.5
25567, 2.1565217391304, 1.2195652173913, 0.5
25568, 2.1782608695652, 1.1934782608696, 0.5
25569, 1.2217391304348, 1.1413043478261, 0.5
25570, 1.2434782608696, 1.1673913043478, 0.5
25571, 1.2652173913043, 1.1413043478261, 0.5
25572, 1.2869565217391, 1.1673913043478, 0.5
25573, 1.3086956521739, 1.1413043478261, 0.5
25574, 1.3304347826087, 1.1673913043478, 0.5
25575, 1.3521739130435, 1.1413043478261, 0.5
25576, 1.3739130434783, 1.1673913043478, 0.5
25577, 1.395652173913, 1.1413043478261, 0.5
25578, 1.4173913043478, 1.1673913043478, 0.5
25579, 1.4391304347826, 1.1413043478261, 0.5
25580, 1.4608695652174, 1.1673913043478, 0.5
25581, 1.4826086956522, 1.1413043478261, 0.5
25582, 1.504347826087, 1.1673913043478, 0.5
25583, 1.5260869565217, 1.1413043478261, 0.5
25584, 1.5478260869565, 1.1673913043478, 0.5
25585, 1.5695652173913, 1.1413043478261, 0.5
25586, 1.5913043478261, 1.1673913043478, 0.5
25587, 1.6130434782609, 1.1413043478261, 0.5
25588, 1.6347826086957, 1.1673913043478, 0.5
25589, 1.6565217391304, 1.1413043478261, 0.5
25590, 1.6782608695652, 1.1673913043478, 0.5
25591, 1.7, 1.1413043478261, 0.5
25592, 1.7217391304348, 1.1673913043478, 0.5
25593, 1.7434782608696, 1.1413043478261, 0.5
25594, 1.7652173913043, 1.1673913043478, 0.5
25595, 1.7869565217391, 1.1413043478261, 0.5
25596, 1.8086956521739, 1.1673913043478, 0.5
25597, 1.8304347826087, 1.1413043478261, 0.5
25598, 1.8521739130435, 1.1673913043478, 0.5
25599, 1.8739130434783, 1.1413043478261, 0.5
25600, 1.895652173913, 1.1673913043478, 0.5
25601, 1.9173913043478, 1.1413043478261, 0.5
25602, 1.9391304347826, 1.1673913043478, 0.5
25603, 1.9608695652174, 1.1413043478261, 0.5
25604, 1.9826086956522, 1.1673913043478, 0.5
25605, 2.004347826087, 1.1413043478261, 0.5
25606, 2.0260869565217, 1.1673913043478, 0.5
25607, 2.0478260869565, 1.1413043478261, 0.5
25608, 2.0695652173913, 1.1673913043478, 0.5
25609, 2.0913043478261, 1.1413043478261, 0.5
25610, 2.1130434782609, 1.1673913043478, 0.5
25611, 2.1347826086957, 1.1413043478261, 0.5
25612, 2.1565217391304, 1.1673913043478, 0.5
25613, 2.1782608695652, 1.1413043478261, 0.5
25614, 1.2217391304348, 1.0891304347826, 0.5
25615, 1.2434782608696, 1.1152173913043, 0.5
25616, 1.2652173913043, 1.0891304347826, 0.5
25617, 1.2869565217391, 1.1152173913043, 0.5
25618, 1.3086956521739, 1.0891304347826, 0.5
25619, 1.3304347826087, 1.1152173913043, 0.5
25620, 1.3521739130435, 1.0891304347826, 0.5
25621, 1.3739130434783, 1.1152173913043, 0.5
25622, 1.395652173913, 1.0891304347826, 0.5
25623, 1.4173913043478, 1.1152173913043, 0.5
25624, 1.4391304347826, 1.0891304347826, 0.5
25625, 1.4608695652174, 1.1152173913043, 0.5
25626, 1.4826086956522, 1.0891304347826, 0.5
25627, 1.504347826087, 1.1152173913043, 0.5
25628, 1.5260869565217, 1.0891304347826, 0.5
25629, 1.5478260869565, 1.1152173913043, 0.5
25630, 1.5695652173913, 1.0891304347826, 0.5
25631, 1.5913043478261, 1.1152173913043, 0.5
25632, 1.6130434782609, 1.0891304347826, 0.5
25633, 1.6347826086957, 1.1152173913043, 0.5
25634, 1.6565217391304, 1.0891304347826, 0.5
25635, 1.6782608695652, 1.1152173913043, 0.5
25636, 1.7, 1.0891304347826, 0.5
25637, 1.7217391304348, 1.1152173913043, 0.5
25638, 1.7434782608696, 1.0891304347826, 0.5
25639, 1.7652173913043, 1.1152173913043, 0.5
25640, 1.7869565217391, 1.0891304347826, 0.5
25641, 1.8086956521739, 1.1152173913043, 0.5
25642, 1.8304347826087, 1.0891304347826, 0.5
25643, 1.8521739130435, 1.1152173913043, 0.5
25644, 1.8739130434783, 1.0891304347826, 0.5
25645, 1.895652173913, 1.1152173913043, 0.5
25646, 1.9173913043478, 1.0891304347826, 0.5
25647, 1.9391304347826, 1.1152173913043, 0.5
25648, 1.9608695652174, 1.0891304347826, 0.5
25649, 1.9826086956522, 1.1152173913043, 0.5
25650, 2.004347826087, 1.0891304347826, 0.5
25651, 2.0260869565217, 1.1152173913043, 0.5
25652, 2.0478260869565, 1.0891304347826, 0.5
25653, 2.0695652173913, 1.1152173913043, 0.5
25654, 2.0913043478261, 1.0891304347826, 0.5
25655, 2.1130434782609, 1.1152173913043, 0.5
25656, 2.1347826086957, 1.0891304347826, 0.5
25657, 2.1565217391304, 1.1152173913043, 0.5
25658, 2.1782608695652, 1.0891304347826, 0.5
25659, 1.2217391304348, 1.0369565217391, 0.5
25660, 1.2434782608696, 1.0630434782609, 0.5
25661, 1.2652173913043, 1.0369565217391, 0.5
25662, 1.2869565217391, 1.0630434782609, 0.5
25663, 1.3086956521739, 1.0369565217391, 0.5
25664, 1.3304347826087, 1.0630434782609, 0.5
25665, 1.3521739130435, 1.0369565217391, 0.5
25666, 1.3739130434783, 1.0630434782609, 0.5
25667, 1.395652173913, 1.0369565217391, 0.5
25668, 1.4173913043478, 1.0630434782609, 0.5
25669, 1.4391304347826, 1.0369565217391, 0.5
25670, 1.4608695652174, 1.0630434782609, 0.5
25671, 1.4826086956522, 1.0369565217391, 0.5
25672, 1.504347826087, 1.0630434782609, 0.5
25673, 1.5260869565217, 1.0369565217391, 0.5
25674, 1.5478260869565, 1.0630434782609, 0.5
25675, 1.5695652173913, 1.0369565217391, 0.5
25676, 1.5913043478261, 1.0630434782609, 0.5
25677, 1.6130434782609, 1.0369565217391, 0.5
25678, 1.6347826086957, 1.0630434782609, 0.5
25679, 1.6565217391304, 1.0369565217391, 0.5
25680, 1.6782608695652, 1.0630434782609, 0.5
25681, 1.7, 1.0369565217391, 0.5
25682, 1.7217391304348, 1.0630434782609, 0.5
25683, 1.7434782608696, 1.0369565217391, 0.5
25684, 1.7652173913043, 1.0630434782609, 0.5
25685, 1.7869565217391, 1.0369565217391, 0.5
25686, 1.8086956521739, 1.0630434782609, 0.5
25687, 1.8304347826087, 1.0369565217391, 0.5
25688, 1.8521739130435, 1.0630434782609, 0.5
25689, 1.8739130434783, 1.0369565217391, 0.5
25690, 1.895652173913, 1.0630434782609, 0.5
25691, 1.9173913043478, 1.0369565217391, 0.5
25692, 1.9391304347826, 1.0630434782609, 0.5
25693, 1.9608695652174, 1.0369565217391, 0.5
25694, 1.9826086956522, 1.0630434782609, 0.5
25695, 2.004347826087, 1.0369565217391, 0.5
25696, 2.0260869565217, 1.0630434782609, 0.5
25697, 2.0478260869565, 1.0369565217391, 0.5
25698, 2.0695652173913, 1.0630434782609, 0.5
25699, 2.0913043478261, 1.0369565217391, 0.5
25700, 2.1130434782609, 1.0630434782609, 0.5
25701, 2.1347826086957, 1.0369565217391, 0.5
25702, 2.1565217391304, 1.0630434782609, 0.5
25703, 2.1782608695652, 1.0369565217391, 0.5
25704, 1.2217391304348, 0.98478260869565, 0.5
25705, 1.2434782608696, 1.0108695652174, 0.5
25706, 1.2652173913043, 0.98478260869565, 0.5
25707, 1.2869565217391, 1.0108695652174, 0.5
25708, 1.3086956521739, 0.98478260869565, 0.5
25709, 1.3304347826087, 1.0108695652174, 0.5
25710, 1.3521739130435, 0.98478260869565, 0.5
25711, 1.3739130434783, 1.0108695652174, 0.5
25712, 1.395652173913, 0.98478260869565, 0.5
25713, 1.4173913043478, 1.0108695652174, 0.5
25714, 1.4391304347826, 0.98478260869565, 0.5
25715, 1.4608695652174, 1.0108695652174, 0.5
25716, 1.4826086956522, 0.98478260869565, 0.5
25717, 1.504347826087, 1.0108695652174, 0.5
25718, 1.5260869565217, 0.98478260869565, 0.5
25719, 1.5478260869565, 1.0108695652174, 0.5
25720, 1.5695652173913, 0.98478260869565, 0.5
25721, 1.5913043478261, 1.0108695652174, 0.5
25722, 1.6130434782609, 0.98478260869565, 0.5
25723, 1.6347826086957, 1.0108695652174, 0.5
25724, 1.6565217391304, 0.98478260869565, 0.5
25725, 1.6782608695652, 1.0108695652174, 0.5
25726, 1.7, 0.98478260869565, 0.5
25727, 1.7217391304348, 1.0108695652174, 0.5
25728, 1.7434782608696, 0.98478260869565, 0.5
25729, 1.7652173913043, 1.0108695652174, 0.5
25730, 1.7869565217391, 0.98478260869565, 0.5
25731, 1.8086956521739, 1.0108695652174, 0.5
25732, 1.8304347826087, 0.98478260869565, 0.5
25733, 1.8521739130435, 1.0108695652174, 0.5
25734, 1.8739130434783, 0.98478260869565, 0.5
25735, 1.895652173913, 1.0108695652174, 0.5
25736, 1.9173913043478, 0.98478260869565, 0.5
25737, 1.9391304347826, 1.0108695652174, 0.5
25738, 1.9608695652174, 0.98478260869565, 0.5
25739, 1.9826086956522, 1.0108695652174, 0.5
25740, 2.004347826087, 0.98478260869565, 0.5
25741, 2.0260869565217, 1.0108695652174, 0.5
25742, 2.0478260869565, 0.98478260869565, 0.5
25743, 2.0695652173913, 1.0108695652174, 0.5
25744, 2.0913043478261, 0.98478260869565, 0.5
25745, 2.1130434782609, 1.0108695652174, 0.5
25746, 2.1347826086957, 0.98478260869565, 0.5
25747, 2.1565217391304, 1.0108695652174, 0.5
25748, 2.1782608695652, 0.98478260869565, 0.5
25749, 1.2217391304348, 0.93260869565217, 0.5
25750, 1.2434782608696, 0.95869565217391, 0.5
25751, 1.2652173913043, 0.93260869565217, 0.5
25752, 1.2869565217391, 0.95869565217391, 0.5
25753, 1.3086956521739, 0.93260869565217, 0.5
25754, 1.3304347826087, 0.95869565217391, 0.5
25755, 1.3521739130435, 0.93260869565217, 0.5
25756, 1.3739130434783, 0.95869565217391, 0.5
25757, 1.395652173913, 0.93260869565217, 0.5
25758, 1.4173913043478, 0.95869565217391, 0.5
25759, 1.4391304347826, 0.93260869565217, 0.5
25760, 1.4608695652174, 0.95869565217391, 0.5
25761, 1.4826086956522, 0.93260869565217, 0.5
25762, 1.504347826087, 0.95869565217391, 0.5
25763, 1.5260869565217, 0.93260869565217, 0.5
25764, 1.5478260869565, 0.95869565217391, 0.5
25765, 1.5695652173913, 0.93260869565217, 0.5
25766, 1.5913043478261, 0.95869565217391, 0.5
25767, 1.6130434782609, 0.93260869565217, 0.5
25768, 1.6347826086957, 0.95869565217391, 0.5
25769, 1.6565217391304, 0.93260869565217, 0.5
25770, 1.6782608695652, 0.95869565217391, 0.5
25771, 1.7, 0.93260869565217, 0.5
25772, 1.7217391304348, 0.95869565217391, 0.5
25773, 1.7434782608696, 0.93260869565217, 0.5
25774, 1.7652173913043, 0.95869565217391, 0.5
25775, 1.7869565217391, 0.93260869565217, 0.5
25776, 1.8086956521739, 0.95869565217391, 0.5
25777, 1.8304347826087, 0.93260869565217, 0.5
25778, 1.8521739130435, 0.95869565217391, 0.5
25779, 1.8739130434783, 0.93260869565217, 0.5
25780, 1.895652173913, 0.95869565217391, 0.5
25781, 1.9173913043478, 0.93260869565217, 0.5
25782, 1.9391304347826, 0.95869565217391, 0.5
25783, 1.9608695652174, 0.93260869565217, 0.5
25784, 1.9826086956522, 0.95869565217391, 0.5
25785, 2.004347826087, 0.93260869565217, 0.5
25786, 2.0260869565217, 0.95869565217391, 0.5
25787, 2.0478260869565, 0.93260869565217, 0.5
25788, 2.0695652173913, 0.95869565217391, 0.5
25789, 2.0913043478261, 0.93260869565217, 0.5
25790, 2.1130434782609, 0.95869565217391, 0.5
25791, 2.1347826086957, 0.93260869565217, 0.5
25792, 2.1565217391304, 0.95869565217391, 0.5
25793, 2.1782608695652, 0.93260869565217, 0.5
25794, 1.2217391304348, 0.8804347826087, 0.5
25795, 1.2434782608696, 0.90652173913044, 0.5
25796, 1.2652173913043, 0.8804347826087, 0.5
25797, 1.2869565217391, 0.90652173913044, 0.5
25798, 1.3086956521739, 0.8804347826087, 0.5
25799, 1.3304347826087, 0.90652173913044, 0.5
25800, 1.3521739130435, 0.8804347826087, 0.5
25801, 1.3739130434783, 0.90652173913044, 0.5
25802, 1.395652173913, 0.8804347826087, 0.5
25803, 1.4173913043478, 0.90652173913044, 0.5
25804, 1.4391304347826, 0.8804347826087, 0.5
25805, 1.4608695652174, 0.90652173913044, 0.5
25806, 1.4826086956522, 0.8804347826087, 0.5
25807, 1.504347826087, 0.90652173913044, 0.5
25808, 1.5260869565217, 0.8804347826087, 0.5
25809, 1.5478260869565, 0.90652173913044, 0.5
25810, 1.5695652173913, 0.8804347826087, 0.5
25811, 1.5913043478261, 0.90652173913044, 0.5
25812, 1.6130434782609, 0.8804347826087, 0.5
25813, 1.6347826086957, 0.90652173913044, 0.5
25814, 1.6565217391304, 0.8804347826087, 0.5
25815, 1.6782608695652, 0.90652173913044, 0.5
25816, 1.7, 0.8804347826087, 0.5
25817, 1.7217391304348, 0.90652173913044, 0.5
25818, 1.7434782608696, 0.8804347826087, 0.5
25819, 1.7652173913043, 0.90652173913044, 0.5
25820, 1.7869565217391, 0.8804347826087, 0.5
25821, 1.8086956521739, 0.90652173913044, 0.5
25822, 1.8304347826087, 0.8804347826087, 0.5
25823, 1.8521739130435, 0.90652173913044, 0.5
25824, 1.8739130434783, 0.8804347826087, 0.5
25825, 1.895652173913, 0.90652173913044, 0.5
25826, 1.9173913043478, 0.8804347826087, 0.5
25827, 1.9391304347826, 0.90652173913044, 0.5
25828, 1.9608695652174, 0.8804347826087, 0.5
25829, 1.9826086956522, 0.90652173913044, 0.5
25830, 2.004347826087, 0.8804347826087, 0.5
25831, 2.0260869565217, 0.90652173913044, 0.5
25832, 2.0478260869565, 0.8804347826087, 0.5
25833, 2.0695652173913, 0.90652173913044, 0.5
25834, 2.0913043478261, 0.8804347826087, 0.5
25835, 2.1130434782609, 0.90652173913044, 0.5
25836, 2.1347826086957, 0.8804347826087, 0.5
25837, 2.1565217391304, 0.90652173913044, 0.5
25838, 2.1782608695652, 0.8804347826087, 0.5
25839, 1.2217391304348, 0.82826086956522, 0.5
25840, 1.2434782608696, 0.85434782608696, 0.5
25841, 1.2652173913043, 0.82826086956522, 0.5
25842, 1.2869565217391, 0.85434782608696, 0.5
25843, 1.3086956521739, 0.82826086956522, 0.5
25844, 1.3304347826087, 0.85434782608696, 0.5
25845, 1.3521739130435, 0.82826086956522, 0.5
25846, 1.3739130434783, 0.85434782608696, 0.5
25847, 1.395652173913, 0.82826086956522, 0.5
25848, 1.4173913043478, 0.85434782608696, 0.5
25849, 1.4391304347826, 0.82826086956522, 0.5
25850, 1.4608695652174, 0.85434782608696, 0.5
25851, 1.4826086956522, 0.82826086956522, 0.5
25852, 1.504347826087, 0.85434782608696, 0.5
25853, 1.5260869565217, 0.82826086956522, 0.5
25854, 1.5478260869565, 0.85434782608696, 0.5
25855, 1.5695652173913, 0.82826086956522, 0.5
25856, 1.5913043478261, 0.85434782608696, 0.5
25857, 1.6130434782609, 0.82826086956522, 0.5
25858, 1.6347826086957, 0.85434782608696, 0.5
25859, 1.6565217391304, 0.82826086956522, 0.5
25860, 1.6782608695652, 0.85434782608696, 0.5
25861, 1.7, 0.82826086956522, 0.5
25862, 1.7217391304348, 0.85434782608696, 0.5
25863, 1.7434782608696, 0.82826086956522, 0.5
25864, 1.7652173913043, 0.85434782608696, 0.5
25865, 1.7869565217391, 0.82826086956522, 0.5
25866, 1.8086956521739, 0.85434782608696, 0.5
25867, 1.8304347826087, 0.82826086956522, 0.5
25868, 1.8521739130435, 0.85434782608696, 0.5
25869, 1.8739130434783, 0.82826086956522, 0.5
25870, 1.895652173913, 0.85434782608696, 0.5
25871, 1.9173913043478, 0.82826086956522, 0.5
25872, 1.9391304347826, 0.85434782608696, 0.5
25873, 1.9608695652174, 0.82826086956522, 0.5
25874, 1.9826086956522, 0.85434782608696, 0.5
25875, 2.004347826087, 0.82826086956522, 0.5
25876, 2.0260869565217, 0.85434782608696, 0.5
25877, 2.0478260869565, 0.82826086956522, 0.5
25878, 2.0695652173913, 0.85434782608696, 0.5
25879, 2.0913043478261, 0.82826086956522, 0.5
25880, 2.1130434782609, 0.85434782608696, 0.5
25881, 2.1347826086957, 0.82826086956522, 0.5
25882, 2.1565217391304, 0.85434782608696, 0.5
25883, 2.1782608695652, 0.82826086956522, 0.5
25884, 1.2217391304348, 0.77608695652174, 0.5
25885, 1.2434782608696, 0.80217391304348, 0.5
25886, 1.2652173913043, 0.77608695652174, 0.5
25887, 1.2869565217391, 0.80217391304348, 0.5
25888, 1.3086956521739, 0.77608695652174, 0.5
25889, 1.3304347826087, 0.80217391304348, 0.5
25890, 1.3521739130435, 0.77608695652174, 0.5
25891, 1.3739130434783, 0.80217391304348, 0.5
25892, 1.395652173913, 0.77608695652174, 0.5
25893, 1.4173913043478, 0.80217391304348, 0.5
25894, 1.4391304347826, 0.77608695652174, 0.5
25895, 1.4608695652174, 0.80217391304348, 0.5
25896, 1.4826086956522, 0.77608695652174, 0.5
25897, 1.504347826087, 0.80217391304348, 0.5
25898, 1.5260869565217, 0.77608695652174, 0.5
25899, 1.5478260869565, 0.80217391304348, 0.5
25900, 1.5695652173913, 0.77608695652174, 0.5
25901, 1.5913043478261, 0.80217391304348, 0.5
25902, 1.6130434782609, 0.77608695652174, 0.5
25903, 1.6347826086957, 0.80217391304348, 0.5
25904, 1.6565217391304, 0.77608695652174, 0.5
25905, 1.6782608695652, 0.80217391304348, 0.5
25906, 1.7, 0.77608695652174, 0.5
25907, 1.7217391304348, 0.80217391304348, 0.5
25908, 1.7434782608696, 0.77608695652174, 0.5
25909, 1.7652173913043, 0.80217391304348, 0.5
25910, 1.7869565217391, 0.77608695652174, 0.5
25911, 1.8086956521739, 0.80217391304348, 0.5
25912, 1.8304347826087, 0.77608695652174, 0.5
25913, 1.8521739130435, 0.80217391304348, 0.5
25914, 1.8739130434783, 0.77608695652174, 0.5
25915, 1.895652173913, 0.80217391304348, 0.5
25916, 1.9173913043478, 0.77608695652174, 0.5
25917, 1.9391304347826, 0.80217391304348, 0.5
25918, 1.9608695652174, 0.77608695652174, 0.5
25919, 1.9826086956522, 0.80217391304348, 0.5
25920, 2.004347826087, 0.77608695652174, 0.5
25921, 2.0260869565217, 0.80217391304348, 0.5
25922, 2.0478260869565, 0.77608695652174, 0.5
25923, 2.0695652173913, 0.80217391304348, 0.5
25924, 2.0913043478261, 0.77608695652174, 0.5
25925, 2.1130434782609, 0.80217391304348, 0.5
25926, 2.1347826086957, 0.77608695652174, 0.5
25927, 2.1565217391304, 0.80217391304348, 0.5
25928, 2.1782608695652, 0.77608695652174, 0.5
25929, 1.2217391304348, 0.72391304347826, 0.5
25930, 1.2434782608696, 0.75, 0.5
25931, 1.2652173913043, 0.72391304347826, 0.5
25932, 1.2869565217391, 0.75, 0.5
25933, 1.3086956521739, 0.72391304347826, 0.5
25934, 1.3304347826087, 0.75, 0.5
25935, 1.3521739130435, 0.72391304347826, 0.5
25936, 1.3739130434783, 0.75, 0.5
25937, 1.395652173913, 0.72391304347826, 0.5
25938, 1.4173913043478, 0.75, 0.5
25939, 1.4391304347826, 0.72391304347826, 0.5
25940, 1.4608695652174, 0.75, 0.5
25941, 1.4826086956522, 0.72391304347826, 0.5
25942, 1.504347826087, 0.75, 0.5
25943, 1.5260869565217, 0.72391304347826, 0.5
25944, 1.5478260869565, 0.75, 0.5
25945, 1.5695652173913, 0.72391304347826, 0.5
25946, 1.5913043478261, 0.75, 0.5
25947, 1.6130434782609, 0.72391304347826, 0.5
25948, 1.6347826086957, 0.75, 0.5
25949, 1.6565217391304, 0.72391304347826, 0.5
25950, 1.6782608695652, 0.75, 0.5
25951, 1.7, 0.72391304347826, 0.5
25952, 1.7217391304348, 0.75, 0.5
25953, 1.7434782608696, 0.72391304347826, 0.5
25954, 1.7652173913043, 0.75, 0.5
25955, 1.7869565217391, 0.72391304347826, 0.5
25956, 1.8086956521739, 0.75, 0.5
25957, 1.8304347826087, 0.72391304347826, 0.5
25958, 1.8521739130435, 0.75, 0.5
25959, 1.8739130434783, 0.72391304347826, 0.5
25960, 1.895652173913, 0.75, 0.5
25961, 1.9173913043478, 0.72391304347826, 0.5
25962, 1.9391304347826, 0.75, 0.5
25963, 1.9608695652174, 0.72391304347826, 0.5
25964, 1.9826086956522, 0.75, 0.5
25965, 2.004347826087, 0.72391304347826, 0.5
25966, 2.0260869565217, 0.75, 0.5
25967, 2.0478260869565, 0.72391304347826, 0.5
25968, 2.0695652173913, 0.75, 0.5
25969, 2.0913043478261, 0.72391304347826, 0.5
25970, 2.1130434782609, 0.75, 0.5
25971, 2.1347826086957, 0.72391304347826, 0.5
25972, 2.1565217391304, 0.75, 0.5
25973, 2.1782608695652, 0.72391304347826, 0.5
25974, 1.2217391304348, 0.67173913043478, 0.5
25975, 1.2434782608696, 0.69782608695652, 0.5
25976, 1.2652173913043, 0.67173913043478, 0.5
25977, 1.2869565217391, 0.69782608695652, 0.5
25978, 1.3086956521739, 0.67173913043478, 0.5
25979, 1.3304347826087, 0.69782608695652, 0.5
25980, 1.3521739130435, 0.67173913043478, 0.5
25981, 1.3739130434783, 0.69782608695652, 0.5
25982, 1.395652173913, 0.67173913043478, 0.5
25983, 1.4173913043478, 0.69782608695652, 0.5
25984, 1.4391304347826, 0.67173913043478, 0.5
25985, 1.4608695652174, 0.69782608695652, 0.5
25986, 1.4826086956522, 0.67173913043478, 0.5
25987, 1.504347826087, 0.69782608695652, 0.5
25988, 1.5260869565217, 0.67173913043478, 0.5
25989, 1.5478260869565, 0.69782608695652, 0.5
25990, 1.5695652173913, 0.67173913043478, 0.5
25991, 1.5913043478261, 0.69782608695652, 0.5
25992, 1.6130434782609, 0.67173913043478, 0.5
25993, 1.6347826086957, 0.69782608695652, 0.5
25994, 1.6565217391304, 0.67173913043478, 0.5
25995, 1.6782608695652, 0.69782608695652, 0.5
25996, 1.7, 0.67173913043478, 0.5
25997, 1.7217391304348, 0.69782608695652, 0.5
25998, 1.7434782608696, 0.67173913043478, 0.5
25999, 1.7652173913043, 0.69782608695652, 0.5
26000, 1.7869565217391, 0.67173913043478, 0.5
26001, 1.8086956521739, 0.69782608695652, 0.5
26002, 1.8304347826087, 0.67173913043478, 0.5
26003, 1.8521739130435, 0.69782608695652, 0.5
26004, 1.8739130434783, 0.67173913043478, 0.5
26005, 1.895652173913, 0.69782608695652, 0.5
26006, 1.9173913043478, 0.67173913043478, 0.5
26007, 1.9391304347826, 0.69782608695652, 0.5
26008, 1.9608695652174, 0.67173913043478, 0.5
26009, 1.9826086956522, 0.69782608695652, 0.5
26010, 2.004347826087, 0.67173913043478, 0.5
26011, 2.0260869565217, 0.69782608695652, 0.5
26012, 2.0478260869565, 0.67173913043478, 0.5
26013, 2.0695652173913, 0.69782608695652, 0.5
26014, 2.0913043478261, 0.67173913043478, 0.5
26015, 2.1130434782609, 0.69782608695652, 0.5
26016, 2.1347826086957, 0.67173913043478, 0.5
26017, 2.1565217391304, 0.69782608695652, 0.5
26018, 2.1782608695652, 0.67173913043478, 0.5
26019, 1.2217391304348, 0.61956521739131, 0.5
26020, 1.2434782608696, 0.64565217391304, 0.5
26021, 1.2652173913043, 0.61956521739131, 0.5
26022, 1.2869565217391, 0.64565217391304, 0.5
26023, 1.3086956521739, 0.61956521739131, 0.5
26024, 1.3304347826087, 0.64565217391304, 0.5
26025, 1.3521739130435, 0.61956521739131, 0.5
26026, 1.3739130434783, 0.64565217391304, 0.5
26027, 1.395652173913, 0.61956521739131, 0.5
26028, 1.4173913043478, 0.64565217391304, 0.5
26029, 1.4391304347826, 0.61956521739131, 0.5
26030, 1.4608695652174, 0.64565217391304, 0.5
26031, 1.4826086956522, 0.61956521739131, 0.5
26032, 1.504347826087, 0.64565217391304, 0.5
26033, 1.5260869565217, 0.61956521739131, 0.5
26034, 1.5478260869565, 0.64565217391304, 0.5
26035, 1.5695652173913, 0.61956521739131, 0.5
26036, 1.5913043478261, 0.64565217391304, 0.5
26037, 1.6130434782609, 0.61956521739131, 0.5
26038, 1.6347826086957, 0.64565217391304, 0.5
26039, 1.6565217391304, 0.61956521739131, 0.5
26040, 1.6782608695652, 0.64565217391304, 0.5
26041, 1.7, 0.61956521739131, 0.5
26042, 1.7217391304348, 0.64565217391304, 0.5
26043, 1.7434782608696, 0.61956521739131, 0.5
26044, 1.7652173913043, 0.64565217391304, 0.5
26045, 1.7869565217391, 0.61956521739131, 0.5
26046, 1.8086956521739, 0.64565217391304, 0.5
26047, 1.8304347826087, 0.61956521739131, 0.5
26048, 1.8521739130435, 0.64565217391304, 0.5
26049, 1.8739130434783, 0.61956521739131, 0.5
26050, 1.895652173913, 0.64565217391304, 0.5
26051, 1.9173913043478, 0.61956521739131, 0.5
26052, 1.9391304347826, 0.64565217391304, 0.5
26053, 1.9608695652174, 0.61956521739131, 0.5
26054, 1.9826086956522, 0.64565217391304, 0.5
26055, 2.004347826087, 0.61956521739131, 0.5
26056, 2.0260869565217, 0.64565217391304, 0.5
26057, 2.0478260869565, 0.61956521739131, 0.5
26058, 2.0695652173913, 0.64565217391304, 0.5
26059, 2.0913043478261, 0.61956521739131, 0.5
26060, 2.1130434782609, 0.64565217391304, 0.5
26061, 2.1347826086957, 0.61956521739131, 0.5
26062, 2.1565217391304, 0.64565217391304, 0.5
26063, 2.1782608695652, 0.61956521739131, 0.5
26064, 1.2217391304348, 0.56739130434783, 0.5
26065, 1.2434782608696, 0.59347826086957, 0.5
26066, 1.2652173913043, 0.56739130434783, 0.5
26067, 1.2869565217391, 0.59347826086957, 0.5
26068, 1.3086956521739, 0.56739130434783, 0.5
26069, 1.3304347826087, 0.59347826086957, 0.5
26070, 1.3521739130435, 0.56739130434783, 0.5
26071, 1.3739130434783, 0.59347826086957, 0.5
26072, 1.395652173913, 0.56739130434783, 0.5
26073, 1.4173913043478, 0.59347826086957, 0.5
26074, 1.4391304347826, 0.56739130434783, 0.5
26075, 1.4608695652174, 0.59347826086957, 0.5
26076, 1.4826086956522, 0.56739130434783, 0.5
26077, 1.504347826087, 0.59347826086957, 0.5
26078, 1.5260869565217, 0.56739130434783, 0.5
26079, 1.5478260869565, 0.59347826086957, 0.5
26080, 1.5695652173913, 0.56739130434783, 0.5
26081, 1.5913043478261, 0.59347826086957, 0.5
26082, 1.6130434782609, 0.56739130434783, 0.5
26083, 1.6347826086957, 0.59347826086957, 0.5
26084, 1.6565217391304, 0.56739130434783, 0.5
26085, 1.6782608695652, 0.59347826086957, 0.5
26086, 1.7, 0.56739130434783, 0.5
26087, 1.7217391304348, 0.59347826086957, 0.5
26088, 1.7434782608696, 0.56739130434783, 0.5
26089, 1.7652173913043, 0.59347826086957, 0.5
26090, 1.7869565217391, 0.56739130434783, 0.5
26091, 1.8086956521739, 0.59347826086957, 0.5
26092, 1.8304347826087, 0.56739130434783, 0.5
26093, 1.8521739130435, 0.59347826086957, 0.5
26094, 1.8739130434783, 0.56739130434783, 0.5
26095, 1.895652173913, 0.59347826086957, 0.5
26096, 1.9173913043478, 0.56739130434783, 0.5
26097, 1.9391304347826, 0.59347826086957, 0.5
26098, 1.9608695652174, 0.56739130434783, 0.5
26099, 1.9826086956522, 0.59347826086957, 0.5
26100, 2.004347826087, 0.56739130434783, 0.5
26101, 2.0260869565217, 0.59347826086957, 0.5
26102, 2.0478260869565, 0.56739130434783, 0.5
26103, 2.0695652173913, 0.59347826086957, 0.5
26104, 2.0913043478261, 0.56739130434783, 0.5
26105, 2.1130434782609, 0.59347826086957, 0.5
26106, 2.1347826086957, 0.56739130434783, 0.5
26107, 2.1565217391304, 0.59347826086957, 0.5
26108, 2.1782608695652, 0.56739130434783, 0.5
26109, 1.2217391304348, 0.51521739130435, 0.5
26110, 1.2434782608696, 0.54130434782609, 0.5
26111, 1.2652173913043, 0.51521739130435, 0.5
26112, 1.2869565217391, 0.54130434782609, 0.5
26113, 1.3086956521739, 0.51521739130435, 0.5
26114, 1.3304347826087, 0.54130434782609, 0.5
26115, 1.3521739130435, 0.51521739130435, 0.5
26116, 1.3739130434783, 0.54130434782609, 0.5
26117, 1.395652173913, 0.51521739130435, 0.5
26118, 1.4173913043478, 0.54130434782609, 0.5
26119, 1.4391304347826, 0.51521739130435, 0.5
26120, 1.4608695652174, 0.54130434782609, 0.5
26121, 1.4826086956522, 0.51521739130435, 0.5
26122, 1.504347826087, 0.54130434782609, 0.5
26123, 1.5260869565217, 0.51521739130435, 0.5
26124, 1.5478260869565, 0.54130434782609, 0.5
26125, 1.5695652173913, 0.51521739130435, 0.5
26126, 1.5913043478261, 0.54130434782609, 0.5
26127, 1.6130434782609, 0.51521739130435, 0.5
26128, 1.6347826086957, 0.54130434782609, 0.5
26129, 1.6565217391304, 0.51521739130435, 0.5
26130, 1.6782608695652, 0.54130434782609, 0.5
26131, 1.7, 0.51521739130435, 0.5
26132, 1.7217391304348, 0.54130434782609, 0.5
26133, 1.7434782608696, 0.51521739130435, 0.5
26134, 1.7652173913043, 0.54130434782609, 0.5
26135, 1.7869565217391, 0.51521739130435, 0.5
26136, 1.8086956521739, 0.54130434782609, 0.5
26137, 1.8304347826087, 0.51521739130435, 0.5
26138, 1.8521739130435, 0.54130434782609, 0.5
26139, 1.8739130434783, 0.51521739130435, 0.5
26140, 1.895652173913, 0.54130434782609, 0.5
26141, 1.9173913043478, 0.51521739130435, 0.5
26142, 1.9391304347826, 0.54130434782609, 0.5
26143, 1.9608695652174, 0.51521739130435, 0.5
26144, 1.9826086956522, 0.54130434782609, 0.5
26145, 2.004347826087, 0.51521739130435, 0.5
26146, 2.0260869565217, 0.54130434782609, 0.5
26147, 2.0478260869565, 0.51521739130435, 0.5
26148, 2.0695652173913, 0.54130434782609, 0.5
26149, 2.0913043478261, 0.51521739130435, 0.5
26150, 2.1130434782609, 0.54130434782609, 0.5
26151, 2.1347826086957, 0.51521739130435, 0.5
26152, 2.1565217391304, 0.54130434782609, 0.5
26153, 2.1782608695652, 0.51521739130435, 0.5
26154, 1.2217391304348, 0.46304347826087, 0.5
26155, 1.2434782608696, 0.48913043478261, 0.5
26156, 1.2652173913043, 0.46304347826087, 0.5
26157, 1.2869565217391, 0.48913043478261, 0.5
26158, 1.3086956521739, 0.46304347826087, 0.5
26159, 1.3304347826087, 0.48913043478261, 0.5
26160, 1.3521739130435, 0.46304347826087, 0.5
26161, 1.3739130434783, 0.48913043478261, 0.5
26162, 1.395652173913, 0.46304347826087, 0.5
26163, 1.4173913043478, 0.48913043478261, 0.5
26164, 1.4391304347826, 0.46304347826087, 0.5
26165, 1.4608695652174, 0.48913043478261, 0.5
26166, 1.4826086956522, 0.46304347826087, 0.5
26167, 1.504347826087, 0.48913043478261, 0.5
26168, 1.5260869565217, 0.46304347826087, 0.5
26169, 1.5478260869565, 0.48913043478261, 0.5
26170, 1.5695652173913, 0.46304347826087, 0.5
26171, 1.5913043478261, 0.48913043478261, 0.5
26172, 1.6130434782609, 0.46304347826087, 0.5
26173, 1.6347826086957, 0.48913043478261, 0.5
26174, 1.6565217391304, 0.46304347826087, 0.5
26175, 1.6782608695652, 0.48913043478261, 0.5
26176, 1.7, 0.46304347826087, 0.5
26177, 1.7217391304348, 0.48913043478261, 0.5
26178, 1.7434782608696, 0.46304347826087, 0.5
26179, 1.7652173913043, 0.48913043478261, 0.5
26180, 1.7869565217391, 0.46304347826087, 0.5
26181, 1.8086956521739, 0.48913043478261, 0.5
26182, 1.8304347826087, 0.46304347826087, 0.5
26183, 1.8521739130435, 0.48913043478261, 0.5
26184, 1.8739130434783, 0.46304347826087, 0.5
26185, 1.895652173913, 0.48913043478261, 0.5
26186, 1.9173913043478, 0.46304347826087, 0.5
26187, 1.9391304347826, 0.48913043478261, 0.5
26188, 1.9608695652174, 0.46304347826087, 0.5
26189, 1.9826086956522, 0.48913043478261, 0.5
26190, 2.004347826087, 0.46304347826087, 0.5
26191, 2.0260869565217, 0.48913043478261, 0.5
26192, 2.0478260869565, 0.46304347826087, 0.5
26193, 2.0695652173913, 0.48913043478261, 0.5
26194, 2.0913043478261, 0.46304347826087, 0.5
26195, 2.1130434782609, 0.48913043478261, 0.5
26196, 2.1347826086957, 0.46304347826087, 0.5
26197, 2.1565217391304, 0.48913043478261, 0.5
26198, 2.1782608695652, 0.46304347826087, 0.5
26199, 1.2217391304348, 0.41086956521739, 0.5
26200, 1.2434782608696, 0.43695652173913, 0.5
26201, 1.2652173913043, 0.41086956521739, 0.5
26202, 1.2869565217391, 0.43695652173913, 0.5
26203, 1.3086956521739, 0.41086956521739, 0.5
26204, 1.3304347826087, 0.43695652173913, 0.5
26205, 1.3521739130435, 0.41086956521739, 0.5
26206, 1.3739130434783, 0.43695652173913, 0.5
26207, 1.395652173913, 0.41086956521739, 0.5
26208, 1.4173913043478, 0.43695652173913, 0.5
26209, 1.4391304347826, 0.41086956521739, 0.5
26210, 1.4608695652174, 0.43695652173913, 0.5
26211, 1.4826086956522, 0.41086956521739, 0.5
26212, 1.504347826087, 0.43695652173913, 0.5
26213, 1.5260869565217, 0.41086956521739, 0.5
26214, 1.5478260869565, 0.43695652173913, 0.5
26215, 1.5695652173913, 0.41086956521739, 0.5
26216, 1.5913043478261, 0.43695652173913, 0.5
26217, 1.6130434782609, 0.41086956521739, 0.5
26218, 1.6347826086957, 0.43695652173913, 0.5
26219, 1.6565217391304, 0.41086956521739, 0.5
26220, 1.6782608695652, 0.43695652173913, 0.5
26221, 1.7, 0.41086956521739, 0.5
26222, 1.7217391304348, 0.43695652173913, 0.5
26223, 1.7434782608696, 0.41086956521739, 0.5
26224, 1.7652173913043, 0.43695652173913, 0.5
26225, 1.7869565217391, 0.41086956521739, 0.5
26226, 1.8086956521739, 0.43695652173913, 0.5
26227, 1.8304347826087, 0.41086956521739, 0.5
26228, 1.8521739130435, 0.43695652173913, 0.5
26229, 1.8739130434783, 0.41086956521739, 0.5
26230, 1.895652173913, 0.43695652173913, 0.5
26231, 1.9173913043478, 0.41086956521739, 0.5
26232, 1.9391304347826, 0.43695652173913, 0.5
26233, 1.9608695652174, 0.41086956521739, 0.5
26234, 1.9826086956522, 0.43695652173913, 0.5
26235, 2.004347826087, 0.41086956521739, 0.5
26236, 2.0260869565217, 0.43695652173913, 0.5
26237, 2.0478260869565, 0.41086956521739, 0.5
26238, 2.0695652173913, 0.43695652173913, 0.5
26239, 2.0913043478261, 0.41086956521739, 0.5
26240, 2.1130434782609, 0.43695652173913, 0.5
26241, 2.1347826086957, 0.41086956521739, 0.5
26242, 2.1565217391304, 0.43695652173913, 0.5
26243, 2.1782608695652, 0.41086956521739, 0.5
26244, 1.2217391304348, 0.35869565217391, 0.5
26245, 1.2434782608696, 0.38478260869565, 0.5
26246, 1.2652173913043, 0.35869565217391, 0.5
26247, 1.2869565217391, 0.38478260869565, 0.5
26248, 1.3086956521739, 0.35869565217391, 0.5
26249, 1.3304347826087, 0.38478260869565, 0.5
26250, 1.3521739130435, 0.35869565217391, 0.5
26251, 1.3739130434783, 0.38478260869565, 0.5
26252, 1.395652173913, 0.35869565217391, 0.5
26253, 1.4173913043478, 0.38478260869565, 0.5
26254, 1.4391304347826, 0.35869565217391, 0.5
26255, 1.4608695652174, 0.38478260869565, 0.5
26256, 1.4826086956522, 0.35869565217391, 0.5
26257, 1.504347826087, 0.38478260869565, 0.5
26258, 1.5260869565217, 0.35869565217391, 0.5
26259, 1.5478260869565, 0.38478260869565, 0.5
26260, 1.5695652173913, 0.35869565217391, 0.5
26261, 1.5913043478261, 0.38478260869565, 0.5
26262, 1.6130434782609, 0.35869565217391, 0.5
26263, 1.6347826086957, 0.38478260869565, 0.5
26264, 1.6565217391304, 0.35869565217391, 0.5
26265, 1.6782608695652, 0.38478260869565, 0.5
26266, 1.7, 0.35869565217391, 0.5
26267, 1.7217391304348, 0.38478260869565, 0.5
26268, 1.7434782608696, 0.35869565217391, 0.5
26269, 1.7652173913043, 0.38478260869565, 0.5
26270, 1.7869565217391, 0.35869565217391, 0.5
26271, 1.8086956521739, 0.38478260869565, 0.5
26272, 1.8304347826087, 0.35869565217391, 0.5
26273, 1.8521739130435, 0.38478260869565, 0.5
26274, 1.8739130434783, 0.35869565217391, 0.5
26275, 1.895652173913, 0.38478260869565, 0.5
26276, 1.9173913043478, 0.35869565217391, 0.5
26277, 1.9391304347826, 0.38478260869565, 0.5
26278, 1.9608695652174, 0.35869565217391, 0.5
26279, 1.9826086956522, 0.38478260869565, 0.5
26280, 2.004347826087, 0.35869565217391, 0.5
26281, 2.0260869565217, 0.38478260869565, 0.5
26282, 2.0478260869565, 0.35869565217391, 0.5
26283, 2.0695652173913, 0.38478260869565, 0.5
26284, 2.0913043478261, 0.35869565217391, 0.5
26285, 2.1130434782609, 0.38478260869565, 0.5
26286, 2.1347826086957, 0.35869565217391, 0.5
26287, 2.1565217391304, 0.38478260869565, 0.5
26288, 2.1782608695652, 0.35869565217391, 0.5
26289, 1.2217391304348, 0.30652173913044, 0.5
26290, 1.2434782608696, 0.33260869565217, 0.5
26291, 1.2652173913043, 0.30652173913044, 0.5
26292, 1.2869565217391, 0.33260869565217, 0.5
26293, 1.3086956521739, 0.30652173913043, 0.5
26294, 1.3304347826087, 0.33260869565217, 0.5
26295, 1.3521739130435, 0.30652173913044, 0.5
26296, 1.3739130434783, 0.33260869565217, 0.5
26297, 1.395652173913, 0.30652173913044, 0.5
26298, 1.4173913043478, 0.33260869565217, 0.5
26299, 1.4391304347826, 0.30652173913044, 0.5
26300, 1.4608695652174, 0.33260869565217, 0.5
26301, 1.4826086956522, 0.30652173913044, 0.5
26302, 1.504347826087, 0.33260869565217, 0.5
26303, 1.5260869565217, 0.30652173913044, 0.5
26304, 1.5478260869565, 0.33260869565217, 0.5
26305, 1.5695652173913, 0.30652173913044, 0.5
26306, 1.5913043478261, 0.33260869565217, 0.5
26307, 1.6130434782609, 0.30652173913044, 0.5
26308, 1.6347826086957, 0.33260869565217, 0.5
26309, 1.6565217391304, 0.30652173913043, 0.5
26310, 1.6782608695652, 0.33260869565217, 0.5
26311, 1.7, 0.30652173913043, 0.5
26312, 1.7217391304348, 0.33260869565217, 0.5
26313, 1.7434782608696, 0.30652173913043, 0.5
26314, 1.7652173913043, 0.33260869565217, 0.5
26315, 1.7869565217391, 0.30652173913044, 0.5
26316, 1.8086956521739, 0.33260869565217, 0.5
26317, 1.8304347826087, 0.30652173913044, 0.5
26318, 1.8521739130435, 0.33260869565217, 0.5
26319, 1.8739130434783, 0.30652173913043, 0.5
26320, 1.895652173913, 0.33260869565217, 0.5
26321, 1.9173913043478, 0.30652173913044, 0.5
26322, 1.9391304347826, 0.33260869565217, 0.5
26323, 1.9608695652174, 0.30652173913044, 0.5
26324, 1.9826086956522, 0.33260869565217, 0.5
26325, 2.004347826087, 0.30652173913044, 0.5
26326, 2.0260869565217, 0.33260869565217, 0.5
26327, 2.0478260869565, 0.30652173913044, 0.5
26328, 2.0695652173913, 0.33260869565217, 0.5
26329, 2.0913043478261, 0.30652173913043, 0.5
26330, 2.1130434782609, 0.33260869565217, 0.5
26331, 2.1347826086957, 0.30652173913043, 0.5
26332, 2.1565217391304, 0.33260869565217, 0.5
26333, 2.1782608695652, 0.30652173913044, 0.5
26334, 1.2217391304348, 0.25434782608696, 0.5
26335, 1.2434782608696, 0.2804347826087, 0.5
26336, 1.2652173913043, 0.25434782608696, 0.5
26337, 1.2869565217391, 0.2804347826087, 0.5
26338, 1.3086956521739, 0.25434782608696, 0.5
26339, 1.3304347826087, 0.2804347826087, 0.5
26340, 1.3521739130435, 0.25434782608696, 0.5
26341, 1.3739130434783, 0.2804347826087, 0.5
26342, 1.395652173913, 0.25434782608696, 0.5
26343, 1.4173913043478, 0.2804347826087, 0.5
26344, 1.4391304347826, 0.25434782608696, 0.5
26345, 1.4608695652174, 0.2804347826087, 0.5
26346, 1.4826086956522, 0.25434782608696, 0.5
26347, 1.504347826087, 0.2804347826087, 0.5
26348, 1.5260869565217, 0.25434782608696, 0.5
26349, 1.5478260869565, 0.2804347826087, 0.5
26350, 1.5695652173913, 0.25434782608696, 0.5
26351, 1.5913043478261, 0.2804347826087, 0.5
26352, 1.6130434782609, 0.25434782608696, 0.5
26353, 1.6347826086957, 0.2804347826087, 0.5
26354, 1.6565217391304, 0.25434782608696, 0.5
26355, 1.6782608695652, 0.2804347826087, 0.5
26356, 1.7, 0.25434782608696, 0.5
26357, 1.7217391304348, 0.2804347826087, 0.5
26358, 1.7434782608696, 0.25434782608696, 0.5
26359, 1.7652173913043, 0.2804347826087, 0.5
26360, 1.7869565217391, 0.25434782608696, 0.5
26361, 1.8086956521739, 0.2804347826087, 0.5
26362, 1.8304347826087, 0.25434782608696, 0.5
26363, 1.8521739130435, 0.2804347826087, 0.5
26364, 1.8739130434783, 0.25434782608696, 0.5
26365, 1.895652173913, 0.2804347826087, 0.5
26366, 1.9173913043478, 0.25434782608696, 0.5
26367, 1.9391304347826, 0.2804347826087, 0.5
26368, 1.9608695652174, 0.25434782608696, 0.5
26369, 1.9826086956522, 0.2804347826087, 0.5
26370, 2.004347826087, 0.25434782608696, 0.5
26371, 2.0260869565217, 0.2804347826087, 0.5
26372, 2.0478260869565, 0.25434782608696, 0.5
26373, 2.0695652173913, 0.2804347826087, 0.5
26374, 2.0913043478261, 0.25434782608696, 0.5
26375, 2.1130434782609, 0.2804347826087, 0.5
26376, 2.1347826086957, 0.25434782608696, 0.5
26377, 2.1565217391304, 0.2804347826087, 0.5
26378, 2.1782608695652, 0.25434782608696, 0.5
26379, 1.2217391304348, 0.20217391304348, 0.5
26380, 1.2434782608696, 0.22826086956522, 0.5
26381, 1.2652173913043, 0.20217391304348, 0.5
26382, 1.2869565217391, 0.22826086956522, 0.5
26383, 1.3086956521739, 0.20217391304348, 0.5
26384, 1.3304347826087, 0.22826086956522, 0.5
26385, 1.3521739130435, 0.20217391304348, 0.5
26386, 1.3739130434783, 0.22826086956522, 0.5
26387, 1.395652173913, 0.20217391304348, 0.5
26388, 1.4173913043478, 0.22826086956522, 0.5
26389, 1.4391304347826, 0.20217391304348, 0.5
26390, 1.4608695652174, 0.22826086956522, 0.5
26391, 1.4826086956522, 0.20217391304348, 0.5
26392, 1.504347826087, 0.22826086956522, 0.5
26393, 1.5260869565217, 0.20217391304348, 0.5
26394, 1.5478260869565, 0.22826086956522, 0.5
26395, 1.5695652173913, 0.20217391304348, 0.5
26396, 1.5913043478261, 0.22826086956522, 0.5
26397, 1.6130434782609, 0.20217391304348, 0.5
26398, 1.6347826086957, 0.22826086956522, 0.5
26399, 1.6565217391304, 0.20217391304348, 0.5
26400, 1.6782608695652, 0.22826086956522, 0.5
26401, 1.7, 0.20217391304348, 0.5
26402, 1.7217391304348, 0.22826086956522, 0.5
26403, 1.7434782608696, 0.20217391304348, 0.5
26404, 1.7652173913043, 0.22826086956522, 0.5
26405, 1.7869565217391, 0.20217391304348, 0.5
26406, 1.8086956521739, 0.22826086956522, 0.5
26407, 1.8304347826087, 0.20217391304348, 0.5
26408, 1.8521739130435, 0.22826086956522, 0.5
26409, 1.8739130434783, 0.20217391304348, 0.5
26410, 1.895652173913, 0.22826086956522, 0.5
26411, 1.9173913043478, 0.20217391304348, 0.5
26412, 1.9391304347826, 0.22826086956522, 0.5
26413, 1.9608695652174, 0.20217391304348, 0.5
26414, 1.9826086956522, 0.22826086956522, 0.5
26415, 2.004347826087, 0.20217391304348, 0.5
26416, 2.0260869565217, 0.22826086956522, 0.5
26417, 2.0478260869565, 0.20217391304348, 0.5
26418, 2.0695652173913, 0.22826086956522, 0.5
26419, 2.0913043478261, 0.20217391304348, 0.5
26420, 2.1130434782609, 0.22826086956522, 0.5
26421, 2.1347826086957, 0.20217391304348, 0.5
26422, 2.1565217391304, 0.22826086956522, 0.5
26423, 2.1782608695652, 0.20217391304348, 0.5
26424, 1.2434782608696, 0.17608695652174, 0.5
26425, 1.2869565217391, 0.17608695652174, 0.5
26426, 1.3304347826087, 0.17608695652174, 0.5
26427, 1.3739130434783, 0.17608695652174, 0.5
26428, 1.4173913043478, 0.17608695652174, 0.5
26429, 1.4608695652174, 0.17608695652174, 0.5
26430, 1.504347826087, 0.17608695652174, 0.5
26431, 1.5478260869565, 0.17608695652174, 0.5
26432, 1.5913043478261, 0.17608695652174, 0.5
26433, 1.6347826086957, 0.17608695652174, 0.5
26434, 1.6782608695652, 0.17608695652174, 0.5
26435, 1.7217391304348, 0.17608695652174, 0.5
26436, 1.7652173913043, 0.17608695652174, 0.5
26437, 1.8086956521739, 0.17608695652174, 0.5
26438, 1.8521739130435, 0.17608695652174, 0.5
26439, 1.895652173913, 0.17608695652174, 0.5
26440, 1.9391304347826, 0.17608695652174, 0.5
26441, 1.9826086956522, 0.17608695652174, 0.5
26442, 2.0260869565217, 0.17608695652174, 0.5
26443, 2.0695652173913, 0.17608695652174, 0.5
26444, 2.1130434782609, 0.17608695652174, 0.5
26445, 2.1565217391304, 0.17608695652174, 0.5
26446, 1.2434782608696, 1.2978260869565, 0
26447, 1.2869565217391, 1.2978260869565, 0
26448, 1.3304347826087, 1.2978260869565, 0
26449, 1.3739130434783, 1.2978260869565, 0
26450, 1.4173913043478, 1.2978260869565, 0
26451, 1.4608695652174, 1.2978260869565, 0
26452, 1.504347826087, 1.2978260869565, 0
26453, 1.5478260869565, 1.2978260869565, 0
26454, 1.5913043478261, 1.2978260869565, 0
26455, 1.6347826086957, 1.2978260869565, 0
26456, 1.6782608695652, 1.2978260869565, 0
26457, 1.7217391304348, 1.2978260869565, 0
26458, 1.7652173913043, 1.2978260869565, 0
26459, 1.8086956521739, 1.2978260869565, 0
26460, 1.8521739130435, 1.2978260869565, 0
26461, 1.895652173913, 1.2978260869565, 0
26462, 1.9391304347826, 1.2978260869565, 0
26463, 1.9826086956522, 1.2978260869565, 0
26464, 2.0260869565217, 1.2978260869565, 0
26465, 2.0695652173913, 1.2978260869565, 0
26466, 2.1130434782609, 1.2978260869565, 0
26467, 2.1565217391304, 1.2978260869565, 0
26468, 1.2434782608696, 1.245652173913, 0
26469, 1.2869565217391, 1.245652173913, 0
26470, 1.3304347826087, 1.245652173913, 0
26471, 1.3739130434783, 1.245652173913, 0
26472, 1.4173913043478, 1.245652173913, 0
26473, 1.4608695652174, 1.245652173913, 0
26474, 1.504347826087, 1.245652173913, 0
26475, 1.5478260869565, 1.245652173913, 0
26476, 1.5913043478261, 1.245652173913, 0
26477, 1.6347826086957, 1.245652173913, 0
26478, 1.6782608695652, 1.245652173913, 0
26479, 1.7217391304348, 1.245652173913, 0
26480, 1.7652173913043, 1.245652173913, 0
26481, 1.8086956521739, 1.245652173913, 0
26482, 1.8521739130435, 1.245652173913, 0
26483, 1.895652173913, 1.245652173913, 0
26484, 1.9391304347826, 1.245652173913, 0
26485, 1.9826086956522, 1.245652173913, 0
26486, 2.0260869565217, 1.245652173913, 0
26487, 2.0695652173913, 1.245652173913, 0
26488, 2.1130434782609, 1.245652173913, 0
26489, 2.1565217391304, 1.245652173913, 0
26490, 1.2434782608696, 1.1934782608696, 0
26491, 1.2869565217391, 1.1934782608696, 0
26492, 1.3304347826087, 1.1934782608696, 0
26493, 1.3739130434783, 1.1934782608696, 0
26494, 1.4173913043478, 1.1934782608696, 0
26495, 1.4608695652174, 1.1934782608696, 0
26496, 1.504347826087, 1.1934782608696, 0
26497, 1.5478260869565, 1.1934782608696, 0
26498, 1.5913043478261, 1.1934782608696, 0
26499, 1.6347826086957, 1.1934782608696, 0
26500, 1.6782608695652, 1.1934782608696, 0
26501, 1.7217391304348, 1.1934782608696, 0
26502, 1.7652173913043, 1.1934782608696, 0
26503, 1.8086956521739, 1.1934782608696, 0
26504, 1.8521739130435, 1.1934782608696, 0
26505, 1.895652173913, 1.1934782608696, 0
26506, 1.9391304347826, 1.1934782608696, 0
26507, 1.9826086956522, 1.1934782608696, 0
26508, 2.0260869565217, 1.1934782608696, 0
26509, 2.0695652173913, 1.1934782608696, 0
26510, 2.1130434782609, 1.1934782608696, 0
26511, 2.1565217391304, 1.1934782608696, 0
26512, 1.2434782608696, 1.1413043478261, 0
26513, 1.2869565217391, 1.1413043478261, 0
26514, 1.3304347826087, 1.1413043478261, 0
26515, 1.3739130434783, 1.1413043478261, 0
26516, 1.4173913043478, 1.1413043478261, 0
26517, 1.4608695652174, 1.1413043478261, 0
26518, 1.504347826087, 1.1413043478261, 0
26519, 1.5478260869565, 1.1413043478261, 0
26520, 1.5913043478261, 1.1413043478261, 0
26521, 1.6347826086957, 1.1413043478261, 0
26522, 1.6782608695652, 1.1413043478261, 0
26523, 1.7217391304348, 1.1413043478261, 0
26524, 1.7652173913043, 1.1413043478261, 0
26525, 1.8086956521739, 1.1413043478261, 0
26526, 1.8521739130435, 1.1413043478261, 0
26527, 1.895652173913, 1.1413043478261, 0
26528, 1.9391304347826, 1.1413043478261, 0
26529, 1.9826086956522, 1.1413043478261, 0
26530, 2.0260869565217, 1.1413043478261, 0
26531, 2.0695652173913, 1.1413043478261, 0
26532, 2.1130434782609, 1.1413043478261, 0
26533, 2.1565217391304, 1.1413043478261, 0
26534, 1.2434782608696, 1.0891304347826, 0
26535, 1.2869565217391, 1.0891304347826, 0
26536, 1.3304347826087, 1.0891304347826, 0
26537, 1.3739130434783, 1.0891304347826, 0
26538, 1.4173913043478, 1.0891304347826, 0
26539, 1.4608695652174, 1.0891304347826, 0
26540, 1.504347826087, 1.0891304347826, 0
26541, 1.5478260869565, 1.0891304347826, 0
26542, 1.5913043478261, 1.0891304347826, 0
26543, 1.6347826086957, 1.0891304347826, 0
26544, 1.6782608695652, 1.0891304347826, 0
26545, 1.7217391304348, 1.0891304347826, 0
26546, 1.7652173913043, 1.0891304347826, 0
26547, 1.8086956521739, 1.0891304347826, 0
26548, 1.8521739130435, 1.0891304347826, 0
26549, 1.895652173913, 1.0891304347826, 0
26550, 1.9391304347826, 1.0891304347826, 0
26551, 1.9826086956522, 1.0891304347826, 0
26552, 2.0260869565217, 1.0891304347826, 0
26553, 2.0695652173913, 1.0891304347826, 0
26554, 2.1130434782609, 1.0891304347826, 0
26555, 2.1565217391304, 1.0891304347826, 0
26556, 1.2434782608696, 1.0369565217391, 0
26557, 1.2869565217391, 1.0369565217391, 0
26558, 1.3304347826087, 1.0369565217391, 0
26559, 1.3739130434783, 1.0369565217391, 0
26560, 1.4173913043478, 1.0369565217391, 0
26561, 1.4608695652174, 1.0369565217391, 0
26562, 1.504347826087, 1.0369565217391, 0
26563, 1.5478260869565, 1.0369565217391, 0
26564, 1.5913043478261, 1.0369565217391, 0
26565, 1.6347826086957, 1.0369565217391, 0
26566, 1.6782608695652, 1.0369565217391, 0
26567, 1.7217391304348, 1.0369565217391, 0
26568, 1.7652173913043, 1.0369565217391, 0
26569, 1.8086956521739, 1.0369565217391, 0
26570, 1.8521739130435, 1.0369565217391, 0
26571, 1.895652173913, 1.0369565217391, 0
26572, 1.9391304347826, 1.0369565217391, 0
26573, 1.9826086956522, 1.0369565217391, 0
26574, 2.0260869565217, 1.0369565217391, 0
26575, 2.0695652173913, 1.0369565217391, 0
26576, 2.1130434782609, 1.0369565217391, 0
26577, 2.1565217391304, 1.0369565217391, 0
26578, 1.2434782608696, 0.98478260869565, 0
26579, 1.2869565217391, 0.98478260869565, 0
26580, 1.3304347826087, 0.98478260869565, 0
26581, 1.3739130434783, 0.98478260869565, 0
26582, 1.4173913043478, 0.98478260869565, 0
26583, 1.4608695652174, 0.98478260869565, 0
26584, 1.504347826087, 0.98478260869565, 0
26585, 1.5478260869565, 0.98478260869565, 0
26586, 1.5913043478261, 0.98478260869565, 0
26587, 1.6347826086957, 0.98478260869565, 0
26588, 1.6782608695652, 0.98478260869565, 0
26589, 1.7217391304348, 0.98478260869565, 0
26590, 1.7652173913043, 0.98478260869565, 0
