35772, 1.8521739130435, 0.8804347826087, -0.075
35773, 1.895652173913, 0.8804347826087, -0.075
35774, 1.9391304347826, 0.8804347826087, -0.075
35775, 1.9826086956522, 0.8804347826087, -0.075
35776, 2.0260869565217, 0.8804347826087, -0.075
35777, 2.0695652173913, 0.8804347826087, -0.075
35778, 2.1130434782609, 0.8804347826087, -0.075
35779, 2.1565217391304, 0.8804347826087, -0.075
35780, 1.2434782608696, 0.82826086956522, -0.075
35781, 1.2869565217391, 0.82826086956522, -0.075
35782, 1.3304347826087, 0.82826086956522, -0.075
35783, 1.3739130434783, 0.82826086956522, -0.075
35784, 1.4173913043478, 0.82826086956522, -0.075
35785, 1.4608695652174, 0.82826086956522, -0.075
35786, 1.504347826087, 0.82826086956522, -0.075
35787, 1.5478260869565, 0.82826086956522, -0.075
35788, 1.5913043478261, 0.82826086956522, -0.075
35789, 1.6347826086957, 0.82826086956522, -0.075
35790, 1.6782608695652, 0.82826086956522, -0.075
35791, 1.7217391304348, 0.82826086956522, -0.075
35792, 1.7652173913043, 0.82826086956522, -0.075
35793, 1.8086956521739, 0.82826086956522, -0.075
35794, 1.8521739130435, 0.82826086956522, -0.075
35795, 1.895652173913, 0.82826086956522, -0.075
35796, 1.9391304347826, 0.82826086956522, -0.075
35797, 1.9826086956522, 0.82826086956522, -0.075
35798, 2.0260869565217, 0.82826086956522, -0.075
35799, 2.0695652173913, 0.82826086956522, -0.075
35800, 2.1130434782609, 0.82826086956522, -0.075
35801, 2.1565217391304, 0.82826086956522, -0.075
35802, 1.2434782608696, 0.77608695652174, -0.075
35803, 1.2869565217391, 0.77608695652174, -0.075
35804, 1.3304347826087, 0.77608695652174, -0.075
35805, 1.3739130434783, 0.77608695652174, -0.075
35806, 1.4173913043478, 0.77608695652174, -0.075
35807, 1.4608695652174, 0.77608695652174, -0.075
35808, 1.504347826087, 0.77608695652174, -0.075
35809, 1.5478260869565, 0.77608695652174, -0.075
35810, 1.5913043478261, 0.77608695652174, -0.075
35811, 1.6347826086957, 0.77608695652174, -0.075
35812, 1.6782608695652, 0.77608695652174, -0.075
35813, 1.7217391304348, 0.77608695652174, -0.075
35814, 1.7652173913043, 0.77608695652174, -0.075
35815, 1.8086956521739, 0.77608695652174, -0.075
35816, 1.8521739130435, 0.77608695652174, -0.075
35817, 1.895652173913, 0.77608695652174, -0.075
35818, 1.9391304347826, 0.77608695652174, -0.075
35819, 1.9826086956522, 0.77608695652174, -0.075
35820, 2.0260869565217, 0.77608695652174, -0.075
35821, 2.0695652173913, 0.77608695652174, -0.075
35822, 2.1130434782609, 0.77608695652174, -0.075
35823, 2.1565217391304, 0.77608695652174, -0.075
35824, 1.2434782608696, 0.72391304347826, -0.075
35825, 1.2869565217391, 0.72391304347826, -0.075
35826, 1.3304347826087, 0.72391304347826, -0.075
35827, 1.3739130434783, 0.72391304347826, -0.075
35828, 1.4173913043478, 0.72391304347826, -0.075
35829, 1.4608695652174, 0.72391304347826, -0.075
35830, 1.504347826087, 0.72391304347826, -0.075
35831, 1.5478260869565, 0.72391304347826, -0.075
35832, 1.5913043478261, 0.72391304347826, -0.075
35833, 1.6347826086957, 0.72391304347826, -0.075
35834, 1.6782608695652, 0.72391304347826, -0.075
35835, 1.7217391304348, 0.72391304347826, -0.075
35836, 1.7652173913043, 0.72391304347826, -0.075
35837, 1.8086956521739, 0.72391304347826, -0.075
35838, 1.8521739130435, 0.72391304347826, -0.075
35839, 1.895652173913, 0.72391304347826, -0.075
35840, 1.9391304347826, 0.72391304347826, -0.075
35841, 1.9826086956522, 0.72391304347826, -0.075
35842, 2.0260869565217, 0.72391304347826, -0.075
35843, 2.0695652173913, 0.72391304347826, -0.075
35844, 2.1130434782609, 0.72391304347826, -0.075
35845, 2.1565217391304, 0.72391304347826, -0.075
35846, 1.2434782608696, 0.67173913043478, -0.075
35847, 1.2869565217391, 0.67173913043478, -0.075
35848, 1.3304347826087, 0.67173913043478, -0.075
35849, 1.3739130434783, 0.67173913043478, -0.075
35850, 1.4173913043478, 0.67173913043478, -0.075
35851, 1.4608695652174, 0.67173913043478, -0.075
35852, 1.504347826087, 0.67173913043478, -0.075
35853, 1.5478260869565, 0.67173913043478, -0.075
35854, 1.5913043478261, 0.67173913043478, -0.075
35855, 1.6347826086957, 0.67173913043478, -0.075
35856, 1.6782608695652, 0.67173913043478, -0.075
35857, 1.7217391304348, 0.67173913043478, -0.075
35858, 1.7652173913043, 0.67173913043478, -0.075
35859, 1.8086956521739, 0.67173913043478, -0.075
35860, 1.8521739130435, 0.67173913043478, -0.075
35861, 1.895652173913, 0.67173913043478, -0.075
35862, 1.9391304347826, 0.67173913043478, -0.075
35863, 1.9826086956522, 0.67173913043478, -0.075
35864, 2.0260869565217, 0.67173913043478, -0.075
35865, 2.0695652173913, 0.67173913043478, -0.075
35866, 2.1130434782609, 0.67173913043478, -0.075
35867, 2.1565217391304, 0.67173913043478, -0.075
35868, 1.2434782608696, 0.61956521739131, -0.075
35869, 1.2869565217391, 0.61956521739131, -0.075
35870, 1.3304347826087, 0.61956521739131, -0.075
35871, 1.3739130434783, 0.61956521739131, -0.075
35872, 1.4173913043478, 0.61956521739131, -0.075
35873, 1.4608695652174, 0.61956521739131, -0.075
35874, 1.504347826087, 0.6195652173913, -0.075
35875, 1.5478260869565, 0.61956521739131, -0.075
35876, 1.5913043478261, 0.61956521739131, -0.075
35877, 1.6347826086957, 0.61956521739131, -0.075
35878, 1.6782608695652, 0.61956521739131, -0.075
35879, 1.7217391304348, 0.61956521739131, -0.075
35880, 1.7652173913043, 0.61956521739131, -0.075
35881, 1.8086956521739, 0.61956521739131, -0.075
35882, 1.8521739130435, 0.61956521739131, -0.075
35883, 1.895652173913, 0.61956521739131, -0.075
35884, 1.9391304347826, 0.61956521739131, -0.075
35885, 1.9826086956522, 0.61956521739131, -0.075
35886, 2.0260869565217, 0.61956521739131, -0.075
35887, 2.0695652173913, 0.61956521739131, -0.075
35888, 2.1130434782609, 0.61956521739131, -0.075
35889, 2.1565217391304, 0.61956521739131, -0.075
35890, 1.2434782608696, 0.56739130434783, -0.075
35891, 1.2869565217391, 0.56739130434783, -0.075
35892, 1.3304347826087, 0.56739130434783, -0.075
35893, 1.3739130434783, 0.56739130434783, -0.075
35894, 1.4173913043478, 0.56739130434783, -0.075
35895, 1.4608695652174, 0.56739130434783, -0.075
35896, 1.504347826087, 0.56739130434783, -0.075
35897, 1.5478260869565, 0.56739130434783, -0.075
35898, 1.5913043478261, 0.56739130434783, -0.075
35899, 1.6347826086957, 0.56739130434783, -0.075
35900, 1.6782608695652, 0.56739130434783, -0.075
35901, 1.7217391304348, 0.56739130434783, -0.075
35902, 1.7652173913043, 0.56739130434783, -0.075
35903, 1.8086956521739, 0.56739130434783, -0.075
35904, 1.8521739130435, 0.56739130434783, -0.075
35905, 1.895652173913, 0.56739130434783, -0.075
35906, 1.9391304347826, 0.56739130434783, -0.075
35907, 1.9826086956522, 0.56739130434783, -0.075
35908, 2.0260869565217, 0.56739130434783, -0.075
35909, 2.0695652173913, 0.56739130434783, -0.075
35910, 2.1130434782609, 0.56739130434783, -0.075
35911, 2.1565217391304, 0.56739130434783, -0.075
35912, 1.2434782608696, 0.51521739130435, -0.075
35913, 1.2869565217391, 0.51521739130435, -0.075
35914, 1.3304347826087, 0.51521739130435, -0.075
35915, 1.3739130434783, 0.51521739130435, -0.075
35916, 1.4173913043478, 0.51521739130435, -0.075
35917, 1.4608695652174, 0.51521739130435, -0.075
35918, 1.504347826087, 0.51521739130435, -0.075
35919, 1.5478260869565, 0.51521739130435, -0.075
35920, 1.5913043478261, 0.51521739130435, -0.075
35921, 1.6347826086957, 0.51521739130435, -0.075
35922, 1.6782608695652, 0.51521739130435, -0.075
35923, 1.7217391304348, 0.51521739130435, -0.075
35924, 1.7652173913043, 0.51521739130435, -0.075
35925, 1.8086956521739, 0.51521739130435, -0.075
35926, 1.8521739130435, 0.51521739130435, -0.075
35927, 1.895652173913, 0.51521739130435, -0.075
35928, 1.9391304347826, 0.51521739130435, -0.075
35929, 1.9826086956522, 0.51521739130435, -0.075
35930, 2.0260869565217, 0.51521739130435, -0.075
35931, 2.0695652173913, 0.51521739130435, -0.075
35932, 2.1130434782609, 0.51521739130435, -0.075
35933, 2.1565217391304, 0.51521739130435, -0.075
35934, 1.2434782608696, 0.46304347826087, -0.075
35935, 1.2869565217391, 0.46304347826087, -0.075
35936, 1.3304347826087, 0.46304347826087, -0.075
35937, 1.3739130434783, 0.46304347826087, -0.075
35938, 1.4173913043478, 0.46304347826087, -0.075
35939, 1.4608695652174, 0.46304347826087, -0.075
35940, 1.504347826087, 0.46304347826087, -0.075
35941, 1.5478260869565, 0.46304347826087, -0.075
35942, 1.5913043478261, 0.46304347826087, -0.075
35943, 1.6347826086957, 0.46304347826087, -0.075
35944, 1.6782608695652, 0.46304347826087, -0.075
35945, 1.7217391304348, 0.46304347826087, -0.075
35946, 1.7652173913043, 0.46304347826087, -0.075
35947, 1.8086956521739, 0.46304347826087, -0.075
35948, 1.8521739130435, 0.46304347826087, -0.075
35949, 1.895652173913, 0.46304347826087, -0.075
35950, 1.9391304347826, 0.46304347826087, -0.075
35951, 1.9826086956522, 0.46304347826087, -0.075
35952, 2.0260869565217, 0.46304347826087, -0.075
35953, 2.0695652173913, 0.46304347826087, -0.075
35954, 2.1130434782609, 0.46304347826087, -0.075
35955, 2.1565217391304, 0.46304347826087, -0.075
35956, 1.2434782608696, 0.41086956521739, -0.075
35957, 1.2869565217391, 0.41086956521739, -0.075
35958, 1.3304347826087, 0.41086956521739, -0.075
35959, 1.3739130434783, 0.41086956521739, -0.075
35960, 1.4173913043478, 0.41086956521739, -0.075
35961, 1.4608695652174, 0.41086956521739, -0.075
35962, 1.504347826087, 0.41086956521739, -0.075
35963, 1.5478260869565, 0.41086956521739, -0.075
35964, 1.5913043478261, 0.41086956521739, -0.075
35965, 1.6347826086957, 0.41086956521739, -0.075
35966, 1.6782608695652, 0.41086956521739, -0.075
35967, 1.7217391304348, 0.41086956521739, -0.075
35968, 1.7652173913043, 0.41086956521739, -0.075
35969, 1.8086956521739, 0.41086956521739, -0.075
35970, 1.8521739130435, 0.41086956521739, -0.075
35971, 1.895652173913, 0.41086956521739, -0.075
35972, 1.9391304347826, 0.41086956521739, -0.075
35973, 1.9826086956522, 0.41086956521739, -0.075
35974, 2.0260869565217, 0.41086956521739, -0.075
35975, 2.0695652173913, 0.41086956521739, -0.075
35976, 2.1130434782609, 0.41086956521739, -0.075
35977, 2.1565217391304, 0.41086956521739, -0.075
35978, 1.2434782608696, 0.35869565217391, -0.075
35979, 1.2869565217391, 0.35869565217391, -0.075
35980, 1.3304347826087, 0.35869565217391, -0.075
35981, 1.3739130434783, 0.35869565217391, -0.075
35982, 1.4173913043478, 0.35869565217391, -0.075
35983, 1.4608695652174, 0.35869565217391, -0.075
35984, 1.504347826087, 0.35869565217391, -0.075
35985, 1.5478260869565, 0.35869565217391, -0.075
35986, 1.5913043478261, 0.35869565217391, -0.075
35987, 1.6347826086957, 0.35869565217391, -0.075
35988, 1.6782608695652, 0.35869565217391, -0.075
35989, 1.7217391304348, 0.35869565217391, -0.075
35990, 1.7652173913043, 0.35869565217391, -0.075
35991, 1.8086956521739, 0.35869565217391, -0.075
35992, 1.8521739130435, 0.35869565217391, -0.075
35993, 1.895652173913, 0.35869565217391, -0.075
35994, 1.9391304347826, 0.35869565217391, -0.075
35995, 1.9826086956522, 0.35869565217391, -0.075
35996, 2.0260869565217, 0.35869565217391, -0.075
35997, 2.0695652173913, 0.35869565217391, -0.075
35998, 2.1130434782609, 0.35869565217391, -0.075
35999, 2.1565217391304, 0.35869565217391, -0.075
36000, 1.2434782608696, 0.30652173913044, -0.075
36001, 1.2869565217391, 0.30652173913043, -0.075
36002, 1.3304347826087, 0.30652173913043, -0.075
36003, 1.3739130434783, 0.30652173913044, -0.075
36004, 1.4173913043478, 0.30652173913044, -0.075
36005, 1.4608695652174, 0.30652173913043, -0.075
36006, 1.504347826087, 0.30652173913044, -0.075
36007, 1.5478260869565, 0.30652173913044, -0.075
36008, 1.5913043478261, 0.30652173913044, -0.075
36009, 1.6347826086957, 0.30652173913043, -0.075
36010, 1.6782608695652, 0.30652173913043, -0.075
36011, 1.7217391304348, 0.30652173913043, -0.075
36012, 1.7652173913043, 0.30652173913043, -0.075
36013, 1.8086956521739, 0.30652173913044, -0.075
36014, 1.8521739130435, 0.30652173913043, -0.075
36015, 1.895652173913, 0.30652173913044, -0.075
36016, 1.9391304347826, 0.30652173913043, -0.075
36017, 1.9826086956522, 0.30652173913044, -0.075
36018, 2.0260869565217, 0.30652173913044, -0.075
36019, 2.0695652173913, 0.30652173913043, -0.075
36020, 2.1130434782609, 0.30652173913043, -0.075
36021, 2.1565217391304, 0.30652173913043, -0.075
36022, 1.2434782608696, 0.25434782608696, -0.075
36023, 1.2869565217391, 0.25434782608696, -0.075
36024, 1.3304347826087, 0.25434782608696, -0.075
36025, 1.3739130434783, 0.25434782608696, -0.075
36026, 1.4173913043478, 0.25434782608696, -0.075
36027, 1.4608695652174, 0.25434782608696, -0.075
36028, 1.504347826087, 0.25434782608696, -0.075
36029, 1.5478260869565, 0.25434782608696, -0.075
36030, 1.5913043478261, 0.25434782608696, -0.075
36031, 1.6347826086957, 0.25434782608696, -0.075
36032, 1.6782608695652, 0.25434782608696, -0.075
36033, 1.7217391304348, 0.25434782608696, -0.075
36034, 1.7652173913043, 0.25434782608696, -0.075
36035, 1.8086956521739, 0.25434782608696, -0.075
36036, 1.8521739130435, 0.25434782608696, -0.075
36037, 1.895652173913, 0.25434782608696, -0.075
36038, 1.9391304347826, 0.25434782608696, -0.075
36039, 1.9826086956522, 0.25434782608696, -0.075
36040, 2.0260869565217, 0.25434782608696, -0.075
36041, 2.0695652173913, 0.25434782608696, -0.075
36042, 2.1130434782609, 0.25434782608696, -0.075
36043, 2.1565217391304, 0.25434782608696, -0.075
36044, 1.2434782608696, 0.20217391304348, -0.075
36045, 1.2869565217391, 0.20217391304348, -0.075
36046, 1.3304347826087, 0.20217391304348, -0.075
36047, 1.3739130434783, 0.20217391304348, -0.075
36048, 1.4173913043478, 0.20217391304348, -0.075
36049, 1.4608695652174, 0.20217391304348, -0.075
36050, 1.504347826087, 0.20217391304348, -0.075
36051, 1.5478260869565, 0.20217391304348, -0.075
36052, 1.5913043478261, 0.20217391304348, -0.075
36053, 1.6347826086957, 0.20217391304348, -0.075
36054, 1.6782608695652, 0.20217391304348, -0.075
36055, 1.7217391304348, 0.20217391304348, -0.075
36056, 1.7652173913043, 0.20217391304348, -0.075
36057, 1.8086956521739, 0.20217391304348, -0.075
36058, 1.8521739130435, 0.20217391304348, -0.075
36059, 1.895652173913, 0.20217391304348, -0.075
36060, 1.9391304347826, 0.20217391304348, -0.075
36061, 1.9826086956522, 0.20217391304348, -0.075
36062, 2.0260869565217, 0.20217391304348, -0.075
36063, 2.0695652173913, 0.20217391304348, -0.075
36064, 2.1130434782609, 0.20217391304348, -0.075
36065, 2.1565217391304, 0.20217391304348, -0.075
36066, 1.2434782608696, 1.3239130434783, -0.075
36067, 1.2217391304348, 1.2978260869565, -0.075
36068, 1.2869565217391, 1.3239130434783, -0.075
36069, 1.2652173913043, 1.2978260869565, -0.075
36070, 1.3304347826087, 1.3239130434783, -0.075
36071, 1.3086956521739, 1.2978260869565, -0.075
36072, 1.3739130434783, 1.3239130434783, -0.075
36073, 1.3521739130435, 1.2978260869565, -0.075
36074, 1.4173913043478, 1.3239130434783, -0.075
36075, 1.395652173913, 1.2978260869565, -0.075
36076, 1.4608695652174, 1.3239130434783, -0.075
36077, 1.4391304347826, 1.2978260869565, -0.075
36078, 1.504347826087, 1.3239130434783, -0.075
36079, 1.4826086956522, 1.2978260869565, -0.075
36080, 1.5478260869565, 1.3239130434783, -0.075
36081, 1.5260869565217, 1.2978260869565, -0.075
36082, 1.5913043478261, 1.3239130434783, -0.075
36083, 1.5695652173913, 1.2978260869565, -0.075
36084, 1.6347826086957, 1.3239130434783, -0.075
36085, 1.6130434782609, 1.2978260869565, -0.075
36086, 1.6782608695652, 1.3239130434783, -0.075
36087, 1.6565217391304, 1.2978260869565, -0.075
36088, 1.7217391304348, 1.3239130434783, -0.075
36089, 1.7, 1.2978260869565, -0.075
36090, 1.7652173913043, 1.3239130434783, -0.075
36091, 1.7434782608696, 1.2978260869565, -0.075
36092, 1.8086956521739, 1.3239130434783, -0.075
36093, 1.7869565217391, 1.2978260869565, -0.075
36094, 1.8521739130435, 1.3239130434783, -0.075
36095, 1.8304347826087, 1.2978260869565, -0.075
36096, 1.895652173913, 1.3239130434783, -0.075
36097, 1.8739130434783, 1.2978260869565, -0.075
36098, 1.9391304347826, 1.3239130434783, -0.075
36099, 1.9173913043478, 1.2978260869565, -0.075
36100, 1.9826086956522, 1.3239130434783, -0.075
36101, 1.9608695652174, 1.2978260869565, -0.075
36102, 2.0260869565217, 1.3239130434783, -0.075
36103, 2.004347826087, 1.2978260869565, -0.075
36104, 2.0695652173913, 1.3239130434783, -0.075
36105, 2.0478260869565, 1.2978260869565, -0.075
36106, 2.1130434782609, 1.3239130434783, -0.075
36107, 2.0913043478261, 1.2978260869565, -0.075
36108, 2.1565217391304, 1.3239130434783, -0.075
36109, 2.1347826086957, 1.2978260869565, -0.075
36110, 2.1782608695652, 1.2978260869565, -0.075
36111, 1.2434782608696, 1.2717391304348, -0.075
36112, 1.2217391304348, 1.245652173913, -0.075
36113, 1.2869565217391, 1.2717391304348, -0.075
36114, 1.2652173913043, 1.245652173913, -0.075
36115, 1.3304347826087, 1.2717391304348, -0.075
36116, 1.3086956521739, 1.245652173913, -0.075
36117, 1.3739130434783, 1.2717391304348, -0.075
36118, 1.3521739130435, 1.245652173913, -0.075
36119, 1.4173913043478, 1.2717391304348, -0.075
36120, 1.395652173913, 1.245652173913, -0.075
36121, 1.4608695652174, 1.2717391304348, -0.075
36122, 1.4391304347826, 1.245652173913, -0.075
36123, 1.504347826087, 1.2717391304348, -0.075
36124, 1.4826086956522, 1.245652173913, -0.075
36125, 1.5478260869565, 1.2717391304348, -0.075
36126, 1.5260869565217, 1.245652173913, -0.075
36127, 1.5913043478261, 1.2717391304348, -0.075
36128, 1.5695652173913, 1.245652173913, -0.075
36129, 1.6347826086957, 1.2717391304348, -0.075
36130, 1.6130434782609, 1.245652173913, -0.075
36131, 1.6782608695652, 1.2717391304348, -0.075
36132, 1.6565217391304, 1.245652173913, -0.075
36133, 1.7217391304348, 1.2717391304348, -0.075
36134, 1.7, 1.245652173913, -0.075
36135, 1.7652173913043, 1.2717391304348, -0.075
36136, 1.7434782608696, 1.245652173913, -0.075
36137, 1.8086956521739, 1.2717391304348, -0.075
36138, 1.7869565217391, 1.245652173913, -0.075
36139, 1.8521739130435, 1.2717391304348, -0.075
36140, 1.8304347826087, 1.245652173913, -0.075
36141, 1.895652173913, 1.2717391304348, -0.075
36142, 1.8739130434783, 1.245652173913, -0.075
36143, 1.9391304347826, 1.2717391304348, -0.075
36144, 1.9173913043478, 1.245652173913, -0.075
36145, 1.9826086956522, 1.2717391304348, -0.075
36146, 1.9608695652174, 1.245652173913, -0.075
36147, 2.0260869565217, 1.2717391304348, -0.075
36148, 2.004347826087, 1.245652173913, -0.075
36149, 2.0695652173913, 1.2717391304348, -0.075
36150, 2.0478260869565, 1.245652173913, -0.075
36151, 2.1130434782609, 1.2717391304348, -0.075
36152, 2.0913043478261, 1.245652173913, -0.075
36153, 2.1565217391304, 1.2717391304348, -0.075
36154, 2.1347826086957, 1.245652173913, -0.075
36155, 2.1782608695652, 1.245652173913, -0.075
36156, 1.2434782608696, 1.2195652173913, -0.075
36157, 1.2217391304348, 1.1934782608696, -0.075
36158, 1.2869565217391, 1.2195652173913, -0.075
36159, 1.2652173913043, 1.1934782608696, -0.075
36160, 1.3304347826087, 1.2195652173913, -0.075
36161, 1.3086956521739, 1.1934782608696, -0.075
36162, 1.3739130434783, 1.2195652173913, -0.075
36163, 1.3521739130435, 1.1934782608696, -0.075
36164, 1.4173913043478, 1.2195652173913, -0.075
36165, 1.395652173913, 1.1934782608696, -0.075
36166, 1.4608695652174, 1.2195652173913, -0.075
36167, 1.4391304347826, 1.1934782608696, -0.075
36168, 1.504347826087, 1.2195652173913, -0.075
36169, 1.4826086956522, 1.1934782608696, -0.075
36170, 1.5478260869565, 1.2195652173913, -0.075
36171, 1.5260869565217, 1.1934782608696, -0.075
36172, 1.5913043478261, 1.2195652173913, -0.075
36173, 1.5695652173913, 1.1934782608696, -0.075
36174, 1.6347826086957, 1.2195652173913, -0.075
36175, 1.6130434782609, 1.1934782608696, -0.075
36176, 1.6782608695652, 1.2195652173913, -0.075
36177, 1.6565217391304, 1.1934782608696, -0.075
36178, 1.7217391304348, 1.2195652173913, -0.075
36179, 1.7, 1.1934782608696, -0.075
36180, 1.7652173913043, 1.2195652173913, -0.075
36181, 1.7434782608696, 1.1934782608696, -0.075
36182, 1.8086956521739, 1.2195652173913, -0.075
36183, 1.7869565217391, 1.1934782608696, -0.075
36184, 1.8521739130435, 1.2195652173913, -0.075
36185, 1.8304347826087, 1.1934782608696, -0.075
36186, 1.895652173913, 1.2195652173913, -0.075
36187, 1.8739130434783, 1.1934782608696, -0.075
36188, 1.9391304347826, 1.2195652173913, -0.075
36189, 1.9173913043478, 1.1934782608696, -0.075
36190, 1.9826086956522, 1.2195652173913, -0.075
36191, 1.9608695652174, 1.1934782608696, -0.075
36192, 2.0260869565217, 1.2195652173913, -0.075
36193, 2.004347826087, 1.1934782608696, -0.075
36194, 2.0695652173913, 1.2195652173913, -0.075
36195, 2.0478260869565, 1.1934782608696, -0.075
36196, 2.1130434782609, 1.2195652173913, -0.075
36197, 2.0913043478261, 1.1934782608696, -0.075
36198, 2.1565217391304, 1.2195652173913, -0.075
36199, 2.1347826086957, 1.1934782608696, -0.075
36200, 2.1782608695652, 1.1934782608696, -0.075
36201, 1.2434782608696, 1.1673913043478, -0.075
36202, 1.2217391304348, 1.1413043478261, -0.075
36203, 1.2869565217391, 1.1673913043478, -0.075
36204, 1.2652173913043, 1.1413043478261, -0.075
36205, 1.3304347826087, 1.1673913043478, -0.075
36206, 1.3086956521739, 1.1413043478261, -0.075
36207, 1.3739130434783, 1.1673913043478, -0.075
36208, 1.3521739130435, 1.1413043478261, -0.075
36209, 1.4173913043478, 1.1673913043478, -0.075
36210, 1.395652173913, 1.1413043478261, -0.075
36211, 1.4608695652174, 1.1673913043478, -0.075
36212, 1.4391304347826, 1.1413043478261, -0.075
36213, 1.504347826087, 1.1673913043478, -0.075
36214, 1.4826086956522, 1.1413043478261, -0.075
36215, 1.5478260869565, 1.1673913043478, -0.075
36216, 1.5260869565217, 1.1413043478261, -0.075
36217, 1.5913043478261, 1.1673913043478, -0.075
36218, 1.5695652173913, 1.1413043478261, -0.075
36219, 1.6347826086957, 1.1673913043478, -0.075
36220, 1.6130434782609, 1.1413043478261, -0.075
36221, 1.6782608695652, 1.1673913043478, -0.075
36222, 1.6565217391304, 1.1413043478261, -0.075
36223, 1.7217391304348, 1.1673913043478, -0.075
36224, 1.7, 1.1413043478261, -0.075
36225, 1.7652173913043, 1.1673913043478, -0.075
36226, 1.7434782608696, 1.1413043478261, -0.075
36227, 1.8086956521739, 1.1673913043478, -0.075
36228, 1.7869565217391, 1.1413043478261, -0.075
36229, 1.8521739130435, 1.1673913043478, -0.075
36230, 1.8304347826087, 1.1413043478261, -0.075
36231, 1.895652173913, 1.1673913043478, -0.075
36232, 1.8739130434783, 1.1413043478261, -0.075
36233, 1.9391304347826, 1.1673913043478, -0.075
36234, 1.9173913043478, 1.1413043478261, -0.075
36235, 1.9826086956522, 1.1673913043478, -0.075
36236, 1.9608695652174, 1.1413043478261, -0.075
36237, 2.0260869565217, 1.1673913043478, -0.075
36238, 2.004347826087, 1.1413043478261, -0.075
36239, 2.0695652173913, 1.1673913043478, -0.075
36240, 2.0478260869565, 1.1413043478261, -0.075
36241, 2.1130434782609, 1.1673913043478, -0.075
36242, 2.0913043478261, 1.1413043478261, -0.075
36243, 2.1565217391304, 1.1673913043478, -0.075
36244, 2.1347826086957, 1.1413043478261, -0.075
36245, 2.1782608695652, 1.1413043478261, -0.075
36246, 1.2434782608696, 1.1152173913043, -0.075
36247, 1.2217391304348, 1.0891304347826, -0.075
36248, 1.2869565217391, 1.1152173913043, -0.075
36249, 1.2652173913043, 1.0891304347826, -0.075
36250, 1.3304347826087, 1.1152173913043, -0.075
36251, 1.3086956521739, 1.0891304347826, -0.075
36252, 1.3739130434783, 1.1152173913043, -0.075
36253, 1.3521739130435, 1.0891304347826, -0.075
36254, 1.4173913043478, 1.1152173913043, -0.075
36255, 1.395652173913, 1.0891304347826, -0.075
36256, 1.4608695652174, 1.1152173913043, -0.075
36257, 1.4391304347826, 1.0891304347826, -0.075
36258, 1.504347826087, 1.1152173913043, -0.075
36259, 1.4826086956522, 1.0891304347826, -0.075
36260, 1.5478260869565, 1.1152173913043, -0.075
36261, 1.5260869565217, 1.0891304347826, -0.075
36262, 1.5913043478261, 1.1152173913043, -0.075
36263, 1.5695652173913, 1.0891304347826, -0.075
36264, 1.6347826086957, 1.1152173913043, -0.075
36265, 1.6130434782609, 1.0891304347826, -0.075
36266, 1.6782608695652, 1.1152173913043, -0.075
36267, 1.6565217391304, 1.0891304347826, -0.075
36268, 1.7217391304348, 1.1152173913043, -0.075
36269, 1.7, 1.0891304347826, -0.075
36270, 1.7652173913043, 1.1152173913043, -0.075
36271, 1.7434782608696, 1.0891304347826, -0.075
36272, 1.8086956521739, 1.1152173913043, -0.075
36273, 1.7869565217391, 1.0891304347826, -0.075
36274, 1.8521739130435, 1.1152173913043, -0.075
36275, 1.8304347826087, 1.0891304347826, -0.075
36276, 1.895652173913, 1.1152173913043, -0.075
36277, 1.8739130434783, 1.0891304347826, -0.075
36278, 1.9391304347826, 1.1152173913043, -0.075
36279, 1.9173913043478, 1.0891304347826, -0.075
36280, 1.9826086956522, 1.1152173913043, -0.075
36281, 1.9608695652174, 1.0891304347826, -0.075
36282, 2.0260869565217, 1.1152173913043, -0.075
36283, 2.004347826087, 1.0891304347826, -0.075
36284, 2.0695652173913, 1.1152173913043, -0.075
36285, 2.0478260869565, 1.0891304347826, -0.075
36286, 2.1130434782609, 1.1152173913043, -0.075
36287, 2.0913043478261, 1.0891304347826, -0.075
36288, 2.1565217391304, 1.1152173913043, -0.075
36289, 2.1347826086957, 1.0891304347826, -0.075
36290, 2.1782608695652, 1.0891304347826, -0.075
36291, 1.2434782608696, 1.0630434782609, -0.075
36292, 1.2217391304348, 1.0369565217391, -0.075
36293, 1.2869565217391, 1.0630434782609, -0.075
36294, 1.2652173913043, 1.0369565217391, -0.075
36295, 1.3304347826087, 1.0630434782609, -0.075
36296, 1.3086956521739, 1.0369565217391, -0.075
36297, 1.3739130434783, 1.0630434782609, -0.075
36298, 1.3521739130435, 1.0369565217391, -0.075
36299, 1.4173913043478, 1.0630434782609, -0.075
36300, 1.395652173913, 1.0369565217391, -0.075
36301, 1.4608695652174, 1.0630434782609, -0.075
36302, 1.4391304347826, 1.0369565217391, -0.075
36303, 1.504347826087, 1.0630434782609, -0.075
36304, 1.4826086956522, 1.0369565217391, -0.075
36305, 1.5478260869565, 1.0630434782609, -0.075
36306, 1.5260869565217, 1.0369565217391, -0.075
36307, 1.5913043478261, 1.0630434782609, -0.075
36308, 1.5695652173913, 1.0369565217391, -0.075
36309, 1.6347826086957, 1.0630434782609, -0.075
36310, 1.6130434782609, 1.0369565217391, -0.075
36311, 1.6782608695652, 1.0630434782609, -0.075
36312, 1.6565217391304, 1.0369565217391, -0.075
36313, 1.7217391304348, 1.0630434782609, -0.075
36314, 1.7, 1.0369565217391, -0.075
36315, 1.7652173913043, 1.0630434782609, -0.075
36316, 1.7434782608696, 1.0369565217391, -0.075
36317, 1.8086956521739, 1.0630434782609, -0.075
36318, 1.7869565217391, 1.0369565217391, -0.075
36319, 1.8521739130435, 1.0630434782609, -0.075
36320, 1.8304347826087, 1.0369565217391, -0.075
36321, 1.895652173913, 1.0630434782609, -0.075
36322, 1.8739130434783, 1.0369565217391, -0.075
36323, 1.9391304347826, 1.0630434782609, -0.075
36324, 1.9173913043478, 1.0369565217391, -0.075
36325, 1.9826086956522, 1.0630434782609, -0.075
36326, 1.9608695652174, 1.0369565217391, -0.075
36327, 2.0260869565217, 1.0630434782609, -0.075
36328, 2.004347826087, 1.0369565217391, -0.075
36329, 2.0695652173913, 1.0630434782609, -0.075
36330, 2.0478260869565, 1.0369565217391, -0.075
36331, 2.1130434782609, 1.0630434782609, -0.075
36332, 2.0913043478261, 1.0369565217391, -0.075
36333, 2.1565217391304, 1.0630434782609, -0.075
36334, 2.1347826086957, 1.0369565217391, -0.075
36335, 2.1782608695652, 1.0369565217391, -0.075
36336, 1.2434782608696, 1.0108695652174, -0.075
36337, 1.2217391304348, 0.98478260869565, -0.075
36338, 1.2869565217391, 1.0108695652174, -0.075
36339, 1.2652173913043, 0.98478260869565, -0.075
36340, 1.3304347826087, 1.0108695652174, -0.075
36341, 1.3086956521739, 0.98478260869565, -0.075
36342, 1.3739130434783, 1.0108695652174, -0.075
36343, 1.3521739130435, 0.98478260869565, -0.075
36344, 1.4173913043478, 1.0108695652174, -0.075
36345, 1.395652173913, 0.98478260869565, -0.075
36346, 1.4608695652174, 1.0108695652174, -0.075
36347, 1.4391304347826, 0.98478260869565, -0.075
36348, 1.504347826087, 1.0108695652174, -0.075
36349, 1.4826086956522, 0.98478260869565, -0.075
36350, 1.5478260869565, 1.0108695652174, -0.075
36351, 1.5260869565217, 0.98478260869565, -0.075
36352, 1.5913043478261, 1.0108695652174, -0.075
36353, 1.5695652173913, 0.98478260869565, -0.075
36354, 1.6347826086957, 1.0108695652174, -0.075
36355, 1.6130434782609, 0.98478260869565, -0.075
36356, 1.6782608695652, 1.0108695652174, -0.075
36357, 1.6565217391304, 0.98478260869565, -0.075
36358, 1.7217391304348, 1.0108695652174, -0.075
36359, 1.7, 0.98478260869565, -0.075
36360, 1.7652173913043, 1.0108695652174, -0.075
36361, 1.7434782608696, 0.98478260869565, -0.075
36362, 1.8086956521739, 1.0108695652174, -0.075
36363, 1.7869565217391, 0.98478260869565, -0.075
36364, 1.8521739130435, 1.0108695652174, -0.075
36365, 1.8304347826087, 0.98478260869565, -0.075
36366, 1.895652173913, 1.0108695652174, -0.075
36367, 1.8739130434783, 0.98478260869565, -0.075
36368, 1.9391304347826, 1.0108695652174, -0.075
36369, 1.9173913043478, 0.98478260869565, -0.075
36370, 1.9826086956522, 1.0108695652174, -0.075
36371, 1.9608695652174, 0.98478260869565, -0.075
36372, 2.0260869565217, 1.0108695652174, -0.075
36373, 2.004347826087, 0.98478260869565, -0.075
36374, 2.0695652173913, 1.0108695652174, -0.075
36375, 2.0478260869565, 0.98478260869565, -0.075
36376, 2.1130434782609, 1.0108695652174, -0.075
36377, 2.0913043478261, 0.98478260869565, -0.075
36378, 2.1565217391304, 1.0108695652174, -0.075
36379, 2.1347826086957, 0.98478260869565, -0.075
36380, 2.1782608695652, 0.98478260869565, -0.075
36381, 1.2434782608696, 0.95869565217391, -0.075
36382, 1.2217391304348, 0.93260869565217, -0.075
36383, 1.2869565217391, 0.95869565217391, -0.075
36384, 1.2652173913043, 0.93260869565217, -0.075
36385, 1.3304347826087, 0.95869565217391, -0.075
36386, 1.3086956521739, 0.93260869565217, -0.075
36387, 1.3739130434783, 0.95869565217391, -0.075
36388, 1.3521739130435, 0.93260869565217, -0.075
36389, 1.4173913043478, 0.95869565217391, -0.075
36390, 1.395652173913, 0.93260869565217, -0.075
36391, 1.4608695652174, 0.95869565217391, -0.075
36392, 1.4391304347826, 0.93260869565217, -0.075
36393, 1.504347826087, 0.95869565217391, -0.075
36394, 1.4826086956522, 0.93260869565217, -0.075
36395, 1.5478260869565, 0.95869565217391, -0.075
36396, 1.5260869565217, 0.93260869565217, -0.075
36397, 1.5913043478261, 0.95869565217391, -0.075
36398, 1.5695652173913, 0.93260869565217, -0.075
36399, 1.6347826086957, 0.95869565217391, -0.075
36400, 1.6130434782609, 0.93260869565217, -0.075
36401, 1.6782608695652, 0.95869565217391, -0.075
36402, 1.6565217391304, 0.93260869565217, -0.075
36403, 1.7217391304348, 0.95869565217391, -0.075
36404, 1.7, 0.93260869565217, -0.075
36405, 1.7652173913043, 0.95869565217391, -0.075
36406, 1.7434782608696, 0.93260869565217, -0.075
36407, 1.8086956521739, 0.95869565217391, -0.075
36408, 1.7869565217391, 0.93260869565217, -0.075
36409, 1.8521739130435, 0.95869565217391, -0.075
36410, 1.8304347826087, 0.93260869565217, -0.075
36411, 1.895652173913, 0.95869565217391, -0.075
36412, 1.8739130434783, 0.93260869565217, -0.075
36413, 1.9391304347826, 0.95869565217391, -0.075
36414, 1.9173913043478, 0.93260869565217, -0.075
36415, 1.9826086956522, 0.95869565217391, -0.075
36416, 1.9608695652174, 0.93260869565217, -0.075
36417, 2.0260869565217, 0.95869565217391, -0.075
36418, 2.004347826087, 0.93260869565217, -0.075
36419, 2.0695652173913, 0.95869565217391, -0.075
36420, 2.0478260869565, 0.93260869565217, -0.075
36421, 2.1130434782609, 0.95869565217391, -0.075
36422, 2.0913043478261, 0.93260869565217, -0.075
36423, 2.1565217391304, 0.95869565217391, -0.075
36424, 2.1347826086957, 0.93260869565217, -0.075
36425, 2.1782608695652, 0.93260869565217, -0.075
36426, 1.2434782608696, 0.90652173913044, -0.075
36427, 1.2217391304348, 0.8804347826087, -0.075
36428, 1.2869565217391, 0.90652173913044, -0.075
36429, 1.2652173913043, 0.8804347826087, -0.075
36430, 1.3304347826087, 0.90652173913044, -0.075
36431, 1.3086956521739, 0.8804347826087, -0.075
36432, 1.3739130434783, 0.90652173913044, -0.075
36433, 1.3521739130435, 0.8804347826087, -0.075
36434, 1.4173913043478, 0.90652173913044, -0.075
36435, 1.395652173913, 0.8804347826087, -0.075
36436, 1.4608695652174, 0.90652173913044, -0.075
36437, 1.4391304347826, 0.8804347826087, -0.075
36438, 1.504347826087, 0.90652173913044, -0.075
36439, 1.4826086956522, 0.8804347826087, -0.075
36440, 1.5478260869565, 0.90652173913044, -0.075
36441, 1.5260869565217, 0.8804347826087, -0.075
36442, 1.5913043478261, 0.90652173913044, -0.075
36443, 1.5695652173913, 0.8804347826087, -0.075
36444, 1.6347826086957, 0.90652173913044, -0.075
36445, 1.6130434782609, 0.8804347826087, -0.075
36446, 1.6782608695652, 0.90652173913044, -0.075
36447, 1.6565217391304, 0.8804347826087, -0.075
36448, 1.7217391304348, 0.90652173913044, -0.075
36449, 1.7, 0.8804347826087, -0.075
36450, 1.7652173913043, 0.90652173913044, -0.075
36451, 1.7434782608696, 0.8804347826087, -0.075
36452, 1.8086956521739, 0.90652173913044, -0.075
36453, 1.7869565217391, 0.8804347826087, -0.075
36454, 1.8521739130435, 0.90652173913044, -0.075
36455, 1.8304347826087, 0.8804347826087, -0.075
36456, 1.895652173913, 0.90652173913044, -0.075
36457, 1.8739130434783, 0.8804347826087, -0.075
36458, 1.9391304347826, 0.90652173913044, -0.075
36459, 1.9173913043478, 0.8804347826087, -0.075
36460, 1.9826086956522, 0.90652173913044, -0.075
36461, 1.9608695652174, 0.8804347826087, -0.075
36462, 2.0260869565217, 0.90652173913044, -0.075
36463, 2.004347826087, 0.8804347826087, -0.075
36464, 2.0695652173913, 0.90652173913044, -0.075
36465, 2.0478260869565, 0.8804347826087, -0.075
36466, 2.1130434782609, 0.90652173913044, -0.075
36467, 2.0913043478261, 0.8804347826087, -0.075
36468, 2.1565217391304, 0.90652173913044, -0.075
36469, 2.1347826086957, 0.8804347826087, -0.075
36470, 2.1782608695652, 0.8804347826087, -0.075
36471, 1.2434782608696, 0.85434782608696, -0.075
36472, 1.2217391304348, 0.82826086956522, -0.075
36473, 1.2869565217391, 0.85434782608696, -0.075
36474, 1.2652173913043, 0.82826086956522, -0.075
36475, 1.3304347826087, 0.85434782608696, -0.075
36476, 1.3086956521739, 0.82826086956522, -0.075
36477, 1.3739130434783, 0.85434782608696, -0.075
36478, 1.3521739130435, 0.82826086956522, -0.075
36479, 1.4173913043478, 0.85434782608696, -0.075
36480, 1.395652173913, 0.82826086956522, -0.075
36481, 1.4608695652174, 0.85434782608696, -0.075
36482, 1.4391304347826, 0.82826086956522, -0.075
36483, 1.504347826087, 0.85434782608696, -0.075
36484, 1.4826086956522, 0.82826086956522, -0.075
36485, 1.5478260869565, 0.85434782608696, -0.075
36486, 1.5260869565217, 0.82826086956522, -0.075
36487, 1.5913043478261, 0.85434782608696, -0.075
36488, 1.5695652173913, 0.82826086956522, -0.075
36489, 1.6347826086957, 0.85434782608696, -0.075
36490, 1.6130434782609, 0.82826086956522, -0.075
36491, 1.6782608695652, 0.85434782608696, -0.075
36492, 1.6565217391304, 0.82826086956522, -0.075
36493, 1.7217391304348, 0.85434782608696, -0.075
36494, 1.7, 0.82826086956522, -0.075
36495, 1.7652173913043, 0.85434782608696, -0.075
36496, 1.7434782608696, 0.82826086956522, -0.075
36497, 1.8086956521739, 0.85434782608696, -0.075
36498, 1.7869565217391, 0.82826086956522, -0.075
36499, 1.8521739130435, 0.85434782608696, -0.075
36500, 1.8304347826087, 0.82826086956522, -0.075
36501, 1.895652173913, 0.85434782608696, -0.075
36502, 1.8739130434783, 0.82826086956522, -0.075
36503, 1.9391304347826, 0.85434782608696, -0.075
36504, 1.9173913043478, 0.82826086956522, -0.075
36505, 1.9826086956522, 0.85434782608696, -0.075
36506, 1.9608695652174, 0.82826086956522, -0.075
36507, 2.0260869565217, 0.85434782608696, -0.075
36508, 2.004347826087, 0.82826086956522, -0.075
36509, 2.0695652173913, 0.85434782608696, -0.075
36510, 2.0478260869565, 0.82826086956522, -0.075
36511, 2.1130434782609, 0.85434782608696, -0.075
36512, 2.0913043478261, 0.82826086956522, -0.075
36513, 2.1565217391304, 0.85434782608696, -0.075
36514, 2.1347826086957, 0.82826086956522, -0.075
36515, 2.1782608695652, 0.82826086956522, -0.075
36516, 1.2434782608696, 0.80217391304348, -0.075
36517, 1.2217391304348, 0.77608695652174, -0.075
36518, 1.2869565217391, 0.80217391304348, -0.075
36519, 1.2652173913043, 0.77608695652174, -0.075
36520, 1.3304347826087, 0.80217391304348, -0.075
36521, 1.3086956521739, 0.77608695652174, -0.075
36522, 1.3739130434783, 0.80217391304348, -0.075
36523, 1.3521739130435, 0.77608695652174, -0.075
36524, 1.4173913043478, 0.80217391304348, -0.075
36525, 1.395652173913, 0.77608695652174, -0.075
36526, 1.4608695652174, 0.80217391304348, -0.075
36527, 1.4391304347826, 0.77608695652174, -0.075
36528, 1.504347826087, 0.80217391304348, -0.075
36529, 1.4826086956522, 0.77608695652174, -0.075
36530, 1.5478260869565, 0.80217391304348, -0.075
36531, 1.5260869565217, 0.77608695652174, -0.075
36532, 1.5913043478261, 0.80217391304348, -0.075
36533, 1.5695652173913, 0.77608695652174, -0.075
36534, 1.6347826086957, 0.80217391304348, -0.075
36535, 1.6130434782609, 0.77608695652174, -0.075
36536, 1.6782608695652, 0.80217391304348, -0.075
36537, 1.6565217391304, 0.77608695652174, -0.075
36538, 1.7217391304348, 0.80217391304348, -0.075
36539, 1.7, 0.77608695652174, -0.075
36540, 1.7652173913043, 0.80217391304348, -0.075
36541, 1.7434782608696, 0.77608695652174, -0.075
36542, 1.8086956521739, 0.80217391304348, -0.075
36543, 1.7869565217391, 0.77608695652174, -0.075
36544, 1.8521739130435, 0.80217391304348, -0.075
36545, 1.8304347826087, 0.77608695652174, -0.075
36546, 1.895652173913, 0.80217391304348, -0.075
36547, 1.8739130434783, 0.77608695652174, -0.075
36548, 1.9391304347826, 0.80217391304348, -0.075
36549, 1.9173913043478, 0.77608695652174, -0.075
36550, 1.9826086956522, 0.80217391304348, -0.075
36551, 1.9608695652174, 0.77608695652174, -0.075
36552, 2.0260869565217, 0.80217391304348, -0.075
36553, 2.004347826087, 0.77608695652174, -0.075
36554, 2.0695652173913, 0.80217391304348, -0.075
36555, 2.0478260869565, 0.77608695652174, -0.075
36556, 2.1130434782609, 0.80217391304348, -0.075
36557, 2.0913043478261, 0.77608695652174, -0.075
36558, 2.1565217391304, 0.80217391304348, -0.075
36559, 2.1347826086957, 0.77608695652174, -0.075
36560, 2.1782608695652, 0.77608695652174, -0.075
36561, 1.2434782608696, 0.75, -0.075
36562, 1.2217391304348, 0.72391304347826, -0.075
36563, 1.2869565217391, 0.75, -0.075
36564, 1.2652173913043, 0.72391304347826, -0.075
36565, 1.3304347826087, 0.75, -0.075
36566, 1.3086956521739, 0.72391304347826, -0.075
36567, 1.3739130434783, 0.75, -0.075
36568, 1.3521739130435, 0.72391304347826, -0.075
36569, 1.4173913043478, 0.75, -0.075
36570, 1.395652173913, 0.72391304347826, -0.075
36571, 1.4608695652174, 0.75, -0.075
36572, 1.4391304347826, 0.72391304347826, -0.075
36573, 1.504347826087, 0.75, -0.075
36574, 1.4826086956522, 0.72391304347826, -0.075
36575, 1.5478260869565, 0.75, -0.075
36576, 1.5260869565217, 0.72391304347826, -0.075
36577, 1.5913043478261, 0.75, -0.075
36578, 1.5695652173913, 0.72391304347826, -0.075
36579, 1.6347826086957, 0.75, -0.075
36580, 1.6130434782609, 0.72391304347826, -0.075
36581, 1.6782608695652, 0.75, -0.075
36582, 1.6565217391304, 0.72391304347826, -0.075
36583, 1.7217391304348, 0.75, -0.075
36584, 1.7, 0.72391304347826, -0.075
36585, 1.7652173913043, 0.75, -0.075
36586, 1.7434782608696, 0.72391304347826, -0.075
36587, 1.8086956521739, 0.75, -0.075
36588, 1.7869565217391, 0.72391304347826, -0.075
36589, 1.8521739130435, 0.75, -0.075
36590, 1.8304347826087, 0.72391304347826, -0.075
36591, 1.895652173913, 0.75, -0.075
36592, 1.8739130434783, 0.72391304347826, -0.075
36593, 1.9391304347826, 0.75, -0.075
36594, 1.9173913043478, 0.72391304347826, -0.075
36595, 1.9826086956522, 0.75, -0.075
36596, 1.9608695652174, 0.72391304347826, -0.075
36597, 2.0260869565217, 0.75, -0.075
36598, 2.004347826087, 0.72391304347826, -0.075
36599, 2.0695652173913, 0.75, -0.075
36600, 2.0478260869565, 0.72391304347826, -0.075
36601, 2.1130434782609, 0.75, -0.075
36602, 2.0913043478261, 0.72391304347826, -0.075
36603, 2.1565217391304, 0.75, -0.075
36604, 2.1347826086957, 0.72391304347826, -0.075
36605, 2.1782608695652, 0.72391304347826, -0.075
36606, 1.2434782608696, 0.69782608695652, -0.075
36607, 1.2217391304348, 0.67173913043478, -0.075
36608, 1.2869565217391, 0.69782608695652, -0.075
36609, 1.2652173913043, 0.67173913043478, -0.075
36610, 1.3304347826087, 0.69782608695652, -0.075
36611, 1.3086956521739, 0.67173913043478, -0.075
36612, 1.3739130434783, 0.69782608695652, -0.075
36613, 1.3521739130435, 0.67173913043478, -0.075
36614, 1.4173913043478, 0.69782608695652, -0.075
36615, 1.395652173913, 0.67173913043478, -0.075
36616, 1.4608695652174, 0.69782608695652, -0.075
36617, 1.4391304347826, 0.67173913043478, -0.075
36618, 1.504347826087, 0.69782608695652, -0.075
36619, 1.4826086956522, 0.67173913043478, -0.075
36620, 1.5478260869565, 0.69782608695652, -0.075
36621, 1.5260869565217, 0.67173913043478, -0.075
36622, 1.5913043478261, 0.69782608695652, -0.075
36623, 1.5695652173913, 0.67173913043478, -0.075
36624, 1.6347826086957, 0.69782608695652, -0.075
36625, 1.6130434782609, 0.67173913043478, -0.075
36626, 1.6782608695652, 0.69782608695652, -0.075
36627, 1.6565217391304, 0.67173913043478, -0.075
36628, 1.7217391304348, 0.69782608695652, -0.075
36629, 1.7, 0.67173913043478, -0.075
36630, 1.7652173913043, 0.69782608695652, -0.075
36631, 1.7434782608696, 0.67173913043478, -0.075
36632, 1.8086956521739, 0.69782608695652, -0.075
36633, 1.7869565217391, 0.67173913043478, -0.075
36634, 1.8521739130435, 0.69782608695652, -0.075
36635, 1.8304347826087, 0.67173913043478, -0.075
36636, 1.895652173913, 0.69782608695652, -0.075
36637, 1.8739130434783, 0.67173913043478, -0.075
36638, 1.9391304347826, 0.69782608695652, -0.075
36639, 1.9173913043478, 0.67173913043478, -0.075
36640, 1.9826086956522, 0.69782608695652, -0.075
36641, 1.9608695652174, 0.67173913043478, -0.075
36642, 2.0260869565217, 0.69782608695652, -0.075
36643, 2.004347826087, 0.67173913043478, -0.075
36644, 2.0695652173913, 0.69782608695652, -0.075
36645, 2.0478260869565, 0.67173913043478, -0.075
36646, 2.1130434782609, 0.69782608695652, -0.075
36647, 2.0913043478261, 0.67173913043478, -0.075
36648, 2.1565217391304, 0.69782608695652, -0.075
36649, 2.1347826086957, 0.67173913043478, -0.075
36650, 2.1782608695652, 0.67173913043478, -0.075
36651, 1.2434782608696, 0.64565217391304, -0.075
36652, 1.2217391304348, 0.61956521739131, -0.075
36653, 1.2869565217391, 0.64565217391304, -0.075
36654, 1.2652173913043, 0.61956521739131, -0.075
36655, 1.3304347826087, 0.64565217391304, -0.075
36656, 1.3086956521739, 0.61956521739131, -0.075
36657, 1.3739130434783, 0.64565217391304, -0.075
36658, 1.3521739130435, 0.61956521739131, -0.075
36659, 1.4173913043478, 0.64565217391304, -0.075
36660, 1.395652173913, 0.61956521739131, -0.075
36661, 1.4608695652174, 0.64565217391304, -0.075
36662, 1.4391304347826, 0.61956521739131, -0.075
36663, 1.504347826087, 0.64565217391304, -0.075
36664, 1.4826086956522, 0.61956521739131, -0.075
36665, 1.5478260869565, 0.64565217391304, -0.075
36666, 1.5260869565217, 0.61956521739131, -0.075
36667, 1.5913043478261, 0.64565217391304, -0.075
36668, 1.5695652173913, 0.61956521739131, -0.075
36669, 1.6347826086957, 0.64565217391304, -0.075
36670, 1.6130434782609, 0.61956521739131, -0.075
36671, 1.6782608695652, 0.64565217391304, -0.075
36672, 1.6565217391304, 0.61956521739131, -0.075
36673, 1.7217391304348, 0.64565217391304, -0.075
36674, 1.7, 0.61956521739131, -0.075
36675, 1.7652173913043, 0.64565217391304, -0.075
36676, 1.7434782608696, 0.61956521739131, -0.075
36677, 1.8086956521739, 0.64565217391304, -0.075
36678, 1.7869565217391, 0.61956521739131, -0.075
36679, 1.8521739130435, 0.64565217391304, -0.075
36680, 1.8304347826087, 0.61956521739131, -0.075
36681, 1.895652173913, 0.64565217391304, -0.075
36682, 1.8739130434783, 0.61956521739131, -0.075
36683, 1.9391304347826, 0.64565217391304, -0.075
36684, 1.9173913043478, 0.61956521739131, -0.075
36685, 1.9826086956522, 0.64565217391304, -0.075
36686, 1.9608695652174, 0.61956521739131, -0.075
36687, 2.0260869565217, 0.64565217391304, -0.075
36688, 2.004347826087, 0.61956521739131, -0.075
36689, 2.0695652173913, 0.64565217391304, -0.075
36690, 2.0478260869565, 0.61956521739131, -0.075
36691, 2.1130434782609, 0.64565217391304, -0.075
36692, 2.0913043478261, 0.61956521739131, -0.075
36693, 2.1565217391304, 0.64565217391304, -0.075
36694, 2.1347826086957, 0.61956521739131, -0.075
36695, 2.1782608695652, 0.61956521739131, -0.075
36696, 1.2434782608696, 0.59347826086957, -0.075
36697, 1.2217391304348, 0.56739130434783, -0.075
36698, 1.2869565217391, 0.59347826086957, -0.075
36699, 1.2652173913043, 0.56739130434783, -0.075
36700, 1.3304347826087, 0.59347826086957, -0.075
36701, 1.3086956521739, 0.56739130434783, -0.075
36702, 1.3739130434783, 0.59347826086957, -0.075
36703, 1.3521739130435, 0.56739130434783, -0.075
36704, 1.4173913043478, 0.59347826086957, -0.075
36705, 1.395652173913, 0.56739130434783, -0.075
36706, 1.4608695652174, 0.59347826086957, -0.075
36707, 1.4391304347826, 0.56739130434783, -0.075
36708, 1.504347826087, 0.59347826086957, -0.075
36709, 1.4826086956522, 0.56739130434783, -0.075
36710, 1.5478260869565, 0.59347826086957, -0.075
36711, 1.5260869565217, 0.56739130434783, -0.075
36712, 1.5913043478261, 0.59347826086957, -0.075
36713, 1.5695652173913, 0.56739130434783, -0.075
36714, 1.6347826086957, 0.59347826086957, -0.075
36715, 1.6130434782609, 0.56739130434783, -0.075
36716, 1.6782608695652, 0.59347826086957, -0.075
36717, 1.6565217391304, 0.56739130434783, -0.075
36718, 1.7217391304348, 0.59347826086957, -0.075
36719, 1.7, 0.56739130434783, -0.075
36720, 1.7652173913043, 0.59347826086957, -0.075
36721, 1.7434782608696, 0.56739130434783, -0.075
36722, 1.8086956521739, 0.59347826086957, -0.075
36723, 1.7869565217391, 0.56739130434783, -0.075
36724, 1.8521739130435, 0.59347826086957, -0.075
36725, 1.8304347826087, 0.56739130434783, -0.075
36726, 1.895652173913, 0.59347826086957, -0.075
36727, 1.8739130434783, 0.56739130434783, -0.075
36728, 1.9391304347826, 0.59347826086957, -0.075
36729, 1.9173913043478, 0.56739130434783, -0.075
36730, 1.9826086956522, 0.59347826086957, -0.075
36731, 1.9608695652174, 0.56739130434783, -0.075
36732, 2.0260869565217, 0.59347826086957, -0.075
36733, 2.004347826087, 0.56739130434783, -0.075
36734, 2.0695652173913, 0.59347826086957, -0.075
36735, 2.0478260869565, 0.56739130434783, -0.075
36736, 2.1130434782609, 0.59347826086957, -0.075
36737, 2.0913043478261, 0.56739130434783, -0.075
36738, 2.1565217391304, 0.59347826086957, -0.075
36739, 2.1347826086957, 0.56739130434783, -0.075
36740, 2.1782608695652, 0.56739130434783, -0.075
36741, 1.2434782608696, 0.54130434782609, -0.075
36742, 1.2217391304348, 0.51521739130435, -0.075
36743, 1.2869565217391, 0.54130434782609, -0.075
36744, 1.2652173913043, 0.51521739130435, -0.075
36745, 1.3304347826087, 0.54130434782609, -0.075
36746, 1.3086956521739, 0.51521739130435, -0.075
36747, 1.3739130434783, 0.54130434782609, -0.075
36748, 1.3521739130435, 0.51521739130435, -0.075
36749, 1.4173913043478, 0.54130434782609, -0.075
36750, 1.395652173913, 0.51521739130435, -0.075
36751, 1.4608695652174, 0.54130434782609, -0.075
36752, 1.4391304347826, 0.51521739130435, -0.075
36753, 1.504347826087, 0.54130434782609, -0.075
36754, 1.4826086956522, 0.51521739130435, -0.075
36755, 1.5478260869565, 0.54130434782609, -0.075
36756, 1.5260869565217, 0.51521739130435, -0.075
36757, 1.5913043478261, 0.54130434782609, -0.075
36758, 1.5695652173913, 0.51521739130435, -0.075
36759, 1.6347826086957, 0.54130434782609, -0.075
36760, 1.6130434782609, 0.51521739130435, -0.075
36761, 1.6782608695652, 0.54130434782609, -0.075
36762, 1.6565217391304, 0.51521739130435, -0.075
36763, 1.7217391304348, 0.54130434782609, -0.075
36764, 1.7, 0.51521739130435, -0.075
36765, 1.7652173913043, 0.54130434782609, -0.075
36766, 1.7434782608696, 0.51521739130435, -0.075
36767, 1.8086956521739, 0.54130434782609, -0.075
36768, 1.7869565217391, 0.51521739130435, -0.075
36769, 1.8521739130435, 0.54130434782609, -0.075
36770, 1.8304347826087, 0.51521739130435, -0.075
36771, 1.895652173913, 0.54130434782609, -0.075
36772, 1.8739130434783, 0.51521739130435, -0.075
36773, 1.9391304347826, 0.54130434782609, -0.075
36774, 1.9173913043478, 0.51521739130435, -0.075
36775, 1.9826086956522, 0.54130434782609, -0.075
36776, 1.9608695652174, 0.51521739130435, -0.075
36777, 2.0260869565217, 0.54130434782609, -0.075
36778, 2.004347826087, 0.51521739130435, -0.075
36779, 2.0695652173913, 0.54130434782609, -0.075
36780, 2.0478260869565, 0.51521739130435, -0.075
36781, 2.1130434782609, 0.54130434782609, -0.075
36782, 2.0913043478261, 0.51521739130435, -0.075
36783, 2.1565217391304, 0.54130434782609, -0.075
36784, 2.1347826086957, 0.51521739130435, -0.075
36785, 2.1782608695652, 0.51521739130435, -0.075
36786, 1.2434782608696, 0.48913043478261, -0.075
36787, 1.2217391304348, 0.46304347826087, -0.075
36788, 1.2869565217391, 0.48913043478261, -0.075
36789, 1.2652173913043, 0.46304347826087, -0.075
36790, 1.3304347826087, 0.48913043478261, -0.075
36791, 1.3086956521739, 0.46304347826087, -0.075
36792, 1.3739130434783, 0.48913043478261, -0.075
36793, 1.3521739130435, 0.46304347826087, -0.075
36794, 1.4173913043478, 0.48913043478261, -0.075
36795, 1.395652173913, 0.46304347826087, -0.075
36796, 1.4608695652174, 0.48913043478261, -0.075
36797, 1.4391304347826, 0.46304347826087, -0.075
36798, 1.504347826087, 0.48913043478261, -0.075
36799, 1.4826086956522, 0.46304347826087, -0.075
36800, 1.5478260869565, 0.48913043478261, -0.075
36801, 1.5260869565217, 0.46304347826087, -0.075
36802, 1.5913043478261, 0.48913043478261, -0.075
36803, 1.5695652173913, 0.46304347826087, -0.075
36804, 1.6347826086957, 0.48913043478261, -0.075
36805, 1.6130434782609, 0.46304347826087, -0.075
36806, 1.6782608695652, 0.48913043478261, -0.075
36807, 1.6565217391304, 0.46304347826087, -0.075
36808, 1.7217391304348, 0.48913043478261, -0.075
36809, 1.7, 0.46304347826087, -0.075
36810, 1.7652173913043, 0.48913043478261, -0.075
36811, 1.7434782608696, 0.46304347826087, -0.075
36812, 1.8086956521739, 0.48913043478261, -0.075
36813, 1.7869565217391, 0.46304347826087, -0.075
36814, 1.8521739130435, 0.48913043478261, -0.075
36815, 1.8304347826087, 0.46304347826087, -0.075
36816, 1.895652173913, 0.48913043478261, -0.075
36817, 1.8739130434783, 0.46304347826087, -0.075
36818, 1.9391304347826, 0.48913043478261, -0.075
36819, 1.9173913043478, 0.46304347826087, -0.075
36820, 1.9826086956522, 0.48913043478261, -0.075
36821, 1.9608695652174, 0.46304347826087, -0.075
36822, 2.0260869565217, 0.48913043478261, -0.075
36823, 2.004347826087, 0.46304347826087, -0.075
36824, 2.0695652173913, 0.48913043478261, -0.075
36825, 2.0478260869565, 0.46304347826087, -0.075
36826, 2.1130434782609, 0.48913043478261, -0.075
36827, 2.0913043478261, 0.46304347826087, -0.075
36828, 2.1565217391304, 0.48913043478261, -0.075
36829, 2.1347826086957, 0.46304347826087, -0.075
36830, 2.1782608695652, 0.46304347826087, -0.075
36831, 1.2434782608696, 0.43695652173913, -0.075
36832, 1.2217391304348, 0.41086956521739, -0.075
36833, 1.2869565217391, 0.43695652173913, -0.075
36834, 1.2652173913043, 0.41086956521739, -0.075
36835, 1.3304347826087, 0.43695652173913, -0.075
36836, 1.3086956521739, 0.41086956521739, -0.075
36837, 1.3739130434783, 0.43695652173913, -0.075
36838, 1.3521739130435, 0.41086956521739, -0.075
36839, 1.4173913043478, 0.43695652173913, -0.075
36840, 1.395652173913, 0.41086956521739, -0.075
36841, 1.4608695652174, 0.43695652173913, -0.075
36842, 1.4391304347826, 0.41086956521739, -0.075
36843, 1.504347826087, 0.43695652173913, -0.075
36844, 1.4826086956522, 0.41086956521739, -0.075
36845, 1.5478260869565, 0.43695652173913, -0.075
36846, 1.5260869565217, 0.41086956521739, -0.075
36847, 1.5913043478261, 0.43695652173913, -0.075
36848, 1.5695652173913, 0.41086956521739, -0.075
36849, 1.6347826086957, 0.43695652173913, -0.075
36850, 1.6130434782609, 0.41086956521739, -0.075
36851, 1.6782608695652, 0.43695652173913, -0.075
36852, 1.6565217391304, 0.41086956521739, -0.075
36853, 1.7217391304348, 0.43695652173913, -0.075
36854, 1.7, 0.41086956521739, -0.075
36855, 1.7652173913043, 0.43695652173913, -0.075
36856, 1.7434782608696, 0.41086956521739, -0.075
36857, 1.8086956521739, 0.43695652173913, -0.075
36858, 1.7869565217391, 0.41086956521739, -0.075
36859, 1.8521739130435, 0.43695652173913, -0.075
36860, 1.8304347826087, 0.41086956521739, -0.075
36861, 1.895652173913, 0.43695652173913, -0.075
36862, 1.8739130434783, 0.41086956521739, -0.075
36863, 1.9391304347826, 0.43695652173913, -0.075
36864, 1.9173913043478, 0.41086956521739, -0.075
36865, 1.9826086956522, 0.43695652173913, -0.075
36866, 1.9608695652174, 0.41086956521739, -0.075
36867, 2.0260869565217, 0.43695652173913, -0.075
36868, 2.004347826087, 0.41086956521739, -0.075
36869, 2.0695652173913, 0.43695652173913, -0.075
36870, 2.0478260869565, 0.41086956521739, -0.075
36871, 2.1130434782609, 0.43695652173913, -0.075
36872, 2.0913043478261, 0.41086956521739, -0.075
36873, 2.1565217391304, 0.43695652173913, -0.075
36874, 2.1347826086957, 0.41086956521739, -0.075
36875, 2.1782608695652, 0.41086956521739, -0.075
36876, 1.2434782608696, 0.38478260869565, -0.075
36877, 1.2217391304348, 0.35869565217391, -0.075
36878, 1.2869565217391, 0.38478260869565, -0.075
36879, 1.2652173913043, 0.35869565217391, -0.075
36880, 1.3304347826087, 0.38478260869565, -0.075
36881, 1.3086956521739, 0.35869565217391, -0.075
36882, 1.3739130434783, 0.38478260869565, -0.075
36883, 1.3521739130435, 0.35869565217391, -0.075
36884, 1.4173913043478, 0.38478260869565, -0.075
36885, 1.395652173913, 0.35869565217391, -0.075
36886, 1.4608695652174, 0.38478260869565, -0.075
36887, 1.4391304347826, 0.35869565217391, -0.075
36888, 1.504347826087, 0.38478260869565, -0.075
36889, 1.4826086956522, 0.35869565217391, -0.075
36890, 1.5478260869565, 0.38478260869565, -0.075
36891, 1.5260869565217, 0.35869565217391, -0.075
36892, 1.5913043478261, 0.38478260869565, -0.075
36893, 1.5695652173913, 0.35869565217391, -0.075
36894, 1.6347826086957, 0.38478260869565, -0.075
36895, 1.6130434782609, 0.35869565217391, -0.075
36896, 1.6782608695652, 0.38478260869565, -0.075
36897, 1.6565217391304, 0.35869565217391, -0.075
36898, 1.7217391304348, 0.38478260869565, -0.075
36899, 1.7, 0.35869565217391, -0.075
36900, 1.7652173913043, 0.38478260869565, -0.075
36901, 1.7434782608696, 0.35869565217391, -0.075
36902, 1.8086956521739, 0.38478260869565, -0.075
36903, 1.7869565217391, 0.35869565217391, -0.075
36904, 1.8521739130435, 0.38478260869565, -0.075
36905, 1.8304347826087, 0.35869565217391, -0.075
36906, 1.895652173913, 0.38478260869565, -0.075
36907, 1.8739130434783, 0.35869565217391, -0.075
36908, 1.9391304347826, 0.38478260869565, -0.075
36909, 1.9173913043478, 0.35869565217391, -0.075
36910, 1.9826086956522, 0.38478260869565, -0.075
36911, 1.9608695652174, 0.35869565217391, -0.075
36912, 2.0260869565217, 0.38478260869565, -0.075
36913, 2.004347826087, 0.35869565217391, -0.075
36914, 2.0695652173913, 0.38478260869565, -0.075
36915, 2.0478260869565, 0.35869565217391, -0.075
36916, 2.1130434782609, 0.38478260869565, -0.075
36917, 2.0913043478261, 0.35869565217391, -0.075
36918, 2.1565217391304, 0.38478260869565, -0.075
36919, 2.1347826086957, 0.35869565217391, -0.075
36920, 2.1782608695652, 0.35869565217391, -0.075
36921, 1.2434782608696, 0.33260869565217, -0.075
36922, 1.2217391304348, 0.30652173913044, -0.075
36923, 1.2869565217391, 0.33260869565217, -0.075
36924, 1.2652173913043, 0.30652173913044, -0.075
36925, 1.3304347826087, 0.33260869565217, -0.075
36926, 1.3086956521739, 0.30652173913043, -0.075
36927, 1.3739130434783, 0.33260869565217, -0.075
36928, 1.3521739130435, 0.30652173913044, -0.075
36929, 1.4173913043478, 0.33260869565217, -0.075
36930, 1.395652173913, 0.30652173913044, -0.075
36931, 1.4608695652174, 0.33260869565217, -0.075
36932, 1.4391304347826, 0.30652173913044, -0.075
36933, 1.504347826087, 0.33260869565217, -0.075
36934, 1.4826086956522, 0.30652173913044, -0.075
36935, 1.5478260869565, 0.33260869565217, -0.075
36936, 1.5260869565217, 0.30652173913044, -0.075
36937, 1.5913043478261, 0.33260869565217, -0.075
36938, 1.5695652173913, 0.30652173913044, -0.075
36939, 1.6347826086957, 0.33260869565217, -0.075
36940, 1.6130434782609, 0.30652173913044, -0.075
36941, 1.6782608695652, 0.33260869565217, -0.075
36942, 1.6565217391304, 0.30652173913043, -0.075
36943, 1.7217391304348, 0.33260869565217, -0.075
36944, 1.7, 0.30652173913043, -0.075
36945, 1.7652173913043, 0.33260869565217, -0.075
36946, 1.7434782608696, 0.30652173913043, -0.075
36947, 1.8086956521739, 0.33260869565217, -0.075
36948, 1.7869565217391, 0.30652173913044, -0.075
36949, 1.8521739130435, 0.33260869565217, -0.075
36950, 1.8304347826087, 0.30652173913044, -0.075
36951, 1.895652173913, 0.33260869565217, -0.075
36952, 1.8739130434783, 0.30652173913043, -0.075
36953, 1.9391304347826, 0.33260869565217, -0.075
36954, 1.9173913043478, 0.30652173913044, -0.075
36955, 1.9826086956522, 0.33260869565217, -0.075
36956, 1.9608695652174, 0.30652173913044, -0.075
36957, 2.0260869565217, 0.33260869565217, -0.075
36958, 2.004347826087, 0.30652173913044, -0.075
36959, 2.0695652173913, 0.33260869565217, -0.075
36960, 2.0478260869565, 0.30652173913044, -0.075
36961, 2.1130434782609, 0.33260869565217, -0.075
36962, 2.0913043478261, 0.30652173913043, -0.075
36963, 2.1565217391304, 0.33260869565217, -0.075
36964, 2.1347826086957, 0.30652173913043, -0.075
36965, 2.1782608695652, 0.30652173913044, -0.075
36966, 1.2434782608696, 0.2804347826087, -0.075
36967, 1.2217391304348, 0.25434782608696, -0.075
36968, 1.2869565217391, 0.2804347826087, -0.075
36969, 1.2652173913043, 0.25434782608696, -0.075
36970, 1.3304347826087, 0.2804347826087, -0.075
36971, 1.3086956521739, 0.25434782608696, -0.075
36972, 1.3739130434783, 0.2804347826087, -0.075
36973, 1.3521739130435, 0.25434782608696, -0.075
36974, 1.4173913043478, 0.2804347826087, -0.075
36975, 1.395652173913, 0.25434782608696, -0.075
36976, 1.4608695652174, 0.2804347826087, -0.075
36977, 1.4391304347826, 0.25434782608696, -0.075
36978, 1.504347826087, 0.2804347826087, -0.075
36979, 1.4826086956522, 0.25434782608696, -0.075
36980, 1.5478260869565, 0.2804347826087, -0.075
36981, 1.5260869565217, 0.25434782608696, -0.075
36982, 1.5913043478261, 0.2804347826087, -0.075
36983, 1.5695652173913, 0.25434782608696, -0.075
36984, 1.6347826086957, 0.2804347826087, -0.075
36985, 1.6130434782609, 0.25434782608696, -0.075
36986, 1.6782608695652, 0.2804347826087, -0.075
36987, 1.6565217391304, 0.25434782608696, -0.075
36988, 1.7217391304348, 0.2804347826087, -0.075
36989, 1.7, 0.25434782608696, -0.075
36990, 1.7652173913043, 0.2804347826087, -0.075
36991, 1.7434782608696, 0.25434782608696, -0.075
36992, 1.8086956521739, 0.2804347826087, -0.075
36993, 1.7869565217391, 0.25434782608696, -0.075
36994, 1.8521739130435, 0.2804347826087, -0.075
36995, 1.8304347826087, 0.25434782608696, -0.075
36996, 1.895652173913, 0.2804347826087, -0.075
36997, 1.8739130434783, 0.25434782608696, -0.075
36998, 1.9391304347826, 0.2804347826087, -0.075
36999, 1.9173913043478, 0.25434782608696, -0.075
37000, 1.9826086956522, 0.2804347826087, -0.075
37001, 1.9608695652174, 0.25434782608696, -0.075
37002, 2.0260869565217, 0.2804347826087, -0.075
37003, 2.004347826087, 0.25434782608696, -0.075
37004, 2.0695652173913, 0.2804347826087, -0.075
37005, 2.0478260869565, 0.25434782608696, -0.075
37006, 2.1130434782609, 0.2804347826087, -0.075
37007, 2.0913043478261, 0.25434782608696, -0.075
37008, 2.1565217391304, 0.2804347826087, -0.075
37009, 2.1347826086957, 0.25434782608696, -0.075
37010, 2.1782608695652, 0.25434782608696, -0.075
37011, 1.2434782608696, 0.22826086956522, -0.075
37012, 1.2217391304348, 0.20217391304348, -0.075
37013, 1.2869565217391, 0.22826086956522, -0.075
37014, 1.2652173913043, 0.20217391304348, -0.075
37015, 1.3304347826087, 0.22826086956522, -0.075
37016, 1.3086956521739, 0.20217391304348, -0.075
37017, 1.3739130434783, 0.22826086956522, -0.075
37018, 1.3521739130435, 0.20217391304348, -0.075
37019, 1.4173913043478, 0.22826086956522, -0.075
37020, 1.395652173913, 0.20217391304348, -0.075
37021, 1.4608695652174, 0.22826086956522, -0.075
37022, 1.4391304347826, 0.20217391304348, -0.075
37023, 1.504347826087, 0.22826086956522, -0.075
37024, 1.4826086956522, 0.20217391304348, -0.075
37025, 1.5478260869565, 0.22826086956522, -0.075
37026, 1.5260869565217, 0.20217391304348, -0.075
37027, 1.5913043478261, 0.22826086956522, -0.075
37028, 1.5695652173913, 0.20217391304348, -0.075
37029, 1.6347826086957, 0.22826086956522, -0.075
37030, 1.6130434782609, 0.20217391304348, -0.075
37031, 1.6782608695652, 0.22826086956522, -0.075
37032, 1.6565217391304, 0.20217391304348, -0.075
37033, 1.7217391304348, 0.22826086956522, -0.075
37034, 1.7, 0.20217391304348, -0.075
37035, 1.7652173913043, 0.22826086956522, -0.075
37036, 1.7434782608696, 0.20217391304348, -0.075
37037, 1.8086956521739, 0.22826086956522, -0.075
37038, 1.7869565217391, 0.20217391304348, -0.075
37039, 1.8521739130435, 0.22826086956522, -0.075
37040, 1.8304347826087, 0.20217391304348, -0.075
37041, 1.895652173913, 0.22826086956522, -0.075
37042, 1.8739130434783, 0.20217391304348, -0.075
37043, 1.9391304347826, 0.22826086956522, -0.075
37044, 1.9173913043478, 0.20217391304348, -0.075
37045, 1.9826086956522, 0.22826086956522, -0.075
37046, 1.9608695652174, 0.20217391304348, -0.075
37047, 2.0260869565217, 0.22826086956522, -0.075
37048, 2.004347826087, 0.20217391304348, -0.075
37049, 2.0695652173913, 0.22826086956522, -0.075
37050, 2.0478260869565, 0.20217391304348, -0.075
37051, 2.1130434782609, 0.22826086956522, -0.075
37052, 2.0913043478261, 0.20217391304348, -0.075
37053, 2.1565217391304, 0.22826086956522, -0.075
37054, 2.1347826086957, 0.20217391304348, -0.075
37055, 2.1782608695652, 0.20217391304348, -0.075
37056, 1.2434782608696, 0.17608695652174, -0.075
37057, 1.2869565217391, 0.17608695652174, -0.075
37058, 1.3304347826087, 0.17608695652174, -0.075
37059, 1.3739130434783, 0.17608695652174, -0.075
37060, 1.4173913043478, 0.17608695652174, -0.075
37061, 1.4608695652174, 0.17608695652174, -0.075
37062, 1.504347826087, 0.17608695652174, -0.075
37063, 1.5478260869565, 0.17608695652174, -0.075
37064, 1.5913043478261, 0.17608695652174, -0.075
37065, 1.6347826086957, 0.17608695652174, -0.075
37066, 1.6782608695652, 0.17608695652174, -0.075
37067, 1.7217391304348, 0.17608695652174, -0.075
37068, 1.7652173913043, 0.17608695652174, -0.075
37069, 1.8086956521739, 0.17608695652174, -0.075
37070, 1.8521739130435, 0.17608695652174, -0.075
37071, 1.895652173913, 0.17608695652174, -0.075
37072, 1.9391304347826, 0.17608695652174, -0.075
37073, 1.9826086956522, 0.17608695652174, -0.075
37074, 2.0260869565217, 0.17608695652174, -0.075
37075, 2.0695652173913, 0.17608695652174, -0.075
37076, 2.1130434782609, 0.17608695652174, -0.075
37077, 2.1565217391304, 0.17608695652174, -0.075
37078, 0.043478260869565, -0.016666666666667, 0.055555555555556
37079, 0.08695652173913, -0.016666666666667, 0.055555555555556
37080, 0.1304347826087, -0.016666666666667, 0.055555555555556
37081, 0.17391304347826, -0.016666666666667, 0.055555555555556
37082, 0.21739130434783, -0.016666666666667, 0.055555555555556
37083, 0.26086956521739, -0.016666666666667, 0.055555555555556
37084, 0.30434782608696, -0.016666666666667, 0.055555555555556
37085, 0.34782608695652, -0.016666666666667, 0.055555555555556
37086, 0.39130434782609, -0.016666666666667, 0.055555555555556
37087, 0.43478260869565, -0.016666666666667, 0.055555555555556
37088, 0.47826086956522, -0.016666666666667, 0.055555555555556
37089, 0.52173913043478, -0.016666666666667, 0.055555555555556
37090, 0.56521739130435, -0.016666666666667, 0.055555555555556
37091, 0.60869565217391, -0.016666666666667, 0.055555555555556
37092, 0.65217391304348, -0.016666666666667, 0.055555555555556
37093, 0.69565217391304, -0.016666666666667, 0.055555555555556
37094, 0.73913043478261, -0.016666666666667, 0.055555555555556
37095, 0.78260869565217, -0.016666666666667, 0.055555555555556
37096, 0.82608695652174, -0.016666666666667, 0.055555555555556
37097, 0.8695652173913, -0.016666666666667, 0.055555555555556
37098, 0.91304347826087, -0.016666666666667, 0.055555555555556
37099, 0.95652173913044, -0.016666666666667, 0.055555555555556
37100, 0.043478260869565, 0.016666666666667, 0.055555555555556
37101, 0.08695652173913, 0.016666666666667, 0.055555555555556
37102, 0.1304347826087, 0.016666666666667, 0.055555555555556
37103, 0.17391304347826, 0.016666666666667, 0.055555555555556
37104, 0.21739130434783, 0.016666666666667, 0.055555555555556
37105, 0.26086956521739, 0.016666666666667, 0.055555555555556
37106, 0.30434782608696, 0.016666666666667, 0.055555555555556
37107, 0.34782608695652, 0.016666666666667, 0.055555555555556
37108, 0.39130434782609, 0.016666666666667, 0.055555555555556
37109, 0.43478260869565, 0.016666666666667, 0.055555555555556
37110, 0.47826086956522, 0.016666666666667, 0.055555555555556
37111, 0.52173913043478, 0.016666666666667, 0.055555555555556
37112, 0.56521739130435, 0.016666666666667, 0.055555555555556
37113, 0.60869565217391, 0.016666666666667, 0.055555555555556
37114, 0.65217391304348, 0.016666666666667, 0.055555555555556
37115, 0.69565217391304, 0.016666666666667, 0.055555555555556
37116, 0.73913043478261, 0.016666666666667, 0.055555555555556
37117, 0.78260869565217, 0.016666666666667, 0.055555555555556
37118, 0.82608695652174, 0.016666666666667, 0.055555555555556
37119, 0.8695652173913, 0.016666666666667, 0.055555555555556
37120, 0.91304347826087, 0.016666666666667, 0.055555555555556
37121, 0.95652173913044, 0.016666666666667, 0.055555555555556
37122, 0.043478260869565, -0.016666666666667, 0.11111111111111
37123, 0.08695652173913, -0.016666666666667, 0.11111111111111
37124, 0.1304347826087, -0.016666666666667, 0.11111111111111
37125, 0.17391304347826, -0.016666666666667, 0.11111111111111
37126, 0.21739130434783, -0.016666666666667, 0.11111111111111
37127, 0.26086956521739, -0.016666666666667, 0.11111111111111
37128, 0.30434782608696, -0.016666666666667, 0.11111111111111
37129, 0.34782608695652, -0.016666666666667, 0.11111111111111
37130, 0.39130434782609, -0.016666666666667, 0.11111111111111
37131, 0.43478260869565, -0.016666666666667, 0.11111111111111
37132, 0.47826086956522, -0.016666666666667, 0.11111111111111
37133, 0.52173913043478, -0.016666666666667, 0.11111111111111
37134, 0.56521739130435, -0.016666666666667, 0.11111111111111
37135, 0.60869565217391, -0.016666666666667, 0.11111111111111
37136, 0.65217391304348, -0.016666666666667, 0.11111111111111
37137, 0.69565217391304, -0.016666666666667, 0.11111111111111
37138, 0.73913043478261, -0.016666666666667, 0.11111111111111
37139, 0.78260869565217, -0.016666666666667, 0.11111111111111
37140, 0.82608695652174, -0.016666666666667, 0.11111111111111
37141, 0.8695652173913, -0.016666666666667, 0.11111111111111
37142, 0.91304347826087, -0.016666666666667, 0.11111111111111
37143, 0.95652173913044, -0.016666666666667, 0.11111111111111
37144, 0.043478260869565, 0.016666666666667, 0.11111111111111
37145, 0.08695652173913, 0.016666666666667, 0.11111111111111
37146, 0.1304347826087, 0.016666666666667, 0.11111111111111
37147, 0.17391304347826, 0.016666666666667, 0.11111111111111
37148, 0.21739130434783, 0.016666666666667, 0.11111111111111
37149, 0.26086956521739, 0.016666666666667, 0.11111111111111
37150, 0.30434782608696, 0.016666666666667, 0.11111111111111
37151, 0.34782608695652, 0.016666666666667, 0.11111111111111
37152, 0.39130434782609, 0.016666666666667, 0.11111111111111
37153, 0.43478260869565, 0.016666666666667, 0.11111111111111
37154, 0.47826086956522, 0.016666666666667, 0.11111111111111
37155, 0.52173913043478, 0.016666666666667, 0.11111111111111
37156, 0.56521739130435, 0.016666666666667, 0.11111111111111
37157, 0.60869565217391, 0.016666666666667, 0.11111111111111
37158, 0.65217391304348, 0.016666666666667, 0.11111111111111
37159, 0.69565217391304, 0.016666666666667, 0.11111111111111
37160, 0.73913043478261, 0.016666666666667, 0.11111111111111
37161, 0.78260869565217, 0.016666666666667, 0.11111111111111
37162, 0.82608695652174, 0.016666666666667, 0.11111111111111
37163, 0.8695652173913, 0.016666666666667, 0.11111111111111
37164, 0.91304347826087, 0.016666666666667, 0.11111111111111
37165, 0.95652173913044, 0.016666666666667, 0.11111111111111
37166, 0.043478260869565, -0.016666666666667, 0.16666666666667
37167, 0.08695652173913, -0.016666666666667, 0.16666666666667
37168, 0.1304347826087, -0.016666666666667, 0.16666666666667
37169, 0.17391304347826, -0.016666666666667, 0.16666666666667
37170, 0.21739130434783, -0.016666666666667, 0.16666666666667
37171, 0.26086956521739, -0.016666666666667, 0.16666666666667
37172, 0.30434782608696, -0.016666666666667, 0.16666666666667
37173, 0.34782608695652, -0.016666666666667, 0.16666666666667
37174, 0.39130434782609, -0.016666666666667, 0.16666666666667
37175, 0.43478260869565, -0.016666666666667, 0.16666666666667
37176, 0.47826086956522, -0.016666666666667, 0.16666666666667
37177, 0.52173913043478, -0.016666666666667, 0.16666666666667
37178, 0.56521739130435, -0.016666666666667, 0.16666666666667
37179, 0.60869565217391, -0.016666666666667, 0.16666666666667
37180, 0.65217391304348, -0.016666666666667, 0.16666666666667
37181, 0.69565217391304, -0.016666666666667, 0.16666666666667
37182, 0.73913043478261, -0.016666666666667, 0.16666666666667
37183, 0.78260869565217, -0.016666666666667, 0.16666666666667
37184, 0.82608695652174, -0.016666666666667, 0.16666666666667
37185, 0.8695652173913, -0.016666666666667, 0.16666666666667
37186, 0.91304347826087, -0.016666666666667, 0.16666666666667
37187, 0.95652173913044, -0.016666666666667, 0.16666666666667
37188, 0.043478260869565, 0.016666666666667, 0.16666666666667
37189, 0.08695652173913, 0.016666666666667, 0.16666666666667
37190, 0.1304347826087, 0.016666666666667, 0.16666666666667
37191, 0.17391304347826, 0.016666666666667, 0.16666666666667
37192, 0.21739130434783, 0.016666666666667, 0.16666666666667
37193, 0.26086956521739, 0.016666666666667, 0.16666666666667
37194, 0.30434782608696, 0.016666666666667, 0.16666666666667
37195, 0.34782608695652, 0.016666666666667, 0.16666666666667
37196, 0.39130434782609, 0.016666666666667, 0.16666666666667
37197, 0.43478260869565, 0.016666666666667, 0.16666666666667
37198, 0.47826086956522, 0.016666666666667, 0.16666666666667
37199, 0.52173913043478, 0.016666666666667, 0.16666666666667
37200, 0.56521739130435, 0.016666666666667, 0.16666666666667
37201, 0.60869565217391, 0.016666666666667, 0.16666666666667
37202, 0.65217391304348, 0.016666666666667, 0.16666666666667
37203, 0.69565217391304, 0.016666666666667, 0.16666666666667
37204, 0.73913043478261, 0.016666666666667, 0.16666666666667
37205, 0.78260869565217, 0.016666666666667, 0.16666666666667
37206, 0.82608695652174, 0.016666666666667, 0.16666666666667
37207, 0.8695652173913, 0.016666666666667, 0.16666666666667
37208, 0.91304347826087, 0.016666666666667, 0.16666666666667
37209, 0.95652173913044, 0.016666666666667, 0.16666666666667
37210, 0.043478260869565, -0.016666666666667, 0.22222222222222
37211, 0.08695652173913, -0.016666666666667, 0.22222222222222
37212, 0.1304347826087, -0.016666666666667, 0.22222222222222
37213, 0.17391304347826, -0.016666666666667, 0.22222222222222
37214, 0.21739130434783, -0.016666666666667, 0.22222222222222
37215, 0.26086956521739, -0.016666666666667, 0.22222222222222
37216, 0.30434782608696, -0.016666666666667, 0.22222222222222
37217, 0.34782608695652, -0.016666666666667, 0.22222222222222
37218, 0.39130434782609, -0.016666666666667, 0.22222222222222
37219, 0.43478260869565, -0.016666666666667, 0.22222222222222
37220, 0.47826086956522, -0.016666666666667, 0.22222222222222
37221, 0.52173913043478, -0.016666666666667, 0.22222222222222
37222, 0.56521739130435, -0.016666666666667, 0.22222222222222
37223, 0.60869565217391, -0.016666666666667, 0.22222222222222
37224, 0.65217391304348, -0.016666666666667, 0.22222222222222
37225, 0.69565217391304, -0.016666666666667, 0.22222222222222
37226, 0.73913043478261, -0.016666666666667, 0.22222222222222
37227, 0.78260869565217, -0.016666666666667, 0.22222222222222
37228, 0.82608695652174, -0.016666666666667, 0.22222222222222
37229, 0.8695652173913, -0.016666666666667, 0.22222222222222
37230, 0.91304347826087, -0.016666666666667, 0.22222222222222
37231, 0.95652173913044, -0.016666666666667, 0.22222222222222
37232, 0.043478260869565, 0.016666666666667, 0.22222222222222
37233, 0.08695652173913, 0.016666666666667, 0.22222222222222
37234, 0.1304347826087, 0.016666666666667, 0.22222222222222
37235, 0.17391304347826, 0.016666666666667, 0.22222222222222
37236, 0.21739130434783, 0.016666666666667, 0.22222222222222
37237, 0.26086956521739, 0.016666666666667, 0.22222222222222
37238, 0.30434782608696, 0.016666666666667, 0.22222222222222
37239, 0.34782608695652, 0.016666666666667, 0.22222222222222
37240, 0.39130434782609, 0.016666666666667, 0.22222222222222
37241, 0.43478260869565, 0.016666666666667, 0.22222222222222
37242, 0.47826086956522, 0.016666666666667, 0.22222222222222
37243, 0.52173913043478, 0.016666666666667, 0.22222222222222
37244, 0.56521739130435, 0.016666666666667, 0.22222222222222
37245, 0.60869565217391, 0.016666666666667, 0.22222222222222
37246, 0.65217391304348, 0.016666666666667, 0.22222222222222
37247, 0.69565217391304, 0.016666666666667, 0.22222222222222
37248, 0.73913043478261, 0.016666666666667, 0.22222222222222
37249, 0.78260869565217, 0.016666666666667, 0.22222222222222
37250, 0.82608695652174, 0.016666666666667, 0.22222222222222
37251, 0.8695652173913, 0.016666666666667, 0.22222222222222
37252, 0.91304347826087, 0.016666666666667, 0.22222222222222
37253, 0.95652173913044, 0.016666666666667, 0.22222222222222
37254, 0.043478260869565, -0.016666666666667, 0.27777777777778
37255, 0.08695652173913, -0.016666666666667, 0.27777777777778
37256, 0.1304347826087, -0.016666666666667, 0.27777777777778
37257, 0.17391304347826, -0.016666666666667, 0.27777777777778
37258, 0.21739130434783, -0.016666666666667, 0.27777777777778
37259, 0.26086956521739, -0.016666666666667, 0.27777777777778
37260, 0.30434782608696, -0.016666666666667, 0.27777777777778
37261, 0.34782608695652, -0.016666666666667, 0.27777777777778
37262, 0.39130434782609, -0.016666666666667, 0.27777777777778
37263, 0.43478260869565, -0.016666666666667, 0.27777777777778
37264, 0.47826086956522, -0.016666666666667, 0.27777777777778
37265, 0.52173913043478, -0.016666666666667, 0.27777777777778
37266, 0.56521739130435, -0.016666666666667, 0.27777777777778
37267, 0.60869565217391, -0.016666666666667, 0.27777777777778
37268, 0.65217391304348, -0.016666666666667, 0.27777777777778
37269, 0.69565217391304, -0.016666666666667, 0.27777777777778
37270, 0.73913043478261, -0.016666666666667, 0.27777777777778
37271, 0.78260869565217, -0.016666666666667, 0.27777777777778
37272, 0.82608695652174, -0.016666666666667, 0.27777777777778
37273, 0.8695652173913, -0.016666666666667, 0.27777777777778
37274, 0.91304347826087, -0.016666666666667, 0.27777777777778
37275, 0.95652173913044, -0.016666666666667, 0.27777777777778
37276, 0.043478260869565, 0.016666666666667, 0.27777777777778
37277, 0.08695652173913, 0.016666666666667, 0.27777777777778
37278, 0.1304347826087, 0.016666666666667, 0.27777777777778
37279, 0.17391304347826, 0.016666666666667, 0.27777777777778
37280, 0.21739130434783, 0.016666666666667, 0.27777777777778
37281, 0.26086956521739, 0.016666666666667, 0.27777777777778
37282, 0.30434782608696, 0.016666666666667, 0.27777777777778
37283, 0.34782608695652, 0.016666666666667, 0.27777777777778
37284, 0.39130434782609, 0.016666666666667, 0.27777777777778
37285, 0.43478260869565, 0.016666666666667, 0.27777777777778
37286, 0.47826086956522, 0.016666666666667, 0.27777777777778
37287, 0.52173913043478, 0.016666666666667, 0.27777777777778
37288, 0.56521739130435, 0.016666666666667, 0.27777777777778
37289, 0.60869565217391, 0.016666666666667, 0.27777777777778
37290, 0.65217391304348, 0.016666666666667, 0.27777777777778
37291, 0.69565217391304, 0.016666666666667, 0.27777777777778
37292, 0.73913043478261, 0.016666666666667, 0.27777777777778
37293, 0.78260869565217, 0.016666666666667, 0.27777777777778
37294, 0.82608695652174, 0.016666666666667, 0.27777777777778
37295, 0.8695652173913, 0.016666666666667, 0.27777777777778
37296, 0.91304347826087, 0.016666666666667, 0.27777777777778
37297, 0.95652173913044, 0.016666666666667, 0.27777777777778
37298, 0.043478260869565, -0.016666666666667, 0.33333333333333
37299, 0.08695652173913, -0.016666666666667, 0.33333333333333
37300, 0.1304347826087, -0.016666666666667, 0.33333333333333
37301, 0.17391304347826, -0.016666666666667, 0.33333333333333
37302, 0.21739130434783, -0.016666666666667, 0.33333333333333
37303, 0.26086956521739, -0.016666666666667, 0.33333333333333
37304, 0.30434782608696, -0.016666666666667, 0.33333333333333
37305, 0.34782608695652, -0.016666666666667, 0.33333333333333
37306, 0.39130434782609, -0.016666666666667, 0.33333333333333
37307, 0.43478260869565, -0.016666666666667, 0.33333333333333
37308, 0.47826086956522, -0.016666666666667, 0.33333333333333
37309, 0.52173913043478, -0.016666666666667, 0.33333333333333
37310, 0.56521739130435, -0.016666666666667, 0.33333333333333
37311, 0.60869565217391, -0.016666666666667, 0.33333333333333
37312, 0.65217391304348, -0.016666666666667, 0.33333333333333
37313, 0.69565217391304, -0.016666666666667, 0.33333333333333
37314, 0.73913043478261, -0.016666666666667, 0.33333333333333
37315, 0.78260869565217, -0.016666666666667, 0.33333333333333
37316, 0.82608695652174, -0.016666666666667, 0.33333333333333
37317, 0.8695652173913, -0.016666666666667, 0.33333333333333
37318, 0.91304347826087, -0.016666666666667, 0.33333333333333
37319, 0.95652173913044, -0.016666666666667, 0.33333333333333
37320, 0.043478260869565, 0.016666666666667, 0.33333333333333
37321, 0.08695652173913, 0.016666666666667, 0.33333333333333
37322, 0.1304347826087, 0.016666666666667, 0.33333333333333
37323, 0.17391304347826, 0.016666666666667, 0.33333333333333
37324, 0.21739130434783, 0.016666666666667, 0.33333333333333
37325, 0.26086956521739, 0.016666666666667, 0.33333333333333
37326, 0.30434782608696, 0.016666666666667, 0.33333333333333
37327, 0.34782608695652, 0.016666666666667, 0.33333333333333
37328, 0.39130434782609, 0.016666666666667, 0.33333333333333
37329, 0.43478260869565, 0.016666666666667, 0.33333333333333
37330, 0.47826086956522, 0.016666666666667, 0.33333333333333
37331, 0.52173913043478, 0.016666666666667, 0.33333333333333
37332, 0.56521739130435, 0.016666666666667, 0.33333333333333
37333, 0.60869565217391, 0.016666666666667, 0.33333333333333
37334, 0.65217391304348, 0.016666666666667, 0.33333333333333
37335, 0.69565217391304, 0.016666666666667, 0.33333333333333
37336, 0.73913043478261, 0.016666666666667, 0.33333333333333
37337, 0.78260869565217, 0.016666666666667, 0.33333333333333
37338, 0.82608695652174, 0.016666666666667, 0.33333333333333
37339, 0.8695652173913, 0.016666666666667, 0.33333333333333
37340, 0.91304347826087, 0.016666666666667, 0.33333333333333
37341, 0.95652173913044, 0.016666666666667, 0.33333333333333
37342, 0.043478260869565, -0.016666666666667, 0.38888888888889
37343, 0.08695652173913, -0.016666666666667, 0.38888888888889
37344, 0.1304347826087, -0.016666666666667, 0.38888888888889
37345, 0.17391304347826, -0.016666666666667, 0.38888888888889
37346, 0.21739130434783, -0.016666666666667, 0.38888888888889
37347, 0.26086956521739, -0.016666666666667, 0.38888888888889
37348, 0.30434782608696, -0.016666666666667, 0.38888888888889
37349, 0.34782608695652, -0.016666666666667, 0.38888888888889
37350, 0.39130434782609, -0.016666666666667, 0.38888888888889
37351, 0.43478260869565, -0.016666666666667, 0.38888888888889
37352, 0.47826086956522, -0.016666666666667, 0.38888888888889
37353, 0.52173913043478, -0.016666666666667, 0.38888888888889
37354, 0.56521739130435, -0.016666666666667, 0.38888888888889
37355, 0.60869565217391, -0.016666666666667, 0.38888888888889
37356, 0.65217391304348, -0.016666666666667, 0.38888888888889
37357, 0.69565217391304, -0.016666666666667, 0.38888888888889
37358, 0.73913043478261, -0.016666666666667, 0.38888888888889
37359, 0.78260869565217, -0.016666666666667, 0.38888888888889
37360, 0.82608695652174, -0.016666666666667, 0.38888888888889
37361, 0.8695652173913, -0.016666666666667, 0.38888888888889
37362, 0.91304347826087, -0.016666666666667, 0.38888888888889
37363, 0.95652173913044, -0.016666666666667, 0.38888888888889
37364, 0.043478260869565, 0.016666666666667, 0.38888888888889
37365, 0.08695652173913, 0.016666666666667, 0.38888888888889
37366, 0.1304347826087, 0.016666666666667, 0.38888888888889
37367, 0.17391304347826, 0.016666666666667, 0.38888888888889
37368, 0.21739130434783, 0.016666666666667, 0.38888888888889
37369, 0.26086956521739, 0.016666666666667, 0.38888888888889
37370, 0.30434782608696, 0.016666666666667, 0.38888888888889
37371, 0.34782608695652, 0.016666666666667, 0.38888888888889
37372, 0.39130434782609, 0.016666666666667, 0.38888888888889
37373, 0.43478260869565, 0.016666666666667, 0.38888888888889
37374, 0.47826086956522, 0.016666666666667, 0.38888888888889
37375, 0.52173913043478, 0.016666666666667, 0.38888888888889
37376, 0.56521739130435, 0.016666666666667, 0.38888888888889
37377, 0.60869565217391, 0.016666666666667, 0.38888888888889
37378, 0.65217391304348, 0.016666666666667, 0.38888888888889
37379, 0.69565217391304, 0.016666666666667, 0.38888888888889
37380, 0.73913043478261, 0.016666666666667, 0.38888888888889
37381, 0.78260869565217, 0.016666666666667, 0.38888888888889
37382, 0.82608695652174, 0.016666666666667, 0.38888888888889
37383, 0.8695652173913, 0.016666666666667, 0.38888888888889
37384, 0.91304347826087, 0.016666666666667, 0.38888888888889
37385, 0.95652173913044, 0.016666666666667, 0.38888888888889
37386, 0.043478260869565, -0.016666666666667, 0.44444444444444
37387, 0.08695652173913, -0.016666666666667, 0.44444444444444
37388, 0.1304347826087, -0.016666666666667, 0.44444444444444
37389, 0.17391304347826, -0.016666666666667, 0.44444444444444
37390, 0.21739130434783, -0.016666666666667, 0.44444444444444
37391, 0.26086956521739, -0.016666666666667, 0.44444444444444
37392, 0.30434782608696, -0.016666666666667, 0.44444444444444
37393, 0.34782608695652, -0.016666666666667, 0.44444444444444
37394, 0.39130434782609, -0.016666666666667, 0.44444444444444
37395, 0.43478260869565, -0.016666666666667, 0.44444444444444
37396, 0.47826086956522, -0.016666666666667, 0.44444444444444
37397, 0.52173913043478, -0.016666666666667, 0.44444444444444
37398, 0.56521739130435, -0.016666666666667, 0.44444444444444
37399, 0.60869565217391, -0.016666666666667, 0.44444444444444
37400, 0.65217391304348, -0.016666666666667, 0.44444444444444
37401, 0.69565217391304, -0.016666666666667, 0.44444444444444
37402, 0.73913043478261, -0.016666666666667, 0.44444444444444
37403, 0.78260869565217, -0.016666666666667, 0.44444444444444
37404, 0.82608695652174, -0.016666666666667, 0.44444444444444
37405, 0.8695652173913, -0.016666666666667, 0.44444444444444
37406, 0.91304347826087, -0.016666666666667, 0.44444444444444
37407, 0.95652173913044, -0.016666666666667, 0.44444444444444
37408, 0.043478260869565, 0.016666666666667, 0.44444444444444
37409, 0.08695652173913, 0.016666666666667, 0.44444444444444
37410, 0.1304347826087, 0.016666666666667, 0.44444444444444
37411, 0.17391304347826, 0.016666666666667, 0.44444444444444
37412, 0.21739130434783, 0.016666666666667, 0.44444444444444
37413, 0.26086956521739, 0.016666666666667, 0.44444444444444
37414, 0.30434782608696, 0.016666666666667, 0.44444444444444
37415, 0.34782608695652, 0.016666666666667, 0.44444444444444
37416, 0.39130434782609, 0.016666666666667, 0.44444444444444
37417, 0.43478260869565, 0.016666666666667, 0.44444444444444
37418, 0.47826086956522, 0.016666666666667, 0.44444444444444
37419, 0.52173913043478, 0.016666666666667, 0.44444444444444
37420, 0.56521739130435, 0.016666666666667, 0.44444444444444
37421, 0.60869565217391, 0.016666666666667, 0.44444444444444
37422, 0.65217391304348, 0.016666666666667, 0.44444444444444
37423, 0.69565217391304, 0.016666666666667, 0.44444444444444
37424, 0.73913043478261, 0.016666666666667, 0.44444444444444
37425, 0.78260869565217, 0.016666666666667, 0.44444444444444
37426, 0.82608695652174, 0.016666666666667, 0.44444444444444
37427, 0.8695652173913, 0.016666666666667, 0.44444444444444
37428, 0.91304347826087, 0.016666666666667, 0.44444444444444
37429, 0.95652173913044, 0.016666666666667, 0.44444444444444
37430, 0.021739130434783, -0.016666666666667, 0.055555555555556
37431, 0.043478260869565, -0.033333333333333, 0.055555555555556
37432, 0.043478260869565, -0.016666666666667, 0.027777777777778
37433, 0.065217391304348, -0.016666666666667, 0.055555555555556
37434, 0.08695652173913, -0.033333333333333, 0.055555555555556
37435, 0.08695652173913, -0.016666666666667, 0.027777777777778
37436, 0.10869565217391, -0.016666666666667, 0.055555555555556
37437, 0.1304347826087, -0.033333333333333, 0.055555555555556
37438, 0.1304347826087, -0.016666666666667, 0.027777777777778
37439, 0.15217391304348, -0.016666666666667, 0.055555555555556
37440, 0.17391304347826, -0.033333333333333, 0.055555555555556
37441, 0.17391304347826, -0.016666666666667, 0.027777777777778
37442, 0.19565217391304, -0.016666666666667, 0.055555555555556
37443, 0.21739130434783, -0.033333333333333, 0.055555555555556
37444, 0.21739130434783, -0.016666666666667, 0.027777777777778
37445, 0.23913043478261, -0.016666666666667, 0.055555555555556
37446, 0.26086956521739, -0.033333333333333, 0.055555555555556
37447, 0.26086956521739, -0.016666666666667, 0.027777777777778
37448, 0.28260869565217, -0.016666666666667, 0.055555555555556
37449, 0.30434782608696, -0.033333333333333, 0.055555555555556
37450, 0.30434782608696, -0.016666666666667, 0.027777777777778
37451, 0.32608695652174, -0.016666666666667, 0.055555555555556
37452, 0.34782608695652, -0.033333333333333, 0.055555555555556
37453, 0.34782608695652, -0.016666666666667, 0.027777777777778
37454, 0.3695652173913, -0.016666666666667, 0.055555555555556
37455, 0.39130434782609, -0.033333333333333, 0.055555555555556
37456, 0.39130434782609, -0.016666666666667, 0.027777777777778
37457, 0.41304347826087, -0.016666666666667, 0.055555555555556
37458, 0.43478260869565, -0.033333333333333, 0.055555555555556
37459, 0.43478260869565, -0.016666666666667, 0.027777777777778
37460, 0.45652173913043, -0.016666666666667, 0.055555555555556
37461, 0.47826086956522, -0.033333333333333, 0.055555555555556
37462, 0.47826086956522, -0.016666666666667, 0.027777777777778
37463, 0.5, -0.016666666666667, 0.055555555555556
37464, 0.52173913043478, -0.033333333333333, 0.055555555555556
37465, 0.52173913043478, -0.016666666666667, 0.027777777777778
37466, 0.54347826086957, -0.016666666666667, 0.055555555555556
37467, 0.56521739130435, -0.033333333333333, 0.055555555555556
37468, 0.56521739130435, -0.016666666666667, 0.027777777777778
37469, 0.58695652173913, -0.016666666666667, 0.055555555555556
37470, 0.60869565217391, -0.033333333333333, 0.055555555555556
37471, 0.60869565217391, -0.016666666666667, 0.027777777777778
37472, 0.6304347826087, -0.016666666666667, 0.055555555555556
37473, 0.65217391304348, -0.033333333333333, 0.055555555555556
37474, 0.65217391304348, -0.016666666666667, 0.027777777777778
37475, 0.67391304347826, -0.016666666666667, 0.055555555555556
37476, 0.69565217391304, -0.033333333333333, 0.055555555555556
37477, 0.69565217391304, -0.016666666666667, 0.027777777777778
37478, 0.71739130434783, -0.016666666666667, 0.055555555555556
37479, 0.73913043478261, -0.033333333333333, 0.055555555555556
37480, 0.73913043478261, -0.016666666666667, 0.027777777777778
37481, 0.76086956521739, -0.016666666666667, 0.055555555555556
37482, 0.78260869565217, -0.033333333333333, 0.055555555555556
37483, 0.78260869565217, -0.016666666666667, 0.027777777777778
37484, 0.80434782608696, -0.016666666666667, 0.055555555555556
37485, 0.82608695652174, -0.033333333333333, 0.055555555555556
37486, 0.82608695652174, -0.016666666666667, 0.027777777777778
37487, 0.84782608695652, -0.016666666666667, 0.055555555555556
37488, 0.8695652173913, -0.033333333333333, 0.055555555555556
37489, 0.8695652173913, -0.016666666666667, 0.027777777777778
37490, 0.89130434782609, -0.016666666666667, 0.055555555555556
37491, 0.91304347826087, -0.033333333333333, 0.055555555555556
37492, 0.91304347826087, -0.016666666666667, 0.027777777777778
37493, 0.93478260869565, -0.016666666666667, 0.055555555555556
37494, 0.95652173913043, -0.033333333333333, 0.055555555555556
37495, 0.95652173913043, -0.016666666666667, 0.027777777777778
37496, 0.97826086956522, -0.016666666666667, 0.055555555555556
37497, 0.021739130434783, 0.016666666666667, 0.055555555555556
37498, 0.043478260869565, 5.7245874707235e-17, 0.055555555555556
37499, 0.043478260869565, 0.016666666666667, 0.027777777777778
37500, 0.065217391304348, 0.016666666666667, 0.055555555555556
37501, 0.08695652173913, 6.5919492087119e-17, 0.055555555555556
37502, 0.08695652173913, 0.016666666666667, 0.027777777777778
37503, 0.10869565217391, 0.016666666666667, 0.055555555555556
37504, 0.1304347826087, 5.7245874707235e-17, 0.055555555555556
37505, 0.1304347826087, 0.016666666666667, 0.027777777777778
37506, 0.15217391304348, 0.016666666666667, 0.055555555555556
37507, 0.17391304347826, 5.7245874707235e-17, 0.055555555555556
37508, 0.17391304347826, 0.016666666666667, 0.027777777777778
37509, 0.19565217391304, 0.016666666666667, 0.055555555555556
37510, 0.21739130434783, 5.3776427755281e-17, 0.055555555555556
37511, 0.21739130434783, 0.016666666666667, 0.027777777777778
37512, 0.23913043478261, 0.016666666666667, 0.055555555555556
37513, 0.26086956521739, 5.3776427755281e-17, 0.055555555555556
37514, 0.26086956521739, 0.016666666666667, 0.027777777777778
37515, 0.28260869565217, 0.016666666666667, 0.055555555555556
37516, 0.30434782608696, 5.8980598183211e-17, 0.055555555555556
37517, 0.30434782608696, 0.016666666666667, 0.027777777777778
37518, 0.32608695652174, 0.016666666666667, 0.055555555555556
37519, 0.34782608695652, 6.0715321659188e-17, 0.055555555555556
37520, 0.34782608695652, 0.016666666666667, 0.027777777777778
37521, 0.3695652173913, 0.016666666666667, 0.055555555555556
37522, 0.39130434782609, 5.5511151231258e-17, 0.055555555555556
37523, 0.39130434782609, 0.016666666666667, 0.027777777777778
37524, 0.41304347826087, 0.016666666666667, 0.055555555555556
37525, 0.43478260869565, 5.8980598183211e-17, 0.055555555555556
37526, 0.43478260869565, 0.016666666666667, 0.027777777777778
37527, 0.45652173913043, 0.016666666666667, 0.055555555555556
37528, 0.47826086956522, 5.7245874707235e-17, 0.055555555555556
37529, 0.47826086956522, 0.016666666666667, 0.027777777777778
37530, 0.5, 0.016666666666667, 0.055555555555556
37531, 0.52173913043478, 5.7245874707235e-17, 0.055555555555556
37532, 0.52173913043478, 0.016666666666667, 0.027777777777778
37533, 0.54347826086957, 0.016666666666667, 0.055555555555556
37534, 0.56521739130435, 6.0715321659188e-17, 0.055555555555556
37535, 0.56521739130435, 0.016666666666667, 0.027777777777778
37536, 0.58695652173913, 0.016666666666667, 0.055555555555556
37537, 0.60869565217391, 5.7245874707235e-17, 0.055555555555556
37538, 0.60869565217391, 0.016666666666667, 0.027777777777778
37539, 0.6304347826087, 0.016666666666667, 0.055555555555556
37540, 0.65217391304348, 5.8980598183211e-17, 0.055555555555556
37541, 0.65217391304348, 0.016666666666667, 0.027777777777778
37542, 0.67391304347826, 0.016666666666667, 0.055555555555556
37543, 0.69565217391304, 5.7245874707235e-17, 0.055555555555556
37544, 0.69565217391304, 0.016666666666667, 0.027777777777778
37545, 0.71739130434783, 0.016666666666667, 0.055555555555556
37546, 0.73913043478261, 5.7245874707235e-17, 0.055555555555556
37547, 0.73913043478261, 0.016666666666667, 0.027777777777778
37548, 0.76086956521739, 0.016666666666667, 0.055555555555556
37549, 0.78260869565217, 6.0715321659188e-17, 0.055555555555556
37550, 0.78260869565217, 0.016666666666667, 0.027777777777778
37551, 0.80434782608696, 0.016666666666667, 0.055555555555556
37552, 0.82608695652174, 5.8980598183211e-17, 0.055555555555556
37553, 0.82608695652174, 0.016666666666667, 0.027777777777778
37554, 0.84782608695652, 0.016666666666667, 0.055555555555556
37555, 0.8695652173913, 5.2041704279304e-17, 0.055555555555556
37556, 0.8695652173913, 0.016666666666667, 0.027777777777778
37557, 0.89130434782609, 0.016666666666667, 0.055555555555556
37558, 0.91304347826087, 5.8980598183211e-17, 0.055555555555556
37559, 0.91304347826087, 0.016666666666667, 0.027777777777778
37560, 0.93478260869565, 0.016666666666667, 0.055555555555556
37561, 0.95652173913044, 6.4184768611142e-17, 0.055555555555556
37562, 0.95652173913043, 0.016666666666667, 0.027777777777778
37563, 0.97826086956522, 0.016666666666667, 0.055555555555556
37564, 0.043478260869565, 0.033333333333333, 0.055555555555556
37565, 0.08695652173913, 0.033333333333333, 0.055555555555556
37566, 0.1304347826087, 0.033333333333333, 0.055555555555556
37567, 0.17391304347826, 0.033333333333333, 0.055555555555556
37568, 0.21739130434783, 0.033333333333333, 0.055555555555556
37569, 0.26086956521739, 0.033333333333333, 0.055555555555556
37570, 0.30434782608696, 0.033333333333333, 0.055555555555556
37571, 0.34782608695652, 0.033333333333333, 0.055555555555556
37572, 0.39130434782609, 0.033333333333333, 0.055555555555556
37573, 0.43478260869565, 0.033333333333333, 0.055555555555556
37574, 0.47826086956522, 0.033333333333333, 0.055555555555556
37575, 0.52173913043478, 0.033333333333333, 0.055555555555556
37576, 0.56521739130435, 0.033333333333333, 0.055555555555556
37577, 0.60869565217391, 0.033333333333333, 0.055555555555556
37578, 0.65217391304348, 0.033333333333333, 0.055555555555556
37579, 0.69565217391304, 0.033333333333333, 0.055555555555556
37580, 0.73913043478261, 0.033333333333333, 0.055555555555556
37581, 0.78260869565217, 0.033333333333333, 0.055555555555556
37582, 0.82608695652174, 0.033333333333333, 0.055555555555556
37583, 0.8695652173913, 0.033333333333333, 0.055555555555556
37584, 0.91304347826087, 0.033333333333333, 0.055555555555556
37585, 0.95652173913043, 0.033333333333333, 0.055555555555556
37586, 0.021739130434783, -0.016666666666667, 0.11111111111111
37587, 0.043478260869565, -0.033333333333333, 0.11111111111111
37588, 0.043478260869565, -0.016666666666667, 0.083333333333333
37589, 0.065217391304348, -0.016666666666667, 0.11111111111111
37590, 0.08695652173913, -0.033333333333333, 0.11111111111111
37591, 0.08695652173913, -0.016666666666667, 0.083333333333333
37592, 0.10869565217391, -0.016666666666667, 0.11111111111111
37593, 0.1304347826087, -0.033333333333333, 0.11111111111111
37594, 0.1304347826087, -0.016666666666667, 0.083333333333333
37595, 0.15217391304348, -0.016666666666667, 0.11111111111111
37596, 0.17391304347826, -0.033333333333333, 0.11111111111111
37597, 0.17391304347826, -0.016666666666667, 0.083333333333333
37598, 0.19565217391304, -0.016666666666667, 0.11111111111111
37599, 0.21739130434783, -0.033333333333333, 0.11111111111111
37600, 0.21739130434783, -0.016666666666667, 0.083333333333333
37601, 0.23913043478261, -0.016666666666667, 0.11111111111111
37602, 0.26086956521739, -0.033333333333333, 0.11111111111111
37603, 0.26086956521739, -0.016666666666667, 0.083333333333333
37604, 0.28260869565217, -0.016666666666667, 0.11111111111111
37605, 0.30434782608696, -0.033333333333333, 0.11111111111111
37606, 0.30434782608696, -0.016666666666667, 0.083333333333333
37607, 0.32608695652174, -0.016666666666667, 0.11111111111111
37608, 0.34782608695652, -0.033333333333333, 0.11111111111111
37609, 0.34782608695652, -0.016666666666667, 0.083333333333333
37610, 0.3695652173913, -0.016666666666667, 0.11111111111111
37611, 0.39130434782609, -0.033333333333333, 0.11111111111111
37612, 0.39130434782609, -0.016666666666667, 0.083333333333333
37613, 0.41304347826087, -0.016666666666667, 0.11111111111111
37614, 0.43478260869565, -0.033333333333333, 0.11111111111111
37615, 0.43478260869565, -0.016666666666667, 0.083333333333333
37616, 0.45652173913043, -0.016666666666667, 0.11111111111111
37617, 0.47826086956522, -0.033333333333333, 0.11111111111111
37618, 0.47826086956522, -0.016666666666667, 0.083333333333333
37619, 0.5, -0.016666666666667, 0.11111111111111
37620, 0.52173913043478, -0.033333333333333, 0.11111111111111
37621, 0.52173913043478, -0.016666666666667, 0.083333333333333
37622, 0.54347826086957, -0.016666666666667, 0.11111111111111
37623, 0.56521739130435, -0.033333333333333, 0.11111111111111
37624, 0.56521739130435, -0.016666666666667, 0.083333333333333
37625, 0.58695652173913, -0.016666666666667, 0.11111111111111
37626, 0.60869565217391, -0.033333333333333, 0.11111111111111
37627, 0.60869565217391, -0.016666666666667, 0.083333333333333
37628, 0.6304347826087, -0.016666666666667, 0.11111111111111
37629, 0.65217391304348, -0.033333333333333, 0.11111111111111
37630, 0.65217391304348, -0.016666666666667, 0.083333333333333
37631, 0.67391304347826, -0.016666666666667, 0.11111111111111
37632, 0.69565217391304, -0.033333333333333, 0.11111111111111
37633, 0.69565217391304, -0.016666666666667, 0.083333333333333
37634, 0.71739130434783, -0.016666666666667, 0.11111111111111
37635, 0.73913043478261, -0.033333333333333, 0.11111111111111
37636, 0.73913043478261, -0.016666666666667, 0.083333333333333
37637, 0.76086956521739, -0.016666666666667, 0.11111111111111
37638, 0.78260869565217, -0.033333333333333, 0.11111111111111
37639, 0.78260869565217, -0.016666666666667, 0.083333333333333
37640, 0.80434782608696, -0.016666666666667, 0.11111111111111
37641, 0.82608695652174, -0.033333333333333, 0.11111111111111
37642, 0.82608695652174, -0.016666666666667, 0.083333333333333
37643, 0.84782608695652, -0.016666666666667, 0.11111111111111
37644, 0.8695652173913, -0.033333333333333, 0.11111111111111
37645, 0.8695652173913, -0.016666666666667, 0.083333333333333
37646, 0.89130434782609, -0.016666666666667, 0.11111111111111
37647, 0.91304347826087, -0.033333333333333, 0.11111111111111
37648, 0.91304347826087, -0.016666666666667, 0.083333333333333
37649, 0.93478260869565, -0.016666666666667, 0.11111111111111
37650, 0.95652173913044, -0.033333333333333, 0.11111111111111
37651, 0.95652173913044, -0.016666666666667, 0.083333333333333
37652, 0.97826086956522, -0.016666666666667, 0.11111111111111
37653, 0.021739130434783, 0.016666666666667, 0.11111111111111
37654, 0.043478260869565, 6.2450045135165e-17, 0.11111111111111
37655, 0.043478260869565, 0.016666666666667, 0.083333333333333
37656, 0.065217391304348, 0.016666666666667, 0.11111111111111
37657, 0.08695652173913, 5.8980598183211e-17, 0.11111111111111
37658, 0.08695652173913, 0.016666666666667, 0.083333333333333
37659, 0.10869565217391, 0.016666666666667, 0.11111111111111
37660, 0.1304347826087, 5.7245874707235e-17, 0.11111111111111
37661, 0.1304347826087, 0.016666666666667, 0.083333333333333
37662, 0.15217391304348, 0.016666666666667, 0.11111111111111
37663, 0.17391304347826, 5.5511151231258e-17, 0.11111111111111
37664, 0.17391304347826, 0.016666666666667, 0.083333333333333
37665, 0.19565217391304, 0.016666666666667, 0.11111111111111
37666, 0.21739130434783, 5.5511151231258e-17, 0.11111111111111
37667, 0.21739130434783, 0.016666666666667, 0.083333333333333
37668, 0.23913043478261, 0.016666666666667, 0.11111111111111
37669, 0.26086956521739, 6.0715321659188e-17, 0.11111111111111
37670, 0.26086956521739, 0.016666666666667, 0.083333333333333
37671, 0.28260869565217, 0.016666666666667, 0.11111111111111
37672, 0.30434782608696, 5.5511151231258e-17, 0.11111111111111
37673, 0.30434782608696, 0.016666666666667, 0.083333333333333
37674, 0.32608695652174, 0.016666666666667, 0.11111111111111
37675, 0.34782608695652, 5.7245874707235e-17, 0.11111111111111
