91991, 2.1565217391304, 0.0875, 0.27777777777778
91992, 2.1565217391304, 0.0875, 0.22222222222222
91993, 2.1565217391304, 0.0875, 0.16666666666667
91994, 2.1565217391304, 0.0875, 0.11111111111111
91995, 2.1565217391304, 0.0875, 0.055555555555556
91996, 0.95652173913043, 0.075, 0.055555555555556
91997, 0.95652173913044, 0.075, 0.11111111111111
91998, 0.95652173913043, 0.075, 0.16666666666667
91999, 0.95652173913044, 0.075, 0.22222222222222
92000, 0.95652173913044, 0.075, 0.27777777777778
92001, 0.95652173913044, 0.075, 0.33333333333333
92002, 0.95652173913044, 0.075, 0.38888888888889
92003, 0.95652173913044, 0.075, 0.44444444444444
92004, 0.91304347826087, 0.075, 0.055555555555556
92005, 0.91304347826087, 0.075, 0.11111111111111
92006, 0.91304347826087, 0.075, 0.16666666666667
92007, 0.91304347826087, 0.075, 0.22222222222222
92008, 0.91304347826087, 0.075, 0.27777777777778
92009, 0.91304347826087, 0.075, 0.33333333333333
92010, 0.91304347826087, 0.075, 0.38888888888889
92011, 0.91304347826087, 0.075, 0.44444444444444
92012, 0.8695652173913, 0.075, 0.055555555555556
92013, 0.8695652173913, 0.075, 0.11111111111111
92014, 0.8695652173913, 0.075, 0.16666666666667
92015, 0.8695652173913, 0.075, 0.22222222222222
92016, 0.8695652173913, 0.075, 0.27777777777778
92017, 0.8695652173913, 0.075, 0.33333333333333
92018, 0.8695652173913, 0.075, 0.38888888888889
92019, 0.8695652173913, 0.075, 0.44444444444444
92020, 0.82608695652174, 0.075, 0.055555555555556
92021, 0.82608695652174, 0.075, 0.11111111111111
92022, 0.82608695652174, 0.075, 0.16666666666667
92023, 0.82608695652174, 0.075, 0.22222222222222
92024, 0.82608695652174, 0.075, 0.27777777777778
92025, 0.82608695652174, 0.075, 0.33333333333333
92026, 0.82608695652174, 0.075, 0.38888888888889
92027, 0.82608695652174, 0.075, 0.44444444444444
92028, 0.78260869565217, 0.075, 0.055555555555556
92029, 0.78260869565217, 0.075, 0.11111111111111
92030, 0.78260869565217, 0.075, 0.16666666666667
92031, 0.78260869565217, 0.075, 0.22222222222222
92032, 0.78260869565217, 0.075, 0.27777777777778
92033, 0.78260869565217, 0.075, 0.33333333333333
92034, 0.78260869565217, 0.075, 0.38888888888889
92035, 0.78260869565217, 0.075, 0.44444444444444
92036, 0.73913043478261, 0.075, 0.055555555555556
92037, 0.73913043478261, 0.075, 0.11111111111111
92038, 0.73913043478261, 0.075, 0.16666666666667
92039, 0.73913043478261, 0.075, 0.22222222222222
92040, 0.73913043478261, 0.075, 0.27777777777778
92041, 0.73913043478261, 0.075, 0.33333333333333
92042, 0.73913043478261, 0.075, 0.38888888888889
92043, 0.73913043478261, 0.075, 0.44444444444444
92044, 0.69565217391304, 0.075, 0.055555555555556
92045, 0.69565217391304, 0.075, 0.11111111111111
92046, 0.69565217391304, 0.075, 0.16666666666667
92047, 0.69565217391304, 0.075, 0.22222222222222
92048, 0.69565217391304, 0.075, 0.27777777777778
92049, 0.69565217391304, 0.075, 0.33333333333333
92050, 0.69565217391304, 0.075, 0.38888888888889
92051, 0.69565217391304, 0.075, 0.44444444444444
92052, 0.65217391304348, 0.075, 0.055555555555556
92053, 0.65217391304348, 0.075, 0.11111111111111
92054, 0.65217391304348, 0.075, 0.16666666666667
92055, 0.65217391304348, 0.075, 0.22222222222222
92056, 0.65217391304348, 0.075, 0.27777777777778
92057, 0.65217391304348, 0.075, 0.33333333333333
92058, 0.65217391304348, 0.075, 0.38888888888889
92059, 0.65217391304348, 0.075, 0.44444444444444
92060, 0.60869565217391, 0.075, 0.055555555555556
92061, 0.60869565217391, 0.075, 0.11111111111111
92062, 0.60869565217391, 0.075, 0.16666666666667
92063, 0.60869565217391, 0.075, 0.22222222222222
92064, 0.60869565217391, 0.075, 0.27777777777778
92065, 0.60869565217391, 0.075, 0.33333333333333
92066, 0.60869565217391, 0.075, 0.38888888888889
92067, 0.60869565217391, 0.075, 0.44444444444444
92068, 0.56521739130435, 0.075, 0.055555555555556
92069, 0.56521739130435, 0.075, 0.11111111111111
92070, 0.56521739130435, 0.075, 0.16666666666667
92071, 0.56521739130435, 0.075, 0.22222222222222
92072, 0.56521739130435, 0.075, 0.27777777777778
92073, 0.56521739130435, 0.075, 0.33333333333333
92074, 0.56521739130435, 0.075, 0.38888888888889
92075, 0.56521739130435, 0.075, 0.44444444444444
92076, 0.52173913043478, 0.075, 0.055555555555556
92077, 0.52173913043478, 0.075, 0.11111111111111
92078, 0.52173913043478, 0.075, 0.16666666666667
92079, 0.52173913043478, 0.075, 0.22222222222222
92080, 0.52173913043478, 0.075, 0.27777777777778
92081, 0.52173913043478, 0.075, 0.33333333333333
92082, 0.52173913043478, 0.075, 0.38888888888889
92083, 0.52173913043478, 0.075, 0.44444444444444
92084, 0.47826086956522, 0.075, 0.055555555555556
92085, 0.47826086956522, 0.075, 0.11111111111111
92086, 0.47826086956522, 0.075, 0.16666666666667
92087, 0.47826086956522, 0.075, 0.22222222222222
92088, 0.47826086956522, 0.075, 0.27777777777778
92089, 0.47826086956522, 0.075, 0.33333333333333
92090, 0.47826086956522, 0.075, 0.38888888888889
92091, 0.47826086956522, 0.075, 0.44444444444444
92092, 0.43478260869565, 0.075, 0.055555555555556
92093, 0.43478260869565, 0.075, 0.11111111111111
92094, 0.43478260869565, 0.075, 0.16666666666667
92095, 0.43478260869565, 0.075, 0.22222222222222
92096, 0.43478260869565, 0.075, 0.27777777777778
92097, 0.43478260869565, 0.075, 0.33333333333333
92098, 0.43478260869565, 0.075, 0.38888888888889
92099, 0.43478260869565, 0.075, 0.44444444444444
92100, 0.39130434782609, 0.075, 0.055555555555556
92101, 0.39130434782609, 0.075, 0.11111111111111
92102, 0.39130434782609, 0.075, 0.16666666666667
92103, 0.39130434782609, 0.075, 0.22222222222222
92104, 0.39130434782609, 0.075, 0.27777777777778
92105, 0.39130434782609, 0.075, 0.33333333333333
92106, 0.39130434782609, 0.075, 0.38888888888889
92107, 0.39130434782609, 0.075, 0.44444444444444
92108, 0.34782608695652, 0.075, 0.055555555555556
92109, 0.34782608695652, 0.075, 0.11111111111111
92110, 0.34782608695652, 0.075, 0.16666666666667
92111, 0.34782608695652, 0.075, 0.22222222222222
92112, 0.34782608695652, 0.075, 0.27777777777778
92113, 0.34782608695652, 0.075, 0.33333333333333
92114, 0.34782608695652, 0.075, 0.38888888888889
92115, 0.34782608695652, 0.075, 0.44444444444444
92116, 0.30434782608696, 0.075, 0.055555555555556
92117, 0.30434782608696, 0.075, 0.11111111111111
92118, 0.30434782608696, 0.075, 0.16666666666667
92119, 0.30434782608696, 0.075, 0.22222222222222
92120, 0.30434782608696, 0.075, 0.27777777777778
92121, 0.30434782608696, 0.075, 0.33333333333333
92122, 0.30434782608696, 0.075, 0.38888888888889
92123, 0.30434782608696, 0.075, 0.44444444444444
92124, 0.26086956521739, 0.075, 0.055555555555556
92125, 0.26086956521739, 0.075, 0.11111111111111
92126, 0.26086956521739, 0.075, 0.16666666666667
92127, 0.26086956521739, 0.075, 0.22222222222222
92128, 0.26086956521739, 0.075, 0.27777777777778
92129, 0.26086956521739, 0.075, 0.33333333333333
92130, 0.26086956521739, 0.075, 0.38888888888889
92131, 0.26086956521739, 0.075, 0.44444444444444
92132, 0.21739130434783, 0.075, 0.055555555555556
92133, 0.21739130434783, 0.075, 0.11111111111111
92134, 0.21739130434783, 0.075, 0.16666666666667
92135, 0.21739130434783, 0.075, 0.22222222222222
92136, 0.21739130434783, 0.075, 0.27777777777778
92137, 0.21739130434783, 0.075, 0.33333333333333
92138, 0.21739130434783, 0.075, 0.38888888888889
92139, 0.21739130434783, 0.075, 0.44444444444444
92140, 0.17391304347826, 0.075, 0.055555555555556
92141, 0.17391304347826, 0.075, 0.11111111111111
92142, 0.17391304347826, 0.075, 0.16666666666667
92143, 0.17391304347826, 0.075, 0.22222222222222
92144, 0.17391304347826, 0.075, 0.27777777777778
92145, 0.17391304347826, 0.075, 0.33333333333333
92146, 0.17391304347826, 0.075, 0.38888888888889
92147, 0.17391304347826, 0.075, 0.44444444444444
92148, 0.1304347826087, 0.075, 0.055555555555556
92149, 0.1304347826087, 0.075, 0.11111111111111
92150, 0.1304347826087, 0.075, 0.16666666666667
92151, 0.1304347826087, 0.075, 0.22222222222222
92152, 0.1304347826087, 0.075, 0.27777777777778
92153, 0.1304347826087, 0.075, 0.33333333333333
92154, 0.1304347826087, 0.075, 0.38888888888889
92155, 0.1304347826087, 0.075, 0.44444444444444
92156, 0.08695652173913, 0.075, 0.055555555555556
92157, 0.08695652173913, 0.075, 0.11111111111111
92158, 0.08695652173913, 0.075, 0.16666666666667
92159, 0.08695652173913, 0.075, 0.22222222222222
92160, 0.08695652173913, 0.075, 0.27777777777778
92161, 0.08695652173913, 0.075, 0.33333333333333
92162, 0.08695652173913, 0.075, 0.38888888888889
92163, 0.08695652173913, 0.075, 0.44444444444444
92164, 0.043478260869565, 0.075, 0.055555555555556
92165, 0.043478260869565, 0.075, 0.11111111111111
92166, 0.043478260869565, 0.075, 0.16666666666667
92167, 0.043478260869565, 0.075, 0.22222222222222
92168, 0.043478260869565, 0.075, 0.27777777777778
92169, 0.043478260869565, 0.075, 0.33333333333333
92170, 0.043478260869565, 0.075, 0.38888888888889
92171, 0.043478260869565, 0.075, 0.44444444444444
92172, 0.95652173913043, 0.075, 0.027777777777778
92173, 0.97826086956522, 0.075, 0.055555555555556
92174, 0.95652173913043, 0.0625, 0.055555555555556
92175, 0.95652173913043, 0.075, 0.083333333333333
92176, 0.97826086956522, 0.075, 0.11111111111111
92177, 0.95652173913043, 0.0625, 0.11111111111111
92178, 0.95652173913044, 0.075, 0.13888888888889
92179, 0.97826086956522, 0.075, 0.16666666666667
92180, 0.95652173913043, 0.0625, 0.16666666666667
92181, 0.95652173913044, 0.075, 0.19444444444444
92182, 0.97826086956522, 0.075, 0.22222222222222
92183, 0.95652173913044, 0.0625, 0.22222222222222
92184, 0.95652173913044, 0.075, 0.25
92185, 0.97826086956522, 0.075, 0.27777777777778
92186, 0.95652173913043, 0.0625, 0.27777777777778
92187, 0.95652173913044, 0.075, 0.30555555555556
92188, 0.97826086956522, 0.075, 0.33333333333333
92189, 0.95652173913043, 0.0625, 0.33333333333333
92190, 0.95652173913044, 0.075, 0.36111111111111
92191, 0.97826086956522, 0.075, 0.38888888888889
92192, 0.95652173913043, 0.0625, 0.38888888888889
92193, 0.95652173913044, 0.075, 0.41666666666667
92194, 0.97826086956522, 0.075, 0.44444444444444
92195, 0.95652173913043, 0.0625, 0.44444444444444
92196, 0.95652173913043, 0.075, 0.47222222222222
92197, 0.91304347826087, 0.075, 0.027777777777778
92198, 0.93478260869565, 0.075, 0.055555555555556
92199, 0.91304347826087, 0.0625, 0.055555555555556
92200, 0.91304347826087, 0.075, 0.083333333333333
92201, 0.93478260869565, 0.075, 0.11111111111111
92202, 0.91304347826087, 0.0625, 0.11111111111111
92203, 0.91304347826087, 0.075, 0.13888888888889
92204, 0.93478260869565, 0.075, 0.16666666666667
92205, 0.91304347826087, 0.0625, 0.16666666666667
92206, 0.91304347826087, 0.075, 0.19444444444444
92207, 0.93478260869565, 0.075, 0.22222222222222
92208, 0.91304347826087, 0.0625, 0.22222222222222
92209, 0.91304347826087, 0.075, 0.25
92210, 0.93478260869565, 0.075, 0.27777777777778
92211, 0.91304347826087, 0.0625, 0.27777777777778
92212, 0.91304347826087, 0.075, 0.30555555555556
92213, 0.93478260869565, 0.075, 0.33333333333333
92214, 0.91304347826087, 0.0625, 0.33333333333333
92215, 0.91304347826087, 0.075, 0.36111111111111
92216, 0.93478260869565, 0.075, 0.38888888888889
92217, 0.91304347826087, 0.0625, 0.38888888888889
92218, 0.91304347826087, 0.075, 0.41666666666667
92219, 0.93478260869565, 0.075, 0.44444444444444
92220, 0.91304347826087, 0.0625, 0.44444444444444
92221, 0.91304347826087, 0.075, 0.47222222222222
92222, 0.8695652173913, 0.075, 0.027777777777778
92223, 0.89130434782609, 0.075, 0.055555555555556
92224, 0.8695652173913, 0.0625, 0.055555555555556
92225, 0.8695652173913, 0.075, 0.083333333333333
92226, 0.89130434782609, 0.075, 0.11111111111111
92227, 0.8695652173913, 0.0625, 0.11111111111111
92228, 0.8695652173913, 0.075, 0.13888888888889
92229, 0.89130434782609, 0.075, 0.16666666666667
92230, 0.8695652173913, 0.0625, 0.16666666666667
92231, 0.8695652173913, 0.075, 0.19444444444444
92232, 0.89130434782609, 0.075, 0.22222222222222
92233, 0.8695652173913, 0.0625, 0.22222222222222
92234, 0.8695652173913, 0.075, 0.25
92235, 0.89130434782609, 0.075, 0.27777777777778
92236, 0.8695652173913, 0.0625, 0.27777777777778
92237, 0.8695652173913, 0.075, 0.30555555555556
92238, 0.89130434782609, 0.075, 0.33333333333333
92239, 0.8695652173913, 0.0625, 0.33333333333333
92240, 0.8695652173913, 0.075, 0.36111111111111
92241, 0.89130434782609, 0.075, 0.38888888888889
92242, 0.8695652173913, 0.0625, 0.38888888888889
92243, 0.8695652173913, 0.075, 0.41666666666667
92244, 0.89130434782609, 0.075, 0.44444444444444
92245, 0.8695652173913, 0.0625, 0.44444444444444
92246, 0.8695652173913, 0.075, 0.47222222222222
92247, 0.82608695652174, 0.075, 0.027777777777778
92248, 0.84782608695652, 0.075, 0.055555555555556
92249, 0.82608695652174, 0.0625, 0.055555555555556
92250, 0.82608695652174, 0.075, 0.083333333333333
92251, 0.84782608695652, 0.075, 0.11111111111111
92252, 0.82608695652174, 0.0625, 0.11111111111111
92253, 0.82608695652174, 0.075, 0.13888888888889
92254, 0.84782608695652, 0.075, 0.16666666666667
92255, 0.82608695652174, 0.0625, 0.16666666666667
92256, 0.82608695652174, 0.075, 0.19444444444444
92257, 0.84782608695652, 0.075, 0.22222222222222
92258, 0.82608695652174, 0.0625, 0.22222222222222
92259, 0.82608695652174, 0.075, 0.25
92260, 0.84782608695652, 0.075, 0.27777777777778
92261, 0.82608695652174, 0.0625, 0.27777777777778
92262, 0.82608695652174, 0.075, 0.30555555555556
92263, 0.84782608695652, 0.075, 0.33333333333333
92264, 0.82608695652174, 0.0625, 0.33333333333333
92265, 0.82608695652174, 0.075, 0.36111111111111
92266, 0.84782608695652, 0.075, 0.38888888888889
92267, 0.82608695652174, 0.0625, 0.38888888888889
92268, 0.82608695652174, 0.075, 0.41666666666667
92269, 0.84782608695652, 0.075, 0.44444444444444
92270, 0.82608695652174, 0.0625, 0.44444444444444
92271, 0.82608695652174, 0.075, 0.47222222222222
92272, 0.78260869565217, 0.075, 0.027777777777778
92273, 0.80434782608696, 0.075, 0.055555555555556
92274, 0.78260869565217, 0.0625, 0.055555555555556
92275, 0.78260869565217, 0.075, 0.083333333333333
92276, 0.80434782608696, 0.075, 0.11111111111111
92277, 0.78260869565217, 0.0625, 0.11111111111111
92278, 0.78260869565217, 0.075, 0.13888888888889
92279, 0.80434782608696, 0.075, 0.16666666666667
92280, 0.78260869565217, 0.0625, 0.16666666666667
92281, 0.78260869565217, 0.075, 0.19444444444444
92282, 0.80434782608696, 0.075, 0.22222222222222
92283, 0.78260869565217, 0.0625, 0.22222222222222
92284, 0.78260869565217, 0.075, 0.25
92285, 0.80434782608696, 0.075, 0.27777777777778
92286, 0.78260869565217, 0.0625, 0.27777777777778
92287, 0.78260869565217, 0.075, 0.30555555555556
92288, 0.80434782608696, 0.075, 0.33333333333333
92289, 0.78260869565217, 0.0625, 0.33333333333333
92290, 0.78260869565217, 0.075, 0.36111111111111
92291, 0.80434782608696, 0.075, 0.38888888888889
92292, 0.78260869565217, 0.0625, 0.38888888888889
92293, 0.78260869565217, 0.075, 0.41666666666667
92294, 0.80434782608696, 0.075, 0.44444444444444
92295, 0.78260869565217, 0.0625, 0.44444444444444
92296, 0.78260869565217, 0.075, 0.47222222222222
92297, 0.73913043478261, 0.075, 0.027777777777778
92298, 0.76086956521739, 0.075, 0.055555555555556
92299, 0.73913043478261, 0.0625, 0.055555555555556
92300, 0.73913043478261, 0.075, 0.083333333333333
92301, 0.76086956521739, 0.075, 0.11111111111111
92302, 0.73913043478261, 0.0625, 0.11111111111111
92303, 0.73913043478261, 0.075, 0.13888888888889
92304, 0.76086956521739, 0.075, 0.16666666666667
92305, 0.73913043478261, 0.0625, 0.16666666666667
92306, 0.73913043478261, 0.075, 0.19444444444444
92307, 0.76086956521739, 0.075, 0.22222222222222
92308, 0.73913043478261, 0.0625, 0.22222222222222
92309, 0.73913043478261, 0.075, 0.25
92310, 0.76086956521739, 0.075, 0.27777777777778
92311, 0.73913043478261, 0.0625, 0.27777777777778
92312, 0.73913043478261, 0.075, 0.30555555555556
92313, 0.76086956521739, 0.075, 0.33333333333333
92314, 0.73913043478261, 0.0625, 0.33333333333333
92315, 0.73913043478261, 0.075, 0.36111111111111
92316, 0.76086956521739, 0.075, 0.38888888888889
92317, 0.73913043478261, 0.0625, 0.38888888888889
92318, 0.73913043478261, 0.075, 0.41666666666667
92319, 0.76086956521739, 0.075, 0.44444444444444
92320, 0.73913043478261, 0.0625, 0.44444444444444
92321, 0.73913043478261, 0.075, 0.47222222222222
92322, 0.69565217391304, 0.075, 0.027777777777778
92323, 0.71739130434783, 0.075, 0.055555555555556
92324, 0.69565217391304, 0.0625, 0.055555555555556
92325, 0.69565217391304, 0.075, 0.083333333333333
92326, 0.71739130434783, 0.075, 0.11111111111111
92327, 0.69565217391304, 0.0625, 0.11111111111111
92328, 0.69565217391304, 0.075, 0.13888888888889
92329, 0.71739130434783, 0.075, 0.16666666666667
92330, 0.69565217391304, 0.0625, 0.16666666666667
92331, 0.69565217391304, 0.075, 0.19444444444444
92332, 0.71739130434783, 0.075, 0.22222222222222
92333, 0.69565217391304, 0.0625, 0.22222222222222
92334, 0.69565217391304, 0.075, 0.25
92335, 0.71739130434783, 0.075, 0.27777777777778
92336, 0.69565217391304, 0.0625, 0.27777777777778
92337, 0.69565217391304, 0.075, 0.30555555555556
92338, 0.71739130434783, 0.075, 0.33333333333333
92339, 0.69565217391304, 0.0625, 0.33333333333333
92340, 0.69565217391304, 0.075, 0.36111111111111
92341, 0.71739130434783, 0.075, 0.38888888888889
92342, 0.69565217391304, 0.0625, 0.38888888888889
92343, 0.69565217391304, 0.075, 0.41666666666667
92344, 0.71739130434783, 0.075, 0.44444444444444
92345, 0.69565217391304, 0.0625, 0.44444444444444
92346, 0.69565217391304, 0.075, 0.47222222222222
92347, 0.65217391304348, 0.075, 0.027777777777778
92348, 0.67391304347826, 0.075, 0.055555555555556
92349, 0.65217391304348, 0.0625, 0.055555555555556
92350, 0.65217391304348, 0.075, 0.083333333333333
92351, 0.67391304347826, 0.075, 0.11111111111111
92352, 0.65217391304348, 0.0625, 0.11111111111111
92353, 0.65217391304348, 0.075, 0.13888888888889
92354, 0.67391304347826, 0.075, 0.16666666666667
92355, 0.65217391304348, 0.0625, 0.16666666666667
92356, 0.65217391304348, 0.075, 0.19444444444444
92357, 0.67391304347826, 0.075, 0.22222222222222
92358, 0.65217391304348, 0.0625, 0.22222222222222
92359, 0.65217391304348, 0.075, 0.25
92360, 0.67391304347826, 0.075, 0.27777777777778
92361, 0.65217391304348, 0.0625, 0.27777777777778
92362, 0.65217391304348, 0.075, 0.30555555555556
92363, 0.67391304347826, 0.075, 0.33333333333333
92364, 0.65217391304348, 0.0625, 0.33333333333333
92365, 0.65217391304348, 0.075, 0.36111111111111
92366, 0.67391304347826, 0.075, 0.38888888888889
92367, 0.65217391304348, 0.0625, 0.38888888888889
92368, 0.65217391304348, 0.075, 0.41666666666667
92369, 0.67391304347826, 0.075, 0.44444444444444
92370, 0.65217391304348, 0.0625, 0.44444444444444
92371, 0.65217391304348, 0.075, 0.47222222222222
92372, 0.60869565217391, 0.075, 0.027777777777778
92373, 0.6304347826087, 0.075, 0.055555555555556
92374, 0.60869565217391, 0.0625, 0.055555555555556
92375, 0.60869565217391, 0.075, 0.083333333333333
92376, 0.6304347826087, 0.075, 0.11111111111111
92377, 0.60869565217391, 0.0625, 0.11111111111111
92378, 0.60869565217391, 0.075, 0.13888888888889
92379, 0.6304347826087, 0.075, 0.16666666666667
92380, 0.60869565217391, 0.0625, 0.16666666666667
92381, 0.60869565217391, 0.075, 0.19444444444444
92382, 0.6304347826087, 0.075, 0.22222222222222
92383, 0.60869565217391, 0.0625, 0.22222222222222
92384, 0.60869565217391, 0.075, 0.25
92385, 0.6304347826087, 0.075, 0.27777777777778
92386, 0.60869565217391, 0.0625, 0.27777777777778
92387, 0.60869565217391, 0.075, 0.30555555555556
92388, 0.6304347826087, 0.075, 0.33333333333333
92389, 0.60869565217391, 0.0625, 0.33333333333333
92390, 0.60869565217391, 0.075, 0.36111111111111
92391, 0.6304347826087, 0.075, 0.38888888888889
92392, 0.60869565217391, 0.0625, 0.38888888888889
92393, 0.60869565217391, 0.075, 0.41666666666667
92394, 0.6304347826087, 0.075, 0.44444444444444
92395, 0.60869565217391, 0.0625, 0.44444444444444
92396, 0.60869565217391, 0.075, 0.47222222222222
92397, 0.56521739130435, 0.075, 0.027777777777778
92398, 0.58695652173913, 0.075, 0.055555555555556
92399, 0.56521739130435, 0.0625, 0.055555555555556
92400, 0.56521739130435, 0.075, 0.083333333333333
92401, 0.58695652173913, 0.075, 0.11111111111111
92402, 0.56521739130435, 0.0625, 0.11111111111111
92403, 0.56521739130435, 0.075, 0.13888888888889
92404, 0.58695652173913, 0.075, 0.16666666666667
92405, 0.56521739130435, 0.0625, 0.16666666666667
92406, 0.56521739130435, 0.075, 0.19444444444444
92407, 0.58695652173913, 0.075, 0.22222222222222
92408, 0.56521739130435, 0.0625, 0.22222222222222
92409, 0.56521739130435, 0.075, 0.25
92410, 0.58695652173913, 0.075, 0.27777777777778
92411, 0.56521739130435, 0.0625, 0.27777777777778
92412, 0.56521739130435, 0.075, 0.30555555555556
92413, 0.58695652173913, 0.075, 0.33333333333333
92414, 0.56521739130435, 0.0625, 0.33333333333333
92415, 0.56521739130435, 0.075, 0.36111111111111
92416, 0.58695652173913, 0.075, 0.38888888888889
92417, 0.56521739130435, 0.0625, 0.38888888888889
92418, 0.56521739130435, 0.075, 0.41666666666667
92419, 0.58695652173913, 0.075, 0.44444444444444
92420, 0.56521739130435, 0.0625, 0.44444444444444
92421, 0.56521739130435, 0.075, 0.47222222222222
92422, 0.52173913043478, 0.075, 0.027777777777778
92423, 0.54347826086957, 0.075, 0.055555555555556
92424, 0.52173913043478, 0.0625, 0.055555555555556
92425, 0.52173913043478, 0.075, 0.083333333333333
92426, 0.54347826086957, 0.075, 0.11111111111111
92427, 0.52173913043478, 0.0625, 0.11111111111111
92428, 0.52173913043478, 0.075, 0.13888888888889
92429, 0.54347826086957, 0.075, 0.16666666666667
92430, 0.52173913043478, 0.0625, 0.16666666666667
92431, 0.52173913043478, 0.075, 0.19444444444444
92432, 0.54347826086956, 0.075, 0.22222222222222
92433, 0.52173913043478, 0.0625, 0.22222222222222
92434, 0.52173913043478, 0.075, 0.25
92435, 0.54347826086956, 0.075, 0.27777777777778
92436, 0.52173913043478, 0.0625, 0.27777777777778
92437, 0.52173913043478, 0.075, 0.30555555555556
92438, 0.54347826086956, 0.075, 0.33333333333333
92439, 0.52173913043478, 0.0625, 0.33333333333333
92440, 0.52173913043478, 0.075, 0.36111111111111
92441, 0.54347826086956, 0.075, 0.38888888888889
92442, 0.52173913043478, 0.0625, 0.38888888888889
92443, 0.52173913043478, 0.075, 0.41666666666667
92444, 0.54347826086956, 0.075, 0.44444444444444
92445, 0.52173913043478, 0.0625, 0.44444444444444
92446, 0.52173913043478, 0.075, 0.47222222222222
92447, 0.47826086956522, 0.075, 0.027777777777778
92448, 0.5, 0.075, 0.055555555555556
92449, 0.47826086956522, 0.0625, 0.055555555555556
92450, 0.47826086956522, 0.075, 0.083333333333333
92451, 0.5, 0.075, 0.11111111111111
92452, 0.47826086956522, 0.0625, 0.11111111111111
92453, 0.47826086956522, 0.075, 0.13888888888889
92454, 0.5, 0.075, 0.16666666666667
92455, 0.47826086956522, 0.0625, 0.16666666666667
92456, 0.47826086956522, 0.075, 0.19444444444444
92457, 0.5, 0.075, 0.22222222222222
92458, 0.47826086956522, 0.0625, 0.22222222222222
92459, 0.47826086956522, 0.075, 0.25
92460, 0.5, 0.075, 0.27777777777778
92461, 0.47826086956522, 0.0625, 0.27777777777778
92462, 0.47826086956522, 0.075, 0.30555555555556
92463, 0.5, 0.075, 0.33333333333333
92464, 0.47826086956522, 0.0625, 0.33333333333333
92465, 0.47826086956522, 0.075, 0.36111111111111
92466, 0.5, 0.075, 0.38888888888889
92467, 0.47826086956522, 0.0625, 0.38888888888889
92468, 0.47826086956522, 0.075, 0.41666666666667
92469, 0.5, 0.075, 0.44444444444444
92470, 0.47826086956522, 0.0625, 0.44444444444444
92471, 0.47826086956522, 0.075, 0.47222222222222
92472, 0.43478260869565, 0.075, 0.027777777777778
92473, 0.45652173913043, 0.075, 0.055555555555556
92474, 0.43478260869565, 0.0625, 0.055555555555556
92475, 0.43478260869565, 0.075, 0.083333333333333
92476, 0.45652173913043, 0.075, 0.11111111111111
92477, 0.43478260869565, 0.0625, 0.11111111111111
92478, 0.43478260869565, 0.075, 0.13888888888889
92479, 0.45652173913043, 0.075, 0.16666666666667
92480, 0.43478260869565, 0.0625, 0.16666666666667
92481, 0.43478260869565, 0.075, 0.19444444444444
92482, 0.45652173913043, 0.075, 0.22222222222222
92483, 0.43478260869565, 0.0625, 0.22222222222222
92484, 0.43478260869565, 0.075, 0.25
92485, 0.45652173913043, 0.075, 0.27777777777778
92486, 0.43478260869565, 0.0625, 0.27777777777778
92487, 0.43478260869565, 0.075, 0.30555555555556
92488, 0.45652173913043, 0.075, 0.33333333333333
92489, 0.43478260869565, 0.0625, 0.33333333333333
92490, 0.43478260869565, 0.075, 0.36111111111111
92491, 0.45652173913044, 0.075, 0.38888888888889
92492, 0.43478260869565, 0.0625, 0.38888888888889
92493, 0.43478260869565, 0.075, 0.41666666666667
92494, 0.45652173913043, 0.075, 0.44444444444444
92495, 0.43478260869565, 0.0625, 0.44444444444444
92496, 0.43478260869565, 0.075, 0.47222222222222
92497, 0.39130434782609, 0.075, 0.027777777777778
92498, 0.41304347826087, 0.075, 0.055555555555556
92499, 0.39130434782609, 0.0625, 0.055555555555556
92500, 0.39130434782609, 0.075, 0.083333333333333
92501, 0.41304347826087, 0.075, 0.11111111111111
92502, 0.39130434782609, 0.0625, 0.11111111111111
92503, 0.39130434782609, 0.075, 0.13888888888889
92504, 0.41304347826087, 0.075, 0.16666666666667
92505, 0.39130434782609, 0.0625, 0.16666666666667
92506, 0.39130434782609, 0.075, 0.19444444444444
92507, 0.41304347826087, 0.075, 0.22222222222222
92508, 0.39130434782609, 0.0625, 0.22222222222222
92509, 0.39130434782609, 0.075, 0.25
92510, 0.41304347826087, 0.075, 0.27777777777778
92511, 0.39130434782609, 0.0625, 0.27777777777778
92512, 0.39130434782609, 0.075, 0.30555555555556
92513, 0.41304347826087, 0.075, 0.33333333333333
92514, 0.39130434782609, 0.0625, 0.33333333333333
92515, 0.39130434782609, 0.075, 0.36111111111111
92516, 0.41304347826087, 0.075, 0.38888888888889
92517, 0.39130434782609, 0.0625, 0.38888888888889
92518, 0.39130434782609, 0.075, 0.41666666666667
92519, 0.41304347826087, 0.075, 0.44444444444444
92520, 0.39130434782609, 0.0625, 0.44444444444444
92521, 0.39130434782609, 0.075, 0.47222222222222
92522, 0.34782608695652, 0.075, 0.027777777777778
92523, 0.3695652173913, 0.075, 0.055555555555556
92524, 0.34782608695652, 0.0625, 0.055555555555556
92525, 0.34782608695652, 0.075, 0.083333333333333
92526, 0.3695652173913, 0.075, 0.11111111111111
92527, 0.34782608695652, 0.0625, 0.11111111111111
92528, 0.34782608695652, 0.075, 0.13888888888889
92529, 0.3695652173913, 0.075, 0.16666666666667
92530, 0.34782608695652, 0.0625, 0.16666666666667
92531, 0.34782608695652, 0.075, 0.19444444444444
92532, 0.3695652173913, 0.075, 0.22222222222222
92533, 0.34782608695652, 0.0625, 0.22222222222222
92534, 0.34782608695652, 0.075, 0.25
92535, 0.3695652173913, 0.075, 0.27777777777778
92536, 0.34782608695652, 0.0625, 0.27777777777778
92537, 0.34782608695652, 0.075, 0.30555555555556
92538, 0.3695652173913, 0.075, 0.33333333333333
92539, 0.34782608695652, 0.0625, 0.33333333333333
92540, 0.34782608695652, 0.075, 0.36111111111111
92541, 0.3695652173913, 0.075, 0.38888888888889
92542, 0.34782608695652, 0.0625, 0.38888888888889
92543, 0.34782608695652, 0.075, 0.41666666666667
92544, 0.3695652173913, 0.075, 0.44444444444444
92545, 0.34782608695652, 0.0625, 0.44444444444444
92546, 0.34782608695652, 0.075, 0.47222222222222
92547, 0.30434782608696, 0.075, 0.027777777777778
92548, 0.32608695652174, 0.075, 0.055555555555556
92549, 0.30434782608696, 0.0625, 0.055555555555556
92550, 0.30434782608696, 0.075, 0.083333333333333
92551, 0.32608695652174, 0.075, 0.11111111111111
92552, 0.30434782608696, 0.0625, 0.11111111111111
92553, 0.30434782608696, 0.075, 0.13888888888889
92554, 0.32608695652174, 0.075, 0.16666666666667
92555, 0.30434782608696, 0.0625, 0.16666666666667
92556, 0.30434782608696, 0.075, 0.19444444444444
92557, 0.32608695652174, 0.075, 0.22222222222222
92558, 0.30434782608696, 0.0625, 0.22222222222222
92559, 0.30434782608696, 0.075, 0.25
92560, 0.32608695652174, 0.075, 0.27777777777778
92561, 0.30434782608696, 0.0625, 0.27777777777778
92562, 0.30434782608696, 0.075, 0.30555555555556
92563, 0.32608695652174, 0.075, 0.33333333333333
92564, 0.30434782608696, 0.0625, 0.33333333333333
92565, 0.30434782608696, 0.075, 0.36111111111111
92566, 0.32608695652174, 0.075, 0.38888888888889
92567, 0.30434782608696, 0.0625, 0.38888888888889
92568, 0.30434782608696, 0.075, 0.41666666666667
92569, 0.32608695652174, 0.075, 0.44444444444444
92570, 0.30434782608696, 0.0625, 0.44444444444444
92571, 0.30434782608696, 0.075, 0.47222222222222
92572, 0.26086956521739, 0.075, 0.027777777777778
92573, 0.28260869565217, 0.075, 0.055555555555556
92574, 0.26086956521739, 0.0625, 0.055555555555556
92575, 0.26086956521739, 0.075, 0.083333333333333
92576, 0.28260869565217, 0.075, 0.11111111111111
92577, 0.26086956521739, 0.0625, 0.11111111111111
92578, 0.26086956521739, 0.075, 0.13888888888889
92579, 0.28260869565217, 0.075, 0.16666666666667
92580, 0.26086956521739, 0.0625, 0.16666666666667
92581, 0.26086956521739, 0.075, 0.19444444444444
92582, 0.28260869565217, 0.075, 0.22222222222222
92583, 0.26086956521739, 0.0625, 0.22222222222222
92584, 0.26086956521739, 0.075, 0.25
92585, 0.28260869565217, 0.075, 0.27777777777778
92586, 0.26086956521739, 0.0625, 0.27777777777778
92587, 0.26086956521739, 0.075, 0.30555555555556
92588, 0.28260869565217, 0.075, 0.33333333333333
92589, 0.26086956521739, 0.0625, 0.33333333333333
92590, 0.26086956521739, 0.075, 0.36111111111111
92591, 0.28260869565217, 0.075, 0.38888888888889
92592, 0.26086956521739, 0.0625, 0.38888888888889
92593, 0.26086956521739, 0.075, 0.41666666666667
92594, 0.28260869565217, 0.075, 0.44444444444444
92595, 0.26086956521739, 0.0625, 0.44444444444444
92596, 0.26086956521739, 0.075, 0.47222222222222
92597, 0.21739130434783, 0.075, 0.027777777777778
92598, 0.23913043478261, 0.075, 0.055555555555556
92599, 0.21739130434783, 0.0625, 0.055555555555556
92600, 0.21739130434783, 0.075, 0.083333333333333
92601, 0.23913043478261, 0.075, 0.11111111111111
92602, 0.21739130434783, 0.0625, 0.11111111111111
92603, 0.21739130434783, 0.075, 0.13888888888889
92604, 0.23913043478261, 0.075, 0.16666666666667
92605, 0.21739130434783, 0.0625, 0.16666666666667
92606, 0.21739130434783, 0.075, 0.19444444444444
92607, 0.23913043478261, 0.075, 0.22222222222222
92608, 0.21739130434783, 0.0625, 0.22222222222222
92609, 0.21739130434783, 0.075, 0.25
92610, 0.23913043478261, 0.075, 0.27777777777778
92611, 0.21739130434783, 0.0625, 0.27777777777778
92612, 0.21739130434783, 0.075, 0.30555555555556
92613, 0.23913043478261, 0.075, 0.33333333333333
92614, 0.21739130434783, 0.0625, 0.33333333333333
92615, 0.21739130434783, 0.075, 0.36111111111111
92616, 0.23913043478261, 0.075, 0.38888888888889
92617, 0.21739130434783, 0.0625, 0.38888888888889
92618, 0.21739130434783, 0.075, 0.41666666666667
92619, 0.23913043478261, 0.075, 0.44444444444444
92620, 0.21739130434783, 0.0625, 0.44444444444444
92621, 0.21739130434783, 0.075, 0.47222222222222
92622, 0.17391304347826, 0.075, 0.027777777777778
92623, 0.19565217391304, 0.075, 0.055555555555556
92624, 0.17391304347826, 0.0625, 0.055555555555556
92625, 0.17391304347826, 0.075, 0.083333333333333
92626, 0.19565217391304, 0.075, 0.11111111111111
92627, 0.17391304347826, 0.0625, 0.11111111111111
92628, 0.17391304347826, 0.075, 0.13888888888889
92629, 0.19565217391304, 0.075, 0.16666666666667
92630, 0.17391304347826, 0.0625, 0.16666666666667
92631, 0.17391304347826, 0.075, 0.19444444444444
92632, 0.19565217391304, 0.075, 0.22222222222222
92633, 0.17391304347826, 0.0625, 0.22222222222222
92634, 0.17391304347826, 0.075, 0.25
92635, 0.19565217391304, 0.075, 0.27777777777778
92636, 0.17391304347826, 0.0625, 0.27777777777778
92637, 0.17391304347826, 0.075, 0.30555555555556
92638, 0.19565217391304, 0.075, 0.33333333333333
92639, 0.17391304347826, 0.0625, 0.33333333333333
92640, 0.17391304347826, 0.075, 0.36111111111111
92641, 0.19565217391304, 0.075, 0.38888888888889
92642, 0.17391304347826, 0.0625, 0.38888888888889
92643, 0.17391304347826, 0.075, 0.41666666666667
92644, 0.19565217391304, 0.075, 0.44444444444444
92645, 0.17391304347826, 0.0625, 0.44444444444444
92646, 0.17391304347826, 0.075, 0.47222222222222
92647, 0.1304347826087, 0.075, 0.027777777777778
92648, 0.15217391304348, 0.075, 0.055555555555556
92649, 0.1304347826087, 0.0625, 0.055555555555556
92650, 0.1304347826087, 0.075, 0.083333333333333
92651, 0.15217391304348, 0.075, 0.11111111111111
92652, 0.1304347826087, 0.0625, 0.11111111111111
92653, 0.1304347826087, 0.075, 0.13888888888889
92654, 0.15217391304348, 0.075, 0.16666666666667
92655, 0.1304347826087, 0.0625, 0.16666666666667
92656, 0.1304347826087, 0.075, 0.19444444444444
92657, 0.15217391304348, 0.075, 0.22222222222222
92658, 0.1304347826087, 0.0625, 0.22222222222222
92659, 0.1304347826087, 0.075, 0.25
92660, 0.15217391304348, 0.075, 0.27777777777778
92661, 0.1304347826087, 0.0625, 0.27777777777778
92662, 0.1304347826087, 0.075, 0.30555555555556
92663, 0.15217391304348, 0.075, 0.33333333333333
92664, 0.1304347826087, 0.0625, 0.33333333333333
92665, 0.1304347826087, 0.075, 0.36111111111111
92666, 0.15217391304348, 0.075, 0.38888888888889
92667, 0.1304347826087, 0.0625, 0.38888888888889
92668, 0.1304347826087, 0.075, 0.41666666666667
92669, 0.15217391304348, 0.075, 0.44444444444444
92670, 0.1304347826087, 0.0625, 0.44444444444444
92671, 0.1304347826087, 0.075, 0.47222222222222
92672, 0.08695652173913, 0.075, 0.027777777777778
92673, 0.10869565217391, 0.075, 0.055555555555556
92674, 0.08695652173913, 0.0625, 0.055555555555556
92675, 0.08695652173913, 0.075, 0.083333333333333
92676, 0.10869565217391, 0.075, 0.11111111111111
92677, 0.08695652173913, 0.0625, 0.11111111111111
92678, 0.08695652173913, 0.075, 0.13888888888889
92679, 0.10869565217391, 0.075, 0.16666666666667
92680, 0.08695652173913, 0.0625, 0.16666666666667
92681, 0.08695652173913, 0.075, 0.19444444444444
92682, 0.10869565217391, 0.075, 0.22222222222222
92683, 0.08695652173913, 0.0625, 0.22222222222222
92684, 0.08695652173913, 0.075, 0.25
92685, 0.10869565217391, 0.075, 0.27777777777778
92686, 0.08695652173913, 0.0625, 0.27777777777778
92687, 0.08695652173913, 0.075, 0.30555555555556
92688, 0.10869565217391, 0.075, 0.33333333333333
92689, 0.08695652173913, 0.0625, 0.33333333333333
92690, 0.08695652173913, 0.075, 0.36111111111111
92691, 0.10869565217391, 0.075, 0.38888888888889
92692, 0.08695652173913, 0.0625, 0.38888888888889
92693, 0.08695652173913, 0.075, 0.41666666666667
92694, 0.10869565217391, 0.075, 0.44444444444444
92695, 0.08695652173913, 0.0625, 0.44444444444444
92696, 0.08695652173913, 0.075, 0.47222222222222
92697, 0.043478260869565, 0.075, 0.027777777777778
92698, 0.065217391304348, 0.075, 0.055555555555556
92699, 0.043478260869565, 0.0625, 0.055555555555556
92700, 0.043478260869565, 0.075, 0.083333333333333
92701, 0.065217391304348, 0.075, 0.11111111111111
92702, 0.043478260869565, 0.0625, 0.11111111111111
92703, 0.043478260869565, 0.075, 0.13888888888889
92704, 0.065217391304348, 0.075, 0.16666666666667
92705, 0.043478260869565, 0.0625, 0.16666666666667
92706, 0.043478260869565, 0.075, 0.19444444444444
92707, 0.065217391304348, 0.075, 0.22222222222222
92708, 0.043478260869565, 0.0625, 0.22222222222222
92709, 0.043478260869565, 0.075, 0.25
92710, 0.065217391304348, 0.075, 0.27777777777778
92711, 0.043478260869565, 0.0625, 0.27777777777778
92712, 0.043478260869565, 0.075, 0.30555555555556
92713, 0.065217391304348, 0.075, 0.33333333333333
92714, 0.043478260869565, 0.0625, 0.33333333333333
92715, 0.043478260869565, 0.075, 0.36111111111111
92716, 0.065217391304348, 0.075, 0.38888888888889
92717, 0.043478260869565, 0.0625, 0.38888888888889
92718, 0.043478260869565, 0.075, 0.41666666666667
92719, 0.065217391304348, 0.075, 0.44444444444444
92720, 0.043478260869565, 0.0625, 0.44444444444444
92721, 0.043478260869565, 0.075, 0.47222222222222
92722, 0.021739130434783, 0.075, 0.055555555555556
92723, 0.021739130434783, 0.075, 0.11111111111111
92724, 0.021739130434783, 0.075, 0.16666666666667
92725, 0.021739130434783, 0.075, 0.22222222222222
92726, 0.021739130434783, 0.075, 0.27777777777778
92727, 0.021739130434783, 0.075, 0.33333333333333
92728, 0.021739130434783, 0.075, 0.38888888888889
92729, 0.021739130434783, 0.075, 0.44444444444444
92730, 0.95652173913043, 0.0875, 0.055555555555556
92731, 0.95652173913043, 0.0875, 0.11111111111111
92732, 0.95652173913043, 0.0875, 0.16666666666667
92733, 0.95652173913044, 0.0875, 0.22222222222222
92734, 0.95652173913043, 0.0875, 0.27777777777778
92735, 0.95652173913043, 0.0875, 0.33333333333333
92736, 0.95652173913043, 0.0875, 0.38888888888889
92737, 0.95652173913043, 0.0875, 0.44444444444444
92738, 0.91304347826087, 0.0875, 0.055555555555556
92739, 0.91304347826087, 0.0875, 0.11111111111111
92740, 0.91304347826087, 0.0875, 0.16666666666667
92741, 0.91304347826087, 0.0875, 0.22222222222222
92742, 0.91304347826087, 0.0875, 0.27777777777778
92743, 0.91304347826087, 0.0875, 0.33333333333333
92744, 0.91304347826087, 0.0875, 0.38888888888889
92745, 0.91304347826087, 0.0875, 0.44444444444444
92746, 0.8695652173913, 0.0875, 0.055555555555556
92747, 0.8695652173913, 0.0875, 0.11111111111111
92748, 0.8695652173913, 0.0875, 0.16666666666667
92749, 0.8695652173913, 0.0875, 0.22222222222222
92750, 0.8695652173913, 0.0875, 0.27777777777778
92751, 0.8695652173913, 0.0875, 0.33333333333333
92752, 0.8695652173913, 0.0875, 0.38888888888889
92753, 0.8695652173913, 0.0875, 0.44444444444444
92754, 0.82608695652174, 0.0875, 0.055555555555556
92755, 0.82608695652174, 0.0875, 0.11111111111111
92756, 0.82608695652174, 0.0875, 0.16666666666667
92757, 0.82608695652174, 0.0875, 0.22222222222222
92758, 0.82608695652174, 0.0875, 0.27777777777778
92759, 0.82608695652174, 0.0875, 0.33333333333333
92760, 0.82608695652174, 0.0875, 0.38888888888889
92761, 0.82608695652174, 0.0875, 0.44444444444444
92762, 0.78260869565217, 0.0875, 0.055555555555556
92763, 0.78260869565217, 0.0875, 0.11111111111111
92764, 0.78260869565217, 0.0875, 0.16666666666667
92765, 0.78260869565217, 0.0875, 0.22222222222222
92766, 0.78260869565217, 0.0875, 0.27777777777778
92767, 0.78260869565217, 0.0875, 0.33333333333333
92768, 0.78260869565217, 0.0875, 0.38888888888889
92769, 0.78260869565217, 0.0875, 0.44444444444444
92770, 0.73913043478261, 0.0875, 0.055555555555556
92771, 0.73913043478261, 0.0875, 0.11111111111111
92772, 0.73913043478261, 0.0875, 0.16666666666667
92773, 0.73913043478261, 0.0875, 0.22222222222222
92774, 0.73913043478261, 0.0875, 0.27777777777778
92775, 0.73913043478261, 0.0875, 0.33333333333333
92776, 0.73913043478261, 0.0875, 0.38888888888889
92777, 0.73913043478261, 0.0875, 0.44444444444444
92778, 0.69565217391304, 0.0875, 0.055555555555556
92779, 0.69565217391304, 0.0875, 0.11111111111111
92780, 0.69565217391304, 0.0875, 0.16666666666667
92781, 0.69565217391304, 0.0875, 0.22222222222222
92782, 0.69565217391304, 0.0875, 0.27777777777778
92783, 0.69565217391304, 0.0875, 0.33333333333333
92784, 0.69565217391304, 0.0875, 0.38888888888889
92785, 0.69565217391304, 0.0875, 0.44444444444444
92786, 0.65217391304348, 0.0875, 0.055555555555556
92787, 0.65217391304348, 0.0875, 0.11111111111111
92788, 0.65217391304348, 0.0875, 0.16666666666667
92789, 0.65217391304348, 0.0875, 0.22222222222222
92790, 0.65217391304348, 0.0875, 0.27777777777778
92791, 0.65217391304348, 0.0875, 0.33333333333333
92792, 0.65217391304348, 0.0875, 0.38888888888889
92793, 0.65217391304348, 0.0875, 0.44444444444444
92794, 0.60869565217391, 0.0875, 0.055555555555556
92795, 0.60869565217391, 0.0875, 0.11111111111111
92796, 0.60869565217391, 0.0875, 0.16666666666667
92797, 0.60869565217391, 0.0875, 0.22222222222222
92798, 0.60869565217391, 0.0875, 0.27777777777778
92799, 0.60869565217391, 0.0875, 0.33333333333333
92800, 0.60869565217391, 0.0875, 0.38888888888889
92801, 0.60869565217391, 0.0875, 0.44444444444444
92802, 0.56521739130435, 0.0875, 0.055555555555556
92803, 0.56521739130435, 0.0875, 0.11111111111111
92804, 0.56521739130435, 0.0875, 0.16666666666667
92805, 0.56521739130435, 0.0875, 0.22222222222222
92806, 0.56521739130435, 0.0875, 0.27777777777778
92807, 0.56521739130435, 0.0875, 0.33333333333333
92808, 0.56521739130435, 0.0875, 0.38888888888889
92809, 0.56521739130435, 0.0875, 0.44444444444444
92810, 0.52173913043478, 0.0875, 0.055555555555556
92811, 0.52173913043478, 0.0875, 0.11111111111111
92812, 0.52173913043478, 0.0875, 0.16666666666667
92813, 0.52173913043478, 0.0875, 0.22222222222222
92814, 0.52173913043478, 0.0875, 0.27777777777778
92815, 0.52173913043478, 0.0875, 0.33333333333333
92816, 0.52173913043478, 0.0875, 0.38888888888889
92817, 0.52173913043478, 0.0875, 0.44444444444444
92818, 0.47826086956522, 0.0875, 0.055555555555556
92819, 0.47826086956522, 0.0875, 0.11111111111111
92820, 0.47826086956522, 0.0875, 0.16666666666667
92821, 0.47826086956522, 0.0875, 0.22222222222222
92822, 0.47826086956522, 0.0875, 0.27777777777778
92823, 0.47826086956522, 0.0875, 0.33333333333333
92824, 0.47826086956522, 0.0875, 0.38888888888889
92825, 0.47826086956522, 0.0875, 0.44444444444444
92826, 0.43478260869565, 0.0875, 0.055555555555556
92827, 0.43478260869565, 0.0875, 0.11111111111111
92828, 0.43478260869565, 0.0875, 0.16666666666667
92829, 0.43478260869565, 0.0875, 0.22222222222222
92830, 0.43478260869565, 0.0875, 0.27777777777778
92831, 0.43478260869565, 0.0875, 0.33333333333333
92832, 0.43478260869565, 0.0875, 0.38888888888889
92833, 0.43478260869565, 0.0875, 0.44444444444444
92834, 0.39130434782609, 0.0875, 0.055555555555556
92835, 0.39130434782609, 0.0875, 0.11111111111111
92836, 0.39130434782609, 0.0875, 0.16666666666667
92837, 0.39130434782609, 0.0875, 0.22222222222222
92838, 0.39130434782609, 0.0875, 0.27777777777778
92839, 0.39130434782609, 0.0875, 0.33333333333333
92840, 0.39130434782609, 0.0875, 0.38888888888889
92841, 0.39130434782609, 0.0875, 0.44444444444444
92842, 0.34782608695652, 0.0875, 0.055555555555556
92843, 0.34782608695652, 0.0875, 0.11111111111111
92844, 0.34782608695652, 0.0875, 0.16666666666667
92845, 0.34782608695652, 0.0875, 0.22222222222222
92846, 0.34782608695652, 0.0875, 0.27777777777778
92847, 0.34782608695652, 0.0875, 0.33333333333333
92848, 0.34782608695652, 0.0875, 0.38888888888889
92849, 0.34782608695652, 0.0875, 0.44444444444444
92850, 0.30434782608696, 0.0875, 0.055555555555556
92851, 0.30434782608696, 0.0875, 0.11111111111111
92852, 0.30434782608696, 0.0875, 0.16666666666667
92853, 0.30434782608696, 0.0875, 0.22222222222222
92854, 0.30434782608696, 0.0875, 0.27777777777778
92855, 0.30434782608696, 0.0875, 0.33333333333333
92856, 0.30434782608696, 0.0875, 0.38888888888889
92857, 0.30434782608696, 0.0875, 0.44444444444444
92858, 0.26086956521739, 0.0875, 0.055555555555556
92859, 0.26086956521739, 0.0875, 0.11111111111111
92860, 0.26086956521739, 0.0875, 0.16666666666667
92861, 0.26086956521739, 0.0875, 0.22222222222222
92862, 0.26086956521739, 0.0875, 0.27777777777778
92863, 0.26086956521739, 0.0875, 0.33333333333333
92864, 0.26086956521739, 0.0875, 0.38888888888889
92865, 0.26086956521739, 0.0875, 0.44444444444444
92866, 0.21739130434783, 0.0875, 0.055555555555556
92867, 0.21739130434783, 0.0875, 0.11111111111111
92868, 0.21739130434783, 0.0875, 0.16666666666667
92869, 0.21739130434783, 0.0875, 0.22222222222222
92870, 0.21739130434783, 0.0875, 0.27777777777778
92871, 0.21739130434783, 0.0875, 0.33333333333333
92872, 0.21739130434783, 0.0875, 0.38888888888889
92873, 0.21739130434783, 0.0875, 0.44444444444444
92874, 0.17391304347826, 0.0875, 0.055555555555556
92875, 0.17391304347826, 0.0875, 0.11111111111111
92876, 0.17391304347826, 0.0875, 0.16666666666667
92877, 0.17391304347826, 0.0875, 0.22222222222222
92878, 0.17391304347826, 0.0875, 0.27777777777778
92879, 0.17391304347826, 0.0875, 0.33333333333333
92880, 0.17391304347826, 0.0875, 0.38888888888889
92881, 0.17391304347826, 0.0875, 0.44444444444444
92882, 0.1304347826087, 0.0875, 0.055555555555556
92883, 0.1304347826087, 0.0875, 0.11111111111111
92884, 0.1304347826087, 0.0875, 0.16666666666667
92885, 0.1304347826087, 0.0875, 0.22222222222222
92886, 0.1304347826087, 0.0875, 0.27777777777778
92887, 0.1304347826087, 0.0875, 0.33333333333333
92888, 0.1304347826087, 0.0875, 0.38888888888889
92889, 0.1304347826087, 0.0875, 0.44444444444444
92890, 0.08695652173913, 0.0875, 0.055555555555556
92891, 0.08695652173913, 0.0875, 0.11111111111111
92892, 0.08695652173913, 0.0875, 0.16666666666667
92893, 0.08695652173913, 0.0875, 0.22222222222222
92894, 0.08695652173913, 0.0875, 0.27777777777778
92895, 0.08695652173913, 0.0875, 0.33333333333333
92896, 0.08695652173913, 0.0875, 0.38888888888889
92897, 0.08695652173913, 0.0875, 0.44444444444444
92898, 0.043478260869565, 0.0875, 0.055555555555556
92899, 0.043478260869565, 0.0875, 0.11111111111111
92900, 0.043478260869565, 0.0875, 0.16666666666667
92901, 0.043478260869565, 0.0875, 0.22222222222222
92902, 0.043478260869565, 0.0875, 0.27777777777778
92903, 0.043478260869565, 0.0875, 0.33333333333333
92904, 0.043478260869565, 0.0875, 0.38888888888889
92905, 0.043478260869565, 0.0875, 0.44444444444444
92906, 1.0375, 0.20217391304348, 0.44444444444444
92907, 1.0375, 0.20217391304348, 0.38888888888889
92908, 1.0375, 0.20217391304348, 0.33333333333333
92909, 1.0375, 0.20217391304348, 0.27777777777778
92910, 1.0375, 0.20217391304348, 0.22222222222222
92911, 1.0375, 0.20217391304348, 0.16666666666667
92912, 1.0375, 0.20217391304348, 0.11111111111111
92913, 1.0375, 0.20217391304348, 0.055555555555556
92914, 1.0375, 0.25434782608696, 0.44444444444444
92915, 1.0375, 0.25434782608696, 0.38888888888889
92916, 1.0375, 0.25434782608696, 0.33333333333333
92917, 1.0375, 0.25434782608696, 0.27777777777778
92918, 1.0375, 0.25434782608696, 0.22222222222222
92919, 1.0375, 0.25434782608696, 0.16666666666667
92920, 1.0375, 0.25434782608696, 0.11111111111111
92921, 1.0375, 0.25434782608696, 0.055555555555556
92922, 1.0375, 0.30652173913043, 0.44444444444444
92923, 1.0375, 0.30652173913043, 0.38888888888889
92924, 1.0375, 0.30652173913043, 0.33333333333333
92925, 1.0375, 0.30652173913043, 0.27777777777778
92926, 1.0375, 0.30652173913043, 0.22222222222222
92927, 1.0375, 0.30652173913043, 0.16666666666667
92928, 1.0375, 0.30652173913043, 0.11111111111111
92929, 1.0375, 0.30652173913043, 0.055555555555556
92930, 1.0375, 0.35869565217391, 0.44444444444444
92931, 1.0375, 0.35869565217391, 0.38888888888889
92932, 1.0375, 0.35869565217391, 0.33333333333333
92933, 1.0375, 0.35869565217391, 0.27777777777778
92934, 1.0375, 0.35869565217391, 0.22222222222222
92935, 1.0375, 0.35869565217391, 0.16666666666667
92936, 1.0375, 0.35869565217391, 0.11111111111111
92937, 1.0375, 0.35869565217391, 0.055555555555556
92938, 1.0375, 0.41086956521739, 0.44444444444444
92939, 1.0375, 0.41086956521739, 0.38888888888889
92940, 1.0375, 0.41086956521739, 0.33333333333333
92941, 1.0375, 0.41086956521739, 0.27777777777778
92942, 1.0375, 0.41086956521739, 0.22222222222222
92943, 1.0375, 0.41086956521739, 0.16666666666667
92944, 1.0375, 0.41086956521739, 0.11111111111111
92945, 1.0375, 0.41086956521739, 0.055555555555556
92946, 1.0375, 0.46304347826087, 0.44444444444444
92947, 1.0375, 0.46304347826087, 0.38888888888889
92948, 1.0375, 0.46304347826087, 0.33333333333333
92949, 1.0375, 0.46304347826087, 0.27777777777778
92950, 1.0375, 0.46304347826087, 0.22222222222222
92951, 1.0375, 0.46304347826087, 0.16666666666667
92952, 1.0375, 0.46304347826087, 0.11111111111111
92953, 1.0375, 0.46304347826087, 0.055555555555556
92954, 1.0375, 0.51521739130435, 0.44444444444444
92955, 1.0375, 0.51521739130435, 0.38888888888889
92956, 1.0375, 0.51521739130435, 0.33333333333333
92957, 1.0375, 0.51521739130435, 0.27777777777778
92958, 1.0375, 0.51521739130435, 0.22222222222222
92959, 1.0375, 0.51521739130435, 0.16666666666667
92960, 1.0375, 0.51521739130435, 0.11111111111111
92961, 1.0375, 0.51521739130435, 0.055555555555556
92962, 1.0375, 0.56739130434783, 0.44444444444444
92963, 1.0375, 0.56739130434783, 0.38888888888889
92964, 1.0375, 0.56739130434783, 0.33333333333333
92965, 1.0375, 0.56739130434783, 0.27777777777778
92966, 1.0375, 0.56739130434783, 0.22222222222222
92967, 1.0375, 0.56739130434783, 0.16666666666667
92968, 1.0375, 0.56739130434783, 0.11111111111111
92969, 1.0375, 0.56739130434783, 0.055555555555556
92970, 1.0375, 0.6195652173913, 0.44444444444444
92971, 1.0375, 0.6195652173913, 0.38888888888889
92972, 1.0375, 0.6195652173913, 0.33333333333333
92973, 1.0375, 0.6195652173913, 0.27777777777778
92974, 1.0375, 0.6195652173913, 0.22222222222222
92975, 1.0375, 0.6195652173913, 0.16666666666667
92976, 1.0375, 0.6195652173913, 0.11111111111111
92977, 1.0375, 0.6195652173913, 0.055555555555556
92978, 1.0375, 0.67173913043478, 0.44444444444444
92979, 1.0375, 0.67173913043478, 0.38888888888889
92980, 1.0375, 0.67173913043478, 0.33333333333333
92981, 1.0375, 0.67173913043478, 0.27777777777778
92982, 1.0375, 0.67173913043478, 0.22222222222222
92983, 1.0375, 0.67173913043478, 0.16666666666667
92984, 1.0375, 0.67173913043478, 0.11111111111111
92985, 1.0375, 0.67173913043478, 0.055555555555556
92986, 1.0375, 0.72391304347826, 0.44444444444444
92987, 1.0375, 0.72391304347826, 0.38888888888889
92988, 1.0375, 0.72391304347826, 0.33333333333333
92989, 1.0375, 0.72391304347826, 0.27777777777778
92990, 1.0375, 0.72391304347826, 0.22222222222222
92991, 1.0375, 0.72391304347826, 0.16666666666667
92992, 1.0375, 0.72391304347826, 0.11111111111111
92993, 1.0375, 0.72391304347826, 0.055555555555556
92994, 1.0375, 0.77608695652174, 0.44444444444444
92995, 1.0375, 0.77608695652174, 0.38888888888889
92996, 1.0375, 0.77608695652174, 0.33333333333333
92997, 1.0375, 0.77608695652174, 0.27777777777778
92998, 1.0375, 0.77608695652174, 0.22222222222222
92999, 1.0375, 0.77608695652174, 0.16666666666667
93000, 1.0375, 0.77608695652174, 0.11111111111111
93001, 1.0375, 0.77608695652174, 0.055555555555556
93002, 1.0375, 0.82826086956522, 0.44444444444444
93003, 1.0375, 0.82826086956522, 0.38888888888889
93004, 1.0375, 0.82826086956522, 0.33333333333333
93005, 1.0375, 0.82826086956522, 0.27777777777778
93006, 1.0375, 0.82826086956522, 0.22222222222222
93007, 1.0375, 0.82826086956522, 0.16666666666667
93008, 1.0375, 0.82826086956522, 0.11111111111111
93009, 1.0375, 0.82826086956522, 0.055555555555556
93010, 1.0375, 0.88043478260869, 0.44444444444444
93011, 1.0375, 0.8804347826087, 0.38888888888889
93012, 1.0375, 0.88043478260869, 0.33333333333333
93013, 1.0375, 0.88043478260869, 0.27777777777778
93014, 1.0375, 0.8804347826087, 0.22222222222222
93015, 1.0375, 0.8804347826087, 0.16666666666667
93016, 1.0375, 0.88043478260869, 0.11111111111111
93017, 1.0375, 0.88043478260869, 0.055555555555556
93018, 1.0375, 0.93260869565217, 0.44444444444444
93019, 1.0375, 0.93260869565217, 0.38888888888889
93020, 1.0375, 0.93260869565217, 0.33333333333333
93021, 1.0375, 0.93260869565217, 0.27777777777778
93022, 1.0375, 0.93260869565217, 0.22222222222222
93023, 1.0375, 0.93260869565217, 0.16666666666667
93024, 1.0375, 0.93260869565217, 0.11111111111111
93025, 1.0375, 0.93260869565217, 0.055555555555556
93026, 1.0375, 0.98478260869565, 0.44444444444444
93027, 1.0375, 0.98478260869565, 0.38888888888889
93028, 1.0375, 0.98478260869565, 0.33333333333333
93029, 1.0375, 0.98478260869565, 0.27777777777778
93030, 1.0375, 0.98478260869565, 0.22222222222222
93031, 1.0375, 0.98478260869565, 0.16666666666667
93032, 1.0375, 0.98478260869565, 0.11111111111111
93033, 1.0375, 0.98478260869565, 0.055555555555556
93034, 1.0375, 1.0369565217391, 0.44444444444444
93035, 1.0375, 1.0369565217391, 0.38888888888889
93036, 1.0375, 1.0369565217391, 0.33333333333333
93037, 1.0375, 1.0369565217391, 0.27777777777778
93038, 1.0375, 1.0369565217391, 0.22222222222222
93039, 1.0375, 1.0369565217391, 0.16666666666667
93040, 1.0375, 1.0369565217391, 0.11111111111111
93041, 1.0375, 1.0369565217391, 0.055555555555556
93042, 1.0375, 1.0891304347826, 0.44444444444444
93043, 1.0375, 1.0891304347826, 0.38888888888889
93044, 1.0375, 1.0891304347826, 0.33333333333333
93045, 1.0375, 1.0891304347826, 0.27777777777778
93046, 1.0375, 1.0891304347826, 0.22222222222222
93047, 1.0375, 1.0891304347826, 0.16666666666667
93048, 1.0375, 1.0891304347826, 0.11111111111111
93049, 1.0375, 1.0891304347826, 0.055555555555556
93050, 1.0375, 1.1413043478261, 0.44444444444444
93051, 1.0375, 1.1413043478261, 0.38888888888889
93052, 1.0375, 1.1413043478261, 0.33333333333333
93053, 1.0375, 1.1413043478261, 0.27777777777778
93054, 1.0375, 1.1413043478261, 0.22222222222222
93055, 1.0375, 1.1413043478261, 0.16666666666667
93056, 1.0375, 1.1413043478261, 0.11111111111111
93057, 1.0375, 1.1413043478261, 0.055555555555556
93058, 1.0375, 1.1934782608696, 0.44444444444444
93059, 1.0375, 1.1934782608696, 0.38888888888889
93060, 1.0375, 1.1934782608696, 0.33333333333333
93061, 1.0375, 1.1934782608696, 0.27777777777778
93062, 1.0375, 1.1934782608696, 0.22222222222222
93063, 1.0375, 1.1934782608696, 0.16666666666667
93064, 1.0375, 1.1934782608696, 0.11111111111111
93065, 1.0375, 1.1934782608696, 0.055555555555556
93066, 1.0375, 1.245652173913, 0.44444444444444
93067, 1.0375, 1.245652173913, 0.38888888888889
93068, 1.0375, 1.245652173913, 0.33333333333333
93069, 1.0375, 1.245652173913, 0.27777777777778
93070, 1.0375, 1.245652173913, 0.22222222222222
93071, 1.0375, 1.245652173913, 0.16666666666667
93072, 1.0375, 1.245652173913, 0.11111111111111
93073, 1.0375, 1.245652173913, 0.055555555555556
93074, 1.0375, 1.2978260869565, 0.44444444444444
93075, 1.0375, 1.2978260869565, 0.38888888888889
93076, 1.0375, 1.2978260869565, 0.33333333333333
93077, 1.0375, 1.2978260869565, 0.27777777777778
93078, 1.0375, 1.2978260869565, 0.22222222222222
93079, 1.0375, 1.2978260869565, 0.16666666666667
93080, 1.0375, 1.2978260869565, 0.11111111111111
93081, 1.0375, 1.2978260869565, 0.055555555555556
93082, 1.0375, 0.20217391304348, 0.47222222222222
93083, 1.0375, 0.17608695652174, 0.44444444444444
93084, 1.01875, 0.20217391304348, 0.44444444444444
93085, 1.0375, 0.20217391304348, 0.41666666666667
93086, 1.0375, 0.17608695652174, 0.38888888888889
93087, 1.01875, 0.20217391304348, 0.38888888888889
93088, 1.0375, 0.20217391304348, 0.36111111111111
93089, 1.0375, 0.17608695652174, 0.33333333333333
93090, 1.01875, 0.20217391304348, 0.33333333333333
93091, 1.0375, 0.20217391304348, 0.30555555555556
93092, 1.0375, 0.17608695652174, 0.27777777777778
93093, 1.01875, 0.20217391304348, 0.27777777777778
93094, 1.0375, 0.20217391304348, 0.25
93095, 1.0375, 0.17608695652174, 0.22222222222222
93096, 1.01875, 0.20217391304348, 0.22222222222222
93097, 1.0375, 0.20217391304348, 0.19444444444444
93098, 1.0375, 0.17608695652174, 0.16666666666667
93099, 1.01875, 0.20217391304348, 0.16666666666667
93100, 1.0375, 0.20217391304348, 0.13888888888889
93101, 1.0375, 0.17608695652174, 0.11111111111111
93102, 1.01875, 0.20217391304348, 0.11111111111111
93103, 1.0375, 0.20217391304348, 0.083333333333333
93104, 1.0375, 0.17608695652174, 0.055555555555556
93105, 1.01875, 0.20217391304348, 0.055555555555556
93106, 1.0375, 0.20217391304348, 0.027777777777778
93107, 1.0375, 0.25434782608696, 0.47222222222222
93108, 1.0375, 0.22826086956522, 0.44444444444444
93109, 1.01875, 0.25434782608696, 0.44444444444444
93110, 1.0375, 0.25434782608696, 0.41666666666667
93111, 1.0375, 0.22826086956522, 0.38888888888889
93112, 1.01875, 0.25434782608696, 0.38888888888889
93113, 1.0375, 0.25434782608696, 0.36111111111111
93114, 1.0375, 0.22826086956522, 0.33333333333333
93115, 1.01875, 0.25434782608696, 0.33333333333333
93116, 1.0375, 0.25434782608696, 0.30555555555556
93117, 1.0375, 0.22826086956522, 0.27777777777778
93118, 1.01875, 0.25434782608696, 0.27777777777778
93119, 1.0375, 0.25434782608696, 0.25
93120, 1.0375, 0.22826086956522, 0.22222222222222
93121, 1.01875, 0.25434782608696, 0.22222222222222
93122, 1.0375, 0.25434782608696, 0.19444444444444
93123, 1.0375, 0.22826086956522, 0.16666666666667
93124, 1.01875, 0.25434782608696, 0.16666666666667
93125, 1.0375, 0.25434782608696, 0.13888888888889
93126, 1.0375, 0.22826086956522, 0.11111111111111
93127, 1.01875, 0.25434782608696, 0.11111111111111
93128, 1.0375, 0.25434782608696, 0.083333333333333
93129, 1.0375, 0.22826086956522, 0.055555555555556
93130, 1.01875, 0.25434782608696, 0.055555555555556
93131, 1.0375, 0.25434782608696, 0.027777777777778
93132, 1.0375, 0.30652173913043, 0.47222222222222
93133, 1.0375, 0.2804347826087, 0.44444444444444
93134, 1.01875, 0.30652173913043, 0.44444444444444
93135, 1.0375, 0.30652173913043, 0.41666666666667
93136, 1.0375, 0.2804347826087, 0.38888888888889
93137, 1.01875, 0.30652173913043, 0.38888888888889
93138, 1.0375, 0.30652173913043, 0.36111111111111
93139, 1.0375, 0.2804347826087, 0.33333333333333
93140, 1.01875, 0.30652173913043, 0.33333333333333
93141, 1.0375, 0.30652173913043, 0.30555555555556
93142, 1.0375, 0.2804347826087, 0.27777777777778
93143, 1.01875, 0.30652173913043, 0.27777777777778
93144, 1.0375, 0.30652173913043, 0.25
93145, 1.0375, 0.2804347826087, 0.22222222222222
93146, 1.01875, 0.30652173913043, 0.22222222222222
93147, 1.0375, 0.30652173913043, 0.19444444444444
93148, 1.0375, 0.2804347826087, 0.16666666666667
93149, 1.01875, 0.30652173913043, 0.16666666666667
93150, 1.0375, 0.30652173913043, 0.13888888888889
93151, 1.0375, 0.2804347826087, 0.11111111111111
93152, 1.01875, 0.30652173913043, 0.11111111111111
93153, 1.0375, 0.30652173913043, 0.083333333333333
93154, 1.0375, 0.2804347826087, 0.055555555555556
93155, 1.01875, 0.30652173913043, 0.055555555555556
93156, 1.0375, 0.30652173913043, 0.027777777777778
93157, 1.0375, 0.35869565217391, 0.47222222222222
93158, 1.0375, 0.33260869565217, 0.44444444444444
93159, 1.01875, 0.35869565217391, 0.44444444444444
93160, 1.0375, 0.35869565217391, 0.41666666666667
93161, 1.0375, 0.33260869565217, 0.38888888888889
93162, 1.01875, 0.35869565217391, 0.38888888888889
93163, 1.0375, 0.35869565217391, 0.36111111111111
93164, 1.0375, 0.33260869565217, 0.33333333333333
93165, 1.01875, 0.35869565217391, 0.33333333333333
93166, 1.0375, 0.35869565217391, 0.30555555555556
93167, 1.0375, 0.33260869565217, 0.27777777777778
93168, 1.01875, 0.35869565217391, 0.27777777777778
93169, 1.0375, 0.35869565217391, 0.25
93170, 1.0375, 0.33260869565217, 0.22222222222222
93171, 1.01875, 0.35869565217391, 0.22222222222222
93172, 1.0375, 0.35869565217391, 0.19444444444444
93173, 1.0375, 0.33260869565217, 0.16666666666667
93174, 1.01875, 0.35869565217391, 0.16666666666667
93175, 1.0375, 0.35869565217391, 0.13888888888889
93176, 1.0375, 0.33260869565217, 0.11111111111111
93177, 1.01875, 0.35869565217391, 0.11111111111111
93178, 1.0375, 0.35869565217391, 0.083333333333333
93179, 1.0375, 0.33260869565217, 0.055555555555556
93180, 1.01875, 0.35869565217391, 0.055555555555556
93181, 1.0375, 0.35869565217391, 0.027777777777778
93182, 1.0375, 0.41086956521739, 0.47222222222222
93183, 1.0375, 0.38478260869565, 0.44444444444444
93184, 1.01875, 0.41086956521739, 0.44444444444444
93185, 1.0375, 0.41086956521739, 0.41666666666667
93186, 1.0375, 0.38478260869565, 0.38888888888889
93187, 1.01875, 0.41086956521739, 0.38888888888889
93188, 1.0375, 0.41086956521739, 0.36111111111111
93189, 1.0375, 0.38478260869565, 0.33333333333333
93190, 1.01875, 0.41086956521739, 0.33333333333333
93191, 1.0375, 0.41086956521739, 0.30555555555556
93192, 1.0375, 0.38478260869565, 0.27777777777778
93193, 1.01875, 0.41086956521739, 0.27777777777778
93194, 1.0375, 0.41086956521739, 0.25
93195, 1.0375, 0.38478260869565, 0.22222222222222
93196, 1.01875, 0.41086956521739, 0.22222222222222
93197, 1.0375, 0.41086956521739, 0.19444444444444
93198, 1.0375, 0.38478260869565, 0.16666666666667
93199, 1.01875, 0.41086956521739, 0.16666666666667
93200, 1.0375, 0.41086956521739, 0.13888888888889
93201, 1.0375, 0.38478260869565, 0.11111111111111
93202, 1.01875, 0.41086956521739, 0.11111111111111
93203, 1.0375, 0.41086956521739, 0.083333333333333
93204, 1.0375, 0.38478260869565, 0.055555555555556
93205, 1.01875, 0.41086956521739, 0.055555555555556
93206, 1.0375, 0.41086956521739, 0.027777777777778
93207, 1.0375, 0.46304347826087, 0.47222222222222
93208, 1.0375, 0.43695652173913, 0.44444444444444
93209, 1.01875, 0.46304347826087, 0.44444444444444
93210, 1.0375, 0.46304347826087, 0.41666666666667
93211, 1.0375, 0.43695652173913, 0.38888888888889
93212, 1.01875, 0.46304347826087, 0.38888888888889
93213, 1.0375, 0.46304347826087, 0.36111111111111
93214, 1.0375, 0.43695652173913, 0.33333333333333
93215, 1.01875, 0.46304347826087, 0.33333333333333
93216, 1.0375, 0.46304347826087, 0.30555555555556
93217, 1.0375, 0.43695652173913, 0.27777777777778
93218, 1.01875, 0.46304347826087, 0.27777777777778
93219, 1.0375, 0.46304347826087, 0.25
93220, 1.0375, 0.43695652173913, 0.22222222222222
93221, 1.01875, 0.46304347826087, 0.22222222222222
93222, 1.0375, 0.46304347826087, 0.19444444444444
93223, 1.0375, 0.43695652173913, 0.16666666666667
93224, 1.01875, 0.46304347826087, 0.16666666666667
93225, 1.0375, 0.46304347826087, 0.13888888888889
93226, 1.0375, 0.43695652173913, 0.11111111111111
93227, 1.01875, 0.46304347826087, 0.11111111111111
93228, 1.0375, 0.46304347826087, 0.083333333333333
93229, 1.0375, 0.43695652173913, 0.055555555555556
93230, 1.01875, 0.46304347826087, 0.055555555555556
93231, 1.0375, 0.46304347826087, 0.027777777777778
93232, 1.0375, 0.51521739130435, 0.47222222222222
93233, 1.0375, 0.48913043478261, 0.44444444444444
93234, 1.01875, 0.51521739130435, 0.44444444444444
93235, 1.0375, 0.51521739130435, 0.41666666666667
93236, 1.0375, 0.48913043478261, 0.38888888888889
93237, 1.01875, 0.51521739130435, 0.38888888888889
93238, 1.0375, 0.51521739130435, 0.36111111111111
93239, 1.0375, 0.48913043478261, 0.33333333333333
93240, 1.01875, 0.51521739130435, 0.33333333333333
93241, 1.0375, 0.51521739130435, 0.30555555555556
93242, 1.0375, 0.48913043478261, 0.27777777777778
93243, 1.01875, 0.51521739130435, 0.27777777777778
93244, 1.0375, 0.51521739130435, 0.25
93245, 1.0375, 0.48913043478261, 0.22222222222222
93246, 1.01875, 0.51521739130435, 0.22222222222222
93247, 1.0375, 0.51521739130435, 0.19444444444444
93248, 1.0375, 0.48913043478261, 0.16666666666667
93249, 1.01875, 0.51521739130435, 0.16666666666667
93250, 1.0375, 0.51521739130435, 0.13888888888889
93251, 1.0375, 0.48913043478261, 0.11111111111111
93252, 1.01875, 0.51521739130435, 0.11111111111111
93253, 1.0375, 0.51521739130435, 0.083333333333333
93254, 1.0375, 0.48913043478261, 0.055555555555556
93255, 1.01875, 0.51521739130435, 0.055555555555556
93256, 1.0375, 0.51521739130435, 0.027777777777778
93257, 1.0375, 0.56739130434783, 0.47222222222222
93258, 1.0375, 0.54130434782609, 0.44444444444444
93259, 1.01875, 0.56739130434783, 0.44444444444444
93260, 1.0375, 0.56739130434783, 0.41666666666667
93261, 1.0375, 0.54130434782609, 0.38888888888889
93262, 1.01875, 0.56739130434783, 0.38888888888889
93263, 1.0375, 0.56739130434783, 0.36111111111111
93264, 1.0375, 0.54130434782609, 0.33333333333333
93265, 1.01875, 0.56739130434783, 0.33333333333333
93266, 1.0375, 0.56739130434783, 0.30555555555556
93267, 1.0375, 0.54130434782609, 0.27777777777778
93268, 1.01875, 0.56739130434783, 0.27777777777778
93269, 1.0375, 0.56739130434783, 0.25
93270, 1.0375, 0.54130434782609, 0.22222222222222
93271, 1.01875, 0.56739130434783, 0.22222222222222
93272, 1.0375, 0.56739130434783, 0.19444444444444
93273, 1.0375, 0.54130434782609, 0.16666666666667
93274, 1.01875, 0.56739130434783, 0.16666666666667
93275, 1.0375, 0.56739130434783, 0.13888888888889
93276, 1.0375, 0.54130434782609, 0.11111111111111
93277, 1.01875, 0.56739130434783, 0.11111111111111
93278, 1.0375, 0.56739130434783, 0.083333333333333
93279, 1.0375, 0.54130434782609, 0.055555555555556
93280, 1.01875, 0.56739130434783, 0.055555555555556
93281, 1.0375, 0.56739130434783, 0.027777777777778
93282, 1.0375, 0.6195652173913, 0.47222222222222
93283, 1.0375, 0.59347826086956, 0.44444444444444
93284, 1.01875, 0.6195652173913, 0.44444444444444
93285, 1.0375, 0.6195652173913, 0.41666666666667
93286, 1.0375, 0.59347826086957, 0.38888888888889
93287, 1.01875, 0.6195652173913, 0.38888888888889
93288, 1.0375, 0.6195652173913, 0.36111111111111
93289, 1.0375, 0.59347826086956, 0.33333333333333
93290, 1.01875, 0.6195652173913, 0.33333333333333
93291, 1.0375, 0.6195652173913, 0.30555555555556
93292, 1.0375, 0.59347826086956, 0.27777777777778
93293, 1.01875, 0.6195652173913, 0.27777777777778
93294, 1.0375, 0.6195652173913, 0.25
93295, 1.0375, 0.59347826086956, 0.22222222222222
93296, 1.01875, 0.6195652173913, 0.22222222222222
93297, 1.0375, 0.6195652173913, 0.19444444444444
93298, 1.0375, 0.59347826086956, 0.16666666666667
93299, 1.01875, 0.6195652173913, 0.16666666666667
93300, 1.0375, 0.6195652173913, 0.13888888888889
93301, 1.0375, 0.59347826086956, 0.11111111111111
93302, 1.01875, 0.6195652173913, 0.11111111111111
93303, 1.0375, 0.6195652173913, 0.083333333333333
93304, 1.0375, 0.59347826086956, 0.055555555555556
93305, 1.01875, 0.6195652173913, 0.055555555555556
93306, 1.0375, 0.6195652173913, 0.027777777777778
93307, 1.0375, 0.67173913043478, 0.47222222222222
93308, 1.0375, 0.64565217391304, 0.44444444444444
93309, 1.01875, 0.67173913043478, 0.44444444444444
93310, 1.0375, 0.67173913043478, 0.41666666666667
93311, 1.0375, 0.64565217391304, 0.38888888888889
93312, 1.01875, 0.67173913043478, 0.38888888888889
93313, 1.0375, 0.67173913043478, 0.36111111111111
93314, 1.0375, 0.64565217391304, 0.33333333333333
93315, 1.01875, 0.67173913043478, 0.33333333333333
93316, 1.0375, 0.67173913043478, 0.30555555555556
93317, 1.0375, 0.64565217391304, 0.27777777777778
93318, 1.01875, 0.67173913043478, 0.27777777777778
93319, 1.0375, 0.67173913043478, 0.25
93320, 1.0375, 0.64565217391304, 0.22222222222222
93321, 1.01875, 0.67173913043478, 0.22222222222222
93322, 1.0375, 0.67173913043478, 0.19444444444444
93323, 1.0375, 0.64565217391304, 0.16666666666667
93324, 1.01875, 0.67173913043478, 0.16666666666667
93325, 1.0375, 0.67173913043478, 0.13888888888889
93326, 1.0375, 0.64565217391304, 0.11111111111111
93327, 1.01875, 0.67173913043478, 0.11111111111111
93328, 1.0375, 0.67173913043478, 0.083333333333333
93329, 1.0375, 0.64565217391304, 0.055555555555556
93330, 1.01875, 0.67173913043478, 0.055555555555556
93331, 1.0375, 0.67173913043478, 0.027777777777778
93332, 1.0375, 0.72391304347826, 0.47222222222222
93333, 1.0375, 0.69782608695652, 0.44444444444444
93334, 1.01875, 0.72391304347826, 0.44444444444444
93335, 1.0375, 0.72391304347826, 0.41666666666667
93336, 1.0375, 0.69782608695652, 0.38888888888889
93337, 1.01875, 0.72391304347826, 0.38888888888889
93338, 1.0375, 0.72391304347826, 0.36111111111111
93339, 1.0375, 0.69782608695652, 0.33333333333333
93340, 1.01875, 0.72391304347826, 0.33333333333333
93341, 1.0375, 0.72391304347826, 0.30555555555556
93342, 1.0375, 0.69782608695652, 0.27777777777778
93343, 1.01875, 0.72391304347826, 0.27777777777778
93344, 1.0375, 0.72391304347826, 0.25
93345, 1.0375, 0.69782608695652, 0.22222222222222
93346, 1.01875, 0.72391304347826, 0.22222222222222
93347, 1.0375, 0.72391304347826, 0.19444444444444
93348, 1.0375, 0.69782608695652, 0.16666666666667
93349, 1.01875, 0.72391304347826, 0.16666666666667
93350, 1.0375, 0.72391304347826, 0.13888888888889
93351, 1.0375, 0.69782608695652, 0.11111111111111
93352, 1.01875, 0.72391304347826, 0.11111111111111
93353, 1.0375, 0.72391304347826, 0.083333333333333
93354, 1.0375, 0.69782608695652, 0.055555555555556
93355, 1.01875, 0.72391304347826, 0.055555555555556
93356, 1.0375, 0.72391304347826, 0.027777777777778
93357, 1.0375, 0.77608695652174, 0.47222222222222
93358, 1.0375, 0.75, 0.44444444444444
93359, 1.01875, 0.77608695652174, 0.44444444444444
93360, 1.0375, 0.77608695652174, 0.41666666666667
93361, 1.0375, 0.75, 0.38888888888889
93362, 1.01875, 0.77608695652174, 0.38888888888889
93363, 1.0375, 0.77608695652174, 0.36111111111111
93364, 1.0375, 0.75, 0.33333333333333
93365, 1.01875, 0.77608695652174, 0.33333333333333
93366, 1.0375, 0.77608695652174, 0.30555555555556
93367, 1.0375, 0.75, 0.27777777777778
93368, 1.01875, 0.77608695652174, 0.27777777777778
93369, 1.0375, 0.77608695652174, 0.25
93370, 1.0375, 0.75, 0.22222222222222
93371, 1.01875, 0.77608695652174, 0.22222222222222
93372, 1.0375, 0.77608695652174, 0.19444444444444
93373, 1.0375, 0.75, 0.16666666666667
93374, 1.01875, 0.77608695652174, 0.16666666666667
93375, 1.0375, 0.77608695652174, 0.13888888888889
93376, 1.0375, 0.75, 0.11111111111111
93377, 1.01875, 0.77608695652174, 0.11111111111111
93378, 1.0375, 0.77608695652174, 0.083333333333333
93379, 1.0375, 0.75, 0.055555555555556
93380, 1.01875, 0.77608695652174, 0.055555555555556
93381, 1.0375, 0.77608695652174, 0.027777777777778
93382, 1.0375, 0.82826086956522, 0.47222222222222
93383, 1.0375, 0.80217391304348, 0.44444444444444
93384, 1.01875, 0.82826086956522, 0.44444444444444
93385, 1.0375, 0.82826086956522, 0.41666666666667
93386, 1.0375, 0.80217391304348, 0.38888888888889
93387, 1.01875, 0.82826086956522, 0.38888888888889
93388, 1.0375, 0.82826086956522, 0.36111111111111
93389, 1.0375, 0.80217391304348, 0.33333333333333
93390, 1.01875, 0.82826086956522, 0.33333333333333
93391, 1.0375, 0.82826086956522, 0.30555555555556
93392, 1.0375, 0.80217391304348, 0.27777777777778
93393, 1.01875, 0.82826086956522, 0.27777777777778
93394, 1.0375, 0.82826086956522, 0.25
93395, 1.0375, 0.80217391304348, 0.22222222222222
93396, 1.01875, 0.82826086956522, 0.22222222222222
93397, 1.0375, 0.82826086956522, 0.19444444444444
93398, 1.0375, 0.80217391304348, 0.16666666666667
93399, 1.01875, 0.82826086956522, 0.16666666666667
93400, 1.0375, 0.82826086956522, 0.13888888888889
93401, 1.0375, 0.80217391304348, 0.11111111111111
93402, 1.01875, 0.82826086956522, 0.11111111111111
93403, 1.0375, 0.82826086956522, 0.083333333333333
93404, 1.0375, 0.80217391304348, 0.055555555555556
93405, 1.01875, 0.82826086956522, 0.055555555555556
93406, 1.0375, 0.82826086956522, 0.027777777777778
93407, 1.0375, 0.88043478260869, 0.47222222222222
93408, 1.0375, 0.85434782608696, 0.44444444444444
93409, 1.01875, 0.88043478260869, 0.44444444444444
93410, 1.0375, 0.88043478260869, 0.41666666666667
93411, 1.0375, 0.85434782608696, 0.38888888888889
93412, 1.01875, 0.8804347826087, 0.38888888888889
93413, 1.0375, 0.88043478260869, 0.36111111111111
93414, 1.0375, 0.85434782608696, 0.33333333333333
93415, 1.01875, 0.88043478260869, 0.33333333333333
93416, 1.0375, 0.88043478260869, 0.30555555555556
93417, 1.0375, 0.85434782608696, 0.27777777777778
93418, 1.01875, 0.88043478260869, 0.27777777777778
93419, 1.0375, 0.8804347826087, 0.25
93420, 1.0375, 0.85434782608696, 0.22222222222222
93421, 1.01875, 0.8804347826087, 0.22222222222222
93422, 1.0375, 0.8804347826087, 0.19444444444444
93423, 1.0375, 0.85434782608696, 0.16666666666667
93424, 1.01875, 0.8804347826087, 0.16666666666667
93425, 1.0375, 0.8804347826087, 0.13888888888889
93426, 1.0375, 0.85434782608696, 0.11111111111111
93427, 1.01875, 0.88043478260869, 0.11111111111111
93428, 1.0375, 0.88043478260869, 0.083333333333333
93429, 1.0375, 0.85434782608696, 0.055555555555556
93430, 1.01875, 0.88043478260869, 0.055555555555556
93431, 1.0375, 0.88043478260869, 0.027777777777778
93432, 1.0375, 0.93260869565217, 0.47222222222222
93433, 1.0375, 0.90652173913043, 0.44444444444444
93434, 1.01875, 0.93260869565217, 0.44444444444444
93435, 1.0375, 0.93260869565217, 0.41666666666667
93436, 1.0375, 0.90652173913043, 0.38888888888889
93437, 1.01875, 0.93260869565217, 0.38888888888889
93438, 1.0375, 0.93260869565217, 0.36111111111111
93439, 1.0375, 0.90652173913043, 0.33333333333333
93440, 1.01875, 0.93260869565217, 0.33333333333333
93441, 1.0375, 0.93260869565217, 0.30555555555556
93442, 1.0375, 0.90652173913043, 0.27777777777778
93443, 1.01875, 0.93260869565217, 0.27777777777778
93444, 1.0375, 0.93260869565217, 0.25
93445, 1.0375, 0.90652173913043, 0.22222222222222
93446, 1.01875, 0.93260869565217, 0.22222222222222
93447, 1.0375, 0.93260869565217, 0.19444444444444
93448, 1.0375, 0.90652173913043, 0.16666666666667
93449, 1.01875, 0.93260869565217, 0.16666666666667
93450, 1.0375, 0.93260869565217, 0.13888888888889
93451, 1.0375, 0.90652173913043, 0.11111111111111
93452, 1.01875, 0.93260869565217, 0.11111111111111
93453, 1.0375, 0.93260869565217, 0.083333333333333
93454, 1.0375, 0.90652173913043, 0.055555555555556
93455, 1.01875, 0.93260869565217, 0.055555555555556
93456, 1.0375, 0.93260869565217, 0.027777777777778
93457, 1.0375, 0.98478260869565, 0.47222222222222
93458, 1.0375, 0.95869565217391, 0.44444444444444
93459, 1.01875, 0.98478260869565, 0.44444444444444
93460, 1.0375, 0.98478260869565, 0.41666666666667
93461, 1.0375, 0.95869565217391, 0.38888888888889
93462, 1.01875, 0.98478260869565, 0.38888888888889
93463, 1.0375, 0.98478260869565, 0.36111111111111
93464, 1.0375, 0.95869565217391, 0.33333333333333
93465, 1.01875, 0.98478260869565, 0.33333333333333
93466, 1.0375, 0.98478260869565, 0.30555555555556
93467, 1.0375, 0.95869565217391, 0.27777777777778
93468, 1.01875, 0.98478260869565, 0.27777777777778
93469, 1.0375, 0.98478260869565, 0.25
93470, 1.0375, 0.95869565217391, 0.22222222222222
93471, 1.01875, 0.98478260869565, 0.22222222222222
93472, 1.0375, 0.98478260869565, 0.19444444444444
93473, 1.0375, 0.95869565217391, 0.16666666666667
93474, 1.01875, 0.98478260869565, 0.16666666666667
93475, 1.0375, 0.98478260869565, 0.13888888888889
93476, 1.0375, 0.95869565217391, 0.11111111111111
93477, 1.01875, 0.98478260869565, 0.11111111111111
93478, 1.0375, 0.98478260869565, 0.083333333333333
93479, 1.0375, 0.95869565217391, 0.055555555555556
93480, 1.01875, 0.98478260869565, 0.055555555555556
93481, 1.0375, 0.98478260869565, 0.027777777777778
93482, 1.0375, 1.0369565217391, 0.47222222222222
93483, 1.0375, 1.0108695652174, 0.44444444444444
93484, 1.01875, 1.0369565217391, 0.44444444444444
93485, 1.0375, 1.0369565217391, 0.41666666666667
93486, 1.0375, 1.0108695652174, 0.38888888888889
93487, 1.01875, 1.0369565217391, 0.38888888888889
93488, 1.0375, 1.0369565217391, 0.36111111111111
93489, 1.0375, 1.0108695652174, 0.33333333333333
93490, 1.01875, 1.0369565217391, 0.33333333333333
93491, 1.0375, 1.0369565217391, 0.30555555555556
93492, 1.0375, 1.0108695652174, 0.27777777777778
93493, 1.01875, 1.0369565217391, 0.27777777777778
93494, 1.0375, 1.0369565217391, 0.25
93495, 1.0375, 1.0108695652174, 0.22222222222222
93496, 1.01875, 1.0369565217391, 0.22222222222222
93497, 1.0375, 1.0369565217391, 0.19444444444444
93498, 1.0375, 1.0108695652174, 0.16666666666667
93499, 1.01875, 1.0369565217391, 0.16666666666667
93500, 1.0375, 1.0369565217391, 0.13888888888889
93501, 1.0375, 1.0108695652174, 0.11111111111111
93502, 1.01875, 1.0369565217391, 0.11111111111111
93503, 1.0375, 1.0369565217391, 0.083333333333333
93504, 1.0375, 1.0108695652174, 0.055555555555556
93505, 1.01875, 1.0369565217391, 0.055555555555556
93506, 1.0375, 1.0369565217391, 0.027777777777778
93507, 1.0375, 1.0891304347826, 0.47222222222222
93508, 1.0375, 1.0630434782609, 0.44444444444444
93509, 1.01875, 1.0891304347826, 0.44444444444444
93510, 1.0375, 1.0891304347826, 0.41666666666667
93511, 1.0375, 1.0630434782609, 0.38888888888889
93512, 1.01875, 1.0891304347826, 0.38888888888889
93513, 1.0375, 1.0891304347826, 0.36111111111111
93514, 1.0375, 1.0630434782609, 0.33333333333333
93515, 1.01875, 1.0891304347826, 0.33333333333333
93516, 1.0375, 1.0891304347826, 0.30555555555556
93517, 1.0375, 1.0630434782609, 0.27777777777778
93518, 1.01875, 1.0891304347826, 0.27777777777778
93519, 1.0375, 1.0891304347826, 0.25
93520, 1.0375, 1.0630434782609, 0.22222222222222
93521, 1.01875, 1.0891304347826, 0.22222222222222
93522, 1.0375, 1.0891304347826, 0.19444444444444
93523, 1.0375, 1.0630434782609, 0.16666666666667
93524, 1.01875, 1.0891304347826, 0.16666666666667
93525, 1.0375, 1.0891304347826, 0.13888888888889
93526, 1.0375, 1.0630434782609, 0.11111111111111
93527, 1.01875, 1.0891304347826, 0.11111111111111
93528, 1.0375, 1.0891304347826, 0.083333333333333
93529, 1.0375, 1.0630434782609, 0.055555555555556
93530, 1.01875, 1.0891304347826, 0.055555555555556
93531, 1.0375, 1.0891304347826, 0.027777777777778
93532, 1.0375, 1.1413043478261, 0.47222222222222
93533, 1.0375, 1.1152173913043, 0.44444444444444
93534, 1.01875, 1.1413043478261, 0.44444444444444
93535, 1.0375, 1.1413043478261, 0.41666666666667
93536, 1.0375, 1.1152173913043, 0.38888888888889
93537, 1.01875, 1.1413043478261, 0.38888888888889
93538, 1.0375, 1.1413043478261, 0.36111111111111
93539, 1.0375, 1.1152173913043, 0.33333333333333
93540, 1.01875, 1.1413043478261, 0.33333333333333
93541, 1.0375, 1.1413043478261, 0.30555555555556
93542, 1.0375, 1.1152173913043, 0.27777777777778
93543, 1.01875, 1.1413043478261, 0.27777777777778
93544, 1.0375, 1.1413043478261, 0.25
93545, 1.0375, 1.1152173913043, 0.22222222222222
93546, 1.01875, 1.1413043478261, 0.22222222222222
93547, 1.0375, 1.1413043478261, 0.19444444444444
93548, 1.0375, 1.1152173913043, 0.16666666666667
93549, 1.01875, 1.1413043478261, 0.16666666666667
93550, 1.0375, 1.1413043478261, 0.13888888888889
93551, 1.0375, 1.1152173913043, 0.11111111111111
93552, 1.01875, 1.1413043478261, 0.11111111111111
93553, 1.0375, 1.1413043478261, 0.083333333333333
93554, 1.0375, 1.1152173913043, 0.055555555555556
93555, 1.01875, 1.1413043478261, 0.055555555555556
93556, 1.0375, 1.1413043478261, 0.027777777777778
93557, 1.0375, 1.1934782608696, 0.47222222222222
93558, 1.0375, 1.1673913043478, 0.44444444444444
93559, 1.01875, 1.1934782608696, 0.44444444444444
93560, 1.0375, 1.1934782608696, 0.41666666666667
93561, 1.0375, 1.1673913043478, 0.38888888888889
93562, 1.01875, 1.1934782608696, 0.38888888888889
93563, 1.0375, 1.1934782608696, 0.36111111111111
93564, 1.0375, 1.1673913043478, 0.33333333333333
93565, 1.01875, 1.1934782608696, 0.33333333333333
93566, 1.0375, 1.1934782608696, 0.30555555555556
93567, 1.0375, 1.1673913043478, 0.27777777777778
93568, 1.01875, 1.1934782608696, 0.27777777777778
93569, 1.0375, 1.1934782608696, 0.25
93570, 1.0375, 1.1673913043478, 0.22222222222222
93571, 1.01875, 1.1934782608696, 0.22222222222222
93572, 1.0375, 1.1934782608696, 0.19444444444444
93573, 1.0375, 1.1673913043478, 0.16666666666667
93574, 1.01875, 1.1934782608696, 0.16666666666667
93575, 1.0375, 1.1934782608696, 0.13888888888889
93576, 1.0375, 1.1673913043478, 0.11111111111111
93577, 1.01875, 1.1934782608696, 0.11111111111111
93578, 1.0375, 1.1934782608696, 0.083333333333333
93579, 1.0375, 1.1673913043478, 0.055555555555556
93580, 1.01875, 1.1934782608696, 0.055555555555556
93581, 1.0375, 1.1934782608696, 0.027777777777778
93582, 1.0375, 1.245652173913, 0.47222222222222
93583, 1.0375, 1.2195652173913, 0.44444444444444
93584, 1.01875, 1.245652173913, 0.44444444444444
93585, 1.0375, 1.245652173913, 0.41666666666667
93586, 1.0375, 1.2195652173913, 0.38888888888889
93587, 1.01875, 1.245652173913, 0.38888888888889
93588, 1.0375, 1.245652173913, 0.36111111111111
93589, 1.0375, 1.2195652173913, 0.33333333333333
93590, 1.01875, 1.245652173913, 0.33333333333333
93591, 1.0375, 1.245652173913, 0.30555555555556
93592, 1.0375, 1.2195652173913, 0.27777777777778
93593, 1.01875, 1.245652173913, 0.27777777777778
93594, 1.0375, 1.245652173913, 0.25
93595, 1.0375, 1.2195652173913, 0.22222222222222
93596, 1.01875, 1.245652173913, 0.22222222222222
93597, 1.0375, 1.245652173913, 0.19444444444444
93598, 1.0375, 1.2195652173913, 0.16666666666667
93599, 1.01875, 1.245652173913, 0.16666666666667
93600, 1.0375, 1.245652173913, 0.13888888888889
93601, 1.0375, 1.2195652173913, 0.11111111111111
93602, 1.01875, 1.245652173913, 0.11111111111111
93603, 1.0375, 1.245652173913, 0.083333333333333
93604, 1.0375, 1.2195652173913, 0.055555555555556
93605, 1.01875, 1.245652173913, 0.055555555555556
93606, 1.0375, 1.245652173913, 0.027777777777778
93607, 1.0375, 1.2978260869565, 0.47222222222222
93608, 1.0375, 1.2717391304348, 0.44444444444444
93609, 1.01875, 1.2978260869565, 0.44444444444444
93610, 1.0375, 1.2978260869565, 0.41666666666667
93611, 1.0375, 1.2717391304348, 0.38888888888889
93612, 1.01875, 1.2978260869565, 0.38888888888889
93613, 1.0375, 1.2978260869565, 0.36111111111111
93614, 1.0375, 1.2717391304348, 0.33333333333333
93615, 1.01875, 1.2978260869565, 0.33333333333333
93616, 1.0375, 1.2978260869565, 0.30555555555556
93617, 1.0375, 1.2717391304348, 0.27777777777778
93618, 1.01875, 1.2978260869565, 0.27777777777778
93619, 1.0375, 1.2978260869565, 0.25
93620, 1.0375, 1.2717391304348, 0.22222222222222
93621, 1.01875, 1.2978260869565, 0.22222222222222
93622, 1.0375, 1.2978260869565, 0.19444444444444
93623, 1.0375, 1.2717391304348, 0.16666666666667
93624, 1.01875, 1.2978260869565, 0.16666666666667
93625, 1.0375, 1.2978260869565, 0.13888888888889
93626, 1.0375, 1.2717391304348, 0.11111111111111
93627, 1.01875, 1.2978260869565, 0.11111111111111
93628, 1.0375, 1.2978260869565, 0.083333333333333
93629, 1.0375, 1.2717391304348, 0.055555555555556
93630, 1.01875, 1.2978260869565, 0.055555555555556
93631, 1.0375, 1.2978260869565, 0.027777777777778
93632, 1.0375, 1.3239130434783, 0.44444444444444
93633, 1.0375, 1.3239130434783, 0.38888888888889
93634, 1.0375, 1.3239130434783, 0.33333333333333
93635, 1.0375, 1.3239130434783, 0.27777777777778
93636, 1.0375, 1.3239130434783, 0.22222222222222
93637, 1.0375, 1.3239130434783, 0.16666666666667
93638, 1.0375, 1.3239130434783, 0.11111111111111
93639, 1.0375, 1.3239130434783, 0.055555555555556
93640, 1.05625, 0.20217391304348, 0.44444444444444
93641, 1.05625, 0.20217391304348, 0.38888888888889
93642, 1.05625, 0.20217391304348, 0.33333333333333
93643, 1.05625, 0.20217391304348, 0.27777777777778
93644, 1.05625, 0.20217391304348, 0.22222222222222
93645, 1.05625, 0.20217391304348, 0.16666666666667
93646, 1.05625, 0.20217391304348, 0.11111111111111
93647, 1.05625, 0.20217391304348, 0.055555555555556
93648, 1.05625, 0.25434782608696, 0.44444444444444
93649, 1.05625, 0.25434782608696, 0.38888888888889
93650, 1.05625, 0.25434782608696, 0.33333333333333
93651, 1.05625, 0.25434782608696, 0.27777777777778
93652, 1.05625, 0.25434782608696, 0.22222222222222
93653, 1.05625, 0.25434782608696, 0.16666666666667
93654, 1.05625, 0.25434782608696, 0.11111111111111
93655, 1.05625, 0.25434782608696, 0.055555555555556
93656, 1.05625, 0.30652173913043, 0.44444444444444
93657, 1.05625, 0.30652173913043, 0.38888888888889
93658, 1.05625, 0.30652173913043, 0.33333333333333
93659, 1.05625, 0.30652173913043, 0.27777777777778
93660, 1.05625, 0.30652173913043, 0.22222222222222
93661, 1.05625, 0.30652173913043, 0.16666666666667
93662, 1.05625, 0.30652173913043, 0.11111111111111
93663, 1.05625, 0.30652173913043, 0.055555555555556
93664, 1.05625, 0.35869565217391, 0.44444444444444
93665, 1.05625, 0.35869565217391, 0.38888888888889
93666, 1.05625, 0.35869565217391, 0.33333333333333
93667, 1.05625, 0.35869565217391, 0.27777777777778
93668, 1.05625, 0.35869565217391, 0.22222222222222
93669, 1.05625, 0.35869565217391, 0.16666666666667
93670, 1.05625, 0.35869565217391, 0.11111111111111
93671, 1.05625, 0.35869565217391, 0.055555555555556
93672, 1.05625, 0.41086956521739, 0.44444444444444
93673, 1.05625, 0.41086956521739, 0.38888888888889
93674, 1.05625, 0.41086956521739, 0.33333333333333
93675, 1.05625, 0.41086956521739, 0.27777777777778
93676, 1.05625, 0.41086956521739, 0.22222222222222
93677, 1.05625, 0.41086956521739, 0.16666666666667
93678, 1.05625, 0.41086956521739, 0.11111111111111
93679, 1.05625, 0.41086956521739, 0.055555555555556
93680, 1.05625, 0.46304347826087, 0.44444444444444
93681, 1.05625, 0.46304347826087, 0.38888888888889
93682, 1.05625, 0.46304347826087, 0.33333333333333
93683, 1.05625, 0.46304347826087, 0.27777777777778
93684, 1.05625, 0.46304347826087, 0.22222222222222
93685, 1.05625, 0.46304347826087, 0.16666666666667
93686, 1.05625, 0.46304347826087, 0.11111111111111
93687, 1.05625, 0.46304347826087, 0.055555555555556
93688, 1.05625, 0.51521739130435, 0.44444444444444
93689, 1.05625, 0.51521739130435, 0.38888888888889
93690, 1.05625, 0.51521739130435, 0.33333333333333
93691, 1.05625, 0.51521739130435, 0.27777777777778
93692, 1.05625, 0.51521739130435, 0.22222222222222
93693, 1.05625, 0.51521739130435, 0.16666666666667
93694, 1.05625, 0.51521739130435, 0.11111111111111
93695, 1.05625, 0.51521739130435, 0.055555555555556
93696, 1.05625, 0.56739130434783, 0.44444444444444
93697, 1.05625, 0.56739130434783, 0.38888888888889
93698, 1.05625, 0.56739130434783, 0.33333333333333
93699, 1.05625, 0.56739130434783, 0.27777777777778
93700, 1.05625, 0.56739130434783, 0.22222222222222
93701, 1.05625, 0.56739130434783, 0.16666666666667
93702, 1.05625, 0.56739130434783, 0.11111111111111
93703, 1.05625, 0.56739130434783, 0.055555555555556
93704, 1.05625, 0.6195652173913, 0.44444444444444
93705, 1.05625, 0.6195652173913, 0.38888888888889
93706, 1.05625, 0.6195652173913, 0.33333333333333
93707, 1.05625, 0.6195652173913, 0.27777777777778
93708, 1.05625, 0.6195652173913, 0.22222222222222
93709, 1.05625, 0.6195652173913, 0.16666666666667
93710, 1.05625, 0.6195652173913, 0.11111111111111
93711, 1.05625, 0.6195652173913, 0.055555555555556
93712, 1.05625, 0.67173913043478, 0.44444444444444
93713, 1.05625, 0.67173913043478, 0.38888888888889
93714, 1.05625, 0.67173913043478, 0.33333333333333
93715, 1.05625, 0.67173913043478, 0.27777777777778
93716, 1.05625, 0.67173913043478, 0.22222222222222
93717, 1.05625, 0.67173913043478, 0.16666666666667
93718, 1.05625, 0.67173913043478, 0.11111111111111
93719, 1.05625, 0.67173913043478, 0.055555555555556
93720, 1.05625, 0.72391304347826, 0.44444444444444
93721, 1.05625, 0.72391304347826, 0.38888888888889
93722, 1.05625, 0.72391304347826, 0.33333333333333
93723, 1.05625, 0.72391304347826, 0.27777777777778
93724, 1.05625, 0.72391304347826, 0.22222222222222
93725, 1.05625, 0.72391304347826, 0.16666666666667
93726, 1.05625, 0.72391304347826, 0.11111111111111
93727, 1.05625, 0.72391304347826, 0.055555555555556
93728, 1.05625, 0.77608695652174, 0.44444444444444
93729, 1.05625, 0.77608695652174, 0.38888888888889
93730, 1.05625, 0.77608695652174, 0.33333333333333
93731, 1.05625, 0.77608695652174, 0.27777777777778
93732, 1.05625, 0.77608695652174, 0.22222222222222
93733, 1.05625, 0.77608695652174, 0.16666666666667
93734, 1.05625, 0.77608695652174, 0.11111111111111
93735, 1.05625, 0.77608695652174, 0.055555555555556
93736, 1.05625, 0.82826086956522, 0.44444444444444
93737, 1.05625, 0.82826086956522, 0.38888888888889
93738, 1.05625, 0.82826086956522, 0.33333333333333
93739, 1.05625, 0.82826086956522, 0.27777777777778
93740, 1.05625, 0.82826086956522, 0.22222222222222
93741, 1.05625, 0.82826086956522, 0.16666666666667
93742, 1.05625, 0.82826086956522, 0.11111111111111
93743, 1.05625, 0.82826086956522, 0.055555555555556
93744, 1.05625, 0.88043478260869, 0.44444444444444
93745, 1.05625, 0.8804347826087, 0.38888888888889
93746, 1.05625, 0.88043478260869, 0.33333333333333
93747, 1.05625, 0.88043478260869, 0.27777777777778
93748, 1.05625, 0.8804347826087, 0.22222222222222
93749, 1.05625, 0.8804347826087, 0.16666666666667
93750, 1.05625, 0.88043478260869, 0.11111111111111
93751, 1.05625, 0.88043478260869, 0.055555555555556
93752, 1.05625, 0.93260869565217, 0.44444444444444
93753, 1.05625, 0.93260869565217, 0.38888888888889
93754, 1.05625, 0.93260869565217, 0.33333333333333
93755, 1.05625, 0.93260869565217, 0.27777777777778
93756, 1.05625, 0.93260869565217, 0.22222222222222
93757, 1.05625, 0.93260869565217, 0.16666666666667
93758, 1.05625, 0.93260869565217, 0.11111111111111
93759, 1.05625, 0.93260869565217, 0.055555555555556
93760, 1.05625, 0.98478260869565, 0.44444444444444
93761, 1.05625, 0.98478260869565, 0.38888888888889
93762, 1.05625, 0.98478260869565, 0.33333333333333
93763, 1.05625, 0.98478260869565, 0.27777777777778
93764, 1.05625, 0.98478260869565, 0.22222222222222
93765, 1.05625, 0.98478260869565, 0.16666666666667
93766, 1.05625, 0.98478260869565, 0.11111111111111
93767, 1.05625, 0.98478260869565, 0.055555555555556
93768, 1.05625, 1.0369565217391, 0.44444444444444
93769, 1.05625, 1.0369565217391, 0.38888888888889
93770, 1.05625, 1.0369565217391, 0.33333333333333
93771, 1.05625, 1.0369565217391, 0.27777777777778
93772, 1.05625, 1.0369565217391, 0.22222222222222
93773, 1.05625, 1.0369565217391, 0.16666666666667
93774, 1.05625, 1.0369565217391, 0.11111111111111
93775, 1.05625, 1.0369565217391, 0.055555555555556
93776, 1.05625, 1.0891304347826, 0.44444444444444
93777, 1.05625, 1.0891304347826, 0.38888888888889
93778, 1.05625, 1.0891304347826, 0.33333333333333
93779, 1.05625, 1.0891304347826, 0.27777777777778
93780, 1.05625, 1.0891304347826, 0.22222222222222
93781, 1.05625, 1.0891304347826, 0.16666666666667
93782, 1.05625, 1.0891304347826, 0.11111111111111
93783, 1.05625, 1.0891304347826, 0.055555555555556
93784, 1.05625, 1.1413043478261, 0.44444444444444
93785, 1.05625, 1.1413043478261, 0.38888888888889
93786, 1.05625, 1.1413043478261, 0.33333333333333
93787, 1.05625, 1.1413043478261, 0.27777777777778
93788, 1.05625, 1.1413043478261, 0.22222222222222
93789, 1.05625, 1.1413043478261, 0.16666666666667
93790, 1.05625, 1.1413043478261, 0.11111111111111
93791, 1.05625, 1.1413043478261, 0.055555555555556
93792, 1.05625, 1.1934782608696, 0.44444444444444
93793, 1.05625, 1.1934782608696, 0.38888888888889
93794, 1.05625, 1.1934782608696, 0.33333333333333
93795, 1.05625, 1.1934782608696, 0.27777777777778
93796, 1.05625, 1.1934782608696, 0.22222222222222
93797, 1.05625, 1.1934782608696, 0.16666666666667
93798, 1.05625, 1.1934782608696, 0.11111111111111
93799, 1.05625, 1.1934782608696, 0.055555555555556
93800, 1.05625, 1.245652173913, 0.44444444444444
93801, 1.05625, 1.245652173913, 0.38888888888889
93802, 1.05625, 1.245652173913, 0.33333333333333
93803, 1.05625, 1.245652173913, 0.27777777777778
93804, 1.05625, 1.245652173913, 0.22222222222222
93805, 1.05625, 1.245652173913, 0.16666666666667
93806, 1.05625, 1.245652173913, 0.11111111111111
93807, 1.05625, 1.245652173913, 0.055555555555556
93808, 1.05625, 1.2978260869565, 0.44444444444444
93809, 1.05625, 1.2978260869565, 0.38888888888889
93810, 1.05625, 1.2978260869565, 0.33333333333333
93811, 1.05625, 1.2978260869565, 0.27777777777778
93812, 1.05625, 1.2978260869565, 0.22222222222222
93813, 1.05625, 1.2978260869565, 0.16666666666667
93814, 1.05625, 1.2978260869565, 0.11111111111111
93815, 1.05625, 1.2978260869565, 0.055555555555556
93816, 1.1625, 1.2978260869565, 0.44444444444444
93817, 1.1625, 1.2978260869565, 0.38888888888889
93818, 1.1625, 1.2978260869565, 0.33333333333333
93819, 1.1625, 1.2978260869565, 0.27777777777778
93820, 1.1625, 1.2978260869565, 0.22222222222222
93821, 1.1625, 1.2978260869565, 0.16666666666667
93822, 1.1625, 1.2978260869565, 0.11111111111111
93823, 1.1625, 1.2978260869565, 0.055555555555556
93824, 1.1625, 1.245652173913, 0.44444444444444
93825, 1.1625, 1.245652173913, 0.38888888888889
93826, 1.1625, 1.245652173913, 0.33333333333333
93827, 1.1625, 1.245652173913, 0.27777777777778
93828, 1.1625, 1.245652173913, 0.22222222222222
93829, 1.1625, 1.245652173913, 0.16666666666667
93830, 1.1625, 1.245652173913, 0.11111111111111
93831, 1.1625, 1.245652173913, 0.055555555555556
93832, 1.1625, 1.1934782608696, 0.44444444444444
93833, 1.1625, 1.1934782608696, 0.38888888888889
93834, 1.1625, 1.1934782608696, 0.33333333333333
93835, 1.1625, 1.1934782608696, 0.27777777777778
93836, 1.1625, 1.1934782608696, 0.22222222222222
93837, 1.1625, 1.1934782608696, 0.16666666666667
93838, 1.1625, 1.1934782608696, 0.11111111111111
93839, 1.1625, 1.1934782608696, 0.055555555555556
93840, 1.1625, 1.1413043478261, 0.44444444444444
93841, 1.1625, 1.1413043478261, 0.38888888888889
93842, 1.1625, 1.1413043478261, 0.33333333333333
93843, 1.1625, 1.1413043478261, 0.27777777777778
93844, 1.1625, 1.1413043478261, 0.22222222222222
93845, 1.1625, 1.1413043478261, 0.16666666666667
93846, 1.1625, 1.1413043478261, 0.11111111111111
93847, 1.1625, 1.1413043478261, 0.055555555555556
93848, 1.1625, 1.0891304347826, 0.44444444444444
93849, 1.1625, 1.0891304347826, 0.38888888888889
93850, 1.1625, 1.0891304347826, 0.33333333333333
93851, 1.1625, 1.0891304347826, 0.27777777777778
93852, 1.1625, 1.0891304347826, 0.22222222222222
93853, 1.1625, 1.0891304347826, 0.16666666666667
93854, 1.1625, 1.0891304347826, 0.11111111111111
93855, 1.1625, 1.0891304347826, 0.055555555555556
93856, 1.1625, 1.0369565217391, 0.44444444444444
93857, 1.1625, 1.0369565217391, 0.38888888888889
93858, 1.1625, 1.0369565217391, 0.33333333333333
93859, 1.1625, 1.0369565217391, 0.27777777777778
93860, 1.1625, 1.0369565217391, 0.22222222222222
93861, 1.1625, 1.0369565217391, 0.16666666666667
93862, 1.1625, 1.0369565217391, 0.11111111111111
93863, 1.1625, 1.0369565217391, 0.055555555555556
93864, 1.1625, 0.98478260869565, 0.44444444444444
93865, 1.1625, 0.98478260869565, 0.38888888888889
93866, 1.1625, 0.98478260869565, 0.33333333333333
93867, 1.1625, 0.98478260869565, 0.27777777777778
93868, 1.1625, 0.98478260869565, 0.22222222222222
93869, 1.1625, 0.98478260869565, 0.16666666666667
93870, 1.1625, 0.98478260869565, 0.11111111111111
93871, 1.1625, 0.98478260869565, 0.055555555555556
93872, 1.1625, 0.93260869565217, 0.44444444444444
93873, 1.1625, 0.93260869565217, 0.38888888888889
93874, 1.1625, 0.93260869565217, 0.33333333333333
93875, 1.1625, 0.93260869565218, 0.27777777777778
93876, 1.1625, 0.93260869565217, 0.22222222222222
93877, 1.1625, 0.93260869565217, 0.16666666666667
93878, 1.1625, 0.93260869565218, 0.11111111111111
93879, 1.1625, 0.93260869565217, 0.055555555555556
93880, 1.1625, 0.8804347826087, 0.44444444444444
93881, 1.1625, 0.8804347826087, 0.38888888888889
93882, 1.1625, 0.8804347826087, 0.33333333333333
93883, 1.1625, 0.8804347826087, 0.27777777777778
93884, 1.1625, 0.8804347826087, 0.22222222222222
93885, 1.1625, 0.8804347826087, 0.16666666666667
93886, 1.1625, 0.8804347826087, 0.11111111111111
93887, 1.1625, 0.8804347826087, 0.055555555555556
93888, 1.1625, 0.82826086956522, 0.44444444444444
93889, 1.1625, 0.82826086956522, 0.38888888888889
93890, 1.1625, 0.82826086956522, 0.33333333333333
93891, 1.1625, 0.82826086956522, 0.27777777777778
93892, 1.1625, 0.82826086956522, 0.22222222222222
93893, 1.1625, 0.82826086956522, 0.16666666666667
93894, 1.1625, 0.82826086956522, 0.11111111111111
93895, 1.1625, 0.82826086956522, 0.055555555555556
93896, 1.1625, 0.77608695652174, 0.44444444444444
93897, 1.1625, 0.77608695652174, 0.38888888888889
93898, 1.1625, 0.77608695652174, 0.33333333333333
93899, 1.1625, 0.77608695652174, 0.27777777777778
93900, 1.1625, 0.77608695652174, 0.22222222222222
93901, 1.1625, 0.77608695652174, 0.16666666666667
93902, 1.1625, 0.77608695652174, 0.11111111111111
93903, 1.1625, 0.77608695652174, 0.055555555555556
93904, 1.1625, 0.72391304347826, 0.44444444444444
93905, 1.1625, 0.72391304347826, 0.38888888888889
93906, 1.1625, 0.72391304347826, 0.33333333333333
93907, 1.1625, 0.72391304347826, 0.27777777777778
93908, 1.1625, 0.72391304347826, 0.22222222222222
93909, 1.1625, 0.72391304347826, 0.16666666666667
93910, 1.1625, 0.72391304347826, 0.11111111111111
93911, 1.1625, 0.72391304347826, 0.055555555555556
93912, 1.1625, 0.67173913043478, 0.44444444444444
93913, 1.1625, 0.67173913043478, 0.38888888888889
93914, 1.1625, 0.67173913043478, 0.33333333333333
93915, 1.1625, 0.67173913043478, 0.27777777777778
93916, 1.1625, 0.67173913043478, 0.22222222222222
93917, 1.1625, 0.67173913043478, 0.16666666666667
93918, 1.1625, 0.67173913043478, 0.11111111111111
93919, 1.1625, 0.67173913043478, 0.055555555555556
93920, 1.1625, 0.61956521739131, 0.44444444444444
93921, 1.1625, 0.61956521739131, 0.38888888888889
93922, 1.1625, 0.61956521739131, 0.33333333333333
93923, 1.1625, 0.61956521739131, 0.27777777777778
93924, 1.1625, 0.61956521739131, 0.22222222222222
93925, 1.1625, 0.6195652173913, 0.16666666666667
93926, 1.1625, 0.6195652173913, 0.11111111111111
93927, 1.1625, 0.61956521739131, 0.055555555555556
93928, 1.1625, 0.56739130434783, 0.44444444444444
93929, 1.1625, 0.56739130434783, 0.38888888888889
93930, 1.1625, 0.56739130434783, 0.33333333333333
93931, 1.1625, 0.56739130434783, 0.27777777777778
93932, 1.1625, 0.56739130434783, 0.22222222222222
93933, 1.1625, 0.56739130434783, 0.16666666666667
93934, 1.1625, 0.56739130434783, 0.11111111111111
93935, 1.1625, 0.56739130434783, 0.055555555555556
93936, 1.1625, 0.51521739130435, 0.44444444444444
93937, 1.1625, 0.51521739130435, 0.38888888888889
93938, 1.1625, 0.51521739130435, 0.33333333333333
93939, 1.1625, 0.51521739130435, 0.27777777777778
93940, 1.1625, 0.51521739130435, 0.22222222222222
93941, 1.1625, 0.51521739130435, 0.16666666666667
93942, 1.1625, 0.51521739130435, 0.11111111111111
93943, 1.1625, 0.51521739130435, 0.055555555555556
93944, 1.1625, 0.46304347826087, 0.44444444444444
93945, 1.1625, 0.46304347826087, 0.38888888888889
93946, 1.1625, 0.46304347826087, 0.33333333333333
93947, 1.1625, 0.46304347826087, 0.27777777777778
93948, 1.1625, 0.46304347826087, 0.22222222222222
93949, 1.1625, 0.46304347826087, 0.16666666666667
93950, 1.1625, 0.46304347826087, 0.11111111111111
93951, 1.1625, 0.46304347826087, 0.055555555555556
93952, 1.1625, 0.41086956521739, 0.44444444444444
93953, 1.1625, 0.41086956521739, 0.38888888888889
93954, 1.1625, 0.41086956521739, 0.33333333333333
93955, 1.1625, 0.41086956521739, 0.27777777777778
93956, 1.1625, 0.41086956521739, 0.22222222222222
93957, 1.1625, 0.41086956521739, 0.16666666666667
93958, 1.1625, 0.41086956521739, 0.11111111111111
93959, 1.1625, 0.41086956521739, 0.055555555555556
93960, 1.1625, 0.35869565217391, 0.44444444444444
93961, 1.1625, 0.35869565217391, 0.38888888888889
93962, 1.1625, 0.35869565217391, 0.33333333333333
93963, 1.1625, 0.35869565217391, 0.27777777777778
93964, 1.1625, 0.35869565217391, 0.22222222222222
93965, 1.1625, 0.35869565217391, 0.16666666666667
93966, 1.1625, 0.35869565217391, 0.11111111111111
93967, 1.1625, 0.35869565217391, 0.055555555555556
93968, 1.1625, 0.30652173913043, 0.44444444444444
93969, 1.1625, 0.30652173913043, 0.38888888888889
93970, 1.1625, 0.30652173913043, 0.33333333333333
93971, 1.1625, 0.30652173913043, 0.27777777777778
93972, 1.1625, 0.30652173913043, 0.22222222222222
93973, 1.1625, 0.30652173913043, 0.16666666666667
93974, 1.1625, 0.30652173913043, 0.11111111111111
93975, 1.1625, 0.30652173913043, 0.055555555555556
93976, 1.1625, 0.25434782608696, 0.44444444444444
93977, 1.1625, 0.25434782608696, 0.38888888888889
93978, 1.1625, 0.25434782608696, 0.33333333333333
93979, 1.1625, 0.25434782608696, 0.27777777777778
93980, 1.1625, 0.25434782608696, 0.22222222222222
93981, 1.1625, 0.25434782608696, 0.16666666666667
93982, 1.1625, 0.25434782608696, 0.11111111111111
93983, 1.1625, 0.25434782608696, 0.055555555555556
93984, 1.1625, 0.20217391304348, 0.44444444444444
93985, 1.1625, 0.20217391304348, 0.38888888888889
93986, 1.1625, 0.20217391304348, 0.33333333333333
93987, 1.1625, 0.20217391304348, 0.27777777777778
93988, 1.1625, 0.20217391304348, 0.22222222222222
93989, 1.1625, 0.20217391304348, 0.16666666666667
93990, 1.1625, 0.20217391304348, 0.11111111111111
93991, 1.1625, 0.20217391304348, 0.055555555555556
93992, 1.1625, 1.2978260869565, 0.47222222222222
93993, 1.1625, 1.3239130434783, 0.44444444444444
93994, 1.18125, 1.2978260869565, 0.44444444444444
93995, 1.1625, 1.2978260869565, 0.41666666666667
93996, 1.1625, 1.3239130434783, 0.38888888888889
93997, 1.18125, 1.2978260869565, 0.38888888888889
93998, 1.1625, 1.2978260869565, 0.36111111111111
93999, 1.1625, 1.3239130434783, 0.33333333333333
94000, 1.18125, 1.2978260869565, 0.33333333333333
94001, 1.1625, 1.2978260869565, 0.30555555555556
94002, 1.1625, 1.3239130434783, 0.27777777777778
94003, 1.18125, 1.2978260869565, 0.27777777777778
94004, 1.1625, 1.2978260869565, 0.25
94005, 1.1625, 1.3239130434783, 0.22222222222222
94006, 1.18125, 1.2978260869565, 0.22222222222222
94007, 1.1625, 1.2978260869565, 0.19444444444444
94008, 1.1625, 1.3239130434783, 0.16666666666667
94009, 1.18125, 1.2978260869565, 0.16666666666667
94010, 1.1625, 1.2978260869565, 0.13888888888889
94011, 1.1625, 1.3239130434783, 0.11111111111111
94012, 1.18125, 1.2978260869565, 0.11111111111111
