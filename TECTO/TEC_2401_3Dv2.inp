37676, 0.34782608695652, 0.016666666666667, 0.083333333333333
37677, 0.3695652173913, 0.016666666666667, 0.11111111111111
37678, 0.39130434782609, 5.7245874707235e-17, 0.11111111111111
37679, 0.39130434782609, 0.016666666666667, 0.083333333333333
37680, 0.41304347826087, 0.016666666666667, 0.11111111111111
37681, 0.43478260869565, 5.5511151231258e-17, 0.11111111111111
37682, 0.43478260869565, 0.016666666666667, 0.083333333333333
37683, 0.45652173913043, 0.016666666666667, 0.11111111111111
37684, 0.47826086956522, 5.5511151231258e-17, 0.11111111111111
37685, 0.47826086956522, 0.016666666666667, 0.083333333333333
37686, 0.5, 0.016666666666667, 0.11111111111111
37687, 0.52173913043478, 5.5511151231258e-17, 0.11111111111111
37688, 0.52173913043478, 0.016666666666667, 0.083333333333333
37689, 0.54347826086957, 0.016666666666667, 0.11111111111111
37690, 0.56521739130435, 5.8980598183211e-17, 0.11111111111111
37691, 0.56521739130435, 0.016666666666667, 0.083333333333333
37692, 0.58695652173913, 0.016666666666667, 0.11111111111111
37693, 0.60869565217391, 5.7245874707235e-17, 0.11111111111111
37694, 0.60869565217391, 0.016666666666667, 0.083333333333333
37695, 0.6304347826087, 0.016666666666667, 0.11111111111111
37696, 0.65217391304348, 5.5511151231258e-17, 0.11111111111111
37697, 0.65217391304348, 0.016666666666667, 0.083333333333333
37698, 0.67391304347826, 0.016666666666667, 0.11111111111111
37699, 0.69565217391304, 5.7245874707235e-17, 0.11111111111111
37700, 0.69565217391304, 0.016666666666667, 0.083333333333333
37701, 0.71739130434783, 0.016666666666667, 0.11111111111111
37702, 0.73913043478261, 5.5511151231258e-17, 0.11111111111111
37703, 0.73913043478261, 0.016666666666667, 0.083333333333333
37704, 0.76086956521739, 0.016666666666667, 0.11111111111111
37705, 0.78260869565217, 5.8980598183211e-17, 0.11111111111111
37706, 0.78260869565217, 0.016666666666667, 0.083333333333333
37707, 0.80434782608696, 0.016666666666667, 0.11111111111111
37708, 0.82608695652174, 5.3776427755281e-17, 0.11111111111111
37709, 0.82608695652174, 0.016666666666667, 0.083333333333333
37710, 0.84782608695652, 0.016666666666667, 0.11111111111111
37711, 0.8695652173913, 5.5511151231258e-17, 0.11111111111111
37712, 0.8695652173913, 0.016666666666667, 0.083333333333333
37713, 0.89130434782609, 0.016666666666667, 0.11111111111111
37714, 0.91304347826087, 5.8980598183211e-17, 0.11111111111111
37715, 0.91304347826087, 0.016666666666667, 0.083333333333333
37716, 0.93478260869565, 0.016666666666667, 0.11111111111111
37717, 0.95652173913044, 5.8980598183211e-17, 0.11111111111111
37718, 0.95652173913044, 0.016666666666667, 0.083333333333333
37719, 0.97826086956522, 0.016666666666667, 0.11111111111111
37720, 0.043478260869565, 0.033333333333333, 0.11111111111111
37721, 0.08695652173913, 0.033333333333333, 0.11111111111111
37722, 0.1304347826087, 0.033333333333333, 0.11111111111111
37723, 0.17391304347826, 0.033333333333333, 0.11111111111111
37724, 0.21739130434783, 0.033333333333333, 0.11111111111111
37725, 0.26086956521739, 0.033333333333333, 0.11111111111111
37726, 0.30434782608696, 0.033333333333333, 0.11111111111111
37727, 0.34782608695652, 0.033333333333333, 0.11111111111111
37728, 0.39130434782609, 0.033333333333333, 0.11111111111111
37729, 0.43478260869565, 0.033333333333333, 0.11111111111111
37730, 0.47826086956522, 0.033333333333333, 0.11111111111111
37731, 0.52173913043478, 0.033333333333333, 0.11111111111111
37732, 0.56521739130435, 0.033333333333333, 0.11111111111111
37733, 0.60869565217391, 0.033333333333333, 0.11111111111111
37734, 0.65217391304348, 0.033333333333333, 0.11111111111111
37735, 0.69565217391304, 0.033333333333333, 0.11111111111111
37736, 0.73913043478261, 0.033333333333333, 0.11111111111111
37737, 0.78260869565217, 0.033333333333333, 0.11111111111111
37738, 0.82608695652174, 0.033333333333333, 0.11111111111111
37739, 0.8695652173913, 0.033333333333333, 0.11111111111111
37740, 0.91304347826087, 0.033333333333333, 0.11111111111111
37741, 0.95652173913043, 0.033333333333333, 0.11111111111111
37742, 0.021739130434783, -0.016666666666667, 0.16666666666667
37743, 0.043478260869565, -0.033333333333333, 0.16666666666667
37744, 0.043478260869565, -0.016666666666667, 0.13888888888889
37745, 0.065217391304348, -0.016666666666667, 0.16666666666667
37746, 0.08695652173913, -0.033333333333333, 0.16666666666667
37747, 0.08695652173913, -0.016666666666667, 0.13888888888889
37748, 0.10869565217391, -0.016666666666667, 0.16666666666667
37749, 0.1304347826087, -0.033333333333333, 0.16666666666667
37750, 0.1304347826087, -0.016666666666667, 0.13888888888889
37751, 0.15217391304348, -0.016666666666667, 0.16666666666667
37752, 0.17391304347826, -0.033333333333333, 0.16666666666667
37753, 0.17391304347826, -0.016666666666667, 0.13888888888889
37754, 0.19565217391304, -0.016666666666667, 0.16666666666667
37755, 0.21739130434783, -0.033333333333333, 0.16666666666667
37756, 0.21739130434783, -0.016666666666667, 0.13888888888889
37757, 0.23913043478261, -0.016666666666667, 0.16666666666667
37758, 0.26086956521739, -0.033333333333333, 0.16666666666667
37759, 0.26086956521739, -0.016666666666667, 0.13888888888889
37760, 0.28260869565217, -0.016666666666667, 0.16666666666667
37761, 0.30434782608696, -0.033333333333333, 0.16666666666667
37762, 0.30434782608696, -0.016666666666667, 0.13888888888889
37763, 0.32608695652174, -0.016666666666667, 0.16666666666667
37764, 0.34782608695652, -0.033333333333333, 0.16666666666667
37765, 0.34782608695652, -0.016666666666667, 0.13888888888889
37766, 0.3695652173913, -0.016666666666667, 0.16666666666667
37767, 0.39130434782609, -0.033333333333333, 0.16666666666667
37768, 0.39130434782609, -0.016666666666667, 0.13888888888889
37769, 0.41304347826087, -0.016666666666667, 0.16666666666667
37770, 0.43478260869565, -0.033333333333333, 0.16666666666667
37771, 0.43478260869565, -0.016666666666667, 0.13888888888889
37772, 0.45652173913043, -0.016666666666667, 0.16666666666667
37773, 0.47826086956522, -0.033333333333333, 0.16666666666667
37774, 0.47826086956522, -0.016666666666667, 0.13888888888889
37775, 0.5, -0.016666666666667, 0.16666666666667
37776, 0.52173913043478, -0.033333333333333, 0.16666666666667
37777, 0.52173913043478, -0.016666666666667, 0.13888888888889
37778, 0.54347826086957, -0.016666666666667, 0.16666666666667
37779, 0.56521739130435, -0.033333333333333, 0.16666666666667
37780, 0.56521739130435, -0.016666666666667, 0.13888888888889
37781, 0.58695652173913, -0.016666666666667, 0.16666666666667
37782, 0.60869565217391, -0.033333333333333, 0.16666666666667
37783, 0.60869565217391, -0.016666666666667, 0.13888888888889
37784, 0.6304347826087, -0.016666666666667, 0.16666666666667
37785, 0.65217391304348, -0.033333333333333, 0.16666666666667
37786, 0.65217391304348, -0.016666666666667, 0.13888888888889
37787, 0.67391304347826, -0.016666666666667, 0.16666666666667
37788, 0.69565217391304, -0.033333333333333, 0.16666666666667
37789, 0.69565217391304, -0.016666666666667, 0.13888888888889
37790, 0.71739130434783, -0.016666666666667, 0.16666666666667
37791, 0.73913043478261, -0.033333333333333, 0.16666666666667
37792, 0.73913043478261, -0.016666666666667, 0.13888888888889
37793, 0.76086956521739, -0.016666666666667, 0.16666666666667
37794, 0.78260869565217, -0.033333333333333, 0.16666666666667
37795, 0.78260869565217, -0.016666666666667, 0.13888888888889
37796, 0.80434782608696, -0.016666666666667, 0.16666666666667
37797, 0.82608695652174, -0.033333333333333, 0.16666666666667
37798, 0.82608695652174, -0.016666666666667, 0.13888888888889
37799, 0.84782608695652, -0.016666666666667, 0.16666666666667
37800, 0.8695652173913, -0.033333333333333, 0.16666666666667
37801, 0.8695652173913, -0.016666666666667, 0.13888888888889
37802, 0.89130434782609, -0.016666666666667, 0.16666666666667
37803, 0.91304347826087, -0.033333333333333, 0.16666666666667
37804, 0.91304347826087, -0.016666666666667, 0.13888888888889
37805, 0.93478260869565, -0.016666666666667, 0.16666666666667
37806, 0.95652173913043, -0.033333333333333, 0.16666666666667
37807, 0.95652173913044, -0.016666666666667, 0.13888888888889
37808, 0.97826086956522, -0.016666666666667, 0.16666666666667
37809, 0.021739130434783, 0.016666666666667, 0.16666666666667
37810, 0.043478260869565, 7.1123662515049e-17, 0.16666666666667
37811, 0.043478260869565, 0.016666666666667, 0.13888888888889
37812, 0.065217391304348, 0.016666666666667, 0.16666666666667
37813, 0.08695652173913, 6.4184768611142e-17, 0.16666666666667
37814, 0.08695652173913, 0.016666666666667, 0.13888888888889
37815, 0.10869565217391, 0.016666666666667, 0.16666666666667
37816, 0.1304347826087, 6.0715321659188e-17, 0.16666666666667
37817, 0.1304347826087, 0.016666666666667, 0.13888888888889
37818, 0.15217391304348, 0.016666666666667, 0.16666666666667
37819, 0.17391304347826, 5.5511151231258e-17, 0.16666666666667
37820, 0.17391304347826, 0.016666666666667, 0.13888888888889
37821, 0.19565217391304, 0.016666666666667, 0.16666666666667
37822, 0.21739130434783, 6.5919492087119e-17, 0.16666666666667
37823, 0.21739130434783, 0.016666666666667, 0.13888888888889
37824, 0.23913043478261, 0.016666666666667, 0.16666666666667
37825, 0.26086956521739, 6.0715321659188e-17, 0.16666666666667
37826, 0.26086956521739, 0.016666666666667, 0.13888888888889
37827, 0.28260869565217, 0.016666666666667, 0.16666666666667
37828, 0.30434782608696, 6.0715321659188e-17, 0.16666666666667
37829, 0.30434782608696, 0.016666666666667, 0.13888888888889
37830, 0.32608695652174, 0.016666666666667, 0.16666666666667
37831, 0.34782608695652, 6.0715321659188e-17, 0.16666666666667
37832, 0.34782608695652, 0.016666666666667, 0.13888888888889
37833, 0.3695652173913, 0.016666666666667, 0.16666666666667
37834, 0.39130434782609, 6.4184768611142e-17, 0.16666666666667
37835, 0.39130434782609, 0.016666666666667, 0.13888888888889
37836, 0.41304347826087, 0.016666666666667, 0.16666666666667
37837, 0.43478260869565, 5.8980598183211e-17, 0.16666666666667
37838, 0.43478260869565, 0.016666666666667, 0.13888888888889
37839, 0.45652173913043, 0.016666666666667, 0.16666666666667
37840, 0.47826086956522, 6.4184768611142e-17, 0.16666666666667
37841, 0.47826086956522, 0.016666666666667, 0.13888888888889
37842, 0.5, 0.016666666666667, 0.16666666666667
37843, 0.52173913043478, 6.0715321659188e-17, 0.16666666666667
37844, 0.52173913043478, 0.016666666666667, 0.13888888888889
37845, 0.54347826086957, 0.016666666666667, 0.16666666666667
37846, 0.56521739130435, 6.0715321659188e-17, 0.16666666666667
37847, 0.56521739130435, 0.016666666666667, 0.13888888888889
37848, 0.58695652173913, 0.016666666666667, 0.16666666666667
37849, 0.60869565217391, 6.2450045135165e-17, 0.16666666666667
37850, 0.60869565217391, 0.016666666666667, 0.13888888888889
37851, 0.6304347826087, 0.016666666666667, 0.16666666666667
37852, 0.65217391304348, 6.4184768611142e-17, 0.16666666666667
37853, 0.65217391304348, 0.016666666666667, 0.13888888888889
37854, 0.67391304347826, 0.016666666666667, 0.16666666666667
37855, 0.69565217391304, 6.5919492087119e-17, 0.16666666666667
37856, 0.69565217391304, 0.016666666666667, 0.13888888888889
37857, 0.71739130434783, 0.016666666666667, 0.16666666666667
37858, 0.73913043478261, 6.2450045135165e-17, 0.16666666666667
37859, 0.73913043478261, 0.016666666666667, 0.13888888888889
37860, 0.76086956521739, 0.016666666666667, 0.16666666666667
37861, 0.78260869565217, 6.4184768611142e-17, 0.16666666666667
37862, 0.78260869565217, 0.016666666666667, 0.13888888888889
37863, 0.80434782608696, 0.016666666666667, 0.16666666666667
37864, 0.82608695652174, 6.0715321659188e-17, 0.16666666666667
37865, 0.82608695652174, 0.016666666666667, 0.13888888888889
37866, 0.84782608695652, 0.016666666666667, 0.16666666666667
37867, 0.8695652173913, 6.2450045135165e-17, 0.16666666666667
37868, 0.8695652173913, 0.016666666666667, 0.13888888888889
37869, 0.89130434782609, 0.016666666666667, 0.16666666666667
37870, 0.91304347826087, 6.2450045135165e-17, 0.16666666666667
37871, 0.91304347826087, 0.016666666666667, 0.13888888888889
37872, 0.93478260869565, 0.016666666666667, 0.16666666666667
37873, 0.95652173913044, 6.9388939039072e-17, 0.16666666666667
37874, 0.95652173913044, 0.016666666666667, 0.13888888888889
37875, 0.97826086956522, 0.016666666666667, 0.16666666666667
37876, 0.043478260869565, 0.033333333333333, 0.16666666666667
37877, 0.08695652173913, 0.033333333333333, 0.16666666666667
37878, 0.1304347826087, 0.033333333333333, 0.16666666666667
37879, 0.17391304347826, 0.033333333333333, 0.16666666666667
37880, 0.21739130434783, 0.033333333333333, 0.16666666666667
37881, 0.26086956521739, 0.033333333333333, 0.16666666666667
37882, 0.30434782608696, 0.033333333333333, 0.16666666666667
37883, 0.34782608695652, 0.033333333333333, 0.16666666666667
37884, 0.39130434782609, 0.033333333333333, 0.16666666666667
37885, 0.43478260869565, 0.033333333333333, 0.16666666666667
37886, 0.47826086956522, 0.033333333333333, 0.16666666666667
37887, 0.52173913043478, 0.033333333333333, 0.16666666666667
37888, 0.56521739130435, 0.033333333333333, 0.16666666666667
37889, 0.60869565217391, 0.033333333333333, 0.16666666666667
37890, 0.65217391304348, 0.033333333333333, 0.16666666666667
37891, 0.69565217391304, 0.033333333333333, 0.16666666666667
37892, 0.73913043478261, 0.033333333333333, 0.16666666666667
37893, 0.78260869565217, 0.033333333333333, 0.16666666666667
37894, 0.82608695652174, 0.033333333333333, 0.16666666666667
37895, 0.8695652173913, 0.033333333333333, 0.16666666666667
37896, 0.91304347826087, 0.033333333333333, 0.16666666666667
37897, 0.95652173913043, 0.033333333333333, 0.16666666666667
37898, 0.021739130434783, -0.016666666666667, 0.22222222222222
37899, 0.043478260869565, -0.033333333333333, 0.22222222222222
37900, 0.043478260869565, -0.016666666666667, 0.19444444444444
37901, 0.065217391304348, -0.016666666666667, 0.22222222222222
37902, 0.08695652173913, -0.033333333333333, 0.22222222222222
37903, 0.08695652173913, -0.016666666666667, 0.19444444444444
37904, 0.10869565217391, -0.016666666666667, 0.22222222222222
37905, 0.1304347826087, -0.033333333333333, 0.22222222222222
37906, 0.1304347826087, -0.016666666666667, 0.19444444444444
37907, 0.15217391304348, -0.016666666666667, 0.22222222222222
37908, 0.17391304347826, -0.033333333333333, 0.22222222222222
37909, 0.17391304347826, -0.016666666666667, 0.19444444444444
37910, 0.19565217391304, -0.016666666666667, 0.22222222222222
37911, 0.21739130434783, -0.033333333333333, 0.22222222222222
37912, 0.21739130434783, -0.016666666666667, 0.19444444444444
37913, 0.23913043478261, -0.016666666666667, 0.22222222222222
37914, 0.26086956521739, -0.033333333333333, 0.22222222222222
37915, 0.26086956521739, -0.016666666666667, 0.19444444444444
37916, 0.28260869565217, -0.016666666666667, 0.22222222222222
37917, 0.30434782608696, -0.033333333333333, 0.22222222222222
37918, 0.30434782608696, -0.016666666666667, 0.19444444444444
37919, 0.32608695652174, -0.016666666666667, 0.22222222222222
37920, 0.34782608695652, -0.033333333333333, 0.22222222222222
37921, 0.34782608695652, -0.016666666666667, 0.19444444444444
37922, 0.3695652173913, -0.016666666666667, 0.22222222222222
37923, 0.39130434782609, -0.033333333333333, 0.22222222222222
37924, 0.39130434782609, -0.016666666666667, 0.19444444444444
37925, 0.41304347826087, -0.016666666666667, 0.22222222222222
37926, 0.43478260869565, -0.033333333333333, 0.22222222222222
37927, 0.43478260869565, -0.016666666666667, 0.19444444444444
37928, 0.45652173913043, -0.016666666666667, 0.22222222222222
37929, 0.47826086956522, -0.033333333333333, 0.22222222222222
37930, 0.47826086956522, -0.016666666666667, 0.19444444444444
37931, 0.5, -0.016666666666667, 0.22222222222222
37932, 0.52173913043478, -0.033333333333333, 0.22222222222222
37933, 0.52173913043478, -0.016666666666667, 0.19444444444444
37934, 0.54347826086957, -0.016666666666667, 0.22222222222222
37935, 0.56521739130435, -0.033333333333333, 0.22222222222222
37936, 0.56521739130435, -0.016666666666667, 0.19444444444444
37937, 0.58695652173913, -0.016666666666667, 0.22222222222222
37938, 0.60869565217391, -0.033333333333333, 0.22222222222222
37939, 0.60869565217391, -0.016666666666667, 0.19444444444444
37940, 0.6304347826087, -0.016666666666667, 0.22222222222222
37941, 0.65217391304348, -0.033333333333333, 0.22222222222222
37942, 0.65217391304348, -0.016666666666667, 0.19444444444444
37943, 0.67391304347826, -0.016666666666667, 0.22222222222222
37944, 0.69565217391304, -0.033333333333333, 0.22222222222222
37945, 0.69565217391304, -0.016666666666667, 0.19444444444444
37946, 0.71739130434783, -0.016666666666667, 0.22222222222222
37947, 0.73913043478261, -0.033333333333333, 0.22222222222222
37948, 0.73913043478261, -0.016666666666667, 0.19444444444444
37949, 0.76086956521739, -0.016666666666667, 0.22222222222222
37950, 0.78260869565217, -0.033333333333333, 0.22222222222222
37951, 0.78260869565217, -0.016666666666667, 0.19444444444444
37952, 0.80434782608696, -0.016666666666667, 0.22222222222222
37953, 0.82608695652174, -0.033333333333333, 0.22222222222222
37954, 0.82608695652174, -0.016666666666667, 0.19444444444444
37955, 0.84782608695652, -0.016666666666667, 0.22222222222222
37956, 0.8695652173913, -0.033333333333333, 0.22222222222222
37957, 0.8695652173913, -0.016666666666667, 0.19444444444444
37958, 0.89130434782609, -0.016666666666667, 0.22222222222222
37959, 0.91304347826087, -0.033333333333333, 0.22222222222222
37960, 0.91304347826087, -0.016666666666667, 0.19444444444444
37961, 0.93478260869565, -0.016666666666667, 0.22222222222222
37962, 0.95652173913043, -0.033333333333333, 0.22222222222222
37963, 0.95652173913044, -0.016666666666667, 0.19444444444444
37964, 0.97826086956522, -0.016666666666667, 0.22222222222222
37965, 0.021739130434783, 0.016666666666667, 0.22222222222222
37966, 0.043478260869565, 5.8980598183211e-17, 0.22222222222222
37967, 0.043478260869565, 0.016666666666667, 0.19444444444444
37968, 0.065217391304348, 0.016666666666667, 0.22222222222222
37969, 0.08695652173913, 5.8980598183211e-17, 0.22222222222222
37970, 0.08695652173913, 0.016666666666667, 0.19444444444444
37971, 0.10869565217391, 0.016666666666667, 0.22222222222222
37972, 0.1304347826087, 5.7245874707235e-17, 0.22222222222222
37973, 0.1304347826087, 0.016666666666667, 0.19444444444444
37974, 0.15217391304348, 0.016666666666667, 0.22222222222222
37975, 0.17391304347826, 5.3776427755281e-17, 0.22222222222222
37976, 0.17391304347826, 0.016666666666667, 0.19444444444444
37977, 0.19565217391304, 0.016666666666667, 0.22222222222222
37978, 0.21739130434783, 5.5511151231258e-17, 0.22222222222222
37979, 0.21739130434783, 0.016666666666667, 0.19444444444444
37980, 0.23913043478261, 0.016666666666667, 0.22222222222222
37981, 0.26086956521739, 5.2041704279304e-17, 0.22222222222222
37982, 0.26086956521739, 0.016666666666667, 0.19444444444444
37983, 0.28260869565217, 0.016666666666667, 0.22222222222222
37984, 0.30434782608696, 5.5511151231258e-17, 0.22222222222222
37985, 0.30434782608696, 0.016666666666667, 0.19444444444444
37986, 0.32608695652174, 0.016666666666667, 0.22222222222222
37987, 0.34782608695652, 5.3776427755281e-17, 0.22222222222222
37988, 0.34782608695652, 0.016666666666667, 0.19444444444444
37989, 0.3695652173913, 0.016666666666667, 0.22222222222222
37990, 0.39130434782609, 5.8980598183211e-17, 0.22222222222222
37991, 0.39130434782609, 0.016666666666667, 0.19444444444444
37992, 0.41304347826087, 0.016666666666667, 0.22222222222222
37993, 0.43478260869565, 5.5511151231258e-17, 0.22222222222222
37994, 0.43478260869565, 0.016666666666667, 0.19444444444444
37995, 0.45652173913043, 0.016666666666667, 0.22222222222222
37996, 0.47826086956522, 5.3776427755281e-17, 0.22222222222222
37997, 0.47826086956522, 0.016666666666667, 0.19444444444444
37998, 0.5, 0.016666666666667, 0.22222222222222
37999, 0.52173913043478, 5.5511151231258e-17, 0.22222222222222
38000, 0.52173913043478, 0.016666666666667, 0.19444444444444
38001, 0.54347826086957, 0.016666666666667, 0.22222222222222
38002, 0.56521739130435, 5.7245874707235e-17, 0.22222222222222
38003, 0.56521739130435, 0.016666666666667, 0.19444444444444
38004, 0.58695652173913, 0.016666666666667, 0.22222222222222
38005, 0.60869565217391, 5.5511151231258e-17, 0.22222222222222
38006, 0.60869565217391, 0.016666666666667, 0.19444444444444
38007, 0.6304347826087, 0.016666666666667, 0.22222222222222
38008, 0.65217391304348, 5.5511151231258e-17, 0.22222222222222
38009, 0.65217391304348, 0.016666666666667, 0.19444444444444
38010, 0.67391304347826, 0.016666666666667, 0.22222222222222
38011, 0.69565217391304, 5.5511151231258e-17, 0.22222222222222
38012, 0.69565217391304, 0.016666666666667, 0.19444444444444
38013, 0.71739130434783, 0.016666666666667, 0.22222222222222
38014, 0.73913043478261, 5.5511151231258e-17, 0.22222222222222
38015, 0.73913043478261, 0.016666666666667, 0.19444444444444
38016, 0.76086956521739, 0.016666666666667, 0.22222222222222
38017, 0.78260869565217, 5.8980598183211e-17, 0.22222222222222
38018, 0.78260869565217, 0.016666666666667, 0.19444444444444
38019, 0.80434782608696, 0.016666666666667, 0.22222222222222
38020, 0.82608695652174, 5.2041704279304e-17, 0.22222222222222
38021, 0.82608695652174, 0.016666666666667, 0.19444444444444
38022, 0.84782608695652, 0.016666666666667, 0.22222222222222
38023, 0.8695652173913, 5.5511151231258e-17, 0.22222222222222
38024, 0.8695652173913, 0.016666666666667, 0.19444444444444
38025, 0.89130434782609, 0.016666666666667, 0.22222222222222
38026, 0.91304347826087, 5.5511151231258e-17, 0.22222222222222
38027, 0.91304347826087, 0.016666666666667, 0.19444444444444
38028, 0.93478260869565, 0.016666666666667, 0.22222222222222
38029, 0.95652173913044, 5.8980598183211e-17, 0.22222222222222
38030, 0.95652173913044, 0.016666666666667, 0.19444444444444
38031, 0.97826086956522, 0.016666666666667, 0.22222222222222
38032, 0.043478260869565, 0.033333333333333, 0.22222222222222
38033, 0.08695652173913, 0.033333333333333, 0.22222222222222
38034, 0.1304347826087, 0.033333333333333, 0.22222222222222
38035, 0.17391304347826, 0.033333333333333, 0.22222222222222
38036, 0.21739130434783, 0.033333333333333, 0.22222222222222
38037, 0.26086956521739, 0.033333333333333, 0.22222222222222
38038, 0.30434782608696, 0.033333333333333, 0.22222222222222
38039, 0.34782608695652, 0.033333333333333, 0.22222222222222
38040, 0.39130434782609, 0.033333333333333, 0.22222222222222
38041, 0.43478260869565, 0.033333333333333, 0.22222222222222
38042, 0.47826086956522, 0.033333333333333, 0.22222222222222
38043, 0.52173913043478, 0.033333333333333, 0.22222222222222
38044, 0.56521739130435, 0.033333333333333, 0.22222222222222
38045, 0.60869565217391, 0.033333333333333, 0.22222222222222
38046, 0.65217391304348, 0.033333333333333, 0.22222222222222
38047, 0.69565217391304, 0.033333333333333, 0.22222222222222
38048, 0.73913043478261, 0.033333333333333, 0.22222222222222
38049, 0.78260869565217, 0.033333333333333, 0.22222222222222
38050, 0.82608695652174, 0.033333333333333, 0.22222222222222
38051, 0.8695652173913, 0.033333333333333, 0.22222222222222
38052, 0.91304347826087, 0.033333333333333, 0.22222222222222
38053, 0.95652173913043, 0.033333333333333, 0.22222222222222
38054, 0.021739130434783, -0.016666666666667, 0.27777777777778
38055, 0.043478260869565, -0.033333333333333, 0.27777777777778
38056, 0.043478260869565, -0.016666666666667, 0.25
38057, 0.065217391304348, -0.016666666666667, 0.27777777777778
38058, 0.08695652173913, -0.033333333333333, 0.27777777777778
38059, 0.08695652173913, -0.016666666666667, 0.25
38060, 0.10869565217391, -0.016666666666667, 0.27777777777778
38061, 0.1304347826087, -0.033333333333333, 0.27777777777778
38062, 0.1304347826087, -0.016666666666667, 0.25
38063, 0.15217391304348, -0.016666666666667, 0.27777777777778
38064, 0.17391304347826, -0.033333333333333, 0.27777777777778
38065, 0.17391304347826, -0.016666666666667, 0.25
38066, 0.19565217391304, -0.016666666666667, 0.27777777777778
38067, 0.21739130434783, -0.033333333333333, 0.27777777777778
38068, 0.21739130434783, -0.016666666666667, 0.25
38069, 0.23913043478261, -0.016666666666667, 0.27777777777778
38070, 0.26086956521739, -0.033333333333333, 0.27777777777778
38071, 0.26086956521739, -0.016666666666667, 0.25
38072, 0.28260869565217, -0.016666666666667, 0.27777777777778
38073, 0.30434782608696, -0.033333333333333, 0.27777777777778
38074, 0.30434782608696, -0.016666666666667, 0.25
38075, 0.32608695652174, -0.016666666666667, 0.27777777777778
38076, 0.34782608695652, -0.033333333333333, 0.27777777777778
38077, 0.34782608695652, -0.016666666666667, 0.25
38078, 0.3695652173913, -0.016666666666667, 0.27777777777778
38079, 0.39130434782609, -0.033333333333333, 0.27777777777778
38080, 0.39130434782609, -0.016666666666667, 0.25
38081, 0.41304347826087, -0.016666666666667, 0.27777777777778
38082, 0.43478260869565, -0.033333333333333, 0.27777777777778
38083, 0.43478260869565, -0.016666666666667, 0.25
38084, 0.45652173913043, -0.016666666666667, 0.27777777777778
38085, 0.47826086956522, -0.033333333333333, 0.27777777777778
38086, 0.47826086956522, -0.016666666666667, 0.25
38087, 0.5, -0.016666666666667, 0.27777777777778
38088, 0.52173913043478, -0.033333333333333, 0.27777777777778
38089, 0.52173913043478, -0.016666666666667, 0.25
38090, 0.54347826086957, -0.016666666666667, 0.27777777777778
38091, 0.56521739130435, -0.033333333333333, 0.27777777777778
38092, 0.56521739130435, -0.016666666666667, 0.25
38093, 0.58695652173913, -0.016666666666667, 0.27777777777778
38094, 0.60869565217391, -0.033333333333333, 0.27777777777778
38095, 0.60869565217391, -0.016666666666667, 0.25
38096, 0.6304347826087, -0.016666666666667, 0.27777777777778
38097, 0.65217391304348, -0.033333333333333, 0.27777777777778
38098, 0.65217391304348, -0.016666666666667, 0.25
38099, 0.67391304347826, -0.016666666666667, 0.27777777777778
38100, 0.69565217391304, -0.033333333333333, 0.27777777777778
38101, 0.69565217391304, -0.016666666666667, 0.25
38102, 0.71739130434783, -0.016666666666667, 0.27777777777778
38103, 0.73913043478261, -0.033333333333333, 0.27777777777778
38104, 0.73913043478261, -0.016666666666667, 0.25
38105, 0.76086956521739, -0.016666666666667, 0.27777777777778
38106, 0.78260869565217, -0.033333333333333, 0.27777777777778
38107, 0.78260869565217, -0.016666666666667, 0.25
38108, 0.80434782608696, -0.016666666666667, 0.27777777777778
38109, 0.82608695652174, -0.033333333333333, 0.27777777777778
38110, 0.82608695652174, -0.016666666666667, 0.25
38111, 0.84782608695652, -0.016666666666667, 0.27777777777778
38112, 0.8695652173913, -0.033333333333333, 0.27777777777778
38113, 0.8695652173913, -0.016666666666667, 0.25
38114, 0.89130434782609, -0.016666666666667, 0.27777777777778
38115, 0.91304347826087, -0.033333333333333, 0.27777777777778
38116, 0.91304347826087, -0.016666666666667, 0.25
38117, 0.93478260869565, -0.016666666666667, 0.27777777777778
38118, 0.95652173913043, -0.033333333333333, 0.27777777777778
38119, 0.95652173913044, -0.016666666666667, 0.25
38120, 0.97826086956522, -0.016666666666667, 0.27777777777778
38121, 0.021739130434783, 0.016666666666667, 0.27777777777778
38122, 0.043478260869565, 6.0715321659188e-17, 0.27777777777778
38123, 0.043478260869565, 0.016666666666667, 0.25
38124, 0.065217391304348, 0.016666666666667, 0.27777777777778
38125, 0.08695652173913, 5.8980598183211e-17, 0.27777777777778
38126, 0.08695652173913, 0.016666666666667, 0.25
38127, 0.10869565217391, 0.016666666666667, 0.27777777777778
38128, 0.1304347826087, 5.7245874707235e-17, 0.27777777777778
38129, 0.1304347826087, 0.016666666666667, 0.25
38130, 0.15217391304348, 0.016666666666667, 0.27777777777778
38131, 0.17391304347826, 5.3776427755281e-17, 0.27777777777778
38132, 0.17391304347826, 0.016666666666667, 0.25
38133, 0.19565217391304, 0.016666666666667, 0.27777777777778
38134, 0.21739130434783, 5.0306980803327e-17, 0.27777777777778
38135, 0.21739130434783, 0.016666666666667, 0.25
38136, 0.23913043478261, 0.016666666666667, 0.27777777777778
38137, 0.26086956521739, 5.2041704279304e-17, 0.27777777777778
38138, 0.26086956521739, 0.016666666666667, 0.25
38139, 0.28260869565217, 0.016666666666667, 0.27777777777778
38140, 0.30434782608696, 5.5511151231258e-17, 0.27777777777778
38141, 0.30434782608696, 0.016666666666667, 0.25
38142, 0.32608695652174, 0.016666666666667, 0.27777777777778
38143, 0.34782608695652, 5.5511151231258e-17, 0.27777777777778
38144, 0.34782608695652, 0.016666666666667, 0.25
38145, 0.3695652173913, 0.016666666666667, 0.27777777777778
38146, 0.39130434782609, 5.5511151231258e-17, 0.27777777777778
38147, 0.39130434782609, 0.016666666666667, 0.25
38148, 0.41304347826087, 0.016666666666667, 0.27777777777778
38149, 0.43478260869565, 5.3776427755281e-17, 0.27777777777778
38150, 0.43478260869565, 0.016666666666667, 0.25
38151, 0.45652173913043, 0.016666666666667, 0.27777777777778
38152, 0.47826086956522, 5.5511151231258e-17, 0.27777777777778
38153, 0.47826086956522, 0.016666666666667, 0.25
38154, 0.5, 0.016666666666667, 0.27777777777778
38155, 0.52173913043478, 5.2041704279304e-17, 0.27777777777778
38156, 0.52173913043478, 0.016666666666667, 0.25
38157, 0.54347826086957, 0.016666666666667, 0.27777777777778
38158, 0.56521739130435, 5.5511151231258e-17, 0.27777777777778
38159, 0.56521739130435, 0.016666666666667, 0.25
38160, 0.58695652173913, 0.016666666666667, 0.27777777777778
38161, 0.60869565217391, 5.5511151231258e-17, 0.27777777777778
38162, 0.60869565217391, 0.016666666666667, 0.25
38163, 0.6304347826087, 0.016666666666667, 0.27777777777778
38164, 0.65217391304348, 5.5511151231258e-17, 0.27777777777778
38165, 0.65217391304348, 0.016666666666667, 0.25
38166, 0.67391304347826, 0.016666666666667, 0.27777777777778
38167, 0.69565217391304, 5.5511151231258e-17, 0.27777777777778
38168, 0.69565217391304, 0.016666666666667, 0.25
38169, 0.71739130434783, 0.016666666666667, 0.27777777777778
38170, 0.73913043478261, 5.7245874707235e-17, 0.27777777777778
38171, 0.73913043478261, 0.016666666666667, 0.25
38172, 0.76086956521739, 0.016666666666667, 0.27777777777778
38173, 0.78260869565217, 5.8980598183211e-17, 0.27777777777778
38174, 0.78260869565217, 0.016666666666667, 0.25
38175, 0.80434782608696, 0.016666666666667, 0.27777777777778
38176, 0.82608695652174, 5.5511151231258e-17, 0.27777777777778
38177, 0.82608695652174, 0.016666666666667, 0.25
38178, 0.84782608695652, 0.016666666666667, 0.27777777777778
38179, 0.8695652173913, 5.7245874707235e-17, 0.27777777777778
38180, 0.8695652173913, 0.016666666666667, 0.25
38181, 0.89130434782609, 0.016666666666667, 0.27777777777778
38182, 0.91304347826087, 5.7245874707235e-17, 0.27777777777778
38183, 0.91304347826087, 0.016666666666667, 0.25
38184, 0.93478260869565, 0.016666666666667, 0.27777777777778
38185, 0.95652173913044, 5.8980598183211e-17, 0.27777777777778
38186, 0.95652173913044, 0.016666666666667, 0.25
38187, 0.97826086956522, 0.016666666666667, 0.27777777777778
38188, 0.043478260869565, 0.033333333333333, 0.27777777777778
38189, 0.08695652173913, 0.033333333333333, 0.27777777777778
38190, 0.1304347826087, 0.033333333333333, 0.27777777777778
38191, 0.17391304347826, 0.033333333333333, 0.27777777777778
38192, 0.21739130434783, 0.033333333333333, 0.27777777777778
38193, 0.26086956521739, 0.033333333333333, 0.27777777777778
38194, 0.30434782608696, 0.033333333333333, 0.27777777777778
38195, 0.34782608695652, 0.033333333333333, 0.27777777777778
38196, 0.39130434782609, 0.033333333333333, 0.27777777777778
38197, 0.43478260869565, 0.033333333333333, 0.27777777777778
38198, 0.47826086956522, 0.033333333333333, 0.27777777777778
38199, 0.52173913043478, 0.033333333333333, 0.27777777777778
38200, 0.56521739130435, 0.033333333333333, 0.27777777777778
38201, 0.60869565217391, 0.033333333333333, 0.27777777777778
38202, 0.65217391304348, 0.033333333333333, 0.27777777777778
38203, 0.69565217391304, 0.033333333333333, 0.27777777777778
38204, 0.73913043478261, 0.033333333333333, 0.27777777777778
38205, 0.78260869565217, 0.033333333333333, 0.27777777777778
38206, 0.82608695652174, 0.033333333333333, 0.27777777777778
38207, 0.8695652173913, 0.033333333333333, 0.27777777777778
38208, 0.91304347826087, 0.033333333333333, 0.27777777777778
38209, 0.95652173913043, 0.033333333333333, 0.27777777777778
38210, 0.021739130434783, -0.016666666666667, 0.33333333333333
38211, 0.043478260869565, -0.033333333333333, 0.33333333333333
38212, 0.043478260869565, -0.016666666666667, 0.30555555555556
38213, 0.065217391304348, -0.016666666666667, 0.33333333333333
38214, 0.08695652173913, -0.033333333333333, 0.33333333333333
38215, 0.08695652173913, -0.016666666666667, 0.30555555555556
38216, 0.10869565217391, -0.016666666666667, 0.33333333333333
38217, 0.1304347826087, -0.033333333333333, 0.33333333333333
38218, 0.1304347826087, -0.016666666666667, 0.30555555555556
38219, 0.15217391304348, -0.016666666666667, 0.33333333333333
38220, 0.17391304347826, -0.033333333333333, 0.33333333333333
38221, 0.17391304347826, -0.016666666666667, 0.30555555555556
38222, 0.19565217391304, -0.016666666666667, 0.33333333333333
38223, 0.21739130434783, -0.033333333333333, 0.33333333333333
38224, 0.21739130434783, -0.016666666666667, 0.30555555555556
38225, 0.23913043478261, -0.016666666666667, 0.33333333333333
38226, 0.26086956521739, -0.033333333333333, 0.33333333333333
38227, 0.26086956521739, -0.016666666666667, 0.30555555555556
38228, 0.28260869565217, -0.016666666666667, 0.33333333333333
38229, 0.30434782608696, -0.033333333333333, 0.33333333333333
38230, 0.30434782608696, -0.016666666666667, 0.30555555555556
38231, 0.32608695652174, -0.016666666666667, 0.33333333333333
38232, 0.34782608695652, -0.033333333333333, 0.33333333333333
38233, 0.34782608695652, -0.016666666666667, 0.30555555555556
38234, 0.3695652173913, -0.016666666666667, 0.33333333333333
38235, 0.39130434782609, -0.033333333333333, 0.33333333333333
38236, 0.39130434782609, -0.016666666666667, 0.30555555555556
38237, 0.41304347826087, -0.016666666666667, 0.33333333333333
38238, 0.43478260869565, -0.033333333333333, 0.33333333333333
38239, 0.43478260869565, -0.016666666666667, 0.30555555555556
38240, 0.45652173913043, -0.016666666666667, 0.33333333333333
38241, 0.47826086956522, -0.033333333333333, 0.33333333333333
38242, 0.47826086956522, -0.016666666666667, 0.30555555555556
38243, 0.5, -0.016666666666667, 0.33333333333333
38244, 0.52173913043478, -0.033333333333333, 0.33333333333333
38245, 0.52173913043478, -0.016666666666667, 0.30555555555556
38246, 0.54347826086957, -0.016666666666667, 0.33333333333333
38247, 0.56521739130435, -0.033333333333333, 0.33333333333333
38248, 0.56521739130435, -0.016666666666667, 0.30555555555556
38249, 0.58695652173913, -0.016666666666667, 0.33333333333333
38250, 0.60869565217391, -0.033333333333333, 0.33333333333333
38251, 0.60869565217391, -0.016666666666667, 0.30555555555556
38252, 0.6304347826087, -0.016666666666667, 0.33333333333333
38253, 0.65217391304348, -0.033333333333333, 0.33333333333333
38254, 0.65217391304348, -0.016666666666667, 0.30555555555556
38255, 0.67391304347826, -0.016666666666667, 0.33333333333333
38256, 0.69565217391304, -0.033333333333333, 0.33333333333333
38257, 0.69565217391304, -0.016666666666667, 0.30555555555556
38258, 0.71739130434783, -0.016666666666667, 0.33333333333333
38259, 0.73913043478261, -0.033333333333333, 0.33333333333333
38260, 0.73913043478261, -0.016666666666667, 0.30555555555556
38261, 0.76086956521739, -0.016666666666667, 0.33333333333333
38262, 0.78260869565217, -0.033333333333333, 0.33333333333333
38263, 0.78260869565217, -0.016666666666667, 0.30555555555556
38264, 0.80434782608696, -0.016666666666667, 0.33333333333333
38265, 0.82608695652174, -0.033333333333333, 0.33333333333333
38266, 0.82608695652174, -0.016666666666667, 0.30555555555556
38267, 0.84782608695652, -0.016666666666667, 0.33333333333333
38268, 0.8695652173913, -0.033333333333333, 0.33333333333333
38269, 0.8695652173913, -0.016666666666667, 0.30555555555556
38270, 0.89130434782609, -0.016666666666667, 0.33333333333333
38271, 0.91304347826087, -0.033333333333333, 0.33333333333333
38272, 0.91304347826087, -0.016666666666667, 0.30555555555556
38273, 0.93478260869565, -0.016666666666667, 0.33333333333333
38274, 0.95652173913044, -0.033333333333333, 0.33333333333333
38275, 0.95652173913044, -0.016666666666667, 0.30555555555556
38276, 0.97826086956522, -0.016666666666667, 0.33333333333333
38277, 0.021739130434783, 0.016666666666667, 0.33333333333333
38278, 0.043478260869565, 6.2450045135165e-17, 0.33333333333333
38279, 0.043478260869565, 0.016666666666667, 0.30555555555556
38280, 0.065217391304348, 0.016666666666667, 0.33333333333333
38281, 0.08695652173913, 5.7245874707235e-17, 0.33333333333333
38282, 0.08695652173913, 0.016666666666667, 0.30555555555556
38283, 0.10869565217391, 0.016666666666667, 0.33333333333333
38284, 0.1304347826087, 5.2041704279304e-17, 0.33333333333333
38285, 0.1304347826087, 0.016666666666667, 0.30555555555556
38286, 0.15217391304348, 0.016666666666667, 0.33333333333333
38287, 0.17391304347826, 5.2041704279304e-17, 0.33333333333333
38288, 0.17391304347826, 0.016666666666667, 0.30555555555556
38289, 0.19565217391304, 0.016666666666667, 0.33333333333333
38290, 0.21739130434783, 5.3776427755281e-17, 0.33333333333333
38291, 0.21739130434783, 0.016666666666667, 0.30555555555556
38292, 0.23913043478261, 0.016666666666667, 0.33333333333333
38293, 0.26086956521739, 5.5511151231258e-17, 0.33333333333333
38294, 0.26086956521739, 0.016666666666667, 0.30555555555556
38295, 0.28260869565217, 0.016666666666667, 0.33333333333333
38296, 0.30434782608696, 5.5511151231258e-17, 0.33333333333333
38297, 0.30434782608696, 0.016666666666667, 0.30555555555556
38298, 0.32608695652174, 0.016666666666667, 0.33333333333333
38299, 0.34782608695652, 5.7245874707235e-17, 0.33333333333333
38300, 0.34782608695652, 0.016666666666667, 0.30555555555556
38301, 0.3695652173913, 0.016666666666667, 0.33333333333333
38302, 0.39130434782609, 5.5511151231258e-17, 0.33333333333333
38303, 0.39130434782609, 0.016666666666667, 0.30555555555556
38304, 0.41304347826087, 0.016666666666667, 0.33333333333333
38305, 0.43478260869565, 5.5511151231258e-17, 0.33333333333333
38306, 0.43478260869565, 0.016666666666667, 0.30555555555556
38307, 0.45652173913043, 0.016666666666667, 0.33333333333333
38308, 0.47826086956522, 5.5511151231258e-17, 0.33333333333333
38309, 0.47826086956522, 0.016666666666667, 0.30555555555556
38310, 0.5, 0.016666666666667, 0.33333333333333
38311, 0.52173913043478, 5.5511151231258e-17, 0.33333333333333
38312, 0.52173913043478, 0.016666666666667, 0.30555555555556
38313, 0.54347826086957, 0.016666666666667, 0.33333333333333
38314, 0.56521739130435, 5.5511151231258e-17, 0.33333333333333
38315, 0.56521739130435, 0.016666666666667, 0.30555555555556
38316, 0.58695652173913, 0.016666666666667, 0.33333333333333
38317, 0.60869565217391, 5.5511151231258e-17, 0.33333333333333
38318, 0.60869565217391, 0.016666666666667, 0.30555555555556
38319, 0.6304347826087, 0.016666666666667, 0.33333333333333
38320, 0.65217391304348, 5.5511151231258e-17, 0.33333333333333
38321, 0.65217391304348, 0.016666666666667, 0.30555555555556
38322, 0.67391304347826, 0.016666666666667, 0.33333333333333
38323, 0.69565217391304, 5.5511151231258e-17, 0.33333333333333
38324, 0.69565217391304, 0.016666666666667, 0.30555555555556
38325, 0.71739130434783, 0.016666666666667, 0.33333333333333
38326, 0.73913043478261, 5.5511151231258e-17, 0.33333333333333
38327, 0.73913043478261, 0.016666666666667, 0.30555555555556
38328, 0.76086956521739, 0.016666666666667, 0.33333333333333
38329, 0.78260869565217, 5.5511151231258e-17, 0.33333333333333
38330, 0.78260869565217, 0.016666666666667, 0.30555555555556
38331, 0.80434782608696, 0.016666666666667, 0.33333333333333
38332, 0.82608695652174, 5.3776427755281e-17, 0.33333333333333
38333, 0.82608695652174, 0.016666666666667, 0.30555555555556
38334, 0.84782608695652, 0.016666666666667, 0.33333333333333
38335, 0.8695652173913, 5.5511151231258e-17, 0.33333333333333
38336, 0.8695652173913, 0.016666666666667, 0.30555555555556
38337, 0.89130434782609, 0.016666666666667, 0.33333333333333
38338, 0.91304347826087, 5.7245874707235e-17, 0.33333333333333
38339, 0.91304347826087, 0.016666666666667, 0.30555555555556
38340, 0.93478260869565, 0.016666666666667, 0.33333333333333
38341, 0.95652173913044, 6.0715321659188e-17, 0.33333333333333
38342, 0.95652173913044, 0.016666666666667, 0.30555555555556
38343, 0.97826086956522, 0.016666666666667, 0.33333333333333
38344, 0.043478260869565, 0.033333333333333, 0.33333333333333
38345, 0.08695652173913, 0.033333333333333, 0.33333333333333
38346, 0.1304347826087, 0.033333333333333, 0.33333333333333
38347, 0.17391304347826, 0.033333333333333, 0.33333333333333
38348, 0.21739130434783, 0.033333333333333, 0.33333333333333
38349, 0.26086956521739, 0.033333333333333, 0.33333333333333
38350, 0.30434782608696, 0.033333333333333, 0.33333333333333
38351, 0.34782608695652, 0.033333333333333, 0.33333333333333
38352, 0.39130434782609, 0.033333333333333, 0.33333333333333
38353, 0.43478260869565, 0.033333333333333, 0.33333333333333
38354, 0.47826086956522, 0.033333333333333, 0.33333333333333
38355, 0.52173913043478, 0.033333333333333, 0.33333333333333
38356, 0.56521739130435, 0.033333333333333, 0.33333333333333
38357, 0.60869565217391, 0.033333333333333, 0.33333333333333
38358, 0.65217391304348, 0.033333333333333, 0.33333333333333
38359, 0.69565217391304, 0.033333333333333, 0.33333333333333
38360, 0.73913043478261, 0.033333333333333, 0.33333333333333
38361, 0.78260869565217, 0.033333333333333, 0.33333333333333
38362, 0.82608695652174, 0.033333333333333, 0.33333333333333
38363, 0.8695652173913, 0.033333333333333, 0.33333333333333
38364, 0.91304347826087, 0.033333333333333, 0.33333333333333
38365, 0.95652173913043, 0.033333333333333, 0.33333333333333
38366, 0.021739130434783, -0.016666666666667, 0.38888888888889
38367, 0.043478260869565, -0.033333333333333, 0.38888888888889
38368, 0.043478260869565, -0.016666666666667, 0.36111111111111
38369, 0.065217391304348, -0.016666666666667, 0.38888888888889
38370, 0.08695652173913, -0.033333333333333, 0.38888888888889
38371, 0.08695652173913, -0.016666666666667, 0.36111111111111
38372, 0.10869565217391, -0.016666666666667, 0.38888888888889
38373, 0.1304347826087, -0.033333333333333, 0.38888888888889
38374, 0.1304347826087, -0.016666666666667, 0.36111111111111
38375, 0.15217391304348, -0.016666666666667, 0.38888888888889
38376, 0.17391304347826, -0.033333333333333, 0.38888888888889
38377, 0.17391304347826, -0.016666666666667, 0.36111111111111
38378, 0.19565217391304, -0.016666666666667, 0.38888888888889
38379, 0.21739130434783, -0.033333333333333, 0.38888888888889
38380, 0.21739130434783, -0.016666666666667, 0.36111111111111
38381, 0.23913043478261, -0.016666666666667, 0.38888888888889
38382, 0.26086956521739, -0.033333333333333, 0.38888888888889
38383, 0.26086956521739, -0.016666666666667, 0.36111111111111
38384, 0.28260869565217, -0.016666666666667, 0.38888888888889
38385, 0.30434782608696, -0.033333333333333, 0.38888888888889
38386, 0.30434782608696, -0.016666666666667, 0.36111111111111
38387, 0.32608695652174, -0.016666666666667, 0.38888888888889
38388, 0.34782608695652, -0.033333333333333, 0.38888888888889
38389, 0.34782608695652, -0.016666666666667, 0.36111111111111
38390, 0.3695652173913, -0.016666666666667, 0.38888888888889
38391, 0.39130434782609, -0.033333333333333, 0.38888888888889
38392, 0.39130434782609, -0.016666666666667, 0.36111111111111
38393, 0.41304347826087, -0.016666666666667, 0.38888888888889
38394, 0.43478260869565, -0.033333333333333, 0.38888888888889
38395, 0.43478260869565, -0.016666666666667, 0.36111111111111
38396, 0.45652173913043, -0.016666666666667, 0.38888888888889
38397, 0.47826086956522, -0.033333333333333, 0.38888888888889
38398, 0.47826086956522, -0.016666666666667, 0.36111111111111
38399, 0.5, -0.016666666666667, 0.38888888888889
38400, 0.52173913043478, -0.033333333333333, 0.38888888888889
38401, 0.52173913043478, -0.016666666666667, 0.36111111111111
38402, 0.54347826086957, -0.016666666666667, 0.38888888888889
38403, 0.56521739130435, -0.033333333333333, 0.38888888888889
38404, 0.56521739130435, -0.016666666666667, 0.36111111111111
38405, 0.58695652173913, -0.016666666666667, 0.38888888888889
38406, 0.60869565217391, -0.033333333333333, 0.38888888888889
38407, 0.60869565217391, -0.016666666666667, 0.36111111111111
38408, 0.6304347826087, -0.016666666666667, 0.38888888888889
38409, 0.65217391304348, -0.033333333333333, 0.38888888888889
38410, 0.65217391304348, -0.016666666666667, 0.36111111111111
38411, 0.67391304347826, -0.016666666666667, 0.38888888888889
38412, 0.69565217391304, -0.033333333333333, 0.38888888888889
38413, 0.69565217391304, -0.016666666666667, 0.36111111111111
38414, 0.71739130434783, -0.016666666666667, 0.38888888888889
38415, 0.73913043478261, -0.033333333333333, 0.38888888888889
38416, 0.73913043478261, -0.016666666666667, 0.36111111111111
38417, 0.76086956521739, -0.016666666666667, 0.38888888888889
38418, 0.78260869565217, -0.033333333333333, 0.38888888888889
38419, 0.78260869565217, -0.016666666666667, 0.36111111111111
38420, 0.80434782608696, -0.016666666666667, 0.38888888888889
38421, 0.82608695652174, -0.033333333333333, 0.38888888888889
38422, 0.82608695652174, -0.016666666666667, 0.36111111111111
38423, 0.84782608695652, -0.016666666666667, 0.38888888888889
38424, 0.8695652173913, -0.033333333333333, 0.38888888888889
38425, 0.8695652173913, -0.016666666666667, 0.36111111111111
38426, 0.89130434782609, -0.016666666666667, 0.38888888888889
38427, 0.91304347826087, -0.033333333333333, 0.38888888888889
38428, 0.91304347826087, -0.016666666666667, 0.36111111111111
38429, 0.93478260869565, -0.016666666666667, 0.38888888888889
38430, 0.95652173913044, -0.033333333333333, 0.38888888888889
38431, 0.95652173913044, -0.016666666666667, 0.36111111111111
38432, 0.97826086956522, -0.016666666666667, 0.38888888888889
38433, 0.021739130434783, 0.016666666666667, 0.38888888888889
38434, 0.043478260869565, 6.0715321659188e-17, 0.38888888888889
38435, 0.043478260869565, 0.016666666666667, 0.36111111111111
38436, 0.065217391304348, 0.016666666666667, 0.38888888888889
38437, 0.08695652173913, 5.7245874707235e-17, 0.38888888888889
38438, 0.08695652173913, 0.016666666666667, 0.36111111111111
38439, 0.10869565217391, 0.016666666666667, 0.38888888888889
38440, 0.1304347826087, 5.5511151231258e-17, 0.38888888888889
38441, 0.1304347826087, 0.016666666666667, 0.36111111111111
38442, 0.15217391304348, 0.016666666666667, 0.38888888888889
38443, 0.17391304347826, 5.3776427755281e-17, 0.38888888888889
38444, 0.17391304347826, 0.016666666666667, 0.36111111111111
38445, 0.19565217391304, 0.016666666666667, 0.38888888888889
38446, 0.21739130434783, 5.5511151231258e-17, 0.38888888888889
38447, 0.21739130434783, 0.016666666666667, 0.36111111111111
38448, 0.23913043478261, 0.016666666666667, 0.38888888888889
38449, 0.26086956521739, 5.8980598183211e-17, 0.38888888888889
38450, 0.26086956521739, 0.016666666666667, 0.36111111111111
38451, 0.28260869565217, 0.016666666666667, 0.38888888888889
38452, 0.30434782608696, 5.7245874707235e-17, 0.38888888888889
38453, 0.30434782608696, 0.016666666666667, 0.36111111111111
38454, 0.32608695652174, 0.016666666666667, 0.38888888888889
38455, 0.34782608695652, 5.8980598183211e-17, 0.38888888888889
38456, 0.34782608695652, 0.016666666666667, 0.36111111111111
38457, 0.3695652173913, 0.016666666666667, 0.38888888888889
38458, 0.39130434782609, 5.8980598183211e-17, 0.38888888888889
38459, 0.39130434782609, 0.016666666666667, 0.36111111111111
38460, 0.41304347826087, 0.016666666666667, 0.38888888888889
38461, 0.43478260869565, 5.2041704279304e-17, 0.38888888888889
38462, 0.43478260869565, 0.016666666666667, 0.36111111111111
38463, 0.45652173913043, 0.016666666666667, 0.38888888888889
38464, 0.47826086956522, 5.3776427755281e-17, 0.38888888888889
38465, 0.47826086956522, 0.016666666666667, 0.36111111111111
38466, 0.5, 0.016666666666667, 0.38888888888889
38467, 0.52173913043478, 5.2041704279304e-17, 0.38888888888889
38468, 0.52173913043478, 0.016666666666667, 0.36111111111111
38469, 0.54347826086957, 0.016666666666667, 0.38888888888889
38470, 0.56521739130435, 5.3776427755281e-17, 0.38888888888889
38471, 0.56521739130435, 0.016666666666667, 0.36111111111111
38472, 0.58695652173913, 0.016666666666667, 0.38888888888889
38473, 0.60869565217391, 5.5511151231258e-17, 0.38888888888889
38474, 0.60869565217391, 0.016666666666667, 0.36111111111111
38475, 0.6304347826087, 0.016666666666667, 0.38888888888889
38476, 0.65217391304348, 5.3776427755281e-17, 0.38888888888889
38477, 0.65217391304348, 0.016666666666667, 0.36111111111111
38478, 0.67391304347826, 0.016666666666667, 0.38888888888889
38479, 0.69565217391304, 5.5511151231258e-17, 0.38888888888889
38480, 0.69565217391304, 0.016666666666667, 0.36111111111111
38481, 0.71739130434783, 0.016666666666667, 0.38888888888889
38482, 0.73913043478261, 5.3776427755281e-17, 0.38888888888889
38483, 0.73913043478261, 0.016666666666667, 0.36111111111111
38484, 0.76086956521739, 0.016666666666667, 0.38888888888889
38485, 0.78260869565217, 5.5511151231258e-17, 0.38888888888889
38486, 0.78260869565217, 0.016666666666667, 0.36111111111111
38487, 0.80434782608696, 0.016666666666667, 0.38888888888889
38488, 0.82608695652174, 5.7245874707235e-17, 0.38888888888889
38489, 0.82608695652174, 0.016666666666667, 0.36111111111111
38490, 0.84782608695652, 0.016666666666667, 0.38888888888889
38491, 0.8695652173913, 5.3776427755281e-17, 0.38888888888889
38492, 0.8695652173913, 0.016666666666667, 0.36111111111111
38493, 0.89130434782609, 0.016666666666667, 0.38888888888889
38494, 0.91304347826087, 5.7245874707235e-17, 0.38888888888889
38495, 0.91304347826087, 0.016666666666667, 0.36111111111111
38496, 0.93478260869565, 0.016666666666667, 0.38888888888889
38497, 0.95652173913044, 6.0715321659188e-17, 0.38888888888889
38498, 0.95652173913044, 0.016666666666667, 0.36111111111111
38499, 0.97826086956522, 0.016666666666667, 0.38888888888889
38500, 0.043478260869565, 0.033333333333333, 0.38888888888889
38501, 0.08695652173913, 0.033333333333333, 0.38888888888889
38502, 0.1304347826087, 0.033333333333333, 0.38888888888889
38503, 0.17391304347826, 0.033333333333333, 0.38888888888889
38504, 0.21739130434783, 0.033333333333333, 0.38888888888889
38505, 0.26086956521739, 0.033333333333333, 0.38888888888889
38506, 0.30434782608696, 0.033333333333333, 0.38888888888889
38507, 0.34782608695652, 0.033333333333333, 0.38888888888889
38508, 0.39130434782609, 0.033333333333333, 0.38888888888889
38509, 0.43478260869565, 0.033333333333333, 0.38888888888889
38510, 0.47826086956522, 0.033333333333333, 0.38888888888889
38511, 0.52173913043478, 0.033333333333333, 0.38888888888889
38512, 0.56521739130435, 0.033333333333333, 0.38888888888889
38513, 0.60869565217391, 0.033333333333333, 0.38888888888889
38514, 0.65217391304348, 0.033333333333333, 0.38888888888889
38515, 0.69565217391304, 0.033333333333333, 0.38888888888889
38516, 0.73913043478261, 0.033333333333333, 0.38888888888889
38517, 0.78260869565217, 0.033333333333333, 0.38888888888889
38518, 0.82608695652174, 0.033333333333333, 0.38888888888889
38519, 0.8695652173913, 0.033333333333333, 0.38888888888889
38520, 0.91304347826087, 0.033333333333333, 0.38888888888889
38521, 0.95652173913043, 0.033333333333333, 0.38888888888889
38522, 0.021739130434783, -0.016666666666667, 0.44444444444444
38523, 0.043478260869565, -0.033333333333333, 0.44444444444444
38524, 0.043478260869565, -0.016666666666667, 0.41666666666667
38525, 0.065217391304348, -0.016666666666667, 0.44444444444444
38526, 0.08695652173913, -0.033333333333333, 0.44444444444444
38527, 0.08695652173913, -0.016666666666667, 0.41666666666667
38528, 0.10869565217391, -0.016666666666667, 0.44444444444444
38529, 0.1304347826087, -0.033333333333333, 0.44444444444444
38530, 0.1304347826087, -0.016666666666667, 0.41666666666667
38531, 0.15217391304348, -0.016666666666667, 0.44444444444444
38532, 0.17391304347826, -0.033333333333333, 0.44444444444444
38533, 0.17391304347826, -0.016666666666667, 0.41666666666667
38534, 0.19565217391304, -0.016666666666667, 0.44444444444444
38535, 0.21739130434783, -0.033333333333333, 0.44444444444444
38536, 0.21739130434783, -0.016666666666667, 0.41666666666667
38537, 0.23913043478261, -0.016666666666667, 0.44444444444444
38538, 0.26086956521739, -0.033333333333333, 0.44444444444444
38539, 0.26086956521739, -0.016666666666667, 0.41666666666667
38540, 0.28260869565217, -0.016666666666667, 0.44444444444444
38541, 0.30434782608696, -0.033333333333333, 0.44444444444444
38542, 0.30434782608696, -0.016666666666667, 0.41666666666667
38543, 0.32608695652174, -0.016666666666667, 0.44444444444444
38544, 0.34782608695652, -0.033333333333333, 0.44444444444444
38545, 0.34782608695652, -0.016666666666667, 0.41666666666667
38546, 0.3695652173913, -0.016666666666667, 0.44444444444444
38547, 0.39130434782609, -0.033333333333333, 0.44444444444444
38548, 0.39130434782609, -0.016666666666667, 0.41666666666667
38549, 0.41304347826087, -0.016666666666667, 0.44444444444444
38550, 0.43478260869565, -0.033333333333333, 0.44444444444444
38551, 0.43478260869565, -0.016666666666667, 0.41666666666667
38552, 0.45652173913043, -0.016666666666667, 0.44444444444444
38553, 0.47826086956522, -0.033333333333333, 0.44444444444444
38554, 0.47826086956522, -0.016666666666667, 0.41666666666667
38555, 0.5, -0.016666666666667, 0.44444444444444
38556, 0.52173913043478, -0.033333333333333, 0.44444444444444
38557, 0.52173913043478, -0.016666666666667, 0.41666666666667
38558, 0.54347826086957, -0.016666666666667, 0.44444444444444
38559, 0.56521739130435, -0.033333333333333, 0.44444444444444
38560, 0.56521739130435, -0.016666666666667, 0.41666666666667
38561, 0.58695652173913, -0.016666666666667, 0.44444444444444
38562, 0.60869565217391, -0.033333333333333, 0.44444444444444
38563, 0.60869565217391, -0.016666666666667, 0.41666666666667
38564, 0.6304347826087, -0.016666666666667, 0.44444444444444
38565, 0.65217391304348, -0.033333333333333, 0.44444444444444
38566, 0.65217391304348, -0.016666666666667, 0.41666666666667
38567, 0.67391304347826, -0.016666666666667, 0.44444444444444
38568, 0.69565217391304, -0.033333333333333, 0.44444444444444
38569, 0.69565217391304, -0.016666666666667, 0.41666666666667
38570, 0.71739130434783, -0.016666666666667, 0.44444444444444
38571, 0.73913043478261, -0.033333333333333, 0.44444444444444
38572, 0.73913043478261, -0.016666666666667, 0.41666666666667
38573, 0.76086956521739, -0.016666666666667, 0.44444444444444
38574, 0.78260869565217, -0.033333333333333, 0.44444444444444
38575, 0.78260869565217, -0.016666666666667, 0.41666666666667
38576, 0.80434782608696, -0.016666666666667, 0.44444444444444
38577, 0.82608695652174, -0.033333333333333, 0.44444444444444
38578, 0.82608695652174, -0.016666666666667, 0.41666666666667
38579, 0.84782608695652, -0.016666666666667, 0.44444444444444
38580, 0.8695652173913, -0.033333333333333, 0.44444444444444
38581, 0.8695652173913, -0.016666666666667, 0.41666666666667
38582, 0.89130434782609, -0.016666666666667, 0.44444444444444
38583, 0.91304347826087, -0.033333333333333, 0.44444444444444
38584, 0.91304347826087, -0.016666666666667, 0.41666666666667
38585, 0.93478260869565, -0.016666666666667, 0.44444444444444
38586, 0.95652173913044, -0.033333333333333, 0.44444444444444
38587, 0.95652173913044, -0.016666666666667, 0.41666666666667
38588, 0.97826086956522, -0.016666666666667, 0.44444444444444
38589, 0.021739130434783, 0.016666666666667, 0.44444444444444
38590, 0.043478260869565, 5.8980598183211e-17, 0.44444444444444
38591, 0.043478260869565, 0.016666666666667, 0.41666666666667
38592, 0.065217391304348, 0.016666666666667, 0.44444444444444
38593, 0.08695652173913, 6.4184768611142e-17, 0.44444444444444
38594, 0.08695652173913, 0.016666666666667, 0.41666666666667
38595, 0.10869565217391, 0.016666666666667, 0.44444444444444
38596, 0.1304347826087, 5.8980598183211e-17, 0.44444444444444
38597, 0.1304347826087, 0.016666666666667, 0.41666666666667
38598, 0.15217391304348, 0.016666666666667, 0.44444444444444
38599, 0.17391304347826, 6.2450045135165e-17, 0.44444444444444
38600, 0.17391304347826, 0.016666666666667, 0.41666666666667
38601, 0.19565217391304, 0.016666666666667, 0.44444444444444
38602, 0.21739130434783, 5.3776427755281e-17, 0.44444444444444
38603, 0.21739130434783, 0.016666666666667, 0.41666666666667
38604, 0.23913043478261, 0.016666666666667, 0.44444444444444
38605, 0.26086956521739, 5.7245874707235e-17, 0.44444444444444
38606, 0.26086956521739, 0.016666666666667, 0.41666666666667
38607, 0.28260869565217, 0.016666666666667, 0.44444444444444
38608, 0.30434782608696, 6.2450045135165e-17, 0.44444444444444
38609, 0.30434782608696, 0.016666666666667, 0.41666666666667
38610, 0.32608695652174, 0.016666666666667, 0.44444444444444
38611, 0.34782608695652, 6.2450045135165e-17, 0.44444444444444
38612, 0.34782608695652, 0.016666666666667, 0.41666666666667
38613, 0.3695652173913, 0.016666666666667, 0.44444444444444
38614, 0.39130434782609, 5.7245874707235e-17, 0.44444444444444
38615, 0.39130434782609, 0.016666666666667, 0.41666666666667
38616, 0.41304347826087, 0.016666666666667, 0.44444444444444
38617, 0.43478260869565, 5.8980598183211e-17, 0.44444444444444
38618, 0.43478260869565, 0.016666666666667, 0.41666666666667
38619, 0.45652173913043, 0.016666666666667, 0.44444444444444
38620, 0.47826086956522, 6.2450045135165e-17, 0.44444444444444
38621, 0.47826086956522, 0.016666666666667, 0.41666666666667
38622, 0.5, 0.016666666666667, 0.44444444444444
38623, 0.52173913043478, 6.2450045135165e-17, 0.44444444444444
38624, 0.52173913043478, 0.016666666666667, 0.41666666666667
38625, 0.54347826086957, 0.016666666666667, 0.44444444444444
38626, 0.56521739130435, 6.0715321659188e-17, 0.44444444444444
38627, 0.56521739130435, 0.016666666666667, 0.41666666666667
38628, 0.58695652173913, 0.016666666666667, 0.44444444444444
38629, 0.60869565217391, 5.7245874707235e-17, 0.44444444444444
38630, 0.60869565217391, 0.016666666666667, 0.41666666666667
38631, 0.6304347826087, 0.016666666666667, 0.44444444444444
38632, 0.65217391304348, 6.0715321659188e-17, 0.44444444444444
38633, 0.65217391304348, 0.016666666666667, 0.41666666666667
38634, 0.67391304347826, 0.016666666666667, 0.44444444444444
38635, 0.69565217391304, 6.2450045135165e-17, 0.44444444444444
38636, 0.69565217391304, 0.016666666666667, 0.41666666666667
38637, 0.71739130434783, 0.016666666666667, 0.44444444444444
38638, 0.73913043478261, 6.2450045135165e-17, 0.44444444444444
38639, 0.73913043478261, 0.016666666666667, 0.41666666666667
38640, 0.76086956521739, 0.016666666666667, 0.44444444444444
38641, 0.78260869565217, 6.4184768611142e-17, 0.44444444444444
38642, 0.78260869565217, 0.016666666666667, 0.41666666666667
38643, 0.80434782608696, 0.016666666666667, 0.44444444444444
38644, 0.82608695652174, 6.2450045135165e-17, 0.44444444444444
38645, 0.82608695652174, 0.016666666666667, 0.41666666666667
38646, 0.84782608695652, 0.016666666666667, 0.44444444444444
38647, 0.8695652173913, 5.3776427755281e-17, 0.44444444444444
38648, 0.8695652173913, 0.016666666666667, 0.41666666666667
38649, 0.89130434782609, 0.016666666666667, 0.44444444444444
38650, 0.91304347826087, 6.0715321659188e-17, 0.44444444444444
38651, 0.91304347826087, 0.016666666666667, 0.41666666666667
38652, 0.93478260869565, 0.016666666666667, 0.44444444444444
38653, 0.95652173913044, 6.2450045135165e-17, 0.44444444444444
38654, 0.95652173913044, 0.016666666666667, 0.41666666666667
38655, 0.97826086956522, 0.016666666666667, 0.44444444444444
38656, 0.043478260869565, 0.033333333333333, 0.44444444444444
38657, 0.08695652173913, 0.033333333333333, 0.44444444444444
38658, 0.1304347826087, 0.033333333333333, 0.44444444444444
38659, 0.17391304347826, 0.033333333333333, 0.44444444444444
38660, 0.21739130434783, 0.033333333333333, 0.44444444444444
38661, 0.26086956521739, 0.033333333333333, 0.44444444444444
38662, 0.30434782608696, 0.033333333333333, 0.44444444444444
38663, 0.34782608695652, 0.033333333333333, 0.44444444444444
38664, 0.39130434782609, 0.033333333333333, 0.44444444444444
38665, 0.43478260869565, 0.033333333333333, 0.44444444444444
38666, 0.47826086956522, 0.033333333333333, 0.44444444444444
38667, 0.52173913043478, 0.033333333333333, 0.44444444444444
38668, 0.56521739130435, 0.033333333333333, 0.44444444444444
38669, 0.60869565217391, 0.033333333333333, 0.44444444444444
38670, 0.65217391304348, 0.033333333333333, 0.44444444444444
38671, 0.69565217391304, 0.033333333333333, 0.44444444444444
38672, 0.73913043478261, 0.033333333333333, 0.44444444444444
38673, 0.78260869565217, 0.033333333333333, 0.44444444444444
38674, 0.82608695652174, 0.033333333333333, 0.44444444444444
38675, 0.8695652173913, 0.033333333333333, 0.44444444444444
38676, 0.91304347826087, 0.033333333333333, 0.44444444444444
38677, 0.95652173913043, 0.033333333333333, 0.44444444444444
38678, 0.043478260869565, -0.016666666666667, 0.47222222222222
38679, 0.08695652173913, -0.016666666666667, 0.47222222222222
38680, 0.1304347826087, -0.016666666666667, 0.47222222222222
38681, 0.17391304347826, -0.016666666666667, 0.47222222222222
38682, 0.21739130434783, -0.016666666666667, 0.47222222222222
38683, 0.26086956521739, -0.016666666666667, 0.47222222222222
38684, 0.30434782608696, -0.016666666666667, 0.47222222222222
38685, 0.34782608695652, -0.016666666666667, 0.47222222222222
38686, 0.39130434782609, -0.016666666666667, 0.47222222222222
38687, 0.43478260869565, -0.016666666666667, 0.47222222222222
38688, 0.47826086956522, -0.016666666666667, 0.47222222222222
38689, 0.52173913043478, -0.016666666666667, 0.47222222222222
38690, 0.56521739130435, -0.016666666666667, 0.47222222222222
38691, 0.60869565217391, -0.016666666666667, 0.47222222222222
38692, 0.65217391304348, -0.016666666666667, 0.47222222222222
38693, 0.69565217391304, -0.016666666666667, 0.47222222222222
38694, 0.73913043478261, -0.016666666666667, 0.47222222222222
38695, 0.78260869565217, -0.016666666666667, 0.47222222222222
38696, 0.82608695652174, -0.016666666666667, 0.47222222222222
38697, 0.8695652173913, -0.016666666666667, 0.47222222222222
38698, 0.91304347826087, -0.016666666666667, 0.47222222222222
38699, 0.95652173913044, -0.016666666666667, 0.47222222222222
38700, 0.043478260869565, 0.016666666666667, 0.47222222222222
38701, 0.08695652173913, 0.016666666666667, 0.47222222222222
38702, 0.1304347826087, 0.016666666666667, 0.47222222222222
38703, 0.17391304347826, 0.016666666666667, 0.47222222222222
38704, 0.21739130434783, 0.016666666666667, 0.47222222222222
38705, 0.26086956521739, 0.016666666666667, 0.47222222222222
38706, 0.30434782608696, 0.016666666666667, 0.47222222222222
38707, 0.34782608695652, 0.016666666666667, 0.47222222222222
38708, 0.39130434782609, 0.016666666666667, 0.47222222222222
38709, 0.43478260869565, 0.016666666666667, 0.47222222222222
38710, 0.47826086956522, 0.016666666666667, 0.47222222222222
38711, 0.52173913043478, 0.016666666666667, 0.47222222222222
38712, 0.56521739130435, 0.016666666666667, 0.47222222222222
38713, 0.60869565217391, 0.016666666666667, 0.47222222222222
38714, 0.65217391304348, 0.016666666666667, 0.47222222222222
38715, 0.69565217391304, 0.016666666666667, 0.47222222222222
38716, 0.73913043478261, 0.016666666666667, 0.47222222222222
38717, 0.78260869565217, 0.016666666666667, 0.47222222222222
38718, 0.82608695652174, 0.016666666666667, 0.47222222222222
38719, 0.8695652173913, 0.016666666666667, 0.47222222222222
38720, 0.91304347826087, 0.016666666666667, 0.47222222222222
38721, 0.95652173913043, 0.016666666666667, 0.47222222222222
38722, 0.95652173913043, 0.125, 0.055555555555556
38723, 0.95652173913044, 0.125, 0.11111111111111
38724, 0.95652173913044, 0.125, 0.16666666666667
38725, 0.95652173913044, 0.125, 0.22222222222222
38726, 0.95652173913044, 0.125, 0.27777777777778
38727, 0.95652173913044, 0.125, 0.33333333333333
38728, 0.95652173913044, 0.125, 0.38888888888889
38729, 0.95652173913044, 0.125, 0.44444444444444
38730, 0.91304347826087, 0.125, 0.055555555555556
38731, 0.91304347826087, 0.125, 0.11111111111111
38732, 0.91304347826087, 0.125, 0.16666666666667
38733, 0.91304347826087, 0.125, 0.22222222222222
38734, 0.91304347826087, 0.125, 0.27777777777778
38735, 0.91304347826087, 0.125, 0.33333333333333
38736, 0.91304347826087, 0.125, 0.38888888888889
38737, 0.91304347826087, 0.125, 0.44444444444444
38738, 0.8695652173913, 0.125, 0.055555555555556
38739, 0.8695652173913, 0.125, 0.11111111111111
38740, 0.8695652173913, 0.125, 0.16666666666667
38741, 0.8695652173913, 0.125, 0.22222222222222
38742, 0.8695652173913, 0.125, 0.27777777777778
38743, 0.8695652173913, 0.125, 0.33333333333333
38744, 0.8695652173913, 0.125, 0.38888888888889
38745, 0.8695652173913, 0.125, 0.44444444444444
38746, 0.82608695652174, 0.125, 0.055555555555556
38747, 0.82608695652174, 0.125, 0.11111111111111
38748, 0.82608695652174, 0.125, 0.16666666666667
38749, 0.82608695652174, 0.125, 0.22222222222222
38750, 0.82608695652174, 0.125, 0.27777777777778
38751, 0.82608695652174, 0.125, 0.33333333333333
38752, 0.82608695652174, 0.125, 0.38888888888889
38753, 0.82608695652174, 0.125, 0.44444444444444
38754, 0.78260869565217, 0.125, 0.055555555555556
38755, 0.78260869565217, 0.125, 0.11111111111111
38756, 0.78260869565217, 0.125, 0.16666666666667
38757, 0.78260869565217, 0.125, 0.22222222222222
38758, 0.78260869565217, 0.125, 0.27777777777778
38759, 0.78260869565217, 0.125, 0.33333333333333
38760, 0.78260869565217, 0.125, 0.38888888888889
38761, 0.78260869565217, 0.125, 0.44444444444444
38762, 0.73913043478261, 0.125, 0.055555555555556
38763, 0.73913043478261, 0.125, 0.11111111111111
38764, 0.73913043478261, 0.125, 0.16666666666667
38765, 0.73913043478261, 0.125, 0.22222222222222
38766, 0.73913043478261, 0.125, 0.27777777777778
38767, 0.73913043478261, 0.125, 0.33333333333333
38768, 0.73913043478261, 0.125, 0.38888888888889
38769, 0.73913043478261, 0.125, 0.44444444444444
38770, 0.69565217391304, 0.125, 0.055555555555556
38771, 0.69565217391304, 0.125, 0.11111111111111
38772, 0.69565217391304, 0.125, 0.16666666666667
38773, 0.69565217391304, 0.125, 0.22222222222222
38774, 0.69565217391304, 0.125, 0.27777777777778
38775, 0.69565217391304, 0.125, 0.33333333333333
38776, 0.69565217391304, 0.125, 0.38888888888889
38777, 0.69565217391304, 0.125, 0.44444444444444
38778, 0.65217391304348, 0.125, 0.055555555555556
38779, 0.65217391304348, 0.125, 0.11111111111111
38780, 0.65217391304348, 0.125, 0.16666666666667
38781, 0.65217391304348, 0.125, 0.22222222222222
38782, 0.65217391304348, 0.125, 0.27777777777778
38783, 0.65217391304348, 0.125, 0.33333333333333
38784, 0.65217391304348, 0.125, 0.38888888888889
38785, 0.65217391304348, 0.125, 0.44444444444444
38786, 0.60869565217391, 0.125, 0.055555555555556
38787, 0.60869565217391, 0.125, 0.11111111111111
38788, 0.60869565217391, 0.125, 0.16666666666667
38789, 0.60869565217391, 0.125, 0.22222222222222
38790, 0.60869565217391, 0.125, 0.27777777777778
38791, 0.60869565217391, 0.125, 0.33333333333333
38792, 0.60869565217391, 0.125, 0.38888888888889
38793, 0.60869565217391, 0.125, 0.44444444444444
38794, 0.56521739130435, 0.125, 0.055555555555556
38795, 0.56521739130435, 0.125, 0.11111111111111
38796, 0.56521739130435, 0.125, 0.16666666666667
38797, 0.56521739130435, 0.125, 0.22222222222222
38798, 0.56521739130435, 0.125, 0.27777777777778
38799, 0.56521739130435, 0.125, 0.33333333333333
38800, 0.56521739130435, 0.125, 0.38888888888889
38801, 0.56521739130435, 0.125, 0.44444444444444
38802, 0.52173913043478, 0.125, 0.055555555555556
38803, 0.52173913043478, 0.125, 0.11111111111111
38804, 0.52173913043478, 0.125, 0.16666666666667
38805, 0.52173913043478, 0.125, 0.22222222222222
38806, 0.52173913043478, 0.125, 0.27777777777778
38807, 0.52173913043478, 0.125, 0.33333333333333
38808, 0.52173913043478, 0.125, 0.38888888888889
38809, 0.52173913043478, 0.125, 0.44444444444444
38810, 0.47826086956522, 0.125, 0.055555555555556
38811, 0.47826086956522, 0.125, 0.11111111111111
38812, 0.47826086956522, 0.125, 0.16666666666667
38813, 0.47826086956522, 0.125, 0.22222222222222
38814, 0.47826086956522, 0.125, 0.27777777777778
38815, 0.47826086956522, 0.125, 0.33333333333333
38816, 0.47826086956522, 0.125, 0.38888888888889
38817, 0.47826086956522, 0.125, 0.44444444444444
38818, 0.43478260869565, 0.125, 0.055555555555556
38819, 0.43478260869565, 0.125, 0.11111111111111
38820, 0.43478260869565, 0.125, 0.16666666666667
38821, 0.43478260869565, 0.125, 0.22222222222222
38822, 0.43478260869565, 0.125, 0.27777777777778
38823, 0.43478260869565, 0.125, 0.33333333333333
38824, 0.43478260869565, 0.125, 0.38888888888889
38825, 0.43478260869565, 0.125, 0.44444444444444
38826, 0.39130434782609, 0.125, 0.055555555555556
38827, 0.39130434782609, 0.125, 0.11111111111111
38828, 0.39130434782609, 0.125, 0.16666666666667
38829, 0.39130434782609, 0.125, 0.22222222222222
38830, 0.39130434782609, 0.125, 0.27777777777778
38831, 0.39130434782609, 0.125, 0.33333333333333
38832, 0.39130434782609, 0.125, 0.38888888888889
38833, 0.39130434782609, 0.125, 0.44444444444444
38834, 0.34782608695652, 0.125, 0.055555555555556
38835, 0.34782608695652, 0.125, 0.11111111111111
38836, 0.34782608695652, 0.125, 0.16666666666667
38837, 0.34782608695652, 0.125, 0.22222222222222
38838, 0.34782608695652, 0.125, 0.27777777777778
38839, 0.34782608695652, 0.125, 0.33333333333333
38840, 0.34782608695652, 0.125, 0.38888888888889
38841, 0.34782608695652, 0.125, 0.44444444444444
38842, 0.30434782608696, 0.125, 0.055555555555556
38843, 0.30434782608696, 0.125, 0.11111111111111
38844, 0.30434782608696, 0.125, 0.16666666666667
38845, 0.30434782608696, 0.125, 0.22222222222222
38846, 0.30434782608696, 0.125, 0.27777777777778
38847, 0.30434782608696, 0.125, 0.33333333333333
38848, 0.30434782608696, 0.125, 0.38888888888889
38849, 0.30434782608696, 0.125, 0.44444444444444
38850, 0.26086956521739, 0.125, 0.055555555555556
38851, 0.26086956521739, 0.125, 0.11111111111111
38852, 0.26086956521739, 0.125, 0.16666666666667
38853, 0.26086956521739, 0.125, 0.22222222222222
38854, 0.26086956521739, 0.125, 0.27777777777778
38855, 0.26086956521739, 0.125, 0.33333333333333
38856, 0.26086956521739, 0.125, 0.38888888888889
38857, 0.26086956521739, 0.125, 0.44444444444444
38858, 0.21739130434783, 0.125, 0.055555555555556
38859, 0.21739130434783, 0.125, 0.11111111111111
38860, 0.21739130434783, 0.125, 0.16666666666667
38861, 0.21739130434783, 0.125, 0.22222222222222
38862, 0.21739130434783, 0.125, 0.27777777777778
38863, 0.21739130434783, 0.125, 0.33333333333333
38864, 0.21739130434783, 0.125, 0.38888888888889
38865, 0.21739130434783, 0.125, 0.44444444444444
38866, 0.17391304347826, 0.125, 0.055555555555556
38867, 0.17391304347826, 0.125, 0.11111111111111
38868, 0.17391304347826, 0.125, 0.16666666666667
38869, 0.17391304347826, 0.125, 0.22222222222222
38870, 0.17391304347826, 0.125, 0.27777777777778
38871, 0.17391304347826, 0.125, 0.33333333333333
38872, 0.17391304347826, 0.125, 0.38888888888889
38873, 0.17391304347826, 0.125, 0.44444444444444
38874, 0.1304347826087, 0.125, 0.055555555555556
38875, 0.1304347826087, 0.125, 0.11111111111111
38876, 0.1304347826087, 0.125, 0.16666666666667
38877, 0.1304347826087, 0.125, 0.22222222222222
38878, 0.1304347826087, 0.125, 0.27777777777778
38879, 0.1304347826087, 0.125, 0.33333333333333
38880, 0.1304347826087, 0.125, 0.38888888888889
38881, 0.1304347826087, 0.125, 0.44444444444444
38882, 0.08695652173913, 0.125, 0.055555555555556
38883, 0.08695652173913, 0.125, 0.11111111111111
38884, 0.08695652173913, 0.125, 0.16666666666667
38885, 0.08695652173913, 0.125, 0.22222222222222
38886, 0.08695652173913, 0.125, 0.27777777777778
38887, 0.08695652173913, 0.125, 0.33333333333333
38888, 0.08695652173913, 0.125, 0.38888888888889
38889, 0.08695652173913, 0.125, 0.44444444444444
38890, 0.043478260869565, 0.125, 0.055555555555556
38891, 0.043478260869565, 0.125, 0.11111111111111
38892, 0.043478260869565, 0.125, 0.16666666666667
38893, 0.043478260869565, 0.125, 0.22222222222222
38894, 0.043478260869565, 0.125, 0.27777777777778
38895, 0.043478260869565, 0.125, 0.33333333333333
38896, 0.043478260869565, 0.125, 0.38888888888889
38897, 0.043478260869565, 0.125, 0.44444444444444
38898, 0.95652173913043, 0.125, 0.027777777777778
38899, 0.97826086956522, 0.125, 0.055555555555556
38900, 0.95652173913043, 0.1125, 0.055555555555556
38901, 0.95652173913043, 0.125, 0.083333333333333
38902, 0.97826086956522, 0.125, 0.11111111111111
38903, 0.95652173913044, 0.1125, 0.11111111111111
38904, 0.95652173913044, 0.125, 0.13888888888889
38905, 0.97826086956522, 0.125, 0.16666666666667
38906, 0.95652173913044, 0.1125, 0.16666666666667
38907, 0.95652173913044, 0.125, 0.19444444444444
38908, 0.97826086956522, 0.125, 0.22222222222222
38909, 0.95652173913043, 0.1125, 0.22222222222222
38910, 0.95652173913044, 0.125, 0.25
38911, 0.97826086956522, 0.125, 0.27777777777778
38912, 0.95652173913043, 0.1125, 0.27777777777778
38913, 0.95652173913044, 0.125, 0.30555555555556
38914, 0.97826086956522, 0.125, 0.33333333333333
38915, 0.95652173913043, 0.1125, 0.33333333333333
38916, 0.95652173913044, 0.125, 0.36111111111111
38917, 0.97826086956522, 0.125, 0.38888888888889
38918, 0.95652173913043, 0.1125, 0.38888888888889
38919, 0.95652173913044, 0.125, 0.41666666666667
38920, 0.97826086956522, 0.125, 0.44444444444444
38921, 0.95652173913043, 0.1125, 0.44444444444444
38922, 0.95652173913043, 0.125, 0.47222222222222
38923, 0.91304347826087, 0.125, 0.027777777777778
38924, 0.93478260869565, 0.125, 0.055555555555556
38925, 0.91304347826087, 0.1125, 0.055555555555556
38926, 0.91304347826087, 0.125, 0.083333333333333
38927, 0.93478260869565, 0.125, 0.11111111111111
38928, 0.91304347826087, 0.1125, 0.11111111111111
38929, 0.91304347826087, 0.125, 0.13888888888889
38930, 0.93478260869565, 0.125, 0.16666666666667
38931, 0.91304347826087, 0.1125, 0.16666666666667
38932, 0.91304347826087, 0.125, 0.19444444444444
38933, 0.93478260869565, 0.125, 0.22222222222222
38934, 0.91304347826087, 0.1125, 0.22222222222222
38935, 0.91304347826087, 0.125, 0.25
38936, 0.93478260869565, 0.125, 0.27777777777778
38937, 0.91304347826087, 0.1125, 0.27777777777778
38938, 0.91304347826087, 0.125, 0.30555555555556
38939, 0.93478260869565, 0.125, 0.33333333333333
38940, 0.91304347826087, 0.1125, 0.33333333333333
38941, 0.91304347826087, 0.125, 0.36111111111111
38942, 0.93478260869565, 0.125, 0.38888888888889
38943, 0.91304347826087, 0.1125, 0.38888888888889
38944, 0.91304347826087, 0.125, 0.41666666666667
38945, 0.93478260869565, 0.125, 0.44444444444444
38946, 0.91304347826087, 0.1125, 0.44444444444444
38947, 0.91304347826087, 0.125, 0.47222222222222
38948, 0.8695652173913, 0.125, 0.027777777777778
38949, 0.89130434782609, 0.125, 0.055555555555556
38950, 0.8695652173913, 0.1125, 0.055555555555556
38951, 0.8695652173913, 0.125, 0.083333333333333
38952, 0.89130434782609, 0.125, 0.11111111111111
38953, 0.8695652173913, 0.1125, 0.11111111111111
38954, 0.8695652173913, 0.125, 0.13888888888889
38955, 0.89130434782609, 0.125, 0.16666666666667
38956, 0.8695652173913, 0.1125, 0.16666666666667
38957, 0.8695652173913, 0.125, 0.19444444444444
38958, 0.89130434782609, 0.125, 0.22222222222222
38959, 0.8695652173913, 0.1125, 0.22222222222222
38960, 0.8695652173913, 0.125, 0.25
38961, 0.89130434782609, 0.125, 0.27777777777778
38962, 0.8695652173913, 0.1125, 0.27777777777778
38963, 0.8695652173913, 0.125, 0.30555555555556
38964, 0.89130434782609, 0.125, 0.33333333333333
38965, 0.8695652173913, 0.1125, 0.33333333333333
38966, 0.8695652173913, 0.125, 0.36111111111111
38967, 0.89130434782609, 0.125, 0.38888888888889
38968, 0.8695652173913, 0.1125, 0.38888888888889
38969, 0.8695652173913, 0.125, 0.41666666666667
38970, 0.89130434782609, 0.125, 0.44444444444444
38971, 0.8695652173913, 0.1125, 0.44444444444444
38972, 0.8695652173913, 0.125, 0.47222222222222
38973, 0.82608695652174, 0.125, 0.027777777777778
38974, 0.84782608695652, 0.125, 0.055555555555556
38975, 0.82608695652174, 0.1125, 0.055555555555556
38976, 0.82608695652174, 0.125, 0.083333333333333
38977, 0.84782608695652, 0.125, 0.11111111111111
38978, 0.82608695652174, 0.1125, 0.11111111111111
38979, 0.82608695652174, 0.125, 0.13888888888889
38980, 0.84782608695652, 0.125, 0.16666666666667
38981, 0.82608695652174, 0.1125, 0.16666666666667
38982, 0.82608695652174, 0.125, 0.19444444444444
38983, 0.84782608695652, 0.125, 0.22222222222222
38984, 0.82608695652174, 0.1125, 0.22222222222222
38985, 0.82608695652174, 0.125, 0.25
38986, 0.84782608695652, 0.125, 0.27777777777778
38987, 0.82608695652174, 0.1125, 0.27777777777778
38988, 0.82608695652174, 0.125, 0.30555555555556
38989, 0.84782608695652, 0.125, 0.33333333333333
38990, 0.82608695652174, 0.1125, 0.33333333333333
38991, 0.82608695652174, 0.125, 0.36111111111111
38992, 0.84782608695652, 0.125, 0.38888888888889
38993, 0.82608695652174, 0.1125, 0.38888888888889
38994, 0.82608695652174, 0.125, 0.41666666666667
38995, 0.84782608695652, 0.125, 0.44444444444444
38996, 0.82608695652174, 0.1125, 0.44444444444444
38997, 0.82608695652174, 0.125, 0.47222222222222
38998, 0.78260869565217, 0.125, 0.027777777777778
38999, 0.80434782608696, 0.125, 0.055555555555556
39000, 0.78260869565217, 0.1125, 0.055555555555556
39001, 0.78260869565217, 0.125, 0.083333333333333
39002, 0.80434782608696, 0.125, 0.11111111111111
39003, 0.78260869565217, 0.1125, 0.11111111111111
39004, 0.78260869565217, 0.125, 0.13888888888889
39005, 0.80434782608696, 0.125, 0.16666666666667
39006, 0.78260869565217, 0.1125, 0.16666666666667
39007, 0.78260869565217, 0.125, 0.19444444444444
39008, 0.80434782608696, 0.125, 0.22222222222222
39009, 0.78260869565217, 0.1125, 0.22222222222222
39010, 0.78260869565217, 0.125, 0.25
39011, 0.80434782608696, 0.125, 0.27777777777778
39012, 0.78260869565217, 0.1125, 0.27777777777778
39013, 0.78260869565217, 0.125, 0.30555555555556
39014, 0.80434782608696, 0.125, 0.33333333333333
39015, 0.78260869565217, 0.1125, 0.33333333333333
39016, 0.78260869565217, 0.125, 0.36111111111111
39017, 0.80434782608696, 0.125, 0.38888888888889
39018, 0.78260869565217, 0.1125, 0.38888888888889
39019, 0.78260869565217, 0.125, 0.41666666666667
39020, 0.80434782608696, 0.125, 0.44444444444444
39021, 0.78260869565217, 0.1125, 0.44444444444444
39022, 0.78260869565217, 0.125, 0.47222222222222
39023, 0.73913043478261, 0.125, 0.027777777777778
39024, 0.76086956521739, 0.125, 0.055555555555556
39025, 0.73913043478261, 0.1125, 0.055555555555556
39026, 0.73913043478261, 0.125, 0.083333333333333
39027, 0.76086956521739, 0.125, 0.11111111111111
39028, 0.73913043478261, 0.1125, 0.11111111111111
39029, 0.73913043478261, 0.125, 0.13888888888889
39030, 0.76086956521739, 0.125, 0.16666666666667
39031, 0.73913043478261, 0.1125, 0.16666666666667
39032, 0.73913043478261, 0.125, 0.19444444444444
39033, 0.76086956521739, 0.125, 0.22222222222222
39034, 0.73913043478261, 0.1125, 0.22222222222222
39035, 0.73913043478261, 0.125, 0.25
39036, 0.76086956521739, 0.125, 0.27777777777778
39037, 0.73913043478261, 0.1125, 0.27777777777778
39038, 0.73913043478261, 0.125, 0.30555555555556
39039, 0.76086956521739, 0.125, 0.33333333333333
39040, 0.73913043478261, 0.1125, 0.33333333333333
39041, 0.73913043478261, 0.125, 0.36111111111111
39042, 0.76086956521739, 0.125, 0.38888888888889
39043, 0.73913043478261, 0.1125, 0.38888888888889
39044, 0.73913043478261, 0.125, 0.41666666666667
39045, 0.76086956521739, 0.125, 0.44444444444444
39046, 0.73913043478261, 0.1125, 0.44444444444444
39047, 0.73913043478261, 0.125, 0.47222222222222
39048, 0.69565217391304, 0.125, 0.027777777777778
39049, 0.71739130434783, 0.125, 0.055555555555556
39050, 0.69565217391304, 0.1125, 0.055555555555556
39051, 0.69565217391304, 0.125, 0.083333333333333
39052, 0.71739130434783, 0.125, 0.11111111111111
39053, 0.69565217391304, 0.1125, 0.11111111111111
39054, 0.69565217391304, 0.125, 0.13888888888889
39055, 0.71739130434783, 0.125, 0.16666666666667
39056, 0.69565217391304, 0.1125, 0.16666666666667
39057, 0.69565217391304, 0.125, 0.19444444444444
39058, 0.71739130434783, 0.125, 0.22222222222222
39059, 0.69565217391304, 0.1125, 0.22222222222222
39060, 0.69565217391304, 0.125, 0.25
39061, 0.71739130434783, 0.125, 0.27777777777778
39062, 0.69565217391304, 0.1125, 0.27777777777778
39063, 0.69565217391304, 0.125, 0.30555555555556
39064, 0.71739130434783, 0.125, 0.33333333333333
39065, 0.69565217391304, 0.1125, 0.33333333333333
39066, 0.69565217391304, 0.125, 0.36111111111111
39067, 0.71739130434783, 0.125, 0.38888888888889
39068, 0.69565217391304, 0.1125, 0.38888888888889
39069, 0.69565217391304, 0.125, 0.41666666666667
39070, 0.71739130434783, 0.125, 0.44444444444444
39071, 0.69565217391304, 0.1125, 0.44444444444444
39072, 0.69565217391304, 0.125, 0.47222222222222
39073, 0.65217391304348, 0.125, 0.027777777777778
39074, 0.67391304347826, 0.125, 0.055555555555556
39075, 0.65217391304348, 0.1125, 0.055555555555556
39076, 0.65217391304348, 0.125, 0.083333333333333
39077, 0.67391304347826, 0.125, 0.11111111111111
39078, 0.65217391304348, 0.1125, 0.11111111111111
39079, 0.65217391304348, 0.125, 0.13888888888889
39080, 0.67391304347826, 0.125, 0.16666666666667
39081, 0.65217391304348, 0.1125, 0.16666666666667
39082, 0.65217391304348, 0.125, 0.19444444444444
39083, 0.67391304347826, 0.125, 0.22222222222222
39084, 0.65217391304348, 0.1125, 0.22222222222222
39085, 0.65217391304348, 0.125, 0.25
39086, 0.67391304347826, 0.125, 0.27777777777778
39087, 0.65217391304348, 0.1125, 0.27777777777778
39088, 0.65217391304348, 0.125, 0.30555555555556
39089, 0.67391304347826, 0.125, 0.33333333333333
39090, 0.65217391304348, 0.1125, 0.33333333333333
39091, 0.65217391304348, 0.125, 0.36111111111111
39092, 0.67391304347826, 0.125, 0.38888888888889
39093, 0.65217391304348, 0.1125, 0.38888888888889
39094, 0.65217391304348, 0.125, 0.41666666666667
39095, 0.67391304347826, 0.125, 0.44444444444444
39096, 0.65217391304348, 0.1125, 0.44444444444444
39097, 0.65217391304348, 0.125, 0.47222222222222
39098, 0.60869565217391, 0.125, 0.027777777777778
39099, 0.6304347826087, 0.125, 0.055555555555556
39100, 0.60869565217391, 0.1125, 0.055555555555556
39101, 0.60869565217391, 0.125, 0.083333333333333
39102, 0.6304347826087, 0.125, 0.11111111111111
39103, 0.60869565217391, 0.1125, 0.11111111111111
39104, 0.60869565217391, 0.125, 0.13888888888889
39105, 0.6304347826087, 0.125, 0.16666666666667
39106, 0.60869565217391, 0.1125, 0.16666666666667
39107, 0.60869565217391, 0.125, 0.19444444444444
39108, 0.6304347826087, 0.125, 0.22222222222222
39109, 0.60869565217391, 0.1125, 0.22222222222222
39110, 0.60869565217391, 0.125, 0.25
39111, 0.6304347826087, 0.125, 0.27777777777778
39112, 0.60869565217391, 0.1125, 0.27777777777778
39113, 0.60869565217391, 0.125, 0.30555555555556
39114, 0.6304347826087, 0.125, 0.33333333333333
39115, 0.60869565217391, 0.1125, 0.33333333333333
39116, 0.60869565217391, 0.125, 0.36111111111111
39117, 0.6304347826087, 0.125, 0.38888888888889
39118, 0.60869565217391, 0.1125, 0.38888888888889
39119, 0.60869565217391, 0.125, 0.41666666666667
39120, 0.6304347826087, 0.125, 0.44444444444444
39121, 0.60869565217391, 0.1125, 0.44444444444444
39122, 0.60869565217391, 0.125, 0.47222222222222
39123, 0.56521739130435, 0.125, 0.027777777777778
39124, 0.58695652173913, 0.125, 0.055555555555556
39125, 0.56521739130435, 0.1125, 0.055555555555556
39126, 0.56521739130435, 0.125, 0.083333333333333
39127, 0.58695652173913, 0.125, 0.11111111111111
39128, 0.56521739130435, 0.1125, 0.11111111111111
39129, 0.56521739130435, 0.125, 0.13888888888889
39130, 0.58695652173913, 0.125, 0.16666666666667
39131, 0.56521739130435, 0.1125, 0.16666666666667
39132, 0.56521739130435, 0.125, 0.19444444444444
39133, 0.58695652173913, 0.125, 0.22222222222222
39134, 0.56521739130435, 0.1125, 0.22222222222222
39135, 0.56521739130435, 0.125, 0.25
39136, 0.58695652173913, 0.125, 0.27777777777778
39137, 0.56521739130435, 0.1125, 0.27777777777778
39138, 0.56521739130435, 0.125, 0.30555555555556
39139, 0.58695652173913, 0.125, 0.33333333333333
39140, 0.56521739130435, 0.1125, 0.33333333333333
39141, 0.56521739130435, 0.125, 0.36111111111111
39142, 0.58695652173913, 0.125, 0.38888888888889
39143, 0.56521739130435, 0.1125, 0.38888888888889
39144, 0.56521739130435, 0.125, 0.41666666666667
39145, 0.58695652173913, 0.125, 0.44444444444444
39146, 0.56521739130435, 0.1125, 0.44444444444444
39147, 0.56521739130435, 0.125, 0.47222222222222
39148, 0.52173913043478, 0.125, 0.027777777777778
39149, 0.54347826086957, 0.125, 0.055555555555556
39150, 0.52173913043478, 0.1125, 0.055555555555556
39151, 0.52173913043478, 0.125, 0.083333333333333
39152, 0.54347826086957, 0.125, 0.11111111111111
39153, 0.52173913043478, 0.1125, 0.11111111111111
39154, 0.52173913043478, 0.125, 0.13888888888889
39155, 0.54347826086957, 0.125, 0.16666666666667
39156, 0.52173913043478, 0.1125, 0.16666666666667
39157, 0.52173913043478, 0.125, 0.19444444444444
39158, 0.54347826086956, 0.125, 0.22222222222222
39159, 0.52173913043478, 0.1125, 0.22222222222222
39160, 0.52173913043478, 0.125, 0.25
39161, 0.54347826086956, 0.125, 0.27777777777778
39162, 0.52173913043478, 0.1125, 0.27777777777778
39163, 0.52173913043478, 0.125, 0.30555555555556
39164, 0.54347826086956, 0.125, 0.33333333333333
39165, 0.52173913043478, 0.1125, 0.33333333333333
39166, 0.52173913043478, 0.125, 0.36111111111111
39167, 0.54347826086956, 0.125, 0.38888888888889
39168, 0.52173913043478, 0.1125, 0.38888888888889
39169, 0.52173913043478, 0.125, 0.41666666666667
39170, 0.54347826086956, 0.125, 0.44444444444444
39171, 0.52173913043478, 0.1125, 0.44444444444444
39172, 0.52173913043478, 0.125, 0.47222222222222
39173, 0.47826086956522, 0.125, 0.027777777777778
39174, 0.5, 0.125, 0.055555555555556
39175, 0.47826086956522, 0.1125, 0.055555555555556
39176, 0.47826086956522, 0.125, 0.083333333333333
39177, 0.5, 0.125, 0.11111111111111
39178, 0.47826086956522, 0.1125, 0.11111111111111
39179, 0.47826086956522, 0.125, 0.13888888888889
39180, 0.5, 0.125, 0.16666666666667
39181, 0.47826086956522, 0.1125, 0.16666666666667
39182, 0.47826086956522, 0.125, 0.19444444444444
39183, 0.5, 0.125, 0.22222222222222
39184, 0.47826086956522, 0.1125, 0.22222222222222
39185, 0.47826086956522, 0.125, 0.25
39186, 0.5, 0.125, 0.27777777777778
39187, 0.47826086956522, 0.1125, 0.27777777777778
39188, 0.47826086956522, 0.125, 0.30555555555556
39189, 0.5, 0.125, 0.33333333333333
39190, 0.47826086956522, 0.1125, 0.33333333333333
39191, 0.47826086956522, 0.125, 0.36111111111111
39192, 0.5, 0.125, 0.38888888888889
39193, 0.47826086956522, 0.1125, 0.38888888888889
39194, 0.47826086956522, 0.125, 0.41666666666667
39195, 0.5, 0.125, 0.44444444444444
39196, 0.47826086956522, 0.1125, 0.44444444444444
39197, 0.47826086956522, 0.125, 0.47222222222222
39198, 0.43478260869565, 0.125, 0.027777777777778
39199, 0.45652173913043, 0.125, 0.055555555555556
39200, 0.43478260869565, 0.1125, 0.055555555555556
39201, 0.43478260869565, 0.125, 0.083333333333333
39202, 0.45652173913043, 0.125, 0.11111111111111
39203, 0.43478260869565, 0.1125, 0.11111111111111
39204, 0.43478260869565, 0.125, 0.13888888888889
39205, 0.45652173913043, 0.125, 0.16666666666667
39206, 0.43478260869565, 0.1125, 0.16666666666667
39207, 0.43478260869565, 0.125, 0.19444444444444
39208, 0.45652173913043, 0.125, 0.22222222222222
39209, 0.43478260869565, 0.1125, 0.22222222222222
39210, 0.43478260869565, 0.125, 0.25
39211, 0.45652173913043, 0.125, 0.27777777777778
39212, 0.43478260869565, 0.1125, 0.27777777777778
39213, 0.43478260869565, 0.125, 0.30555555555556
39214, 0.45652173913043, 0.125, 0.33333333333333
39215, 0.43478260869565, 0.1125, 0.33333333333333
39216, 0.43478260869565, 0.125, 0.36111111111111
39217, 0.45652173913043, 0.125, 0.38888888888889
39218, 0.43478260869565, 0.1125, 0.38888888888889
39219, 0.43478260869565, 0.125, 0.41666666666667
39220, 0.45652173913043, 0.125, 0.44444444444444
39221, 0.43478260869565, 0.1125, 0.44444444444444
39222, 0.43478260869565, 0.125, 0.47222222222222
39223, 0.39130434782609, 0.125, 0.027777777777778
39224, 0.41304347826087, 0.125, 0.055555555555556
39225, 0.39130434782609, 0.1125, 0.055555555555556
39226, 0.39130434782609, 0.125, 0.083333333333333
39227, 0.41304347826087, 0.125, 0.11111111111111
39228, 0.39130434782609, 0.1125, 0.11111111111111
39229, 0.39130434782609, 0.125, 0.13888888888889
39230, 0.41304347826087, 0.125, 0.16666666666667
39231, 0.39130434782609, 0.1125, 0.16666666666667
39232, 0.39130434782609, 0.125, 0.19444444444444
39233, 0.41304347826087, 0.125, 0.22222222222222
39234, 0.39130434782609, 0.1125, 0.22222222222222
39235, 0.39130434782609, 0.125, 0.25
39236, 0.41304347826087, 0.125, 0.27777777777778
39237, 0.39130434782609, 0.1125, 0.27777777777778
39238, 0.39130434782609, 0.125, 0.30555555555556
39239, 0.41304347826087, 0.125, 0.33333333333333
39240, 0.39130434782609, 0.1125, 0.33333333333333
39241, 0.39130434782609, 0.125, 0.36111111111111
39242, 0.41304347826087, 0.125, 0.38888888888889
39243, 0.39130434782609, 0.1125, 0.38888888888889
39244, 0.39130434782609, 0.125, 0.41666666666667
39245, 0.41304347826087, 0.125, 0.44444444444444
39246, 0.39130434782609, 0.1125, 0.44444444444444
39247, 0.39130434782609, 0.125, 0.47222222222222
39248, 0.34782608695652, 0.125, 0.027777777777778
39249, 0.3695652173913, 0.125, 0.055555555555556
39250, 0.34782608695652, 0.1125, 0.055555555555556
39251, 0.34782608695652, 0.125, 0.083333333333333
39252, 0.3695652173913, 0.125, 0.11111111111111
39253, 0.34782608695652, 0.1125, 0.11111111111111
39254, 0.34782608695652, 0.125, 0.13888888888889
39255, 0.3695652173913, 0.125, 0.16666666666667
39256, 0.34782608695652, 0.1125, 0.16666666666667
39257, 0.34782608695652, 0.125, 0.19444444444444
39258, 0.3695652173913, 0.125, 0.22222222222222
39259, 0.34782608695652, 0.1125, 0.22222222222222
39260, 0.34782608695652, 0.125, 0.25
39261, 0.3695652173913, 0.125, 0.27777777777778
39262, 0.34782608695652, 0.1125, 0.27777777777778
39263, 0.34782608695652, 0.125, 0.30555555555556
39264, 0.3695652173913, 0.125, 0.33333333333333
39265, 0.34782608695652, 0.1125, 0.33333333333333
39266, 0.34782608695652, 0.125, 0.36111111111111
39267, 0.3695652173913, 0.125, 0.38888888888889
39268, 0.34782608695652, 0.1125, 0.38888888888889
39269, 0.34782608695652, 0.125, 0.41666666666667
39270, 0.3695652173913, 0.125, 0.44444444444444
39271, 0.34782608695652, 0.1125, 0.44444444444444
39272, 0.34782608695652, 0.125, 0.47222222222222
39273, 0.30434782608696, 0.125, 0.027777777777778
39274, 0.32608695652174, 0.125, 0.055555555555556
39275, 0.30434782608696, 0.1125, 0.055555555555556
39276, 0.30434782608696, 0.125, 0.083333333333333
39277, 0.32608695652174, 0.125, 0.11111111111111
39278, 0.30434782608696, 0.1125, 0.11111111111111
39279, 0.30434782608696, 0.125, 0.13888888888889
39280, 0.32608695652174, 0.125, 0.16666666666667
39281, 0.30434782608696, 0.1125, 0.16666666666667
39282, 0.30434782608696, 0.125, 0.19444444444444
39283, 0.32608695652174, 0.125, 0.22222222222222
39284, 0.30434782608696, 0.1125, 0.22222222222222
39285, 0.30434782608696, 0.125, 0.25
39286, 0.32608695652174, 0.125, 0.27777777777778
39287, 0.30434782608696, 0.1125, 0.27777777777778
39288, 0.30434782608696, 0.125, 0.30555555555556
39289, 0.32608695652174, 0.125, 0.33333333333333
39290, 0.30434782608696, 0.1125, 0.33333333333333
39291, 0.30434782608696, 0.125, 0.36111111111111
39292, 0.32608695652174, 0.125, 0.38888888888889
39293, 0.30434782608696, 0.1125, 0.38888888888889
39294, 0.30434782608696, 0.125, 0.41666666666667
39295, 0.32608695652174, 0.125, 0.44444444444444
39296, 0.30434782608696, 0.1125, 0.44444444444444
39297, 0.30434782608696, 0.125, 0.47222222222222
39298, 0.26086956521739, 0.125, 0.027777777777778
39299, 0.28260869565217, 0.125, 0.055555555555556
39300, 0.26086956521739, 0.1125, 0.055555555555556
39301, 0.26086956521739, 0.125, 0.083333333333333
39302, 0.28260869565217, 0.125, 0.11111111111111
39303, 0.26086956521739, 0.1125, 0.11111111111111
39304, 0.26086956521739, 0.125, 0.13888888888889
39305, 0.28260869565217, 0.125, 0.16666666666667
39306, 0.26086956521739, 0.1125, 0.16666666666667
39307, 0.26086956521739, 0.125, 0.19444444444444
39308, 0.28260869565217, 0.125, 0.22222222222222
39309, 0.26086956521739, 0.1125, 0.22222222222222
39310, 0.26086956521739, 0.125, 0.25
39311, 0.28260869565217, 0.125, 0.27777777777778
39312, 0.26086956521739, 0.1125, 0.27777777777778
39313, 0.26086956521739, 0.125, 0.30555555555556
39314, 0.28260869565217, 0.125, 0.33333333333333
39315, 0.26086956521739, 0.1125, 0.33333333333333
39316, 0.26086956521739, 0.125, 0.36111111111111
39317, 0.28260869565217, 0.125, 0.38888888888889
39318, 0.26086956521739, 0.1125, 0.38888888888889
39319, 0.26086956521739, 0.125, 0.41666666666667
39320, 0.28260869565217, 0.125, 0.44444444444444
39321, 0.26086956521739, 0.1125, 0.44444444444444
39322, 0.26086956521739, 0.125, 0.47222222222222
39323, 0.21739130434783, 0.125, 0.027777777777778
39324, 0.23913043478261, 0.125, 0.055555555555556
39325, 0.21739130434783, 0.1125, 0.055555555555556
39326, 0.21739130434783, 0.125, 0.083333333333333
39327, 0.23913043478261, 0.125, 0.11111111111111
39328, 0.21739130434783, 0.1125, 0.11111111111111
39329, 0.21739130434783, 0.125, 0.13888888888889
39330, 0.23913043478261, 0.125, 0.16666666666667
39331, 0.21739130434783, 0.1125, 0.16666666666667
39332, 0.21739130434783, 0.125, 0.19444444444444
39333, 0.23913043478261, 0.125, 0.22222222222222
39334, 0.21739130434783, 0.1125, 0.22222222222222
39335, 0.21739130434783, 0.125, 0.25
39336, 0.23913043478261, 0.125, 0.27777777777778
39337, 0.21739130434783, 0.1125, 0.27777777777778
39338, 0.21739130434783, 0.125, 0.30555555555556
39339, 0.23913043478261, 0.125, 0.33333333333333
39340, 0.21739130434783, 0.1125, 0.33333333333333
39341, 0.21739130434783, 0.125, 0.36111111111111
39342, 0.23913043478261, 0.125, 0.38888888888889
39343, 0.21739130434783, 0.1125, 0.38888888888889
39344, 0.21739130434783, 0.125, 0.41666666666667
39345, 0.23913043478261, 0.125, 0.44444444444444
39346, 0.21739130434783, 0.1125, 0.44444444444444
39347, 0.21739130434783, 0.125, 0.47222222222222
39348, 0.17391304347826, 0.125, 0.027777777777778
39349, 0.19565217391304, 0.125, 0.055555555555556
39350, 0.17391304347826, 0.1125, 0.055555555555556
39351, 0.17391304347826, 0.125, 0.083333333333333
39352, 0.19565217391304, 0.125, 0.11111111111111
39353, 0.17391304347826, 0.1125, 0.11111111111111
39354, 0.17391304347826, 0.125, 0.13888888888889
39355, 0.19565217391304, 0.125, 0.16666666666667
39356, 0.17391304347826, 0.1125, 0.16666666666667
39357, 0.17391304347826, 0.125, 0.19444444444444
39358, 0.19565217391304, 0.125, 0.22222222222222
39359, 0.17391304347826, 0.1125, 0.22222222222222
39360, 0.17391304347826, 0.125, 0.25
39361, 0.19565217391304, 0.125, 0.27777777777778
39362, 0.17391304347826, 0.1125, 0.27777777777778
39363, 0.17391304347826, 0.125, 0.30555555555556
39364, 0.19565217391304, 0.125, 0.33333333333333
39365, 0.17391304347826, 0.1125, 0.33333333333333
39366, 0.17391304347826, 0.125, 0.36111111111111
39367, 0.19565217391304, 0.125, 0.38888888888889
39368, 0.17391304347826, 0.1125, 0.38888888888889
39369, 0.17391304347826, 0.125, 0.41666666666667
39370, 0.19565217391304, 0.125, 0.44444444444444
39371, 0.17391304347826, 0.1125, 0.44444444444444
39372, 0.17391304347826, 0.125, 0.47222222222222
39373, 0.1304347826087, 0.125, 0.027777777777778
39374, 0.15217391304348, 0.125, 0.055555555555556
39375, 0.1304347826087, 0.1125, 0.055555555555556
39376, 0.1304347826087, 0.125, 0.083333333333333
39377, 0.15217391304348, 0.125, 0.11111111111111
39378, 0.1304347826087, 0.1125, 0.11111111111111
39379, 0.1304347826087, 0.125, 0.13888888888889
39380, 0.15217391304348, 0.125, 0.16666666666667
39381, 0.1304347826087, 0.1125, 0.16666666666667
39382, 0.1304347826087, 0.125, 0.19444444444444
39383, 0.15217391304348, 0.125, 0.22222222222222
39384, 0.1304347826087, 0.1125, 0.22222222222222
39385, 0.1304347826087, 0.125, 0.25
39386, 0.15217391304348, 0.125, 0.27777777777778
39387, 0.1304347826087, 0.1125, 0.27777777777778
39388, 0.1304347826087, 0.125, 0.30555555555556
39389, 0.15217391304348, 0.125, 0.33333333333333
39390, 0.1304347826087, 0.1125, 0.33333333333333
39391, 0.1304347826087, 0.125, 0.36111111111111
39392, 0.15217391304348, 0.125, 0.38888888888889
39393, 0.1304347826087, 0.1125, 0.38888888888889
39394, 0.1304347826087, 0.125, 0.41666666666667
39395, 0.15217391304348, 0.125, 0.44444444444444
39396, 0.1304347826087, 0.1125, 0.44444444444444
39397, 0.1304347826087, 0.125, 0.47222222222222
39398, 0.08695652173913, 0.125, 0.027777777777778
39399, 0.10869565217391, 0.125, 0.055555555555556
39400, 0.08695652173913, 0.1125, 0.055555555555556
39401, 0.08695652173913, 0.125, 0.083333333333333
39402, 0.10869565217391, 0.125, 0.11111111111111
39403, 0.08695652173913, 0.1125, 0.11111111111111
39404, 0.08695652173913, 0.125, 0.13888888888889
39405, 0.10869565217391, 0.125, 0.16666666666667
39406, 0.08695652173913, 0.1125, 0.16666666666667
39407, 0.08695652173913, 0.125, 0.19444444444444
39408, 0.10869565217391, 0.125, 0.22222222222222
39409, 0.08695652173913, 0.1125, 0.22222222222222
39410, 0.08695652173913, 0.125, 0.25
39411, 0.10869565217391, 0.125, 0.27777777777778
39412, 0.08695652173913, 0.1125, 0.27777777777778
39413, 0.08695652173913, 0.125, 0.30555555555556
39414, 0.10869565217391, 0.125, 0.33333333333333
39415, 0.08695652173913, 0.1125, 0.33333333333333
39416, 0.08695652173913, 0.125, 0.36111111111111
39417, 0.10869565217391, 0.125, 0.38888888888889
39418, 0.08695652173913, 0.1125, 0.38888888888889
39419, 0.08695652173913, 0.125, 0.41666666666667
39420, 0.10869565217391, 0.125, 0.44444444444444
39421, 0.08695652173913, 0.1125, 0.44444444444444
39422, 0.08695652173913, 0.125, 0.47222222222222
39423, 0.043478260869565, 0.125, 0.027777777777778
39424, 0.065217391304348, 0.125, 0.055555555555556
39425, 0.043478260869565, 0.1125, 0.055555555555556
39426, 0.043478260869565, 0.125, 0.083333333333333
39427, 0.065217391304348, 0.125, 0.11111111111111
39428, 0.043478260869565, 0.1125, 0.11111111111111
39429, 0.043478260869565, 0.125, 0.13888888888889
39430, 0.065217391304348, 0.125, 0.16666666666667
39431, 0.043478260869565, 0.1125, 0.16666666666667
39432, 0.043478260869565, 0.125, 0.19444444444444
39433, 0.065217391304348, 0.125, 0.22222222222222
39434, 0.043478260869565, 0.1125, 0.22222222222222
39435, 0.043478260869565, 0.125, 0.25
39436, 0.065217391304348, 0.125, 0.27777777777778
39437, 0.043478260869565, 0.1125, 0.27777777777778
39438, 0.043478260869565, 0.125, 0.30555555555556
39439, 0.065217391304348, 0.125, 0.33333333333333
39440, 0.043478260869565, 0.1125, 0.33333333333333
39441, 0.043478260869565, 0.125, 0.36111111111111
39442, 0.065217391304348, 0.125, 0.38888888888889
39443, 0.043478260869565, 0.1125, 0.38888888888889
39444, 0.043478260869565, 0.125, 0.41666666666667
39445, 0.065217391304348, 0.125, 0.44444444444444
39446, 0.043478260869565, 0.1125, 0.44444444444444
39447, 0.043478260869565, 0.125, 0.47222222222222
39448, 0.021739130434783, 0.125, 0.055555555555556
39449, 0.021739130434783, 0.125, 0.11111111111111
39450, 0.021739130434783, 0.125, 0.16666666666667
39451, 0.021739130434783, 0.125, 0.22222222222222
39452, 0.021739130434783, 0.125, 0.27777777777778
39453, 0.021739130434783, 0.125, 0.33333333333333
39454, 0.021739130434783, 0.125, 0.38888888888889
39455, 0.021739130434783, 0.125, 0.44444444444444
39456, 0.95652173913043, 0.1375, 0.055555555555556
39457, 0.95652173913044, 0.1375, 0.11111111111111
39458, 0.95652173913044, 0.1375, 0.16666666666667
39459, 0.95652173913043, 0.1375, 0.22222222222222
39460, 0.95652173913043, 0.1375, 0.27777777777778
39461, 0.95652173913043, 0.1375, 0.33333333333333
