83386, 1.895652173913, 1.65, 0.055555555555556
83387, 1.9391304347826, 1.65, 0.44444444444444
83388, 1.9391304347826, 1.65, 0.38888888888889
83389, 1.9391304347826, 1.65, 0.33333333333333
83390, 1.9391304347826, 1.65, 0.27777777777778
83391, 1.9391304347826, 1.65, 0.22222222222222
83392, 1.9391304347826, 1.65, 0.16666666666667
83393, 1.9391304347826, 1.65, 0.11111111111111
83394, 1.9391304347826, 1.65, 0.055555555555556
83395, 1.9826086956522, 1.65, 0.44444444444444
83396, 1.9826086956522, 1.65, 0.38888888888889
83397, 1.9826086956522, 1.65, 0.33333333333333
83398, 1.9826086956522, 1.65, 0.27777777777778
83399, 1.9826086956522, 1.65, 0.22222222222222
83400, 1.9826086956522, 1.65, 0.16666666666667
83401, 1.9826086956522, 1.65, 0.11111111111111
83402, 1.9826086956522, 1.65, 0.055555555555556
83403, 2.0260869565217, 1.65, 0.44444444444444
83404, 2.0260869565217, 1.65, 0.38888888888889
83405, 2.0260869565217, 1.65, 0.33333333333333
83406, 2.0260869565217, 1.65, 0.27777777777778
83407, 2.0260869565217, 1.65, 0.22222222222222
83408, 2.0260869565217, 1.65, 0.16666666666667
83409, 2.0260869565217, 1.65, 0.11111111111111
83410, 2.0260869565217, 1.65, 0.055555555555556
83411, 2.0695652173913, 1.65, 0.44444444444444
83412, 2.0695652173913, 1.65, 0.38888888888889
83413, 2.0695652173913, 1.65, 0.33333333333333
83414, 2.0695652173913, 1.65, 0.27777777777778
83415, 2.0695652173913, 1.65, 0.22222222222222
83416, 2.0695652173913, 1.65, 0.16666666666667
83417, 2.0695652173913, 1.65, 0.11111111111111
83418, 2.0695652173913, 1.65, 0.055555555555556
83419, 2.1130434782609, 1.65, 0.44444444444444
83420, 2.1130434782609, 1.65, 0.38888888888889
83421, 2.1130434782609, 1.65, 0.33333333333333
83422, 2.1130434782609, 1.65, 0.27777777777778
83423, 2.1130434782609, 1.65, 0.22222222222222
83424, 2.1130434782609, 1.65, 0.16666666666667
83425, 2.1130434782609, 1.65, 0.11111111111111
83426, 2.1130434782609, 1.65, 0.055555555555556
83427, 2.1565217391304, 1.65, 0.44444444444444
83428, 2.1565217391304, 1.65, 0.38888888888889
83429, 2.1565217391304, 1.65, 0.33333333333333
83430, 2.1565217391304, 1.65, 0.27777777777778
83431, 2.1565217391304, 1.65, 0.22222222222222
83432, 2.1565217391304, 1.65, 0.16666666666667
83433, 2.1565217391304, 1.65, 0.11111111111111
83434, 2.1565217391304, 1.65, 0.055555555555556
83435, 1.2434782608696, 1.7, 0.44444444444444
83436, 1.2434782608696, 1.7, 0.38888888888889
83437, 1.2434782608696, 1.7, 0.33333333333333
83438, 1.2434782608696, 1.7, 0.27777777777778
83439, 1.2434782608696, 1.7, 0.22222222222222
83440, 1.2434782608696, 1.7, 0.16666666666667
83441, 1.2434782608696, 1.7, 0.11111111111111
83442, 1.2434782608696, 1.7, 0.055555555555556
83443, 1.2869565217391, 1.7, 0.44444444444444
83444, 1.2869565217391, 1.7, 0.38888888888889
83445, 1.2869565217391, 1.7, 0.33333333333333
83446, 1.2869565217391, 1.7, 0.27777777777778
83447, 1.2869565217391, 1.7, 0.22222222222222
83448, 1.2869565217391, 1.7, 0.16666666666667
83449, 1.2869565217391, 1.7, 0.11111111111111
83450, 1.2869565217391, 1.7, 0.055555555555556
83451, 1.3304347826087, 1.7, 0.44444444444444
83452, 1.3304347826087, 1.7, 0.38888888888889
83453, 1.3304347826087, 1.7, 0.33333333333333
83454, 1.3304347826087, 1.7, 0.27777777777778
83455, 1.3304347826087, 1.7, 0.22222222222222
83456, 1.3304347826087, 1.7, 0.16666666666667
83457, 1.3304347826087, 1.7, 0.11111111111111
83458, 1.3304347826087, 1.7, 0.055555555555556
83459, 1.3739130434783, 1.7, 0.44444444444444
83460, 1.3739130434783, 1.7, 0.38888888888889
83461, 1.3739130434783, 1.7, 0.33333333333333
83462, 1.3739130434783, 1.7, 0.27777777777778
83463, 1.3739130434783, 1.7, 0.22222222222222
83464, 1.3739130434783, 1.7, 0.16666666666667
83465, 1.3739130434783, 1.7, 0.11111111111111
83466, 1.3739130434783, 1.7, 0.055555555555556
83467, 1.4173913043478, 1.7, 0.44444444444444
83468, 1.4173913043478, 1.7, 0.38888888888889
83469, 1.4173913043478, 1.7, 0.33333333333333
83470, 1.4173913043478, 1.7, 0.27777777777778
83471, 1.4173913043478, 1.7, 0.22222222222222
83472, 1.4173913043478, 1.7, 0.16666666666667
83473, 1.4173913043478, 1.7, 0.11111111111111
83474, 1.4173913043478, 1.7, 0.055555555555556
83475, 1.4608695652174, 1.7, 0.44444444444444
83476, 1.4608695652174, 1.7, 0.38888888888889
83477, 1.4608695652174, 1.7, 0.33333333333333
83478, 1.4608695652174, 1.7, 0.27777777777778
83479, 1.4608695652174, 1.7, 0.22222222222222
83480, 1.4608695652174, 1.7, 0.16666666666667
83481, 1.4608695652174, 1.7, 0.11111111111111
83482, 1.4608695652174, 1.7, 0.055555555555556
83483, 1.504347826087, 1.7, 0.44444444444444
83484, 1.504347826087, 1.7, 0.38888888888889
83485, 1.504347826087, 1.7, 0.33333333333333
83486, 1.504347826087, 1.7, 0.27777777777778
83487, 1.504347826087, 1.7, 0.22222222222222
83488, 1.504347826087, 1.7, 0.16666666666667
83489, 1.504347826087, 1.7, 0.11111111111111
83490, 1.504347826087, 1.7, 0.055555555555556
83491, 1.5478260869565, 1.7, 0.44444444444444
83492, 1.5478260869565, 1.7, 0.38888888888889
83493, 1.5478260869565, 1.7, 0.33333333333333
83494, 1.5478260869565, 1.7, 0.27777777777778
83495, 1.5478260869565, 1.7, 0.22222222222222
83496, 1.5478260869565, 1.7, 0.16666666666667
83497, 1.5478260869565, 1.7, 0.11111111111111
83498, 1.5478260869565, 1.7, 0.055555555555556
83499, 1.5913043478261, 1.7, 0.44444444444444
83500, 1.5913043478261, 1.7, 0.38888888888889
83501, 1.5913043478261, 1.7, 0.33333333333333
83502, 1.5913043478261, 1.7, 0.27777777777778
83503, 1.5913043478261, 1.7, 0.22222222222222
83504, 1.5913043478261, 1.7, 0.16666666666667
83505, 1.5913043478261, 1.7, 0.11111111111111
83506, 1.5913043478261, 1.7, 0.055555555555556
83507, 1.6347826086957, 1.7, 0.44444444444444
83508, 1.6347826086957, 1.7, 0.38888888888889
83509, 1.6347826086957, 1.7, 0.33333333333333
83510, 1.6347826086957, 1.7, 0.27777777777778
83511, 1.6347826086957, 1.7, 0.22222222222222
83512, 1.6347826086957, 1.7, 0.16666666666667
83513, 1.6347826086957, 1.7, 0.11111111111111
83514, 1.6347826086957, 1.7, 0.055555555555556
83515, 1.6782608695652, 1.7, 0.44444444444444
83516, 1.6782608695652, 1.7, 0.38888888888889
83517, 1.6782608695652, 1.7, 0.33333333333333
83518, 1.6782608695652, 1.7, 0.27777777777778
83519, 1.6782608695652, 1.7, 0.22222222222222
83520, 1.6782608695652, 1.7, 0.16666666666667
83521, 1.6782608695652, 1.7, 0.11111111111111
83522, 1.6782608695652, 1.7, 0.055555555555556
83523, 1.7217391304348, 1.7, 0.44444444444444
83524, 1.7217391304348, 1.7, 0.38888888888889
83525, 1.7217391304348, 1.7, 0.33333333333333
83526, 1.7217391304348, 1.7, 0.27777777777778
83527, 1.7217391304348, 1.7, 0.22222222222222
83528, 1.7217391304348, 1.7, 0.16666666666667
83529, 1.7217391304348, 1.7, 0.11111111111111
83530, 1.7217391304348, 1.7, 0.055555555555556
83531, 1.7652173913043, 1.7, 0.44444444444444
83532, 1.7652173913043, 1.7, 0.38888888888889
83533, 1.7652173913043, 1.7, 0.33333333333333
83534, 1.7652173913043, 1.7, 0.27777777777778
83535, 1.7652173913043, 1.7, 0.22222222222222
83536, 1.7652173913043, 1.7, 0.16666666666667
83537, 1.7652173913043, 1.7, 0.11111111111111
83538, 1.7652173913043, 1.7, 0.055555555555556
83539, 1.8086956521739, 1.7, 0.44444444444444
83540, 1.8086956521739, 1.7, 0.38888888888889
83541, 1.8086956521739, 1.7, 0.33333333333333
83542, 1.8086956521739, 1.7, 0.27777777777778
83543, 1.8086956521739, 1.7, 0.22222222222222
83544, 1.8086956521739, 1.7, 0.16666666666667
83545, 1.8086956521739, 1.7, 0.11111111111111
83546, 1.8086956521739, 1.7, 0.055555555555556
83547, 1.8521739130435, 1.7, 0.44444444444444
83548, 1.8521739130435, 1.7, 0.38888888888889
83549, 1.8521739130435, 1.7, 0.33333333333333
83550, 1.8521739130435, 1.7, 0.27777777777778
83551, 1.8521739130435, 1.7, 0.22222222222222
83552, 1.8521739130435, 1.7, 0.16666666666667
83553, 1.8521739130435, 1.7, 0.11111111111111
83554, 1.8521739130435, 1.7, 0.055555555555556
83555, 1.895652173913, 1.7, 0.44444444444444
83556, 1.895652173913, 1.7, 0.38888888888889
83557, 1.895652173913, 1.7, 0.33333333333333
83558, 1.895652173913, 1.7, 0.27777777777778
83559, 1.895652173913, 1.7, 0.22222222222222
83560, 1.895652173913, 1.7, 0.16666666666667
83561, 1.895652173913, 1.7, 0.11111111111111
83562, 1.895652173913, 1.7, 0.055555555555556
83563, 1.9391304347826, 1.7, 0.44444444444444
83564, 1.9391304347826, 1.7, 0.38888888888889
83565, 1.9391304347826, 1.7, 0.33333333333333
83566, 1.9391304347826, 1.7, 0.27777777777778
83567, 1.9391304347826, 1.7, 0.22222222222222
83568, 1.9391304347826, 1.7, 0.16666666666667
83569, 1.9391304347826, 1.7, 0.11111111111111
83570, 1.9391304347826, 1.7, 0.055555555555556
83571, 1.9826086956522, 1.7, 0.44444444444444
83572, 1.9826086956522, 1.7, 0.38888888888889
83573, 1.9826086956522, 1.7, 0.33333333333333
83574, 1.9826086956522, 1.7, 0.27777777777778
83575, 1.9826086956522, 1.7, 0.22222222222222
83576, 1.9826086956522, 1.7, 0.16666666666667
83577, 1.9826086956522, 1.7, 0.11111111111111
83578, 1.9826086956522, 1.7, 0.055555555555556
83579, 2.0260869565217, 1.7, 0.44444444444444
83580, 2.0260869565217, 1.7, 0.38888888888889
83581, 2.0260869565217, 1.7, 0.33333333333333
83582, 2.0260869565217, 1.7, 0.27777777777778
83583, 2.0260869565217, 1.7, 0.22222222222222
83584, 2.0260869565217, 1.7, 0.16666666666667
83585, 2.0260869565217, 1.7, 0.11111111111111
83586, 2.0260869565217, 1.7, 0.055555555555556
83587, 2.0695652173913, 1.7, 0.44444444444444
83588, 2.0695652173913, 1.7, 0.38888888888889
83589, 2.0695652173913, 1.7, 0.33333333333333
83590, 2.0695652173913, 1.7, 0.27777777777778
83591, 2.0695652173913, 1.7, 0.22222222222222
83592, 2.0695652173913, 1.7, 0.16666666666667
83593, 2.0695652173913, 1.7, 0.11111111111111
83594, 2.0695652173913, 1.7, 0.055555555555556
83595, 2.1130434782609, 1.7, 0.44444444444444
83596, 2.1130434782609, 1.7, 0.38888888888889
83597, 2.1130434782609, 1.7, 0.33333333333333
83598, 2.1130434782609, 1.7, 0.27777777777778
83599, 2.1130434782609, 1.7, 0.22222222222222
83600, 2.1130434782609, 1.7, 0.16666666666667
83601, 2.1130434782609, 1.7, 0.11111111111111
83602, 2.1130434782609, 1.7, 0.055555555555556
83603, 2.1565217391304, 1.7, 0.44444444444444
83604, 2.1565217391304, 1.7, 0.38888888888889
83605, 2.1565217391304, 1.7, 0.33333333333333
83606, 2.1565217391304, 1.7, 0.27777777777778
83607, 2.1565217391304, 1.7, 0.22222222222222
83608, 2.1565217391304, 1.7, 0.16666666666667
83609, 2.1565217391304, 1.7, 0.11111111111111
83610, 2.1565217391304, 1.7, 0.055555555555556
83611, 1.2434782608696, 1.6, 0.47222222222222
83612, 1.2217391304348, 1.6, 0.44444444444444
83613, 1.2434782608696, 1.575, 0.44444444444444
83614, 1.2434782608696, 1.6, 0.41666666666667
83615, 1.2217391304348, 1.6, 0.38888888888889
83616, 1.2434782608696, 1.575, 0.38888888888889
83617, 1.2434782608696, 1.6, 0.36111111111111
83618, 1.2217391304348, 1.6, 0.33333333333333
83619, 1.2434782608696, 1.575, 0.33333333333333
83620, 1.2434782608696, 1.6, 0.30555555555556
83621, 1.2217391304348, 1.6, 0.27777777777778
83622, 1.2434782608696, 1.575, 0.27777777777778
83623, 1.2434782608696, 1.6, 0.25
83624, 1.2217391304348, 1.6, 0.22222222222222
83625, 1.2434782608696, 1.575, 0.22222222222222
83626, 1.2434782608696, 1.6, 0.19444444444444
83627, 1.2217391304348, 1.6, 0.16666666666667
83628, 1.2434782608696, 1.575, 0.16666666666667
83629, 1.2434782608696, 1.6, 0.13888888888889
83630, 1.2217391304348, 1.6, 0.11111111111111
83631, 1.2434782608696, 1.575, 0.11111111111111
83632, 1.2434782608696, 1.6, 0.083333333333333
83633, 1.2217391304348, 1.6, 0.055555555555556
83634, 1.2434782608696, 1.575, 0.055555555555556
83635, 1.2434782608696, 1.6, 0.027777777777778
83636, 1.2869565217391, 1.6, 0.47222222222222
83637, 1.2652173913043, 1.6, 0.44444444444444
83638, 1.2869565217391, 1.575, 0.44444444444444
83639, 1.2869565217391, 1.6, 0.41666666666667
83640, 1.2652173913043, 1.6, 0.38888888888889
83641, 1.2869565217391, 1.575, 0.38888888888889
83642, 1.2869565217391, 1.6, 0.36111111111111
83643, 1.2652173913043, 1.6, 0.33333333333333
83644, 1.2869565217391, 1.575, 0.33333333333333
83645, 1.2869565217391, 1.6, 0.30555555555556
83646, 1.2652173913043, 1.6, 0.27777777777778
83647, 1.2869565217391, 1.575, 0.27777777777778
83648, 1.2869565217391, 1.6, 0.25
83649, 1.2652173913043, 1.6, 0.22222222222222
83650, 1.2869565217391, 1.575, 0.22222222222222
83651, 1.2869565217391, 1.6, 0.19444444444444
83652, 1.2652173913043, 1.6, 0.16666666666667
83653, 1.2869565217391, 1.575, 0.16666666666667
83654, 1.2869565217391, 1.6, 0.13888888888889
83655, 1.2652173913043, 1.6, 0.11111111111111
83656, 1.2869565217391, 1.575, 0.11111111111111
83657, 1.2869565217391, 1.6, 0.083333333333333
83658, 1.2652173913043, 1.6, 0.055555555555556
83659, 1.2869565217391, 1.575, 0.055555555555556
83660, 1.2869565217391, 1.6, 0.027777777777778
83661, 1.3304347826087, 1.6, 0.47222222222222
83662, 1.3086956521739, 1.6, 0.44444444444444
83663, 1.3304347826087, 1.575, 0.44444444444444
83664, 1.3304347826087, 1.6, 0.41666666666667
83665, 1.3086956521739, 1.6, 0.38888888888889
83666, 1.3304347826087, 1.575, 0.38888888888889
83667, 1.3304347826087, 1.6, 0.36111111111111
83668, 1.3086956521739, 1.6, 0.33333333333333
83669, 1.3304347826087, 1.575, 0.33333333333333
83670, 1.3304347826087, 1.6, 0.30555555555556
83671, 1.3086956521739, 1.6, 0.27777777777778
83672, 1.3304347826087, 1.575, 0.27777777777778
83673, 1.3304347826087, 1.6, 0.25
83674, 1.3086956521739, 1.6, 0.22222222222222
83675, 1.3304347826087, 1.575, 0.22222222222222
83676, 1.3304347826087, 1.6, 0.19444444444444
83677, 1.3086956521739, 1.6, 0.16666666666667
83678, 1.3304347826087, 1.575, 0.16666666666667
83679, 1.3304347826087, 1.6, 0.13888888888889
83680, 1.3086956521739, 1.6, 0.11111111111111
83681, 1.3304347826087, 1.575, 0.11111111111111
83682, 1.3304347826087, 1.6, 0.083333333333333
83683, 1.3086956521739, 1.6, 0.055555555555556
83684, 1.3304347826087, 1.575, 0.055555555555556
83685, 1.3304347826087, 1.6, 0.027777777777778
83686, 1.3739130434783, 1.6, 0.47222222222222
83687, 1.3521739130435, 1.6, 0.44444444444444
83688, 1.3739130434783, 1.575, 0.44444444444444
83689, 1.3739130434783, 1.6, 0.41666666666667
83690, 1.3521739130435, 1.6, 0.38888888888889
83691, 1.3739130434783, 1.575, 0.38888888888889
83692, 1.3739130434783, 1.6, 0.36111111111111
83693, 1.3521739130435, 1.6, 0.33333333333333
83694, 1.3739130434783, 1.575, 0.33333333333333
83695, 1.3739130434783, 1.6, 0.30555555555556
83696, 1.3521739130435, 1.6, 0.27777777777778
83697, 1.3739130434783, 1.575, 0.27777777777778
83698, 1.3739130434783, 1.6, 0.25
83699, 1.3521739130435, 1.6, 0.22222222222222
83700, 1.3739130434783, 1.575, 0.22222222222222
83701, 1.3739130434783, 1.6, 0.19444444444444
83702, 1.3521739130435, 1.6, 0.16666666666667
83703, 1.3739130434783, 1.575, 0.16666666666667
83704, 1.3739130434783, 1.6, 0.13888888888889
83705, 1.3521739130435, 1.6, 0.11111111111111
83706, 1.3739130434783, 1.575, 0.11111111111111
83707, 1.3739130434783, 1.6, 0.083333333333333
83708, 1.3521739130435, 1.6, 0.055555555555556
83709, 1.3739130434783, 1.575, 0.055555555555556
83710, 1.3739130434783, 1.6, 0.027777777777778
83711, 1.4173913043478, 1.6, 0.47222222222222
83712, 1.395652173913, 1.6, 0.44444444444444
83713, 1.4173913043478, 1.575, 0.44444444444444
83714, 1.4173913043478, 1.6, 0.41666666666667
83715, 1.395652173913, 1.6, 0.38888888888889
83716, 1.4173913043478, 1.575, 0.38888888888889
83717, 1.4173913043478, 1.6, 0.36111111111111
83718, 1.395652173913, 1.6, 0.33333333333333
83719, 1.4173913043478, 1.575, 0.33333333333333
83720, 1.4173913043478, 1.6, 0.30555555555556
83721, 1.395652173913, 1.6, 0.27777777777778
83722, 1.4173913043478, 1.575, 0.27777777777778
83723, 1.4173913043478, 1.6, 0.25
83724, 1.395652173913, 1.6, 0.22222222222222
83725, 1.4173913043478, 1.575, 0.22222222222222
83726, 1.4173913043478, 1.6, 0.19444444444444
83727, 1.395652173913, 1.6, 0.16666666666667
83728, 1.4173913043478, 1.575, 0.16666666666667
83729, 1.4173913043478, 1.6, 0.13888888888889
83730, 1.395652173913, 1.6, 0.11111111111111
83731, 1.4173913043478, 1.575, 0.11111111111111
83732, 1.4173913043478, 1.6, 0.083333333333333
83733, 1.395652173913, 1.6, 0.055555555555556
83734, 1.4173913043478, 1.575, 0.055555555555556
83735, 1.4173913043478, 1.6, 0.027777777777778
83736, 1.4608695652174, 1.6, 0.47222222222222
83737, 1.4391304347826, 1.6, 0.44444444444444
83738, 1.4608695652174, 1.575, 0.44444444444444
83739, 1.4608695652174, 1.6, 0.41666666666667
83740, 1.4391304347826, 1.6, 0.38888888888889
83741, 1.4608695652174, 1.575, 0.38888888888889
83742, 1.4608695652174, 1.6, 0.36111111111111
83743, 1.4391304347826, 1.6, 0.33333333333333
83744, 1.4608695652174, 1.575, 0.33333333333333
83745, 1.4608695652174, 1.6, 0.30555555555556
83746, 1.4391304347826, 1.6, 0.27777777777778
83747, 1.4608695652174, 1.575, 0.27777777777778
83748, 1.4608695652174, 1.6, 0.25
83749, 1.4391304347826, 1.6, 0.22222222222222
83750, 1.4608695652174, 1.575, 0.22222222222222
83751, 1.4608695652174, 1.6, 0.19444444444444
83752, 1.4391304347826, 1.6, 0.16666666666667
83753, 1.4608695652174, 1.575, 0.16666666666667
83754, 1.4608695652174, 1.6, 0.13888888888889
83755, 1.4391304347826, 1.6, 0.11111111111111
83756, 1.4608695652174, 1.575, 0.11111111111111
83757, 1.4608695652174, 1.6, 0.083333333333333
83758, 1.4391304347826, 1.6, 0.055555555555556
83759, 1.4608695652174, 1.575, 0.055555555555556
83760, 1.4608695652174, 1.6, 0.027777777777778
83761, 1.504347826087, 1.6, 0.47222222222222
83762, 1.4826086956522, 1.6, 0.44444444444444
83763, 1.504347826087, 1.575, 0.44444444444444
83764, 1.504347826087, 1.6, 0.41666666666667
83765, 1.4826086956522, 1.6, 0.38888888888889
83766, 1.504347826087, 1.575, 0.38888888888889
83767, 1.504347826087, 1.6, 0.36111111111111
83768, 1.4826086956522, 1.6, 0.33333333333333
83769, 1.504347826087, 1.575, 0.33333333333333
83770, 1.504347826087, 1.6, 0.30555555555556
83771, 1.4826086956522, 1.6, 0.27777777777778
83772, 1.504347826087, 1.575, 0.27777777777778
83773, 1.504347826087, 1.6, 0.25
83774, 1.4826086956522, 1.6, 0.22222222222222
83775, 1.504347826087, 1.575, 0.22222222222222
83776, 1.504347826087, 1.6, 0.19444444444444
83777, 1.4826086956522, 1.6, 0.16666666666667
83778, 1.504347826087, 1.575, 0.16666666666667
83779, 1.504347826087, 1.6, 0.13888888888889
83780, 1.4826086956522, 1.6, 0.11111111111111
83781, 1.504347826087, 1.575, 0.11111111111111
83782, 1.504347826087, 1.6, 0.083333333333333
83783, 1.4826086956522, 1.6, 0.055555555555556
83784, 1.504347826087, 1.575, 0.055555555555556
83785, 1.504347826087, 1.6, 0.027777777777778
83786, 1.5478260869565, 1.6, 0.47222222222222
83787, 1.5260869565217, 1.6, 0.44444444444444
83788, 1.5478260869565, 1.575, 0.44444444444444
83789, 1.5478260869565, 1.6, 0.41666666666667
83790, 1.5260869565217, 1.6, 0.38888888888889
83791, 1.5478260869565, 1.575, 0.38888888888889
83792, 1.5478260869565, 1.6, 0.36111111111111
83793, 1.5260869565217, 1.6, 0.33333333333333
83794, 1.5478260869565, 1.575, 0.33333333333333
83795, 1.5478260869565, 1.6, 0.30555555555556
83796, 1.5260869565217, 1.6, 0.27777777777778
83797, 1.5478260869565, 1.575, 0.27777777777778
83798, 1.5478260869565, 1.6, 0.25
83799, 1.5260869565217, 1.6, 0.22222222222222
83800, 1.5478260869565, 1.575, 0.22222222222222
83801, 1.5478260869565, 1.6, 0.19444444444444
83802, 1.5260869565217, 1.6, 0.16666666666667
83803, 1.5478260869565, 1.575, 0.16666666666667
83804, 1.5478260869565, 1.6, 0.13888888888889
83805, 1.5260869565217, 1.6, 0.11111111111111
83806, 1.5478260869565, 1.575, 0.11111111111111
83807, 1.5478260869565, 1.6, 0.083333333333333
83808, 1.5260869565217, 1.6, 0.055555555555556
83809, 1.5478260869565, 1.575, 0.055555555555556
83810, 1.5478260869565, 1.6, 0.027777777777778
83811, 1.5913043478261, 1.6, 0.47222222222222
83812, 1.5695652173913, 1.6, 0.44444444444444
83813, 1.5913043478261, 1.575, 0.44444444444444
83814, 1.5913043478261, 1.6, 0.41666666666667
83815, 1.5695652173913, 1.6, 0.38888888888889
83816, 1.5913043478261, 1.575, 0.38888888888889
83817, 1.5913043478261, 1.6, 0.36111111111111
83818, 1.5695652173913, 1.6, 0.33333333333333
83819, 1.5913043478261, 1.575, 0.33333333333333
83820, 1.5913043478261, 1.6, 0.30555555555556
83821, 1.5695652173913, 1.6, 0.27777777777778
83822, 1.5913043478261, 1.575, 0.27777777777778
83823, 1.5913043478261, 1.6, 0.25
83824, 1.5695652173913, 1.6, 0.22222222222222
83825, 1.5913043478261, 1.575, 0.22222222222222
83826, 1.5913043478261, 1.6, 0.19444444444444
83827, 1.5695652173913, 1.6, 0.16666666666667
83828, 1.5913043478261, 1.575, 0.16666666666667
83829, 1.5913043478261, 1.6, 0.13888888888889
83830, 1.5695652173913, 1.6, 0.11111111111111
83831, 1.5913043478261, 1.575, 0.11111111111111
83832, 1.5913043478261, 1.6, 0.083333333333333
83833, 1.5695652173913, 1.6, 0.055555555555556
83834, 1.5913043478261, 1.575, 0.055555555555556
83835, 1.5913043478261, 1.6, 0.027777777777778
83836, 1.6347826086957, 1.6, 0.47222222222222
83837, 1.6130434782609, 1.6, 0.44444444444444
83838, 1.6347826086957, 1.575, 0.44444444444444
83839, 1.6347826086957, 1.6, 0.41666666666667
83840, 1.6130434782609, 1.6, 0.38888888888889
83841, 1.6347826086957, 1.575, 0.38888888888889
83842, 1.6347826086957, 1.6, 0.36111111111111
83843, 1.6130434782609, 1.6, 0.33333333333333
83844, 1.6347826086957, 1.575, 0.33333333333333
83845, 1.6347826086957, 1.6, 0.30555555555556
83846, 1.6130434782609, 1.6, 0.27777777777778
83847, 1.6347826086957, 1.575, 0.27777777777778
83848, 1.6347826086957, 1.6, 0.25
83849, 1.6130434782609, 1.6, 0.22222222222222
83850, 1.6347826086957, 1.575, 0.22222222222222
83851, 1.6347826086957, 1.6, 0.19444444444444
83852, 1.6130434782609, 1.6, 0.16666666666667
83853, 1.6347826086957, 1.575, 0.16666666666667
83854, 1.6347826086957, 1.6, 0.13888888888889
83855, 1.6130434782609, 1.6, 0.11111111111111
83856, 1.6347826086957, 1.575, 0.11111111111111
83857, 1.6347826086957, 1.6, 0.083333333333333
83858, 1.6130434782609, 1.6, 0.055555555555556
83859, 1.6347826086957, 1.575, 0.055555555555556
83860, 1.6347826086957, 1.6, 0.027777777777778
83861, 1.6782608695652, 1.6, 0.47222222222222
83862, 1.6565217391304, 1.6, 0.44444444444444
83863, 1.6782608695652, 1.575, 0.44444444444444
83864, 1.6782608695652, 1.6, 0.41666666666667
83865, 1.6565217391304, 1.6, 0.38888888888889
83866, 1.6782608695652, 1.575, 0.38888888888889
83867, 1.6782608695652, 1.6, 0.36111111111111
83868, 1.6565217391304, 1.6, 0.33333333333333
83869, 1.6782608695652, 1.575, 0.33333333333333
83870, 1.6782608695652, 1.6, 0.30555555555556
83871, 1.6565217391304, 1.6, 0.27777777777778
83872, 1.6782608695652, 1.575, 0.27777777777778
83873, 1.6782608695652, 1.6, 0.25
83874, 1.6565217391304, 1.6, 0.22222222222222
83875, 1.6782608695652, 1.575, 0.22222222222222
83876, 1.6782608695652, 1.6, 0.19444444444444
83877, 1.6565217391304, 1.6, 0.16666666666667
83878, 1.6782608695652, 1.575, 0.16666666666667
83879, 1.6782608695652, 1.6, 0.13888888888889
83880, 1.6565217391304, 1.6, 0.11111111111111
83881, 1.6782608695652, 1.575, 0.11111111111111
83882, 1.6782608695652, 1.6, 0.083333333333333
83883, 1.6565217391304, 1.6, 0.055555555555556
83884, 1.6782608695652, 1.575, 0.055555555555556
83885, 1.6782608695652, 1.6, 0.027777777777778
83886, 1.7217391304348, 1.6, 0.47222222222222
83887, 1.7, 1.6, 0.44444444444444
83888, 1.7217391304348, 1.575, 0.44444444444444
83889, 1.7217391304348, 1.6, 0.41666666666667
83890, 1.7, 1.6, 0.38888888888889
83891, 1.7217391304348, 1.575, 0.38888888888889
83892, 1.7217391304348, 1.6, 0.36111111111111
83893, 1.7, 1.6, 0.33333333333333
83894, 1.7217391304348, 1.575, 0.33333333333333
83895, 1.7217391304348, 1.6, 0.30555555555556
83896, 1.7, 1.6, 0.27777777777778
83897, 1.7217391304348, 1.575, 0.27777777777778
83898, 1.7217391304348, 1.6, 0.25
83899, 1.7, 1.6, 0.22222222222222
83900, 1.7217391304348, 1.575, 0.22222222222222
83901, 1.7217391304348, 1.6, 0.19444444444444
83902, 1.7, 1.6, 0.16666666666667
83903, 1.7217391304348, 1.575, 0.16666666666667
83904, 1.7217391304348, 1.6, 0.13888888888889
83905, 1.7, 1.6, 0.11111111111111
83906, 1.7217391304348, 1.575, 0.11111111111111
83907, 1.7217391304348, 1.6, 0.083333333333333
83908, 1.7, 1.6, 0.055555555555556
83909, 1.7217391304348, 1.575, 0.055555555555556
83910, 1.7217391304348, 1.6, 0.027777777777778
83911, 1.7652173913043, 1.6, 0.47222222222222
83912, 1.7434782608696, 1.6, 0.44444444444444
83913, 1.7652173913043, 1.575, 0.44444444444444
83914, 1.7652173913043, 1.6, 0.41666666666667
83915, 1.7434782608696, 1.6, 0.38888888888889
83916, 1.7652173913043, 1.575, 0.38888888888889
83917, 1.7652173913043, 1.6, 0.36111111111111
83918, 1.7434782608696, 1.6, 0.33333333333333
83919, 1.7652173913043, 1.575, 0.33333333333333
83920, 1.7652173913043, 1.6, 0.30555555555556
83921, 1.7434782608696, 1.6, 0.27777777777778
83922, 1.7652173913043, 1.575, 0.27777777777778
83923, 1.7652173913043, 1.6, 0.25
83924, 1.7434782608696, 1.6, 0.22222222222222
83925, 1.7652173913043, 1.575, 0.22222222222222
83926, 1.7652173913043, 1.6, 0.19444444444444
83927, 1.7434782608696, 1.6, 0.16666666666667
83928, 1.7652173913043, 1.575, 0.16666666666667
83929, 1.7652173913043, 1.6, 0.13888888888889
83930, 1.7434782608696, 1.6, 0.11111111111111
83931, 1.7652173913043, 1.575, 0.11111111111111
83932, 1.7652173913043, 1.6, 0.083333333333333
83933, 1.7434782608696, 1.6, 0.055555555555556
83934, 1.7652173913043, 1.575, 0.055555555555556
83935, 1.7652173913043, 1.6, 0.027777777777778
83936, 1.8086956521739, 1.6, 0.47222222222222
83937, 1.7869565217391, 1.6, 0.44444444444444
83938, 1.8086956521739, 1.575, 0.44444444444444
83939, 1.8086956521739, 1.6, 0.41666666666667
83940, 1.7869565217391, 1.6, 0.38888888888889
83941, 1.8086956521739, 1.575, 0.38888888888889
83942, 1.8086956521739, 1.6, 0.36111111111111
83943, 1.7869565217391, 1.6, 0.33333333333333
83944, 1.8086956521739, 1.575, 0.33333333333333
83945, 1.8086956521739, 1.6, 0.30555555555556
83946, 1.7869565217391, 1.6, 0.27777777777778
83947, 1.8086956521739, 1.575, 0.27777777777778
83948, 1.8086956521739, 1.6, 0.25
83949, 1.7869565217391, 1.6, 0.22222222222222
83950, 1.8086956521739, 1.575, 0.22222222222222
83951, 1.8086956521739, 1.6, 0.19444444444444
83952, 1.7869565217391, 1.6, 0.16666666666667
83953, 1.8086956521739, 1.575, 0.16666666666667
83954, 1.8086956521739, 1.6, 0.13888888888889
83955, 1.7869565217391, 1.6, 0.11111111111111
83956, 1.8086956521739, 1.575, 0.11111111111111
83957, 1.8086956521739, 1.6, 0.083333333333333
83958, 1.7869565217391, 1.6, 0.055555555555556
83959, 1.8086956521739, 1.575, 0.055555555555556
83960, 1.8086956521739, 1.6, 0.027777777777778
83961, 1.8521739130435, 1.6, 0.47222222222222
83962, 1.8304347826087, 1.6, 0.44444444444444
83963, 1.8521739130435, 1.575, 0.44444444444444
83964, 1.8521739130435, 1.6, 0.41666666666667
83965, 1.8304347826087, 1.6, 0.38888888888889
83966, 1.8521739130435, 1.575, 0.38888888888889
83967, 1.8521739130435, 1.6, 0.36111111111111
83968, 1.8304347826087, 1.6, 0.33333333333333
83969, 1.8521739130435, 1.575, 0.33333333333333
83970, 1.8521739130435, 1.6, 0.30555555555556
83971, 1.8304347826087, 1.6, 0.27777777777778
83972, 1.8521739130435, 1.575, 0.27777777777778
83973, 1.8521739130435, 1.6, 0.25
83974, 1.8304347826087, 1.6, 0.22222222222222
83975, 1.8521739130435, 1.575, 0.22222222222222
83976, 1.8521739130435, 1.6, 0.19444444444444
83977, 1.8304347826087, 1.6, 0.16666666666667
83978, 1.8521739130435, 1.575, 0.16666666666667
83979, 1.8521739130435, 1.6, 0.13888888888889
83980, 1.8304347826087, 1.6, 0.11111111111111
83981, 1.8521739130435, 1.575, 0.11111111111111
83982, 1.8521739130435, 1.6, 0.083333333333333
83983, 1.8304347826087, 1.6, 0.055555555555556
83984, 1.8521739130435, 1.575, 0.055555555555556
83985, 1.8521739130435, 1.6, 0.027777777777778
83986, 1.895652173913, 1.6, 0.47222222222222
83987, 1.8739130434783, 1.6, 0.44444444444444
83988, 1.895652173913, 1.575, 0.44444444444444
83989, 1.895652173913, 1.6, 0.41666666666667
83990, 1.8739130434783, 1.6, 0.38888888888889
83991, 1.895652173913, 1.575, 0.38888888888889
83992, 1.895652173913, 1.6, 0.36111111111111
83993, 1.8739130434783, 1.6, 0.33333333333333
83994, 1.895652173913, 1.575, 0.33333333333333
83995, 1.895652173913, 1.6, 0.30555555555556
83996, 1.8739130434783, 1.6, 0.27777777777778
83997, 1.895652173913, 1.575, 0.27777777777778
83998, 1.895652173913, 1.6, 0.25
83999, 1.8739130434783, 1.6, 0.22222222222222
84000, 1.895652173913, 1.575, 0.22222222222222
84001, 1.895652173913, 1.6, 0.19444444444444
84002, 1.8739130434783, 1.6, 0.16666666666667
84003, 1.895652173913, 1.575, 0.16666666666667
84004, 1.895652173913, 1.6, 0.13888888888889
84005, 1.8739130434783, 1.6, 0.11111111111111
84006, 1.895652173913, 1.575, 0.11111111111111
84007, 1.895652173913, 1.6, 0.083333333333333
84008, 1.8739130434783, 1.6, 0.055555555555556
84009, 1.895652173913, 1.575, 0.055555555555556
84010, 1.895652173913, 1.6, 0.027777777777778
84011, 1.9391304347826, 1.6, 0.47222222222222
84012, 1.9173913043478, 1.6, 0.44444444444444
84013, 1.9391304347826, 1.575, 0.44444444444444
84014, 1.9391304347826, 1.6, 0.41666666666667
84015, 1.9173913043478, 1.6, 0.38888888888889
84016, 1.9391304347826, 1.575, 0.38888888888889
84017, 1.9391304347826, 1.6, 0.36111111111111
84018, 1.9173913043478, 1.6, 0.33333333333333
84019, 1.9391304347826, 1.575, 0.33333333333333
84020, 1.9391304347826, 1.6, 0.30555555555556
84021, 1.9173913043478, 1.6, 0.27777777777778
84022, 1.9391304347826, 1.575, 0.27777777777778
84023, 1.9391304347826, 1.6, 0.25
84024, 1.9173913043478, 1.6, 0.22222222222222
84025, 1.9391304347826, 1.575, 0.22222222222222
84026, 1.9391304347826, 1.6, 0.19444444444444
84027, 1.9173913043478, 1.6, 0.16666666666667
84028, 1.9391304347826, 1.575, 0.16666666666667
84029, 1.9391304347826, 1.6, 0.13888888888889
84030, 1.9173913043478, 1.6, 0.11111111111111
84031, 1.9391304347826, 1.575, 0.11111111111111
84032, 1.9391304347826, 1.6, 0.083333333333333
84033, 1.9173913043478, 1.6, 0.055555555555556
84034, 1.9391304347826, 1.575, 0.055555555555556
84035, 1.9391304347826, 1.6, 0.027777777777778
84036, 1.9826086956522, 1.6, 0.47222222222222
84037, 1.9608695652174, 1.6, 0.44444444444444
84038, 1.9826086956522, 1.575, 0.44444444444444
84039, 1.9826086956522, 1.6, 0.41666666666667
84040, 1.9608695652174, 1.6, 0.38888888888889
84041, 1.9826086956522, 1.575, 0.38888888888889
84042, 1.9826086956522, 1.6, 0.36111111111111
84043, 1.9608695652174, 1.6, 0.33333333333333
84044, 1.9826086956522, 1.575, 0.33333333333333
84045, 1.9826086956522, 1.6, 0.30555555555556
84046, 1.9608695652174, 1.6, 0.27777777777778
84047, 1.9826086956522, 1.575, 0.27777777777778
84048, 1.9826086956522, 1.6, 0.25
84049, 1.9608695652174, 1.6, 0.22222222222222
84050, 1.9826086956522, 1.575, 0.22222222222222
84051, 1.9826086956522, 1.6, 0.19444444444444
84052, 1.9608695652174, 1.6, 0.16666666666667
84053, 1.9826086956522, 1.575, 0.16666666666667
84054, 1.9826086956522, 1.6, 0.13888888888889
84055, 1.9608695652174, 1.6, 0.11111111111111
84056, 1.9826086956522, 1.575, 0.11111111111111
84057, 1.9826086956522, 1.6, 0.083333333333333
84058, 1.9608695652174, 1.6, 0.055555555555556
84059, 1.9826086956522, 1.575, 0.055555555555556
84060, 1.9826086956522, 1.6, 0.027777777777778
84061, 2.0260869565217, 1.6, 0.47222222222222
84062, 2.004347826087, 1.6, 0.44444444444444
84063, 2.0260869565217, 1.575, 0.44444444444444
84064, 2.0260869565217, 1.6, 0.41666666666667
84065, 2.004347826087, 1.6, 0.38888888888889
84066, 2.0260869565217, 1.575, 0.38888888888889
84067, 2.0260869565217, 1.6, 0.36111111111111
84068, 2.004347826087, 1.6, 0.33333333333333
84069, 2.0260869565217, 1.575, 0.33333333333333
84070, 2.0260869565217, 1.6, 0.30555555555556
84071, 2.004347826087, 1.6, 0.27777777777778
84072, 2.0260869565217, 1.575, 0.27777777777778
84073, 2.0260869565217, 1.6, 0.25
84074, 2.004347826087, 1.6, 0.22222222222222
84075, 2.0260869565217, 1.575, 0.22222222222222
84076, 2.0260869565217, 1.6, 0.19444444444444
84077, 2.004347826087, 1.6, 0.16666666666667
84078, 2.0260869565217, 1.575, 0.16666666666667
84079, 2.0260869565217, 1.6, 0.13888888888889
84080, 2.004347826087, 1.6, 0.11111111111111
84081, 2.0260869565217, 1.575, 0.11111111111111
84082, 2.0260869565217, 1.6, 0.083333333333333
84083, 2.004347826087, 1.6, 0.055555555555556
84084, 2.0260869565217, 1.575, 0.055555555555556
84085, 2.0260869565217, 1.6, 0.027777777777778
84086, 2.0695652173913, 1.6, 0.47222222222222
84087, 2.0478260869565, 1.6, 0.44444444444444
84088, 2.0695652173913, 1.575, 0.44444444444444
84089, 2.0695652173913, 1.6, 0.41666666666667
84090, 2.0478260869565, 1.6, 0.38888888888889
84091, 2.0695652173913, 1.575, 0.38888888888889
84092, 2.0695652173913, 1.6, 0.36111111111111
84093, 2.0478260869565, 1.6, 0.33333333333333
84094, 2.0695652173913, 1.575, 0.33333333333333
84095, 2.0695652173913, 1.6, 0.30555555555556
84096, 2.0478260869565, 1.6, 0.27777777777778
84097, 2.0695652173913, 1.575, 0.27777777777778
84098, 2.0695652173913, 1.6, 0.25
84099, 2.0478260869565, 1.6, 0.22222222222222
84100, 2.0695652173913, 1.575, 0.22222222222222
84101, 2.0695652173913, 1.6, 0.19444444444444
84102, 2.0478260869565, 1.6, 0.16666666666667
84103, 2.0695652173913, 1.575, 0.16666666666667
84104, 2.0695652173913, 1.6, 0.13888888888889
84105, 2.0478260869565, 1.6, 0.11111111111111
84106, 2.0695652173913, 1.575, 0.11111111111111
84107, 2.0695652173913, 1.6, 0.083333333333333
84108, 2.0478260869565, 1.6, 0.055555555555556
84109, 2.0695652173913, 1.575, 0.055555555555556
84110, 2.0695652173913, 1.6, 0.027777777777778
84111, 2.1130434782609, 1.6, 0.47222222222222
84112, 2.0913043478261, 1.6, 0.44444444444444
84113, 2.1130434782609, 1.575, 0.44444444444444
84114, 2.1130434782609, 1.6, 0.41666666666667
84115, 2.0913043478261, 1.6, 0.38888888888889
84116, 2.1130434782609, 1.575, 0.38888888888889
84117, 2.1130434782609, 1.6, 0.36111111111111
84118, 2.0913043478261, 1.6, 0.33333333333333
84119, 2.1130434782609, 1.575, 0.33333333333333
84120, 2.1130434782609, 1.6, 0.30555555555556
84121, 2.0913043478261, 1.6, 0.27777777777778
84122, 2.1130434782609, 1.575, 0.27777777777778
84123, 2.1130434782609, 1.6, 0.25
84124, 2.0913043478261, 1.6, 0.22222222222222
84125, 2.1130434782609, 1.575, 0.22222222222222
84126, 2.1130434782609, 1.6, 0.19444444444444
84127, 2.0913043478261, 1.6, 0.16666666666667
84128, 2.1130434782609, 1.575, 0.16666666666667
84129, 2.1130434782609, 1.6, 0.13888888888889
84130, 2.0913043478261, 1.6, 0.11111111111111
84131, 2.1130434782609, 1.575, 0.11111111111111
84132, 2.1130434782609, 1.6, 0.083333333333333
84133, 2.0913043478261, 1.6, 0.055555555555556
84134, 2.1130434782609, 1.575, 0.055555555555556
84135, 2.1130434782609, 1.6, 0.027777777777778
84136, 2.1565217391304, 1.6, 0.47222222222222
84137, 2.1347826086957, 1.6, 0.44444444444444
84138, 2.1565217391304, 1.575, 0.44444444444444
84139, 2.1565217391304, 1.6, 0.41666666666667
84140, 2.1347826086957, 1.6, 0.38888888888889
84141, 2.1565217391304, 1.575, 0.38888888888889
84142, 2.1565217391304, 1.6, 0.36111111111111
84143, 2.1347826086957, 1.6, 0.33333333333333
84144, 2.1565217391304, 1.575, 0.33333333333333
84145, 2.1565217391304, 1.6, 0.30555555555556
84146, 2.1347826086957, 1.6, 0.27777777777778
84147, 2.1565217391304, 1.575, 0.27777777777778
84148, 2.1565217391304, 1.6, 0.25
84149, 2.1347826086957, 1.6, 0.22222222222222
84150, 2.1565217391304, 1.575, 0.22222222222222
84151, 2.1565217391304, 1.6, 0.19444444444444
84152, 2.1347826086957, 1.6, 0.16666666666667
84153, 2.1565217391304, 1.575, 0.16666666666667
84154, 2.1565217391304, 1.6, 0.13888888888889
84155, 2.1347826086957, 1.6, 0.11111111111111
84156, 2.1565217391304, 1.575, 0.11111111111111
84157, 2.1565217391304, 1.6, 0.083333333333333
84158, 2.1347826086957, 1.6, 0.055555555555556
84159, 2.1565217391304, 1.575, 0.055555555555556
84160, 2.1565217391304, 1.6, 0.027777777777778
84161, 2.1782608695652, 1.6, 0.44444444444444
84162, 2.1782608695652, 1.6, 0.38888888888889
84163, 2.1782608695652, 1.6, 0.33333333333333
84164, 2.1782608695652, 1.6, 0.27777777777778
84165, 2.1782608695652, 1.6, 0.22222222222222
84166, 2.1782608695652, 1.6, 0.16666666666667
84167, 2.1782608695652, 1.6, 0.11111111111111
84168, 2.1782608695652, 1.6, 0.055555555555556
84169, 1.2434782608696, 1.65, 0.47222222222222
84170, 1.2217391304348, 1.65, 0.44444444444444
84171, 1.2434782608696, 1.625, 0.44444444444444
84172, 1.2434782608696, 1.65, 0.41666666666667
84173, 1.2217391304348, 1.65, 0.38888888888889
84174, 1.2434782608696, 1.625, 0.38888888888889
84175, 1.2434782608696, 1.65, 0.36111111111111
84176, 1.2217391304348, 1.65, 0.33333333333333
84177, 1.2434782608696, 1.625, 0.33333333333333
84178, 1.2434782608696, 1.65, 0.30555555555556
84179, 1.2217391304348, 1.65, 0.27777777777778
84180, 1.2434782608696, 1.625, 0.27777777777778
84181, 1.2434782608696, 1.65, 0.25
84182, 1.2217391304348, 1.65, 0.22222222222222
84183, 1.2434782608696, 1.625, 0.22222222222222
84184, 1.2434782608696, 1.65, 0.19444444444444
84185, 1.2217391304348, 1.65, 0.16666666666667
84186, 1.2434782608696, 1.625, 0.16666666666667
84187, 1.2434782608696, 1.65, 0.13888888888889
84188, 1.2217391304348, 1.65, 0.11111111111111
84189, 1.2434782608696, 1.625, 0.11111111111111
84190, 1.2434782608696, 1.65, 0.083333333333333
84191, 1.2217391304348, 1.65, 0.055555555555556
84192, 1.2434782608696, 1.625, 0.055555555555556
84193, 1.2434782608696, 1.65, 0.027777777777778
84194, 1.2869565217391, 1.65, 0.47222222222222
84195, 1.2652173913043, 1.65, 0.44444444444444
84196, 1.2869565217391, 1.625, 0.44444444444444
84197, 1.2869565217391, 1.65, 0.41666666666667
84198, 1.2652173913043, 1.65, 0.38888888888889
84199, 1.2869565217391, 1.625, 0.38888888888889
84200, 1.2869565217391, 1.65, 0.36111111111111
84201, 1.2652173913043, 1.65, 0.33333333333333
84202, 1.2869565217391, 1.625, 0.33333333333333
84203, 1.2869565217391, 1.65, 0.30555555555556
84204, 1.2652173913043, 1.65, 0.27777777777778
84205, 1.2869565217391, 1.625, 0.27777777777778
84206, 1.2869565217391, 1.65, 0.25
84207, 1.2652173913043, 1.65, 0.22222222222222
84208, 1.2869565217391, 1.625, 0.22222222222222
84209, 1.2869565217391, 1.65, 0.19444444444444
84210, 1.2652173913043, 1.65, 0.16666666666667
84211, 1.2869565217391, 1.625, 0.16666666666667
84212, 1.2869565217391, 1.65, 0.13888888888889
84213, 1.2652173913043, 1.65, 0.11111111111111
84214, 1.2869565217391, 1.625, 0.11111111111111
84215, 1.2869565217391, 1.65, 0.083333333333333
84216, 1.2652173913043, 1.65, 0.055555555555556
84217, 1.2869565217391, 1.625, 0.055555555555556
84218, 1.2869565217391, 1.65, 0.027777777777778
84219, 1.3304347826087, 1.65, 0.47222222222222
84220, 1.3086956521739, 1.65, 0.44444444444444
84221, 1.3304347826087, 1.625, 0.44444444444444
84222, 1.3304347826087, 1.65, 0.41666666666667
84223, 1.3086956521739, 1.65, 0.38888888888889
84224, 1.3304347826087, 1.625, 0.38888888888889
84225, 1.3304347826087, 1.65, 0.36111111111111
84226, 1.3086956521739, 1.65, 0.33333333333333
84227, 1.3304347826087, 1.625, 0.33333333333333
84228, 1.3304347826087, 1.65, 0.30555555555556
84229, 1.3086956521739, 1.65, 0.27777777777778
84230, 1.3304347826087, 1.625, 0.27777777777778
84231, 1.3304347826087, 1.65, 0.25
84232, 1.3086956521739, 1.65, 0.22222222222222
84233, 1.3304347826087, 1.625, 0.22222222222222
84234, 1.3304347826087, 1.65, 0.19444444444444
84235, 1.3086956521739, 1.65, 0.16666666666667
84236, 1.3304347826087, 1.625, 0.16666666666667
84237, 1.3304347826087, 1.65, 0.13888888888889
84238, 1.3086956521739, 1.65, 0.11111111111111
84239, 1.3304347826087, 1.625, 0.11111111111111
84240, 1.3304347826087, 1.65, 0.083333333333333
84241, 1.3086956521739, 1.65, 0.055555555555556
84242, 1.3304347826087, 1.625, 0.055555555555556
84243, 1.3304347826087, 1.65, 0.027777777777778
84244, 1.3739130434783, 1.65, 0.47222222222222
84245, 1.3521739130435, 1.65, 0.44444444444444
84246, 1.3739130434783, 1.625, 0.44444444444444
84247, 1.3739130434783, 1.65, 0.41666666666667
84248, 1.3521739130435, 1.65, 0.38888888888889
84249, 1.3739130434783, 1.625, 0.38888888888889
84250, 1.3739130434783, 1.65, 0.36111111111111
84251, 1.3521739130435, 1.65, 0.33333333333333
84252, 1.3739130434783, 1.625, 0.33333333333333
84253, 1.3739130434783, 1.65, 0.30555555555556
84254, 1.3521739130435, 1.65, 0.27777777777778
84255, 1.3739130434783, 1.625, 0.27777777777778
84256, 1.3739130434783, 1.65, 0.25
84257, 1.3521739130435, 1.65, 0.22222222222222
84258, 1.3739130434783, 1.625, 0.22222222222222
84259, 1.3739130434783, 1.65, 0.19444444444444
84260, 1.3521739130435, 1.65, 0.16666666666667
84261, 1.3739130434783, 1.625, 0.16666666666667
84262, 1.3739130434783, 1.65, 0.13888888888889
84263, 1.3521739130435, 1.65, 0.11111111111111
84264, 1.3739130434783, 1.625, 0.11111111111111
84265, 1.3739130434783, 1.65, 0.083333333333333
84266, 1.3521739130435, 1.65, 0.055555555555556
84267, 1.3739130434783, 1.625, 0.055555555555556
84268, 1.3739130434783, 1.65, 0.027777777777778
84269, 1.4173913043478, 1.65, 0.47222222222222
84270, 1.395652173913, 1.65, 0.44444444444444
84271, 1.4173913043478, 1.625, 0.44444444444444
84272, 1.4173913043478, 1.65, 0.41666666666667
84273, 1.395652173913, 1.65, 0.38888888888889
84274, 1.4173913043478, 1.625, 0.38888888888889
84275, 1.4173913043478, 1.65, 0.36111111111111
84276, 1.395652173913, 1.65, 0.33333333333333
84277, 1.4173913043478, 1.625, 0.33333333333333
84278, 1.4173913043478, 1.65, 0.30555555555556
84279, 1.395652173913, 1.65, 0.27777777777778
84280, 1.4173913043478, 1.625, 0.27777777777778
84281, 1.4173913043478, 1.65, 0.25
84282, 1.395652173913, 1.65, 0.22222222222222
84283, 1.4173913043478, 1.625, 0.22222222222222
84284, 1.4173913043478, 1.65, 0.19444444444444
84285, 1.395652173913, 1.65, 0.16666666666667
84286, 1.4173913043478, 1.625, 0.16666666666667
84287, 1.4173913043478, 1.65, 0.13888888888889
84288, 1.395652173913, 1.65, 0.11111111111111
84289, 1.4173913043478, 1.625, 0.11111111111111
84290, 1.4173913043478, 1.65, 0.083333333333333
84291, 1.395652173913, 1.65, 0.055555555555556
84292, 1.4173913043478, 1.625, 0.055555555555556
84293, 1.4173913043478, 1.65, 0.027777777777778
84294, 1.4608695652174, 1.65, 0.47222222222222
84295, 1.4391304347826, 1.65, 0.44444444444444
84296, 1.4608695652174, 1.625, 0.44444444444444
84297, 1.4608695652174, 1.65, 0.41666666666667
84298, 1.4391304347826, 1.65, 0.38888888888889
84299, 1.4608695652174, 1.625, 0.38888888888889
84300, 1.4608695652174, 1.65, 0.36111111111111
84301, 1.4391304347826, 1.65, 0.33333333333333
84302, 1.4608695652174, 1.625, 0.33333333333333
84303, 1.4608695652174, 1.65, 0.30555555555556
84304, 1.4391304347826, 1.65, 0.27777777777778
84305, 1.4608695652174, 1.625, 0.27777777777778
84306, 1.4608695652174, 1.65, 0.25
84307, 1.4391304347826, 1.65, 0.22222222222222
84308, 1.4608695652174, 1.625, 0.22222222222222
84309, 1.4608695652174, 1.65, 0.19444444444444
84310, 1.4391304347826, 1.65, 0.16666666666667
84311, 1.4608695652174, 1.625, 0.16666666666667
84312, 1.4608695652174, 1.65, 0.13888888888889
84313, 1.4391304347826, 1.65, 0.11111111111111
84314, 1.4608695652174, 1.625, 0.11111111111111
84315, 1.4608695652174, 1.65, 0.083333333333333
84316, 1.4391304347826, 1.65, 0.055555555555556
84317, 1.4608695652174, 1.625, 0.055555555555556
84318, 1.4608695652174, 1.65, 0.027777777777778
84319, 1.504347826087, 1.65, 0.47222222222222
84320, 1.4826086956522, 1.65, 0.44444444444444
84321, 1.504347826087, 1.625, 0.44444444444444
84322, 1.504347826087, 1.65, 0.41666666666667
84323, 1.4826086956522, 1.65, 0.38888888888889
84324, 1.504347826087, 1.625, 0.38888888888889
84325, 1.504347826087, 1.65, 0.36111111111111
84326, 1.4826086956522, 1.65, 0.33333333333333
84327, 1.504347826087, 1.625, 0.33333333333333
84328, 1.504347826087, 1.65, 0.30555555555556
84329, 1.4826086956522, 1.65, 0.27777777777778
84330, 1.504347826087, 1.625, 0.27777777777778
84331, 1.504347826087, 1.65, 0.25
84332, 1.4826086956522, 1.65, 0.22222222222222
84333, 1.504347826087, 1.625, 0.22222222222222
84334, 1.504347826087, 1.65, 0.19444444444444
84335, 1.4826086956522, 1.65, 0.16666666666667
84336, 1.504347826087, 1.625, 0.16666666666667
84337, 1.504347826087, 1.65, 0.13888888888889
84338, 1.4826086956522, 1.65, 0.11111111111111
84339, 1.504347826087, 1.625, 0.11111111111111
84340, 1.504347826087, 1.65, 0.083333333333333
84341, 1.4826086956522, 1.65, 0.055555555555556
84342, 1.504347826087, 1.625, 0.055555555555556
84343, 1.504347826087, 1.65, 0.027777777777778
84344, 1.5478260869565, 1.65, 0.47222222222222
84345, 1.5260869565217, 1.65, 0.44444444444444
84346, 1.5478260869565, 1.625, 0.44444444444444
84347, 1.5478260869565, 1.65, 0.41666666666667
84348, 1.5260869565217, 1.65, 0.38888888888889
84349, 1.5478260869565, 1.625, 0.38888888888889
84350, 1.5478260869565, 1.65, 0.36111111111111
84351, 1.5260869565217, 1.65, 0.33333333333333
84352, 1.5478260869565, 1.625, 0.33333333333333
84353, 1.5478260869565, 1.65, 0.30555555555556
84354, 1.5260869565217, 1.65, 0.27777777777778
84355, 1.5478260869565, 1.625, 0.27777777777778
84356, 1.5478260869565, 1.65, 0.25
84357, 1.5260869565217, 1.65, 0.22222222222222
84358, 1.5478260869565, 1.625, 0.22222222222222
84359, 1.5478260869565, 1.65, 0.19444444444444
84360, 1.5260869565217, 1.65, 0.16666666666667
84361, 1.5478260869565, 1.625, 0.16666666666667
84362, 1.5478260869565, 1.65, 0.13888888888889
84363, 1.5260869565217, 1.65, 0.11111111111111
84364, 1.5478260869565, 1.625, 0.11111111111111
84365, 1.5478260869565, 1.65, 0.083333333333333
84366, 1.5260869565217, 1.65, 0.055555555555556
84367, 1.5478260869565, 1.625, 0.055555555555556
84368, 1.5478260869565, 1.65, 0.027777777777778
84369, 1.5913043478261, 1.65, 0.47222222222222
84370, 1.5695652173913, 1.65, 0.44444444444444
84371, 1.5913043478261, 1.625, 0.44444444444444
84372, 1.5913043478261, 1.65, 0.41666666666667
84373, 1.5695652173913, 1.65, 0.38888888888889
84374, 1.5913043478261, 1.625, 0.38888888888889
84375, 1.5913043478261, 1.65, 0.36111111111111
84376, 1.5695652173913, 1.65, 0.33333333333333
84377, 1.5913043478261, 1.625, 0.33333333333333
84378, 1.5913043478261, 1.65, 0.30555555555556
84379, 1.5695652173913, 1.65, 0.27777777777778
84380, 1.5913043478261, 1.625, 0.27777777777778
84381, 1.5913043478261, 1.65, 0.25
84382, 1.5695652173913, 1.65, 0.22222222222222
84383, 1.5913043478261, 1.625, 0.22222222222222
84384, 1.5913043478261, 1.65, 0.19444444444444
84385, 1.5695652173913, 1.65, 0.16666666666667
84386, 1.5913043478261, 1.625, 0.16666666666667
84387, 1.5913043478261, 1.65, 0.13888888888889
84388, 1.5695652173913, 1.65, 0.11111111111111
84389, 1.5913043478261, 1.625, 0.11111111111111
84390, 1.5913043478261, 1.65, 0.083333333333333
84391, 1.5695652173913, 1.65, 0.055555555555556
84392, 1.5913043478261, 1.625, 0.055555555555556
84393, 1.5913043478261, 1.65, 0.027777777777778
84394, 1.6347826086957, 1.65, 0.47222222222222
84395, 1.6130434782609, 1.65, 0.44444444444444
84396, 1.6347826086957, 1.625, 0.44444444444444
84397, 1.6347826086957, 1.65, 0.41666666666667
84398, 1.6130434782609, 1.65, 0.38888888888889
84399, 1.6347826086957, 1.625, 0.38888888888889
84400, 1.6347826086957, 1.65, 0.36111111111111
84401, 1.6130434782609, 1.65, 0.33333333333333
84402, 1.6347826086957, 1.625, 0.33333333333333
84403, 1.6347826086957, 1.65, 0.30555555555556
84404, 1.6130434782609, 1.65, 0.27777777777778
84405, 1.6347826086957, 1.625, 0.27777777777778
84406, 1.6347826086957, 1.65, 0.25
84407, 1.6130434782609, 1.65, 0.22222222222222
84408, 1.6347826086957, 1.625, 0.22222222222222
84409, 1.6347826086957, 1.65, 0.19444444444444
84410, 1.6130434782609, 1.65, 0.16666666666667
84411, 1.6347826086957, 1.625, 0.16666666666667
84412, 1.6347826086957, 1.65, 0.13888888888889
84413, 1.6130434782609, 1.65, 0.11111111111111
84414, 1.6347826086957, 1.625, 0.11111111111111
84415, 1.6347826086957, 1.65, 0.083333333333333
84416, 1.6130434782609, 1.65, 0.055555555555556
84417, 1.6347826086957, 1.625, 0.055555555555556
84418, 1.6347826086957, 1.65, 0.027777777777778
84419, 1.6782608695652, 1.65, 0.47222222222222
84420, 1.6565217391304, 1.65, 0.44444444444444
84421, 1.6782608695652, 1.625, 0.44444444444444
84422, 1.6782608695652, 1.65, 0.41666666666667
84423, 1.6565217391304, 1.65, 0.38888888888889
84424, 1.6782608695652, 1.625, 0.38888888888889
84425, 1.6782608695652, 1.65, 0.36111111111111
84426, 1.6565217391304, 1.65, 0.33333333333333
84427, 1.6782608695652, 1.625, 0.33333333333333
84428, 1.6782608695652, 1.65, 0.30555555555556
84429, 1.6565217391304, 1.65, 0.27777777777778
84430, 1.6782608695652, 1.625, 0.27777777777778
84431, 1.6782608695652, 1.65, 0.25
84432, 1.6565217391304, 1.65, 0.22222222222222
84433, 1.6782608695652, 1.625, 0.22222222222222
84434, 1.6782608695652, 1.65, 0.19444444444444
84435, 1.6565217391304, 1.65, 0.16666666666667
84436, 1.6782608695652, 1.625, 0.16666666666667
84437, 1.6782608695652, 1.65, 0.13888888888889
84438, 1.6565217391304, 1.65, 0.11111111111111
84439, 1.6782608695652, 1.625, 0.11111111111111
84440, 1.6782608695652, 1.65, 0.083333333333333
84441, 1.6565217391304, 1.65, 0.055555555555556
84442, 1.6782608695652, 1.625, 0.055555555555556
84443, 1.6782608695652, 1.65, 0.027777777777778
84444, 1.7217391304348, 1.65, 0.47222222222222
84445, 1.7, 1.65, 0.44444444444444
84446, 1.7217391304348, 1.625, 0.44444444444444
84447, 1.7217391304348, 1.65, 0.41666666666667
84448, 1.7, 1.65, 0.38888888888889
84449, 1.7217391304348, 1.625, 0.38888888888889
84450, 1.7217391304348, 1.65, 0.36111111111111
84451, 1.7, 1.65, 0.33333333333333
84452, 1.7217391304348, 1.625, 0.33333333333333
84453, 1.7217391304348, 1.65, 0.30555555555556
84454, 1.7, 1.65, 0.27777777777778
84455, 1.7217391304348, 1.625, 0.27777777777778
84456, 1.7217391304348, 1.65, 0.25
84457, 1.7, 1.65, 0.22222222222222
84458, 1.7217391304348, 1.625, 0.22222222222222
84459, 1.7217391304348, 1.65, 0.19444444444444
84460, 1.7, 1.65, 0.16666666666667
84461, 1.7217391304348, 1.625, 0.16666666666667
84462, 1.7217391304348, 1.65, 0.13888888888889
84463, 1.7, 1.65, 0.11111111111111
84464, 1.7217391304348, 1.625, 0.11111111111111
84465, 1.7217391304348, 1.65, 0.083333333333333
84466, 1.7, 1.65, 0.055555555555556
84467, 1.7217391304348, 1.625, 0.055555555555556
84468, 1.7217391304348, 1.65, 0.027777777777778
84469, 1.7652173913043, 1.65, 0.47222222222222
84470, 1.7434782608696, 1.65, 0.44444444444444
84471, 1.7652173913043, 1.625, 0.44444444444444
84472, 1.7652173913043, 1.65, 0.41666666666667
84473, 1.7434782608696, 1.65, 0.38888888888889
84474, 1.7652173913043, 1.625, 0.38888888888889
84475, 1.7652173913043, 1.65, 0.36111111111111
84476, 1.7434782608696, 1.65, 0.33333333333333
84477, 1.7652173913043, 1.625, 0.33333333333333
84478, 1.7652173913043, 1.65, 0.30555555555556
84479, 1.7434782608696, 1.65, 0.27777777777778
84480, 1.7652173913043, 1.625, 0.27777777777778
84481, 1.7652173913043, 1.65, 0.25
84482, 1.7434782608696, 1.65, 0.22222222222222
84483, 1.7652173913043, 1.625, 0.22222222222222
84484, 1.7652173913043, 1.65, 0.19444444444444
84485, 1.7434782608696, 1.65, 0.16666666666667
84486, 1.7652173913043, 1.625, 0.16666666666667
84487, 1.7652173913043, 1.65, 0.13888888888889
84488, 1.7434782608696, 1.65, 0.11111111111111
84489, 1.7652173913043, 1.625, 0.11111111111111
84490, 1.7652173913043, 1.65, 0.083333333333333
84491, 1.7434782608696, 1.65, 0.055555555555556
84492, 1.7652173913043, 1.625, 0.055555555555556
84493, 1.7652173913043, 1.65, 0.027777777777778
84494, 1.8086956521739, 1.65, 0.47222222222222
84495, 1.7869565217391, 1.65, 0.44444444444444
84496, 1.8086956521739, 1.625, 0.44444444444444
84497, 1.8086956521739, 1.65, 0.41666666666667
84498, 1.7869565217391, 1.65, 0.38888888888889
84499, 1.8086956521739, 1.625, 0.38888888888889
84500, 1.8086956521739, 1.65, 0.36111111111111
84501, 1.7869565217391, 1.65, 0.33333333333333
84502, 1.8086956521739, 1.625, 0.33333333333333
84503, 1.8086956521739, 1.65, 0.30555555555556
84504, 1.7869565217391, 1.65, 0.27777777777778
84505, 1.8086956521739, 1.625, 0.27777777777778
84506, 1.8086956521739, 1.65, 0.25
84507, 1.7869565217391, 1.65, 0.22222222222222
84508, 1.8086956521739, 1.625, 0.22222222222222
84509, 1.8086956521739, 1.65, 0.19444444444444
84510, 1.7869565217391, 1.65, 0.16666666666667
84511, 1.8086956521739, 1.625, 0.16666666666667
84512, 1.8086956521739, 1.65, 0.13888888888889
84513, 1.7869565217391, 1.65, 0.11111111111111
84514, 1.8086956521739, 1.625, 0.11111111111111
84515, 1.8086956521739, 1.65, 0.083333333333333
84516, 1.7869565217391, 1.65, 0.055555555555556
84517, 1.8086956521739, 1.625, 0.055555555555556
84518, 1.8086956521739, 1.65, 0.027777777777778
84519, 1.8521739130435, 1.65, 0.47222222222222
84520, 1.8304347826087, 1.65, 0.44444444444444
84521, 1.8521739130435, 1.625, 0.44444444444444
84522, 1.8521739130435, 1.65, 0.41666666666667
84523, 1.8304347826087, 1.65, 0.38888888888889
84524, 1.8521739130435, 1.625, 0.38888888888889
84525, 1.8521739130435, 1.65, 0.36111111111111
84526, 1.8304347826087, 1.65, 0.33333333333333
84527, 1.8521739130435, 1.625, 0.33333333333333
84528, 1.8521739130435, 1.65, 0.30555555555556
84529, 1.8304347826087, 1.65, 0.27777777777778
84530, 1.8521739130435, 1.625, 0.27777777777778
84531, 1.8521739130435, 1.65, 0.25
84532, 1.8304347826087, 1.65, 0.22222222222222
84533, 1.8521739130435, 1.625, 0.22222222222222
84534, 1.8521739130435, 1.65, 0.19444444444444
84535, 1.8304347826087, 1.65, 0.16666666666667
84536, 1.8521739130435, 1.625, 0.16666666666667
84537, 1.8521739130435, 1.65, 0.13888888888889
84538, 1.8304347826087, 1.65, 0.11111111111111
84539, 1.8521739130435, 1.625, 0.11111111111111
84540, 1.8521739130435, 1.65, 0.083333333333333
84541, 1.8304347826087, 1.65, 0.055555555555556
84542, 1.8521739130435, 1.625, 0.055555555555556
84543, 1.8521739130435, 1.65, 0.027777777777778
84544, 1.895652173913, 1.65, 0.47222222222222
84545, 1.8739130434783, 1.65, 0.44444444444444
84546, 1.895652173913, 1.625, 0.44444444444444
84547, 1.895652173913, 1.65, 0.41666666666667
84548, 1.8739130434783, 1.65, 0.38888888888889
84549, 1.895652173913, 1.625, 0.38888888888889
84550, 1.895652173913, 1.65, 0.36111111111111
84551, 1.8739130434783, 1.65, 0.33333333333333
84552, 1.895652173913, 1.625, 0.33333333333333
84553, 1.895652173913, 1.65, 0.30555555555556
84554, 1.8739130434783, 1.65, 0.27777777777778
84555, 1.895652173913, 1.625, 0.27777777777778
84556, 1.895652173913, 1.65, 0.25
84557, 1.8739130434783, 1.65, 0.22222222222222
84558, 1.895652173913, 1.625, 0.22222222222222
84559, 1.895652173913, 1.65, 0.19444444444444
84560, 1.8739130434783, 1.65, 0.16666666666667
84561, 1.895652173913, 1.625, 0.16666666666667
84562, 1.895652173913, 1.65, 0.13888888888889
84563, 1.8739130434783, 1.65, 0.11111111111111
84564, 1.895652173913, 1.625, 0.11111111111111
84565, 1.895652173913, 1.65, 0.083333333333333
84566, 1.8739130434783, 1.65, 0.055555555555556
84567, 1.895652173913, 1.625, 0.055555555555556
84568, 1.895652173913, 1.65, 0.027777777777778
84569, 1.9391304347826, 1.65, 0.47222222222222
84570, 1.9173913043478, 1.65, 0.44444444444444
84571, 1.9391304347826, 1.625, 0.44444444444444
84572, 1.9391304347826, 1.65, 0.41666666666667
84573, 1.9173913043478, 1.65, 0.38888888888889
84574, 1.9391304347826, 1.625, 0.38888888888889
84575, 1.9391304347826, 1.65, 0.36111111111111
84576, 1.9173913043478, 1.65, 0.33333333333333
84577, 1.9391304347826, 1.625, 0.33333333333333
84578, 1.9391304347826, 1.65, 0.30555555555556
84579, 1.9173913043478, 1.65, 0.27777777777778
84580, 1.9391304347826, 1.625, 0.27777777777778
84581, 1.9391304347826, 1.65, 0.25
84582, 1.9173913043478, 1.65, 0.22222222222222
84583, 1.9391304347826, 1.625, 0.22222222222222
84584, 1.9391304347826, 1.65, 0.19444444444444
84585, 1.9173913043478, 1.65, 0.16666666666667
84586, 1.9391304347826, 1.625, 0.16666666666667
84587, 1.9391304347826, 1.65, 0.13888888888889
84588, 1.9173913043478, 1.65, 0.11111111111111
84589, 1.9391304347826, 1.625, 0.11111111111111
84590, 1.9391304347826, 1.65, 0.083333333333333
84591, 1.9173913043478, 1.65, 0.055555555555556
84592, 1.9391304347826, 1.625, 0.055555555555556
84593, 1.9391304347826, 1.65, 0.027777777777778
84594, 1.9826086956522, 1.65, 0.47222222222222
84595, 1.9608695652174, 1.65, 0.44444444444444
84596, 1.9826086956522, 1.625, 0.44444444444444
84597, 1.9826086956522, 1.65, 0.41666666666667
84598, 1.9608695652174, 1.65, 0.38888888888889
84599, 1.9826086956522, 1.625, 0.38888888888889
84600, 1.9826086956522, 1.65, 0.36111111111111
84601, 1.9608695652174, 1.65, 0.33333333333333
84602, 1.9826086956522, 1.625, 0.33333333333333
84603, 1.9826086956522, 1.65, 0.30555555555556
84604, 1.9608695652174, 1.65, 0.27777777777778
84605, 1.9826086956522, 1.625, 0.27777777777778
84606, 1.9826086956522, 1.65, 0.25
84607, 1.9608695652174, 1.65, 0.22222222222222
84608, 1.9826086956522, 1.625, 0.22222222222222
84609, 1.9826086956522, 1.65, 0.19444444444444
84610, 1.9608695652174, 1.65, 0.16666666666667
84611, 1.9826086956522, 1.625, 0.16666666666667
84612, 1.9826086956522, 1.65, 0.13888888888889
84613, 1.9608695652174, 1.65, 0.11111111111111
84614, 1.9826086956522, 1.625, 0.11111111111111
84615, 1.9826086956522, 1.65, 0.083333333333333
84616, 1.9608695652174, 1.65, 0.055555555555556
84617, 1.9826086956522, 1.625, 0.055555555555556
84618, 1.9826086956522, 1.65, 0.027777777777778
84619, 2.0260869565217, 1.65, 0.47222222222222
84620, 2.004347826087, 1.65, 0.44444444444444
84621, 2.0260869565217, 1.625, 0.44444444444444
84622, 2.0260869565217, 1.65, 0.41666666666667
84623, 2.004347826087, 1.65, 0.38888888888889
84624, 2.0260869565217, 1.625, 0.38888888888889
84625, 2.0260869565217, 1.65, 0.36111111111111
84626, 2.004347826087, 1.65, 0.33333333333333
84627, 2.0260869565217, 1.625, 0.33333333333333
84628, 2.0260869565217, 1.65, 0.30555555555556
84629, 2.004347826087, 1.65, 0.27777777777778
84630, 2.0260869565217, 1.625, 0.27777777777778
84631, 2.0260869565217, 1.65, 0.25
84632, 2.004347826087, 1.65, 0.22222222222222
84633, 2.0260869565217, 1.625, 0.22222222222222
84634, 2.0260869565217, 1.65, 0.19444444444444
84635, 2.004347826087, 1.65, 0.16666666666667
84636, 2.0260869565217, 1.625, 0.16666666666667
84637, 2.0260869565217, 1.65, 0.13888888888889
84638, 2.004347826087, 1.65, 0.11111111111111
84639, 2.0260869565217, 1.625, 0.11111111111111
84640, 2.0260869565217, 1.65, 0.083333333333333
84641, 2.004347826087, 1.65, 0.055555555555556
84642, 2.0260869565217, 1.625, 0.055555555555556
84643, 2.0260869565217, 1.65, 0.027777777777778
84644, 2.0695652173913, 1.65, 0.47222222222222
84645, 2.0478260869565, 1.65, 0.44444444444444
84646, 2.0695652173913, 1.625, 0.44444444444444
84647, 2.0695652173913, 1.65, 0.41666666666667
84648, 2.0478260869565, 1.65, 0.38888888888889
84649, 2.0695652173913, 1.625, 0.38888888888889
84650, 2.0695652173913, 1.65, 0.36111111111111
84651, 2.0478260869565, 1.65, 0.33333333333333
84652, 2.0695652173913, 1.625, 0.33333333333333
84653, 2.0695652173913, 1.65, 0.30555555555556
84654, 2.0478260869565, 1.65, 0.27777777777778
84655, 2.0695652173913, 1.625, 0.27777777777778
84656, 2.0695652173913, 1.65, 0.25
84657, 2.0478260869565, 1.65, 0.22222222222222
84658, 2.0695652173913, 1.625, 0.22222222222222
84659, 2.0695652173913, 1.65, 0.19444444444444
84660, 2.0478260869565, 1.65, 0.16666666666667
84661, 2.0695652173913, 1.625, 0.16666666666667
84662, 2.0695652173913, 1.65, 0.13888888888889
84663, 2.0478260869565, 1.65, 0.11111111111111
84664, 2.0695652173913, 1.625, 0.11111111111111
84665, 2.0695652173913, 1.65, 0.083333333333333
84666, 2.0478260869565, 1.65, 0.055555555555556
84667, 2.0695652173913, 1.625, 0.055555555555556
84668, 2.0695652173913, 1.65, 0.027777777777778
84669, 2.1130434782609, 1.65, 0.47222222222222
84670, 2.0913043478261, 1.65, 0.44444444444444
84671, 2.1130434782609, 1.625, 0.44444444444444
84672, 2.1130434782609, 1.65, 0.41666666666667
84673, 2.0913043478261, 1.65, 0.38888888888889
84674, 2.1130434782609, 1.625, 0.38888888888889
84675, 2.1130434782609, 1.65, 0.36111111111111
84676, 2.0913043478261, 1.65, 0.33333333333333
84677, 2.1130434782609, 1.625, 0.33333333333333
84678, 2.1130434782609, 1.65, 0.30555555555556
84679, 2.0913043478261, 1.65, 0.27777777777778
84680, 2.1130434782609, 1.625, 0.27777777777778
84681, 2.1130434782609, 1.65, 0.25
84682, 2.0913043478261, 1.65, 0.22222222222222
84683, 2.1130434782609, 1.625, 0.22222222222222
84684, 2.1130434782609, 1.65, 0.19444444444444
84685, 2.0913043478261, 1.65, 0.16666666666667
84686, 2.1130434782609, 1.625, 0.16666666666667
84687, 2.1130434782609, 1.65, 0.13888888888889
84688, 2.0913043478261, 1.65, 0.11111111111111
84689, 2.1130434782609, 1.625, 0.11111111111111
84690, 2.1130434782609, 1.65, 0.083333333333333
84691, 2.0913043478261, 1.65, 0.055555555555556
84692, 2.1130434782609, 1.625, 0.055555555555556
84693, 2.1130434782609, 1.65, 0.027777777777778
84694, 2.1565217391304, 1.65, 0.47222222222222
84695, 2.1347826086957, 1.65, 0.44444444444444
84696, 2.1565217391304, 1.625, 0.44444444444444
84697, 2.1565217391304, 1.65, 0.41666666666667
84698, 2.1347826086957, 1.65, 0.38888888888889
84699, 2.1565217391304, 1.625, 0.38888888888889
84700, 2.1565217391304, 1.65, 0.36111111111111
84701, 2.1347826086957, 1.65, 0.33333333333333
84702, 2.1565217391304, 1.625, 0.33333333333333
84703, 2.1565217391304, 1.65, 0.30555555555556
84704, 2.1347826086957, 1.65, 0.27777777777778
84705, 2.1565217391304, 1.625, 0.27777777777778
84706, 2.1565217391304, 1.65, 0.25
84707, 2.1347826086957, 1.65, 0.22222222222222
84708, 2.1565217391304, 1.625, 0.22222222222222
84709, 2.1565217391304, 1.65, 0.19444444444444
84710, 2.1347826086957, 1.65, 0.16666666666667
84711, 2.1565217391304, 1.625, 0.16666666666667
84712, 2.1565217391304, 1.65, 0.13888888888889
84713, 2.1347826086957, 1.65, 0.11111111111111
84714, 2.1565217391304, 1.625, 0.11111111111111
84715, 2.1565217391304, 1.65, 0.083333333333333
84716, 2.1347826086957, 1.65, 0.055555555555556
84717, 2.1565217391304, 1.625, 0.055555555555556
84718, 2.1565217391304, 1.65, 0.027777777777778
84719, 2.1782608695652, 1.65, 0.44444444444444
84720, 2.1782608695652, 1.65, 0.38888888888889
84721, 2.1782608695652, 1.65, 0.33333333333333
84722, 2.1782608695652, 1.65, 0.27777777777778
84723, 2.1782608695652, 1.65, 0.22222222222222
84724, 2.1782608695652, 1.65, 0.16666666666667
84725, 2.1782608695652, 1.65, 0.11111111111111
84726, 2.1782608695652, 1.65, 0.055555555555556
84727, 1.2434782608696, 1.7, 0.47222222222222
84728, 1.2217391304348, 1.7, 0.44444444444444
84729, 1.2434782608696, 1.675, 0.44444444444444
84730, 1.2434782608696, 1.7, 0.41666666666667
84731, 1.2217391304348, 1.7, 0.38888888888889
84732, 1.2434782608696, 1.675, 0.38888888888889
84733, 1.2434782608696, 1.7, 0.36111111111111
84734, 1.2217391304348, 1.7, 0.33333333333333
84735, 1.2434782608696, 1.675, 0.33333333333333
84736, 1.2434782608696, 1.7, 0.30555555555556
84737, 1.2217391304348, 1.7, 0.27777777777778
84738, 1.2434782608696, 1.675, 0.27777777777778
84739, 1.2434782608696, 1.7, 0.25
84740, 1.2217391304348, 1.7, 0.22222222222222
84741, 1.2434782608696, 1.675, 0.22222222222222
84742, 1.2434782608696, 1.7, 0.19444444444444
84743, 1.2217391304348, 1.7, 0.16666666666667
84744, 1.2434782608696, 1.675, 0.16666666666667
84745, 1.2434782608696, 1.7, 0.13888888888889
84746, 1.2217391304348, 1.7, 0.11111111111111
84747, 1.2434782608696, 1.675, 0.11111111111111
84748, 1.2434782608696, 1.7, 0.083333333333333
84749, 1.2217391304348, 1.7, 0.055555555555556
84750, 1.2434782608696, 1.675, 0.055555555555556
84751, 1.2434782608696, 1.7, 0.027777777777778
84752, 1.2869565217391, 1.7, 0.47222222222222
84753, 1.2652173913043, 1.7, 0.44444444444444
84754, 1.2869565217391, 1.675, 0.44444444444444
84755, 1.2869565217391, 1.7, 0.41666666666667
84756, 1.2652173913043, 1.7, 0.38888888888889
84757, 1.2869565217391, 1.675, 0.38888888888889
84758, 1.2869565217391, 1.7, 0.36111111111111
84759, 1.2652173913043, 1.7, 0.33333333333333
84760, 1.2869565217391, 1.675, 0.33333333333333
84761, 1.2869565217391, 1.7, 0.30555555555556
84762, 1.2652173913043, 1.7, 0.27777777777778
84763, 1.2869565217391, 1.675, 0.27777777777778
84764, 1.2869565217391, 1.7, 0.25
84765, 1.2652173913043, 1.7, 0.22222222222222
84766, 1.2869565217391, 1.675, 0.22222222222222
84767, 1.2869565217391, 1.7, 0.19444444444444
84768, 1.2652173913043, 1.7, 0.16666666666667
84769, 1.2869565217391, 1.675, 0.16666666666667
84770, 1.2869565217391, 1.7, 0.13888888888889
84771, 1.2652173913043, 1.7, 0.11111111111111
84772, 1.2869565217391, 1.675, 0.11111111111111
84773, 1.2869565217391, 1.7, 0.083333333333333
84774, 1.2652173913043, 1.7, 0.055555555555556
84775, 1.2869565217391, 1.675, 0.055555555555556
84776, 1.2869565217391, 1.7, 0.027777777777778
84777, 1.3304347826087, 1.7, 0.47222222222222
84778, 1.3086956521739, 1.7, 0.44444444444444
84779, 1.3304347826087, 1.675, 0.44444444444444
84780, 1.3304347826087, 1.7, 0.41666666666667
84781, 1.3086956521739, 1.7, 0.38888888888889
84782, 1.3304347826087, 1.675, 0.38888888888889
84783, 1.3304347826087, 1.7, 0.36111111111111
84784, 1.3086956521739, 1.7, 0.33333333333333
84785, 1.3304347826087, 1.675, 0.33333333333333
84786, 1.3304347826087, 1.7, 0.30555555555556
84787, 1.3086956521739, 1.7, 0.27777777777778
84788, 1.3304347826087, 1.675, 0.27777777777778
84789, 1.3304347826087, 1.7, 0.25
84790, 1.3086956521739, 1.7, 0.22222222222222
84791, 1.3304347826087, 1.675, 0.22222222222222
84792, 1.3304347826087, 1.7, 0.19444444444444
84793, 1.3086956521739, 1.7, 0.16666666666667
84794, 1.3304347826087, 1.675, 0.16666666666667
84795, 1.3304347826087, 1.7, 0.13888888888889
84796, 1.3086956521739, 1.7, 0.11111111111111
84797, 1.3304347826087, 1.675, 0.11111111111111
84798, 1.3304347826087, 1.7, 0.083333333333333
84799, 1.3086956521739, 1.7, 0.055555555555556
84800, 1.3304347826087, 1.675, 0.055555555555556
84801, 1.3304347826087, 1.7, 0.027777777777778
84802, 1.3739130434783, 1.7, 0.47222222222222
84803, 1.3521739130435, 1.7, 0.44444444444444
84804, 1.3739130434783, 1.675, 0.44444444444444
84805, 1.3739130434783, 1.7, 0.41666666666667
84806, 1.3521739130435, 1.7, 0.38888888888889
84807, 1.3739130434783, 1.675, 0.38888888888889
84808, 1.3739130434783, 1.7, 0.36111111111111
84809, 1.3521739130435, 1.7, 0.33333333333333
84810, 1.3739130434783, 1.675, 0.33333333333333
84811, 1.3739130434783, 1.7, 0.30555555555556
84812, 1.3521739130435, 1.7, 0.27777777777778
84813, 1.3739130434783, 1.675, 0.27777777777778
84814, 1.3739130434783, 1.7, 0.25
84815, 1.3521739130435, 1.7, 0.22222222222222
84816, 1.3739130434783, 1.675, 0.22222222222222
84817, 1.3739130434783, 1.7, 0.19444444444444
84818, 1.3521739130435, 1.7, 0.16666666666667
84819, 1.3739130434783, 1.675, 0.16666666666667
84820, 1.3739130434783, 1.7, 0.13888888888889
84821, 1.3521739130435, 1.7, 0.11111111111111
84822, 1.3739130434783, 1.675, 0.11111111111111
84823, 1.3739130434783, 1.7, 0.083333333333333
84824, 1.3521739130435, 1.7, 0.055555555555556
84825, 1.3739130434783, 1.675, 0.055555555555556
84826, 1.3739130434783, 1.7, 0.027777777777778
84827, 1.4173913043478, 1.7, 0.47222222222222
84828, 1.395652173913, 1.7, 0.44444444444444
84829, 1.4173913043478, 1.675, 0.44444444444444
84830, 1.4173913043478, 1.7, 0.41666666666667
84831, 1.395652173913, 1.7, 0.38888888888889
84832, 1.4173913043478, 1.675, 0.38888888888889
84833, 1.4173913043478, 1.7, 0.36111111111111
84834, 1.395652173913, 1.7, 0.33333333333333
84835, 1.4173913043478, 1.675, 0.33333333333333
84836, 1.4173913043478, 1.7, 0.30555555555556
84837, 1.395652173913, 1.7, 0.27777777777778
84838, 1.4173913043478, 1.675, 0.27777777777778
84839, 1.4173913043478, 1.7, 0.25
84840, 1.395652173913, 1.7, 0.22222222222222
84841, 1.4173913043478, 1.675, 0.22222222222222
84842, 1.4173913043478, 1.7, 0.19444444444444
84843, 1.395652173913, 1.7, 0.16666666666667
84844, 1.4173913043478, 1.675, 0.16666666666667
84845, 1.4173913043478, 1.7, 0.13888888888889
84846, 1.395652173913, 1.7, 0.11111111111111
84847, 1.4173913043478, 1.675, 0.11111111111111
84848, 1.4173913043478, 1.7, 0.083333333333333
84849, 1.395652173913, 1.7, 0.055555555555556
84850, 1.4173913043478, 1.675, 0.055555555555556
84851, 1.4173913043478, 1.7, 0.027777777777778
84852, 1.4608695652174, 1.7, 0.47222222222222
84853, 1.4391304347826, 1.7, 0.44444444444444
84854, 1.4608695652174, 1.675, 0.44444444444444
84855, 1.4608695652174, 1.7, 0.41666666666667
84856, 1.4391304347826, 1.7, 0.38888888888889
84857, 1.4608695652174, 1.675, 0.38888888888889
84858, 1.4608695652174, 1.7, 0.36111111111111
84859, 1.4391304347826, 1.7, 0.33333333333333
84860, 1.4608695652174, 1.675, 0.33333333333333
84861, 1.4608695652174, 1.7, 0.30555555555556
84862, 1.4391304347826, 1.7, 0.27777777777778
84863, 1.4608695652174, 1.675, 0.27777777777778
84864, 1.4608695652174, 1.7, 0.25
84865, 1.4391304347826, 1.7, 0.22222222222222
84866, 1.4608695652174, 1.675, 0.22222222222222
84867, 1.4608695652174, 1.7, 0.19444444444444
84868, 1.4391304347826, 1.7, 0.16666666666667
84869, 1.4608695652174, 1.675, 0.16666666666667
84870, 1.4608695652174, 1.7, 0.13888888888889
84871, 1.4391304347826, 1.7, 0.11111111111111
84872, 1.4608695652174, 1.675, 0.11111111111111
84873, 1.4608695652174, 1.7, 0.083333333333333
84874, 1.4391304347826, 1.7, 0.055555555555556
84875, 1.4608695652174, 1.675, 0.055555555555556
84876, 1.4608695652174, 1.7, 0.027777777777778
84877, 1.504347826087, 1.7, 0.47222222222222
84878, 1.4826086956522, 1.7, 0.44444444444444
84879, 1.504347826087, 1.675, 0.44444444444444
84880, 1.504347826087, 1.7, 0.41666666666667
84881, 1.4826086956522, 1.7, 0.38888888888889
84882, 1.504347826087, 1.675, 0.38888888888889
84883, 1.504347826087, 1.7, 0.36111111111111
84884, 1.4826086956522, 1.7, 0.33333333333333
84885, 1.504347826087, 1.675, 0.33333333333333
84886, 1.504347826087, 1.7, 0.30555555555556
84887, 1.4826086956522, 1.7, 0.27777777777778
84888, 1.504347826087, 1.675, 0.27777777777778
84889, 1.504347826087, 1.7, 0.25
84890, 1.4826086956522, 1.7, 0.22222222222222
84891, 1.504347826087, 1.675, 0.22222222222222
84892, 1.504347826087, 1.7, 0.19444444444444
84893, 1.4826086956522, 1.7, 0.16666666666667
84894, 1.504347826087, 1.675, 0.16666666666667
84895, 1.504347826087, 1.7, 0.13888888888889
84896, 1.4826086956522, 1.7, 0.11111111111111
84897, 1.504347826087, 1.675, 0.11111111111111
84898, 1.504347826087, 1.7, 0.083333333333333
84899, 1.4826086956522, 1.7, 0.055555555555556
84900, 1.504347826087, 1.675, 0.055555555555556
84901, 1.504347826087, 1.7, 0.027777777777778
84902, 1.5478260869565, 1.7, 0.47222222222222
84903, 1.5260869565217, 1.7, 0.44444444444444
84904, 1.5478260869565, 1.675, 0.44444444444444
84905, 1.5478260869565, 1.7, 0.41666666666667
84906, 1.5260869565217, 1.7, 0.38888888888889
84907, 1.5478260869565, 1.675, 0.38888888888889
84908, 1.5478260869565, 1.7, 0.36111111111111
84909, 1.5260869565217, 1.7, 0.33333333333333
84910, 1.5478260869565, 1.675, 0.33333333333333
84911, 1.5478260869565, 1.7, 0.30555555555556
84912, 1.5260869565217, 1.7, 0.27777777777778
84913, 1.5478260869565, 1.675, 0.27777777777778
84914, 1.5478260869565, 1.7, 0.25
84915, 1.5260869565217, 1.7, 0.22222222222222
84916, 1.5478260869565, 1.675, 0.22222222222222
84917, 1.5478260869565, 1.7, 0.19444444444444
84918, 1.5260869565217, 1.7, 0.16666666666667
84919, 1.5478260869565, 1.675, 0.16666666666667
84920, 1.5478260869565, 1.7, 0.13888888888889
84921, 1.5260869565217, 1.7, 0.11111111111111
84922, 1.5478260869565, 1.675, 0.11111111111111
84923, 1.5478260869565, 1.7, 0.083333333333333
84924, 1.5260869565217, 1.7, 0.055555555555556
84925, 1.5478260869565, 1.675, 0.055555555555556
84926, 1.5478260869565, 1.7, 0.027777777777778
84927, 1.5913043478261, 1.7, 0.47222222222222
84928, 1.5695652173913, 1.7, 0.44444444444444
84929, 1.5913043478261, 1.675, 0.44444444444444
84930, 1.5913043478261, 1.7, 0.41666666666667
84931, 1.5695652173913, 1.7, 0.38888888888889
84932, 1.5913043478261, 1.675, 0.38888888888889
84933, 1.5913043478261, 1.7, 0.36111111111111
84934, 1.5695652173913, 1.7, 0.33333333333333
84935, 1.5913043478261, 1.675, 0.33333333333333
84936, 1.5913043478261, 1.7, 0.30555555555556
84937, 1.5695652173913, 1.7, 0.27777777777778
84938, 1.5913043478261, 1.675, 0.27777777777778
84939, 1.5913043478261, 1.7, 0.25
84940, 1.5695652173913, 1.7, 0.22222222222222
84941, 1.5913043478261, 1.675, 0.22222222222222
84942, 1.5913043478261, 1.7, 0.19444444444444
84943, 1.5695652173913, 1.7, 0.16666666666667
84944, 1.5913043478261, 1.675, 0.16666666666667
84945, 1.5913043478261, 1.7, 0.13888888888889
84946, 1.5695652173913, 1.7, 0.11111111111111
84947, 1.5913043478261, 1.675, 0.11111111111111
84948, 1.5913043478261, 1.7, 0.083333333333333
84949, 1.5695652173913, 1.7, 0.055555555555556
84950, 1.5913043478261, 1.675, 0.055555555555556
84951, 1.5913043478261, 1.7, 0.027777777777778
84952, 1.6347826086957, 1.7, 0.47222222222222
84953, 1.6130434782609, 1.7, 0.44444444444444
84954, 1.6347826086957, 1.675, 0.44444444444444
84955, 1.6347826086957, 1.7, 0.41666666666667
84956, 1.6130434782609, 1.7, 0.38888888888889
84957, 1.6347826086957, 1.675, 0.38888888888889
84958, 1.6347826086957, 1.7, 0.36111111111111
84959, 1.6130434782609, 1.7, 0.33333333333333
84960, 1.6347826086957, 1.675, 0.33333333333333
84961, 1.6347826086957, 1.7, 0.30555555555556
84962, 1.6130434782609, 1.7, 0.27777777777778
84963, 1.6347826086957, 1.675, 0.27777777777778
84964, 1.6347826086957, 1.7, 0.25
84965, 1.6130434782609, 1.7, 0.22222222222222
84966, 1.6347826086957, 1.675, 0.22222222222222
84967, 1.6347826086957, 1.7, 0.19444444444444
84968, 1.6130434782609, 1.7, 0.16666666666667
84969, 1.6347826086957, 1.675, 0.16666666666667
84970, 1.6347826086957, 1.7, 0.13888888888889
84971, 1.6130434782609, 1.7, 0.11111111111111
84972, 1.6347826086957, 1.675, 0.11111111111111
84973, 1.6347826086957, 1.7, 0.083333333333333
84974, 1.6130434782609, 1.7, 0.055555555555556
84975, 1.6347826086957, 1.675, 0.055555555555556
84976, 1.6347826086957, 1.7, 0.027777777777778
84977, 1.6782608695652, 1.7, 0.47222222222222
84978, 1.6565217391304, 1.7, 0.44444444444444
84979, 1.6782608695652, 1.675, 0.44444444444444
84980, 1.6782608695652, 1.7, 0.41666666666667
84981, 1.6565217391304, 1.7, 0.38888888888889
84982, 1.6782608695652, 1.675, 0.38888888888889
84983, 1.6782608695652, 1.7, 0.36111111111111
84984, 1.6565217391304, 1.7, 0.33333333333333
84985, 1.6782608695652, 1.675, 0.33333333333333
84986, 1.6782608695652, 1.7, 0.30555555555556
84987, 1.6565217391304, 1.7, 0.27777777777778
84988, 1.6782608695652, 1.675, 0.27777777777778
84989, 1.6782608695652, 1.7, 0.25
84990, 1.6565217391304, 1.7, 0.22222222222222
84991, 1.6782608695652, 1.675, 0.22222222222222
84992, 1.6782608695652, 1.7, 0.19444444444444
84993, 1.6565217391304, 1.7, 0.16666666666667
84994, 1.6782608695652, 1.675, 0.16666666666667
84995, 1.6782608695652, 1.7, 0.13888888888889
84996, 1.6565217391304, 1.7, 0.11111111111111
84997, 1.6782608695652, 1.675, 0.11111111111111
84998, 1.6782608695652, 1.7, 0.083333333333333
84999, 1.6565217391304, 1.7, 0.055555555555556
85000, 1.6782608695652, 1.675, 0.055555555555556
85001, 1.6782608695652, 1.7, 0.027777777777778
85002, 1.7217391304348, 1.7, 0.47222222222222
85003, 1.7, 1.7, 0.44444444444444
85004, 1.7217391304348, 1.675, 0.44444444444444
85005, 1.7217391304348, 1.7, 0.41666666666667
85006, 1.7, 1.7, 0.38888888888889
85007, 1.7217391304348, 1.675, 0.38888888888889
85008, 1.7217391304348, 1.7, 0.36111111111111
85009, 1.7, 1.7, 0.33333333333333
85010, 1.7217391304348, 1.675, 0.33333333333333
85011, 1.7217391304348, 1.7, 0.30555555555556
85012, 1.7, 1.7, 0.27777777777778
85013, 1.7217391304348, 1.675, 0.27777777777778
85014, 1.7217391304348, 1.7, 0.25
85015, 1.7, 1.7, 0.22222222222222
85016, 1.7217391304348, 1.675, 0.22222222222222
85017, 1.7217391304348, 1.7, 0.19444444444444
85018, 1.7, 1.7, 0.16666666666667
85019, 1.7217391304348, 1.675, 0.16666666666667
85020, 1.7217391304348, 1.7, 0.13888888888889
85021, 1.7, 1.7, 0.11111111111111
85022, 1.7217391304348, 1.675, 0.11111111111111
85023, 1.7217391304348, 1.7, 0.083333333333333
85024, 1.7, 1.7, 0.055555555555556
85025, 1.7217391304348, 1.675, 0.055555555555556
85026, 1.7217391304348, 1.7, 0.027777777777778
85027, 1.7652173913043, 1.7, 0.47222222222222
85028, 1.7434782608696, 1.7, 0.44444444444444
85029, 1.7652173913043, 1.675, 0.44444444444444
85030, 1.7652173913043, 1.7, 0.41666666666667
85031, 1.7434782608696, 1.7, 0.38888888888889
85032, 1.7652173913043, 1.675, 0.38888888888889
85033, 1.7652173913043, 1.7, 0.36111111111111
85034, 1.7434782608696, 1.7, 0.33333333333333
85035, 1.7652173913043, 1.675, 0.33333333333333
85036, 1.7652173913043, 1.7, 0.30555555555556
85037, 1.7434782608696, 1.7, 0.27777777777778
85038, 1.7652173913043, 1.675, 0.27777777777778
85039, 1.7652173913043, 1.7, 0.25
85040, 1.7434782608696, 1.7, 0.22222222222222
85041, 1.7652173913043, 1.675, 0.22222222222222
85042, 1.7652173913043, 1.7, 0.19444444444444
85043, 1.7434782608696, 1.7, 0.16666666666667
85044, 1.7652173913043, 1.675, 0.16666666666667
85045, 1.7652173913043, 1.7, 0.13888888888889
85046, 1.7434782608696, 1.7, 0.11111111111111
85047, 1.7652173913043, 1.675, 0.11111111111111
85048, 1.7652173913043, 1.7, 0.083333333333333
85049, 1.7434782608696, 1.7, 0.055555555555556
85050, 1.7652173913043, 1.675, 0.055555555555556
85051, 1.7652173913043, 1.7, 0.027777777777778
85052, 1.8086956521739, 1.7, 0.47222222222222
85053, 1.7869565217391, 1.7, 0.44444444444444
85054, 1.8086956521739, 1.675, 0.44444444444444
85055, 1.8086956521739, 1.7, 0.41666666666667
85056, 1.7869565217391, 1.7, 0.38888888888889
85057, 1.8086956521739, 1.675, 0.38888888888889
85058, 1.8086956521739, 1.7, 0.36111111111111
85059, 1.7869565217391, 1.7, 0.33333333333333
85060, 1.8086956521739, 1.675, 0.33333333333333
85061, 1.8086956521739, 1.7, 0.30555555555556
85062, 1.7869565217391, 1.7, 0.27777777777778
85063, 1.8086956521739, 1.675, 0.27777777777778
85064, 1.8086956521739, 1.7, 0.25
85065, 1.7869565217391, 1.7, 0.22222222222222
85066, 1.8086956521739, 1.675, 0.22222222222222
85067, 1.8086956521739, 1.7, 0.19444444444444
85068, 1.7869565217391, 1.7, 0.16666666666667
85069, 1.8086956521739, 1.675, 0.16666666666667
85070, 1.8086956521739, 1.7, 0.13888888888889
85071, 1.7869565217391, 1.7, 0.11111111111111
85072, 1.8086956521739, 1.675, 0.11111111111111
85073, 1.8086956521739, 1.7, 0.083333333333333
85074, 1.7869565217391, 1.7, 0.055555555555556
85075, 1.8086956521739, 1.675, 0.055555555555556
85076, 1.8086956521739, 1.7, 0.027777777777778
85077, 1.8521739130435, 1.7, 0.47222222222222
85078, 1.8304347826087, 1.7, 0.44444444444444
85079, 1.8521739130435, 1.675, 0.44444444444444
85080, 1.8521739130435, 1.7, 0.41666666666667
85081, 1.8304347826087, 1.7, 0.38888888888889
85082, 1.8521739130435, 1.675, 0.38888888888889
85083, 1.8521739130435, 1.7, 0.36111111111111
85084, 1.8304347826087, 1.7, 0.33333333333333
85085, 1.8521739130435, 1.675, 0.33333333333333
85086, 1.8521739130435, 1.7, 0.30555555555556
85087, 1.8304347826087, 1.7, 0.27777777777778
85088, 1.8521739130435, 1.675, 0.27777777777778
85089, 1.8521739130435, 1.7, 0.25
85090, 1.8304347826087, 1.7, 0.22222222222222
85091, 1.8521739130435, 1.675, 0.22222222222222
85092, 1.8521739130435, 1.7, 0.19444444444444
85093, 1.8304347826087, 1.7, 0.16666666666667
85094, 1.8521739130435, 1.675, 0.16666666666667
85095, 1.8521739130435, 1.7, 0.13888888888889
85096, 1.8304347826087, 1.7, 0.11111111111111
85097, 1.8521739130435, 1.675, 0.11111111111111
85098, 1.8521739130435, 1.7, 0.083333333333333
85099, 1.8304347826087, 1.7, 0.055555555555556
85100, 1.8521739130435, 1.675, 0.055555555555556
85101, 1.8521739130435, 1.7, 0.027777777777778
85102, 1.895652173913, 1.7, 0.47222222222222
85103, 1.8739130434783, 1.7, 0.44444444444444
85104, 1.895652173913, 1.675, 0.44444444444444
85105, 1.895652173913, 1.7, 0.41666666666667
85106, 1.8739130434783, 1.7, 0.38888888888889
85107, 1.895652173913, 1.675, 0.38888888888889
85108, 1.895652173913, 1.7, 0.36111111111111
85109, 1.8739130434783, 1.7, 0.33333333333333
85110, 1.895652173913, 1.675, 0.33333333333333
85111, 1.895652173913, 1.7, 0.30555555555556
85112, 1.8739130434783, 1.7, 0.27777777777778
85113, 1.895652173913, 1.675, 0.27777777777778
85114, 1.895652173913, 1.7, 0.25
85115, 1.8739130434783, 1.7, 0.22222222222222
85116, 1.895652173913, 1.675, 0.22222222222222
85117, 1.895652173913, 1.7, 0.19444444444444
85118, 1.8739130434783, 1.7, 0.16666666666667
85119, 1.895652173913, 1.675, 0.16666666666667
85120, 1.895652173913, 1.7, 0.13888888888889
85121, 1.8739130434783, 1.7, 0.11111111111111
85122, 1.895652173913, 1.675, 0.11111111111111
85123, 1.895652173913, 1.7, 0.083333333333333
85124, 1.8739130434783, 1.7, 0.055555555555556
85125, 1.895652173913, 1.675, 0.055555555555556
85126, 1.895652173913, 1.7, 0.027777777777778
85127, 1.9391304347826, 1.7, 0.47222222222222
85128, 1.9173913043478, 1.7, 0.44444444444444
85129, 1.9391304347826, 1.675, 0.44444444444444
85130, 1.9391304347826, 1.7, 0.41666666666667
85131, 1.9173913043478, 1.7, 0.38888888888889
85132, 1.9391304347826, 1.675, 0.38888888888889
85133, 1.9391304347826, 1.7, 0.36111111111111
85134, 1.9173913043478, 1.7, 0.33333333333333
85135, 1.9391304347826, 1.675, 0.33333333333333
85136, 1.9391304347826, 1.7, 0.30555555555556
85137, 1.9173913043478, 1.7, 0.27777777777778
85138, 1.9391304347826, 1.675, 0.27777777777778
85139, 1.9391304347826, 1.7, 0.25
85140, 1.9173913043478, 1.7, 0.22222222222222
85141, 1.9391304347826, 1.675, 0.22222222222222
85142, 1.9391304347826, 1.7, 0.19444444444444
85143, 1.9173913043478, 1.7, 0.16666666666667
85144, 1.9391304347826, 1.675, 0.16666666666667
85145, 1.9391304347826, 1.7, 0.13888888888889
85146, 1.9173913043478, 1.7, 0.11111111111111
85147, 1.9391304347826, 1.675, 0.11111111111111
85148, 1.9391304347826, 1.7, 0.083333333333333
85149, 1.9173913043478, 1.7, 0.055555555555556
85150, 1.9391304347826, 1.675, 0.055555555555556
85151, 1.9391304347826, 1.7, 0.027777777777778
85152, 1.9826086956522, 1.7, 0.47222222222222
85153, 1.9608695652174, 1.7, 0.44444444444444
85154, 1.9826086956522, 1.675, 0.44444444444444
85155, 1.9826086956522, 1.7, 0.41666666666667
85156, 1.9608695652174, 1.7, 0.38888888888889
85157, 1.9826086956522, 1.675, 0.38888888888889
85158, 1.9826086956522, 1.7, 0.36111111111111
85159, 1.9608695652174, 1.7, 0.33333333333333
85160, 1.9826086956522, 1.675, 0.33333333333333
85161, 1.9826086956522, 1.7, 0.30555555555556
85162, 1.9608695652174, 1.7, 0.27777777777778
85163, 1.9826086956522, 1.675, 0.27777777777778
85164, 1.9826086956522, 1.7, 0.25
85165, 1.9608695652174, 1.7, 0.22222222222222
85166, 1.9826086956522, 1.675, 0.22222222222222
85167, 1.9826086956522, 1.7, 0.19444444444444
85168, 1.9608695652174, 1.7, 0.16666666666667
85169, 1.9826086956522, 1.675, 0.16666666666667
85170, 1.9826086956522, 1.7, 0.13888888888889
85171, 1.9608695652174, 1.7, 0.11111111111111
85172, 1.9826086956522, 1.675, 0.11111111111111
85173, 1.9826086956522, 1.7, 0.083333333333333
85174, 1.9608695652174, 1.7, 0.055555555555556
85175, 1.9826086956522, 1.675, 0.055555555555556
85176, 1.9826086956522, 1.7, 0.027777777777778
85177, 2.0260869565217, 1.7, 0.47222222222222
85178, 2.004347826087, 1.7, 0.44444444444444
85179, 2.0260869565217, 1.675, 0.44444444444444
85180, 2.0260869565217, 1.7, 0.41666666666667
85181, 2.004347826087, 1.7, 0.38888888888889
85182, 2.0260869565217, 1.675, 0.38888888888889
85183, 2.0260869565217, 1.7, 0.36111111111111
85184, 2.004347826087, 1.7, 0.33333333333333
85185, 2.0260869565217, 1.675, 0.33333333333333
85186, 2.0260869565217, 1.7, 0.30555555555556
85187, 2.004347826087, 1.7, 0.27777777777778
85188, 2.0260869565217, 1.675, 0.27777777777778
85189, 2.0260869565217, 1.7, 0.25
85190, 2.004347826087, 1.7, 0.22222222222222
85191, 2.0260869565217, 1.675, 0.22222222222222
85192, 2.0260869565217, 1.7, 0.19444444444444
85193, 2.004347826087, 1.7, 0.16666666666667
85194, 2.0260869565217, 1.675, 0.16666666666667
85195, 2.0260869565217, 1.7, 0.13888888888889
85196, 2.004347826087, 1.7, 0.11111111111111
85197, 2.0260869565217, 1.675, 0.11111111111111
85198, 2.0260869565217, 1.7, 0.083333333333333
85199, 2.004347826087, 1.7, 0.055555555555556
85200, 2.0260869565217, 1.675, 0.055555555555556
85201, 2.0260869565217, 1.7, 0.027777777777778
85202, 2.0695652173913, 1.7, 0.47222222222222
85203, 2.0478260869565, 1.7, 0.44444444444444
85204, 2.0695652173913, 1.675, 0.44444444444444
85205, 2.0695652173913, 1.7, 0.41666666666667
85206, 2.0478260869565, 1.7, 0.38888888888889
85207, 2.0695652173913, 1.675, 0.38888888888889
85208, 2.0695652173913, 1.7, 0.36111111111111
85209, 2.0478260869565, 1.7, 0.33333333333333
85210, 2.0695652173913, 1.675, 0.33333333333333
85211, 2.0695652173913, 1.7, 0.30555555555556
85212, 2.0478260869565, 1.7, 0.27777777777778
85213, 2.0695652173913, 1.675, 0.27777777777778
85214, 2.0695652173913, 1.7, 0.25
85215, 2.0478260869565, 1.7, 0.22222222222222
85216, 2.0695652173913, 1.675, 0.22222222222222
85217, 2.0695652173913, 1.7, 0.19444444444444
85218, 2.0478260869565, 1.7, 0.16666666666667
85219, 2.0695652173913, 1.675, 0.16666666666667
85220, 2.0695652173913, 1.7, 0.13888888888889
85221, 2.0478260869565, 1.7, 0.11111111111111
85222, 2.0695652173913, 1.675, 0.11111111111111
85223, 2.0695652173913, 1.7, 0.083333333333333
85224, 2.0478260869565, 1.7, 0.055555555555556
85225, 2.0695652173913, 1.675, 0.055555555555556
85226, 2.0695652173913, 1.7, 0.027777777777778
85227, 2.1130434782609, 1.7, 0.47222222222222
85228, 2.0913043478261, 1.7, 0.44444444444444
85229, 2.1130434782609, 1.675, 0.44444444444444
85230, 2.1130434782609, 1.7, 0.41666666666667
85231, 2.0913043478261, 1.7, 0.38888888888889
85232, 2.1130434782609, 1.675, 0.38888888888889
85233, 2.1130434782609, 1.7, 0.36111111111111
85234, 2.0913043478261, 1.7, 0.33333333333333
85235, 2.1130434782609, 1.675, 0.33333333333333
85236, 2.1130434782609, 1.7, 0.30555555555556
85237, 2.0913043478261, 1.7, 0.27777777777778
85238, 2.1130434782609, 1.675, 0.27777777777778
85239, 2.1130434782609, 1.7, 0.25
85240, 2.0913043478261, 1.7, 0.22222222222222
85241, 2.1130434782609, 1.675, 0.22222222222222
85242, 2.1130434782609, 1.7, 0.19444444444444
85243, 2.0913043478261, 1.7, 0.16666666666667
85244, 2.1130434782609, 1.675, 0.16666666666667
85245, 2.1130434782609, 1.7, 0.13888888888889
85246, 2.0913043478261, 1.7, 0.11111111111111
85247, 2.1130434782609, 1.675, 0.11111111111111
85248, 2.1130434782609, 1.7, 0.083333333333333
85249, 2.0913043478261, 1.7, 0.055555555555556
85250, 2.1130434782609, 1.675, 0.055555555555556
85251, 2.1130434782609, 1.7, 0.027777777777778
85252, 2.1565217391304, 1.7, 0.47222222222222
85253, 2.1347826086957, 1.7, 0.44444444444444
85254, 2.1565217391304, 1.675, 0.44444444444444
85255, 2.1565217391304, 1.7, 0.41666666666667
85256, 2.1347826086957, 1.7, 0.38888888888889
85257, 2.1565217391304, 1.675, 0.38888888888889
85258, 2.1565217391304, 1.7, 0.36111111111111
85259, 2.1347826086957, 1.7, 0.33333333333333
85260, 2.1565217391304, 1.675, 0.33333333333333
85261, 2.1565217391304, 1.7, 0.30555555555556
85262, 2.1347826086957, 1.7, 0.27777777777778
85263, 2.1565217391304, 1.675, 0.27777777777778
85264, 2.1565217391304, 1.7, 0.25
85265, 2.1347826086957, 1.7, 0.22222222222222
85266, 2.1565217391304, 1.675, 0.22222222222222
85267, 2.1565217391304, 1.7, 0.19444444444444
85268, 2.1347826086957, 1.7, 0.16666666666667
85269, 2.1565217391304, 1.675, 0.16666666666667
85270, 2.1565217391304, 1.7, 0.13888888888889
85271, 2.1347826086957, 1.7, 0.11111111111111
85272, 2.1565217391304, 1.675, 0.11111111111111
85273, 2.1565217391304, 1.7, 0.083333333333333
85274, 2.1347826086957, 1.7, 0.055555555555556
85275, 2.1565217391304, 1.675, 0.055555555555556
85276, 2.1565217391304, 1.7, 0.027777777777778
85277, 2.1782608695652, 1.7, 0.44444444444444
85278, 2.1782608695652, 1.7, 0.38888888888889
85279, 2.1782608695652, 1.7, 0.33333333333333
85280, 2.1782608695652, 1.7, 0.27777777777778
85281, 2.1782608695652, 1.7, 0.22222222222222
85282, 2.1782608695652, 1.7, 0.16666666666667
85283, 2.1782608695652, 1.7, 0.11111111111111
85284, 2.1782608695652, 1.7, 0.055555555555556
85285, 1.2434782608696, 1.725, 0.44444444444444
85286, 1.2434782608696, 1.725, 0.38888888888889
85287, 1.2434782608696, 1.725, 0.33333333333333
85288, 1.2434782608696, 1.725, 0.27777777777778
85289, 1.2434782608696, 1.725, 0.22222222222222
85290, 1.2434782608696, 1.725, 0.16666666666667
85291, 1.2434782608696, 1.725, 0.11111111111111
85292, 1.2434782608696, 1.725, 0.055555555555556
85293, 1.2869565217391, 1.725, 0.44444444444444
85294, 1.2869565217391, 1.725, 0.38888888888889
85295, 1.2869565217391, 1.725, 0.33333333333333
85296, 1.2869565217391, 1.725, 0.27777777777778
85297, 1.2869565217391, 1.725, 0.22222222222222
85298, 1.2869565217391, 1.725, 0.16666666666667
85299, 1.2869565217391, 1.725, 0.11111111111111
85300, 1.2869565217391, 1.725, 0.055555555555556
85301, 1.3304347826087, 1.725, 0.44444444444444
85302, 1.3304347826087, 1.725, 0.38888888888889
85303, 1.3304347826087, 1.725, 0.33333333333333
85304, 1.3304347826087, 1.725, 0.27777777777778
85305, 1.3304347826087, 1.725, 0.22222222222222
85306, 1.3304347826087, 1.725, 0.16666666666667
85307, 1.3304347826087, 1.725, 0.11111111111111
85308, 1.3304347826087, 1.725, 0.055555555555556
85309, 1.3739130434783, 1.725, 0.44444444444444
85310, 1.3739130434783, 1.725, 0.38888888888889
85311, 1.3739130434783, 1.725, 0.33333333333333
85312, 1.3739130434783, 1.725, 0.27777777777778
85313, 1.3739130434783, 1.725, 0.22222222222222
85314, 1.3739130434783, 1.725, 0.16666666666667
85315, 1.3739130434783, 1.725, 0.11111111111111
85316, 1.3739130434783, 1.725, 0.055555555555556
85317, 1.4173913043478, 1.725, 0.44444444444444
85318, 1.4173913043478, 1.725, 0.38888888888889
85319, 1.4173913043478, 1.725, 0.33333333333333
85320, 1.4173913043478, 1.725, 0.27777777777778
85321, 1.4173913043478, 1.725, 0.22222222222222
85322, 1.4173913043478, 1.725, 0.16666666666667
85323, 1.4173913043478, 1.725, 0.11111111111111
85324, 1.4173913043478, 1.725, 0.055555555555556
85325, 1.4608695652174, 1.725, 0.44444444444444
85326, 1.4608695652174, 1.725, 0.38888888888889
85327, 1.4608695652174, 1.725, 0.33333333333333
85328, 1.4608695652174, 1.725, 0.27777777777778
85329, 1.4608695652174, 1.725, 0.22222222222222
85330, 1.4608695652174, 1.725, 0.16666666666667
85331, 1.4608695652174, 1.725, 0.11111111111111
85332, 1.4608695652174, 1.725, 0.055555555555556
85333, 1.504347826087, 1.725, 0.44444444444444
85334, 1.504347826087, 1.725, 0.38888888888889
85335, 1.504347826087, 1.725, 0.33333333333333
85336, 1.504347826087, 1.725, 0.27777777777778
85337, 1.504347826087, 1.725, 0.22222222222222
85338, 1.504347826087, 1.725, 0.16666666666667
85339, 1.504347826087, 1.725, 0.11111111111111
85340, 1.504347826087, 1.725, 0.055555555555556
85341, 1.5478260869565, 1.725, 0.44444444444444
85342, 1.5478260869565, 1.725, 0.38888888888889
85343, 1.5478260869565, 1.725, 0.33333333333333
85344, 1.5478260869565, 1.725, 0.27777777777778
85345, 1.5478260869565, 1.725, 0.22222222222222
85346, 1.5478260869565, 1.725, 0.16666666666667
85347, 1.5478260869565, 1.725, 0.11111111111111
85348, 1.5478260869565, 1.725, 0.055555555555556
85349, 1.5913043478261, 1.725, 0.44444444444444
85350, 1.5913043478261, 1.725, 0.38888888888889
85351, 1.5913043478261, 1.725, 0.33333333333333
85352, 1.5913043478261, 1.725, 0.27777777777778
85353, 1.5913043478261, 1.725, 0.22222222222222
85354, 1.5913043478261, 1.725, 0.16666666666667
85355, 1.5913043478261, 1.725, 0.11111111111111
85356, 1.5913043478261, 1.725, 0.055555555555556
85357, 1.6347826086957, 1.725, 0.44444444444444
85358, 1.6347826086957, 1.725, 0.38888888888889
85359, 1.6347826086957, 1.725, 0.33333333333333
85360, 1.6347826086957, 1.725, 0.27777777777778
85361, 1.6347826086957, 1.725, 0.22222222222222
85362, 1.6347826086957, 1.725, 0.16666666666667
85363, 1.6347826086957, 1.725, 0.11111111111111
85364, 1.6347826086957, 1.725, 0.055555555555556
85365, 1.6782608695652, 1.725, 0.44444444444444
85366, 1.6782608695652, 1.725, 0.38888888888889
85367, 1.6782608695652, 1.725, 0.33333333333333
85368, 1.6782608695652, 1.725, 0.27777777777778
85369, 1.6782608695652, 1.725, 0.22222222222222
85370, 1.6782608695652, 1.725, 0.16666666666667
85371, 1.6782608695652, 1.725, 0.11111111111111
85372, 1.6782608695652, 1.725, 0.055555555555556
85373, 1.7217391304348, 1.725, 0.44444444444444
85374, 1.7217391304348, 1.725, 0.38888888888889
85375, 1.7217391304348, 1.725, 0.33333333333333
85376, 1.7217391304348, 1.725, 0.27777777777778
85377, 1.7217391304348, 1.725, 0.22222222222222
85378, 1.7217391304348, 1.725, 0.16666666666667
85379, 1.7217391304348, 1.725, 0.11111111111111
85380, 1.7217391304348, 1.725, 0.055555555555556
85381, 1.7652173913043, 1.725, 0.44444444444444
85382, 1.7652173913043, 1.725, 0.38888888888889
85383, 1.7652173913043, 1.725, 0.33333333333333
85384, 1.7652173913043, 1.725, 0.27777777777778
85385, 1.7652173913043, 1.725, 0.22222222222222
85386, 1.7652173913043, 1.725, 0.16666666666667
85387, 1.7652173913043, 1.725, 0.11111111111111
85388, 1.7652173913043, 1.725, 0.055555555555556
85389, 1.8086956521739, 1.725, 0.44444444444444
85390, 1.8086956521739, 1.725, 0.38888888888889
85391, 1.8086956521739, 1.725, 0.33333333333333
85392, 1.8086956521739, 1.725, 0.27777777777778
85393, 1.8086956521739, 1.725, 0.22222222222222
85394, 1.8086956521739, 1.725, 0.16666666666667
85395, 1.8086956521739, 1.725, 0.11111111111111
85396, 1.8086956521739, 1.725, 0.055555555555556
85397, 1.8521739130435, 1.725, 0.44444444444444
85398, 1.8521739130435, 1.725, 0.38888888888889
85399, 1.8521739130435, 1.725, 0.33333333333333
85400, 1.8521739130435, 1.725, 0.27777777777778
85401, 1.8521739130435, 1.725, 0.22222222222222
85402, 1.8521739130435, 1.725, 0.16666666666667
85403, 1.8521739130435, 1.725, 0.11111111111111
85404, 1.8521739130435, 1.725, 0.055555555555556
85405, 1.895652173913, 1.725, 0.44444444444444
85406, 1.895652173913, 1.725, 0.38888888888889
85407, 1.895652173913, 1.725, 0.33333333333333
85408, 1.895652173913, 1.725, 0.27777777777778
85409, 1.895652173913, 1.725, 0.22222222222222
85410, 1.895652173913, 1.725, 0.16666666666667
85411, 1.895652173913, 1.725, 0.11111111111111
85412, 1.895652173913, 1.725, 0.055555555555556
85413, 1.9391304347826, 1.725, 0.44444444444444
85414, 1.9391304347826, 1.725, 0.38888888888889
85415, 1.9391304347826, 1.725, 0.33333333333333
85416, 1.9391304347826, 1.725, 0.27777777777778
85417, 1.9391304347826, 1.725, 0.22222222222222
85418, 1.9391304347826, 1.725, 0.16666666666667
85419, 1.9391304347826, 1.725, 0.11111111111111
85420, 1.9391304347826, 1.725, 0.055555555555556
85421, 1.9826086956522, 1.725, 0.44444444444444
85422, 1.9826086956522, 1.725, 0.38888888888889
85423, 1.9826086956522, 1.725, 0.33333333333333
85424, 1.9826086956522, 1.725, 0.27777777777778
85425, 1.9826086956522, 1.725, 0.22222222222222
85426, 1.9826086956522, 1.725, 0.16666666666667
85427, 1.9826086956522, 1.725, 0.11111111111111
85428, 1.9826086956522, 1.725, 0.055555555555556
85429, 2.0260869565217, 1.725, 0.44444444444444
85430, 2.0260869565217, 1.725, 0.38888888888889
85431, 2.0260869565217, 1.725, 0.33333333333333
85432, 2.0260869565217, 1.725, 0.27777777777778
85433, 2.0260869565217, 1.725, 0.22222222222222
85434, 2.0260869565217, 1.725, 0.16666666666667
85435, 2.0260869565217, 1.725, 0.11111111111111
85436, 2.0260869565217, 1.725, 0.055555555555556
85437, 2.0695652173913, 1.725, 0.44444444444444
85438, 2.0695652173913, 1.725, 0.38888888888889
85439, 2.0695652173913, 1.725, 0.33333333333333
85440, 2.0695652173913, 1.725, 0.27777777777778
85441, 2.0695652173913, 1.725, 0.22222222222222
85442, 2.0695652173913, 1.725, 0.16666666666667
85443, 2.0695652173913, 1.725, 0.11111111111111
85444, 2.0695652173913, 1.725, 0.055555555555556
85445, 2.1130434782609, 1.725, 0.44444444444444
85446, 2.1130434782609, 1.725, 0.38888888888889
85447, 2.1130434782609, 1.725, 0.33333333333333
85448, 2.1130434782609, 1.725, 0.27777777777778
85449, 2.1130434782609, 1.725, 0.22222222222222
85450, 2.1130434782609, 1.725, 0.16666666666667
85451, 2.1130434782609, 1.725, 0.11111111111111
85452, 2.1130434782609, 1.725, 0.055555555555556
85453, 2.1565217391304, 1.725, 0.44444444444444
85454, 2.1565217391304, 1.725, 0.38888888888889
85455, 2.1565217391304, 1.725, 0.33333333333333
85456, 2.1565217391304, 1.725, 0.27777777777778
85457, 2.1565217391304, 1.725, 0.22222222222222
85458, 2.1565217391304, 1.725, 0.16666666666667
85459, 2.1565217391304, 1.725, 0.11111111111111
85460, 2.1565217391304, 1.725, 0.055555555555556
85461, 0.95652173913043, -0.1, 0.055555555555556
85462, 0.95652173913043, -0.1, 0.11111111111111
85463, 0.95652173913043, -0.1, 0.16666666666667
85464, 0.95652173913043, -0.1, 0.22222222222222
85465, 0.95652173913043, -0.1, 0.27777777777778
85466, 0.95652173913043, -0.1, 0.33333333333333
85467, 0.95652173913043, -0.1, 0.38888888888889
85468, 0.95652173913043, -0.1, 0.44444444444444
85469, 0.91304347826087, -0.1, 0.055555555555556
85470, 0.91304347826087, -0.1, 0.11111111111111
85471, 0.91304347826087, -0.1, 0.16666666666667
85472, 0.91304347826087, -0.1, 0.22222222222222
85473, 0.91304347826087, -0.1, 0.27777777777778
85474, 0.91304347826087, -0.1, 0.33333333333333
85475, 0.91304347826087, -0.1, 0.38888888888889
85476, 0.91304347826087, -0.1, 0.44444444444444
85477, 0.8695652173913, -0.1, 0.055555555555556
85478, 0.8695652173913, -0.1, 0.11111111111111
85479, 0.8695652173913, -0.1, 0.16666666666667
85480, 0.8695652173913, -0.1, 0.22222222222222
85481, 0.8695652173913, -0.1, 0.27777777777778
85482, 0.8695652173913, -0.1, 0.33333333333333
85483, 0.8695652173913, -0.1, 0.38888888888889
85484, 0.8695652173913, -0.1, 0.44444444444444
85485, 0.82608695652174, -0.1, 0.055555555555556
85486, 0.82608695652174, -0.1, 0.11111111111111
85487, 0.82608695652174, -0.1, 0.16666666666667
85488, 0.82608695652174, -0.1, 0.22222222222222
85489, 0.82608695652174, -0.1, 0.27777777777778
85490, 0.82608695652174, -0.1, 0.33333333333333
85491, 0.82608695652174, -0.1, 0.38888888888889
85492, 0.82608695652174, -0.1, 0.44444444444444
85493, 0.78260869565217, -0.1, 0.055555555555556
85494, 0.78260869565217, -0.1, 0.11111111111111
85495, 0.78260869565217, -0.1, 0.16666666666667
85496, 0.78260869565217, -0.1, 0.22222222222222
85497, 0.78260869565217, -0.1, 0.27777777777778
85498, 0.78260869565217, -0.1, 0.33333333333333
85499, 0.78260869565217, -0.1, 0.38888888888889
85500, 0.78260869565217, -0.1, 0.44444444444444
85501, 0.73913043478261, -0.1, 0.055555555555556
85502, 0.73913043478261, -0.1, 0.11111111111111
85503, 0.73913043478261, -0.1, 0.16666666666667
85504, 0.73913043478261, -0.1, 0.22222222222222
85505, 0.73913043478261, -0.1, 0.27777777777778
85506, 0.73913043478261, -0.1, 0.33333333333333
85507, 0.73913043478261, -0.1, 0.38888888888889
85508, 0.73913043478261, -0.1, 0.44444444444444
85509, 0.69565217391304, -0.1, 0.055555555555556
85510, 0.69565217391304, -0.1, 0.11111111111111
85511, 0.69565217391304, -0.1, 0.16666666666667
85512, 0.69565217391304, -0.1, 0.22222222222222
85513, 0.69565217391304, -0.1, 0.27777777777778
85514, 0.69565217391304, -0.1, 0.33333333333333
85515, 0.69565217391304, -0.1, 0.38888888888889
85516, 0.69565217391304, -0.1, 0.44444444444444
85517, 0.65217391304348, -0.1, 0.055555555555556
85518, 0.65217391304348, -0.1, 0.11111111111111
85519, 0.65217391304348, -0.1, 0.16666666666667
85520, 0.65217391304348, -0.1, 0.22222222222222
85521, 0.65217391304348, -0.1, 0.27777777777778
85522, 0.65217391304348, -0.1, 0.33333333333333
85523, 0.65217391304348, -0.1, 0.38888888888889
85524, 0.65217391304348, -0.1, 0.44444444444444
85525, 0.60869565217391, -0.1, 0.055555555555556
85526, 0.60869565217391, -0.1, 0.11111111111111
85527, 0.60869565217391, -0.1, 0.16666666666667
85528, 0.60869565217391, -0.1, 0.22222222222222
85529, 0.60869565217391, -0.1, 0.27777777777778
85530, 0.60869565217391, -0.1, 0.33333333333333
85531, 0.60869565217391, -0.1, 0.38888888888889
85532, 0.60869565217391, -0.1, 0.44444444444444
85533, 0.56521739130435, -0.1, 0.055555555555556
85534, 0.56521739130435, -0.1, 0.11111111111111
85535, 0.56521739130435, -0.1, 0.16666666666667
85536, 0.56521739130435, -0.1, 0.22222222222222
