87605, 0.08695652173913, -0.2, 0.027777777777778
87606, 0.10869565217391, -0.2, 0.055555555555556
87607, 0.08695652173913, -0.175, 0.055555555555556
87608, 0.08695652173913, -0.2, 0.083333333333333
87609, 0.10869565217391, -0.2, 0.11111111111111
87610, 0.08695652173913, -0.175, 0.11111111111111
87611, 0.08695652173913, -0.2, 0.13888888888889
87612, 0.10869565217391, -0.2, 0.16666666666667
87613, 0.08695652173913, -0.175, 0.16666666666667
87614, 0.08695652173913, -0.2, 0.19444444444444
87615, 0.10869565217391, -0.2, 0.22222222222222
87616, 0.08695652173913, -0.175, 0.22222222222222
87617, 0.08695652173913, -0.2, 0.25
87618, 0.10869565217391, -0.2, 0.27777777777778
87619, 0.08695652173913, -0.175, 0.27777777777778
87620, 0.08695652173913, -0.2, 0.30555555555556
87621, 0.10869565217391, -0.2, 0.33333333333333
87622, 0.08695652173913, -0.175, 0.33333333333333
87623, 0.08695652173913, -0.2, 0.36111111111111
87624, 0.10869565217391, -0.2, 0.38888888888889
87625, 0.08695652173913, -0.175, 0.38888888888889
87626, 0.08695652173913, -0.2, 0.41666666666667
87627, 0.10869565217391, -0.2, 0.44444444444444
87628, 0.08695652173913, -0.175, 0.44444444444444
87629, 0.08695652173913, -0.2, 0.47222222222222
87630, 0.043478260869565, -0.2, 0.027777777777778
87631, 0.065217391304348, -0.2, 0.055555555555556
87632, 0.043478260869565, -0.175, 0.055555555555556
87633, 0.043478260869565, -0.2, 0.083333333333333
87634, 0.065217391304348, -0.2, 0.11111111111111
87635, 0.043478260869565, -0.175, 0.11111111111111
87636, 0.043478260869565, -0.2, 0.13888888888889
87637, 0.065217391304348, -0.2, 0.16666666666667
87638, 0.043478260869565, -0.175, 0.16666666666667
87639, 0.043478260869565, -0.2, 0.19444444444444
87640, 0.065217391304348, -0.2, 0.22222222222222
87641, 0.043478260869565, -0.175, 0.22222222222222
87642, 0.043478260869565, -0.2, 0.25
87643, 0.065217391304348, -0.2, 0.27777777777778
87644, 0.043478260869565, -0.175, 0.27777777777778
87645, 0.043478260869565, -0.2, 0.30555555555556
87646, 0.065217391304348, -0.2, 0.33333333333333
87647, 0.043478260869565, -0.175, 0.33333333333333
87648, 0.043478260869565, -0.2, 0.36111111111111
87649, 0.065217391304348, -0.2, 0.38888888888889
87650, 0.043478260869565, -0.175, 0.38888888888889
87651, 0.043478260869565, -0.2, 0.41666666666667
87652, 0.065217391304348, -0.2, 0.44444444444444
87653, 0.043478260869565, -0.175, 0.44444444444444
87654, 0.043478260869565, -0.2, 0.47222222222222
87655, 0.021739130434783, -0.2, 0.055555555555556
87656, 0.021739130434783, -0.2, 0.11111111111111
87657, 0.021739130434783, -0.2, 0.16666666666667
87658, 0.021739130434783, -0.2, 0.22222222222222
87659, 0.021739130434783, -0.2, 0.27777777777778
87660, 0.021739130434783, -0.2, 0.33333333333333
87661, 0.021739130434783, -0.2, 0.38888888888889
87662, 0.021739130434783, -0.2, 0.44444444444444
87663, 0.95652173913043, -0.225, 0.055555555555556
87664, 0.95652173913044, -0.225, 0.11111111111111
87665, 0.95652173913043, -0.225, 0.16666666666667
87666, 0.95652173913043, -0.225, 0.22222222222222
87667, 0.95652173913043, -0.225, 0.27777777777778
87668, 0.95652173913043, -0.225, 0.33333333333333
87669, 0.95652173913043, -0.225, 0.38888888888889
87670, 0.95652173913043, -0.225, 0.44444444444444
87671, 0.91304347826087, -0.225, 0.055555555555556
87672, 0.91304347826087, -0.225, 0.11111111111111
87673, 0.91304347826087, -0.225, 0.16666666666667
87674, 0.91304347826087, -0.225, 0.22222222222222
87675, 0.91304347826087, -0.225, 0.27777777777778
87676, 0.91304347826087, -0.225, 0.33333333333333
87677, 0.91304347826087, -0.225, 0.38888888888889
87678, 0.91304347826087, -0.225, 0.44444444444444
87679, 0.8695652173913, -0.225, 0.055555555555556
87680, 0.8695652173913, -0.225, 0.11111111111111
87681, 0.8695652173913, -0.225, 0.16666666666667
87682, 0.8695652173913, -0.225, 0.22222222222222
87683, 0.8695652173913, -0.225, 0.27777777777778
87684, 0.8695652173913, -0.225, 0.33333333333333
87685, 0.8695652173913, -0.225, 0.38888888888889
87686, 0.8695652173913, -0.225, 0.44444444444444
87687, 0.82608695652174, -0.225, 0.055555555555556
87688, 0.82608695652174, -0.225, 0.11111111111111
87689, 0.82608695652174, -0.225, 0.16666666666667
87690, 0.82608695652174, -0.225, 0.22222222222222
87691, 0.82608695652174, -0.225, 0.27777777777778
87692, 0.82608695652174, -0.225, 0.33333333333333
87693, 0.82608695652174, -0.225, 0.38888888888889
87694, 0.82608695652174, -0.225, 0.44444444444444
87695, 0.78260869565217, -0.225, 0.055555555555556
87696, 0.78260869565217, -0.225, 0.11111111111111
87697, 0.78260869565217, -0.225, 0.16666666666667
87698, 0.78260869565217, -0.225, 0.22222222222222
87699, 0.78260869565217, -0.225, 0.27777777777778
87700, 0.78260869565217, -0.225, 0.33333333333333
87701, 0.78260869565217, -0.225, 0.38888888888889
87702, 0.78260869565217, -0.225, 0.44444444444444
87703, 0.73913043478261, -0.225, 0.055555555555556
87704, 0.73913043478261, -0.225, 0.11111111111111
87705, 0.73913043478261, -0.225, 0.16666666666667
87706, 0.73913043478261, -0.225, 0.22222222222222
87707, 0.73913043478261, -0.225, 0.27777777777778
87708, 0.73913043478261, -0.225, 0.33333333333333
87709, 0.73913043478261, -0.225, 0.38888888888889
87710, 0.73913043478261, -0.225, 0.44444444444444
87711, 0.69565217391304, -0.225, 0.055555555555556
87712, 0.69565217391304, -0.225, 0.11111111111111
87713, 0.69565217391304, -0.225, 0.16666666666667
87714, 0.69565217391304, -0.225, 0.22222222222222
87715, 0.69565217391304, -0.225, 0.27777777777778
87716, 0.69565217391304, -0.225, 0.33333333333333
87717, 0.69565217391304, -0.225, 0.38888888888889
87718, 0.69565217391304, -0.225, 0.44444444444444
87719, 0.65217391304348, -0.225, 0.055555555555556
87720, 0.65217391304348, -0.225, 0.11111111111111
87721, 0.65217391304348, -0.225, 0.16666666666667
87722, 0.65217391304348, -0.225, 0.22222222222222
87723, 0.65217391304348, -0.225, 0.27777777777778
87724, 0.65217391304348, -0.225, 0.33333333333333
87725, 0.65217391304348, -0.225, 0.38888888888889
87726, 0.65217391304348, -0.225, 0.44444444444444
87727, 0.60869565217391, -0.225, 0.055555555555556
87728, 0.60869565217391, -0.225, 0.11111111111111
87729, 0.60869565217391, -0.225, 0.16666666666667
87730, 0.60869565217391, -0.225, 0.22222222222222
87731, 0.60869565217391, -0.225, 0.27777777777778
87732, 0.60869565217391, -0.225, 0.33333333333333
87733, 0.60869565217391, -0.225, 0.38888888888889
87734, 0.60869565217391, -0.225, 0.44444444444444
87735, 0.56521739130435, -0.225, 0.055555555555556
87736, 0.56521739130435, -0.225, 0.11111111111111
87737, 0.56521739130435, -0.225, 0.16666666666667
87738, 0.56521739130435, -0.225, 0.22222222222222
87739, 0.56521739130435, -0.225, 0.27777777777778
87740, 0.56521739130435, -0.225, 0.33333333333333
87741, 0.56521739130435, -0.225, 0.38888888888889
87742, 0.56521739130435, -0.225, 0.44444444444444
87743, 0.52173913043478, -0.225, 0.055555555555556
87744, 0.52173913043478, -0.225, 0.11111111111111
87745, 0.52173913043478, -0.225, 0.16666666666667
87746, 0.52173913043478, -0.225, 0.22222222222222
87747, 0.52173913043478, -0.225, 0.27777777777778
87748, 0.52173913043478, -0.225, 0.33333333333333
87749, 0.52173913043478, -0.225, 0.38888888888889
87750, 0.52173913043478, -0.225, 0.44444444444444
87751, 0.47826086956522, -0.225, 0.055555555555556
87752, 0.47826086956522, -0.225, 0.11111111111111
87753, 0.47826086956522, -0.225, 0.16666666666667
87754, 0.47826086956522, -0.225, 0.22222222222222
87755, 0.47826086956522, -0.225, 0.27777777777778
87756, 0.47826086956522, -0.225, 0.33333333333333
87757, 0.47826086956522, -0.225, 0.38888888888889
87758, 0.47826086956522, -0.225, 0.44444444444444
87759, 0.43478260869565, -0.225, 0.055555555555556
87760, 0.43478260869565, -0.225, 0.11111111111111
87761, 0.43478260869565, -0.225, 0.16666666666667
87762, 0.43478260869565, -0.225, 0.22222222222222
87763, 0.43478260869565, -0.225, 0.27777777777778
87764, 0.43478260869565, -0.225, 0.33333333333333
87765, 0.43478260869565, -0.225, 0.38888888888889
87766, 0.43478260869565, -0.225, 0.44444444444444
87767, 0.39130434782609, -0.225, 0.055555555555556
87768, 0.39130434782609, -0.225, 0.11111111111111
87769, 0.39130434782609, -0.225, 0.16666666666667
87770, 0.39130434782609, -0.225, 0.22222222222222
87771, 0.39130434782609, -0.225, 0.27777777777778
87772, 0.39130434782609, -0.225, 0.33333333333333
87773, 0.39130434782609, -0.225, 0.38888888888889
87774, 0.39130434782609, -0.225, 0.44444444444444
87775, 0.34782608695652, -0.225, 0.055555555555556
87776, 0.34782608695652, -0.225, 0.11111111111111
87777, 0.34782608695652, -0.225, 0.16666666666667
87778, 0.34782608695652, -0.225, 0.22222222222222
87779, 0.34782608695652, -0.225, 0.27777777777778
87780, 0.34782608695652, -0.225, 0.33333333333333
87781, 0.34782608695652, -0.225, 0.38888888888889
87782, 0.34782608695652, -0.225, 0.44444444444444
87783, 0.30434782608696, -0.225, 0.055555555555556
87784, 0.30434782608696, -0.225, 0.11111111111111
87785, 0.30434782608696, -0.225, 0.16666666666667
87786, 0.30434782608696, -0.225, 0.22222222222222
87787, 0.30434782608696, -0.225, 0.27777777777778
87788, 0.30434782608696, -0.225, 0.33333333333333
87789, 0.30434782608696, -0.225, 0.38888888888889
87790, 0.30434782608696, -0.225, 0.44444444444444
87791, 0.26086956521739, -0.225, 0.055555555555556
87792, 0.26086956521739, -0.225, 0.11111111111111
87793, 0.26086956521739, -0.225, 0.16666666666667
87794, 0.26086956521739, -0.225, 0.22222222222222
87795, 0.26086956521739, -0.225, 0.27777777777778
87796, 0.26086956521739, -0.225, 0.33333333333333
87797, 0.26086956521739, -0.225, 0.38888888888889
87798, 0.26086956521739, -0.225, 0.44444444444444
87799, 0.21739130434783, -0.225, 0.055555555555556
87800, 0.21739130434783, -0.225, 0.11111111111111
87801, 0.21739130434783, -0.225, 0.16666666666667
87802, 0.21739130434783, -0.225, 0.22222222222222
87803, 0.21739130434783, -0.225, 0.27777777777778
87804, 0.21739130434783, -0.225, 0.33333333333333
87805, 0.21739130434783, -0.225, 0.38888888888889
87806, 0.21739130434783, -0.225, 0.44444444444444
87807, 0.17391304347826, -0.225, 0.055555555555556
87808, 0.17391304347826, -0.225, 0.11111111111111
87809, 0.17391304347826, -0.225, 0.16666666666667
87810, 0.17391304347826, -0.225, 0.22222222222222
87811, 0.17391304347826, -0.225, 0.27777777777778
87812, 0.17391304347826, -0.225, 0.33333333333333
87813, 0.17391304347826, -0.225, 0.38888888888889
87814, 0.17391304347826, -0.225, 0.44444444444444
87815, 0.1304347826087, -0.225, 0.055555555555556
87816, 0.1304347826087, -0.225, 0.11111111111111
87817, 0.1304347826087, -0.225, 0.16666666666667
87818, 0.1304347826087, -0.225, 0.22222222222222
87819, 0.1304347826087, -0.225, 0.27777777777778
87820, 0.1304347826087, -0.225, 0.33333333333333
87821, 0.1304347826087, -0.225, 0.38888888888889
87822, 0.1304347826087, -0.225, 0.44444444444444
87823, 0.08695652173913, -0.225, 0.055555555555556
87824, 0.08695652173913, -0.225, 0.11111111111111
87825, 0.08695652173913, -0.225, 0.16666666666667
87826, 0.08695652173913, -0.225, 0.22222222222222
87827, 0.08695652173913, -0.225, 0.27777777777778
87828, 0.08695652173913, -0.225, 0.33333333333333
87829, 0.08695652173913, -0.225, 0.38888888888889
87830, 0.08695652173913, -0.225, 0.44444444444444
87831, 0.043478260869565, -0.225, 0.055555555555556
87832, 0.043478260869565, -0.225, 0.11111111111111
87833, 0.043478260869565, -0.225, 0.16666666666667
87834, 0.043478260869565, -0.225, 0.22222222222222
87835, 0.043478260869565, -0.225, 0.27777777777778
87836, 0.043478260869565, -0.225, 0.33333333333333
87837, 0.043478260869565, -0.225, 0.38888888888889
87838, 0.043478260869565, -0.225, 0.44444444444444
87839, -0.05, -0.1, 0.44444444444444
87840, -0.05, -0.1, 0.38888888888889
87841, -0.05, -0.1, 0.33333333333333
87842, -0.05, -0.1, 0.27777777777778
87843, -0.05, -0.1, 0.22222222222222
87844, -0.05, -0.1, 0.16666666666667
87845, -0.05, -0.1, 0.11111111111111
87846, -0.05, -0.1, 0.055555555555556
87847, -0.05, -0.15, 0.44444444444444
87848, -0.05, -0.15, 0.38888888888889
87849, -0.05, -0.15, 0.33333333333333
87850, -0.05, -0.15, 0.27777777777778
87851, -0.05, -0.15, 0.22222222222222
87852, -0.05, -0.15, 0.16666666666667
87853, -0.05, -0.15, 0.11111111111111
87854, -0.05, -0.15, 0.055555555555556
87855, -0.05, -0.2, 0.44444444444444
87856, -0.05, -0.2, 0.38888888888889
87857, -0.05, -0.2, 0.33333333333333
87858, -0.05, -0.2, 0.27777777777778
87859, -0.05, -0.2, 0.22222222222222
87860, -0.05, -0.2, 0.16666666666667
87861, -0.05, -0.2, 0.11111111111111
87862, -0.05, -0.2, 0.055555555555556
87863, -0.05, -0.1, 0.47222222222222
87864, -0.025, -0.1, 0.44444444444444
87865, -0.05, -0.075, 0.44444444444444
87866, -0.05, -0.1, 0.41666666666667
87867, -0.025, -0.1, 0.38888888888889
87868, -0.05, -0.075, 0.38888888888889
87869, -0.05, -0.1, 0.36111111111111
87870, -0.025, -0.1, 0.33333333333333
87871, -0.05, -0.075, 0.33333333333333
87872, -0.05, -0.1, 0.30555555555556
87873, -0.025, -0.1, 0.27777777777778
87874, -0.05, -0.075, 0.27777777777778
87875, -0.05, -0.1, 0.25
87876, -0.025, -0.1, 0.22222222222222
87877, -0.05, -0.075, 0.22222222222222
87878, -0.05, -0.1, 0.19444444444444
87879, -0.025, -0.1, 0.16666666666667
87880, -0.05, -0.075, 0.16666666666667
87881, -0.05, -0.1, 0.13888888888889
87882, -0.025, -0.1, 0.11111111111111
87883, -0.05, -0.075, 0.11111111111111
87884, -0.05, -0.1, 0.083333333333333
87885, -0.025, -0.1, 0.055555555555556
87886, -0.05, -0.075, 0.055555555555556
87887, -0.05, -0.1, 0.027777777777778
87888, -0.075, -0.1, 0.44444444444444
87889, -0.075, -0.1, 0.38888888888889
87890, -0.075, -0.1, 0.33333333333333
87891, -0.075, -0.1, 0.27777777777778
87892, -0.075, -0.1, 0.22222222222222
87893, -0.075, -0.1, 0.16666666666667
87894, -0.075, -0.1, 0.11111111111111
87895, -0.075, -0.1, 0.055555555555556
87896, -0.05, -0.15, 0.47222222222222
87897, -0.025, -0.15, 0.44444444444444
87898, -0.05, -0.125, 0.44444444444444
87899, -0.05, -0.15, 0.41666666666667
87900, -0.025, -0.15, 0.38888888888889
87901, -0.05, -0.125, 0.38888888888889
87902, -0.05, -0.15, 0.36111111111111
87903, -0.025, -0.15, 0.33333333333333
87904, -0.05, -0.125, 0.33333333333333
87905, -0.05, -0.15, 0.30555555555556
87906, -0.025, -0.15, 0.27777777777778
87907, -0.05, -0.125, 0.27777777777778
87908, -0.05, -0.15, 0.25
87909, -0.025, -0.15, 0.22222222222222
87910, -0.05, -0.125, 0.22222222222222
87911, -0.05, -0.15, 0.19444444444444
87912, -0.025, -0.15, 0.16666666666667
87913, -0.05, -0.125, 0.16666666666667
87914, -0.05, -0.15, 0.13888888888889
87915, -0.025, -0.15, 0.11111111111111
87916, -0.05, -0.125, 0.11111111111111
87917, -0.05, -0.15, 0.083333333333333
87918, -0.025, -0.15, 0.055555555555556
87919, -0.05, -0.125, 0.055555555555556
87920, -0.05, -0.15, 0.027777777777778
87921, -0.075, -0.15, 0.44444444444444
87922, -0.075, -0.15, 0.38888888888889
87923, -0.075, -0.15, 0.33333333333333
87924, -0.075, -0.15, 0.27777777777778
87925, -0.075, -0.15, 0.22222222222222
87926, -0.075, -0.15, 0.16666666666667
87927, -0.075, -0.15, 0.11111111111111
87928, -0.075, -0.15, 0.055555555555556
87929, -0.05, -0.2, 0.47222222222222
87930, -0.025, -0.2, 0.44444444444444
87931, -0.05, -0.175, 0.44444444444444
87932, -0.05, -0.2, 0.41666666666667
87933, -0.025, -0.2, 0.38888888888889
87934, -0.05, -0.175, 0.38888888888889
87935, -0.05, -0.2, 0.36111111111111
87936, -0.025, -0.2, 0.33333333333333
87937, -0.05, -0.175, 0.33333333333333
87938, -0.05, -0.2, 0.30555555555556
87939, -0.025, -0.2, 0.27777777777778
87940, -0.05, -0.175, 0.27777777777778
87941, -0.05, -0.2, 0.25
87942, -0.025, -0.2, 0.22222222222222
87943, -0.05, -0.175, 0.22222222222222
87944, -0.05, -0.2, 0.19444444444444
87945, -0.025, -0.2, 0.16666666666667
87946, -0.05, -0.175, 0.16666666666667
87947, -0.05, -0.2, 0.13888888888889
87948, -0.025, -0.2, 0.11111111111111
87949, -0.05, -0.175, 0.11111111111111
87950, -0.05, -0.2, 0.083333333333333
87951, -0.025, -0.2, 0.055555555555556
87952, -0.05, -0.175, 0.055555555555556
87953, -0.05, -0.2, 0.027777777777778
87954, -0.075, -0.2, 0.44444444444444
87955, -0.075, -0.2, 0.38888888888889
87956, -0.075, -0.2, 0.33333333333333
87957, -0.075, -0.2, 0.27777777777778
87958, -0.075, -0.2, 0.22222222222222
87959, -0.075, -0.2, 0.16666666666667
87960, -0.075, -0.2, 0.11111111111111
87961, -0.075, -0.2, 0.055555555555556
87962, -0.05, -0.225, 0.44444444444444
87963, -0.05, -0.225, 0.38888888888889
87964, -0.05, -0.225, 0.33333333333333
87965, -0.05, -0.225, 0.27777777777778
87966, -0.05, -0.225, 0.22222222222222
87967, -0.05, -0.225, 0.16666666666667
87968, -0.05, -0.225, 0.11111111111111
87969, -0.05, -0.225, 0.055555555555556
87970, 1.2434782608696, -0.1, 0.44444444444444
87971, 1.2434782608696, -0.1, 0.38888888888889
87972, 1.2434782608696, -0.1, 0.33333333333333
87973, 1.2434782608696, -0.1, 0.27777777777778
87974, 1.2434782608696, -0.1, 0.22222222222222
87975, 1.2434782608696, -0.1, 0.16666666666667
87976, 1.2434782608696, -0.1, 0.11111111111111
87977, 1.2434782608696, -0.1, 0.055555555555556
87978, 1.2869565217391, -0.1, 0.44444444444444
87979, 1.2869565217391, -0.1, 0.38888888888889
87980, 1.2869565217391, -0.1, 0.33333333333333
87981, 1.2869565217391, -0.1, 0.27777777777778
87982, 1.2869565217391, -0.1, 0.22222222222222
87983, 1.2869565217391, -0.1, 0.16666666666667
87984, 1.2869565217391, -0.1, 0.11111111111111
87985, 1.2869565217391, -0.1, 0.055555555555556
87986, 1.3304347826087, -0.1, 0.44444444444444
87987, 1.3304347826087, -0.1, 0.38888888888889
87988, 1.3304347826087, -0.1, 0.33333333333333
87989, 1.3304347826087, -0.1, 0.27777777777778
87990, 1.3304347826087, -0.1, 0.22222222222222
87991, 1.3304347826087, -0.1, 0.16666666666667
87992, 1.3304347826087, -0.1, 0.11111111111111
87993, 1.3304347826087, -0.1, 0.055555555555556
87994, 1.3739130434783, -0.1, 0.44444444444444
87995, 1.3739130434783, -0.1, 0.38888888888889
87996, 1.3739130434783, -0.1, 0.33333333333333
87997, 1.3739130434783, -0.1, 0.27777777777778
87998, 1.3739130434783, -0.1, 0.22222222222222
87999, 1.3739130434783, -0.1, 0.16666666666667
88000, 1.3739130434783, -0.1, 0.11111111111111
88001, 1.3739130434783, -0.1, 0.055555555555556
88002, 1.4173913043478, -0.1, 0.44444444444444
88003, 1.4173913043478, -0.1, 0.38888888888889
88004, 1.4173913043478, -0.1, 0.33333333333333
88005, 1.4173913043478, -0.1, 0.27777777777778
88006, 1.4173913043478, -0.1, 0.22222222222222
88007, 1.4173913043478, -0.1, 0.16666666666667
88008, 1.4173913043478, -0.1, 0.11111111111111
88009, 1.4173913043478, -0.1, 0.055555555555556
88010, 1.4608695652174, -0.1, 0.44444444444444
88011, 1.4608695652174, -0.1, 0.38888888888889
88012, 1.4608695652174, -0.1, 0.33333333333333
88013, 1.4608695652174, -0.1, 0.27777777777778
88014, 1.4608695652174, -0.1, 0.22222222222222
88015, 1.4608695652174, -0.1, 0.16666666666667
88016, 1.4608695652174, -0.1, 0.11111111111111
88017, 1.4608695652174, -0.1, 0.055555555555556
88018, 1.504347826087, -0.1, 0.44444444444444
88019, 1.504347826087, -0.1, 0.38888888888889
88020, 1.504347826087, -0.1, 0.33333333333333
88021, 1.504347826087, -0.1, 0.27777777777778
88022, 1.504347826087, -0.1, 0.22222222222222
88023, 1.504347826087, -0.1, 0.16666666666667
88024, 1.504347826087, -0.1, 0.11111111111111
88025, 1.504347826087, -0.1, 0.055555555555556
88026, 1.5478260869565, -0.1, 0.44444444444444
88027, 1.5478260869565, -0.1, 0.38888888888889
88028, 1.5478260869565, -0.1, 0.33333333333333
88029, 1.5478260869565, -0.1, 0.27777777777778
88030, 1.5478260869565, -0.1, 0.22222222222222
88031, 1.5478260869565, -0.1, 0.16666666666667
88032, 1.5478260869565, -0.1, 0.11111111111111
88033, 1.5478260869565, -0.1, 0.055555555555556
88034, 1.5913043478261, -0.1, 0.44444444444444
88035, 1.5913043478261, -0.1, 0.38888888888889
88036, 1.5913043478261, -0.1, 0.33333333333333
88037, 1.5913043478261, -0.1, 0.27777777777778
88038, 1.5913043478261, -0.1, 0.22222222222222
88039, 1.5913043478261, -0.1, 0.16666666666667
88040, 1.5913043478261, -0.1, 0.11111111111111
88041, 1.5913043478261, -0.1, 0.055555555555556
88042, 1.6347826086957, -0.1, 0.44444444444444
88043, 1.6347826086957, -0.1, 0.38888888888889
88044, 1.6347826086957, -0.1, 0.33333333333333
88045, 1.6347826086957, -0.1, 0.27777777777778
88046, 1.6347826086957, -0.1, 0.22222222222222
88047, 1.6347826086957, -0.1, 0.16666666666667
88048, 1.6347826086957, -0.1, 0.11111111111111
88049, 1.6347826086957, -0.1, 0.055555555555556
88050, 1.6782608695652, -0.1, 0.44444444444444
88051, 1.6782608695652, -0.1, 0.38888888888889
88052, 1.6782608695652, -0.1, 0.33333333333333
88053, 1.6782608695652, -0.1, 0.27777777777778
88054, 1.6782608695652, -0.1, 0.22222222222222
88055, 1.6782608695652, -0.1, 0.16666666666667
88056, 1.6782608695652, -0.1, 0.11111111111111
88057, 1.6782608695652, -0.1, 0.055555555555556
88058, 1.7217391304348, -0.1, 0.44444444444444
88059, 1.7217391304348, -0.1, 0.38888888888889
88060, 1.7217391304348, -0.1, 0.33333333333333
88061, 1.7217391304348, -0.1, 0.27777777777778
88062, 1.7217391304348, -0.1, 0.22222222222222
88063, 1.7217391304348, -0.1, 0.16666666666667
88064, 1.7217391304348, -0.1, 0.11111111111111
88065, 1.7217391304348, -0.1, 0.055555555555556
88066, 1.7652173913043, -0.1, 0.44444444444444
88067, 1.7652173913043, -0.1, 0.38888888888889
88068, 1.7652173913043, -0.1, 0.33333333333333
88069, 1.7652173913043, -0.1, 0.27777777777778
88070, 1.7652173913043, -0.1, 0.22222222222222
88071, 1.7652173913043, -0.1, 0.16666666666667
88072, 1.7652173913043, -0.1, 0.11111111111111
88073, 1.7652173913043, -0.1, 0.055555555555556
88074, 1.8086956521739, -0.1, 0.44444444444444
88075, 1.8086956521739, -0.1, 0.38888888888889
88076, 1.8086956521739, -0.1, 0.33333333333333
88077, 1.8086956521739, -0.1, 0.27777777777778
88078, 1.8086956521739, -0.1, 0.22222222222222
88079, 1.8086956521739, -0.1, 0.16666666666667
88080, 1.8086956521739, -0.1, 0.11111111111111
88081, 1.8086956521739, -0.1, 0.055555555555556
88082, 1.8521739130435, -0.1, 0.44444444444444
88083, 1.8521739130435, -0.1, 0.38888888888889
88084, 1.8521739130435, -0.1, 0.33333333333333
88085, 1.8521739130435, -0.1, 0.27777777777778
88086, 1.8521739130435, -0.1, 0.22222222222222
88087, 1.8521739130435, -0.1, 0.16666666666667
88088, 1.8521739130435, -0.1, 0.11111111111111
88089, 1.8521739130435, -0.1, 0.055555555555556
88090, 1.895652173913, -0.1, 0.44444444444444
88091, 1.895652173913, -0.1, 0.38888888888889
88092, 1.895652173913, -0.1, 0.33333333333333
88093, 1.895652173913, -0.1, 0.27777777777778
88094, 1.895652173913, -0.1, 0.22222222222222
88095, 1.895652173913, -0.1, 0.16666666666667
88096, 1.895652173913, -0.1, 0.11111111111111
88097, 1.895652173913, -0.1, 0.055555555555556
88098, 1.9391304347826, -0.1, 0.44444444444444
88099, 1.9391304347826, -0.1, 0.38888888888889
88100, 1.9391304347826, -0.1, 0.33333333333333
88101, 1.9391304347826, -0.1, 0.27777777777778
88102, 1.9391304347826, -0.1, 0.22222222222222
88103, 1.9391304347826, -0.1, 0.16666666666667
88104, 1.9391304347826, -0.1, 0.11111111111111
88105, 1.9391304347826, -0.1, 0.055555555555556
88106, 1.9826086956522, -0.1, 0.44444444444444
88107, 1.9826086956522, -0.1, 0.38888888888889
88108, 1.9826086956522, -0.1, 0.33333333333333
88109, 1.9826086956522, -0.1, 0.27777777777778
88110, 1.9826086956522, -0.1, 0.22222222222222
88111, 1.9826086956522, -0.1, 0.16666666666667
88112, 1.9826086956522, -0.1, 0.11111111111111
88113, 1.9826086956522, -0.1, 0.055555555555556
88114, 2.0260869565217, -0.1, 0.44444444444444
88115, 2.0260869565217, -0.1, 0.38888888888889
88116, 2.0260869565217, -0.1, 0.33333333333333
88117, 2.0260869565217, -0.1, 0.27777777777778
88118, 2.0260869565217, -0.1, 0.22222222222222
88119, 2.0260869565217, -0.1, 0.16666666666667
88120, 2.0260869565217, -0.1, 0.11111111111111
88121, 2.0260869565217, -0.1, 0.055555555555556
88122, 2.0695652173913, -0.1, 0.44444444444444
88123, 2.0695652173913, -0.1, 0.38888888888889
88124, 2.0695652173913, -0.1, 0.33333333333333
88125, 2.0695652173913, -0.1, 0.27777777777778
88126, 2.0695652173913, -0.1, 0.22222222222222
88127, 2.0695652173913, -0.1, 0.16666666666667
88128, 2.0695652173913, -0.1, 0.11111111111111
88129, 2.0695652173913, -0.1, 0.055555555555556
88130, 2.1130434782609, -0.1, 0.44444444444444
88131, 2.1130434782609, -0.1, 0.38888888888889
88132, 2.1130434782609, -0.1, 0.33333333333333
88133, 2.1130434782609, -0.1, 0.27777777777778
88134, 2.1130434782609, -0.1, 0.22222222222222
88135, 2.1130434782609, -0.1, 0.16666666666667
88136, 2.1130434782609, -0.1, 0.11111111111111
88137, 2.1130434782609, -0.1, 0.055555555555556
88138, 2.1565217391304, -0.1, 0.44444444444444
88139, 2.1565217391304, -0.1, 0.38888888888889
88140, 2.1565217391304, -0.1, 0.33333333333333
88141, 2.1565217391304, -0.1, 0.27777777777778
88142, 2.1565217391304, -0.1, 0.22222222222222
88143, 2.1565217391304, -0.1, 0.16666666666667
88144, 2.1565217391304, -0.1, 0.11111111111111
88145, 2.1565217391304, -0.1, 0.055555555555556
88146, 1.2434782608696, -0.15, 0.44444444444444
88147, 1.2434782608696, -0.15, 0.38888888888889
88148, 1.2434782608696, -0.15, 0.33333333333333
88149, 1.2434782608696, -0.15, 0.27777777777778
88150, 1.2434782608696, -0.15, 0.22222222222222
88151, 1.2434782608696, -0.15, 0.16666666666667
88152, 1.2434782608696, -0.15, 0.11111111111111
88153, 1.2434782608696, -0.15, 0.055555555555556
88154, 1.2869565217391, -0.15, 0.44444444444444
88155, 1.2869565217391, -0.15, 0.38888888888889
88156, 1.2869565217391, -0.15, 0.33333333333333
88157, 1.2869565217391, -0.15, 0.27777777777778
88158, 1.2869565217391, -0.15, 0.22222222222222
88159, 1.2869565217391, -0.15, 0.16666666666667
88160, 1.2869565217391, -0.15, 0.11111111111111
88161, 1.2869565217391, -0.15, 0.055555555555556
88162, 1.3304347826087, -0.15, 0.44444444444444
88163, 1.3304347826087, -0.15, 0.38888888888889
88164, 1.3304347826087, -0.15, 0.33333333333333
88165, 1.3304347826087, -0.15, 0.27777777777778
88166, 1.3304347826087, -0.15, 0.22222222222222
88167, 1.3304347826087, -0.15, 0.16666666666667
88168, 1.3304347826087, -0.15, 0.11111111111111
88169, 1.3304347826087, -0.15, 0.055555555555556
88170, 1.3739130434783, -0.15, 0.44444444444444
88171, 1.3739130434783, -0.15, 0.38888888888889
88172, 1.3739130434783, -0.15, 0.33333333333333
88173, 1.3739130434783, -0.15, 0.27777777777778
88174, 1.3739130434783, -0.15, 0.22222222222222
88175, 1.3739130434783, -0.15, 0.16666666666667
88176, 1.3739130434783, -0.15, 0.11111111111111
88177, 1.3739130434783, -0.15, 0.055555555555556
88178, 1.4173913043478, -0.15, 0.44444444444444
88179, 1.4173913043478, -0.15, 0.38888888888889
88180, 1.4173913043478, -0.15, 0.33333333333333
88181, 1.4173913043478, -0.15, 0.27777777777778
88182, 1.4173913043478, -0.15, 0.22222222222222
88183, 1.4173913043478, -0.15, 0.16666666666667
88184, 1.4173913043478, -0.15, 0.11111111111111
88185, 1.4173913043478, -0.15, 0.055555555555556
88186, 1.4608695652174, -0.15, 0.44444444444444
88187, 1.4608695652174, -0.15, 0.38888888888889
88188, 1.4608695652174, -0.15, 0.33333333333333
88189, 1.4608695652174, -0.15, 0.27777777777778
88190, 1.4608695652174, -0.15, 0.22222222222222
88191, 1.4608695652174, -0.15, 0.16666666666667
88192, 1.4608695652174, -0.15, 0.11111111111111
88193, 1.4608695652174, -0.15, 0.055555555555556
88194, 1.504347826087, -0.15, 0.44444444444444
88195, 1.504347826087, -0.15, 0.38888888888889
88196, 1.504347826087, -0.15, 0.33333333333333
88197, 1.504347826087, -0.15, 0.27777777777778
88198, 1.504347826087, -0.15, 0.22222222222222
88199, 1.504347826087, -0.15, 0.16666666666667
88200, 1.504347826087, -0.15, 0.11111111111111
88201, 1.504347826087, -0.15, 0.055555555555556
88202, 1.5478260869565, -0.15, 0.44444444444444
88203, 1.5478260869565, -0.15, 0.38888888888889
88204, 1.5478260869565, -0.15, 0.33333333333333
88205, 1.5478260869565, -0.15, 0.27777777777778
88206, 1.5478260869565, -0.15, 0.22222222222222
88207, 1.5478260869565, -0.15, 0.16666666666667
88208, 1.5478260869565, -0.15, 0.11111111111111
88209, 1.5478260869565, -0.15, 0.055555555555556
88210, 1.5913043478261, -0.15, 0.44444444444444
88211, 1.5913043478261, -0.15, 0.38888888888889
88212, 1.5913043478261, -0.15, 0.33333333333333
88213, 1.5913043478261, -0.15, 0.27777777777778
88214, 1.5913043478261, -0.15, 0.22222222222222
88215, 1.5913043478261, -0.15, 0.16666666666667
88216, 1.5913043478261, -0.15, 0.11111111111111
88217, 1.5913043478261, -0.15, 0.055555555555556
88218, 1.6347826086957, -0.15, 0.44444444444444
88219, 1.6347826086957, -0.15, 0.38888888888889
88220, 1.6347826086957, -0.15, 0.33333333333333
88221, 1.6347826086957, -0.15, 0.27777777777778
88222, 1.6347826086957, -0.15, 0.22222222222222
88223, 1.6347826086957, -0.15, 0.16666666666667
88224, 1.6347826086957, -0.15, 0.11111111111111
88225, 1.6347826086957, -0.15, 0.055555555555556
88226, 1.6782608695652, -0.15, 0.44444444444444
88227, 1.6782608695652, -0.15, 0.38888888888889
88228, 1.6782608695652, -0.15, 0.33333333333333
88229, 1.6782608695652, -0.15, 0.27777777777778
88230, 1.6782608695652, -0.15, 0.22222222222222
88231, 1.6782608695652, -0.15, 0.16666666666667
88232, 1.6782608695652, -0.15, 0.11111111111111
88233, 1.6782608695652, -0.15, 0.055555555555556
88234, 1.7217391304348, -0.15, 0.44444444444444
88235, 1.7217391304348, -0.15, 0.38888888888889
88236, 1.7217391304348, -0.15, 0.33333333333333
88237, 1.7217391304348, -0.15, 0.27777777777778
88238, 1.7217391304348, -0.15, 0.22222222222222
88239, 1.7217391304348, -0.15, 0.16666666666667
88240, 1.7217391304348, -0.15, 0.11111111111111
88241, 1.7217391304348, -0.15, 0.055555555555556
88242, 1.7652173913043, -0.15, 0.44444444444444
88243, 1.7652173913043, -0.15, 0.38888888888889
88244, 1.7652173913043, -0.15, 0.33333333333333
88245, 1.7652173913043, -0.15, 0.27777777777778
88246, 1.7652173913043, -0.15, 0.22222222222222
88247, 1.7652173913043, -0.15, 0.16666666666667
88248, 1.7652173913043, -0.15, 0.11111111111111
88249, 1.7652173913043, -0.15, 0.055555555555556
88250, 1.8086956521739, -0.15, 0.44444444444444
88251, 1.8086956521739, -0.15, 0.38888888888889
88252, 1.8086956521739, -0.15, 0.33333333333333
88253, 1.8086956521739, -0.15, 0.27777777777778
88254, 1.8086956521739, -0.15, 0.22222222222222
88255, 1.8086956521739, -0.15, 0.16666666666667
88256, 1.8086956521739, -0.15, 0.11111111111111
88257, 1.8086956521739, -0.15, 0.055555555555556
88258, 1.8521739130435, -0.15, 0.44444444444444
88259, 1.8521739130435, -0.15, 0.38888888888889
88260, 1.8521739130435, -0.15, 0.33333333333333
88261, 1.8521739130435, -0.15, 0.27777777777778
88262, 1.8521739130435, -0.15, 0.22222222222222
88263, 1.8521739130435, -0.15, 0.16666666666667
88264, 1.8521739130435, -0.15, 0.11111111111111
88265, 1.8521739130435, -0.15, 0.055555555555556
88266, 1.895652173913, -0.15, 0.44444444444444
88267, 1.895652173913, -0.15, 0.38888888888889
88268, 1.895652173913, -0.15, 0.33333333333333
88269, 1.895652173913, -0.15, 0.27777777777778
88270, 1.895652173913, -0.15, 0.22222222222222
88271, 1.895652173913, -0.15, 0.16666666666667
88272, 1.895652173913, -0.15, 0.11111111111111
88273, 1.895652173913, -0.15, 0.055555555555556
88274, 1.9391304347826, -0.15, 0.44444444444444
88275, 1.9391304347826, -0.15, 0.38888888888889
88276, 1.9391304347826, -0.15, 0.33333333333333
88277, 1.9391304347826, -0.15, 0.27777777777778
88278, 1.9391304347826, -0.15, 0.22222222222222
88279, 1.9391304347826, -0.15, 0.16666666666667
88280, 1.9391304347826, -0.15, 0.11111111111111
88281, 1.9391304347826, -0.15, 0.055555555555556
88282, 1.9826086956522, -0.15, 0.44444444444444
88283, 1.9826086956522, -0.15, 0.38888888888889
88284, 1.9826086956522, -0.15, 0.33333333333333
88285, 1.9826086956522, -0.15, 0.27777777777778
88286, 1.9826086956522, -0.15, 0.22222222222222
88287, 1.9826086956522, -0.15, 0.16666666666667
88288, 1.9826086956522, -0.15, 0.11111111111111
88289, 1.9826086956522, -0.15, 0.055555555555556
88290, 2.0260869565217, -0.15, 0.44444444444444
88291, 2.0260869565217, -0.15, 0.38888888888889
88292, 2.0260869565217, -0.15, 0.33333333333333
88293, 2.0260869565217, -0.15, 0.27777777777778
88294, 2.0260869565217, -0.15, 0.22222222222222
88295, 2.0260869565217, -0.15, 0.16666666666667
88296, 2.0260869565217, -0.15, 0.11111111111111
88297, 2.0260869565217, -0.15, 0.055555555555556
88298, 2.0695652173913, -0.15, 0.44444444444444
88299, 2.0695652173913, -0.15, 0.38888888888889
88300, 2.0695652173913, -0.15, 0.33333333333333
88301, 2.0695652173913, -0.15, 0.27777777777778
88302, 2.0695652173913, -0.15, 0.22222222222222
88303, 2.0695652173913, -0.15, 0.16666666666667
88304, 2.0695652173913, -0.15, 0.11111111111111
88305, 2.0695652173913, -0.15, 0.055555555555556
88306, 2.1130434782609, -0.15, 0.44444444444444
88307, 2.1130434782609, -0.15, 0.38888888888889
88308, 2.1130434782609, -0.15, 0.33333333333333
88309, 2.1130434782609, -0.15, 0.27777777777778
88310, 2.1130434782609, -0.15, 0.22222222222222
88311, 2.1130434782609, -0.15, 0.16666666666667
88312, 2.1130434782609, -0.15, 0.11111111111111
88313, 2.1130434782609, -0.15, 0.055555555555556
88314, 2.1565217391304, -0.15, 0.44444444444444
88315, 2.1565217391304, -0.15, 0.38888888888889
88316, 2.1565217391304, -0.15, 0.33333333333333
88317, 2.1565217391304, -0.15, 0.27777777777778
88318, 2.1565217391304, -0.15, 0.22222222222222
88319, 2.1565217391304, -0.15, 0.16666666666667
88320, 2.1565217391304, -0.15, 0.11111111111111
88321, 2.1565217391304, -0.15, 0.055555555555556
88322, 1.2434782608696, -0.2, 0.44444444444444
88323, 1.2434782608696, -0.2, 0.38888888888889
88324, 1.2434782608696, -0.2, 0.33333333333333
88325, 1.2434782608696, -0.2, 0.27777777777778
88326, 1.2434782608696, -0.2, 0.22222222222222
88327, 1.2434782608696, -0.2, 0.16666666666667
88328, 1.2434782608696, -0.2, 0.11111111111111
88329, 1.2434782608696, -0.2, 0.055555555555556
88330, 1.2869565217391, -0.2, 0.44444444444444
88331, 1.2869565217391, -0.2, 0.38888888888889
88332, 1.2869565217391, -0.2, 0.33333333333333
88333, 1.2869565217391, -0.2, 0.27777777777778
88334, 1.2869565217391, -0.2, 0.22222222222222
88335, 1.2869565217391, -0.2, 0.16666666666667
88336, 1.2869565217391, -0.2, 0.11111111111111
88337, 1.2869565217391, -0.2, 0.055555555555556
88338, 1.3304347826087, -0.2, 0.44444444444444
88339, 1.3304347826087, -0.2, 0.38888888888889
88340, 1.3304347826087, -0.2, 0.33333333333333
88341, 1.3304347826087, -0.2, 0.27777777777778
88342, 1.3304347826087, -0.2, 0.22222222222222
88343, 1.3304347826087, -0.2, 0.16666666666667
88344, 1.3304347826087, -0.2, 0.11111111111111
88345, 1.3304347826087, -0.2, 0.055555555555556
88346, 1.3739130434783, -0.2, 0.44444444444444
88347, 1.3739130434783, -0.2, 0.38888888888889
88348, 1.3739130434783, -0.2, 0.33333333333333
88349, 1.3739130434783, -0.2, 0.27777777777778
88350, 1.3739130434783, -0.2, 0.22222222222222
88351, 1.3739130434783, -0.2, 0.16666666666667
88352, 1.3739130434783, -0.2, 0.11111111111111
88353, 1.3739130434783, -0.2, 0.055555555555556
88354, 1.4173913043478, -0.2, 0.44444444444444
88355, 1.4173913043478, -0.2, 0.38888888888889
88356, 1.4173913043478, -0.2, 0.33333333333333
88357, 1.4173913043478, -0.2, 0.27777777777778
88358, 1.4173913043478, -0.2, 0.22222222222222
88359, 1.4173913043478, -0.2, 0.16666666666667
88360, 1.4173913043478, -0.2, 0.11111111111111
88361, 1.4173913043478, -0.2, 0.055555555555556
88362, 1.4608695652174, -0.2, 0.44444444444444
88363, 1.4608695652174, -0.2, 0.38888888888889
88364, 1.4608695652174, -0.2, 0.33333333333333
88365, 1.4608695652174, -0.2, 0.27777777777778
88366, 1.4608695652174, -0.2, 0.22222222222222
88367, 1.4608695652174, -0.2, 0.16666666666667
88368, 1.4608695652174, -0.2, 0.11111111111111
88369, 1.4608695652174, -0.2, 0.055555555555556
88370, 1.504347826087, -0.2, 0.44444444444444
88371, 1.504347826087, -0.2, 0.38888888888889
88372, 1.504347826087, -0.2, 0.33333333333333
88373, 1.504347826087, -0.2, 0.27777777777778
88374, 1.504347826087, -0.2, 0.22222222222222
88375, 1.504347826087, -0.2, 0.16666666666667
88376, 1.504347826087, -0.2, 0.11111111111111
88377, 1.504347826087, -0.2, 0.055555555555556
88378, 1.5478260869565, -0.2, 0.44444444444444
88379, 1.5478260869565, -0.2, 0.38888888888889
88380, 1.5478260869565, -0.2, 0.33333333333333
88381, 1.5478260869565, -0.2, 0.27777777777778
88382, 1.5478260869565, -0.2, 0.22222222222222
88383, 1.5478260869565, -0.2, 0.16666666666667
88384, 1.5478260869565, -0.2, 0.11111111111111
88385, 1.5478260869565, -0.2, 0.055555555555556
88386, 1.5913043478261, -0.2, 0.44444444444444
88387, 1.5913043478261, -0.2, 0.38888888888889
88388, 1.5913043478261, -0.2, 0.33333333333333
88389, 1.5913043478261, -0.2, 0.27777777777778
88390, 1.5913043478261, -0.2, 0.22222222222222
88391, 1.5913043478261, -0.2, 0.16666666666667
88392, 1.5913043478261, -0.2, 0.11111111111111
88393, 1.5913043478261, -0.2, 0.055555555555556
88394, 1.6347826086957, -0.2, 0.44444444444444
88395, 1.6347826086957, -0.2, 0.38888888888889
88396, 1.6347826086957, -0.2, 0.33333333333333
88397, 1.6347826086957, -0.2, 0.27777777777778
88398, 1.6347826086957, -0.2, 0.22222222222222
88399, 1.6347826086957, -0.2, 0.16666666666667
88400, 1.6347826086957, -0.2, 0.11111111111111
88401, 1.6347826086957, -0.2, 0.055555555555556
88402, 1.6782608695652, -0.2, 0.44444444444444
88403, 1.6782608695652, -0.2, 0.38888888888889
88404, 1.6782608695652, -0.2, 0.33333333333333
88405, 1.6782608695652, -0.2, 0.27777777777778
88406, 1.6782608695652, -0.2, 0.22222222222222
88407, 1.6782608695652, -0.2, 0.16666666666667
88408, 1.6782608695652, -0.2, 0.11111111111111
88409, 1.6782608695652, -0.2, 0.055555555555556
88410, 1.7217391304348, -0.2, 0.44444444444444
88411, 1.7217391304348, -0.2, 0.38888888888889
88412, 1.7217391304348, -0.2, 0.33333333333333
88413, 1.7217391304348, -0.2, 0.27777777777778
88414, 1.7217391304348, -0.2, 0.22222222222222
88415, 1.7217391304348, -0.2, 0.16666666666667
88416, 1.7217391304348, -0.2, 0.11111111111111
88417, 1.7217391304348, -0.2, 0.055555555555556
88418, 1.7652173913043, -0.2, 0.44444444444444
88419, 1.7652173913043, -0.2, 0.38888888888889
88420, 1.7652173913043, -0.2, 0.33333333333333
88421, 1.7652173913043, -0.2, 0.27777777777778
88422, 1.7652173913043, -0.2, 0.22222222222222
88423, 1.7652173913043, -0.2, 0.16666666666667
88424, 1.7652173913043, -0.2, 0.11111111111111
88425, 1.7652173913043, -0.2, 0.055555555555556
88426, 1.8086956521739, -0.2, 0.44444444444444
88427, 1.8086956521739, -0.2, 0.38888888888889
88428, 1.8086956521739, -0.2, 0.33333333333333
88429, 1.8086956521739, -0.2, 0.27777777777778
88430, 1.8086956521739, -0.2, 0.22222222222222
88431, 1.8086956521739, -0.2, 0.16666666666667
88432, 1.8086956521739, -0.2, 0.11111111111111
88433, 1.8086956521739, -0.2, 0.055555555555556
88434, 1.8521739130435, -0.2, 0.44444444444444
88435, 1.8521739130435, -0.2, 0.38888888888889
88436, 1.8521739130435, -0.2, 0.33333333333333
88437, 1.8521739130435, -0.2, 0.27777777777778
88438, 1.8521739130435, -0.2, 0.22222222222222
88439, 1.8521739130435, -0.2, 0.16666666666667
88440, 1.8521739130435, -0.2, 0.11111111111111
88441, 1.8521739130435, -0.2, 0.055555555555556
88442, 1.895652173913, -0.2, 0.44444444444444
88443, 1.895652173913, -0.2, 0.38888888888889
88444, 1.895652173913, -0.2, 0.33333333333333
88445, 1.895652173913, -0.2, 0.27777777777778
88446, 1.895652173913, -0.2, 0.22222222222222
88447, 1.895652173913, -0.2, 0.16666666666667
88448, 1.895652173913, -0.2, 0.11111111111111
88449, 1.895652173913, -0.2, 0.055555555555556
88450, 1.9391304347826, -0.2, 0.44444444444444
88451, 1.9391304347826, -0.2, 0.38888888888889
88452, 1.9391304347826, -0.2, 0.33333333333333
88453, 1.9391304347826, -0.2, 0.27777777777778
88454, 1.9391304347826, -0.2, 0.22222222222222
88455, 1.9391304347826, -0.2, 0.16666666666667
88456, 1.9391304347826, -0.2, 0.11111111111111
88457, 1.9391304347826, -0.2, 0.055555555555556
88458, 1.9826086956522, -0.2, 0.44444444444444
88459, 1.9826086956522, -0.2, 0.38888888888889
88460, 1.9826086956522, -0.2, 0.33333333333333
88461, 1.9826086956522, -0.2, 0.27777777777778
88462, 1.9826086956522, -0.2, 0.22222222222222
88463, 1.9826086956522, -0.2, 0.16666666666667
88464, 1.9826086956522, -0.2, 0.11111111111111
88465, 1.9826086956522, -0.2, 0.055555555555556
88466, 2.0260869565217, -0.2, 0.44444444444444
88467, 2.0260869565217, -0.2, 0.38888888888889
88468, 2.0260869565217, -0.2, 0.33333333333333
88469, 2.0260869565217, -0.2, 0.27777777777778
88470, 2.0260869565217, -0.2, 0.22222222222222
88471, 2.0260869565217, -0.2, 0.16666666666667
88472, 2.0260869565217, -0.2, 0.11111111111111
88473, 2.0260869565217, -0.2, 0.055555555555556
88474, 2.0695652173913, -0.2, 0.44444444444444
88475, 2.0695652173913, -0.2, 0.38888888888889
88476, 2.0695652173913, -0.2, 0.33333333333333
88477, 2.0695652173913, -0.2, 0.27777777777778
88478, 2.0695652173913, -0.2, 0.22222222222222
88479, 2.0695652173913, -0.2, 0.16666666666667
88480, 2.0695652173913, -0.2, 0.11111111111111
88481, 2.0695652173913, -0.2, 0.055555555555556
88482, 2.1130434782609, -0.2, 0.44444444444444
88483, 2.1130434782609, -0.2, 0.38888888888889
88484, 2.1130434782609, -0.2, 0.33333333333333
88485, 2.1130434782609, -0.2, 0.27777777777778
88486, 2.1130434782609, -0.2, 0.22222222222222
88487, 2.1130434782609, -0.2, 0.16666666666667
88488, 2.1130434782609, -0.2, 0.11111111111111
88489, 2.1130434782609, -0.2, 0.055555555555556
88490, 2.1565217391304, -0.2, 0.44444444444444
88491, 2.1565217391304, -0.2, 0.38888888888889
88492, 2.1565217391304, -0.2, 0.33333333333333
88493, 2.1565217391304, -0.2, 0.27777777777778
88494, 2.1565217391304, -0.2, 0.22222222222222
88495, 2.1565217391304, -0.2, 0.16666666666667
88496, 2.1565217391304, -0.2, 0.11111111111111
88497, 2.1565217391304, -0.2, 0.055555555555556
88498, 1.2434782608696, -0.1, 0.47222222222222
88499, 1.2217391304348, -0.1, 0.44444444444444
88500, 1.2434782608696, -0.075, 0.44444444444444
88501, 1.2434782608696, -0.1, 0.41666666666667
88502, 1.2217391304348, -0.1, 0.38888888888889
88503, 1.2434782608696, -0.075, 0.38888888888889
88504, 1.2434782608696, -0.1, 0.36111111111111
88505, 1.2217391304348, -0.1, 0.33333333333333
88506, 1.2434782608696, -0.075, 0.33333333333333
88507, 1.2434782608696, -0.1, 0.30555555555556
88508, 1.2217391304348, -0.1, 0.27777777777778
88509, 1.2434782608696, -0.075, 0.27777777777778
88510, 1.2434782608696, -0.1, 0.25
88511, 1.2217391304348, -0.1, 0.22222222222222
88512, 1.2434782608696, -0.075, 0.22222222222222
88513, 1.2434782608696, -0.1, 0.19444444444444
88514, 1.2217391304348, -0.1, 0.16666666666667
88515, 1.2434782608696, -0.075, 0.16666666666667
88516, 1.2434782608696, -0.1, 0.13888888888889
88517, 1.2217391304348, -0.1, 0.11111111111111
88518, 1.2434782608696, -0.075, 0.11111111111111
88519, 1.2434782608696, -0.1, 0.083333333333333
88520, 1.2217391304348, -0.1, 0.055555555555556
88521, 1.2434782608696, -0.075, 0.055555555555556
88522, 1.2434782608696, -0.1, 0.027777777777778
88523, 1.2869565217391, -0.1, 0.47222222222222
88524, 1.2652173913043, -0.1, 0.44444444444444
88525, 1.2869565217391, -0.075, 0.44444444444444
88526, 1.2869565217391, -0.1, 0.41666666666667
88527, 1.2652173913043, -0.1, 0.38888888888889
88528, 1.2869565217391, -0.075, 0.38888888888889
88529, 1.2869565217391, -0.1, 0.36111111111111
88530, 1.2652173913043, -0.1, 0.33333333333333
88531, 1.2869565217391, -0.075, 0.33333333333333
88532, 1.2869565217391, -0.1, 0.30555555555556
88533, 1.2652173913043, -0.1, 0.27777777777778
88534, 1.2869565217391, -0.075, 0.27777777777778
88535, 1.2869565217391, -0.1, 0.25
88536, 1.2652173913043, -0.1, 0.22222222222222
88537, 1.2869565217391, -0.075, 0.22222222222222
88538, 1.2869565217391, -0.1, 0.19444444444444
88539, 1.2652173913043, -0.1, 0.16666666666667
88540, 1.2869565217391, -0.075, 0.16666666666667
88541, 1.2869565217391, -0.1, 0.13888888888889
88542, 1.2652173913043, -0.1, 0.11111111111111
88543, 1.2869565217391, -0.075, 0.11111111111111
88544, 1.2869565217391, -0.1, 0.083333333333333
88545, 1.2652173913043, -0.1, 0.055555555555556
88546, 1.2869565217391, -0.075, 0.055555555555556
88547, 1.2869565217391, -0.1, 0.027777777777778
88548, 1.3304347826087, -0.1, 0.47222222222222
88549, 1.3086956521739, -0.1, 0.44444444444444
88550, 1.3304347826087, -0.075, 0.44444444444444
88551, 1.3304347826087, -0.1, 0.41666666666667
88552, 1.3086956521739, -0.1, 0.38888888888889
88553, 1.3304347826087, -0.075, 0.38888888888889
88554, 1.3304347826087, -0.1, 0.36111111111111
88555, 1.3086956521739, -0.1, 0.33333333333333
88556, 1.3304347826087, -0.075, 0.33333333333333
88557, 1.3304347826087, -0.1, 0.30555555555556
88558, 1.3086956521739, -0.1, 0.27777777777778
88559, 1.3304347826087, -0.075, 0.27777777777778
88560, 1.3304347826087, -0.1, 0.25
88561, 1.3086956521739, -0.1, 0.22222222222222
88562, 1.3304347826087, -0.075, 0.22222222222222
88563, 1.3304347826087, -0.1, 0.19444444444444
88564, 1.3086956521739, -0.1, 0.16666666666667
88565, 1.3304347826087, -0.075, 0.16666666666667
88566, 1.3304347826087, -0.1, 0.13888888888889
88567, 1.3086956521739, -0.1, 0.11111111111111
88568, 1.3304347826087, -0.075, 0.11111111111111
88569, 1.3304347826087, -0.1, 0.083333333333333
88570, 1.3086956521739, -0.1, 0.055555555555556
88571, 1.3304347826087, -0.075, 0.055555555555556
88572, 1.3304347826087, -0.1, 0.027777777777778
88573, 1.3739130434783, -0.1, 0.47222222222222
88574, 1.3521739130435, -0.1, 0.44444444444444
88575, 1.3739130434783, -0.075, 0.44444444444444
88576, 1.3739130434783, -0.1, 0.41666666666667
88577, 1.3521739130435, -0.1, 0.38888888888889
88578, 1.3739130434783, -0.075, 0.38888888888889
88579, 1.3739130434783, -0.1, 0.36111111111111
88580, 1.3521739130435, -0.1, 0.33333333333333
88581, 1.3739130434783, -0.075, 0.33333333333333
88582, 1.3739130434783, -0.1, 0.30555555555556
88583, 1.3521739130435, -0.1, 0.27777777777778
88584, 1.3739130434783, -0.075, 0.27777777777778
88585, 1.3739130434783, -0.1, 0.25
88586, 1.3521739130435, -0.1, 0.22222222222222
88587, 1.3739130434783, -0.075, 0.22222222222222
88588, 1.3739130434783, -0.1, 0.19444444444444
88589, 1.3521739130435, -0.1, 0.16666666666667
88590, 1.3739130434783, -0.075, 0.16666666666667
88591, 1.3739130434783, -0.1, 0.13888888888889
88592, 1.3521739130435, -0.1, 0.11111111111111
88593, 1.3739130434783, -0.075, 0.11111111111111
88594, 1.3739130434783, -0.1, 0.083333333333333
88595, 1.3521739130435, -0.1, 0.055555555555556
88596, 1.3739130434783, -0.075, 0.055555555555556
88597, 1.3739130434783, -0.1, 0.027777777777778
88598, 1.4173913043478, -0.1, 0.47222222222222
88599, 1.395652173913, -0.1, 0.44444444444444
88600, 1.4173913043478, -0.075, 0.44444444444444
88601, 1.4173913043478, -0.1, 0.41666666666667
88602, 1.395652173913, -0.1, 0.38888888888889
88603, 1.4173913043478, -0.075, 0.38888888888889
88604, 1.4173913043478, -0.1, 0.36111111111111
88605, 1.395652173913, -0.1, 0.33333333333333
88606, 1.4173913043478, -0.075, 0.33333333333333
88607, 1.4173913043478, -0.1, 0.30555555555556
88608, 1.395652173913, -0.1, 0.27777777777778
88609, 1.4173913043478, -0.075, 0.27777777777778
88610, 1.4173913043478, -0.1, 0.25
88611, 1.395652173913, -0.1, 0.22222222222222
88612, 1.4173913043478, -0.075, 0.22222222222222
88613, 1.4173913043478, -0.1, 0.19444444444444
88614, 1.395652173913, -0.1, 0.16666666666667
88615, 1.4173913043478, -0.075, 0.16666666666667
88616, 1.4173913043478, -0.1, 0.13888888888889
88617, 1.395652173913, -0.1, 0.11111111111111
88618, 1.4173913043478, -0.075, 0.11111111111111
88619, 1.4173913043478, -0.1, 0.083333333333333
88620, 1.395652173913, -0.1, 0.055555555555556
88621, 1.4173913043478, -0.075, 0.055555555555556
88622, 1.4173913043478, -0.1, 0.027777777777778
88623, 1.4608695652174, -0.1, 0.47222222222222
88624, 1.4391304347826, -0.1, 0.44444444444444
88625, 1.4608695652174, -0.075, 0.44444444444444
88626, 1.4608695652174, -0.1, 0.41666666666667
88627, 1.4391304347826, -0.1, 0.38888888888889
88628, 1.4608695652174, -0.075, 0.38888888888889
88629, 1.4608695652174, -0.1, 0.36111111111111
88630, 1.4391304347826, -0.1, 0.33333333333333
88631, 1.4608695652174, -0.075, 0.33333333333333
88632, 1.4608695652174, -0.1, 0.30555555555556
88633, 1.4391304347826, -0.1, 0.27777777777778
88634, 1.4608695652174, -0.075, 0.27777777777778
88635, 1.4608695652174, -0.1, 0.25
88636, 1.4391304347826, -0.1, 0.22222222222222
88637, 1.4608695652174, -0.075, 0.22222222222222
88638, 1.4608695652174, -0.1, 0.19444444444444
88639, 1.4391304347826, -0.1, 0.16666666666667
88640, 1.4608695652174, -0.075, 0.16666666666667
88641, 1.4608695652174, -0.1, 0.13888888888889
88642, 1.4391304347826, -0.1, 0.11111111111111
88643, 1.4608695652174, -0.075, 0.11111111111111
88644, 1.4608695652174, -0.1, 0.083333333333333
88645, 1.4391304347826, -0.1, 0.055555555555556
88646, 1.4608695652174, -0.075, 0.055555555555556
88647, 1.4608695652174, -0.1, 0.027777777777778
88648, 1.504347826087, -0.1, 0.47222222222222
88649, 1.4826086956522, -0.1, 0.44444444444444
88650, 1.504347826087, -0.075, 0.44444444444444
88651, 1.504347826087, -0.1, 0.41666666666667
88652, 1.4826086956522, -0.1, 0.38888888888889
88653, 1.504347826087, -0.075, 0.38888888888889
88654, 1.504347826087, -0.1, 0.36111111111111
88655, 1.4826086956522, -0.1, 0.33333333333333
88656, 1.504347826087, -0.075, 0.33333333333333
88657, 1.504347826087, -0.1, 0.30555555555556
88658, 1.4826086956522, -0.1, 0.27777777777778
88659, 1.504347826087, -0.075, 0.27777777777778
88660, 1.504347826087, -0.1, 0.25
88661, 1.4826086956522, -0.1, 0.22222222222222
88662, 1.504347826087, -0.075, 0.22222222222222
88663, 1.504347826087, -0.1, 0.19444444444444
88664, 1.4826086956522, -0.1, 0.16666666666667
88665, 1.504347826087, -0.075, 0.16666666666667
88666, 1.504347826087, -0.1, 0.13888888888889
88667, 1.4826086956522, -0.1, 0.11111111111111
88668, 1.504347826087, -0.075, 0.11111111111111
88669, 1.504347826087, -0.1, 0.083333333333333
88670, 1.4826086956522, -0.1, 0.055555555555556
88671, 1.504347826087, -0.075, 0.055555555555556
88672, 1.504347826087, -0.1, 0.027777777777778
88673, 1.5478260869565, -0.1, 0.47222222222222
88674, 1.5260869565217, -0.1, 0.44444444444444
88675, 1.5478260869565, -0.075, 0.44444444444444
88676, 1.5478260869565, -0.1, 0.41666666666667
88677, 1.5260869565217, -0.1, 0.38888888888889
88678, 1.5478260869565, -0.075, 0.38888888888889
88679, 1.5478260869565, -0.1, 0.36111111111111
88680, 1.5260869565217, -0.1, 0.33333333333333
88681, 1.5478260869565, -0.075, 0.33333333333333
88682, 1.5478260869565, -0.1, 0.30555555555556
88683, 1.5260869565217, -0.1, 0.27777777777778
88684, 1.5478260869565, -0.075, 0.27777777777778
88685, 1.5478260869565, -0.1, 0.25
88686, 1.5260869565217, -0.1, 0.22222222222222
88687, 1.5478260869565, -0.075, 0.22222222222222
88688, 1.5478260869565, -0.1, 0.19444444444444
88689, 1.5260869565217, -0.1, 0.16666666666667
88690, 1.5478260869565, -0.075, 0.16666666666667
88691, 1.5478260869565, -0.1, 0.13888888888889
88692, 1.5260869565217, -0.1, 0.11111111111111
88693, 1.5478260869565, -0.075, 0.11111111111111
88694, 1.5478260869565, -0.1, 0.083333333333333
88695, 1.5260869565217, -0.1, 0.055555555555556
88696, 1.5478260869565, -0.075, 0.055555555555556
88697, 1.5478260869565, -0.1, 0.027777777777778
88698, 1.5913043478261, -0.1, 0.47222222222222
88699, 1.5695652173913, -0.1, 0.44444444444444
88700, 1.5913043478261, -0.075, 0.44444444444444
88701, 1.5913043478261, -0.1, 0.41666666666667
88702, 1.5695652173913, -0.1, 0.38888888888889
88703, 1.5913043478261, -0.075, 0.38888888888889
88704, 1.5913043478261, -0.1, 0.36111111111111
88705, 1.5695652173913, -0.1, 0.33333333333333
88706, 1.5913043478261, -0.075, 0.33333333333333
88707, 1.5913043478261, -0.1, 0.30555555555556
88708, 1.5695652173913, -0.1, 0.27777777777778
88709, 1.5913043478261, -0.075, 0.27777777777778
88710, 1.5913043478261, -0.1, 0.25
88711, 1.5695652173913, -0.1, 0.22222222222222
88712, 1.5913043478261, -0.075, 0.22222222222222
88713, 1.5913043478261, -0.1, 0.19444444444444
88714, 1.5695652173913, -0.1, 0.16666666666667
88715, 1.5913043478261, -0.075, 0.16666666666667
88716, 1.5913043478261, -0.1, 0.13888888888889
88717, 1.5695652173913, -0.1, 0.11111111111111
88718, 1.5913043478261, -0.075, 0.11111111111111
88719, 1.5913043478261, -0.1, 0.083333333333333
88720, 1.5695652173913, -0.1, 0.055555555555556
88721, 1.5913043478261, -0.075, 0.055555555555556
88722, 1.5913043478261, -0.1, 0.027777777777778
88723, 1.6347826086957, -0.1, 0.47222222222222
88724, 1.6130434782609, -0.1, 0.44444444444444
88725, 1.6347826086957, -0.075, 0.44444444444444
88726, 1.6347826086957, -0.1, 0.41666666666667
88727, 1.6130434782609, -0.1, 0.38888888888889
88728, 1.6347826086957, -0.075, 0.38888888888889
88729, 1.6347826086957, -0.1, 0.36111111111111
88730, 1.6130434782609, -0.1, 0.33333333333333
88731, 1.6347826086957, -0.075, 0.33333333333333
88732, 1.6347826086957, -0.1, 0.30555555555556
88733, 1.6130434782609, -0.1, 0.27777777777778
88734, 1.6347826086957, -0.075, 0.27777777777778
88735, 1.6347826086957, -0.1, 0.25
88736, 1.6130434782609, -0.1, 0.22222222222222
88737, 1.6347826086957, -0.075, 0.22222222222222
88738, 1.6347826086957, -0.1, 0.19444444444444
88739, 1.6130434782609, -0.1, 0.16666666666667
88740, 1.6347826086957, -0.075, 0.16666666666667
88741, 1.6347826086957, -0.1, 0.13888888888889
88742, 1.6130434782609, -0.1, 0.11111111111111
88743, 1.6347826086957, -0.075, 0.11111111111111
88744, 1.6347826086957, -0.1, 0.083333333333333
88745, 1.6130434782609, -0.1, 0.055555555555556
88746, 1.6347826086957, -0.075, 0.055555555555556
88747, 1.6347826086957, -0.1, 0.027777777777778
88748, 1.6782608695652, -0.1, 0.47222222222222
88749, 1.6565217391304, -0.1, 0.44444444444444
88750, 1.6782608695652, -0.075, 0.44444444444444
88751, 1.6782608695652, -0.1, 0.41666666666667
88752, 1.6565217391304, -0.1, 0.38888888888889
88753, 1.6782608695652, -0.075, 0.38888888888889
88754, 1.6782608695652, -0.1, 0.36111111111111
88755, 1.6565217391304, -0.1, 0.33333333333333
88756, 1.6782608695652, -0.075, 0.33333333333333
88757, 1.6782608695652, -0.1, 0.30555555555556
88758, 1.6565217391304, -0.1, 0.27777777777778
88759, 1.6782608695652, -0.075, 0.27777777777778
88760, 1.6782608695652, -0.1, 0.25
88761, 1.6565217391304, -0.1, 0.22222222222222
88762, 1.6782608695652, -0.075, 0.22222222222222
88763, 1.6782608695652, -0.1, 0.19444444444444
88764, 1.6565217391304, -0.1, 0.16666666666667
88765, 1.6782608695652, -0.075, 0.16666666666667
88766, 1.6782608695652, -0.1, 0.13888888888889
88767, 1.6565217391304, -0.1, 0.11111111111111
88768, 1.6782608695652, -0.075, 0.11111111111111
88769, 1.6782608695652, -0.1, 0.083333333333333
88770, 1.6565217391304, -0.1, 0.055555555555556
88771, 1.6782608695652, -0.075, 0.055555555555556
88772, 1.6782608695652, -0.1, 0.027777777777778
88773, 1.7217391304348, -0.1, 0.47222222222222
88774, 1.7, -0.1, 0.44444444444444
88775, 1.7217391304348, -0.075, 0.44444444444444
88776, 1.7217391304348, -0.1, 0.41666666666667
88777, 1.7, -0.1, 0.38888888888889
88778, 1.7217391304348, -0.075, 0.38888888888889
88779, 1.7217391304348, -0.1, 0.36111111111111
88780, 1.7, -0.1, 0.33333333333333
88781, 1.7217391304348, -0.075, 0.33333333333333
88782, 1.7217391304348, -0.1, 0.30555555555556
88783, 1.7, -0.1, 0.27777777777778
88784, 1.7217391304348, -0.075, 0.27777777777778
88785, 1.7217391304348, -0.1, 0.25
88786, 1.7, -0.1, 0.22222222222222
88787, 1.7217391304348, -0.075, 0.22222222222222
88788, 1.7217391304348, -0.1, 0.19444444444444
88789, 1.7, -0.1, 0.16666666666667
88790, 1.7217391304348, -0.075, 0.16666666666667
88791, 1.7217391304348, -0.1, 0.13888888888889
88792, 1.7, -0.1, 0.11111111111111
88793, 1.7217391304348, -0.075, 0.11111111111111
88794, 1.7217391304348, -0.1, 0.083333333333333
88795, 1.7, -0.1, 0.055555555555556
88796, 1.7217391304348, -0.075, 0.055555555555556
88797, 1.7217391304348, -0.1, 0.027777777777778
88798, 1.7652173913043, -0.1, 0.47222222222222
88799, 1.7434782608696, -0.1, 0.44444444444444
88800, 1.7652173913043, -0.075, 0.44444444444444
88801, 1.7652173913043, -0.1, 0.41666666666667
88802, 1.7434782608696, -0.1, 0.38888888888889
88803, 1.7652173913043, -0.075, 0.38888888888889
88804, 1.7652173913043, -0.1, 0.36111111111111
88805, 1.7434782608696, -0.1, 0.33333333333333
88806, 1.7652173913043, -0.075, 0.33333333333333
88807, 1.7652173913043, -0.1, 0.30555555555556
88808, 1.7434782608696, -0.1, 0.27777777777778
88809, 1.7652173913043, -0.075, 0.27777777777778
88810, 1.7652173913043, -0.1, 0.25
88811, 1.7434782608696, -0.1, 0.22222222222222
88812, 1.7652173913043, -0.075, 0.22222222222222
88813, 1.7652173913043, -0.1, 0.19444444444444
88814, 1.7434782608696, -0.1, 0.16666666666667
88815, 1.7652173913043, -0.075, 0.16666666666667
88816, 1.7652173913043, -0.1, 0.13888888888889
88817, 1.7434782608696, -0.1, 0.11111111111111
88818, 1.7652173913043, -0.075, 0.11111111111111
88819, 1.7652173913043, -0.1, 0.083333333333333
88820, 1.7434782608696, -0.1, 0.055555555555556
88821, 1.7652173913043, -0.075, 0.055555555555556
88822, 1.7652173913043, -0.1, 0.027777777777778
88823, 1.8086956521739, -0.1, 0.47222222222222
88824, 1.7869565217391, -0.1, 0.44444444444444
88825, 1.8086956521739, -0.075, 0.44444444444444
88826, 1.8086956521739, -0.1, 0.41666666666667
88827, 1.7869565217391, -0.1, 0.38888888888889
88828, 1.8086956521739, -0.075, 0.38888888888889
88829, 1.8086956521739, -0.1, 0.36111111111111
88830, 1.7869565217391, -0.1, 0.33333333333333
88831, 1.8086956521739, -0.075, 0.33333333333333
88832, 1.8086956521739, -0.1, 0.30555555555556
88833, 1.7869565217391, -0.1, 0.27777777777778
88834, 1.8086956521739, -0.075, 0.27777777777778
88835, 1.8086956521739, -0.1, 0.25
88836, 1.7869565217391, -0.1, 0.22222222222222
88837, 1.8086956521739, -0.075, 0.22222222222222
88838, 1.8086956521739, -0.1, 0.19444444444444
88839, 1.7869565217391, -0.1, 0.16666666666667
88840, 1.8086956521739, -0.075, 0.16666666666667
88841, 1.8086956521739, -0.1, 0.13888888888889
88842, 1.7869565217391, -0.1, 0.11111111111111
88843, 1.8086956521739, -0.075, 0.11111111111111
88844, 1.8086956521739, -0.1, 0.083333333333333
88845, 1.7869565217391, -0.1, 0.055555555555556
88846, 1.8086956521739, -0.075, 0.055555555555556
88847, 1.8086956521739, -0.1, 0.027777777777778
88848, 1.8521739130435, -0.1, 0.47222222222222
88849, 1.8304347826087, -0.1, 0.44444444444444
88850, 1.8521739130435, -0.075, 0.44444444444444
88851, 1.8521739130435, -0.1, 0.41666666666667
88852, 1.8304347826087, -0.1, 0.38888888888889
88853, 1.8521739130435, -0.075, 0.38888888888889
88854, 1.8521739130435, -0.1, 0.36111111111111
88855, 1.8304347826087, -0.1, 0.33333333333333
88856, 1.8521739130435, -0.075, 0.33333333333333
88857, 1.8521739130435, -0.1, 0.30555555555556
88858, 1.8304347826087, -0.1, 0.27777777777778
88859, 1.8521739130435, -0.075, 0.27777777777778
88860, 1.8521739130435, -0.1, 0.25
88861, 1.8304347826087, -0.1, 0.22222222222222
88862, 1.8521739130435, -0.075, 0.22222222222222
88863, 1.8521739130435, -0.1, 0.19444444444444
88864, 1.8304347826087, -0.1, 0.16666666666667
88865, 1.8521739130435, -0.075, 0.16666666666667
88866, 1.8521739130435, -0.1, 0.13888888888889
88867, 1.8304347826087, -0.1, 0.11111111111111
88868, 1.8521739130435, -0.075, 0.11111111111111
88869, 1.8521739130435, -0.1, 0.083333333333333
88870, 1.8304347826087, -0.1, 0.055555555555556
88871, 1.8521739130435, -0.075, 0.055555555555556
88872, 1.8521739130435, -0.1, 0.027777777777778
88873, 1.895652173913, -0.1, 0.47222222222222
88874, 1.8739130434783, -0.1, 0.44444444444444
88875, 1.895652173913, -0.075, 0.44444444444444
88876, 1.895652173913, -0.1, 0.41666666666667
88877, 1.8739130434783, -0.1, 0.38888888888889
88878, 1.895652173913, -0.075, 0.38888888888889
88879, 1.895652173913, -0.1, 0.36111111111111
88880, 1.8739130434783, -0.1, 0.33333333333333
88881, 1.895652173913, -0.075, 0.33333333333333
88882, 1.895652173913, -0.1, 0.30555555555556
88883, 1.8739130434783, -0.1, 0.27777777777778
88884, 1.895652173913, -0.075, 0.27777777777778
88885, 1.895652173913, -0.1, 0.25
88886, 1.8739130434783, -0.1, 0.22222222222222
88887, 1.895652173913, -0.075, 0.22222222222222
88888, 1.895652173913, -0.1, 0.19444444444444
88889, 1.8739130434783, -0.1, 0.16666666666667
88890, 1.895652173913, -0.075, 0.16666666666667
88891, 1.895652173913, -0.1, 0.13888888888889
88892, 1.8739130434783, -0.1, 0.11111111111111
88893, 1.895652173913, -0.075, 0.11111111111111
88894, 1.895652173913, -0.1, 0.083333333333333
88895, 1.8739130434783, -0.1, 0.055555555555556
88896, 1.895652173913, -0.075, 0.055555555555556
88897, 1.895652173913, -0.1, 0.027777777777778
88898, 1.9391304347826, -0.1, 0.47222222222222
88899, 1.9173913043478, -0.1, 0.44444444444444
88900, 1.9391304347826, -0.075, 0.44444444444444
88901, 1.9391304347826, -0.1, 0.41666666666667
88902, 1.9173913043478, -0.1, 0.38888888888889
88903, 1.9391304347826, -0.075, 0.38888888888889
88904, 1.9391304347826, -0.1, 0.36111111111111
88905, 1.9173913043478, -0.1, 0.33333333333333
88906, 1.9391304347826, -0.075, 0.33333333333333
88907, 1.9391304347826, -0.1, 0.30555555555556
88908, 1.9173913043478, -0.1, 0.27777777777778
88909, 1.9391304347826, -0.075, 0.27777777777778
88910, 1.9391304347826, -0.1, 0.25
88911, 1.9173913043478, -0.1, 0.22222222222222
88912, 1.9391304347826, -0.075, 0.22222222222222
88913, 1.9391304347826, -0.1, 0.19444444444444
88914, 1.9173913043478, -0.1, 0.16666666666667
88915, 1.9391304347826, -0.075, 0.16666666666667
88916, 1.9391304347826, -0.1, 0.13888888888889
88917, 1.9173913043478, -0.1, 0.11111111111111
88918, 1.9391304347826, -0.075, 0.11111111111111
88919, 1.9391304347826, -0.1, 0.083333333333333
88920, 1.9173913043478, -0.1, 0.055555555555556
88921, 1.9391304347826, -0.075, 0.055555555555556
88922, 1.9391304347826, -0.1, 0.027777777777778
88923, 1.9826086956522, -0.1, 0.47222222222222
88924, 1.9608695652174, -0.1, 0.44444444444444
88925, 1.9826086956522, -0.075, 0.44444444444444
88926, 1.9826086956522, -0.1, 0.41666666666667
88927, 1.9608695652174, -0.1, 0.38888888888889
88928, 1.9826086956522, -0.075, 0.38888888888889
88929, 1.9826086956522, -0.1, 0.36111111111111
88930, 1.9608695652174, -0.1, 0.33333333333333
88931, 1.9826086956522, -0.075, 0.33333333333333
88932, 1.9826086956522, -0.1, 0.30555555555556
88933, 1.9608695652174, -0.1, 0.27777777777778
88934, 1.9826086956522, -0.075, 0.27777777777778
88935, 1.9826086956522, -0.1, 0.25
88936, 1.9608695652174, -0.1, 0.22222222222222
88937, 1.9826086956522, -0.075, 0.22222222222222
88938, 1.9826086956522, -0.1, 0.19444444444444
88939, 1.9608695652174, -0.1, 0.16666666666667
88940, 1.9826086956522, -0.075, 0.16666666666667
88941, 1.9826086956522, -0.1, 0.13888888888889
88942, 1.9608695652174, -0.1, 0.11111111111111
88943, 1.9826086956522, -0.075, 0.11111111111111
88944, 1.9826086956522, -0.1, 0.083333333333333
88945, 1.9608695652174, -0.1, 0.055555555555556
88946, 1.9826086956522, -0.075, 0.055555555555556
88947, 1.9826086956522, -0.1, 0.027777777777778
88948, 2.0260869565217, -0.1, 0.47222222222222
88949, 2.004347826087, -0.1, 0.44444444444444
88950, 2.0260869565217, -0.075, 0.44444444444444
88951, 2.0260869565217, -0.1, 0.41666666666667
88952, 2.004347826087, -0.1, 0.38888888888889
88953, 2.0260869565217, -0.075, 0.38888888888889
88954, 2.0260869565217, -0.1, 0.36111111111111
88955, 2.004347826087, -0.1, 0.33333333333333
88956, 2.0260869565217, -0.075, 0.33333333333333
88957, 2.0260869565217, -0.1, 0.30555555555556
88958, 2.004347826087, -0.1, 0.27777777777778
88959, 2.0260869565217, -0.075, 0.27777777777778
88960, 2.0260869565217, -0.1, 0.25
88961, 2.004347826087, -0.1, 0.22222222222222
88962, 2.0260869565217, -0.075, 0.22222222222222
88963, 2.0260869565217, -0.1, 0.19444444444444
88964, 2.004347826087, -0.1, 0.16666666666667
88965, 2.0260869565217, -0.075, 0.16666666666667
88966, 2.0260869565217, -0.1, 0.13888888888889
88967, 2.004347826087, -0.1, 0.11111111111111
88968, 2.0260869565217, -0.075, 0.11111111111111
88969, 2.0260869565217, -0.1, 0.083333333333333
88970, 2.004347826087, -0.1, 0.055555555555556
88971, 2.0260869565217, -0.075, 0.055555555555556
88972, 2.0260869565217, -0.1, 0.027777777777778
88973, 2.0695652173913, -0.1, 0.47222222222222
88974, 2.0478260869565, -0.1, 0.44444444444444
88975, 2.0695652173913, -0.075, 0.44444444444444
88976, 2.0695652173913, -0.1, 0.41666666666667
88977, 2.0478260869565, -0.1, 0.38888888888889
88978, 2.0695652173913, -0.075, 0.38888888888889
88979, 2.0695652173913, -0.1, 0.36111111111111
88980, 2.0478260869565, -0.1, 0.33333333333333
88981, 2.0695652173913, -0.075, 0.33333333333333
88982, 2.0695652173913, -0.1, 0.30555555555556
88983, 2.0478260869565, -0.1, 0.27777777777778
88984, 2.0695652173913, -0.075, 0.27777777777778
88985, 2.0695652173913, -0.1, 0.25
88986, 2.0478260869565, -0.1, 0.22222222222222
88987, 2.0695652173913, -0.075, 0.22222222222222
88988, 2.0695652173913, -0.1, 0.19444444444444
88989, 2.0478260869565, -0.1, 0.16666666666667
88990, 2.0695652173913, -0.075, 0.16666666666667
88991, 2.0695652173913, -0.1, 0.13888888888889
88992, 2.0478260869565, -0.1, 0.11111111111111
88993, 2.0695652173913, -0.075, 0.11111111111111
88994, 2.0695652173913, -0.1, 0.083333333333333
88995, 2.0478260869565, -0.1, 0.055555555555556
88996, 2.0695652173913, -0.075, 0.055555555555556
88997, 2.0695652173913, -0.1, 0.027777777777778
88998, 2.1130434782609, -0.1, 0.47222222222222
88999, 2.0913043478261, -0.1, 0.44444444444444
89000, 2.1130434782609, -0.075, 0.44444444444444
89001, 2.1130434782609, -0.1, 0.41666666666667
89002, 2.0913043478261, -0.1, 0.38888888888889
89003, 2.1130434782609, -0.075, 0.38888888888889
89004, 2.1130434782609, -0.1, 0.36111111111111
89005, 2.0913043478261, -0.1, 0.33333333333333
89006, 2.1130434782609, -0.075, 0.33333333333333
89007, 2.1130434782609, -0.1, 0.30555555555556
89008, 2.0913043478261, -0.1, 0.27777777777778
89009, 2.1130434782609, -0.075, 0.27777777777778
89010, 2.1130434782609, -0.1, 0.25
89011, 2.0913043478261, -0.1, 0.22222222222222
89012, 2.1130434782609, -0.075, 0.22222222222222
89013, 2.1130434782609, -0.1, 0.19444444444444
89014, 2.0913043478261, -0.1, 0.16666666666667
89015, 2.1130434782609, -0.075, 0.16666666666667
89016, 2.1130434782609, -0.1, 0.13888888888889
89017, 2.0913043478261, -0.1, 0.11111111111111
89018, 2.1130434782609, -0.075, 0.11111111111111
89019, 2.1130434782609, -0.1, 0.083333333333333
89020, 2.0913043478261, -0.1, 0.055555555555556
89021, 2.1130434782609, -0.075, 0.055555555555556
89022, 2.1130434782609, -0.1, 0.027777777777778
89023, 2.1565217391304, -0.1, 0.47222222222222
89024, 2.1347826086957, -0.1, 0.44444444444444
89025, 2.1565217391304, -0.075, 0.44444444444444
89026, 2.1565217391304, -0.1, 0.41666666666667
89027, 2.1347826086957, -0.1, 0.38888888888889
89028, 2.1565217391304, -0.075, 0.38888888888889
89029, 2.1565217391304, -0.1, 0.36111111111111
89030, 2.1347826086957, -0.1, 0.33333333333333
89031, 2.1565217391304, -0.075, 0.33333333333333
89032, 2.1565217391304, -0.1, 0.30555555555556
89033, 2.1347826086957, -0.1, 0.27777777777778
89034, 2.1565217391304, -0.075, 0.27777777777778
89035, 2.1565217391304, -0.1, 0.25
89036, 2.1347826086957, -0.1, 0.22222222222222
89037, 2.1565217391304, -0.075, 0.22222222222222
89038, 2.1565217391304, -0.1, 0.19444444444444
89039, 2.1347826086957, -0.1, 0.16666666666667
89040, 2.1565217391304, -0.075, 0.16666666666667
89041, 2.1565217391304, -0.1, 0.13888888888889
89042, 2.1347826086957, -0.1, 0.11111111111111
89043, 2.1565217391304, -0.075, 0.11111111111111
89044, 2.1565217391304, -0.1, 0.083333333333333
89045, 2.1347826086957, -0.1, 0.055555555555556
89046, 2.1565217391304, -0.075, 0.055555555555556
89047, 2.1565217391304, -0.1, 0.027777777777778
89048, 2.1782608695652, -0.1, 0.44444444444444
89049, 2.1782608695652, -0.1, 0.38888888888889
89050, 2.1782608695652, -0.1, 0.33333333333333
89051, 2.1782608695652, -0.1, 0.27777777777778
89052, 2.1782608695652, -0.1, 0.22222222222222
89053, 2.1782608695652, -0.1, 0.16666666666667
89054, 2.1782608695652, -0.1, 0.11111111111111
89055, 2.1782608695652, -0.1, 0.055555555555556
89056, 1.2434782608696, -0.15, 0.47222222222222
89057, 1.2217391304348, -0.15, 0.44444444444444
89058, 1.2434782608696, -0.125, 0.44444444444444
89059, 1.2434782608696, -0.15, 0.41666666666667
89060, 1.2217391304348, -0.15, 0.38888888888889
89061, 1.2434782608696, -0.125, 0.38888888888889
89062, 1.2434782608696, -0.15, 0.36111111111111
89063, 1.2217391304348, -0.15, 0.33333333333333
89064, 1.2434782608696, -0.125, 0.33333333333333
89065, 1.2434782608696, -0.15, 0.30555555555556
89066, 1.2217391304348, -0.15, 0.27777777777778
89067, 1.2434782608696, -0.125, 0.27777777777778
89068, 1.2434782608696, -0.15, 0.25
89069, 1.2217391304348, -0.15, 0.22222222222222
89070, 1.2434782608696, -0.125, 0.22222222222222
89071, 1.2434782608696, -0.15, 0.19444444444444
89072, 1.2217391304348, -0.15, 0.16666666666667
89073, 1.2434782608696, -0.125, 0.16666666666667
89074, 1.2434782608696, -0.15, 0.13888888888889
89075, 1.2217391304348, -0.15, 0.11111111111111
89076, 1.2434782608696, -0.125, 0.11111111111111
89077, 1.2434782608696, -0.15, 0.083333333333333
89078, 1.2217391304348, -0.15, 0.055555555555556
89079, 1.2434782608696, -0.125, 0.055555555555556
89080, 1.2434782608696, -0.15, 0.027777777777778
89081, 1.2869565217391, -0.15, 0.47222222222222
89082, 1.2652173913043, -0.15, 0.44444444444444
89083, 1.2869565217391, -0.125, 0.44444444444444
89084, 1.2869565217391, -0.15, 0.41666666666667
89085, 1.2652173913043, -0.15, 0.38888888888889
89086, 1.2869565217391, -0.125, 0.38888888888889
89087, 1.2869565217391, -0.15, 0.36111111111111
89088, 1.2652173913043, -0.15, 0.33333333333333
89089, 1.2869565217391, -0.125, 0.33333333333333
89090, 1.2869565217391, -0.15, 0.30555555555556
89091, 1.2652173913043, -0.15, 0.27777777777778
89092, 1.2869565217391, -0.125, 0.27777777777778
89093, 1.2869565217391, -0.15, 0.25
89094, 1.2652173913043, -0.15, 0.22222222222222
89095, 1.2869565217391, -0.125, 0.22222222222222
89096, 1.2869565217391, -0.15, 0.19444444444444
89097, 1.2652173913043, -0.15, 0.16666666666667
89098, 1.2869565217391, -0.125, 0.16666666666667
89099, 1.2869565217391, -0.15, 0.13888888888889
89100, 1.2652173913043, -0.15, 0.11111111111111
89101, 1.2869565217391, -0.125, 0.11111111111111
89102, 1.2869565217391, -0.15, 0.083333333333333
89103, 1.2652173913043, -0.15, 0.055555555555556
89104, 1.2869565217391, -0.125, 0.055555555555556
89105, 1.2869565217391, -0.15, 0.027777777777778
89106, 1.3304347826087, -0.15, 0.47222222222222
89107, 1.3086956521739, -0.15, 0.44444444444444
89108, 1.3304347826087, -0.125, 0.44444444444444
89109, 1.3304347826087, -0.15, 0.41666666666667
89110, 1.3086956521739, -0.15, 0.38888888888889
89111, 1.3304347826087, -0.125, 0.38888888888889
89112, 1.3304347826087, -0.15, 0.36111111111111
89113, 1.3086956521739, -0.15, 0.33333333333333
89114, 1.3304347826087, -0.125, 0.33333333333333
89115, 1.3304347826087, -0.15, 0.30555555555556
89116, 1.3086956521739, -0.15, 0.27777777777778
89117, 1.3304347826087, -0.125, 0.27777777777778
89118, 1.3304347826087, -0.15, 0.25
89119, 1.3086956521739, -0.15, 0.22222222222222
89120, 1.3304347826087, -0.125, 0.22222222222222
89121, 1.3304347826087, -0.15, 0.19444444444444
89122, 1.3086956521739, -0.15, 0.16666666666667
89123, 1.3304347826087, -0.125, 0.16666666666667
89124, 1.3304347826087, -0.15, 0.13888888888889
89125, 1.3086956521739, -0.15, 0.11111111111111
89126, 1.3304347826087, -0.125, 0.11111111111111
89127, 1.3304347826087, -0.15, 0.083333333333333
89128, 1.3086956521739, -0.15, 0.055555555555556
89129, 1.3304347826087, -0.125, 0.055555555555556
89130, 1.3304347826087, -0.15, 0.027777777777778
89131, 1.3739130434783, -0.15, 0.47222222222222
89132, 1.3521739130435, -0.15, 0.44444444444444
89133, 1.3739130434783, -0.125, 0.44444444444444
89134, 1.3739130434783, -0.15, 0.41666666666667
89135, 1.3521739130435, -0.15, 0.38888888888889
89136, 1.3739130434783, -0.125, 0.38888888888889
89137, 1.3739130434783, -0.15, 0.36111111111111
89138, 1.3521739130435, -0.15, 0.33333333333333
89139, 1.3739130434783, -0.125, 0.33333333333333
89140, 1.3739130434783, -0.15, 0.30555555555556
89141, 1.3521739130435, -0.15, 0.27777777777778
89142, 1.3739130434783, -0.125, 0.27777777777778
89143, 1.3739130434783, -0.15, 0.25
89144, 1.3521739130435, -0.15, 0.22222222222222
89145, 1.3739130434783, -0.125, 0.22222222222222
89146, 1.3739130434783, -0.15, 0.19444444444444
89147, 1.3521739130435, -0.15, 0.16666666666667
89148, 1.3739130434783, -0.125, 0.16666666666667
89149, 1.3739130434783, -0.15, 0.13888888888889
89150, 1.3521739130435, -0.15, 0.11111111111111
89151, 1.3739130434783, -0.125, 0.11111111111111
89152, 1.3739130434783, -0.15, 0.083333333333333
89153, 1.3521739130435, -0.15, 0.055555555555556
89154, 1.3739130434783, -0.125, 0.055555555555556
89155, 1.3739130434783, -0.15, 0.027777777777778
89156, 1.4173913043478, -0.15, 0.47222222222222
89157, 1.395652173913, -0.15, 0.44444444444444
89158, 1.4173913043478, -0.125, 0.44444444444444
89159, 1.4173913043478, -0.15, 0.41666666666667
89160, 1.395652173913, -0.15, 0.38888888888889
89161, 1.4173913043478, -0.125, 0.38888888888889
89162, 1.4173913043478, -0.15, 0.36111111111111
89163, 1.395652173913, -0.15, 0.33333333333333
89164, 1.4173913043478, -0.125, 0.33333333333333
89165, 1.4173913043478, -0.15, 0.30555555555556
89166, 1.395652173913, -0.15, 0.27777777777778
89167, 1.4173913043478, -0.125, 0.27777777777778
89168, 1.4173913043478, -0.15, 0.25
89169, 1.395652173913, -0.15, 0.22222222222222
89170, 1.4173913043478, -0.125, 0.22222222222222
89171, 1.4173913043478, -0.15, 0.19444444444444
89172, 1.395652173913, -0.15, 0.16666666666667
89173, 1.4173913043478, -0.125, 0.16666666666667
89174, 1.4173913043478, -0.15, 0.13888888888889
89175, 1.395652173913, -0.15, 0.11111111111111
89176, 1.4173913043478, -0.125, 0.11111111111111
89177, 1.4173913043478, -0.15, 0.083333333333333
89178, 1.395652173913, -0.15, 0.055555555555556
89179, 1.4173913043478, -0.125, 0.055555555555556
89180, 1.4173913043478, -0.15, 0.027777777777778
89181, 1.4608695652174, -0.15, 0.47222222222222
89182, 1.4391304347826, -0.15, 0.44444444444444
89183, 1.4608695652174, -0.125, 0.44444444444444
89184, 1.4608695652174, -0.15, 0.41666666666667
89185, 1.4391304347826, -0.15, 0.38888888888889
89186, 1.4608695652174, -0.125, 0.38888888888889
89187, 1.4608695652174, -0.15, 0.36111111111111
89188, 1.4391304347826, -0.15, 0.33333333333333
89189, 1.4608695652174, -0.125, 0.33333333333333
89190, 1.4608695652174, -0.15, 0.30555555555556
89191, 1.4391304347826, -0.15, 0.27777777777778
89192, 1.4608695652174, -0.125, 0.27777777777778
89193, 1.4608695652174, -0.15, 0.25
89194, 1.4391304347826, -0.15, 0.22222222222222
89195, 1.4608695652174, -0.125, 0.22222222222222
89196, 1.4608695652174, -0.15, 0.19444444444444
89197, 1.4391304347826, -0.15, 0.16666666666667
89198, 1.4608695652174, -0.125, 0.16666666666667
89199, 1.4608695652174, -0.15, 0.13888888888889
89200, 1.4391304347826, -0.15, 0.11111111111111
89201, 1.4608695652174, -0.125, 0.11111111111111
89202, 1.4608695652174, -0.15, 0.083333333333333
89203, 1.4391304347826, -0.15, 0.055555555555556
89204, 1.4608695652174, -0.125, 0.055555555555556
89205, 1.4608695652174, -0.15, 0.027777777777778
89206, 1.504347826087, -0.15, 0.47222222222222
89207, 1.4826086956522, -0.15, 0.44444444444444
89208, 1.504347826087, -0.125, 0.44444444444444
89209, 1.504347826087, -0.15, 0.41666666666667
89210, 1.4826086956522, -0.15, 0.38888888888889
89211, 1.504347826087, -0.125, 0.38888888888889
89212, 1.504347826087, -0.15, 0.36111111111111
89213, 1.4826086956522, -0.15, 0.33333333333333
89214, 1.504347826087, -0.125, 0.33333333333333
89215, 1.504347826087, -0.15, 0.30555555555556
89216, 1.4826086956522, -0.15, 0.27777777777778
89217, 1.504347826087, -0.125, 0.27777777777778
89218, 1.504347826087, -0.15, 0.25
89219, 1.4826086956522, -0.15, 0.22222222222222
89220, 1.504347826087, -0.125, 0.22222222222222
89221, 1.504347826087, -0.15, 0.19444444444444
89222, 1.4826086956522, -0.15, 0.16666666666667
89223, 1.504347826087, -0.125, 0.16666666666667
89224, 1.504347826087, -0.15, 0.13888888888889
89225, 1.4826086956522, -0.15, 0.11111111111111
89226, 1.504347826087, -0.125, 0.11111111111111
89227, 1.504347826087, -0.15, 0.083333333333333
89228, 1.4826086956522, -0.15, 0.055555555555556
89229, 1.504347826087, -0.125, 0.055555555555556
89230, 1.504347826087, -0.15, 0.027777777777778
89231, 1.5478260869565, -0.15, 0.47222222222222
89232, 1.5260869565217, -0.15, 0.44444444444444
89233, 1.5478260869565, -0.125, 0.44444444444444
89234, 1.5478260869565, -0.15, 0.41666666666667
89235, 1.5260869565217, -0.15, 0.38888888888889
89236, 1.5478260869565, -0.125, 0.38888888888889
89237, 1.5478260869565, -0.15, 0.36111111111111
89238, 1.5260869565217, -0.15, 0.33333333333333
89239, 1.5478260869565, -0.125, 0.33333333333333
89240, 1.5478260869565, -0.15, 0.30555555555556
89241, 1.5260869565217, -0.15, 0.27777777777778
89242, 1.5478260869565, -0.125, 0.27777777777778
89243, 1.5478260869565, -0.15, 0.25
89244, 1.5260869565217, -0.15, 0.22222222222222
89245, 1.5478260869565, -0.125, 0.22222222222222
89246, 1.5478260869565, -0.15, 0.19444444444444
89247, 1.5260869565217, -0.15, 0.16666666666667
89248, 1.5478260869565, -0.125, 0.16666666666667
89249, 1.5478260869565, -0.15, 0.13888888888889
89250, 1.5260869565217, -0.15, 0.11111111111111
89251, 1.5478260869565, -0.125, 0.11111111111111
89252, 1.5478260869565, -0.15, 0.083333333333333
89253, 1.5260869565217, -0.15, 0.055555555555556
89254, 1.5478260869565, -0.125, 0.055555555555556
89255, 1.5478260869565, -0.15, 0.027777777777778
89256, 1.5913043478261, -0.15, 0.47222222222222
89257, 1.5695652173913, -0.15, 0.44444444444444
89258, 1.5913043478261, -0.125, 0.44444444444444
89259, 1.5913043478261, -0.15, 0.41666666666667
89260, 1.5695652173913, -0.15, 0.38888888888889
89261, 1.5913043478261, -0.125, 0.38888888888889
89262, 1.5913043478261, -0.15, 0.36111111111111
89263, 1.5695652173913, -0.15, 0.33333333333333
89264, 1.5913043478261, -0.125, 0.33333333333333
89265, 1.5913043478261, -0.15, 0.30555555555556
89266, 1.5695652173913, -0.15, 0.27777777777778
89267, 1.5913043478261, -0.125, 0.27777777777778
89268, 1.5913043478261, -0.15, 0.25
89269, 1.5695652173913, -0.15, 0.22222222222222
89270, 1.5913043478261, -0.125, 0.22222222222222
89271, 1.5913043478261, -0.15, 0.19444444444444
89272, 1.5695652173913, -0.15, 0.16666666666667
89273, 1.5913043478261, -0.125, 0.16666666666667
89274, 1.5913043478261, -0.15, 0.13888888888889
89275, 1.5695652173913, -0.15, 0.11111111111111
89276, 1.5913043478261, -0.125, 0.11111111111111
89277, 1.5913043478261, -0.15, 0.083333333333333
89278, 1.5695652173913, -0.15, 0.055555555555556
89279, 1.5913043478261, -0.125, 0.055555555555556
89280, 1.5913043478261, -0.15, 0.027777777777778
89281, 1.6347826086957, -0.15, 0.47222222222222
89282, 1.6130434782609, -0.15, 0.44444444444444
89283, 1.6347826086957, -0.125, 0.44444444444444
89284, 1.6347826086957, -0.15, 0.41666666666667
89285, 1.6130434782609, -0.15, 0.38888888888889
89286, 1.6347826086957, -0.125, 0.38888888888889
89287, 1.6347826086957, -0.15, 0.36111111111111
89288, 1.6130434782609, -0.15, 0.33333333333333
89289, 1.6347826086957, -0.125, 0.33333333333333
89290, 1.6347826086957, -0.15, 0.30555555555556
89291, 1.6130434782609, -0.15, 0.27777777777778
89292, 1.6347826086957, -0.125, 0.27777777777778
89293, 1.6347826086957, -0.15, 0.25
89294, 1.6130434782609, -0.15, 0.22222222222222
89295, 1.6347826086957, -0.125, 0.22222222222222
89296, 1.6347826086957, -0.15, 0.19444444444444
89297, 1.6130434782609, -0.15, 0.16666666666667
89298, 1.6347826086957, -0.125, 0.16666666666667
89299, 1.6347826086957, -0.15, 0.13888888888889
89300, 1.6130434782609, -0.15, 0.11111111111111
89301, 1.6347826086957, -0.125, 0.11111111111111
89302, 1.6347826086957, -0.15, 0.083333333333333
89303, 1.6130434782609, -0.15, 0.055555555555556
89304, 1.6347826086957, -0.125, 0.055555555555556
89305, 1.6347826086957, -0.15, 0.027777777777778
89306, 1.6782608695652, -0.15, 0.47222222222222
89307, 1.6565217391304, -0.15, 0.44444444444444
89308, 1.6782608695652, -0.125, 0.44444444444444
89309, 1.6782608695652, -0.15, 0.41666666666667
89310, 1.6565217391304, -0.15, 0.38888888888889
89311, 1.6782608695652, -0.125, 0.38888888888889
89312, 1.6782608695652, -0.15, 0.36111111111111
89313, 1.6565217391304, -0.15, 0.33333333333333
89314, 1.6782608695652, -0.125, 0.33333333333333
89315, 1.6782608695652, -0.15, 0.30555555555556
89316, 1.6565217391304, -0.15, 0.27777777777778
89317, 1.6782608695652, -0.125, 0.27777777777778
89318, 1.6782608695652, -0.15, 0.25
89319, 1.6565217391304, -0.15, 0.22222222222222
89320, 1.6782608695652, -0.125, 0.22222222222222
89321, 1.6782608695652, -0.15, 0.19444444444444
89322, 1.6565217391304, -0.15, 0.16666666666667
89323, 1.6782608695652, -0.125, 0.16666666666667
89324, 1.6782608695652, -0.15, 0.13888888888889
89325, 1.6565217391304, -0.15, 0.11111111111111
89326, 1.6782608695652, -0.125, 0.11111111111111
89327, 1.6782608695652, -0.15, 0.083333333333333
89328, 1.6565217391304, -0.15, 0.055555555555556
89329, 1.6782608695652, -0.125, 0.055555555555556
89330, 1.6782608695652, -0.15, 0.027777777777778
89331, 1.7217391304348, -0.15, 0.47222222222222
89332, 1.7, -0.15, 0.44444444444444
89333, 1.7217391304348, -0.125, 0.44444444444444
89334, 1.7217391304348, -0.15, 0.41666666666667
89335, 1.7, -0.15, 0.38888888888889
89336, 1.7217391304348, -0.125, 0.38888888888889
89337, 1.7217391304348, -0.15, 0.36111111111111
89338, 1.7, -0.15, 0.33333333333333
89339, 1.7217391304348, -0.125, 0.33333333333333
89340, 1.7217391304348, -0.15, 0.30555555555556
89341, 1.7, -0.15, 0.27777777777778
89342, 1.7217391304348, -0.125, 0.27777777777778
89343, 1.7217391304348, -0.15, 0.25
89344, 1.7, -0.15, 0.22222222222222
89345, 1.7217391304348, -0.125, 0.22222222222222
89346, 1.7217391304348, -0.15, 0.19444444444444
89347, 1.7, -0.15, 0.16666666666667
89348, 1.7217391304348, -0.125, 0.16666666666667
89349, 1.7217391304348, -0.15, 0.13888888888889
89350, 1.7, -0.15, 0.11111111111111
89351, 1.7217391304348, -0.125, 0.11111111111111
89352, 1.7217391304348, -0.15, 0.083333333333333
89353, 1.7, -0.15, 0.055555555555556
89354, 1.7217391304348, -0.125, 0.055555555555556
89355, 1.7217391304348, -0.15, 0.027777777777778
89356, 1.7652173913043, -0.15, 0.47222222222222
89357, 1.7434782608696, -0.15, 0.44444444444444
89358, 1.7652173913043, -0.125, 0.44444444444444
89359, 1.7652173913043, -0.15, 0.41666666666667
89360, 1.7434782608696, -0.15, 0.38888888888889
89361, 1.7652173913043, -0.125, 0.38888888888889
89362, 1.7652173913043, -0.15, 0.36111111111111
89363, 1.7434782608696, -0.15, 0.33333333333333
89364, 1.7652173913043, -0.125, 0.33333333333333
89365, 1.7652173913043, -0.15, 0.30555555555556
89366, 1.7434782608696, -0.15, 0.27777777777778
89367, 1.7652173913043, -0.125, 0.27777777777778
89368, 1.7652173913043, -0.15, 0.25
89369, 1.7434782608696, -0.15, 0.22222222222222
89370, 1.7652173913043, -0.125, 0.22222222222222
89371, 1.7652173913043, -0.15, 0.19444444444444
89372, 1.7434782608696, -0.15, 0.16666666666667
89373, 1.7652173913043, -0.125, 0.16666666666667
89374, 1.7652173913043, -0.15, 0.13888888888889
89375, 1.7434782608696, -0.15, 0.11111111111111
89376, 1.7652173913043, -0.125, 0.11111111111111
89377, 1.7652173913043, -0.15, 0.083333333333333
89378, 1.7434782608696, -0.15, 0.055555555555556
89379, 1.7652173913043, -0.125, 0.055555555555556
89380, 1.7652173913043, -0.15, 0.027777777777778
89381, 1.8086956521739, -0.15, 0.47222222222222
89382, 1.7869565217391, -0.15, 0.44444444444444
89383, 1.8086956521739, -0.125, 0.44444444444444
89384, 1.8086956521739, -0.15, 0.41666666666667
89385, 1.7869565217391, -0.15, 0.38888888888889
89386, 1.8086956521739, -0.125, 0.38888888888889
89387, 1.8086956521739, -0.15, 0.36111111111111
89388, 1.7869565217391, -0.15, 0.33333333333333
89389, 1.8086956521739, -0.125, 0.33333333333333
89390, 1.8086956521739, -0.15, 0.30555555555556
89391, 1.7869565217391, -0.15, 0.27777777777778
89392, 1.8086956521739, -0.125, 0.27777777777778
89393, 1.8086956521739, -0.15, 0.25
89394, 1.7869565217391, -0.15, 0.22222222222222
89395, 1.8086956521739, -0.125, 0.22222222222222
89396, 1.8086956521739, -0.15, 0.19444444444444
89397, 1.7869565217391, -0.15, 0.16666666666667
89398, 1.8086956521739, -0.125, 0.16666666666667
89399, 1.8086956521739, -0.15, 0.13888888888889
89400, 1.7869565217391, -0.15, 0.11111111111111
89401, 1.8086956521739, -0.125, 0.11111111111111
89402, 1.8086956521739, -0.15, 0.083333333333333
89403, 1.7869565217391, -0.15, 0.055555555555556
89404, 1.8086956521739, -0.125, 0.055555555555556
89405, 1.8086956521739, -0.15, 0.027777777777778
89406, 1.8521739130435, -0.15, 0.47222222222222
89407, 1.8304347826087, -0.15, 0.44444444444444
89408, 1.8521739130435, -0.125, 0.44444444444444
89409, 1.8521739130435, -0.15, 0.41666666666667
89410, 1.8304347826087, -0.15, 0.38888888888889
89411, 1.8521739130435, -0.125, 0.38888888888889
89412, 1.8521739130435, -0.15, 0.36111111111111
89413, 1.8304347826087, -0.15, 0.33333333333333
89414, 1.8521739130435, -0.125, 0.33333333333333
89415, 1.8521739130435, -0.15, 0.30555555555556
89416, 1.8304347826087, -0.15, 0.27777777777778
89417, 1.8521739130435, -0.125, 0.27777777777778
89418, 1.8521739130435, -0.15, 0.25
89419, 1.8304347826087, -0.15, 0.22222222222222
89420, 1.8521739130435, -0.125, 0.22222222222222
89421, 1.8521739130435, -0.15, 0.19444444444444
89422, 1.8304347826087, -0.15, 0.16666666666667
89423, 1.8521739130435, -0.125, 0.16666666666667
89424, 1.8521739130435, -0.15, 0.13888888888889
89425, 1.8304347826087, -0.15, 0.11111111111111
89426, 1.8521739130435, -0.125, 0.11111111111111
89427, 1.8521739130435, -0.15, 0.083333333333333
89428, 1.8304347826087, -0.15, 0.055555555555556
89429, 1.8521739130435, -0.125, 0.055555555555556
89430, 1.8521739130435, -0.15, 0.027777777777778
89431, 1.895652173913, -0.15, 0.47222222222222
89432, 1.8739130434783, -0.15, 0.44444444444444
89433, 1.895652173913, -0.125, 0.44444444444444
89434, 1.895652173913, -0.15, 0.41666666666667
89435, 1.8739130434783, -0.15, 0.38888888888889
89436, 1.895652173913, -0.125, 0.38888888888889
89437, 1.895652173913, -0.15, 0.36111111111111
89438, 1.8739130434783, -0.15, 0.33333333333333
89439, 1.895652173913, -0.125, 0.33333333333333
89440, 1.895652173913, -0.15, 0.30555555555556
89441, 1.8739130434783, -0.15, 0.27777777777778
89442, 1.895652173913, -0.125, 0.27777777777778
89443, 1.895652173913, -0.15, 0.25
89444, 1.8739130434783, -0.15, 0.22222222222222
89445, 1.895652173913, -0.125, 0.22222222222222
89446, 1.895652173913, -0.15, 0.19444444444444
89447, 1.8739130434783, -0.15, 0.16666666666667
89448, 1.895652173913, -0.125, 0.16666666666667
89449, 1.895652173913, -0.15, 0.13888888888889
89450, 1.8739130434783, -0.15, 0.11111111111111
89451, 1.895652173913, -0.125, 0.11111111111111
89452, 1.895652173913, -0.15, 0.083333333333333
89453, 1.8739130434783, -0.15, 0.055555555555556
89454, 1.895652173913, -0.125, 0.055555555555556
89455, 1.895652173913, -0.15, 0.027777777777778
89456, 1.9391304347826, -0.15, 0.47222222222222
89457, 1.9173913043478, -0.15, 0.44444444444444
89458, 1.9391304347826, -0.125, 0.44444444444444
89459, 1.9391304347826, -0.15, 0.41666666666667
89460, 1.9173913043478, -0.15, 0.38888888888889
89461, 1.9391304347826, -0.125, 0.38888888888889
89462, 1.9391304347826, -0.15, 0.36111111111111
89463, 1.9173913043478, -0.15, 0.33333333333333
89464, 1.9391304347826, -0.125, 0.33333333333333
89465, 1.9391304347826, -0.15, 0.30555555555556
89466, 1.9173913043478, -0.15, 0.27777777777778
89467, 1.9391304347826, -0.125, 0.27777777777778
89468, 1.9391304347826, -0.15, 0.25
89469, 1.9173913043478, -0.15, 0.22222222222222
89470, 1.9391304347826, -0.125, 0.22222222222222
89471, 1.9391304347826, -0.15, 0.19444444444444
89472, 1.9173913043478, -0.15, 0.16666666666667
89473, 1.9391304347826, -0.125, 0.16666666666667
89474, 1.9391304347826, -0.15, 0.13888888888889
89475, 1.9173913043478, -0.15, 0.11111111111111
89476, 1.9391304347826, -0.125, 0.11111111111111
89477, 1.9391304347826, -0.15, 0.083333333333333
89478, 1.9173913043478, -0.15, 0.055555555555556
89479, 1.9391304347826, -0.125, 0.055555555555556
89480, 1.9391304347826, -0.15, 0.027777777777778
89481, 1.9826086956522, -0.15, 0.47222222222222
89482, 1.9608695652174, -0.15, 0.44444444444444
89483, 1.9826086956522, -0.125, 0.44444444444444
89484, 1.9826086956522, -0.15, 0.41666666666667
89485, 1.9608695652174, -0.15, 0.38888888888889
89486, 1.9826086956522, -0.125, 0.38888888888889
89487, 1.9826086956522, -0.15, 0.36111111111111
89488, 1.9608695652174, -0.15, 0.33333333333333
89489, 1.9826086956522, -0.125, 0.33333333333333
89490, 1.9826086956522, -0.15, 0.30555555555556
89491, 1.9608695652174, -0.15, 0.27777777777778
89492, 1.9826086956522, -0.125, 0.27777777777778
89493, 1.9826086956522, -0.15, 0.25
89494, 1.9608695652174, -0.15, 0.22222222222222
89495, 1.9826086956522, -0.125, 0.22222222222222
89496, 1.9826086956522, -0.15, 0.19444444444444
89497, 1.9608695652174, -0.15, 0.16666666666667
89498, 1.9826086956522, -0.125, 0.16666666666667
89499, 1.9826086956522, -0.15, 0.13888888888889
89500, 1.9608695652174, -0.15, 0.11111111111111
89501, 1.9826086956522, -0.125, 0.11111111111111
89502, 1.9826086956522, -0.15, 0.083333333333333
89503, 1.9608695652174, -0.15, 0.055555555555556
89504, 1.9826086956522, -0.125, 0.055555555555556
89505, 1.9826086956522, -0.15, 0.027777777777778
89506, 2.0260869565217, -0.15, 0.47222222222222
89507, 2.004347826087, -0.15, 0.44444444444444
89508, 2.0260869565217, -0.125, 0.44444444444444
89509, 2.0260869565217, -0.15, 0.41666666666667
89510, 2.004347826087, -0.15, 0.38888888888889
89511, 2.0260869565217, -0.125, 0.38888888888889
89512, 2.0260869565217, -0.15, 0.36111111111111
89513, 2.004347826087, -0.15, 0.33333333333333
89514, 2.0260869565217, -0.125, 0.33333333333333
89515, 2.0260869565217, -0.15, 0.30555555555556
89516, 2.004347826087, -0.15, 0.27777777777778
89517, 2.0260869565217, -0.125, 0.27777777777778
89518, 2.0260869565217, -0.15, 0.25
89519, 2.004347826087, -0.15, 0.22222222222222
89520, 2.0260869565217, -0.125, 0.22222222222222
89521, 2.0260869565217, -0.15, 0.19444444444444
89522, 2.004347826087, -0.15, 0.16666666666667
89523, 2.0260869565217, -0.125, 0.16666666666667
89524, 2.0260869565217, -0.15, 0.13888888888889
89525, 2.004347826087, -0.15, 0.11111111111111
89526, 2.0260869565217, -0.125, 0.11111111111111
89527, 2.0260869565217, -0.15, 0.083333333333333
89528, 2.004347826087, -0.15, 0.055555555555556
89529, 2.0260869565217, -0.125, 0.055555555555556
89530, 2.0260869565217, -0.15, 0.027777777777778
89531, 2.0695652173913, -0.15, 0.47222222222222
89532, 2.0478260869565, -0.15, 0.44444444444444
89533, 2.0695652173913, -0.125, 0.44444444444444
89534, 2.0695652173913, -0.15, 0.41666666666667
89535, 2.0478260869565, -0.15, 0.38888888888889
89536, 2.0695652173913, -0.125, 0.38888888888889
89537, 2.0695652173913, -0.15, 0.36111111111111
89538, 2.0478260869565, -0.15, 0.33333333333333
89539, 2.0695652173913, -0.125, 0.33333333333333
89540, 2.0695652173913, -0.15, 0.30555555555556
89541, 2.0478260869565, -0.15, 0.27777777777778
89542, 2.0695652173913, -0.125, 0.27777777777778
89543, 2.0695652173913, -0.15, 0.25
89544, 2.0478260869565, -0.15, 0.22222222222222
89545, 2.0695652173913, -0.125, 0.22222222222222
89546, 2.0695652173913, -0.15, 0.19444444444444
89547, 2.0478260869565, -0.15, 0.16666666666667
89548, 2.0695652173913, -0.125, 0.16666666666667
89549, 2.0695652173913, -0.15, 0.13888888888889
89550, 2.0478260869565, -0.15, 0.11111111111111
89551, 2.0695652173913, -0.125, 0.11111111111111
89552, 2.0695652173913, -0.15, 0.083333333333333
89553, 2.0478260869565, -0.15, 0.055555555555556
89554, 2.0695652173913, -0.125, 0.055555555555556
89555, 2.0695652173913, -0.15, 0.027777777777778
89556, 2.1130434782609, -0.15, 0.47222222222222
89557, 2.0913043478261, -0.15, 0.44444444444444
89558, 2.1130434782609, -0.125, 0.44444444444444
89559, 2.1130434782609, -0.15, 0.41666666666667
89560, 2.0913043478261, -0.15, 0.38888888888889
89561, 2.1130434782609, -0.125, 0.38888888888889
89562, 2.1130434782609, -0.15, 0.36111111111111
89563, 2.0913043478261, -0.15, 0.33333333333333
89564, 2.1130434782609, -0.125, 0.33333333333333
89565, 2.1130434782609, -0.15, 0.30555555555556
89566, 2.0913043478261, -0.15, 0.27777777777778
89567, 2.1130434782609, -0.125, 0.27777777777778
89568, 2.1130434782609, -0.15, 0.25
89569, 2.0913043478261, -0.15, 0.22222222222222
89570, 2.1130434782609, -0.125, 0.22222222222222
89571, 2.1130434782609, -0.15, 0.19444444444444
89572, 2.0913043478261, -0.15, 0.16666666666667
89573, 2.1130434782609, -0.125, 0.16666666666667
89574, 2.1130434782609, -0.15, 0.13888888888889
89575, 2.0913043478261, -0.15, 0.11111111111111
89576, 2.1130434782609, -0.125, 0.11111111111111
89577, 2.1130434782609, -0.15, 0.083333333333333
89578, 2.0913043478261, -0.15, 0.055555555555556
89579, 2.1130434782609, -0.125, 0.055555555555556
89580, 2.1130434782609, -0.15, 0.027777777777778
89581, 2.1565217391304, -0.15, 0.47222222222222
89582, 2.1347826086957, -0.15, 0.44444444444444
89583, 2.1565217391304, -0.125, 0.44444444444444
89584, 2.1565217391304, -0.15, 0.41666666666667
89585, 2.1347826086957, -0.15, 0.38888888888889
89586, 2.1565217391304, -0.125, 0.38888888888889
89587, 2.1565217391304, -0.15, 0.36111111111111
89588, 2.1347826086957, -0.15, 0.33333333333333
89589, 2.1565217391304, -0.125, 0.33333333333333
89590, 2.1565217391304, -0.15, 0.30555555555556
89591, 2.1347826086957, -0.15, 0.27777777777778
89592, 2.1565217391304, -0.125, 0.27777777777778
89593, 2.1565217391304, -0.15, 0.25
89594, 2.1347826086957, -0.15, 0.22222222222222
89595, 2.1565217391304, -0.125, 0.22222222222222
89596, 2.1565217391304, -0.15, 0.19444444444444
89597, 2.1347826086957, -0.15, 0.16666666666667
89598, 2.1565217391304, -0.125, 0.16666666666667
89599, 2.1565217391304, -0.15, 0.13888888888889
89600, 2.1347826086957, -0.15, 0.11111111111111
89601, 2.1565217391304, -0.125, 0.11111111111111
89602, 2.1565217391304, -0.15, 0.083333333333333
89603, 2.1347826086957, -0.15, 0.055555555555556
89604, 2.1565217391304, -0.125, 0.055555555555556
89605, 2.1565217391304, -0.15, 0.027777777777778
89606, 2.1782608695652, -0.15, 0.44444444444444
89607, 2.1782608695652, -0.15, 0.38888888888889
89608, 2.1782608695652, -0.15, 0.33333333333333
89609, 2.1782608695652, -0.15, 0.27777777777778
89610, 2.1782608695652, -0.15, 0.22222222222222
89611, 2.1782608695652, -0.15, 0.16666666666667
89612, 2.1782608695652, -0.15, 0.11111111111111
89613, 2.1782608695652, -0.15, 0.055555555555556
89614, 1.2434782608696, -0.2, 0.47222222222222
89615, 1.2217391304348, -0.2, 0.44444444444444
89616, 1.2434782608696, -0.175, 0.44444444444444
89617, 1.2434782608696, -0.2, 0.41666666666667
89618, 1.2217391304348, -0.2, 0.38888888888889
89619, 1.2434782608696, -0.175, 0.38888888888889
89620, 1.2434782608696, -0.2, 0.36111111111111
89621, 1.2217391304348, -0.2, 0.33333333333333
89622, 1.2434782608696, -0.175, 0.33333333333333
89623, 1.2434782608696, -0.2, 0.30555555555556
89624, 1.2217391304348, -0.2, 0.27777777777778
89625, 1.2434782608696, -0.175, 0.27777777777778
89626, 1.2434782608696, -0.2, 0.25
89627, 1.2217391304348, -0.2, 0.22222222222222
89628, 1.2434782608696, -0.175, 0.22222222222222
89629, 1.2434782608696, -0.2, 0.19444444444444
89630, 1.2217391304348, -0.2, 0.16666666666667
89631, 1.2434782608696, -0.175, 0.16666666666667
89632, 1.2434782608696, -0.2, 0.13888888888889
89633, 1.2217391304348, -0.2, 0.11111111111111
89634, 1.2434782608696, -0.175, 0.11111111111111
89635, 1.2434782608696, -0.2, 0.083333333333333
89636, 1.2217391304348, -0.2, 0.055555555555556
89637, 1.2434782608696, -0.175, 0.055555555555556
89638, 1.2434782608696, -0.2, 0.027777777777778
89639, 1.2869565217391, -0.2, 0.47222222222222
89640, 1.2652173913043, -0.2, 0.44444444444444
89641, 1.2869565217391, -0.175, 0.44444444444444
89642, 1.2869565217391, -0.2, 0.41666666666667
89643, 1.2652173913043, -0.2, 0.38888888888889
89644, 1.2869565217391, -0.175, 0.38888888888889
89645, 1.2869565217391, -0.2, 0.36111111111111
89646, 1.2652173913043, -0.2, 0.33333333333333
89647, 1.2869565217391, -0.175, 0.33333333333333
89648, 1.2869565217391, -0.2, 0.30555555555556
89649, 1.2652173913043, -0.2, 0.27777777777778
89650, 1.2869565217391, -0.175, 0.27777777777778
89651, 1.2869565217391, -0.2, 0.25
89652, 1.2652173913043, -0.2, 0.22222222222222
89653, 1.2869565217391, -0.175, 0.22222222222222
89654, 1.2869565217391, -0.2, 0.19444444444444
89655, 1.2652173913043, -0.2, 0.16666666666667
89656, 1.2869565217391, -0.175, 0.16666666666667
89657, 1.2869565217391, -0.2, 0.13888888888889
89658, 1.2652173913043, -0.2, 0.11111111111111
89659, 1.2869565217391, -0.175, 0.11111111111111
89660, 1.2869565217391, -0.2, 0.083333333333333
89661, 1.2652173913043, -0.2, 0.055555555555556
89662, 1.2869565217391, -0.175, 0.055555555555556
89663, 1.2869565217391, -0.2, 0.027777777777778
89664, 1.3304347826087, -0.2, 0.47222222222222
89665, 1.3086956521739, -0.2, 0.44444444444444
89666, 1.3304347826087, -0.175, 0.44444444444444
89667, 1.3304347826087, -0.2, 0.41666666666667
89668, 1.3086956521739, -0.2, 0.38888888888889
89669, 1.3304347826087, -0.175, 0.38888888888889
89670, 1.3304347826087, -0.2, 0.36111111111111
89671, 1.3086956521739, -0.2, 0.33333333333333
89672, 1.3304347826087, -0.175, 0.33333333333333
89673, 1.3304347826087, -0.2, 0.30555555555556
89674, 1.3086956521739, -0.2, 0.27777777777778
89675, 1.3304347826087, -0.175, 0.27777777777778
89676, 1.3304347826087, -0.2, 0.25
89677, 1.3086956521739, -0.2, 0.22222222222222
89678, 1.3304347826087, -0.175, 0.22222222222222
89679, 1.3304347826087, -0.2, 0.19444444444444
89680, 1.3086956521739, -0.2, 0.16666666666667
89681, 1.3304347826087, -0.175, 0.16666666666667
89682, 1.3304347826087, -0.2, 0.13888888888889
89683, 1.3086956521739, -0.2, 0.11111111111111
89684, 1.3304347826087, -0.175, 0.11111111111111
89685, 1.3304347826087, -0.2, 0.083333333333333
89686, 1.3086956521739, -0.2, 0.055555555555556
89687, 1.3304347826087, -0.175, 0.055555555555556
89688, 1.3304347826087, -0.2, 0.027777777777778
89689, 1.3739130434783, -0.2, 0.47222222222222
89690, 1.3521739130435, -0.2, 0.44444444444444
89691, 1.3739130434783, -0.175, 0.44444444444444
89692, 1.3739130434783, -0.2, 0.41666666666667
89693, 1.3521739130435, -0.2, 0.38888888888889
89694, 1.3739130434783, -0.175, 0.38888888888889
89695, 1.3739130434783, -0.2, 0.36111111111111
89696, 1.3521739130435, -0.2, 0.33333333333333
89697, 1.3739130434783, -0.175, 0.33333333333333
89698, 1.3739130434783, -0.2, 0.30555555555556
89699, 1.3521739130435, -0.2, 0.27777777777778
89700, 1.3739130434783, -0.175, 0.27777777777778
89701, 1.3739130434783, -0.2, 0.25
89702, 1.3521739130435, -0.2, 0.22222222222222
89703, 1.3739130434783, -0.175, 0.22222222222222
89704, 1.3739130434783, -0.2, 0.19444444444444
89705, 1.3521739130435, -0.2, 0.16666666666667
89706, 1.3739130434783, -0.175, 0.16666666666667
89707, 1.3739130434783, -0.2, 0.13888888888889
89708, 1.3521739130435, -0.2, 0.11111111111111
89709, 1.3739130434783, -0.175, 0.11111111111111
89710, 1.3739130434783, -0.2, 0.083333333333333
89711, 1.3521739130435, -0.2, 0.055555555555556
89712, 1.3739130434783, -0.175, 0.055555555555556
89713, 1.3739130434783, -0.2, 0.027777777777778
89714, 1.4173913043478, -0.2, 0.47222222222222
89715, 1.395652173913, -0.2, 0.44444444444444
89716, 1.4173913043478, -0.175, 0.44444444444444
89717, 1.4173913043478, -0.2, 0.41666666666667
89718, 1.395652173913, -0.2, 0.38888888888889
89719, 1.4173913043478, -0.175, 0.38888888888889
89720, 1.4173913043478, -0.2, 0.36111111111111
89721, 1.395652173913, -0.2, 0.33333333333333
89722, 1.4173913043478, -0.175, 0.33333333333333
89723, 1.4173913043478, -0.2, 0.30555555555556
89724, 1.395652173913, -0.2, 0.27777777777778
89725, 1.4173913043478, -0.175, 0.27777777777778
89726, 1.4173913043478, -0.2, 0.25
89727, 1.395652173913, -0.2, 0.22222222222222
89728, 1.4173913043478, -0.175, 0.22222222222222
