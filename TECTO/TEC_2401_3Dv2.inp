54688, 0.95652173913043, 1.245652173913, 0.47222222222222
54689, 0.91304347826087, 1.245652173913, 0.027777777777778
54690, 0.93478260869565, 1.245652173913, 0.055555555555556
54691, 0.91304347826087, 1.2195652173913, 0.055555555555556
54692, 0.91304347826087, 1.245652173913, 0.083333333333333
54693, 0.93478260869565, 1.245652173913, 0.11111111111111
54694, 0.91304347826087, 1.2195652173913, 0.11111111111111
54695, 0.91304347826087, 1.245652173913, 0.13888888888889
54696, 0.93478260869565, 1.245652173913, 0.16666666666667
54697, 0.91304347826087, 1.2195652173913, 0.16666666666667
54698, 0.91304347826087, 1.245652173913, 0.19444444444444
54699, 0.93478260869565, 1.245652173913, 0.22222222222222
54700, 0.91304347826087, 1.2195652173913, 0.22222222222222
54701, 0.91304347826087, 1.245652173913, 0.25
54702, 0.93478260869565, 1.245652173913, 0.27777777777778
54703, 0.91304347826087, 1.2195652173913, 0.27777777777778
54704, 0.91304347826087, 1.245652173913, 0.30555555555556
54705, 0.93478260869565, 1.245652173913, 0.33333333333333
54706, 0.91304347826087, 1.2195652173913, 0.33333333333333
54707, 0.91304347826087, 1.245652173913, 0.36111111111111
54708, 0.93478260869565, 1.245652173913, 0.38888888888889
54709, 0.91304347826087, 1.2195652173913, 0.38888888888889
54710, 0.91304347826087, 1.245652173913, 0.41666666666667
54711, 0.93478260869565, 1.245652173913, 0.44444444444444
54712, 0.91304347826087, 1.2195652173913, 0.44444444444444
54713, 0.91304347826087, 1.245652173913, 0.47222222222222
54714, 0.8695652173913, 1.245652173913, 0.027777777777778
54715, 0.89130434782609, 1.245652173913, 0.055555555555556
54716, 0.8695652173913, 1.2195652173913, 0.055555555555556
54717, 0.8695652173913, 1.245652173913, 0.083333333333333
54718, 0.89130434782609, 1.245652173913, 0.11111111111111
54719, 0.8695652173913, 1.2195652173913, 0.11111111111111
54720, 0.8695652173913, 1.245652173913, 0.13888888888889
54721, 0.89130434782609, 1.245652173913, 0.16666666666667
54722, 0.8695652173913, 1.2195652173913, 0.16666666666667
54723, 0.8695652173913, 1.245652173913, 0.19444444444444
54724, 0.89130434782609, 1.245652173913, 0.22222222222222
54725, 0.8695652173913, 1.2195652173913, 0.22222222222222
54726, 0.8695652173913, 1.245652173913, 0.25
54727, 0.89130434782609, 1.245652173913, 0.27777777777778
54728, 0.8695652173913, 1.2195652173913, 0.27777777777778
54729, 0.8695652173913, 1.245652173913, 0.30555555555556
54730, 0.89130434782609, 1.245652173913, 0.33333333333333
54731, 0.8695652173913, 1.2195652173913, 0.33333333333333
54732, 0.8695652173913, 1.245652173913, 0.36111111111111
54733, 0.89130434782609, 1.245652173913, 0.38888888888889
54734, 0.8695652173913, 1.2195652173913, 0.38888888888889
54735, 0.8695652173913, 1.245652173913, 0.41666666666667
54736, 0.89130434782609, 1.245652173913, 0.44444444444444
54737, 0.8695652173913, 1.2195652173913, 0.44444444444444
54738, 0.8695652173913, 1.245652173913, 0.47222222222222
54739, 0.82608695652174, 1.245652173913, 0.027777777777778
54740, 0.84782608695652, 1.245652173913, 0.055555555555556
54741, 0.82608695652174, 1.2195652173913, 0.055555555555556
54742, 0.82608695652174, 1.245652173913, 0.083333333333333
54743, 0.84782608695652, 1.245652173913, 0.11111111111111
54744, 0.82608695652174, 1.2195652173913, 0.11111111111111
54745, 0.82608695652174, 1.245652173913, 0.13888888888889
54746, 0.84782608695652, 1.245652173913, 0.16666666666667
54747, 0.82608695652174, 1.2195652173913, 0.16666666666667
54748, 0.82608695652174, 1.245652173913, 0.19444444444444
54749, 0.84782608695652, 1.245652173913, 0.22222222222222
54750, 0.82608695652174, 1.2195652173913, 0.22222222222222
54751, 0.82608695652174, 1.245652173913, 0.25
54752, 0.84782608695652, 1.245652173913, 0.27777777777778
54753, 0.82608695652174, 1.2195652173913, 0.27777777777778
54754, 0.82608695652174, 1.245652173913, 0.30555555555556
54755, 0.84782608695652, 1.245652173913, 0.33333333333333
54756, 0.82608695652174, 1.2195652173913, 0.33333333333333
54757, 0.82608695652174, 1.245652173913, 0.36111111111111
54758, 0.84782608695652, 1.245652173913, 0.38888888888889
54759, 0.82608695652174, 1.2195652173913, 0.38888888888889
54760, 0.82608695652174, 1.245652173913, 0.41666666666667
54761, 0.84782608695652, 1.245652173913, 0.44444444444444
54762, 0.82608695652174, 1.2195652173913, 0.44444444444444
54763, 0.82608695652174, 1.245652173913, 0.47222222222222
54764, 0.78260869565217, 1.245652173913, 0.027777777777778
54765, 0.80434782608696, 1.245652173913, 0.055555555555556
54766, 0.78260869565217, 1.2195652173913, 0.055555555555556
54767, 0.78260869565217, 1.245652173913, 0.083333333333333
54768, 0.80434782608696, 1.245652173913, 0.11111111111111
54769, 0.78260869565217, 1.2195652173913, 0.11111111111111
54770, 0.78260869565217, 1.245652173913, 0.13888888888889
54771, 0.80434782608696, 1.245652173913, 0.16666666666667
54772, 0.78260869565217, 1.2195652173913, 0.16666666666667
54773, 0.78260869565217, 1.245652173913, 0.19444444444444
54774, 0.80434782608696, 1.245652173913, 0.22222222222222
54775, 0.78260869565217, 1.2195652173913, 0.22222222222222
54776, 0.78260869565217, 1.245652173913, 0.25
54777, 0.80434782608696, 1.245652173913, 0.27777777777778
54778, 0.78260869565217, 1.2195652173913, 0.27777777777778
54779, 0.78260869565217, 1.245652173913, 0.30555555555556
54780, 0.80434782608696, 1.245652173913, 0.33333333333333
54781, 0.78260869565217, 1.2195652173913, 0.33333333333333
54782, 0.78260869565217, 1.245652173913, 0.36111111111111
54783, 0.80434782608696, 1.245652173913, 0.38888888888889
54784, 0.78260869565217, 1.2195652173913, 0.38888888888889
54785, 0.78260869565217, 1.245652173913, 0.41666666666667
54786, 0.80434782608696, 1.245652173913, 0.44444444444444
54787, 0.78260869565217, 1.2195652173913, 0.44444444444444
54788, 0.78260869565217, 1.245652173913, 0.47222222222222
54789, 0.73913043478261, 1.245652173913, 0.027777777777778
54790, 0.76086956521739, 1.245652173913, 0.055555555555556
54791, 0.73913043478261, 1.2195652173913, 0.055555555555556
54792, 0.73913043478261, 1.245652173913, 0.083333333333333
54793, 0.76086956521739, 1.245652173913, 0.11111111111111
54794, 0.73913043478261, 1.2195652173913, 0.11111111111111
54795, 0.73913043478261, 1.245652173913, 0.13888888888889
54796, 0.76086956521739, 1.245652173913, 0.16666666666667
54797, 0.73913043478261, 1.2195652173913, 0.16666666666667
54798, 0.73913043478261, 1.245652173913, 0.19444444444444
54799, 0.76086956521739, 1.245652173913, 0.22222222222222
54800, 0.73913043478261, 1.2195652173913, 0.22222222222222
54801, 0.73913043478261, 1.245652173913, 0.25
54802, 0.76086956521739, 1.245652173913, 0.27777777777778
54803, 0.73913043478261, 1.2195652173913, 0.27777777777778
54804, 0.73913043478261, 1.245652173913, 0.30555555555556
54805, 0.76086956521739, 1.245652173913, 0.33333333333333
54806, 0.73913043478261, 1.2195652173913, 0.33333333333333
54807, 0.73913043478261, 1.245652173913, 0.36111111111111
54808, 0.76086956521739, 1.245652173913, 0.38888888888889
54809, 0.73913043478261, 1.2195652173913, 0.38888888888889
54810, 0.73913043478261, 1.245652173913, 0.41666666666667
54811, 0.76086956521739, 1.245652173913, 0.44444444444444
54812, 0.73913043478261, 1.2195652173913, 0.44444444444444
54813, 0.73913043478261, 1.245652173913, 0.47222222222222
54814, 0.69565217391304, 1.245652173913, 0.027777777777778
54815, 0.71739130434783, 1.245652173913, 0.055555555555556
54816, 0.69565217391304, 1.2195652173913, 0.055555555555556
54817, 0.69565217391304, 1.245652173913, 0.083333333333333
54818, 0.71739130434783, 1.245652173913, 0.11111111111111
54819, 0.69565217391304, 1.2195652173913, 0.11111111111111
54820, 0.69565217391304, 1.245652173913, 0.13888888888889
54821, 0.71739130434783, 1.245652173913, 0.16666666666667
54822, 0.69565217391304, 1.2195652173913, 0.16666666666667
54823, 0.69565217391304, 1.245652173913, 0.19444444444444
54824, 0.71739130434783, 1.245652173913, 0.22222222222222
54825, 0.69565217391304, 1.2195652173913, 0.22222222222222
54826, 0.69565217391304, 1.245652173913, 0.25
54827, 0.71739130434783, 1.245652173913, 0.27777777777778
54828, 0.69565217391304, 1.2195652173913, 0.27777777777778
54829, 0.69565217391304, 1.245652173913, 0.30555555555556
54830, 0.71739130434783, 1.245652173913, 0.33333333333333
54831, 0.69565217391304, 1.2195652173913, 0.33333333333333
54832, 0.69565217391304, 1.245652173913, 0.36111111111111
54833, 0.71739130434783, 1.245652173913, 0.38888888888889
54834, 0.69565217391304, 1.2195652173913, 0.38888888888889
54835, 0.69565217391304, 1.245652173913, 0.41666666666667
54836, 0.71739130434783, 1.245652173913, 0.44444444444444
54837, 0.69565217391304, 1.2195652173913, 0.44444444444444
54838, 0.69565217391304, 1.245652173913, 0.47222222222222
54839, 0.65217391304348, 1.245652173913, 0.027777777777778
54840, 0.67391304347826, 1.245652173913, 0.055555555555556
54841, 0.65217391304348, 1.2195652173913, 0.055555555555556
54842, 0.65217391304348, 1.245652173913, 0.083333333333333
54843, 0.67391304347826, 1.245652173913, 0.11111111111111
54844, 0.65217391304348, 1.2195652173913, 0.11111111111111
54845, 0.65217391304348, 1.245652173913, 0.13888888888889
54846, 0.67391304347826, 1.245652173913, 0.16666666666667
54847, 0.65217391304348, 1.2195652173913, 0.16666666666667
54848, 0.65217391304348, 1.245652173913, 0.19444444444444
54849, 0.67391304347826, 1.245652173913, 0.22222222222222
54850, 0.65217391304348, 1.2195652173913, 0.22222222222222
54851, 0.65217391304348, 1.245652173913, 0.25
54852, 0.67391304347826, 1.245652173913, 0.27777777777778
54853, 0.65217391304348, 1.2195652173913, 0.27777777777778
54854, 0.65217391304348, 1.245652173913, 0.30555555555556
54855, 0.67391304347826, 1.245652173913, 0.33333333333333
54856, 0.65217391304348, 1.2195652173913, 0.33333333333333
54857, 0.65217391304348, 1.245652173913, 0.36111111111111
54858, 0.67391304347826, 1.245652173913, 0.38888888888889
54859, 0.65217391304348, 1.2195652173913, 0.38888888888889
54860, 0.65217391304348, 1.245652173913, 0.41666666666667
54861, 0.67391304347826, 1.245652173913, 0.44444444444444
54862, 0.65217391304348, 1.2195652173913, 0.44444444444444
54863, 0.65217391304348, 1.245652173913, 0.47222222222222
54864, 0.60869565217391, 1.245652173913, 0.027777777777778
54865, 0.6304347826087, 1.245652173913, 0.055555555555556
54866, 0.60869565217391, 1.2195652173913, 0.055555555555556
54867, 0.60869565217391, 1.245652173913, 0.083333333333333
54868, 0.6304347826087, 1.245652173913, 0.11111111111111
54869, 0.60869565217391, 1.2195652173913, 0.11111111111111
54870, 0.60869565217391, 1.245652173913, 0.13888888888889
54871, 0.6304347826087, 1.245652173913, 0.16666666666667
54872, 0.60869565217391, 1.2195652173913, 0.16666666666667
54873, 0.60869565217391, 1.245652173913, 0.19444444444444
54874, 0.6304347826087, 1.245652173913, 0.22222222222222
54875, 0.60869565217391, 1.2195652173913, 0.22222222222222
54876, 0.60869565217391, 1.245652173913, 0.25
54877, 0.6304347826087, 1.245652173913, 0.27777777777778
54878, 0.60869565217391, 1.2195652173913, 0.27777777777778
54879, 0.60869565217391, 1.245652173913, 0.30555555555556
54880, 0.6304347826087, 1.245652173913, 0.33333333333333
54881, 0.60869565217391, 1.2195652173913, 0.33333333333333
54882, 0.60869565217391, 1.245652173913, 0.36111111111111
54883, 0.6304347826087, 1.245652173913, 0.38888888888889
54884, 0.60869565217391, 1.2195652173913, 0.38888888888889
54885, 0.60869565217391, 1.245652173913, 0.41666666666667
54886, 0.6304347826087, 1.245652173913, 0.44444444444444
54887, 0.60869565217391, 1.2195652173913, 0.44444444444444
54888, 0.60869565217391, 1.245652173913, 0.47222222222222
54889, 0.56521739130435, 1.245652173913, 0.027777777777778
54890, 0.58695652173913, 1.245652173913, 0.055555555555556
54891, 0.56521739130435, 1.2195652173913, 0.055555555555556
54892, 0.56521739130435, 1.245652173913, 0.083333333333333
54893, 0.58695652173913, 1.245652173913, 0.11111111111111
54894, 0.56521739130435, 1.2195652173913, 0.11111111111111
54895, 0.56521739130435, 1.245652173913, 0.13888888888889
54896, 0.58695652173913, 1.245652173913, 0.16666666666667
54897, 0.56521739130435, 1.2195652173913, 0.16666666666667
54898, 0.56521739130435, 1.245652173913, 0.19444444444444
54899, 0.58695652173913, 1.245652173913, 0.22222222222222
54900, 0.56521739130435, 1.2195652173913, 0.22222222222222
54901, 0.56521739130435, 1.245652173913, 0.25
54902, 0.58695652173913, 1.245652173913, 0.27777777777778
54903, 0.56521739130435, 1.2195652173913, 0.27777777777778
54904, 0.56521739130435, 1.245652173913, 0.30555555555556
54905, 0.58695652173913, 1.245652173913, 0.33333333333333
54906, 0.56521739130435, 1.2195652173913, 0.33333333333333
54907, 0.56521739130435, 1.245652173913, 0.36111111111111
54908, 0.58695652173913, 1.245652173913, 0.38888888888889
54909, 0.56521739130435, 1.2195652173913, 0.38888888888889
54910, 0.56521739130435, 1.245652173913, 0.41666666666667
54911, 0.58695652173913, 1.245652173913, 0.44444444444444
54912, 0.56521739130435, 1.2195652173913, 0.44444444444444
54913, 0.56521739130435, 1.245652173913, 0.47222222222222
54914, 0.52173913043478, 1.245652173913, 0.027777777777778
54915, 0.54347826086957, 1.245652173913, 0.055555555555556
54916, 0.52173913043478, 1.2195652173913, 0.055555555555556
54917, 0.52173913043478, 1.245652173913, 0.083333333333333
54918, 0.54347826086957, 1.245652173913, 0.11111111111111
54919, 0.52173913043478, 1.2195652173913, 0.11111111111111
54920, 0.52173913043478, 1.245652173913, 0.13888888888889
54921, 0.54347826086956, 1.245652173913, 0.16666666666667
54922, 0.52173913043478, 1.2195652173913, 0.16666666666667
54923, 0.52173913043478, 1.245652173913, 0.19444444444444
54924, 0.54347826086956, 1.245652173913, 0.22222222222222
54925, 0.52173913043478, 1.2195652173913, 0.22222222222222
54926, 0.52173913043478, 1.245652173913, 0.25
54927, 0.54347826086956, 1.245652173913, 0.27777777777778
54928, 0.52173913043478, 1.2195652173913, 0.27777777777778
54929, 0.52173913043478, 1.245652173913, 0.30555555555556
54930, 0.54347826086956, 1.245652173913, 0.33333333333333
54931, 0.52173913043478, 1.2195652173913, 0.33333333333333
54932, 0.52173913043478, 1.245652173913, 0.36111111111111
54933, 0.54347826086956, 1.245652173913, 0.38888888888889
54934, 0.52173913043478, 1.2195652173913, 0.38888888888889
54935, 0.52173913043478, 1.245652173913, 0.41666666666667
54936, 0.54347826086956, 1.245652173913, 0.44444444444444
54937, 0.52173913043478, 1.2195652173913, 0.44444444444444
54938, 0.52173913043478, 1.245652173913, 0.47222222222222
54939, 0.47826086956522, 1.245652173913, 0.027777777777778
54940, 0.5, 1.245652173913, 0.055555555555556
54941, 0.47826086956522, 1.2195652173913, 0.055555555555556
54942, 0.47826086956522, 1.245652173913, 0.083333333333333
54943, 0.5, 1.245652173913, 0.11111111111111
54944, 0.47826086956522, 1.2195652173913, 0.11111111111111
54945, 0.47826086956522, 1.245652173913, 0.13888888888889
54946, 0.5, 1.245652173913, 0.16666666666667
54947, 0.47826086956522, 1.2195652173913, 0.16666666666667
54948, 0.47826086956522, 1.245652173913, 0.19444444444444
54949, 0.5, 1.245652173913, 0.22222222222222
54950, 0.47826086956522, 1.2195652173913, 0.22222222222222
54951, 0.47826086956522, 1.245652173913, 0.25
54952, 0.5, 1.245652173913, 0.27777777777778
54953, 0.47826086956522, 1.2195652173913, 0.27777777777778
54954, 0.47826086956522, 1.245652173913, 0.30555555555556
54955, 0.5, 1.245652173913, 0.33333333333333
54956, 0.47826086956522, 1.2195652173913, 0.33333333333333
54957, 0.47826086956522, 1.245652173913, 0.36111111111111
54958, 0.5, 1.245652173913, 0.38888888888889
54959, 0.47826086956522, 1.2195652173913, 0.38888888888889
54960, 0.47826086956522, 1.245652173913, 0.41666666666667
54961, 0.5, 1.245652173913, 0.44444444444444
54962, 0.47826086956522, 1.2195652173913, 0.44444444444444
54963, 0.47826086956522, 1.245652173913, 0.47222222222222
54964, 0.43478260869565, 1.245652173913, 0.027777777777778
54965, 0.45652173913043, 1.245652173913, 0.055555555555556
54966, 0.43478260869565, 1.2195652173913, 0.055555555555556
54967, 0.43478260869565, 1.245652173913, 0.083333333333333
54968, 0.45652173913043, 1.245652173913, 0.11111111111111
54969, 0.43478260869565, 1.2195652173913, 0.11111111111111
54970, 0.43478260869565, 1.245652173913, 0.13888888888889
54971, 0.45652173913043, 1.245652173913, 0.16666666666667
54972, 0.43478260869565, 1.2195652173913, 0.16666666666667
54973, 0.43478260869565, 1.245652173913, 0.19444444444444
54974, 0.45652173913043, 1.245652173913, 0.22222222222222
54975, 0.43478260869565, 1.2195652173913, 0.22222222222222
54976, 0.43478260869565, 1.245652173913, 0.25
54977, 0.45652173913043, 1.245652173913, 0.27777777777778
54978, 0.43478260869565, 1.2195652173913, 0.27777777777778
54979, 0.43478260869565, 1.245652173913, 0.30555555555556
54980, 0.45652173913043, 1.245652173913, 0.33333333333333
54981, 0.43478260869565, 1.2195652173913, 0.33333333333333
54982, 0.43478260869565, 1.245652173913, 0.36111111111111
54983, 0.45652173913044, 1.245652173913, 0.38888888888889
54984, 0.43478260869565, 1.2195652173913, 0.38888888888889
54985, 0.43478260869565, 1.245652173913, 0.41666666666667
54986, 0.45652173913043, 1.245652173913, 0.44444444444444
54987, 0.43478260869565, 1.2195652173913, 0.44444444444444
54988, 0.43478260869565, 1.245652173913, 0.47222222222222
54989, 0.39130434782609, 1.245652173913, 0.027777777777778
54990, 0.41304347826087, 1.245652173913, 0.055555555555556
54991, 0.39130434782609, 1.2195652173913, 0.055555555555556
54992, 0.39130434782609, 1.245652173913, 0.083333333333333
54993, 0.41304347826087, 1.245652173913, 0.11111111111111
54994, 0.39130434782609, 1.2195652173913, 0.11111111111111
54995, 0.39130434782609, 1.245652173913, 0.13888888888889
54996, 0.41304347826087, 1.245652173913, 0.16666666666667
54997, 0.39130434782609, 1.2195652173913, 0.16666666666667
54998, 0.39130434782609, 1.245652173913, 0.19444444444444
54999, 0.41304347826087, 1.245652173913, 0.22222222222222
55000, 0.39130434782609, 1.2195652173913, 0.22222222222222
55001, 0.39130434782609, 1.245652173913, 0.25
55002, 0.41304347826087, 1.245652173913, 0.27777777777778
55003, 0.39130434782609, 1.2195652173913, 0.27777777777778
55004, 0.39130434782609, 1.245652173913, 0.30555555555556
55005, 0.41304347826087, 1.245652173913, 0.33333333333333
55006, 0.39130434782609, 1.2195652173913, 0.33333333333333
55007, 0.39130434782609, 1.245652173913, 0.36111111111111
55008, 0.41304347826087, 1.245652173913, 0.38888888888889
55009, 0.39130434782609, 1.2195652173913, 0.38888888888889
55010, 0.39130434782609, 1.245652173913, 0.41666666666667
55011, 0.41304347826087, 1.245652173913, 0.44444444444444
55012, 0.39130434782609, 1.2195652173913, 0.44444444444444
55013, 0.39130434782609, 1.245652173913, 0.47222222222222
55014, 0.34782608695652, 1.245652173913, 0.027777777777778
55015, 0.3695652173913, 1.245652173913, 0.055555555555556
55016, 0.34782608695652, 1.2195652173913, 0.055555555555556
55017, 0.34782608695652, 1.245652173913, 0.083333333333333
55018, 0.3695652173913, 1.245652173913, 0.11111111111111
55019, 0.34782608695652, 1.2195652173913, 0.11111111111111
55020, 0.34782608695652, 1.245652173913, 0.13888888888889
55021, 0.3695652173913, 1.245652173913, 0.16666666666667
55022, 0.34782608695652, 1.2195652173913, 0.16666666666667
55023, 0.34782608695652, 1.245652173913, 0.19444444444444
55024, 0.3695652173913, 1.245652173913, 0.22222222222222
55025, 0.34782608695652, 1.2195652173913, 0.22222222222222
55026, 0.34782608695652, 1.245652173913, 0.25
55027, 0.3695652173913, 1.245652173913, 0.27777777777778
55028, 0.34782608695652, 1.2195652173913, 0.27777777777778
55029, 0.34782608695652, 1.245652173913, 0.30555555555556
55030, 0.3695652173913, 1.245652173913, 0.33333333333333
55031, 0.34782608695652, 1.2195652173913, 0.33333333333333
55032, 0.34782608695652, 1.245652173913, 0.36111111111111
55033, 0.3695652173913, 1.245652173913, 0.38888888888889
55034, 0.34782608695652, 1.2195652173913, 0.38888888888889
55035, 0.34782608695652, 1.245652173913, 0.41666666666667
55036, 0.3695652173913, 1.245652173913, 0.44444444444444
55037, 0.34782608695652, 1.2195652173913, 0.44444444444444
55038, 0.34782608695652, 1.245652173913, 0.47222222222222
55039, 0.30434782608696, 1.245652173913, 0.027777777777778
55040, 0.32608695652174, 1.245652173913, 0.055555555555556
55041, 0.30434782608696, 1.2195652173913, 0.055555555555556
55042, 0.30434782608696, 1.245652173913, 0.083333333333333
55043, 0.32608695652174, 1.245652173913, 0.11111111111111
55044, 0.30434782608696, 1.2195652173913, 0.11111111111111
55045, 0.30434782608696, 1.245652173913, 0.13888888888889
55046, 0.32608695652174, 1.245652173913, 0.16666666666667
55047, 0.30434782608696, 1.2195652173913, 0.16666666666667
55048, 0.30434782608696, 1.245652173913, 0.19444444444444
55049, 0.32608695652174, 1.245652173913, 0.22222222222222
55050, 0.30434782608696, 1.2195652173913, 0.22222222222222
55051, 0.30434782608696, 1.245652173913, 0.25
55052, 0.32608695652174, 1.245652173913, 0.27777777777778
55053, 0.30434782608696, 1.2195652173913, 0.27777777777778
55054, 0.30434782608696, 1.245652173913, 0.30555555555556
55055, 0.32608695652174, 1.245652173913, 0.33333333333333
55056, 0.30434782608696, 1.2195652173913, 0.33333333333333
55057, 0.30434782608696, 1.245652173913, 0.36111111111111
55058, 0.32608695652174, 1.245652173913, 0.38888888888889
55059, 0.30434782608696, 1.2195652173913, 0.38888888888889
55060, 0.30434782608696, 1.245652173913, 0.41666666666667
55061, 0.32608695652174, 1.245652173913, 0.44444444444444
55062, 0.30434782608696, 1.2195652173913, 0.44444444444444
55063, 0.30434782608696, 1.245652173913, 0.47222222222222
55064, 0.26086956521739, 1.245652173913, 0.027777777777778
55065, 0.28260869565217, 1.245652173913, 0.055555555555556
55066, 0.26086956521739, 1.2195652173913, 0.055555555555556
55067, 0.26086956521739, 1.245652173913, 0.083333333333333
55068, 0.28260869565217, 1.245652173913, 0.11111111111111
55069, 0.26086956521739, 1.2195652173913, 0.11111111111111
55070, 0.26086956521739, 1.245652173913, 0.13888888888889
55071, 0.28260869565217, 1.245652173913, 0.16666666666667
55072, 0.26086956521739, 1.2195652173913, 0.16666666666667
55073, 0.26086956521739, 1.245652173913, 0.19444444444444
55074, 0.28260869565217, 1.245652173913, 0.22222222222222
55075, 0.26086956521739, 1.2195652173913, 0.22222222222222
55076, 0.26086956521739, 1.245652173913, 0.25
55077, 0.28260869565217, 1.245652173913, 0.27777777777778
55078, 0.26086956521739, 1.2195652173913, 0.27777777777778
55079, 0.26086956521739, 1.245652173913, 0.30555555555556
55080, 0.28260869565217, 1.245652173913, 0.33333333333333
55081, 0.26086956521739, 1.2195652173913, 0.33333333333333
55082, 0.26086956521739, 1.245652173913, 0.36111111111111
55083, 0.28260869565217, 1.245652173913, 0.38888888888889
55084, 0.26086956521739, 1.2195652173913, 0.38888888888889
55085, 0.26086956521739, 1.245652173913, 0.41666666666667
55086, 0.28260869565217, 1.245652173913, 0.44444444444444
55087, 0.26086956521739, 1.2195652173913, 0.44444444444444
55088, 0.26086956521739, 1.245652173913, 0.47222222222222
55089, 0.21739130434783, 1.245652173913, 0.027777777777778
55090, 0.23913043478261, 1.245652173913, 0.055555555555556
55091, 0.21739130434783, 1.2195652173913, 0.055555555555556
55092, 0.21739130434783, 1.245652173913, 0.083333333333333
55093, 0.23913043478261, 1.245652173913, 0.11111111111111
55094, 0.21739130434783, 1.2195652173913, 0.11111111111111
55095, 0.21739130434783, 1.245652173913, 0.13888888888889
55096, 0.23913043478261, 1.245652173913, 0.16666666666667
55097, 0.21739130434783, 1.2195652173913, 0.16666666666667
55098, 0.21739130434783, 1.245652173913, 0.19444444444444
55099, 0.23913043478261, 1.245652173913, 0.22222222222222
55100, 0.21739130434783, 1.2195652173913, 0.22222222222222
55101, 0.21739130434783, 1.245652173913, 0.25
55102, 0.23913043478261, 1.245652173913, 0.27777777777778
55103, 0.21739130434783, 1.2195652173913, 0.27777777777778
55104, 0.21739130434783, 1.245652173913, 0.30555555555556
55105, 0.23913043478261, 1.245652173913, 0.33333333333333
55106, 0.21739130434783, 1.2195652173913, 0.33333333333333
55107, 0.21739130434783, 1.245652173913, 0.36111111111111
55108, 0.23913043478261, 1.245652173913, 0.38888888888889
55109, 0.21739130434783, 1.2195652173913, 0.38888888888889
55110, 0.21739130434783, 1.245652173913, 0.41666666666667
55111, 0.23913043478261, 1.245652173913, 0.44444444444444
55112, 0.21739130434783, 1.2195652173913, 0.44444444444444
55113, 0.21739130434783, 1.245652173913, 0.47222222222222
55114, 0.17391304347826, 1.245652173913, 0.027777777777778
55115, 0.19565217391304, 1.245652173913, 0.055555555555556
55116, 0.17391304347826, 1.2195652173913, 0.055555555555556
55117, 0.17391304347826, 1.245652173913, 0.083333333333333
55118, 0.19565217391304, 1.245652173913, 0.11111111111111
55119, 0.17391304347826, 1.2195652173913, 0.11111111111111
55120, 0.17391304347826, 1.245652173913, 0.13888888888889
55121, 0.19565217391304, 1.245652173913, 0.16666666666667
55122, 0.17391304347826, 1.2195652173913, 0.16666666666667
55123, 0.17391304347826, 1.245652173913, 0.19444444444444
55124, 0.19565217391304, 1.245652173913, 0.22222222222222
55125, 0.17391304347826, 1.2195652173913, 0.22222222222222
55126, 0.17391304347826, 1.245652173913, 0.25
55127, 0.19565217391304, 1.245652173913, 0.27777777777778
55128, 0.17391304347826, 1.2195652173913, 0.27777777777778
55129, 0.17391304347826, 1.245652173913, 0.30555555555556
55130, 0.19565217391304, 1.245652173913, 0.33333333333333
55131, 0.17391304347826, 1.2195652173913, 0.33333333333333
55132, 0.17391304347826, 1.245652173913, 0.36111111111111
55133, 0.19565217391304, 1.245652173913, 0.38888888888889
55134, 0.17391304347826, 1.2195652173913, 0.38888888888889
55135, 0.17391304347826, 1.245652173913, 0.41666666666667
55136, 0.19565217391304, 1.245652173913, 0.44444444444444
55137, 0.17391304347826, 1.2195652173913, 0.44444444444444
55138, 0.17391304347826, 1.245652173913, 0.47222222222222
55139, 0.1304347826087, 1.245652173913, 0.027777777777778
55140, 0.15217391304348, 1.245652173913, 0.055555555555556
55141, 0.1304347826087, 1.2195652173913, 0.055555555555556
55142, 0.1304347826087, 1.245652173913, 0.083333333333333
55143, 0.15217391304348, 1.245652173913, 0.11111111111111
55144, 0.1304347826087, 1.2195652173913, 0.11111111111111
55145, 0.1304347826087, 1.245652173913, 0.13888888888889
55146, 0.15217391304348, 1.245652173913, 0.16666666666667
55147, 0.1304347826087, 1.2195652173913, 0.16666666666667
55148, 0.1304347826087, 1.245652173913, 0.19444444444444
55149, 0.15217391304348, 1.245652173913, 0.22222222222222
55150, 0.1304347826087, 1.2195652173913, 0.22222222222222
55151, 0.1304347826087, 1.245652173913, 0.25
55152, 0.15217391304348, 1.245652173913, 0.27777777777778
55153, 0.1304347826087, 1.2195652173913, 0.27777777777778
55154, 0.1304347826087, 1.245652173913, 0.30555555555556
55155, 0.15217391304348, 1.245652173913, 0.33333333333333
55156, 0.1304347826087, 1.2195652173913, 0.33333333333333
55157, 0.1304347826087, 1.245652173913, 0.36111111111111
55158, 0.15217391304348, 1.245652173913, 0.38888888888889
55159, 0.1304347826087, 1.2195652173913, 0.38888888888889
55160, 0.1304347826087, 1.245652173913, 0.41666666666667
55161, 0.15217391304348, 1.245652173913, 0.44444444444444
55162, 0.1304347826087, 1.2195652173913, 0.44444444444444
55163, 0.1304347826087, 1.245652173913, 0.47222222222222
55164, 0.08695652173913, 1.245652173913, 0.027777777777778
55165, 0.10869565217391, 1.245652173913, 0.055555555555556
55166, 0.08695652173913, 1.2195652173913, 0.055555555555556
55167, 0.08695652173913, 1.245652173913, 0.083333333333333
55168, 0.10869565217391, 1.245652173913, 0.11111111111111
55169, 0.08695652173913, 1.2195652173913, 0.11111111111111
55170, 0.08695652173913, 1.245652173913, 0.13888888888889
55171, 0.10869565217391, 1.245652173913, 0.16666666666667
55172, 0.08695652173913, 1.2195652173913, 0.16666666666667
55173, 0.08695652173913, 1.245652173913, 0.19444444444444
55174, 0.10869565217391, 1.245652173913, 0.22222222222222
55175, 0.08695652173913, 1.2195652173913, 0.22222222222222
55176, 0.08695652173913, 1.245652173913, 0.25
55177, 0.10869565217391, 1.245652173913, 0.27777777777778
55178, 0.08695652173913, 1.2195652173913, 0.27777777777778
55179, 0.08695652173913, 1.245652173913, 0.30555555555556
55180, 0.10869565217391, 1.245652173913, 0.33333333333333
55181, 0.08695652173913, 1.2195652173913, 0.33333333333333
55182, 0.08695652173913, 1.245652173913, 0.36111111111111
55183, 0.10869565217391, 1.245652173913, 0.38888888888889
55184, 0.08695652173913, 1.2195652173913, 0.38888888888889
55185, 0.08695652173913, 1.245652173913, 0.41666666666667
55186, 0.10869565217391, 1.245652173913, 0.44444444444444
55187, 0.08695652173913, 1.2195652173913, 0.44444444444444
55188, 0.08695652173913, 1.245652173913, 0.47222222222222
55189, 0.043478260869565, 1.245652173913, 0.027777777777778
55190, 0.065217391304348, 1.245652173913, 0.055555555555556
55191, 0.043478260869565, 1.2195652173913, 0.055555555555556
55192, 0.043478260869565, 1.245652173913, 0.083333333333333
55193, 0.065217391304348, 1.245652173913, 0.11111111111111
55194, 0.043478260869565, 1.2195652173913, 0.11111111111111
55195, 0.043478260869565, 1.245652173913, 0.13888888888889
55196, 0.065217391304348, 1.245652173913, 0.16666666666667
55197, 0.043478260869565, 1.2195652173913, 0.16666666666667
55198, 0.043478260869565, 1.245652173913, 0.19444444444444
55199, 0.065217391304348, 1.245652173913, 0.22222222222222
55200, 0.043478260869565, 1.2195652173913, 0.22222222222222
55201, 0.043478260869565, 1.245652173913, 0.25
55202, 0.065217391304348, 1.245652173913, 0.27777777777778
55203, 0.043478260869565, 1.2195652173913, 0.27777777777778
55204, 0.043478260869565, 1.245652173913, 0.30555555555556
55205, 0.065217391304348, 1.245652173913, 0.33333333333333
55206, 0.043478260869565, 1.2195652173913, 0.33333333333333
55207, 0.043478260869565, 1.245652173913, 0.36111111111111
55208, 0.065217391304348, 1.245652173913, 0.38888888888889
55209, 0.043478260869565, 1.2195652173913, 0.38888888888889
55210, 0.043478260869565, 1.245652173913, 0.41666666666667
55211, 0.065217391304348, 1.245652173913, 0.44444444444444
55212, 0.043478260869565, 1.2195652173913, 0.44444444444444
55213, 0.043478260869565, 1.245652173913, 0.47222222222222
55214, 0.021739130434783, 1.245652173913, 0.055555555555556
55215, 0.021739130434783, 1.245652173913, 0.11111111111111
55216, 0.021739130434783, 1.245652173913, 0.16666666666667
55217, 0.021739130434783, 1.245652173913, 0.22222222222222
55218, 0.021739130434783, 1.245652173913, 0.27777777777778
55219, 0.021739130434783, 1.245652173913, 0.33333333333333
55220, 0.021739130434783, 1.245652173913, 0.38888888888889
55221, 0.021739130434783, 1.245652173913, 0.44444444444444
55222, 0.95652173913043, 1.2978260869565, 0.027777777777778
55223, 0.97826086956522, 1.2978260869565, 0.055555555555556
55224, 0.95652173913043, 1.2717391304348, 0.055555555555556
55225, 0.95652173913043, 1.2978260869565, 0.083333333333333
55226, 0.97826086956522, 1.2978260869565, 0.11111111111111
55227, 0.95652173913044, 1.2717391304348, 0.11111111111111
55228, 0.95652173913044, 1.2978260869565, 0.13888888888889
55229, 0.97826086956522, 1.2978260869565, 0.16666666666667
55230, 0.95652173913044, 1.2717391304348, 0.16666666666667
55231, 0.95652173913044, 1.2978260869565, 0.19444444444444
55232, 0.97826086956522, 1.2978260869565, 0.22222222222222
55233, 0.95652173913044, 1.2717391304348, 0.22222222222222
55234, 0.95652173913044, 1.2978260869565, 0.25
55235, 0.97826086956522, 1.2978260869565, 0.27777777777778
55236, 0.95652173913044, 1.2717391304348, 0.27777777777778
55237, 0.95652173913044, 1.2978260869565, 0.30555555555556
55238, 0.97826086956522, 1.2978260869565, 0.33333333333333
55239, 0.95652173913044, 1.2717391304348, 0.33333333333333
55240, 0.95652173913044, 1.2978260869565, 0.36111111111111
55241, 0.97826086956522, 1.2978260869565, 0.38888888888889
55242, 0.95652173913044, 1.2717391304348, 0.38888888888889
55243, 0.95652173913044, 1.2978260869565, 0.41666666666667
55244, 0.97826086956522, 1.2978260869565, 0.44444444444444
55245, 0.95652173913044, 1.2717391304348, 0.44444444444444
55246, 0.95652173913043, 1.2978260869565, 0.47222222222222
55247, 0.91304347826087, 1.2978260869565, 0.027777777777778
55248, 0.93478260869565, 1.2978260869565, 0.055555555555556
55249, 0.91304347826087, 1.2717391304348, 0.055555555555556
55250, 0.91304347826087, 1.2978260869565, 0.083333333333333
55251, 0.93478260869565, 1.2978260869565, 0.11111111111111
55252, 0.91304347826087, 1.2717391304348, 0.11111111111111
55253, 0.91304347826087, 1.2978260869565, 0.13888888888889
55254, 0.93478260869565, 1.2978260869565, 0.16666666666667
55255, 0.91304347826087, 1.2717391304348, 0.16666666666667
55256, 0.91304347826087, 1.2978260869565, 0.19444444444444
55257, 0.93478260869565, 1.2978260869565, 0.22222222222222
55258, 0.91304347826087, 1.2717391304348, 0.22222222222222
55259, 0.91304347826087, 1.2978260869565, 0.25
55260, 0.93478260869565, 1.2978260869565, 0.27777777777778
55261, 0.91304347826087, 1.2717391304348, 0.27777777777778
55262, 0.91304347826087, 1.2978260869565, 0.30555555555556
55263, 0.93478260869565, 1.2978260869565, 0.33333333333333
55264, 0.91304347826087, 1.2717391304348, 0.33333333333333
55265, 0.91304347826087, 1.2978260869565, 0.36111111111111
55266, 0.93478260869565, 1.2978260869565, 0.38888888888889
55267, 0.91304347826087, 1.2717391304348, 0.38888888888889
55268, 0.91304347826087, 1.2978260869565, 0.41666666666667
55269, 0.93478260869565, 1.2978260869565, 0.44444444444444
55270, 0.91304347826087, 1.2717391304348, 0.44444444444444
55271, 0.91304347826087, 1.2978260869565, 0.47222222222222
55272, 0.8695652173913, 1.2978260869565, 0.027777777777778
55273, 0.89130434782609, 1.2978260869565, 0.055555555555556
55274, 0.8695652173913, 1.2717391304348, 0.055555555555556
55275, 0.8695652173913, 1.2978260869565, 0.083333333333333
55276, 0.89130434782609, 1.2978260869565, 0.11111111111111
55277, 0.8695652173913, 1.2717391304348, 0.11111111111111
55278, 0.8695652173913, 1.2978260869565, 0.13888888888889
55279, 0.89130434782609, 1.2978260869565, 0.16666666666667
55280, 0.8695652173913, 1.2717391304348, 0.16666666666667
55281, 0.8695652173913, 1.2978260869565, 0.19444444444444
55282, 0.89130434782609, 1.2978260869565, 0.22222222222222
55283, 0.8695652173913, 1.2717391304348, 0.22222222222222
55284, 0.8695652173913, 1.2978260869565, 0.25
55285, 0.89130434782609, 1.2978260869565, 0.27777777777778
55286, 0.8695652173913, 1.2717391304348, 0.27777777777778
55287, 0.8695652173913, 1.2978260869565, 0.30555555555556
55288, 0.89130434782609, 1.2978260869565, 0.33333333333333
55289, 0.8695652173913, 1.2717391304348, 0.33333333333333
55290, 0.8695652173913, 1.2978260869565, 0.36111111111111
55291, 0.89130434782609, 1.2978260869565, 0.38888888888889
55292, 0.8695652173913, 1.2717391304348, 0.38888888888889
55293, 0.8695652173913, 1.2978260869565, 0.41666666666667
55294, 0.89130434782609, 1.2978260869565, 0.44444444444444
55295, 0.8695652173913, 1.2717391304348, 0.44444444444444
55296, 0.8695652173913, 1.2978260869565, 0.47222222222222
55297, 0.82608695652174, 1.2978260869565, 0.027777777777778
55298, 0.84782608695652, 1.2978260869565, 0.055555555555556
55299, 0.82608695652174, 1.2717391304348, 0.055555555555556
55300, 0.82608695652174, 1.2978260869565, 0.083333333333333
55301, 0.84782608695652, 1.2978260869565, 0.11111111111111
55302, 0.82608695652174, 1.2717391304348, 0.11111111111111
55303, 0.82608695652174, 1.2978260869565, 0.13888888888889
55304, 0.84782608695652, 1.2978260869565, 0.16666666666667
55305, 0.82608695652174, 1.2717391304348, 0.16666666666667
55306, 0.82608695652174, 1.2978260869565, 0.19444444444444
55307, 0.84782608695652, 1.2978260869565, 0.22222222222222
55308, 0.82608695652174, 1.2717391304348, 0.22222222222222
55309, 0.82608695652174, 1.2978260869565, 0.25
55310, 0.84782608695652, 1.2978260869565, 0.27777777777778
55311, 0.82608695652174, 1.2717391304348, 0.27777777777778
55312, 0.82608695652174, 1.2978260869565, 0.30555555555556
55313, 0.84782608695652, 1.2978260869565, 0.33333333333333
55314, 0.82608695652174, 1.2717391304348, 0.33333333333333
55315, 0.82608695652174, 1.2978260869565, 0.36111111111111
55316, 0.84782608695652, 1.2978260869565, 0.38888888888889
55317, 0.82608695652174, 1.2717391304348, 0.38888888888889
55318, 0.82608695652174, 1.2978260869565, 0.41666666666667
55319, 0.84782608695652, 1.2978260869565, 0.44444444444444
55320, 0.82608695652174, 1.2717391304348, 0.44444444444444
55321, 0.82608695652174, 1.2978260869565, 0.47222222222222
55322, 0.78260869565217, 1.2978260869565, 0.027777777777778
55323, 0.80434782608696, 1.2978260869565, 0.055555555555556
55324, 0.78260869565217, 1.2717391304348, 0.055555555555556
55325, 0.78260869565217, 1.2978260869565, 0.083333333333333
55326, 0.80434782608696, 1.2978260869565, 0.11111111111111
55327, 0.78260869565217, 1.2717391304348, 0.11111111111111
55328, 0.78260869565217, 1.2978260869565, 0.13888888888889
55329, 0.80434782608696, 1.2978260869565, 0.16666666666667
55330, 0.78260869565217, 1.2717391304348, 0.16666666666667
55331, 0.78260869565217, 1.2978260869565, 0.19444444444444
55332, 0.80434782608696, 1.2978260869565, 0.22222222222222
55333, 0.78260869565217, 1.2717391304348, 0.22222222222222
55334, 0.78260869565217, 1.2978260869565, 0.25
55335, 0.80434782608696, 1.2978260869565, 0.27777777777778
55336, 0.78260869565217, 1.2717391304348, 0.27777777777778
55337, 0.78260869565217, 1.2978260869565, 0.30555555555556
55338, 0.80434782608696, 1.2978260869565, 0.33333333333333
55339, 0.78260869565217, 1.2717391304348, 0.33333333333333
55340, 0.78260869565217, 1.2978260869565, 0.36111111111111
55341, 0.80434782608696, 1.2978260869565, 0.38888888888889
55342, 0.78260869565217, 1.2717391304348, 0.38888888888889
55343, 0.78260869565217, 1.2978260869565, 0.41666666666667
55344, 0.80434782608696, 1.2978260869565, 0.44444444444444
55345, 0.78260869565217, 1.2717391304348, 0.44444444444444
55346, 0.78260869565217, 1.2978260869565, 0.47222222222222
55347, 0.73913043478261, 1.2978260869565, 0.027777777777778
55348, 0.76086956521739, 1.2978260869565, 0.055555555555556
55349, 0.73913043478261, 1.2717391304348, 0.055555555555556
55350, 0.73913043478261, 1.2978260869565, 0.083333333333333
55351, 0.76086956521739, 1.2978260869565, 0.11111111111111
55352, 0.73913043478261, 1.2717391304348, 0.11111111111111
55353, 0.73913043478261, 1.2978260869565, 0.13888888888889
55354, 0.76086956521739, 1.2978260869565, 0.16666666666667
55355, 0.73913043478261, 1.2717391304348, 0.16666666666667
55356, 0.73913043478261, 1.2978260869565, 0.19444444444444
55357, 0.76086956521739, 1.2978260869565, 0.22222222222222
55358, 0.73913043478261, 1.2717391304348, 0.22222222222222
55359, 0.73913043478261, 1.2978260869565, 0.25
55360, 0.76086956521739, 1.2978260869565, 0.27777777777778
55361, 0.73913043478261, 1.2717391304348, 0.27777777777778
55362, 0.73913043478261, 1.2978260869565, 0.30555555555556
55363, 0.76086956521739, 1.2978260869565, 0.33333333333333
55364, 0.73913043478261, 1.2717391304348, 0.33333333333333
55365, 0.73913043478261, 1.2978260869565, 0.36111111111111
55366, 0.76086956521739, 1.2978260869565, 0.38888888888889
55367, 0.73913043478261, 1.2717391304348, 0.38888888888889
55368, 0.73913043478261, 1.2978260869565, 0.41666666666667
55369, 0.76086956521739, 1.2978260869565, 0.44444444444444
55370, 0.73913043478261, 1.2717391304348, 0.44444444444444
55371, 0.73913043478261, 1.2978260869565, 0.47222222222222
55372, 0.69565217391304, 1.2978260869565, 0.027777777777778
55373, 0.71739130434783, 1.2978260869565, 0.055555555555556
55374, 0.69565217391304, 1.2717391304348, 0.055555555555556
55375, 0.69565217391304, 1.2978260869565, 0.083333333333333
55376, 0.71739130434783, 1.2978260869565, 0.11111111111111
55377, 0.69565217391304, 1.2717391304348, 0.11111111111111
55378, 0.69565217391304, 1.2978260869565, 0.13888888888889
55379, 0.71739130434783, 1.2978260869565, 0.16666666666667
55380, 0.69565217391304, 1.2717391304348, 0.16666666666667
55381, 0.69565217391304, 1.2978260869565, 0.19444444444444
55382, 0.71739130434783, 1.2978260869565, 0.22222222222222
55383, 0.69565217391304, 1.2717391304348, 0.22222222222222
55384, 0.69565217391304, 1.2978260869565, 0.25
55385, 0.71739130434783, 1.2978260869565, 0.27777777777778
55386, 0.69565217391304, 1.2717391304348, 0.27777777777778
55387, 0.69565217391304, 1.2978260869565, 0.30555555555556
55388, 0.71739130434783, 1.2978260869565, 0.33333333333333
55389, 0.69565217391304, 1.2717391304348, 0.33333333333333
55390, 0.69565217391304, 1.2978260869565, 0.36111111111111
55391, 0.71739130434783, 1.2978260869565, 0.38888888888889
55392, 0.69565217391304, 1.2717391304348, 0.38888888888889
55393, 0.69565217391304, 1.2978260869565, 0.41666666666667
55394, 0.71739130434783, 1.2978260869565, 0.44444444444444
55395, 0.69565217391304, 1.2717391304348, 0.44444444444444
55396, 0.69565217391304, 1.2978260869565, 0.47222222222222
55397, 0.65217391304348, 1.2978260869565, 0.027777777777778
55398, 0.67391304347826, 1.2978260869565, 0.055555555555556
55399, 0.65217391304348, 1.2717391304348, 0.055555555555556
55400, 0.65217391304348, 1.2978260869565, 0.083333333333333
55401, 0.67391304347826, 1.2978260869565, 0.11111111111111
55402, 0.65217391304348, 1.2717391304348, 0.11111111111111
55403, 0.65217391304348, 1.2978260869565, 0.13888888888889
55404, 0.67391304347826, 1.2978260869565, 0.16666666666667
55405, 0.65217391304348, 1.2717391304348, 0.16666666666667
55406, 0.65217391304348, 1.2978260869565, 0.19444444444444
55407, 0.67391304347826, 1.2978260869565, 0.22222222222222
55408, 0.65217391304348, 1.2717391304348, 0.22222222222222
55409, 0.65217391304348, 1.2978260869565, 0.25
55410, 0.67391304347826, 1.2978260869565, 0.27777777777778
55411, 0.65217391304348, 1.2717391304348, 0.27777777777778
55412, 0.65217391304348, 1.2978260869565, 0.30555555555556
55413, 0.67391304347826, 1.2978260869565, 0.33333333333333
55414, 0.65217391304348, 1.2717391304348, 0.33333333333333
55415, 0.65217391304348, 1.2978260869565, 0.36111111111111
55416, 0.67391304347826, 1.2978260869565, 0.38888888888889
55417, 0.65217391304348, 1.2717391304348, 0.38888888888889
55418, 0.65217391304348, 1.2978260869565, 0.41666666666667
55419, 0.67391304347826, 1.2978260869565, 0.44444444444444
55420, 0.65217391304348, 1.2717391304348, 0.44444444444444
55421, 0.65217391304348, 1.2978260869565, 0.47222222222222
55422, 0.60869565217391, 1.2978260869565, 0.027777777777778
55423, 0.6304347826087, 1.2978260869565, 0.055555555555556
55424, 0.60869565217391, 1.2717391304348, 0.055555555555556
55425, 0.60869565217391, 1.2978260869565, 0.083333333333333
55426, 0.6304347826087, 1.2978260869565, 0.11111111111111
55427, 0.60869565217391, 1.2717391304348, 0.11111111111111
55428, 0.60869565217391, 1.2978260869565, 0.13888888888889
55429, 0.6304347826087, 1.2978260869565, 0.16666666666667
55430, 0.60869565217391, 1.2717391304348, 0.16666666666667
55431, 0.60869565217391, 1.2978260869565, 0.19444444444444
55432, 0.6304347826087, 1.2978260869565, 0.22222222222222
55433, 0.60869565217391, 1.2717391304348, 0.22222222222222
55434, 0.60869565217391, 1.2978260869565, 0.25
55435, 0.6304347826087, 1.2978260869565, 0.27777777777778
55436, 0.60869565217391, 1.2717391304348, 0.27777777777778
55437, 0.60869565217391, 1.2978260869565, 0.30555555555556
55438, 0.6304347826087, 1.2978260869565, 0.33333333333333
55439, 0.60869565217391, 1.2717391304348, 0.33333333333333
55440, 0.60869565217391, 1.2978260869565, 0.36111111111111
55441, 0.6304347826087, 1.2978260869565, 0.38888888888889
55442, 0.60869565217391, 1.2717391304348, 0.38888888888889
55443, 0.60869565217391, 1.2978260869565, 0.41666666666667
55444, 0.6304347826087, 1.2978260869565, 0.44444444444444
55445, 0.60869565217391, 1.2717391304348, 0.44444444444444
55446, 0.60869565217391, 1.2978260869565, 0.47222222222222
55447, 0.56521739130435, 1.2978260869565, 0.027777777777778
55448, 0.58695652173913, 1.2978260869565, 0.055555555555556
55449, 0.56521739130435, 1.2717391304348, 0.055555555555556
55450, 0.56521739130435, 1.2978260869565, 0.083333333333333
55451, 0.58695652173913, 1.2978260869565, 0.11111111111111
55452, 0.56521739130435, 1.2717391304348, 0.11111111111111
55453, 0.56521739130435, 1.2978260869565, 0.13888888888889
55454, 0.58695652173913, 1.2978260869565, 0.16666666666667
55455, 0.56521739130435, 1.2717391304348, 0.16666666666667
55456, 0.56521739130435, 1.2978260869565, 0.19444444444444
55457, 0.58695652173913, 1.2978260869565, 0.22222222222222
55458, 0.56521739130435, 1.2717391304348, 0.22222222222222
55459, 0.56521739130435, 1.2978260869565, 0.25
55460, 0.58695652173913, 1.2978260869565, 0.27777777777778
55461, 0.56521739130435, 1.2717391304348, 0.27777777777778
55462, 0.56521739130435, 1.2978260869565, 0.30555555555556
55463, 0.58695652173913, 1.2978260869565, 0.33333333333333
55464, 0.56521739130435, 1.2717391304348, 0.33333333333333
55465, 0.56521739130435, 1.2978260869565, 0.36111111111111
55466, 0.58695652173913, 1.2978260869565, 0.38888888888889
55467, 0.56521739130435, 1.2717391304348, 0.38888888888889
55468, 0.56521739130435, 1.2978260869565, 0.41666666666667
55469, 0.58695652173913, 1.2978260869565, 0.44444444444444
55470, 0.56521739130435, 1.2717391304348, 0.44444444444444
55471, 0.56521739130435, 1.2978260869565, 0.47222222222222
55472, 0.52173913043478, 1.2978260869565, 0.027777777777778
55473, 0.54347826086957, 1.2978260869565, 0.055555555555556
55474, 0.52173913043478, 1.2717391304348, 0.055555555555556
55475, 0.52173913043478, 1.2978260869565, 0.083333333333333
55476, 0.54347826086957, 1.2978260869565, 0.11111111111111
55477, 0.52173913043478, 1.2717391304348, 0.11111111111111
55478, 0.52173913043478, 1.2978260869565, 0.13888888888889
55479, 0.54347826086956, 1.2978260869565, 0.16666666666667
55480, 0.52173913043478, 1.2717391304348, 0.16666666666667
55481, 0.52173913043478, 1.2978260869565, 0.19444444444444
55482, 0.54347826086956, 1.2978260869565, 0.22222222222222
55483, 0.52173913043478, 1.2717391304348, 0.22222222222222
55484, 0.52173913043478, 1.2978260869565, 0.25
55485, 0.54347826086956, 1.2978260869565, 0.27777777777778
55486, 0.52173913043478, 1.2717391304348, 0.27777777777778
55487, 0.52173913043478, 1.2978260869565, 0.30555555555556
55488, 0.54347826086956, 1.2978260869565, 0.33333333333333
55489, 0.52173913043478, 1.2717391304348, 0.33333333333333
55490, 0.52173913043478, 1.2978260869565, 0.36111111111111
55491, 0.54347826086956, 1.2978260869565, 0.38888888888889
55492, 0.52173913043478, 1.2717391304348, 0.38888888888889
55493, 0.52173913043478, 1.2978260869565, 0.41666666666667
55494, 0.54347826086956, 1.2978260869565, 0.44444444444444
55495, 0.52173913043478, 1.2717391304348, 0.44444444444444
55496, 0.52173913043478, 1.2978260869565, 0.47222222222222
55497, 0.47826086956522, 1.2978260869565, 0.027777777777778
55498, 0.5, 1.2978260869565, 0.055555555555556
55499, 0.47826086956522, 1.2717391304348, 0.055555555555556
55500, 0.47826086956522, 1.2978260869565, 0.083333333333333
55501, 0.5, 1.2978260869565, 0.11111111111111
55502, 0.47826086956522, 1.2717391304348, 0.11111111111111
55503, 0.47826086956522, 1.2978260869565, 0.13888888888889
55504, 0.5, 1.2978260869565, 0.16666666666667
55505, 0.47826086956522, 1.2717391304348, 0.16666666666667
55506, 0.47826086956522, 1.2978260869565, 0.19444444444444
55507, 0.5, 1.2978260869565, 0.22222222222222
55508, 0.47826086956522, 1.2717391304348, 0.22222222222222
55509, 0.47826086956522, 1.2978260869565, 0.25
55510, 0.5, 1.2978260869565, 0.27777777777778
55511, 0.47826086956522, 1.2717391304348, 0.27777777777778
55512, 0.47826086956522, 1.2978260869565, 0.30555555555556
55513, 0.5, 1.2978260869565, 0.33333333333333
55514, 0.47826086956522, 1.2717391304348, 0.33333333333333
55515, 0.47826086956522, 1.2978260869565, 0.36111111111111
55516, 0.5, 1.2978260869565, 0.38888888888889
55517, 0.47826086956522, 1.2717391304348, 0.38888888888889
55518, 0.47826086956522, 1.2978260869565, 0.41666666666667
55519, 0.5, 1.2978260869565, 0.44444444444444
55520, 0.47826086956522, 1.2717391304348, 0.44444444444444
55521, 0.47826086956522, 1.2978260869565, 0.47222222222222
55522, 0.43478260869565, 1.2978260869565, 0.027777777777778
55523, 0.45652173913043, 1.2978260869565, 0.055555555555556
55524, 0.43478260869565, 1.2717391304348, 0.055555555555556
55525, 0.43478260869565, 1.2978260869565, 0.083333333333333
55526, 0.45652173913043, 1.2978260869565, 0.11111111111111
55527, 0.43478260869565, 1.2717391304348, 0.11111111111111
55528, 0.43478260869565, 1.2978260869565, 0.13888888888889
55529, 0.45652173913043, 1.2978260869565, 0.16666666666667
55530, 0.43478260869565, 1.2717391304348, 0.16666666666667
55531, 0.43478260869565, 1.2978260869565, 0.19444444444444
55532, 0.45652173913043, 1.2978260869565, 0.22222222222222
55533, 0.43478260869565, 1.2717391304348, 0.22222222222222
55534, 0.43478260869565, 1.2978260869565, 0.25
55535, 0.45652173913043, 1.2978260869565, 0.27777777777778
55536, 0.43478260869565, 1.2717391304348, 0.27777777777778
55537, 0.43478260869565, 1.2978260869565, 0.30555555555556
55538, 0.45652173913043, 1.2978260869565, 0.33333333333333
55539, 0.43478260869565, 1.2717391304348, 0.33333333333333
55540, 0.43478260869565, 1.2978260869565, 0.36111111111111
55541, 0.45652173913044, 1.2978260869565, 0.38888888888889
55542, 0.43478260869565, 1.2717391304348, 0.38888888888889
55543, 0.43478260869565, 1.2978260869565, 0.41666666666667
55544, 0.45652173913043, 1.2978260869565, 0.44444444444444
55545, 0.43478260869565, 1.2717391304348, 0.44444444444444
55546, 0.43478260869565, 1.2978260869565, 0.47222222222222
55547, 0.39130434782609, 1.2978260869565, 0.027777777777778
55548, 0.41304347826087, 1.2978260869565, 0.055555555555556
55549, 0.39130434782609, 1.2717391304348, 0.055555555555556
55550, 0.39130434782609, 1.2978260869565, 0.083333333333333
55551, 0.41304347826087, 1.2978260869565, 0.11111111111111
55552, 0.39130434782609, 1.2717391304348, 0.11111111111111
55553, 0.39130434782609, 1.2978260869565, 0.13888888888889
55554, 0.41304347826087, 1.2978260869565, 0.16666666666667
55555, 0.39130434782609, 1.2717391304348, 0.16666666666667
55556, 0.39130434782609, 1.2978260869565, 0.19444444444444
55557, 0.41304347826087, 1.2978260869565, 0.22222222222222
55558, 0.39130434782609, 1.2717391304348, 0.22222222222222
55559, 0.39130434782609, 1.2978260869565, 0.25
55560, 0.41304347826087, 1.2978260869565, 0.27777777777778
55561, 0.39130434782609, 1.2717391304348, 0.27777777777778
55562, 0.39130434782609, 1.2978260869565, 0.30555555555556
55563, 0.41304347826087, 1.2978260869565, 0.33333333333333
55564, 0.39130434782609, 1.2717391304348, 0.33333333333333
55565, 0.39130434782609, 1.2978260869565, 0.36111111111111
55566, 0.41304347826087, 1.2978260869565, 0.38888888888889
55567, 0.39130434782609, 1.2717391304348, 0.38888888888889
55568, 0.39130434782609, 1.2978260869565, 0.41666666666667
55569, 0.41304347826087, 1.2978260869565, 0.44444444444444
55570, 0.39130434782609, 1.2717391304348, 0.44444444444444
55571, 0.39130434782609, 1.2978260869565, 0.47222222222222
55572, 0.34782608695652, 1.2978260869565, 0.027777777777778
55573, 0.3695652173913, 1.2978260869565, 0.055555555555556
55574, 0.34782608695652, 1.2717391304348, 0.055555555555556
55575, 0.34782608695652, 1.2978260869565, 0.083333333333333
55576, 0.3695652173913, 1.2978260869565, 0.11111111111111
55577, 0.34782608695652, 1.2717391304348, 0.11111111111111
55578, 0.34782608695652, 1.2978260869565, 0.13888888888889
55579, 0.3695652173913, 1.2978260869565, 0.16666666666667
55580, 0.34782608695652, 1.2717391304348, 0.16666666666667
55581, 0.34782608695652, 1.2978260869565, 0.19444444444444
55582, 0.3695652173913, 1.2978260869565, 0.22222222222222
55583, 0.34782608695652, 1.2717391304348, 0.22222222222222
55584, 0.34782608695652, 1.2978260869565, 0.25
55585, 0.3695652173913, 1.2978260869565, 0.27777777777778
55586, 0.34782608695652, 1.2717391304348, 0.27777777777778
55587, 0.34782608695652, 1.2978260869565, 0.30555555555556
55588, 0.3695652173913, 1.2978260869565, 0.33333333333333
55589, 0.34782608695652, 1.2717391304348, 0.33333333333333
55590, 0.34782608695652, 1.2978260869565, 0.36111111111111
55591, 0.3695652173913, 1.2978260869565, 0.38888888888889
55592, 0.34782608695652, 1.2717391304348, 0.38888888888889
55593, 0.34782608695652, 1.2978260869565, 0.41666666666667
55594, 0.3695652173913, 1.2978260869565, 0.44444444444444
55595, 0.34782608695652, 1.2717391304348, 0.44444444444444
55596, 0.34782608695652, 1.2978260869565, 0.47222222222222
55597, 0.30434782608696, 1.2978260869565, 0.027777777777778
55598, 0.32608695652174, 1.2978260869565, 0.055555555555556
55599, 0.30434782608696, 1.2717391304348, 0.055555555555556
55600, 0.30434782608696, 1.2978260869565, 0.083333333333333
55601, 0.32608695652174, 1.2978260869565, 0.11111111111111
55602, 0.30434782608696, 1.2717391304348, 0.11111111111111
55603, 0.30434782608696, 1.2978260869565, 0.13888888888889
55604, 0.32608695652174, 1.2978260869565, 0.16666666666667
55605, 0.30434782608696, 1.2717391304348, 0.16666666666667
55606, 0.30434782608696, 1.2978260869565, 0.19444444444444
55607, 0.32608695652174, 1.2978260869565, 0.22222222222222
55608, 0.30434782608696, 1.2717391304348, 0.22222222222222
55609, 0.30434782608696, 1.2978260869565, 0.25
55610, 0.32608695652174, 1.2978260869565, 0.27777777777778
55611, 0.30434782608696, 1.2717391304348, 0.27777777777778
55612, 0.30434782608696, 1.2978260869565, 0.30555555555556
55613, 0.32608695652174, 1.2978260869565, 0.33333333333333
55614, 0.30434782608696, 1.2717391304348, 0.33333333333333
55615, 0.30434782608696, 1.2978260869565, 0.36111111111111
55616, 0.32608695652174, 1.2978260869565, 0.38888888888889
55617, 0.30434782608696, 1.2717391304348, 0.38888888888889
55618, 0.30434782608696, 1.2978260869565, 0.41666666666667
55619, 0.32608695652174, 1.2978260869565, 0.44444444444444
55620, 0.30434782608696, 1.2717391304348, 0.44444444444444
55621, 0.30434782608696, 1.2978260869565, 0.47222222222222
55622, 0.26086956521739, 1.2978260869565, 0.027777777777778
55623, 0.28260869565217, 1.2978260869565, 0.055555555555556
55624, 0.26086956521739, 1.2717391304348, 0.055555555555556
55625, 0.26086956521739, 1.2978260869565, 0.083333333333333
55626, 0.28260869565217, 1.2978260869565, 0.11111111111111
55627, 0.26086956521739, 1.2717391304348, 0.11111111111111
55628, 0.26086956521739, 1.2978260869565, 0.13888888888889
55629, 0.28260869565217, 1.2978260869565, 0.16666666666667
55630, 0.26086956521739, 1.2717391304348, 0.16666666666667
55631, 0.26086956521739, 1.2978260869565, 0.19444444444444
55632, 0.28260869565217, 1.2978260869565, 0.22222222222222
55633, 0.26086956521739, 1.2717391304348, 0.22222222222222
55634, 0.26086956521739, 1.2978260869565, 0.25
55635, 0.28260869565217, 1.2978260869565, 0.27777777777778
55636, 0.26086956521739, 1.2717391304348, 0.27777777777778
55637, 0.26086956521739, 1.2978260869565, 0.30555555555556
55638, 0.28260869565217, 1.2978260869565, 0.33333333333333
55639, 0.26086956521739, 1.2717391304348, 0.33333333333333
55640, 0.26086956521739, 1.2978260869565, 0.36111111111111
55641, 0.28260869565217, 1.2978260869565, 0.38888888888889
55642, 0.26086956521739, 1.2717391304348, 0.38888888888889
55643, 0.26086956521739, 1.2978260869565, 0.41666666666667
55644, 0.28260869565217, 1.2978260869565, 0.44444444444444
55645, 0.26086956521739, 1.2717391304348, 0.44444444444444
55646, 0.26086956521739, 1.2978260869565, 0.47222222222222
55647, 0.21739130434783, 1.2978260869565, 0.027777777777778
55648, 0.23913043478261, 1.2978260869565, 0.055555555555556
55649, 0.21739130434783, 1.2717391304348, 0.055555555555556
55650, 0.21739130434783, 1.2978260869565, 0.083333333333333
55651, 0.23913043478261, 1.2978260869565, 0.11111111111111
55652, 0.21739130434783, 1.2717391304348, 0.11111111111111
55653, 0.21739130434783, 1.2978260869565, 0.13888888888889
55654, 0.23913043478261, 1.2978260869565, 0.16666666666667
55655, 0.21739130434783, 1.2717391304348, 0.16666666666667
55656, 0.21739130434783, 1.2978260869565, 0.19444444444444
55657, 0.23913043478261, 1.2978260869565, 0.22222222222222
55658, 0.21739130434783, 1.2717391304348, 0.22222222222222
55659, 0.21739130434783, 1.2978260869565, 0.25
55660, 0.23913043478261, 1.2978260869565, 0.27777777777778
55661, 0.21739130434783, 1.2717391304348, 0.27777777777778
55662, 0.21739130434783, 1.2978260869565, 0.30555555555556
55663, 0.23913043478261, 1.2978260869565, 0.33333333333333
55664, 0.21739130434783, 1.2717391304348, 0.33333333333333
55665, 0.21739130434783, 1.2978260869565, 0.36111111111111
55666, 0.23913043478261, 1.2978260869565, 0.38888888888889
55667, 0.21739130434783, 1.2717391304348, 0.38888888888889
55668, 0.21739130434783, 1.2978260869565, 0.41666666666667
55669, 0.23913043478261, 1.2978260869565, 0.44444444444444
55670, 0.21739130434783, 1.2717391304348, 0.44444444444444
55671, 0.21739130434783, 1.2978260869565, 0.47222222222222
55672, 0.17391304347826, 1.2978260869565, 0.027777777777778
55673, 0.19565217391304, 1.2978260869565, 0.055555555555556
55674, 0.17391304347826, 1.2717391304348, 0.055555555555556
55675, 0.17391304347826, 1.2978260869565, 0.083333333333333
55676, 0.19565217391304, 1.2978260869565, 0.11111111111111
55677, 0.17391304347826, 1.2717391304348, 0.11111111111111
55678, 0.17391304347826, 1.2978260869565, 0.13888888888889
55679, 0.19565217391304, 1.2978260869565, 0.16666666666667
55680, 0.17391304347826, 1.2717391304348, 0.16666666666667
55681, 0.17391304347826, 1.2978260869565, 0.19444444444444
55682, 0.19565217391304, 1.2978260869565, 0.22222222222222
55683, 0.17391304347826, 1.2717391304348, 0.22222222222222
55684, 0.17391304347826, 1.2978260869565, 0.25
55685, 0.19565217391304, 1.2978260869565, 0.27777777777778
55686, 0.17391304347826, 1.2717391304348, 0.27777777777778
55687, 0.17391304347826, 1.2978260869565, 0.30555555555556
55688, 0.19565217391304, 1.2978260869565, 0.33333333333333
55689, 0.17391304347826, 1.2717391304348, 0.33333333333333
55690, 0.17391304347826, 1.2978260869565, 0.36111111111111
55691, 0.19565217391304, 1.2978260869565, 0.38888888888889
55692, 0.17391304347826, 1.2717391304348, 0.38888888888889
55693, 0.17391304347826, 1.2978260869565, 0.41666666666667
55694, 0.19565217391304, 1.2978260869565, 0.44444444444444
55695, 0.17391304347826, 1.2717391304348, 0.44444444444444
55696, 0.17391304347826, 1.2978260869565, 0.47222222222222
55697, 0.1304347826087, 1.2978260869565, 0.027777777777778
55698, 0.15217391304348, 1.2978260869565, 0.055555555555556
55699, 0.1304347826087, 1.2717391304348, 0.055555555555556
55700, 0.1304347826087, 1.2978260869565, 0.083333333333333
55701, 0.15217391304348, 1.2978260869565, 0.11111111111111
55702, 0.1304347826087, 1.2717391304348, 0.11111111111111
55703, 0.1304347826087, 1.2978260869565, 0.13888888888889
55704, 0.15217391304348, 1.2978260869565, 0.16666666666667
55705, 0.1304347826087, 1.2717391304348, 0.16666666666667
55706, 0.1304347826087, 1.2978260869565, 0.19444444444444
55707, 0.15217391304348, 1.2978260869565, 0.22222222222222
55708, 0.1304347826087, 1.2717391304348, 0.22222222222222
55709, 0.1304347826087, 1.2978260869565, 0.25
55710, 0.15217391304348, 1.2978260869565, 0.27777777777778
55711, 0.1304347826087, 1.2717391304348, 0.27777777777778
55712, 0.1304347826087, 1.2978260869565, 0.30555555555556
55713, 0.15217391304348, 1.2978260869565, 0.33333333333333
55714, 0.1304347826087, 1.2717391304348, 0.33333333333333
55715, 0.1304347826087, 1.2978260869565, 0.36111111111111
55716, 0.15217391304348, 1.2978260869565, 0.38888888888889
55717, 0.1304347826087, 1.2717391304348, 0.38888888888889
55718, 0.1304347826087, 1.2978260869565, 0.41666666666667
55719, 0.15217391304348, 1.2978260869565, 0.44444444444444
55720, 0.1304347826087, 1.2717391304348, 0.44444444444444
55721, 0.1304347826087, 1.2978260869565, 0.47222222222222
55722, 0.08695652173913, 1.2978260869565, 0.027777777777778
55723, 0.10869565217391, 1.2978260869565, 0.055555555555556
55724, 0.08695652173913, 1.2717391304348, 0.055555555555556
55725, 0.08695652173913, 1.2978260869565, 0.083333333333333
55726, 0.10869565217391, 1.2978260869565, 0.11111111111111
55727, 0.08695652173913, 1.2717391304348, 0.11111111111111
55728, 0.08695652173913, 1.2978260869565, 0.13888888888889
55729, 0.10869565217391, 1.2978260869565, 0.16666666666667
55730, 0.08695652173913, 1.2717391304348, 0.16666666666667
55731, 0.08695652173913, 1.2978260869565, 0.19444444444444
55732, 0.10869565217391, 1.2978260869565, 0.22222222222222
55733, 0.08695652173913, 1.2717391304348, 0.22222222222222
55734, 0.08695652173913, 1.2978260869565, 0.25
55735, 0.10869565217391, 1.2978260869565, 0.27777777777778
55736, 0.08695652173913, 1.2717391304348, 0.27777777777778
55737, 0.08695652173913, 1.2978260869565, 0.30555555555556
55738, 0.10869565217391, 1.2978260869565, 0.33333333333333
55739, 0.08695652173913, 1.2717391304348, 0.33333333333333
55740, 0.08695652173913, 1.2978260869565, 0.36111111111111
55741, 0.10869565217391, 1.2978260869565, 0.38888888888889
55742, 0.08695652173913, 1.2717391304348, 0.38888888888889
55743, 0.08695652173913, 1.2978260869565, 0.41666666666667
55744, 0.10869565217391, 1.2978260869565, 0.44444444444444
55745, 0.08695652173913, 1.2717391304348, 0.44444444444444
55746, 0.08695652173913, 1.2978260869565, 0.47222222222222
55747, 0.043478260869565, 1.2978260869565, 0.027777777777778
55748, 0.065217391304348, 1.2978260869565, 0.055555555555556
55749, 0.043478260869565, 1.2717391304348, 0.055555555555556
55750, 0.043478260869565, 1.2978260869565, 0.083333333333333
55751, 0.065217391304348, 1.2978260869565, 0.11111111111111
55752, 0.043478260869565, 1.2717391304348, 0.11111111111111
55753, 0.043478260869565, 1.2978260869565, 0.13888888888889
55754, 0.065217391304348, 1.2978260869565, 0.16666666666667
55755, 0.043478260869565, 1.2717391304348, 0.16666666666667
55756, 0.043478260869565, 1.2978260869565, 0.19444444444444
55757, 0.065217391304348, 1.2978260869565, 0.22222222222222
55758, 0.043478260869565, 1.2717391304348, 0.22222222222222
55759, 0.043478260869565, 1.2978260869565, 0.25
55760, 0.065217391304348, 1.2978260869565, 0.27777777777778
55761, 0.043478260869565, 1.2717391304348, 0.27777777777778
55762, 0.043478260869565, 1.2978260869565, 0.30555555555556
55763, 0.065217391304348, 1.2978260869565, 0.33333333333333
55764, 0.043478260869565, 1.2717391304348, 0.33333333333333
55765, 0.043478260869565, 1.2978260869565, 0.36111111111111
55766, 0.065217391304348, 1.2978260869565, 0.38888888888889
55767, 0.043478260869565, 1.2717391304348, 0.38888888888889
55768, 0.043478260869565, 1.2978260869565, 0.41666666666667
55769, 0.065217391304348, 1.2978260869565, 0.44444444444444
55770, 0.043478260869565, 1.2717391304348, 0.44444444444444
55771, 0.043478260869565, 1.2978260869565, 0.47222222222222
55772, 0.021739130434783, 1.2978260869565, 0.055555555555556
55773, 0.021739130434783, 1.2978260869565, 0.11111111111111
55774, 0.021739130434783, 1.2978260869565, 0.16666666666667
55775, 0.021739130434783, 1.2978260869565, 0.22222222222222
55776, 0.021739130434783, 1.2978260869565, 0.27777777777778
55777, 0.021739130434783, 1.2978260869565, 0.33333333333333
55778, 0.021739130434783, 1.2978260869565, 0.38888888888889
55779, 0.021739130434783, 1.2978260869565, 0.44444444444444
55780, 0.95652173913043, 1.3239130434783, 0.055555555555556
55781, 0.95652173913043, 1.3239130434783, 0.11111111111111
55782, 0.95652173913043, 1.3239130434783, 0.16666666666667
55783, 0.95652173913043, 1.3239130434783, 0.22222222222222
55784, 0.95652173913043, 1.3239130434783, 0.27777777777778
55785, 0.95652173913043, 1.3239130434783, 0.33333333333333
55786, 0.95652173913043, 1.3239130434783, 0.38888888888889
55787, 0.95652173913043, 1.3239130434783, 0.44444444444444
55788, 0.91304347826087, 1.3239130434783, 0.055555555555556
55789, 0.91304347826087, 1.3239130434783, 0.11111111111111
55790, 0.91304347826087, 1.3239130434783, 0.16666666666667
55791, 0.91304347826087, 1.3239130434783, 0.22222222222222
55792, 0.91304347826087, 1.3239130434783, 0.27777777777778
55793, 0.91304347826087, 1.3239130434783, 0.33333333333333
55794, 0.91304347826087, 1.3239130434783, 0.38888888888889
55795, 0.91304347826087, 1.3239130434783, 0.44444444444444
55796, 0.8695652173913, 1.3239130434783, 0.055555555555556
55797, 0.8695652173913, 1.3239130434783, 0.11111111111111
55798, 0.8695652173913, 1.3239130434783, 0.16666666666667
55799, 0.8695652173913, 1.3239130434783, 0.22222222222222
55800, 0.8695652173913, 1.3239130434783, 0.27777777777778
55801, 0.8695652173913, 1.3239130434783, 0.33333333333333
55802, 0.8695652173913, 1.3239130434783, 0.38888888888889
55803, 0.8695652173913, 1.3239130434783, 0.44444444444444
55804, 0.82608695652174, 1.3239130434783, 0.055555555555556
55805, 0.82608695652174, 1.3239130434783, 0.11111111111111
55806, 0.82608695652174, 1.3239130434783, 0.16666666666667
55807, 0.82608695652174, 1.3239130434783, 0.22222222222222
55808, 0.82608695652174, 1.3239130434783, 0.27777777777778
55809, 0.82608695652174, 1.3239130434783, 0.33333333333333
55810, 0.82608695652174, 1.3239130434783, 0.38888888888889
55811, 0.82608695652174, 1.3239130434783, 0.44444444444444
55812, 0.78260869565217, 1.3239130434783, 0.055555555555556
55813, 0.78260869565217, 1.3239130434783, 0.11111111111111
55814, 0.78260869565217, 1.3239130434783, 0.16666666666667
55815, 0.78260869565217, 1.3239130434783, 0.22222222222222
55816, 0.78260869565217, 1.3239130434783, 0.27777777777778
55817, 0.78260869565217, 1.3239130434783, 0.33333333333333
55818, 0.78260869565217, 1.3239130434783, 0.38888888888889
55819, 0.78260869565217, 1.3239130434783, 0.44444444444444
55820, 0.73913043478261, 1.3239130434783, 0.055555555555556
55821, 0.73913043478261, 1.3239130434783, 0.11111111111111
55822, 0.73913043478261, 1.3239130434783, 0.16666666666667
55823, 0.73913043478261, 1.3239130434783, 0.22222222222222
55824, 0.73913043478261, 1.3239130434783, 0.27777777777778
55825, 0.73913043478261, 1.3239130434783, 0.33333333333333
55826, 0.73913043478261, 1.3239130434783, 0.38888888888889
55827, 0.73913043478261, 1.3239130434783, 0.44444444444444
55828, 0.69565217391304, 1.3239130434783, 0.055555555555556
55829, 0.69565217391304, 1.3239130434783, 0.11111111111111
55830, 0.69565217391304, 1.3239130434783, 0.16666666666667
55831, 0.69565217391304, 1.3239130434783, 0.22222222222222
55832, 0.69565217391304, 1.3239130434783, 0.27777777777778
55833, 0.69565217391304, 1.3239130434783, 0.33333333333333
55834, 0.69565217391304, 1.3239130434783, 0.38888888888889
55835, 0.69565217391304, 1.3239130434783, 0.44444444444444
55836, 0.65217391304348, 1.3239130434783, 0.055555555555556
55837, 0.65217391304348, 1.3239130434783, 0.11111111111111
55838, 0.65217391304348, 1.3239130434783, 0.16666666666667
55839, 0.65217391304348, 1.3239130434783, 0.22222222222222
55840, 0.65217391304348, 1.3239130434783, 0.27777777777778
55841, 0.65217391304348, 1.3239130434783, 0.33333333333333
55842, 0.65217391304348, 1.3239130434783, 0.38888888888889
55843, 0.65217391304348, 1.3239130434783, 0.44444444444444
55844, 0.60869565217391, 1.3239130434783, 0.055555555555556
55845, 0.60869565217391, 1.3239130434783, 0.11111111111111
55846, 0.60869565217391, 1.3239130434783, 0.16666666666667
55847, 0.60869565217391, 1.3239130434783, 0.22222222222222
55848, 0.60869565217391, 1.3239130434783, 0.27777777777778
55849, 0.60869565217391, 1.3239130434783, 0.33333333333333
55850, 0.60869565217391, 1.3239130434783, 0.38888888888889
55851, 0.60869565217391, 1.3239130434783, 0.44444444444444
55852, 0.56521739130435, 1.3239130434783, 0.055555555555556
55853, 0.56521739130435, 1.3239130434783, 0.11111111111111
55854, 0.56521739130435, 1.3239130434783, 0.16666666666667
55855, 0.56521739130435, 1.3239130434783, 0.22222222222222
55856, 0.56521739130435, 1.3239130434783, 0.27777777777778
55857, 0.56521739130435, 1.3239130434783, 0.33333333333333
55858, 0.56521739130435, 1.3239130434783, 0.38888888888889
55859, 0.56521739130435, 1.3239130434783, 0.44444444444444
55860, 0.52173913043478, 1.3239130434783, 0.055555555555556
55861, 0.52173913043478, 1.3239130434783, 0.11111111111111
55862, 0.52173913043478, 1.3239130434783, 0.16666666666667
55863, 0.52173913043478, 1.3239130434783, 0.22222222222222
55864, 0.52173913043478, 1.3239130434783, 0.27777777777778
55865, 0.52173913043478, 1.3239130434783, 0.33333333333333
55866, 0.52173913043478, 1.3239130434783, 0.38888888888889
55867, 0.52173913043478, 1.3239130434783, 0.44444444444444
55868, 0.47826086956522, 1.3239130434783, 0.055555555555556
55869, 0.47826086956522, 1.3239130434783, 0.11111111111111
55870, 0.47826086956522, 1.3239130434783, 0.16666666666667
55871, 0.47826086956522, 1.3239130434783, 0.22222222222222
55872, 0.47826086956522, 1.3239130434783, 0.27777777777778
55873, 0.47826086956522, 1.3239130434783, 0.33333333333333
55874, 0.47826086956522, 1.3239130434783, 0.38888888888889
55875, 0.47826086956522, 1.3239130434783, 0.44444444444444
55876, 0.43478260869565, 1.3239130434783, 0.055555555555556
55877, 0.43478260869565, 1.3239130434783, 0.11111111111111
55878, 0.43478260869565, 1.3239130434783, 0.16666666666667
55879, 0.43478260869565, 1.3239130434783, 0.22222222222222
55880, 0.43478260869565, 1.3239130434783, 0.27777777777778
55881, 0.43478260869565, 1.3239130434783, 0.33333333333333
55882, 0.43478260869565, 1.3239130434783, 0.38888888888889
55883, 0.43478260869565, 1.3239130434783, 0.44444444444444
55884, 0.39130434782609, 1.3239130434783, 0.055555555555556
55885, 0.39130434782609, 1.3239130434783, 0.11111111111111
55886, 0.39130434782609, 1.3239130434783, 0.16666666666667
55887, 0.39130434782609, 1.3239130434783, 0.22222222222222
55888, 0.39130434782609, 1.3239130434783, 0.27777777777778
55889, 0.39130434782609, 1.3239130434783, 0.33333333333333
55890, 0.39130434782609, 1.3239130434783, 0.38888888888889
55891, 0.39130434782609, 1.3239130434783, 0.44444444444444
55892, 0.34782608695652, 1.3239130434783, 0.055555555555556
55893, 0.34782608695652, 1.3239130434783, 0.11111111111111
55894, 0.34782608695652, 1.3239130434783, 0.16666666666667
55895, 0.34782608695652, 1.3239130434783, 0.22222222222222
55896, 0.34782608695652, 1.3239130434783, 0.27777777777778
55897, 0.34782608695652, 1.3239130434783, 0.33333333333333
55898, 0.34782608695652, 1.3239130434783, 0.38888888888889
55899, 0.34782608695652, 1.3239130434783, 0.44444444444444
55900, 0.30434782608696, 1.3239130434783, 0.055555555555556
55901, 0.30434782608696, 1.3239130434783, 0.11111111111111
55902, 0.30434782608696, 1.3239130434783, 0.16666666666667
55903, 0.30434782608696, 1.3239130434783, 0.22222222222222
55904, 0.30434782608696, 1.3239130434783, 0.27777777777778
55905, 0.30434782608696, 1.3239130434783, 0.33333333333333
55906, 0.30434782608696, 1.3239130434783, 0.38888888888889
55907, 0.30434782608696, 1.3239130434783, 0.44444444444444
55908, 0.26086956521739, 1.3239130434783, 0.055555555555556
55909, 0.26086956521739, 1.3239130434783, 0.11111111111111
55910, 0.26086956521739, 1.3239130434783, 0.16666666666667
55911, 0.26086956521739, 1.3239130434783, 0.22222222222222
55912, 0.26086956521739, 1.3239130434783, 0.27777777777778
55913, 0.26086956521739, 1.3239130434783, 0.33333333333333
55914, 0.26086956521739, 1.3239130434783, 0.38888888888889
55915, 0.26086956521739, 1.3239130434783, 0.44444444444444
55916, 0.21739130434783, 1.3239130434783, 0.055555555555556
55917, 0.21739130434783, 1.3239130434783, 0.11111111111111
55918, 0.21739130434783, 1.3239130434783, 0.16666666666667
55919, 0.21739130434783, 1.3239130434783, 0.22222222222222
55920, 0.21739130434783, 1.3239130434783, 0.27777777777778
55921, 0.21739130434783, 1.3239130434783, 0.33333333333333
55922, 0.21739130434783, 1.3239130434783, 0.38888888888889
55923, 0.21739130434783, 1.3239130434783, 0.44444444444444
55924, 0.17391304347826, 1.3239130434783, 0.055555555555556
55925, 0.17391304347826, 1.3239130434783, 0.11111111111111
55926, 0.17391304347826, 1.3239130434783, 0.16666666666667
55927, 0.17391304347826, 1.3239130434783, 0.22222222222222
55928, 0.17391304347826, 1.3239130434783, 0.27777777777778
55929, 0.17391304347826, 1.3239130434783, 0.33333333333333
55930, 0.17391304347826, 1.3239130434783, 0.38888888888889
55931, 0.17391304347826, 1.3239130434783, 0.44444444444444
55932, 0.1304347826087, 1.3239130434783, 0.055555555555556
55933, 0.1304347826087, 1.3239130434783, 0.11111111111111
55934, 0.1304347826087, 1.3239130434783, 0.16666666666667
55935, 0.1304347826087, 1.3239130434783, 0.22222222222222
55936, 0.1304347826087, 1.3239130434783, 0.27777777777778
55937, 0.1304347826087, 1.3239130434783, 0.33333333333333
55938, 0.1304347826087, 1.3239130434783, 0.38888888888889
55939, 0.1304347826087, 1.3239130434783, 0.44444444444444
55940, 0.08695652173913, 1.3239130434783, 0.055555555555556
55941, 0.08695652173913, 1.3239130434783, 0.11111111111111
55942, 0.08695652173913, 1.3239130434783, 0.16666666666667
55943, 0.08695652173913, 1.3239130434783, 0.22222222222222
55944, 0.08695652173913, 1.3239130434783, 0.27777777777778
55945, 0.08695652173913, 1.3239130434783, 0.33333333333333
55946, 0.08695652173913, 1.3239130434783, 0.38888888888889
55947, 0.08695652173913, 1.3239130434783, 0.44444444444444
55948, 0.043478260869565, 1.3239130434783, 0.055555555555556
55949, 0.043478260869565, 1.3239130434783, 0.11111111111111
55950, 0.043478260869565, 1.3239130434783, 0.16666666666667
55951, 0.043478260869565, 1.3239130434783, 0.22222222222222
55952, 0.043478260869565, 1.3239130434783, 0.27777777777778
55953, 0.043478260869565, 1.3239130434783, 0.33333333333333
55954, 0.043478260869565, 1.3239130434783, 0.38888888888889
55955, 0.043478260869565, 1.3239130434783, 0.44444444444444
55956, 0.95652173913043, 1.425, 0.055555555555556
55957, 0.95652173913044, 1.425, 0.11111111111111
55958, 0.95652173913044, 1.425, 0.16666666666667
55959, 0.95652173913044, 1.425, 0.22222222222222
55960, 0.95652173913044, 1.425, 0.27777777777778
55961, 0.95652173913044, 1.425, 0.33333333333333
55962, 0.95652173913044, 1.425, 0.38888888888889
55963, 0.95652173913044, 1.425, 0.44444444444444
55964, 0.91304347826087, 1.425, 0.055555555555556
55965, 0.91304347826087, 1.425, 0.11111111111111
55966, 0.91304347826087, 1.425, 0.16666666666667
55967, 0.91304347826087, 1.425, 0.22222222222222
55968, 0.91304347826087, 1.425, 0.27777777777778
55969, 0.91304347826087, 1.425, 0.33333333333333
55970, 0.91304347826087, 1.425, 0.38888888888889
55971, 0.91304347826087, 1.425, 0.44444444444444
55972, 0.8695652173913, 1.425, 0.055555555555556
55973, 0.8695652173913, 1.425, 0.11111111111111
55974, 0.8695652173913, 1.425, 0.16666666666667
55975, 0.8695652173913, 1.425, 0.22222222222222
55976, 0.8695652173913, 1.425, 0.27777777777778
55977, 0.8695652173913, 1.425, 0.33333333333333
55978, 0.8695652173913, 1.425, 0.38888888888889
55979, 0.8695652173913, 1.425, 0.44444444444444
55980, 0.82608695652174, 1.425, 0.055555555555556
55981, 0.82608695652174, 1.425, 0.11111111111111
55982, 0.82608695652174, 1.425, 0.16666666666667
55983, 0.82608695652174, 1.425, 0.22222222222222
55984, 0.82608695652174, 1.425, 0.27777777777778
55985, 0.82608695652174, 1.425, 0.33333333333333
55986, 0.82608695652174, 1.425, 0.38888888888889
55987, 0.82608695652174, 1.425, 0.44444444444444
55988, 0.78260869565217, 1.425, 0.055555555555556
55989, 0.78260869565217, 1.425, 0.11111111111111
55990, 0.78260869565217, 1.425, 0.16666666666667
55991, 0.78260869565217, 1.425, 0.22222222222222
55992, 0.78260869565217, 1.425, 0.27777777777778
55993, 0.78260869565217, 1.425, 0.33333333333333
55994, 0.78260869565217, 1.425, 0.38888888888889
55995, 0.78260869565217, 1.425, 0.44444444444444
55996, 0.73913043478261, 1.425, 0.055555555555556
55997, 0.73913043478261, 1.425, 0.11111111111111
55998, 0.73913043478261, 1.425, 0.16666666666667
55999, 0.73913043478261, 1.425, 0.22222222222222
56000, 0.73913043478261, 1.425, 0.27777777777778
56001, 0.73913043478261, 1.425, 0.33333333333333
56002, 0.73913043478261, 1.425, 0.38888888888889
56003, 0.73913043478261, 1.425, 0.44444444444444
56004, 0.69565217391304, 1.425, 0.055555555555556
56005, 0.69565217391304, 1.425, 0.11111111111111
56006, 0.69565217391304, 1.425, 0.16666666666667
56007, 0.69565217391304, 1.425, 0.22222222222222
56008, 0.69565217391304, 1.425, 0.27777777777778
56009, 0.69565217391304, 1.425, 0.33333333333333
56010, 0.69565217391304, 1.425, 0.38888888888889
56011, 0.69565217391304, 1.425, 0.44444444444444
56012, 0.65217391304348, 1.425, 0.055555555555556
56013, 0.65217391304348, 1.425, 0.11111111111111
56014, 0.65217391304348, 1.425, 0.16666666666667
56015, 0.65217391304348, 1.425, 0.22222222222222
56016, 0.65217391304348, 1.425, 0.27777777777778
56017, 0.65217391304348, 1.425, 0.33333333333333
56018, 0.65217391304348, 1.425, 0.38888888888889
56019, 0.65217391304348, 1.425, 0.44444444444444
56020, 0.60869565217391, 1.425, 0.055555555555556
56021, 0.60869565217391, 1.425, 0.11111111111111
56022, 0.60869565217391, 1.425, 0.16666666666667
56023, 0.60869565217391, 1.425, 0.22222222222222
56024, 0.60869565217391, 1.425, 0.27777777777778
56025, 0.60869565217391, 1.425, 0.33333333333333
56026, 0.60869565217391, 1.425, 0.38888888888889
56027, 0.60869565217391, 1.425, 0.44444444444444
56028, 0.56521739130435, 1.425, 0.055555555555556
56029, 0.56521739130435, 1.425, 0.11111111111111
56030, 0.56521739130435, 1.425, 0.16666666666667
56031, 0.56521739130435, 1.425, 0.22222222222222
56032, 0.56521739130435, 1.425, 0.27777777777778
56033, 0.56521739130435, 1.425, 0.33333333333333
56034, 0.56521739130435, 1.425, 0.38888888888889
56035, 0.56521739130435, 1.425, 0.44444444444444
56036, 0.52173913043478, 1.425, 0.055555555555556
56037, 0.52173913043478, 1.425, 0.11111111111111
56038, 0.52173913043478, 1.425, 0.16666666666667
56039, 0.52173913043478, 1.425, 0.22222222222222
56040, 0.52173913043478, 1.425, 0.27777777777778
56041, 0.52173913043478, 1.425, 0.33333333333333
56042, 0.52173913043478, 1.425, 0.38888888888889
56043, 0.52173913043478, 1.425, 0.44444444444444
56044, 0.47826086956522, 1.425, 0.055555555555556
56045, 0.47826086956522, 1.425, 0.11111111111111
56046, 0.47826086956522, 1.425, 0.16666666666667
56047, 0.47826086956522, 1.425, 0.22222222222222
56048, 0.47826086956522, 1.425, 0.27777777777778
56049, 0.47826086956522, 1.425, 0.33333333333333
56050, 0.47826086956522, 1.425, 0.38888888888889
56051, 0.47826086956522, 1.425, 0.44444444444444
56052, 0.43478260869565, 1.425, 0.055555555555556
56053, 0.43478260869565, 1.425, 0.11111111111111
56054, 0.43478260869565, 1.425, 0.16666666666667
56055, 0.43478260869565, 1.425, 0.22222222222222
56056, 0.43478260869565, 1.425, 0.27777777777778
56057, 0.43478260869565, 1.425, 0.33333333333333
56058, 0.43478260869565, 1.425, 0.38888888888889
56059, 0.43478260869565, 1.425, 0.44444444444444
56060, 0.39130434782609, 1.425, 0.055555555555556
56061, 0.39130434782609, 1.425, 0.11111111111111
56062, 0.39130434782609, 1.425, 0.16666666666667
56063, 0.39130434782609, 1.425, 0.22222222222222
56064, 0.39130434782609, 1.425, 0.27777777777778
56065, 0.39130434782609, 1.425, 0.33333333333333
56066, 0.39130434782609, 1.425, 0.38888888888889
56067, 0.39130434782609, 1.425, 0.44444444444444
56068, 0.34782608695652, 1.425, 0.055555555555556
56069, 0.34782608695652, 1.425, 0.11111111111111
56070, 0.34782608695652, 1.425, 0.16666666666667
56071, 0.34782608695652, 1.425, 0.22222222222222
56072, 0.34782608695652, 1.425, 0.27777777777778
56073, 0.34782608695652, 1.425, 0.33333333333333
56074, 0.34782608695652, 1.425, 0.38888888888889
56075, 0.34782608695652, 1.425, 0.44444444444444
56076, 0.30434782608696, 1.425, 0.055555555555556
56077, 0.30434782608696, 1.425, 0.11111111111111
56078, 0.30434782608696, 1.425, 0.16666666666667
56079, 0.30434782608696, 1.425, 0.22222222222222
56080, 0.30434782608696, 1.425, 0.27777777777778
56081, 0.30434782608696, 1.425, 0.33333333333333
56082, 0.30434782608696, 1.425, 0.38888888888889
56083, 0.30434782608696, 1.425, 0.44444444444444
56084, 0.26086956521739, 1.425, 0.055555555555556
56085, 0.26086956521739, 1.425, 0.11111111111111
56086, 0.26086956521739, 1.425, 0.16666666666667
56087, 0.26086956521739, 1.425, 0.22222222222222
56088, 0.26086956521739, 1.425, 0.27777777777778
56089, 0.26086956521739, 1.425, 0.33333333333333
56090, 0.26086956521739, 1.425, 0.38888888888889
56091, 0.26086956521739, 1.425, 0.44444444444444
56092, 0.21739130434783, 1.425, 0.055555555555556
56093, 0.21739130434783, 1.425, 0.11111111111111
56094, 0.21739130434783, 1.425, 0.16666666666667
56095, 0.21739130434783, 1.425, 0.22222222222222
56096, 0.21739130434783, 1.425, 0.27777777777778
56097, 0.21739130434783, 1.425, 0.33333333333333
56098, 0.21739130434783, 1.425, 0.38888888888889
56099, 0.21739130434783, 1.425, 0.44444444444444
56100, 0.17391304347826, 1.425, 0.055555555555556
56101, 0.17391304347826, 1.425, 0.11111111111111
56102, 0.17391304347826, 1.425, 0.16666666666667
56103, 0.17391304347826, 1.425, 0.22222222222222
56104, 0.17391304347826, 1.425, 0.27777777777778
56105, 0.17391304347826, 1.425, 0.33333333333333
56106, 0.17391304347826, 1.425, 0.38888888888889
56107, 0.17391304347826, 1.425, 0.44444444444444
56108, 0.1304347826087, 1.425, 0.055555555555556
56109, 0.1304347826087, 1.425, 0.11111111111111
56110, 0.1304347826087, 1.425, 0.16666666666667
56111, 0.1304347826087, 1.425, 0.22222222222222
56112, 0.1304347826087, 1.425, 0.27777777777778
56113, 0.1304347826087, 1.425, 0.33333333333333
56114, 0.1304347826087, 1.425, 0.38888888888889
56115, 0.1304347826087, 1.425, 0.44444444444444
56116, 0.08695652173913, 1.425, 0.055555555555556
56117, 0.08695652173913, 1.425, 0.11111111111111
56118, 0.08695652173913, 1.425, 0.16666666666667
56119, 0.08695652173913, 1.425, 0.22222222222222
56120, 0.08695652173913, 1.425, 0.27777777777778
56121, 0.08695652173913, 1.425, 0.33333333333333
56122, 0.08695652173913, 1.425, 0.38888888888889
56123, 0.08695652173913, 1.425, 0.44444444444444
56124, 0.043478260869565, 1.425, 0.055555555555556
56125, 0.043478260869565, 1.425, 0.11111111111111
56126, 0.043478260869565, 1.425, 0.16666666666667
56127, 0.043478260869565, 1.425, 0.22222222222222
56128, 0.043478260869565, 1.425, 0.27777777777778
56129, 0.043478260869565, 1.425, 0.33333333333333
56130, 0.043478260869565, 1.425, 0.38888888888889
56131, 0.043478260869565, 1.425, 0.44444444444444
56132, 0.95652173913043, 1.425, 0.027777777777778
56133, 0.97826086956522, 1.425, 0.055555555555556
56134, 0.95652173913043, 1.4125, 0.055555555555556
56135, 0.95652173913043, 1.425, 0.083333333333333
56136, 0.97826086956522, 1.425, 0.11111111111111
56137, 0.95652173913044, 1.4125, 0.11111111111111
56138, 0.95652173913044, 1.425, 0.13888888888889
56139, 0.97826086956522, 1.425, 0.16666666666667
56140, 0.95652173913044, 1.4125, 0.16666666666667
56141, 0.95652173913044, 1.425, 0.19444444444444
56142, 0.97826086956522, 1.425, 0.22222222222222
56143, 0.95652173913043, 1.4125, 0.22222222222222
56144, 0.95652173913044, 1.425, 0.25
56145, 0.97826086956522, 1.425, 0.27777777777778
56146, 0.95652173913043, 1.4125, 0.27777777777778
56147, 0.95652173913044, 1.425, 0.30555555555556
56148, 0.97826086956522, 1.425, 0.33333333333333
56149, 0.95652173913043, 1.4125, 0.33333333333333
56150, 0.95652173913044, 1.425, 0.36111111111111
56151, 0.97826086956522, 1.425, 0.38888888888889
56152, 0.95652173913043, 1.4125, 0.38888888888889
56153, 0.95652173913044, 1.425, 0.41666666666667
56154, 0.97826086956522, 1.425, 0.44444444444444
56155, 0.95652173913043, 1.4125, 0.44444444444444
56156, 0.95652173913043, 1.425, 0.47222222222222
56157, 0.91304347826087, 1.425, 0.027777777777778
56158, 0.93478260869565, 1.425, 0.055555555555556
56159, 0.91304347826087, 1.4125, 0.055555555555556
56160, 0.91304347826087, 1.425, 0.083333333333333
56161, 0.93478260869565, 1.425, 0.11111111111111
56162, 0.91304347826087, 1.4125, 0.11111111111111
56163, 0.91304347826087, 1.425, 0.13888888888889
56164, 0.93478260869565, 1.425, 0.16666666666667
56165, 0.91304347826087, 1.4125, 0.16666666666667
56166, 0.91304347826087, 1.425, 0.19444444444444
56167, 0.93478260869565, 1.425, 0.22222222222222
56168, 0.91304347826087, 1.4125, 0.22222222222222
56169, 0.91304347826087, 1.425, 0.25
56170, 0.93478260869565, 1.425, 0.27777777777778
56171, 0.91304347826087, 1.4125, 0.27777777777778
56172, 0.91304347826087, 1.425, 0.30555555555556
56173, 0.93478260869565, 1.425, 0.33333333333333
56174, 0.91304347826087, 1.4125, 0.33333333333333
56175, 0.91304347826087, 1.425, 0.36111111111111
56176, 0.93478260869565, 1.425, 0.38888888888889
56177, 0.91304347826087, 1.4125, 0.38888888888889
56178, 0.91304347826087, 1.425, 0.41666666666667
56179, 0.93478260869565, 1.425, 0.44444444444444
56180, 0.91304347826087, 1.4125, 0.44444444444444
56181, 0.91304347826087, 1.425, 0.47222222222222
56182, 0.8695652173913, 1.425, 0.027777777777778
56183, 0.89130434782609, 1.425, 0.055555555555556
56184, 0.8695652173913, 1.4125, 0.055555555555556
56185, 0.8695652173913, 1.425, 0.083333333333333
56186, 0.89130434782609, 1.425, 0.11111111111111
56187, 0.8695652173913, 1.4125, 0.11111111111111
56188, 0.8695652173913, 1.425, 0.13888888888889
56189, 0.89130434782609, 1.425, 0.16666666666667
56190, 0.8695652173913, 1.4125, 0.16666666666667
56191, 0.8695652173913, 1.425, 0.19444444444444
56192, 0.89130434782609, 1.425, 0.22222222222222
56193, 0.8695652173913, 1.4125, 0.22222222222222
56194, 0.8695652173913, 1.425, 0.25
56195, 0.89130434782609, 1.425, 0.27777777777778
56196, 0.8695652173913, 1.4125, 0.27777777777778
56197, 0.8695652173913, 1.425, 0.30555555555556
56198, 0.89130434782609, 1.425, 0.33333333333333
56199, 0.8695652173913, 1.4125, 0.33333333333333
56200, 0.8695652173913, 1.425, 0.36111111111111
56201, 0.89130434782609, 1.425, 0.38888888888889
56202, 0.8695652173913, 1.4125, 0.38888888888889
56203, 0.8695652173913, 1.425, 0.41666666666667
56204, 0.89130434782609, 1.425, 0.44444444444444
56205, 0.8695652173913, 1.4125, 0.44444444444444
56206, 0.8695652173913, 1.425, 0.47222222222222
56207, 0.82608695652174, 1.425, 0.027777777777778
56208, 0.84782608695652, 1.425, 0.055555555555556
56209, 0.82608695652174, 1.4125, 0.055555555555556
56210, 0.82608695652174, 1.425, 0.083333333333333
56211, 0.84782608695652, 1.425, 0.11111111111111
56212, 0.82608695652174, 1.4125, 0.11111111111111
56213, 0.82608695652174, 1.425, 0.13888888888889
56214, 0.84782608695652, 1.425, 0.16666666666667
56215, 0.82608695652174, 1.4125, 0.16666666666667
56216, 0.82608695652174, 1.425, 0.19444444444444
56217, 0.84782608695652, 1.425, 0.22222222222222
56218, 0.82608695652174, 1.4125, 0.22222222222222
56219, 0.82608695652174, 1.425, 0.25
56220, 0.84782608695652, 1.425, 0.27777777777778
56221, 0.82608695652174, 1.4125, 0.27777777777778
56222, 0.82608695652174, 1.425, 0.30555555555556
56223, 0.84782608695652, 1.425, 0.33333333333333
56224, 0.82608695652174, 1.4125, 0.33333333333333
56225, 0.82608695652174, 1.425, 0.36111111111111
56226, 0.84782608695652, 1.425, 0.38888888888889
56227, 0.82608695652174, 1.4125, 0.38888888888889
56228, 0.82608695652174, 1.425, 0.41666666666667
56229, 0.84782608695652, 1.425, 0.44444444444444
56230, 0.82608695652174, 1.4125, 0.44444444444444
56231, 0.82608695652174, 1.425, 0.47222222222222
56232, 0.78260869565217, 1.425, 0.027777777777778
56233, 0.80434782608696, 1.425, 0.055555555555556
56234, 0.78260869565217, 1.4125, 0.055555555555556
56235, 0.78260869565217, 1.425, 0.083333333333333
56236, 0.80434782608696, 1.425, 0.11111111111111
56237, 0.78260869565217, 1.4125, 0.11111111111111
56238, 0.78260869565217, 1.425, 0.13888888888889
56239, 0.80434782608696, 1.425, 0.16666666666667
56240, 0.78260869565217, 1.4125, 0.16666666666667
56241, 0.78260869565217, 1.425, 0.19444444444444
56242, 0.80434782608696, 1.425, 0.22222222222222
56243, 0.78260869565217, 1.4125, 0.22222222222222
56244, 0.78260869565217, 1.425, 0.25
56245, 0.80434782608696, 1.425, 0.27777777777778
56246, 0.78260869565217, 1.4125, 0.27777777777778
56247, 0.78260869565217, 1.425, 0.30555555555556
56248, 0.80434782608696, 1.425, 0.33333333333333
56249, 0.78260869565217, 1.4125, 0.33333333333333
56250, 0.78260869565217, 1.425, 0.36111111111111
56251, 0.80434782608696, 1.425, 0.38888888888889
56252, 0.78260869565217, 1.4125, 0.38888888888889
56253, 0.78260869565217, 1.425, 0.41666666666667
56254, 0.80434782608696, 1.425, 0.44444444444444
56255, 0.78260869565217, 1.4125, 0.44444444444444
56256, 0.78260869565217, 1.425, 0.47222222222222
56257, 0.73913043478261, 1.425, 0.027777777777778
56258, 0.76086956521739, 1.425, 0.055555555555556
56259, 0.73913043478261, 1.4125, 0.055555555555556
56260, 0.73913043478261, 1.425, 0.083333333333333
56261, 0.76086956521739, 1.425, 0.11111111111111
56262, 0.73913043478261, 1.4125, 0.11111111111111
56263, 0.73913043478261, 1.425, 0.13888888888889
56264, 0.76086956521739, 1.425, 0.16666666666667
56265, 0.73913043478261, 1.4125, 0.16666666666667
56266, 0.73913043478261, 1.425, 0.19444444444444
56267, 0.76086956521739, 1.425, 0.22222222222222
56268, 0.73913043478261, 1.4125, 0.22222222222222
56269, 0.73913043478261, 1.425, 0.25
56270, 0.76086956521739, 1.425, 0.27777777777778
56271, 0.73913043478261, 1.4125, 0.27777777777778
56272, 0.73913043478261, 1.425, 0.30555555555556
56273, 0.76086956521739, 1.425, 0.33333333333333
56274, 0.73913043478261, 1.4125, 0.33333333333333
56275, 0.73913043478261, 1.425, 0.36111111111111
56276, 0.76086956521739, 1.425, 0.38888888888889
56277, 0.73913043478261, 1.4125, 0.38888888888889
56278, 0.73913043478261, 1.425, 0.41666666666667
56279, 0.76086956521739, 1.425, 0.44444444444444
56280, 0.73913043478261, 1.4125, 0.44444444444444
56281, 0.73913043478261, 1.425, 0.47222222222222
56282, 0.69565217391304, 1.425, 0.027777777777778
56283, 0.71739130434783, 1.425, 0.055555555555556
56284, 0.69565217391304, 1.4125, 0.055555555555556
56285, 0.69565217391304, 1.425, 0.083333333333333
56286, 0.71739130434783, 1.425, 0.11111111111111
56287, 0.69565217391304, 1.4125, 0.11111111111111
56288, 0.69565217391304, 1.425, 0.13888888888889
56289, 0.71739130434783, 1.425, 0.16666666666667
56290, 0.69565217391304, 1.4125, 0.16666666666667
56291, 0.69565217391304, 1.425, 0.19444444444444
56292, 0.71739130434783, 1.425, 0.22222222222222
56293, 0.69565217391304, 1.4125, 0.22222222222222
56294, 0.69565217391304, 1.425, 0.25
56295, 0.71739130434783, 1.425, 0.27777777777778
56296, 0.69565217391304, 1.4125, 0.27777777777778
56297, 0.69565217391304, 1.425, 0.30555555555556
56298, 0.71739130434783, 1.425, 0.33333333333333
56299, 0.69565217391304, 1.4125, 0.33333333333333
56300, 0.69565217391304, 1.425, 0.36111111111111
56301, 0.71739130434783, 1.425, 0.38888888888889
56302, 0.69565217391304, 1.4125, 0.38888888888889
56303, 0.69565217391304, 1.425, 0.41666666666667
56304, 0.71739130434783, 1.425, 0.44444444444444
56305, 0.69565217391304, 1.4125, 0.44444444444444
56306, 0.69565217391304, 1.425, 0.47222222222222
56307, 0.65217391304348, 1.425, 0.027777777777778
56308, 0.67391304347826, 1.425, 0.055555555555556
56309, 0.65217391304348, 1.4125, 0.055555555555556
56310, 0.65217391304348, 1.425, 0.083333333333333
56311, 0.67391304347826, 1.425, 0.11111111111111
56312, 0.65217391304348, 1.4125, 0.11111111111111
56313, 0.65217391304348, 1.425, 0.13888888888889
56314, 0.67391304347826, 1.425, 0.16666666666667
56315, 0.65217391304348, 1.4125, 0.16666666666667
56316, 0.65217391304348, 1.425, 0.19444444444444
56317, 0.67391304347826, 1.425, 0.22222222222222
56318, 0.65217391304348, 1.4125, 0.22222222222222
56319, 0.65217391304348, 1.425, 0.25
56320, 0.67391304347826, 1.425, 0.27777777777778
56321, 0.65217391304348, 1.4125, 0.27777777777778
56322, 0.65217391304348, 1.425, 0.30555555555556
56323, 0.67391304347826, 1.425, 0.33333333333333
56324, 0.65217391304348, 1.4125, 0.33333333333333
56325, 0.65217391304348, 1.425, 0.36111111111111
56326, 0.67391304347826, 1.425, 0.38888888888889
56327, 0.65217391304348, 1.4125, 0.38888888888889
56328, 0.65217391304348, 1.425, 0.41666666666667
56329, 0.67391304347826, 1.425, 0.44444444444444
56330, 0.65217391304348, 1.4125, 0.44444444444444
56331, 0.65217391304348, 1.425, 0.47222222222222
56332, 0.60869565217391, 1.425, 0.027777777777778
56333, 0.6304347826087, 1.425, 0.055555555555556
56334, 0.60869565217391, 1.4125, 0.055555555555556
56335, 0.60869565217391, 1.425, 0.083333333333333
56336, 0.6304347826087, 1.425, 0.11111111111111
56337, 0.60869565217391, 1.4125, 0.11111111111111
56338, 0.60869565217391, 1.425, 0.13888888888889
56339, 0.6304347826087, 1.425, 0.16666666666667
56340, 0.60869565217391, 1.4125, 0.16666666666667
56341, 0.60869565217391, 1.425, 0.19444444444444
56342, 0.6304347826087, 1.425, 0.22222222222222
56343, 0.60869565217391, 1.4125, 0.22222222222222
56344, 0.60869565217391, 1.425, 0.25
56345, 0.6304347826087, 1.425, 0.27777777777778
56346, 0.60869565217391, 1.4125, 0.27777777777778
56347, 0.60869565217391, 1.425, 0.30555555555556
56348, 0.6304347826087, 1.425, 0.33333333333333
56349, 0.60869565217391, 1.4125, 0.33333333333333
56350, 0.60869565217391, 1.425, 0.36111111111111
56351, 0.6304347826087, 1.425, 0.38888888888889
56352, 0.60869565217391, 1.4125, 0.38888888888889
56353, 0.60869565217391, 1.425, 0.41666666666667
56354, 0.6304347826087, 1.425, 0.44444444444444
56355, 0.60869565217391, 1.4125, 0.44444444444444
56356, 0.60869565217391, 1.425, 0.47222222222222
56357, 0.56521739130435, 1.425, 0.027777777777778
56358, 0.58695652173913, 1.425, 0.055555555555556
56359, 0.56521739130435, 1.4125, 0.055555555555556
56360, 0.56521739130435, 1.425, 0.083333333333333
56361, 0.58695652173913, 1.425, 0.11111111111111
56362, 0.56521739130435, 1.4125, 0.11111111111111
56363, 0.56521739130435, 1.425, 0.13888888888889
56364, 0.58695652173913, 1.425, 0.16666666666667
56365, 0.56521739130435, 1.4125, 0.16666666666667
56366, 0.56521739130435, 1.425, 0.19444444444444
56367, 0.58695652173913, 1.425, 0.22222222222222
56368, 0.56521739130435, 1.4125, 0.22222222222222
56369, 0.56521739130435, 1.425, 0.25
56370, 0.58695652173913, 1.425, 0.27777777777778
56371, 0.56521739130435, 1.4125, 0.27777777777778
56372, 0.56521739130435, 1.425, 0.30555555555556
56373, 0.58695652173913, 1.425, 0.33333333333333
56374, 0.56521739130435, 1.4125, 0.33333333333333
56375, 0.56521739130435, 1.425, 0.36111111111111
56376, 0.58695652173913, 1.425, 0.38888888888889
56377, 0.56521739130435, 1.4125, 0.38888888888889
56378, 0.56521739130435, 1.425, 0.41666666666667
56379, 0.58695652173913, 1.425, 0.44444444444444
56380, 0.56521739130435, 1.4125, 0.44444444444444
56381, 0.56521739130435, 1.425, 0.47222222222222
56382, 0.52173913043478, 1.425, 0.027777777777778
56383, 0.54347826086957, 1.425, 0.055555555555556
56384, 0.52173913043478, 1.4125, 0.055555555555556
56385, 0.52173913043478, 1.425, 0.083333333333333
56386, 0.54347826086957, 1.425, 0.11111111111111
56387, 0.52173913043478, 1.4125, 0.11111111111111
56388, 0.52173913043478, 1.425, 0.13888888888889
56389, 0.54347826086957, 1.425, 0.16666666666667
56390, 0.52173913043478, 1.4125, 0.16666666666667
56391, 0.52173913043478, 1.425, 0.19444444444444
56392, 0.54347826086956, 1.425, 0.22222222222222
56393, 0.52173913043478, 1.4125, 0.22222222222222
56394, 0.52173913043478, 1.425, 0.25
56395, 0.54347826086956, 1.425, 0.27777777777778
56396, 0.52173913043478, 1.4125, 0.27777777777778
56397, 0.52173913043478, 1.425, 0.30555555555556
56398, 0.54347826086956, 1.425, 0.33333333333333
56399, 0.52173913043478, 1.4125, 0.33333333333333
56400, 0.52173913043478, 1.425, 0.36111111111111
56401, 0.54347826086956, 1.425, 0.38888888888889
56402, 0.52173913043478, 1.4125, 0.38888888888889
56403, 0.52173913043478, 1.425, 0.41666666666667
56404, 0.54347826086956, 1.425, 0.44444444444444
56405, 0.52173913043478, 1.4125, 0.44444444444444
56406, 0.52173913043478, 1.425, 0.47222222222222
56407, 0.47826086956522, 1.425, 0.027777777777778
56408, 0.5, 1.425, 0.055555555555556
56409, 0.47826086956522, 1.4125, 0.055555555555556
56410, 0.47826086956522, 1.425, 0.083333333333333
56411, 0.5, 1.425, 0.11111111111111
56412, 0.47826086956522, 1.4125, 0.11111111111111
56413, 0.47826086956522, 1.425, 0.13888888888889
56414, 0.5, 1.425, 0.16666666666667
56415, 0.47826086956522, 1.4125, 0.16666666666667
56416, 0.47826086956522, 1.425, 0.19444444444444
56417, 0.5, 1.425, 0.22222222222222
56418, 0.47826086956522, 1.4125, 0.22222222222222
56419, 0.47826086956522, 1.425, 0.25
56420, 0.5, 1.425, 0.27777777777778
56421, 0.47826086956522, 1.4125, 0.27777777777778
56422, 0.47826086956522, 1.425, 0.30555555555556
56423, 0.5, 1.425, 0.33333333333333
56424, 0.47826086956522, 1.4125, 0.33333333333333
56425, 0.47826086956522, 1.425, 0.36111111111111
56426, 0.5, 1.425, 0.38888888888889
56427, 0.47826086956522, 1.4125, 0.38888888888889
56428, 0.47826086956522, 1.425, 0.41666666666667
56429, 0.5, 1.425, 0.44444444444444
56430, 0.47826086956522, 1.4125, 0.44444444444444
56431, 0.47826086956522, 1.425, 0.47222222222222
56432, 0.43478260869565, 1.425, 0.027777777777778
56433, 0.45652173913043, 1.425, 0.055555555555556
56434, 0.43478260869565, 1.4125, 0.055555555555556
56435, 0.43478260869565, 1.425, 0.083333333333333
56436, 0.45652173913043, 1.425, 0.11111111111111
56437, 0.43478260869565, 1.4125, 0.11111111111111
56438, 0.43478260869565, 1.425, 0.13888888888889
56439, 0.45652173913043, 1.425, 0.16666666666667
56440, 0.43478260869565, 1.4125, 0.16666666666667
56441, 0.43478260869565, 1.425, 0.19444444444444
56442, 0.45652173913043, 1.425, 0.22222222222222
56443, 0.43478260869565, 1.4125, 0.22222222222222
56444, 0.43478260869565, 1.425, 0.25
56445, 0.45652173913043, 1.425, 0.27777777777778
56446, 0.43478260869565, 1.4125, 0.27777777777778
56447, 0.43478260869565, 1.425, 0.30555555555556
56448, 0.45652173913043, 1.425, 0.33333333333333
56449, 0.43478260869565, 1.4125, 0.33333333333333
56450, 0.43478260869565, 1.425, 0.36111111111111
56451, 0.45652173913044, 1.425, 0.38888888888889
56452, 0.43478260869565, 1.4125, 0.38888888888889
56453, 0.43478260869565, 1.425, 0.41666666666667
56454, 0.45652173913043, 1.425, 0.44444444444444
56455, 0.43478260869565, 1.4125, 0.44444444444444
56456, 0.43478260869565, 1.425, 0.47222222222222
56457, 0.39130434782609, 1.425, 0.027777777777778
56458, 0.41304347826087, 1.425, 0.055555555555556
56459, 0.39130434782609, 1.4125, 0.055555555555556
56460, 0.39130434782609, 1.425, 0.083333333333333
56461, 0.41304347826087, 1.425, 0.11111111111111
56462, 0.39130434782609, 1.4125, 0.11111111111111
56463, 0.39130434782609, 1.425, 0.13888888888889
56464, 0.41304347826087, 1.425, 0.16666666666667
56465, 0.39130434782609, 1.4125, 0.16666666666667
56466, 0.39130434782609, 1.425, 0.19444444444444
56467, 0.41304347826087, 1.425, 0.22222222222222
56468, 0.39130434782609, 1.4125, 0.22222222222222
56469, 0.39130434782609, 1.425, 0.25
56470, 0.41304347826087, 1.425, 0.27777777777778
56471, 0.39130434782609, 1.4125, 0.27777777777778
56472, 0.39130434782609, 1.425, 0.30555555555556
56473, 0.41304347826087, 1.425, 0.33333333333333
56474, 0.39130434782609, 1.4125, 0.33333333333333
56475, 0.39130434782609, 1.425, 0.36111111111111
56476, 0.41304347826087, 1.425, 0.38888888888889
56477, 0.39130434782609, 1.4125, 0.38888888888889
56478, 0.39130434782609, 1.425, 0.41666666666667
56479, 0.41304347826087, 1.425, 0.44444444444444
56480, 0.39130434782609, 1.4125, 0.44444444444444
56481, 0.39130434782609, 1.425, 0.47222222222222
56482, 0.34782608695652, 1.425, 0.027777777777778
56483, 0.3695652173913, 1.425, 0.055555555555556
56484, 0.34782608695652, 1.4125, 0.055555555555556
56485, 0.34782608695652, 1.425, 0.083333333333333
56486, 0.3695652173913, 1.425, 0.11111111111111
56487, 0.34782608695652, 1.4125, 0.11111111111111
56488, 0.34782608695652, 1.425, 0.13888888888889
56489, 0.3695652173913, 1.425, 0.16666666666667
56490, 0.34782608695652, 1.4125, 0.16666666666667
