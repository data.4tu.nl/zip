74056, 2.1130434782609, 0.51521739130435, 0.25
74057, 2.0913043478261, 0.51521739130435, 0.22222222222222
74058, 2.1130434782609, 0.54130434782609, 0.22222222222222
74059, 2.1130434782609, 0.51521739130435, 0.19444444444444
74060, 2.0913043478261, 0.51521739130435, 0.16666666666667
74061, 2.1130434782609, 0.54130434782609, 0.16666666666667
74062, 2.1130434782609, 0.51521739130435, 0.13888888888889
74063, 2.0913043478261, 0.51521739130435, 0.11111111111111
74064, 2.1130434782609, 0.54130434782609, 0.11111111111111
74065, 2.1130434782609, 0.51521739130435, 0.083333333333333
74066, 2.0913043478261, 0.51521739130435, 0.055555555555556
74067, 2.1130434782609, 0.54130434782609, 0.055555555555556
74068, 2.1130434782609, 0.51521739130435, 0.027777777777778
74069, 2.1565217391304, 0.51521739130435, 0.47222222222222
74070, 2.1347826086957, 0.51521739130435, 0.44444444444444
74071, 2.1565217391304, 0.54130434782609, 0.44444444444444
74072, 2.1565217391304, 0.51521739130435, 0.41666666666667
74073, 2.1347826086957, 0.51521739130435, 0.38888888888889
74074, 2.1565217391304, 0.54130434782609, 0.38888888888889
74075, 2.1565217391304, 0.51521739130435, 0.36111111111111
74076, 2.1347826086957, 0.51521739130435, 0.33333333333333
74077, 2.1565217391304, 0.54130434782609, 0.33333333333333
74078, 2.1565217391304, 0.51521739130435, 0.30555555555556
74079, 2.1347826086957, 0.51521739130435, 0.27777777777778
74080, 2.1565217391304, 0.54130434782609, 0.27777777777778
74081, 2.1565217391304, 0.51521739130435, 0.25
74082, 2.1347826086957, 0.51521739130435, 0.22222222222222
74083, 2.1565217391304, 0.54130434782609, 0.22222222222222
74084, 2.1565217391304, 0.51521739130435, 0.19444444444444
74085, 2.1347826086957, 0.51521739130435, 0.16666666666667
74086, 2.1565217391304, 0.54130434782609, 0.16666666666667
74087, 2.1565217391304, 0.51521739130435, 0.13888888888889
74088, 2.1347826086957, 0.51521739130435, 0.11111111111111
74089, 2.1565217391304, 0.54130434782609, 0.11111111111111
74090, 2.1565217391304, 0.51521739130435, 0.083333333333333
74091, 2.1347826086957, 0.51521739130435, 0.055555555555556
74092, 2.1565217391304, 0.54130434782609, 0.055555555555556
74093, 2.1565217391304, 0.51521739130435, 0.027777777777778
74094, 2.1782608695652, 0.51521739130435, 0.44444444444444
74095, 2.1782608695652, 0.51521739130435, 0.38888888888889
74096, 2.1782608695652, 0.51521739130435, 0.33333333333333
74097, 2.1782608695652, 0.51521739130435, 0.27777777777778
74098, 2.1782608695652, 0.51521739130435, 0.22222222222222
74099, 2.1782608695652, 0.51521739130435, 0.16666666666667
74100, 2.1782608695652, 0.51521739130435, 0.11111111111111
74101, 2.1782608695652, 0.51521739130435, 0.055555555555556
74102, 1.2434782608696, 0.46304347826087, 0.47222222222222
74103, 1.2217391304348, 0.46304347826087, 0.44444444444444
74104, 1.2434782608696, 0.48913043478261, 0.44444444444444
74105, 1.2434782608696, 0.46304347826087, 0.41666666666667
74106, 1.2217391304348, 0.46304347826087, 0.38888888888889
74107, 1.2434782608696, 0.48913043478261, 0.38888888888889
74108, 1.2434782608696, 0.46304347826087, 0.36111111111111
74109, 1.2217391304348, 0.46304347826087, 0.33333333333333
74110, 1.2434782608696, 0.48913043478261, 0.33333333333333
74111, 1.2434782608696, 0.46304347826087, 0.30555555555556
74112, 1.2217391304348, 0.46304347826087, 0.27777777777778
74113, 1.2434782608696, 0.48913043478261, 0.27777777777778
74114, 1.2434782608696, 0.46304347826087, 0.25
74115, 1.2217391304348, 0.46304347826087, 0.22222222222222
74116, 1.2434782608696, 0.48913043478261, 0.22222222222222
74117, 1.2434782608696, 0.46304347826087, 0.19444444444444
74118, 1.2217391304348, 0.46304347826087, 0.16666666666667
74119, 1.2434782608696, 0.48913043478261, 0.16666666666667
74120, 1.2434782608696, 0.46304347826087, 0.13888888888889
74121, 1.2217391304348, 0.46304347826087, 0.11111111111111
74122, 1.2434782608696, 0.48913043478261, 0.11111111111111
74123, 1.2434782608696, 0.46304347826087, 0.083333333333333
74124, 1.2217391304348, 0.46304347826087, 0.055555555555556
74125, 1.2434782608696, 0.48913043478261, 0.055555555555556
74126, 1.2434782608696, 0.46304347826087, 0.027777777777778
74127, 1.2869565217391, 0.46304347826087, 0.47222222222222
74128, 1.2652173913043, 0.46304347826087, 0.44444444444444
74129, 1.2869565217391, 0.48913043478261, 0.44444444444444
74130, 1.2869565217391, 0.46304347826087, 0.41666666666667
74131, 1.2652173913043, 0.46304347826087, 0.38888888888889
74132, 1.2869565217391, 0.48913043478261, 0.38888888888889
74133, 1.2869565217391, 0.46304347826087, 0.36111111111111
74134, 1.2652173913043, 0.46304347826087, 0.33333333333333
74135, 1.2869565217391, 0.48913043478261, 0.33333333333333
74136, 1.2869565217391, 0.46304347826087, 0.30555555555556
74137, 1.2652173913043, 0.46304347826087, 0.27777777777778
74138, 1.2869565217391, 0.48913043478261, 0.27777777777778
74139, 1.2869565217391, 0.46304347826087, 0.25
74140, 1.2652173913043, 0.46304347826087, 0.22222222222222
74141, 1.2869565217391, 0.48913043478261, 0.22222222222222
74142, 1.2869565217391, 0.46304347826087, 0.19444444444444
74143, 1.2652173913043, 0.46304347826087, 0.16666666666667
74144, 1.2869565217391, 0.48913043478261, 0.16666666666667
74145, 1.2869565217391, 0.46304347826087, 0.13888888888889
74146, 1.2652173913043, 0.46304347826087, 0.11111111111111
74147, 1.2869565217391, 0.48913043478261, 0.11111111111111
74148, 1.2869565217391, 0.46304347826087, 0.083333333333333
74149, 1.2652173913043, 0.46304347826087, 0.055555555555556
74150, 1.2869565217391, 0.48913043478261, 0.055555555555556
74151, 1.2869565217391, 0.46304347826087, 0.027777777777778
74152, 1.3304347826087, 0.46304347826087, 0.47222222222222
74153, 1.3086956521739, 0.46304347826087, 0.44444444444444
74154, 1.3304347826087, 0.48913043478261, 0.44444444444444
74155, 1.3304347826087, 0.46304347826087, 0.41666666666667
74156, 1.3086956521739, 0.46304347826087, 0.38888888888889
74157, 1.3304347826087, 0.48913043478261, 0.38888888888889
74158, 1.3304347826087, 0.46304347826087, 0.36111111111111
74159, 1.3086956521739, 0.46304347826087, 0.33333333333333
74160, 1.3304347826087, 0.48913043478261, 0.33333333333333
74161, 1.3304347826087, 0.46304347826087, 0.30555555555556
74162, 1.3086956521739, 0.46304347826087, 0.27777777777778
74163, 1.3304347826087, 0.48913043478261, 0.27777777777778
74164, 1.3304347826087, 0.46304347826087, 0.25
74165, 1.3086956521739, 0.46304347826087, 0.22222222222222
74166, 1.3304347826087, 0.48913043478261, 0.22222222222222
74167, 1.3304347826087, 0.46304347826087, 0.19444444444444
74168, 1.3086956521739, 0.46304347826087, 0.16666666666667
74169, 1.3304347826087, 0.48913043478261, 0.16666666666667
74170, 1.3304347826087, 0.46304347826087, 0.13888888888889
74171, 1.3086956521739, 0.46304347826087, 0.11111111111111
74172, 1.3304347826087, 0.48913043478261, 0.11111111111111
74173, 1.3304347826087, 0.46304347826087, 0.083333333333333
74174, 1.3086956521739, 0.46304347826087, 0.055555555555556
74175, 1.3304347826087, 0.48913043478261, 0.055555555555556
74176, 1.3304347826087, 0.46304347826087, 0.027777777777778
74177, 1.3739130434783, 0.46304347826087, 0.47222222222222
74178, 1.3521739130435, 0.46304347826087, 0.44444444444444
74179, 1.3739130434783, 0.48913043478261, 0.44444444444444
74180, 1.3739130434783, 0.46304347826087, 0.41666666666667
74181, 1.3521739130435, 0.46304347826087, 0.38888888888889
74182, 1.3739130434783, 0.48913043478261, 0.38888888888889
74183, 1.3739130434783, 0.46304347826087, 0.36111111111111
74184, 1.3521739130435, 0.46304347826087, 0.33333333333333
74185, 1.3739130434783, 0.48913043478261, 0.33333333333333
74186, 1.3739130434783, 0.46304347826087, 0.30555555555556
74187, 1.3521739130435, 0.46304347826087, 0.27777777777778
74188, 1.3739130434783, 0.48913043478261, 0.27777777777778
74189, 1.3739130434783, 0.46304347826087, 0.25
74190, 1.3521739130435, 0.46304347826087, 0.22222222222222
74191, 1.3739130434783, 0.48913043478261, 0.22222222222222
74192, 1.3739130434783, 0.46304347826087, 0.19444444444444
74193, 1.3521739130435, 0.46304347826087, 0.16666666666667
74194, 1.3739130434783, 0.48913043478261, 0.16666666666667
74195, 1.3739130434783, 0.46304347826087, 0.13888888888889
74196, 1.3521739130435, 0.46304347826087, 0.11111111111111
74197, 1.3739130434783, 0.48913043478261, 0.11111111111111
74198, 1.3739130434783, 0.46304347826087, 0.083333333333333
74199, 1.3521739130435, 0.46304347826087, 0.055555555555556
74200, 1.3739130434783, 0.48913043478261, 0.055555555555556
74201, 1.3739130434783, 0.46304347826087, 0.027777777777778
74202, 1.4173913043478, 0.46304347826087, 0.47222222222222
74203, 1.395652173913, 0.46304347826087, 0.44444444444444
74204, 1.4173913043478, 0.48913043478261, 0.44444444444444
74205, 1.4173913043478, 0.46304347826087, 0.41666666666667
74206, 1.395652173913, 0.46304347826087, 0.38888888888889
74207, 1.4173913043478, 0.48913043478261, 0.38888888888889
74208, 1.4173913043478, 0.46304347826087, 0.36111111111111
74209, 1.395652173913, 0.46304347826087, 0.33333333333333
74210, 1.4173913043478, 0.48913043478261, 0.33333333333333
74211, 1.4173913043478, 0.46304347826087, 0.30555555555556
74212, 1.395652173913, 0.46304347826087, 0.27777777777778
74213, 1.4173913043478, 0.48913043478261, 0.27777777777778
74214, 1.4173913043478, 0.46304347826087, 0.25
74215, 1.395652173913, 0.46304347826087, 0.22222222222222
74216, 1.4173913043478, 0.48913043478261, 0.22222222222222
74217, 1.4173913043478, 0.46304347826087, 0.19444444444444
74218, 1.395652173913, 0.46304347826087, 0.16666666666667
74219, 1.4173913043478, 0.48913043478261, 0.16666666666667
74220, 1.4173913043478, 0.46304347826087, 0.13888888888889
74221, 1.395652173913, 0.46304347826087, 0.11111111111111
74222, 1.4173913043478, 0.48913043478261, 0.11111111111111
74223, 1.4173913043478, 0.46304347826087, 0.083333333333333
74224, 1.395652173913, 0.46304347826087, 0.055555555555556
74225, 1.4173913043478, 0.48913043478261, 0.055555555555556
74226, 1.4173913043478, 0.46304347826087, 0.027777777777778
74227, 1.4608695652174, 0.46304347826087, 0.47222222222222
74228, 1.4391304347826, 0.46304347826087, 0.44444444444444
74229, 1.4608695652174, 0.48913043478261, 0.44444444444444
74230, 1.4608695652174, 0.46304347826087, 0.41666666666667
74231, 1.4391304347826, 0.46304347826087, 0.38888888888889
74232, 1.4608695652174, 0.48913043478261, 0.38888888888889
74233, 1.4608695652174, 0.46304347826087, 0.36111111111111
74234, 1.4391304347826, 0.46304347826087, 0.33333333333333
74235, 1.4608695652174, 0.48913043478261, 0.33333333333333
74236, 1.4608695652174, 0.46304347826087, 0.30555555555556
74237, 1.4391304347826, 0.46304347826087, 0.27777777777778
74238, 1.4608695652174, 0.48913043478261, 0.27777777777778
74239, 1.4608695652174, 0.46304347826087, 0.25
74240, 1.4391304347826, 0.46304347826087, 0.22222222222222
74241, 1.4608695652174, 0.48913043478261, 0.22222222222222
74242, 1.4608695652174, 0.46304347826087, 0.19444444444444
74243, 1.4391304347826, 0.46304347826087, 0.16666666666667
74244, 1.4608695652174, 0.48913043478261, 0.16666666666667
74245, 1.4608695652174, 0.46304347826087, 0.13888888888889
74246, 1.4391304347826, 0.46304347826087, 0.11111111111111
74247, 1.4608695652174, 0.48913043478261, 0.11111111111111
74248, 1.4608695652174, 0.46304347826087, 0.083333333333333
74249, 1.4391304347826, 0.46304347826087, 0.055555555555556
74250, 1.4608695652174, 0.48913043478261, 0.055555555555556
74251, 1.4608695652174, 0.46304347826087, 0.027777777777778
74252, 1.504347826087, 0.46304347826087, 0.47222222222222
74253, 1.4826086956522, 0.46304347826087, 0.44444444444444
74254, 1.504347826087, 0.48913043478261, 0.44444444444444
74255, 1.504347826087, 0.46304347826087, 0.41666666666667
74256, 1.4826086956522, 0.46304347826087, 0.38888888888889
74257, 1.504347826087, 0.48913043478261, 0.38888888888889
74258, 1.504347826087, 0.46304347826087, 0.36111111111111
74259, 1.4826086956522, 0.46304347826087, 0.33333333333333
74260, 1.504347826087, 0.48913043478261, 0.33333333333333
74261, 1.504347826087, 0.46304347826087, 0.30555555555556
74262, 1.4826086956522, 0.46304347826087, 0.27777777777778
74263, 1.504347826087, 0.48913043478261, 0.27777777777778
74264, 1.504347826087, 0.46304347826087, 0.25
74265, 1.4826086956522, 0.46304347826087, 0.22222222222222
74266, 1.504347826087, 0.48913043478261, 0.22222222222222
74267, 1.504347826087, 0.46304347826087, 0.19444444444444
74268, 1.4826086956522, 0.46304347826087, 0.16666666666667
74269, 1.504347826087, 0.48913043478261, 0.16666666666667
74270, 1.504347826087, 0.46304347826087, 0.13888888888889
74271, 1.4826086956522, 0.46304347826087, 0.11111111111111
74272, 1.504347826087, 0.48913043478261, 0.11111111111111
74273, 1.504347826087, 0.46304347826087, 0.083333333333333
74274, 1.4826086956522, 0.46304347826087, 0.055555555555556
74275, 1.504347826087, 0.48913043478261, 0.055555555555556
74276, 1.504347826087, 0.46304347826087, 0.027777777777778
74277, 1.5478260869565, 0.46304347826087, 0.47222222222222
74278, 1.5260869565217, 0.46304347826087, 0.44444444444444
74279, 1.5478260869565, 0.48913043478261, 0.44444444444444
74280, 1.5478260869565, 0.46304347826087, 0.41666666666667
74281, 1.5260869565217, 0.46304347826087, 0.38888888888889
74282, 1.5478260869565, 0.48913043478261, 0.38888888888889
74283, 1.5478260869565, 0.46304347826087, 0.36111111111111
74284, 1.5260869565217, 0.46304347826087, 0.33333333333333
74285, 1.5478260869565, 0.48913043478261, 0.33333333333333
74286, 1.5478260869565, 0.46304347826087, 0.30555555555556
74287, 1.5260869565217, 0.46304347826087, 0.27777777777778
74288, 1.5478260869565, 0.48913043478261, 0.27777777777778
74289, 1.5478260869565, 0.46304347826087, 0.25
74290, 1.5260869565217, 0.46304347826087, 0.22222222222222
74291, 1.5478260869565, 0.48913043478261, 0.22222222222222
74292, 1.5478260869565, 0.46304347826087, 0.19444444444444
74293, 1.5260869565217, 0.46304347826087, 0.16666666666667
74294, 1.5478260869565, 0.48913043478261, 0.16666666666667
74295, 1.5478260869565, 0.46304347826087, 0.13888888888889
74296, 1.5260869565217, 0.46304347826087, 0.11111111111111
74297, 1.5478260869565, 0.48913043478261, 0.11111111111111
74298, 1.5478260869565, 0.46304347826087, 0.083333333333333
74299, 1.5260869565217, 0.46304347826087, 0.055555555555556
74300, 1.5478260869565, 0.48913043478261, 0.055555555555556
74301, 1.5478260869565, 0.46304347826087, 0.027777777777778
74302, 1.5913043478261, 0.46304347826087, 0.47222222222222
74303, 1.5695652173913, 0.46304347826087, 0.44444444444444
74304, 1.5913043478261, 0.48913043478261, 0.44444444444444
74305, 1.5913043478261, 0.46304347826087, 0.41666666666667
74306, 1.5695652173913, 0.46304347826087, 0.38888888888889
74307, 1.5913043478261, 0.48913043478261, 0.38888888888889
74308, 1.5913043478261, 0.46304347826087, 0.36111111111111
74309, 1.5695652173913, 0.46304347826087, 0.33333333333333
74310, 1.5913043478261, 0.48913043478261, 0.33333333333333
74311, 1.5913043478261, 0.46304347826087, 0.30555555555556
74312, 1.5695652173913, 0.46304347826087, 0.27777777777778
74313, 1.5913043478261, 0.48913043478261, 0.27777777777778
74314, 1.5913043478261, 0.46304347826087, 0.25
74315, 1.5695652173913, 0.46304347826087, 0.22222222222222
74316, 1.5913043478261, 0.48913043478261, 0.22222222222222
74317, 1.5913043478261, 0.46304347826087, 0.19444444444444
74318, 1.5695652173913, 0.46304347826087, 0.16666666666667
74319, 1.5913043478261, 0.48913043478261, 0.16666666666667
74320, 1.5913043478261, 0.46304347826087, 0.13888888888889
74321, 1.5695652173913, 0.46304347826087, 0.11111111111111
74322, 1.5913043478261, 0.48913043478261, 0.11111111111111
74323, 1.5913043478261, 0.46304347826087, 0.083333333333333
74324, 1.5695652173913, 0.46304347826087, 0.055555555555556
74325, 1.5913043478261, 0.48913043478261, 0.055555555555556
74326, 1.5913043478261, 0.46304347826087, 0.027777777777778
74327, 1.6347826086957, 0.46304347826087, 0.47222222222222
74328, 1.6130434782609, 0.46304347826087, 0.44444444444444
74329, 1.6347826086957, 0.48913043478261, 0.44444444444444
74330, 1.6347826086957, 0.46304347826087, 0.41666666666667
74331, 1.6130434782609, 0.46304347826087, 0.38888888888889
74332, 1.6347826086957, 0.48913043478261, 0.38888888888889
74333, 1.6347826086957, 0.46304347826087, 0.36111111111111
74334, 1.6130434782609, 0.46304347826087, 0.33333333333333
74335, 1.6347826086957, 0.48913043478261, 0.33333333333333
74336, 1.6347826086957, 0.46304347826087, 0.30555555555556
74337, 1.6130434782609, 0.46304347826087, 0.27777777777778
74338, 1.6347826086957, 0.48913043478261, 0.27777777777778
74339, 1.6347826086957, 0.46304347826087, 0.25
74340, 1.6130434782609, 0.46304347826087, 0.22222222222222
74341, 1.6347826086957, 0.48913043478261, 0.22222222222222
74342, 1.6347826086957, 0.46304347826087, 0.19444444444444
74343, 1.6130434782609, 0.46304347826087, 0.16666666666667
74344, 1.6347826086957, 0.48913043478261, 0.16666666666667
74345, 1.6347826086957, 0.46304347826087, 0.13888888888889
74346, 1.6130434782609, 0.46304347826087, 0.11111111111111
74347, 1.6347826086957, 0.48913043478261, 0.11111111111111
74348, 1.6347826086957, 0.46304347826087, 0.083333333333333
74349, 1.6130434782609, 0.46304347826087, 0.055555555555556
74350, 1.6347826086957, 0.48913043478261, 0.055555555555556
74351, 1.6347826086957, 0.46304347826087, 0.027777777777778
74352, 1.6782608695652, 0.46304347826087, 0.47222222222222
74353, 1.6565217391304, 0.46304347826087, 0.44444444444444
74354, 1.6782608695652, 0.48913043478261, 0.44444444444444
74355, 1.6782608695652, 0.46304347826087, 0.41666666666667
74356, 1.6565217391304, 0.46304347826087, 0.38888888888889
74357, 1.6782608695652, 0.48913043478261, 0.38888888888889
74358, 1.6782608695652, 0.46304347826087, 0.36111111111111
74359, 1.6565217391304, 0.46304347826087, 0.33333333333333
74360, 1.6782608695652, 0.48913043478261, 0.33333333333333
74361, 1.6782608695652, 0.46304347826087, 0.30555555555556
74362, 1.6565217391304, 0.46304347826087, 0.27777777777778
74363, 1.6782608695652, 0.48913043478261, 0.27777777777778
74364, 1.6782608695652, 0.46304347826087, 0.25
74365, 1.6565217391304, 0.46304347826087, 0.22222222222222
74366, 1.6782608695652, 0.48913043478261, 0.22222222222222
74367, 1.6782608695652, 0.46304347826087, 0.19444444444444
74368, 1.6565217391304, 0.46304347826087, 0.16666666666667
74369, 1.6782608695652, 0.48913043478261, 0.16666666666667
74370, 1.6782608695652, 0.46304347826087, 0.13888888888889
74371, 1.6565217391304, 0.46304347826087, 0.11111111111111
74372, 1.6782608695652, 0.48913043478261, 0.11111111111111
74373, 1.6782608695652, 0.46304347826087, 0.083333333333333
74374, 1.6565217391304, 0.46304347826087, 0.055555555555556
74375, 1.6782608695652, 0.48913043478261, 0.055555555555556
74376, 1.6782608695652, 0.46304347826087, 0.027777777777778
74377, 1.7217391304348, 0.46304347826087, 0.47222222222222
74378, 1.7, 0.46304347826087, 0.44444444444444
74379, 1.7217391304348, 0.48913043478261, 0.44444444444444
74380, 1.7217391304348, 0.46304347826087, 0.41666666666667
74381, 1.7, 0.46304347826087, 0.38888888888889
74382, 1.7217391304348, 0.48913043478261, 0.38888888888889
74383, 1.7217391304348, 0.46304347826087, 0.36111111111111
74384, 1.7, 0.46304347826087, 0.33333333333333
74385, 1.7217391304348, 0.48913043478261, 0.33333333333333
74386, 1.7217391304348, 0.46304347826087, 0.30555555555556
74387, 1.7, 0.46304347826087, 0.27777777777778
74388, 1.7217391304348, 0.48913043478261, 0.27777777777778
74389, 1.7217391304348, 0.46304347826087, 0.25
74390, 1.7, 0.46304347826087, 0.22222222222222
74391, 1.7217391304348, 0.48913043478261, 0.22222222222222
74392, 1.7217391304348, 0.46304347826087, 0.19444444444444
74393, 1.7, 0.46304347826087, 0.16666666666667
74394, 1.7217391304348, 0.48913043478261, 0.16666666666667
74395, 1.7217391304348, 0.46304347826087, 0.13888888888889
74396, 1.7, 0.46304347826087, 0.11111111111111
74397, 1.7217391304348, 0.48913043478261, 0.11111111111111
74398, 1.7217391304348, 0.46304347826087, 0.083333333333333
74399, 1.7, 0.46304347826087, 0.055555555555556
74400, 1.7217391304348, 0.48913043478261, 0.055555555555556
74401, 1.7217391304348, 0.46304347826087, 0.027777777777778
74402, 1.7652173913043, 0.46304347826087, 0.47222222222222
74403, 1.7434782608696, 0.46304347826087, 0.44444444444444
74404, 1.7652173913043, 0.48913043478261, 0.44444444444444
74405, 1.7652173913043, 0.46304347826087, 0.41666666666667
74406, 1.7434782608696, 0.46304347826087, 0.38888888888889
74407, 1.7652173913043, 0.48913043478261, 0.38888888888889
74408, 1.7652173913043, 0.46304347826087, 0.36111111111111
74409, 1.7434782608696, 0.46304347826087, 0.33333333333333
74410, 1.7652173913043, 0.48913043478261, 0.33333333333333
74411, 1.7652173913043, 0.46304347826087, 0.30555555555556
74412, 1.7434782608696, 0.46304347826087, 0.27777777777778
74413, 1.7652173913043, 0.48913043478261, 0.27777777777778
74414, 1.7652173913043, 0.46304347826087, 0.25
74415, 1.7434782608696, 0.46304347826087, 0.22222222222222
74416, 1.7652173913043, 0.48913043478261, 0.22222222222222
74417, 1.7652173913043, 0.46304347826087, 0.19444444444444
74418, 1.7434782608696, 0.46304347826087, 0.16666666666667
74419, 1.7652173913043, 0.48913043478261, 0.16666666666667
74420, 1.7652173913043, 0.46304347826087, 0.13888888888889
74421, 1.7434782608696, 0.46304347826087, 0.11111111111111
74422, 1.7652173913043, 0.48913043478261, 0.11111111111111
74423, 1.7652173913043, 0.46304347826087, 0.083333333333333
74424, 1.7434782608696, 0.46304347826087, 0.055555555555556
74425, 1.7652173913043, 0.48913043478261, 0.055555555555556
74426, 1.7652173913043, 0.46304347826087, 0.027777777777778
74427, 1.8086956521739, 0.46304347826087, 0.47222222222222
74428, 1.7869565217391, 0.46304347826087, 0.44444444444444
74429, 1.8086956521739, 0.48913043478261, 0.44444444444444
74430, 1.8086956521739, 0.46304347826087, 0.41666666666667
74431, 1.7869565217391, 0.46304347826087, 0.38888888888889
74432, 1.8086956521739, 0.48913043478261, 0.38888888888889
74433, 1.8086956521739, 0.46304347826087, 0.36111111111111
74434, 1.7869565217391, 0.46304347826087, 0.33333333333333
74435, 1.8086956521739, 0.48913043478261, 0.33333333333333
74436, 1.8086956521739, 0.46304347826087, 0.30555555555556
74437, 1.7869565217391, 0.46304347826087, 0.27777777777778
74438, 1.8086956521739, 0.48913043478261, 0.27777777777778
74439, 1.8086956521739, 0.46304347826087, 0.25
74440, 1.7869565217391, 0.46304347826087, 0.22222222222222
74441, 1.8086956521739, 0.48913043478261, 0.22222222222222
74442, 1.8086956521739, 0.46304347826087, 0.19444444444444
74443, 1.7869565217391, 0.46304347826087, 0.16666666666667
74444, 1.8086956521739, 0.48913043478261, 0.16666666666667
74445, 1.8086956521739, 0.46304347826087, 0.13888888888889
74446, 1.7869565217391, 0.46304347826087, 0.11111111111111
74447, 1.8086956521739, 0.48913043478261, 0.11111111111111
74448, 1.8086956521739, 0.46304347826087, 0.083333333333333
74449, 1.7869565217391, 0.46304347826087, 0.055555555555556
74450, 1.8086956521739, 0.48913043478261, 0.055555555555556
74451, 1.8086956521739, 0.46304347826087, 0.027777777777778
74452, 1.8521739130435, 0.46304347826087, 0.47222222222222
74453, 1.8304347826087, 0.46304347826087, 0.44444444444444
74454, 1.8521739130435, 0.48913043478261, 0.44444444444444
74455, 1.8521739130435, 0.46304347826087, 0.41666666666667
74456, 1.8304347826087, 0.46304347826087, 0.38888888888889
74457, 1.8521739130435, 0.48913043478261, 0.38888888888889
74458, 1.8521739130435, 0.46304347826087, 0.36111111111111
74459, 1.8304347826087, 0.46304347826087, 0.33333333333333
74460, 1.8521739130435, 0.48913043478261, 0.33333333333333
74461, 1.8521739130435, 0.46304347826087, 0.30555555555556
74462, 1.8304347826087, 0.46304347826087, 0.27777777777778
74463, 1.8521739130435, 0.48913043478261, 0.27777777777778
74464, 1.8521739130435, 0.46304347826087, 0.25
74465, 1.8304347826087, 0.46304347826087, 0.22222222222222
74466, 1.8521739130435, 0.48913043478261, 0.22222222222222
74467, 1.8521739130435, 0.46304347826087, 0.19444444444444
74468, 1.8304347826087, 0.46304347826087, 0.16666666666667
74469, 1.8521739130435, 0.48913043478261, 0.16666666666667
74470, 1.8521739130435, 0.46304347826087, 0.13888888888889
74471, 1.8304347826087, 0.46304347826087, 0.11111111111111
74472, 1.8521739130435, 0.48913043478261, 0.11111111111111
74473, 1.8521739130435, 0.46304347826087, 0.083333333333333
74474, 1.8304347826087, 0.46304347826087, 0.055555555555556
74475, 1.8521739130435, 0.48913043478261, 0.055555555555556
74476, 1.8521739130435, 0.46304347826087, 0.027777777777778
74477, 1.895652173913, 0.46304347826087, 0.47222222222222
74478, 1.8739130434783, 0.46304347826087, 0.44444444444444
74479, 1.895652173913, 0.48913043478261, 0.44444444444444
74480, 1.895652173913, 0.46304347826087, 0.41666666666667
74481, 1.8739130434783, 0.46304347826087, 0.38888888888889
74482, 1.895652173913, 0.48913043478261, 0.38888888888889
74483, 1.895652173913, 0.46304347826087, 0.36111111111111
74484, 1.8739130434783, 0.46304347826087, 0.33333333333333
74485, 1.895652173913, 0.48913043478261, 0.33333333333333
74486, 1.895652173913, 0.46304347826087, 0.30555555555556
74487, 1.8739130434783, 0.46304347826087, 0.27777777777778
74488, 1.895652173913, 0.48913043478261, 0.27777777777778
74489, 1.895652173913, 0.46304347826087, 0.25
74490, 1.8739130434783, 0.46304347826087, 0.22222222222222
74491, 1.895652173913, 0.48913043478261, 0.22222222222222
74492, 1.895652173913, 0.46304347826087, 0.19444444444444
74493, 1.8739130434783, 0.46304347826087, 0.16666666666667
74494, 1.895652173913, 0.48913043478261, 0.16666666666667
74495, 1.895652173913, 0.46304347826087, 0.13888888888889
74496, 1.8739130434783, 0.46304347826087, 0.11111111111111
74497, 1.895652173913, 0.48913043478261, 0.11111111111111
74498, 1.895652173913, 0.46304347826087, 0.083333333333333
74499, 1.8739130434783, 0.46304347826087, 0.055555555555556
74500, 1.895652173913, 0.48913043478261, 0.055555555555556
74501, 1.895652173913, 0.46304347826087, 0.027777777777778
74502, 1.9391304347826, 0.46304347826087, 0.47222222222222
74503, 1.9173913043478, 0.46304347826087, 0.44444444444444
74504, 1.9391304347826, 0.48913043478261, 0.44444444444444
74505, 1.9391304347826, 0.46304347826087, 0.41666666666667
74506, 1.9173913043478, 0.46304347826087, 0.38888888888889
74507, 1.9391304347826, 0.48913043478261, 0.38888888888889
74508, 1.9391304347826, 0.46304347826087, 0.36111111111111
74509, 1.9173913043478, 0.46304347826087, 0.33333333333333
74510, 1.9391304347826, 0.48913043478261, 0.33333333333333
74511, 1.9391304347826, 0.46304347826087, 0.30555555555556
74512, 1.9173913043478, 0.46304347826087, 0.27777777777778
74513, 1.9391304347826, 0.48913043478261, 0.27777777777778
74514, 1.9391304347826, 0.46304347826087, 0.25
74515, 1.9173913043478, 0.46304347826087, 0.22222222222222
74516, 1.9391304347826, 0.48913043478261, 0.22222222222222
74517, 1.9391304347826, 0.46304347826087, 0.19444444444444
74518, 1.9173913043478, 0.46304347826087, 0.16666666666667
74519, 1.9391304347826, 0.48913043478261, 0.16666666666667
74520, 1.9391304347826, 0.46304347826087, 0.13888888888889
74521, 1.9173913043478, 0.46304347826087, 0.11111111111111
74522, 1.9391304347826, 0.48913043478261, 0.11111111111111
74523, 1.9391304347826, 0.46304347826087, 0.083333333333333
74524, 1.9173913043478, 0.46304347826087, 0.055555555555556
74525, 1.9391304347826, 0.48913043478261, 0.055555555555556
74526, 1.9391304347826, 0.46304347826087, 0.027777777777778
74527, 1.9826086956522, 0.46304347826087, 0.47222222222222
74528, 1.9608695652174, 0.46304347826087, 0.44444444444444
74529, 1.9826086956522, 0.48913043478261, 0.44444444444444
74530, 1.9826086956522, 0.46304347826087, 0.41666666666667
74531, 1.9608695652174, 0.46304347826087, 0.38888888888889
74532, 1.9826086956522, 0.48913043478261, 0.38888888888889
74533, 1.9826086956522, 0.46304347826087, 0.36111111111111
74534, 1.9608695652174, 0.46304347826087, 0.33333333333333
74535, 1.9826086956522, 0.48913043478261, 0.33333333333333
74536, 1.9826086956522, 0.46304347826087, 0.30555555555556
74537, 1.9608695652174, 0.46304347826087, 0.27777777777778
74538, 1.9826086956522, 0.48913043478261, 0.27777777777778
74539, 1.9826086956522, 0.46304347826087, 0.25
74540, 1.9608695652174, 0.46304347826087, 0.22222222222222
74541, 1.9826086956522, 0.48913043478261, 0.22222222222222
74542, 1.9826086956522, 0.46304347826087, 0.19444444444444
74543, 1.9608695652174, 0.46304347826087, 0.16666666666667
74544, 1.9826086956522, 0.48913043478261, 0.16666666666667
74545, 1.9826086956522, 0.46304347826087, 0.13888888888889
74546, 1.9608695652174, 0.46304347826087, 0.11111111111111
74547, 1.9826086956522, 0.48913043478261, 0.11111111111111
74548, 1.9826086956522, 0.46304347826087, 0.083333333333333
74549, 1.9608695652174, 0.46304347826087, 0.055555555555556
74550, 1.9826086956522, 0.48913043478261, 0.055555555555556
74551, 1.9826086956522, 0.46304347826087, 0.027777777777778
74552, 2.0260869565217, 0.46304347826087, 0.47222222222222
74553, 2.004347826087, 0.46304347826087, 0.44444444444444
74554, 2.0260869565217, 0.48913043478261, 0.44444444444444
74555, 2.0260869565217, 0.46304347826087, 0.41666666666667
74556, 2.004347826087, 0.46304347826087, 0.38888888888889
74557, 2.0260869565217, 0.48913043478261, 0.38888888888889
74558, 2.0260869565217, 0.46304347826087, 0.36111111111111
74559, 2.004347826087, 0.46304347826087, 0.33333333333333
74560, 2.0260869565217, 0.48913043478261, 0.33333333333333
74561, 2.0260869565217, 0.46304347826087, 0.30555555555556
74562, 2.004347826087, 0.46304347826087, 0.27777777777778
74563, 2.0260869565217, 0.48913043478261, 0.27777777777778
74564, 2.0260869565217, 0.46304347826087, 0.25
74565, 2.004347826087, 0.46304347826087, 0.22222222222222
74566, 2.0260869565217, 0.48913043478261, 0.22222222222222
74567, 2.0260869565217, 0.46304347826087, 0.19444444444444
74568, 2.004347826087, 0.46304347826087, 0.16666666666667
74569, 2.0260869565217, 0.48913043478261, 0.16666666666667
74570, 2.0260869565217, 0.46304347826087, 0.13888888888889
74571, 2.004347826087, 0.46304347826087, 0.11111111111111
74572, 2.0260869565217, 0.48913043478261, 0.11111111111111
74573, 2.0260869565217, 0.46304347826087, 0.083333333333333
74574, 2.004347826087, 0.46304347826087, 0.055555555555556
74575, 2.0260869565217, 0.48913043478261, 0.055555555555556
74576, 2.0260869565217, 0.46304347826087, 0.027777777777778
74577, 2.0695652173913, 0.46304347826087, 0.47222222222222
74578, 2.0478260869565, 0.46304347826087, 0.44444444444444
74579, 2.0695652173913, 0.48913043478261, 0.44444444444444
74580, 2.0695652173913, 0.46304347826087, 0.41666666666667
74581, 2.0478260869565, 0.46304347826087, 0.38888888888889
74582, 2.0695652173913, 0.48913043478261, 0.38888888888889
74583, 2.0695652173913, 0.46304347826087, 0.36111111111111
74584, 2.0478260869565, 0.46304347826087, 0.33333333333333
74585, 2.0695652173913, 0.48913043478261, 0.33333333333333
74586, 2.0695652173913, 0.46304347826087, 0.30555555555556
74587, 2.0478260869565, 0.46304347826087, 0.27777777777778
74588, 2.0695652173913, 0.48913043478261, 0.27777777777778
74589, 2.0695652173913, 0.46304347826087, 0.25
74590, 2.0478260869565, 0.46304347826087, 0.22222222222222
74591, 2.0695652173913, 0.48913043478261, 0.22222222222222
74592, 2.0695652173913, 0.46304347826087, 0.19444444444444
74593, 2.0478260869565, 0.46304347826087, 0.16666666666667
74594, 2.0695652173913, 0.48913043478261, 0.16666666666667
74595, 2.0695652173913, 0.46304347826087, 0.13888888888889
74596, 2.0478260869565, 0.46304347826087, 0.11111111111111
74597, 2.0695652173913, 0.48913043478261, 0.11111111111111
74598, 2.0695652173913, 0.46304347826087, 0.083333333333333
74599, 2.0478260869565, 0.46304347826087, 0.055555555555556
74600, 2.0695652173913, 0.48913043478261, 0.055555555555556
74601, 2.0695652173913, 0.46304347826087, 0.027777777777778
74602, 2.1130434782609, 0.46304347826087, 0.47222222222222
74603, 2.0913043478261, 0.46304347826087, 0.44444444444444
74604, 2.1130434782609, 0.48913043478261, 0.44444444444444
74605, 2.1130434782609, 0.46304347826087, 0.41666666666667
74606, 2.0913043478261, 0.46304347826087, 0.38888888888889
74607, 2.1130434782609, 0.48913043478261, 0.38888888888889
74608, 2.1130434782609, 0.46304347826087, 0.36111111111111
74609, 2.0913043478261, 0.46304347826087, 0.33333333333333
74610, 2.1130434782609, 0.48913043478261, 0.33333333333333
74611, 2.1130434782609, 0.46304347826087, 0.30555555555556
74612, 2.0913043478261, 0.46304347826087, 0.27777777777778
74613, 2.1130434782609, 0.48913043478261, 0.27777777777778
74614, 2.1130434782609, 0.46304347826087, 0.25
74615, 2.0913043478261, 0.46304347826087, 0.22222222222222
74616, 2.1130434782609, 0.48913043478261, 0.22222222222222
74617, 2.1130434782609, 0.46304347826087, 0.19444444444444
74618, 2.0913043478261, 0.46304347826087, 0.16666666666667
74619, 2.1130434782609, 0.48913043478261, 0.16666666666667
74620, 2.1130434782609, 0.46304347826087, 0.13888888888889
74621, 2.0913043478261, 0.46304347826087, 0.11111111111111
74622, 2.1130434782609, 0.48913043478261, 0.11111111111111
74623, 2.1130434782609, 0.46304347826087, 0.083333333333333
74624, 2.0913043478261, 0.46304347826087, 0.055555555555556
74625, 2.1130434782609, 0.48913043478261, 0.055555555555556
74626, 2.1130434782609, 0.46304347826087, 0.027777777777778
74627, 2.1565217391304, 0.46304347826087, 0.47222222222222
74628, 2.1347826086957, 0.46304347826087, 0.44444444444444
74629, 2.1565217391304, 0.48913043478261, 0.44444444444444
74630, 2.1565217391304, 0.46304347826087, 0.41666666666667
74631, 2.1347826086957, 0.46304347826087, 0.38888888888889
74632, 2.1565217391304, 0.48913043478261, 0.38888888888889
74633, 2.1565217391304, 0.46304347826087, 0.36111111111111
74634, 2.1347826086957, 0.46304347826087, 0.33333333333333
74635, 2.1565217391304, 0.48913043478261, 0.33333333333333
74636, 2.1565217391304, 0.46304347826087, 0.30555555555556
74637, 2.1347826086957, 0.46304347826087, 0.27777777777778
74638, 2.1565217391304, 0.48913043478261, 0.27777777777778
74639, 2.1565217391304, 0.46304347826087, 0.25
74640, 2.1347826086957, 0.46304347826087, 0.22222222222222
74641, 2.1565217391304, 0.48913043478261, 0.22222222222222
74642, 2.1565217391304, 0.46304347826087, 0.19444444444444
74643, 2.1347826086957, 0.46304347826087, 0.16666666666667
74644, 2.1565217391304, 0.48913043478261, 0.16666666666667
74645, 2.1565217391304, 0.46304347826087, 0.13888888888889
74646, 2.1347826086957, 0.46304347826087, 0.11111111111111
74647, 2.1565217391304, 0.48913043478261, 0.11111111111111
74648, 2.1565217391304, 0.46304347826087, 0.083333333333333
74649, 2.1347826086957, 0.46304347826087, 0.055555555555556
74650, 2.1565217391304, 0.48913043478261, 0.055555555555556
74651, 2.1565217391304, 0.46304347826087, 0.027777777777778
74652, 2.1782608695652, 0.46304347826087, 0.44444444444444
74653, 2.1782608695652, 0.46304347826087, 0.38888888888889
74654, 2.1782608695652, 0.46304347826087, 0.33333333333333
74655, 2.1782608695652, 0.46304347826087, 0.27777777777778
74656, 2.1782608695652, 0.46304347826087, 0.22222222222222
74657, 2.1782608695652, 0.46304347826087, 0.16666666666667
74658, 2.1782608695652, 0.46304347826087, 0.11111111111111
74659, 2.1782608695652, 0.46304347826087, 0.055555555555556
74660, 1.2434782608696, 0.41086956521739, 0.47222222222222
74661, 1.2217391304348, 0.41086956521739, 0.44444444444444
74662, 1.2434782608696, 0.43695652173913, 0.44444444444444
74663, 1.2434782608696, 0.41086956521739, 0.41666666666667
74664, 1.2217391304348, 0.41086956521739, 0.38888888888889
74665, 1.2434782608696, 0.43695652173913, 0.38888888888889
74666, 1.2434782608696, 0.41086956521739, 0.36111111111111
74667, 1.2217391304348, 0.41086956521739, 0.33333333333333
74668, 1.2434782608696, 0.43695652173913, 0.33333333333333
74669, 1.2434782608696, 0.41086956521739, 0.30555555555556
74670, 1.2217391304348, 0.41086956521739, 0.27777777777778
74671, 1.2434782608696, 0.43695652173913, 0.27777777777778
74672, 1.2434782608696, 0.41086956521739, 0.25
74673, 1.2217391304348, 0.41086956521739, 0.22222222222222
74674, 1.2434782608696, 0.43695652173913, 0.22222222222222
74675, 1.2434782608696, 0.41086956521739, 0.19444444444444
74676, 1.2217391304348, 0.41086956521739, 0.16666666666667
74677, 1.2434782608696, 0.43695652173913, 0.16666666666667
74678, 1.2434782608696, 0.41086956521739, 0.13888888888889
74679, 1.2217391304348, 0.41086956521739, 0.11111111111111
74680, 1.2434782608696, 0.43695652173913, 0.11111111111111
74681, 1.2434782608696, 0.41086956521739, 0.083333333333333
74682, 1.2217391304348, 0.41086956521739, 0.055555555555556
74683, 1.2434782608696, 0.43695652173913, 0.055555555555556
74684, 1.2434782608696, 0.41086956521739, 0.027777777777778
74685, 1.2869565217391, 0.41086956521739, 0.47222222222222
74686, 1.2652173913043, 0.41086956521739, 0.44444444444444
74687, 1.2869565217391, 0.43695652173913, 0.44444444444444
74688, 1.2869565217391, 0.41086956521739, 0.41666666666667
74689, 1.2652173913043, 0.41086956521739, 0.38888888888889
74690, 1.2869565217391, 0.43695652173913, 0.38888888888889
74691, 1.2869565217391, 0.41086956521739, 0.36111111111111
74692, 1.2652173913043, 0.41086956521739, 0.33333333333333
74693, 1.2869565217391, 0.43695652173913, 0.33333333333333
74694, 1.2869565217391, 0.41086956521739, 0.30555555555556
74695, 1.2652173913043, 0.41086956521739, 0.27777777777778
74696, 1.2869565217391, 0.43695652173913, 0.27777777777778
74697, 1.2869565217391, 0.41086956521739, 0.25
74698, 1.2652173913043, 0.41086956521739, 0.22222222222222
74699, 1.2869565217391, 0.43695652173913, 0.22222222222222
74700, 1.2869565217391, 0.41086956521739, 0.19444444444444
74701, 1.2652173913043, 0.41086956521739, 0.16666666666667
74702, 1.2869565217391, 0.43695652173913, 0.16666666666667
74703, 1.2869565217391, 0.41086956521739, 0.13888888888889
74704, 1.2652173913043, 0.41086956521739, 0.11111111111111
74705, 1.2869565217391, 0.43695652173913, 0.11111111111111
74706, 1.2869565217391, 0.41086956521739, 0.083333333333333
74707, 1.2652173913043, 0.41086956521739, 0.055555555555556
74708, 1.2869565217391, 0.43695652173913, 0.055555555555556
74709, 1.2869565217391, 0.41086956521739, 0.027777777777778
74710, 1.3304347826087, 0.41086956521739, 0.47222222222222
74711, 1.3086956521739, 0.41086956521739, 0.44444444444444
74712, 1.3304347826087, 0.43695652173913, 0.44444444444444
74713, 1.3304347826087, 0.41086956521739, 0.41666666666667
74714, 1.3086956521739, 0.41086956521739, 0.38888888888889
74715, 1.3304347826087, 0.43695652173913, 0.38888888888889
74716, 1.3304347826087, 0.41086956521739, 0.36111111111111
74717, 1.3086956521739, 0.41086956521739, 0.33333333333333
74718, 1.3304347826087, 0.43695652173913, 0.33333333333333
74719, 1.3304347826087, 0.41086956521739, 0.30555555555556
74720, 1.3086956521739, 0.41086956521739, 0.27777777777778
74721, 1.3304347826087, 0.43695652173913, 0.27777777777778
74722, 1.3304347826087, 0.41086956521739, 0.25
74723, 1.3086956521739, 0.41086956521739, 0.22222222222222
74724, 1.3304347826087, 0.43695652173913, 0.22222222222222
74725, 1.3304347826087, 0.41086956521739, 0.19444444444444
74726, 1.3086956521739, 0.41086956521739, 0.16666666666667
74727, 1.3304347826087, 0.43695652173913, 0.16666666666667
74728, 1.3304347826087, 0.41086956521739, 0.13888888888889
74729, 1.3086956521739, 0.41086956521739, 0.11111111111111
74730, 1.3304347826087, 0.43695652173913, 0.11111111111111
74731, 1.3304347826087, 0.41086956521739, 0.083333333333333
74732, 1.3086956521739, 0.41086956521739, 0.055555555555556
74733, 1.3304347826087, 0.43695652173913, 0.055555555555556
74734, 1.3304347826087, 0.41086956521739, 0.027777777777778
74735, 1.3739130434783, 0.41086956521739, 0.47222222222222
74736, 1.3521739130435, 0.41086956521739, 0.44444444444444
74737, 1.3739130434783, 0.43695652173913, 0.44444444444444
74738, 1.3739130434783, 0.41086956521739, 0.41666666666667
74739, 1.3521739130435, 0.41086956521739, 0.38888888888889
74740, 1.3739130434783, 0.43695652173913, 0.38888888888889
74741, 1.3739130434783, 0.41086956521739, 0.36111111111111
74742, 1.3521739130435, 0.41086956521739, 0.33333333333333
74743, 1.3739130434783, 0.43695652173913, 0.33333333333333
74744, 1.3739130434783, 0.41086956521739, 0.30555555555556
74745, 1.3521739130435, 0.41086956521739, 0.27777777777778
74746, 1.3739130434783, 0.43695652173913, 0.27777777777778
74747, 1.3739130434783, 0.41086956521739, 0.25
74748, 1.3521739130435, 0.41086956521739, 0.22222222222222
74749, 1.3739130434783, 0.43695652173913, 0.22222222222222
74750, 1.3739130434783, 0.41086956521739, 0.19444444444444
74751, 1.3521739130435, 0.41086956521739, 0.16666666666667
74752, 1.3739130434783, 0.43695652173913, 0.16666666666667
74753, 1.3739130434783, 0.41086956521739, 0.13888888888889
74754, 1.3521739130435, 0.41086956521739, 0.11111111111111
74755, 1.3739130434783, 0.43695652173913, 0.11111111111111
74756, 1.3739130434783, 0.41086956521739, 0.083333333333333
74757, 1.3521739130435, 0.41086956521739, 0.055555555555556
74758, 1.3739130434783, 0.43695652173913, 0.055555555555556
74759, 1.3739130434783, 0.41086956521739, 0.027777777777778
74760, 1.4173913043478, 0.41086956521739, 0.47222222222222
74761, 1.395652173913, 0.41086956521739, 0.44444444444444
74762, 1.4173913043478, 0.43695652173913, 0.44444444444444
74763, 1.4173913043478, 0.41086956521739, 0.41666666666667
74764, 1.395652173913, 0.41086956521739, 0.38888888888889
74765, 1.4173913043478, 0.43695652173913, 0.38888888888889
74766, 1.4173913043478, 0.41086956521739, 0.36111111111111
74767, 1.395652173913, 0.41086956521739, 0.33333333333333
74768, 1.4173913043478, 0.43695652173913, 0.33333333333333
74769, 1.4173913043478, 0.41086956521739, 0.30555555555556
74770, 1.395652173913, 0.41086956521739, 0.27777777777778
74771, 1.4173913043478, 0.43695652173913, 0.27777777777778
74772, 1.4173913043478, 0.41086956521739, 0.25
74773, 1.395652173913, 0.41086956521739, 0.22222222222222
74774, 1.4173913043478, 0.43695652173913, 0.22222222222222
74775, 1.4173913043478, 0.41086956521739, 0.19444444444444
74776, 1.395652173913, 0.41086956521739, 0.16666666666667
74777, 1.4173913043478, 0.43695652173913, 0.16666666666667
74778, 1.4173913043478, 0.41086956521739, 0.13888888888889
74779, 1.395652173913, 0.41086956521739, 0.11111111111111
74780, 1.4173913043478, 0.43695652173913, 0.11111111111111
74781, 1.4173913043478, 0.41086956521739, 0.083333333333333
74782, 1.395652173913, 0.41086956521739, 0.055555555555556
74783, 1.4173913043478, 0.43695652173913, 0.055555555555556
74784, 1.4173913043478, 0.41086956521739, 0.027777777777778
74785, 1.4608695652174, 0.41086956521739, 0.47222222222222
74786, 1.4391304347826, 0.41086956521739, 0.44444444444444
74787, 1.4608695652174, 0.43695652173913, 0.44444444444444
74788, 1.4608695652174, 0.41086956521739, 0.41666666666667
74789, 1.4391304347826, 0.41086956521739, 0.38888888888889
74790, 1.4608695652174, 0.43695652173913, 0.38888888888889
74791, 1.4608695652174, 0.41086956521739, 0.36111111111111
74792, 1.4391304347826, 0.41086956521739, 0.33333333333333
74793, 1.4608695652174, 0.43695652173913, 0.33333333333333
74794, 1.4608695652174, 0.41086956521739, 0.30555555555556
74795, 1.4391304347826, 0.41086956521739, 0.27777777777778
74796, 1.4608695652174, 0.43695652173913, 0.27777777777778
74797, 1.4608695652174, 0.41086956521739, 0.25
74798, 1.4391304347826, 0.41086956521739, 0.22222222222222
74799, 1.4608695652174, 0.43695652173913, 0.22222222222222
74800, 1.4608695652174, 0.41086956521739, 0.19444444444444
74801, 1.4391304347826, 0.41086956521739, 0.16666666666667
74802, 1.4608695652174, 0.43695652173913, 0.16666666666667
74803, 1.4608695652174, 0.41086956521739, 0.13888888888889
74804, 1.4391304347826, 0.41086956521739, 0.11111111111111
74805, 1.4608695652174, 0.43695652173913, 0.11111111111111
74806, 1.4608695652174, 0.41086956521739, 0.083333333333333
74807, 1.4391304347826, 0.41086956521739, 0.055555555555556
74808, 1.4608695652174, 0.43695652173913, 0.055555555555556
74809, 1.4608695652174, 0.41086956521739, 0.027777777777778
74810, 1.504347826087, 0.41086956521739, 0.47222222222222
74811, 1.4826086956522, 0.41086956521739, 0.44444444444444
74812, 1.504347826087, 0.43695652173913, 0.44444444444444
74813, 1.504347826087, 0.41086956521739, 0.41666666666667
74814, 1.4826086956522, 0.41086956521739, 0.38888888888889
74815, 1.504347826087, 0.43695652173913, 0.38888888888889
74816, 1.504347826087, 0.41086956521739, 0.36111111111111
74817, 1.4826086956522, 0.41086956521739, 0.33333333333333
74818, 1.504347826087, 0.43695652173913, 0.33333333333333
74819, 1.504347826087, 0.41086956521739, 0.30555555555556
74820, 1.4826086956522, 0.41086956521739, 0.27777777777778
74821, 1.504347826087, 0.43695652173913, 0.27777777777778
74822, 1.504347826087, 0.41086956521739, 0.25
74823, 1.4826086956522, 0.41086956521739, 0.22222222222222
74824, 1.504347826087, 0.43695652173913, 0.22222222222222
74825, 1.504347826087, 0.41086956521739, 0.19444444444444
74826, 1.4826086956522, 0.41086956521739, 0.16666666666667
74827, 1.504347826087, 0.43695652173913, 0.16666666666667
74828, 1.504347826087, 0.41086956521739, 0.13888888888889
74829, 1.4826086956522, 0.41086956521739, 0.11111111111111
74830, 1.504347826087, 0.43695652173913, 0.11111111111111
74831, 1.504347826087, 0.41086956521739, 0.083333333333333
74832, 1.4826086956522, 0.41086956521739, 0.055555555555556
74833, 1.504347826087, 0.43695652173913, 0.055555555555556
74834, 1.504347826087, 0.41086956521739, 0.027777777777778
74835, 1.5478260869565, 0.41086956521739, 0.47222222222222
74836, 1.5260869565217, 0.41086956521739, 0.44444444444444
74837, 1.5478260869565, 0.43695652173913, 0.44444444444444
74838, 1.5478260869565, 0.41086956521739, 0.41666666666667
74839, 1.5260869565217, 0.41086956521739, 0.38888888888889
74840, 1.5478260869565, 0.43695652173913, 0.38888888888889
74841, 1.5478260869565, 0.41086956521739, 0.36111111111111
74842, 1.5260869565217, 0.41086956521739, 0.33333333333333
74843, 1.5478260869565, 0.43695652173913, 0.33333333333333
74844, 1.5478260869565, 0.41086956521739, 0.30555555555556
74845, 1.5260869565217, 0.41086956521739, 0.27777777777778
74846, 1.5478260869565, 0.43695652173913, 0.27777777777778
74847, 1.5478260869565, 0.41086956521739, 0.25
74848, 1.5260869565217, 0.41086956521739, 0.22222222222222
74849, 1.5478260869565, 0.43695652173913, 0.22222222222222
74850, 1.5478260869565, 0.41086956521739, 0.19444444444444
74851, 1.5260869565217, 0.41086956521739, 0.16666666666667
74852, 1.5478260869565, 0.43695652173913, 0.16666666666667
74853, 1.5478260869565, 0.41086956521739, 0.13888888888889
74854, 1.5260869565217, 0.41086956521739, 0.11111111111111
74855, 1.5478260869565, 0.43695652173913, 0.11111111111111
74856, 1.5478260869565, 0.41086956521739, 0.083333333333333
74857, 1.5260869565217, 0.41086956521739, 0.055555555555556
74858, 1.5478260869565, 0.43695652173913, 0.055555555555556
74859, 1.5478260869565, 0.41086956521739, 0.027777777777778
74860, 1.5913043478261, 0.41086956521739, 0.47222222222222
74861, 1.5695652173913, 0.41086956521739, 0.44444444444444
74862, 1.5913043478261, 0.43695652173913, 0.44444444444444
74863, 1.5913043478261, 0.41086956521739, 0.41666666666667
74864, 1.5695652173913, 0.41086956521739, 0.38888888888889
74865, 1.5913043478261, 0.43695652173913, 0.38888888888889
74866, 1.5913043478261, 0.41086956521739, 0.36111111111111
74867, 1.5695652173913, 0.41086956521739, 0.33333333333333
74868, 1.5913043478261, 0.43695652173913, 0.33333333333333
74869, 1.5913043478261, 0.41086956521739, 0.30555555555556
74870, 1.5695652173913, 0.41086956521739, 0.27777777777778
74871, 1.5913043478261, 0.43695652173913, 0.27777777777778
74872, 1.5913043478261, 0.41086956521739, 0.25
74873, 1.5695652173913, 0.41086956521739, 0.22222222222222
74874, 1.5913043478261, 0.43695652173913, 0.22222222222222
74875, 1.5913043478261, 0.41086956521739, 0.19444444444444
74876, 1.5695652173913, 0.41086956521739, 0.16666666666667
74877, 1.5913043478261, 0.43695652173913, 0.16666666666667
74878, 1.5913043478261, 0.41086956521739, 0.13888888888889
74879, 1.5695652173913, 0.41086956521739, 0.11111111111111
74880, 1.5913043478261, 0.43695652173913, 0.11111111111111
74881, 1.5913043478261, 0.41086956521739, 0.083333333333333
74882, 1.5695652173913, 0.41086956521739, 0.055555555555556
74883, 1.5913043478261, 0.43695652173913, 0.055555555555556
74884, 1.5913043478261, 0.41086956521739, 0.027777777777778
74885, 1.6347826086957, 0.41086956521739, 0.47222222222222
74886, 1.6130434782609, 0.41086956521739, 0.44444444444444
74887, 1.6347826086957, 0.43695652173913, 0.44444444444444
74888, 1.6347826086957, 0.41086956521739, 0.41666666666667
74889, 1.6130434782609, 0.41086956521739, 0.38888888888889
74890, 1.6347826086957, 0.43695652173913, 0.38888888888889
74891, 1.6347826086957, 0.41086956521739, 0.36111111111111
74892, 1.6130434782609, 0.41086956521739, 0.33333333333333
74893, 1.6347826086957, 0.43695652173913, 0.33333333333333
74894, 1.6347826086957, 0.41086956521739, 0.30555555555556
74895, 1.6130434782609, 0.41086956521739, 0.27777777777778
74896, 1.6347826086957, 0.43695652173913, 0.27777777777778
74897, 1.6347826086957, 0.41086956521739, 0.25
74898, 1.6130434782609, 0.41086956521739, 0.22222222222222
74899, 1.6347826086957, 0.43695652173913, 0.22222222222222
74900, 1.6347826086957, 0.41086956521739, 0.19444444444444
74901, 1.6130434782609, 0.41086956521739, 0.16666666666667
74902, 1.6347826086957, 0.43695652173913, 0.16666666666667
74903, 1.6347826086957, 0.41086956521739, 0.13888888888889
74904, 1.6130434782609, 0.41086956521739, 0.11111111111111
74905, 1.6347826086957, 0.43695652173913, 0.11111111111111
74906, 1.6347826086957, 0.41086956521739, 0.083333333333333
74907, 1.6130434782609, 0.41086956521739, 0.055555555555556
74908, 1.6347826086957, 0.43695652173913, 0.055555555555556
74909, 1.6347826086957, 0.41086956521739, 0.027777777777778
74910, 1.6782608695652, 0.41086956521739, 0.47222222222222
74911, 1.6565217391304, 0.41086956521739, 0.44444444444444
74912, 1.6782608695652, 0.43695652173913, 0.44444444444444
74913, 1.6782608695652, 0.41086956521739, 0.41666666666667
74914, 1.6565217391304, 0.41086956521739, 0.38888888888889
74915, 1.6782608695652, 0.43695652173913, 0.38888888888889
74916, 1.6782608695652, 0.41086956521739, 0.36111111111111
74917, 1.6565217391304, 0.41086956521739, 0.33333333333333
74918, 1.6782608695652, 0.43695652173913, 0.33333333333333
74919, 1.6782608695652, 0.41086956521739, 0.30555555555556
74920, 1.6565217391304, 0.41086956521739, 0.27777777777778
74921, 1.6782608695652, 0.43695652173913, 0.27777777777778
74922, 1.6782608695652, 0.41086956521739, 0.25
74923, 1.6565217391304, 0.41086956521739, 0.22222222222222
74924, 1.6782608695652, 0.43695652173913, 0.22222222222222
74925, 1.6782608695652, 0.41086956521739, 0.19444444444444
74926, 1.6565217391304, 0.41086956521739, 0.16666666666667
74927, 1.6782608695652, 0.43695652173913, 0.16666666666667
74928, 1.6782608695652, 0.41086956521739, 0.13888888888889
74929, 1.6565217391304, 0.41086956521739, 0.11111111111111
74930, 1.6782608695652, 0.43695652173913, 0.11111111111111
74931, 1.6782608695652, 0.41086956521739, 0.083333333333333
74932, 1.6565217391304, 0.41086956521739, 0.055555555555556
74933, 1.6782608695652, 0.43695652173913, 0.055555555555556
74934, 1.6782608695652, 0.41086956521739, 0.027777777777778
74935, 1.7217391304348, 0.41086956521739, 0.47222222222222
74936, 1.7, 0.41086956521739, 0.44444444444444
74937, 1.7217391304348, 0.43695652173913, 0.44444444444444
74938, 1.7217391304348, 0.41086956521739, 0.41666666666667
74939, 1.7, 0.41086956521739, 0.38888888888889
74940, 1.7217391304348, 0.43695652173913, 0.38888888888889
74941, 1.7217391304348, 0.41086956521739, 0.36111111111111
74942, 1.7, 0.41086956521739, 0.33333333333333
74943, 1.7217391304348, 0.43695652173913, 0.33333333333333
74944, 1.7217391304348, 0.41086956521739, 0.30555555555556
74945, 1.7, 0.41086956521739, 0.27777777777778
74946, 1.7217391304348, 0.43695652173913, 0.27777777777778
74947, 1.7217391304348, 0.41086956521739, 0.25
74948, 1.7, 0.41086956521739, 0.22222222222222
74949, 1.7217391304348, 0.43695652173913, 0.22222222222222
74950, 1.7217391304348, 0.41086956521739, 0.19444444444444
74951, 1.7, 0.41086956521739, 0.16666666666667
74952, 1.7217391304348, 0.43695652173913, 0.16666666666667
74953, 1.7217391304348, 0.41086956521739, 0.13888888888889
74954, 1.7, 0.41086956521739, 0.11111111111111
74955, 1.7217391304348, 0.43695652173913, 0.11111111111111
74956, 1.7217391304348, 0.41086956521739, 0.083333333333333
74957, 1.7, 0.41086956521739, 0.055555555555556
74958, 1.7217391304348, 0.43695652173913, 0.055555555555556
74959, 1.7217391304348, 0.41086956521739, 0.027777777777778
74960, 1.7652173913043, 0.41086956521739, 0.47222222222222
74961, 1.7434782608696, 0.41086956521739, 0.44444444444444
74962, 1.7652173913043, 0.43695652173913, 0.44444444444444
74963, 1.7652173913043, 0.41086956521739, 0.41666666666667
74964, 1.7434782608696, 0.41086956521739, 0.38888888888889
74965, 1.7652173913043, 0.43695652173913, 0.38888888888889
74966, 1.7652173913043, 0.41086956521739, 0.36111111111111
74967, 1.7434782608696, 0.41086956521739, 0.33333333333333
74968, 1.7652173913043, 0.43695652173913, 0.33333333333333
74969, 1.7652173913043, 0.41086956521739, 0.30555555555556
74970, 1.7434782608696, 0.41086956521739, 0.27777777777778
74971, 1.7652173913043, 0.43695652173913, 0.27777777777778
74972, 1.7652173913043, 0.41086956521739, 0.25
74973, 1.7434782608696, 0.41086956521739, 0.22222222222222
74974, 1.7652173913043, 0.43695652173913, 0.22222222222222
74975, 1.7652173913043, 0.41086956521739, 0.19444444444444
74976, 1.7434782608696, 0.41086956521739, 0.16666666666667
74977, 1.7652173913043, 0.43695652173913, 0.16666666666667
74978, 1.7652173913043, 0.41086956521739, 0.13888888888889
74979, 1.7434782608696, 0.41086956521739, 0.11111111111111
74980, 1.7652173913043, 0.43695652173913, 0.11111111111111
74981, 1.7652173913043, 0.41086956521739, 0.083333333333333
74982, 1.7434782608696, 0.41086956521739, 0.055555555555556
74983, 1.7652173913043, 0.43695652173913, 0.055555555555556
74984, 1.7652173913043, 0.41086956521739, 0.027777777777778
74985, 1.8086956521739, 0.41086956521739, 0.47222222222222
74986, 1.7869565217391, 0.41086956521739, 0.44444444444444
74987, 1.8086956521739, 0.43695652173913, 0.44444444444444
74988, 1.8086956521739, 0.41086956521739, 0.41666666666667
74989, 1.7869565217391, 0.41086956521739, 0.38888888888889
74990, 1.8086956521739, 0.43695652173913, 0.38888888888889
74991, 1.8086956521739, 0.41086956521739, 0.36111111111111
74992, 1.7869565217391, 0.41086956521739, 0.33333333333333
74993, 1.8086956521739, 0.43695652173913, 0.33333333333333
74994, 1.8086956521739, 0.41086956521739, 0.30555555555556
74995, 1.7869565217391, 0.41086956521739, 0.27777777777778
74996, 1.8086956521739, 0.43695652173913, 0.27777777777778
74997, 1.8086956521739, 0.41086956521739, 0.25
74998, 1.7869565217391, 0.41086956521739, 0.22222222222222
74999, 1.8086956521739, 0.43695652173913, 0.22222222222222
75000, 1.8086956521739, 0.41086956521739, 0.19444444444444
75001, 1.7869565217391, 0.41086956521739, 0.16666666666667
75002, 1.8086956521739, 0.43695652173913, 0.16666666666667
75003, 1.8086956521739, 0.41086956521739, 0.13888888888889
75004, 1.7869565217391, 0.41086956521739, 0.11111111111111
75005, 1.8086956521739, 0.43695652173913, 0.11111111111111
75006, 1.8086956521739, 0.41086956521739, 0.083333333333333
75007, 1.7869565217391, 0.41086956521739, 0.055555555555556
75008, 1.8086956521739, 0.43695652173913, 0.055555555555556
75009, 1.8086956521739, 0.41086956521739, 0.027777777777778
75010, 1.8521739130435, 0.41086956521739, 0.47222222222222
75011, 1.8304347826087, 0.41086956521739, 0.44444444444444
75012, 1.8521739130435, 0.43695652173913, 0.44444444444444
75013, 1.8521739130435, 0.41086956521739, 0.41666666666667
75014, 1.8304347826087, 0.41086956521739, 0.38888888888889
75015, 1.8521739130435, 0.43695652173913, 0.38888888888889
75016, 1.8521739130435, 0.41086956521739, 0.36111111111111
75017, 1.8304347826087, 0.41086956521739, 0.33333333333333
75018, 1.8521739130435, 0.43695652173913, 0.33333333333333
75019, 1.8521739130435, 0.41086956521739, 0.30555555555556
75020, 1.8304347826087, 0.41086956521739, 0.27777777777778
75021, 1.8521739130435, 0.43695652173913, 0.27777777777778
75022, 1.8521739130435, 0.41086956521739, 0.25
75023, 1.8304347826087, 0.41086956521739, 0.22222222222222
75024, 1.8521739130435, 0.43695652173913, 0.22222222222222
75025, 1.8521739130435, 0.41086956521739, 0.19444444444444
75026, 1.8304347826087, 0.41086956521739, 0.16666666666667
75027, 1.8521739130435, 0.43695652173913, 0.16666666666667
75028, 1.8521739130435, 0.41086956521739, 0.13888888888889
75029, 1.8304347826087, 0.41086956521739, 0.11111111111111
75030, 1.8521739130435, 0.43695652173913, 0.11111111111111
75031, 1.8521739130435, 0.41086956521739, 0.083333333333333
75032, 1.8304347826087, 0.41086956521739, 0.055555555555556
75033, 1.8521739130435, 0.43695652173913, 0.055555555555556
75034, 1.8521739130435, 0.41086956521739, 0.027777777777778
75035, 1.895652173913, 0.41086956521739, 0.47222222222222
75036, 1.8739130434783, 0.41086956521739, 0.44444444444444
75037, 1.895652173913, 0.43695652173913, 0.44444444444444
75038, 1.895652173913, 0.41086956521739, 0.41666666666667
75039, 1.8739130434783, 0.41086956521739, 0.38888888888889
75040, 1.895652173913, 0.43695652173913, 0.38888888888889
75041, 1.895652173913, 0.41086956521739, 0.36111111111111
75042, 1.8739130434783, 0.41086956521739, 0.33333333333333
75043, 1.895652173913, 0.43695652173913, 0.33333333333333
75044, 1.895652173913, 0.41086956521739, 0.30555555555556
75045, 1.8739130434783, 0.41086956521739, 0.27777777777778
75046, 1.895652173913, 0.43695652173913, 0.27777777777778
75047, 1.895652173913, 0.41086956521739, 0.25
75048, 1.8739130434783, 0.41086956521739, 0.22222222222222
75049, 1.895652173913, 0.43695652173913, 0.22222222222222
75050, 1.895652173913, 0.41086956521739, 0.19444444444444
75051, 1.8739130434783, 0.41086956521739, 0.16666666666667
75052, 1.895652173913, 0.43695652173913, 0.16666666666667
75053, 1.895652173913, 0.41086956521739, 0.13888888888889
75054, 1.8739130434783, 0.41086956521739, 0.11111111111111
75055, 1.895652173913, 0.43695652173913, 0.11111111111111
75056, 1.895652173913, 0.41086956521739, 0.083333333333333
75057, 1.8739130434783, 0.41086956521739, 0.055555555555556
75058, 1.895652173913, 0.43695652173913, 0.055555555555556
75059, 1.895652173913, 0.41086956521739, 0.027777777777778
75060, 1.9391304347826, 0.41086956521739, 0.47222222222222
75061, 1.9173913043478, 0.41086956521739, 0.44444444444444
75062, 1.9391304347826, 0.43695652173913, 0.44444444444444
75063, 1.9391304347826, 0.41086956521739, 0.41666666666667
75064, 1.9173913043478, 0.41086956521739, 0.38888888888889
75065, 1.9391304347826, 0.43695652173913, 0.38888888888889
75066, 1.9391304347826, 0.41086956521739, 0.36111111111111
75067, 1.9173913043478, 0.41086956521739, 0.33333333333333
75068, 1.9391304347826, 0.43695652173913, 0.33333333333333
75069, 1.9391304347826, 0.41086956521739, 0.30555555555556
75070, 1.9173913043478, 0.41086956521739, 0.27777777777778
75071, 1.9391304347826, 0.43695652173913, 0.27777777777778
75072, 1.9391304347826, 0.41086956521739, 0.25
75073, 1.9173913043478, 0.41086956521739, 0.22222222222222
75074, 1.9391304347826, 0.43695652173913, 0.22222222222222
75075, 1.9391304347826, 0.41086956521739, 0.19444444444444
75076, 1.9173913043478, 0.41086956521739, 0.16666666666667
75077, 1.9391304347826, 0.43695652173913, 0.16666666666667
75078, 1.9391304347826, 0.41086956521739, 0.13888888888889
75079, 1.9173913043478, 0.41086956521739, 0.11111111111111
75080, 1.9391304347826, 0.43695652173913, 0.11111111111111
75081, 1.9391304347826, 0.41086956521739, 0.083333333333333
75082, 1.9173913043478, 0.41086956521739, 0.055555555555556
75083, 1.9391304347826, 0.43695652173913, 0.055555555555556
75084, 1.9391304347826, 0.41086956521739, 0.027777777777778
75085, 1.9826086956522, 0.41086956521739, 0.47222222222222
75086, 1.9608695652174, 0.41086956521739, 0.44444444444444
75087, 1.9826086956522, 0.43695652173913, 0.44444444444444
75088, 1.9826086956522, 0.41086956521739, 0.41666666666667
75089, 1.9608695652174, 0.41086956521739, 0.38888888888889
75090, 1.9826086956522, 0.43695652173913, 0.38888888888889
75091, 1.9826086956522, 0.41086956521739, 0.36111111111111
75092, 1.9608695652174, 0.41086956521739, 0.33333333333333
75093, 1.9826086956522, 0.43695652173913, 0.33333333333333
75094, 1.9826086956522, 0.41086956521739, 0.30555555555556
75095, 1.9608695652174, 0.41086956521739, 0.27777777777778
75096, 1.9826086956522, 0.43695652173913, 0.27777777777778
75097, 1.9826086956522, 0.41086956521739, 0.25
75098, 1.9608695652174, 0.41086956521739, 0.22222222222222
75099, 1.9826086956522, 0.43695652173913, 0.22222222222222
75100, 1.9826086956522, 0.41086956521739, 0.19444444444444
75101, 1.9608695652174, 0.41086956521739, 0.16666666666667
75102, 1.9826086956522, 0.43695652173913, 0.16666666666667
75103, 1.9826086956522, 0.41086956521739, 0.13888888888889
75104, 1.9608695652174, 0.41086956521739, 0.11111111111111
75105, 1.9826086956522, 0.43695652173913, 0.11111111111111
75106, 1.9826086956522, 0.41086956521739, 0.083333333333333
75107, 1.9608695652174, 0.41086956521739, 0.055555555555556
75108, 1.9826086956522, 0.43695652173913, 0.055555555555556
75109, 1.9826086956522, 0.41086956521739, 0.027777777777778
75110, 2.0260869565217, 0.41086956521739, 0.47222222222222
75111, 2.004347826087, 0.41086956521739, 0.44444444444444
75112, 2.0260869565217, 0.43695652173913, 0.44444444444444
75113, 2.0260869565217, 0.41086956521739, 0.41666666666667
75114, 2.004347826087, 0.41086956521739, 0.38888888888889
75115, 2.0260869565217, 0.43695652173913, 0.38888888888889
75116, 2.0260869565217, 0.41086956521739, 0.36111111111111
75117, 2.004347826087, 0.41086956521739, 0.33333333333333
75118, 2.0260869565217, 0.43695652173913, 0.33333333333333
75119, 2.0260869565217, 0.41086956521739, 0.30555555555556
75120, 2.004347826087, 0.41086956521739, 0.27777777777778
75121, 2.0260869565217, 0.43695652173913, 0.27777777777778
75122, 2.0260869565217, 0.41086956521739, 0.25
75123, 2.004347826087, 0.41086956521739, 0.22222222222222
75124, 2.0260869565217, 0.43695652173913, 0.22222222222222
75125, 2.0260869565217, 0.41086956521739, 0.19444444444444
75126, 2.004347826087, 0.41086956521739, 0.16666666666667
75127, 2.0260869565217, 0.43695652173913, 0.16666666666667
75128, 2.0260869565217, 0.41086956521739, 0.13888888888889
75129, 2.004347826087, 0.41086956521739, 0.11111111111111
75130, 2.0260869565217, 0.43695652173913, 0.11111111111111
75131, 2.0260869565217, 0.41086956521739, 0.083333333333333
75132, 2.004347826087, 0.41086956521739, 0.055555555555556
75133, 2.0260869565217, 0.43695652173913, 0.055555555555556
75134, 2.0260869565217, 0.41086956521739, 0.027777777777778
75135, 2.0695652173913, 0.41086956521739, 0.47222222222222
75136, 2.0478260869565, 0.41086956521739, 0.44444444444444
75137, 2.0695652173913, 0.43695652173913, 0.44444444444444
75138, 2.0695652173913, 0.41086956521739, 0.41666666666667
75139, 2.0478260869565, 0.41086956521739, 0.38888888888889
75140, 2.0695652173913, 0.43695652173913, 0.38888888888889
75141, 2.0695652173913, 0.41086956521739, 0.36111111111111
75142, 2.0478260869565, 0.41086956521739, 0.33333333333333
75143, 2.0695652173913, 0.43695652173913, 0.33333333333333
75144, 2.0695652173913, 0.41086956521739, 0.30555555555556
75145, 2.0478260869565, 0.41086956521739, 0.27777777777778
75146, 2.0695652173913, 0.43695652173913, 0.27777777777778
75147, 2.0695652173913, 0.41086956521739, 0.25
75148, 2.0478260869565, 0.41086956521739, 0.22222222222222
75149, 2.0695652173913, 0.43695652173913, 0.22222222222222
75150, 2.0695652173913, 0.41086956521739, 0.19444444444444
75151, 2.0478260869565, 0.41086956521739, 0.16666666666667
75152, 2.0695652173913, 0.43695652173913, 0.16666666666667
75153, 2.0695652173913, 0.41086956521739, 0.13888888888889
75154, 2.0478260869565, 0.41086956521739, 0.11111111111111
75155, 2.0695652173913, 0.43695652173913, 0.11111111111111
75156, 2.0695652173913, 0.41086956521739, 0.083333333333333
75157, 2.0478260869565, 0.41086956521739, 0.055555555555556
75158, 2.0695652173913, 0.43695652173913, 0.055555555555556
75159, 2.0695652173913, 0.41086956521739, 0.027777777777778
75160, 2.1130434782609, 0.41086956521739, 0.47222222222222
75161, 2.0913043478261, 0.41086956521739, 0.44444444444444
75162, 2.1130434782609, 0.43695652173913, 0.44444444444444
75163, 2.1130434782609, 0.41086956521739, 0.41666666666667
75164, 2.0913043478261, 0.41086956521739, 0.38888888888889
75165, 2.1130434782609, 0.43695652173913, 0.38888888888889
75166, 2.1130434782609, 0.41086956521739, 0.36111111111111
75167, 2.0913043478261, 0.41086956521739, 0.33333333333333
75168, 2.1130434782609, 0.43695652173913, 0.33333333333333
75169, 2.1130434782609, 0.41086956521739, 0.30555555555556
75170, 2.0913043478261, 0.41086956521739, 0.27777777777778
75171, 2.1130434782609, 0.43695652173913, 0.27777777777778
75172, 2.1130434782609, 0.41086956521739, 0.25
75173, 2.0913043478261, 0.41086956521739, 0.22222222222222
75174, 2.1130434782609, 0.43695652173913, 0.22222222222222
75175, 2.1130434782609, 0.41086956521739, 0.19444444444444
75176, 2.0913043478261, 0.41086956521739, 0.16666666666667
75177, 2.1130434782609, 0.43695652173913, 0.16666666666667
75178, 2.1130434782609, 0.41086956521739, 0.13888888888889
75179, 2.0913043478261, 0.41086956521739, 0.11111111111111
75180, 2.1130434782609, 0.43695652173913, 0.11111111111111
75181, 2.1130434782609, 0.41086956521739, 0.083333333333333
75182, 2.0913043478261, 0.41086956521739, 0.055555555555556
75183, 2.1130434782609, 0.43695652173913, 0.055555555555556
75184, 2.1130434782609, 0.41086956521739, 0.027777777777778
75185, 2.1565217391304, 0.41086956521739, 0.47222222222222
75186, 2.1347826086957, 0.41086956521739, 0.44444444444444
75187, 2.1565217391304, 0.43695652173913, 0.44444444444444
75188, 2.1565217391304, 0.41086956521739, 0.41666666666667
75189, 2.1347826086957, 0.41086956521739, 0.38888888888889
75190, 2.1565217391304, 0.43695652173913, 0.38888888888889
75191, 2.1565217391304, 0.41086956521739, 0.36111111111111
75192, 2.1347826086957, 0.41086956521739, 0.33333333333333
75193, 2.1565217391304, 0.43695652173913, 0.33333333333333
75194, 2.1565217391304, 0.41086956521739, 0.30555555555556
75195, 2.1347826086957, 0.41086956521739, 0.27777777777778
75196, 2.1565217391304, 0.43695652173913, 0.27777777777778
75197, 2.1565217391304, 0.41086956521739, 0.25
75198, 2.1347826086957, 0.41086956521739, 0.22222222222222
75199, 2.1565217391304, 0.43695652173913, 0.22222222222222
75200, 2.1565217391304, 0.41086956521739, 0.19444444444444
75201, 2.1347826086957, 0.41086956521739, 0.16666666666667
75202, 2.1565217391304, 0.43695652173913, 0.16666666666667
75203, 2.1565217391304, 0.41086956521739, 0.13888888888889
75204, 2.1347826086957, 0.41086956521739, 0.11111111111111
75205, 2.1565217391304, 0.43695652173913, 0.11111111111111
75206, 2.1565217391304, 0.41086956521739, 0.083333333333333
75207, 2.1347826086957, 0.41086956521739, 0.055555555555556
75208, 2.1565217391304, 0.43695652173913, 0.055555555555556
75209, 2.1565217391304, 0.41086956521739, 0.027777777777778
75210, 2.1782608695652, 0.41086956521739, 0.44444444444444
75211, 2.1782608695652, 0.41086956521739, 0.38888888888889
75212, 2.1782608695652, 0.41086956521739, 0.33333333333333
75213, 2.1782608695652, 0.41086956521739, 0.27777777777778
75214, 2.1782608695652, 0.41086956521739, 0.22222222222222
75215, 2.1782608695652, 0.41086956521739, 0.16666666666667
75216, 2.1782608695652, 0.41086956521739, 0.11111111111111
75217, 2.1782608695652, 0.41086956521739, 0.055555555555556
75218, 1.2434782608696, 0.35869565217391, 0.47222222222222
75219, 1.2217391304348, 0.35869565217391, 0.44444444444444
75220, 1.2434782608696, 0.38478260869565, 0.44444444444444
75221, 1.2434782608696, 0.35869565217391, 0.41666666666667
75222, 1.2217391304348, 0.35869565217391, 0.38888888888889
75223, 1.2434782608696, 0.38478260869565, 0.38888888888889
75224, 1.2434782608696, 0.35869565217391, 0.36111111111111
75225, 1.2217391304348, 0.35869565217391, 0.33333333333333
75226, 1.2434782608696, 0.38478260869565, 0.33333333333333
75227, 1.2434782608696, 0.35869565217391, 0.30555555555556
75228, 1.2217391304348, 0.35869565217391, 0.27777777777778
75229, 1.2434782608696, 0.38478260869565, 0.27777777777778
75230, 1.2434782608696, 0.35869565217391, 0.25
75231, 1.2217391304348, 0.35869565217391, 0.22222222222222
75232, 1.2434782608696, 0.38478260869565, 0.22222222222222
75233, 1.2434782608696, 0.35869565217391, 0.19444444444444
75234, 1.2217391304348, 0.35869565217391, 0.16666666666667
75235, 1.2434782608696, 0.38478260869565, 0.16666666666667
75236, 1.2434782608696, 0.35869565217391, 0.13888888888889
75237, 1.2217391304348, 0.35869565217391, 0.11111111111111
75238, 1.2434782608696, 0.38478260869565, 0.11111111111111
75239, 1.2434782608696, 0.35869565217391, 0.083333333333333
75240, 1.2217391304348, 0.35869565217391, 0.055555555555556
75241, 1.2434782608696, 0.38478260869565, 0.055555555555556
75242, 1.2434782608696, 0.35869565217391, 0.027777777777778
75243, 1.2869565217391, 0.35869565217391, 0.47222222222222
75244, 1.2652173913043, 0.35869565217391, 0.44444444444444
75245, 1.2869565217391, 0.38478260869565, 0.44444444444444
75246, 1.2869565217391, 0.35869565217391, 0.41666666666667
75247, 1.2652173913043, 0.35869565217391, 0.38888888888889
75248, 1.2869565217391, 0.38478260869565, 0.38888888888889
75249, 1.2869565217391, 0.35869565217391, 0.36111111111111
75250, 1.2652173913043, 0.35869565217391, 0.33333333333333
75251, 1.2869565217391, 0.38478260869565, 0.33333333333333
75252, 1.2869565217391, 0.35869565217391, 0.30555555555556
75253, 1.2652173913043, 0.35869565217391, 0.27777777777778
75254, 1.2869565217391, 0.38478260869565, 0.27777777777778
75255, 1.2869565217391, 0.35869565217391, 0.25
75256, 1.2652173913043, 0.35869565217391, 0.22222222222222
75257, 1.2869565217391, 0.38478260869565, 0.22222222222222
75258, 1.2869565217391, 0.35869565217391, 0.19444444444444
75259, 1.2652173913043, 0.35869565217391, 0.16666666666667
75260, 1.2869565217391, 0.38478260869565, 0.16666666666667
75261, 1.2869565217391, 0.35869565217391, 0.13888888888889
75262, 1.2652173913043, 0.35869565217391, 0.11111111111111
75263, 1.2869565217391, 0.38478260869565, 0.11111111111111
75264, 1.2869565217391, 0.35869565217391, 0.083333333333333
75265, 1.2652173913043, 0.35869565217391, 0.055555555555556
75266, 1.2869565217391, 0.38478260869565, 0.055555555555556
75267, 1.2869565217391, 0.35869565217391, 0.027777777777778
75268, 1.3304347826087, 0.35869565217391, 0.47222222222222
75269, 1.3086956521739, 0.35869565217391, 0.44444444444444
75270, 1.3304347826087, 0.38478260869565, 0.44444444444444
75271, 1.3304347826087, 0.35869565217391, 0.41666666666667
75272, 1.3086956521739, 0.35869565217391, 0.38888888888889
75273, 1.3304347826087, 0.38478260869565, 0.38888888888889
75274, 1.3304347826087, 0.35869565217391, 0.36111111111111
75275, 1.3086956521739, 0.35869565217391, 0.33333333333333
75276, 1.3304347826087, 0.38478260869565, 0.33333333333333
75277, 1.3304347826087, 0.35869565217391, 0.30555555555556
75278, 1.3086956521739, 0.35869565217391, 0.27777777777778
75279, 1.3304347826087, 0.38478260869565, 0.27777777777778
75280, 1.3304347826087, 0.35869565217391, 0.25
75281, 1.3086956521739, 0.35869565217391, 0.22222222222222
75282, 1.3304347826087, 0.38478260869565, 0.22222222222222
75283, 1.3304347826087, 0.35869565217391, 0.19444444444444
75284, 1.3086956521739, 0.35869565217391, 0.16666666666667
75285, 1.3304347826087, 0.38478260869565, 0.16666666666667
75286, 1.3304347826087, 0.35869565217391, 0.13888888888889
75287, 1.3086956521739, 0.35869565217391, 0.11111111111111
75288, 1.3304347826087, 0.38478260869565, 0.11111111111111
75289, 1.3304347826087, 0.35869565217391, 0.083333333333333
75290, 1.3086956521739, 0.35869565217391, 0.055555555555556
75291, 1.3304347826087, 0.38478260869565, 0.055555555555556
75292, 1.3304347826087, 0.35869565217391, 0.027777777777778
75293, 1.3739130434783, 0.35869565217391, 0.47222222222222
75294, 1.3521739130435, 0.35869565217391, 0.44444444444444
75295, 1.3739130434783, 0.38478260869565, 0.44444444444444
75296, 1.3739130434783, 0.35869565217391, 0.41666666666667
75297, 1.3521739130435, 0.35869565217391, 0.38888888888889
75298, 1.3739130434783, 0.38478260869565, 0.38888888888889
75299, 1.3739130434783, 0.35869565217391, 0.36111111111111
75300, 1.3521739130435, 0.35869565217391, 0.33333333333333
75301, 1.3739130434783, 0.38478260869565, 0.33333333333333
75302, 1.3739130434783, 0.35869565217391, 0.30555555555556
75303, 1.3521739130435, 0.35869565217391, 0.27777777777778
75304, 1.3739130434783, 0.38478260869565, 0.27777777777778
75305, 1.3739130434783, 0.35869565217391, 0.25
75306, 1.3521739130435, 0.35869565217391, 0.22222222222222
75307, 1.3739130434783, 0.38478260869565, 0.22222222222222
75308, 1.3739130434783, 0.35869565217391, 0.19444444444444
75309, 1.3521739130435, 0.35869565217391, 0.16666666666667
75310, 1.3739130434783, 0.38478260869565, 0.16666666666667
75311, 1.3739130434783, 0.35869565217391, 0.13888888888889
75312, 1.3521739130435, 0.35869565217391, 0.11111111111111
75313, 1.3739130434783, 0.38478260869565, 0.11111111111111
75314, 1.3739130434783, 0.35869565217391, 0.083333333333333
75315, 1.3521739130435, 0.35869565217391, 0.055555555555556
75316, 1.3739130434783, 0.38478260869565, 0.055555555555556
75317, 1.3739130434783, 0.35869565217391, 0.027777777777778
75318, 1.4173913043478, 0.35869565217391, 0.47222222222222
75319, 1.395652173913, 0.35869565217391, 0.44444444444444
75320, 1.4173913043478, 0.38478260869565, 0.44444444444444
75321, 1.4173913043478, 0.35869565217391, 0.41666666666667
75322, 1.395652173913, 0.35869565217391, 0.38888888888889
75323, 1.4173913043478, 0.38478260869565, 0.38888888888889
75324, 1.4173913043478, 0.35869565217391, 0.36111111111111
75325, 1.395652173913, 0.35869565217391, 0.33333333333333
75326, 1.4173913043478, 0.38478260869565, 0.33333333333333
75327, 1.4173913043478, 0.35869565217391, 0.30555555555556
75328, 1.395652173913, 0.35869565217391, 0.27777777777778
75329, 1.4173913043478, 0.38478260869565, 0.27777777777778
75330, 1.4173913043478, 0.35869565217391, 0.25
75331, 1.395652173913, 0.35869565217391, 0.22222222222222
75332, 1.4173913043478, 0.38478260869565, 0.22222222222222
75333, 1.4173913043478, 0.35869565217391, 0.19444444444444
75334, 1.395652173913, 0.35869565217391, 0.16666666666667
75335, 1.4173913043478, 0.38478260869565, 0.16666666666667
75336, 1.4173913043478, 0.35869565217391, 0.13888888888889
75337, 1.395652173913, 0.35869565217391, 0.11111111111111
75338, 1.4173913043478, 0.38478260869565, 0.11111111111111
75339, 1.4173913043478, 0.35869565217391, 0.083333333333333
75340, 1.395652173913, 0.35869565217391, 0.055555555555556
75341, 1.4173913043478, 0.38478260869565, 0.055555555555556
75342, 1.4173913043478, 0.35869565217391, 0.027777777777778
75343, 1.4608695652174, 0.35869565217391, 0.47222222222222
75344, 1.4391304347826, 0.35869565217391, 0.44444444444444
75345, 1.4608695652174, 0.38478260869565, 0.44444444444444
75346, 1.4608695652174, 0.35869565217391, 0.41666666666667
75347, 1.4391304347826, 0.35869565217391, 0.38888888888889
75348, 1.4608695652174, 0.38478260869565, 0.38888888888889
75349, 1.4608695652174, 0.35869565217391, 0.36111111111111
75350, 1.4391304347826, 0.35869565217391, 0.33333333333333
75351, 1.4608695652174, 0.38478260869565, 0.33333333333333
75352, 1.4608695652174, 0.35869565217391, 0.30555555555556
75353, 1.4391304347826, 0.35869565217391, 0.27777777777778
75354, 1.4608695652174, 0.38478260869565, 0.27777777777778
75355, 1.4608695652174, 0.35869565217391, 0.25
75356, 1.4391304347826, 0.35869565217391, 0.22222222222222
75357, 1.4608695652174, 0.38478260869565, 0.22222222222222
75358, 1.4608695652174, 0.35869565217391, 0.19444444444444
75359, 1.4391304347826, 0.35869565217391, 0.16666666666667
75360, 1.4608695652174, 0.38478260869565, 0.16666666666667
75361, 1.4608695652174, 0.35869565217391, 0.13888888888889
75362, 1.4391304347826, 0.35869565217391, 0.11111111111111
75363, 1.4608695652174, 0.38478260869565, 0.11111111111111
75364, 1.4608695652174, 0.35869565217391, 0.083333333333333
75365, 1.4391304347826, 0.35869565217391, 0.055555555555556
75366, 1.4608695652174, 0.38478260869565, 0.055555555555556
75367, 1.4608695652174, 0.35869565217391, 0.027777777777778
75368, 1.504347826087, 0.35869565217391, 0.47222222222222
75369, 1.4826086956522, 0.35869565217391, 0.44444444444444
75370, 1.504347826087, 0.38478260869565, 0.44444444444444
75371, 1.504347826087, 0.35869565217391, 0.41666666666667
75372, 1.4826086956522, 0.35869565217391, 0.38888888888889
75373, 1.504347826087, 0.38478260869565, 0.38888888888889
75374, 1.504347826087, 0.35869565217391, 0.36111111111111
75375, 1.4826086956522, 0.35869565217391, 0.33333333333333
75376, 1.504347826087, 0.38478260869565, 0.33333333333333
75377, 1.504347826087, 0.35869565217391, 0.30555555555556
75378, 1.4826086956522, 0.35869565217391, 0.27777777777778
75379, 1.504347826087, 0.38478260869565, 0.27777777777778
75380, 1.504347826087, 0.35869565217391, 0.25
75381, 1.4826086956522, 0.35869565217391, 0.22222222222222
75382, 1.504347826087, 0.38478260869565, 0.22222222222222
75383, 1.504347826087, 0.35869565217391, 0.19444444444444
75384, 1.4826086956522, 0.35869565217391, 0.16666666666667
75385, 1.504347826087, 0.38478260869565, 0.16666666666667
75386, 1.504347826087, 0.35869565217391, 0.13888888888889
75387, 1.4826086956522, 0.35869565217391, 0.11111111111111
75388, 1.504347826087, 0.38478260869565, 0.11111111111111
75389, 1.504347826087, 0.35869565217391, 0.083333333333333
75390, 1.4826086956522, 0.35869565217391, 0.055555555555556
75391, 1.504347826087, 0.38478260869565, 0.055555555555556
75392, 1.504347826087, 0.35869565217391, 0.027777777777778
75393, 1.5478260869565, 0.35869565217391, 0.47222222222222
75394, 1.5260869565217, 0.35869565217391, 0.44444444444444
75395, 1.5478260869565, 0.38478260869565, 0.44444444444444
75396, 1.5478260869565, 0.35869565217391, 0.41666666666667
75397, 1.5260869565217, 0.35869565217391, 0.38888888888889
75398, 1.5478260869565, 0.38478260869565, 0.38888888888889
75399, 1.5478260869565, 0.35869565217391, 0.36111111111111
75400, 1.5260869565217, 0.35869565217391, 0.33333333333333
75401, 1.5478260869565, 0.38478260869565, 0.33333333333333
75402, 1.5478260869565, 0.35869565217391, 0.30555555555556
75403, 1.5260869565217, 0.35869565217391, 0.27777777777778
75404, 1.5478260869565, 0.38478260869565, 0.27777777777778
75405, 1.5478260869565, 0.35869565217391, 0.25
75406, 1.5260869565217, 0.35869565217391, 0.22222222222222
75407, 1.5478260869565, 0.38478260869565, 0.22222222222222
75408, 1.5478260869565, 0.35869565217391, 0.19444444444444
75409, 1.5260869565217, 0.35869565217391, 0.16666666666667
75410, 1.5478260869565, 0.38478260869565, 0.16666666666667
75411, 1.5478260869565, 0.35869565217391, 0.13888888888889
75412, 1.5260869565217, 0.35869565217391, 0.11111111111111
75413, 1.5478260869565, 0.38478260869565, 0.11111111111111
75414, 1.5478260869565, 0.35869565217391, 0.083333333333333
75415, 1.5260869565217, 0.35869565217391, 0.055555555555556
75416, 1.5478260869565, 0.38478260869565, 0.055555555555556
75417, 1.5478260869565, 0.35869565217391, 0.027777777777778
75418, 1.5913043478261, 0.35869565217391, 0.47222222222222
75419, 1.5695652173913, 0.35869565217391, 0.44444444444444
75420, 1.5913043478261, 0.38478260869565, 0.44444444444444
75421, 1.5913043478261, 0.35869565217391, 0.41666666666667
75422, 1.5695652173913, 0.35869565217391, 0.38888888888889
75423, 1.5913043478261, 0.38478260869565, 0.38888888888889
75424, 1.5913043478261, 0.35869565217391, 0.36111111111111
75425, 1.5695652173913, 0.35869565217391, 0.33333333333333
75426, 1.5913043478261, 0.38478260869565, 0.33333333333333
75427, 1.5913043478261, 0.35869565217391, 0.30555555555556
75428, 1.5695652173913, 0.35869565217391, 0.27777777777778
75429, 1.5913043478261, 0.38478260869565, 0.27777777777778
75430, 1.5913043478261, 0.35869565217391, 0.25
75431, 1.5695652173913, 0.35869565217391, 0.22222222222222
75432, 1.5913043478261, 0.38478260869565, 0.22222222222222
75433, 1.5913043478261, 0.35869565217391, 0.19444444444444
75434, 1.5695652173913, 0.35869565217391, 0.16666666666667
75435, 1.5913043478261, 0.38478260869565, 0.16666666666667
75436, 1.5913043478261, 0.35869565217391, 0.13888888888889
75437, 1.5695652173913, 0.35869565217391, 0.11111111111111
75438, 1.5913043478261, 0.38478260869565, 0.11111111111111
75439, 1.5913043478261, 0.35869565217391, 0.083333333333333
75440, 1.5695652173913, 0.35869565217391, 0.055555555555556
75441, 1.5913043478261, 0.38478260869565, 0.055555555555556
75442, 1.5913043478261, 0.35869565217391, 0.027777777777778
75443, 1.6347826086957, 0.35869565217391, 0.47222222222222
75444, 1.6130434782609, 0.35869565217391, 0.44444444444444
75445, 1.6347826086957, 0.38478260869565, 0.44444444444444
75446, 1.6347826086957, 0.35869565217391, 0.41666666666667
75447, 1.6130434782609, 0.35869565217391, 0.38888888888889
75448, 1.6347826086957, 0.38478260869565, 0.38888888888889
75449, 1.6347826086957, 0.35869565217391, 0.36111111111111
75450, 1.6130434782609, 0.35869565217391, 0.33333333333333
75451, 1.6347826086957, 0.38478260869565, 0.33333333333333
75452, 1.6347826086957, 0.35869565217391, 0.30555555555556
75453, 1.6130434782609, 0.35869565217391, 0.27777777777778
75454, 1.6347826086957, 0.38478260869565, 0.27777777777778
75455, 1.6347826086957, 0.35869565217391, 0.25
75456, 1.6130434782609, 0.35869565217391, 0.22222222222222
75457, 1.6347826086957, 0.38478260869565, 0.22222222222222
75458, 1.6347826086957, 0.35869565217391, 0.19444444444444
75459, 1.6130434782609, 0.35869565217391, 0.16666666666667
75460, 1.6347826086957, 0.38478260869565, 0.16666666666667
75461, 1.6347826086957, 0.35869565217391, 0.13888888888889
75462, 1.6130434782609, 0.35869565217391, 0.11111111111111
75463, 1.6347826086957, 0.38478260869565, 0.11111111111111
75464, 1.6347826086957, 0.35869565217391, 0.083333333333333
75465, 1.6130434782609, 0.35869565217391, 0.055555555555556
75466, 1.6347826086957, 0.38478260869565, 0.055555555555556
75467, 1.6347826086957, 0.35869565217391, 0.027777777777778
75468, 1.6782608695652, 0.35869565217391, 0.47222222222222
75469, 1.6565217391304, 0.35869565217391, 0.44444444444444
75470, 1.6782608695652, 0.38478260869565, 0.44444444444444
75471, 1.6782608695652, 0.35869565217391, 0.41666666666667
75472, 1.6565217391304, 0.35869565217391, 0.38888888888889
75473, 1.6782608695652, 0.38478260869565, 0.38888888888889
75474, 1.6782608695652, 0.35869565217391, 0.36111111111111
75475, 1.6565217391304, 0.35869565217391, 0.33333333333333
75476, 1.6782608695652, 0.38478260869565, 0.33333333333333
75477, 1.6782608695652, 0.35869565217391, 0.30555555555556
75478, 1.6565217391304, 0.35869565217391, 0.27777777777778
75479, 1.6782608695652, 0.38478260869565, 0.27777777777778
75480, 1.6782608695652, 0.35869565217391, 0.25
75481, 1.6565217391304, 0.35869565217391, 0.22222222222222
75482, 1.6782608695652, 0.38478260869565, 0.22222222222222
75483, 1.6782608695652, 0.35869565217391, 0.19444444444444
75484, 1.6565217391304, 0.35869565217391, 0.16666666666667
75485, 1.6782608695652, 0.38478260869565, 0.16666666666667
75486, 1.6782608695652, 0.35869565217391, 0.13888888888889
75487, 1.6565217391304, 0.35869565217391, 0.11111111111111
75488, 1.6782608695652, 0.38478260869565, 0.11111111111111
75489, 1.6782608695652, 0.35869565217391, 0.083333333333333
75490, 1.6565217391304, 0.35869565217391, 0.055555555555556
75491, 1.6782608695652, 0.38478260869565, 0.055555555555556
75492, 1.6782608695652, 0.35869565217391, 0.027777777777778
75493, 1.7217391304348, 0.35869565217391, 0.47222222222222
75494, 1.7, 0.35869565217391, 0.44444444444444
75495, 1.7217391304348, 0.38478260869565, 0.44444444444444
75496, 1.7217391304348, 0.35869565217391, 0.41666666666667
75497, 1.7, 0.35869565217391, 0.38888888888889
75498, 1.7217391304348, 0.38478260869565, 0.38888888888889
75499, 1.7217391304348, 0.35869565217391, 0.36111111111111
75500, 1.7, 0.35869565217391, 0.33333333333333
75501, 1.7217391304348, 0.38478260869565, 0.33333333333333
75502, 1.7217391304348, 0.35869565217391, 0.30555555555556
75503, 1.7, 0.35869565217391, 0.27777777777778
75504, 1.7217391304348, 0.38478260869565, 0.27777777777778
75505, 1.7217391304348, 0.35869565217391, 0.25
75506, 1.7, 0.35869565217391, 0.22222222222222
75507, 1.7217391304348, 0.38478260869565, 0.22222222222222
75508, 1.7217391304348, 0.35869565217391, 0.19444444444444
75509, 1.7, 0.35869565217391, 0.16666666666667
75510, 1.7217391304348, 0.38478260869565, 0.16666666666667
75511, 1.7217391304348, 0.35869565217391, 0.13888888888889
75512, 1.7, 0.35869565217391, 0.11111111111111
75513, 1.7217391304348, 0.38478260869565, 0.11111111111111
75514, 1.7217391304348, 0.35869565217391, 0.083333333333333
75515, 1.7, 0.35869565217391, 0.055555555555556
75516, 1.7217391304348, 0.38478260869565, 0.055555555555556
75517, 1.7217391304348, 0.35869565217391, 0.027777777777778
75518, 1.7652173913043, 0.35869565217391, 0.47222222222222
75519, 1.7434782608696, 0.35869565217391, 0.44444444444444
75520, 1.7652173913043, 0.38478260869565, 0.44444444444444
75521, 1.7652173913043, 0.35869565217391, 0.41666666666667
75522, 1.7434782608696, 0.35869565217391, 0.38888888888889
75523, 1.7652173913043, 0.38478260869565, 0.38888888888889
75524, 1.7652173913043, 0.35869565217391, 0.36111111111111
75525, 1.7434782608696, 0.35869565217391, 0.33333333333333
75526, 1.7652173913043, 0.38478260869565, 0.33333333333333
75527, 1.7652173913043, 0.35869565217391, 0.30555555555556
75528, 1.7434782608696, 0.35869565217391, 0.27777777777778
75529, 1.7652173913043, 0.38478260869565, 0.27777777777778
75530, 1.7652173913043, 0.35869565217391, 0.25
75531, 1.7434782608696, 0.35869565217391, 0.22222222222222
75532, 1.7652173913043, 0.38478260869565, 0.22222222222222
75533, 1.7652173913043, 0.35869565217391, 0.19444444444444
75534, 1.7434782608696, 0.35869565217391, 0.16666666666667
75535, 1.7652173913043, 0.38478260869565, 0.16666666666667
75536, 1.7652173913043, 0.35869565217391, 0.13888888888889
75537, 1.7434782608696, 0.35869565217391, 0.11111111111111
75538, 1.7652173913043, 0.38478260869565, 0.11111111111111
75539, 1.7652173913043, 0.35869565217391, 0.083333333333333
75540, 1.7434782608696, 0.35869565217391, 0.055555555555556
75541, 1.7652173913043, 0.38478260869565, 0.055555555555556
75542, 1.7652173913043, 0.35869565217391, 0.027777777777778
75543, 1.8086956521739, 0.35869565217391, 0.47222222222222
75544, 1.7869565217391, 0.35869565217391, 0.44444444444444
75545, 1.8086956521739, 0.38478260869565, 0.44444444444444
75546, 1.8086956521739, 0.35869565217391, 0.41666666666667
75547, 1.7869565217391, 0.35869565217391, 0.38888888888889
75548, 1.8086956521739, 0.38478260869565, 0.38888888888889
75549, 1.8086956521739, 0.35869565217391, 0.36111111111111
75550, 1.7869565217391, 0.35869565217391, 0.33333333333333
75551, 1.8086956521739, 0.38478260869565, 0.33333333333333
75552, 1.8086956521739, 0.35869565217391, 0.30555555555556
75553, 1.7869565217391, 0.35869565217391, 0.27777777777778
75554, 1.8086956521739, 0.38478260869565, 0.27777777777778
75555, 1.8086956521739, 0.35869565217391, 0.25
75556, 1.7869565217391, 0.35869565217391, 0.22222222222222
75557, 1.8086956521739, 0.38478260869565, 0.22222222222222
75558, 1.8086956521739, 0.35869565217391, 0.19444444444444
75559, 1.7869565217391, 0.35869565217391, 0.16666666666667
75560, 1.8086956521739, 0.38478260869565, 0.16666666666667
75561, 1.8086956521739, 0.35869565217391, 0.13888888888889
75562, 1.7869565217391, 0.35869565217391, 0.11111111111111
75563, 1.8086956521739, 0.38478260869565, 0.11111111111111
75564, 1.8086956521739, 0.35869565217391, 0.083333333333333
75565, 1.7869565217391, 0.35869565217391, 0.055555555555556
75566, 1.8086956521739, 0.38478260869565, 0.055555555555556
75567, 1.8086956521739, 0.35869565217391, 0.027777777777778
75568, 1.8521739130435, 0.35869565217391, 0.47222222222222
75569, 1.8304347826087, 0.35869565217391, 0.44444444444444
75570, 1.8521739130435, 0.38478260869565, 0.44444444444444
75571, 1.8521739130435, 0.35869565217391, 0.41666666666667
75572, 1.8304347826087, 0.35869565217391, 0.38888888888889
75573, 1.8521739130435, 0.38478260869565, 0.38888888888889
75574, 1.8521739130435, 0.35869565217391, 0.36111111111111
75575, 1.8304347826087, 0.35869565217391, 0.33333333333333
75576, 1.8521739130435, 0.38478260869565, 0.33333333333333
75577, 1.8521739130435, 0.35869565217391, 0.30555555555556
75578, 1.8304347826087, 0.35869565217391, 0.27777777777778
75579, 1.8521739130435, 0.38478260869565, 0.27777777777778
75580, 1.8521739130435, 0.35869565217391, 0.25
75581, 1.8304347826087, 0.35869565217391, 0.22222222222222
75582, 1.8521739130435, 0.38478260869565, 0.22222222222222
75583, 1.8521739130435, 0.35869565217391, 0.19444444444444
75584, 1.8304347826087, 0.35869565217391, 0.16666666666667
75585, 1.8521739130435, 0.38478260869565, 0.16666666666667
75586, 1.8521739130435, 0.35869565217391, 0.13888888888889
75587, 1.8304347826087, 0.35869565217391, 0.11111111111111
75588, 1.8521739130435, 0.38478260869565, 0.11111111111111
75589, 1.8521739130435, 0.35869565217391, 0.083333333333333
75590, 1.8304347826087, 0.35869565217391, 0.055555555555556
75591, 1.8521739130435, 0.38478260869565, 0.055555555555556
75592, 1.8521739130435, 0.35869565217391, 0.027777777777778
75593, 1.895652173913, 0.35869565217391, 0.47222222222222
75594, 1.8739130434783, 0.35869565217391, 0.44444444444444
75595, 1.895652173913, 0.38478260869565, 0.44444444444444
75596, 1.895652173913, 0.35869565217391, 0.41666666666667
75597, 1.8739130434783, 0.35869565217391, 0.38888888888889
75598, 1.895652173913, 0.38478260869565, 0.38888888888889
75599, 1.895652173913, 0.35869565217391, 0.36111111111111
75600, 1.8739130434783, 0.35869565217391, 0.33333333333333
75601, 1.895652173913, 0.38478260869565, 0.33333333333333
75602, 1.895652173913, 0.35869565217391, 0.30555555555556
75603, 1.8739130434783, 0.35869565217391, 0.27777777777778
75604, 1.895652173913, 0.38478260869565, 0.27777777777778
75605, 1.895652173913, 0.35869565217391, 0.25
75606, 1.8739130434783, 0.35869565217391, 0.22222222222222
75607, 1.895652173913, 0.38478260869565, 0.22222222222222
75608, 1.895652173913, 0.35869565217391, 0.19444444444444
75609, 1.8739130434783, 0.35869565217391, 0.16666666666667
75610, 1.895652173913, 0.38478260869565, 0.16666666666667
75611, 1.895652173913, 0.35869565217391, 0.13888888888889
75612, 1.8739130434783, 0.35869565217391, 0.11111111111111
75613, 1.895652173913, 0.38478260869565, 0.11111111111111
75614, 1.895652173913, 0.35869565217391, 0.083333333333333
75615, 1.8739130434783, 0.35869565217391, 0.055555555555556
75616, 1.895652173913, 0.38478260869565, 0.055555555555556
75617, 1.895652173913, 0.35869565217391, 0.027777777777778
75618, 1.9391304347826, 0.35869565217391, 0.47222222222222
75619, 1.9173913043478, 0.35869565217391, 0.44444444444444
75620, 1.9391304347826, 0.38478260869565, 0.44444444444444
75621, 1.9391304347826, 0.35869565217391, 0.41666666666667
75622, 1.9173913043478, 0.35869565217391, 0.38888888888889
75623, 1.9391304347826, 0.38478260869565, 0.38888888888889
75624, 1.9391304347826, 0.35869565217391, 0.36111111111111
75625, 1.9173913043478, 0.35869565217391, 0.33333333333333
75626, 1.9391304347826, 0.38478260869565, 0.33333333333333
75627, 1.9391304347826, 0.35869565217391, 0.30555555555556
75628, 1.9173913043478, 0.35869565217391, 0.27777777777778
75629, 1.9391304347826, 0.38478260869565, 0.27777777777778
75630, 1.9391304347826, 0.35869565217391, 0.25
75631, 1.9173913043478, 0.35869565217391, 0.22222222222222
75632, 1.9391304347826, 0.38478260869565, 0.22222222222222
75633, 1.9391304347826, 0.35869565217391, 0.19444444444444
75634, 1.9173913043478, 0.35869565217391, 0.16666666666667
75635, 1.9391304347826, 0.38478260869565, 0.16666666666667
75636, 1.9391304347826, 0.35869565217391, 0.13888888888889
75637, 1.9173913043478, 0.35869565217391, 0.11111111111111
75638, 1.9391304347826, 0.38478260869565, 0.11111111111111
75639, 1.9391304347826, 0.35869565217391, 0.083333333333333
75640, 1.9173913043478, 0.35869565217391, 0.055555555555556
75641, 1.9391304347826, 0.38478260869565, 0.055555555555556
75642, 1.9391304347826, 0.35869565217391, 0.027777777777778
75643, 1.9826086956522, 0.35869565217391, 0.47222222222222
75644, 1.9608695652174, 0.35869565217391, 0.44444444444444
75645, 1.9826086956522, 0.38478260869565, 0.44444444444444
75646, 1.9826086956522, 0.35869565217391, 0.41666666666667
75647, 1.9608695652174, 0.35869565217391, 0.38888888888889
75648, 1.9826086956522, 0.38478260869565, 0.38888888888889
75649, 1.9826086956522, 0.35869565217391, 0.36111111111111
75650, 1.9608695652174, 0.35869565217391, 0.33333333333333
75651, 1.9826086956522, 0.38478260869565, 0.33333333333333
75652, 1.9826086956522, 0.35869565217391, 0.30555555555556
75653, 1.9608695652174, 0.35869565217391, 0.27777777777778
75654, 1.9826086956522, 0.38478260869565, 0.27777777777778
75655, 1.9826086956522, 0.35869565217391, 0.25
75656, 1.9608695652174, 0.35869565217391, 0.22222222222222
75657, 1.9826086956522, 0.38478260869565, 0.22222222222222
75658, 1.9826086956522, 0.35869565217391, 0.19444444444444
75659, 1.9608695652174, 0.35869565217391, 0.16666666666667
75660, 1.9826086956522, 0.38478260869565, 0.16666666666667
75661, 1.9826086956522, 0.35869565217391, 0.13888888888889
75662, 1.9608695652174, 0.35869565217391, 0.11111111111111
75663, 1.9826086956522, 0.38478260869565, 0.11111111111111
75664, 1.9826086956522, 0.35869565217391, 0.083333333333333
75665, 1.9608695652174, 0.35869565217391, 0.055555555555556
75666, 1.9826086956522, 0.38478260869565, 0.055555555555556
75667, 1.9826086956522, 0.35869565217391, 0.027777777777778
75668, 2.0260869565217, 0.35869565217391, 0.47222222222222
75669, 2.004347826087, 0.35869565217391, 0.44444444444444
75670, 2.0260869565217, 0.38478260869565, 0.44444444444444
75671, 2.0260869565217, 0.35869565217391, 0.41666666666667
75672, 2.004347826087, 0.35869565217391, 0.38888888888889
75673, 2.0260869565217, 0.38478260869565, 0.38888888888889
75674, 2.0260869565217, 0.35869565217391, 0.36111111111111
75675, 2.004347826087, 0.35869565217391, 0.33333333333333
75676, 2.0260869565217, 0.38478260869565, 0.33333333333333
75677, 2.0260869565217, 0.35869565217391, 0.30555555555556
75678, 2.004347826087, 0.35869565217391, 0.27777777777778
75679, 2.0260869565217, 0.38478260869565, 0.27777777777778
75680, 2.0260869565217, 0.35869565217391, 0.25
75681, 2.004347826087, 0.35869565217391, 0.22222222222222
75682, 2.0260869565217, 0.38478260869565, 0.22222222222222
75683, 2.0260869565217, 0.35869565217391, 0.19444444444444
75684, 2.004347826087, 0.35869565217391, 0.16666666666667
75685, 2.0260869565217, 0.38478260869565, 0.16666666666667
75686, 2.0260869565217, 0.35869565217391, 0.13888888888889
75687, 2.004347826087, 0.35869565217391, 0.11111111111111
75688, 2.0260869565217, 0.38478260869565, 0.11111111111111
75689, 2.0260869565217, 0.35869565217391, 0.083333333333333
75690, 2.004347826087, 0.35869565217391, 0.055555555555556
75691, 2.0260869565217, 0.38478260869565, 0.055555555555556
75692, 2.0260869565217, 0.35869565217391, 0.027777777777778
75693, 2.0695652173913, 0.35869565217391, 0.47222222222222
75694, 2.0478260869565, 0.35869565217391, 0.44444444444444
75695, 2.0695652173913, 0.38478260869565, 0.44444444444444
75696, 2.0695652173913, 0.35869565217391, 0.41666666666667
75697, 2.0478260869565, 0.35869565217391, 0.38888888888889
75698, 2.0695652173913, 0.38478260869565, 0.38888888888889
75699, 2.0695652173913, 0.35869565217391, 0.36111111111111
75700, 2.0478260869565, 0.35869565217391, 0.33333333333333
75701, 2.0695652173913, 0.38478260869565, 0.33333333333333
75702, 2.0695652173913, 0.35869565217391, 0.30555555555556
75703, 2.0478260869565, 0.35869565217391, 0.27777777777778
75704, 2.0695652173913, 0.38478260869565, 0.27777777777778
75705, 2.0695652173913, 0.35869565217391, 0.25
75706, 2.0478260869565, 0.35869565217391, 0.22222222222222
75707, 2.0695652173913, 0.38478260869565, 0.22222222222222
75708, 2.0695652173913, 0.35869565217391, 0.19444444444444
75709, 2.0478260869565, 0.35869565217391, 0.16666666666667
75710, 2.0695652173913, 0.38478260869565, 0.16666666666667
75711, 2.0695652173913, 0.35869565217391, 0.13888888888889
75712, 2.0478260869565, 0.35869565217391, 0.11111111111111
75713, 2.0695652173913, 0.38478260869565, 0.11111111111111
75714, 2.0695652173913, 0.35869565217391, 0.083333333333333
75715, 2.0478260869565, 0.35869565217391, 0.055555555555556
75716, 2.0695652173913, 0.38478260869565, 0.055555555555556
75717, 2.0695652173913, 0.35869565217391, 0.027777777777778
75718, 2.1130434782609, 0.35869565217391, 0.47222222222222
75719, 2.0913043478261, 0.35869565217391, 0.44444444444444
75720, 2.1130434782609, 0.38478260869565, 0.44444444444444
75721, 2.1130434782609, 0.35869565217391, 0.41666666666667
75722, 2.0913043478261, 0.35869565217391, 0.38888888888889
75723, 2.1130434782609, 0.38478260869565, 0.38888888888889
75724, 2.1130434782609, 0.35869565217391, 0.36111111111111
75725, 2.0913043478261, 0.35869565217391, 0.33333333333333
75726, 2.1130434782609, 0.38478260869565, 0.33333333333333
75727, 2.1130434782609, 0.35869565217391, 0.30555555555556
75728, 2.0913043478261, 0.35869565217391, 0.27777777777778
75729, 2.1130434782609, 0.38478260869565, 0.27777777777778
75730, 2.1130434782609, 0.35869565217391, 0.25
75731, 2.0913043478261, 0.35869565217391, 0.22222222222222
75732, 2.1130434782609, 0.38478260869565, 0.22222222222222
75733, 2.1130434782609, 0.35869565217391, 0.19444444444444
75734, 2.0913043478261, 0.35869565217391, 0.16666666666667
75735, 2.1130434782609, 0.38478260869565, 0.16666666666667
75736, 2.1130434782609, 0.35869565217391, 0.13888888888889
75737, 2.0913043478261, 0.35869565217391, 0.11111111111111
75738, 2.1130434782609, 0.38478260869565, 0.11111111111111
75739, 2.1130434782609, 0.35869565217391, 0.083333333333333
75740, 2.0913043478261, 0.35869565217391, 0.055555555555556
75741, 2.1130434782609, 0.38478260869565, 0.055555555555556
75742, 2.1130434782609, 0.35869565217391, 0.027777777777778
75743, 2.1565217391304, 0.35869565217391, 0.47222222222222
75744, 2.1347826086957, 0.35869565217391, 0.44444444444444
75745, 2.1565217391304, 0.38478260869565, 0.44444444444444
75746, 2.1565217391304, 0.35869565217391, 0.41666666666667
75747, 2.1347826086957, 0.35869565217391, 0.38888888888889
75748, 2.1565217391304, 0.38478260869565, 0.38888888888889
75749, 2.1565217391304, 0.35869565217391, 0.36111111111111
75750, 2.1347826086957, 0.35869565217391, 0.33333333333333
75751, 2.1565217391304, 0.38478260869565, 0.33333333333333
75752, 2.1565217391304, 0.35869565217391, 0.30555555555556
75753, 2.1347826086957, 0.35869565217391, 0.27777777777778
75754, 2.1565217391304, 0.38478260869565, 0.27777777777778
75755, 2.1565217391304, 0.35869565217391, 0.25
75756, 2.1347826086957, 0.35869565217391, 0.22222222222222
75757, 2.1565217391304, 0.38478260869565, 0.22222222222222
75758, 2.1565217391304, 0.35869565217391, 0.19444444444444
75759, 2.1347826086957, 0.35869565217391, 0.16666666666667
75760, 2.1565217391304, 0.38478260869565, 0.16666666666667
75761, 2.1565217391304, 0.35869565217391, 0.13888888888889
75762, 2.1347826086957, 0.35869565217391, 0.11111111111111
75763, 2.1565217391304, 0.38478260869565, 0.11111111111111
75764, 2.1565217391304, 0.35869565217391, 0.083333333333333
75765, 2.1347826086957, 0.35869565217391, 0.055555555555556
75766, 2.1565217391304, 0.38478260869565, 0.055555555555556
