19957, 0.17391304347826, 0.1, 0.13888888888889
19958, 0.15217391304348, 0.1, 0.16666666666667
19959, 0.17391304347826, 0.1, 0.19444444444444
19960, 0.15217391304348, 0.1, 0.22222222222222
19961, 0.17391304347826, 0.1, 0.25
19962, 0.15217391304348, 0.1, 0.27777777777778
19963, 0.17391304347826, 0.1, 0.30555555555556
19964, 0.15217391304348, 0.1, 0.33333333333333
19965, 0.17391304347826, 0.1, 0.36111111111111
19966, 0.15217391304348, 0.1, 0.38888888888889
19967, 0.17391304347826, 0.1, 0.41666666666667
19968, 0.15217391304348, 0.1, 0.44444444444444
19969, 0.17391304347826, 0.1, 0.47222222222222
19970, 0.21739130434783, 0.1, 0.027777777777778
19971, 0.19565217391304, 0.1, 0.055555555555556
19972, 0.21739130434783, 0.1, 0.083333333333333
19973, 0.19565217391304, 0.1, 0.11111111111111
19974, 0.21739130434783, 0.1, 0.13888888888889
19975, 0.19565217391304, 0.1, 0.16666666666667
19976, 0.21739130434783, 0.1, 0.19444444444444
19977, 0.19565217391304, 0.1, 0.22222222222222
19978, 0.21739130434783, 0.1, 0.25
19979, 0.19565217391304, 0.1, 0.27777777777778
19980, 0.21739130434783, 0.1, 0.30555555555556
19981, 0.19565217391304, 0.1, 0.33333333333333
19982, 0.21739130434783, 0.1, 0.36111111111111
19983, 0.19565217391304, 0.1, 0.38888888888889
19984, 0.21739130434783, 0.1, 0.41666666666667
19985, 0.19565217391304, 0.1, 0.44444444444444
19986, 0.21739130434783, 0.1, 0.47222222222222
19987, 0.26086956521739, 0.1, 0.027777777777778
19988, 0.23913043478261, 0.1, 0.055555555555556
19989, 0.26086956521739, 0.1, 0.083333333333333
19990, 0.23913043478261, 0.1, 0.11111111111111
19991, 0.26086956521739, 0.1, 0.13888888888889
19992, 0.23913043478261, 0.1, 0.16666666666667
19993, 0.26086956521739, 0.1, 0.19444444444444
19994, 0.23913043478261, 0.1, 0.22222222222222
19995, 0.26086956521739, 0.1, 0.25
19996, 0.23913043478261, 0.1, 0.27777777777778
19997, 0.26086956521739, 0.1, 0.30555555555556
19998, 0.23913043478261, 0.1, 0.33333333333333
19999, 0.26086956521739, 0.1, 0.36111111111111
20000, 0.23913043478261, 0.1, 0.38888888888889
20001, 0.26086956521739, 0.1, 0.41666666666667
20002, 0.23913043478261, 0.1, 0.44444444444444
20003, 0.26086956521739, 0.1, 0.47222222222222
20004, 0.30434782608696, 0.1, 0.027777777777778
20005, 0.28260869565217, 0.1, 0.055555555555556
20006, 0.30434782608696, 0.1, 0.083333333333333
20007, 0.28260869565217, 0.1, 0.11111111111111
20008, 0.30434782608696, 0.1, 0.13888888888889
20009, 0.28260869565217, 0.1, 0.16666666666667
20010, 0.30434782608696, 0.1, 0.19444444444444
20011, 0.28260869565217, 0.1, 0.22222222222222
20012, 0.30434782608696, 0.1, 0.25
20013, 0.28260869565217, 0.1, 0.27777777777778
20014, 0.30434782608696, 0.1, 0.30555555555556
20015, 0.28260869565217, 0.1, 0.33333333333333
20016, 0.30434782608696, 0.1, 0.36111111111111
20017, 0.28260869565217, 0.1, 0.38888888888889
20018, 0.30434782608696, 0.1, 0.41666666666667
20019, 0.28260869565217, 0.1, 0.44444444444444
20020, 0.30434782608696, 0.1, 0.47222222222222
20021, 0.34782608695652, 0.1, 0.027777777777778
20022, 0.32608695652174, 0.1, 0.055555555555556
20023, 0.34782608695652, 0.1, 0.083333333333333
20024, 0.32608695652174, 0.1, 0.11111111111111
20025, 0.34782608695652, 0.1, 0.13888888888889
20026, 0.32608695652174, 0.1, 0.16666666666667
20027, 0.34782608695652, 0.1, 0.19444444444444
20028, 0.32608695652174, 0.1, 0.22222222222222
20029, 0.34782608695652, 0.1, 0.25
20030, 0.32608695652174, 0.1, 0.27777777777778
20031, 0.34782608695652, 0.1, 0.30555555555556
20032, 0.32608695652174, 0.1, 0.33333333333333
20033, 0.34782608695652, 0.1, 0.36111111111111
20034, 0.32608695652174, 0.1, 0.38888888888889
20035, 0.34782608695652, 0.1, 0.41666666666667
20036, 0.32608695652174, 0.1, 0.44444444444444
20037, 0.34782608695652, 0.1, 0.47222222222222
20038, 0.39130434782609, 0.1, 0.027777777777778
20039, 0.3695652173913, 0.1, 0.055555555555556
20040, 0.39130434782609, 0.1, 0.083333333333333
20041, 0.3695652173913, 0.1, 0.11111111111111
20042, 0.39130434782609, 0.1, 0.13888888888889
20043, 0.3695652173913, 0.1, 0.16666666666667
20044, 0.39130434782609, 0.1, 0.19444444444444
20045, 0.3695652173913, 0.1, 0.22222222222222
20046, 0.39130434782609, 0.1, 0.25
20047, 0.3695652173913, 0.1, 0.27777777777778
20048, 0.39130434782609, 0.1, 0.30555555555556
20049, 0.3695652173913, 0.1, 0.33333333333333
20050, 0.39130434782609, 0.1, 0.36111111111111
20051, 0.3695652173913, 0.1, 0.38888888888889
20052, 0.39130434782609, 0.1, 0.41666666666667
20053, 0.3695652173913, 0.1, 0.44444444444444
20054, 0.39130434782609, 0.1, 0.47222222222222
20055, 0.43478260869565, 0.1, 0.027777777777778
20056, 0.41304347826087, 0.1, 0.055555555555556
20057, 0.43478260869565, 0.1, 0.083333333333333
20058, 0.41304347826087, 0.1, 0.11111111111111
20059, 0.43478260869565, 0.1, 0.13888888888889
20060, 0.41304347826087, 0.1, 0.16666666666667
20061, 0.43478260869565, 0.1, 0.19444444444444
20062, 0.41304347826087, 0.1, 0.22222222222222
20063, 0.43478260869565, 0.1, 0.25
20064, 0.41304347826087, 0.1, 0.27777777777778
20065, 0.43478260869565, 0.1, 0.30555555555556
20066, 0.41304347826087, 0.1, 0.33333333333333
20067, 0.43478260869565, 0.1, 0.36111111111111
20068, 0.41304347826087, 0.1, 0.38888888888889
20069, 0.43478260869565, 0.1, 0.41666666666667
20070, 0.41304347826087, 0.1, 0.44444444444444
20071, 0.43478260869565, 0.1, 0.47222222222222
20072, 0.47826086956522, 0.1, 0.027777777777778
20073, 0.45652173913043, 0.1, 0.055555555555556
20074, 0.47826086956522, 0.1, 0.083333333333333
20075, 0.45652173913043, 0.1, 0.11111111111111
20076, 0.47826086956522, 0.1, 0.13888888888889
20077, 0.45652173913043, 0.1, 0.16666666666667
20078, 0.47826086956522, 0.1, 0.19444444444444
20079, 0.45652173913043, 0.1, 0.22222222222222
20080, 0.47826086956522, 0.1, 0.25
20081, 0.45652173913043, 0.1, 0.27777777777778
20082, 0.47826086956522, 0.1, 0.30555555555556
20083, 0.45652173913043, 0.1, 0.33333333333333
20084, 0.47826086956522, 0.1, 0.36111111111111
20085, 0.45652173913043, 0.1, 0.38888888888889
20086, 0.47826086956522, 0.1, 0.41666666666667
20087, 0.45652173913043, 0.1, 0.44444444444444
20088, 0.47826086956522, 0.1, 0.47222222222222
20089, 0.52173913043478, 0.1, 0.027777777777778
20090, 0.5, 0.1, 0.055555555555556
20091, 0.52173913043478, 0.1, 0.083333333333333
20092, 0.5, 0.1, 0.11111111111111
20093, 0.52173913043478, 0.1, 0.13888888888889
20094, 0.5, 0.1, 0.16666666666667
20095, 0.52173913043478, 0.1, 0.19444444444444
20096, 0.5, 0.1, 0.22222222222222
20097, 0.52173913043478, 0.1, 0.25
20098, 0.5, 0.1, 0.27777777777778
20099, 0.52173913043478, 0.1, 0.30555555555556
20100, 0.5, 0.1, 0.33333333333333
20101, 0.52173913043478, 0.1, 0.36111111111111
20102, 0.5, 0.1, 0.38888888888889
20103, 0.52173913043478, 0.1, 0.41666666666667
20104, 0.5, 0.1, 0.44444444444444
20105, 0.52173913043478, 0.1, 0.47222222222222
20106, 0.56521739130435, 0.1, 0.027777777777778
20107, 0.54347826086957, 0.1, 0.055555555555556
20108, 0.56521739130435, 0.1, 0.083333333333333
20109, 0.54347826086957, 0.1, 0.11111111111111
20110, 0.56521739130435, 0.1, 0.13888888888889
20111, 0.54347826086957, 0.1, 0.16666666666667
20112, 0.56521739130435, 0.1, 0.19444444444444
20113, 0.54347826086957, 0.1, 0.22222222222222
20114, 0.56521739130435, 0.1, 0.25
20115, 0.54347826086957, 0.1, 0.27777777777778
20116, 0.56521739130435, 0.1, 0.30555555555556
20117, 0.54347826086957, 0.1, 0.33333333333333
20118, 0.56521739130435, 0.1, 0.36111111111111
20119, 0.54347826086957, 0.1, 0.38888888888889
20120, 0.56521739130435, 0.1, 0.41666666666667
20121, 0.54347826086957, 0.1, 0.44444444444444
20122, 0.56521739130435, 0.1, 0.47222222222222
20123, 0.60869565217391, 0.1, 0.027777777777778
20124, 0.58695652173913, 0.1, 0.055555555555556
20125, 0.60869565217391, 0.1, 0.083333333333333
20126, 0.58695652173913, 0.1, 0.11111111111111
20127, 0.60869565217391, 0.1, 0.13888888888889
20128, 0.58695652173913, 0.1, 0.16666666666667
20129, 0.60869565217391, 0.1, 0.19444444444444
20130, 0.58695652173913, 0.1, 0.22222222222222
20131, 0.60869565217391, 0.1, 0.25
20132, 0.58695652173913, 0.1, 0.27777777777778
20133, 0.60869565217391, 0.1, 0.30555555555556
20134, 0.58695652173913, 0.1, 0.33333333333333
20135, 0.60869565217391, 0.1, 0.36111111111111
20136, 0.58695652173913, 0.1, 0.38888888888889
20137, 0.60869565217391, 0.1, 0.41666666666667
20138, 0.58695652173913, 0.1, 0.44444444444444
20139, 0.60869565217391, 0.1, 0.47222222222222
20140, 0.65217391304348, 0.1, 0.027777777777778
20141, 0.6304347826087, 0.1, 0.055555555555556
20142, 0.65217391304348, 0.1, 0.083333333333333
20143, 0.6304347826087, 0.1, 0.11111111111111
20144, 0.65217391304348, 0.1, 0.13888888888889
20145, 0.6304347826087, 0.1, 0.16666666666667
20146, 0.65217391304348, 0.1, 0.19444444444444
20147, 0.6304347826087, 0.1, 0.22222222222222
20148, 0.65217391304348, 0.1, 0.25
20149, 0.6304347826087, 0.1, 0.27777777777778
20150, 0.65217391304348, 0.1, 0.30555555555556
20151, 0.6304347826087, 0.1, 0.33333333333333
20152, 0.65217391304348, 0.1, 0.36111111111111
20153, 0.6304347826087, 0.1, 0.38888888888889
20154, 0.65217391304348, 0.1, 0.41666666666667
20155, 0.6304347826087, 0.1, 0.44444444444444
20156, 0.65217391304348, 0.1, 0.47222222222222
20157, 0.69565217391304, 0.1, 0.027777777777778
20158, 0.67391304347826, 0.1, 0.055555555555556
20159, 0.69565217391304, 0.1, 0.083333333333333
20160, 0.67391304347826, 0.1, 0.11111111111111
20161, 0.69565217391304, 0.1, 0.13888888888889
20162, 0.67391304347826, 0.1, 0.16666666666667
20163, 0.69565217391304, 0.1, 0.19444444444444
20164, 0.67391304347826, 0.1, 0.22222222222222
20165, 0.69565217391304, 0.1, 0.25
20166, 0.67391304347826, 0.1, 0.27777777777778
20167, 0.69565217391304, 0.1, 0.30555555555556
20168, 0.67391304347826, 0.1, 0.33333333333333
20169, 0.69565217391304, 0.1, 0.36111111111111
20170, 0.67391304347826, 0.1, 0.38888888888889
20171, 0.69565217391304, 0.1, 0.41666666666667
20172, 0.67391304347826, 0.1, 0.44444444444444
20173, 0.69565217391304, 0.1, 0.47222222222222
20174, 0.73913043478261, 0.1, 0.027777777777778
20175, 0.71739130434783, 0.1, 0.055555555555556
20176, 0.73913043478261, 0.1, 0.083333333333333
20177, 0.71739130434783, 0.1, 0.11111111111111
20178, 0.73913043478261, 0.1, 0.13888888888889
20179, 0.71739130434783, 0.1, 0.16666666666667
20180, 0.73913043478261, 0.1, 0.19444444444444
20181, 0.71739130434783, 0.1, 0.22222222222222
20182, 0.73913043478261, 0.1, 0.25
20183, 0.71739130434783, 0.1, 0.27777777777778
20184, 0.73913043478261, 0.1, 0.30555555555556
20185, 0.71739130434783, 0.1, 0.33333333333333
20186, 0.73913043478261, 0.1, 0.36111111111111
20187, 0.71739130434783, 0.1, 0.38888888888889
20188, 0.73913043478261, 0.1, 0.41666666666667
20189, 0.71739130434783, 0.1, 0.44444444444444
20190, 0.73913043478261, 0.1, 0.47222222222222
20191, 0.78260869565217, 0.1, 0.027777777777778
20192, 0.76086956521739, 0.1, 0.055555555555556
20193, 0.78260869565217, 0.1, 0.083333333333333
20194, 0.76086956521739, 0.1, 0.11111111111111
20195, 0.78260869565217, 0.1, 0.13888888888889
20196, 0.76086956521739, 0.1, 0.16666666666667
20197, 0.78260869565217, 0.1, 0.19444444444444
20198, 0.76086956521739, 0.1, 0.22222222222222
20199, 0.78260869565217, 0.1, 0.25
20200, 0.76086956521739, 0.1, 0.27777777777778
20201, 0.78260869565217, 0.1, 0.30555555555556
20202, 0.76086956521739, 0.1, 0.33333333333333
20203, 0.78260869565217, 0.1, 0.36111111111111
20204, 0.76086956521739, 0.1, 0.38888888888889
20205, 0.78260869565217, 0.1, 0.41666666666667
20206, 0.76086956521739, 0.1, 0.44444444444444
20207, 0.78260869565217, 0.1, 0.47222222222222
20208, 0.82608695652174, 0.1, 0.027777777777778
20209, 0.80434782608696, 0.1, 0.055555555555556
20210, 0.82608695652174, 0.1, 0.083333333333333
20211, 0.80434782608696, 0.1, 0.11111111111111
20212, 0.82608695652174, 0.1, 0.13888888888889
20213, 0.80434782608696, 0.1, 0.16666666666667
20214, 0.82608695652174, 0.1, 0.19444444444444
20215, 0.80434782608696, 0.1, 0.22222222222222
20216, 0.82608695652174, 0.1, 0.25
20217, 0.80434782608696, 0.1, 0.27777777777778
20218, 0.82608695652174, 0.1, 0.30555555555556
20219, 0.80434782608696, 0.1, 0.33333333333333
20220, 0.82608695652174, 0.1, 0.36111111111111
20221, 0.80434782608696, 0.1, 0.38888888888889
20222, 0.82608695652174, 0.1, 0.41666666666667
20223, 0.80434782608696, 0.1, 0.44444444444444
20224, 0.82608695652174, 0.1, 0.47222222222222
20225, 0.8695652173913, 0.1, 0.027777777777778
20226, 0.84782608695652, 0.1, 0.055555555555556
20227, 0.8695652173913, 0.1, 0.083333333333333
20228, 0.84782608695652, 0.1, 0.11111111111111
20229, 0.8695652173913, 0.1, 0.13888888888889
20230, 0.84782608695652, 0.1, 0.16666666666667
20231, 0.8695652173913, 0.1, 0.19444444444444
20232, 0.84782608695652, 0.1, 0.22222222222222
20233, 0.8695652173913, 0.1, 0.25
20234, 0.84782608695652, 0.1, 0.27777777777778
20235, 0.8695652173913, 0.1, 0.30555555555556
20236, 0.84782608695652, 0.1, 0.33333333333333
20237, 0.8695652173913, 0.1, 0.36111111111111
20238, 0.84782608695652, 0.1, 0.38888888888889
20239, 0.8695652173913, 0.1, 0.41666666666667
20240, 0.84782608695652, 0.1, 0.44444444444444
20241, 0.8695652173913, 0.1, 0.47222222222222
20242, 0.91304347826087, 0.1, 0.027777777777778
20243, 0.89130434782609, 0.1, 0.055555555555556
20244, 0.91304347826087, 0.1, 0.083333333333333
20245, 0.89130434782609, 0.1, 0.11111111111111
20246, 0.91304347826087, 0.1, 0.13888888888889
20247, 0.89130434782609, 0.1, 0.16666666666667
20248, 0.91304347826087, 0.1, 0.19444444444444
20249, 0.89130434782609, 0.1, 0.22222222222222
20250, 0.91304347826087, 0.1, 0.25
20251, 0.89130434782609, 0.1, 0.27777777777778
20252, 0.91304347826087, 0.1, 0.30555555555556
20253, 0.89130434782609, 0.1, 0.33333333333333
20254, 0.91304347826087, 0.1, 0.36111111111111
20255, 0.89130434782609, 0.1, 0.38888888888889
20256, 0.91304347826087, 0.1, 0.41666666666667
20257, 0.89130434782609, 0.1, 0.44444444444444
20258, 0.91304347826087, 0.1, 0.47222222222222
20259, 0.95652173913043, 0.1, 0.027777777777778
20260, 0.93478260869565, 0.1, 0.055555555555556
20261, 0.95652173913043, 0.1, 0.083333333333333
20262, 0.93478260869565, 0.1, 0.11111111111111
20263, 0.95652173913043, 0.1, 0.13888888888889
20264, 0.93478260869565, 0.1, 0.16666666666667
20265, 0.95652173913043, 0.1, 0.19444444444444
20266, 0.93478260869565, 0.1, 0.22222222222222
20267, 0.95652173913043, 0.1, 0.25
20268, 0.93478260869565, 0.1, 0.27777777777778
20269, 0.95652173913043, 0.1, 0.30555555555556
20270, 0.93478260869565, 0.1, 0.33333333333333
20271, 0.95652173913043, 0.1, 0.36111111111111
20272, 0.93478260869565, 0.1, 0.38888888888889
20273, 0.95652173913043, 0.1, 0.41666666666667
20274, 0.93478260869565, 0.1, 0.44444444444444
20275, 0.95652173913043, 0.1, 0.47222222222222
20276, 0.97826086956522, 0.1, 0.055555555555556
20277, 0.97826086956522, 0.1, 0.11111111111111
20278, 0.97826086956522, 0.1, 0.16666666666667
20279, 0.97826086956522, 0.1, 0.22222222222222
20280, 0.97826086956522, 0.1, 0.27777777777778
20281, 0.97826086956522, 0.1, 0.33333333333333
20282, 0.97826086956522, 0.1, 0.38888888888889
20283, 0.97826086956522, 0.1, 0.44444444444444
20284, 0.95652173913043, 0.20217391304348, 0
20285, 0.91304347826087, 0.20217391304348, 0
20286, 0.8695652173913, 0.20217391304348, 0
20287, 0.82608695652174, 0.20217391304348, 0
20288, 0.78260869565217, 0.20217391304348, 0
20289, 0.73913043478261, 0.20217391304348, 0
20290, 0.69565217391304, 0.20217391304348, 0
20291, 0.65217391304348, 0.20217391304348, 0
20292, 0.60869565217391, 0.20217391304348, 0
20293, 0.56521739130435, 0.20217391304348, 0
20294, 0.52173913043478, 0.20217391304348, 0
20295, 0.47826086956522, 0.20217391304348, 0
20296, 0.43478260869565, 0.20217391304348, 0
20297, 0.39130434782609, 0.20217391304348, 0
20298, 0.34782608695652, 0.20217391304348, 0
20299, 0.30434782608696, 0.20217391304348, 0
20300, 0.26086956521739, 0.20217391304348, 0
20301, 0.21739130434783, 0.20217391304348, 0
20302, 0.17391304347826, 0.20217391304348, 0
20303, 0.1304347826087, 0.20217391304348, 0
20304, 0.08695652173913, 0.20217391304348, 0
20305, 0.043478260869565, 0.20217391304348, 0
20306, 0.95652173913043, 0.25434782608696, 0
20307, 0.91304347826087, 0.25434782608696, 0
20308, 0.8695652173913, 0.25434782608696, 0
20309, 0.82608695652174, 0.25434782608696, 0
20310, 0.78260869565217, 0.25434782608696, 0
20311, 0.73913043478261, 0.25434782608696, 0
20312, 0.69565217391304, 0.25434782608696, 0
20313, 0.65217391304348, 0.25434782608696, 0
20314, 0.60869565217391, 0.25434782608696, 0
20315, 0.56521739130435, 0.25434782608696, 0
20316, 0.52173913043478, 0.25434782608696, 0
20317, 0.47826086956522, 0.25434782608696, 0
20318, 0.43478260869565, 0.25434782608696, 0
20319, 0.39130434782609, 0.25434782608696, 0
20320, 0.34782608695652, 0.25434782608696, 0
20321, 0.30434782608696, 0.25434782608696, 0
20322, 0.26086956521739, 0.25434782608696, 0
20323, 0.21739130434783, 0.25434782608696, 0
20324, 0.17391304347826, 0.25434782608696, 0
20325, 0.1304347826087, 0.25434782608696, 0
20326, 0.08695652173913, 0.25434782608696, 0
20327, 0.043478260869565, 0.25434782608696, 0
20328, 0.95652173913043, 0.30652173913043, 0
20329, 0.91304347826087, 0.30652173913043, 0
20330, 0.8695652173913, 0.30652173913043, 0
20331, 0.82608695652174, 0.30652173913043, 0
20332, 0.78260869565217, 0.30652173913043, 0
20333, 0.73913043478261, 0.30652173913043, 0
20334, 0.69565217391304, 0.30652173913043, 0
20335, 0.65217391304348, 0.30652173913043, 0
20336, 0.60869565217391, 0.30652173913043, 0
20337, 0.56521739130435, 0.30652173913043, 0
20338, 0.52173913043478, 0.30652173913043, 0
20339, 0.47826086956522, 0.30652173913043, 0
20340, 0.43478260869565, 0.30652173913043, 0
20341, 0.39130434782609, 0.30652173913043, 0
20342, 0.34782608695652, 0.30652173913043, 0
20343, 0.30434782608696, 0.30652173913043, 0
20344, 0.26086956521739, 0.30652173913043, 0
20345, 0.21739130434783, 0.30652173913043, 0
20346, 0.17391304347826, 0.30652173913043, 0
20347, 0.1304347826087, 0.30652173913043, 0
20348, 0.08695652173913, 0.30652173913043, 0
20349, 0.043478260869565, 0.30652173913043, 0
20350, 0.95652173913043, 0.35869565217391, 0
20351, 0.91304347826087, 0.35869565217391, 0
20352, 0.8695652173913, 0.35869565217391, 0
20353, 0.82608695652174, 0.35869565217391, 0
20354, 0.78260869565217, 0.35869565217391, 0
20355, 0.73913043478261, 0.35869565217391, 0
20356, 0.69565217391304, 0.35869565217391, 0
20357, 0.65217391304348, 0.35869565217391, 0
20358, 0.60869565217391, 0.35869565217391, 0
20359, 0.56521739130435, 0.35869565217391, 0
20360, 0.52173913043478, 0.35869565217391, 0
20361, 0.47826086956522, 0.35869565217391, 0
20362, 0.43478260869565, 0.35869565217391, 0
20363, 0.39130434782609, 0.35869565217391, 0
20364, 0.34782608695652, 0.35869565217391, 0
20365, 0.30434782608696, 0.35869565217391, 0
20366, 0.26086956521739, 0.35869565217391, 0
20367, 0.21739130434783, 0.35869565217391, 0
20368, 0.17391304347826, 0.35869565217391, 0
20369, 0.1304347826087, 0.35869565217391, 0
20370, 0.08695652173913, 0.35869565217391, 0
20371, 0.043478260869565, 0.35869565217391, 0
20372, 0.95652173913043, 0.41086956521739, 0
20373, 0.91304347826087, 0.41086956521739, 0
20374, 0.8695652173913, 0.41086956521739, 0
20375, 0.82608695652174, 0.41086956521739, 0
20376, 0.78260869565217, 0.41086956521739, 0
20377, 0.73913043478261, 0.41086956521739, 0
20378, 0.69565217391304, 0.41086956521739, 0
20379, 0.65217391304348, 0.41086956521739, 0
20380, 0.60869565217391, 0.41086956521739, 0
20381, 0.56521739130435, 0.41086956521739, 0
20382, 0.52173913043478, 0.41086956521739, 0
20383, 0.47826086956522, 0.41086956521739, 0
20384, 0.43478260869565, 0.41086956521739, 0
20385, 0.39130434782609, 0.41086956521739, 0
20386, 0.34782608695652, 0.41086956521739, 0
20387, 0.30434782608696, 0.41086956521739, 0
20388, 0.26086956521739, 0.41086956521739, 0
20389, 0.21739130434783, 0.41086956521739, 0
20390, 0.17391304347826, 0.41086956521739, 0
20391, 0.1304347826087, 0.41086956521739, 0
20392, 0.08695652173913, 0.41086956521739, 0
20393, 0.043478260869565, 0.41086956521739, 0
20394, 0.95652173913043, 0.46304347826087, 0
20395, 0.91304347826087, 0.46304347826087, 0
20396, 0.8695652173913, 0.46304347826087, 0
20397, 0.82608695652174, 0.46304347826087, 0
20398, 0.78260869565217, 0.46304347826087, 0
20399, 0.73913043478261, 0.46304347826087, 0
20400, 0.69565217391304, 0.46304347826087, 0
20401, 0.65217391304348, 0.46304347826087, 0
20402, 0.60869565217391, 0.46304347826087, 0
20403, 0.56521739130435, 0.46304347826087, 0
20404, 0.52173913043478, 0.46304347826087, 0
20405, 0.47826086956522, 0.46304347826087, 0
20406, 0.43478260869565, 0.46304347826087, 0
20407, 0.39130434782609, 0.46304347826087, 0
20408, 0.34782608695652, 0.46304347826087, 0
20409, 0.30434782608696, 0.46304347826087, 0
20410, 0.26086956521739, 0.46304347826087, 0
20411, 0.21739130434783, 0.46304347826087, 0
20412, 0.17391304347826, 0.46304347826087, 0
20413, 0.1304347826087, 0.46304347826087, 0
20414, 0.08695652173913, 0.46304347826087, 0
20415, 0.043478260869565, 0.46304347826087, 0
20416, 0.95652173913043, 0.51521739130435, 0
20417, 0.91304347826087, 0.51521739130435, 0
20418, 0.8695652173913, 0.51521739130435, 0
20419, 0.82608695652174, 0.51521739130435, 0
20420, 0.78260869565217, 0.51521739130435, 0
20421, 0.73913043478261, 0.51521739130435, 0
20422, 0.69565217391304, 0.51521739130435, 0
20423, 0.65217391304348, 0.51521739130435, 0
20424, 0.60869565217391, 0.51521739130435, 0
20425, 0.56521739130435, 0.51521739130435, 0
20426, 0.52173913043478, 0.51521739130435, 0
20427, 0.47826086956522, 0.51521739130435, 0
20428, 0.43478260869565, 0.51521739130435, 0
20429, 0.39130434782609, 0.51521739130435, 0
20430, 0.34782608695652, 0.51521739130435, 0
20431, 0.30434782608696, 0.51521739130435, 0
20432, 0.26086956521739, 0.51521739130435, 0
20433, 0.21739130434783, 0.51521739130435, 0
20434, 0.17391304347826, 0.51521739130435, 0
20435, 0.1304347826087, 0.51521739130435, 0
20436, 0.08695652173913, 0.51521739130435, 0
20437, 0.043478260869565, 0.51521739130435, 0
20438, 0.95652173913043, 0.56739130434783, 0
20439, 0.91304347826087, 0.56739130434783, 0
20440, 0.8695652173913, 0.56739130434783, 0
20441, 0.82608695652174, 0.56739130434783, 0
20442, 0.78260869565217, 0.56739130434783, 0
20443, 0.73913043478261, 0.56739130434783, 0
20444, 0.69565217391304, 0.56739130434783, 0
20445, 0.65217391304348, 0.56739130434783, 0
20446, 0.60869565217391, 0.56739130434783, 0
20447, 0.56521739130435, 0.56739130434783, 0
20448, 0.52173913043478, 0.56739130434783, 0
20449, 0.47826086956522, 0.56739130434783, 0
20450, 0.43478260869565, 0.56739130434783, 0
20451, 0.39130434782609, 0.56739130434783, 0
20452, 0.34782608695652, 0.56739130434783, 0
20453, 0.30434782608696, 0.56739130434783, 0
20454, 0.26086956521739, 0.56739130434783, 0
20455, 0.21739130434783, 0.56739130434783, 0
20456, 0.17391304347826, 0.56739130434783, 0
20457, 0.1304347826087, 0.56739130434783, 0
20458, 0.08695652173913, 0.56739130434783, 0
20459, 0.043478260869565, 0.56739130434783, 0
20460, 0.95652173913043, 0.6195652173913, 0
20461, 0.91304347826087, 0.6195652173913, 0
20462, 0.8695652173913, 0.6195652173913, 0
20463, 0.82608695652174, 0.6195652173913, 0
20464, 0.78260869565217, 0.6195652173913, 0
20465, 0.73913043478261, 0.6195652173913, 0
20466, 0.69565217391304, 0.6195652173913, 0
20467, 0.65217391304348, 0.6195652173913, 0
20468, 0.60869565217391, 0.6195652173913, 0
20469, 0.56521739130435, 0.6195652173913, 0
20470, 0.52173913043478, 0.6195652173913, 0
20471, 0.47826086956522, 0.6195652173913, 0
20472, 0.43478260869565, 0.6195652173913, 0
20473, 0.39130434782609, 0.6195652173913, 0
20474, 0.34782608695652, 0.6195652173913, 0
20475, 0.30434782608696, 0.6195652173913, 0
20476, 0.26086956521739, 0.6195652173913, 0
20477, 0.21739130434783, 0.6195652173913, 0
20478, 0.17391304347826, 0.6195652173913, 0
20479, 0.1304347826087, 0.6195652173913, 0
20480, 0.08695652173913, 0.6195652173913, 0
20481, 0.043478260869565, 0.6195652173913, 0
20482, 0.95652173913043, 0.67173913043478, 0
20483, 0.91304347826087, 0.67173913043478, 0
20484, 0.8695652173913, 0.67173913043478, 0
20485, 0.82608695652174, 0.67173913043478, 0
20486, 0.78260869565217, 0.67173913043478, 0
20487, 0.73913043478261, 0.67173913043478, 0
20488, 0.69565217391304, 0.67173913043478, 0
20489, 0.65217391304348, 0.67173913043478, 0
20490, 0.60869565217391, 0.67173913043478, 0
20491, 0.56521739130435, 0.67173913043478, 0
20492, 0.52173913043478, 0.67173913043478, 0
20493, 0.47826086956522, 0.67173913043478, 0
20494, 0.43478260869565, 0.67173913043478, 0
20495, 0.39130434782609, 0.67173913043478, 0
20496, 0.34782608695652, 0.67173913043478, 0
20497, 0.30434782608696, 0.67173913043478, 0
20498, 0.26086956521739, 0.67173913043478, 0
20499, 0.21739130434783, 0.67173913043478, 0
20500, 0.17391304347826, 0.67173913043478, 0
20501, 0.1304347826087, 0.67173913043478, 0
20502, 0.08695652173913, 0.67173913043478, 0
20503, 0.043478260869565, 0.67173913043478, 0
20504, 0.95652173913043, 0.72391304347826, 0
20505, 0.91304347826087, 0.72391304347826, 0
20506, 0.8695652173913, 0.72391304347826, 0
20507, 0.82608695652174, 0.72391304347826, 0
20508, 0.78260869565217, 0.72391304347826, 0
20509, 0.73913043478261, 0.72391304347826, 0
20510, 0.69565217391304, 0.72391304347826, 0
20511, 0.65217391304348, 0.72391304347826, 0
20512, 0.60869565217391, 0.72391304347826, 0
20513, 0.56521739130435, 0.72391304347826, 0
20514, 0.52173913043478, 0.72391304347826, 0
20515, 0.47826086956522, 0.72391304347826, 0
20516, 0.43478260869565, 0.72391304347826, 0
20517, 0.39130434782609, 0.72391304347826, 0
20518, 0.34782608695652, 0.72391304347826, 0
20519, 0.30434782608696, 0.72391304347826, 0
20520, 0.26086956521739, 0.72391304347826, 0
20521, 0.21739130434783, 0.72391304347826, 0
20522, 0.17391304347826, 0.72391304347826, 0
20523, 0.1304347826087, 0.72391304347826, 0
20524, 0.08695652173913, 0.72391304347826, 0
20525, 0.043478260869565, 0.72391304347826, 0
20526, 0.95652173913043, 0.77608695652174, 0
20527, 0.91304347826087, 0.77608695652174, 0
20528, 0.8695652173913, 0.77608695652174, 0
20529, 0.82608695652174, 0.77608695652174, 0
20530, 0.78260869565217, 0.77608695652174, 0
20531, 0.73913043478261, 0.77608695652174, 0
20532, 0.69565217391304, 0.77608695652174, 0
20533, 0.65217391304348, 0.77608695652174, 0
20534, 0.60869565217391, 0.77608695652174, 0
20535, 0.56521739130435, 0.77608695652174, 0
20536, 0.52173913043478, 0.77608695652174, 0
20537, 0.47826086956522, 0.77608695652174, 0
20538, 0.43478260869565, 0.77608695652174, 0
20539, 0.39130434782609, 0.77608695652174, 0
20540, 0.34782608695652, 0.77608695652174, 0
20541, 0.30434782608696, 0.77608695652174, 0
20542, 0.26086956521739, 0.77608695652174, 0
20543, 0.21739130434783, 0.77608695652174, 0
20544, 0.17391304347826, 0.77608695652174, 0
20545, 0.1304347826087, 0.77608695652174, 0
20546, 0.08695652173913, 0.77608695652174, 0
20547, 0.043478260869565, 0.77608695652174, 0
20548, 0.95652173913043, 0.82826086956522, 0
20549, 0.91304347826087, 0.82826086956522, 0
20550, 0.8695652173913, 0.82826086956522, 0
20551, 0.82608695652174, 0.82826086956522, 0
20552, 0.78260869565217, 0.82826086956522, 0
20553, 0.73913043478261, 0.82826086956522, 0
20554, 0.69565217391304, 0.82826086956522, 0
20555, 0.65217391304348, 0.82826086956522, 0
20556, 0.60869565217391, 0.82826086956522, 0
20557, 0.56521739130435, 0.82826086956522, 0
20558, 0.52173913043478, 0.82826086956522, 0
20559, 0.47826086956522, 0.82826086956522, 0
20560, 0.43478260869565, 0.82826086956522, 0
20561, 0.39130434782609, 0.82826086956522, 0
20562, 0.34782608695652, 0.82826086956522, 0
20563, 0.30434782608696, 0.82826086956522, 0
20564, 0.26086956521739, 0.82826086956522, 0
20565, 0.21739130434783, 0.82826086956522, 0
20566, 0.17391304347826, 0.82826086956522, 0
20567, 0.1304347826087, 0.82826086956522, 0
20568, 0.08695652173913, 0.82826086956522, 0
20569, 0.043478260869565, 0.82826086956522, 0
20570, 0.95652173913043, 0.8804347826087, 0
20571, 0.91304347826087, 0.8804347826087, 0
20572, 0.8695652173913, 0.88043478260869, 0
20573, 0.82608695652174, 0.8804347826087, 0
20574, 0.78260869565217, 0.8804347826087, 0
20575, 0.73913043478261, 0.8804347826087, 0
20576, 0.69565217391304, 0.8804347826087, 0
20577, 0.65217391304348, 0.8804347826087, 0
20578, 0.60869565217391, 0.8804347826087, 0
20579, 0.56521739130435, 0.8804347826087, 0
20580, 0.52173913043478, 0.88043478260869, 0
20581, 0.47826086956522, 0.8804347826087, 0
20582, 0.43478260869565, 0.8804347826087, 0
20583, 0.39130434782609, 0.88043478260869, 0
20584, 0.34782608695652, 0.8804347826087, 0
20585, 0.30434782608696, 0.8804347826087, 0
20586, 0.26086956521739, 0.8804347826087, 0
20587, 0.21739130434783, 0.8804347826087, 0
20588, 0.17391304347826, 0.8804347826087, 0
20589, 0.1304347826087, 0.8804347826087, 0
20590, 0.08695652173913, 0.8804347826087, 0
20591, 0.043478260869565, 0.8804347826087, 0
20592, 0.95652173913043, 0.93260869565217, 0
20593, 0.91304347826087, 0.93260869565217, 0
20594, 0.8695652173913, 0.93260869565217, 0
20595, 0.82608695652174, 0.93260869565217, 0
20596, 0.78260869565217, 0.93260869565217, 0
20597, 0.73913043478261, 0.93260869565217, 0
20598, 0.69565217391304, 0.93260869565217, 0
20599, 0.65217391304348, 0.93260869565217, 0
20600, 0.60869565217391, 0.93260869565217, 0
20601, 0.56521739130435, 0.93260869565217, 0
20602, 0.52173913043478, 0.93260869565217, 0
20603, 0.47826086956522, 0.93260869565217, 0
20604, 0.43478260869565, 0.93260869565217, 0
20605, 0.39130434782609, 0.93260869565217, 0
20606, 0.34782608695652, 0.93260869565217, 0
20607, 0.30434782608696, 0.93260869565217, 0
20608, 0.26086956521739, 0.93260869565217, 0
20609, 0.21739130434783, 0.93260869565217, 0
20610, 0.17391304347826, 0.93260869565217, 0
20611, 0.1304347826087, 0.93260869565217, 0
20612, 0.08695652173913, 0.93260869565217, 0
20613, 0.043478260869565, 0.93260869565217, 0
20614, 0.95652173913043, 0.98478260869565, 0
20615, 0.91304347826087, 0.98478260869565, 0
20616, 0.8695652173913, 0.98478260869565, 0
20617, 0.82608695652174, 0.98478260869565, 0
20618, 0.78260869565217, 0.98478260869565, 0
20619, 0.73913043478261, 0.98478260869565, 0
20620, 0.69565217391304, 0.98478260869565, 0
20621, 0.65217391304348, 0.98478260869565, 0
20622, 0.60869565217391, 0.98478260869565, 0
20623, 0.56521739130435, 0.98478260869565, 0
20624, 0.52173913043478, 0.98478260869565, 0
20625, 0.47826086956522, 0.98478260869565, 0
20626, 0.43478260869565, 0.98478260869565, 0
20627, 0.39130434782609, 0.98478260869565, 0
20628, 0.34782608695652, 0.98478260869565, 0
20629, 0.30434782608696, 0.98478260869565, 0
20630, 0.26086956521739, 0.98478260869565, 0
20631, 0.21739130434783, 0.98478260869565, 0
20632, 0.17391304347826, 0.98478260869565, 0
20633, 0.1304347826087, 0.98478260869565, 0
20634, 0.08695652173913, 0.98478260869565, 0
20635, 0.043478260869565, 0.98478260869565, 0
20636, 0.95652173913043, 1.0369565217391, 0
20637, 0.91304347826087, 1.0369565217391, 0
20638, 0.8695652173913, 1.0369565217391, 0
20639, 0.82608695652174, 1.0369565217391, 0
20640, 0.78260869565217, 1.0369565217391, 0
20641, 0.73913043478261, 1.0369565217391, 0
20642, 0.69565217391304, 1.0369565217391, 0
20643, 0.65217391304348, 1.0369565217391, 0
20644, 0.60869565217391, 1.0369565217391, 0
20645, 0.56521739130435, 1.0369565217391, 0
20646, 0.52173913043478, 1.0369565217391, 0
20647, 0.47826086956522, 1.0369565217391, 0
20648, 0.43478260869565, 1.0369565217391, 0
20649, 0.39130434782609, 1.0369565217391, 0
20650, 0.34782608695652, 1.0369565217391, 0
20651, 0.30434782608696, 1.0369565217391, 0
20652, 0.26086956521739, 1.0369565217391, 0
20653, 0.21739130434783, 1.0369565217391, 0
20654, 0.17391304347826, 1.0369565217391, 0
20655, 0.1304347826087, 1.0369565217391, 0
20656, 0.08695652173913, 1.0369565217391, 0
20657, 0.043478260869565, 1.0369565217391, 0
20658, 0.95652173913043, 1.0891304347826, 0
20659, 0.91304347826087, 1.0891304347826, 0
20660, 0.8695652173913, 1.0891304347826, 0
20661, 0.82608695652174, 1.0891304347826, 0
20662, 0.78260869565217, 1.0891304347826, 0
20663, 0.73913043478261, 1.0891304347826, 0
20664, 0.69565217391304, 1.0891304347826, 0
20665, 0.65217391304348, 1.0891304347826, 0
20666, 0.60869565217391, 1.0891304347826, 0
20667, 0.56521739130435, 1.0891304347826, 0
20668, 0.52173913043478, 1.0891304347826, 0
20669, 0.47826086956522, 1.0891304347826, 0
20670, 0.43478260869565, 1.0891304347826, 0
20671, 0.39130434782609, 1.0891304347826, 0
20672, 0.34782608695652, 1.0891304347826, 0
20673, 0.30434782608696, 1.0891304347826, 0
20674, 0.26086956521739, 1.0891304347826, 0
20675, 0.21739130434783, 1.0891304347826, 0
20676, 0.17391304347826, 1.0891304347826, 0
20677, 0.1304347826087, 1.0891304347826, 0
20678, 0.08695652173913, 1.0891304347826, 0
20679, 0.043478260869565, 1.0891304347826, 0
20680, 0.95652173913043, 1.1413043478261, 0
20681, 0.91304347826087, 1.1413043478261, 0
20682, 0.8695652173913, 1.1413043478261, 0
20683, 0.82608695652174, 1.1413043478261, 0
20684, 0.78260869565217, 1.1413043478261, 0
20685, 0.73913043478261, 1.1413043478261, 0
20686, 0.69565217391304, 1.1413043478261, 0
20687, 0.65217391304348, 1.1413043478261, 0
20688, 0.60869565217391, 1.1413043478261, 0
20689, 0.56521739130435, 1.1413043478261, 0
20690, 0.52173913043478, 1.1413043478261, 0
20691, 0.47826086956522, 1.1413043478261, 0
20692, 0.43478260869565, 1.1413043478261, 0
20693, 0.39130434782609, 1.1413043478261, 0
20694, 0.34782608695652, 1.1413043478261, 0
20695, 0.30434782608696, 1.1413043478261, 0
20696, 0.26086956521739, 1.1413043478261, 0
20697, 0.21739130434783, 1.1413043478261, 0
20698, 0.17391304347826, 1.1413043478261, 0
20699, 0.1304347826087, 1.1413043478261, 0
20700, 0.08695652173913, 1.1413043478261, 0
20701, 0.043478260869565, 1.1413043478261, 0
20702, 0.95652173913043, 1.1934782608696, 0
20703, 0.91304347826087, 1.1934782608696, 0
20704, 0.8695652173913, 1.1934782608696, 0
20705, 0.82608695652174, 1.1934782608696, 0
20706, 0.78260869565217, 1.1934782608696, 0
20707, 0.73913043478261, 1.1934782608696, 0
20708, 0.69565217391304, 1.1934782608696, 0
20709, 0.65217391304348, 1.1934782608696, 0
20710, 0.60869565217391, 1.1934782608696, 0
20711, 0.56521739130435, 1.1934782608696, 0
20712, 0.52173913043478, 1.1934782608696, 0
20713, 0.47826086956522, 1.1934782608696, 0
20714, 0.43478260869565, 1.1934782608696, 0
20715, 0.39130434782609, 1.1934782608696, 0
20716, 0.34782608695652, 1.1934782608696, 0
20717, 0.30434782608696, 1.1934782608696, 0
20718, 0.26086956521739, 1.1934782608696, 0
20719, 0.21739130434783, 1.1934782608696, 0
20720, 0.17391304347826, 1.1934782608696, 0
20721, 0.1304347826087, 1.1934782608696, 0
20722, 0.08695652173913, 1.1934782608696, 0
20723, 0.043478260869565, 1.1934782608696, 0
20724, 0.95652173913043, 1.245652173913, 0
20725, 0.91304347826087, 1.245652173913, 0
20726, 0.8695652173913, 1.245652173913, 0
20727, 0.82608695652174, 1.245652173913, 0
20728, 0.78260869565217, 1.245652173913, 0
20729, 0.73913043478261, 1.245652173913, 0
20730, 0.69565217391304, 1.245652173913, 0
20731, 0.65217391304348, 1.245652173913, 0
20732, 0.60869565217391, 1.245652173913, 0
20733, 0.56521739130435, 1.245652173913, 0
20734, 0.52173913043478, 1.245652173913, 0
20735, 0.47826086956522, 1.245652173913, 0
20736, 0.43478260869565, 1.245652173913, 0
20737, 0.39130434782609, 1.245652173913, 0
20738, 0.34782608695652, 1.245652173913, 0
20739, 0.30434782608696, 1.245652173913, 0
20740, 0.26086956521739, 1.245652173913, 0
20741, 0.21739130434783, 1.245652173913, 0
20742, 0.17391304347826, 1.245652173913, 0
20743, 0.1304347826087, 1.245652173913, 0
20744, 0.08695652173913, 1.245652173913, 0
20745, 0.043478260869565, 1.245652173913, 0
20746, 0.95652173913043, 1.2978260869565, 0
20747, 0.91304347826087, 1.2978260869565, 0
20748, 0.8695652173913, 1.2978260869565, 0
20749, 0.82608695652174, 1.2978260869565, 0
20750, 0.78260869565217, 1.2978260869565, 0
20751, 0.73913043478261, 1.2978260869565, 0
20752, 0.69565217391304, 1.2978260869565, 0
20753, 0.65217391304348, 1.2978260869565, 0
20754, 0.60869565217391, 1.2978260869565, 0
20755, 0.56521739130435, 1.2978260869565, 0
20756, 0.52173913043478, 1.2978260869565, 0
20757, 0.47826086956522, 1.2978260869565, 0
20758, 0.43478260869565, 1.2978260869565, 0
20759, 0.39130434782609, 1.2978260869565, 0
20760, 0.34782608695652, 1.2978260869565, 0
20761, 0.30434782608696, 1.2978260869565, 0
20762, 0.26086956521739, 1.2978260869565, 0
20763, 0.21739130434783, 1.2978260869565, 0
20764, 0.17391304347826, 1.2978260869565, 0
20765, 0.1304347826087, 1.2978260869565, 0
20766, 0.08695652173913, 1.2978260869565, 0
20767, 0.043478260869565, 1.2978260869565, 0
20768, 0.95652173913043, 0.17608695652174, 0
20769, 0.97826086956522, 0.20217391304348, 0
20770, 0.91304347826087, 0.17608695652174, 0
20771, 0.93478260869565, 0.20217391304348, 0
20772, 0.8695652173913, 0.17608695652174, 0
20773, 0.89130434782609, 0.20217391304348, 0
20774, 0.82608695652174, 0.17608695652174, 0
20775, 0.84782608695652, 0.20217391304348, 0
20776, 0.78260869565217, 0.17608695652174, 0
20777, 0.80434782608696, 0.20217391304348, 0
20778, 0.73913043478261, 0.17608695652174, 0
20779, 0.76086956521739, 0.20217391304348, 0
20780, 0.69565217391304, 0.17608695652174, 0
20781, 0.71739130434783, 0.20217391304348, 0
20782, 0.65217391304348, 0.17608695652174, 0
20783, 0.67391304347826, 0.20217391304348, 0
20784, 0.60869565217391, 0.17608695652174, 0
20785, 0.6304347826087, 0.20217391304348, 0
20786, 0.56521739130435, 0.17608695652174, 0
20787, 0.58695652173913, 0.20217391304348, 0
20788, 0.52173913043478, 0.17608695652174, 0
20789, 0.54347826086957, 0.20217391304348, 0
20790, 0.47826086956522, 0.17608695652174, 0
20791, 0.5, 0.20217391304348, 0
20792, 0.43478260869565, 0.17608695652174, 0
20793, 0.45652173913043, 0.20217391304348, 0
20794, 0.39130434782609, 0.17608695652174, 0
20795, 0.41304347826087, 0.20217391304348, 0
20796, 0.34782608695652, 0.17608695652174, 0
20797, 0.3695652173913, 0.20217391304348, 0
20798, 0.30434782608696, 0.17608695652174, 0
20799, 0.32608695652174, 0.20217391304348, 0
20800, 0.26086956521739, 0.17608695652174, 0
20801, 0.28260869565217, 0.20217391304348, 0
20802, 0.21739130434783, 0.17608695652174, 0
20803, 0.23913043478261, 0.20217391304348, 0
20804, 0.17391304347826, 0.17608695652174, 0
20805, 0.19565217391304, 0.20217391304348, 0
20806, 0.1304347826087, 0.17608695652174, 0
20807, 0.15217391304348, 0.20217391304348, 0
20808, 0.08695652173913, 0.17608695652174, 0
20809, 0.10869565217391, 0.20217391304348, 0
20810, 0.043478260869565, 0.17608695652174, 0
20811, 0.065217391304348, 0.20217391304348, 0
20812, 0.021739130434783, 0.20217391304348, 0
20813, 0.95652173913043, 0.22826086956522, 0
20814, 0.97826086956522, 0.25434782608696, 0
20815, 0.91304347826087, 0.22826086956522, 0
20816, 0.93478260869565, 0.25434782608696, 0
20817, 0.8695652173913, 0.22826086956522, 0
20818, 0.89130434782609, 0.25434782608696, 0
20819, 0.82608695652174, 0.22826086956522, 0
20820, 0.84782608695652, 0.25434782608696, 0
20821, 0.78260869565217, 0.22826086956522, 0
20822, 0.80434782608696, 0.25434782608696, 0
20823, 0.73913043478261, 0.22826086956522, 0
20824, 0.76086956521739, 0.25434782608696, 0
20825, 0.69565217391304, 0.22826086956522, 0
20826, 0.71739130434783, 0.25434782608696, 0
20827, 0.65217391304348, 0.22826086956522, 0
20828, 0.67391304347826, 0.25434782608696, 0
20829, 0.60869565217391, 0.22826086956522, 0
20830, 0.6304347826087, 0.25434782608696, 0
20831, 0.56521739130435, 0.22826086956522, 0
20832, 0.58695652173913, 0.25434782608696, 0
20833, 0.52173913043478, 0.22826086956522, 0
20834, 0.54347826086957, 0.25434782608696, 0
20835, 0.47826086956522, 0.22826086956522, 0
20836, 0.5, 0.25434782608696, 0
20837, 0.43478260869565, 0.22826086956522, 0
20838, 0.45652173913043, 0.25434782608696, 0
20839, 0.39130434782609, 0.22826086956522, 0
20840, 0.41304347826087, 0.25434782608696, 0
20841, 0.34782608695652, 0.22826086956522, 0
20842, 0.3695652173913, 0.25434782608696, 0
20843, 0.30434782608696, 0.22826086956522, 0
20844, 0.32608695652174, 0.25434782608696, 0
20845, 0.26086956521739, 0.22826086956522, 0
20846, 0.28260869565217, 0.25434782608696, 0
20847, 0.21739130434783, 0.22826086956522, 0
20848, 0.23913043478261, 0.25434782608696, 0
20849, 0.17391304347826, 0.22826086956522, 0
20850, 0.19565217391304, 0.25434782608696, 0
20851, 0.1304347826087, 0.22826086956522, 0
20852, 0.15217391304348, 0.25434782608696, 0
20853, 0.08695652173913, 0.22826086956522, 0
20854, 0.10869565217391, 0.25434782608696, 0
20855, 0.043478260869565, 0.22826086956522, 0
20856, 0.065217391304348, 0.25434782608696, 0
20857, 0.021739130434783, 0.25434782608696, 0
20858, 0.95652173913043, 0.2804347826087, 0
20859, 0.97826086956522, 0.30652173913043, 0
20860, 0.91304347826087, 0.2804347826087, 0
20861, 0.93478260869565, 0.30652173913043, 0
20862, 0.8695652173913, 0.2804347826087, 0
20863, 0.89130434782609, 0.30652173913043, 0
20864, 0.82608695652174, 0.2804347826087, 0
20865, 0.84782608695652, 0.30652173913043, 0
20866, 0.78260869565217, 0.2804347826087, 0
20867, 0.80434782608696, 0.30652173913043, 0
20868, 0.73913043478261, 0.2804347826087, 0
20869, 0.76086956521739, 0.30652173913043, 0
20870, 0.69565217391304, 0.2804347826087, 0
20871, 0.71739130434783, 0.30652173913043, 0
20872, 0.65217391304348, 0.2804347826087, 0
20873, 0.67391304347826, 0.30652173913043, 0
20874, 0.60869565217391, 0.2804347826087, 0
20875, 0.6304347826087, 0.30652173913043, 0
20876, 0.56521739130435, 0.2804347826087, 0
20877, 0.58695652173913, 0.30652173913043, 0
20878, 0.52173913043478, 0.2804347826087, 0
20879, 0.54347826086957, 0.30652173913043, 0
20880, 0.47826086956522, 0.2804347826087, 0
20881, 0.5, 0.30652173913043, 0
20882, 0.43478260869565, 0.2804347826087, 0
20883, 0.45652173913043, 0.30652173913043, 0
20884, 0.39130434782609, 0.2804347826087, 0
20885, 0.41304347826087, 0.30652173913043, 0
20886, 0.34782608695652, 0.2804347826087, 0
20887, 0.3695652173913, 0.30652173913043, 0
20888, 0.30434782608696, 0.2804347826087, 0
20889, 0.32608695652174, 0.30652173913043, 0
20890, 0.26086956521739, 0.2804347826087, 0
20891, 0.28260869565217, 0.30652173913043, 0
20892, 0.21739130434783, 0.2804347826087, 0
20893, 0.23913043478261, 0.30652173913043, 0
20894, 0.17391304347826, 0.2804347826087, 0
20895, 0.19565217391304, 0.30652173913043, 0
20896, 0.1304347826087, 0.2804347826087, 0
20897, 0.15217391304348, 0.30652173913043, 0
20898, 0.08695652173913, 0.2804347826087, 0
20899, 0.10869565217391, 0.30652173913043, 0
20900, 0.043478260869565, 0.2804347826087, 0
20901, 0.065217391304348, 0.30652173913043, 0
20902, 0.021739130434783, 0.30652173913043, 0
20903, 0.95652173913043, 0.33260869565217, 0
20904, 0.97826086956522, 0.35869565217391, 0
20905, 0.91304347826087, 0.33260869565217, 0
20906, 0.93478260869565, 0.35869565217391, 0
20907, 0.8695652173913, 0.33260869565217, 0
20908, 0.89130434782609, 0.35869565217391, 0
20909, 0.82608695652174, 0.33260869565217, 0
20910, 0.84782608695652, 0.35869565217391, 0
20911, 0.78260869565217, 0.33260869565217, 0
20912, 0.80434782608696, 0.35869565217391, 0
20913, 0.73913043478261, 0.33260869565217, 0
20914, 0.76086956521739, 0.35869565217391, 0
20915, 0.69565217391304, 0.33260869565217, 0
20916, 0.71739130434783, 0.35869565217391, 0
20917, 0.65217391304348, 0.33260869565217, 0
20918, 0.67391304347826, 0.35869565217391, 0
20919, 0.60869565217391, 0.33260869565217, 0
20920, 0.6304347826087, 0.35869565217391, 0
20921, 0.56521739130435, 0.33260869565217, 0
20922, 0.58695652173913, 0.35869565217391, 0
20923, 0.52173913043478, 0.33260869565217, 0
20924, 0.54347826086957, 0.35869565217391, 0
20925, 0.47826086956522, 0.33260869565217, 0
20926, 0.5, 0.35869565217391, 0
20927, 0.43478260869565, 0.33260869565217, 0
20928, 0.45652173913043, 0.35869565217391, 0
20929, 0.39130434782609, 0.33260869565217, 0
20930, 0.41304347826087, 0.35869565217391, 0
20931, 0.34782608695652, 0.33260869565217, 0
20932, 0.3695652173913, 0.35869565217391, 0
20933, 0.30434782608696, 0.33260869565217, 0
20934, 0.32608695652174, 0.35869565217391, 0
20935, 0.26086956521739, 0.33260869565217, 0
20936, 0.28260869565217, 0.35869565217391, 0
20937, 0.21739130434783, 0.33260869565217, 0
20938, 0.23913043478261, 0.35869565217391, 0
20939, 0.17391304347826, 0.33260869565217, 0
20940, 0.19565217391304, 0.35869565217391, 0
20941, 0.1304347826087, 0.33260869565217, 0
20942, 0.15217391304348, 0.35869565217391, 0
20943, 0.08695652173913, 0.33260869565217, 0
20944, 0.10869565217391, 0.35869565217391, 0
20945, 0.043478260869565, 0.33260869565217, 0
20946, 0.065217391304348, 0.35869565217391, 0
20947, 0.021739130434783, 0.35869565217391, 0
20948, 0.95652173913043, 0.38478260869565, 0
20949, 0.97826086956522, 0.41086956521739, 0
20950, 0.91304347826087, 0.38478260869565, 0
20951, 0.93478260869565, 0.41086956521739, 0
20952, 0.8695652173913, 0.38478260869565, 0
20953, 0.89130434782609, 0.41086956521739, 0
20954, 0.82608695652174, 0.38478260869565, 0
20955, 0.84782608695652, 0.41086956521739, 0
20956, 0.78260869565217, 0.38478260869565, 0
20957, 0.80434782608696, 0.41086956521739, 0
20958, 0.73913043478261, 0.38478260869565, 0
20959, 0.76086956521739, 0.41086956521739, 0
20960, 0.69565217391304, 0.38478260869565, 0
20961, 0.71739130434783, 0.41086956521739, 0
20962, 0.65217391304348, 0.38478260869565, 0
20963, 0.67391304347826, 0.41086956521739, 0
20964, 0.60869565217391, 0.38478260869565, 0
20965, 0.6304347826087, 0.41086956521739, 0
20966, 0.56521739130435, 0.38478260869565, 0
20967, 0.58695652173913, 0.41086956521739, 0
20968, 0.52173913043478, 0.38478260869565, 0
20969, 0.54347826086957, 0.41086956521739, 0
20970, 0.47826086956522, 0.38478260869565, 0
20971, 0.5, 0.41086956521739, 0
20972, 0.43478260869565, 0.38478260869565, 0
20973, 0.45652173913043, 0.41086956521739, 0
20974, 0.39130434782609, 0.38478260869565, 0
20975, 0.41304347826087, 0.41086956521739, 0
20976, 0.34782608695652, 0.38478260869565, 0
20977, 0.3695652173913, 0.41086956521739, 0
20978, 0.30434782608696, 0.38478260869565, 0
20979, 0.32608695652174, 0.41086956521739, 0
20980, 0.26086956521739, 0.38478260869565, 0
20981, 0.28260869565217, 0.41086956521739, 0
20982, 0.21739130434783, 0.38478260869565, 0
20983, 0.23913043478261, 0.41086956521739, 0
20984, 0.17391304347826, 0.38478260869565, 0
20985, 0.19565217391304, 0.41086956521739, 0
20986, 0.1304347826087, 0.38478260869565, 0
20987, 0.15217391304348, 0.41086956521739, 0
20988, 0.08695652173913, 0.38478260869565, 0
20989, 0.10869565217391, 0.41086956521739, 0
20990, 0.043478260869565, 0.38478260869565, 0
20991, 0.065217391304348, 0.41086956521739, 0
20992, 0.021739130434783, 0.41086956521739, 0
20993, 0.95652173913043, 0.43695652173913, 0
20994, 0.97826086956522, 0.46304347826087, 0
20995, 0.91304347826087, 0.43695652173913, 0
20996, 0.93478260869565, 0.46304347826087, 0
20997, 0.8695652173913, 0.43695652173913, 0
20998, 0.89130434782609, 0.46304347826087, 0
20999, 0.82608695652174, 0.43695652173913, 0
21000, 0.84782608695652, 0.46304347826087, 0
21001, 0.78260869565217, 0.43695652173913, 0
21002, 0.80434782608696, 0.46304347826087, 0
21003, 0.73913043478261, 0.43695652173913, 0
21004, 0.76086956521739, 0.46304347826087, 0
21005, 0.69565217391304, 0.43695652173913, 0
21006, 0.71739130434783, 0.46304347826087, 0
21007, 0.65217391304348, 0.43695652173913, 0
21008, 0.67391304347826, 0.46304347826087, 0
21009, 0.60869565217391, 0.43695652173913, 0
21010, 0.6304347826087, 0.46304347826087, 0
21011, 0.56521739130435, 0.43695652173913, 0
21012, 0.58695652173913, 0.46304347826087, 0
21013, 0.52173913043478, 0.43695652173913, 0
21014, 0.54347826086957, 0.46304347826087, 0
21015, 0.47826086956522, 0.43695652173913, 0
21016, 0.5, 0.46304347826087, 0
21017, 0.43478260869565, 0.43695652173913, 0
21018, 0.45652173913043, 0.46304347826087, 0
21019, 0.39130434782609, 0.43695652173913, 0
21020, 0.41304347826087, 0.46304347826087, 0
21021, 0.34782608695652, 0.43695652173913, 0
21022, 0.3695652173913, 0.46304347826087, 0
21023, 0.30434782608696, 0.43695652173913, 0
21024, 0.32608695652174, 0.46304347826087, 0
21025, 0.26086956521739, 0.43695652173913, 0
21026, 0.28260869565217, 0.46304347826087, 0
21027, 0.21739130434783, 0.43695652173913, 0
21028, 0.23913043478261, 0.46304347826087, 0
21029, 0.17391304347826, 0.43695652173913, 0
21030, 0.19565217391304, 0.46304347826087, 0
21031, 0.1304347826087, 0.43695652173913, 0
21032, 0.15217391304348, 0.46304347826087, 0
21033, 0.08695652173913, 0.43695652173913, 0
21034, 0.10869565217391, 0.46304347826087, 0
21035, 0.043478260869565, 0.43695652173913, 0
21036, 0.065217391304348, 0.46304347826087, 0
21037, 0.021739130434783, 0.46304347826087, 0
21038, 0.95652173913043, 0.48913043478261, 0
21039, 0.97826086956522, 0.51521739130435, 0
21040, 0.91304347826087, 0.48913043478261, 0
21041, 0.93478260869565, 0.51521739130435, 0
21042, 0.8695652173913, 0.48913043478261, 0
21043, 0.89130434782609, 0.51521739130435, 0
21044, 0.82608695652174, 0.48913043478261, 0
21045, 0.84782608695652, 0.51521739130435, 0
21046, 0.78260869565217, 0.48913043478261, 0
21047, 0.80434782608696, 0.51521739130435, 0
21048, 0.73913043478261, 0.48913043478261, 0
21049, 0.76086956521739, 0.51521739130435, 0
21050, 0.69565217391304, 0.48913043478261, 0
21051, 0.71739130434783, 0.51521739130435, 0
21052, 0.65217391304348, 0.48913043478261, 0
21053, 0.67391304347826, 0.51521739130435, 0
21054, 0.60869565217391, 0.48913043478261, 0
21055, 0.6304347826087, 0.51521739130435, 0
21056, 0.56521739130435, 0.48913043478261, 0
21057, 0.58695652173913, 0.51521739130435, 0
21058, 0.52173913043478, 0.48913043478261, 0
21059, 0.54347826086957, 0.51521739130435, 0
21060, 0.47826086956522, 0.48913043478261, 0
21061, 0.5, 0.51521739130435, 0
21062, 0.43478260869565, 0.48913043478261, 0
21063, 0.45652173913043, 0.51521739130435, 0
21064, 0.39130434782609, 0.48913043478261, 0
21065, 0.41304347826087, 0.51521739130435, 0
21066, 0.34782608695652, 0.48913043478261, 0
21067, 0.3695652173913, 0.51521739130435, 0
21068, 0.30434782608696, 0.48913043478261, 0
21069, 0.32608695652174, 0.51521739130435, 0
21070, 0.26086956521739, 0.48913043478261, 0
21071, 0.28260869565217, 0.51521739130435, 0
21072, 0.21739130434783, 0.48913043478261, 0
21073, 0.23913043478261, 0.51521739130435, 0
21074, 0.17391304347826, 0.48913043478261, 0
21075, 0.19565217391304, 0.51521739130435, 0
21076, 0.1304347826087, 0.48913043478261, 0
21077, 0.15217391304348, 0.51521739130435, 0
21078, 0.08695652173913, 0.48913043478261, 0
21079, 0.10869565217391, 0.51521739130435, 0
21080, 0.043478260869565, 0.48913043478261, 0
21081, 0.065217391304348, 0.51521739130435, 0
21082, 0.021739130434783, 0.51521739130435, 0
21083, 0.95652173913043, 0.54130434782609, 0
21084, 0.97826086956522, 0.56739130434783, 0
21085, 0.91304347826087, 0.54130434782609, 0
21086, 0.93478260869565, 0.56739130434783, 0
21087, 0.8695652173913, 0.54130434782609, 0
21088, 0.89130434782609, 0.56739130434783, 0
21089, 0.82608695652174, 0.54130434782609, 0
21090, 0.84782608695652, 0.56739130434783, 0
21091, 0.78260869565217, 0.54130434782609, 0
21092, 0.80434782608696, 0.56739130434783, 0
21093, 0.73913043478261, 0.54130434782609, 0
21094, 0.76086956521739, 0.56739130434783, 0
21095, 0.69565217391304, 0.54130434782609, 0
21096, 0.71739130434783, 0.56739130434783, 0
21097, 0.65217391304348, 0.54130434782609, 0
21098, 0.67391304347826, 0.56739130434783, 0
21099, 0.60869565217391, 0.54130434782609, 0
21100, 0.6304347826087, 0.56739130434783, 0
21101, 0.56521739130435, 0.54130434782609, 0
21102, 0.58695652173913, 0.56739130434783, 0
21103, 0.52173913043478, 0.54130434782609, 0
21104, 0.54347826086957, 0.56739130434783, 0
21105, 0.47826086956522, 0.54130434782609, 0
21106, 0.5, 0.56739130434783, 0
21107, 0.43478260869565, 0.54130434782609, 0
21108, 0.45652173913043, 0.56739130434783, 0
21109, 0.39130434782609, 0.54130434782609, 0
21110, 0.41304347826087, 0.56739130434783, 0
21111, 0.34782608695652, 0.54130434782609, 0
21112, 0.3695652173913, 0.56739130434783, 0
21113, 0.30434782608696, 0.54130434782609, 0
21114, 0.32608695652174, 0.56739130434783, 0
21115, 0.26086956521739, 0.54130434782609, 0
21116, 0.28260869565217, 0.56739130434783, 0
21117, 0.21739130434783, 0.54130434782609, 0
21118, 0.23913043478261, 0.56739130434783, 0
21119, 0.17391304347826, 0.54130434782609, 0
21120, 0.19565217391304, 0.56739130434783, 0
21121, 0.1304347826087, 0.54130434782609, 0
21122, 0.15217391304348, 0.56739130434783, 0
21123, 0.08695652173913, 0.54130434782609, 0
21124, 0.10869565217391, 0.56739130434783, 0
21125, 0.043478260869565, 0.54130434782609, 0
21126, 0.065217391304348, 0.56739130434783, 0
21127, 0.021739130434783, 0.56739130434783, 0
21128, 0.95652173913043, 0.59347826086956, 0
21129, 0.97826086956522, 0.6195652173913, 0
21130, 0.91304347826087, 0.59347826086956, 0
21131, 0.93478260869565, 0.6195652173913, 0
21132, 0.8695652173913, 0.59347826086956, 0
21133, 0.89130434782609, 0.6195652173913, 0
21134, 0.82608695652174, 0.59347826086956, 0
21135, 0.84782608695652, 0.6195652173913, 0
21136, 0.78260869565217, 0.59347826086956, 0
21137, 0.80434782608696, 0.6195652173913, 0
21138, 0.73913043478261, 0.59347826086956, 0
21139, 0.76086956521739, 0.6195652173913, 0
21140, 0.69565217391304, 0.59347826086956, 0
21141, 0.71739130434783, 0.6195652173913, 0
21142, 0.65217391304348, 0.59347826086956, 0
21143, 0.67391304347826, 0.6195652173913, 0
21144, 0.60869565217391, 0.59347826086956, 0
21145, 0.6304347826087, 0.6195652173913, 0
21146, 0.56521739130435, 0.59347826086956, 0
21147, 0.58695652173913, 0.6195652173913, 0
21148, 0.52173913043478, 0.59347826086956, 0
21149, 0.54347826086957, 0.6195652173913, 0
21150, 0.47826086956522, 0.59347826086956, 0
21151, 0.5, 0.6195652173913, 0
21152, 0.43478260869565, 0.59347826086956, 0
21153, 0.45652173913043, 0.6195652173913, 0
21154, 0.39130434782609, 0.59347826086956, 0
21155, 0.41304347826087, 0.6195652173913, 0
21156, 0.34782608695652, 0.59347826086956, 0
21157, 0.3695652173913, 0.6195652173913, 0
21158, 0.30434782608696, 0.59347826086956, 0
21159, 0.32608695652174, 0.6195652173913, 0
21160, 0.26086956521739, 0.59347826086956, 0
21161, 0.28260869565217, 0.6195652173913, 0
21162, 0.21739130434783, 0.59347826086956, 0
21163, 0.23913043478261, 0.6195652173913, 0
21164, 0.17391304347826, 0.59347826086956, 0
21165, 0.19565217391304, 0.6195652173913, 0
21166, 0.1304347826087, 0.59347826086956, 0
21167, 0.15217391304348, 0.6195652173913, 0
21168, 0.08695652173913, 0.59347826086956, 0
21169, 0.10869565217391, 0.6195652173913, 0
21170, 0.043478260869565, 0.59347826086956, 0
21171, 0.065217391304348, 0.6195652173913, 0
21172, 0.021739130434783, 0.6195652173913, 0
21173, 0.95652173913043, 0.64565217391304, 0
21174, 0.97826086956522, 0.67173913043478, 0
21175, 0.91304347826087, 0.64565217391304, 0
21176, 0.93478260869565, 0.67173913043478, 0
21177, 0.8695652173913, 0.64565217391304, 0
21178, 0.89130434782609, 0.67173913043478, 0
21179, 0.82608695652174, 0.64565217391304, 0
21180, 0.84782608695652, 0.67173913043478, 0
21181, 0.78260869565217, 0.64565217391304, 0
21182, 0.80434782608696, 0.67173913043478, 0
21183, 0.73913043478261, 0.64565217391304, 0
21184, 0.76086956521739, 0.67173913043478, 0
21185, 0.69565217391304, 0.64565217391304, 0
21186, 0.71739130434783, 0.67173913043478, 0
21187, 0.65217391304348, 0.64565217391304, 0
21188, 0.67391304347826, 0.67173913043478, 0
21189, 0.60869565217391, 0.64565217391304, 0
21190, 0.6304347826087, 0.67173913043478, 0
21191, 0.56521739130435, 0.64565217391304, 0
21192, 0.58695652173913, 0.67173913043478, 0
21193, 0.52173913043478, 0.64565217391304, 0
21194, 0.54347826086957, 0.67173913043478, 0
21195, 0.47826086956522, 0.64565217391304, 0
21196, 0.5, 0.67173913043478, 0
21197, 0.43478260869565, 0.64565217391304, 0
21198, 0.45652173913043, 0.67173913043478, 0
21199, 0.39130434782609, 0.64565217391304, 0
21200, 0.41304347826087, 0.67173913043478, 0
21201, 0.34782608695652, 0.64565217391304, 0
21202, 0.3695652173913, 0.67173913043478, 0
21203, 0.30434782608696, 0.64565217391304, 0
21204, 0.32608695652174, 0.67173913043478, 0
21205, 0.26086956521739, 0.64565217391304, 0
21206, 0.28260869565217, 0.67173913043478, 0
21207, 0.21739130434783, 0.64565217391304, 0
21208, 0.23913043478261, 0.67173913043478, 0
21209, 0.17391304347826, 0.64565217391304, 0
21210, 0.19565217391304, 0.67173913043478, 0
21211, 0.1304347826087, 0.64565217391304, 0
21212, 0.15217391304348, 0.67173913043478, 0
21213, 0.08695652173913, 0.64565217391304, 0
21214, 0.10869565217391, 0.67173913043478, 0
21215, 0.043478260869565, 0.64565217391304, 0
21216, 0.065217391304348, 0.67173913043478, 0
21217, 0.021739130434783, 0.67173913043478, 0
21218, 0.95652173913043, 0.69782608695652, 0
21219, 0.97826086956522, 0.72391304347826, 0
21220, 0.91304347826087, 0.69782608695652, 0
21221, 0.93478260869565, 0.72391304347826, 0
21222, 0.8695652173913, 0.69782608695652, 0
21223, 0.89130434782609, 0.72391304347826, 0
21224, 0.82608695652174, 0.69782608695652, 0
21225, 0.84782608695652, 0.72391304347826, 0
21226, 0.78260869565217, 0.69782608695652, 0
21227, 0.80434782608696, 0.72391304347826, 0
21228, 0.73913043478261, 0.69782608695652, 0
21229, 0.76086956521739, 0.72391304347826, 0
21230, 0.69565217391304, 0.69782608695652, 0
21231, 0.71739130434783, 0.72391304347826, 0
21232, 0.65217391304348, 0.69782608695652, 0
21233, 0.67391304347826, 0.72391304347826, 0
21234, 0.60869565217391, 0.69782608695652, 0
21235, 0.6304347826087, 0.72391304347826, 0
21236, 0.56521739130435, 0.69782608695652, 0
21237, 0.58695652173913, 0.72391304347826, 0
21238, 0.52173913043478, 0.69782608695652, 0
21239, 0.54347826086957, 0.72391304347826, 0
21240, 0.47826086956522, 0.69782608695652, 0
21241, 0.5, 0.72391304347826, 0
21242, 0.43478260869565, 0.69782608695652, 0
21243, 0.45652173913043, 0.72391304347826, 0
21244, 0.39130434782609, 0.69782608695652, 0
21245, 0.41304347826087, 0.72391304347826, 0
21246, 0.34782608695652, 0.69782608695652, 0
21247, 0.3695652173913, 0.72391304347826, 0
21248, 0.30434782608696, 0.69782608695652, 0
21249, 0.32608695652174, 0.72391304347826, 0
21250, 0.26086956521739, 0.69782608695652, 0
21251, 0.28260869565217, 0.72391304347826, 0
21252, 0.21739130434783, 0.69782608695652, 0
21253, 0.23913043478261, 0.72391304347826, 0
21254, 0.17391304347826, 0.69782608695652, 0
21255, 0.19565217391304, 0.72391304347826, 0
21256, 0.1304347826087, 0.69782608695652, 0
21257, 0.15217391304348, 0.72391304347826, 0
21258, 0.08695652173913, 0.69782608695652, 0
21259, 0.10869565217391, 0.72391304347826, 0
21260, 0.043478260869565, 0.69782608695652, 0
21261, 0.065217391304348, 0.72391304347826, 0
21262, 0.021739130434783, 0.72391304347826, 0
21263, 0.95652173913043, 0.75, 0
21264, 0.97826086956522, 0.77608695652174, 0
21265, 0.91304347826087, 0.75, 0
21266, 0.93478260869565, 0.77608695652174, 0
21267, 0.8695652173913, 0.75, 0
21268, 0.89130434782609, 0.77608695652174, 0
21269, 0.82608695652174, 0.75, 0
21270, 0.84782608695652, 0.77608695652174, 0
21271, 0.78260869565217, 0.75, 0
21272, 0.80434782608696, 0.77608695652174, 0
21273, 0.73913043478261, 0.75, 0
21274, 0.76086956521739, 0.77608695652174, 0
21275, 0.69565217391304, 0.75, 0
21276, 0.71739130434783, 0.77608695652174, 0
21277, 0.65217391304348, 0.75, 0
21278, 0.67391304347826, 0.77608695652174, 0
21279, 0.60869565217391, 0.75, 0
21280, 0.6304347826087, 0.77608695652174, 0
21281, 0.56521739130435, 0.75, 0
21282, 0.58695652173913, 0.77608695652174, 0
21283, 0.52173913043478, 0.75, 0
21284, 0.54347826086957, 0.77608695652174, 0
21285, 0.47826086956522, 0.75, 0
21286, 0.5, 0.77608695652174, 0
21287, 0.43478260869565, 0.75, 0
21288, 0.45652173913043, 0.77608695652174, 0
21289, 0.39130434782609, 0.75, 0
21290, 0.41304347826087, 0.77608695652174, 0
21291, 0.34782608695652, 0.75, 0
21292, 0.3695652173913, 0.77608695652174, 0
21293, 0.30434782608696, 0.75, 0
21294, 0.32608695652174, 0.77608695652174, 0
21295, 0.26086956521739, 0.75, 0
21296, 0.28260869565217, 0.77608695652174, 0
21297, 0.21739130434783, 0.75, 0
21298, 0.23913043478261, 0.77608695652174, 0
21299, 0.17391304347826, 0.75, 0
21300, 0.19565217391304, 0.77608695652174, 0
21301, 0.1304347826087, 0.75, 0
21302, 0.15217391304348, 0.77608695652174, 0
21303, 0.08695652173913, 0.75, 0
21304, 0.10869565217391, 0.77608695652174, 0
21305, 0.043478260869565, 0.75, 0
21306, 0.065217391304348, 0.77608695652174, 0
21307, 0.021739130434783, 0.77608695652174, 0
21308, 0.95652173913043, 0.80217391304348, 0
21309, 0.97826086956522, 0.82826086956522, 0
21310, 0.91304347826087, 0.80217391304348, 0
21311, 0.93478260869565, 0.82826086956522, 0
21312, 0.8695652173913, 0.80217391304348, 0
21313, 0.89130434782609, 0.82826086956522, 0
21314, 0.82608695652174, 0.80217391304348, 0
21315, 0.84782608695652, 0.82826086956522, 0
21316, 0.78260869565217, 0.80217391304348, 0
21317, 0.80434782608696, 0.82826086956522, 0
21318, 0.73913043478261, 0.80217391304348, 0
21319, 0.76086956521739, 0.82826086956522, 0
21320, 0.69565217391304, 0.80217391304348, 0
21321, 0.71739130434783, 0.82826086956522, 0
21322, 0.65217391304348, 0.80217391304348, 0
21323, 0.67391304347826, 0.82826086956522, 0
21324, 0.60869565217391, 0.80217391304348, 0
21325, 0.6304347826087, 0.82826086956522, 0
21326, 0.56521739130435, 0.80217391304348, 0
21327, 0.58695652173913, 0.82826086956522, 0
21328, 0.52173913043478, 0.80217391304348, 0
21329, 0.54347826086957, 0.82826086956522, 0
21330, 0.47826086956522, 0.80217391304348, 0
21331, 0.5, 0.82826086956522, 0
21332, 0.43478260869565, 0.80217391304348, 0
21333, 0.45652173913043, 0.82826086956522, 0
21334, 0.39130434782609, 0.80217391304348, 0
21335, 0.41304347826087, 0.82826086956522, 0
21336, 0.34782608695652, 0.80217391304348, 0
21337, 0.3695652173913, 0.82826086956522, 0
21338, 0.30434782608696, 0.80217391304348, 0
21339, 0.32608695652174, 0.82826086956522, 0
21340, 0.26086956521739, 0.80217391304348, 0
21341, 0.28260869565217, 0.82826086956522, 0
21342, 0.21739130434783, 0.80217391304348, 0
21343, 0.23913043478261, 0.82826086956522, 0
21344, 0.17391304347826, 0.80217391304348, 0
21345, 0.19565217391304, 0.82826086956522, 0
21346, 0.1304347826087, 0.80217391304348, 0
21347, 0.15217391304348, 0.82826086956522, 0
21348, 0.08695652173913, 0.80217391304348, 0
21349, 0.10869565217391, 0.82826086956522, 0
21350, 0.043478260869565, 0.80217391304348, 0
21351, 0.065217391304348, 0.82826086956522, 0
21352, 0.021739130434783, 0.82826086956522, 0
21353, 0.95652173913043, 0.85434782608696, 0
21354, 0.97826086956522, 0.8804347826087, 0
21355, 0.91304347826087, 0.85434782608696, 0
21356, 0.93478260869565, 0.8804347826087, 0
21357, 0.8695652173913, 0.85434782608696, 0
21358, 0.89130434782609, 0.8804347826087, 0
21359, 0.82608695652174, 0.85434782608696, 0
21360, 0.84782608695652, 0.8804347826087, 0
21361, 0.78260869565217, 0.85434782608696, 0
21362, 0.80434782608696, 0.8804347826087, 0
21363, 0.73913043478261, 0.85434782608696, 0
21364, 0.76086956521739, 0.8804347826087, 0
21365, 0.69565217391304, 0.85434782608696, 0
21366, 0.71739130434783, 0.8804347826087, 0
21367, 0.65217391304348, 0.85434782608696, 0
21368, 0.67391304347826, 0.8804347826087, 0
21369, 0.60869565217391, 0.85434782608696, 0
21370, 0.6304347826087, 0.8804347826087, 0
21371, 0.56521739130435, 0.85434782608696, 0
21372, 0.58695652173913, 0.8804347826087, 0
21373, 0.52173913043478, 0.85434782608696, 0
21374, 0.54347826086957, 0.88043478260869, 0
21375, 0.47826086956522, 0.85434782608696, 0
21376, 0.5, 0.88043478260869, 0
21377, 0.43478260869565, 0.85434782608696, 0
21378, 0.45652173913043, 0.8804347826087, 0
21379, 0.39130434782609, 0.85434782608696, 0
21380, 0.41304347826087, 0.88043478260869, 0
21381, 0.34782608695652, 0.85434782608696, 0
21382, 0.3695652173913, 0.8804347826087, 0
21383, 0.30434782608696, 0.85434782608696, 0
21384, 0.32608695652174, 0.8804347826087, 0
21385, 0.26086956521739, 0.85434782608696, 0
21386, 0.28260869565217, 0.8804347826087, 0
21387, 0.21739130434783, 0.85434782608696, 0
21388, 0.23913043478261, 0.8804347826087, 0
21389, 0.17391304347826, 0.85434782608696, 0
21390, 0.19565217391304, 0.8804347826087, 0
21391, 0.1304347826087, 0.85434782608696, 0
21392, 0.15217391304348, 0.8804347826087, 0
21393, 0.08695652173913, 0.85434782608696, 0
21394, 0.10869565217391, 0.8804347826087, 0
21395, 0.043478260869565, 0.85434782608696, 0
21396, 0.065217391304348, 0.8804347826087, 0
21397, 0.021739130434783, 0.8804347826087, 0
21398, 0.95652173913043, 0.90652173913043, 0
21399, 0.97826086956522, 0.93260869565217, 0
21400, 0.91304347826087, 0.90652173913043, 0
21401, 0.93478260869565, 0.93260869565217, 0
21402, 0.8695652173913, 0.90652173913043, 0
21403, 0.89130434782609, 0.93260869565217, 0
21404, 0.82608695652174, 0.90652173913043, 0
21405, 0.84782608695652, 0.93260869565217, 0
21406, 0.78260869565217, 0.90652173913043, 0
21407, 0.80434782608696, 0.93260869565217, 0
21408, 0.73913043478261, 0.90652173913043, 0
21409, 0.76086956521739, 0.93260869565217, 0
21410, 0.69565217391304, 0.90652173913043, 0
21411, 0.71739130434783, 0.93260869565217, 0
21412, 0.65217391304348, 0.90652173913043, 0
21413, 0.67391304347826, 0.93260869565217, 0
21414, 0.60869565217391, 0.90652173913043, 0
21415, 0.6304347826087, 0.93260869565217, 0
21416, 0.56521739130435, 0.90652173913043, 0
21417, 0.58695652173913, 0.93260869565217, 0
21418, 0.52173913043478, 0.90652173913043, 0
21419, 0.54347826086957, 0.93260869565217, 0
21420, 0.47826086956522, 0.90652173913043, 0
21421, 0.5, 0.93260869565217, 0
21422, 0.43478260869565, 0.90652173913043, 0
21423, 0.45652173913043, 0.93260869565217, 0
21424, 0.39130434782609, 0.90652173913043, 0
21425, 0.41304347826087, 0.93260869565217, 0
21426, 0.34782608695652, 0.90652173913043, 0
21427, 0.3695652173913, 0.93260869565217, 0
21428, 0.30434782608696, 0.90652173913043, 0
21429, 0.32608695652174, 0.93260869565217, 0
21430, 0.26086956521739, 0.90652173913043, 0
21431, 0.28260869565217, 0.93260869565217, 0
21432, 0.21739130434783, 0.90652173913043, 0
21433, 0.23913043478261, 0.93260869565217, 0
21434, 0.17391304347826, 0.90652173913043, 0
21435, 0.19565217391304, 0.93260869565217, 0
21436, 0.1304347826087, 0.90652173913043, 0
21437, 0.15217391304348, 0.93260869565217, 0
21438, 0.08695652173913, 0.90652173913043, 0
21439, 0.10869565217391, 0.93260869565217, 0
21440, 0.043478260869565, 0.90652173913043, 0
21441, 0.065217391304348, 0.93260869565217, 0
21442, 0.021739130434783, 0.93260869565217, 0
21443, 0.95652173913043, 0.95869565217391, 0
21444, 0.97826086956522, 0.98478260869565, 0
21445, 0.91304347826087, 0.95869565217391, 0
21446, 0.93478260869565, 0.98478260869565, 0
21447, 0.8695652173913, 0.95869565217391, 0
21448, 0.89130434782609, 0.98478260869565, 0
21449, 0.82608695652174, 0.95869565217391, 0
21450, 0.84782608695652, 0.98478260869565, 0
21451, 0.78260869565217, 0.95869565217391, 0
21452, 0.80434782608696, 0.98478260869565, 0
21453, 0.73913043478261, 0.95869565217391, 0
21454, 0.76086956521739, 0.98478260869565, 0
21455, 0.69565217391304, 0.95869565217391, 0
21456, 0.71739130434783, 0.98478260869565, 0
21457, 0.65217391304348, 0.95869565217391, 0
21458, 0.67391304347826, 0.98478260869565, 0
21459, 0.60869565217391, 0.95869565217391, 0
21460, 0.6304347826087, 0.98478260869565, 0
21461, 0.56521739130435, 0.95869565217391, 0
21462, 0.58695652173913, 0.98478260869565, 0
21463, 0.52173913043478, 0.95869565217391, 0
21464, 0.54347826086957, 0.98478260869565, 0
21465, 0.47826086956522, 0.95869565217391, 0
21466, 0.5, 0.98478260869565, 0
21467, 0.43478260869565, 0.95869565217391, 0
21468, 0.45652173913043, 0.98478260869565, 0
21469, 0.39130434782609, 0.95869565217391, 0
21470, 0.41304347826087, 0.98478260869565, 0
21471, 0.34782608695652, 0.95869565217391, 0
21472, 0.3695652173913, 0.98478260869565, 0
21473, 0.30434782608696, 0.95869565217391, 0
21474, 0.32608695652174, 0.98478260869565, 0
21475, 0.26086956521739, 0.95869565217391, 0
21476, 0.28260869565217, 0.98478260869565, 0
21477, 0.21739130434783, 0.95869565217391, 0
21478, 0.23913043478261, 0.98478260869565, 0
21479, 0.17391304347826, 0.95869565217391, 0
21480, 0.19565217391304, 0.98478260869565, 0
21481, 0.1304347826087, 0.95869565217391, 0
21482, 0.15217391304348, 0.98478260869565, 0
21483, 0.08695652173913, 0.95869565217391, 0
21484, 0.10869565217391, 0.98478260869565, 0
21485, 0.043478260869565, 0.95869565217391, 0
21486, 0.065217391304348, 0.98478260869565, 0
21487, 0.021739130434783, 0.98478260869565, 0
21488, 0.95652173913043, 1.0108695652174, 0
21489, 0.97826086956522, 1.0369565217391, 0
21490, 0.91304347826087, 1.0108695652174, 0
21491, 0.93478260869565, 1.0369565217391, 0
21492, 0.8695652173913, 1.0108695652174, 0
21493, 0.89130434782609, 1.0369565217391, 0
21494, 0.82608695652174, 1.0108695652174, 0
21495, 0.84782608695652, 1.0369565217391, 0
21496, 0.78260869565217, 1.0108695652174, 0
21497, 0.80434782608696, 1.0369565217391, 0
21498, 0.73913043478261, 1.0108695652174, 0
21499, 0.76086956521739, 1.0369565217391, 0
21500, 0.69565217391304, 1.0108695652174, 0
21501, 0.71739130434783, 1.0369565217391, 0
21502, 0.65217391304348, 1.0108695652174, 0
21503, 0.67391304347826, 1.0369565217391, 0
21504, 0.60869565217391, 1.0108695652174, 0
21505, 0.6304347826087, 1.0369565217391, 0
21506, 0.56521739130435, 1.0108695652174, 0
21507, 0.58695652173913, 1.0369565217391, 0
21508, 0.52173913043478, 1.0108695652174, 0
21509, 0.54347826086957, 1.0369565217391, 0
21510, 0.47826086956522, 1.0108695652174, 0
21511, 0.5, 1.0369565217391, 0
21512, 0.43478260869565, 1.0108695652174, 0
21513, 0.45652173913043, 1.0369565217391, 0
21514, 0.39130434782609, 1.0108695652174, 0
21515, 0.41304347826087, 1.0369565217391, 0
21516, 0.34782608695652, 1.0108695652174, 0
21517, 0.3695652173913, 1.0369565217391, 0
21518, 0.30434782608696, 1.0108695652174, 0
21519, 0.32608695652174, 1.0369565217391, 0
21520, 0.26086956521739, 1.0108695652174, 0
21521, 0.28260869565217, 1.0369565217391, 0
21522, 0.21739130434783, 1.0108695652174, 0
21523, 0.23913043478261, 1.0369565217391, 0
21524, 0.17391304347826, 1.0108695652174, 0
21525, 0.19565217391304, 1.0369565217391, 0
21526, 0.1304347826087, 1.0108695652174, 0
21527, 0.15217391304348, 1.0369565217391, 0
21528, 0.08695652173913, 1.0108695652174, 0
21529, 0.10869565217391, 1.0369565217391, 0
21530, 0.043478260869565, 1.0108695652174, 0
21531, 0.065217391304348, 1.0369565217391, 0
21532, 0.021739130434783, 1.0369565217391, 0
21533, 0.95652173913043, 1.0630434782609, 0
21534, 0.97826086956522, 1.0891304347826, 0
21535, 0.91304347826087, 1.0630434782609, 0
21536, 0.93478260869565, 1.0891304347826, 0
21537, 0.8695652173913, 1.0630434782609, 0
21538, 0.89130434782609, 1.0891304347826, 0
21539, 0.82608695652174, 1.0630434782609, 0
21540, 0.84782608695652, 1.0891304347826, 0
21541, 0.78260869565217, 1.0630434782609, 0
21542, 0.80434782608696, 1.0891304347826, 0
21543, 0.73913043478261, 1.0630434782609, 0
21544, 0.76086956521739, 1.0891304347826, 0
21545, 0.69565217391304, 1.0630434782609, 0
21546, 0.71739130434783, 1.0891304347826, 0
21547, 0.65217391304348, 1.0630434782609, 0
21548, 0.67391304347826, 1.0891304347826, 0
21549, 0.60869565217391, 1.0630434782609, 0
21550, 0.6304347826087, 1.0891304347826, 0
21551, 0.56521739130435, 1.0630434782609, 0
21552, 0.58695652173913, 1.0891304347826, 0
21553, 0.52173913043478, 1.0630434782609, 0
21554, 0.54347826086957, 1.0891304347826, 0
21555, 0.47826086956522, 1.0630434782609, 0
21556, 0.5, 1.0891304347826, 0
21557, 0.43478260869565, 1.0630434782609, 0
21558, 0.45652173913043, 1.0891304347826, 0
21559, 0.39130434782609, 1.0630434782609, 0
21560, 0.41304347826087, 1.0891304347826, 0
21561, 0.34782608695652, 1.0630434782609, 0
21562, 0.3695652173913, 1.0891304347826, 0
21563, 0.30434782608696, 1.0630434782609, 0
21564, 0.32608695652174, 1.0891304347826, 0
21565, 0.26086956521739, 1.0630434782609, 0
21566, 0.28260869565217, 1.0891304347826, 0
21567, 0.21739130434783, 1.0630434782609, 0
21568, 0.23913043478261, 1.0891304347826, 0
21569, 0.17391304347826, 1.0630434782609, 0
21570, 0.19565217391304, 1.0891304347826, 0
21571, 0.1304347826087, 1.0630434782609, 0
21572, 0.15217391304348, 1.0891304347826, 0
21573, 0.08695652173913, 1.0630434782609, 0
21574, 0.10869565217391, 1.0891304347826, 0
21575, 0.043478260869565, 1.0630434782609, 0
21576, 0.065217391304348, 1.0891304347826, 0
21577, 0.021739130434783, 1.0891304347826, 0
21578, 0.95652173913043, 1.1152173913043, 0
21579, 0.97826086956522, 1.1413043478261, 0
21580, 0.91304347826087, 1.1152173913043, 0
21581, 0.93478260869565, 1.1413043478261, 0
21582, 0.8695652173913, 1.1152173913043, 0
21583, 0.89130434782609, 1.1413043478261, 0
21584, 0.82608695652174, 1.1152173913043, 0
21585, 0.84782608695652, 1.1413043478261, 0
21586, 0.78260869565217, 1.1152173913043, 0
21587, 0.80434782608696, 1.1413043478261, 0
21588, 0.73913043478261, 1.1152173913043, 0
21589, 0.76086956521739, 1.1413043478261, 0
21590, 0.69565217391304, 1.1152173913043, 0
21591, 0.71739130434783, 1.1413043478261, 0
21592, 0.65217391304348, 1.1152173913043, 0
21593, 0.67391304347826, 1.1413043478261, 0
21594, 0.60869565217391, 1.1152173913043, 0
21595, 0.6304347826087, 1.1413043478261, 0
21596, 0.56521739130435, 1.1152173913043, 0
21597, 0.58695652173913, 1.1413043478261, 0
21598, 0.52173913043478, 1.1152173913043, 0
21599, 0.54347826086957, 1.1413043478261, 0
21600, 0.47826086956522, 1.1152173913043, 0
21601, 0.5, 1.1413043478261, 0
21602, 0.43478260869565, 1.1152173913043, 0
21603, 0.45652173913043, 1.1413043478261, 0
21604, 0.39130434782609, 1.1152173913043, 0
21605, 0.41304347826087, 1.1413043478261, 0
21606, 0.34782608695652, 1.1152173913043, 0
21607, 0.3695652173913, 1.1413043478261, 0
21608, 0.30434782608696, 1.1152173913043, 0
21609, 0.32608695652174, 1.1413043478261, 0
21610, 0.26086956521739, 1.1152173913043, 0
21611, 0.28260869565217, 1.1413043478261, 0
21612, 0.21739130434783, 1.1152173913043, 0
21613, 0.23913043478261, 1.1413043478261, 0
21614, 0.17391304347826, 1.1152173913043, 0
21615, 0.19565217391304, 1.1413043478261, 0
21616, 0.1304347826087, 1.1152173913043, 0
21617, 0.15217391304348, 1.1413043478261, 0
21618, 0.08695652173913, 1.1152173913043, 0
21619, 0.10869565217391, 1.1413043478261, 0
21620, 0.043478260869565, 1.1152173913043, 0
21621, 0.065217391304348, 1.1413043478261, 0
21622, 0.021739130434783, 1.1413043478261, 0
21623, 0.95652173913043, 1.1673913043478, 0
21624, 0.97826086956522, 1.1934782608696, 0
21625, 0.91304347826087, 1.1673913043478, 0
21626, 0.93478260869565, 1.1934782608696, 0
21627, 0.8695652173913, 1.1673913043478, 0
21628, 0.89130434782609, 1.1934782608696, 0
21629, 0.82608695652174, 1.1673913043478, 0
21630, 0.84782608695652, 1.1934782608696, 0
21631, 0.78260869565217, 1.1673913043478, 0
21632, 0.80434782608696, 1.1934782608696, 0
21633, 0.73913043478261, 1.1673913043478, 0
21634, 0.76086956521739, 1.1934782608696, 0
21635, 0.69565217391304, 1.1673913043478, 0
21636, 0.71739130434783, 1.1934782608696, 0
21637, 0.65217391304348, 1.1673913043478, 0
21638, 0.67391304347826, 1.1934782608696, 0
21639, 0.60869565217391, 1.1673913043478, 0
21640, 0.6304347826087, 1.1934782608696, 0
21641, 0.56521739130435, 1.1673913043478, 0
21642, 0.58695652173913, 1.1934782608696, 0
21643, 0.52173913043478, 1.1673913043478, 0
21644, 0.54347826086957, 1.1934782608696, 0
21645, 0.47826086956522, 1.1673913043478, 0
21646, 0.5, 1.1934782608696, 0
21647, 0.43478260869565, 1.1673913043478, 0
21648, 0.45652173913043, 1.1934782608696, 0
21649, 0.39130434782609, 1.1673913043478, 0
21650, 0.41304347826087, 1.1934782608696, 0
21651, 0.34782608695652, 1.1673913043478, 0
21652, 0.3695652173913, 1.1934782608696, 0
21653, 0.30434782608696, 1.1673913043478, 0
21654, 0.32608695652174, 1.1934782608696, 0
21655, 0.26086956521739, 1.1673913043478, 0
21656, 0.28260869565217, 1.1934782608696, 0
21657, 0.21739130434783, 1.1673913043478, 0
21658, 0.23913043478261, 1.1934782608696, 0
21659, 0.17391304347826, 1.1673913043478, 0
21660, 0.19565217391304, 1.1934782608696, 0
21661, 0.1304347826087, 1.1673913043478, 0
21662, 0.15217391304348, 1.1934782608696, 0
21663, 0.08695652173913, 1.1673913043478, 0
21664, 0.10869565217391, 1.1934782608696, 0
21665, 0.043478260869565, 1.1673913043478, 0
21666, 0.065217391304348, 1.1934782608696, 0
21667, 0.021739130434783, 1.1934782608696, 0
21668, 0.95652173913043, 1.2195652173913, 0
21669, 0.97826086956522, 1.245652173913, 0
21670, 0.91304347826087, 1.2195652173913, 0
21671, 0.93478260869565, 1.245652173913, 0
21672, 0.8695652173913, 1.2195652173913, 0
21673, 0.89130434782609, 1.245652173913, 0
21674, 0.82608695652174, 1.2195652173913, 0
21675, 0.84782608695652, 1.245652173913, 0
21676, 0.78260869565217, 1.2195652173913, 0
21677, 0.80434782608696, 1.245652173913, 0
21678, 0.73913043478261, 1.2195652173913, 0
21679, 0.76086956521739, 1.245652173913, 0
21680, 0.69565217391304, 1.2195652173913, 0
21681, 0.71739130434783, 1.245652173913, 0
21682, 0.65217391304348, 1.2195652173913, 0
21683, 0.67391304347826, 1.245652173913, 0
21684, 0.60869565217391, 1.2195652173913, 0
21685, 0.6304347826087, 1.245652173913, 0
21686, 0.56521739130435, 1.2195652173913, 0
21687, 0.58695652173913, 1.245652173913, 0
21688, 0.52173913043478, 1.2195652173913, 0
21689, 0.54347826086957, 1.245652173913, 0
21690, 0.47826086956522, 1.2195652173913, 0
21691, 0.5, 1.245652173913, 0
21692, 0.43478260869565, 1.2195652173913, 0
21693, 0.45652173913043, 1.245652173913, 0
21694, 0.39130434782609, 1.2195652173913, 0
21695, 0.41304347826087, 1.245652173913, 0
21696, 0.34782608695652, 1.2195652173913, 0
21697, 0.3695652173913, 1.245652173913, 0
21698, 0.30434782608696, 1.2195652173913, 0
21699, 0.32608695652174, 1.245652173913, 0
21700, 0.26086956521739, 1.2195652173913, 0
21701, 0.28260869565217, 1.245652173913, 0
21702, 0.21739130434783, 1.2195652173913, 0
21703, 0.23913043478261, 1.245652173913, 0
21704, 0.17391304347826, 1.2195652173913, 0
21705, 0.19565217391304, 1.245652173913, 0
21706, 0.1304347826087, 1.2195652173913, 0
21707, 0.15217391304348, 1.245652173913, 0
21708, 0.08695652173913, 1.2195652173913, 0
21709, 0.10869565217391, 1.245652173913, 0
21710, 0.043478260869565, 1.2195652173913, 0
21711, 0.065217391304348, 1.245652173913, 0
21712, 0.021739130434783, 1.245652173913, 0
21713, 0.95652173913043, 1.2717391304348, 0
21714, 0.97826086956522, 1.2978260869565, 0
21715, 0.91304347826087, 1.2717391304348, 0
21716, 0.93478260869565, 1.2978260869565, 0
21717, 0.8695652173913, 1.2717391304348, 0
21718, 0.89130434782609, 1.2978260869565, 0
21719, 0.82608695652174, 1.2717391304348, 0
21720, 0.84782608695652, 1.2978260869565, 0
21721, 0.78260869565217, 1.2717391304348, 0
21722, 0.80434782608696, 1.2978260869565, 0
21723, 0.73913043478261, 1.2717391304348, 0
21724, 0.76086956521739, 1.2978260869565, 0
21725, 0.69565217391304, 1.2717391304348, 0
21726, 0.71739130434783, 1.2978260869565, 0
21727, 0.65217391304348, 1.2717391304348, 0
21728, 0.67391304347826, 1.2978260869565, 0
21729, 0.60869565217391, 1.2717391304348, 0
21730, 0.6304347826087, 1.2978260869565, 0
21731, 0.56521739130435, 1.2717391304348, 0
21732, 0.58695652173913, 1.2978260869565, 0
21733, 0.52173913043478, 1.2717391304348, 0
21734, 0.54347826086957, 1.2978260869565, 0
21735, 0.47826086956522, 1.2717391304348, 0
21736, 0.5, 1.2978260869565, 0
21737, 0.43478260869565, 1.2717391304348, 0
21738, 0.45652173913043, 1.2978260869565, 0
21739, 0.39130434782609, 1.2717391304348, 0
21740, 0.41304347826087, 1.2978260869565, 0
21741, 0.34782608695652, 1.2717391304348, 0
21742, 0.3695652173913, 1.2978260869565, 0
21743, 0.30434782608696, 1.2717391304348, 0
21744, 0.32608695652174, 1.2978260869565, 0
21745, 0.26086956521739, 1.2717391304348, 0
21746, 0.28260869565217, 1.2978260869565, 0
21747, 0.21739130434783, 1.2717391304348, 0
21748, 0.23913043478261, 1.2978260869565, 0
21749, 0.17391304347826, 1.2717391304348, 0
21750, 0.19565217391304, 1.2978260869565, 0
21751, 0.1304347826087, 1.2717391304348, 0
21752, 0.15217391304348, 1.2978260869565, 0
21753, 0.08695652173913, 1.2717391304348, 0
21754, 0.10869565217391, 1.2978260869565, 0
21755, 0.043478260869565, 1.2717391304348, 0
21756, 0.065217391304348, 1.2978260869565, 0
21757, 0.021739130434783, 1.2978260869565, 0
21758, 0.95652173913043, 1.3239130434783, 0
21759, 0.91304347826087, 1.3239130434783, 0
21760, 0.8695652173913, 1.3239130434783, 0
21761, 0.82608695652174, 1.3239130434783, 0
21762, 0.78260869565217, 1.3239130434783, 0
21763, 0.73913043478261, 1.3239130434783, 0
21764, 0.69565217391304, 1.3239130434783, 0
21765, 0.65217391304348, 1.3239130434783, 0
21766, 0.60869565217391, 1.3239130434783, 0
21767, 0.56521739130435, 1.3239130434783, 0
21768, 0.52173913043478, 1.3239130434783, 0
21769, 0.47826086956522, 1.3239130434783, 0
21770, 0.43478260869565, 1.3239130434783, 0
21771, 0.39130434782609, 1.3239130434783, 0
21772, 0.34782608695652, 1.3239130434783, 0
21773, 0.30434782608696, 1.3239130434783, 0
21774, 0.26086956521739, 1.3239130434783, 0
21775, 0.21739130434783, 1.3239130434783, 0
21776, 0.17391304347826, 1.3239130434783, 0
21777, 0.1304347826087, 1.3239130434783, 0
21778, 0.08695652173913, 1.3239130434783, 0
21779, 0.043478260869565, 1.3239130434783, 0
21780, 1, 0.20217391304348, 0.44444444444444
21781, 1, 0.20217391304348, 0.38888888888889
21782, 1, 0.20217391304348, 0.33333333333333
21783, 1, 0.20217391304348, 0.27777777777778
21784, 1, 0.20217391304348, 0.22222222222222
21785, 1, 0.20217391304348, 0.16666666666667
21786, 1, 0.20217391304348, 0.11111111111111
21787, 1, 0.20217391304348, 0.055555555555556
21788, 1, 0.25434782608696, 0.44444444444444
21789, 1, 0.25434782608696, 0.38888888888889
21790, 1, 0.25434782608696, 0.33333333333333
21791, 1, 0.25434782608696, 0.27777777777778
21792, 1, 0.25434782608696, 0.22222222222222
21793, 1, 0.25434782608696, 0.16666666666667
21794, 1, 0.25434782608696, 0.11111111111111
21795, 1, 0.25434782608696, 0.055555555555556
21796, 1, 0.30652173913043, 0.44444444444444
21797, 1, 0.30652173913043, 0.38888888888889
21798, 1, 0.30652173913043, 0.33333333333333
21799, 1, 0.30652173913043, 0.27777777777778
21800, 1, 0.30652173913043, 0.22222222222222
21801, 1, 0.30652173913043, 0.16666666666667
21802, 1, 0.30652173913043, 0.11111111111111
21803, 1, 0.30652173913043, 0.055555555555556
21804, 1, 0.35869565217391, 0.44444444444444
21805, 1, 0.35869565217391, 0.38888888888889
21806, 1, 0.35869565217391, 0.33333333333333
21807, 1, 0.35869565217391, 0.27777777777778
21808, 1, 0.35869565217391, 0.22222222222222
21809, 1, 0.35869565217391, 0.16666666666667
21810, 1, 0.35869565217391, 0.11111111111111
21811, 1, 0.35869565217391, 0.055555555555556
21812, 1, 0.41086956521739, 0.44444444444444
21813, 1, 0.41086956521739, 0.38888888888889
21814, 1, 0.41086956521739, 0.33333333333333
21815, 1, 0.41086956521739, 0.27777777777778
21816, 1, 0.41086956521739, 0.22222222222222
21817, 1, 0.41086956521739, 0.16666666666667
21818, 1, 0.41086956521739, 0.11111111111111
21819, 1, 0.41086956521739, 0.055555555555556
21820, 1, 0.46304347826087, 0.44444444444444
21821, 1, 0.46304347826087, 0.38888888888889
21822, 1, 0.46304347826087, 0.33333333333333
21823, 1, 0.46304347826087, 0.27777777777778
21824, 1, 0.46304347826087, 0.22222222222222
21825, 1, 0.46304347826087, 0.16666666666667
21826, 1, 0.46304347826087, 0.11111111111111
21827, 1, 0.46304347826087, 0.055555555555556
21828, 1, 0.51521739130435, 0.44444444444444
21829, 1, 0.51521739130435, 0.38888888888889
21830, 1, 0.51521739130435, 0.33333333333333
21831, 1, 0.51521739130435, 0.27777777777778
21832, 1, 0.51521739130435, 0.22222222222222
21833, 1, 0.51521739130435, 0.16666666666667
21834, 1, 0.51521739130435, 0.11111111111111
21835, 1, 0.51521739130435, 0.055555555555556
21836, 1, 0.56739130434783, 0.44444444444444
21837, 1, 0.56739130434783, 0.38888888888889
21838, 1, 0.56739130434783, 0.33333333333333
21839, 1, 0.56739130434783, 0.27777777777778
21840, 1, 0.56739130434783, 0.22222222222222
21841, 1, 0.56739130434783, 0.16666666666667
21842, 1, 0.56739130434783, 0.11111111111111
21843, 1, 0.56739130434783, 0.055555555555556
21844, 1, 0.6195652173913, 0.44444444444444
21845, 1, 0.6195652173913, 0.38888888888889
21846, 1, 0.6195652173913, 0.33333333333333
21847, 1, 0.6195652173913, 0.27777777777778
21848, 1, 0.6195652173913, 0.22222222222222
21849, 1, 0.6195652173913, 0.16666666666667
21850, 1, 0.6195652173913, 0.11111111111111
21851, 1, 0.6195652173913, 0.055555555555556
21852, 1, 0.67173913043478, 0.44444444444444
21853, 1, 0.67173913043478, 0.38888888888889
21854, 1, 0.67173913043478, 0.33333333333333
21855, 1, 0.67173913043478, 0.27777777777778
21856, 1, 0.67173913043478, 0.22222222222222
21857, 1, 0.67173913043478, 0.16666666666667
21858, 1, 0.67173913043478, 0.11111111111111
21859, 1, 0.67173913043478, 0.055555555555556
21860, 1, 0.72391304347826, 0.44444444444444
21861, 1, 0.72391304347826, 0.38888888888889
21862, 1, 0.72391304347826, 0.33333333333333
21863, 1, 0.72391304347826, 0.27777777777778
21864, 1, 0.72391304347826, 0.22222222222222
21865, 1, 0.72391304347826, 0.16666666666667
21866, 1, 0.72391304347826, 0.11111111111111
21867, 1, 0.72391304347826, 0.055555555555556
21868, 1, 0.77608695652174, 0.44444444444444
21869, 1, 0.77608695652174, 0.38888888888889
21870, 1, 0.77608695652174, 0.33333333333333
21871, 1, 0.77608695652174, 0.27777777777778
21872, 1, 0.77608695652174, 0.22222222222222
21873, 1, 0.77608695652174, 0.16666666666667
21874, 1, 0.77608695652174, 0.11111111111111
21875, 1, 0.77608695652174, 0.055555555555556
21876, 1, 0.82826086956522, 0.44444444444444
21877, 1, 0.82826086956522, 0.38888888888889
21878, 1, 0.82826086956522, 0.33333333333333
21879, 1, 0.82826086956522, 0.27777777777778
21880, 1, 0.82826086956522, 0.22222222222222
21881, 1, 0.82826086956522, 0.16666666666667
21882, 1, 0.82826086956522, 0.11111111111111
21883, 1, 0.82826086956522, 0.055555555555556
21884, 1, 0.88043478260869, 0.44444444444444
21885, 1, 0.8804347826087, 0.38888888888889
21886, 1, 0.8804347826087, 0.33333333333333
21887, 1, 0.8804347826087, 0.27777777777778
21888, 1, 0.8804347826087, 0.22222222222222
21889, 1, 0.8804347826087, 0.16666666666667
21890, 1, 0.8804347826087, 0.11111111111111
21891, 1, 0.8804347826087, 0.055555555555556
21892, 1, 0.93260869565217, 0.44444444444444
21893, 1, 0.93260869565217, 0.38888888888889
21894, 1, 0.93260869565217, 0.33333333333333
21895, 1, 0.93260869565217, 0.27777777777778
21896, 1, 0.93260869565217, 0.22222222222222
21897, 1, 0.93260869565217, 0.16666666666667
21898, 1, 0.93260869565217, 0.11111111111111
21899, 1, 0.93260869565217, 0.055555555555556
21900, 1, 0.98478260869565, 0.44444444444444
21901, 1, 0.98478260869565, 0.38888888888889
21902, 1, 0.98478260869565, 0.33333333333333
21903, 1, 0.98478260869565, 0.27777777777778
21904, 1, 0.98478260869565, 0.22222222222222
21905, 1, 0.98478260869565, 0.16666666666667
21906, 1, 0.98478260869565, 0.11111111111111
21907, 1, 0.98478260869565, 0.055555555555556
21908, 1, 1.0369565217391, 0.44444444444444
21909, 1, 1.0369565217391, 0.38888888888889
21910, 1, 1.0369565217391, 0.33333333333333
21911, 1, 1.0369565217391, 0.27777777777778
21912, 1, 1.0369565217391, 0.22222222222222
21913, 1, 1.0369565217391, 0.16666666666667
21914, 1, 1.0369565217391, 0.11111111111111
21915, 1, 1.0369565217391, 0.055555555555556
21916, 1, 1.0891304347826, 0.44444444444444
21917, 1, 1.0891304347826, 0.38888888888889
21918, 1, 1.0891304347826, 0.33333333333333
21919, 1, 1.0891304347826, 0.27777777777778
21920, 1, 1.0891304347826, 0.22222222222222
21921, 1, 1.0891304347826, 0.16666666666667
21922, 1, 1.0891304347826, 0.11111111111111
21923, 1, 1.0891304347826, 0.055555555555556
21924, 1, 1.1413043478261, 0.44444444444444
21925, 1, 1.1413043478261, 0.38888888888889
21926, 1, 1.1413043478261, 0.33333333333333
21927, 1, 1.1413043478261, 0.27777777777778
21928, 1, 1.1413043478261, 0.22222222222222
21929, 1, 1.1413043478261, 0.16666666666667
21930, 1, 1.1413043478261, 0.11111111111111
21931, 1, 1.1413043478261, 0.055555555555556
21932, 1, 1.1934782608696, 0.44444444444444
21933, 1, 1.1934782608696, 0.38888888888889
21934, 1, 1.1934782608696, 0.33333333333333
21935, 1, 1.1934782608696, 0.27777777777778
21936, 1, 1.1934782608696, 0.22222222222222
21937, 1, 1.1934782608696, 0.16666666666667
21938, 1, 1.1934782608696, 0.11111111111111
21939, 1, 1.1934782608696, 0.055555555555556
21940, 1, 1.245652173913, 0.44444444444444
21941, 1, 1.245652173913, 0.38888888888889
21942, 1, 1.245652173913, 0.33333333333333
21943, 1, 1.245652173913, 0.27777777777778
21944, 1, 1.245652173913, 0.22222222222222
21945, 1, 1.245652173913, 0.16666666666667
21946, 1, 1.245652173913, 0.11111111111111
21947, 1, 1.245652173913, 0.055555555555556
21948, 1, 1.2978260869565, 0.44444444444444
21949, 1, 1.2978260869565, 0.38888888888889
21950, 1, 1.2978260869565, 0.33333333333333
21951, 1, 1.2978260869565, 0.27777777777778
21952, 1, 1.2978260869565, 0.22222222222222
21953, 1, 1.2978260869565, 0.16666666666667
21954, 1, 1.2978260869565, 0.11111111111111
21955, 1, 1.2978260869565, 0.055555555555556
21956, 1, 0.17608695652174, 0.44444444444444
21957, 1, 0.20217391304348, 0.47222222222222
21958, 1, 0.17608695652174, 0.38888888888889
21959, 1, 0.20217391304348, 0.41666666666667
21960, 1, 0.17608695652174, 0.33333333333333
21961, 1, 0.20217391304348, 0.36111111111111
21962, 1, 0.17608695652174, 0.27777777777778
21963, 1, 0.20217391304348, 0.30555555555556
21964, 1, 0.17608695652174, 0.22222222222222
21965, 1, 0.20217391304348, 0.25
21966, 1, 0.17608695652174, 0.16666666666667
21967, 1, 0.20217391304348, 0.19444444444444
21968, 1, 0.17608695652174, 0.11111111111111
21969, 1, 0.20217391304348, 0.13888888888889
21970, 1, 0.17608695652174, 0.055555555555556
21971, 1, 0.20217391304348, 0.083333333333333
21972, 1, 0.20217391304348, 0.027777777777778
21973, 1, 0.22826086956522, 0.44444444444444
21974, 1, 0.25434782608696, 0.47222222222222
21975, 1, 0.22826086956522, 0.38888888888889
21976, 1, 0.25434782608696, 0.41666666666667
21977, 1, 0.22826086956522, 0.33333333333333
21978, 1, 0.25434782608696, 0.36111111111111
21979, 1, 0.22826086956522, 0.27777777777778
21980, 1, 0.25434782608696, 0.30555555555556
21981, 1, 0.22826086956522, 0.22222222222222
21982, 1, 0.25434782608696, 0.25
21983, 1, 0.22826086956522, 0.16666666666667
21984, 1, 0.25434782608696, 0.19444444444444
21985, 1, 0.22826086956522, 0.11111111111111
21986, 1, 0.25434782608696, 0.13888888888889
21987, 1, 0.22826086956522, 0.055555555555556
21988, 1, 0.25434782608696, 0.083333333333333
21989, 1, 0.25434782608696, 0.027777777777778
21990, 1, 0.2804347826087, 0.44444444444444
21991, 1, 0.30652173913043, 0.47222222222222
21992, 1, 0.2804347826087, 0.38888888888889
21993, 1, 0.30652173913043, 0.41666666666667
21994, 1, 0.2804347826087, 0.33333333333333
21995, 1, 0.30652173913043, 0.36111111111111
21996, 1, 0.2804347826087, 0.27777777777778
21997, 1, 0.30652173913043, 0.30555555555556
21998, 1, 0.2804347826087, 0.22222222222222
21999, 1, 0.30652173913043, 0.25
22000, 1, 0.2804347826087, 0.16666666666667
22001, 1, 0.30652173913043, 0.19444444444444
22002, 1, 0.2804347826087, 0.11111111111111
22003, 1, 0.30652173913043, 0.13888888888889
22004, 1, 0.2804347826087, 0.055555555555556
22005, 1, 0.30652173913043, 0.083333333333333
22006, 1, 0.30652173913043, 0.027777777777778
22007, 1, 0.33260869565217, 0.44444444444444
22008, 1, 0.35869565217391, 0.47222222222222
22009, 1, 0.33260869565217, 0.38888888888889
22010, 1, 0.35869565217391, 0.41666666666667
22011, 1, 0.33260869565217, 0.33333333333333
22012, 1, 0.35869565217391, 0.36111111111111
22013, 1, 0.33260869565217, 0.27777777777778
22014, 1, 0.35869565217391, 0.30555555555556
22015, 1, 0.33260869565217, 0.22222222222222
22016, 1, 0.35869565217391, 0.25
22017, 1, 0.33260869565217, 0.16666666666667
22018, 1, 0.35869565217391, 0.19444444444444
22019, 1, 0.33260869565217, 0.11111111111111
22020, 1, 0.35869565217391, 0.13888888888889
22021, 1, 0.33260869565217, 0.055555555555556
22022, 1, 0.35869565217391, 0.083333333333333
22023, 1, 0.35869565217391, 0.027777777777778
22024, 1, 0.38478260869565, 0.44444444444444
22025, 1, 0.41086956521739, 0.47222222222222
22026, 1, 0.38478260869565, 0.38888888888889
22027, 1, 0.41086956521739, 0.41666666666667
22028, 1, 0.38478260869565, 0.33333333333333
22029, 1, 0.41086956521739, 0.36111111111111
22030, 1, 0.38478260869565, 0.27777777777778
22031, 1, 0.41086956521739, 0.30555555555556
22032, 1, 0.38478260869565, 0.22222222222222
22033, 1, 0.41086956521739, 0.25
22034, 1, 0.38478260869565, 0.16666666666667
22035, 1, 0.41086956521739, 0.19444444444444
22036, 1, 0.38478260869565, 0.11111111111111
22037, 1, 0.41086956521739, 0.13888888888889
22038, 1, 0.38478260869565, 0.055555555555556
22039, 1, 0.41086956521739, 0.083333333333333
22040, 1, 0.41086956521739, 0.027777777777778
22041, 1, 0.43695652173913, 0.44444444444444
22042, 1, 0.46304347826087, 0.47222222222222
22043, 1, 0.43695652173913, 0.38888888888889
22044, 1, 0.46304347826087, 0.41666666666667
22045, 1, 0.43695652173913, 0.33333333333333
22046, 1, 0.46304347826087, 0.36111111111111
22047, 1, 0.43695652173913, 0.27777777777778
22048, 1, 0.46304347826087, 0.30555555555556
22049, 1, 0.43695652173913, 0.22222222222222
22050, 1, 0.46304347826087, 0.25
22051, 1, 0.43695652173913, 0.16666666666667
22052, 1, 0.46304347826087, 0.19444444444444
22053, 1, 0.43695652173913, 0.11111111111111
22054, 1, 0.46304347826087, 0.13888888888889
22055, 1, 0.43695652173913, 0.055555555555556
22056, 1, 0.46304347826087, 0.083333333333333
22057, 1, 0.46304347826087, 0.027777777777778
22058, 1, 0.48913043478261, 0.44444444444444
22059, 1, 0.51521739130435, 0.47222222222222
22060, 1, 0.48913043478261, 0.38888888888889
22061, 1, 0.51521739130435, 0.41666666666667
22062, 1, 0.48913043478261, 0.33333333333333
22063, 1, 0.51521739130435, 0.36111111111111
22064, 1, 0.48913043478261, 0.27777777777778
22065, 1, 0.51521739130435, 0.30555555555556
22066, 1, 0.48913043478261, 0.22222222222222
22067, 1, 0.51521739130435, 0.25
22068, 1, 0.48913043478261, 0.16666666666667
22069, 1, 0.51521739130435, 0.19444444444444
22070, 1, 0.48913043478261, 0.11111111111111
22071, 1, 0.51521739130435, 0.13888888888889
22072, 1, 0.48913043478261, 0.055555555555556
22073, 1, 0.51521739130435, 0.083333333333333
22074, 1, 0.51521739130435, 0.027777777777778
22075, 1, 0.54130434782609, 0.44444444444444
22076, 1, 0.56739130434783, 0.47222222222222
22077, 1, 0.54130434782609, 0.38888888888889
22078, 1, 0.56739130434783, 0.41666666666667
22079, 1, 0.54130434782609, 0.33333333333333
22080, 1, 0.56739130434783, 0.36111111111111
22081, 1, 0.54130434782609, 0.27777777777778
22082, 1, 0.56739130434783, 0.30555555555556
22083, 1, 0.54130434782609, 0.22222222222222
22084, 1, 0.56739130434783, 0.25
22085, 1, 0.54130434782609, 0.16666666666667
22086, 1, 0.56739130434783, 0.19444444444444
22087, 1, 0.54130434782609, 0.11111111111111
22088, 1, 0.56739130434783, 0.13888888888889
22089, 1, 0.54130434782609, 0.055555555555556
22090, 1, 0.56739130434783, 0.083333333333333
22091, 1, 0.56739130434783, 0.027777777777778
22092, 1, 0.59347826086956, 0.44444444444444
22093, 1, 0.6195652173913, 0.47222222222222
22094, 1, 0.59347826086956, 0.38888888888889
22095, 1, 0.6195652173913, 0.41666666666667
22096, 1, 0.59347826086956, 0.33333333333333
22097, 1, 0.6195652173913, 0.36111111111111
22098, 1, 0.59347826086956, 0.27777777777778
22099, 1, 0.6195652173913, 0.30555555555556
22100, 1, 0.59347826086956, 0.22222222222222
22101, 1, 0.6195652173913, 0.25
22102, 1, 0.59347826086956, 0.16666666666667
22103, 1, 0.6195652173913, 0.19444444444444
22104, 1, 0.59347826086956, 0.11111111111111
22105, 1, 0.6195652173913, 0.13888888888889
22106, 1, 0.59347826086956, 0.055555555555556
22107, 1, 0.6195652173913, 0.083333333333333
22108, 1, 0.6195652173913, 0.027777777777778
22109, 1, 0.64565217391304, 0.44444444444444
22110, 1, 0.67173913043478, 0.47222222222222
22111, 1, 0.64565217391304, 0.38888888888889
22112, 1, 0.67173913043478, 0.41666666666667
22113, 1, 0.64565217391304, 0.33333333333333
22114, 1, 0.67173913043478, 0.36111111111111
22115, 1, 0.64565217391304, 0.27777777777778
22116, 1, 0.67173913043478, 0.30555555555556
22117, 1, 0.64565217391304, 0.22222222222222
22118, 1, 0.67173913043478, 0.25
22119, 1, 0.64565217391304, 0.16666666666667
22120, 1, 0.67173913043478, 0.19444444444444
22121, 1, 0.64565217391304, 0.11111111111111
22122, 1, 0.67173913043478, 0.13888888888889
22123, 1, 0.64565217391304, 0.055555555555556
22124, 1, 0.67173913043478, 0.083333333333333
22125, 1, 0.67173913043478, 0.027777777777778
22126, 1, 0.69782608695652, 0.44444444444444
22127, 1, 0.72391304347826, 0.47222222222222
22128, 1, 0.69782608695652, 0.38888888888889
22129, 1, 0.72391304347826, 0.41666666666667
22130, 1, 0.69782608695652, 0.33333333333333
22131, 1, 0.72391304347826, 0.36111111111111
22132, 1, 0.69782608695652, 0.27777777777778
22133, 1, 0.72391304347826, 0.30555555555556
22134, 1, 0.69782608695652, 0.22222222222222
22135, 1, 0.72391304347826, 0.25
22136, 1, 0.69782608695652, 0.16666666666667
22137, 1, 0.72391304347826, 0.19444444444444
22138, 1, 0.69782608695652, 0.11111111111111
22139, 1, 0.72391304347826, 0.13888888888889
22140, 1, 0.69782608695652, 0.055555555555556
22141, 1, 0.72391304347826, 0.083333333333333
22142, 1, 0.72391304347826, 0.027777777777778
22143, 1, 0.75, 0.44444444444444
22144, 1, 0.77608695652174, 0.47222222222222
22145, 1, 0.75, 0.38888888888889
22146, 1, 0.77608695652174, 0.41666666666667
22147, 1, 0.75, 0.33333333333333
22148, 1, 0.77608695652174, 0.36111111111111
22149, 1, 0.75, 0.27777777777778
22150, 1, 0.77608695652174, 0.30555555555556
22151, 1, 0.75, 0.22222222222222
22152, 1, 0.77608695652174, 0.25
22153, 1, 0.75, 0.16666666666667
22154, 1, 0.77608695652174, 0.19444444444444
22155, 1, 0.75, 0.11111111111111
22156, 1, 0.77608695652174, 0.13888888888889
22157, 1, 0.75, 0.055555555555556
22158, 1, 0.77608695652174, 0.083333333333333
22159, 1, 0.77608695652174, 0.027777777777778
22160, 1, 0.80217391304348, 0.44444444444444
22161, 1, 0.82826086956522, 0.47222222222222
22162, 1, 0.80217391304348, 0.38888888888889
22163, 1, 0.82826086956522, 0.41666666666667
22164, 1, 0.80217391304348, 0.33333333333333
22165, 1, 0.82826086956522, 0.36111111111111
22166, 1, 0.80217391304348, 0.27777777777778
22167, 1, 0.82826086956522, 0.30555555555556
22168, 1, 0.80217391304348, 0.22222222222222
22169, 1, 0.82826086956522, 0.25
22170, 1, 0.80217391304348, 0.16666666666667
22171, 1, 0.82826086956522, 0.19444444444444
22172, 1, 0.80217391304348, 0.11111111111111
22173, 1, 0.82826086956522, 0.13888888888889
22174, 1, 0.80217391304348, 0.055555555555556
22175, 1, 0.82826086956522, 0.083333333333333
22176, 1, 0.82826086956522, 0.027777777777778
22177, 1, 0.85434782608696, 0.44444444444444
22178, 1, 0.88043478260869, 0.47222222222222
22179, 1, 0.85434782608696, 0.38888888888889
22180, 1, 0.88043478260869, 0.41666666666667
22181, 1, 0.85434782608696, 0.33333333333333
22182, 1, 0.8804347826087, 0.36111111111111
22183, 1, 0.85434782608696, 0.27777777777778
22184, 1, 0.8804347826087, 0.30555555555556
22185, 1, 0.85434782608696, 0.22222222222222
22186, 1, 0.8804347826087, 0.25
22187, 1, 0.85434782608696, 0.16666666666667
22188, 1, 0.8804347826087, 0.19444444444444
22189, 1, 0.85434782608696, 0.11111111111111
22190, 1, 0.8804347826087, 0.13888888888889
22191, 1, 0.85434782608696, 0.055555555555556
22192, 1, 0.8804347826087, 0.083333333333333
22193, 1, 0.8804347826087, 0.027777777777778
22194, 1, 0.90652173913043, 0.44444444444444
22195, 1, 0.93260869565217, 0.47222222222222
22196, 1, 0.90652173913043, 0.38888888888889
22197, 1, 0.93260869565217, 0.41666666666667
22198, 1, 0.90652173913043, 0.33333333333333
22199, 1, 0.93260869565217, 0.36111111111111
22200, 1, 0.90652173913043, 0.27777777777778
22201, 1, 0.93260869565217, 0.30555555555556
22202, 1, 0.90652173913043, 0.22222222222222
22203, 1, 0.93260869565217, 0.25
