39462, 0.95652173913043, 0.1375, 0.38888888888889
39463, 0.95652173913043, 0.1375, 0.44444444444444
39464, 0.91304347826087, 0.1375, 0.055555555555556
39465, 0.91304347826087, 0.1375, 0.11111111111111
39466, 0.91304347826087, 0.1375, 0.16666666666667
39467, 0.91304347826087, 0.1375, 0.22222222222222
39468, 0.91304347826087, 0.1375, 0.27777777777778
39469, 0.91304347826087, 0.1375, 0.33333333333333
39470, 0.91304347826087, 0.1375, 0.38888888888889
39471, 0.91304347826087, 0.1375, 0.44444444444444
39472, 0.8695652173913, 0.1375, 0.055555555555556
39473, 0.8695652173913, 0.1375, 0.11111111111111
39474, 0.8695652173913, 0.1375, 0.16666666666667
39475, 0.8695652173913, 0.1375, 0.22222222222222
39476, 0.8695652173913, 0.1375, 0.27777777777778
39477, 0.8695652173913, 0.1375, 0.33333333333333
39478, 0.8695652173913, 0.1375, 0.38888888888889
39479, 0.8695652173913, 0.1375, 0.44444444444444
39480, 0.82608695652174, 0.1375, 0.055555555555556
39481, 0.82608695652174, 0.1375, 0.11111111111111
39482, 0.82608695652174, 0.1375, 0.16666666666667
39483, 0.82608695652174, 0.1375, 0.22222222222222
39484, 0.82608695652174, 0.1375, 0.27777777777778
39485, 0.82608695652174, 0.1375, 0.33333333333333
39486, 0.82608695652174, 0.1375, 0.38888888888889
39487, 0.82608695652174, 0.1375, 0.44444444444444
39488, 0.78260869565217, 0.1375, 0.055555555555556
39489, 0.78260869565217, 0.1375, 0.11111111111111
39490, 0.78260869565217, 0.1375, 0.16666666666667
39491, 0.78260869565217, 0.1375, 0.22222222222222
39492, 0.78260869565217, 0.1375, 0.27777777777778
39493, 0.78260869565217, 0.1375, 0.33333333333333
39494, 0.78260869565217, 0.1375, 0.38888888888889
39495, 0.78260869565217, 0.1375, 0.44444444444444
39496, 0.73913043478261, 0.1375, 0.055555555555556
39497, 0.73913043478261, 0.1375, 0.11111111111111
39498, 0.73913043478261, 0.1375, 0.16666666666667
39499, 0.73913043478261, 0.1375, 0.22222222222222
39500, 0.73913043478261, 0.1375, 0.27777777777778
39501, 0.73913043478261, 0.1375, 0.33333333333333
39502, 0.73913043478261, 0.1375, 0.38888888888889
39503, 0.73913043478261, 0.1375, 0.44444444444444
39504, 0.69565217391304, 0.1375, 0.055555555555556
39505, 0.69565217391304, 0.1375, 0.11111111111111
39506, 0.69565217391304, 0.1375, 0.16666666666667
39507, 0.69565217391304, 0.1375, 0.22222222222222
39508, 0.69565217391304, 0.1375, 0.27777777777778
39509, 0.69565217391304, 0.1375, 0.33333333333333
39510, 0.69565217391304, 0.1375, 0.38888888888889
39511, 0.69565217391304, 0.1375, 0.44444444444444
39512, 0.65217391304348, 0.1375, 0.055555555555556
39513, 0.65217391304348, 0.1375, 0.11111111111111
39514, 0.65217391304348, 0.1375, 0.16666666666667
39515, 0.65217391304348, 0.1375, 0.22222222222222
39516, 0.65217391304348, 0.1375, 0.27777777777778
39517, 0.65217391304348, 0.1375, 0.33333333333333
39518, 0.65217391304348, 0.1375, 0.38888888888889
39519, 0.65217391304348, 0.1375, 0.44444444444444
39520, 0.60869565217391, 0.1375, 0.055555555555556
39521, 0.60869565217391, 0.1375, 0.11111111111111
39522, 0.60869565217391, 0.1375, 0.16666666666667
39523, 0.60869565217391, 0.1375, 0.22222222222222
39524, 0.60869565217391, 0.1375, 0.27777777777778
39525, 0.60869565217391, 0.1375, 0.33333333333333
39526, 0.60869565217391, 0.1375, 0.38888888888889
39527, 0.60869565217391, 0.1375, 0.44444444444444
39528, 0.56521739130435, 0.1375, 0.055555555555556
39529, 0.56521739130435, 0.1375, 0.11111111111111
39530, 0.56521739130435, 0.1375, 0.16666666666667
39531, 0.56521739130435, 0.1375, 0.22222222222222
39532, 0.56521739130435, 0.1375, 0.27777777777778
39533, 0.56521739130435, 0.1375, 0.33333333333333
39534, 0.56521739130435, 0.1375, 0.38888888888889
39535, 0.56521739130435, 0.1375, 0.44444444444444
39536, 0.52173913043478, 0.1375, 0.055555555555556
39537, 0.52173913043478, 0.1375, 0.11111111111111
39538, 0.52173913043478, 0.1375, 0.16666666666667
39539, 0.52173913043478, 0.1375, 0.22222222222222
39540, 0.52173913043478, 0.1375, 0.27777777777778
39541, 0.52173913043478, 0.1375, 0.33333333333333
39542, 0.52173913043478, 0.1375, 0.38888888888889
39543, 0.52173913043478, 0.1375, 0.44444444444444
39544, 0.47826086956522, 0.1375, 0.055555555555556
39545, 0.47826086956522, 0.1375, 0.11111111111111
39546, 0.47826086956522, 0.1375, 0.16666666666667
39547, 0.47826086956522, 0.1375, 0.22222222222222
39548, 0.47826086956522, 0.1375, 0.27777777777778
39549, 0.47826086956522, 0.1375, 0.33333333333333
39550, 0.47826086956522, 0.1375, 0.38888888888889
39551, 0.47826086956522, 0.1375, 0.44444444444444
39552, 0.43478260869565, 0.1375, 0.055555555555556
39553, 0.43478260869565, 0.1375, 0.11111111111111
39554, 0.43478260869565, 0.1375, 0.16666666666667
39555, 0.43478260869565, 0.1375, 0.22222222222222
39556, 0.43478260869565, 0.1375, 0.27777777777778
39557, 0.43478260869565, 0.1375, 0.33333333333333
39558, 0.43478260869565, 0.1375, 0.38888888888889
39559, 0.43478260869565, 0.1375, 0.44444444444444
39560, 0.39130434782609, 0.1375, 0.055555555555556
39561, 0.39130434782609, 0.1375, 0.11111111111111
39562, 0.39130434782609, 0.1375, 0.16666666666667
39563, 0.39130434782609, 0.1375, 0.22222222222222
39564, 0.39130434782609, 0.1375, 0.27777777777778
39565, 0.39130434782609, 0.1375, 0.33333333333333
39566, 0.39130434782609, 0.1375, 0.38888888888889
39567, 0.39130434782609, 0.1375, 0.44444444444444
39568, 0.34782608695652, 0.1375, 0.055555555555556
39569, 0.34782608695652, 0.1375, 0.11111111111111
39570, 0.34782608695652, 0.1375, 0.16666666666667
39571, 0.34782608695652, 0.1375, 0.22222222222222
39572, 0.34782608695652, 0.1375, 0.27777777777778
39573, 0.34782608695652, 0.1375, 0.33333333333333
39574, 0.34782608695652, 0.1375, 0.38888888888889
39575, 0.34782608695652, 0.1375, 0.44444444444444
39576, 0.30434782608696, 0.1375, 0.055555555555556
39577, 0.30434782608696, 0.1375, 0.11111111111111
39578, 0.30434782608696, 0.1375, 0.16666666666667
39579, 0.30434782608696, 0.1375, 0.22222222222222
39580, 0.30434782608696, 0.1375, 0.27777777777778
39581, 0.30434782608696, 0.1375, 0.33333333333333
39582, 0.30434782608696, 0.1375, 0.38888888888889
39583, 0.30434782608696, 0.1375, 0.44444444444444
39584, 0.26086956521739, 0.1375, 0.055555555555556
39585, 0.26086956521739, 0.1375, 0.11111111111111
39586, 0.26086956521739, 0.1375, 0.16666666666667
39587, 0.26086956521739, 0.1375, 0.22222222222222
39588, 0.26086956521739, 0.1375, 0.27777777777778
39589, 0.26086956521739, 0.1375, 0.33333333333333
39590, 0.26086956521739, 0.1375, 0.38888888888889
39591, 0.26086956521739, 0.1375, 0.44444444444444
39592, 0.21739130434783, 0.1375, 0.055555555555556
39593, 0.21739130434783, 0.1375, 0.11111111111111
39594, 0.21739130434783, 0.1375, 0.16666666666667
39595, 0.21739130434783, 0.1375, 0.22222222222222
39596, 0.21739130434783, 0.1375, 0.27777777777778
39597, 0.21739130434783, 0.1375, 0.33333333333333
39598, 0.21739130434783, 0.1375, 0.38888888888889
39599, 0.21739130434783, 0.1375, 0.44444444444444
39600, 0.17391304347826, 0.1375, 0.055555555555556
39601, 0.17391304347826, 0.1375, 0.11111111111111
39602, 0.17391304347826, 0.1375, 0.16666666666667
39603, 0.17391304347826, 0.1375, 0.22222222222222
39604, 0.17391304347826, 0.1375, 0.27777777777778
39605, 0.17391304347826, 0.1375, 0.33333333333333
39606, 0.17391304347826, 0.1375, 0.38888888888889
39607, 0.17391304347826, 0.1375, 0.44444444444444
39608, 0.1304347826087, 0.1375, 0.055555555555556
39609, 0.1304347826087, 0.1375, 0.11111111111111
39610, 0.1304347826087, 0.1375, 0.16666666666667
39611, 0.1304347826087, 0.1375, 0.22222222222222
39612, 0.1304347826087, 0.1375, 0.27777777777778
39613, 0.1304347826087, 0.1375, 0.33333333333333
39614, 0.1304347826087, 0.1375, 0.38888888888889
39615, 0.1304347826087, 0.1375, 0.44444444444444
39616, 0.08695652173913, 0.1375, 0.055555555555556
39617, 0.08695652173913, 0.1375, 0.11111111111111
39618, 0.08695652173913, 0.1375, 0.16666666666667
39619, 0.08695652173913, 0.1375, 0.22222222222222
39620, 0.08695652173913, 0.1375, 0.27777777777778
39621, 0.08695652173913, 0.1375, 0.33333333333333
39622, 0.08695652173913, 0.1375, 0.38888888888889
39623, 0.08695652173913, 0.1375, 0.44444444444444
39624, 0.043478260869565, 0.1375, 0.055555555555556
39625, 0.043478260869565, 0.1375, 0.11111111111111
39626, 0.043478260869565, 0.1375, 0.16666666666667
39627, 0.043478260869565, 0.1375, 0.22222222222222
39628, 0.043478260869565, 0.1375, 0.27777777777778
39629, 0.043478260869565, 0.1375, 0.33333333333333
39630, 0.043478260869565, 0.1375, 0.38888888888889
39631, 0.043478260869565, 0.1375, 0.44444444444444
39632, 0.95652173913043, 0.20217391304348, 0.055555555555556
39633, 0.95652173913044, 0.20217391304348, 0.11111111111111
39634, 0.95652173913044, 0.20217391304348, 0.16666666666667
39635, 0.95652173913044, 0.20217391304348, 0.22222222222222
39636, 0.95652173913044, 0.20217391304348, 0.27777777777778
39637, 0.95652173913044, 0.20217391304348, 0.33333333333333
39638, 0.95652173913043, 0.20217391304348, 0.38888888888889
39639, 0.95652173913044, 0.20217391304348, 0.44444444444444
39640, 0.91304347826087, 0.20217391304348, 0.055555555555556
39641, 0.91304347826087, 0.20217391304348, 0.11111111111111
39642, 0.91304347826087, 0.20217391304348, 0.16666666666667
39643, 0.91304347826087, 0.20217391304348, 0.22222222222222
39644, 0.91304347826087, 0.20217391304348, 0.27777777777778
39645, 0.91304347826087, 0.20217391304348, 0.33333333333333
39646, 0.91304347826087, 0.20217391304348, 0.38888888888889
39647, 0.91304347826087, 0.20217391304348, 0.44444444444444
39648, 0.8695652173913, 0.20217391304348, 0.055555555555556
39649, 0.8695652173913, 0.20217391304348, 0.11111111111111
39650, 0.8695652173913, 0.20217391304348, 0.16666666666667
39651, 0.8695652173913, 0.20217391304348, 0.22222222222222
39652, 0.8695652173913, 0.20217391304348, 0.27777777777778
39653, 0.8695652173913, 0.20217391304348, 0.33333333333333
39654, 0.8695652173913, 0.20217391304348, 0.38888888888889
39655, 0.8695652173913, 0.20217391304348, 0.44444444444444
39656, 0.82608695652174, 0.20217391304348, 0.055555555555556
39657, 0.82608695652174, 0.20217391304348, 0.11111111111111
39658, 0.82608695652174, 0.20217391304348, 0.16666666666667
39659, 0.82608695652174, 0.20217391304348, 0.22222222222222
39660, 0.82608695652174, 0.20217391304348, 0.27777777777778
39661, 0.82608695652174, 0.20217391304348, 0.33333333333333
39662, 0.82608695652174, 0.20217391304348, 0.38888888888889
39663, 0.82608695652174, 0.20217391304348, 0.44444444444444
39664, 0.78260869565217, 0.20217391304348, 0.055555555555556
39665, 0.78260869565217, 0.20217391304348, 0.11111111111111
39666, 0.78260869565217, 0.20217391304348, 0.16666666666667
39667, 0.78260869565217, 0.20217391304348, 0.22222222222222
39668, 0.78260869565217, 0.20217391304348, 0.27777777777778
39669, 0.78260869565217, 0.20217391304348, 0.33333333333333
39670, 0.78260869565217, 0.20217391304348, 0.38888888888889
39671, 0.78260869565217, 0.20217391304348, 0.44444444444444
39672, 0.73913043478261, 0.20217391304348, 0.055555555555556
39673, 0.73913043478261, 0.20217391304348, 0.11111111111111
39674, 0.73913043478261, 0.20217391304348, 0.16666666666667
39675, 0.73913043478261, 0.20217391304348, 0.22222222222222
39676, 0.73913043478261, 0.20217391304348, 0.27777777777778
39677, 0.73913043478261, 0.20217391304348, 0.33333333333333
39678, 0.73913043478261, 0.20217391304348, 0.38888888888889
39679, 0.73913043478261, 0.20217391304348, 0.44444444444444
39680, 0.69565217391304, 0.20217391304348, 0.055555555555556
39681, 0.69565217391304, 0.20217391304348, 0.11111111111111
39682, 0.69565217391304, 0.20217391304348, 0.16666666666667
39683, 0.69565217391304, 0.20217391304348, 0.22222222222222
39684, 0.69565217391304, 0.20217391304348, 0.27777777777778
39685, 0.69565217391304, 0.20217391304348, 0.33333333333333
39686, 0.69565217391304, 0.20217391304348, 0.38888888888889
39687, 0.69565217391304, 0.20217391304348, 0.44444444444444
39688, 0.65217391304348, 0.20217391304348, 0.055555555555556
39689, 0.65217391304348, 0.20217391304348, 0.11111111111111
39690, 0.65217391304348, 0.20217391304348, 0.16666666666667
39691, 0.65217391304348, 0.20217391304348, 0.22222222222222
39692, 0.65217391304348, 0.20217391304348, 0.27777777777778
39693, 0.65217391304348, 0.20217391304348, 0.33333333333333
39694, 0.65217391304348, 0.20217391304348, 0.38888888888889
39695, 0.65217391304348, 0.20217391304348, 0.44444444444444
39696, 0.60869565217391, 0.20217391304348, 0.055555555555556
39697, 0.60869565217391, 0.20217391304348, 0.11111111111111
39698, 0.60869565217391, 0.20217391304348, 0.16666666666667
39699, 0.60869565217391, 0.20217391304348, 0.22222222222222
39700, 0.60869565217391, 0.20217391304348, 0.27777777777778
39701, 0.60869565217391, 0.20217391304348, 0.33333333333333
39702, 0.60869565217391, 0.20217391304348, 0.38888888888889
39703, 0.60869565217391, 0.20217391304348, 0.44444444444444
39704, 0.56521739130435, 0.20217391304348, 0.055555555555556
39705, 0.56521739130435, 0.20217391304348, 0.11111111111111
39706, 0.56521739130435, 0.20217391304348, 0.16666666666667
39707, 0.56521739130435, 0.20217391304348, 0.22222222222222
39708, 0.56521739130435, 0.20217391304348, 0.27777777777778
39709, 0.56521739130435, 0.20217391304348, 0.33333333333333
39710, 0.56521739130435, 0.20217391304348, 0.38888888888889
39711, 0.56521739130435, 0.20217391304348, 0.44444444444444
39712, 0.52173913043478, 0.20217391304348, 0.055555555555556
39713, 0.52173913043478, 0.20217391304348, 0.11111111111111
39714, 0.52173913043478, 0.20217391304348, 0.16666666666667
39715, 0.52173913043478, 0.20217391304348, 0.22222222222222
39716, 0.52173913043478, 0.20217391304348, 0.27777777777778
39717, 0.52173913043478, 0.20217391304348, 0.33333333333333
39718, 0.52173913043478, 0.20217391304348, 0.38888888888889
39719, 0.52173913043478, 0.20217391304348, 0.44444444444444
39720, 0.47826086956522, 0.20217391304348, 0.055555555555556
39721, 0.47826086956522, 0.20217391304348, 0.11111111111111
39722, 0.47826086956522, 0.20217391304348, 0.16666666666667
39723, 0.47826086956522, 0.20217391304348, 0.22222222222222
39724, 0.47826086956522, 0.20217391304348, 0.27777777777778
39725, 0.47826086956522, 0.20217391304348, 0.33333333333333
39726, 0.47826086956522, 0.20217391304348, 0.38888888888889
39727, 0.47826086956522, 0.20217391304348, 0.44444444444444
39728, 0.43478260869565, 0.20217391304348, 0.055555555555556
39729, 0.43478260869565, 0.20217391304348, 0.11111111111111
39730, 0.43478260869565, 0.20217391304348, 0.16666666666667
39731, 0.43478260869565, 0.20217391304348, 0.22222222222222
39732, 0.43478260869565, 0.20217391304348, 0.27777777777778
39733, 0.43478260869565, 0.20217391304348, 0.33333333333333
39734, 0.43478260869565, 0.20217391304348, 0.38888888888889
39735, 0.43478260869565, 0.20217391304348, 0.44444444444444
39736, 0.39130434782609, 0.20217391304348, 0.055555555555556
39737, 0.39130434782609, 0.20217391304348, 0.11111111111111
39738, 0.39130434782609, 0.20217391304348, 0.16666666666667
39739, 0.39130434782609, 0.20217391304348, 0.22222222222222
39740, 0.39130434782609, 0.20217391304348, 0.27777777777778
39741, 0.39130434782609, 0.20217391304348, 0.33333333333333
39742, 0.39130434782609, 0.20217391304348, 0.38888888888889
39743, 0.39130434782609, 0.20217391304348, 0.44444444444444
39744, 0.34782608695652, 0.20217391304348, 0.055555555555556
39745, 0.34782608695652, 0.20217391304348, 0.11111111111111
39746, 0.34782608695652, 0.20217391304348, 0.16666666666667
39747, 0.34782608695652, 0.20217391304348, 0.22222222222222
39748, 0.34782608695652, 0.20217391304348, 0.27777777777778
39749, 0.34782608695652, 0.20217391304348, 0.33333333333333
39750, 0.34782608695652, 0.20217391304348, 0.38888888888889
39751, 0.34782608695652, 0.20217391304348, 0.44444444444444
39752, 0.30434782608696, 0.20217391304348, 0.055555555555556
39753, 0.30434782608696, 0.20217391304348, 0.11111111111111
39754, 0.30434782608696, 0.20217391304348, 0.16666666666667
39755, 0.30434782608696, 0.20217391304348, 0.22222222222222
39756, 0.30434782608696, 0.20217391304348, 0.27777777777778
39757, 0.30434782608696, 0.20217391304348, 0.33333333333333
39758, 0.30434782608696, 0.20217391304348, 0.38888888888889
39759, 0.30434782608696, 0.20217391304348, 0.44444444444444
39760, 0.26086956521739, 0.20217391304348, 0.055555555555556
39761, 0.26086956521739, 0.20217391304348, 0.11111111111111
39762, 0.26086956521739, 0.20217391304348, 0.16666666666667
39763, 0.26086956521739, 0.20217391304348, 0.22222222222222
39764, 0.26086956521739, 0.20217391304348, 0.27777777777778
39765, 0.26086956521739, 0.20217391304348, 0.33333333333333
39766, 0.26086956521739, 0.20217391304348, 0.38888888888889
39767, 0.26086956521739, 0.20217391304348, 0.44444444444444
39768, 0.21739130434783, 0.20217391304348, 0.055555555555556
39769, 0.21739130434783, 0.20217391304348, 0.11111111111111
39770, 0.21739130434783, 0.20217391304348, 0.16666666666667
39771, 0.21739130434783, 0.20217391304348, 0.22222222222222
39772, 0.21739130434783, 0.20217391304348, 0.27777777777778
39773, 0.21739130434783, 0.20217391304348, 0.33333333333333
39774, 0.21739130434783, 0.20217391304348, 0.38888888888889
39775, 0.21739130434783, 0.20217391304348, 0.44444444444444
39776, 0.17391304347826, 0.20217391304348, 0.055555555555556
39777, 0.17391304347826, 0.20217391304348, 0.11111111111111
39778, 0.17391304347826, 0.20217391304348, 0.16666666666667
39779, 0.17391304347826, 0.20217391304348, 0.22222222222222
39780, 0.17391304347826, 0.20217391304348, 0.27777777777778
39781, 0.17391304347826, 0.20217391304348, 0.33333333333333
39782, 0.17391304347826, 0.20217391304348, 0.38888888888889
39783, 0.17391304347826, 0.20217391304348, 0.44444444444444
39784, 0.1304347826087, 0.20217391304348, 0.055555555555556
39785, 0.1304347826087, 0.20217391304348, 0.11111111111111
39786, 0.1304347826087, 0.20217391304348, 0.16666666666667
39787, 0.1304347826087, 0.20217391304348, 0.22222222222222
39788, 0.1304347826087, 0.20217391304348, 0.27777777777778
39789, 0.1304347826087, 0.20217391304348, 0.33333333333333
39790, 0.1304347826087, 0.20217391304348, 0.38888888888889
39791, 0.1304347826087, 0.20217391304348, 0.44444444444444
39792, 0.08695652173913, 0.20217391304348, 0.055555555555556
39793, 0.08695652173913, 0.20217391304348, 0.11111111111111
39794, 0.08695652173913, 0.20217391304348, 0.16666666666667
39795, 0.08695652173913, 0.20217391304348, 0.22222222222222
39796, 0.08695652173913, 0.20217391304348, 0.27777777777778
39797, 0.08695652173913, 0.20217391304348, 0.33333333333333
39798, 0.08695652173913, 0.20217391304348, 0.38888888888889
39799, 0.08695652173913, 0.20217391304348, 0.44444444444444
39800, 0.043478260869565, 0.20217391304348, 0.055555555555556
39801, 0.043478260869565, 0.20217391304348, 0.11111111111111
39802, 0.043478260869565, 0.20217391304348, 0.16666666666667
39803, 0.043478260869565, 0.20217391304348, 0.22222222222222
39804, 0.043478260869565, 0.20217391304348, 0.27777777777778
39805, 0.043478260869565, 0.20217391304348, 0.33333333333333
39806, 0.043478260869565, 0.20217391304348, 0.38888888888889
39807, 0.043478260869565, 0.20217391304348, 0.44444444444444
39808, 0.95652173913043, 0.25434782608696, 0.055555555555556
39809, 0.95652173913043, 0.25434782608696, 0.11111111111111
39810, 0.95652173913044, 0.25434782608696, 0.16666666666667
39811, 0.95652173913043, 0.25434782608696, 0.22222222222222
39812, 0.95652173913043, 0.25434782608696, 0.27777777777778
39813, 0.95652173913043, 0.25434782608696, 0.33333333333333
39814, 0.95652173913043, 0.25434782608696, 0.38888888888889
39815, 0.95652173913043, 0.25434782608696, 0.44444444444444
39816, 0.91304347826087, 0.25434782608696, 0.055555555555556
39817, 0.91304347826087, 0.25434782608696, 0.11111111111111
39818, 0.91304347826087, 0.25434782608696, 0.16666666666667
39819, 0.91304347826087, 0.25434782608696, 0.22222222222222
39820, 0.91304347826087, 0.25434782608696, 0.27777777777778
39821, 0.91304347826087, 0.25434782608696, 0.33333333333333
39822, 0.91304347826087, 0.25434782608696, 0.38888888888889
39823, 0.91304347826087, 0.25434782608696, 0.44444444444444
39824, 0.8695652173913, 0.25434782608696, 0.055555555555556
39825, 0.8695652173913, 0.25434782608696, 0.11111111111111
39826, 0.8695652173913, 0.25434782608696, 0.16666666666667
39827, 0.8695652173913, 0.25434782608696, 0.22222222222222
39828, 0.8695652173913, 0.25434782608696, 0.27777777777778
39829, 0.8695652173913, 0.25434782608696, 0.33333333333333
39830, 0.8695652173913, 0.25434782608696, 0.38888888888889
39831, 0.8695652173913, 0.25434782608696, 0.44444444444444
39832, 0.82608695652174, 0.25434782608696, 0.055555555555556
39833, 0.82608695652174, 0.25434782608696, 0.11111111111111
39834, 0.82608695652174, 0.25434782608696, 0.16666666666667
39835, 0.82608695652174, 0.25434782608696, 0.22222222222222
39836, 0.82608695652174, 0.25434782608696, 0.27777777777778
39837, 0.82608695652174, 0.25434782608696, 0.33333333333333
39838, 0.82608695652174, 0.25434782608696, 0.38888888888889
39839, 0.82608695652174, 0.25434782608696, 0.44444444444444
39840, 0.78260869565217, 0.25434782608696, 0.055555555555556
39841, 0.78260869565217, 0.25434782608696, 0.11111111111111
39842, 0.78260869565217, 0.25434782608696, 0.16666666666667
39843, 0.78260869565217, 0.25434782608696, 0.22222222222222
39844, 0.78260869565217, 0.25434782608696, 0.27777777777778
39845, 0.78260869565217, 0.25434782608696, 0.33333333333333
39846, 0.78260869565217, 0.25434782608696, 0.38888888888889
39847, 0.78260869565217, 0.25434782608696, 0.44444444444444
39848, 0.73913043478261, 0.25434782608696, 0.055555555555556
39849, 0.73913043478261, 0.25434782608696, 0.11111111111111
39850, 0.73913043478261, 0.25434782608696, 0.16666666666667
39851, 0.73913043478261, 0.25434782608696, 0.22222222222222
39852, 0.73913043478261, 0.25434782608696, 0.27777777777778
39853, 0.73913043478261, 0.25434782608696, 0.33333333333333
39854, 0.73913043478261, 0.25434782608696, 0.38888888888889
39855, 0.73913043478261, 0.25434782608696, 0.44444444444444
39856, 0.69565217391304, 0.25434782608696, 0.055555555555556
39857, 0.69565217391304, 0.25434782608696, 0.11111111111111
39858, 0.69565217391304, 0.25434782608696, 0.16666666666667
39859, 0.69565217391304, 0.25434782608696, 0.22222222222222
39860, 0.69565217391304, 0.25434782608696, 0.27777777777778
39861, 0.69565217391304, 0.25434782608696, 0.33333333333333
39862, 0.69565217391304, 0.25434782608696, 0.38888888888889
39863, 0.69565217391304, 0.25434782608696, 0.44444444444444
39864, 0.65217391304348, 0.25434782608696, 0.055555555555556
39865, 0.65217391304348, 0.25434782608696, 0.11111111111111
39866, 0.65217391304348, 0.25434782608696, 0.16666666666667
39867, 0.65217391304348, 0.25434782608696, 0.22222222222222
39868, 0.65217391304348, 0.25434782608696, 0.27777777777778
39869, 0.65217391304348, 0.25434782608696, 0.33333333333333
39870, 0.65217391304348, 0.25434782608696, 0.38888888888889
39871, 0.65217391304348, 0.25434782608696, 0.44444444444444
39872, 0.60869565217391, 0.25434782608696, 0.055555555555556
39873, 0.60869565217391, 0.25434782608696, 0.11111111111111
39874, 0.60869565217391, 0.25434782608696, 0.16666666666667
39875, 0.60869565217391, 0.25434782608696, 0.22222222222222
39876, 0.60869565217391, 0.25434782608696, 0.27777777777778
39877, 0.60869565217391, 0.25434782608696, 0.33333333333333
39878, 0.60869565217391, 0.25434782608696, 0.38888888888889
39879, 0.60869565217391, 0.25434782608696, 0.44444444444444
39880, 0.56521739130435, 0.25434782608696, 0.055555555555556
39881, 0.56521739130435, 0.25434782608696, 0.11111111111111
39882, 0.56521739130435, 0.25434782608696, 0.16666666666667
39883, 0.56521739130435, 0.25434782608696, 0.22222222222222
39884, 0.56521739130435, 0.25434782608696, 0.27777777777778
39885, 0.56521739130435, 0.25434782608696, 0.33333333333333
39886, 0.56521739130435, 0.25434782608696, 0.38888888888889
39887, 0.56521739130435, 0.25434782608696, 0.44444444444444
39888, 0.52173913043478, 0.25434782608696, 0.055555555555556
39889, 0.52173913043478, 0.25434782608696, 0.11111111111111
39890, 0.52173913043478, 0.25434782608696, 0.16666666666667
39891, 0.52173913043478, 0.25434782608696, 0.22222222222222
39892, 0.52173913043478, 0.25434782608696, 0.27777777777778
39893, 0.52173913043478, 0.25434782608696, 0.33333333333333
39894, 0.52173913043478, 0.25434782608696, 0.38888888888889
39895, 0.52173913043478, 0.25434782608696, 0.44444444444444
39896, 0.47826086956522, 0.25434782608696, 0.055555555555556
39897, 0.47826086956522, 0.25434782608696, 0.11111111111111
39898, 0.47826086956522, 0.25434782608696, 0.16666666666667
39899, 0.47826086956522, 0.25434782608696, 0.22222222222222
39900, 0.47826086956522, 0.25434782608696, 0.27777777777778
39901, 0.47826086956522, 0.25434782608696, 0.33333333333333
39902, 0.47826086956522, 0.25434782608696, 0.38888888888889
39903, 0.47826086956522, 0.25434782608696, 0.44444444444444
39904, 0.43478260869565, 0.25434782608696, 0.055555555555556
39905, 0.43478260869565, 0.25434782608696, 0.11111111111111
39906, 0.43478260869565, 0.25434782608696, 0.16666666666667
39907, 0.43478260869565, 0.25434782608696, 0.22222222222222
39908, 0.43478260869565, 0.25434782608696, 0.27777777777778
39909, 0.43478260869565, 0.25434782608696, 0.33333333333333
39910, 0.43478260869565, 0.25434782608696, 0.38888888888889
39911, 0.43478260869565, 0.25434782608696, 0.44444444444444
39912, 0.39130434782609, 0.25434782608696, 0.055555555555556
39913, 0.39130434782609, 0.25434782608696, 0.11111111111111
39914, 0.39130434782609, 0.25434782608696, 0.16666666666667
39915, 0.39130434782609, 0.25434782608696, 0.22222222222222
39916, 0.39130434782609, 0.25434782608696, 0.27777777777778
39917, 0.39130434782609, 0.25434782608696, 0.33333333333333
39918, 0.39130434782609, 0.25434782608696, 0.38888888888889
39919, 0.39130434782609, 0.25434782608696, 0.44444444444444
39920, 0.34782608695652, 0.25434782608696, 0.055555555555556
39921, 0.34782608695652, 0.25434782608696, 0.11111111111111
39922, 0.34782608695652, 0.25434782608696, 0.16666666666667
39923, 0.34782608695652, 0.25434782608696, 0.22222222222222
39924, 0.34782608695652, 0.25434782608696, 0.27777777777778
39925, 0.34782608695652, 0.25434782608696, 0.33333333333333
39926, 0.34782608695652, 0.25434782608696, 0.38888888888889
39927, 0.34782608695652, 0.25434782608696, 0.44444444444444
39928, 0.30434782608696, 0.25434782608696, 0.055555555555556
39929, 0.30434782608696, 0.25434782608696, 0.11111111111111
39930, 0.30434782608696, 0.25434782608696, 0.16666666666667
39931, 0.30434782608696, 0.25434782608696, 0.22222222222222
39932, 0.30434782608696, 0.25434782608696, 0.27777777777778
39933, 0.30434782608696, 0.25434782608696, 0.33333333333333
39934, 0.30434782608696, 0.25434782608696, 0.38888888888889
39935, 0.30434782608696, 0.25434782608696, 0.44444444444444
39936, 0.26086956521739, 0.25434782608696, 0.055555555555556
39937, 0.26086956521739, 0.25434782608696, 0.11111111111111
39938, 0.26086956521739, 0.25434782608696, 0.16666666666667
39939, 0.26086956521739, 0.25434782608696, 0.22222222222222
39940, 0.26086956521739, 0.25434782608696, 0.27777777777778
39941, 0.26086956521739, 0.25434782608696, 0.33333333333333
39942, 0.26086956521739, 0.25434782608696, 0.38888888888889
39943, 0.26086956521739, 0.25434782608696, 0.44444444444444
39944, 0.21739130434783, 0.25434782608696, 0.055555555555556
39945, 0.21739130434783, 0.25434782608696, 0.11111111111111
39946, 0.21739130434783, 0.25434782608696, 0.16666666666667
39947, 0.21739130434783, 0.25434782608696, 0.22222222222222
39948, 0.21739130434783, 0.25434782608696, 0.27777777777778
39949, 0.21739130434783, 0.25434782608696, 0.33333333333333
39950, 0.21739130434783, 0.25434782608696, 0.38888888888889
39951, 0.21739130434783, 0.25434782608696, 0.44444444444444
39952, 0.17391304347826, 0.25434782608696, 0.055555555555556
39953, 0.17391304347826, 0.25434782608696, 0.11111111111111
39954, 0.17391304347826, 0.25434782608696, 0.16666666666667
39955, 0.17391304347826, 0.25434782608696, 0.22222222222222
39956, 0.17391304347826, 0.25434782608696, 0.27777777777778
39957, 0.17391304347826, 0.25434782608696, 0.33333333333333
39958, 0.17391304347826, 0.25434782608696, 0.38888888888889
39959, 0.17391304347826, 0.25434782608696, 0.44444444444444
39960, 0.1304347826087, 0.25434782608696, 0.055555555555556
39961, 0.1304347826087, 0.25434782608696, 0.11111111111111
39962, 0.1304347826087, 0.25434782608696, 0.16666666666667
39963, 0.1304347826087, 0.25434782608696, 0.22222222222222
39964, 0.1304347826087, 0.25434782608696, 0.27777777777778
39965, 0.1304347826087, 0.25434782608696, 0.33333333333333
39966, 0.1304347826087, 0.25434782608696, 0.38888888888889
39967, 0.1304347826087, 0.25434782608696, 0.44444444444444
39968, 0.08695652173913, 0.25434782608696, 0.055555555555556
39969, 0.08695652173913, 0.25434782608696, 0.11111111111111
39970, 0.08695652173913, 0.25434782608696, 0.16666666666667
39971, 0.08695652173913, 0.25434782608696, 0.22222222222222
39972, 0.08695652173913, 0.25434782608696, 0.27777777777778
39973, 0.08695652173913, 0.25434782608696, 0.33333333333333
39974, 0.08695652173913, 0.25434782608696, 0.38888888888889
39975, 0.08695652173913, 0.25434782608696, 0.44444444444444
39976, 0.043478260869565, 0.25434782608696, 0.055555555555556
39977, 0.043478260869565, 0.25434782608696, 0.11111111111111
39978, 0.043478260869565, 0.25434782608696, 0.16666666666667
39979, 0.043478260869565, 0.25434782608696, 0.22222222222222
39980, 0.043478260869565, 0.25434782608696, 0.27777777777778
39981, 0.043478260869565, 0.25434782608696, 0.33333333333333
39982, 0.043478260869565, 0.25434782608696, 0.38888888888889
39983, 0.043478260869565, 0.25434782608696, 0.44444444444444
39984, 0.95652173913044, 0.30652173913043, 0.055555555555556
39985, 0.95652173913044, 0.30652173913043, 0.11111111111111
39986, 0.95652173913044, 0.30652173913043, 0.16666666666667
39987, 0.95652173913044, 0.30652173913043, 0.22222222222222
39988, 0.95652173913044, 0.30652173913043, 0.27777777777778
39989, 0.95652173913044, 0.30652173913043, 0.33333333333333
39990, 0.95652173913044, 0.30652173913043, 0.38888888888889
39991, 0.95652173913044, 0.30652173913043, 0.44444444444444
39992, 0.91304347826087, 0.30652173913043, 0.055555555555556
39993, 0.91304347826087, 0.30652173913043, 0.11111111111111
39994, 0.91304347826087, 0.30652173913043, 0.16666666666667
39995, 0.91304347826087, 0.30652173913043, 0.22222222222222
39996, 0.91304347826087, 0.30652173913043, 0.27777777777778
39997, 0.91304347826087, 0.30652173913043, 0.33333333333333
39998, 0.91304347826087, 0.30652173913043, 0.38888888888889
39999, 0.91304347826087, 0.30652173913043, 0.44444444444444
40000, 0.8695652173913, 0.30652173913043, 0.055555555555556
40001, 0.8695652173913, 0.30652173913043, 0.11111111111111
40002, 0.8695652173913, 0.30652173913043, 0.16666666666667
40003, 0.8695652173913, 0.30652173913043, 0.22222222222222
40004, 0.8695652173913, 0.30652173913043, 0.27777777777778
40005, 0.8695652173913, 0.30652173913043, 0.33333333333333
40006, 0.8695652173913, 0.30652173913043, 0.38888888888889
40007, 0.8695652173913, 0.30652173913043, 0.44444444444444
40008, 0.82608695652174, 0.30652173913043, 0.055555555555556
40009, 0.82608695652174, 0.30652173913043, 0.11111111111111
40010, 0.82608695652174, 0.30652173913043, 0.16666666666667
40011, 0.82608695652174, 0.30652173913043, 0.22222222222222
40012, 0.82608695652174, 0.30652173913043, 0.27777777777778
40013, 0.82608695652174, 0.30652173913043, 0.33333333333333
40014, 0.82608695652174, 0.30652173913043, 0.38888888888889
40015, 0.82608695652174, 0.30652173913043, 0.44444444444444
40016, 0.78260869565217, 0.30652173913043, 0.055555555555556
40017, 0.78260869565217, 0.30652173913043, 0.11111111111111
40018, 0.78260869565217, 0.30652173913043, 0.16666666666667
40019, 0.78260869565217, 0.30652173913043, 0.22222222222222
40020, 0.78260869565217, 0.30652173913043, 0.27777777777778
40021, 0.78260869565217, 0.30652173913043, 0.33333333333333
40022, 0.78260869565217, 0.30652173913043, 0.38888888888889
40023, 0.78260869565217, 0.30652173913043, 0.44444444444444
40024, 0.73913043478261, 0.30652173913043, 0.055555555555556
40025, 0.73913043478261, 0.30652173913043, 0.11111111111111
40026, 0.73913043478261, 0.30652173913043, 0.16666666666667
40027, 0.73913043478261, 0.30652173913043, 0.22222222222222
40028, 0.73913043478261, 0.30652173913043, 0.27777777777778
40029, 0.73913043478261, 0.30652173913043, 0.33333333333333
40030, 0.73913043478261, 0.30652173913043, 0.38888888888889
40031, 0.73913043478261, 0.30652173913043, 0.44444444444444
40032, 0.69565217391304, 0.30652173913043, 0.055555555555556
40033, 0.69565217391304, 0.30652173913043, 0.11111111111111
40034, 0.69565217391304, 0.30652173913043, 0.16666666666667
40035, 0.69565217391304, 0.30652173913044, 0.22222222222222
40036, 0.69565217391304, 0.30652173913043, 0.27777777777778
40037, 0.69565217391304, 0.30652173913043, 0.33333333333333
40038, 0.69565217391304, 0.30652173913043, 0.38888888888889
40039, 0.69565217391304, 0.30652173913043, 0.44444444444444
40040, 0.65217391304348, 0.30652173913043, 0.055555555555556
40041, 0.65217391304348, 0.30652173913043, 0.11111111111111
40042, 0.65217391304348, 0.30652173913043, 0.16666666666667
40043, 0.65217391304348, 0.30652173913043, 0.22222222222222
40044, 0.65217391304348, 0.30652173913043, 0.27777777777778
40045, 0.65217391304348, 0.30652173913043, 0.33333333333333
40046, 0.65217391304348, 0.30652173913043, 0.38888888888889
40047, 0.65217391304348, 0.30652173913043, 0.44444444444444
40048, 0.60869565217391, 0.30652173913043, 0.055555555555556
40049, 0.60869565217391, 0.30652173913043, 0.11111111111111
40050, 0.60869565217391, 0.30652173913043, 0.16666666666667
40051, 0.60869565217391, 0.30652173913043, 0.22222222222222
40052, 0.60869565217391, 0.30652173913043, 0.27777777777778
40053, 0.60869565217391, 0.30652173913043, 0.33333333333333
40054, 0.60869565217391, 0.30652173913043, 0.38888888888889
40055, 0.60869565217391, 0.30652173913043, 0.44444444444444
40056, 0.56521739130435, 0.30652173913043, 0.055555555555556
40057, 0.56521739130435, 0.30652173913043, 0.11111111111111
40058, 0.56521739130435, 0.30652173913043, 0.16666666666667
40059, 0.56521739130435, 0.30652173913043, 0.22222222222222
40060, 0.56521739130435, 0.30652173913043, 0.27777777777778
40061, 0.56521739130435, 0.30652173913043, 0.33333333333333
40062, 0.56521739130435, 0.30652173913043, 0.38888888888889
40063, 0.56521739130435, 0.30652173913043, 0.44444444444444
40064, 0.52173913043478, 0.30652173913043, 0.055555555555556
40065, 0.52173913043478, 0.30652173913043, 0.11111111111111
40066, 0.52173913043478, 0.30652173913043, 0.16666666666667
40067, 0.52173913043478, 0.30652173913043, 0.22222222222222
40068, 0.52173913043478, 0.30652173913043, 0.27777777777778
40069, 0.52173913043478, 0.30652173913043, 0.33333333333333
40070, 0.52173913043478, 0.30652173913043, 0.38888888888889
40071, 0.52173913043478, 0.30652173913043, 0.44444444444444
40072, 0.47826086956522, 0.30652173913043, 0.055555555555556
40073, 0.47826086956522, 0.30652173913043, 0.11111111111111
40074, 0.47826086956522, 0.30652173913043, 0.16666666666667
40075, 0.47826086956522, 0.30652173913043, 0.22222222222222
40076, 0.47826086956522, 0.30652173913043, 0.27777777777778
40077, 0.47826086956522, 0.30652173913043, 0.33333333333333
40078, 0.47826086956522, 0.30652173913043, 0.38888888888889
40079, 0.47826086956522, 0.30652173913043, 0.44444444444444
40080, 0.43478260869565, 0.30652173913043, 0.055555555555556
40081, 0.43478260869565, 0.30652173913043, 0.11111111111111
40082, 0.43478260869565, 0.30652173913043, 0.16666666666667
40083, 0.43478260869565, 0.30652173913043, 0.22222222222222
40084, 0.43478260869565, 0.30652173913043, 0.27777777777778
40085, 0.43478260869565, 0.30652173913043, 0.33333333333333
40086, 0.43478260869565, 0.30652173913043, 0.38888888888889
40087, 0.43478260869565, 0.30652173913043, 0.44444444444444
40088, 0.39130434782609, 0.30652173913043, 0.055555555555556
40089, 0.39130434782609, 0.30652173913043, 0.11111111111111
40090, 0.39130434782609, 0.30652173913043, 0.16666666666667
40091, 0.39130434782609, 0.30652173913043, 0.22222222222222
40092, 0.39130434782609, 0.30652173913043, 0.27777777777778
40093, 0.39130434782609, 0.30652173913043, 0.33333333333333
40094, 0.39130434782609, 0.30652173913043, 0.38888888888889
40095, 0.39130434782609, 0.30652173913043, 0.44444444444444
40096, 0.34782608695652, 0.30652173913043, 0.055555555555556
40097, 0.34782608695652, 0.30652173913043, 0.11111111111111
40098, 0.34782608695652, 0.30652173913043, 0.16666666666667
40099, 0.34782608695652, 0.30652173913043, 0.22222222222222
40100, 0.34782608695652, 0.30652173913043, 0.27777777777778
40101, 0.34782608695652, 0.30652173913043, 0.33333333333333
40102, 0.34782608695652, 0.30652173913043, 0.38888888888889
40103, 0.34782608695652, 0.30652173913043, 0.44444444444444
40104, 0.30434782608696, 0.30652173913043, 0.055555555555556
40105, 0.30434782608696, 0.30652173913043, 0.11111111111111
40106, 0.30434782608696, 0.30652173913043, 0.16666666666667
40107, 0.30434782608696, 0.30652173913043, 0.22222222222222
40108, 0.30434782608696, 0.30652173913043, 0.27777777777778
40109, 0.30434782608696, 0.30652173913043, 0.33333333333333
40110, 0.30434782608696, 0.30652173913043, 0.38888888888889
40111, 0.30434782608696, 0.30652173913043, 0.44444444444444
40112, 0.26086956521739, 0.30652173913043, 0.055555555555556
40113, 0.26086956521739, 0.30652173913043, 0.11111111111111
40114, 0.26086956521739, 0.30652173913043, 0.16666666666667
40115, 0.26086956521739, 0.30652173913043, 0.22222222222222
40116, 0.26086956521739, 0.30652173913043, 0.27777777777778
40117, 0.26086956521739, 0.30652173913043, 0.33333333333333
40118, 0.26086956521739, 0.30652173913043, 0.38888888888889
40119, 0.26086956521739, 0.30652173913043, 0.44444444444444
40120, 0.21739130434783, 0.30652173913043, 0.055555555555556
40121, 0.21739130434783, 0.30652173913043, 0.11111111111111
40122, 0.21739130434783, 0.30652173913043, 0.16666666666667
40123, 0.21739130434783, 0.30652173913043, 0.22222222222222
40124, 0.21739130434783, 0.30652173913043, 0.27777777777778
40125, 0.21739130434783, 0.30652173913043, 0.33333333333333
40126, 0.21739130434783, 0.30652173913043, 0.38888888888889
40127, 0.21739130434783, 0.30652173913043, 0.44444444444444
40128, 0.17391304347826, 0.30652173913043, 0.055555555555556
40129, 0.17391304347826, 0.30652173913043, 0.11111111111111
40130, 0.17391304347826, 0.30652173913043, 0.16666666666667
40131, 0.17391304347826, 0.30652173913043, 0.22222222222222
40132, 0.17391304347826, 0.30652173913043, 0.27777777777778
40133, 0.17391304347826, 0.30652173913043, 0.33333333333333
40134, 0.17391304347826, 0.30652173913043, 0.38888888888889
40135, 0.17391304347826, 0.30652173913043, 0.44444444444444
40136, 0.1304347826087, 0.30652173913043, 0.055555555555556
40137, 0.1304347826087, 0.30652173913043, 0.11111111111111
40138, 0.1304347826087, 0.30652173913043, 0.16666666666667
40139, 0.1304347826087, 0.30652173913043, 0.22222222222222
40140, 0.1304347826087, 0.30652173913043, 0.27777777777778
40141, 0.1304347826087, 0.30652173913043, 0.33333333333333
40142, 0.1304347826087, 0.30652173913043, 0.38888888888889
40143, 0.1304347826087, 0.30652173913043, 0.44444444444444
40144, 0.08695652173913, 0.30652173913043, 0.055555555555556
40145, 0.08695652173913, 0.30652173913043, 0.11111111111111
40146, 0.08695652173913, 0.30652173913043, 0.16666666666667
40147, 0.08695652173913, 0.30652173913043, 0.22222222222222
40148, 0.08695652173913, 0.30652173913043, 0.27777777777778
40149, 0.08695652173913, 0.30652173913043, 0.33333333333333
40150, 0.08695652173913, 0.30652173913043, 0.38888888888889
40151, 0.08695652173913, 0.30652173913043, 0.44444444444444
40152, 0.043478260869565, 0.30652173913043, 0.055555555555556
40153, 0.043478260869565, 0.30652173913043, 0.11111111111111
40154, 0.043478260869565, 0.30652173913043, 0.16666666666667
40155, 0.043478260869565, 0.30652173913043, 0.22222222222222
40156, 0.043478260869565, 0.30652173913043, 0.27777777777778
40157, 0.043478260869565, 0.30652173913043, 0.33333333333333
40158, 0.043478260869565, 0.30652173913043, 0.38888888888889
40159, 0.043478260869565, 0.30652173913043, 0.44444444444444
40160, 0.95652173913043, 0.35869565217391, 0.055555555555556
40161, 0.95652173913044, 0.35869565217391, 0.11111111111111
40162, 0.95652173913044, 0.35869565217391, 0.16666666666667
40163, 0.95652173913044, 0.35869565217391, 0.22222222222222
40164, 0.95652173913044, 0.35869565217391, 0.27777777777778
40165, 0.95652173913044, 0.35869565217391, 0.33333333333333
40166, 0.95652173913043, 0.35869565217391, 0.38888888888889
40167, 0.95652173913044, 0.35869565217391, 0.44444444444444
40168, 0.91304347826087, 0.35869565217391, 0.055555555555556
40169, 0.91304347826087, 0.35869565217391, 0.11111111111111
40170, 0.91304347826087, 0.35869565217391, 0.16666666666667
40171, 0.91304347826087, 0.35869565217391, 0.22222222222222
40172, 0.91304347826087, 0.35869565217391, 0.27777777777778
40173, 0.91304347826087, 0.35869565217391, 0.33333333333333
40174, 0.91304347826087, 0.35869565217391, 0.38888888888889
40175, 0.91304347826087, 0.35869565217391, 0.44444444444444
40176, 0.8695652173913, 0.35869565217391, 0.055555555555556
40177, 0.8695652173913, 0.35869565217391, 0.11111111111111
40178, 0.8695652173913, 0.35869565217391, 0.16666666666667
40179, 0.8695652173913, 0.35869565217391, 0.22222222222222
40180, 0.8695652173913, 0.35869565217391, 0.27777777777778
40181, 0.8695652173913, 0.35869565217391, 0.33333333333333
40182, 0.8695652173913, 0.35869565217391, 0.38888888888889
40183, 0.8695652173913, 0.35869565217391, 0.44444444444444
40184, 0.82608695652174, 0.35869565217391, 0.055555555555556
40185, 0.82608695652174, 0.35869565217391, 0.11111111111111
40186, 0.82608695652174, 0.35869565217391, 0.16666666666667
40187, 0.82608695652174, 0.35869565217391, 0.22222222222222
40188, 0.82608695652174, 0.35869565217391, 0.27777777777778
40189, 0.82608695652174, 0.35869565217391, 0.33333333333333
40190, 0.82608695652174, 0.35869565217391, 0.38888888888889
40191, 0.82608695652174, 0.35869565217391, 0.44444444444444
40192, 0.78260869565217, 0.35869565217391, 0.055555555555556
40193, 0.78260869565217, 0.35869565217391, 0.11111111111111
40194, 0.78260869565217, 0.35869565217391, 0.16666666666667
40195, 0.78260869565217, 0.35869565217391, 0.22222222222222
40196, 0.78260869565217, 0.35869565217391, 0.27777777777778
40197, 0.78260869565217, 0.35869565217391, 0.33333333333333
40198, 0.78260869565217, 0.35869565217391, 0.38888888888889
40199, 0.78260869565217, 0.35869565217391, 0.44444444444444
40200, 0.73913043478261, 0.35869565217391, 0.055555555555556
40201, 0.73913043478261, 0.35869565217391, 0.11111111111111
40202, 0.73913043478261, 0.35869565217391, 0.16666666666667
40203, 0.73913043478261, 0.35869565217391, 0.22222222222222
40204, 0.73913043478261, 0.35869565217391, 0.27777777777778
40205, 0.73913043478261, 0.35869565217391, 0.33333333333333
40206, 0.73913043478261, 0.35869565217391, 0.38888888888889
40207, 0.73913043478261, 0.35869565217391, 0.44444444444444
40208, 0.69565217391304, 0.35869565217391, 0.055555555555556
40209, 0.69565217391304, 0.35869565217391, 0.11111111111111
40210, 0.69565217391304, 0.35869565217391, 0.16666666666667
40211, 0.69565217391304, 0.35869565217391, 0.22222222222222
40212, 0.69565217391304, 0.35869565217391, 0.27777777777778
40213, 0.69565217391304, 0.35869565217391, 0.33333333333333
40214, 0.69565217391304, 0.35869565217391, 0.38888888888889
40215, 0.69565217391304, 0.35869565217391, 0.44444444444444
40216, 0.65217391304348, 0.35869565217391, 0.055555555555556
40217, 0.65217391304348, 0.35869565217391, 0.11111111111111
40218, 0.65217391304348, 0.35869565217391, 0.16666666666667
40219, 0.65217391304348, 0.35869565217391, 0.22222222222222
40220, 0.65217391304348, 0.35869565217391, 0.27777777777778
40221, 0.65217391304348, 0.35869565217391, 0.33333333333333
40222, 0.65217391304348, 0.35869565217391, 0.38888888888889
40223, 0.65217391304348, 0.35869565217391, 0.44444444444444
40224, 0.60869565217391, 0.35869565217391, 0.055555555555556
40225, 0.60869565217391, 0.35869565217391, 0.11111111111111
40226, 0.60869565217391, 0.35869565217391, 0.16666666666667
40227, 0.60869565217391, 0.35869565217391, 0.22222222222222
40228, 0.60869565217391, 0.35869565217391, 0.27777777777778
40229, 0.60869565217391, 0.35869565217391, 0.33333333333333
40230, 0.60869565217391, 0.35869565217391, 0.38888888888889
40231, 0.60869565217391, 0.35869565217391, 0.44444444444444
40232, 0.56521739130435, 0.35869565217391, 0.055555555555556
40233, 0.56521739130435, 0.35869565217391, 0.11111111111111
40234, 0.56521739130435, 0.35869565217391, 0.16666666666667
40235, 0.56521739130435, 0.35869565217391, 0.22222222222222
40236, 0.56521739130435, 0.35869565217391, 0.27777777777778
40237, 0.56521739130435, 0.35869565217391, 0.33333333333333
40238, 0.56521739130435, 0.35869565217391, 0.38888888888889
40239, 0.56521739130435, 0.35869565217391, 0.44444444444444
40240, 0.52173913043478, 0.35869565217391, 0.055555555555556
40241, 0.52173913043478, 0.35869565217391, 0.11111111111111
40242, 0.52173913043478, 0.35869565217391, 0.16666666666667
40243, 0.52173913043478, 0.35869565217391, 0.22222222222222
40244, 0.52173913043478, 0.35869565217391, 0.27777777777778
40245, 0.52173913043478, 0.35869565217391, 0.33333333333333
40246, 0.52173913043478, 0.35869565217391, 0.38888888888889
40247, 0.52173913043478, 0.35869565217391, 0.44444444444444
40248, 0.47826086956522, 0.35869565217391, 0.055555555555556
40249, 0.47826086956522, 0.35869565217391, 0.11111111111111
40250, 0.47826086956522, 0.35869565217391, 0.16666666666667
40251, 0.47826086956522, 0.35869565217391, 0.22222222222222
40252, 0.47826086956522, 0.35869565217391, 0.27777777777778
40253, 0.47826086956522, 0.35869565217391, 0.33333333333333
40254, 0.47826086956522, 0.35869565217391, 0.38888888888889
40255, 0.47826086956522, 0.35869565217391, 0.44444444444444
40256, 0.43478260869565, 0.35869565217391, 0.055555555555556
40257, 0.43478260869565, 0.35869565217391, 0.11111111111111
40258, 0.43478260869565, 0.35869565217391, 0.16666666666667
40259, 0.43478260869565, 0.35869565217391, 0.22222222222222
40260, 0.43478260869565, 0.35869565217391, 0.27777777777778
40261, 0.43478260869565, 0.35869565217391, 0.33333333333333
40262, 0.43478260869565, 0.35869565217391, 0.38888888888889
40263, 0.43478260869565, 0.35869565217391, 0.44444444444444
40264, 0.39130434782609, 0.35869565217391, 0.055555555555556
40265, 0.39130434782609, 0.35869565217391, 0.11111111111111
40266, 0.39130434782609, 0.35869565217391, 0.16666666666667
40267, 0.39130434782609, 0.35869565217391, 0.22222222222222
40268, 0.39130434782609, 0.35869565217391, 0.27777777777778
40269, 0.39130434782609, 0.35869565217391, 0.33333333333333
40270, 0.39130434782609, 0.35869565217391, 0.38888888888889
40271, 0.39130434782609, 0.35869565217391, 0.44444444444444
40272, 0.34782608695652, 0.35869565217391, 0.055555555555556
40273, 0.34782608695652, 0.35869565217391, 0.11111111111111
40274, 0.34782608695652, 0.35869565217391, 0.16666666666667
40275, 0.34782608695652, 0.35869565217391, 0.22222222222222
40276, 0.34782608695652, 0.35869565217391, 0.27777777777778
40277, 0.34782608695652, 0.35869565217391, 0.33333333333333
40278, 0.34782608695652, 0.35869565217391, 0.38888888888889
40279, 0.34782608695652, 0.35869565217391, 0.44444444444444
40280, 0.30434782608696, 0.35869565217391, 0.055555555555556
40281, 0.30434782608696, 0.35869565217391, 0.11111111111111
40282, 0.30434782608696, 0.35869565217391, 0.16666666666667
40283, 0.30434782608696, 0.35869565217391, 0.22222222222222
40284, 0.30434782608696, 0.35869565217391, 0.27777777777778
40285, 0.30434782608696, 0.35869565217391, 0.33333333333333
40286, 0.30434782608696, 0.35869565217391, 0.38888888888889
40287, 0.30434782608696, 0.35869565217391, 0.44444444444444
40288, 0.26086956521739, 0.35869565217391, 0.055555555555556
40289, 0.26086956521739, 0.35869565217391, 0.11111111111111
40290, 0.26086956521739, 0.35869565217391, 0.16666666666667
40291, 0.26086956521739, 0.35869565217391, 0.22222222222222
40292, 0.26086956521739, 0.35869565217391, 0.27777777777778
40293, 0.26086956521739, 0.35869565217391, 0.33333333333333
40294, 0.26086956521739, 0.35869565217391, 0.38888888888889
40295, 0.26086956521739, 0.35869565217391, 0.44444444444444
40296, 0.21739130434783, 0.35869565217391, 0.055555555555556
40297, 0.21739130434783, 0.35869565217391, 0.11111111111111
40298, 0.21739130434783, 0.35869565217391, 0.16666666666667
40299, 0.21739130434783, 0.35869565217391, 0.22222222222222
40300, 0.21739130434783, 0.35869565217391, 0.27777777777778
40301, 0.21739130434783, 0.35869565217391, 0.33333333333333
40302, 0.21739130434783, 0.35869565217391, 0.38888888888889
40303, 0.21739130434783, 0.35869565217391, 0.44444444444444
40304, 0.17391304347826, 0.35869565217391, 0.055555555555556
40305, 0.17391304347826, 0.35869565217391, 0.11111111111111
40306, 0.17391304347826, 0.35869565217391, 0.16666666666667
40307, 0.17391304347826, 0.35869565217391, 0.22222222222222
40308, 0.17391304347826, 0.35869565217391, 0.27777777777778
40309, 0.17391304347826, 0.35869565217391, 0.33333333333333
40310, 0.17391304347826, 0.35869565217391, 0.38888888888889
40311, 0.17391304347826, 0.35869565217391, 0.44444444444444
40312, 0.1304347826087, 0.35869565217391, 0.055555555555556
40313, 0.1304347826087, 0.35869565217391, 0.11111111111111
40314, 0.1304347826087, 0.35869565217391, 0.16666666666667
40315, 0.1304347826087, 0.35869565217391, 0.22222222222222
40316, 0.1304347826087, 0.35869565217391, 0.27777777777778
40317, 0.1304347826087, 0.35869565217391, 0.33333333333333
40318, 0.1304347826087, 0.35869565217391, 0.38888888888889
40319, 0.1304347826087, 0.35869565217391, 0.44444444444444
40320, 0.08695652173913, 0.35869565217391, 0.055555555555556
40321, 0.08695652173913, 0.35869565217391, 0.11111111111111
40322, 0.08695652173913, 0.35869565217391, 0.16666666666667
40323, 0.08695652173913, 0.35869565217391, 0.22222222222222
40324, 0.08695652173913, 0.35869565217391, 0.27777777777778
40325, 0.08695652173913, 0.35869565217391, 0.33333333333333
40326, 0.08695652173913, 0.35869565217391, 0.38888888888889
40327, 0.08695652173913, 0.35869565217391, 0.44444444444444
40328, 0.043478260869565, 0.35869565217391, 0.055555555555556
40329, 0.043478260869565, 0.35869565217391, 0.11111111111111
40330, 0.043478260869565, 0.35869565217391, 0.16666666666667
40331, 0.043478260869565, 0.35869565217391, 0.22222222222222
40332, 0.043478260869565, 0.35869565217391, 0.27777777777778
40333, 0.043478260869565, 0.35869565217391, 0.33333333333333
40334, 0.043478260869565, 0.35869565217391, 0.38888888888889
40335, 0.043478260869565, 0.35869565217391, 0.44444444444444
40336, 0.95652173913043, 0.41086956521739, 0.055555555555556
40337, 0.95652173913044, 0.41086956521739, 0.11111111111111
40338, 0.95652173913044, 0.41086956521739, 0.16666666666667
40339, 0.95652173913044, 0.41086956521739, 0.22222222222222
40340, 0.95652173913044, 0.41086956521739, 0.27777777777778
40341, 0.95652173913044, 0.41086956521739, 0.33333333333333
40342, 0.95652173913044, 0.41086956521739, 0.38888888888889
40343, 0.95652173913043, 0.41086956521739, 0.44444444444444
40344, 0.91304347826087, 0.41086956521739, 0.055555555555556
40345, 0.91304347826087, 0.41086956521739, 0.11111111111111
40346, 0.91304347826087, 0.41086956521739, 0.16666666666667
40347, 0.91304347826087, 0.41086956521739, 0.22222222222222
40348, 0.91304347826087, 0.41086956521739, 0.27777777777778
40349, 0.91304347826087, 0.41086956521739, 0.33333333333333
40350, 0.91304347826087, 0.41086956521739, 0.38888888888889
40351, 0.91304347826087, 0.41086956521739, 0.44444444444444
40352, 0.8695652173913, 0.41086956521739, 0.055555555555556
40353, 0.8695652173913, 0.41086956521739, 0.11111111111111
40354, 0.8695652173913, 0.41086956521739, 0.16666666666667
40355, 0.8695652173913, 0.41086956521739, 0.22222222222222
40356, 0.8695652173913, 0.41086956521739, 0.27777777777778
40357, 0.8695652173913, 0.41086956521739, 0.33333333333333
40358, 0.8695652173913, 0.41086956521739, 0.38888888888889
40359, 0.8695652173913, 0.41086956521739, 0.44444444444444
40360, 0.82608695652174, 0.41086956521739, 0.055555555555556
40361, 0.82608695652174, 0.41086956521739, 0.11111111111111
40362, 0.82608695652174, 0.41086956521739, 0.16666666666667
40363, 0.82608695652174, 0.41086956521739, 0.22222222222222
40364, 0.82608695652174, 0.41086956521739, 0.27777777777778
40365, 0.82608695652174, 0.41086956521739, 0.33333333333333
40366, 0.82608695652174, 0.41086956521739, 0.38888888888889
40367, 0.82608695652174, 0.41086956521739, 0.44444444444444
40368, 0.78260869565217, 0.41086956521739, 0.055555555555556
40369, 0.78260869565217, 0.41086956521739, 0.11111111111111
40370, 0.78260869565217, 0.41086956521739, 0.16666666666667
40371, 0.78260869565217, 0.41086956521739, 0.22222222222222
40372, 0.78260869565217, 0.41086956521739, 0.27777777777778
40373, 0.78260869565217, 0.41086956521739, 0.33333333333333
40374, 0.78260869565217, 0.41086956521739, 0.38888888888889
40375, 0.78260869565217, 0.41086956521739, 0.44444444444444
40376, 0.73913043478261, 0.41086956521739, 0.055555555555556
40377, 0.73913043478261, 0.41086956521739, 0.11111111111111
40378, 0.73913043478261, 0.41086956521739, 0.16666666666667
40379, 0.73913043478261, 0.41086956521739, 0.22222222222222
40380, 0.73913043478261, 0.41086956521739, 0.27777777777778
40381, 0.73913043478261, 0.41086956521739, 0.33333333333333
40382, 0.73913043478261, 0.41086956521739, 0.38888888888889
40383, 0.73913043478261, 0.41086956521739, 0.44444444444444
40384, 0.69565217391304, 0.41086956521739, 0.055555555555556
40385, 0.69565217391304, 0.41086956521739, 0.11111111111111
40386, 0.69565217391304, 0.41086956521739, 0.16666666666667
40387, 0.69565217391304, 0.41086956521739, 0.22222222222222
40388, 0.69565217391304, 0.41086956521739, 0.27777777777778
40389, 0.69565217391304, 0.41086956521739, 0.33333333333333
40390, 0.69565217391304, 0.41086956521739, 0.38888888888889
40391, 0.69565217391304, 0.41086956521739, 0.44444444444444
40392, 0.65217391304348, 0.41086956521739, 0.055555555555556
40393, 0.65217391304348, 0.41086956521739, 0.11111111111111
40394, 0.65217391304348, 0.41086956521739, 0.16666666666667
40395, 0.65217391304348, 0.41086956521739, 0.22222222222222
40396, 0.65217391304348, 0.41086956521739, 0.27777777777778
40397, 0.65217391304348, 0.41086956521739, 0.33333333333333
40398, 0.65217391304348, 0.41086956521739, 0.38888888888889
40399, 0.65217391304348, 0.41086956521739, 0.44444444444444
40400, 0.60869565217391, 0.41086956521739, 0.055555555555556
40401, 0.60869565217391, 0.41086956521739, 0.11111111111111
40402, 0.60869565217391, 0.41086956521739, 0.16666666666667
40403, 0.60869565217391, 0.41086956521739, 0.22222222222222
40404, 0.60869565217391, 0.41086956521739, 0.27777777777778
40405, 0.60869565217391, 0.41086956521739, 0.33333333333333
40406, 0.60869565217391, 0.41086956521739, 0.38888888888889
40407, 0.60869565217391, 0.41086956521739, 0.44444444444444
40408, 0.56521739130435, 0.41086956521739, 0.055555555555556
40409, 0.56521739130435, 0.41086956521739, 0.11111111111111
40410, 0.56521739130435, 0.41086956521739, 0.16666666666667
40411, 0.56521739130435, 0.41086956521739, 0.22222222222222
40412, 0.56521739130435, 0.41086956521739, 0.27777777777778
40413, 0.56521739130435, 0.41086956521739, 0.33333333333333
40414, 0.56521739130435, 0.41086956521739, 0.38888888888889
40415, 0.56521739130435, 0.41086956521739, 0.44444444444444
40416, 0.52173913043478, 0.41086956521739, 0.055555555555556
40417, 0.52173913043478, 0.41086956521739, 0.11111111111111
40418, 0.52173913043478, 0.41086956521739, 0.16666666666667
40419, 0.52173913043478, 0.41086956521739, 0.22222222222222
40420, 0.52173913043478, 0.41086956521739, 0.27777777777778
40421, 0.52173913043478, 0.41086956521739, 0.33333333333333
40422, 0.52173913043478, 0.41086956521739, 0.38888888888889
40423, 0.52173913043478, 0.41086956521739, 0.44444444444444
40424, 0.47826086956522, 0.41086956521739, 0.055555555555556
40425, 0.47826086956522, 0.41086956521739, 0.11111111111111
40426, 0.47826086956522, 0.41086956521739, 0.16666666666667
40427, 0.47826086956522, 0.41086956521739, 0.22222222222222
40428, 0.47826086956522, 0.41086956521739, 0.27777777777778
40429, 0.47826086956522, 0.41086956521739, 0.33333333333333
40430, 0.47826086956522, 0.41086956521739, 0.38888888888889
40431, 0.47826086956522, 0.41086956521739, 0.44444444444444
40432, 0.43478260869565, 0.41086956521739, 0.055555555555556
40433, 0.43478260869565, 0.41086956521739, 0.11111111111111
40434, 0.43478260869565, 0.41086956521739, 0.16666666666667
40435, 0.43478260869565, 0.41086956521739, 0.22222222222222
40436, 0.43478260869565, 0.41086956521739, 0.27777777777778
40437, 0.43478260869565, 0.41086956521739, 0.33333333333333
40438, 0.43478260869565, 0.41086956521739, 0.38888888888889
40439, 0.43478260869565, 0.41086956521739, 0.44444444444444
40440, 0.39130434782609, 0.41086956521739, 0.055555555555556
40441, 0.39130434782609, 0.41086956521739, 0.11111111111111
40442, 0.39130434782609, 0.41086956521739, 0.16666666666667
40443, 0.39130434782609, 0.41086956521739, 0.22222222222222
40444, 0.39130434782609, 0.41086956521739, 0.27777777777778
40445, 0.39130434782609, 0.41086956521739, 0.33333333333333
40446, 0.39130434782609, 0.41086956521739, 0.38888888888889
40447, 0.39130434782609, 0.41086956521739, 0.44444444444444
40448, 0.34782608695652, 0.41086956521739, 0.055555555555556
40449, 0.34782608695652, 0.41086956521739, 0.11111111111111
40450, 0.34782608695652, 0.41086956521739, 0.16666666666667
40451, 0.34782608695652, 0.41086956521739, 0.22222222222222
40452, 0.34782608695652, 0.41086956521739, 0.27777777777778
40453, 0.34782608695652, 0.41086956521739, 0.33333333333333
40454, 0.34782608695652, 0.41086956521739, 0.38888888888889
40455, 0.34782608695652, 0.41086956521739, 0.44444444444444
40456, 0.30434782608696, 0.41086956521739, 0.055555555555556
40457, 0.30434782608696, 0.41086956521739, 0.11111111111111
40458, 0.30434782608696, 0.41086956521739, 0.16666666666667
40459, 0.30434782608696, 0.41086956521739, 0.22222222222222
40460, 0.30434782608696, 0.41086956521739, 0.27777777777778
40461, 0.30434782608696, 0.41086956521739, 0.33333333333333
40462, 0.30434782608696, 0.41086956521739, 0.38888888888889
40463, 0.30434782608696, 0.41086956521739, 0.44444444444444
40464, 0.26086956521739, 0.41086956521739, 0.055555555555556
40465, 0.26086956521739, 0.41086956521739, 0.11111111111111
40466, 0.26086956521739, 0.41086956521739, 0.16666666666667
40467, 0.26086956521739, 0.41086956521739, 0.22222222222222
40468, 0.26086956521739, 0.41086956521739, 0.27777777777778
40469, 0.26086956521739, 0.41086956521739, 0.33333333333333
40470, 0.26086956521739, 0.41086956521739, 0.38888888888889
40471, 0.26086956521739, 0.41086956521739, 0.44444444444444
40472, 0.21739130434783, 0.41086956521739, 0.055555555555556
40473, 0.21739130434783, 0.41086956521739, 0.11111111111111
40474, 0.21739130434783, 0.41086956521739, 0.16666666666667
40475, 0.21739130434783, 0.41086956521739, 0.22222222222222
40476, 0.21739130434783, 0.41086956521739, 0.27777777777778
40477, 0.21739130434783, 0.41086956521739, 0.33333333333333
40478, 0.21739130434783, 0.41086956521739, 0.38888888888889
40479, 0.21739130434783, 0.41086956521739, 0.44444444444444
40480, 0.17391304347826, 0.41086956521739, 0.055555555555556
40481, 0.17391304347826, 0.41086956521739, 0.11111111111111
40482, 0.17391304347826, 0.41086956521739, 0.16666666666667
40483, 0.17391304347826, 0.41086956521739, 0.22222222222222
40484, 0.17391304347826, 0.41086956521739, 0.27777777777778
40485, 0.17391304347826, 0.41086956521739, 0.33333333333333
40486, 0.17391304347826, 0.41086956521739, 0.38888888888889
40487, 0.17391304347826, 0.41086956521739, 0.44444444444444
40488, 0.1304347826087, 0.41086956521739, 0.055555555555556
40489, 0.1304347826087, 0.41086956521739, 0.11111111111111
40490, 0.1304347826087, 0.41086956521739, 0.16666666666667
40491, 0.1304347826087, 0.41086956521739, 0.22222222222222
40492, 0.1304347826087, 0.41086956521739, 0.27777777777778
40493, 0.1304347826087, 0.41086956521739, 0.33333333333333
40494, 0.1304347826087, 0.41086956521739, 0.38888888888889
40495, 0.1304347826087, 0.41086956521739, 0.44444444444444
40496, 0.08695652173913, 0.41086956521739, 0.055555555555556
40497, 0.08695652173913, 0.41086956521739, 0.11111111111111
40498, 0.08695652173913, 0.41086956521739, 0.16666666666667
40499, 0.08695652173913, 0.41086956521739, 0.22222222222222
40500, 0.08695652173913, 0.41086956521739, 0.27777777777778
40501, 0.08695652173913, 0.41086956521739, 0.33333333333333
40502, 0.08695652173913, 0.41086956521739, 0.38888888888889
40503, 0.08695652173913, 0.41086956521739, 0.44444444444444
40504, 0.043478260869565, 0.41086956521739, 0.055555555555556
40505, 0.043478260869565, 0.41086956521739, 0.11111111111111
40506, 0.043478260869565, 0.41086956521739, 0.16666666666667
40507, 0.043478260869565, 0.41086956521739, 0.22222222222222
40508, 0.043478260869565, 0.41086956521739, 0.27777777777778
40509, 0.043478260869565, 0.41086956521739, 0.33333333333333
40510, 0.043478260869565, 0.41086956521739, 0.38888888888889
40511, 0.043478260869565, 0.41086956521739, 0.44444444444444
40512, 0.95652173913043, 0.46304347826087, 0.055555555555556
40513, 0.95652173913044, 0.46304347826087, 0.11111111111111
40514, 0.95652173913043, 0.46304347826087, 0.16666666666667
40515, 0.95652173913044, 0.46304347826087, 0.22222222222222
40516, 0.95652173913044, 0.46304347826087, 0.27777777777778
40517, 0.95652173913044, 0.46304347826087, 0.33333333333333
40518, 0.95652173913044, 0.46304347826087, 0.38888888888889
40519, 0.95652173913044, 0.46304347826087, 0.44444444444444
40520, 0.91304347826087, 0.46304347826087, 0.055555555555556
40521, 0.91304347826087, 0.46304347826087, 0.11111111111111
40522, 0.91304347826087, 0.46304347826087, 0.16666666666667
40523, 0.91304347826087, 0.46304347826087, 0.22222222222222
40524, 0.91304347826087, 0.46304347826087, 0.27777777777778
40525, 0.91304347826087, 0.46304347826087, 0.33333333333333
40526, 0.91304347826087, 0.46304347826087, 0.38888888888889
40527, 0.91304347826087, 0.46304347826087, 0.44444444444444
40528, 0.8695652173913, 0.46304347826087, 0.055555555555556
40529, 0.8695652173913, 0.46304347826087, 0.11111111111111
40530, 0.8695652173913, 0.46304347826087, 0.16666666666667
40531, 0.8695652173913, 0.46304347826087, 0.22222222222222
40532, 0.8695652173913, 0.46304347826087, 0.27777777777778
40533, 0.8695652173913, 0.46304347826087, 0.33333333333333
40534, 0.8695652173913, 0.46304347826087, 0.38888888888889
40535, 0.8695652173913, 0.46304347826087, 0.44444444444444
40536, 0.82608695652174, 0.46304347826087, 0.055555555555556
40537, 0.82608695652174, 0.46304347826087, 0.11111111111111
40538, 0.82608695652174, 0.46304347826087, 0.16666666666667
40539, 0.82608695652174, 0.46304347826087, 0.22222222222222
40540, 0.82608695652174, 0.46304347826087, 0.27777777777778
40541, 0.82608695652174, 0.46304347826087, 0.33333333333333
40542, 0.82608695652174, 0.46304347826087, 0.38888888888889
40543, 0.82608695652174, 0.46304347826087, 0.44444444444444
40544, 0.78260869565217, 0.46304347826087, 0.055555555555556
40545, 0.78260869565217, 0.46304347826087, 0.11111111111111
40546, 0.78260869565217, 0.46304347826087, 0.16666666666667
40547, 0.78260869565217, 0.46304347826087, 0.22222222222222
40548, 0.78260869565217, 0.46304347826087, 0.27777777777778
40549, 0.78260869565217, 0.46304347826087, 0.33333333333333
40550, 0.78260869565217, 0.46304347826087, 0.38888888888889
40551, 0.78260869565217, 0.46304347826087, 0.44444444444444
40552, 0.73913043478261, 0.46304347826087, 0.055555555555556
40553, 0.73913043478261, 0.46304347826087, 0.11111111111111
40554, 0.73913043478261, 0.46304347826087, 0.16666666666667
40555, 0.73913043478261, 0.46304347826087, 0.22222222222222
40556, 0.73913043478261, 0.46304347826087, 0.27777777777778
40557, 0.73913043478261, 0.46304347826087, 0.33333333333333
40558, 0.73913043478261, 0.46304347826087, 0.38888888888889
40559, 0.73913043478261, 0.46304347826087, 0.44444444444444
40560, 0.69565217391304, 0.46304347826087, 0.055555555555556
40561, 0.69565217391304, 0.46304347826087, 0.11111111111111
40562, 0.69565217391304, 0.46304347826087, 0.16666666666667
40563, 0.69565217391304, 0.46304347826087, 0.22222222222222
40564, 0.69565217391304, 0.46304347826087, 0.27777777777778
40565, 0.69565217391304, 0.46304347826087, 0.33333333333333
40566, 0.69565217391304, 0.46304347826087, 0.38888888888889
40567, 0.69565217391304, 0.46304347826087, 0.44444444444444
40568, 0.65217391304348, 0.46304347826087, 0.055555555555556
40569, 0.65217391304348, 0.46304347826087, 0.11111111111111
40570, 0.65217391304348, 0.46304347826087, 0.16666666666667
40571, 0.65217391304348, 0.46304347826087, 0.22222222222222
40572, 0.65217391304348, 0.46304347826087, 0.27777777777778
40573, 0.65217391304348, 0.46304347826087, 0.33333333333333
40574, 0.65217391304348, 0.46304347826087, 0.38888888888889
40575, 0.65217391304348, 0.46304347826087, 0.44444444444444
40576, 0.60869565217391, 0.46304347826087, 0.055555555555556
40577, 0.60869565217391, 0.46304347826087, 0.11111111111111
40578, 0.60869565217391, 0.46304347826087, 0.16666666666667
40579, 0.60869565217391, 0.46304347826087, 0.22222222222222
40580, 0.60869565217391, 0.46304347826087, 0.27777777777778
40581, 0.60869565217391, 0.46304347826087, 0.33333333333333
40582, 0.60869565217391, 0.46304347826087, 0.38888888888889
40583, 0.60869565217391, 0.46304347826087, 0.44444444444444
40584, 0.56521739130435, 0.46304347826087, 0.055555555555556
40585, 0.56521739130435, 0.46304347826087, 0.11111111111111
40586, 0.56521739130435, 0.46304347826087, 0.16666666666667
40587, 0.56521739130435, 0.46304347826087, 0.22222222222222
40588, 0.56521739130435, 0.46304347826087, 0.27777777777778
40589, 0.56521739130435, 0.46304347826087, 0.33333333333333
40590, 0.56521739130435, 0.46304347826087, 0.38888888888889
40591, 0.56521739130435, 0.46304347826087, 0.44444444444444
40592, 0.52173913043478, 0.46304347826087, 0.055555555555556
40593, 0.52173913043478, 0.46304347826087, 0.11111111111111
40594, 0.52173913043478, 0.46304347826087, 0.16666666666667
40595, 0.52173913043478, 0.46304347826087, 0.22222222222222
40596, 0.52173913043478, 0.46304347826087, 0.27777777777778
40597, 0.52173913043478, 0.46304347826087, 0.33333333333333
40598, 0.52173913043478, 0.46304347826087, 0.38888888888889
40599, 0.52173913043478, 0.46304347826087, 0.44444444444444
40600, 0.47826086956522, 0.46304347826087, 0.055555555555556
40601, 0.47826086956522, 0.46304347826087, 0.11111111111111
40602, 0.47826086956522, 0.46304347826087, 0.16666666666667
40603, 0.47826086956522, 0.46304347826087, 0.22222222222222
40604, 0.47826086956522, 0.46304347826087, 0.27777777777778
40605, 0.47826086956522, 0.46304347826087, 0.33333333333333
40606, 0.47826086956522, 0.46304347826087, 0.38888888888889
40607, 0.47826086956522, 0.46304347826087, 0.44444444444444
40608, 0.43478260869565, 0.46304347826087, 0.055555555555556
40609, 0.43478260869565, 0.46304347826087, 0.11111111111111
40610, 0.43478260869565, 0.46304347826087, 0.16666666666667
40611, 0.43478260869565, 0.46304347826087, 0.22222222222222
40612, 0.43478260869565, 0.46304347826087, 0.27777777777778
40613, 0.43478260869565, 0.46304347826087, 0.33333333333333
40614, 0.43478260869565, 0.46304347826087, 0.38888888888889
40615, 0.43478260869565, 0.46304347826087, 0.44444444444444
40616, 0.39130434782609, 0.46304347826087, 0.055555555555556
40617, 0.39130434782609, 0.46304347826087, 0.11111111111111
40618, 0.39130434782609, 0.46304347826087, 0.16666666666667
40619, 0.39130434782609, 0.46304347826087, 0.22222222222222
40620, 0.39130434782609, 0.46304347826087, 0.27777777777778
40621, 0.39130434782609, 0.46304347826087, 0.33333333333333
40622, 0.39130434782609, 0.46304347826087, 0.38888888888889
40623, 0.39130434782609, 0.46304347826087, 0.44444444444444
40624, 0.34782608695652, 0.46304347826087, 0.055555555555556
40625, 0.34782608695652, 0.46304347826087, 0.11111111111111
40626, 0.34782608695652, 0.46304347826087, 0.16666666666667
40627, 0.34782608695652, 0.46304347826087, 0.22222222222222
40628, 0.34782608695652, 0.46304347826087, 0.27777777777778
40629, 0.34782608695652, 0.46304347826087, 0.33333333333333
40630, 0.34782608695652, 0.46304347826087, 0.38888888888889
40631, 0.34782608695652, 0.46304347826087, 0.44444444444444
40632, 0.30434782608696, 0.46304347826087, 0.055555555555556
40633, 0.30434782608696, 0.46304347826087, 0.11111111111111
40634, 0.30434782608696, 0.46304347826087, 0.16666666666667
40635, 0.30434782608696, 0.46304347826087, 0.22222222222222
40636, 0.30434782608696, 0.46304347826087, 0.27777777777778
40637, 0.30434782608696, 0.46304347826087, 0.33333333333333
40638, 0.30434782608696, 0.46304347826087, 0.38888888888889
40639, 0.30434782608696, 0.46304347826087, 0.44444444444444
40640, 0.26086956521739, 0.46304347826087, 0.055555555555556
40641, 0.26086956521739, 0.46304347826087, 0.11111111111111
40642, 0.26086956521739, 0.46304347826087, 0.16666666666667
40643, 0.26086956521739, 0.46304347826087, 0.22222222222222
40644, 0.26086956521739, 0.46304347826087, 0.27777777777778
40645, 0.26086956521739, 0.46304347826087, 0.33333333333333
40646, 0.26086956521739, 0.46304347826087, 0.38888888888889
40647, 0.26086956521739, 0.46304347826087, 0.44444444444444
40648, 0.21739130434783, 0.46304347826087, 0.055555555555556
40649, 0.21739130434783, 0.46304347826087, 0.11111111111111
40650, 0.21739130434783, 0.46304347826087, 0.16666666666667
40651, 0.21739130434783, 0.46304347826087, 0.22222222222222
40652, 0.21739130434783, 0.46304347826087, 0.27777777777778
40653, 0.21739130434783, 0.46304347826087, 0.33333333333333
40654, 0.21739130434783, 0.46304347826087, 0.38888888888889
40655, 0.21739130434783, 0.46304347826087, 0.44444444444444
40656, 0.17391304347826, 0.46304347826087, 0.055555555555556
40657, 0.17391304347826, 0.46304347826087, 0.11111111111111
40658, 0.17391304347826, 0.46304347826087, 0.16666666666667
40659, 0.17391304347826, 0.46304347826087, 0.22222222222222
40660, 0.17391304347826, 0.46304347826087, 0.27777777777778
40661, 0.17391304347826, 0.46304347826087, 0.33333333333333
40662, 0.17391304347826, 0.46304347826087, 0.38888888888889
40663, 0.17391304347826, 0.46304347826087, 0.44444444444444
40664, 0.1304347826087, 0.46304347826087, 0.055555555555556
40665, 0.1304347826087, 0.46304347826087, 0.11111111111111
40666, 0.1304347826087, 0.46304347826087, 0.16666666666667
40667, 0.1304347826087, 0.46304347826087, 0.22222222222222
40668, 0.1304347826087, 0.46304347826087, 0.27777777777778
40669, 0.1304347826087, 0.46304347826087, 0.33333333333333
40670, 0.1304347826087, 0.46304347826087, 0.38888888888889
40671, 0.1304347826087, 0.46304347826087, 0.44444444444444
40672, 0.08695652173913, 0.46304347826087, 0.055555555555556
40673, 0.08695652173913, 0.46304347826087, 0.11111111111111
40674, 0.08695652173913, 0.46304347826087, 0.16666666666667
40675, 0.08695652173913, 0.46304347826087, 0.22222222222222
40676, 0.08695652173913, 0.46304347826087, 0.27777777777778
40677, 0.08695652173913, 0.46304347826087, 0.33333333333333
40678, 0.08695652173913, 0.46304347826087, 0.38888888888889
40679, 0.08695652173913, 0.46304347826087, 0.44444444444444
40680, 0.043478260869565, 0.46304347826087, 0.055555555555556
40681, 0.043478260869565, 0.46304347826087, 0.11111111111111
40682, 0.043478260869565, 0.46304347826087, 0.16666666666667
40683, 0.043478260869565, 0.46304347826087, 0.22222222222222
40684, 0.043478260869565, 0.46304347826087, 0.27777777777778
40685, 0.043478260869565, 0.46304347826087, 0.33333333333333
40686, 0.043478260869565, 0.46304347826087, 0.38888888888889
40687, 0.043478260869565, 0.46304347826087, 0.44444444444444
40688, 0.95652173913043, 0.51521739130435, 0.055555555555556
40689, 0.95652173913044, 0.51521739130435, 0.11111111111111
40690, 0.95652173913043, 0.51521739130435, 0.16666666666667
40691, 0.95652173913044, 0.51521739130435, 0.22222222222222
40692, 0.95652173913044, 0.51521739130435, 0.27777777777778
40693, 0.95652173913043, 0.51521739130435, 0.33333333333333
40694, 0.95652173913043, 0.51521739130435, 0.38888888888889
40695, 0.95652173913043, 0.51521739130435, 0.44444444444444
40696, 0.91304347826087, 0.51521739130435, 0.055555555555556
40697, 0.91304347826087, 0.51521739130435, 0.11111111111111
40698, 0.91304347826087, 0.51521739130435, 0.16666666666667
40699, 0.91304347826087, 0.51521739130435, 0.22222222222222
40700, 0.91304347826087, 0.51521739130435, 0.27777777777778
40701, 0.91304347826087, 0.51521739130435, 0.33333333333333
40702, 0.91304347826087, 0.51521739130435, 0.38888888888889
40703, 0.91304347826087, 0.51521739130435, 0.44444444444444
40704, 0.8695652173913, 0.51521739130435, 0.055555555555556
40705, 0.8695652173913, 0.51521739130435, 0.11111111111111
40706, 0.8695652173913, 0.51521739130435, 0.16666666666667
40707, 0.8695652173913, 0.51521739130435, 0.22222222222222
40708, 0.8695652173913, 0.51521739130435, 0.27777777777778
40709, 0.8695652173913, 0.51521739130435, 0.33333333333333
40710, 0.8695652173913, 0.51521739130435, 0.38888888888889
40711, 0.8695652173913, 0.51521739130435, 0.44444444444444
40712, 0.82608695652174, 0.51521739130435, 0.055555555555556
40713, 0.82608695652174, 0.51521739130435, 0.11111111111111
40714, 0.82608695652174, 0.51521739130435, 0.16666666666667
40715, 0.82608695652174, 0.51521739130435, 0.22222222222222
40716, 0.82608695652174, 0.51521739130435, 0.27777777777778
40717, 0.82608695652174, 0.51521739130435, 0.33333333333333
40718, 0.82608695652174, 0.51521739130435, 0.38888888888889
40719, 0.82608695652174, 0.51521739130435, 0.44444444444444
40720, 0.78260869565217, 0.51521739130435, 0.055555555555556
40721, 0.78260869565217, 0.51521739130435, 0.11111111111111
40722, 0.78260869565217, 0.51521739130435, 0.16666666666667
40723, 0.78260869565217, 0.51521739130435, 0.22222222222222
40724, 0.78260869565217, 0.51521739130435, 0.27777777777778
40725, 0.78260869565217, 0.51521739130435, 0.33333333333333
40726, 0.78260869565217, 0.51521739130435, 0.38888888888889
40727, 0.78260869565217, 0.51521739130435, 0.44444444444444
40728, 0.73913043478261, 0.51521739130435, 0.055555555555556
40729, 0.73913043478261, 0.51521739130435, 0.11111111111111
40730, 0.73913043478261, 0.51521739130435, 0.16666666666667
40731, 0.73913043478261, 0.51521739130435, 0.22222222222222
40732, 0.73913043478261, 0.51521739130435, 0.27777777777778
40733, 0.73913043478261, 0.51521739130435, 0.33333333333333
40734, 0.73913043478261, 0.51521739130435, 0.38888888888889
40735, 0.73913043478261, 0.51521739130435, 0.44444444444444
40736, 0.69565217391304, 0.51521739130435, 0.055555555555556
40737, 0.69565217391304, 0.51521739130435, 0.11111111111111
40738, 0.69565217391304, 0.51521739130435, 0.16666666666667
40739, 0.69565217391304, 0.51521739130435, 0.22222222222222
40740, 0.69565217391304, 0.51521739130435, 0.27777777777778
40741, 0.69565217391304, 0.51521739130435, 0.33333333333333
40742, 0.69565217391304, 0.51521739130435, 0.38888888888889
40743, 0.69565217391304, 0.51521739130435, 0.44444444444444
40744, 0.65217391304348, 0.51521739130435, 0.055555555555556
40745, 0.65217391304348, 0.51521739130435, 0.11111111111111
40746, 0.65217391304348, 0.51521739130435, 0.16666666666667
40747, 0.65217391304348, 0.51521739130435, 0.22222222222222
40748, 0.65217391304348, 0.51521739130435, 0.27777777777778
40749, 0.65217391304348, 0.51521739130435, 0.33333333333333
40750, 0.65217391304348, 0.51521739130435, 0.38888888888889
40751, 0.65217391304348, 0.51521739130435, 0.44444444444444
40752, 0.60869565217391, 0.51521739130435, 0.055555555555556
40753, 0.60869565217391, 0.51521739130435, 0.11111111111111
40754, 0.60869565217391, 0.51521739130435, 0.16666666666667
40755, 0.60869565217391, 0.51521739130435, 0.22222222222222
40756, 0.60869565217391, 0.51521739130435, 0.27777777777778
40757, 0.60869565217391, 0.51521739130435, 0.33333333333333
40758, 0.60869565217391, 0.51521739130435, 0.38888888888889
40759, 0.60869565217391, 0.51521739130435, 0.44444444444444
40760, 0.56521739130435, 0.51521739130435, 0.055555555555556
40761, 0.56521739130435, 0.51521739130435, 0.11111111111111
40762, 0.56521739130435, 0.51521739130435, 0.16666666666667
40763, 0.56521739130435, 0.51521739130435, 0.22222222222222
40764, 0.56521739130435, 0.51521739130435, 0.27777777777778
40765, 0.56521739130435, 0.51521739130435, 0.33333333333333
40766, 0.56521739130435, 0.51521739130435, 0.38888888888889
40767, 0.56521739130435, 0.51521739130435, 0.44444444444444
40768, 0.52173913043478, 0.51521739130435, 0.055555555555556
40769, 0.52173913043478, 0.51521739130435, 0.11111111111111
40770, 0.52173913043478, 0.51521739130435, 0.16666666666667
40771, 0.52173913043478, 0.51521739130435, 0.22222222222222
40772, 0.52173913043478, 0.51521739130435, 0.27777777777778
40773, 0.52173913043478, 0.51521739130435, 0.33333333333333
40774, 0.52173913043478, 0.51521739130435, 0.38888888888889
40775, 0.52173913043478, 0.51521739130435, 0.44444444444444
40776, 0.47826086956522, 0.51521739130435, 0.055555555555556
40777, 0.47826086956522, 0.51521739130435, 0.11111111111111
40778, 0.47826086956522, 0.51521739130435, 0.16666666666667
40779, 0.47826086956522, 0.51521739130435, 0.22222222222222
40780, 0.47826086956522, 0.51521739130435, 0.27777777777778
40781, 0.47826086956522, 0.51521739130435, 0.33333333333333
40782, 0.47826086956522, 0.51521739130435, 0.38888888888889
40783, 0.47826086956522, 0.51521739130435, 0.44444444444444
40784, 0.43478260869565, 0.51521739130435, 0.055555555555556
40785, 0.43478260869565, 0.51521739130435, 0.11111111111111
40786, 0.43478260869565, 0.51521739130435, 0.16666666666667
40787, 0.43478260869565, 0.51521739130435, 0.22222222222222
40788, 0.43478260869565, 0.51521739130435, 0.27777777777778
40789, 0.43478260869565, 0.51521739130435, 0.33333333333333
40790, 0.43478260869565, 0.51521739130435, 0.38888888888889
40791, 0.43478260869565, 0.51521739130435, 0.44444444444444
40792, 0.39130434782609, 0.51521739130435, 0.055555555555556
40793, 0.39130434782609, 0.51521739130435, 0.11111111111111
40794, 0.39130434782609, 0.51521739130435, 0.16666666666667
40795, 0.39130434782609, 0.51521739130435, 0.22222222222222
40796, 0.39130434782609, 0.51521739130435, 0.27777777777778
40797, 0.39130434782609, 0.51521739130435, 0.33333333333333
40798, 0.39130434782609, 0.51521739130435, 0.38888888888889
40799, 0.39130434782609, 0.51521739130435, 0.44444444444444
40800, 0.34782608695652, 0.51521739130435, 0.055555555555556
40801, 0.34782608695652, 0.51521739130435, 0.11111111111111
40802, 0.34782608695652, 0.51521739130435, 0.16666666666667
40803, 0.34782608695652, 0.51521739130435, 0.22222222222222
40804, 0.34782608695652, 0.51521739130435, 0.27777777777778
40805, 0.34782608695652, 0.51521739130435, 0.33333333333333
40806, 0.34782608695652, 0.51521739130435, 0.38888888888889
40807, 0.34782608695652, 0.51521739130435, 0.44444444444444
40808, 0.30434782608696, 0.51521739130435, 0.055555555555556
40809, 0.30434782608696, 0.51521739130435, 0.11111111111111
40810, 0.30434782608696, 0.51521739130435, 0.16666666666667
40811, 0.30434782608696, 0.51521739130435, 0.22222222222222
40812, 0.30434782608696, 0.51521739130435, 0.27777777777778
40813, 0.30434782608696, 0.51521739130435, 0.33333333333333
40814, 0.30434782608696, 0.51521739130435, 0.38888888888889
40815, 0.30434782608696, 0.51521739130435, 0.44444444444444
40816, 0.26086956521739, 0.51521739130435, 0.055555555555556
40817, 0.26086956521739, 0.51521739130435, 0.11111111111111
40818, 0.26086956521739, 0.51521739130435, 0.16666666666667
40819, 0.26086956521739, 0.51521739130435, 0.22222222222222
40820, 0.26086956521739, 0.51521739130435, 0.27777777777778
40821, 0.26086956521739, 0.51521739130435, 0.33333333333333
40822, 0.26086956521739, 0.51521739130435, 0.38888888888889
40823, 0.26086956521739, 0.51521739130435, 0.44444444444444
40824, 0.21739130434783, 0.51521739130435, 0.055555555555556
40825, 0.21739130434783, 0.51521739130435, 0.11111111111111
40826, 0.21739130434783, 0.51521739130435, 0.16666666666667
40827, 0.21739130434783, 0.51521739130435, 0.22222222222222
40828, 0.21739130434783, 0.51521739130435, 0.27777777777778
40829, 0.21739130434783, 0.51521739130435, 0.33333333333333
40830, 0.21739130434783, 0.51521739130435, 0.38888888888889
40831, 0.21739130434783, 0.51521739130435, 0.44444444444444
40832, 0.17391304347826, 0.51521739130435, 0.055555555555556
40833, 0.17391304347826, 0.51521739130435, 0.11111111111111
40834, 0.17391304347826, 0.51521739130435, 0.16666666666667
40835, 0.17391304347826, 0.51521739130435, 0.22222222222222
40836, 0.17391304347826, 0.51521739130435, 0.27777777777778
40837, 0.17391304347826, 0.51521739130435, 0.33333333333333
40838, 0.17391304347826, 0.51521739130435, 0.38888888888889
40839, 0.17391304347826, 0.51521739130435, 0.44444444444444
40840, 0.1304347826087, 0.51521739130435, 0.055555555555556
40841, 0.1304347826087, 0.51521739130435, 0.11111111111111
40842, 0.1304347826087, 0.51521739130435, 0.16666666666667
40843, 0.1304347826087, 0.51521739130435, 0.22222222222222
40844, 0.1304347826087, 0.51521739130435, 0.27777777777778
40845, 0.1304347826087, 0.51521739130435, 0.33333333333333
40846, 0.1304347826087, 0.51521739130435, 0.38888888888889
40847, 0.1304347826087, 0.51521739130435, 0.44444444444444
40848, 0.08695652173913, 0.51521739130435, 0.055555555555556
40849, 0.08695652173913, 0.51521739130435, 0.11111111111111
40850, 0.08695652173913, 0.51521739130435, 0.16666666666667
40851, 0.08695652173913, 0.51521739130435, 0.22222222222222
40852, 0.08695652173913, 0.51521739130435, 0.27777777777778
40853, 0.08695652173913, 0.51521739130435, 0.33333333333333
40854, 0.08695652173913, 0.51521739130435, 0.38888888888889
40855, 0.08695652173913, 0.51521739130435, 0.44444444444444
40856, 0.043478260869565, 0.51521739130435, 0.055555555555556
40857, 0.043478260869565, 0.51521739130435, 0.11111111111111
40858, 0.043478260869565, 0.51521739130435, 0.16666666666667
40859, 0.043478260869565, 0.51521739130435, 0.22222222222222
40860, 0.043478260869565, 0.51521739130435, 0.27777777777778
40861, 0.043478260869565, 0.51521739130435, 0.33333333333333
40862, 0.043478260869565, 0.51521739130435, 0.38888888888889
40863, 0.043478260869565, 0.51521739130435, 0.44444444444444
40864, 0.95652173913043, 0.56739130434783, 0.055555555555556
40865, 0.95652173913043, 0.56739130434783, 0.11111111111111
40866, 0.95652173913044, 0.56739130434783, 0.16666666666667
40867, 0.95652173913044, 0.56739130434783, 0.22222222222222
40868, 0.95652173913044, 0.56739130434783, 0.27777777777778
40869, 0.95652173913044, 0.56739130434783, 0.33333333333333
40870, 0.95652173913044, 0.56739130434783, 0.38888888888889
40871, 0.95652173913043, 0.56739130434783, 0.44444444444444
40872, 0.91304347826087, 0.56739130434783, 0.055555555555556
40873, 0.91304347826087, 0.56739130434783, 0.11111111111111
40874, 0.91304347826087, 0.56739130434783, 0.16666666666667
40875, 0.91304347826087, 0.56739130434783, 0.22222222222222
40876, 0.91304347826087, 0.56739130434783, 0.27777777777778
40877, 0.91304347826087, 0.56739130434783, 0.33333333333333
40878, 0.91304347826087, 0.56739130434783, 0.38888888888889
40879, 0.91304347826087, 0.56739130434783, 0.44444444444444
40880, 0.8695652173913, 0.56739130434783, 0.055555555555556
40881, 0.8695652173913, 0.56739130434783, 0.11111111111111
40882, 0.8695652173913, 0.56739130434783, 0.16666666666667
40883, 0.8695652173913, 0.56739130434783, 0.22222222222222
40884, 0.8695652173913, 0.56739130434783, 0.27777777777778
40885, 0.8695652173913, 0.56739130434783, 0.33333333333333
40886, 0.8695652173913, 0.56739130434783, 0.38888888888889
40887, 0.8695652173913, 0.56739130434783, 0.44444444444444
40888, 0.82608695652174, 0.56739130434783, 0.055555555555556
40889, 0.82608695652174, 0.56739130434783, 0.11111111111111
40890, 0.82608695652174, 0.56739130434783, 0.16666666666667
40891, 0.82608695652174, 0.56739130434783, 0.22222222222222
40892, 0.82608695652174, 0.56739130434783, 0.27777777777778
40893, 0.82608695652174, 0.56739130434783, 0.33333333333333
40894, 0.82608695652174, 0.56739130434783, 0.38888888888889
40895, 0.82608695652174, 0.56739130434783, 0.44444444444444
40896, 0.78260869565217, 0.56739130434783, 0.055555555555556
40897, 0.78260869565217, 0.56739130434783, 0.11111111111111
40898, 0.78260869565217, 0.56739130434783, 0.16666666666667
40899, 0.78260869565217, 0.56739130434783, 0.22222222222222
40900, 0.78260869565217, 0.56739130434783, 0.27777777777778
40901, 0.78260869565217, 0.56739130434783, 0.33333333333333
40902, 0.78260869565217, 0.56739130434783, 0.38888888888889
40903, 0.78260869565217, 0.56739130434783, 0.44444444444444
40904, 0.73913043478261, 0.56739130434783, 0.055555555555556
40905, 0.73913043478261, 0.56739130434783, 0.11111111111111
40906, 0.73913043478261, 0.56739130434783, 0.16666666666667
40907, 0.73913043478261, 0.56739130434783, 0.22222222222222
40908, 0.73913043478261, 0.56739130434783, 0.27777777777778
40909, 0.73913043478261, 0.56739130434783, 0.33333333333333
40910, 0.73913043478261, 0.56739130434783, 0.38888888888889
40911, 0.73913043478261, 0.56739130434783, 0.44444444444444
40912, 0.69565217391304, 0.56739130434783, 0.055555555555556
40913, 0.69565217391304, 0.56739130434783, 0.11111111111111
40914, 0.69565217391304, 0.56739130434783, 0.16666666666667
40915, 0.69565217391304, 0.56739130434783, 0.22222222222222
40916, 0.69565217391304, 0.56739130434783, 0.27777777777778
40917, 0.69565217391304, 0.56739130434783, 0.33333333333333
40918, 0.69565217391304, 0.56739130434783, 0.38888888888889
40919, 0.69565217391304, 0.56739130434783, 0.44444444444444
40920, 0.65217391304348, 0.56739130434783, 0.055555555555556
40921, 0.65217391304348, 0.56739130434783, 0.11111111111111
40922, 0.65217391304348, 0.56739130434783, 0.16666666666667
40923, 0.65217391304348, 0.56739130434783, 0.22222222222222
40924, 0.65217391304348, 0.56739130434783, 0.27777777777778
40925, 0.65217391304348, 0.56739130434783, 0.33333333333333
40926, 0.65217391304348, 0.56739130434783, 0.38888888888889
40927, 0.65217391304348, 0.56739130434783, 0.44444444444444
40928, 0.60869565217391, 0.56739130434783, 0.055555555555556
40929, 0.60869565217391, 0.56739130434783, 0.11111111111111
40930, 0.60869565217391, 0.56739130434783, 0.16666666666667
40931, 0.60869565217391, 0.56739130434783, 0.22222222222222
40932, 0.60869565217391, 0.56739130434783, 0.27777777777778
40933, 0.60869565217391, 0.56739130434783, 0.33333333333333
40934, 0.60869565217391, 0.56739130434783, 0.38888888888889
40935, 0.60869565217391, 0.56739130434783, 0.44444444444444
40936, 0.56521739130435, 0.56739130434783, 0.055555555555556
40937, 0.56521739130435, 0.56739130434783, 0.11111111111111
40938, 0.56521739130435, 0.56739130434783, 0.16666666666667
40939, 0.56521739130435, 0.56739130434783, 0.22222222222222
40940, 0.56521739130435, 0.56739130434783, 0.27777777777778
40941, 0.56521739130435, 0.56739130434783, 0.33333333333333
40942, 0.56521739130435, 0.56739130434783, 0.38888888888889
40943, 0.56521739130435, 0.56739130434783, 0.44444444444444
40944, 0.52173913043478, 0.56739130434783, 0.055555555555556
40945, 0.52173913043478, 0.56739130434783, 0.11111111111111
40946, 0.52173913043478, 0.56739130434783, 0.16666666666667
40947, 0.52173913043478, 0.56739130434783, 0.22222222222222
40948, 0.52173913043478, 0.56739130434783, 0.27777777777778
40949, 0.52173913043478, 0.56739130434783, 0.33333333333333
40950, 0.52173913043478, 0.56739130434783, 0.38888888888889
40951, 0.52173913043478, 0.56739130434783, 0.44444444444444
40952, 0.47826086956522, 0.56739130434783, 0.055555555555556
40953, 0.47826086956522, 0.56739130434783, 0.11111111111111
40954, 0.47826086956522, 0.56739130434783, 0.16666666666667
40955, 0.47826086956522, 0.56739130434783, 0.22222222222222
40956, 0.47826086956522, 0.56739130434783, 0.27777777777778
40957, 0.47826086956522, 0.56739130434783, 0.33333333333333
40958, 0.47826086956522, 0.56739130434783, 0.38888888888889
40959, 0.47826086956522, 0.56739130434783, 0.44444444444444
40960, 0.43478260869565, 0.56739130434783, 0.055555555555556
40961, 0.43478260869565, 0.56739130434783, 0.11111111111111
40962, 0.43478260869565, 0.56739130434783, 0.16666666666667
40963, 0.43478260869565, 0.56739130434783, 0.22222222222222
40964, 0.43478260869565, 0.56739130434783, 0.27777777777778
40965, 0.43478260869565, 0.56739130434783, 0.33333333333333
40966, 0.43478260869565, 0.56739130434783, 0.38888888888889
40967, 0.43478260869565, 0.56739130434783, 0.44444444444444
40968, 0.39130434782609, 0.56739130434783, 0.055555555555556
40969, 0.39130434782609, 0.56739130434783, 0.11111111111111
40970, 0.39130434782609, 0.56739130434783, 0.16666666666667
40971, 0.39130434782609, 0.56739130434783, 0.22222222222222
40972, 0.39130434782609, 0.56739130434783, 0.27777777777778
40973, 0.39130434782609, 0.56739130434783, 0.33333333333333
40974, 0.39130434782609, 0.56739130434783, 0.38888888888889
40975, 0.39130434782609, 0.56739130434783, 0.44444444444444
40976, 0.34782608695652, 0.56739130434783, 0.055555555555556
40977, 0.34782608695652, 0.56739130434783, 0.11111111111111
40978, 0.34782608695652, 0.56739130434783, 0.16666666666667
40979, 0.34782608695652, 0.56739130434783, 0.22222222222222
40980, 0.34782608695652, 0.56739130434783, 0.27777777777778
40981, 0.34782608695652, 0.56739130434783, 0.33333333333333
40982, 0.34782608695652, 0.56739130434783, 0.38888888888889
40983, 0.34782608695652, 0.56739130434783, 0.44444444444444
40984, 0.30434782608696, 0.56739130434783, 0.055555555555556
40985, 0.30434782608696, 0.56739130434783, 0.11111111111111
40986, 0.30434782608696, 0.56739130434783, 0.16666666666667
40987, 0.30434782608696, 0.56739130434783, 0.22222222222222
40988, 0.30434782608696, 0.56739130434783, 0.27777777777778
40989, 0.30434782608696, 0.56739130434783, 0.33333333333333
40990, 0.30434782608696, 0.56739130434783, 0.38888888888889
40991, 0.30434782608696, 0.56739130434783, 0.44444444444444
40992, 0.26086956521739, 0.56739130434783, 0.055555555555556
40993, 0.26086956521739, 0.56739130434783, 0.11111111111111
40994, 0.26086956521739, 0.56739130434783, 0.16666666666667
40995, 0.26086956521739, 0.56739130434783, 0.22222222222222
40996, 0.26086956521739, 0.56739130434783, 0.27777777777778
40997, 0.26086956521739, 0.56739130434783, 0.33333333333333
40998, 0.26086956521739, 0.56739130434783, 0.38888888888889
40999, 0.26086956521739, 0.56739130434783, 0.44444444444444
41000, 0.21739130434783, 0.56739130434783, 0.055555555555556
41001, 0.21739130434783, 0.56739130434783, 0.11111111111111
41002, 0.21739130434783, 0.56739130434783, 0.16666666666667
41003, 0.21739130434783, 0.56739130434783, 0.22222222222222
41004, 0.21739130434783, 0.56739130434783, 0.27777777777778
41005, 0.21739130434783, 0.56739130434783, 0.33333333333333
41006, 0.21739130434783, 0.56739130434783, 0.38888888888889
41007, 0.21739130434783, 0.56739130434783, 0.44444444444444
41008, 0.17391304347826, 0.56739130434783, 0.055555555555556
41009, 0.17391304347826, 0.56739130434783, 0.11111111111111
41010, 0.17391304347826, 0.56739130434783, 0.16666666666667
41011, 0.17391304347826, 0.56739130434783, 0.22222222222222
41012, 0.17391304347826, 0.56739130434783, 0.27777777777778
41013, 0.17391304347826, 0.56739130434783, 0.33333333333333
41014, 0.17391304347826, 0.56739130434783, 0.38888888888889
41015, 0.17391304347826, 0.56739130434783, 0.44444444444444
41016, 0.1304347826087, 0.56739130434783, 0.055555555555556
41017, 0.1304347826087, 0.56739130434783, 0.11111111111111
41018, 0.1304347826087, 0.56739130434783, 0.16666666666667
41019, 0.1304347826087, 0.56739130434783, 0.22222222222222
41020, 0.1304347826087, 0.56739130434783, 0.27777777777778
41021, 0.1304347826087, 0.56739130434783, 0.33333333333333
41022, 0.1304347826087, 0.56739130434783, 0.38888888888889
41023, 0.1304347826087, 0.56739130434783, 0.44444444444444
41024, 0.08695652173913, 0.56739130434783, 0.055555555555556
41025, 0.08695652173913, 0.56739130434783, 0.11111111111111
41026, 0.08695652173913, 0.56739130434783, 0.16666666666667
41027, 0.08695652173913, 0.56739130434783, 0.22222222222222
41028, 0.08695652173913, 0.56739130434783, 0.27777777777778
41029, 0.08695652173913, 0.56739130434783, 0.33333333333333
41030, 0.08695652173913, 0.56739130434783, 0.38888888888889
41031, 0.08695652173913, 0.56739130434783, 0.44444444444444
41032, 0.043478260869565, 0.56739130434783, 0.055555555555556
41033, 0.043478260869565, 0.56739130434783, 0.11111111111111
41034, 0.043478260869565, 0.56739130434783, 0.16666666666667
41035, 0.043478260869565, 0.56739130434783, 0.22222222222222
41036, 0.043478260869565, 0.56739130434783, 0.27777777777778
41037, 0.043478260869565, 0.56739130434783, 0.33333333333333
41038, 0.043478260869565, 0.56739130434783, 0.38888888888889
41039, 0.043478260869565, 0.56739130434783, 0.44444444444444
41040, 0.95652173913043, 0.6195652173913, 0.055555555555556
41041, 0.95652173913044, 0.6195652173913, 0.11111111111111
41042, 0.95652173913044, 0.6195652173913, 0.16666666666667
41043, 0.95652173913044, 0.6195652173913, 0.22222222222222
41044, 0.95652173913044, 0.6195652173913, 0.27777777777778
41045, 0.95652173913044, 0.6195652173913, 0.33333333333333
41046, 0.95652173913044, 0.6195652173913, 0.38888888888889
41047, 0.95652173913044, 0.6195652173913, 0.44444444444444
41048, 0.91304347826087, 0.6195652173913, 0.055555555555556
41049, 0.91304347826087, 0.6195652173913, 0.11111111111111
41050, 0.91304347826087, 0.6195652173913, 0.16666666666667
41051, 0.91304347826087, 0.6195652173913, 0.22222222222222
41052, 0.91304347826087, 0.6195652173913, 0.27777777777778
41053, 0.91304347826087, 0.6195652173913, 0.33333333333333
41054, 0.91304347826087, 0.6195652173913, 0.38888888888889
41055, 0.91304347826087, 0.6195652173913, 0.44444444444444
41056, 0.8695652173913, 0.6195652173913, 0.055555555555556
41057, 0.8695652173913, 0.6195652173913, 0.11111111111111
41058, 0.8695652173913, 0.6195652173913, 0.16666666666667
41059, 0.8695652173913, 0.6195652173913, 0.22222222222222
41060, 0.8695652173913, 0.6195652173913, 0.27777777777778
41061, 0.8695652173913, 0.6195652173913, 0.33333333333333
41062, 0.8695652173913, 0.6195652173913, 0.38888888888889
41063, 0.8695652173913, 0.6195652173913, 0.44444444444444
41064, 0.82608695652174, 0.6195652173913, 0.055555555555556
41065, 0.82608695652174, 0.6195652173913, 0.11111111111111
41066, 0.82608695652174, 0.6195652173913, 0.16666666666667
41067, 0.82608695652174, 0.6195652173913, 0.22222222222222
41068, 0.82608695652174, 0.6195652173913, 0.27777777777778
41069, 0.82608695652174, 0.6195652173913, 0.33333333333333
41070, 0.82608695652174, 0.6195652173913, 0.38888888888889
41071, 0.82608695652174, 0.6195652173913, 0.44444444444444
41072, 0.78260869565217, 0.6195652173913, 0.055555555555556
41073, 0.78260869565217, 0.6195652173913, 0.11111111111111
41074, 0.78260869565217, 0.6195652173913, 0.16666666666667
41075, 0.78260869565217, 0.6195652173913, 0.22222222222222
41076, 0.78260869565217, 0.6195652173913, 0.27777777777778
41077, 0.78260869565217, 0.6195652173913, 0.33333333333333
41078, 0.78260869565217, 0.6195652173913, 0.38888888888889
41079, 0.78260869565217, 0.6195652173913, 0.44444444444444
41080, 0.73913043478261, 0.6195652173913, 0.055555555555556
41081, 0.73913043478261, 0.6195652173913, 0.11111111111111
41082, 0.73913043478261, 0.6195652173913, 0.16666666666667
41083, 0.73913043478261, 0.6195652173913, 0.22222222222222
41084, 0.73913043478261, 0.6195652173913, 0.27777777777778
41085, 0.73913043478261, 0.6195652173913, 0.33333333333333
41086, 0.73913043478261, 0.6195652173913, 0.38888888888889
41087, 0.73913043478261, 0.6195652173913, 0.44444444444444
41088, 0.69565217391304, 0.6195652173913, 0.055555555555556
41089, 0.69565217391304, 0.6195652173913, 0.11111111111111
41090, 0.69565217391304, 0.6195652173913, 0.16666666666667
41091, 0.69565217391304, 0.6195652173913, 0.22222222222222
41092, 0.69565217391304, 0.6195652173913, 0.27777777777778
41093, 0.69565217391304, 0.6195652173913, 0.33333333333333
41094, 0.69565217391304, 0.6195652173913, 0.38888888888889
41095, 0.69565217391304, 0.6195652173913, 0.44444444444444
41096, 0.65217391304348, 0.6195652173913, 0.055555555555556
41097, 0.65217391304348, 0.6195652173913, 0.11111111111111
41098, 0.65217391304348, 0.6195652173913, 0.16666666666667
41099, 0.65217391304348, 0.6195652173913, 0.22222222222222
41100, 0.65217391304348, 0.6195652173913, 0.27777777777778
41101, 0.65217391304348, 0.6195652173913, 0.33333333333333
41102, 0.65217391304348, 0.6195652173913, 0.38888888888889
41103, 0.65217391304348, 0.6195652173913, 0.44444444444444
41104, 0.60869565217391, 0.6195652173913, 0.055555555555556
41105, 0.60869565217391, 0.6195652173913, 0.11111111111111
41106, 0.60869565217391, 0.6195652173913, 0.16666666666667
41107, 0.60869565217391, 0.6195652173913, 0.22222222222222
41108, 0.60869565217391, 0.6195652173913, 0.27777777777778
41109, 0.60869565217391, 0.6195652173913, 0.33333333333333
41110, 0.60869565217391, 0.6195652173913, 0.38888888888889
41111, 0.60869565217391, 0.6195652173913, 0.44444444444444
41112, 0.56521739130435, 0.6195652173913, 0.055555555555556
41113, 0.56521739130435, 0.6195652173913, 0.11111111111111
41114, 0.56521739130435, 0.6195652173913, 0.16666666666667
41115, 0.56521739130435, 0.6195652173913, 0.22222222222222
41116, 0.56521739130435, 0.6195652173913, 0.27777777777778
41117, 0.56521739130435, 0.6195652173913, 0.33333333333333
41118, 0.56521739130435, 0.6195652173913, 0.38888888888889
41119, 0.56521739130435, 0.6195652173913, 0.44444444444444
41120, 0.52173913043478, 0.6195652173913, 0.055555555555556
41121, 0.52173913043478, 0.6195652173913, 0.11111111111111
41122, 0.52173913043478, 0.6195652173913, 0.16666666666667
41123, 0.52173913043478, 0.6195652173913, 0.22222222222222
41124, 0.52173913043478, 0.6195652173913, 0.27777777777778
41125, 0.52173913043478, 0.6195652173913, 0.33333333333333
41126, 0.52173913043478, 0.6195652173913, 0.38888888888889
41127, 0.52173913043478, 0.6195652173913, 0.44444444444444
41128, 0.47826086956522, 0.6195652173913, 0.055555555555556
41129, 0.47826086956522, 0.6195652173913, 0.11111111111111
41130, 0.47826086956522, 0.6195652173913, 0.16666666666667
41131, 0.47826086956522, 0.6195652173913, 0.22222222222222
41132, 0.47826086956522, 0.6195652173913, 0.27777777777778
41133, 0.47826086956522, 0.6195652173913, 0.33333333333333
41134, 0.47826086956522, 0.6195652173913, 0.38888888888889
41135, 0.47826086956522, 0.6195652173913, 0.44444444444444
41136, 0.43478260869565, 0.6195652173913, 0.055555555555556
41137, 0.43478260869565, 0.6195652173913, 0.11111111111111
41138, 0.43478260869565, 0.6195652173913, 0.16666666666667
41139, 0.43478260869565, 0.6195652173913, 0.22222222222222
41140, 0.43478260869565, 0.6195652173913, 0.27777777777778
41141, 0.43478260869565, 0.6195652173913, 0.33333333333333
41142, 0.43478260869565, 0.6195652173913, 0.38888888888889
41143, 0.43478260869565, 0.6195652173913, 0.44444444444444
41144, 0.39130434782609, 0.6195652173913, 0.055555555555556
41145, 0.39130434782609, 0.6195652173913, 0.11111111111111
41146, 0.39130434782609, 0.6195652173913, 0.16666666666667
41147, 0.39130434782609, 0.6195652173913, 0.22222222222222
41148, 0.39130434782609, 0.6195652173913, 0.27777777777778
41149, 0.39130434782609, 0.6195652173913, 0.33333333333333
41150, 0.39130434782609, 0.6195652173913, 0.38888888888889
41151, 0.39130434782609, 0.6195652173913, 0.44444444444444
41152, 0.34782608695652, 0.6195652173913, 0.055555555555556
41153, 0.34782608695652, 0.6195652173913, 0.11111111111111
41154, 0.34782608695652, 0.6195652173913, 0.16666666666667
41155, 0.34782608695652, 0.6195652173913, 0.22222222222222
