63694, 1.8086956521739, 0.61956521739131, 0.44444444444444
63695, 1.8086956521739, 0.61956521739131, 0.38888888888889
63696, 1.8086956521739, 0.61956521739131, 0.33333333333333
63697, 1.8086956521739, 0.61956521739131, 0.27777777777778
63698, 1.8086956521739, 0.61956521739131, 0.22222222222222
63699, 1.8086956521739, 0.6195652173913, 0.16666666666667
63700, 1.8086956521739, 0.61956521739131, 0.11111111111111
63701, 1.8086956521739, 0.61956521739131, 0.055555555555556
63702, 1.8521739130435, 0.61956521739131, 0.44444444444444
63703, 1.8521739130435, 0.61956521739131, 0.38888888888889
63704, 1.8521739130435, 0.61956521739131, 0.33333333333333
63705, 1.8521739130435, 0.61956521739131, 0.27777777777778
63706, 1.8521739130435, 0.61956521739131, 0.22222222222222
63707, 1.8521739130435, 0.61956521739131, 0.16666666666667
63708, 1.8521739130435, 0.61956521739131, 0.11111111111111
63709, 1.8521739130435, 0.61956521739131, 0.055555555555556
63710, 1.895652173913, 0.61956521739131, 0.44444444444444
63711, 1.895652173913, 0.61956521739131, 0.38888888888889
63712, 1.895652173913, 0.61956521739131, 0.33333333333333
63713, 1.895652173913, 0.61956521739131, 0.27777777777778
63714, 1.895652173913, 0.61956521739131, 0.22222222222222
63715, 1.895652173913, 0.6195652173913, 0.16666666666667
63716, 1.895652173913, 0.61956521739131, 0.11111111111111
63717, 1.895652173913, 0.61956521739131, 0.055555555555556
63718, 1.9391304347826, 0.61956521739131, 0.44444444444444
63719, 1.9391304347826, 0.61956521739131, 0.38888888888889
63720, 1.9391304347826, 0.61956521739131, 0.33333333333333
63721, 1.9391304347826, 0.61956521739131, 0.27777777777778
63722, 1.9391304347826, 0.61956521739131, 0.22222222222222
63723, 1.9391304347826, 0.61956521739131, 0.16666666666667
63724, 1.9391304347826, 0.61956521739131, 0.11111111111111
63725, 1.9391304347826, 0.61956521739131, 0.055555555555556
63726, 1.9826086956522, 0.61956521739131, 0.44444444444444
63727, 1.9826086956522, 0.61956521739131, 0.38888888888889
63728, 1.9826086956522, 0.61956521739131, 0.33333333333333
63729, 1.9826086956522, 0.61956521739131, 0.27777777777778
63730, 1.9826086956522, 0.61956521739131, 0.22222222222222
63731, 1.9826086956522, 0.61956521739131, 0.16666666666667
63732, 1.9826086956522, 0.61956521739131, 0.11111111111111
63733, 1.9826086956522, 0.61956521739131, 0.055555555555556
63734, 2.0260869565217, 0.61956521739131, 0.44444444444444
63735, 2.0260869565217, 0.61956521739131, 0.38888888888889
63736, 2.0260869565217, 0.6195652173913, 0.33333333333333
63737, 2.0260869565217, 0.6195652173913, 0.27777777777778
63738, 2.0260869565217, 0.61956521739131, 0.22222222222222
63739, 2.0260869565217, 0.6195652173913, 0.16666666666667
63740, 2.0260869565217, 0.61956521739131, 0.11111111111111
63741, 2.0260869565217, 0.61956521739131, 0.055555555555556
63742, 2.0695652173913, 0.61956521739131, 0.44444444444444
63743, 2.0695652173913, 0.61956521739131, 0.38888888888889
63744, 2.0695652173913, 0.61956521739131, 0.33333333333333
63745, 2.0695652173913, 0.6195652173913, 0.27777777777778
63746, 2.0695652173913, 0.61956521739131, 0.22222222222222
63747, 2.0695652173913, 0.6195652173913, 0.16666666666667
63748, 2.0695652173913, 0.61956521739131, 0.11111111111111
63749, 2.0695652173913, 0.61956521739131, 0.055555555555556
63750, 2.1130434782609, 0.61956521739131, 0.44444444444444
63751, 2.1130434782609, 0.61956521739131, 0.38888888888889
63752, 2.1130434782609, 0.61956521739131, 0.33333333333333
63753, 2.1130434782609, 0.61956521739131, 0.27777777777778
63754, 2.1130434782609, 0.61956521739131, 0.22222222222222
63755, 2.1130434782609, 0.61956521739131, 0.16666666666667
63756, 2.1130434782609, 0.61956521739131, 0.11111111111111
63757, 2.1130434782609, 0.61956521739131, 0.055555555555556
63758, 2.1565217391304, 0.61956521739131, 0.44444444444444
63759, 2.1565217391304, 0.61956521739131, 0.38888888888889
63760, 2.1565217391304, 0.61956521739131, 0.33333333333333
63761, 2.1565217391304, 0.61956521739131, 0.27777777777778
63762, 2.1565217391304, 0.61956521739131, 0.22222222222222
63763, 2.1565217391304, 0.61956521739131, 0.16666666666667
63764, 2.1565217391304, 0.61956521739131, 0.11111111111111
63765, 2.1565217391304, 0.61956521739131, 0.055555555555556
63766, 1.2434782608696, 0.56739130434783, 0.44444444444444
63767, 1.2434782608696, 0.56739130434783, 0.38888888888889
63768, 1.2434782608696, 0.56739130434783, 0.33333333333333
63769, 1.2434782608696, 0.56739130434783, 0.27777777777778
63770, 1.2434782608696, 0.56739130434783, 0.22222222222222
63771, 1.2434782608696, 0.56739130434783, 0.16666666666667
63772, 1.2434782608696, 0.56739130434783, 0.11111111111111
63773, 1.2434782608696, 0.56739130434783, 0.055555555555556
63774, 1.2869565217391, 0.56739130434783, 0.44444444444444
63775, 1.2869565217391, 0.56739130434783, 0.38888888888889
63776, 1.2869565217391, 0.56739130434783, 0.33333333333333
63777, 1.2869565217391, 0.56739130434783, 0.27777777777778
63778, 1.2869565217391, 0.56739130434783, 0.22222222222222
63779, 1.2869565217391, 0.56739130434783, 0.16666666666667
63780, 1.2869565217391, 0.56739130434783, 0.11111111111111
63781, 1.2869565217391, 0.56739130434783, 0.055555555555556
63782, 1.3304347826087, 0.56739130434783, 0.44444444444444
63783, 1.3304347826087, 0.56739130434783, 0.38888888888889
63784, 1.3304347826087, 0.56739130434783, 0.33333333333333
63785, 1.3304347826087, 0.56739130434783, 0.27777777777778
63786, 1.3304347826087, 0.56739130434783, 0.22222222222222
63787, 1.3304347826087, 0.56739130434783, 0.16666666666667
63788, 1.3304347826087, 0.56739130434783, 0.11111111111111
63789, 1.3304347826087, 0.56739130434783, 0.055555555555556
63790, 1.3739130434783, 0.56739130434783, 0.44444444444444
63791, 1.3739130434783, 0.56739130434783, 0.38888888888889
63792, 1.3739130434783, 0.56739130434783, 0.33333333333333
63793, 1.3739130434783, 0.56739130434783, 0.27777777777778
63794, 1.3739130434783, 0.56739130434783, 0.22222222222222
63795, 1.3739130434783, 0.56739130434783, 0.16666666666667
63796, 1.3739130434783, 0.56739130434783, 0.11111111111111
63797, 1.3739130434783, 0.56739130434783, 0.055555555555556
63798, 1.4173913043478, 0.56739130434783, 0.44444444444444
63799, 1.4173913043478, 0.56739130434783, 0.38888888888889
63800, 1.4173913043478, 0.56739130434783, 0.33333333333333
63801, 1.4173913043478, 0.56739130434783, 0.27777777777778
63802, 1.4173913043478, 0.56739130434783, 0.22222222222222
63803, 1.4173913043478, 0.56739130434783, 0.16666666666667
63804, 1.4173913043478, 0.56739130434783, 0.11111111111111
63805, 1.4173913043478, 0.56739130434783, 0.055555555555556
63806, 1.4608695652174, 0.56739130434783, 0.44444444444444
63807, 1.4608695652174, 0.56739130434783, 0.38888888888889
63808, 1.4608695652174, 0.56739130434783, 0.33333333333333
63809, 1.4608695652174, 0.56739130434783, 0.27777777777778
63810, 1.4608695652174, 0.56739130434783, 0.22222222222222
63811, 1.4608695652174, 0.56739130434783, 0.16666666666667
63812, 1.4608695652174, 0.56739130434783, 0.11111111111111
63813, 1.4608695652174, 0.56739130434783, 0.055555555555556
63814, 1.504347826087, 0.56739130434783, 0.44444444444444
63815, 1.504347826087, 0.56739130434783, 0.38888888888889
63816, 1.504347826087, 0.56739130434783, 0.33333333333333
63817, 1.504347826087, 0.56739130434783, 0.27777777777778
63818, 1.504347826087, 0.56739130434783, 0.22222222222222
63819, 1.504347826087, 0.56739130434783, 0.16666666666667
63820, 1.504347826087, 0.56739130434783, 0.11111111111111
63821, 1.504347826087, 0.56739130434783, 0.055555555555556
63822, 1.5478260869565, 0.56739130434783, 0.44444444444444
63823, 1.5478260869565, 0.56739130434783, 0.38888888888889
63824, 1.5478260869565, 0.56739130434783, 0.33333333333333
63825, 1.5478260869565, 0.56739130434783, 0.27777777777778
63826, 1.5478260869565, 0.56739130434783, 0.22222222222222
63827, 1.5478260869565, 0.56739130434783, 0.16666666666667
63828, 1.5478260869565, 0.56739130434783, 0.11111111111111
63829, 1.5478260869565, 0.56739130434783, 0.055555555555556
63830, 1.5913043478261, 0.56739130434783, 0.44444444444444
63831, 1.5913043478261, 0.56739130434783, 0.38888888888889
63832, 1.5913043478261, 0.56739130434783, 0.33333333333333
63833, 1.5913043478261, 0.56739130434783, 0.27777777777778
63834, 1.5913043478261, 0.56739130434783, 0.22222222222222
63835, 1.5913043478261, 0.56739130434783, 0.16666666666667
63836, 1.5913043478261, 0.56739130434783, 0.11111111111111
63837, 1.5913043478261, 0.56739130434783, 0.055555555555556
63838, 1.6347826086957, 0.56739130434783, 0.44444444444444
63839, 1.6347826086957, 0.56739130434783, 0.38888888888889
63840, 1.6347826086957, 0.56739130434783, 0.33333333333333
63841, 1.6347826086957, 0.56739130434783, 0.27777777777778
63842, 1.6347826086957, 0.56739130434783, 0.22222222222222
63843, 1.6347826086957, 0.56739130434783, 0.16666666666667
63844, 1.6347826086957, 0.56739130434783, 0.11111111111111
63845, 1.6347826086957, 0.56739130434783, 0.055555555555556
63846, 1.6782608695652, 0.56739130434783, 0.44444444444444
63847, 1.6782608695652, 0.56739130434783, 0.38888888888889
63848, 1.6782608695652, 0.56739130434783, 0.33333333333333
63849, 1.6782608695652, 0.56739130434783, 0.27777777777778
63850, 1.6782608695652, 0.56739130434783, 0.22222222222222
63851, 1.6782608695652, 0.56739130434783, 0.16666666666667
63852, 1.6782608695652, 0.56739130434783, 0.11111111111111
63853, 1.6782608695652, 0.56739130434783, 0.055555555555556
63854, 1.7217391304348, 0.56739130434783, 0.44444444444444
63855, 1.7217391304348, 0.56739130434783, 0.38888888888889
63856, 1.7217391304348, 0.56739130434783, 0.33333333333333
63857, 1.7217391304348, 0.56739130434783, 0.27777777777778
63858, 1.7217391304348, 0.56739130434783, 0.22222222222222
63859, 1.7217391304348, 0.56739130434783, 0.16666666666667
63860, 1.7217391304348, 0.56739130434783, 0.11111111111111
63861, 1.7217391304348, 0.56739130434783, 0.055555555555556
63862, 1.7652173913043, 0.56739130434783, 0.44444444444444
63863, 1.7652173913043, 0.56739130434783, 0.38888888888889
63864, 1.7652173913043, 0.56739130434783, 0.33333333333333
63865, 1.7652173913043, 0.56739130434783, 0.27777777777778
63866, 1.7652173913043, 0.56739130434783, 0.22222222222222
63867, 1.7652173913043, 0.56739130434783, 0.16666666666667
63868, 1.7652173913043, 0.56739130434783, 0.11111111111111
63869, 1.7652173913043, 0.56739130434783, 0.055555555555556
63870, 1.8086956521739, 0.56739130434783, 0.44444444444444
63871, 1.8086956521739, 0.56739130434783, 0.38888888888889
63872, 1.8086956521739, 0.56739130434783, 0.33333333333333
63873, 1.8086956521739, 0.56739130434783, 0.27777777777778
63874, 1.8086956521739, 0.56739130434783, 0.22222222222222
63875, 1.8086956521739, 0.56739130434783, 0.16666666666667
63876, 1.8086956521739, 0.56739130434783, 0.11111111111111
63877, 1.8086956521739, 0.56739130434783, 0.055555555555556
63878, 1.8521739130435, 0.56739130434783, 0.44444444444444
63879, 1.8521739130435, 0.56739130434783, 0.38888888888889
63880, 1.8521739130435, 0.56739130434783, 0.33333333333333
63881, 1.8521739130435, 0.56739130434783, 0.27777777777778
63882, 1.8521739130435, 0.56739130434783, 0.22222222222222
63883, 1.8521739130435, 0.56739130434783, 0.16666666666667
63884, 1.8521739130435, 0.56739130434783, 0.11111111111111
63885, 1.8521739130435, 0.56739130434783, 0.055555555555556
63886, 1.895652173913, 0.56739130434783, 0.44444444444444
63887, 1.895652173913, 0.56739130434783, 0.38888888888889
63888, 1.895652173913, 0.56739130434783, 0.33333333333333
63889, 1.895652173913, 0.56739130434783, 0.27777777777778
63890, 1.895652173913, 0.56739130434783, 0.22222222222222
63891, 1.895652173913, 0.56739130434783, 0.16666666666667
63892, 1.895652173913, 0.56739130434783, 0.11111111111111
63893, 1.895652173913, 0.56739130434783, 0.055555555555556
63894, 1.9391304347826, 0.56739130434783, 0.44444444444444
63895, 1.9391304347826, 0.56739130434783, 0.38888888888889
63896, 1.9391304347826, 0.56739130434783, 0.33333333333333
63897, 1.9391304347826, 0.56739130434783, 0.27777777777778
63898, 1.9391304347826, 0.56739130434783, 0.22222222222222
63899, 1.9391304347826, 0.56739130434783, 0.16666666666667
63900, 1.9391304347826, 0.56739130434783, 0.11111111111111
63901, 1.9391304347826, 0.56739130434783, 0.055555555555556
63902, 1.9826086956522, 0.56739130434783, 0.44444444444444
63903, 1.9826086956522, 0.56739130434783, 0.38888888888889
63904, 1.9826086956522, 0.56739130434783, 0.33333333333333
63905, 1.9826086956522, 0.56739130434783, 0.27777777777778
63906, 1.9826086956522, 0.56739130434783, 0.22222222222222
63907, 1.9826086956522, 0.56739130434783, 0.16666666666667
63908, 1.9826086956522, 0.56739130434783, 0.11111111111111
63909, 1.9826086956522, 0.56739130434783, 0.055555555555556
63910, 2.0260869565217, 0.56739130434783, 0.44444444444444
63911, 2.0260869565217, 0.56739130434783, 0.38888888888889
63912, 2.0260869565217, 0.56739130434783, 0.33333333333333
63913, 2.0260869565217, 0.56739130434783, 0.27777777777778
63914, 2.0260869565217, 0.56739130434783, 0.22222222222222
63915, 2.0260869565217, 0.56739130434783, 0.16666666666667
63916, 2.0260869565217, 0.56739130434783, 0.11111111111111
63917, 2.0260869565217, 0.56739130434783, 0.055555555555556
63918, 2.0695652173913, 0.56739130434783, 0.44444444444444
63919, 2.0695652173913, 0.56739130434783, 0.38888888888889
63920, 2.0695652173913, 0.56739130434783, 0.33333333333333
63921, 2.0695652173913, 0.56739130434783, 0.27777777777778
63922, 2.0695652173913, 0.56739130434783, 0.22222222222222
63923, 2.0695652173913, 0.56739130434783, 0.16666666666667
63924, 2.0695652173913, 0.56739130434783, 0.11111111111111
63925, 2.0695652173913, 0.56739130434783, 0.055555555555556
63926, 2.1130434782609, 0.56739130434783, 0.44444444444444
63927, 2.1130434782609, 0.56739130434783, 0.38888888888889
63928, 2.1130434782609, 0.56739130434783, 0.33333333333333
63929, 2.1130434782609, 0.56739130434783, 0.27777777777778
63930, 2.1130434782609, 0.56739130434783, 0.22222222222222
63931, 2.1130434782609, 0.56739130434783, 0.16666666666667
63932, 2.1130434782609, 0.56739130434783, 0.11111111111111
63933, 2.1130434782609, 0.56739130434783, 0.055555555555556
63934, 2.1565217391304, 0.56739130434783, 0.44444444444444
63935, 2.1565217391304, 0.56739130434783, 0.38888888888889
63936, 2.1565217391304, 0.56739130434783, 0.33333333333333
63937, 2.1565217391304, 0.56739130434783, 0.27777777777778
63938, 2.1565217391304, 0.56739130434783, 0.22222222222222
63939, 2.1565217391304, 0.56739130434783, 0.16666666666667
63940, 2.1565217391304, 0.56739130434783, 0.11111111111111
63941, 2.1565217391304, 0.56739130434783, 0.055555555555556
63942, 1.2434782608696, 0.51521739130435, 0.44444444444444
63943, 1.2434782608696, 0.51521739130435, 0.38888888888889
63944, 1.2434782608696, 0.51521739130435, 0.33333333333333
63945, 1.2434782608696, 0.51521739130435, 0.27777777777778
63946, 1.2434782608696, 0.51521739130435, 0.22222222222222
63947, 1.2434782608696, 0.51521739130435, 0.16666666666667
63948, 1.2434782608696, 0.51521739130435, 0.11111111111111
63949, 1.2434782608696, 0.51521739130435, 0.055555555555556
63950, 1.2869565217391, 0.51521739130435, 0.44444444444444
63951, 1.2869565217391, 0.51521739130435, 0.38888888888889
63952, 1.2869565217391, 0.51521739130435, 0.33333333333333
63953, 1.2869565217391, 0.51521739130435, 0.27777777777778
63954, 1.2869565217391, 0.51521739130435, 0.22222222222222
63955, 1.2869565217391, 0.51521739130435, 0.16666666666667
63956, 1.2869565217391, 0.51521739130435, 0.11111111111111
63957, 1.2869565217391, 0.51521739130435, 0.055555555555556
63958, 1.3304347826087, 0.51521739130435, 0.44444444444444
63959, 1.3304347826087, 0.51521739130435, 0.38888888888889
63960, 1.3304347826087, 0.51521739130435, 0.33333333333333
63961, 1.3304347826087, 0.51521739130435, 0.27777777777778
63962, 1.3304347826087, 0.51521739130435, 0.22222222222222
63963, 1.3304347826087, 0.51521739130435, 0.16666666666667
63964, 1.3304347826087, 0.51521739130435, 0.11111111111111
63965, 1.3304347826087, 0.51521739130435, 0.055555555555556
63966, 1.3739130434783, 0.51521739130435, 0.44444444444444
63967, 1.3739130434783, 0.51521739130435, 0.38888888888889
63968, 1.3739130434783, 0.51521739130435, 0.33333333333333
63969, 1.3739130434783, 0.51521739130435, 0.27777777777778
63970, 1.3739130434783, 0.51521739130435, 0.22222222222222
63971, 1.3739130434783, 0.51521739130435, 0.16666666666667
63972, 1.3739130434783, 0.51521739130435, 0.11111111111111
63973, 1.3739130434783, 0.51521739130435, 0.055555555555556
63974, 1.4173913043478, 0.51521739130435, 0.44444444444444
63975, 1.4173913043478, 0.51521739130435, 0.38888888888889
63976, 1.4173913043478, 0.51521739130435, 0.33333333333333
63977, 1.4173913043478, 0.51521739130435, 0.27777777777778
63978, 1.4173913043478, 0.51521739130435, 0.22222222222222
63979, 1.4173913043478, 0.51521739130435, 0.16666666666667
63980, 1.4173913043478, 0.51521739130435, 0.11111111111111
63981, 1.4173913043478, 0.51521739130435, 0.055555555555556
63982, 1.4608695652174, 0.51521739130435, 0.44444444444444
63983, 1.4608695652174, 0.51521739130435, 0.38888888888889
63984, 1.4608695652174, 0.51521739130435, 0.33333333333333
63985, 1.4608695652174, 0.51521739130435, 0.27777777777778
63986, 1.4608695652174, 0.51521739130435, 0.22222222222222
63987, 1.4608695652174, 0.51521739130435, 0.16666666666667
63988, 1.4608695652174, 0.51521739130435, 0.11111111111111
63989, 1.4608695652174, 0.51521739130435, 0.055555555555556
63990, 1.504347826087, 0.51521739130435, 0.44444444444444
63991, 1.504347826087, 0.51521739130435, 0.38888888888889
63992, 1.504347826087, 0.51521739130435, 0.33333333333333
63993, 1.504347826087, 0.51521739130435, 0.27777777777778
63994, 1.504347826087, 0.51521739130435, 0.22222222222222
63995, 1.504347826087, 0.51521739130435, 0.16666666666667
63996, 1.504347826087, 0.51521739130435, 0.11111111111111
63997, 1.504347826087, 0.51521739130435, 0.055555555555556
63998, 1.5478260869565, 0.51521739130435, 0.44444444444444
63999, 1.5478260869565, 0.51521739130435, 0.38888888888889
64000, 1.5478260869565, 0.51521739130435, 0.33333333333333
64001, 1.5478260869565, 0.51521739130435, 0.27777777777778
64002, 1.5478260869565, 0.51521739130435, 0.22222222222222
64003, 1.5478260869565, 0.51521739130435, 0.16666666666667
64004, 1.5478260869565, 0.51521739130435, 0.11111111111111
64005, 1.5478260869565, 0.51521739130435, 0.055555555555556
64006, 1.5913043478261, 0.51521739130435, 0.44444444444444
64007, 1.5913043478261, 0.51521739130435, 0.38888888888889
64008, 1.5913043478261, 0.51521739130435, 0.33333333333333
64009, 1.5913043478261, 0.51521739130435, 0.27777777777778
64010, 1.5913043478261, 0.51521739130435, 0.22222222222222
64011, 1.5913043478261, 0.51521739130435, 0.16666666666667
64012, 1.5913043478261, 0.51521739130435, 0.11111111111111
64013, 1.5913043478261, 0.51521739130435, 0.055555555555556
64014, 1.6347826086957, 0.51521739130435, 0.44444444444444
64015, 1.6347826086957, 0.51521739130435, 0.38888888888889
64016, 1.6347826086957, 0.51521739130435, 0.33333333333333
64017, 1.6347826086957, 0.51521739130435, 0.27777777777778
64018, 1.6347826086957, 0.51521739130435, 0.22222222222222
64019, 1.6347826086957, 0.51521739130435, 0.16666666666667
64020, 1.6347826086957, 0.51521739130435, 0.11111111111111
64021, 1.6347826086957, 0.51521739130435, 0.055555555555556
64022, 1.6782608695652, 0.51521739130435, 0.44444444444444
64023, 1.6782608695652, 0.51521739130435, 0.38888888888889
64024, 1.6782608695652, 0.51521739130435, 0.33333333333333
64025, 1.6782608695652, 0.51521739130435, 0.27777777777778
64026, 1.6782608695652, 0.51521739130435, 0.22222222222222
64027, 1.6782608695652, 0.51521739130435, 0.16666666666667
64028, 1.6782608695652, 0.51521739130435, 0.11111111111111
64029, 1.6782608695652, 0.51521739130435, 0.055555555555556
64030, 1.7217391304348, 0.51521739130435, 0.44444444444444
64031, 1.7217391304348, 0.51521739130435, 0.38888888888889
64032, 1.7217391304348, 0.51521739130435, 0.33333333333333
64033, 1.7217391304348, 0.51521739130435, 0.27777777777778
64034, 1.7217391304348, 0.51521739130435, 0.22222222222222
64035, 1.7217391304348, 0.51521739130435, 0.16666666666667
64036, 1.7217391304348, 0.51521739130435, 0.11111111111111
64037, 1.7217391304348, 0.51521739130435, 0.055555555555556
64038, 1.7652173913043, 0.51521739130435, 0.44444444444444
64039, 1.7652173913043, 0.51521739130435, 0.38888888888889
64040, 1.7652173913043, 0.51521739130435, 0.33333333333333
64041, 1.7652173913043, 0.51521739130435, 0.27777777777778
64042, 1.7652173913043, 0.51521739130435, 0.22222222222222
64043, 1.7652173913043, 0.51521739130435, 0.16666666666667
64044, 1.7652173913043, 0.51521739130435, 0.11111111111111
64045, 1.7652173913043, 0.51521739130435, 0.055555555555556
64046, 1.8086956521739, 0.51521739130435, 0.44444444444444
64047, 1.8086956521739, 0.51521739130435, 0.38888888888889
64048, 1.8086956521739, 0.51521739130435, 0.33333333333333
64049, 1.8086956521739, 0.51521739130435, 0.27777777777778
64050, 1.8086956521739, 0.51521739130435, 0.22222222222222
64051, 1.8086956521739, 0.51521739130435, 0.16666666666667
64052, 1.8086956521739, 0.51521739130435, 0.11111111111111
64053, 1.8086956521739, 0.51521739130435, 0.055555555555556
64054, 1.8521739130435, 0.51521739130435, 0.44444444444444
64055, 1.8521739130435, 0.51521739130435, 0.38888888888889
64056, 1.8521739130435, 0.51521739130435, 0.33333333333333
64057, 1.8521739130435, 0.51521739130435, 0.27777777777778
64058, 1.8521739130435, 0.51521739130435, 0.22222222222222
64059, 1.8521739130435, 0.51521739130435, 0.16666666666667
64060, 1.8521739130435, 0.51521739130435, 0.11111111111111
64061, 1.8521739130435, 0.51521739130435, 0.055555555555556
64062, 1.895652173913, 0.51521739130435, 0.44444444444444
64063, 1.895652173913, 0.51521739130435, 0.38888888888889
64064, 1.895652173913, 0.51521739130435, 0.33333333333333
64065, 1.895652173913, 0.51521739130435, 0.27777777777778
64066, 1.895652173913, 0.51521739130435, 0.22222222222222
64067, 1.895652173913, 0.51521739130435, 0.16666666666667
64068, 1.895652173913, 0.51521739130435, 0.11111111111111
64069, 1.895652173913, 0.51521739130435, 0.055555555555556
64070, 1.9391304347826, 0.51521739130435, 0.44444444444444
64071, 1.9391304347826, 0.51521739130435, 0.38888888888889
64072, 1.9391304347826, 0.51521739130435, 0.33333333333333
64073, 1.9391304347826, 0.51521739130435, 0.27777777777778
64074, 1.9391304347826, 0.51521739130435, 0.22222222222222
64075, 1.9391304347826, 0.51521739130435, 0.16666666666667
64076, 1.9391304347826, 0.51521739130435, 0.11111111111111
64077, 1.9391304347826, 0.51521739130435, 0.055555555555556
64078, 1.9826086956522, 0.51521739130435, 0.44444444444444
64079, 1.9826086956522, 0.51521739130435, 0.38888888888889
64080, 1.9826086956522, 0.51521739130435, 0.33333333333333
64081, 1.9826086956522, 0.51521739130435, 0.27777777777778
64082, 1.9826086956522, 0.51521739130435, 0.22222222222222
64083, 1.9826086956522, 0.51521739130435, 0.16666666666667
64084, 1.9826086956522, 0.51521739130435, 0.11111111111111
64085, 1.9826086956522, 0.51521739130435, 0.055555555555556
64086, 2.0260869565217, 0.51521739130435, 0.44444444444444
64087, 2.0260869565217, 0.51521739130435, 0.38888888888889
64088, 2.0260869565217, 0.51521739130435, 0.33333333333333
64089, 2.0260869565217, 0.51521739130435, 0.27777777777778
64090, 2.0260869565217, 0.51521739130435, 0.22222222222222
64091, 2.0260869565217, 0.51521739130435, 0.16666666666667
64092, 2.0260869565217, 0.51521739130435, 0.11111111111111
64093, 2.0260869565217, 0.51521739130435, 0.055555555555556
64094, 2.0695652173913, 0.51521739130435, 0.44444444444444
64095, 2.0695652173913, 0.51521739130435, 0.38888888888889
64096, 2.0695652173913, 0.51521739130435, 0.33333333333333
64097, 2.0695652173913, 0.51521739130435, 0.27777777777778
64098, 2.0695652173913, 0.51521739130435, 0.22222222222222
64099, 2.0695652173913, 0.51521739130435, 0.16666666666667
64100, 2.0695652173913, 0.51521739130435, 0.11111111111111
64101, 2.0695652173913, 0.51521739130435, 0.055555555555556
64102, 2.1130434782609, 0.51521739130435, 0.44444444444444
64103, 2.1130434782609, 0.51521739130435, 0.38888888888889
64104, 2.1130434782609, 0.51521739130435, 0.33333333333333
64105, 2.1130434782609, 0.51521739130435, 0.27777777777778
64106, 2.1130434782609, 0.51521739130435, 0.22222222222222
64107, 2.1130434782609, 0.51521739130435, 0.16666666666667
64108, 2.1130434782609, 0.51521739130435, 0.11111111111111
64109, 2.1130434782609, 0.51521739130435, 0.055555555555556
64110, 2.1565217391304, 0.51521739130435, 0.44444444444444
64111, 2.1565217391304, 0.51521739130435, 0.38888888888889
64112, 2.1565217391304, 0.51521739130435, 0.33333333333333
64113, 2.1565217391304, 0.51521739130435, 0.27777777777778
64114, 2.1565217391304, 0.51521739130435, 0.22222222222222
64115, 2.1565217391304, 0.51521739130435, 0.16666666666667
64116, 2.1565217391304, 0.51521739130435, 0.11111111111111
64117, 2.1565217391304, 0.51521739130435, 0.055555555555556
64118, 1.2434782608696, 0.46304347826087, 0.44444444444444
64119, 1.2434782608696, 0.46304347826087, 0.38888888888889
64120, 1.2434782608696, 0.46304347826087, 0.33333333333333
64121, 1.2434782608696, 0.46304347826087, 0.27777777777778
64122, 1.2434782608696, 0.46304347826087, 0.22222222222222
64123, 1.2434782608696, 0.46304347826087, 0.16666666666667
64124, 1.2434782608696, 0.46304347826087, 0.11111111111111
64125, 1.2434782608696, 0.46304347826087, 0.055555555555556
64126, 1.2869565217391, 0.46304347826087, 0.44444444444444
64127, 1.2869565217391, 0.46304347826087, 0.38888888888889
64128, 1.2869565217391, 0.46304347826087, 0.33333333333333
64129, 1.2869565217391, 0.46304347826087, 0.27777777777778
64130, 1.2869565217391, 0.46304347826087, 0.22222222222222
64131, 1.2869565217391, 0.46304347826087, 0.16666666666667
64132, 1.2869565217391, 0.46304347826087, 0.11111111111111
64133, 1.2869565217391, 0.46304347826087, 0.055555555555556
64134, 1.3304347826087, 0.46304347826087, 0.44444444444444
64135, 1.3304347826087, 0.46304347826087, 0.38888888888889
64136, 1.3304347826087, 0.46304347826087, 0.33333333333333
64137, 1.3304347826087, 0.46304347826087, 0.27777777777778
64138, 1.3304347826087, 0.46304347826087, 0.22222222222222
64139, 1.3304347826087, 0.46304347826087, 0.16666666666667
64140, 1.3304347826087, 0.46304347826087, 0.11111111111111
64141, 1.3304347826087, 0.46304347826087, 0.055555555555556
64142, 1.3739130434783, 0.46304347826087, 0.44444444444444
64143, 1.3739130434783, 0.46304347826087, 0.38888888888889
64144, 1.3739130434783, 0.46304347826087, 0.33333333333333
64145, 1.3739130434783, 0.46304347826087, 0.27777777777778
64146, 1.3739130434783, 0.46304347826087, 0.22222222222222
64147, 1.3739130434783, 0.46304347826087, 0.16666666666667
64148, 1.3739130434783, 0.46304347826087, 0.11111111111111
64149, 1.3739130434783, 0.46304347826087, 0.055555555555556
64150, 1.4173913043478, 0.46304347826087, 0.44444444444444
64151, 1.4173913043478, 0.46304347826087, 0.38888888888889
64152, 1.4173913043478, 0.46304347826087, 0.33333333333333
64153, 1.4173913043478, 0.46304347826087, 0.27777777777778
64154, 1.4173913043478, 0.46304347826087, 0.22222222222222
64155, 1.4173913043478, 0.46304347826087, 0.16666666666667
64156, 1.4173913043478, 0.46304347826087, 0.11111111111111
64157, 1.4173913043478, 0.46304347826087, 0.055555555555556
64158, 1.4608695652174, 0.46304347826087, 0.44444444444444
64159, 1.4608695652174, 0.46304347826087, 0.38888888888889
64160, 1.4608695652174, 0.46304347826087, 0.33333333333333
64161, 1.4608695652174, 0.46304347826087, 0.27777777777778
64162, 1.4608695652174, 0.46304347826087, 0.22222222222222
64163, 1.4608695652174, 0.46304347826087, 0.16666666666667
64164, 1.4608695652174, 0.46304347826087, 0.11111111111111
64165, 1.4608695652174, 0.46304347826087, 0.055555555555556
64166, 1.504347826087, 0.46304347826087, 0.44444444444444
64167, 1.504347826087, 0.46304347826087, 0.38888888888889
64168, 1.504347826087, 0.46304347826087, 0.33333333333333
64169, 1.504347826087, 0.46304347826087, 0.27777777777778
64170, 1.504347826087, 0.46304347826087, 0.22222222222222
64171, 1.504347826087, 0.46304347826087, 0.16666666666667
64172, 1.504347826087, 0.46304347826087, 0.11111111111111
64173, 1.504347826087, 0.46304347826087, 0.055555555555556
64174, 1.5478260869565, 0.46304347826087, 0.44444444444444
64175, 1.5478260869565, 0.46304347826087, 0.38888888888889
64176, 1.5478260869565, 0.46304347826087, 0.33333333333333
64177, 1.5478260869565, 0.46304347826087, 0.27777777777778
64178, 1.5478260869565, 0.46304347826087, 0.22222222222222
64179, 1.5478260869565, 0.46304347826087, 0.16666666666667
64180, 1.5478260869565, 0.46304347826087, 0.11111111111111
64181, 1.5478260869565, 0.46304347826087, 0.055555555555556
64182, 1.5913043478261, 0.46304347826087, 0.44444444444444
64183, 1.5913043478261, 0.46304347826087, 0.38888888888889
64184, 1.5913043478261, 0.46304347826087, 0.33333333333333
64185, 1.5913043478261, 0.46304347826087, 0.27777777777778
64186, 1.5913043478261, 0.46304347826087, 0.22222222222222
64187, 1.5913043478261, 0.46304347826087, 0.16666666666667
64188, 1.5913043478261, 0.46304347826087, 0.11111111111111
64189, 1.5913043478261, 0.46304347826087, 0.055555555555556
64190, 1.6347826086957, 0.46304347826087, 0.44444444444444
64191, 1.6347826086957, 0.46304347826087, 0.38888888888889
64192, 1.6347826086957, 0.46304347826087, 0.33333333333333
64193, 1.6347826086957, 0.46304347826087, 0.27777777777778
64194, 1.6347826086957, 0.46304347826087, 0.22222222222222
64195, 1.6347826086957, 0.46304347826087, 0.16666666666667
64196, 1.6347826086957, 0.46304347826087, 0.11111111111111
64197, 1.6347826086957, 0.46304347826087, 0.055555555555556
64198, 1.6782608695652, 0.46304347826087, 0.44444444444444
64199, 1.6782608695652, 0.46304347826087, 0.38888888888889
64200, 1.6782608695652, 0.46304347826087, 0.33333333333333
64201, 1.6782608695652, 0.46304347826087, 0.27777777777778
64202, 1.6782608695652, 0.46304347826087, 0.22222222222222
64203, 1.6782608695652, 0.46304347826087, 0.16666666666667
64204, 1.6782608695652, 0.46304347826087, 0.11111111111111
64205, 1.6782608695652, 0.46304347826087, 0.055555555555556
64206, 1.7217391304348, 0.46304347826087, 0.44444444444444
64207, 1.7217391304348, 0.46304347826087, 0.38888888888889
64208, 1.7217391304348, 0.46304347826087, 0.33333333333333
64209, 1.7217391304348, 0.46304347826087, 0.27777777777778
64210, 1.7217391304348, 0.46304347826087, 0.22222222222222
64211, 1.7217391304348, 0.46304347826087, 0.16666666666667
64212, 1.7217391304348, 0.46304347826087, 0.11111111111111
64213, 1.7217391304348, 0.46304347826087, 0.055555555555556
64214, 1.7652173913043, 0.46304347826087, 0.44444444444444
64215, 1.7652173913043, 0.46304347826087, 0.38888888888889
64216, 1.7652173913043, 0.46304347826087, 0.33333333333333
64217, 1.7652173913043, 0.46304347826087, 0.27777777777778
64218, 1.7652173913043, 0.46304347826087, 0.22222222222222
64219, 1.7652173913043, 0.46304347826087, 0.16666666666667
64220, 1.7652173913043, 0.46304347826087, 0.11111111111111
64221, 1.7652173913043, 0.46304347826087, 0.055555555555556
64222, 1.8086956521739, 0.46304347826087, 0.44444444444444
64223, 1.8086956521739, 0.46304347826087, 0.38888888888889
64224, 1.8086956521739, 0.46304347826087, 0.33333333333333
64225, 1.8086956521739, 0.46304347826087, 0.27777777777778
64226, 1.8086956521739, 0.46304347826087, 0.22222222222222
64227, 1.8086956521739, 0.46304347826087, 0.16666666666667
64228, 1.8086956521739, 0.46304347826087, 0.11111111111111
64229, 1.8086956521739, 0.46304347826087, 0.055555555555556
64230, 1.8521739130435, 0.46304347826087, 0.44444444444444
64231, 1.8521739130435, 0.46304347826087, 0.38888888888889
64232, 1.8521739130435, 0.46304347826087, 0.33333333333333
64233, 1.8521739130435, 0.46304347826087, 0.27777777777778
64234, 1.8521739130435, 0.46304347826087, 0.22222222222222
64235, 1.8521739130435, 0.46304347826087, 0.16666666666667
64236, 1.8521739130435, 0.46304347826087, 0.11111111111111
64237, 1.8521739130435, 0.46304347826087, 0.055555555555556
64238, 1.895652173913, 0.46304347826087, 0.44444444444444
64239, 1.895652173913, 0.46304347826087, 0.38888888888889
64240, 1.895652173913, 0.46304347826087, 0.33333333333333
64241, 1.895652173913, 0.46304347826087, 0.27777777777778
64242, 1.895652173913, 0.46304347826087, 0.22222222222222
64243, 1.895652173913, 0.46304347826087, 0.16666666666667
64244, 1.895652173913, 0.46304347826087, 0.11111111111111
64245, 1.895652173913, 0.46304347826087, 0.055555555555556
64246, 1.9391304347826, 0.46304347826087, 0.44444444444444
64247, 1.9391304347826, 0.46304347826087, 0.38888888888889
64248, 1.9391304347826, 0.46304347826087, 0.33333333333333
64249, 1.9391304347826, 0.46304347826087, 0.27777777777778
64250, 1.9391304347826, 0.46304347826087, 0.22222222222222
64251, 1.9391304347826, 0.46304347826087, 0.16666666666667
64252, 1.9391304347826, 0.46304347826087, 0.11111111111111
64253, 1.9391304347826, 0.46304347826087, 0.055555555555556
64254, 1.9826086956522, 0.46304347826087, 0.44444444444444
64255, 1.9826086956522, 0.46304347826087, 0.38888888888889
64256, 1.9826086956522, 0.46304347826087, 0.33333333333333
64257, 1.9826086956522, 0.46304347826087, 0.27777777777778
64258, 1.9826086956522, 0.46304347826087, 0.22222222222222
64259, 1.9826086956522, 0.46304347826087, 0.16666666666667
64260, 1.9826086956522, 0.46304347826087, 0.11111111111111
64261, 1.9826086956522, 0.46304347826087, 0.055555555555556
64262, 2.0260869565217, 0.46304347826087, 0.44444444444444
64263, 2.0260869565217, 0.46304347826087, 0.38888888888889
64264, 2.0260869565217, 0.46304347826087, 0.33333333333333
64265, 2.0260869565217, 0.46304347826087, 0.27777777777778
64266, 2.0260869565217, 0.46304347826087, 0.22222222222222
64267, 2.0260869565217, 0.46304347826087, 0.16666666666667
64268, 2.0260869565217, 0.46304347826087, 0.11111111111111
64269, 2.0260869565217, 0.46304347826087, 0.055555555555556
64270, 2.0695652173913, 0.46304347826087, 0.44444444444444
64271, 2.0695652173913, 0.46304347826087, 0.38888888888889
64272, 2.0695652173913, 0.46304347826087, 0.33333333333333
64273, 2.0695652173913, 0.46304347826087, 0.27777777777778
64274, 2.0695652173913, 0.46304347826087, 0.22222222222222
64275, 2.0695652173913, 0.46304347826087, 0.16666666666667
64276, 2.0695652173913, 0.46304347826087, 0.11111111111111
64277, 2.0695652173913, 0.46304347826087, 0.055555555555556
64278, 2.1130434782609, 0.46304347826087, 0.44444444444444
64279, 2.1130434782609, 0.46304347826087, 0.38888888888889
64280, 2.1130434782609, 0.46304347826087, 0.33333333333333
64281, 2.1130434782609, 0.46304347826087, 0.27777777777778
64282, 2.1130434782609, 0.46304347826087, 0.22222222222222
64283, 2.1130434782609, 0.46304347826087, 0.16666666666667
64284, 2.1130434782609, 0.46304347826087, 0.11111111111111
64285, 2.1130434782609, 0.46304347826087, 0.055555555555556
64286, 2.1565217391304, 0.46304347826087, 0.44444444444444
64287, 2.1565217391304, 0.46304347826087, 0.38888888888889
64288, 2.1565217391304, 0.46304347826087, 0.33333333333333
64289, 2.1565217391304, 0.46304347826087, 0.27777777777778
64290, 2.1565217391304, 0.46304347826087, 0.22222222222222
64291, 2.1565217391304, 0.46304347826087, 0.16666666666667
64292, 2.1565217391304, 0.46304347826087, 0.11111111111111
64293, 2.1565217391304, 0.46304347826087, 0.055555555555556
64294, 1.2434782608696, 0.41086956521739, 0.44444444444444
64295, 1.2434782608696, 0.41086956521739, 0.38888888888889
64296, 1.2434782608696, 0.41086956521739, 0.33333333333333
64297, 1.2434782608696, 0.41086956521739, 0.27777777777778
64298, 1.2434782608696, 0.41086956521739, 0.22222222222222
64299, 1.2434782608696, 0.41086956521739, 0.16666666666667
64300, 1.2434782608696, 0.41086956521739, 0.11111111111111
64301, 1.2434782608696, 0.41086956521739, 0.055555555555556
64302, 1.2869565217391, 0.41086956521739, 0.44444444444444
64303, 1.2869565217391, 0.41086956521739, 0.38888888888889
64304, 1.2869565217391, 0.41086956521739, 0.33333333333333
64305, 1.2869565217391, 0.41086956521739, 0.27777777777778
64306, 1.2869565217391, 0.41086956521739, 0.22222222222222
64307, 1.2869565217391, 0.41086956521739, 0.16666666666667
64308, 1.2869565217391, 0.41086956521739, 0.11111111111111
64309, 1.2869565217391, 0.41086956521739, 0.055555555555556
64310, 1.3304347826087, 0.41086956521739, 0.44444444444444
64311, 1.3304347826087, 0.41086956521739, 0.38888888888889
64312, 1.3304347826087, 0.41086956521739, 0.33333333333333
64313, 1.3304347826087, 0.41086956521739, 0.27777777777778
64314, 1.3304347826087, 0.41086956521739, 0.22222222222222
64315, 1.3304347826087, 0.41086956521739, 0.16666666666667
64316, 1.3304347826087, 0.41086956521739, 0.11111111111111
64317, 1.3304347826087, 0.41086956521739, 0.055555555555556
64318, 1.3739130434783, 0.41086956521739, 0.44444444444444
64319, 1.3739130434783, 0.41086956521739, 0.38888888888889
64320, 1.3739130434783, 0.41086956521739, 0.33333333333333
64321, 1.3739130434783, 0.41086956521739, 0.27777777777778
64322, 1.3739130434783, 0.41086956521739, 0.22222222222222
64323, 1.3739130434783, 0.41086956521739, 0.16666666666667
64324, 1.3739130434783, 0.41086956521739, 0.11111111111111
64325, 1.3739130434783, 0.41086956521739, 0.055555555555556
64326, 1.4173913043478, 0.41086956521739, 0.44444444444444
64327, 1.4173913043478, 0.41086956521739, 0.38888888888889
64328, 1.4173913043478, 0.41086956521739, 0.33333333333333
64329, 1.4173913043478, 0.41086956521739, 0.27777777777778
64330, 1.4173913043478, 0.41086956521739, 0.22222222222222
64331, 1.4173913043478, 0.41086956521739, 0.16666666666667
64332, 1.4173913043478, 0.41086956521739, 0.11111111111111
64333, 1.4173913043478, 0.41086956521739, 0.055555555555556
64334, 1.4608695652174, 0.41086956521739, 0.44444444444444
64335, 1.4608695652174, 0.41086956521739, 0.38888888888889
64336, 1.4608695652174, 0.41086956521739, 0.33333333333333
64337, 1.4608695652174, 0.41086956521739, 0.27777777777778
64338, 1.4608695652174, 0.41086956521739, 0.22222222222222
64339, 1.4608695652174, 0.41086956521739, 0.16666666666667
64340, 1.4608695652174, 0.41086956521739, 0.11111111111111
64341, 1.4608695652174, 0.41086956521739, 0.055555555555556
64342, 1.504347826087, 0.41086956521739, 0.44444444444444
64343, 1.504347826087, 0.41086956521739, 0.38888888888889
64344, 1.504347826087, 0.41086956521739, 0.33333333333333
64345, 1.504347826087, 0.41086956521739, 0.27777777777778
64346, 1.504347826087, 0.41086956521739, 0.22222222222222
64347, 1.504347826087, 0.41086956521739, 0.16666666666667
64348, 1.504347826087, 0.41086956521739, 0.11111111111111
64349, 1.504347826087, 0.41086956521739, 0.055555555555556
64350, 1.5478260869565, 0.41086956521739, 0.44444444444444
64351, 1.5478260869565, 0.41086956521739, 0.38888888888889
64352, 1.5478260869565, 0.41086956521739, 0.33333333333333
64353, 1.5478260869565, 0.41086956521739, 0.27777777777778
64354, 1.5478260869565, 0.41086956521739, 0.22222222222222
64355, 1.5478260869565, 0.41086956521739, 0.16666666666667
64356, 1.5478260869565, 0.41086956521739, 0.11111111111111
64357, 1.5478260869565, 0.41086956521739, 0.055555555555556
64358, 1.5913043478261, 0.41086956521739, 0.44444444444444
64359, 1.5913043478261, 0.41086956521739, 0.38888888888889
64360, 1.5913043478261, 0.41086956521739, 0.33333333333333
64361, 1.5913043478261, 0.41086956521739, 0.27777777777778
64362, 1.5913043478261, 0.41086956521739, 0.22222222222222
64363, 1.5913043478261, 0.41086956521739, 0.16666666666667
64364, 1.5913043478261, 0.41086956521739, 0.11111111111111
64365, 1.5913043478261, 0.41086956521739, 0.055555555555556
64366, 1.6347826086957, 0.41086956521739, 0.44444444444444
64367, 1.6347826086957, 0.41086956521739, 0.38888888888889
64368, 1.6347826086957, 0.41086956521739, 0.33333333333333
64369, 1.6347826086957, 0.41086956521739, 0.27777777777778
64370, 1.6347826086957, 0.41086956521739, 0.22222222222222
64371, 1.6347826086957, 0.41086956521739, 0.16666666666667
64372, 1.6347826086957, 0.41086956521739, 0.11111111111111
64373, 1.6347826086957, 0.41086956521739, 0.055555555555556
64374, 1.6782608695652, 0.41086956521739, 0.44444444444444
64375, 1.6782608695652, 0.41086956521739, 0.38888888888889
64376, 1.6782608695652, 0.41086956521739, 0.33333333333333
64377, 1.6782608695652, 0.41086956521739, 0.27777777777778
64378, 1.6782608695652, 0.41086956521739, 0.22222222222222
64379, 1.6782608695652, 0.41086956521739, 0.16666666666667
64380, 1.6782608695652, 0.41086956521739, 0.11111111111111
64381, 1.6782608695652, 0.41086956521739, 0.055555555555556
64382, 1.7217391304348, 0.41086956521739, 0.44444444444444
64383, 1.7217391304348, 0.41086956521739, 0.38888888888889
64384, 1.7217391304348, 0.41086956521739, 0.33333333333333
64385, 1.7217391304348, 0.41086956521739, 0.27777777777778
64386, 1.7217391304348, 0.41086956521739, 0.22222222222222
64387, 1.7217391304348, 0.41086956521739, 0.16666666666667
64388, 1.7217391304348, 0.41086956521739, 0.11111111111111
64389, 1.7217391304348, 0.41086956521739, 0.055555555555556
64390, 1.7652173913043, 0.41086956521739, 0.44444444444444
64391, 1.7652173913043, 0.41086956521739, 0.38888888888889
64392, 1.7652173913043, 0.41086956521739, 0.33333333333333
64393, 1.7652173913043, 0.41086956521739, 0.27777777777778
64394, 1.7652173913043, 0.41086956521739, 0.22222222222222
64395, 1.7652173913043, 0.41086956521739, 0.16666666666667
64396, 1.7652173913043, 0.41086956521739, 0.11111111111111
64397, 1.7652173913043, 0.41086956521739, 0.055555555555556
64398, 1.8086956521739, 0.41086956521739, 0.44444444444444
64399, 1.8086956521739, 0.41086956521739, 0.38888888888889
64400, 1.8086956521739, 0.41086956521739, 0.33333333333333
64401, 1.8086956521739, 0.41086956521739, 0.27777777777778
64402, 1.8086956521739, 0.41086956521739, 0.22222222222222
64403, 1.8086956521739, 0.41086956521739, 0.16666666666667
64404, 1.8086956521739, 0.41086956521739, 0.11111111111111
64405, 1.8086956521739, 0.41086956521739, 0.055555555555556
64406, 1.8521739130435, 0.41086956521739, 0.44444444444444
64407, 1.8521739130435, 0.41086956521739, 0.38888888888889
64408, 1.8521739130435, 0.41086956521739, 0.33333333333333
64409, 1.8521739130435, 0.41086956521739, 0.27777777777778
64410, 1.8521739130435, 0.41086956521739, 0.22222222222222
64411, 1.8521739130435, 0.41086956521739, 0.16666666666667
64412, 1.8521739130435, 0.41086956521739, 0.11111111111111
64413, 1.8521739130435, 0.41086956521739, 0.055555555555556
64414, 1.895652173913, 0.41086956521739, 0.44444444444444
64415, 1.895652173913, 0.41086956521739, 0.38888888888889
64416, 1.895652173913, 0.41086956521739, 0.33333333333333
64417, 1.895652173913, 0.41086956521739, 0.27777777777778
64418, 1.895652173913, 0.41086956521739, 0.22222222222222
64419, 1.895652173913, 0.41086956521739, 0.16666666666667
64420, 1.895652173913, 0.41086956521739, 0.11111111111111
64421, 1.895652173913, 0.41086956521739, 0.055555555555556
64422, 1.9391304347826, 0.41086956521739, 0.44444444444444
64423, 1.9391304347826, 0.41086956521739, 0.38888888888889
64424, 1.9391304347826, 0.41086956521739, 0.33333333333333
64425, 1.9391304347826, 0.41086956521739, 0.27777777777778
64426, 1.9391304347826, 0.41086956521739, 0.22222222222222
64427, 1.9391304347826, 0.41086956521739, 0.16666666666667
64428, 1.9391304347826, 0.41086956521739, 0.11111111111111
64429, 1.9391304347826, 0.41086956521739, 0.055555555555556
64430, 1.9826086956522, 0.41086956521739, 0.44444444444444
64431, 1.9826086956522, 0.41086956521739, 0.38888888888889
64432, 1.9826086956522, 0.41086956521739, 0.33333333333333
64433, 1.9826086956522, 0.41086956521739, 0.27777777777778
64434, 1.9826086956522, 0.41086956521739, 0.22222222222222
64435, 1.9826086956522, 0.41086956521739, 0.16666666666667
64436, 1.9826086956522, 0.41086956521739, 0.11111111111111
64437, 1.9826086956522, 0.41086956521739, 0.055555555555556
64438, 2.0260869565217, 0.41086956521739, 0.44444444444444
64439, 2.0260869565217, 0.41086956521739, 0.38888888888889
64440, 2.0260869565217, 0.41086956521739, 0.33333333333333
64441, 2.0260869565217, 0.41086956521739, 0.27777777777778
64442, 2.0260869565217, 0.41086956521739, 0.22222222222222
64443, 2.0260869565217, 0.41086956521739, 0.16666666666667
64444, 2.0260869565217, 0.41086956521739, 0.11111111111111
64445, 2.0260869565217, 0.41086956521739, 0.055555555555556
64446, 2.0695652173913, 0.41086956521739, 0.44444444444444
64447, 2.0695652173913, 0.41086956521739, 0.38888888888889
64448, 2.0695652173913, 0.41086956521739, 0.33333333333333
64449, 2.0695652173913, 0.41086956521739, 0.27777777777778
64450, 2.0695652173913, 0.41086956521739, 0.22222222222222
64451, 2.0695652173913, 0.41086956521739, 0.16666666666667
64452, 2.0695652173913, 0.41086956521739, 0.11111111111111
64453, 2.0695652173913, 0.41086956521739, 0.055555555555556
64454, 2.1130434782609, 0.41086956521739, 0.44444444444444
64455, 2.1130434782609, 0.41086956521739, 0.38888888888889
64456, 2.1130434782609, 0.41086956521739, 0.33333333333333
64457, 2.1130434782609, 0.41086956521739, 0.27777777777778
64458, 2.1130434782609, 0.41086956521739, 0.22222222222222
64459, 2.1130434782609, 0.41086956521739, 0.16666666666667
64460, 2.1130434782609, 0.41086956521739, 0.11111111111111
64461, 2.1130434782609, 0.41086956521739, 0.055555555555556
64462, 2.1565217391304, 0.41086956521739, 0.44444444444444
64463, 2.1565217391304, 0.41086956521739, 0.38888888888889
64464, 2.1565217391304, 0.41086956521739, 0.33333333333333
64465, 2.1565217391304, 0.41086956521739, 0.27777777777778
64466, 2.1565217391304, 0.41086956521739, 0.22222222222222
64467, 2.1565217391304, 0.41086956521739, 0.16666666666667
64468, 2.1565217391304, 0.41086956521739, 0.11111111111111
64469, 2.1565217391304, 0.41086956521739, 0.055555555555556
64470, 1.2434782608696, 0.35869565217391, 0.44444444444444
64471, 1.2434782608696, 0.35869565217391, 0.38888888888889
64472, 1.2434782608696, 0.35869565217391, 0.33333333333333
64473, 1.2434782608696, 0.35869565217391, 0.27777777777778
64474, 1.2434782608696, 0.35869565217391, 0.22222222222222
64475, 1.2434782608696, 0.35869565217391, 0.16666666666667
64476, 1.2434782608696, 0.35869565217391, 0.11111111111111
64477, 1.2434782608696, 0.35869565217391, 0.055555555555556
64478, 1.2869565217391, 0.35869565217391, 0.44444444444444
64479, 1.2869565217391, 0.35869565217391, 0.38888888888889
64480, 1.2869565217391, 0.35869565217391, 0.33333333333333
64481, 1.2869565217391, 0.35869565217391, 0.27777777777778
64482, 1.2869565217391, 0.35869565217391, 0.22222222222222
64483, 1.2869565217391, 0.35869565217391, 0.16666666666667
64484, 1.2869565217391, 0.35869565217391, 0.11111111111111
64485, 1.2869565217391, 0.35869565217391, 0.055555555555556
64486, 1.3304347826087, 0.35869565217391, 0.44444444444444
64487, 1.3304347826087, 0.35869565217391, 0.38888888888889
64488, 1.3304347826087, 0.35869565217391, 0.33333333333333
64489, 1.3304347826087, 0.35869565217391, 0.27777777777778
64490, 1.3304347826087, 0.35869565217391, 0.22222222222222
64491, 1.3304347826087, 0.35869565217391, 0.16666666666667
64492, 1.3304347826087, 0.35869565217391, 0.11111111111111
64493, 1.3304347826087, 0.35869565217391, 0.055555555555556
64494, 1.3739130434783, 0.35869565217391, 0.44444444444444
64495, 1.3739130434783, 0.35869565217391, 0.38888888888889
64496, 1.3739130434783, 0.35869565217391, 0.33333333333333
64497, 1.3739130434783, 0.35869565217391, 0.27777777777778
64498, 1.3739130434783, 0.35869565217391, 0.22222222222222
64499, 1.3739130434783, 0.35869565217391, 0.16666666666667
64500, 1.3739130434783, 0.35869565217391, 0.11111111111111
64501, 1.3739130434783, 0.35869565217391, 0.055555555555556
64502, 1.4173913043478, 0.35869565217391, 0.44444444444444
64503, 1.4173913043478, 0.35869565217391, 0.38888888888889
64504, 1.4173913043478, 0.35869565217391, 0.33333333333333
64505, 1.4173913043478, 0.35869565217391, 0.27777777777778
64506, 1.4173913043478, 0.35869565217391, 0.22222222222222
64507, 1.4173913043478, 0.35869565217391, 0.16666666666667
64508, 1.4173913043478, 0.35869565217391, 0.11111111111111
64509, 1.4173913043478, 0.35869565217391, 0.055555555555556
64510, 1.4608695652174, 0.35869565217391, 0.44444444444444
64511, 1.4608695652174, 0.35869565217391, 0.38888888888889
64512, 1.4608695652174, 0.35869565217391, 0.33333333333333
64513, 1.4608695652174, 0.35869565217391, 0.27777777777778
64514, 1.4608695652174, 0.35869565217391, 0.22222222222222
64515, 1.4608695652174, 0.35869565217391, 0.16666666666667
64516, 1.4608695652174, 0.35869565217391, 0.11111111111111
64517, 1.4608695652174, 0.35869565217391, 0.055555555555556
64518, 1.504347826087, 0.35869565217391, 0.44444444444444
64519, 1.504347826087, 0.35869565217391, 0.38888888888889
64520, 1.504347826087, 0.35869565217391, 0.33333333333333
64521, 1.504347826087, 0.35869565217391, 0.27777777777778
64522, 1.504347826087, 0.35869565217391, 0.22222222222222
64523, 1.504347826087, 0.35869565217391, 0.16666666666667
64524, 1.504347826087, 0.35869565217391, 0.11111111111111
64525, 1.504347826087, 0.35869565217391, 0.055555555555556
64526, 1.5478260869565, 0.35869565217391, 0.44444444444444
64527, 1.5478260869565, 0.35869565217391, 0.38888888888889
64528, 1.5478260869565, 0.35869565217391, 0.33333333333333
64529, 1.5478260869565, 0.35869565217391, 0.27777777777778
64530, 1.5478260869565, 0.35869565217391, 0.22222222222222
64531, 1.5478260869565, 0.35869565217391, 0.16666666666667
64532, 1.5478260869565, 0.35869565217391, 0.11111111111111
64533, 1.5478260869565, 0.35869565217391, 0.055555555555556
64534, 1.5913043478261, 0.35869565217391, 0.44444444444444
64535, 1.5913043478261, 0.35869565217391, 0.38888888888889
64536, 1.5913043478261, 0.35869565217391, 0.33333333333333
64537, 1.5913043478261, 0.35869565217391, 0.27777777777778
64538, 1.5913043478261, 0.35869565217391, 0.22222222222222
64539, 1.5913043478261, 0.35869565217391, 0.16666666666667
64540, 1.5913043478261, 0.35869565217391, 0.11111111111111
64541, 1.5913043478261, 0.35869565217391, 0.055555555555556
64542, 1.6347826086957, 0.35869565217391, 0.44444444444444
64543, 1.6347826086957, 0.35869565217391, 0.38888888888889
64544, 1.6347826086957, 0.35869565217391, 0.33333333333333
64545, 1.6347826086957, 0.35869565217391, 0.27777777777778
64546, 1.6347826086957, 0.35869565217391, 0.22222222222222
64547, 1.6347826086957, 0.35869565217391, 0.16666666666667
64548, 1.6347826086957, 0.35869565217391, 0.11111111111111
64549, 1.6347826086957, 0.35869565217391, 0.055555555555556
64550, 1.6782608695652, 0.35869565217391, 0.44444444444444
64551, 1.6782608695652, 0.35869565217391, 0.38888888888889
64552, 1.6782608695652, 0.35869565217391, 0.33333333333333
64553, 1.6782608695652, 0.35869565217391, 0.27777777777778
64554, 1.6782608695652, 0.35869565217391, 0.22222222222222
64555, 1.6782608695652, 0.35869565217391, 0.16666666666667
64556, 1.6782608695652, 0.35869565217391, 0.11111111111111
64557, 1.6782608695652, 0.35869565217391, 0.055555555555556
64558, 1.7217391304348, 0.35869565217391, 0.44444444444444
64559, 1.7217391304348, 0.35869565217391, 0.38888888888889
64560, 1.7217391304348, 0.35869565217391, 0.33333333333333
64561, 1.7217391304348, 0.35869565217391, 0.27777777777778
64562, 1.7217391304348, 0.35869565217391, 0.22222222222222
64563, 1.7217391304348, 0.35869565217391, 0.16666666666667
64564, 1.7217391304348, 0.35869565217391, 0.11111111111111
64565, 1.7217391304348, 0.35869565217391, 0.055555555555556
64566, 1.7652173913043, 0.35869565217391, 0.44444444444444
64567, 1.7652173913043, 0.35869565217391, 0.38888888888889
64568, 1.7652173913043, 0.35869565217391, 0.33333333333333
64569, 1.7652173913043, 0.35869565217391, 0.27777777777778
64570, 1.7652173913043, 0.35869565217391, 0.22222222222222
64571, 1.7652173913043, 0.35869565217391, 0.16666666666667
64572, 1.7652173913043, 0.35869565217391, 0.11111111111111
64573, 1.7652173913043, 0.35869565217391, 0.055555555555556
64574, 1.8086956521739, 0.35869565217391, 0.44444444444444
64575, 1.8086956521739, 0.35869565217391, 0.38888888888889
64576, 1.8086956521739, 0.35869565217391, 0.33333333333333
64577, 1.8086956521739, 0.35869565217391, 0.27777777777778
64578, 1.8086956521739, 0.35869565217391, 0.22222222222222
64579, 1.8086956521739, 0.35869565217391, 0.16666666666667
64580, 1.8086956521739, 0.35869565217391, 0.11111111111111
64581, 1.8086956521739, 0.35869565217391, 0.055555555555556
64582, 1.8521739130435, 0.35869565217391, 0.44444444444444
64583, 1.8521739130435, 0.35869565217391, 0.38888888888889
64584, 1.8521739130435, 0.35869565217391, 0.33333333333333
64585, 1.8521739130435, 0.35869565217391, 0.27777777777778
64586, 1.8521739130435, 0.35869565217391, 0.22222222222222
64587, 1.8521739130435, 0.35869565217391, 0.16666666666667
64588, 1.8521739130435, 0.35869565217391, 0.11111111111111
64589, 1.8521739130435, 0.35869565217391, 0.055555555555556
64590, 1.895652173913, 0.35869565217391, 0.44444444444444
64591, 1.895652173913, 0.35869565217391, 0.38888888888889
64592, 1.895652173913, 0.35869565217391, 0.33333333333333
64593, 1.895652173913, 0.35869565217391, 0.27777777777778
64594, 1.895652173913, 0.35869565217391, 0.22222222222222
64595, 1.895652173913, 0.35869565217391, 0.16666666666667
64596, 1.895652173913, 0.35869565217391, 0.11111111111111
64597, 1.895652173913, 0.35869565217391, 0.055555555555556
64598, 1.9391304347826, 0.35869565217391, 0.44444444444444
64599, 1.9391304347826, 0.35869565217391, 0.38888888888889
64600, 1.9391304347826, 0.35869565217391, 0.33333333333333
64601, 1.9391304347826, 0.35869565217391, 0.27777777777778
64602, 1.9391304347826, 0.35869565217391, 0.22222222222222
64603, 1.9391304347826, 0.35869565217391, 0.16666666666667
64604, 1.9391304347826, 0.35869565217391, 0.11111111111111
64605, 1.9391304347826, 0.35869565217391, 0.055555555555556
64606, 1.9826086956522, 0.35869565217391, 0.44444444444444
64607, 1.9826086956522, 0.35869565217391, 0.38888888888889
64608, 1.9826086956522, 0.35869565217391, 0.33333333333333
64609, 1.9826086956522, 0.35869565217391, 0.27777777777778
64610, 1.9826086956522, 0.35869565217391, 0.22222222222222
64611, 1.9826086956522, 0.35869565217391, 0.16666666666667
64612, 1.9826086956522, 0.35869565217391, 0.11111111111111
64613, 1.9826086956522, 0.35869565217391, 0.055555555555556
64614, 2.0260869565217, 0.35869565217391, 0.44444444444444
64615, 2.0260869565217, 0.35869565217391, 0.38888888888889
64616, 2.0260869565217, 0.35869565217391, 0.33333333333333
64617, 2.0260869565217, 0.35869565217391, 0.27777777777778
64618, 2.0260869565217, 0.35869565217391, 0.22222222222222
64619, 2.0260869565217, 0.35869565217391, 0.16666666666667
64620, 2.0260869565217, 0.35869565217391, 0.11111111111111
64621, 2.0260869565217, 0.35869565217391, 0.055555555555556
64622, 2.0695652173913, 0.35869565217391, 0.44444444444444
64623, 2.0695652173913, 0.35869565217391, 0.38888888888889
64624, 2.0695652173913, 0.35869565217391, 0.33333333333333
64625, 2.0695652173913, 0.35869565217391, 0.27777777777778
64626, 2.0695652173913, 0.35869565217391, 0.22222222222222
64627, 2.0695652173913, 0.35869565217391, 0.16666666666667
64628, 2.0695652173913, 0.35869565217391, 0.11111111111111
64629, 2.0695652173913, 0.35869565217391, 0.055555555555556
64630, 2.1130434782609, 0.35869565217391, 0.44444444444444
64631, 2.1130434782609, 0.35869565217391, 0.38888888888889
64632, 2.1130434782609, 0.35869565217391, 0.33333333333333
64633, 2.1130434782609, 0.35869565217391, 0.27777777777778
64634, 2.1130434782609, 0.35869565217391, 0.22222222222222
64635, 2.1130434782609, 0.35869565217391, 0.16666666666667
64636, 2.1130434782609, 0.35869565217391, 0.11111111111111
64637, 2.1130434782609, 0.35869565217391, 0.055555555555556
64638, 2.1565217391304, 0.35869565217391, 0.44444444444444
64639, 2.1565217391304, 0.35869565217391, 0.38888888888889
64640, 2.1565217391304, 0.35869565217391, 0.33333333333333
64641, 2.1565217391304, 0.35869565217391, 0.27777777777778
64642, 2.1565217391304, 0.35869565217391, 0.22222222222222
64643, 2.1565217391304, 0.35869565217391, 0.16666666666667
64644, 2.1565217391304, 0.35869565217391, 0.11111111111111
64645, 2.1565217391304, 0.35869565217391, 0.055555555555556
64646, 1.2434782608696, 0.30652173913044, 0.44444444444444
64647, 1.2434782608696, 0.30652173913044, 0.38888888888889
64648, 1.2434782608696, 0.30652173913044, 0.33333333333333
64649, 1.2434782608696, 0.30652173913044, 0.27777777777778
64650, 1.2434782608696, 0.30652173913044, 0.22222222222222
64651, 1.2434782608696, 0.30652173913044, 0.16666666666667
64652, 1.2434782608696, 0.30652173913044, 0.11111111111111
64653, 1.2434782608696, 0.30652173913044, 0.055555555555556
64654, 1.2869565217391, 0.30652173913043, 0.44444444444444
64655, 1.2869565217391, 0.30652173913043, 0.38888888888889
64656, 1.2869565217391, 0.30652173913043, 0.33333333333333
64657, 1.2869565217391, 0.30652173913043, 0.27777777777778
64658, 1.2869565217391, 0.30652173913043, 0.22222222222222
64659, 1.2869565217391, 0.30652173913043, 0.16666666666667
64660, 1.2869565217391, 0.30652173913043, 0.11111111111111
64661, 1.2869565217391, 0.30652173913043, 0.055555555555556
64662, 1.3304347826087, 0.30652173913043, 0.44444444444444
64663, 1.3304347826087, 0.30652173913043, 0.38888888888889
64664, 1.3304347826087, 0.30652173913044, 0.33333333333333
64665, 1.3304347826087, 0.30652173913043, 0.27777777777778
64666, 1.3304347826087, 0.30652173913043, 0.22222222222222
64667, 1.3304347826087, 0.30652173913043, 0.16666666666667
64668, 1.3304347826087, 0.30652173913043, 0.11111111111111
64669, 1.3304347826087, 0.30652173913043, 0.055555555555556
64670, 1.3739130434783, 0.30652173913044, 0.44444444444444
64671, 1.3739130434783, 0.30652173913044, 0.38888888888889
64672, 1.3739130434783, 0.30652173913044, 0.33333333333333
64673, 1.3739130434783, 0.30652173913044, 0.27777777777778
64674, 1.3739130434783, 0.30652173913044, 0.22222222222222
64675, 1.3739130434783, 0.30652173913044, 0.16666666666667
64676, 1.3739130434783, 0.30652173913044, 0.11111111111111
64677, 1.3739130434783, 0.30652173913044, 0.055555555555556
64678, 1.4173913043478, 0.30652173913044, 0.44444444444444
64679, 1.4173913043478, 0.30652173913044, 0.38888888888889
64680, 1.4173913043478, 0.30652173913044, 0.33333333333333
64681, 1.4173913043478, 0.30652173913044, 0.27777777777778
64682, 1.4173913043478, 0.30652173913044, 0.22222222222222
64683, 1.4173913043478, 0.30652173913044, 0.16666666666667
64684, 1.4173913043478, 0.30652173913044, 0.11111111111111
64685, 1.4173913043478, 0.30652173913044, 0.055555555555556
64686, 1.4608695652174, 0.30652173913043, 0.44444444444444
64687, 1.4608695652174, 0.30652173913043, 0.38888888888889
64688, 1.4608695652174, 0.30652173913044, 0.33333333333333
64689, 1.4608695652174, 0.30652173913043, 0.27777777777778
64690, 1.4608695652174, 0.30652173913043, 0.22222222222222
64691, 1.4608695652174, 0.30652173913043, 0.16666666666667
64692, 1.4608695652174, 0.30652173913043, 0.11111111111111
64693, 1.4608695652174, 0.30652173913043, 0.055555555555556
64694, 1.504347826087, 0.30652173913044, 0.44444444444444
64695, 1.504347826087, 0.30652173913044, 0.38888888888889
64696, 1.504347826087, 0.30652173913044, 0.33333333333333
64697, 1.504347826087, 0.30652173913044, 0.27777777777778
64698, 1.504347826087, 0.30652173913044, 0.22222222222222
64699, 1.504347826087, 0.30652173913044, 0.16666666666667
64700, 1.504347826087, 0.30652173913044, 0.11111111111111
64701, 1.504347826087, 0.30652173913044, 0.055555555555556
64702, 1.5478260869565, 0.30652173913044, 0.44444444444444
64703, 1.5478260869565, 0.30652173913044, 0.38888888888889
64704, 1.5478260869565, 0.30652173913044, 0.33333333333333
64705, 1.5478260869565, 0.30652173913044, 0.27777777777778
64706, 1.5478260869565, 0.30652173913044, 0.22222222222222
64707, 1.5478260869565, 0.30652173913044, 0.16666666666667
64708, 1.5478260869565, 0.30652173913044, 0.11111111111111
64709, 1.5478260869565, 0.30652173913044, 0.055555555555556
64710, 1.5913043478261, 0.30652173913044, 0.44444444444444
64711, 1.5913043478261, 0.30652173913044, 0.38888888888889
64712, 1.5913043478261, 0.30652173913044, 0.33333333333333
64713, 1.5913043478261, 0.30652173913044, 0.27777777777778
64714, 1.5913043478261, 0.30652173913044, 0.22222222222222
64715, 1.5913043478261, 0.30652173913044, 0.16666666666667
64716, 1.5913043478261, 0.30652173913043, 0.11111111111111
64717, 1.5913043478261, 0.30652173913044, 0.055555555555556
64718, 1.6347826086957, 0.30652173913043, 0.44444444444444
64719, 1.6347826086957, 0.30652173913043, 0.38888888888889
64720, 1.6347826086957, 0.30652173913044, 0.33333333333333
64721, 1.6347826086957, 0.30652173913043, 0.27777777777778
64722, 1.6347826086957, 0.30652173913043, 0.22222222222222
64723, 1.6347826086957, 0.30652173913043, 0.16666666666667
64724, 1.6347826086957, 0.30652173913043, 0.11111111111111
64725, 1.6347826086957, 0.30652173913043, 0.055555555555556
64726, 1.6782608695652, 0.30652173913043, 0.44444444444444
64727, 1.6782608695652, 0.30652173913043, 0.38888888888889
64728, 1.6782608695652, 0.30652173913044, 0.33333333333333
64729, 1.6782608695652, 0.30652173913043, 0.27777777777778
64730, 1.6782608695652, 0.30652173913043, 0.22222222222222
64731, 1.6782608695652, 0.30652173913043, 0.16666666666667
64732, 1.6782608695652, 0.30652173913043, 0.11111111111111
64733, 1.6782608695652, 0.30652173913043, 0.055555555555556
64734, 1.7217391304348, 0.30652173913043, 0.44444444444444
64735, 1.7217391304348, 0.30652173913043, 0.38888888888889
64736, 1.7217391304348, 0.30652173913044, 0.33333333333333
64737, 1.7217391304348, 0.30652173913043, 0.27777777777778
64738, 1.7217391304348, 0.30652173913043, 0.22222222222222
64739, 1.7217391304348, 0.30652173913043, 0.16666666666667
64740, 1.7217391304348, 0.30652173913043, 0.11111111111111
64741, 1.7217391304348, 0.30652173913043, 0.055555555555556
64742, 1.7652173913043, 0.30652173913043, 0.44444444444444
64743, 1.7652173913043, 0.30652173913043, 0.38888888888889
64744, 1.7652173913043, 0.30652173913044, 0.33333333333333
64745, 1.7652173913043, 0.30652173913043, 0.27777777777778
64746, 1.7652173913043, 0.30652173913043, 0.22222222222222
64747, 1.7652173913043, 0.30652173913043, 0.16666666666667
64748, 1.7652173913043, 0.30652173913043, 0.11111111111111
64749, 1.7652173913043, 0.30652173913043, 0.055555555555556
64750, 1.8086956521739, 0.30652173913044, 0.44444444444444
64751, 1.8086956521739, 0.30652173913044, 0.38888888888889
64752, 1.8086956521739, 0.30652173913044, 0.33333333333333
64753, 1.8086956521739, 0.30652173913044, 0.27777777777778
64754, 1.8086956521739, 0.30652173913044, 0.22222222222222
64755, 1.8086956521739, 0.30652173913044, 0.16666666666667
64756, 1.8086956521739, 0.30652173913044, 0.11111111111111
64757, 1.8086956521739, 0.30652173913044, 0.055555555555556
64758, 1.8521739130435, 0.30652173913043, 0.44444444444444
64759, 1.8521739130435, 0.30652173913043, 0.38888888888889
64760, 1.8521739130435, 0.30652173913043, 0.33333333333333
64761, 1.8521739130435, 0.30652173913043, 0.27777777777778
64762, 1.8521739130435, 0.30652173913043, 0.22222222222222
64763, 1.8521739130435, 0.30652173913043, 0.16666666666667
64764, 1.8521739130435, 0.30652173913043, 0.11111111111111
64765, 1.8521739130435, 0.30652173913043, 0.055555555555556
64766, 1.895652173913, 0.30652173913044, 0.44444444444444
64767, 1.895652173913, 0.30652173913044, 0.38888888888889
64768, 1.895652173913, 0.30652173913044, 0.33333333333333
64769, 1.895652173913, 0.30652173913044, 0.27777777777778
64770, 1.895652173913, 0.30652173913044, 0.22222222222222
64771, 1.895652173913, 0.30652173913044, 0.16666666666667
64772, 1.895652173913, 0.30652173913044, 0.11111111111111
64773, 1.895652173913, 0.30652173913044, 0.055555555555556
64774, 1.9391304347826, 0.30652173913043, 0.44444444444444
64775, 1.9391304347826, 0.30652173913043, 0.38888888888889
64776, 1.9391304347826, 0.30652173913044, 0.33333333333333
64777, 1.9391304347826, 0.30652173913043, 0.27777777777778
64778, 1.9391304347826, 0.30652173913043, 0.22222222222222
64779, 1.9391304347826, 0.30652173913043, 0.16666666666667
64780, 1.9391304347826, 0.30652173913043, 0.11111111111111
64781, 1.9391304347826, 0.30652173913043, 0.055555555555556
64782, 1.9826086956522, 0.30652173913044, 0.44444444444444
64783, 1.9826086956522, 0.30652173913044, 0.38888888888889
64784, 1.9826086956522, 0.30652173913044, 0.33333333333333
64785, 1.9826086956522, 0.30652173913044, 0.27777777777778
64786, 1.9826086956522, 0.30652173913044, 0.22222222222222
64787, 1.9826086956522, 0.30652173913044, 0.16666666666667
64788, 1.9826086956522, 0.30652173913044, 0.11111111111111
64789, 1.9826086956522, 0.30652173913044, 0.055555555555556
64790, 2.0260869565217, 0.30652173913044, 0.44444444444444
64791, 2.0260869565217, 0.30652173913044, 0.38888888888889
64792, 2.0260869565217, 0.30652173913044, 0.33333333333333
64793, 2.0260869565217, 0.30652173913044, 0.27777777777778
64794, 2.0260869565217, 0.30652173913044, 0.22222222222222
64795, 2.0260869565217, 0.30652173913044, 0.16666666666667
64796, 2.0260869565217, 0.30652173913044, 0.11111111111111
64797, 2.0260869565217, 0.30652173913044, 0.055555555555556
64798, 2.0695652173913, 0.30652173913043, 0.44444444444444
64799, 2.0695652173913, 0.30652173913043, 0.38888888888889
64800, 2.0695652173913, 0.30652173913044, 0.33333333333333
64801, 2.0695652173913, 0.30652173913043, 0.27777777777778
64802, 2.0695652173913, 0.30652173913043, 0.22222222222222
64803, 2.0695652173913, 0.30652173913043, 0.16666666666667
64804, 2.0695652173913, 0.30652173913043, 0.11111111111111
64805, 2.0695652173913, 0.30652173913043, 0.055555555555556
64806, 2.1130434782609, 0.30652173913043, 0.44444444444444
64807, 2.1130434782609, 0.30652173913043, 0.38888888888889
64808, 2.1130434782609, 0.30652173913044, 0.33333333333333
64809, 2.1130434782609, 0.30652173913043, 0.27777777777778
64810, 2.1130434782609, 0.30652173913043, 0.22222222222222
64811, 2.1130434782609, 0.30652173913043, 0.16666666666667
64812, 2.1130434782609, 0.30652173913043, 0.11111111111111
64813, 2.1130434782609, 0.30652173913043, 0.055555555555556
64814, 2.1565217391304, 0.30652173913044, 0.44444444444444
64815, 2.1565217391304, 0.30652173913043, 0.38888888888889
64816, 2.1565217391304, 0.30652173913044, 0.33333333333333
64817, 2.1565217391304, 0.30652173913043, 0.27777777777778
64818, 2.1565217391304, 0.30652173913043, 0.22222222222222
64819, 2.1565217391304, 0.30652173913043, 0.16666666666667
64820, 2.1565217391304, 0.30652173913043, 0.11111111111111
64821, 2.1565217391304, 0.30652173913043, 0.055555555555556
64822, 1.2434782608696, 0.25434782608696, 0.44444444444444
64823, 1.2434782608696, 0.25434782608696, 0.38888888888889
64824, 1.2434782608696, 0.25434782608696, 0.33333333333333
64825, 1.2434782608696, 0.25434782608696, 0.27777777777778
64826, 1.2434782608696, 0.25434782608696, 0.22222222222222
64827, 1.2434782608696, 0.25434782608696, 0.16666666666667
64828, 1.2434782608696, 0.25434782608696, 0.11111111111111
64829, 1.2434782608696, 0.25434782608696, 0.055555555555556
64830, 1.2869565217391, 0.25434782608696, 0.44444444444444
64831, 1.2869565217391, 0.25434782608696, 0.38888888888889
64832, 1.2869565217391, 0.25434782608696, 0.33333333333333
64833, 1.2869565217391, 0.25434782608696, 0.27777777777778
64834, 1.2869565217391, 0.25434782608696, 0.22222222222222
64835, 1.2869565217391, 0.25434782608696, 0.16666666666667
64836, 1.2869565217391, 0.25434782608696, 0.11111111111111
64837, 1.2869565217391, 0.25434782608696, 0.055555555555556
64838, 1.3304347826087, 0.25434782608696, 0.44444444444444
64839, 1.3304347826087, 0.25434782608696, 0.38888888888889
64840, 1.3304347826087, 0.25434782608696, 0.33333333333333
64841, 1.3304347826087, 0.25434782608696, 0.27777777777778
64842, 1.3304347826087, 0.25434782608696, 0.22222222222222
64843, 1.3304347826087, 0.25434782608696, 0.16666666666667
64844, 1.3304347826087, 0.25434782608696, 0.11111111111111
64845, 1.3304347826087, 0.25434782608696, 0.055555555555556
64846, 1.3739130434783, 0.25434782608696, 0.44444444444444
64847, 1.3739130434783, 0.25434782608696, 0.38888888888889
64848, 1.3739130434783, 0.25434782608696, 0.33333333333333
64849, 1.3739130434783, 0.25434782608696, 0.27777777777778
64850, 1.3739130434783, 0.25434782608696, 0.22222222222222
64851, 1.3739130434783, 0.25434782608696, 0.16666666666667
64852, 1.3739130434783, 0.25434782608696, 0.11111111111111
64853, 1.3739130434783, 0.25434782608696, 0.055555555555556
64854, 1.4173913043478, 0.25434782608696, 0.44444444444444
64855, 1.4173913043478, 0.25434782608696, 0.38888888888889
64856, 1.4173913043478, 0.25434782608696, 0.33333333333333
64857, 1.4173913043478, 0.25434782608696, 0.27777777777778
64858, 1.4173913043478, 0.25434782608696, 0.22222222222222
64859, 1.4173913043478, 0.25434782608696, 0.16666666666667
64860, 1.4173913043478, 0.25434782608696, 0.11111111111111
64861, 1.4173913043478, 0.25434782608696, 0.055555555555556
64862, 1.4608695652174, 0.25434782608696, 0.44444444444444
64863, 1.4608695652174, 0.25434782608696, 0.38888888888889
64864, 1.4608695652174, 0.25434782608696, 0.33333333333333
64865, 1.4608695652174, 0.25434782608696, 0.27777777777778
64866, 1.4608695652174, 0.25434782608696, 0.22222222222222
64867, 1.4608695652174, 0.25434782608696, 0.16666666666667
64868, 1.4608695652174, 0.25434782608696, 0.11111111111111
64869, 1.4608695652174, 0.25434782608696, 0.055555555555556
64870, 1.504347826087, 0.25434782608696, 0.44444444444444
64871, 1.504347826087, 0.25434782608696, 0.38888888888889
64872, 1.504347826087, 0.25434782608696, 0.33333333333333
64873, 1.504347826087, 0.25434782608696, 0.27777777777778
64874, 1.504347826087, 0.25434782608696, 0.22222222222222
64875, 1.504347826087, 0.25434782608696, 0.16666666666667
64876, 1.504347826087, 0.25434782608696, 0.11111111111111
64877, 1.504347826087, 0.25434782608696, 0.055555555555556
64878, 1.5478260869565, 0.25434782608696, 0.44444444444444
64879, 1.5478260869565, 0.25434782608696, 0.38888888888889
64880, 1.5478260869565, 0.25434782608696, 0.33333333333333
64881, 1.5478260869565, 0.25434782608696, 0.27777777777778
64882, 1.5478260869565, 0.25434782608696, 0.22222222222222
64883, 1.5478260869565, 0.25434782608696, 0.16666666666667
64884, 1.5478260869565, 0.25434782608696, 0.11111111111111
64885, 1.5478260869565, 0.25434782608696, 0.055555555555556
64886, 1.5913043478261, 0.25434782608696, 0.44444444444444
64887, 1.5913043478261, 0.25434782608696, 0.38888888888889
64888, 1.5913043478261, 0.25434782608696, 0.33333333333333
64889, 1.5913043478261, 0.25434782608696, 0.27777777777778
64890, 1.5913043478261, 0.25434782608696, 0.22222222222222
64891, 1.5913043478261, 0.25434782608696, 0.16666666666667
64892, 1.5913043478261, 0.25434782608696, 0.11111111111111
64893, 1.5913043478261, 0.25434782608696, 0.055555555555556
64894, 1.6347826086957, 0.25434782608696, 0.44444444444444
64895, 1.6347826086957, 0.25434782608696, 0.38888888888889
64896, 1.6347826086957, 0.25434782608696, 0.33333333333333
64897, 1.6347826086957, 0.25434782608696, 0.27777777777778
64898, 1.6347826086957, 0.25434782608696, 0.22222222222222
64899, 1.6347826086957, 0.25434782608696, 0.16666666666667
64900, 1.6347826086957, 0.25434782608696, 0.11111111111111
64901, 1.6347826086957, 0.25434782608696, 0.055555555555556
64902, 1.6782608695652, 0.25434782608696, 0.44444444444444
64903, 1.6782608695652, 0.25434782608696, 0.38888888888889
64904, 1.6782608695652, 0.25434782608696, 0.33333333333333
64905, 1.6782608695652, 0.25434782608696, 0.27777777777778
64906, 1.6782608695652, 0.25434782608696, 0.22222222222222
64907, 1.6782608695652, 0.25434782608696, 0.16666666666667
64908, 1.6782608695652, 0.25434782608696, 0.11111111111111
64909, 1.6782608695652, 0.25434782608696, 0.055555555555556
64910, 1.7217391304348, 0.25434782608696, 0.44444444444444
64911, 1.7217391304348, 0.25434782608696, 0.38888888888889
64912, 1.7217391304348, 0.25434782608696, 0.33333333333333
64913, 1.7217391304348, 0.25434782608696, 0.27777777777778
64914, 1.7217391304348, 0.25434782608696, 0.22222222222222
64915, 1.7217391304348, 0.25434782608696, 0.16666666666667
64916, 1.7217391304348, 0.25434782608696, 0.11111111111111
64917, 1.7217391304348, 0.25434782608696, 0.055555555555556
64918, 1.7652173913043, 0.25434782608696, 0.44444444444444
64919, 1.7652173913043, 0.25434782608696, 0.38888888888889
64920, 1.7652173913043, 0.25434782608696, 0.33333333333333
64921, 1.7652173913043, 0.25434782608696, 0.27777777777778
64922, 1.7652173913043, 0.25434782608696, 0.22222222222222
64923, 1.7652173913043, 0.25434782608696, 0.16666666666667
64924, 1.7652173913043, 0.25434782608696, 0.11111111111111
64925, 1.7652173913043, 0.25434782608696, 0.055555555555556
64926, 1.8086956521739, 0.25434782608696, 0.44444444444444
64927, 1.8086956521739, 0.25434782608696, 0.38888888888889
64928, 1.8086956521739, 0.25434782608696, 0.33333333333333
64929, 1.8086956521739, 0.25434782608696, 0.27777777777778
64930, 1.8086956521739, 0.25434782608696, 0.22222222222222
64931, 1.8086956521739, 0.25434782608696, 0.16666666666667
64932, 1.8086956521739, 0.25434782608696, 0.11111111111111
64933, 1.8086956521739, 0.25434782608696, 0.055555555555556
64934, 1.8521739130435, 0.25434782608696, 0.44444444444444
64935, 1.8521739130435, 0.25434782608696, 0.38888888888889
64936, 1.8521739130435, 0.25434782608696, 0.33333333333333
64937, 1.8521739130435, 0.25434782608696, 0.27777777777778
64938, 1.8521739130435, 0.25434782608696, 0.22222222222222
64939, 1.8521739130435, 0.25434782608696, 0.16666666666667
64940, 1.8521739130435, 0.25434782608696, 0.11111111111111
64941, 1.8521739130435, 0.25434782608696, 0.055555555555556
64942, 1.895652173913, 0.25434782608696, 0.44444444444444
64943, 1.895652173913, 0.25434782608696, 0.38888888888889
64944, 1.895652173913, 0.25434782608696, 0.33333333333333
64945, 1.895652173913, 0.25434782608696, 0.27777777777778
64946, 1.895652173913, 0.25434782608696, 0.22222222222222
64947, 1.895652173913, 0.25434782608696, 0.16666666666667
64948, 1.895652173913, 0.25434782608696, 0.11111111111111
64949, 1.895652173913, 0.25434782608696, 0.055555555555556
64950, 1.9391304347826, 0.25434782608696, 0.44444444444444
64951, 1.9391304347826, 0.25434782608696, 0.38888888888889
64952, 1.9391304347826, 0.25434782608696, 0.33333333333333
64953, 1.9391304347826, 0.25434782608696, 0.27777777777778
64954, 1.9391304347826, 0.25434782608696, 0.22222222222222
64955, 1.9391304347826, 0.25434782608696, 0.16666666666667
64956, 1.9391304347826, 0.25434782608696, 0.11111111111111
64957, 1.9391304347826, 0.25434782608696, 0.055555555555556
64958, 1.9826086956522, 0.25434782608696, 0.44444444444444
64959, 1.9826086956522, 0.25434782608696, 0.38888888888889
64960, 1.9826086956522, 0.25434782608696, 0.33333333333333
64961, 1.9826086956522, 0.25434782608696, 0.27777777777778
64962, 1.9826086956522, 0.25434782608696, 0.22222222222222
64963, 1.9826086956522, 0.25434782608696, 0.16666666666667
64964, 1.9826086956522, 0.25434782608696, 0.11111111111111
64965, 1.9826086956522, 0.25434782608696, 0.055555555555556
64966, 2.0260869565217, 0.25434782608696, 0.44444444444444
64967, 2.0260869565217, 0.25434782608696, 0.38888888888889
64968, 2.0260869565217, 0.25434782608696, 0.33333333333333
64969, 2.0260869565217, 0.25434782608696, 0.27777777777778
64970, 2.0260869565217, 0.25434782608696, 0.22222222222222
64971, 2.0260869565217, 0.25434782608696, 0.16666666666667
64972, 2.0260869565217, 0.25434782608696, 0.11111111111111
64973, 2.0260869565217, 0.25434782608696, 0.055555555555556
64974, 2.0695652173913, 0.25434782608696, 0.44444444444444
64975, 2.0695652173913, 0.25434782608696, 0.38888888888889
64976, 2.0695652173913, 0.25434782608696, 0.33333333333333
64977, 2.0695652173913, 0.25434782608696, 0.27777777777778
64978, 2.0695652173913, 0.25434782608696, 0.22222222222222
64979, 2.0695652173913, 0.25434782608696, 0.16666666666667
64980, 2.0695652173913, 0.25434782608696, 0.11111111111111
64981, 2.0695652173913, 0.25434782608696, 0.055555555555556
64982, 2.1130434782609, 0.25434782608696, 0.44444444444444
64983, 2.1130434782609, 0.25434782608696, 0.38888888888889
64984, 2.1130434782609, 0.25434782608696, 0.33333333333333
64985, 2.1130434782609, 0.25434782608696, 0.27777777777778
64986, 2.1130434782609, 0.25434782608696, 0.22222222222222
64987, 2.1130434782609, 0.25434782608696, 0.16666666666667
64988, 2.1130434782609, 0.25434782608696, 0.11111111111111
64989, 2.1130434782609, 0.25434782608696, 0.055555555555556
64990, 2.1565217391304, 0.25434782608696, 0.44444444444444
64991, 2.1565217391304, 0.25434782608696, 0.38888888888889
64992, 2.1565217391304, 0.25434782608696, 0.33333333333333
64993, 2.1565217391304, 0.25434782608696, 0.27777777777778
64994, 2.1565217391304, 0.25434782608696, 0.22222222222222
64995, 2.1565217391304, 0.25434782608696, 0.16666666666667
64996, 2.1565217391304, 0.25434782608696, 0.11111111111111
64997, 2.1565217391304, 0.25434782608696, 0.055555555555556
64998, 1.2434782608696, 0.20217391304348, 0.44444444444444
64999, 1.2434782608696, 0.20217391304348, 0.38888888888889
65000, 1.2434782608696, 0.20217391304348, 0.33333333333333
65001, 1.2434782608696, 0.20217391304348, 0.27777777777778
65002, 1.2434782608696, 0.20217391304348, 0.22222222222222
65003, 1.2434782608696, 0.20217391304348, 0.16666666666667
65004, 1.2434782608696, 0.20217391304348, 0.11111111111111
65005, 1.2434782608696, 0.20217391304348, 0.055555555555556
65006, 1.2869565217391, 0.20217391304348, 0.44444444444444
65007, 1.2869565217391, 0.20217391304348, 0.38888888888889
65008, 1.2869565217391, 0.20217391304348, 0.33333333333333
65009, 1.2869565217391, 0.20217391304348, 0.27777777777778
65010, 1.2869565217391, 0.20217391304348, 0.22222222222222
65011, 1.2869565217391, 0.20217391304348, 0.16666666666667
65012, 1.2869565217391, 0.20217391304348, 0.11111111111111
65013, 1.2869565217391, 0.20217391304348, 0.055555555555556
65014, 1.3304347826087, 0.20217391304348, 0.44444444444444
65015, 1.3304347826087, 0.20217391304348, 0.38888888888889
65016, 1.3304347826087, 0.20217391304348, 0.33333333333333
65017, 1.3304347826087, 0.20217391304348, 0.27777777777778
65018, 1.3304347826087, 0.20217391304348, 0.22222222222222
65019, 1.3304347826087, 0.20217391304348, 0.16666666666667
65020, 1.3304347826087, 0.20217391304348, 0.11111111111111
65021, 1.3304347826087, 0.20217391304348, 0.055555555555556
65022, 1.3739130434783, 0.20217391304348, 0.44444444444444
65023, 1.3739130434783, 0.20217391304348, 0.38888888888889
65024, 1.3739130434783, 0.20217391304348, 0.33333333333333
65025, 1.3739130434783, 0.20217391304348, 0.27777777777778
65026, 1.3739130434783, 0.20217391304348, 0.22222222222222
65027, 1.3739130434783, 0.20217391304348, 0.16666666666667
65028, 1.3739130434783, 0.20217391304348, 0.11111111111111
65029, 1.3739130434783, 0.20217391304348, 0.055555555555556
65030, 1.4173913043478, 0.20217391304348, 0.44444444444444
65031, 1.4173913043478, 0.20217391304348, 0.38888888888889
65032, 1.4173913043478, 0.20217391304348, 0.33333333333333
65033, 1.4173913043478, 0.20217391304348, 0.27777777777778
65034, 1.4173913043478, 0.20217391304348, 0.22222222222222
65035, 1.4173913043478, 0.20217391304348, 0.16666666666667
65036, 1.4173913043478, 0.20217391304348, 0.11111111111111
65037, 1.4173913043478, 0.20217391304348, 0.055555555555556
65038, 1.4608695652174, 0.20217391304348, 0.44444444444444
65039, 1.4608695652174, 0.20217391304348, 0.38888888888889
65040, 1.4608695652174, 0.20217391304348, 0.33333333333333
65041, 1.4608695652174, 0.20217391304348, 0.27777777777778
65042, 1.4608695652174, 0.20217391304348, 0.22222222222222
65043, 1.4608695652174, 0.20217391304348, 0.16666666666667
65044, 1.4608695652174, 0.20217391304348, 0.11111111111111
65045, 1.4608695652174, 0.20217391304348, 0.055555555555556
65046, 1.504347826087, 0.20217391304348, 0.44444444444444
65047, 1.504347826087, 0.20217391304348, 0.38888888888889
65048, 1.504347826087, 0.20217391304348, 0.33333333333333
65049, 1.504347826087, 0.20217391304348, 0.27777777777778
65050, 1.504347826087, 0.20217391304348, 0.22222222222222
65051, 1.504347826087, 0.20217391304348, 0.16666666666667
65052, 1.504347826087, 0.20217391304348, 0.11111111111111
65053, 1.504347826087, 0.20217391304348, 0.055555555555556
65054, 1.5478260869565, 0.20217391304348, 0.44444444444444
65055, 1.5478260869565, 0.20217391304348, 0.38888888888889
65056, 1.5478260869565, 0.20217391304348, 0.33333333333333
65057, 1.5478260869565, 0.20217391304348, 0.27777777777778
65058, 1.5478260869565, 0.20217391304348, 0.22222222222222
65059, 1.5478260869565, 0.20217391304348, 0.16666666666667
65060, 1.5478260869565, 0.20217391304348, 0.11111111111111
65061, 1.5478260869565, 0.20217391304348, 0.055555555555556
65062, 1.5913043478261, 0.20217391304348, 0.44444444444444
65063, 1.5913043478261, 0.20217391304348, 0.38888888888889
65064, 1.5913043478261, 0.20217391304348, 0.33333333333333
65065, 1.5913043478261, 0.20217391304348, 0.27777777777778
65066, 1.5913043478261, 0.20217391304348, 0.22222222222222
65067, 1.5913043478261, 0.20217391304348, 0.16666666666667
65068, 1.5913043478261, 0.20217391304348, 0.11111111111111
65069, 1.5913043478261, 0.20217391304348, 0.055555555555556
65070, 1.6347826086957, 0.20217391304348, 0.44444444444444
65071, 1.6347826086957, 0.20217391304348, 0.38888888888889
65072, 1.6347826086957, 0.20217391304348, 0.33333333333333
65073, 1.6347826086957, 0.20217391304348, 0.27777777777778
65074, 1.6347826086957, 0.20217391304348, 0.22222222222222
65075, 1.6347826086957, 0.20217391304348, 0.16666666666667
65076, 1.6347826086957, 0.20217391304348, 0.11111111111111
65077, 1.6347826086957, 0.20217391304348, 0.055555555555556
65078, 1.6782608695652, 0.20217391304348, 0.44444444444444
65079, 1.6782608695652, 0.20217391304348, 0.38888888888889
65080, 1.6782608695652, 0.20217391304348, 0.33333333333333
65081, 1.6782608695652, 0.20217391304348, 0.27777777777778
65082, 1.6782608695652, 0.20217391304348, 0.22222222222222
65083, 1.6782608695652, 0.20217391304348, 0.16666666666667
65084, 1.6782608695652, 0.20217391304348, 0.11111111111111
65085, 1.6782608695652, 0.20217391304348, 0.055555555555556
65086, 1.7217391304348, 0.20217391304348, 0.44444444444444
65087, 1.7217391304348, 0.20217391304348, 0.38888888888889
65088, 1.7217391304348, 0.20217391304348, 0.33333333333333
65089, 1.7217391304348, 0.20217391304348, 0.27777777777778
65090, 1.7217391304348, 0.20217391304348, 0.22222222222222
65091, 1.7217391304348, 0.20217391304348, 0.16666666666667
65092, 1.7217391304348, 0.20217391304348, 0.11111111111111
65093, 1.7217391304348, 0.20217391304348, 0.055555555555556
65094, 1.7652173913043, 0.20217391304348, 0.44444444444444
65095, 1.7652173913043, 0.20217391304348, 0.38888888888889
65096, 1.7652173913043, 0.20217391304348, 0.33333333333333
65097, 1.7652173913043, 0.20217391304348, 0.27777777777778
65098, 1.7652173913043, 0.20217391304348, 0.22222222222222
65099, 1.7652173913043, 0.20217391304348, 0.16666666666667
65100, 1.7652173913043, 0.20217391304348, 0.11111111111111
65101, 1.7652173913043, 0.20217391304348, 0.055555555555556
65102, 1.8086956521739, 0.20217391304348, 0.44444444444444
65103, 1.8086956521739, 0.20217391304348, 0.38888888888889
65104, 1.8086956521739, 0.20217391304348, 0.33333333333333
65105, 1.8086956521739, 0.20217391304348, 0.27777777777778
65106, 1.8086956521739, 0.20217391304348, 0.22222222222222
65107, 1.8086956521739, 0.20217391304348, 0.16666666666667
65108, 1.8086956521739, 0.20217391304348, 0.11111111111111
65109, 1.8086956521739, 0.20217391304348, 0.055555555555556
65110, 1.8521739130435, 0.20217391304348, 0.44444444444444
65111, 1.8521739130435, 0.20217391304348, 0.38888888888889
65112, 1.8521739130435, 0.20217391304348, 0.33333333333333
65113, 1.8521739130435, 0.20217391304348, 0.27777777777778
65114, 1.8521739130435, 0.20217391304348, 0.22222222222222
65115, 1.8521739130435, 0.20217391304348, 0.16666666666667
65116, 1.8521739130435, 0.20217391304348, 0.11111111111111
65117, 1.8521739130435, 0.20217391304348, 0.055555555555556
65118, 1.895652173913, 0.20217391304348, 0.44444444444444
65119, 1.895652173913, 0.20217391304348, 0.38888888888889
65120, 1.895652173913, 0.20217391304348, 0.33333333333333
65121, 1.895652173913, 0.20217391304348, 0.27777777777778
65122, 1.895652173913, 0.20217391304348, 0.22222222222222
65123, 1.895652173913, 0.20217391304348, 0.16666666666667
65124, 1.895652173913, 0.20217391304348, 0.11111111111111
65125, 1.895652173913, 0.20217391304348, 0.055555555555556
65126, 1.9391304347826, 0.20217391304348, 0.44444444444444
65127, 1.9391304347826, 0.20217391304348, 0.38888888888889
65128, 1.9391304347826, 0.20217391304348, 0.33333333333333
65129, 1.9391304347826, 0.20217391304348, 0.27777777777778
65130, 1.9391304347826, 0.20217391304348, 0.22222222222222
65131, 1.9391304347826, 0.20217391304348, 0.16666666666667
65132, 1.9391304347826, 0.20217391304348, 0.11111111111111
65133, 1.9391304347826, 0.20217391304348, 0.055555555555556
65134, 1.9826086956522, 0.20217391304348, 0.44444444444444
65135, 1.9826086956522, 0.20217391304348, 0.38888888888889
65136, 1.9826086956522, 0.20217391304348, 0.33333333333333
65137, 1.9826086956522, 0.20217391304348, 0.27777777777778
65138, 1.9826086956522, 0.20217391304348, 0.22222222222222
65139, 1.9826086956522, 0.20217391304348, 0.16666666666667
65140, 1.9826086956522, 0.20217391304348, 0.11111111111111
65141, 1.9826086956522, 0.20217391304348, 0.055555555555556
65142, 2.0260869565217, 0.20217391304348, 0.44444444444444
65143, 2.0260869565217, 0.20217391304348, 0.38888888888889
65144, 2.0260869565217, 0.20217391304348, 0.33333333333333
65145, 2.0260869565217, 0.20217391304348, 0.27777777777778
65146, 2.0260869565217, 0.20217391304348, 0.22222222222222
65147, 2.0260869565217, 0.20217391304348, 0.16666666666667
65148, 2.0260869565217, 0.20217391304348, 0.11111111111111
65149, 2.0260869565217, 0.20217391304348, 0.055555555555556
65150, 2.0695652173913, 0.20217391304348, 0.44444444444444
65151, 2.0695652173913, 0.20217391304348, 0.38888888888889
65152, 2.0695652173913, 0.20217391304348, 0.33333333333333
65153, 2.0695652173913, 0.20217391304348, 0.27777777777778
65154, 2.0695652173913, 0.20217391304348, 0.22222222222222
65155, 2.0695652173913, 0.20217391304348, 0.16666666666667
65156, 2.0695652173913, 0.20217391304348, 0.11111111111111
65157, 2.0695652173913, 0.20217391304348, 0.055555555555556
65158, 2.1130434782609, 0.20217391304348, 0.44444444444444
65159, 2.1130434782609, 0.20217391304348, 0.38888888888889
65160, 2.1130434782609, 0.20217391304348, 0.33333333333333
65161, 2.1130434782609, 0.20217391304348, 0.27777777777778
65162, 2.1130434782609, 0.20217391304348, 0.22222222222222
65163, 2.1130434782609, 0.20217391304348, 0.16666666666667
65164, 2.1130434782609, 0.20217391304348, 0.11111111111111
65165, 2.1130434782609, 0.20217391304348, 0.055555555555556
65166, 2.1565217391304, 0.20217391304348, 0.44444444444444
65167, 2.1565217391304, 0.20217391304348, 0.38888888888889
65168, 2.1565217391304, 0.20217391304348, 0.33333333333333
65169, 2.1565217391304, 0.20217391304348, 0.27777777777778
65170, 2.1565217391304, 0.20217391304348, 0.22222222222222
65171, 2.1565217391304, 0.20217391304348, 0.16666666666667
65172, 2.1565217391304, 0.20217391304348, 0.11111111111111
65173, 2.1565217391304, 0.20217391304348, 0.055555555555556
65174, 1.2434782608696, 1.2978260869565, 0.47222222222222
65175, 1.2217391304348, 1.2978260869565, 0.44444444444444
65176, 1.2434782608696, 1.3239130434783, 0.44444444444444
65177, 1.2434782608696, 1.2978260869565, 0.41666666666667
65178, 1.2217391304348, 1.2978260869565, 0.38888888888889
65179, 1.2434782608696, 1.3239130434783, 0.38888888888889
65180, 1.2434782608696, 1.2978260869565, 0.36111111111111
65181, 1.2217391304348, 1.2978260869565, 0.33333333333333
65182, 1.2434782608696, 1.3239130434783, 0.33333333333333
65183, 1.2434782608696, 1.2978260869565, 0.30555555555556
65184, 1.2217391304348, 1.2978260869565, 0.27777777777778
65185, 1.2434782608696, 1.3239130434783, 0.27777777777778
65186, 1.2434782608696, 1.2978260869565, 0.25
65187, 1.2217391304348, 1.2978260869565, 0.22222222222222
65188, 1.2434782608696, 1.3239130434783, 0.22222222222222
65189, 1.2434782608696, 1.2978260869565, 0.19444444444444
65190, 1.2217391304348, 1.2978260869565, 0.16666666666667
65191, 1.2434782608696, 1.3239130434783, 0.16666666666667
65192, 1.2434782608696, 1.2978260869565, 0.13888888888889
65193, 1.2217391304348, 1.2978260869565, 0.11111111111111
65194, 1.2434782608696, 1.3239130434783, 0.11111111111111
65195, 1.2434782608696, 1.2978260869565, 0.083333333333333
65196, 1.2217391304348, 1.2978260869565, 0.055555555555556
65197, 1.2434782608696, 1.3239130434783, 0.055555555555556
65198, 1.2434782608696, 1.2978260869565, 0.027777777777778
65199, 1.2869565217391, 1.2978260869565, 0.47222222222222
65200, 1.2652173913043, 1.2978260869565, 0.44444444444444
65201, 1.2869565217391, 1.3239130434783, 0.44444444444444
65202, 1.2869565217391, 1.2978260869565, 0.41666666666667
65203, 1.2652173913043, 1.2978260869565, 0.38888888888889
65204, 1.2869565217391, 1.3239130434783, 0.38888888888889
65205, 1.2869565217391, 1.2978260869565, 0.36111111111111
65206, 1.2652173913043, 1.2978260869565, 0.33333333333333
65207, 1.2869565217391, 1.3239130434783, 0.33333333333333
65208, 1.2869565217391, 1.2978260869565, 0.30555555555556
65209, 1.2652173913043, 1.2978260869565, 0.27777777777778
65210, 1.2869565217391, 1.3239130434783, 0.27777777777778
65211, 1.2869565217391, 1.2978260869565, 0.25
65212, 1.2652173913043, 1.2978260869565, 0.22222222222222
65213, 1.2869565217391, 1.3239130434783, 0.22222222222222
65214, 1.2869565217391, 1.2978260869565, 0.19444444444444
65215, 1.2652173913043, 1.2978260869565, 0.16666666666667
65216, 1.2869565217391, 1.3239130434783, 0.16666666666667
65217, 1.2869565217391, 1.2978260869565, 0.13888888888889
65218, 1.2652173913043, 1.2978260869565, 0.11111111111111
65219, 1.2869565217391, 1.3239130434783, 0.11111111111111
65220, 1.2869565217391, 1.2978260869565, 0.083333333333333
65221, 1.2652173913043, 1.2978260869565, 0.055555555555556
65222, 1.2869565217391, 1.3239130434783, 0.055555555555556
65223, 1.2869565217391, 1.2978260869565, 0.027777777777778
65224, 1.3304347826087, 1.2978260869565, 0.47222222222222
65225, 1.3086956521739, 1.2978260869565, 0.44444444444444
65226, 1.3304347826087, 1.3239130434783, 0.44444444444444
65227, 1.3304347826087, 1.2978260869565, 0.41666666666667
65228, 1.3086956521739, 1.2978260869565, 0.38888888888889
65229, 1.3304347826087, 1.3239130434783, 0.38888888888889
65230, 1.3304347826087, 1.2978260869565, 0.36111111111111
65231, 1.3086956521739, 1.2978260869565, 0.33333333333333
65232, 1.3304347826087, 1.3239130434783, 0.33333333333333
65233, 1.3304347826087, 1.2978260869565, 0.30555555555556
65234, 1.3086956521739, 1.2978260869565, 0.27777777777778
65235, 1.3304347826087, 1.3239130434783, 0.27777777777778
65236, 1.3304347826087, 1.2978260869565, 0.25
65237, 1.3086956521739, 1.2978260869565, 0.22222222222222
65238, 1.3304347826087, 1.3239130434783, 0.22222222222222
65239, 1.3304347826087, 1.2978260869565, 0.19444444444444
65240, 1.3086956521739, 1.2978260869565, 0.16666666666667
65241, 1.3304347826087, 1.3239130434783, 0.16666666666667
65242, 1.3304347826087, 1.2978260869565, 0.13888888888889
65243, 1.3086956521739, 1.2978260869565, 0.11111111111111
65244, 1.3304347826087, 1.3239130434783, 0.11111111111111
65245, 1.3304347826087, 1.2978260869565, 0.083333333333333
65246, 1.3086956521739, 1.2978260869565, 0.055555555555556
65247, 1.3304347826087, 1.3239130434783, 0.055555555555556
65248, 1.3304347826087, 1.2978260869565, 0.027777777777778
65249, 1.3739130434783, 1.2978260869565, 0.47222222222222
65250, 1.3521739130435, 1.2978260869565, 0.44444444444444
65251, 1.3739130434783, 1.3239130434783, 0.44444444444444
65252, 1.3739130434783, 1.2978260869565, 0.41666666666667
65253, 1.3521739130435, 1.2978260869565, 0.38888888888889
65254, 1.3739130434783, 1.3239130434783, 0.38888888888889
65255, 1.3739130434783, 1.2978260869565, 0.36111111111111
65256, 1.3521739130435, 1.2978260869565, 0.33333333333333
65257, 1.3739130434783, 1.3239130434783, 0.33333333333333
65258, 1.3739130434783, 1.2978260869565, 0.30555555555556
65259, 1.3521739130435, 1.2978260869565, 0.27777777777778
65260, 1.3739130434783, 1.3239130434783, 0.27777777777778
65261, 1.3739130434783, 1.2978260869565, 0.25
65262, 1.3521739130435, 1.2978260869565, 0.22222222222222
65263, 1.3739130434783, 1.3239130434783, 0.22222222222222
65264, 1.3739130434783, 1.2978260869565, 0.19444444444444
65265, 1.3521739130435, 1.2978260869565, 0.16666666666667
65266, 1.3739130434783, 1.3239130434783, 0.16666666666667
65267, 1.3739130434783, 1.2978260869565, 0.13888888888889
65268, 1.3521739130435, 1.2978260869565, 0.11111111111111
65269, 1.3739130434783, 1.3239130434783, 0.11111111111111
65270, 1.3739130434783, 1.2978260869565, 0.083333333333333
65271, 1.3521739130435, 1.2978260869565, 0.055555555555556
65272, 1.3739130434783, 1.3239130434783, 0.055555555555556
65273, 1.3739130434783, 1.2978260869565, 0.027777777777778
65274, 1.4173913043478, 1.2978260869565, 0.47222222222222
65275, 1.395652173913, 1.2978260869565, 0.44444444444444
65276, 1.4173913043478, 1.3239130434783, 0.44444444444444
65277, 1.4173913043478, 1.2978260869565, 0.41666666666667
65278, 1.395652173913, 1.2978260869565, 0.38888888888889
65279, 1.4173913043478, 1.3239130434783, 0.38888888888889
65280, 1.4173913043478, 1.2978260869565, 0.36111111111111
65281, 1.395652173913, 1.2978260869565, 0.33333333333333
65282, 1.4173913043478, 1.3239130434783, 0.33333333333333
65283, 1.4173913043478, 1.2978260869565, 0.30555555555556
65284, 1.395652173913, 1.2978260869565, 0.27777777777778
65285, 1.4173913043478, 1.3239130434783, 0.27777777777778
65286, 1.4173913043478, 1.2978260869565, 0.25
65287, 1.395652173913, 1.2978260869565, 0.22222222222222
65288, 1.4173913043478, 1.3239130434783, 0.22222222222222
65289, 1.4173913043478, 1.2978260869565, 0.19444444444444
65290, 1.395652173913, 1.2978260869565, 0.16666666666667
65291, 1.4173913043478, 1.3239130434783, 0.16666666666667
65292, 1.4173913043478, 1.2978260869565, 0.13888888888889
65293, 1.395652173913, 1.2978260869565, 0.11111111111111
65294, 1.4173913043478, 1.3239130434783, 0.11111111111111
65295, 1.4173913043478, 1.2978260869565, 0.083333333333333
65296, 1.395652173913, 1.2978260869565, 0.055555555555556
65297, 1.4173913043478, 1.3239130434783, 0.055555555555556
65298, 1.4173913043478, 1.2978260869565, 0.027777777777778
65299, 1.4608695652174, 1.2978260869565, 0.47222222222222
65300, 1.4391304347826, 1.2978260869565, 0.44444444444444
65301, 1.4608695652174, 1.3239130434783, 0.44444444444444
65302, 1.4608695652174, 1.2978260869565, 0.41666666666667
65303, 1.4391304347826, 1.2978260869565, 0.38888888888889
65304, 1.4608695652174, 1.3239130434783, 0.38888888888889
65305, 1.4608695652174, 1.2978260869565, 0.36111111111111
65306, 1.4391304347826, 1.2978260869565, 0.33333333333333
65307, 1.4608695652174, 1.3239130434783, 0.33333333333333
65308, 1.4608695652174, 1.2978260869565, 0.30555555555556
65309, 1.4391304347826, 1.2978260869565, 0.27777777777778
65310, 1.4608695652174, 1.3239130434783, 0.27777777777778
65311, 1.4608695652174, 1.2978260869565, 0.25
65312, 1.4391304347826, 1.2978260869565, 0.22222222222222
65313, 1.4608695652174, 1.3239130434783, 0.22222222222222
65314, 1.4608695652174, 1.2978260869565, 0.19444444444444
65315, 1.4391304347826, 1.2978260869565, 0.16666666666667
65316, 1.4608695652174, 1.3239130434783, 0.16666666666667
65317, 1.4608695652174, 1.2978260869565, 0.13888888888889
65318, 1.4391304347826, 1.2978260869565, 0.11111111111111
65319, 1.4608695652174, 1.3239130434783, 0.11111111111111
65320, 1.4608695652174, 1.2978260869565, 0.083333333333333
65321, 1.4391304347826, 1.2978260869565, 0.055555555555556
65322, 1.4608695652174, 1.3239130434783, 0.055555555555556
65323, 1.4608695652174, 1.2978260869565, 0.027777777777778
65324, 1.504347826087, 1.2978260869565, 0.47222222222222
65325, 1.4826086956522, 1.2978260869565, 0.44444444444444
65326, 1.504347826087, 1.3239130434783, 0.44444444444444
65327, 1.504347826087, 1.2978260869565, 0.41666666666667
65328, 1.4826086956522, 1.2978260869565, 0.38888888888889
65329, 1.504347826087, 1.3239130434783, 0.38888888888889
65330, 1.504347826087, 1.2978260869565, 0.36111111111111
65331, 1.4826086956522, 1.2978260869565, 0.33333333333333
65332, 1.504347826087, 1.3239130434783, 0.33333333333333
65333, 1.504347826087, 1.2978260869565, 0.30555555555556
65334, 1.4826086956522, 1.2978260869565, 0.27777777777778
65335, 1.504347826087, 1.3239130434783, 0.27777777777778
65336, 1.504347826087, 1.2978260869565, 0.25
65337, 1.4826086956522, 1.2978260869565, 0.22222222222222
65338, 1.504347826087, 1.3239130434783, 0.22222222222222
65339, 1.504347826087, 1.2978260869565, 0.19444444444444
65340, 1.4826086956522, 1.2978260869565, 0.16666666666667
65341, 1.504347826087, 1.3239130434783, 0.16666666666667
65342, 1.504347826087, 1.2978260869565, 0.13888888888889
65343, 1.4826086956522, 1.2978260869565, 0.11111111111111
65344, 1.504347826087, 1.3239130434783, 0.11111111111111
65345, 1.504347826087, 1.2978260869565, 0.083333333333333
65346, 1.4826086956522, 1.2978260869565, 0.055555555555556
65347, 1.504347826087, 1.3239130434783, 0.055555555555556
65348, 1.504347826087, 1.2978260869565, 0.027777777777778
65349, 1.5478260869565, 1.2978260869565, 0.47222222222222
65350, 1.5260869565217, 1.2978260869565, 0.44444444444444
65351, 1.5478260869565, 1.3239130434783, 0.44444444444444
65352, 1.5478260869565, 1.2978260869565, 0.41666666666667
65353, 1.5260869565217, 1.2978260869565, 0.38888888888889
65354, 1.5478260869565, 1.3239130434783, 0.38888888888889
65355, 1.5478260869565, 1.2978260869565, 0.36111111111111
65356, 1.5260869565217, 1.2978260869565, 0.33333333333333
65357, 1.5478260869565, 1.3239130434783, 0.33333333333333
65358, 1.5478260869565, 1.2978260869565, 0.30555555555556
65359, 1.5260869565217, 1.2978260869565, 0.27777777777778
65360, 1.5478260869565, 1.3239130434783, 0.27777777777778
65361, 1.5478260869565, 1.2978260869565, 0.25
65362, 1.5260869565217, 1.2978260869565, 0.22222222222222
65363, 1.5478260869565, 1.3239130434783, 0.22222222222222
65364, 1.5478260869565, 1.2978260869565, 0.19444444444444
65365, 1.5260869565217, 1.2978260869565, 0.16666666666667
65366, 1.5478260869565, 1.3239130434783, 0.16666666666667
65367, 1.5478260869565, 1.2978260869565, 0.13888888888889
65368, 1.5260869565217, 1.2978260869565, 0.11111111111111
65369, 1.5478260869565, 1.3239130434783, 0.11111111111111
65370, 1.5478260869565, 1.2978260869565, 0.083333333333333
65371, 1.5260869565217, 1.2978260869565, 0.055555555555556
65372, 1.5478260869565, 1.3239130434783, 0.055555555555556
65373, 1.5478260869565, 1.2978260869565, 0.027777777777778
65374, 1.5913043478261, 1.2978260869565, 0.47222222222222
65375, 1.5695652173913, 1.2978260869565, 0.44444444444444
65376, 1.5913043478261, 1.3239130434783, 0.44444444444444
65377, 1.5913043478261, 1.2978260869565, 0.41666666666667
65378, 1.5695652173913, 1.2978260869565, 0.38888888888889
65379, 1.5913043478261, 1.3239130434783, 0.38888888888889
65380, 1.5913043478261, 1.2978260869565, 0.36111111111111
65381, 1.5695652173913, 1.2978260869565, 0.33333333333333
65382, 1.5913043478261, 1.3239130434783, 0.33333333333333
65383, 1.5913043478261, 1.2978260869565, 0.30555555555556
65384, 1.5695652173913, 1.2978260869565, 0.27777777777778
65385, 1.5913043478261, 1.3239130434783, 0.27777777777778
65386, 1.5913043478261, 1.2978260869565, 0.25
65387, 1.5695652173913, 1.2978260869565, 0.22222222222222
65388, 1.5913043478261, 1.3239130434783, 0.22222222222222
65389, 1.5913043478261, 1.2978260869565, 0.19444444444444
65390, 1.5695652173913, 1.2978260869565, 0.16666666666667
65391, 1.5913043478261, 1.3239130434783, 0.16666666666667
65392, 1.5913043478261, 1.2978260869565, 0.13888888888889
