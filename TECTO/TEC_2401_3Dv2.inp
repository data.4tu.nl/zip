5849, -0.1, -0.1, 0.36111111111111
5850, -0.1, -0.075, 0.27777777777778
5851, -0.1, -0.1, 0.30555555555556
5852, -0.1, -0.075, 0.22222222222222
5853, -0.1, -0.1, 0.25
5854, -0.1, -0.075, 0.16666666666667
5855, -0.1, -0.1, 0.19444444444444
5856, -0.1, -0.075, 0.11111111111111
5857, -0.1, -0.1, 0.13888888888889
5858, -0.1, -0.075, 0.055555555555556
5859, -0.1, -0.1, 0.083333333333333
5860, -0.1, -0.1, 0.027777777777778
5861, -0.1, -0.125, 0.44444444444444
5862, -0.1, -0.15, 0.47222222222222
5863, -0.1, -0.125, 0.38888888888889
5864, -0.1, -0.15, 0.41666666666667
5865, -0.1, -0.125, 0.33333333333333
5866, -0.1, -0.15, 0.36111111111111
5867, -0.1, -0.125, 0.27777777777778
5868, -0.1, -0.15, 0.30555555555556
5869, -0.1, -0.125, 0.22222222222222
5870, -0.1, -0.15, 0.25
5871, -0.1, -0.125, 0.16666666666667
5872, -0.1, -0.15, 0.19444444444444
5873, -0.1, -0.125, 0.11111111111111
5874, -0.1, -0.15, 0.13888888888889
5875, -0.1, -0.125, 0.055555555555556
5876, -0.1, -0.15, 0.083333333333333
5877, -0.1, -0.15, 0.027777777777778
5878, -0.1, -0.175, 0.44444444444444
5879, -0.1, -0.2, 0.47222222222222
5880, -0.1, -0.175, 0.38888888888889
5881, -0.1, -0.2, 0.41666666666667
5882, -0.1, -0.175, 0.33333333333333
5883, -0.1, -0.2, 0.36111111111111
5884, -0.1, -0.175, 0.27777777777778
5885, -0.1, -0.2, 0.30555555555556
5886, -0.1, -0.175, 0.22222222222222
5887, -0.1, -0.2, 0.25
5888, -0.1, -0.175, 0.16666666666667
5889, -0.1, -0.2, 0.19444444444444
5890, -0.1, -0.175, 0.11111111111111
5891, -0.1, -0.2, 0.13888888888889
5892, -0.1, -0.175, 0.055555555555556
5893, -0.1, -0.2, 0.083333333333333
5894, -0.1, -0.2, 0.027777777777778
5895, -0.1, -0.225, 0.44444444444444
5896, -0.1, -0.225, 0.38888888888889
5897, -0.1, -0.225, 0.33333333333333
5898, -0.1, -0.225, 0.27777777777778
5899, -0.1, -0.225, 0.22222222222222
5900, -0.1, -0.225, 0.16666666666667
5901, -0.1, -0.225, 0.11111111111111
5902, -0.1, -0.225, 0.055555555555556
5903, -0.05, -0.25, 0.44444444444444
5904, -0.05, -0.25, 0.38888888888889
5905, -0.05, -0.25, 0.33333333333333
5906, -0.05, -0.25, 0.27777777777778
5907, -0.05, -0.25, 0.22222222222222
5908, -0.05, -0.25, 0.16666666666667
5909, -0.05, -0.25, 0.11111111111111
5910, -0.05, -0.25, 0.055555555555556
5911, -0.05, -0.25, 0.47222222222222
5912, -0.025, -0.25, 0.44444444444444
5913, -0.05, -0.25, 0.41666666666667
5914, -0.025, -0.25, 0.38888888888889
5915, -0.05, -0.25, 0.36111111111111
5916, -0.025, -0.25, 0.33333333333333
5917, -0.05, -0.25, 0.30555555555556
5918, -0.025, -0.25, 0.27777777777778
5919, -0.05, -0.25, 0.25
5920, -0.025, -0.25, 0.22222222222222
5921, -0.05, -0.25, 0.19444444444444
5922, -0.025, -0.25, 0.16666666666667
5923, -0.05, -0.25, 0.13888888888889
5924, -0.025, -0.25, 0.11111111111111
5925, -0.05, -0.25, 0.083333333333333
5926, -0.025, -0.25, 0.055555555555556
5927, -0.05, -0.25, 0.027777777777778
5928, -0.075, -0.25, 0.44444444444444
5929, -0.075, -0.25, 0.38888888888889
5930, -0.075, -0.25, 0.33333333333333
5931, -0.075, -0.25, 0.27777777777778
5932, -0.075, -0.25, 0.22222222222222
5933, -0.075, -0.25, 0.16666666666667
5934, -0.075, -0.25, 0.11111111111111
5935, -0.075, -0.25, 0.055555555555556
5936, 1, -0.016666666666667, 0.055555555555556
5937, 1, 0.016666666666667, 0.055555555555556
5938, 1, -0.016666666666667, 0.11111111111111
5939, 1, 0.016666666666667, 0.11111111111111
5940, 1, -0.016666666666667, 0.16666666666667
5941, 1, 0.016666666666667, 0.16666666666667
5942, 1, -0.016666666666667, 0.22222222222222
5943, 1, 0.016666666666667, 0.22222222222222
5944, 1, -0.016666666666667, 0.27777777777778
5945, 1, 0.016666666666667, 0.27777777777778
5946, 1, -0.016666666666667, 0.33333333333333
5947, 1, 0.016666666666667, 0.33333333333333
5948, 1, -0.016666666666667, 0.38888888888889
5949, 1, 0.016666666666667, 0.38888888888889
5950, 1, -0.016666666666667, 0.44444444444444
5951, 1, 0.016666666666667, 0.44444444444444
5952, 1, -0.016666666666667, 0.027777777777778
5953, 1, -0.033333333333333, 0.055555555555556
5954, 1, 0.016666666666667, 0.027777777777778
5955, 1, 5.5511151231258e-17, 0.055555555555556
5956, 1, 0.033333333333333, 0.055555555555556
5957, 1, -0.016666666666667, 0.083333333333333
5958, 1, -0.033333333333333, 0.11111111111111
5959, 1, 0.016666666666667, 0.083333333333333
5960, 1, 5.5511151231258e-17, 0.11111111111111
5961, 1, 0.033333333333333, 0.11111111111111
5962, 1, -0.016666666666667, 0.13888888888889
5963, 1, -0.033333333333333, 0.16666666666667
5964, 1, 0.016666666666667, 0.13888888888889
5965, 1, 6.2450045135165e-17, 0.16666666666667
5966, 1, 0.033333333333333, 0.16666666666667
5967, 1, -0.016666666666667, 0.19444444444444
5968, 1, -0.033333333333333, 0.22222222222222
5969, 1, 0.016666666666667, 0.19444444444444
5970, 1, 5.5511151231258e-17, 0.22222222222222
5971, 1, 0.033333333333333, 0.22222222222222
5972, 1, -0.016666666666667, 0.25
5973, 1, -0.033333333333333, 0.27777777777778
5974, 1, 0.016666666666667, 0.25
5975, 1, 5.5511151231258e-17, 0.27777777777778
5976, 1, 0.033333333333333, 0.27777777777778
5977, 1, -0.016666666666667, 0.30555555555556
5978, 1, -0.033333333333333, 0.33333333333333
5979, 1, 0.016666666666667, 0.30555555555556
5980, 1, 5.5511151231258e-17, 0.33333333333333
5981, 1, 0.033333333333333, 0.33333333333333
5982, 1, -0.016666666666667, 0.36111111111111
5983, 1, -0.033333333333333, 0.38888888888889
5984, 1, 0.016666666666667, 0.36111111111111
5985, 1, 5.5511151231258e-17, 0.38888888888889
5986, 1, 0.033333333333333, 0.38888888888889
5987, 1, -0.016666666666667, 0.41666666666667
5988, 1, -0.033333333333333, 0.44444444444444
5989, 1, 0.016666666666667, 0.41666666666667
5990, 1, 5.5511151231258e-17, 0.44444444444444
5991, 1, 0.033333333333333, 0.44444444444444
5992, 1, -0.016666666666667, 0.47222222222222
5993, 1, 0.016666666666667, 0.47222222222222
5994, 0.043478260869565, -0.05, 0.055555555555556
5995, 0.043478260869565, -0.05, 0.11111111111111
5996, 0.043478260869565, -0.05, 0.16666666666667
5997, 0.043478260869565, -0.05, 0.22222222222222
5998, 0.043478260869565, -0.05, 0.27777777777778
5999, 0.043478260869565, -0.05, 0.33333333333333
6000, 0.043478260869565, -0.05, 0.38888888888889
6001, 0.043478260869565, -0.05, 0.44444444444444
6002, 0.08695652173913, -0.05, 0.055555555555556
6003, 0.08695652173913, -0.05, 0.11111111111111
6004, 0.08695652173913, -0.05, 0.16666666666667
6005, 0.08695652173913, -0.05, 0.22222222222222
6006, 0.08695652173913, -0.05, 0.27777777777778
6007, 0.08695652173913, -0.05, 0.33333333333333
6008, 0.08695652173913, -0.05, 0.38888888888889
6009, 0.08695652173913, -0.05, 0.44444444444444
6010, 0.1304347826087, -0.05, 0.055555555555556
6011, 0.1304347826087, -0.05, 0.11111111111111
6012, 0.1304347826087, -0.05, 0.16666666666667
6013, 0.1304347826087, -0.05, 0.22222222222222
6014, 0.1304347826087, -0.05, 0.27777777777778
6015, 0.1304347826087, -0.05, 0.33333333333333
6016, 0.1304347826087, -0.05, 0.38888888888889
6017, 0.1304347826087, -0.05, 0.44444444444444
6018, 0.17391304347826, -0.05, 0.055555555555556
6019, 0.17391304347826, -0.05, 0.11111111111111
6020, 0.17391304347826, -0.05, 0.16666666666667
6021, 0.17391304347826, -0.05, 0.22222222222222
6022, 0.17391304347826, -0.05, 0.27777777777778
6023, 0.17391304347826, -0.05, 0.33333333333333
6024, 0.17391304347826, -0.05, 0.38888888888889
6025, 0.17391304347826, -0.05, 0.44444444444444
6026, 0.21739130434783, -0.05, 0.055555555555556
6027, 0.21739130434783, -0.05, 0.11111111111111
6028, 0.21739130434783, -0.05, 0.16666666666667
6029, 0.21739130434783, -0.05, 0.22222222222222
6030, 0.21739130434783, -0.05, 0.27777777777778
6031, 0.21739130434783, -0.05, 0.33333333333333
6032, 0.21739130434783, -0.05, 0.38888888888889
6033, 0.21739130434783, -0.05, 0.44444444444444
6034, 0.26086956521739, -0.05, 0.055555555555556
6035, 0.26086956521739, -0.05, 0.11111111111111
6036, 0.26086956521739, -0.05, 0.16666666666667
6037, 0.26086956521739, -0.05, 0.22222222222222
6038, 0.26086956521739, -0.05, 0.27777777777778
6039, 0.26086956521739, -0.05, 0.33333333333333
6040, 0.26086956521739, -0.05, 0.38888888888889
6041, 0.26086956521739, -0.05, 0.44444444444444
6042, 0.30434782608696, -0.05, 0.055555555555556
6043, 0.30434782608696, -0.05, 0.11111111111111
6044, 0.30434782608696, -0.05, 0.16666666666667
6045, 0.30434782608696, -0.05, 0.22222222222222
6046, 0.30434782608696, -0.05, 0.27777777777778
6047, 0.30434782608696, -0.05, 0.33333333333333
6048, 0.30434782608696, -0.05, 0.38888888888889
6049, 0.30434782608696, -0.05, 0.44444444444444
6050, 0.34782608695652, -0.05, 0.055555555555556
6051, 0.34782608695652, -0.05, 0.11111111111111
6052, 0.34782608695652, -0.05, 0.16666666666667
6053, 0.34782608695652, -0.05, 0.22222222222222
6054, 0.34782608695652, -0.05, 0.27777777777778
6055, 0.34782608695652, -0.05, 0.33333333333333
6056, 0.34782608695652, -0.05, 0.38888888888889
6057, 0.34782608695652, -0.05, 0.44444444444444
6058, 0.39130434782609, -0.05, 0.055555555555556
6059, 0.39130434782609, -0.05, 0.11111111111111
6060, 0.39130434782609, -0.05, 0.16666666666667
6061, 0.39130434782609, -0.05, 0.22222222222222
6062, 0.39130434782609, -0.05, 0.27777777777778
6063, 0.39130434782609, -0.05, 0.33333333333333
6064, 0.39130434782609, -0.05, 0.38888888888889
6065, 0.39130434782609, -0.05, 0.44444444444444
6066, 0.43478260869565, -0.05, 0.055555555555556
6067, 0.43478260869565, -0.05, 0.11111111111111
6068, 0.43478260869565, -0.05, 0.16666666666667
6069, 0.43478260869565, -0.05, 0.22222222222222
6070, 0.43478260869565, -0.05, 0.27777777777778
6071, 0.43478260869565, -0.05, 0.33333333333333
6072, 0.43478260869565, -0.05, 0.38888888888889
6073, 0.43478260869565, -0.05, 0.44444444444444
6074, 0.47826086956522, -0.05, 0.055555555555556
6075, 0.47826086956522, -0.05, 0.11111111111111
6076, 0.47826086956522, -0.05, 0.16666666666667
6077, 0.47826086956522, -0.05, 0.22222222222222
6078, 0.47826086956522, -0.05, 0.27777777777778
6079, 0.47826086956522, -0.05, 0.33333333333333
6080, 0.47826086956522, -0.05, 0.38888888888889
6081, 0.47826086956522, -0.05, 0.44444444444444
6082, 0.52173913043478, -0.05, 0.055555555555556
6083, 0.52173913043478, -0.05, 0.11111111111111
6084, 0.52173913043478, -0.05, 0.16666666666667
6085, 0.52173913043478, -0.05, 0.22222222222222
6086, 0.52173913043478, -0.05, 0.27777777777778
6087, 0.52173913043478, -0.05, 0.33333333333333
6088, 0.52173913043478, -0.05, 0.38888888888889
6089, 0.52173913043478, -0.05, 0.44444444444444
6090, 0.56521739130435, -0.05, 0.055555555555556
6091, 0.56521739130435, -0.05, 0.11111111111111
6092, 0.56521739130435, -0.05, 0.16666666666667
6093, 0.56521739130435, -0.05, 0.22222222222222
6094, 0.56521739130435, -0.05, 0.27777777777778
6095, 0.56521739130435, -0.05, 0.33333333333333
6096, 0.56521739130435, -0.05, 0.38888888888889
6097, 0.56521739130435, -0.05, 0.44444444444444
6098, 0.60869565217391, -0.05, 0.055555555555556
6099, 0.60869565217391, -0.05, 0.11111111111111
6100, 0.60869565217391, -0.05, 0.16666666666667
6101, 0.60869565217391, -0.05, 0.22222222222222
6102, 0.60869565217391, -0.05, 0.27777777777778
6103, 0.60869565217391, -0.05, 0.33333333333333
6104, 0.60869565217391, -0.05, 0.38888888888889
6105, 0.60869565217391, -0.05, 0.44444444444444
6106, 0.65217391304348, -0.05, 0.055555555555556
6107, 0.65217391304348, -0.05, 0.11111111111111
6108, 0.65217391304348, -0.05, 0.16666666666667
6109, 0.65217391304348, -0.05, 0.22222222222222
6110, 0.65217391304348, -0.05, 0.27777777777778
6111, 0.65217391304348, -0.05, 0.33333333333333
6112, 0.65217391304348, -0.05, 0.38888888888889
6113, 0.65217391304348, -0.05, 0.44444444444444
6114, 0.69565217391304, -0.05, 0.055555555555556
6115, 0.69565217391304, -0.05, 0.11111111111111
6116, 0.69565217391304, -0.05, 0.16666666666667
6117, 0.69565217391304, -0.05, 0.22222222222222
6118, 0.69565217391304, -0.05, 0.27777777777778
6119, 0.69565217391304, -0.05, 0.33333333333333
6120, 0.69565217391304, -0.05, 0.38888888888889
6121, 0.69565217391304, -0.05, 0.44444444444444
6122, 0.73913043478261, -0.05, 0.055555555555556
6123, 0.73913043478261, -0.05, 0.11111111111111
6124, 0.73913043478261, -0.05, 0.16666666666667
6125, 0.73913043478261, -0.05, 0.22222222222222
6126, 0.73913043478261, -0.05, 0.27777777777778
6127, 0.73913043478261, -0.05, 0.33333333333333
6128, 0.73913043478261, -0.05, 0.38888888888889
6129, 0.73913043478261, -0.05, 0.44444444444444
6130, 0.78260869565217, -0.05, 0.055555555555556
6131, 0.78260869565217, -0.05, 0.11111111111111
6132, 0.78260869565217, -0.05, 0.16666666666667
6133, 0.78260869565217, -0.05, 0.22222222222222
6134, 0.78260869565217, -0.05, 0.27777777777778
6135, 0.78260869565217, -0.05, 0.33333333333333
6136, 0.78260869565217, -0.05, 0.38888888888889
6137, 0.78260869565217, -0.05, 0.44444444444444
6138, 0.82608695652174, -0.05, 0.055555555555556
6139, 0.82608695652174, -0.05, 0.11111111111111
6140, 0.82608695652174, -0.05, 0.16666666666667
6141, 0.82608695652174, -0.05, 0.22222222222222
6142, 0.82608695652174, -0.05, 0.27777777777778
6143, 0.82608695652174, -0.05, 0.33333333333333
6144, 0.82608695652174, -0.05, 0.38888888888889
6145, 0.82608695652174, -0.05, 0.44444444444444
6146, 0.8695652173913, -0.05, 0.055555555555556
6147, 0.8695652173913, -0.05, 0.11111111111111
6148, 0.8695652173913, -0.05, 0.16666666666667
6149, 0.8695652173913, -0.05, 0.22222222222222
6150, 0.8695652173913, -0.05, 0.27777777777778
6151, 0.8695652173913, -0.05, 0.33333333333333
6152, 0.8695652173913, -0.05, 0.38888888888889
6153, 0.8695652173913, -0.05, 0.44444444444444
6154, 0.91304347826087, -0.05, 0.055555555555556
6155, 0.91304347826087, -0.05, 0.11111111111111
6156, 0.91304347826087, -0.05, 0.16666666666667
6157, 0.91304347826087, -0.05, 0.22222222222222
6158, 0.91304347826087, -0.05, 0.27777777777778
6159, 0.91304347826087, -0.05, 0.33333333333333
6160, 0.91304347826087, -0.05, 0.38888888888889
6161, 0.91304347826087, -0.05, 0.44444444444444
6162, 0.95652173913043, -0.05, 0.055555555555556
6163, 0.95652173913043, -0.05, 0.11111111111111
6164, 0.95652173913043, -0.05, 0.16666666666667
6165, 0.95652173913043, -0.05, 0.22222222222222
6166, 0.95652173913043, -0.05, 0.27777777777778
6167, 0.95652173913043, -0.05, 0.33333333333333
6168, 0.95652173913043, -0.05, 0.38888888888889
6169, 0.95652173913043, -0.05, 0.44444444444444
6170, 0.043478260869565, -0.05, 0.027777777777778
6171, 0.021739130434783, -0.05, 0.055555555555556
6172, 0.043478260869565, -0.05, 0.083333333333333
6173, 0.021739130434783, -0.05, 0.11111111111111
6174, 0.043478260869565, -0.05, 0.13888888888889
6175, 0.021739130434783, -0.05, 0.16666666666667
6176, 0.043478260869565, -0.05, 0.19444444444444
6177, 0.021739130434783, -0.05, 0.22222222222222
6178, 0.043478260869565, -0.05, 0.25
6179, 0.021739130434783, -0.05, 0.27777777777778
6180, 0.043478260869565, -0.05, 0.30555555555556
6181, 0.021739130434783, -0.05, 0.33333333333333
6182, 0.043478260869565, -0.05, 0.36111111111111
6183, 0.021739130434783, -0.05, 0.38888888888889
6184, 0.043478260869565, -0.05, 0.41666666666667
6185, 0.021739130434783, -0.05, 0.44444444444444
6186, 0.043478260869565, -0.05, 0.47222222222222
6187, 0.08695652173913, -0.05, 0.027777777777778
6188, 0.065217391304348, -0.05, 0.055555555555556
6189, 0.08695652173913, -0.05, 0.083333333333333
6190, 0.065217391304348, -0.05, 0.11111111111111
6191, 0.08695652173913, -0.05, 0.13888888888889
6192, 0.065217391304348, -0.05, 0.16666666666667
6193, 0.08695652173913, -0.05, 0.19444444444444
6194, 0.065217391304348, -0.05, 0.22222222222222
6195, 0.08695652173913, -0.05, 0.25
6196, 0.065217391304348, -0.05, 0.27777777777778
6197, 0.08695652173913, -0.05, 0.30555555555556
6198, 0.065217391304348, -0.05, 0.33333333333333
6199, 0.08695652173913, -0.05, 0.36111111111111
6200, 0.065217391304348, -0.05, 0.38888888888889
6201, 0.08695652173913, -0.05, 0.41666666666667
6202, 0.065217391304348, -0.05, 0.44444444444444
6203, 0.08695652173913, -0.05, 0.47222222222222
6204, 0.1304347826087, -0.05, 0.027777777777778
6205, 0.10869565217391, -0.05, 0.055555555555556
6206, 0.1304347826087, -0.05, 0.083333333333333
6207, 0.10869565217391, -0.05, 0.11111111111111
6208, 0.1304347826087, -0.05, 0.13888888888889
6209, 0.10869565217391, -0.05, 0.16666666666667
6210, 0.1304347826087, -0.05, 0.19444444444444
6211, 0.10869565217391, -0.05, 0.22222222222222
6212, 0.1304347826087, -0.05, 0.25
6213, 0.10869565217391, -0.05, 0.27777777777778
6214, 0.1304347826087, -0.05, 0.30555555555556
6215, 0.10869565217391, -0.05, 0.33333333333333
6216, 0.1304347826087, -0.05, 0.36111111111111
6217, 0.10869565217391, -0.05, 0.38888888888889
6218, 0.1304347826087, -0.05, 0.41666666666667
6219, 0.10869565217391, -0.05, 0.44444444444444
6220, 0.1304347826087, -0.05, 0.47222222222222
6221, 0.17391304347826, -0.05, 0.027777777777778
6222, 0.15217391304348, -0.05, 0.055555555555556
6223, 0.17391304347826, -0.05, 0.083333333333333
6224, 0.15217391304348, -0.05, 0.11111111111111
6225, 0.17391304347826, -0.05, 0.13888888888889
6226, 0.15217391304348, -0.05, 0.16666666666667
6227, 0.17391304347826, -0.05, 0.19444444444444
6228, 0.15217391304348, -0.05, 0.22222222222222
6229, 0.17391304347826, -0.05, 0.25
6230, 0.15217391304348, -0.05, 0.27777777777778
6231, 0.17391304347826, -0.05, 0.30555555555556
6232, 0.15217391304348, -0.05, 0.33333333333333
6233, 0.17391304347826, -0.05, 0.36111111111111
6234, 0.15217391304348, -0.05, 0.38888888888889
6235, 0.17391304347826, -0.05, 0.41666666666667
6236, 0.15217391304348, -0.05, 0.44444444444444
6237, 0.17391304347826, -0.05, 0.47222222222222
6238, 0.21739130434783, -0.05, 0.027777777777778
6239, 0.19565217391304, -0.05, 0.055555555555556
6240, 0.21739130434783, -0.05, 0.083333333333333
6241, 0.19565217391304, -0.05, 0.11111111111111
6242, 0.21739130434783, -0.05, 0.13888888888889
6243, 0.19565217391304, -0.05, 0.16666666666667
6244, 0.21739130434783, -0.05, 0.19444444444444
6245, 0.19565217391304, -0.05, 0.22222222222222
6246, 0.21739130434783, -0.05, 0.25
6247, 0.19565217391304, -0.05, 0.27777777777778
6248, 0.21739130434783, -0.05, 0.30555555555556
6249, 0.19565217391304, -0.05, 0.33333333333333
6250, 0.21739130434783, -0.05, 0.36111111111111
6251, 0.19565217391304, -0.05, 0.38888888888889
6252, 0.21739130434783, -0.05, 0.41666666666667
6253, 0.19565217391304, -0.05, 0.44444444444444
6254, 0.21739130434783, -0.05, 0.47222222222222
6255, 0.26086956521739, -0.05, 0.027777777777778
6256, 0.23913043478261, -0.05, 0.055555555555556
6257, 0.26086956521739, -0.05, 0.083333333333333
6258, 0.23913043478261, -0.05, 0.11111111111111
6259, 0.26086956521739, -0.05, 0.13888888888889
6260, 0.23913043478261, -0.05, 0.16666666666667
6261, 0.26086956521739, -0.05, 0.19444444444444
6262, 0.23913043478261, -0.05, 0.22222222222222
6263, 0.26086956521739, -0.05, 0.25
6264, 0.23913043478261, -0.05, 0.27777777777778
6265, 0.26086956521739, -0.05, 0.30555555555556
6266, 0.23913043478261, -0.05, 0.33333333333333
6267, 0.26086956521739, -0.05, 0.36111111111111
6268, 0.23913043478261, -0.05, 0.38888888888889
6269, 0.26086956521739, -0.05, 0.41666666666667
6270, 0.23913043478261, -0.05, 0.44444444444444
6271, 0.26086956521739, -0.05, 0.47222222222222
6272, 0.30434782608696, -0.05, 0.027777777777778
6273, 0.28260869565217, -0.05, 0.055555555555556
6274, 0.30434782608696, -0.05, 0.083333333333333
6275, 0.28260869565217, -0.05, 0.11111111111111
6276, 0.30434782608696, -0.05, 0.13888888888889
6277, 0.28260869565217, -0.05, 0.16666666666667
6278, 0.30434782608696, -0.05, 0.19444444444444
6279, 0.28260869565217, -0.05, 0.22222222222222
6280, 0.30434782608696, -0.05, 0.25
6281, 0.28260869565217, -0.05, 0.27777777777778
6282, 0.30434782608696, -0.05, 0.30555555555556
6283, 0.28260869565217, -0.05, 0.33333333333333
6284, 0.30434782608696, -0.05, 0.36111111111111
6285, 0.28260869565217, -0.05, 0.38888888888889
6286, 0.30434782608696, -0.05, 0.41666666666667
6287, 0.28260869565217, -0.05, 0.44444444444444
6288, 0.30434782608696, -0.05, 0.47222222222222
6289, 0.34782608695652, -0.05, 0.027777777777778
6290, 0.32608695652174, -0.05, 0.055555555555556
6291, 0.34782608695652, -0.05, 0.083333333333333
6292, 0.32608695652174, -0.05, 0.11111111111111
6293, 0.34782608695652, -0.05, 0.13888888888889
6294, 0.32608695652174, -0.05, 0.16666666666667
6295, 0.34782608695652, -0.05, 0.19444444444444
6296, 0.32608695652174, -0.05, 0.22222222222222
6297, 0.34782608695652, -0.05, 0.25
6298, 0.32608695652174, -0.05, 0.27777777777778
6299, 0.34782608695652, -0.05, 0.30555555555556
6300, 0.32608695652174, -0.05, 0.33333333333333
6301, 0.34782608695652, -0.05, 0.36111111111111
6302, 0.32608695652174, -0.05, 0.38888888888889
6303, 0.34782608695652, -0.05, 0.41666666666667
6304, 0.32608695652174, -0.05, 0.44444444444444
6305, 0.34782608695652, -0.05, 0.47222222222222
6306, 0.39130434782609, -0.05, 0.027777777777778
6307, 0.3695652173913, -0.05, 0.055555555555556
6308, 0.39130434782609, -0.05, 0.083333333333333
6309, 0.3695652173913, -0.05, 0.11111111111111
6310, 0.39130434782609, -0.05, 0.13888888888889
6311, 0.3695652173913, -0.05, 0.16666666666667
6312, 0.39130434782609, -0.05, 0.19444444444444
6313, 0.3695652173913, -0.05, 0.22222222222222
6314, 0.39130434782609, -0.05, 0.25
6315, 0.3695652173913, -0.05, 0.27777777777778
6316, 0.39130434782609, -0.05, 0.30555555555556
6317, 0.3695652173913, -0.05, 0.33333333333333
6318, 0.39130434782609, -0.05, 0.36111111111111
6319, 0.3695652173913, -0.05, 0.38888888888889
6320, 0.39130434782609, -0.05, 0.41666666666667
6321, 0.3695652173913, -0.05, 0.44444444444444
6322, 0.39130434782609, -0.05, 0.47222222222222
6323, 0.43478260869565, -0.05, 0.027777777777778
6324, 0.41304347826087, -0.05, 0.055555555555556
6325, 0.43478260869565, -0.05, 0.083333333333333
6326, 0.41304347826087, -0.05, 0.11111111111111
6327, 0.43478260869565, -0.05, 0.13888888888889
6328, 0.41304347826087, -0.05, 0.16666666666667
6329, 0.43478260869565, -0.05, 0.19444444444444
6330, 0.41304347826087, -0.05, 0.22222222222222
6331, 0.43478260869565, -0.05, 0.25
6332, 0.41304347826087, -0.05, 0.27777777777778
6333, 0.43478260869565, -0.05, 0.30555555555556
6334, 0.41304347826087, -0.05, 0.33333333333333
6335, 0.43478260869565, -0.05, 0.36111111111111
6336, 0.41304347826087, -0.05, 0.38888888888889
6337, 0.43478260869565, -0.05, 0.41666666666667
6338, 0.41304347826087, -0.05, 0.44444444444444
6339, 0.43478260869565, -0.05, 0.47222222222222
6340, 0.47826086956522, -0.05, 0.027777777777778
6341, 0.45652173913043, -0.05, 0.055555555555556
6342, 0.47826086956522, -0.05, 0.083333333333333
6343, 0.45652173913043, -0.05, 0.11111111111111
6344, 0.47826086956522, -0.05, 0.13888888888889
6345, 0.45652173913043, -0.05, 0.16666666666667
6346, 0.47826086956522, -0.05, 0.19444444444444
6347, 0.45652173913043, -0.05, 0.22222222222222
6348, 0.47826086956522, -0.05, 0.25
6349, 0.45652173913043, -0.05, 0.27777777777778
6350, 0.47826086956522, -0.05, 0.30555555555556
6351, 0.45652173913043, -0.05, 0.33333333333333
6352, 0.47826086956522, -0.05, 0.36111111111111
6353, 0.45652173913043, -0.05, 0.38888888888889
6354, 0.47826086956522, -0.05, 0.41666666666667
6355, 0.45652173913043, -0.05, 0.44444444444444
6356, 0.47826086956522, -0.05, 0.47222222222222
6357, 0.52173913043478, -0.05, 0.027777777777778
6358, 0.5, -0.05, 0.055555555555556
6359, 0.52173913043478, -0.05, 0.083333333333333
6360, 0.5, -0.05, 0.11111111111111
6361, 0.52173913043478, -0.05, 0.13888888888889
6362, 0.5, -0.05, 0.16666666666667
6363, 0.52173913043478, -0.05, 0.19444444444444
6364, 0.5, -0.05, 0.22222222222222
6365, 0.52173913043478, -0.05, 0.25
6366, 0.5, -0.05, 0.27777777777778
6367, 0.52173913043478, -0.05, 0.30555555555556
6368, 0.5, -0.05, 0.33333333333333
6369, 0.52173913043478, -0.05, 0.36111111111111
6370, 0.5, -0.05, 0.38888888888889
6371, 0.52173913043478, -0.05, 0.41666666666667
6372, 0.5, -0.05, 0.44444444444444
6373, 0.52173913043478, -0.05, 0.47222222222222
6374, 0.56521739130435, -0.05, 0.027777777777778
6375, 0.54347826086957, -0.05, 0.055555555555556
6376, 0.56521739130435, -0.05, 0.083333333333333
6377, 0.54347826086957, -0.05, 0.11111111111111
6378, 0.56521739130435, -0.05, 0.13888888888889
6379, 0.54347826086957, -0.05, 0.16666666666667
6380, 0.56521739130435, -0.05, 0.19444444444444
6381, 0.54347826086957, -0.05, 0.22222222222222
6382, 0.56521739130435, -0.05, 0.25
6383, 0.54347826086957, -0.05, 0.27777777777778
6384, 0.56521739130435, -0.05, 0.30555555555556
6385, 0.54347826086957, -0.05, 0.33333333333333
6386, 0.56521739130435, -0.05, 0.36111111111111
6387, 0.54347826086957, -0.05, 0.38888888888889
6388, 0.56521739130435, -0.05, 0.41666666666667
6389, 0.54347826086957, -0.05, 0.44444444444444
6390, 0.56521739130435, -0.05, 0.47222222222222
6391, 0.60869565217391, -0.05, 0.027777777777778
6392, 0.58695652173913, -0.05, 0.055555555555556
6393, 0.60869565217391, -0.05, 0.083333333333333
6394, 0.58695652173913, -0.05, 0.11111111111111
6395, 0.60869565217391, -0.05, 0.13888888888889
6396, 0.58695652173913, -0.05, 0.16666666666667
6397, 0.60869565217391, -0.05, 0.19444444444444
6398, 0.58695652173913, -0.05, 0.22222222222222
6399, 0.60869565217391, -0.05, 0.25
6400, 0.58695652173913, -0.05, 0.27777777777778
6401, 0.60869565217391, -0.05, 0.30555555555556
6402, 0.58695652173913, -0.05, 0.33333333333333
6403, 0.60869565217391, -0.05, 0.36111111111111
6404, 0.58695652173913, -0.05, 0.38888888888889
6405, 0.60869565217391, -0.05, 0.41666666666667
6406, 0.58695652173913, -0.05, 0.44444444444444
6407, 0.60869565217391, -0.05, 0.47222222222222
6408, 0.65217391304348, -0.05, 0.027777777777778
6409, 0.6304347826087, -0.05, 0.055555555555556
6410, 0.65217391304348, -0.05, 0.083333333333333
6411, 0.6304347826087, -0.05, 0.11111111111111
6412, 0.65217391304348, -0.05, 0.13888888888889
6413, 0.6304347826087, -0.05, 0.16666666666667
6414, 0.65217391304348, -0.05, 0.19444444444444
6415, 0.6304347826087, -0.05, 0.22222222222222
6416, 0.65217391304348, -0.05, 0.25
6417, 0.6304347826087, -0.05, 0.27777777777778
6418, 0.65217391304348, -0.05, 0.30555555555556
6419, 0.6304347826087, -0.05, 0.33333333333333
6420, 0.65217391304348, -0.05, 0.36111111111111
6421, 0.6304347826087, -0.05, 0.38888888888889
6422, 0.65217391304348, -0.05, 0.41666666666667
6423, 0.6304347826087, -0.05, 0.44444444444444
6424, 0.65217391304348, -0.05, 0.47222222222222
6425, 0.69565217391304, -0.05, 0.027777777777778
6426, 0.67391304347826, -0.05, 0.055555555555556
6427, 0.69565217391304, -0.05, 0.083333333333333
6428, 0.67391304347826, -0.05, 0.11111111111111
6429, 0.69565217391304, -0.05, 0.13888888888889
6430, 0.67391304347826, -0.05, 0.16666666666667
6431, 0.69565217391304, -0.05, 0.19444444444444
6432, 0.67391304347826, -0.05, 0.22222222222222
6433, 0.69565217391304, -0.05, 0.25
6434, 0.67391304347826, -0.05, 0.27777777777778
6435, 0.69565217391304, -0.05, 0.30555555555556
6436, 0.67391304347826, -0.05, 0.33333333333333
6437, 0.69565217391304, -0.05, 0.36111111111111
6438, 0.67391304347826, -0.05, 0.38888888888889
6439, 0.69565217391304, -0.05, 0.41666666666667
6440, 0.67391304347826, -0.05, 0.44444444444444
6441, 0.69565217391304, -0.05, 0.47222222222222
6442, 0.73913043478261, -0.05, 0.027777777777778
6443, 0.71739130434783, -0.05, 0.055555555555556
6444, 0.73913043478261, -0.05, 0.083333333333333
6445, 0.71739130434783, -0.05, 0.11111111111111
6446, 0.73913043478261, -0.05, 0.13888888888889
6447, 0.71739130434783, -0.05, 0.16666666666667
6448, 0.73913043478261, -0.05, 0.19444444444444
6449, 0.71739130434783, -0.05, 0.22222222222222
6450, 0.73913043478261, -0.05, 0.25
6451, 0.71739130434783, -0.05, 0.27777777777778
6452, 0.73913043478261, -0.05, 0.30555555555556
6453, 0.71739130434783, -0.05, 0.33333333333333
6454, 0.73913043478261, -0.05, 0.36111111111111
6455, 0.71739130434783, -0.05, 0.38888888888889
6456, 0.73913043478261, -0.05, 0.41666666666667
6457, 0.71739130434783, -0.05, 0.44444444444444
6458, 0.73913043478261, -0.05, 0.47222222222222
6459, 0.78260869565217, -0.05, 0.027777777777778
6460, 0.76086956521739, -0.05, 0.055555555555556
6461, 0.78260869565217, -0.05, 0.083333333333333
6462, 0.76086956521739, -0.05, 0.11111111111111
6463, 0.78260869565217, -0.05, 0.13888888888889
6464, 0.76086956521739, -0.05, 0.16666666666667
6465, 0.78260869565217, -0.05, 0.19444444444444
6466, 0.76086956521739, -0.05, 0.22222222222222
6467, 0.78260869565217, -0.05, 0.25
6468, 0.76086956521739, -0.05, 0.27777777777778
6469, 0.78260869565217, -0.05, 0.30555555555556
6470, 0.76086956521739, -0.05, 0.33333333333333
6471, 0.78260869565217, -0.05, 0.36111111111111
6472, 0.76086956521739, -0.05, 0.38888888888889
6473, 0.78260869565217, -0.05, 0.41666666666667
6474, 0.76086956521739, -0.05, 0.44444444444444
6475, 0.78260869565217, -0.05, 0.47222222222222
6476, 0.82608695652174, -0.05, 0.027777777777778
6477, 0.80434782608696, -0.05, 0.055555555555556
6478, 0.82608695652174, -0.05, 0.083333333333333
6479, 0.80434782608696, -0.05, 0.11111111111111
6480, 0.82608695652174, -0.05, 0.13888888888889
6481, 0.80434782608696, -0.05, 0.16666666666667
6482, 0.82608695652174, -0.05, 0.19444444444444
6483, 0.80434782608696, -0.05, 0.22222222222222
6484, 0.82608695652174, -0.05, 0.25
6485, 0.80434782608696, -0.05, 0.27777777777778
6486, 0.82608695652174, -0.05, 0.30555555555556
6487, 0.80434782608696, -0.05, 0.33333333333333
6488, 0.82608695652174, -0.05, 0.36111111111111
6489, 0.80434782608696, -0.05, 0.38888888888889
6490, 0.82608695652174, -0.05, 0.41666666666667
6491, 0.80434782608696, -0.05, 0.44444444444444
6492, 0.82608695652174, -0.05, 0.47222222222222
6493, 0.8695652173913, -0.05, 0.027777777777778
6494, 0.84782608695652, -0.05, 0.055555555555556
6495, 0.8695652173913, -0.05, 0.083333333333333
6496, 0.84782608695652, -0.05, 0.11111111111111
6497, 0.8695652173913, -0.05, 0.13888888888889
6498, 0.84782608695652, -0.05, 0.16666666666667
6499, 0.8695652173913, -0.05, 0.19444444444444
6500, 0.84782608695652, -0.05, 0.22222222222222
6501, 0.8695652173913, -0.05, 0.25
6502, 0.84782608695652, -0.05, 0.27777777777778
6503, 0.8695652173913, -0.05, 0.30555555555556
6504, 0.84782608695652, -0.05, 0.33333333333333
6505, 0.8695652173913, -0.05, 0.36111111111111
6506, 0.84782608695652, -0.05, 0.38888888888889
6507, 0.8695652173913, -0.05, 0.41666666666667
6508, 0.84782608695652, -0.05, 0.44444444444444
6509, 0.8695652173913, -0.05, 0.47222222222222
6510, 0.91304347826087, -0.05, 0.027777777777778
6511, 0.89130434782609, -0.05, 0.055555555555556
6512, 0.91304347826087, -0.05, 0.083333333333333
6513, 0.89130434782609, -0.05, 0.11111111111111
6514, 0.91304347826087, -0.05, 0.13888888888889
6515, 0.89130434782609, -0.05, 0.16666666666667
6516, 0.91304347826087, -0.05, 0.19444444444444
6517, 0.89130434782609, -0.05, 0.22222222222222
6518, 0.91304347826087, -0.05, 0.25
6519, 0.89130434782609, -0.05, 0.27777777777778
6520, 0.91304347826087, -0.05, 0.30555555555556
6521, 0.89130434782609, -0.05, 0.33333333333333
6522, 0.91304347826087, -0.05, 0.36111111111111
6523, 0.89130434782609, -0.05, 0.38888888888889
6524, 0.91304347826087, -0.05, 0.41666666666667
6525, 0.89130434782609, -0.05, 0.44444444444444
6526, 0.91304347826087, -0.05, 0.47222222222222
6527, 0.95652173913043, -0.05, 0.027777777777778
6528, 0.93478260869565, -0.05, 0.055555555555556
6529, 0.95652173913043, -0.05, 0.083333333333333
6530, 0.93478260869565, -0.05, 0.11111111111111
6531, 0.95652173913043, -0.05, 0.13888888888889
6532, 0.93478260869565, -0.05, 0.16666666666667
6533, 0.95652173913043, -0.05, 0.19444444444444
6534, 0.93478260869565, -0.05, 0.22222222222222
6535, 0.95652173913043, -0.05, 0.25
6536, 0.93478260869565, -0.05, 0.27777777777778
6537, 0.95652173913043, -0.05, 0.30555555555556
6538, 0.93478260869565, -0.05, 0.33333333333333
6539, 0.95652173913043, -0.05, 0.36111111111111
6540, 0.93478260869565, -0.05, 0.38888888888889
6541, 0.95652173913043, -0.05, 0.41666666666667
6542, 0.93478260869565, -0.05, 0.44444444444444
6543, 0.95652173913043, -0.05, 0.47222222222222
6544, 0.97826086956522, -0.05, 0.055555555555556
6545, 0.97826086956522, -0.05, 0.11111111111111
6546, 0.97826086956522, -0.05, 0.16666666666667
6547, 0.97826086956522, -0.05, 0.22222222222222
6548, 0.97826086956522, -0.05, 0.27777777777778
6549, 0.97826086956522, -0.05, 0.33333333333333
6550, 0.97826086956522, -0.05, 0.38888888888889
6551, 0.97826086956522, -0.05, 0.44444444444444
6552, 0.043478260869565, 0.05, 0.055555555555556
6553, 0.043478260869565, 0.05, 0.11111111111111
6554, 0.043478260869565, 0.05, 0.16666666666667
6555, 0.043478260869565, 0.05, 0.22222222222222
6556, 0.043478260869565, 0.05, 0.27777777777778
6557, 0.043478260869565, 0.05, 0.33333333333333
6558, 0.043478260869565, 0.05, 0.38888888888889
6559, 0.043478260869565, 0.05, 0.44444444444444
6560, 0.08695652173913, 0.05, 0.055555555555556
6561, 0.08695652173913, 0.05, 0.11111111111111
6562, 0.08695652173913, 0.05, 0.16666666666667
6563, 0.08695652173913, 0.05, 0.22222222222222
6564, 0.08695652173913, 0.05, 0.27777777777778
6565, 0.08695652173913, 0.05, 0.33333333333333
6566, 0.08695652173913, 0.05, 0.38888888888889
6567, 0.08695652173913, 0.05, 0.44444444444444
6568, 0.1304347826087, 0.05, 0.055555555555556
6569, 0.1304347826087, 0.05, 0.11111111111111
6570, 0.1304347826087, 0.05, 0.16666666666667
6571, 0.1304347826087, 0.05, 0.22222222222222
6572, 0.1304347826087, 0.05, 0.27777777777778
6573, 0.1304347826087, 0.05, 0.33333333333333
6574, 0.1304347826087, 0.05, 0.38888888888889
6575, 0.1304347826087, 0.05, 0.44444444444444
6576, 0.17391304347826, 0.05, 0.055555555555556
6577, 0.17391304347826, 0.05, 0.11111111111111
6578, 0.17391304347826, 0.05, 0.16666666666667
6579, 0.17391304347826, 0.05, 0.22222222222222
6580, 0.17391304347826, 0.05, 0.27777777777778
6581, 0.17391304347826, 0.05, 0.33333333333333
6582, 0.17391304347826, 0.05, 0.38888888888889
6583, 0.17391304347826, 0.05, 0.44444444444444
6584, 0.21739130434783, 0.05, 0.055555555555556
6585, 0.21739130434783, 0.05, 0.11111111111111
6586, 0.21739130434783, 0.05, 0.16666666666667
6587, 0.21739130434783, 0.05, 0.22222222222222
6588, 0.21739130434783, 0.05, 0.27777777777778
6589, 0.21739130434783, 0.05, 0.33333333333333
6590, 0.21739130434783, 0.05, 0.38888888888889
6591, 0.21739130434783, 0.05, 0.44444444444444
6592, 0.26086956521739, 0.05, 0.055555555555556
6593, 0.26086956521739, 0.05, 0.11111111111111
6594, 0.26086956521739, 0.05, 0.16666666666667
6595, 0.26086956521739, 0.05, 0.22222222222222
6596, 0.26086956521739, 0.05, 0.27777777777778
6597, 0.26086956521739, 0.05, 0.33333333333333
6598, 0.26086956521739, 0.05, 0.38888888888889
6599, 0.26086956521739, 0.05, 0.44444444444444
6600, 0.30434782608696, 0.05, 0.055555555555556
6601, 0.30434782608696, 0.05, 0.11111111111111
6602, 0.30434782608696, 0.05, 0.16666666666667
6603, 0.30434782608696, 0.05, 0.22222222222222
6604, 0.30434782608696, 0.05, 0.27777777777778
6605, 0.30434782608696, 0.05, 0.33333333333333
6606, 0.30434782608696, 0.05, 0.38888888888889
6607, 0.30434782608696, 0.05, 0.44444444444444
6608, 0.34782608695652, 0.05, 0.055555555555556
6609, 0.34782608695652, 0.05, 0.11111111111111
6610, 0.34782608695652, 0.05, 0.16666666666667
6611, 0.34782608695652, 0.05, 0.22222222222222
6612, 0.34782608695652, 0.05, 0.27777777777778
6613, 0.34782608695652, 0.05, 0.33333333333333
6614, 0.34782608695652, 0.05, 0.38888888888889
6615, 0.34782608695652, 0.05, 0.44444444444444
6616, 0.39130434782609, 0.05, 0.055555555555556
6617, 0.39130434782609, 0.05, 0.11111111111111
6618, 0.39130434782609, 0.05, 0.16666666666667
6619, 0.39130434782609, 0.05, 0.22222222222222
6620, 0.39130434782609, 0.05, 0.27777777777778
6621, 0.39130434782609, 0.05, 0.33333333333333
6622, 0.39130434782609, 0.05, 0.38888888888889
6623, 0.39130434782609, 0.05, 0.44444444444444
6624, 0.43478260869565, 0.05, 0.055555555555556
6625, 0.43478260869565, 0.05, 0.11111111111111
6626, 0.43478260869565, 0.05, 0.16666666666667
6627, 0.43478260869565, 0.05, 0.22222222222222
6628, 0.43478260869565, 0.05, 0.27777777777778
6629, 0.43478260869565, 0.05, 0.33333333333333
6630, 0.43478260869565, 0.05, 0.38888888888889
6631, 0.43478260869565, 0.05, 0.44444444444444
6632, 0.47826086956522, 0.05, 0.055555555555556
6633, 0.47826086956522, 0.05, 0.11111111111111
6634, 0.47826086956522, 0.05, 0.16666666666667
6635, 0.47826086956522, 0.05, 0.22222222222222
6636, 0.47826086956522, 0.05, 0.27777777777778
6637, 0.47826086956522, 0.05, 0.33333333333333
6638, 0.47826086956522, 0.05, 0.38888888888889
6639, 0.47826086956522, 0.05, 0.44444444444444
6640, 0.52173913043478, 0.05, 0.055555555555556
6641, 0.52173913043478, 0.05, 0.11111111111111
6642, 0.52173913043478, 0.05, 0.16666666666667
6643, 0.52173913043478, 0.05, 0.22222222222222
6644, 0.52173913043478, 0.05, 0.27777777777778
6645, 0.52173913043478, 0.05, 0.33333333333333
6646, 0.52173913043478, 0.05, 0.38888888888889
6647, 0.52173913043478, 0.05, 0.44444444444444
6648, 0.56521739130435, 0.05, 0.055555555555556
6649, 0.56521739130435, 0.05, 0.11111111111111
6650, 0.56521739130435, 0.05, 0.16666666666667
6651, 0.56521739130435, 0.05, 0.22222222222222
6652, 0.56521739130435, 0.05, 0.27777777777778
6653, 0.56521739130435, 0.05, 0.33333333333333
6654, 0.56521739130435, 0.05, 0.38888888888889
6655, 0.56521739130435, 0.05, 0.44444444444444
6656, 0.60869565217391, 0.05, 0.055555555555556
6657, 0.60869565217391, 0.05, 0.11111111111111
6658, 0.60869565217391, 0.05, 0.16666666666667
6659, 0.60869565217391, 0.05, 0.22222222222222
6660, 0.60869565217391, 0.05, 0.27777777777778
6661, 0.60869565217391, 0.05, 0.33333333333333
6662, 0.60869565217391, 0.05, 0.38888888888889
6663, 0.60869565217391, 0.05, 0.44444444444444
6664, 0.65217391304348, 0.05, 0.055555555555556
6665, 0.65217391304348, 0.05, 0.11111111111111
6666, 0.65217391304348, 0.05, 0.16666666666667
6667, 0.65217391304348, 0.05, 0.22222222222222
6668, 0.65217391304348, 0.05, 0.27777777777778
6669, 0.65217391304348, 0.05, 0.33333333333333
6670, 0.65217391304348, 0.05, 0.38888888888889
6671, 0.65217391304348, 0.05, 0.44444444444444
6672, 0.69565217391304, 0.05, 0.055555555555556
6673, 0.69565217391304, 0.05, 0.11111111111111
6674, 0.69565217391304, 0.05, 0.16666666666667
6675, 0.69565217391304, 0.05, 0.22222222222222
6676, 0.69565217391304, 0.05, 0.27777777777778
6677, 0.69565217391304, 0.05, 0.33333333333333
6678, 0.69565217391304, 0.05, 0.38888888888889
6679, 0.69565217391304, 0.05, 0.44444444444444
6680, 0.73913043478261, 0.05, 0.055555555555556
6681, 0.73913043478261, 0.05, 0.11111111111111
6682, 0.73913043478261, 0.05, 0.16666666666667
6683, 0.73913043478261, 0.05, 0.22222222222222
6684, 0.73913043478261, 0.05, 0.27777777777778
6685, 0.73913043478261, 0.05, 0.33333333333333
6686, 0.73913043478261, 0.05, 0.38888888888889
6687, 0.73913043478261, 0.05, 0.44444444444444
6688, 0.78260869565217, 0.05, 0.055555555555556
6689, 0.78260869565217, 0.05, 0.11111111111111
6690, 0.78260869565217, 0.05, 0.16666666666667
6691, 0.78260869565217, 0.05, 0.22222222222222
6692, 0.78260869565217, 0.05, 0.27777777777778
6693, 0.78260869565217, 0.05, 0.33333333333333
6694, 0.78260869565217, 0.05, 0.38888888888889
6695, 0.78260869565217, 0.05, 0.44444444444444
6696, 0.82608695652174, 0.05, 0.055555555555556
6697, 0.82608695652174, 0.05, 0.11111111111111
6698, 0.82608695652174, 0.05, 0.16666666666667
6699, 0.82608695652174, 0.05, 0.22222222222222
6700, 0.82608695652174, 0.05, 0.27777777777778
6701, 0.82608695652174, 0.05, 0.33333333333333
6702, 0.82608695652174, 0.05, 0.38888888888889
6703, 0.82608695652174, 0.05, 0.44444444444444
6704, 0.8695652173913, 0.05, 0.055555555555556
6705, 0.8695652173913, 0.05, 0.11111111111111
6706, 0.8695652173913, 0.05, 0.16666666666667
6707, 0.8695652173913, 0.05, 0.22222222222222
6708, 0.8695652173913, 0.05, 0.27777777777778
6709, 0.8695652173913, 0.05, 0.33333333333333
6710, 0.8695652173913, 0.05, 0.38888888888889
6711, 0.8695652173913, 0.05, 0.44444444444444
6712, 0.91304347826087, 0.05, 0.055555555555556
6713, 0.91304347826087, 0.05, 0.11111111111111
6714, 0.91304347826087, 0.05, 0.16666666666667
6715, 0.91304347826087, 0.05, 0.22222222222222
6716, 0.91304347826087, 0.05, 0.27777777777778
6717, 0.91304347826087, 0.05, 0.33333333333333
6718, 0.91304347826087, 0.05, 0.38888888888889
6719, 0.91304347826087, 0.05, 0.44444444444444
6720, 0.95652173913043, 0.05, 0.055555555555556
6721, 0.95652173913043, 0.05, 0.11111111111111
6722, 0.95652173913043, 0.05, 0.16666666666667
6723, 0.95652173913043, 0.05, 0.22222222222222
6724, 0.95652173913043, 0.05, 0.27777777777778
6725, 0.95652173913043, 0.05, 0.33333333333333
6726, 0.95652173913043, 0.05, 0.38888888888889
6727, 0.95652173913043, 0.05, 0.44444444444444
6728, 0.021739130434783, 0.05, 0.055555555555556
6729, 0.043478260869565, 0.05, 0.027777777777778
6730, 0.021739130434783, 0.05, 0.11111111111111
6731, 0.043478260869565, 0.05, 0.083333333333333
6732, 0.021739130434783, 0.05, 0.16666666666667
6733, 0.043478260869565, 0.05, 0.13888888888889
6734, 0.021739130434783, 0.05, 0.22222222222222
6735, 0.043478260869565, 0.05, 0.19444444444444
6736, 0.021739130434783, 0.05, 0.27777777777778
6737, 0.043478260869565, 0.05, 0.25
6738, 0.021739130434783, 0.05, 0.33333333333333
6739, 0.043478260869565, 0.05, 0.30555555555556
6740, 0.021739130434783, 0.05, 0.38888888888889
6741, 0.043478260869565, 0.05, 0.36111111111111
6742, 0.021739130434783, 0.05, 0.44444444444444
6743, 0.043478260869565, 0.05, 0.41666666666667
6744, 0.043478260869565, 0.05, 0.47222222222222
6745, 0.065217391304348, 0.05, 0.055555555555556
6746, 0.08695652173913, 0.05, 0.027777777777778
6747, 0.065217391304348, 0.05, 0.11111111111111
6748, 0.08695652173913, 0.05, 0.083333333333333
6749, 0.065217391304348, 0.05, 0.16666666666667
6750, 0.08695652173913, 0.05, 0.13888888888889
6751, 0.065217391304348, 0.05, 0.22222222222222
6752, 0.08695652173913, 0.05, 0.19444444444444
6753, 0.065217391304348, 0.05, 0.27777777777778
6754, 0.08695652173913, 0.05, 0.25
6755, 0.065217391304348, 0.05, 0.33333333333333
6756, 0.08695652173913, 0.05, 0.30555555555556
6757, 0.065217391304348, 0.05, 0.38888888888889
6758, 0.08695652173913, 0.05, 0.36111111111111
6759, 0.065217391304348, 0.05, 0.44444444444444
6760, 0.08695652173913, 0.05, 0.41666666666667
6761, 0.08695652173913, 0.05, 0.47222222222222
6762, 0.10869565217391, 0.05, 0.055555555555556
6763, 0.1304347826087, 0.05, 0.027777777777778
6764, 0.10869565217391, 0.05, 0.11111111111111
6765, 0.1304347826087, 0.05, 0.083333333333333
6766, 0.10869565217391, 0.05, 0.16666666666667
6767, 0.1304347826087, 0.05, 0.13888888888889
6768, 0.10869565217391, 0.05, 0.22222222222222
6769, 0.1304347826087, 0.05, 0.19444444444444
6770, 0.10869565217391, 0.05, 0.27777777777778
6771, 0.1304347826087, 0.05, 0.25
6772, 0.10869565217391, 0.05, 0.33333333333333
6773, 0.1304347826087, 0.05, 0.30555555555556
6774, 0.10869565217391, 0.05, 0.38888888888889
6775, 0.1304347826087, 0.05, 0.36111111111111
6776, 0.10869565217391, 0.05, 0.44444444444444
6777, 0.1304347826087, 0.05, 0.41666666666667
6778, 0.1304347826087, 0.05, 0.47222222222222
6779, 0.15217391304348, 0.05, 0.055555555555556
6780, 0.17391304347826, 0.05, 0.027777777777778
6781, 0.15217391304348, 0.05, 0.11111111111111
6782, 0.17391304347826, 0.05, 0.083333333333333
6783, 0.15217391304348, 0.05, 0.16666666666667
6784, 0.17391304347826, 0.05, 0.13888888888889
6785, 0.15217391304348, 0.05, 0.22222222222222
6786, 0.17391304347826, 0.05, 0.19444444444444
6787, 0.15217391304348, 0.05, 0.27777777777778
6788, 0.17391304347826, 0.05, 0.25
6789, 0.15217391304348, 0.05, 0.33333333333333
6790, 0.17391304347826, 0.05, 0.30555555555556
6791, 0.15217391304348, 0.05, 0.38888888888889
6792, 0.17391304347826, 0.05, 0.36111111111111
6793, 0.15217391304348, 0.05, 0.44444444444444
6794, 0.17391304347826, 0.05, 0.41666666666667
6795, 0.17391304347826, 0.05, 0.47222222222222
6796, 0.19565217391304, 0.05, 0.055555555555556
6797, 0.21739130434783, 0.05, 0.027777777777778
6798, 0.19565217391304, 0.05, 0.11111111111111
6799, 0.21739130434783, 0.05, 0.083333333333333
6800, 0.19565217391304, 0.05, 0.16666666666667
6801, 0.21739130434783, 0.05, 0.13888888888889
6802, 0.19565217391304, 0.05, 0.22222222222222
6803, 0.21739130434783, 0.05, 0.19444444444444
6804, 0.19565217391304, 0.05, 0.27777777777778
6805, 0.21739130434783, 0.05, 0.25
6806, 0.19565217391304, 0.05, 0.33333333333333
6807, 0.21739130434783, 0.05, 0.30555555555556
6808, 0.19565217391304, 0.05, 0.38888888888889
6809, 0.21739130434783, 0.05, 0.36111111111111
6810, 0.19565217391304, 0.05, 0.44444444444444
6811, 0.21739130434783, 0.05, 0.41666666666667
6812, 0.21739130434783, 0.05, 0.47222222222222
6813, 0.23913043478261, 0.05, 0.055555555555556
6814, 0.26086956521739, 0.05, 0.027777777777778
6815, 0.23913043478261, 0.05, 0.11111111111111
6816, 0.26086956521739, 0.05, 0.083333333333333
6817, 0.23913043478261, 0.05, 0.16666666666667
6818, 0.26086956521739, 0.05, 0.13888888888889
6819, 0.23913043478261, 0.05, 0.22222222222222
6820, 0.26086956521739, 0.05, 0.19444444444444
6821, 0.23913043478261, 0.05, 0.27777777777778
6822, 0.26086956521739, 0.05, 0.25
6823, 0.23913043478261, 0.05, 0.33333333333333
6824, 0.26086956521739, 0.05, 0.30555555555556
6825, 0.23913043478261, 0.05, 0.38888888888889
6826, 0.26086956521739, 0.05, 0.36111111111111
6827, 0.23913043478261, 0.05, 0.44444444444444
6828, 0.26086956521739, 0.05, 0.41666666666667
6829, 0.26086956521739, 0.05, 0.47222222222222
6830, 0.28260869565217, 0.05, 0.055555555555556
6831, 0.30434782608696, 0.05, 0.027777777777778
6832, 0.28260869565217, 0.05, 0.11111111111111
6833, 0.30434782608696, 0.05, 0.083333333333333
6834, 0.28260869565217, 0.05, 0.16666666666667
6835, 0.30434782608696, 0.05, 0.13888888888889
6836, 0.28260869565217, 0.05, 0.22222222222222
6837, 0.30434782608696, 0.05, 0.19444444444444
6838, 0.28260869565217, 0.05, 0.27777777777778
6839, 0.30434782608696, 0.05, 0.25
6840, 0.28260869565217, 0.05, 0.33333333333333
6841, 0.30434782608696, 0.05, 0.30555555555556
6842, 0.28260869565217, 0.05, 0.38888888888889
6843, 0.30434782608696, 0.05, 0.36111111111111
6844, 0.28260869565217, 0.05, 0.44444444444444
6845, 0.30434782608696, 0.05, 0.41666666666667
6846, 0.30434782608696, 0.05, 0.47222222222222
6847, 0.32608695652174, 0.05, 0.055555555555556
6848, 0.34782608695652, 0.05, 0.027777777777778
6849, 0.32608695652174, 0.05, 0.11111111111111
6850, 0.34782608695652, 0.05, 0.083333333333333
6851, 0.32608695652174, 0.05, 0.16666666666667
6852, 0.34782608695652, 0.05, 0.13888888888889
6853, 0.32608695652174, 0.05, 0.22222222222222
6854, 0.34782608695652, 0.05, 0.19444444444444
6855, 0.32608695652174, 0.05, 0.27777777777778
6856, 0.34782608695652, 0.05, 0.25
6857, 0.32608695652174, 0.05, 0.33333333333333
6858, 0.34782608695652, 0.05, 0.30555555555556
6859, 0.32608695652174, 0.05, 0.38888888888889
6860, 0.34782608695652, 0.05, 0.36111111111111
6861, 0.32608695652174, 0.05, 0.44444444444444
6862, 0.34782608695652, 0.05, 0.41666666666667
6863, 0.34782608695652, 0.05, 0.47222222222222
6864, 0.3695652173913, 0.05, 0.055555555555556
6865, 0.39130434782609, 0.05, 0.027777777777778
6866, 0.3695652173913, 0.05, 0.11111111111111
6867, 0.39130434782609, 0.05, 0.083333333333333
6868, 0.3695652173913, 0.05, 0.16666666666667
6869, 0.39130434782609, 0.05, 0.13888888888889
6870, 0.3695652173913, 0.05, 0.22222222222222
6871, 0.39130434782609, 0.05, 0.19444444444444
6872, 0.3695652173913, 0.05, 0.27777777777778
6873, 0.39130434782609, 0.05, 0.25
6874, 0.3695652173913, 0.05, 0.33333333333333
6875, 0.39130434782609, 0.05, 0.30555555555556
6876, 0.3695652173913, 0.05, 0.38888888888889
6877, 0.39130434782609, 0.05, 0.36111111111111
6878, 0.3695652173913, 0.05, 0.44444444444444
6879, 0.39130434782609, 0.05, 0.41666666666667
6880, 0.39130434782609, 0.05, 0.47222222222222
6881, 0.41304347826087, 0.05, 0.055555555555556
6882, 0.43478260869565, 0.05, 0.027777777777778
6883, 0.41304347826087, 0.05, 0.11111111111111
6884, 0.43478260869565, 0.05, 0.083333333333333
6885, 0.41304347826087, 0.05, 0.16666666666667
6886, 0.43478260869565, 0.05, 0.13888888888889
6887, 0.41304347826087, 0.05, 0.22222222222222
6888, 0.43478260869565, 0.05, 0.19444444444444
6889, 0.41304347826087, 0.05, 0.27777777777778
6890, 0.43478260869565, 0.05, 0.25
6891, 0.41304347826087, 0.05, 0.33333333333333
6892, 0.43478260869565, 0.05, 0.30555555555556
6893, 0.41304347826087, 0.05, 0.38888888888889
6894, 0.43478260869565, 0.05, 0.36111111111111
6895, 0.41304347826087, 0.05, 0.44444444444444
6896, 0.43478260869565, 0.05, 0.41666666666667
6897, 0.43478260869565, 0.05, 0.47222222222222
6898, 0.45652173913043, 0.05, 0.055555555555556
6899, 0.47826086956522, 0.05, 0.027777777777778
6900, 0.45652173913043, 0.05, 0.11111111111111
6901, 0.47826086956522, 0.05, 0.083333333333333
6902, 0.45652173913043, 0.05, 0.16666666666667
6903, 0.47826086956522, 0.05, 0.13888888888889
6904, 0.45652173913043, 0.05, 0.22222222222222
6905, 0.47826086956522, 0.05, 0.19444444444444
6906, 0.45652173913043, 0.05, 0.27777777777778
6907, 0.47826086956522, 0.05, 0.25
6908, 0.45652173913043, 0.05, 0.33333333333333
6909, 0.47826086956522, 0.05, 0.30555555555556
6910, 0.45652173913043, 0.05, 0.38888888888889
6911, 0.47826086956522, 0.05, 0.36111111111111
6912, 0.45652173913043, 0.05, 0.44444444444444
6913, 0.47826086956522, 0.05, 0.41666666666667
6914, 0.47826086956522, 0.05, 0.47222222222222
6915, 0.5, 0.05, 0.055555555555556
6916, 0.52173913043478, 0.05, 0.027777777777778
6917, 0.5, 0.05, 0.11111111111111
6918, 0.52173913043478, 0.05, 0.083333333333333
6919, 0.5, 0.05, 0.16666666666667
6920, 0.52173913043478, 0.05, 0.13888888888889
6921, 0.5, 0.05, 0.22222222222222
6922, 0.52173913043478, 0.05, 0.19444444444444
6923, 0.5, 0.05, 0.27777777777778
6924, 0.52173913043478, 0.05, 0.25
6925, 0.5, 0.05, 0.33333333333333
6926, 0.52173913043478, 0.05, 0.30555555555556
6927, 0.5, 0.05, 0.38888888888889
6928, 0.52173913043478, 0.05, 0.36111111111111
6929, 0.5, 0.05, 0.44444444444444
6930, 0.52173913043478, 0.05, 0.41666666666667
6931, 0.52173913043478, 0.05, 0.47222222222222
6932, 0.54347826086957, 0.05, 0.055555555555556
6933, 0.56521739130435, 0.05, 0.027777777777778
6934, 0.54347826086957, 0.05, 0.11111111111111
6935, 0.56521739130435, 0.05, 0.083333333333333
6936, 0.54347826086957, 0.05, 0.16666666666667
6937, 0.56521739130435, 0.05, 0.13888888888889
6938, 0.54347826086957, 0.05, 0.22222222222222
6939, 0.56521739130435, 0.05, 0.19444444444444
6940, 0.54347826086957, 0.05, 0.27777777777778
6941, 0.56521739130435, 0.05, 0.25
6942, 0.54347826086957, 0.05, 0.33333333333333
6943, 0.56521739130435, 0.05, 0.30555555555556
6944, 0.54347826086957, 0.05, 0.38888888888889
6945, 0.56521739130435, 0.05, 0.36111111111111
6946, 0.54347826086957, 0.05, 0.44444444444444
6947, 0.56521739130435, 0.05, 0.41666666666667
6948, 0.56521739130435, 0.05, 0.47222222222222
6949, 0.58695652173913, 0.05, 0.055555555555556
6950, 0.60869565217391, 0.05, 0.027777777777778
6951, 0.58695652173913, 0.05, 0.11111111111111
6952, 0.60869565217391, 0.05, 0.083333333333333
6953, 0.58695652173913, 0.05, 0.16666666666667
6954, 0.60869565217391, 0.05, 0.13888888888889
6955, 0.58695652173913, 0.05, 0.22222222222222
6956, 0.60869565217391, 0.05, 0.19444444444444
6957, 0.58695652173913, 0.05, 0.27777777777778
6958, 0.60869565217391, 0.05, 0.25
6959, 0.58695652173913, 0.05, 0.33333333333333
6960, 0.60869565217391, 0.05, 0.30555555555556
6961, 0.58695652173913, 0.05, 0.38888888888889
6962, 0.60869565217391, 0.05, 0.36111111111111
6963, 0.58695652173913, 0.05, 0.44444444444444
6964, 0.60869565217391, 0.05, 0.41666666666667
6965, 0.60869565217391, 0.05, 0.47222222222222
6966, 0.6304347826087, 0.05, 0.055555555555556
6967, 0.65217391304348, 0.05, 0.027777777777778
6968, 0.6304347826087, 0.05, 0.11111111111111
6969, 0.65217391304348, 0.05, 0.083333333333333
6970, 0.6304347826087, 0.05, 0.16666666666667
6971, 0.65217391304348, 0.05, 0.13888888888889
6972, 0.6304347826087, 0.05, 0.22222222222222
6973, 0.65217391304348, 0.05, 0.19444444444444
6974, 0.6304347826087, 0.05, 0.27777777777778
6975, 0.65217391304348, 0.05, 0.25
6976, 0.6304347826087, 0.05, 0.33333333333333
6977, 0.65217391304348, 0.05, 0.30555555555556
6978, 0.6304347826087, 0.05, 0.38888888888889
6979, 0.65217391304348, 0.05, 0.36111111111111
6980, 0.6304347826087, 0.05, 0.44444444444444
6981, 0.65217391304348, 0.05, 0.41666666666667
6982, 0.65217391304348, 0.05, 0.47222222222222
6983, 0.67391304347826, 0.05, 0.055555555555556
6984, 0.69565217391304, 0.05, 0.027777777777778
6985, 0.67391304347826, 0.05, 0.11111111111111
6986, 0.69565217391304, 0.05, 0.083333333333333
6987, 0.67391304347826, 0.05, 0.16666666666667
6988, 0.69565217391304, 0.05, 0.13888888888889
6989, 0.67391304347826, 0.05, 0.22222222222222
6990, 0.69565217391304, 0.05, 0.19444444444444
6991, 0.67391304347826, 0.05, 0.27777777777778
6992, 0.69565217391304, 0.05, 0.25
6993, 0.67391304347826, 0.05, 0.33333333333333
6994, 0.69565217391304, 0.05, 0.30555555555556
6995, 0.67391304347826, 0.05, 0.38888888888889
6996, 0.69565217391304, 0.05, 0.36111111111111
6997, 0.67391304347826, 0.05, 0.44444444444444
6998, 0.69565217391304, 0.05, 0.41666666666667
6999, 0.69565217391304, 0.05, 0.47222222222222
7000, 0.71739130434783, 0.05, 0.055555555555556
7001, 0.73913043478261, 0.05, 0.027777777777778
7002, 0.71739130434783, 0.05, 0.11111111111111
7003, 0.73913043478261, 0.05, 0.083333333333333
7004, 0.71739130434783, 0.05, 0.16666666666667
7005, 0.73913043478261, 0.05, 0.13888888888889
7006, 0.71739130434783, 0.05, 0.22222222222222
7007, 0.73913043478261, 0.05, 0.19444444444444
7008, 0.71739130434783, 0.05, 0.27777777777778
7009, 0.73913043478261, 0.05, 0.25
7010, 0.71739130434783, 0.05, 0.33333333333333
7011, 0.73913043478261, 0.05, 0.30555555555556
7012, 0.71739130434783, 0.05, 0.38888888888889
7013, 0.73913043478261, 0.05, 0.36111111111111
7014, 0.71739130434783, 0.05, 0.44444444444444
7015, 0.73913043478261, 0.05, 0.41666666666667
7016, 0.73913043478261, 0.05, 0.47222222222222
7017, 0.76086956521739, 0.05, 0.055555555555556
7018, 0.78260869565217, 0.05, 0.027777777777778
7019, 0.76086956521739, 0.05, 0.11111111111111
7020, 0.78260869565217, 0.05, 0.083333333333333
7021, 0.76086956521739, 0.05, 0.16666666666667
7022, 0.78260869565217, 0.05, 0.13888888888889
7023, 0.76086956521739, 0.05, 0.22222222222222
7024, 0.78260869565217, 0.05, 0.19444444444444
7025, 0.76086956521739, 0.05, 0.27777777777778
7026, 0.78260869565217, 0.05, 0.25
7027, 0.76086956521739, 0.05, 0.33333333333333
7028, 0.78260869565217, 0.05, 0.30555555555556
7029, 0.76086956521739, 0.05, 0.38888888888889
7030, 0.78260869565217, 0.05, 0.36111111111111
7031, 0.76086956521739, 0.05, 0.44444444444444
7032, 0.78260869565217, 0.05, 0.41666666666667
7033, 0.78260869565217, 0.05, 0.47222222222222
7034, 0.80434782608696, 0.05, 0.055555555555556
7035, 0.82608695652174, 0.05, 0.027777777777778
7036, 0.80434782608696, 0.05, 0.11111111111111
7037, 0.82608695652174, 0.05, 0.083333333333333
7038, 0.80434782608696, 0.05, 0.16666666666667
7039, 0.82608695652174, 0.05, 0.13888888888889
7040, 0.80434782608696, 0.05, 0.22222222222222
7041, 0.82608695652174, 0.05, 0.19444444444444
7042, 0.80434782608696, 0.05, 0.27777777777778
7043, 0.82608695652174, 0.05, 0.25
7044, 0.80434782608696, 0.05, 0.33333333333333
7045, 0.82608695652174, 0.05, 0.30555555555556
7046, 0.80434782608696, 0.05, 0.38888888888889
7047, 0.82608695652174, 0.05, 0.36111111111111
7048, 0.80434782608696, 0.05, 0.44444444444444
7049, 0.82608695652174, 0.05, 0.41666666666667
7050, 0.82608695652174, 0.05, 0.47222222222222
7051, 0.84782608695652, 0.05, 0.055555555555556
7052, 0.8695652173913, 0.05, 0.027777777777778
7053, 0.84782608695652, 0.05, 0.11111111111111
7054, 0.8695652173913, 0.05, 0.083333333333333
7055, 0.84782608695652, 0.05, 0.16666666666667
7056, 0.8695652173913, 0.05, 0.13888888888889
7057, 0.84782608695652, 0.05, 0.22222222222222
7058, 0.8695652173913, 0.05, 0.19444444444444
7059, 0.84782608695652, 0.05, 0.27777777777778
7060, 0.8695652173913, 0.05, 0.25
7061, 0.84782608695652, 0.05, 0.33333333333333
7062, 0.8695652173913, 0.05, 0.30555555555556
7063, 0.84782608695652, 0.05, 0.38888888888889
7064, 0.8695652173913, 0.05, 0.36111111111111
7065, 0.84782608695652, 0.05, 0.44444444444444
7066, 0.8695652173913, 0.05, 0.41666666666667
7067, 0.8695652173913, 0.05, 0.47222222222222
7068, 0.89130434782609, 0.05, 0.055555555555556
7069, 0.91304347826087, 0.05, 0.027777777777778
7070, 0.89130434782609, 0.05, 0.11111111111111
7071, 0.91304347826087, 0.05, 0.083333333333333
7072, 0.89130434782609, 0.05, 0.16666666666667
7073, 0.91304347826087, 0.05, 0.13888888888889
7074, 0.89130434782609, 0.05, 0.22222222222222
7075, 0.91304347826087, 0.05, 0.19444444444444
7076, 0.89130434782609, 0.05, 0.27777777777778
7077, 0.91304347826087, 0.05, 0.25
7078, 0.89130434782609, 0.05, 0.33333333333333
7079, 0.91304347826087, 0.05, 0.30555555555556
7080, 0.89130434782609, 0.05, 0.38888888888889
7081, 0.91304347826087, 0.05, 0.36111111111111
7082, 0.89130434782609, 0.05, 0.44444444444444
7083, 0.91304347826087, 0.05, 0.41666666666667
7084, 0.91304347826087, 0.05, 0.47222222222222
7085, 0.93478260869565, 0.05, 0.055555555555556
7086, 0.95652173913043, 0.05, 0.027777777777778
7087, 0.93478260869565, 0.05, 0.11111111111111
7088, 0.95652173913043, 0.05, 0.083333333333333
7089, 0.93478260869565, 0.05, 0.16666666666667
7090, 0.95652173913043, 0.05, 0.13888888888889
7091, 0.93478260869565, 0.05, 0.22222222222222
7092, 0.95652173913043, 0.05, 0.19444444444444
7093, 0.93478260869565, 0.05, 0.27777777777778
7094, 0.95652173913043, 0.05, 0.25
7095, 0.93478260869565, 0.05, 0.33333333333333
7096, 0.95652173913043, 0.05, 0.30555555555556
7097, 0.93478260869565, 0.05, 0.38888888888889
7098, 0.95652173913043, 0.05, 0.36111111111111
7099, 0.93478260869565, 0.05, 0.44444444444444
7100, 0.95652173913043, 0.05, 0.41666666666667
7101, 0.95652173913043, 0.05, 0.47222222222222
7102, 0.97826086956522, 0.05, 0.055555555555556
7103, 0.97826086956522, 0.05, 0.11111111111111
7104, 0.97826086956522, 0.05, 0.16666666666667
7105, 0.97826086956522, 0.05, 0.22222222222222
7106, 0.97826086956522, 0.05, 0.27777777777778
7107, 0.97826086956522, 0.05, 0.33333333333333
7108, 0.97826086956522, 0.05, 0.38888888888889
7109, 0.97826086956522, 0.05, 0.44444444444444
7110, 0.043478260869565, -0.016666666666667, 0
7111, 0.08695652173913, -0.016666666666667, 0
7112, 0.1304347826087, -0.016666666666667, 0
7113, 0.17391304347826, -0.016666666666667, 0
7114, 0.21739130434783, -0.016666666666667, 0
7115, 0.26086956521739, -0.016666666666667, 0
7116, 0.30434782608696, -0.016666666666667, 0
7117, 0.34782608695652, -0.016666666666667, 0
7118, 0.39130434782609, -0.016666666666667, 0
7119, 0.43478260869565, -0.016666666666667, 0
7120, 0.47826086956522, -0.016666666666667, 0
7121, 0.52173913043478, -0.016666666666667, 0
7122, 0.56521739130435, -0.016666666666667, 0
7123, 0.60869565217391, -0.016666666666667, 0
7124, 0.65217391304348, -0.016666666666667, 0
7125, 0.69565217391304, -0.016666666666667, 0
7126, 0.73913043478261, -0.016666666666667, 0
7127, 0.78260869565217, -0.016666666666667, 0
7128, 0.82608695652174, -0.016666666666667, 0
7129, 0.8695652173913, -0.016666666666667, 0
7130, 0.91304347826087, -0.016666666666667, 0
7131, 0.95652173913043, -0.016666666666667, 0
7132, 0.043478260869565, 0.016666666666667, 0
7133, 0.08695652173913, 0.016666666666667, 0
7134, 0.1304347826087, 0.016666666666667, 0
7135, 0.17391304347826, 0.016666666666667, 0
7136, 0.21739130434783, 0.016666666666667, 0
7137, 0.26086956521739, 0.016666666666667, 0
7138, 0.30434782608696, 0.016666666666667, 0
7139, 0.34782608695652, 0.016666666666667, 0
7140, 0.39130434782609, 0.016666666666667, 0
7141, 0.43478260869565, 0.016666666666667, 0
7142, 0.47826086956522, 0.016666666666667, 0
7143, 0.52173913043478, 0.016666666666667, 0
7144, 0.56521739130435, 0.016666666666667, 0
7145, 0.60869565217391, 0.016666666666667, 0
7146, 0.65217391304348, 0.016666666666667, 0
7147, 0.69565217391304, 0.016666666666667, 0
7148, 0.73913043478261, 0.016666666666667, 0
7149, 0.78260869565217, 0.016666666666667, 0
7150, 0.82608695652174, 0.016666666666667, 0
7151, 0.8695652173913, 0.016666666666667, 0
7152, 0.91304347826087, 0.016666666666667, 0
7153, 0.95652173913043, 0.016666666666667, 0
7154, 0.021739130434783, -0.016666666666667, 0
7155, 0.043478260869565, -0.033333333333333, 0
7156, 0.065217391304348, -0.016666666666667, 0
7157, 0.08695652173913, -0.033333333333333, 0
7158, 0.10869565217391, -0.016666666666667, 0
7159, 0.1304347826087, -0.033333333333333, 0
7160, 0.15217391304348, -0.016666666666667, 0
7161, 0.17391304347826, -0.033333333333333, 0
7162, 0.19565217391304, -0.016666666666667, 0
7163, 0.21739130434783, -0.033333333333333, 0
7164, 0.23913043478261, -0.016666666666667, 0
7165, 0.26086956521739, -0.033333333333333, 0
7166, 0.28260869565217, -0.016666666666667, 0
7167, 0.30434782608696, -0.033333333333333, 0
7168, 0.32608695652174, -0.016666666666667, 0
7169, 0.34782608695652, -0.033333333333333, 0
7170, 0.3695652173913, -0.016666666666667, 0
7171, 0.39130434782609, -0.033333333333333, 0
7172, 0.41304347826087, -0.016666666666667, 0
7173, 0.43478260869565, -0.033333333333333, 0
7174, 0.45652173913043, -0.016666666666667, 0
7175, 0.47826086956522, -0.033333333333333, 0
7176, 0.5, -0.016666666666667, 0
7177, 0.52173913043478, -0.033333333333333, 0
7178, 0.54347826086957, -0.016666666666667, 0
7179, 0.56521739130435, -0.033333333333333, 0
7180, 0.58695652173913, -0.016666666666667, 0
7181, 0.60869565217391, -0.033333333333333, 0
7182, 0.6304347826087, -0.016666666666667, 0
7183, 0.65217391304348, -0.033333333333333, 0
7184, 0.67391304347826, -0.016666666666667, 0
7185, 0.69565217391304, -0.033333333333333, 0
7186, 0.71739130434783, -0.016666666666667, 0
7187, 0.73913043478261, -0.033333333333333, 0
7188, 0.76086956521739, -0.016666666666667, 0
7189, 0.78260869565217, -0.033333333333333, 0
7190, 0.80434782608696, -0.016666666666667, 0
7191, 0.82608695652174, -0.033333333333333, 0
7192, 0.84782608695652, -0.016666666666667, 0
7193, 0.8695652173913, -0.033333333333333, 0
7194, 0.89130434782609, -0.016666666666667, 0
7195, 0.91304347826087, -0.033333333333333, 0
7196, 0.93478260869565, -0.016666666666667, 0
7197, 0.95652173913043, -0.033333333333333, 0
7198, 0.97826086956522, -0.016666666666667, 0
7199, 0.021739130434783, 0.016666666666667, 0
7200, 0.043478260869565, 5.5511151231258e-17, 0
7201, 0.065217391304348, 0.016666666666667, 0
7202, 0.08695652173913, 5.5511151231258e-17, 0
7203, 0.10869565217391, 0.016666666666667, 0
7204, 0.1304347826087, 5.5511151231258e-17, 0
7205, 0.15217391304348, 0.016666666666667, 0
7206, 0.17391304347826, 5.5511151231258e-17, 0
7207, 0.19565217391304, 0.016666666666667, 0
7208, 0.21739130434783, 5.5511151231258e-17, 0
7209, 0.23913043478261, 0.016666666666667, 0
7210, 0.26086956521739, 5.5511151231258e-17, 0
7211, 0.28260869565217, 0.016666666666667, 0
7212, 0.30434782608696, 5.5511151231258e-17, 0
7213, 0.32608695652174, 0.016666666666667, 0
7214, 0.34782608695652, 5.5511151231258e-17, 0
7215, 0.3695652173913, 0.016666666666667, 0
7216, 0.39130434782609, 5.5511151231258e-17, 0
7217, 0.41304347826087, 0.016666666666667, 0
7218, 0.43478260869565, 4.8572257327351e-17, 0
7219, 0.45652173913043, 0.016666666666667, 0
7220, 0.47826086956522, 5.5511151231258e-17, 0
7221, 0.5, 0.016666666666667, 0
7222, 0.52173913043478, 5.5511151231258e-17, 0
7223, 0.54347826086957, 0.016666666666667, 0
7224, 0.56521739130435, 5.5511151231258e-17, 0
7225, 0.58695652173913, 0.016666666666667, 0
7226, 0.60869565217391, 5.5511151231258e-17, 0
7227, 0.6304347826087, 0.016666666666667, 0
7228, 0.65217391304348, 5.5511151231258e-17, 0
7229, 0.67391304347826, 0.016666666666667, 0
7230, 0.69565217391304, 5.5511151231258e-17, 0
7231, 0.71739130434783, 0.016666666666667, 0
7232, 0.73913043478261, 5.5511151231258e-17, 0
7233, 0.76086956521739, 0.016666666666667, 0
7234, 0.78260869565217, 5.5511151231258e-17, 0
7235, 0.80434782608696, 0.016666666666667, 0
7236, 0.82608695652174, 5.5511151231258e-17, 0
7237, 0.84782608695652, 0.016666666666667, 0
7238, 0.8695652173913, 5.5511151231258e-17, 0
7239, 0.89130434782609, 0.016666666666667, 0
7240, 0.91304347826087, 5.5511151231258e-17, 0
7241, 0.93478260869565, 0.016666666666667, 0
7242, 0.95652173913043, 5.5511151231258e-17, 0
7243, 0.97826086956522, 0.016666666666667, 0
7244, 0.043478260869565, 0.033333333333333, 0
7245, 0.08695652173913, 0.033333333333333, 0
7246, 0.1304347826087, 0.033333333333333, 0
7247, 0.17391304347826, 0.033333333333333, 0
7248, 0.21739130434783, 0.033333333333333, 0
7249, 0.26086956521739, 0.033333333333333, 0
7250, 0.30434782608696, 0.033333333333333, 0
7251, 0.34782608695652, 0.033333333333333, 0
7252, 0.39130434782609, 0.033333333333333, 0
7253, 0.43478260869565, 0.033333333333333, 0
7254, 0.47826086956522, 0.033333333333333, 0
7255, 0.52173913043478, 0.033333333333333, 0
7256, 0.56521739130435, 0.033333333333333, 0
7257, 0.60869565217391, 0.033333333333333, 0
7258, 0.65217391304348, 0.033333333333333, 0
7259, 0.69565217391304, 0.033333333333333, 0
7260, 0.73913043478261, 0.033333333333333, 0
7261, 0.78260869565217, 0.033333333333333, 0
7262, 0.82608695652174, 0.033333333333333, 0
7263, 0.8695652173913, 0.033333333333333, 0
7264, 0.91304347826087, 0.033333333333333, 0
7265, 0.95652173913043, 0.033333333333333, 0
7266, 0.043478260869565, -0.016666666666667, 0.5
7267, 0.08695652173913, -0.016666666666667, 0.5
7268, 0.1304347826087, -0.016666666666667, 0.5
7269, 0.17391304347826, -0.016666666666667, 0.5
7270, 0.21739130434783, -0.016666666666667, 0.5
7271, 0.26086956521739, -0.016666666666667, 0.5
7272, 0.30434782608696, -0.016666666666667, 0.5
7273, 0.34782608695652, -0.016666666666667, 0.5
7274, 0.39130434782609, -0.016666666666667, 0.5
7275, 0.43478260869565, -0.016666666666667, 0.5
7276, 0.47826086956522, -0.016666666666667, 0.5
7277, 0.52173913043478, -0.016666666666667, 0.5
7278, 0.56521739130435, -0.016666666666667, 0.5
7279, 0.60869565217391, -0.016666666666667, 0.5
7280, 0.65217391304348, -0.016666666666667, 0.5
7281, 0.69565217391304, -0.016666666666667, 0.5
7282, 0.73913043478261, -0.016666666666667, 0.5
7283, 0.78260869565217, -0.016666666666667, 0.5
7284, 0.82608695652174, -0.016666666666667, 0.5
7285, 0.8695652173913, -0.016666666666667, 0.5
7286, 0.91304347826087, -0.016666666666667, 0.5
7287, 0.95652173913043, -0.016666666666667, 0.5
7288, 0.043478260869565, 0.016666666666667, 0.5
7289, 0.08695652173913, 0.016666666666667, 0.5
7290, 0.1304347826087, 0.016666666666667, 0.5
7291, 0.17391304347826, 0.016666666666667, 0.5
7292, 0.21739130434783, 0.016666666666667, 0.5
7293, 0.26086956521739, 0.016666666666667, 0.5
7294, 0.30434782608696, 0.016666666666667, 0.5
7295, 0.34782608695652, 0.016666666666667, 0.5
7296, 0.39130434782609, 0.016666666666667, 0.5
7297, 0.43478260869565, 0.016666666666667, 0.5
7298, 0.47826086956522, 0.016666666666667, 0.5
7299, 0.52173913043478, 0.016666666666667, 0.5
7300, 0.56521739130435, 0.016666666666667, 0.5
7301, 0.60869565217391, 0.016666666666667, 0.5
7302, 0.65217391304348, 0.016666666666667, 0.5
7303, 0.69565217391304, 0.016666666666667, 0.5
7304, 0.73913043478261, 0.016666666666667, 0.5
7305, 0.78260869565217, 0.016666666666667, 0.5
7306, 0.82608695652174, 0.016666666666667, 0.5
7307, 0.8695652173913, 0.016666666666667, 0.5
7308, 0.91304347826087, 0.016666666666667, 0.5
7309, 0.95652173913043, 0.016666666666667, 0.5
7310, 0.043478260869565, -0.033333333333333, 0.5
7311, 0.021739130434783, -0.016666666666667, 0.5
7312, 0.08695652173913, -0.033333333333333, 0.5
7313, 0.065217391304348, -0.016666666666667, 0.5
7314, 0.1304347826087, -0.033333333333333, 0.5
7315, 0.10869565217391, -0.016666666666667, 0.5
7316, 0.17391304347826, -0.033333333333333, 0.5
7317, 0.15217391304348, -0.016666666666667, 0.5
7318, 0.21739130434783, -0.033333333333333, 0.5
7319, 0.19565217391304, -0.016666666666667, 0.5
7320, 0.26086956521739, -0.033333333333333, 0.5
7321, 0.23913043478261, -0.016666666666667, 0.5
7322, 0.30434782608696, -0.033333333333333, 0.5
7323, 0.28260869565217, -0.016666666666667, 0.5
7324, 0.34782608695652, -0.033333333333333, 0.5
7325, 0.32608695652174, -0.016666666666667, 0.5
7326, 0.39130434782609, -0.033333333333333, 0.5
7327, 0.3695652173913, -0.016666666666667, 0.5
7328, 0.43478260869565, -0.033333333333333, 0.5
7329, 0.41304347826087, -0.016666666666667, 0.5
7330, 0.47826086956522, -0.033333333333333, 0.5
7331, 0.45652173913043, -0.016666666666667, 0.5
7332, 0.52173913043478, -0.033333333333333, 0.5
7333, 0.5, -0.016666666666667, 0.5
7334, 0.56521739130435, -0.033333333333333, 0.5
7335, 0.54347826086957, -0.016666666666667, 0.5
7336, 0.60869565217391, -0.033333333333333, 0.5
7337, 0.58695652173913, -0.016666666666667, 0.5
7338, 0.65217391304348, -0.033333333333333, 0.5
7339, 0.6304347826087, -0.016666666666667, 0.5
7340, 0.69565217391304, -0.033333333333333, 0.5
7341, 0.67391304347826, -0.016666666666667, 0.5
7342, 0.73913043478261, -0.033333333333333, 0.5
7343, 0.71739130434783, -0.016666666666667, 0.5
7344, 0.78260869565217, -0.033333333333333, 0.5
7345, 0.76086956521739, -0.016666666666667, 0.5
7346, 0.82608695652174, -0.033333333333333, 0.5
7347, 0.80434782608696, -0.016666666666667, 0.5
7348, 0.8695652173913, -0.033333333333333, 0.5
7349, 0.84782608695652, -0.016666666666667, 0.5
7350, 0.91304347826087, -0.033333333333333, 0.5
7351, 0.89130434782609, -0.016666666666667, 0.5
7352, 0.95652173913043, -0.033333333333333, 0.5
7353, 0.93478260869565, -0.016666666666667, 0.5
7354, 0.97826086956522, -0.016666666666667, 0.5
7355, 0.043478260869565, 5.5511151231258e-17, 0.5
7356, 0.021739130434783, 0.016666666666667, 0.5
7357, 0.08695652173913, 5.5511151231258e-17, 0.5
7358, 0.065217391304348, 0.016666666666667, 0.5
7359, 0.1304347826087, 5.5511151231258e-17, 0.5
7360, 0.10869565217391, 0.016666666666667, 0.5
7361, 0.17391304347826, 5.5511151231258e-17, 0.5
7362, 0.15217391304348, 0.016666666666667, 0.5
7363, 0.21739130434783, 5.5511151231258e-17, 0.5
7364, 0.19565217391304, 0.016666666666667, 0.5
7365, 0.26086956521739, 5.5511151231258e-17, 0.5
7366, 0.23913043478261, 0.016666666666667, 0.5
7367, 0.30434782608696, 5.5511151231258e-17, 0.5
7368, 0.28260869565217, 0.016666666666667, 0.5
7369, 0.34782608695652, 5.5511151231258e-17, 0.5
7370, 0.32608695652174, 0.016666666666667, 0.5
7371, 0.39130434782609, 5.5511151231258e-17, 0.5
7372, 0.3695652173913, 0.016666666666667, 0.5
7373, 0.43478260869565, 4.8572257327351e-17, 0.5
7374, 0.41304347826087, 0.016666666666667, 0.5
7375, 0.47826086956522, 5.5511151231258e-17, 0.5
7376, 0.45652173913043, 0.016666666666667, 0.5
7377, 0.52173913043478, 5.5511151231258e-17, 0.5
7378, 0.5, 0.016666666666667, 0.5
7379, 0.56521739130435, 5.5511151231258e-17, 0.5
7380, 0.54347826086957, 0.016666666666667, 0.5
7381, 0.60869565217391, 5.5511151231258e-17, 0.5
7382, 0.58695652173913, 0.016666666666667, 0.5
7383, 0.65217391304348, 5.5511151231258e-17, 0.5
7384, 0.6304347826087, 0.016666666666667, 0.5
7385, 0.69565217391304, 5.5511151231258e-17, 0.5
7386, 0.67391304347826, 0.016666666666667, 0.5
7387, 0.73913043478261, 5.5511151231258e-17, 0.5
7388, 0.71739130434783, 0.016666666666667, 0.5
7389, 0.78260869565217, 5.5511151231258e-17, 0.5
7390, 0.76086956521739, 0.016666666666667, 0.5
7391, 0.82608695652174, 5.5511151231258e-17, 0.5
7392, 0.80434782608696, 0.016666666666667, 0.5
7393, 0.8695652173913, 5.5511151231258e-17, 0.5
7394, 0.84782608695652, 0.016666666666667, 0.5
7395, 0.91304347826087, 5.5511151231258e-17, 0.5
7396, 0.89130434782609, 0.016666666666667, 0.5
7397, 0.95652173913043, 5.5511151231258e-17, 0.5
7398, 0.93478260869565, 0.016666666666667, 0.5
7399, 0.97826086956522, 0.016666666666667, 0.5
7400, 0.043478260869565, 0.033333333333333, 0.5
7401, 0.08695652173913, 0.033333333333333, 0.5
7402, 0.1304347826087, 0.033333333333333, 0.5
7403, 0.17391304347826, 0.033333333333333, 0.5
7404, 0.21739130434783, 0.033333333333333, 0.5
7405, 0.26086956521739, 0.033333333333333, 0.5
7406, 0.30434782608696, 0.033333333333333, 0.5
7407, 0.34782608695652, 0.033333333333333, 0.5
7408, 0.39130434782609, 0.033333333333333, 0.5
7409, 0.43478260869565, 0.033333333333333, 0.5
7410, 0.47826086956522, 0.033333333333333, 0.5
7411, 0.52173913043478, 0.033333333333333, 0.5
7412, 0.56521739130435, 0.033333333333333, 0.5
7413, 0.60869565217391, 0.033333333333333, 0.5
7414, 0.65217391304348, 0.033333333333333, 0.5
7415, 0.69565217391304, 0.033333333333333, 0.5
7416, 0.73913043478261, 0.033333333333333, 0.5
7417, 0.78260869565217, 0.033333333333333, 0.5
7418, 0.82608695652174, 0.033333333333333, 0.5
7419, 0.8695652173913, 0.033333333333333, 0.5
7420, 0.91304347826087, 0.033333333333333, 0.5
7421, 0.95652173913043, 0.033333333333333, 0.5
7422, 0.95652173913043, -0.1, 0
7423, 0.91304347826087, -0.1, 0
7424, 0.8695652173913, -0.1, 0
7425, 0.82608695652174, -0.1, 0
7426, 0.78260869565217, -0.1, 0
7427, 0.73913043478261, -0.1, 0
7428, 0.69565217391304, -0.1, 0
7429, 0.65217391304348, -0.1, 0
7430, 0.60869565217391, -0.1, 0
7431, 0.56521739130435, -0.1, 0
7432, 0.52173913043478, -0.1, 0
7433, 0.47826086956522, -0.1, 0
7434, 0.43478260869565, -0.1, 0
7435, 0.39130434782609, -0.1, 0
7436, 0.34782608695652, -0.1, 0
7437, 0.30434782608696, -0.1, 0
7438, 0.26086956521739, -0.1, 0
7439, 0.21739130434783, -0.1, 0
7440, 0.17391304347826, -0.1, 0
7441, 0.1304347826087, -0.1, 0
7442, 0.08695652173913, -0.1, 0
7443, 0.043478260869565, -0.1, 0
7444, 0.95652173913043, -0.15, 0
7445, 0.91304347826087, -0.15, 0
7446, 0.8695652173913, -0.15, 0
7447, 0.82608695652174, -0.15, 0
7448, 0.78260869565217, -0.15, 0
7449, 0.73913043478261, -0.15, 0
7450, 0.69565217391304, -0.15, 0
7451, 0.65217391304348, -0.15, 0
7452, 0.60869565217391, -0.15, 0
7453, 0.56521739130435, -0.15, 0
7454, 0.52173913043478, -0.15, 0
7455, 0.47826086956522, -0.15, 0
7456, 0.43478260869565, -0.15, 0
7457, 0.39130434782609, -0.15, 0
7458, 0.34782608695652, -0.15, 0
7459, 0.30434782608696, -0.15, 0
7460, 0.26086956521739, -0.15, 0
7461, 0.21739130434783, -0.15, 0
7462, 0.17391304347826, -0.15, 0
7463, 0.1304347826087, -0.15, 0
7464, 0.08695652173913, -0.15, 0
7465, 0.043478260869565, -0.15, 0
7466, 0.95652173913043, -0.2, 0
7467, 0.91304347826087, -0.2, 0
7468, 0.8695652173913, -0.2, 0
7469, 0.82608695652174, -0.2, 0
7470, 0.78260869565217, -0.2, 0
7471, 0.73913043478261, -0.2, 0
7472, 0.69565217391304, -0.2, 0
7473, 0.65217391304348, -0.2, 0
7474, 0.60869565217391, -0.2, 0
7475, 0.56521739130435, -0.2, 0
7476, 0.52173913043478, -0.2, 0
7477, 0.47826086956522, -0.2, 0
7478, 0.43478260869565, -0.2, 0
7479, 0.39130434782609, -0.2, 0
7480, 0.34782608695652, -0.2, 0
7481, 0.30434782608696, -0.2, 0
7482, 0.26086956521739, -0.2, 0
7483, 0.21739130434783, -0.2, 0
7484, 0.17391304347826, -0.2, 0
7485, 0.1304347826087, -0.2, 0
7486, 0.08695652173913, -0.2, 0
7487, 0.043478260869565, -0.2, 0
7488, 0.97826086956522, -0.1, 0
7489, 0.95652173913043, -0.075, 0
7490, 0.93478260869565, -0.1, 0
7491, 0.91304347826087, -0.075, 0
7492, 0.89130434782609, -0.1, 0
7493, 0.8695652173913, -0.075, 0
7494, 0.84782608695652, -0.1, 0
7495, 0.82608695652174, -0.075, 0
7496, 0.80434782608696, -0.1, 0
7497, 0.78260869565217, -0.075, 0
7498, 0.76086956521739, -0.1, 0
7499, 0.73913043478261, -0.075, 0
7500, 0.71739130434783, -0.1, 0
7501, 0.69565217391304, -0.075, 0
7502, 0.67391304347826, -0.1, 0
7503, 0.65217391304348, -0.075, 0
7504, 0.6304347826087, -0.1, 0
7505, 0.60869565217391, -0.075, 0
7506, 0.58695652173913, -0.1, 0
7507, 0.56521739130435, -0.075, 0
7508, 0.54347826086957, -0.1, 0
7509, 0.52173913043478, -0.075, 0
7510, 0.5, -0.1, 0
7511, 0.47826086956522, -0.075, 0
7512, 0.45652173913043, -0.1, 0
7513, 0.43478260869565, -0.075, 0
7514, 0.41304347826087, -0.1, 0
7515, 0.39130434782609, -0.075, 0
7516, 0.3695652173913, -0.1, 0
7517, 0.34782608695652, -0.075, 0
7518, 0.32608695652174, -0.1, 0
7519, 0.30434782608696, -0.075, 0
7520, 0.28260869565217, -0.1, 0
7521, 0.26086956521739, -0.075, 0
7522, 0.23913043478261, -0.1, 0
7523, 0.21739130434783, -0.075, 0
7524, 0.19565217391304, -0.1, 0
7525, 0.17391304347826, -0.075, 0
7526, 0.15217391304348, -0.1, 0
7527, 0.1304347826087, -0.075, 0
7528, 0.10869565217391, -0.1, 0
7529, 0.08695652173913, -0.075, 0
7530, 0.065217391304348, -0.1, 0
7531, 0.043478260869565, -0.075, 0
7532, 0.021739130434783, -0.1, 0
7533, 0.97826086956522, -0.15, 0
7534, 0.95652173913043, -0.125, 0
7535, 0.93478260869565, -0.15, 0
7536, 0.91304347826087, -0.125, 0
7537, 0.89130434782609, -0.15, 0
7538, 0.8695652173913, -0.125, 0
7539, 0.84782608695652, -0.15, 0
7540, 0.82608695652174, -0.125, 0
7541, 0.80434782608696, -0.15, 0
7542, 0.78260869565217, -0.125, 0
7543, 0.76086956521739, -0.15, 0
7544, 0.73913043478261, -0.125, 0
7545, 0.71739130434783, -0.15, 0
7546, 0.69565217391304, -0.125, 0
7547, 0.67391304347826, -0.15, 0
7548, 0.65217391304348, -0.125, 0
7549, 0.6304347826087, -0.15, 0
7550, 0.60869565217391, -0.125, 0
7551, 0.58695652173913, -0.15, 0
7552, 0.56521739130435, -0.125, 0
7553, 0.54347826086957, -0.15, 0
7554, 0.52173913043478, -0.125, 0
7555, 0.5, -0.15, 0
7556, 0.47826086956522, -0.125, 0
7557, 0.45652173913043, -0.15, 0
7558, 0.43478260869565, -0.125, 0
7559, 0.41304347826087, -0.15, 0
7560, 0.39130434782609, -0.125, 0
7561, 0.3695652173913, -0.15, 0
7562, 0.34782608695652, -0.125, 0
7563, 0.32608695652174, -0.15, 0
7564, 0.30434782608696, -0.125, 0
7565, 0.28260869565217, -0.15, 0
7566, 0.26086956521739, -0.125, 0
7567, 0.23913043478261, -0.15, 0
7568, 0.21739130434783, -0.125, 0
7569, 0.19565217391304, -0.15, 0
7570, 0.17391304347826, -0.125, 0
7571, 0.15217391304348, -0.15, 0
7572, 0.1304347826087, -0.125, 0
7573, 0.10869565217391, -0.15, 0
7574, 0.08695652173913, -0.125, 0
7575, 0.065217391304348, -0.15, 0
7576, 0.043478260869565, -0.125, 0
7577, 0.021739130434783, -0.15, 0
7578, 0.97826086956522, -0.2, 0
7579, 0.95652173913043, -0.175, 0
7580, 0.93478260869565, -0.2, 0
7581, 0.91304347826087, -0.175, 0
7582, 0.89130434782609, -0.2, 0
7583, 0.8695652173913, -0.175, 0
7584, 0.84782608695652, -0.2, 0
7585, 0.82608695652174, -0.175, 0
7586, 0.80434782608696, -0.2, 0
7587, 0.78260869565217, -0.175, 0
7588, 0.76086956521739, -0.2, 0
7589, 0.73913043478261, -0.175, 0
7590, 0.71739130434783, -0.2, 0
7591, 0.69565217391304, -0.175, 0
7592, 0.67391304347826, -0.2, 0
7593, 0.65217391304348, -0.175, 0
7594, 0.6304347826087, -0.2, 0
7595, 0.60869565217391, -0.175, 0
7596, 0.58695652173913, -0.2, 0
7597, 0.56521739130435, -0.175, 0
7598, 0.54347826086957, -0.2, 0
7599, 0.52173913043478, -0.175, 0
7600, 0.5, -0.2, 0
7601, 0.47826086956522, -0.175, 0
7602, 0.45652173913043, -0.2, 0
7603, 0.43478260869565, -0.175, 0
7604, 0.41304347826087, -0.2, 0
7605, 0.39130434782609, -0.175, 0
7606, 0.3695652173913, -0.2, 0
7607, 0.34782608695652, -0.175, 0
7608, 0.32608695652174, -0.2, 0
7609, 0.30434782608696, -0.175, 0
7610, 0.28260869565217, -0.2, 0
7611, 0.26086956521739, -0.175, 0
7612, 0.23913043478261, -0.2, 0
7613, 0.21739130434783, -0.175, 0
7614, 0.19565217391304, -0.2, 0
7615, 0.17391304347826, -0.175, 0
7616, 0.15217391304348, -0.2, 0
7617, 0.1304347826087, -0.175, 0
7618, 0.10869565217391, -0.2, 0
7619, 0.08695652173913, -0.175, 0
7620, 0.065217391304348, -0.2, 0
7621, 0.043478260869565, -0.175, 0
7622, 0.021739130434783, -0.2, 0
7623, 0.95652173913043, -0.225, 0
7624, 0.91304347826087, -0.225, 0
7625, 0.8695652173913, -0.225, 0
7626, 0.82608695652174, -0.225, 0
7627, 0.78260869565217, -0.225, 0
7628, 0.73913043478261, -0.225, 0
7629, 0.69565217391304, -0.225, 0
7630, 0.65217391304348, -0.225, 0
7631, 0.60869565217391, -0.225, 0
7632, 0.56521739130435, -0.225, 0
7633, 0.52173913043478, -0.225, 0
7634, 0.47826086956522, -0.225, 0
7635, 0.43478260869565, -0.225, 0
7636, 0.39130434782609, -0.225, 0
7637, 0.34782608695652, -0.225, 0
7638, 0.30434782608696, -0.225, 0
7639, 0.26086956521739, -0.225, 0
7640, 0.21739130434783, -0.225, 0
7641, 0.17391304347826, -0.225, 0
7642, 0.1304347826087, -0.225, 0
7643, 0.08695652173913, -0.225, 0
7644, 0.043478260869565, -0.225, 0
7645, 1, -0.1, 0.44444444444444
7646, 1, -0.1, 0.38888888888889
7647, 1, -0.1, 0.33333333333333
7648, 1, -0.1, 0.27777777777778
7649, 1, -0.1, 0.22222222222222
7650, 1, -0.1, 0.16666666666667
7651, 1, -0.1, 0.11111111111111
7652, 1, -0.1, 0.055555555555556
7653, 1, -0.15, 0.44444444444444
7654, 1, -0.15, 0.38888888888889
7655, 1, -0.15, 0.33333333333333
7656, 1, -0.15, 0.27777777777778
7657, 1, -0.15, 0.22222222222222
7658, 1, -0.15, 0.16666666666667
7659, 1, -0.15, 0.11111111111111
7660, 1, -0.15, 0.055555555555556
7661, 1, -0.2, 0.44444444444444
7662, 1, -0.2, 0.38888888888889
7663, 1, -0.2, 0.33333333333333
7664, 1, -0.2, 0.27777777777778
7665, 1, -0.2, 0.22222222222222
7666, 1, -0.2, 0.16666666666667
7667, 1, -0.2, 0.11111111111111
7668, 1, -0.2, 0.055555555555556
7669, 1, -0.1, 0.47222222222222
7670, 1, -0.075, 0.44444444444444
7671, 1, -0.1, 0.41666666666667
7672, 1, -0.075, 0.38888888888889
7673, 1, -0.1, 0.36111111111111
7674, 1, -0.075, 0.33333333333333
7675, 1, -0.1, 0.30555555555556
7676, 1, -0.075, 0.27777777777778
7677, 1, -0.1, 0.25
7678, 1, -0.075, 0.22222222222222
7679, 1, -0.1, 0.19444444444444
7680, 1, -0.075, 0.16666666666667
7681, 1, -0.1, 0.13888888888889
7682, 1, -0.075, 0.11111111111111
7683, 1, -0.1, 0.083333333333333
7684, 1, -0.075, 0.055555555555556
7685, 1, -0.1, 0.027777777777778
7686, 1, -0.15, 0.47222222222222
7687, 1, -0.125, 0.44444444444444
7688, 1, -0.15, 0.41666666666667
7689, 1, -0.125, 0.38888888888889
7690, 1, -0.15, 0.36111111111111
7691, 1, -0.125, 0.33333333333333
7692, 1, -0.15, 0.30555555555556
7693, 1, -0.125, 0.27777777777778
7694, 1, -0.15, 0.25
7695, 1, -0.125, 0.22222222222222
7696, 1, -0.15, 0.19444444444444
7697, 1, -0.125, 0.16666666666667
7698, 1, -0.15, 0.13888888888889
7699, 1, -0.125, 0.11111111111111
7700, 1, -0.15, 0.083333333333333
7701, 1, -0.125, 0.055555555555556
7702, 1, -0.15, 0.027777777777778
7703, 1, -0.2, 0.47222222222222
7704, 1, -0.175, 0.44444444444444
7705, 1, -0.2, 0.41666666666667
7706, 1, -0.175, 0.38888888888889
7707, 1, -0.2, 0.36111111111111
7708, 1, -0.175, 0.33333333333333
7709, 1, -0.2, 0.30555555555556
7710, 1, -0.175, 0.27777777777778
7711, 1, -0.2, 0.25
7712, 1, -0.175, 0.22222222222222
7713, 1, -0.2, 0.19444444444444
7714, 1, -0.175, 0.16666666666667
7715, 1, -0.2, 0.13888888888889
7716, 1, -0.175, 0.11111111111111
7717, 1, -0.2, 0.083333333333333
7718, 1, -0.175, 0.055555555555556
7719, 1, -0.2, 0.027777777777778
7720, 1, -0.225, 0.44444444444444
7721, 1, -0.225, 0.38888888888889
7722, 1, -0.225, 0.33333333333333
7723, 1, -0.225, 0.27777777777778
7724, 1, -0.225, 0.22222222222222
7725, 1, -0.225, 0.16666666666667
7726, 1, -0.225, 0.11111111111111
7727, 1, -0.225, 0.055555555555556
7728, 0.95652173913043, -0.1, 0.5
7729, 0.91304347826087, -0.1, 0.5
7730, 0.8695652173913, -0.1, 0.5
7731, 0.82608695652174, -0.1, 0.5
7732, 0.78260869565217, -0.1, 0.5
7733, 0.73913043478261, -0.1, 0.5
7734, 0.69565217391304, -0.1, 0.5
7735, 0.65217391304348, -0.1, 0.5
7736, 0.60869565217391, -0.1, 0.5
7737, 0.56521739130435, -0.1, 0.5
7738, 0.52173913043478, -0.1, 0.5
7739, 0.47826086956522, -0.1, 0.5
7740, 0.43478260869565, -0.1, 0.5
7741, 0.39130434782609, -0.1, 0.5
7742, 0.34782608695652, -0.1, 0.5
7743, 0.30434782608696, -0.1, 0.5
7744, 0.26086956521739, -0.1, 0.5
7745, 0.21739130434783, -0.1, 0.5
7746, 0.17391304347826, -0.1, 0.5
7747, 0.1304347826087, -0.1, 0.5
7748, 0.08695652173913, -0.1, 0.5
7749, 0.043478260869565, -0.1, 0.5
7750, 0.95652173913043, -0.15, 0.5
7751, 0.91304347826087, -0.15, 0.5
7752, 0.8695652173913, -0.15, 0.5
7753, 0.82608695652174, -0.15, 0.5
7754, 0.78260869565217, -0.15, 0.5
7755, 0.73913043478261, -0.15, 0.5
7756, 0.69565217391304, -0.15, 0.5
7757, 0.65217391304348, -0.15, 0.5
7758, 0.60869565217391, -0.15, 0.5
7759, 0.56521739130435, -0.15, 0.5
7760, 0.52173913043478, -0.15, 0.5
7761, 0.47826086956522, -0.15, 0.5
7762, 0.43478260869565, -0.15, 0.5
7763, 0.39130434782609, -0.15, 0.5
7764, 0.34782608695652, -0.15, 0.5
7765, 0.30434782608696, -0.15, 0.5
7766, 0.26086956521739, -0.15, 0.5
7767, 0.21739130434783, -0.15, 0.5
7768, 0.17391304347826, -0.15, 0.5
7769, 0.1304347826087, -0.15, 0.5
7770, 0.08695652173913, -0.15, 0.5
7771, 0.043478260869565, -0.15, 0.5
7772, 0.95652173913043, -0.2, 0.5
7773, 0.91304347826087, -0.2, 0.5
7774, 0.8695652173913, -0.2, 0.5
7775, 0.82608695652174, -0.2, 0.5
7776, 0.78260869565217, -0.2, 0.5
7777, 0.73913043478261, -0.2, 0.5
7778, 0.69565217391304, -0.2, 0.5
7779, 0.65217391304348, -0.2, 0.5
7780, 0.60869565217391, -0.2, 0.5
7781, 0.56521739130435, -0.2, 0.5
7782, 0.52173913043478, -0.2, 0.5
7783, 0.47826086956522, -0.2, 0.5
7784, 0.43478260869565, -0.2, 0.5
7785, 0.39130434782609, -0.2, 0.5
7786, 0.34782608695652, -0.2, 0.5
7787, 0.30434782608696, -0.2, 0.5
7788, 0.26086956521739, -0.2, 0.5
7789, 0.21739130434783, -0.2, 0.5
7790, 0.17391304347826, -0.2, 0.5
7791, 0.1304347826087, -0.2, 0.5
7792, 0.08695652173913, -0.2, 0.5
7793, 0.043478260869565, -0.2, 0.5
7794, 0.95652173913043, -0.075, 0.5
7795, 0.97826086956522, -0.1, 0.5
7796, 0.91304347826087, -0.075, 0.5
7797, 0.93478260869565, -0.1, 0.5
7798, 0.8695652173913, -0.075, 0.5
7799, 0.89130434782609, -0.1, 0.5
7800, 0.82608695652174, -0.075, 0.5
7801, 0.84782608695652, -0.1, 0.5
7802, 0.78260869565217, -0.075, 0.5
7803, 0.80434782608696, -0.1, 0.5
7804, 0.73913043478261, -0.075, 0.5
7805, 0.76086956521739, -0.1, 0.5
7806, 0.69565217391304, -0.075, 0.5
7807, 0.71739130434783, -0.1, 0.5
7808, 0.65217391304348, -0.075, 0.5
7809, 0.67391304347826, -0.1, 0.5
7810, 0.60869565217391, -0.075, 0.5
7811, 0.6304347826087, -0.1, 0.5
7812, 0.56521739130435, -0.075, 0.5
7813, 0.58695652173913, -0.1, 0.5
7814, 0.52173913043478, -0.075, 0.5
7815, 0.54347826086957, -0.1, 0.5
7816, 0.47826086956522, -0.075, 0.5
7817, 0.5, -0.1, 0.5
7818, 0.43478260869565, -0.075, 0.5
7819, 0.45652173913043, -0.1, 0.5
7820, 0.39130434782609, -0.075, 0.5
7821, 0.41304347826087, -0.1, 0.5
7822, 0.34782608695652, -0.075, 0.5
7823, 0.3695652173913, -0.1, 0.5
7824, 0.30434782608696, -0.075, 0.5
7825, 0.32608695652174, -0.1, 0.5
7826, 0.26086956521739, -0.075, 0.5
7827, 0.28260869565217, -0.1, 0.5
7828, 0.21739130434783, -0.075, 0.5
7829, 0.23913043478261, -0.1, 0.5
7830, 0.17391304347826, -0.075, 0.5
7831, 0.19565217391304, -0.1, 0.5
7832, 0.1304347826087, -0.075, 0.5
7833, 0.15217391304348, -0.1, 0.5
7834, 0.08695652173913, -0.075, 0.5
7835, 0.10869565217391, -0.1, 0.5
7836, 0.043478260869565, -0.075, 0.5
7837, 0.065217391304348, -0.1, 0.5
7838, 0.021739130434783, -0.1, 0.5
7839, 0.95652173913043, -0.125, 0.5
7840, 0.97826086956522, -0.15, 0.5
7841, 0.91304347826087, -0.125, 0.5
7842, 0.93478260869565, -0.15, 0.5
7843, 0.8695652173913, -0.125, 0.5
7844, 0.89130434782609, -0.15, 0.5
7845, 0.82608695652174, -0.125, 0.5
7846, 0.84782608695652, -0.15, 0.5
7847, 0.78260869565217, -0.125, 0.5
7848, 0.80434782608696, -0.15, 0.5
7849, 0.73913043478261, -0.125, 0.5
7850, 0.76086956521739, -0.15, 0.5
7851, 0.69565217391304, -0.125, 0.5
7852, 0.71739130434783, -0.15, 0.5
7853, 0.65217391304348, -0.125, 0.5
7854, 0.67391304347826, -0.15, 0.5
7855, 0.60869565217391, -0.125, 0.5
7856, 0.6304347826087, -0.15, 0.5
7857, 0.56521739130435, -0.125, 0.5
7858, 0.58695652173913, -0.15, 0.5
7859, 0.52173913043478, -0.125, 0.5
7860, 0.54347826086957, -0.15, 0.5
7861, 0.47826086956522, -0.125, 0.5
7862, 0.5, -0.15, 0.5
7863, 0.43478260869565, -0.125, 0.5
7864, 0.45652173913043, -0.15, 0.5
7865, 0.39130434782609, -0.125, 0.5
7866, 0.41304347826087, -0.15, 0.5
7867, 0.34782608695652, -0.125, 0.5
7868, 0.3695652173913, -0.15, 0.5
7869, 0.30434782608696, -0.125, 0.5
7870, 0.32608695652174, -0.15, 0.5
7871, 0.26086956521739, -0.125, 0.5
7872, 0.28260869565217, -0.15, 0.5
7873, 0.21739130434783, -0.125, 0.5
7874, 0.23913043478261, -0.15, 0.5
7875, 0.17391304347826, -0.125, 0.5
7876, 0.19565217391304, -0.15, 0.5
7877, 0.1304347826087, -0.125, 0.5
7878, 0.15217391304348, -0.15, 0.5
7879, 0.08695652173913, -0.125, 0.5
7880, 0.10869565217391, -0.15, 0.5
7881, 0.043478260869565, -0.125, 0.5
7882, 0.065217391304348, -0.15, 0.5
7883, 0.021739130434783, -0.15, 0.5
7884, 0.95652173913043, -0.175, 0.5
7885, 0.97826086956522, -0.2, 0.5
7886, 0.91304347826087, -0.175, 0.5
7887, 0.93478260869565, -0.2, 0.5
7888, 0.8695652173913, -0.175, 0.5
7889, 0.89130434782609, -0.2, 0.5
7890, 0.82608695652174, -0.175, 0.5
7891, 0.84782608695652, -0.2, 0.5
7892, 0.78260869565217, -0.175, 0.5
7893, 0.80434782608696, -0.2, 0.5
7894, 0.73913043478261, -0.175, 0.5
7895, 0.76086956521739, -0.2, 0.5
7896, 0.69565217391304, -0.175, 0.5
7897, 0.71739130434783, -0.2, 0.5
7898, 0.65217391304348, -0.175, 0.5
7899, 0.67391304347826, -0.2, 0.5
7900, 0.60869565217391, -0.175, 0.5
7901, 0.6304347826087, -0.2, 0.5
7902, 0.56521739130435, -0.175, 0.5
7903, 0.58695652173913, -0.2, 0.5
7904, 0.52173913043478, -0.175, 0.5
7905, 0.54347826086957, -0.2, 0.5
7906, 0.47826086956522, -0.175, 0.5
7907, 0.5, -0.2, 0.5
7908, 0.43478260869565, -0.175, 0.5
7909, 0.45652173913043, -0.2, 0.5
7910, 0.39130434782609, -0.175, 0.5
7911, 0.41304347826087, -0.2, 0.5
7912, 0.34782608695652, -0.175, 0.5
7913, 0.3695652173913, -0.2, 0.5
7914, 0.30434782608696, -0.175, 0.5
7915, 0.32608695652174, -0.2, 0.5
7916, 0.26086956521739, -0.175, 0.5
7917, 0.28260869565217, -0.2, 0.5
7918, 0.21739130434783, -0.175, 0.5
7919, 0.23913043478261, -0.2, 0.5
7920, 0.17391304347826, -0.175, 0.5
7921, 0.19565217391304, -0.2, 0.5
7922, 0.1304347826087, -0.175, 0.5
7923, 0.15217391304348, -0.2, 0.5
7924, 0.08695652173913, -0.175, 0.5
7925, 0.10869565217391, -0.2, 0.5
7926, 0.043478260869565, -0.175, 0.5
7927, 0.065217391304348, -0.2, 0.5
7928, 0.021739130434783, -0.2, 0.5
7929, 0.95652173913043, -0.225, 0.5
7930, 0.91304347826087, -0.225, 0.5
7931, 0.8695652173913, -0.225, 0.5
7932, 0.82608695652174, -0.225, 0.5
7933, 0.78260869565217, -0.225, 0.5
7934, 0.73913043478261, -0.225, 0.5
7935, 0.69565217391304, -0.225, 0.5
7936, 0.65217391304348, -0.225, 0.5
7937, 0.60869565217391, -0.225, 0.5
7938, 0.56521739130435, -0.225, 0.5
7939, 0.52173913043478, -0.225, 0.5
7940, 0.47826086956522, -0.225, 0.5
7941, 0.43478260869565, -0.225, 0.5
7942, 0.39130434782609, -0.225, 0.5
7943, 0.34782608695652, -0.225, 0.5
7944, 0.30434782608696, -0.225, 0.5
7945, 0.26086956521739, -0.225, 0.5
7946, 0.21739130434783, -0.225, 0.5
7947, 0.17391304347826, -0.225, 0.5
7948, 0.1304347826087, -0.225, 0.5
7949, 0.08695652173913, -0.225, 0.5
7950, 0.043478260869565, -0.225, 0.5
7951, 0.043478260869565, -0.25, 0.055555555555556
7952, 0.043478260869565, -0.25, 0.11111111111111
7953, 0.043478260869565, -0.25, 0.16666666666667
7954, 0.043478260869565, -0.25, 0.22222222222222
7955, 0.043478260869565, -0.25, 0.27777777777778
7956, 0.043478260869565, -0.25, 0.33333333333333
7957, 0.043478260869565, -0.25, 0.38888888888889
7958, 0.043478260869565, -0.25, 0.44444444444444
7959, 0.08695652173913, -0.25, 0.055555555555556
7960, 0.08695652173913, -0.25, 0.11111111111111
7961, 0.08695652173913, -0.25, 0.16666666666667
7962, 0.08695652173913, -0.25, 0.22222222222222
7963, 0.08695652173913, -0.25, 0.27777777777778
7964, 0.08695652173913, -0.25, 0.33333333333333
7965, 0.08695652173913, -0.25, 0.38888888888889
7966, 0.08695652173913, -0.25, 0.44444444444444
7967, 0.1304347826087, -0.25, 0.055555555555556
7968, 0.1304347826087, -0.25, 0.11111111111111
7969, 0.1304347826087, -0.25, 0.16666666666667
7970, 0.1304347826087, -0.25, 0.22222222222222
7971, 0.1304347826087, -0.25, 0.27777777777778
7972, 0.1304347826087, -0.25, 0.33333333333333
7973, 0.1304347826087, -0.25, 0.38888888888889
7974, 0.1304347826087, -0.25, 0.44444444444444
7975, 0.17391304347826, -0.25, 0.055555555555556
7976, 0.17391304347826, -0.25, 0.11111111111111
7977, 0.17391304347826, -0.25, 0.16666666666667
7978, 0.17391304347826, -0.25, 0.22222222222222
7979, 0.17391304347826, -0.25, 0.27777777777778
7980, 0.17391304347826, -0.25, 0.33333333333333
7981, 0.17391304347826, -0.25, 0.38888888888889
7982, 0.17391304347826, -0.25, 0.44444444444444
7983, 0.21739130434783, -0.25, 0.055555555555556
7984, 0.21739130434783, -0.25, 0.11111111111111
7985, 0.21739130434783, -0.25, 0.16666666666667
7986, 0.21739130434783, -0.25, 0.22222222222222
7987, 0.21739130434783, -0.25, 0.27777777777778
7988, 0.21739130434783, -0.25, 0.33333333333333
7989, 0.21739130434783, -0.25, 0.38888888888889
7990, 0.21739130434783, -0.25, 0.44444444444444
7991, 0.26086956521739, -0.25, 0.055555555555556
7992, 0.26086956521739, -0.25, 0.11111111111111
7993, 0.26086956521739, -0.25, 0.16666666666667
7994, 0.26086956521739, -0.25, 0.22222222222222
7995, 0.26086956521739, -0.25, 0.27777777777778
7996, 0.26086956521739, -0.25, 0.33333333333333
7997, 0.26086956521739, -0.25, 0.38888888888889
7998, 0.26086956521739, -0.25, 0.44444444444444
7999, 0.30434782608696, -0.25, 0.055555555555556
8000, 0.30434782608696, -0.25, 0.11111111111111
8001, 0.30434782608696, -0.25, 0.16666666666667
8002, 0.30434782608696, -0.25, 0.22222222222222
8003, 0.30434782608696, -0.25, 0.27777777777778
8004, 0.30434782608696, -0.25, 0.33333333333333
8005, 0.30434782608696, -0.25, 0.38888888888889
8006, 0.30434782608696, -0.25, 0.44444444444444
8007, 0.34782608695652, -0.25, 0.055555555555556
8008, 0.34782608695652, -0.25, 0.11111111111111
8009, 0.34782608695652, -0.25, 0.16666666666667
8010, 0.34782608695652, -0.25, 0.22222222222222
8011, 0.34782608695652, -0.25, 0.27777777777778
8012, 0.34782608695652, -0.25, 0.33333333333333
8013, 0.34782608695652, -0.25, 0.38888888888889
8014, 0.34782608695652, -0.25, 0.44444444444444
8015, 0.39130434782609, -0.25, 0.055555555555556
8016, 0.39130434782609, -0.25, 0.11111111111111
8017, 0.39130434782609, -0.25, 0.16666666666667
8018, 0.39130434782609, -0.25, 0.22222222222222
8019, 0.39130434782609, -0.25, 0.27777777777778
8020, 0.39130434782609, -0.25, 0.33333333333333
8021, 0.39130434782609, -0.25, 0.38888888888889
8022, 0.39130434782609, -0.25, 0.44444444444444
8023, 0.43478260869565, -0.25, 0.055555555555556
8024, 0.43478260869565, -0.25, 0.11111111111111
8025, 0.43478260869565, -0.25, 0.16666666666667
8026, 0.43478260869565, -0.25, 0.22222222222222
8027, 0.43478260869565, -0.25, 0.27777777777778
8028, 0.43478260869565, -0.25, 0.33333333333333
8029, 0.43478260869565, -0.25, 0.38888888888889
8030, 0.43478260869565, -0.25, 0.44444444444444
8031, 0.47826086956522, -0.25, 0.055555555555556
8032, 0.47826086956522, -0.25, 0.11111111111111
8033, 0.47826086956522, -0.25, 0.16666666666667
8034, 0.47826086956522, -0.25, 0.22222222222222
8035, 0.47826086956522, -0.25, 0.27777777777778
8036, 0.47826086956522, -0.25, 0.33333333333333
8037, 0.47826086956522, -0.25, 0.38888888888889
8038, 0.47826086956522, -0.25, 0.44444444444444
8039, 0.52173913043478, -0.25, 0.055555555555556
8040, 0.52173913043478, -0.25, 0.11111111111111
8041, 0.52173913043478, -0.25, 0.16666666666667
8042, 0.52173913043478, -0.25, 0.22222222222222
8043, 0.52173913043478, -0.25, 0.27777777777778
8044, 0.52173913043478, -0.25, 0.33333333333333
8045, 0.52173913043478, -0.25, 0.38888888888889
8046, 0.52173913043478, -0.25, 0.44444444444444
8047, 0.56521739130435, -0.25, 0.055555555555556
8048, 0.56521739130435, -0.25, 0.11111111111111
8049, 0.56521739130435, -0.25, 0.16666666666667
8050, 0.56521739130435, -0.25, 0.22222222222222
8051, 0.56521739130435, -0.25, 0.27777777777778
8052, 0.56521739130435, -0.25, 0.33333333333333
8053, 0.56521739130435, -0.25, 0.38888888888889
8054, 0.56521739130435, -0.25, 0.44444444444444
8055, 0.60869565217391, -0.25, 0.055555555555556
8056, 0.60869565217391, -0.25, 0.11111111111111
8057, 0.60869565217391, -0.25, 0.16666666666667
8058, 0.60869565217391, -0.25, 0.22222222222222
8059, 0.60869565217391, -0.25, 0.27777777777778
8060, 0.60869565217391, -0.25, 0.33333333333333
8061, 0.60869565217391, -0.25, 0.38888888888889
8062, 0.60869565217391, -0.25, 0.44444444444444
8063, 0.65217391304348, -0.25, 0.055555555555556
8064, 0.65217391304348, -0.25, 0.11111111111111
8065, 0.65217391304348, -0.25, 0.16666666666667
8066, 0.65217391304348, -0.25, 0.22222222222222
8067, 0.65217391304348, -0.25, 0.27777777777778
8068, 0.65217391304348, -0.25, 0.33333333333333
8069, 0.65217391304348, -0.25, 0.38888888888889
8070, 0.65217391304348, -0.25, 0.44444444444444
8071, 0.69565217391304, -0.25, 0.055555555555556
8072, 0.69565217391304, -0.25, 0.11111111111111
8073, 0.69565217391304, -0.25, 0.16666666666667
8074, 0.69565217391304, -0.25, 0.22222222222222
8075, 0.69565217391304, -0.25, 0.27777777777778
8076, 0.69565217391304, -0.25, 0.33333333333333
8077, 0.69565217391304, -0.25, 0.38888888888889
8078, 0.69565217391304, -0.25, 0.44444444444444
8079, 0.73913043478261, -0.25, 0.055555555555556
8080, 0.73913043478261, -0.25, 0.11111111111111
8081, 0.73913043478261, -0.25, 0.16666666666667
8082, 0.73913043478261, -0.25, 0.22222222222222
8083, 0.73913043478261, -0.25, 0.27777777777778
8084, 0.73913043478261, -0.25, 0.33333333333333
8085, 0.73913043478261, -0.25, 0.38888888888889
8086, 0.73913043478261, -0.25, 0.44444444444444
8087, 0.78260869565217, -0.25, 0.055555555555556
8088, 0.78260869565217, -0.25, 0.11111111111111
8089, 0.78260869565217, -0.25, 0.16666666666667
8090, 0.78260869565217, -0.25, 0.22222222222222
8091, 0.78260869565217, -0.25, 0.27777777777778
8092, 0.78260869565217, -0.25, 0.33333333333333
8093, 0.78260869565217, -0.25, 0.38888888888889
8094, 0.78260869565217, -0.25, 0.44444444444444
8095, 0.82608695652174, -0.25, 0.055555555555556
8096, 0.82608695652174, -0.25, 0.11111111111111
8097, 0.82608695652174, -0.25, 0.16666666666667
8098, 0.82608695652174, -0.25, 0.22222222222222
8099, 0.82608695652174, -0.25, 0.27777777777778
8100, 0.82608695652174, -0.25, 0.33333333333333
8101, 0.82608695652174, -0.25, 0.38888888888889
8102, 0.82608695652174, -0.25, 0.44444444444444
8103, 0.8695652173913, -0.25, 0.055555555555556
8104, 0.8695652173913, -0.25, 0.11111111111111
8105, 0.8695652173913, -0.25, 0.16666666666667
8106, 0.8695652173913, -0.25, 0.22222222222222
8107, 0.8695652173913, -0.25, 0.27777777777778
8108, 0.8695652173913, -0.25, 0.33333333333333
8109, 0.8695652173913, -0.25, 0.38888888888889
8110, 0.8695652173913, -0.25, 0.44444444444444
8111, 0.91304347826087, -0.25, 0.055555555555556
8112, 0.91304347826087, -0.25, 0.11111111111111
8113, 0.91304347826087, -0.25, 0.16666666666667
8114, 0.91304347826087, -0.25, 0.22222222222222
8115, 0.91304347826087, -0.25, 0.27777777777778
8116, 0.91304347826087, -0.25, 0.33333333333333
8117, 0.91304347826087, -0.25, 0.38888888888889
8118, 0.91304347826087, -0.25, 0.44444444444444
8119, 0.95652173913043, -0.25, 0.055555555555556
8120, 0.95652173913043, -0.25, 0.11111111111111
8121, 0.95652173913043, -0.25, 0.16666666666667
8122, 0.95652173913043, -0.25, 0.22222222222222
8123, 0.95652173913043, -0.25, 0.27777777777778
8124, 0.95652173913043, -0.25, 0.33333333333333
8125, 0.95652173913043, -0.25, 0.38888888888889
8126, 0.95652173913043, -0.25, 0.44444444444444
8127, 0.043478260869565, -0.25, 0.027777777777778
8128, 0.021739130434783, -0.25, 0.055555555555556
8129, 0.043478260869565, -0.25, 0.083333333333333
8130, 0.021739130434783, -0.25, 0.11111111111111
8131, 0.043478260869565, -0.25, 0.13888888888889
8132, 0.021739130434783, -0.25, 0.16666666666667
8133, 0.043478260869565, -0.25, 0.19444444444444
8134, 0.021739130434783, -0.25, 0.22222222222222
8135, 0.043478260869565, -0.25, 0.25
8136, 0.021739130434783, -0.25, 0.27777777777778
8137, 0.043478260869565, -0.25, 0.30555555555556
8138, 0.021739130434783, -0.25, 0.33333333333333
8139, 0.043478260869565, -0.25, 0.36111111111111
8140, 0.021739130434783, -0.25, 0.38888888888889
8141, 0.043478260869565, -0.25, 0.41666666666667
8142, 0.021739130434783, -0.25, 0.44444444444444
8143, 0.043478260869565, -0.25, 0.47222222222222
8144, 0.08695652173913, -0.25, 0.027777777777778
8145, 0.065217391304348, -0.25, 0.055555555555556
8146, 0.08695652173913, -0.25, 0.083333333333333
8147, 0.065217391304348, -0.25, 0.11111111111111
