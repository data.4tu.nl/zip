78403, 30128, 30111, 77911, 77936
28302, 29903, 29895, 77661, 77669, 29904, 29896, 77662, 77670, 30127, 78395, 77937, 78403, 30129, 78396, 77940, 
78404, 30130, 30113, 77914, 77939
28303, 29904, 29896, 77662, 77670, 29905, 29897, 77663, 77671, 30129, 78396, 77940, 78404, 30131, 78397, 77943, 
78405, 30132, 30115, 77917, 77942
28304, 29905, 29897, 77663, 77671, 29906, 29898, 77664, 77672, 30131, 78397, 77943, 78405, 30133, 78398, 77946, 
78406, 30134, 30117, 77920, 77945
28305, 29906, 29898, 77664, 77672, 29907, 29899, 77665, 77673, 30133, 78398, 77946, 78406, 30135, 78399, 77949, 
78407, 30136, 30119, 77923, 77948
28306, 29907, 29899, 77665, 77673, 3503, 3502, 29709, 29710, 30135, 78399, 77949, 78407, 3525, 29776, 29738, 
29777, 30137, 30120, 77926, 77951
28307, 3453, 3452, 29621, 29622, 29908, 29900, 77666, 77674, 3475, 29688, 29650, 29689, 30138, 78400, 77953, 
78408, 30139, 30122, 77927, 77952
28308, 29908, 29900, 77666, 77674, 29909, 29901, 77667, 77675, 30138, 78400, 77953, 78408, 30140, 78401, 77956, 
78409, 30141, 30124, 77930, 77955
28309, 29909, 29901, 77667, 77675, 29910, 29902, 77668, 77676, 30140, 78401, 77956, 78409, 30142, 78402, 77959, 
78410, 30143, 30126, 77933, 77958
28310, 29910, 29902, 77668, 77676, 29911, 29903, 77669, 77677, 30142, 78402, 77959, 78410, 30144, 78403, 77962, 
78411, 30145, 30128, 77936, 77961
28311, 29911, 29903, 77669, 77677, 29912, 29904, 77670, 77678, 30144, 78403, 77962, 78411, 30146, 78404, 77965, 
78412, 30147, 30130, 77939, 77964
28312, 29912, 29904, 77670, 77678, 29913, 29905, 77671, 77679, 30146, 78404, 77965, 78412, 30148, 78405, 77968, 
78413, 30149, 30132, 77942, 77967
28313, 29913, 29905, 77671, 77679, 29914, 29906, 77672, 77680, 30148, 78405, 77968, 78413, 30150, 78406, 77971, 
78414, 30151, 30134, 77945, 77970
28314, 29914, 29906, 77672, 77680, 29915, 29907, 77673, 77681, 30150, 78406, 77971, 78414, 30152, 78407, 77974, 
78415, 30153, 30136, 77948, 77973
28315, 29915, 29907, 77673, 77681, 3504, 3503, 29710, 29711, 30152, 78407, 77974, 78415, 3526, 29777, 29740, 
29778, 30154, 30137, 77951, 77976
28316, 3454, 3453, 29622, 29623, 29916, 29908, 77674, 77682, 3476, 29689, 29652, 29690, 30155, 78408, 77978, 
78416, 30156, 30139, 77952, 77977
28317, 29916, 29908, 77674, 77682, 29917, 29909, 77675, 77683, 30155, 78408, 77978, 78416, 30157, 78409, 77981, 
78417, 30158, 30141, 77955, 77980
28318, 29917, 29909, 77675, 77683, 29918, 29910, 77676, 77684, 30157, 78409, 77981, 78417, 30159, 78410, 77984, 
78418, 30160, 30143, 77958, 77983
28319, 29918, 29910, 77676, 77684, 29919, 29911, 77677, 77685, 30159, 78410, 77984, 78418, 30161, 78411, 77987, 
78419, 30162, 30145, 77961, 77986
28320, 29919, 29911, 77677, 77685, 29920, 29912, 77678, 77686, 30161, 78411, 77987, 78419, 30163, 78412, 77990, 
78420, 30164, 30147, 77964, 77989
28321, 29920, 29912, 77678, 77686, 29921, 29913, 77679, 77687, 30163, 78412, 77990, 78420, 30165, 78413, 77993, 
78421, 30166, 30149, 77967, 77992
28322, 29921, 29913, 77679, 77687, 29922, 29914, 77680, 77688, 30165, 78413, 77993, 78421, 30167, 78414, 77996, 
78422, 30168, 30151, 77970, 77995
28323, 29922, 29914, 77680, 77688, 29923, 29915, 77681, 77689, 30167, 78414, 77996, 78422, 30169, 78415, 77999, 
78423, 30170, 30153, 77973, 77998
28324, 29923, 29915, 77681, 77689, 3505, 3504, 29711, 29712, 30169, 78415, 77999, 78423, 3527, 29778, 29742, 
29779, 30171, 30154, 77976, 78001
28325, 3455, 3454, 29623, 29624, 29924, 29916, 77682, 77690, 3477, 29690, 29654, 29691, 30172, 78416, 78003, 
78424, 30173, 30156, 77977, 78002
28326, 29924, 29916, 77682, 77690, 29925, 29917, 77683, 77691, 30172, 78416, 78003, 78424, 30174, 78417, 78006, 
78425, 30175, 30158, 77980, 78005
28327, 29925, 29917, 77683, 77691, 29926, 29918, 77684, 77692, 30174, 78417, 78006, 78425, 30176, 78418, 78009, 
78426, 30177, 30160, 77983, 78008
28328, 29926, 29918, 77684, 77692, 29927, 29919, 77685, 77693, 30176, 78418, 78009, 78426, 30178, 78419, 78012, 
78427, 30179, 30162, 77986, 78011
28329, 29927, 29919, 77685, 77693, 29928, 29920, 77686, 77694, 30178, 78419, 78012, 78427, 30180, 78420, 78015, 
78428, 30181, 30164, 77989, 78014
28330, 29928, 29920, 77686, 77694, 29929, 29921, 77687, 77695, 30180, 78420, 78015, 78428, 30182, 78421, 78018, 
78429, 30183, 30166, 77992, 78017
28331, 29929, 29921, 77687, 77695, 29930, 29922, 77688, 77696, 30182, 78421, 78018, 78429, 30184, 78422, 78021, 
78430, 30185, 30168, 77995, 78020
28332, 29930, 29922, 77688, 77696, 29931, 29923, 77689, 77697, 30184, 78422, 78021, 78430, 30186, 78423, 78024, 
78431, 30187, 30170, 77998, 78023
28333, 29931, 29923, 77689, 77697, 3506, 3505, 29712, 29713, 30186, 78423, 78024, 78431, 3528, 29779, 29744, 
29780, 30188, 30171, 78001, 78026
28334, 3456, 3455, 29624, 29625, 29932, 29924, 77690, 77698, 3478, 29691, 29656, 29692, 30189, 78424, 78028, 
78432, 30190, 30173, 78002, 78027
28335, 29932, 29924, 77690, 77698, 29933, 29925, 77691, 77699, 30189, 78424, 78028, 78432, 30191, 78425, 78031, 
78433, 30192, 30175, 78005, 78030
28336, 29933, 29925, 77691, 77699, 29934, 29926, 77692, 77700, 30191, 78425, 78031, 78433, 30193, 78426, 78034, 
78434, 30194, 30177, 78008, 78033
28337, 29934, 29926, 77692, 77700, 29935, 29927, 77693, 77701, 30193, 78426, 78034, 78434, 30195, 78427, 78037, 
78435, 30196, 30179, 78011, 78036
28338, 29935, 29927, 77693, 77701, 29936, 29928, 77694, 77702, 30195, 78427, 78037, 78435, 30197, 78428, 78040, 
78436, 30198, 30181, 78014, 78039
28339, 29936, 29928, 77694, 77702, 29937, 29929, 77695, 77703, 30197, 78428, 78040, 78436, 30199, 78429, 78043, 
78437, 30200, 30183, 78017, 78042
28340, 29937, 29929, 77695, 77703, 29938, 29930, 77696, 77704, 30199, 78429, 78043, 78437, 30201, 78430, 78046, 
78438, 30202, 30185, 78020, 78045
28341, 29938, 29930, 77696, 77704, 29939, 29931, 77697, 77705, 30201, 78430, 78046, 78438, 30203, 78431, 78049, 
78439, 30204, 30187, 78023, 78048
28342, 29939, 29931, 77697, 77705, 3507, 3506, 29713, 29714, 30203, 78431, 78049, 78439, 3529, 29780, 29746, 
29781, 30205, 30188, 78026, 78051
28343, 3457, 3456, 29625, 29626, 29940, 29932, 77698, 77706, 3479, 29692, 29658, 29693, 30206, 78432, 78053, 
78440, 30207, 30190, 78027, 78052
28344, 29940, 29932, 77698, 77706, 29941, 29933, 77699, 77707, 30206, 78432, 78053, 78440, 30208, 78433, 78056, 
78441, 30209, 30192, 78030, 78055
28345, 29941, 29933, 77699, 77707, 29942, 29934, 77700, 77708, 30208, 78433, 78056, 78441, 30210, 78434, 78059, 
78442, 30211, 30194, 78033, 78058
28346, 29942, 29934, 77700, 77708, 29943, 29935, 77701, 77709, 30210, 78434, 78059, 78442, 30212, 78435, 78062, 
78443, 30213, 30196, 78036, 78061
28347, 29943, 29935, 77701, 77709, 29944, 29936, 77702, 77710, 30212, 78435, 78062, 78443, 30214, 78436, 78065, 
78444, 30215, 30198, 78039, 78064
28348, 29944, 29936, 77702, 77710, 29945, 29937, 77703, 77711, 30214, 78436, 78065, 78444, 30216, 78437, 78068, 
78445, 30217, 30200, 78042, 78067
28349, 29945, 29937, 77703, 77711, 29946, 29938, 77704, 77712, 30216, 78437, 78068, 78445, 30218, 78438, 78071, 
78446, 30219, 30202, 78045, 78070
28350, 29946, 29938, 77704, 77712, 29947, 29939, 77705, 77713, 30218, 78438, 78071, 78446, 30220, 78439, 78074, 
78447, 30221, 30204, 78048, 78073
28351, 29947, 29939, 77705, 77713, 3508, 3507, 29714, 29715, 30220, 78439, 78074, 78447, 3530, 29781, 29748, 
29782, 30222, 30205, 78051, 78076
28352, 3458, 3457, 29626, 29627, 29948, 29940, 77706, 77714, 3480, 29693, 29660, 29694, 30223, 78440, 78078, 
78448, 30224, 30207, 78052, 78077
28353, 29948, 29940, 77706, 77714, 29949, 29941, 77707, 77715, 30223, 78440, 78078, 78448, 30225, 78441, 78081, 
78449, 30226, 30209, 78055, 78080
28354, 29949, 29941, 77707, 77715, 29950, 29942, 77708, 77716, 30225, 78441, 78081, 78449, 30227, 78442, 78084, 
78450, 30228, 30211, 78058, 78083
28355, 29950, 29942, 77708, 77716, 29951, 29943, 77709, 77717, 30227, 78442, 78084, 78450, 30229, 78443, 78087, 
78451, 30230, 30213, 78061, 78086
28356, 29951, 29943, 77709, 77717, 29952, 29944, 77710, 77718, 30229, 78443, 78087, 78451, 30231, 78444, 78090, 
78452, 30232, 30215, 78064, 78089
28357, 29952, 29944, 77710, 77718, 29953, 29945, 77711, 77719, 30231, 78444, 78090, 78452, 30233, 78445, 78093, 
78453, 30234, 30217, 78067, 78092
28358, 29953, 29945, 77711, 77719, 29954, 29946, 77712, 77720, 30233, 78445, 78093, 78453, 30235, 78446, 78096, 
78454, 30236, 30219, 78070, 78095
28359, 29954, 29946, 77712, 77720, 29955, 29947, 77713, 77721, 30235, 78446, 78096, 78454, 30237, 78447, 78099, 
78455, 30238, 30221, 78073, 78098
28360, 29955, 29947, 77713, 77721, 3509, 3508, 29715, 29716, 30237, 78447, 78099, 78455, 3531, 29782, 29750, 
29783, 30239, 30222, 78076, 78101
28361, 3459, 3458, 29627, 29628, 29956, 29948, 77714, 77722, 3481, 29694, 29662, 29695, 30240, 78448, 78103, 
78456, 30241, 30224, 78077, 78102
28362, 29956, 29948, 77714, 77722, 29957, 29949, 77715, 77723, 30240, 78448, 78103, 78456, 30242, 78449, 78106, 
78457, 30243, 30226, 78080, 78105
28363, 29957, 29949, 77715, 77723, 29958, 29950, 77716, 77724, 30242, 78449, 78106, 78457, 30244, 78450, 78109, 
78458, 30245, 30228, 78083, 78108
28364, 29958, 29950, 77716, 77724, 29959, 29951, 77717, 77725, 30244, 78450, 78109, 78458, 30246, 78451, 78112, 
78459, 30247, 30230, 78086, 78111
28365, 29959, 29951, 77717, 77725, 29960, 29952, 77718, 77726, 30246, 78451, 78112, 78459, 30248, 78452, 78115, 
78460, 30249, 30232, 78089, 78114
28366, 29960, 29952, 77718, 77726, 29961, 29953, 77719, 77727, 30248, 78452, 78115, 78460, 30250, 78453, 78118, 
78461, 30251, 30234, 78092, 78117
28367, 29961, 29953, 77719, 77727, 29962, 29954, 77720, 77728, 30250, 78453, 78118, 78461, 30252, 78454, 78121, 
78462, 30253, 30236, 78095, 78120
28368, 29962, 29954, 77720, 77728, 29963, 29955, 77721, 77729, 30252, 78454, 78121, 78462, 30254, 78455, 78124, 
78463, 30255, 30238, 78098, 78123
28369, 29963, 29955, 77721, 77729, 3510, 3509, 29716, 29717, 30254, 78455, 78124, 78463, 3532, 29783, 29752, 
29784, 30256, 30239, 78101, 78126
28370, 3460, 3459, 29628, 29629, 29964, 29956, 77722, 77730, 3482, 29695, 29664, 29696, 30257, 78456, 78128, 
78464, 30258, 30241, 78102, 78127
28371, 29964, 29956, 77722, 77730, 29965, 29957, 77723, 77731, 30257, 78456, 78128, 78464, 30259, 78457, 78131, 
78465, 30260, 30243, 78105, 78130
28372, 29965, 29957, 77723, 77731, 29966, 29958, 77724, 77732, 30259, 78457, 78131, 78465, 30261, 78458, 78134, 
78466, 30262, 30245, 78108, 78133
28373, 29966, 29958, 77724, 77732, 29967, 29959, 77725, 77733, 30261, 78458, 78134, 78466, 30263, 78459, 78137, 
78467, 30264, 30247, 78111, 78136
28374, 29967, 29959, 77725, 77733, 29968, 29960, 77726, 77734, 30263, 78459, 78137, 78467, 30265, 78460, 78140, 
78468, 30266, 30249, 78114, 78139
28375, 29968, 29960, 77726, 77734, 29969, 29961, 77727, 77735, 30265, 78460, 78140, 78468, 30267, 78461, 78143, 
78469, 30268, 30251, 78117, 78142
28376, 29969, 29961, 77727, 77735, 29970, 29962, 77728, 77736, 30267, 78461, 78143, 78469, 30269, 78462, 78146, 
78470, 30270, 30253, 78120, 78145
28377, 29970, 29962, 77728, 77736, 29971, 29963, 77729, 77737, 30269, 78462, 78146, 78470, 30271, 78463, 78149, 
78471, 30272, 30255, 78123, 78148
28378, 29971, 29963, 77729, 77737, 3511, 3510, 29717, 29718, 30271, 78463, 78149, 78471, 3533, 29784, 29754, 
29785, 30273, 30256, 78126, 78151
28379, 3461, 3460, 29629, 29630, 29972, 29964, 77730, 77738, 3483, 29696, 29666, 29697, 30274, 78464, 78153, 
78472, 30275, 30258, 78127, 78152
28380, 29972, 29964, 77730, 77738, 29973, 29965, 77731, 77739, 30274, 78464, 78153, 78472, 30276, 78465, 78156, 
78473, 30277, 30260, 78130, 78155
28381, 29973, 29965, 77731, 77739, 29974, 29966, 77732, 77740, 30276, 78465, 78156, 78473, 30278, 78466, 78159, 
78474, 30279, 30262, 78133, 78158
28382, 29974, 29966, 77732, 77740, 29975, 29967, 77733, 77741, 30278, 78466, 78159, 78474, 30280, 78467, 78162, 
78475, 30281, 30264, 78136, 78161
28383, 29975, 29967, 77733, 77741, 29976, 29968, 77734, 77742, 30280, 78467, 78162, 78475, 30282, 78468, 78165, 
78476, 30283, 30266, 78139, 78164
28384, 29976, 29968, 77734, 77742, 29977, 29969, 77735, 77743, 30282, 78468, 78165, 78476, 30284, 78469, 78168, 
78477, 30285, 30268, 78142, 78167
28385, 29977, 29969, 77735, 77743, 29978, 29970, 77736, 77744, 30284, 78469, 78168, 78477, 30286, 78470, 78171, 
78478, 30287, 30270, 78145, 78170
28386, 29978, 29970, 77736, 77744, 29979, 29971, 77737, 77745, 30286, 78470, 78171, 78478, 30288, 78471, 78174, 
78479, 30289, 30272, 78148, 78173
28387, 29979, 29971, 77737, 77745, 3512, 3511, 29718, 29719, 30288, 78471, 78174, 78479, 3534, 29785, 29756, 
29786, 30290, 30273, 78151, 78176
28388, 3462, 3461, 29630, 29631, 29980, 29972, 77738, 77746, 3484, 29697, 29668, 29698, 30291, 78472, 78178, 
78480, 30292, 30275, 78152, 78177
28389, 29980, 29972, 77738, 77746, 29981, 29973, 77739, 77747, 30291, 78472, 78178, 78480, 30293, 78473, 78181, 
78481, 30294, 30277, 78155, 78180
28390, 29981, 29973, 77739, 77747, 29982, 29974, 77740, 77748, 30293, 78473, 78181, 78481, 30295, 78474, 78184, 
78482, 30296, 30279, 78158, 78183
28391, 29982, 29974, 77740, 77748, 29983, 29975, 77741, 77749, 30295, 78474, 78184, 78482, 30297, 78475, 78187, 
78483, 30298, 30281, 78161, 78186
28392, 29983, 29975, 77741, 77749, 29984, 29976, 77742, 77750, 30297, 78475, 78187, 78483, 30299, 78476, 78190, 
78484, 30300, 30283, 78164, 78189
28393, 29984, 29976, 77742, 77750, 29985, 29977, 77743, 77751, 30299, 78476, 78190, 78484, 30301, 78477, 78193, 
78485, 30302, 30285, 78167, 78192
28394, 29985, 29977, 77743, 77751, 29986, 29978, 77744, 77752, 30301, 78477, 78193, 78485, 30303, 78478, 78196, 
78486, 30304, 30287, 78170, 78195
28395, 29986, 29978, 77744, 77752, 29987, 29979, 77745, 77753, 30303, 78478, 78196, 78486, 30305, 78479, 78199, 
78487, 30306, 30289, 78173, 78198
28396, 29987, 29979, 77745, 77753, 3513, 3512, 29719, 29720, 30305, 78479, 78199, 78487, 3535, 29786, 29758, 
29787, 30307, 30290, 78176, 78201
28397, 3463, 3462, 29631, 29632, 29988, 29980, 77746, 77754, 3485, 29698, 29670, 29699, 30308, 78480, 78203, 
78488, 30309, 30292, 78177, 78202
28398, 29988, 29980, 77746, 77754, 29989, 29981, 77747, 77755, 30308, 78480, 78203, 78488, 30310, 78481, 78206, 
78489, 30311, 30294, 78180, 78205
28399, 29989, 29981, 77747, 77755, 29990, 29982, 77748, 77756, 30310, 78481, 78206, 78489, 30312, 78482, 78209, 
78490, 30313, 30296, 78183, 78208
28400, 29990, 29982, 77748, 77756, 29991, 29983, 77749, 77757, 30312, 78482, 78209, 78490, 30314, 78483, 78212, 
78491, 30315, 30298, 78186, 78211
28401, 29991, 29983, 77749, 77757, 29992, 29984, 77750, 77758, 30314, 78483, 78212, 78491, 30316, 78484, 78215, 
78492, 30317, 30300, 78189, 78214
28402, 29992, 29984, 77750, 77758, 29993, 29985, 77751, 77759, 30316, 78484, 78215, 78492, 30318, 78485, 78218, 
78493, 30319, 30302, 78192, 78217
28403, 29993, 29985, 77751, 77759, 29994, 29986, 77752, 77760, 30318, 78485, 78218, 78493, 30320, 78486, 78221, 
78494, 30321, 30304, 78195, 78220
28404, 29994, 29986, 77752, 77760, 29995, 29987, 77753, 77761, 30320, 78486, 78221, 78494, 30322, 78487, 78224, 
78495, 30323, 30306, 78198, 78223
28405, 29995, 29987, 77753, 77761, 3514, 3513, 29720, 29721, 30322, 78487, 78224, 78495, 3536, 29787, 29760, 
29788, 30324, 30307, 78201, 78226
28406, 3464, 3463, 29632, 29633, 29996, 29988, 77754, 77762, 3486, 29699, 29672, 29700, 30325, 78488, 78228, 
78496, 30326, 30309, 78202, 78227
28407, 29996, 29988, 77754, 77762, 29997, 29989, 77755, 77763, 30325, 78488, 78228, 78496, 30327, 78489, 78231, 
78497, 30328, 30311, 78205, 78230
28408, 29997, 29989, 77755, 77763, 29998, 29990, 77756, 77764, 30327, 78489, 78231, 78497, 30329, 78490, 78234, 
78498, 30330, 30313, 78208, 78233
28409, 29998, 29990, 77756, 77764, 29999, 29991, 77757, 77765, 30329, 78490, 78234, 78498, 30331, 78491, 78237, 
78499, 30332, 30315, 78211, 78236
28410, 29999, 29991, 77757, 77765, 30000, 29992, 77758, 77766, 30331, 78491, 78237, 78499, 30333, 78492, 78240, 
78500, 30334, 30317, 78214, 78239
28411, 30000, 29992, 77758, 77766, 30001, 29993, 77759, 77767, 30333, 78492, 78240, 78500, 30335, 78493, 78243, 
78501, 30336, 30319, 78217, 78242
28412, 30001, 29993, 77759, 77767, 30002, 29994, 77760, 77768, 30335, 78493, 78243, 78501, 30337, 78494, 78246, 
78502, 30338, 30321, 78220, 78245
28413, 30002, 29994, 77760, 77768, 30003, 29995, 77761, 77769, 30337, 78494, 78246, 78502, 30339, 78495, 78249, 
78503, 30340, 30323, 78223, 78248
28414, 30003, 29995, 77761, 77769, 3515, 3514, 29721, 29722, 30339, 78495, 78249, 78503, 3537, 29788, 29762, 
29789, 30341, 30324, 78226, 78251
28415, 3465, 3464, 29633, 29634, 30004, 29996, 77762, 77770, 3487, 29700, 29674, 29701, 30342, 78496, 78253, 
78504, 30343, 30326, 78227, 78252
28416, 30004, 29996, 77762, 77770, 30005, 29997, 77763, 77771, 30342, 78496, 78253, 78504, 30344, 78497, 78256, 
78505, 30345, 30328, 78230, 78255
28417, 30005, 29997, 77763, 77771, 30006, 29998, 77764, 77772, 30344, 78497, 78256, 78505, 30346, 78498, 78259, 
78506, 30347, 30330, 78233, 78258
28418, 30006, 29998, 77764, 77772, 30007, 29999, 77765, 77773, 30346, 78498, 78259, 78506, 30348, 78499, 78262, 
78507, 30349, 30332, 78236, 78261
28419, 30007, 29999, 77765, 77773, 30008, 30000, 77766, 77774, 30348, 78499, 78262, 78507, 30350, 78500, 78265, 
78508, 30351, 30334, 78239, 78264
28420, 30008, 30000, 77766, 77774, 30009, 30001, 77767, 77775, 30350, 78500, 78265, 78508, 30352, 78501, 78268, 
78509, 30353, 30336, 78242, 78267
28421, 30009, 30001, 77767, 77775, 30010, 30002, 77768, 77776, 30352, 78501, 78268, 78509, 30354, 78502, 78271, 
78510, 30355, 30338, 78245, 78270
28422, 30010, 30002, 77768, 77776, 30011, 30003, 77769, 77777, 30354, 78502, 78271, 78510, 30356, 78503, 78274, 
78511, 30357, 30340, 78248, 78273
28423, 30011, 30003, 77769, 77777, 3516, 3515, 29722, 29723, 30356, 78503, 78274, 78511, 3538, 29789, 29764, 
29790, 30358, 30341, 78251, 78276
28424, 3466, 3465, 29634, 29635, 30012, 30004, 77770, 77778, 3488, 29701, 29676, 29702, 30359, 78504, 78278, 
78512, 30360, 30343, 78252, 78277
28425, 30012, 30004, 77770, 77778, 30013, 30005, 77771, 77779, 30359, 78504, 78278, 78512, 30361, 78505, 78281, 
78513, 30362, 30345, 78255, 78280
28426, 30013, 30005, 77771, 77779, 30014, 30006, 77772, 77780, 30361, 78505, 78281, 78513, 30363, 78506, 78284, 
78514, 30364, 30347, 78258, 78283
28427, 30014, 30006, 77772, 77780, 30015, 30007, 77773, 77781, 30363, 78506, 78284, 78514, 30365, 78507, 78287, 
78515, 30366, 30349, 78261, 78286
28428, 30015, 30007, 77773, 77781, 30016, 30008, 77774, 77782, 30365, 78507, 78287, 78515, 30367, 78508, 78290, 
78516, 30368, 30351, 78264, 78289
28429, 30016, 30008, 77774, 77782, 30017, 30009, 77775, 77783, 30367, 78508, 78290, 78516, 30369, 78509, 78293, 
78517, 30370, 30353, 78267, 78292
28430, 30017, 30009, 77775, 77783, 30018, 30010, 77776, 77784, 30369, 78509, 78293, 78517, 30371, 78510, 78296, 
78518, 30372, 30355, 78270, 78295
28431, 30018, 30010, 77776, 77784, 30019, 30011, 77777, 77785, 30371, 78510, 78296, 78518, 30373, 78511, 78299, 
78519, 30374, 30357, 78273, 78298
28432, 30019, 30011, 77777, 77785, 3517, 3516, 29723, 29724, 30373, 78511, 78299, 78519, 3539, 29790, 29766, 
29791, 30375, 30358, 78276, 78301
28433, 3467, 3466, 29635, 29636, 30020, 30012, 77778, 77786, 3489, 29702, 29678, 29703, 30376, 78512, 78303, 
78520, 30377, 30360, 78277, 78302
28434, 30020, 30012, 77778, 77786, 30021, 30013, 77779, 77787, 30376, 78512, 78303, 78520, 30378, 78513, 78306, 
78521, 30379, 30362, 78280, 78305
28435, 30021, 30013, 77779, 77787, 30022, 30014, 77780, 77788, 30378, 78513, 78306, 78521, 30380, 78514, 78309, 
78522, 30381, 30364, 78283, 78308
28436, 30022, 30014, 77780, 77788, 30023, 30015, 77781, 77789, 30380, 78514, 78309, 78522, 30382, 78515, 78312, 
78523, 30383, 30366, 78286, 78311
28437, 30023, 30015, 77781, 77789, 30024, 30016, 77782, 77790, 30382, 78515, 78312, 78523, 30384, 78516, 78315, 
78524, 30385, 30368, 78289, 78314
28438, 30024, 30016, 77782, 77790, 30025, 30017, 77783, 77791, 30384, 78516, 78315, 78524, 30386, 78517, 78318, 
78525, 30387, 30370, 78292, 78317
28439, 30025, 30017, 77783, 77791, 30026, 30018, 77784, 77792, 30386, 78517, 78318, 78525, 30388, 78518, 78321, 
78526, 30389, 30372, 78295, 78320
28440, 30026, 30018, 77784, 77792, 30027, 30019, 77785, 77793, 30388, 78518, 78321, 78526, 30390, 78519, 78324, 
78527, 30391, 30374, 78298, 78323
28441, 30027, 30019, 77785, 77793, 3518, 3517, 29724, 29725, 30390, 78519, 78324, 78527, 3540, 29791, 29768, 
29792, 30392, 30375, 78301, 78326
28442, 3468, 3467, 29636, 29637, 30028, 30020, 77786, 77794, 3490, 29703, 29680, 29704, 30393, 78520, 78328, 
78528, 30394, 30377, 78302, 78327
28443, 30028, 30020, 77786, 77794, 30029, 30021, 77787, 77795, 30393, 78520, 78328, 78528, 30395, 78521, 78331, 
78529, 30396, 30379, 78305, 78330
28444, 30029, 30021, 77787, 77795, 30030, 30022, 77788, 77796, 30395, 78521, 78331, 78529, 30397, 78522, 78334, 
78530, 30398, 30381, 78308, 78333
28445, 30030, 30022, 77788, 77796, 30031, 30023, 77789, 77797, 30397, 78522, 78334, 78530, 30399, 78523, 78337, 
78531, 30400, 30383, 78311, 78336
28446, 30031, 30023, 77789, 77797, 30032, 30024, 77790, 77798, 30399, 78523, 78337, 78531, 30401, 78524, 78340, 
78532, 30402, 30385, 78314, 78339
28447, 30032, 30024, 77790, 77798, 30033, 30025, 77791, 77799, 30401, 78524, 78340, 78532, 30403, 78525, 78343, 
78533, 30404, 30387, 78317, 78342
28448, 30033, 30025, 77791, 77799, 30034, 30026, 77792, 77800, 30403, 78525, 78343, 78533, 30405, 78526, 78346, 
78534, 30406, 30389, 78320, 78345
28449, 30034, 30026, 77792, 77800, 30035, 30027, 77793, 77801, 30405, 78526, 78346, 78534, 30407, 78527, 78349, 
78535, 30408, 30391, 78323, 78348
28450, 30035, 30027, 77793, 77801, 3519, 3518, 29725, 29726, 30407, 78527, 78349, 78535, 3541, 29792, 29770, 
29793, 30409, 30392, 78326, 78351
28451, 98, 3468, 29637, 3444, 3567, 30028, 77794, 29827, 3491, 29704, 29682, 3446, 30410, 78528, 78352, 
29852, 3576, 30394, 78327, 29835
28452, 3567, 30028, 77794, 29827, 3566, 30029, 77795, 29828, 30410, 78528, 78352, 29852, 30411, 78529, 78353, 
29853, 3575, 30396, 78330, 29837
28453, 3566, 30029, 77795, 29828, 3565, 30030, 77796, 29829, 30411, 78529, 78353, 29853, 30412, 78530, 78354, 
29854, 3574, 30398, 78333, 29839
28454, 3565, 30030, 77796, 29829, 3564, 30031, 77797, 29830, 30412, 78530, 78354, 29854, 30413, 78531, 78355, 
29855, 3573, 30400, 78336, 29841
28455, 3564, 30031, 77797, 29830, 3563, 30032, 77798, 29831, 30413, 78531, 78355, 29855, 30414, 78532, 78356, 
29856, 3572, 30402, 78339, 29843
28456, 3563, 30032, 77798, 29831, 3562, 30033, 77799, 29832, 30414, 78532, 78356, 29856, 30415, 78533, 78357, 
29857, 3571, 30404, 78342, 29845
28457, 3562, 30033, 77799, 29832, 3561, 30034, 77800, 29833, 30415, 78533, 78357, 29857, 30416, 78534, 78358, 
29858, 3570, 30406, 78345, 29847
28458, 3561, 30034, 77800, 29833, 3560, 30035, 77801, 29834, 30416, 78534, 78358, 29858, 30417, 78535, 78359, 
29859, 3569, 30408, 78348, 29849
28459, 3560, 30035, 77801, 29834, 100, 3519, 29726, 3495, 30417, 78535, 78359, 29859, 3542, 29793, 29771, 
3497, 3568, 30409, 78351, 29851
*ELEMENT, type=C3D20, ELSET=Volume11
28460, 10469, 1186, 35, 1196, 78536, 10781, 1303, 10897, 10513, 1188, 1218, 10514, 78889, 10797, 11074, 
78890, 78888, 10798, 1312, 11073
28461, 78536, 10781, 1303, 10897, 78537, 10782, 1302, 10898, 78889, 10797, 11074, 78890, 78892, 10799, 11076, 
78893, 78891, 10800, 1311, 11075
28462, 78537, 10782, 1302, 10898, 78538, 10783, 1301, 10899, 78892, 10799, 11076, 78893, 78895, 10801, 11078, 
78896, 78894, 10802, 1310, 11077
28463, 78538, 10783, 1301, 10899, 78539, 10784, 1300, 10900, 78895, 10801, 11078, 78896, 78898, 10803, 11080, 
78899, 78897, 10804, 1309, 11079
28464, 78539, 10784, 1300, 10900, 78540, 10785, 1299, 10901, 78898, 10803, 11080, 78899, 78901, 10805, 11082, 
78902, 78900, 10806, 1308, 11081
28465, 78540, 10785, 1299, 10901, 78541, 10786, 1298, 10902, 78901, 10805, 11082, 78902, 78904, 10807, 11084, 
78905, 78903, 10808, 1307, 11083
28466, 78541, 10786, 1298, 10902, 78542, 10787, 1297, 10903, 78904, 10807, 11084, 78905, 78907, 10809, 11086, 
78908, 78906, 10810, 1306, 11085
28467, 78542, 10787, 1297, 10903, 78543, 10788, 1296, 10904, 78907, 10809, 11086, 78908, 78910, 10811, 11088, 
78911, 78909, 10812, 1305, 11087
28468, 78543, 10788, 1296, 10904, 10625, 1241, 37, 1251, 78910, 10811, 11088, 78911, 10670, 1243, 1273, 
10669, 78912, 10813, 1304, 11089
28469, 10470, 10469, 1196, 1197, 78544, 78536, 10897, 10905, 10515, 10514, 1219, 10516, 78914, 78890, 11091, 
78915, 78913, 78888, 11073, 11090
28470, 78544, 78536, 10897, 10905, 78545, 78537, 10898, 10906, 78914, 78890, 11091, 78915, 78917, 78893, 11093, 
78918, 78916, 78891, 11075, 11092
28471, 78545, 78537, 10898, 10906, 78546, 78538, 10899, 10907, 78917, 78893, 11093, 78918, 78920, 78896, 11095, 
78921, 78919, 78894, 11077, 11094
28472, 78546, 78538, 10899, 10907, 78547, 78539, 10900, 10908, 78920, 78896, 11095, 78921, 78923, 78899, 11097, 
78924, 78922, 78897, 11079, 11096
28473, 78547, 78539, 10900, 10908, 78548, 78540, 10901, 10909, 78923, 78899, 11097, 78924, 78926, 78902, 11099, 
78927, 78925, 78900, 11081, 11098
28474, 78548, 78540, 10901, 10909, 78549, 78541, 10902, 10910, 78926, 78902, 11099, 78927, 78929, 78905, 11101, 
78930, 78928, 78903, 11083, 11100
28475, 78549, 78541, 10902, 10910, 78550, 78542, 10903, 10911, 78929, 78905, 11101, 78930, 78932, 78908, 11103, 
78933, 78931, 78906, 11085, 11102
28476, 78550, 78542, 10903, 10911, 78551, 78543, 10904, 10912, 78932, 78908, 11103, 78933, 78935, 78911, 11105, 
78936, 78934, 78909, 11087, 11104
28477, 78551, 78543, 10904, 10912, 10626, 10625, 1251, 1252, 78935, 78911, 11105, 78936, 10672, 10669, 1274, 
10671, 78937, 78912, 11089, 11106
28478, 10471, 10470, 1197, 1198, 78552, 78544, 10905, 10913, 10517, 10516, 1220, 10518, 78939, 78915, 11108, 
78940, 78938, 78913, 11090, 11107
28479, 78552, 78544, 10905, 10913, 78553, 78545, 10906, 10914, 78939, 78915, 11108, 78940, 78942, 78918, 11110, 
78943, 78941, 78916, 11092, 11109
28480, 78553, 78545, 10906, 10914, 78554, 78546, 10907, 10915, 78942, 78918, 11110, 78943, 78945, 78921, 11112, 
78946, 78944, 78919, 11094, 11111
28481, 78554, 78546, 10907, 10915, 78555, 78547, 10908, 10916, 78945, 78921, 11112, 78946, 78948, 78924, 11114, 
78949, 78947, 78922, 11096, 11113
28482, 78555, 78547, 10908, 10916, 78556, 78548, 10909, 10917, 78948, 78924, 11114, 78949, 78951, 78927, 11116, 
78952, 78950, 78925, 11098, 11115
28483, 78556, 78548, 10909, 10917, 78557, 78549, 10910, 10918, 78951, 78927, 11116, 78952, 78954, 78930, 11118, 
78955, 78953, 78928, 11100, 11117
28484, 78557, 78549, 10910, 10918, 78558, 78550, 10911, 10919, 78954, 78930, 11118, 78955, 78957, 78933, 11120, 
78958, 78956, 78931, 11102, 11119
28485, 78558, 78550, 10911, 10919, 78559, 78551, 10912, 10920, 78957, 78933, 11120, 78958, 78960, 78936, 11122, 
78961, 78959, 78934, 11104, 11121
28486, 78559, 78551, 10912, 10920, 10627, 10626, 1252, 1253, 78960, 78936, 11122, 78961, 10674, 10671, 1275, 
10673, 78962, 78937, 11106, 11123
28487, 10472, 10471, 1198, 1199, 78560, 78552, 10913, 10921, 10519, 10518, 1221, 10520, 78964, 78940, 11125, 
78965, 78963, 78938, 11107, 11124
28488, 78560, 78552, 10913, 10921, 78561, 78553, 10914, 10922, 78964, 78940, 11125, 78965, 78967, 78943, 11127, 
78968, 78966, 78941, 11109, 11126
28489, 78561, 78553, 10914, 10922, 78562, 78554, 10915, 10923, 78967, 78943, 11127, 78968, 78970, 78946, 11129, 
78971, 78969, 78944, 11111, 11128
28490, 78562, 78554, 10915, 10923, 78563, 78555, 10916, 10924, 78970, 78946, 11129, 78971, 78973, 78949, 11131, 
78974, 78972, 78947, 11113, 11130
28491, 78563, 78555, 10916, 10924, 78564, 78556, 10917, 10925, 78973, 78949, 11131, 78974, 78976, 78952, 11133, 
78977, 78975, 78950, 11115, 11132
28492, 78564, 78556, 10917, 10925, 78565, 78557, 10918, 10926, 78976, 78952, 11133, 78977, 78979, 78955, 11135, 
78980, 78978, 78953, 11117, 11134
28493, 78565, 78557, 10918, 10926, 78566, 78558, 10919, 10927, 78979, 78955, 11135, 78980, 78982, 78958, 11137, 
78983, 78981, 78956, 11119, 11136
28494, 78566, 78558, 10919, 10927, 78567, 78559, 10920, 10928, 78982, 78958, 11137, 78983, 78985, 78961, 11139, 
78986, 78984, 78959, 11121, 11138
28495, 78567, 78559, 10920, 10928, 10628, 10627, 1253, 1254, 78985, 78961, 11139, 78986, 10676, 10673, 1276, 
10675, 78987, 78962, 11123, 11140
28496, 10473, 10472, 1199, 1200, 78568, 78560, 10921, 10929, 10521, 10520, 1222, 10522, 78989, 78965, 11142, 
78990, 78988, 78963, 11124, 11141
28497, 78568, 78560, 10921, 10929, 78569, 78561, 10922, 10930, 78989, 78965, 11142, 78990, 78992, 78968, 11144, 
78993, 78991, 78966, 11126, 11143
28498, 78569, 78561, 10922, 10930, 78570, 78562, 10923, 10931, 78992, 78968, 11144, 78993, 78995, 78971, 11146, 
78996, 78994, 78969, 11128, 11145
28499, 78570, 78562, 10923, 10931, 78571, 78563, 10924, 10932, 78995, 78971, 11146, 78996, 78998, 78974, 11148, 
78999, 78997, 78972, 11130, 11147
28500, 78571, 78563, 10924, 10932, 78572, 78564, 10925, 10933, 78998, 78974, 11148, 78999, 79001, 78977, 11150, 
79002, 79000, 78975, 11132, 11149
28501, 78572, 78564, 10925, 10933, 78573, 78565, 10926, 10934, 79001, 78977, 11150, 79002, 79004, 78980, 11152, 
79005, 79003, 78978, 11134, 11151
28502, 78573, 78565, 10926, 10934, 78574, 78566, 10927, 10935, 79004, 78980, 11152, 79005, 79007, 78983, 11154, 
79008, 79006, 78981, 11136, 11153
28503, 78574, 78566, 10927, 10935, 78575, 78567, 10928, 10936, 79007, 78983, 11154, 79008, 79010, 78986, 11156, 
79011, 79009, 78984, 11138, 11155
28504, 78575, 78567, 10928, 10936, 10629, 10628, 1254, 1255, 79010, 78986, 11156, 79011, 10678, 10675, 1277, 
10677, 79012, 78987, 11140, 11157
28505, 10474, 10473, 1200, 1201, 78576, 78568, 10929, 10937, 10523, 10522, 1223, 10524, 79014, 78990, 11159, 
79015, 79013, 78988, 11141, 11158
28506, 78576, 78568, 10929, 10937, 78577, 78569, 10930, 10938, 79014, 78990, 11159, 79015, 79017, 78993, 11161, 
79018, 79016, 78991, 11143, 11160
28507, 78577, 78569, 10930, 10938, 78578, 78570, 10931, 10939, 79017, 78993, 11161, 79018, 79020, 78996, 11163, 
79021, 79019, 78994, 11145, 11162
28508, 78578, 78570, 10931, 10939, 78579, 78571, 10932, 10940, 79020, 78996, 11163, 79021, 79023, 78999, 11165, 
79024, 79022, 78997, 11147, 11164
28509, 78579, 78571, 10932, 10940, 78580, 78572, 10933, 10941, 79023, 78999, 11165, 79024, 79026, 79002, 11167, 
79027, 79025, 79000, 11149, 11166
28510, 78580, 78572, 10933, 10941, 78581, 78573, 10934, 10942, 79026, 79002, 11167, 79027, 79029, 79005, 11169, 
79030, 79028, 79003, 11151, 11168
28511, 78581, 78573, 10934, 10942, 78582, 78574, 10935, 10943, 79029, 79005, 11169, 79030, 79032, 79008, 11171, 
79033, 79031, 79006, 11153, 11170
28512, 78582, 78574, 10935, 10943, 78583, 78575, 10936, 10944, 79032, 79008, 11171, 79033, 79035, 79011, 11173, 
79036, 79034, 79009, 11155, 11172
28513, 78583, 78575, 10936, 10944, 10630, 10629, 1255, 1256, 79035, 79011, 11173, 79036, 10680, 10677, 1278, 
10679, 79037, 79012, 11157, 11174
28514, 10475, 10474, 1201, 1202, 78584, 78576, 10937, 10945, 10525, 10524, 1224, 10526, 79039, 79015, 11176, 
79040, 79038, 79013, 11158, 11175
28515, 78584, 78576, 10937, 10945, 78585, 78577, 10938, 10946, 79039, 79015, 11176, 79040, 79042, 79018, 11178, 
79043, 79041, 79016, 11160, 11177
28516, 78585, 78577, 10938, 10946, 78586, 78578, 10939, 10947, 79042, 79018, 11178, 79043, 79045, 79021, 11180, 
79046, 79044, 79019, 11162, 11179
28517, 78586, 78578, 10939, 10947, 78587, 78579, 10940, 10948, 79045, 79021, 11180, 79046, 79048, 79024, 11182, 
79049, 79047, 79022, 11164, 11181
28518, 78587, 78579, 10940, 10948, 78588, 78580, 10941, 10949, 79048, 79024, 11182, 79049, 79051, 79027, 11184, 
79052, 79050, 79025, 11166, 11183
28519, 78588, 78580, 10941, 10949, 78589, 78581, 10942, 10950, 79051, 79027, 11184, 79052, 79054, 79030, 11186, 
79055, 79053, 79028, 11168, 11185
28520, 78589, 78581, 10942, 10950, 78590, 78582, 10943, 10951, 79054, 79030, 11186, 79055, 79057, 79033, 11188, 
79058, 79056, 79031, 11170, 11187
28521, 78590, 78582, 10943, 10951, 78591, 78583, 10944, 10952, 79057, 79033, 11188, 79058, 79060, 79036, 11190, 
79061, 79059, 79034, 11172, 11189
28522, 78591, 78583, 10944, 10952, 10631, 10630, 1256, 1257, 79060, 79036, 11190, 79061, 10682, 10679, 1279, 
10681, 79062, 79037, 11174, 11191
28523, 10476, 10475, 1202, 1203, 78592, 78584, 10945, 10953, 10527, 10526, 1225, 10528, 79064, 79040, 11193, 
79065, 79063, 79038, 11175, 11192
28524, 78592, 78584, 10945, 10953, 78593, 78585, 10946, 10954, 79064, 79040, 11193, 79065, 79067, 79043, 11195, 
79068, 79066, 79041, 11177, 11194
28525, 78593, 78585, 10946, 10954, 78594, 78586, 10947, 10955, 79067, 79043, 11195, 79068, 79070, 79046, 11197, 
79071, 79069, 79044, 11179, 11196
28526, 78594, 78586, 10947, 10955, 78595, 78587, 10948, 10956, 79070, 79046, 11197, 79071, 79073, 79049, 11199, 
79074, 79072, 79047, 11181, 11198
28527, 78595, 78587, 10948, 10956, 78596, 78588, 10949, 10957, 79073, 79049, 11199, 79074, 79076, 79052, 11201, 
79077, 79075, 79050, 11183, 11200
28528, 78596, 78588, 10949, 10957, 78597, 78589, 10950, 10958, 79076, 79052, 11201, 79077, 79079, 79055, 11203, 
79080, 79078, 79053, 11185, 11202
28529, 78597, 78589, 10950, 10958, 78598, 78590, 10951, 10959, 79079, 79055, 11203, 79080, 79082, 79058, 11205, 
79083, 79081, 79056, 11187, 11204
28530, 78598, 78590, 10951, 10959, 78599, 78591, 10952, 10960, 79082, 79058, 11205, 79083, 79085, 79061, 11207, 
79086, 79084, 79059, 11189, 11206
28531, 78599, 78591, 10952, 10960, 10632, 10631, 1257, 1258, 79085, 79061, 11207, 79086, 10684, 10681, 1280, 
10683, 79087, 79062, 11191, 11208
28532, 10477, 10476, 1203, 1204, 78600, 78592, 10953, 10961, 10529, 10528, 1226, 10530, 79089, 79065, 11210, 
79090, 79088, 79063, 11192, 11209
28533, 78600, 78592, 10953, 10961, 78601, 78593, 10954, 10962, 79089, 79065, 11210, 79090, 79092, 79068, 11212, 
79093, 79091, 79066, 11194, 11211
28534, 78601, 78593, 10954, 10962, 78602, 78594, 10955, 10963, 79092, 79068, 11212, 79093, 79095, 79071, 11214, 
79096, 79094, 79069, 11196, 11213
28535, 78602, 78594, 10955, 10963, 78603, 78595, 10956, 10964, 79095, 79071, 11214, 79096, 79098, 79074, 11216, 
79099, 79097, 79072, 11198, 11215
28536, 78603, 78595, 10956, 10964, 78604, 78596, 10957, 10965, 79098, 79074, 11216, 79099, 79101, 79077, 11218, 
79102, 79100, 79075, 11200, 11217
28537, 78604, 78596, 10957, 10965, 78605, 78597, 10958, 10966, 79101, 79077, 11218, 79102, 79104, 79080, 11220, 
79105, 79103, 79078, 11202, 11219
28538, 78605, 78597, 10958, 10966, 78606, 78598, 10959, 10967, 79104, 79080, 11220, 79105, 79107, 79083, 11222, 
79108, 79106, 79081, 11204, 11221
28539, 78606, 78598, 10959, 10967, 78607, 78599, 10960, 10968, 79107, 79083, 11222, 79108, 79110, 79086, 11224, 
79111, 79109, 79084, 11206, 11223
28540, 78607, 78599, 10960, 10968, 10633, 10632, 1258, 1259, 79110, 79086, 11224, 79111, 10686, 10683, 1281, 
10685, 79112, 79087, 11208, 11225
28541, 10478, 10477, 1204, 1205, 78608, 78600, 10961, 10969, 10531, 10530, 1227, 10532, 79114, 79090, 11227, 
79115, 79113, 79088, 11209, 11226
28542, 78608, 78600, 10961, 10969, 78609, 78601, 10962, 10970, 79114, 79090, 11227, 79115, 79117, 79093, 11229, 
79118, 79116, 79091, 11211, 11228
28543, 78609, 78601, 10962, 10970, 78610, 78602, 10963, 10971, 79117, 79093, 11229, 79118, 79120, 79096, 11231, 
79121, 79119, 79094, 11213, 11230
28544, 78610, 78602, 10963, 10971, 78611, 78603, 10964, 10972, 79120, 79096, 11231, 79121, 79123, 79099, 11233, 
79124, 79122, 79097, 11215, 11232
28545, 78611, 78603, 10964, 10972, 78612, 78604, 10965, 10973, 79123, 79099, 11233, 79124, 79126, 79102, 11235, 
79127, 79125, 79100, 11217, 11234
28546, 78612, 78604, 10965, 10973, 78613, 78605, 10966, 10974, 79126, 79102, 11235, 79127, 79129, 79105, 11237, 
79130, 79128, 79103, 11219, 11236
28547, 78613, 78605, 10966, 10974, 78614, 78606, 10967, 10975, 79129, 79105, 11237, 79130, 79132, 79108, 11239, 
79133, 79131, 79106, 11221, 11238
28548, 78614, 78606, 10967, 10975, 78615, 78607, 10968, 10976, 79132, 79108, 11239, 79133, 79135, 79111, 11241, 
79136, 79134, 79109, 11223, 11240
28549, 78615, 78607, 10968, 10976, 10634, 10633, 1259, 1260, 79135, 79111, 11241, 79136, 10688, 10685, 1282, 
10687, 79137, 79112, 11225, 11242
28550, 10479, 10478, 1205, 1206, 78616, 78608, 10969, 10977, 10533, 10532, 1228, 10534, 79139, 79115, 11244, 
79140, 79138, 79113, 11226, 11243
28551, 78616, 78608, 10969, 10977, 78617, 78609, 10970, 10978, 79139, 79115, 11244, 79140, 79142, 79118, 11246, 
79143, 79141, 79116, 11228, 11245
28552, 78617, 78609, 10970, 10978, 78618, 78610, 10971, 10979, 79142, 79118, 11246, 79143, 79145, 79121, 11248, 
79146, 79144, 79119, 11230, 11247
28553, 78618, 78610, 10971, 10979, 78619, 78611, 10972, 10980, 79145, 79121, 11248, 79146, 79148, 79124, 11250, 
79149, 79147, 79122, 11232, 11249
28554, 78619, 78611, 10972, 10980, 78620, 78612, 10973, 10981, 79148, 79124, 11250, 79149, 79151, 79127, 11252, 
79152, 79150, 79125, 11234, 11251
28555, 78620, 78612, 10973, 10981, 78621, 78613, 10974, 10982, 79151, 79127, 11252, 79152, 79154, 79130, 11254, 
79155, 79153, 79128, 11236, 11253
28556, 78621, 78613, 10974, 10982, 78622, 78614, 10975, 10983, 79154, 79130, 11254, 79155, 79157, 79133, 11256, 
79158, 79156, 79131, 11238, 11255
28557, 78622, 78614, 10975, 10983, 78623, 78615, 10976, 10984, 79157, 79133, 11256, 79158, 79160, 79136, 11258, 
79161, 79159, 79134, 11240, 11257
28558, 78623, 78615, 10976, 10984, 10635, 10634, 1260, 1261, 79160, 79136, 11258, 79161, 10690, 10687, 1283, 
10689, 79162, 79137, 11242, 11259
28559, 10480, 10479, 1206, 1207, 78624, 78616, 10977, 10985, 10535, 10534, 1229, 10536, 79164, 79140, 11261, 
79165, 79163, 79138, 11243, 11260
28560, 78624, 78616, 10977, 10985, 78625, 78617, 10978, 10986, 79164, 79140, 11261, 79165, 79167, 79143, 11263, 
79168, 79166, 79141, 11245, 11262
28561, 78625, 78617, 10978, 10986, 78626, 78618, 10979, 10987, 79167, 79143, 11263, 79168, 79170, 79146, 11265, 
79171, 79169, 79144, 11247, 11264
28562, 78626, 78618, 10979, 10987, 78627, 78619, 10980, 10988, 79170, 79146, 11265, 79171, 79173, 79149, 11267, 
79174, 79172, 79147, 11249, 11266
28563, 78627, 78619, 10980, 10988, 78628, 78620, 10981, 10989, 79173, 79149, 11267, 79174, 79176, 79152, 11269, 
79177, 79175, 79150, 11251, 11268
28564, 78628, 78620, 10981, 10989, 78629, 78621, 10982, 10990, 79176, 79152, 11269, 79177, 79179, 79155, 11271, 
79180, 79178, 79153, 11253, 11270
28565, 78629, 78621, 10982, 10990, 78630, 78622, 10983, 10991, 79179, 79155, 11271, 79180, 79182, 79158, 11273, 
79183, 79181, 79156, 11255, 11272
28566, 78630, 78622, 10983, 10991, 78631, 78623, 10984, 10992, 79182, 79158, 11273, 79183, 79185, 79161, 11275, 
79186, 79184, 79159, 11257, 11274
28567, 78631, 78623, 10984, 10992, 10636, 10635, 1261, 1262, 79185, 79161, 11275, 79186, 10692, 10689, 1284, 
10691, 79187, 79162, 11259, 11276
28568, 10481, 10480, 1207, 1208, 78632, 78624, 10985, 10993, 10537, 10536, 1230, 10538, 79189, 79165, 11278, 
79190, 79188, 79163, 11260, 11277
28569, 78632, 78624, 10985, 10993, 78633, 78625, 10986, 10994, 79189, 79165, 11278, 79190, 79192, 79168, 11280, 
79193, 79191, 79166, 11262, 11279
28570, 78633, 78625, 10986, 10994, 78634, 78626, 10987, 10995, 79192, 79168, 11280, 79193, 79195, 79171, 11282, 
79196, 79194, 79169, 11264, 11281
28571, 78634, 78626, 10987, 10995, 78635, 78627, 10988, 10996, 79195, 79171, 11282, 79196, 79198, 79174, 11284, 
79199, 79197, 79172, 11266, 11283
28572, 78635, 78627, 10988, 10996, 78636, 78628, 10989, 10997, 79198, 79174, 11284, 79199, 79201, 79177, 11286, 
79202, 79200, 79175, 11268, 11285
28573, 78636, 78628, 10989, 10997, 78637, 78629, 10990, 10998, 79201, 79177, 11286, 79202, 79204, 79180, 11288, 
79205, 79203, 79178, 11270, 11287
28574, 78637, 78629, 10990, 10998, 78638, 78630, 10991, 10999, 79204, 79180, 11288, 79205, 79207, 79183, 11290, 
79208, 79206, 79181, 11272, 11289
28575, 78638, 78630, 10991, 10999, 78639, 78631, 10992, 11000, 79207, 79183, 11290, 79208, 79210, 79186, 11292, 
79211, 79209, 79184, 11274, 11291
28576, 78639, 78631, 10992, 11000, 10637, 10636, 1262, 1263, 79210, 79186, 11292, 79211, 10694, 10691, 1285, 
10693, 79212, 79187, 11276, 11293
28577, 10482, 10481, 1208, 1209, 78640, 78632, 10993, 11001, 10539, 10538, 1231, 10540, 79214, 79190, 11295, 
79215, 79213, 79188, 11277, 11294
28578, 78640, 78632, 10993, 11001, 78641, 78633, 10994, 11002, 79214, 79190, 11295, 79215, 79217, 79193, 11297, 
79218, 79216, 79191, 11279, 11296
28579, 78641, 78633, 10994, 11002, 78642, 78634, 10995, 11003, 79217, 79193, 11297, 79218, 79220, 79196, 11299, 
79221, 79219, 79194, 11281, 11298
28580, 78642, 78634, 10995, 11003, 78643, 78635, 10996, 11004, 79220, 79196, 11299, 79221, 79223, 79199, 11301, 
79224, 79222, 79197, 11283, 11300
28581, 78643, 78635, 10996, 11004, 78644, 78636, 10997, 11005, 79223, 79199, 11301, 79224, 79226, 79202, 11303, 
79227, 79225, 79200, 11285, 11302
28582, 78644, 78636, 10997, 11005, 78645, 78637, 10998, 11006, 79226, 79202, 11303, 79227, 79229, 79205, 11305, 
79230, 79228, 79203, 11287, 11304
28583, 78645, 78637, 10998, 11006, 78646, 78638, 10999, 11007, 79229, 79205, 11305, 79230, 79232, 79208, 11307, 
79233, 79231, 79206, 11289, 11306
28584, 78646, 78638, 10999, 11007, 78647, 78639, 11000, 11008, 79232, 79208, 11307, 79233, 79235, 79211, 11309, 
79236, 79234, 79209, 11291, 11308
28585, 78647, 78639, 11000, 11008, 10638, 10637, 1263, 1264, 79235, 79211, 11309, 79236, 10696, 10693, 1286, 
10695, 79237, 79212, 11293, 11310
28586, 10483, 10482, 1209, 1210, 78648, 78640, 11001, 11009, 10541, 10540, 1232, 10542, 79239, 79215, 11312, 
79240, 79238, 79213, 11294, 11311
28587, 78648, 78640, 11001, 11009, 78649, 78641, 11002, 11010, 79239, 79215, 11312, 79240, 79242, 79218, 11314, 
79243, 79241, 79216, 11296, 11313
28588, 78649, 78641, 11002, 11010, 78650, 78642, 11003, 11011, 79242, 79218, 11314, 79243, 79245, 79221, 11316, 
79246, 79244, 79219, 11298, 11315
28589, 78650, 78642, 11003, 11011, 78651, 78643, 11004, 11012, 79245, 79221, 11316, 79246, 79248, 79224, 11318, 
79249, 79247, 79222, 11300, 11317
28590, 78651, 78643, 11004, 11012, 78652, 78644, 11005, 11013, 79248, 79224, 11318, 79249, 79251, 79227, 11320, 
79252, 79250, 79225, 11302, 11319
28591, 78652, 78644, 11005, 11013, 78653, 78645, 11006, 11014, 79251, 79227, 11320, 79252, 79254, 79230, 11322, 
79255, 79253, 79228, 11304, 11321
28592, 78653, 78645, 11006, 11014, 78654, 78646, 11007, 11015, 79254, 79230, 11322, 79255, 79257, 79233, 11324, 
79258, 79256, 79231, 11306, 11323
28593, 78654, 78646, 11007, 11015, 78655, 78647, 11008, 11016, 79257, 79233, 11324, 79258, 79260, 79236, 11326, 
79261, 79259, 79234, 11308, 11325
28594, 78655, 78647, 11008, 11016, 10639, 10638, 1264, 1265, 79260, 79236, 11326, 79261, 10698, 10695, 1287, 
10697, 79262, 79237, 11310, 11327
28595, 10484, 10483, 1210, 1211, 78656, 78648, 11009, 11017, 10543, 10542, 1233, 10544, 79264, 79240, 11329, 
79265, 79263, 79238, 11311, 11328
28596, 78656, 78648, 11009, 11017, 78657, 78649, 11010, 11018, 79264, 79240, 11329, 79265, 79267, 79243, 11331, 
79268, 79266, 79241, 11313, 11330
28597, 78657, 78649, 11010, 11018, 78658, 78650, 11011, 11019, 79267, 79243, 11331, 79268, 79270, 79246, 11333, 
79271, 79269, 79244, 11315, 11332
28598, 78658, 78650, 11011, 11019, 78659, 78651, 11012, 11020, 79270, 79246, 11333, 79271, 79273, 79249, 11335, 
79274, 79272, 79247, 11317, 11334
28599, 78659, 78651, 11012, 11020, 78660, 78652, 11013, 11021, 79273, 79249, 11335, 79274, 79276, 79252, 11337, 
79277, 79275, 79250, 11319, 11336
28600, 78660, 78652, 11013, 11021, 78661, 78653, 11014, 11022, 79276, 79252, 11337, 79277, 79279, 79255, 11339, 
79280, 79278, 79253, 11321, 11338
28601, 78661, 78653, 11014, 11022, 78662, 78654, 11015, 11023, 79279, 79255, 11339, 79280, 79282, 79258, 11341, 
79283, 79281, 79256, 11323, 11340
28602, 78662, 78654, 11015, 11023, 78663, 78655, 11016, 11024, 79282, 79258, 11341, 79283, 79285, 79261, 11343, 
79286, 79284, 79259, 11325, 11342
28603, 78663, 78655, 11016, 11024, 10640, 10639, 1265, 1266, 79285, 79261, 11343, 79286, 10700, 10697, 1288, 
10699, 79287, 79262, 11327, 11344
28604, 10485, 10484, 1211, 1212, 78664, 78656, 11017, 11025, 10545, 10544, 1234, 10546, 79289, 79265, 11346, 
79290, 79288, 79263, 11328, 11345
28605, 78664, 78656, 11017, 11025, 78665, 78657, 11018, 11026, 79289, 79265, 11346, 79290, 79292, 79268, 11348, 
79293, 79291, 79266, 11330, 11347
28606, 78665, 78657, 11018, 11026, 78666, 78658, 11019, 11027, 79292, 79268, 11348, 79293, 79295, 79271, 11350, 
79296, 79294, 79269, 11332, 11349
28607, 78666, 78658, 11019, 11027, 78667, 78659, 11020, 11028, 79295, 79271, 11350, 79296, 79298, 79274, 11352, 
79299, 79297, 79272, 11334, 11351
28608, 78667, 78659, 11020, 11028, 78668, 78660, 11021, 11029, 79298, 79274, 11352, 79299, 79301, 79277, 11354, 
79302, 79300, 79275, 11336, 11353
28609, 78668, 78660, 11021, 11029, 78669, 78661, 11022, 11030, 79301, 79277, 11354, 79302, 79304, 79280, 11356, 
79305, 79303, 79278, 11338, 11355
28610, 78669, 78661, 11022, 11030, 78670, 78662, 11023, 11031, 79304, 79280, 11356, 79305, 79307, 79283, 11358, 
79308, 79306, 79281, 11340, 11357
28611, 78670, 78662, 11023, 11031, 78671, 78663, 11024, 11032, 79307, 79283, 11358, 79308, 79310, 79286, 11360, 
79311, 79309, 79284, 11342, 11359
28612, 78671, 78663, 11024, 11032, 10641, 10640, 1266, 1267, 79310, 79286, 11360, 79311, 10702, 10699, 1289, 
10701, 79312, 79287, 11344, 11361
28613, 10486, 10485, 1212, 1213, 78672, 78664, 11025, 11033, 10547, 10546, 1235, 10548, 79314, 79290, 11363, 
79315, 79313, 79288, 11345, 11362
28614, 78672, 78664, 11025, 11033, 78673, 78665, 11026, 11034, 79314, 79290, 11363, 79315, 79317, 79293, 11365, 
79318, 79316, 79291, 11347, 11364
28615, 78673, 78665, 11026, 11034, 78674, 78666, 11027, 11035, 79317, 79293, 11365, 79318, 79320, 79296, 11367, 
79321, 79319, 79294, 11349, 11366
28616, 78674, 78666, 11027, 11035, 78675, 78667, 11028, 11036, 79320, 79296, 11367, 79321, 79323, 79299, 11369, 
79324, 79322, 79297, 11351, 11368
28617, 78675, 78667, 11028, 11036, 78676, 78668, 11029, 11037, 79323, 79299, 11369, 79324, 79326, 79302, 11371, 
79327, 79325, 79300, 11353, 11370
28618, 78676, 78668, 11029, 11037, 78677, 78669, 11030, 11038, 79326, 79302, 11371, 79327, 79329, 79305, 11373, 
79330, 79328, 79303, 11355, 11372
28619, 78677, 78669, 11030, 11038, 78678, 78670, 11031, 11039, 79329, 79305, 11373, 79330, 79332, 79308, 11375, 
79333, 79331, 79306, 11357, 11374
28620, 78678, 78670, 11031, 11039, 78679, 78671, 11032, 11040, 79332, 79308, 11375, 79333, 79335, 79311, 11377, 
79336, 79334, 79309, 11359, 11376
28621, 78679, 78671, 11032, 11040, 10642, 10641, 1267, 1268, 79335, 79311, 11377, 79336, 10704, 10701, 1290, 
10703, 79337, 79312, 11361, 11378
28622, 10487, 10486, 1213, 1214, 78680, 78672, 11033, 11041, 10549, 10548, 1236, 10550, 79339, 79315, 11380, 
79340, 79338, 79313, 11362, 11379
28623, 78680, 78672, 11033, 11041, 78681, 78673, 11034, 11042, 79339, 79315, 11380, 79340, 79342, 79318, 11382, 
79343, 79341, 79316, 11364, 11381
28624, 78681, 78673, 11034, 11042, 78682, 78674, 11035, 11043, 79342, 79318, 11382, 79343, 79345, 79321, 11384, 
79346, 79344, 79319, 11366, 11383
28625, 78682, 78674, 11035, 11043, 78683, 78675, 11036, 11044, 79345, 79321, 11384, 79346, 79348, 79324, 11386, 
79349, 79347, 79322, 11368, 11385
28626, 78683, 78675, 11036, 11044, 78684, 78676, 11037, 11045, 79348, 79324, 11386, 79349, 79351, 79327, 11388, 
79352, 79350, 79325, 11370, 11387
28627, 78684, 78676, 11037, 11045, 78685, 78677, 11038, 11046, 79351, 79327, 11388, 79352, 79354, 79330, 11390, 
79355, 79353, 79328, 11372, 11389
28628, 78685, 78677, 11038, 11046, 78686, 78678, 11039, 11047, 79354, 79330, 11390, 79355, 79357, 79333, 11392, 
79358, 79356, 79331, 11374, 11391
28629, 78686, 78678, 11039, 11047, 78687, 78679, 11040, 11048, 79357, 79333, 11392, 79358, 79360, 79336, 11394, 
79361, 79359, 79334, 11376, 11393
28630, 78687, 78679, 11040, 11048, 10643, 10642, 1268, 1269, 79360, 79336, 11394, 79361, 10706, 10703, 1291, 
10705, 79362, 79337, 11378, 11395
28631, 10488, 10487, 1214, 1215, 78688, 78680, 11041, 11049, 10551, 10550, 1237, 10552, 79364, 79340, 11397, 
79365, 79363, 79338, 11379, 11396
28632, 78688, 78680, 11041, 11049, 78689, 78681, 11042, 11050, 79364, 79340, 11397, 79365, 79367, 79343, 11399, 
79368, 79366, 79341, 11381, 11398
28633, 78689, 78681, 11042, 11050, 78690, 78682, 11043, 11051, 79367, 79343, 11399, 79368, 79370, 79346, 11401, 
79371, 79369, 79344, 11383, 11400
28634, 78690, 78682, 11043, 11051, 78691, 78683, 11044, 11052, 79370, 79346, 11401, 79371, 79373, 79349, 11403, 
79374, 79372, 79347, 11385, 11402
28635, 78691, 78683, 11044, 11052, 78692, 78684, 11045, 11053, 79373, 79349, 11403, 79374, 79376, 79352, 11405, 
79377, 79375, 79350, 11387, 11404
28636, 78692, 78684, 11045, 11053, 78693, 78685, 11046, 11054, 79376, 79352, 11405, 79377, 79379, 79355, 11407, 
79380, 79378, 79353, 11389, 11406
28637, 78693, 78685, 11046, 11054, 78694, 78686, 11047, 11055, 79379, 79355, 11407, 79380, 79382, 79358, 11409, 
79383, 79381, 79356, 11391, 11408
28638, 78694, 78686, 11047, 11055, 78695, 78687, 11048, 11056, 79382, 79358, 11409, 79383, 79385, 79361, 11411, 
79386, 79384, 79359, 11393, 11410
28639, 78695, 78687, 11048, 11056, 10644, 10643, 1269, 1270, 79385, 79361, 11411, 79386, 10708, 10705, 1292, 
10707, 79387, 79362, 11395, 11412
28640, 10489, 10488, 1215, 1216, 78696, 78688, 11049, 11057, 10553, 10552, 1238, 10554, 79389, 79365, 11414, 
79390, 79388, 79363, 11396, 11413
28641, 78696, 78688, 11049, 11057, 78697, 78689, 11050, 11058, 79389, 79365, 11414, 79390, 79392, 79368, 11416, 
79393, 79391, 79366, 11398, 11415
28642, 78697, 78689, 11050, 11058, 78698, 78690, 11051, 11059, 79392, 79368, 11416, 79393, 79395, 79371, 11418, 
79396, 79394, 79369, 11400, 11417
28643, 78698, 78690, 11051, 11059, 78699, 78691, 11052, 11060, 79395, 79371, 11418, 79396, 79398, 79374, 11420, 
79399, 79397, 79372, 11402, 11419
28644, 78699, 78691, 11052, 11060, 78700, 78692, 11053, 11061, 79398, 79374, 11420, 79399, 79401, 79377, 11422, 
79402, 79400, 79375, 11404, 11421
28645, 78700, 78692, 11053, 11061, 78701, 78693, 11054, 11062, 79401, 79377, 11422, 79402, 79404, 79380, 11424, 
79405, 79403, 79378, 11406, 11423
28646, 78701, 78693, 11054, 11062, 78702, 78694, 11055, 11063, 79404, 79380, 11424, 79405, 79407, 79383, 11426, 
79408, 79406, 79381, 11408, 11425
28647, 78702, 78694, 11055, 11063, 78703, 78695, 11056, 11064, 79407, 79383, 11426, 79408, 79410, 79386, 11428, 
79411, 79409, 79384, 11410, 11427
28648, 78703, 78695, 11056, 11064, 10645, 10644, 1270, 1271, 79410, 79386, 11428, 79411, 10710, 10707, 1293, 
10709, 79412, 79387, 11412, 11429
28649, 10490, 10489, 1216, 1217, 78704, 78696, 11057, 11065, 10555, 10554, 1239, 10556, 79414, 79390, 11431, 
79415, 79413, 79388, 11413, 11430
28650, 78704, 78696, 11057, 11065, 78705, 78697, 11058, 11066, 79414, 79390, 11431, 79415, 79417, 79393, 11433, 
79418, 79416, 79391, 11415, 11432
28651, 78705, 78697, 11058, 11066, 78706, 78698, 11059, 11067, 79417, 79393, 11433, 79418, 79420, 79396, 11435, 
79421, 79419, 79394, 11417, 11434
28652, 78706, 78698, 11059, 11067, 78707, 78699, 11060, 11068, 79420, 79396, 11435, 79421, 79423, 79399, 11437, 
79424, 79422, 79397, 11419, 11436
28653, 78707, 78699, 11060, 11068, 78708, 78700, 11061, 11069, 79423, 79399, 11437, 79424, 79426, 79402, 11439, 
79427, 79425, 79400, 11421, 11438
28654, 78708, 78700, 11061, 11069, 78709, 78701, 11062, 11070, 79426, 79402, 11439, 79427, 79429, 79405, 11441, 
79430, 79428, 79403, 11423, 11440
28655, 78709, 78701, 11062, 11070, 78710, 78702, 11063, 11071, 79429, 79405, 11441, 79430, 79432, 79408, 11443, 
79433, 79431, 79406, 11425, 11442
28656, 78710, 78702, 11063, 11071, 78711, 78703, 11064, 11072, 79432, 79408, 11443, 79433, 79435, 79411, 11445, 
79436, 79434, 79409, 11427, 11444
28657, 78711, 78703, 11064, 11072, 10646, 10645, 1271, 1272, 79435, 79411, 11445, 79436, 10712, 10709, 1294, 
10711, 79437, 79412, 11429, 11446
28658, 1191, 10490, 1217, 36, 10839, 78704, 11065, 1320, 10557, 10556, 1240, 1193, 79438, 79415, 11447, 
10856, 10855, 79413, 11430, 1329
28659, 10839, 78704, 11065, 1320, 10840, 78705, 11066, 1319, 79438, 79415, 11447, 10856, 79439, 79418, 11448, 
10858, 10857, 79416, 11432, 1328
28660, 10840, 78705, 11066, 1319, 10841, 78706, 11067, 1318, 79439, 79418, 11448, 10858, 79440, 79421, 11449, 
10860, 10859, 79419, 11434, 1327
28661, 10841, 78706, 11067, 1318, 10842, 78707, 11068, 1317, 79440, 79421, 11449, 10860, 79441, 79424, 11450, 
10862, 10861, 79422, 11436, 1326
28662, 10842, 78707, 11068, 1317, 10843, 78708, 11069, 1316, 79441, 79424, 11450, 10862, 79442, 79427, 11451, 
10864, 10863, 79425, 11438, 1325
28663, 10843, 78708, 11069, 1316, 10844, 78709, 11070, 1315, 79442, 79427, 11451, 10864, 79443, 79430, 11452, 
10866, 10865, 79428, 11440, 1324
28664, 10844, 78709, 11070, 1315, 10845, 78710, 11071, 1314, 79443, 79430, 11452, 10866, 79444, 79433, 11453, 
10868, 10867, 79431, 11442, 1323
28665, 10845, 78710, 11071, 1314, 10846, 78711, 11072, 1313, 79444, 79433, 11453, 10868, 79445, 79436, 11454, 
10870, 10869, 79434, 11444, 1322
28666, 10846, 78711, 11072, 1313, 1246, 10646, 1272, 38, 79445, 79436, 11454, 10870, 10713, 10711, 1295, 
1248, 10871, 79437, 11446, 1321
28667, 10491, 1187, 1186, 10469, 78712, 10789, 10781, 78536, 10558, 1189, 10513, 10559, 79447, 10814, 78889, 
79448, 79446, 10815, 10798, 78888
28668, 78712, 10789, 10781, 78536, 78713, 10790, 10782, 78537, 79447, 10814, 78889, 79448, 79450, 10816, 78892, 
79451, 79449, 10817, 10800, 78891
28669, 78713, 10790, 10782, 78537, 78714, 10791, 10783, 78538, 79450, 10816, 78892, 79451, 79453, 10818, 78895, 
79454, 79452, 10819, 10802, 78894
28670, 78714, 10791, 10783, 78538, 78715, 10792, 10784, 78539, 79453, 10818, 78895, 79454, 79456, 10820, 78898, 
79457, 79455, 10821, 10804, 78897
28671, 78715, 10792, 10784, 78539, 78716, 10793, 10785, 78540, 79456, 10820, 78898, 79457, 79459, 10822, 78901, 
79460, 79458, 10823, 10806, 78900
28672, 78716, 10793, 10785, 78540, 78717, 10794, 10786, 78541, 79459, 10822, 78901, 79460, 79462, 10824, 78904, 
79463, 79461, 10825, 10808, 78903
28673, 78717, 10794, 10786, 78541, 78718, 10795, 10787, 78542, 79462, 10824, 78904, 79463, 79465, 10826, 78907, 
79466, 79464, 10827, 10810, 78906
28674, 78718, 10795, 10787, 78542, 78719, 10796, 10788, 78543, 79465, 10826, 78907, 79466, 79468, 10828, 78910, 
79469, 79467, 10829, 10812, 78909
28675, 78719, 10796, 10788, 78543, 10647, 1242, 1241, 10625, 79468, 10828, 78910, 79469, 10715, 1244, 10670, 
10714, 79470, 10830, 10813, 78912
28676, 10492, 10491, 10469, 10470, 78720, 78712, 78536, 78544, 10560, 10559, 10515, 10561, 79472, 79448, 78914, 
79473, 79471, 79446, 78888, 78913
28677, 78720, 78712, 78536, 78544, 78721, 78713, 78537, 78545, 79472, 79448, 78914, 79473, 79475, 79451, 78917, 
79476, 79474, 79449, 78891, 78916
28678, 78721, 78713, 78537, 78545, 78722, 78714, 78538, 78546, 79475, 79451, 78917, 79476, 79478, 79454, 78920, 
79479, 79477, 79452, 78894, 78919
28679, 78722, 78714, 78538, 78546, 78723, 78715, 78539, 78547, 79478, 79454, 78920, 79479, 79481, 79457, 78923, 
79482, 79480, 79455, 78897, 78922
28680, 78723, 78715, 78539, 78547, 78724, 78716, 78540, 78548, 79481, 79457, 78923, 79482, 79484, 79460, 78926, 
79485, 79483, 79458, 78900, 78925
28681, 78724, 78716, 78540, 78548, 78725, 78717, 78541, 78549, 79484, 79460, 78926, 79485, 79487, 79463, 78929, 
79488, 79486, 79461, 78903, 78928
28682, 78725, 78717, 78541, 78549, 78726, 78718, 78542, 78550, 79487, 79463, 78929, 79488, 79490, 79466, 78932, 
79491, 79489, 79464, 78906, 78931
28683, 78726, 78718, 78542, 78550, 78727, 78719, 78543, 78551, 79490, 79466, 78932, 79491, 79493, 79469, 78935, 
79494, 79492, 79467, 78909, 78934
28684, 78727, 78719, 78543, 78551, 10648, 10647, 10625, 10626, 79493, 79469, 78935, 79494, 10717, 10714, 10672, 
10716, 79495, 79470, 78912, 78937
28685, 10493, 10492, 10470, 10471, 78728, 78720, 78544, 78552, 10562, 10561, 10517, 10563, 79497, 79473, 78939, 
79498, 79496, 79471, 78913, 78938
28686, 78728, 78720, 78544, 78552, 78729, 78721, 78545, 78553, 79497, 79473, 78939, 79498, 79500, 79476, 78942, 
79501, 79499, 79474, 78916, 78941
28687, 78729, 78721, 78545, 78553, 78730, 78722, 78546, 78554, 79500, 79476, 78942, 79501, 79503, 79479, 78945, 
79504, 79502, 79477, 78919, 78944
28688, 78730, 78722, 78546, 78554, 78731, 78723, 78547, 78555, 79503, 79479, 78945, 79504, 79506, 79482, 78948, 
79507, 79505, 79480, 78922, 78947
28689, 78731, 78723, 78547, 78555, 78732, 78724, 78548, 78556, 79506, 79482, 78948, 79507, 79509, 79485, 78951, 
79510, 79508, 79483, 78925, 78950
28690, 78732, 78724, 78548, 78556, 78733, 78725, 78549, 78557, 79509, 79485, 78951, 79510, 79512, 79488, 78954, 
79513, 79511, 79486, 78928, 78953
28691, 78733, 78725, 78549, 78557, 78734, 78726, 78550, 78558, 79512, 79488, 78954, 79513, 79515, 79491, 78957, 
79516, 79514, 79489, 78931, 78956
28692, 78734, 78726, 78550, 78558, 78735, 78727, 78551, 78559, 79515, 79491, 78957, 79516, 79518, 79494, 78960, 
79519, 79517, 79492, 78934, 78959
28693, 78735, 78727, 78551, 78559, 10649, 10648, 10626, 10627, 79518, 79494, 78960, 79519, 10719, 10716, 10674, 
10718, 79520, 79495, 78937, 78962
28694, 10494, 10493, 10471, 10472, 78736, 78728, 78552, 78560, 10564, 10563, 10519, 10565, 79522, 79498, 78964, 
79523, 79521, 79496, 78938, 78963
28695, 78736, 78728, 78552, 78560, 78737, 78729, 78553, 78561, 79522, 79498, 78964, 79523, 79525, 79501, 78967, 
79526, 79524, 79499, 78941, 78966
28696, 78737, 78729, 78553, 78561, 78738, 78730, 78554, 78562, 79525, 79501, 78967, 79526, 79528, 79504, 78970, 
79529, 79527, 79502, 78944, 78969
28697, 78738, 78730, 78554, 78562, 78739, 78731, 78555, 78563, 79528, 79504, 78970, 79529, 79531, 79507, 78973, 
79532, 79530, 79505, 78947, 78972
28698, 78739, 78731, 78555, 78563, 78740, 78732, 78556, 78564, 79531, 79507, 78973, 79532, 79534, 79510, 78976, 
79535, 79533, 79508, 78950, 78975
28699, 78740, 78732, 78556, 78564, 78741, 78733, 78557, 78565, 79534, 79510, 78976, 79535, 79537, 79513, 78979, 
79538, 79536, 79511, 78953, 78978
28700, 78741, 78733, 78557, 78565, 78742, 78734, 78558, 78566, 79537, 79513, 78979, 79538, 79540, 79516, 78982, 
79541, 79539, 79514, 78956, 78981
28701, 78742, 78734, 78558, 78566, 78743, 78735, 78559, 78567, 79540, 79516, 78982, 79541, 79543, 79519, 78985, 
79544, 79542, 79517, 78959, 78984
28702, 78743, 78735, 78559, 78567, 10650, 10649, 10627, 10628, 79543, 79519, 78985, 79544, 10721, 10718, 10676, 
10720, 79545, 79520, 78962, 78987
28703, 10495, 10494, 10472, 10473, 78744, 78736, 78560, 78568, 10566, 10565, 10521, 10567, 79547, 79523, 78989, 
79548, 79546, 79521, 78963, 78988
28704, 78744, 78736, 78560, 78568, 78745, 78737, 78561, 78569, 79547, 79523, 78989, 79548, 79550, 79526, 78992, 
79551, 79549, 79524, 78966, 78991
28705, 78745, 78737, 78561, 78569, 78746, 78738, 78562, 78570, 79550, 79526, 78992, 79551, 79553, 79529, 78995, 
79554, 79552, 79527, 78969, 78994
28706, 78746, 78738, 78562, 78570, 78747, 78739, 78563, 78571, 79553, 79529, 78995, 79554, 79556, 79532, 78998, 
79557, 79555, 79530, 78972, 78997
28707, 78747, 78739, 78563, 78571, 78748, 78740, 78564, 78572, 79556, 79532, 78998, 79557, 79559, 79535, 79001, 
79560, 79558, 79533, 78975, 79000
28708, 78748, 78740, 78564, 78572, 78749, 78741, 78565, 78573, 79559, 79535, 79001, 79560, 79562, 79538, 79004, 
79563, 79561, 79536, 78978, 79003
28709, 78749, 78741, 78565, 78573, 78750, 78742, 78566, 78574, 79562, 79538, 79004, 79563, 79565, 79541, 79007, 
79566, 79564, 79539, 78981, 79006
28710, 78750, 78742, 78566, 78574, 78751, 78743, 78567, 78575, 79565, 79541, 79007, 79566, 79568, 79544, 79010, 
79569, 79567, 79542, 78984, 79009
28711, 78751, 78743, 78567, 78575, 10651, 10650, 10628, 10629, 79568, 79544, 79010, 79569, 10723, 10720, 10678, 
10722, 79570, 79545, 78987, 79012
28712, 10496, 10495, 10473, 10474, 78752, 78744, 78568, 78576, 10568, 10567, 10523, 10569, 79572, 79548, 79014, 
79573, 79571, 79546, 78988, 79013
28713, 78752, 78744, 78568, 78576, 78753, 78745, 78569, 78577, 79572, 79548, 79014, 79573, 79575, 79551, 79017, 
79576, 79574, 79549, 78991, 79016
28714, 78753, 78745, 78569, 78577, 78754, 78746, 78570, 78578, 79575, 79551, 79017, 79576, 79578, 79554, 79020, 
79579, 79577, 79552, 78994, 79019
28715, 78754, 78746, 78570, 78578, 78755, 78747, 78571, 78579, 79578, 79554, 79020, 79579, 79581, 79557, 79023, 
79582, 79580, 79555, 78997, 79022
28716, 78755, 78747, 78571, 78579, 78756, 78748, 78572, 78580, 79581, 79557, 79023, 79582, 79584, 79560, 79026, 
79585, 79583, 79558, 79000, 79025
28717, 78756, 78748, 78572, 78580, 78757, 78749, 78573, 78581, 79584, 79560, 79026, 79585, 79587, 79563, 79029, 
79588, 79586, 79561, 79003, 79028
28718, 78757, 78749, 78573, 78581, 78758, 78750, 78574, 78582, 79587, 79563, 79029, 79588, 79590, 79566, 79032, 
79591, 79589, 79564, 79006, 79031
28719, 78758, 78750, 78574, 78582, 78759, 78751, 78575, 78583, 79590, 79566, 79032, 79591, 79593, 79569, 79035, 
79594, 79592, 79567, 79009, 79034
28720, 78759, 78751, 78575, 78583, 10652, 10651, 10629, 10630, 79593, 79569, 79035, 79594, 10725, 10722, 10680, 
10724, 79595, 79570, 79012, 79037
28721, 10497, 10496, 10474, 10475, 78760, 78752, 78576, 78584, 10570, 10569, 10525, 10571, 79597, 79573, 79039, 
79598, 79596, 79571, 79013, 79038
28722, 78760, 78752, 78576, 78584, 78761, 78753, 78577, 78585, 79597, 79573, 79039, 79598, 79600, 79576, 79042, 
79601, 79599, 79574, 79016, 79041
28723, 78761, 78753, 78577, 78585, 78762, 78754, 78578, 78586, 79600, 79576, 79042, 79601, 79603, 79579, 79045, 
79604, 79602, 79577, 79019, 79044
28724, 78762, 78754, 78578, 78586, 78763, 78755, 78579, 78587, 79603, 79579, 79045, 79604, 79606, 79582, 79048, 
79607, 79605, 79580, 79022, 79047
28725, 78763, 78755, 78579, 78587, 78764, 78756, 78580, 78588, 79606, 79582, 79048, 79607, 79609, 79585, 79051, 
79610, 79608, 79583, 79025, 79050
28726, 78764, 78756, 78580, 78588, 78765, 78757, 78581, 78589, 79609, 79585, 79051, 79610, 79612, 79588, 79054, 
79613, 79611, 79586, 79028, 79053
28727, 78765, 78757, 78581, 78589, 78766, 78758, 78582, 78590, 79612, 79588, 79054, 79613, 79615, 79591, 79057, 
79616, 79614, 79589, 79031, 79056
28728, 78766, 78758, 78582, 78590, 78767, 78759, 78583, 78591, 79615, 79591, 79057, 79616, 79618, 79594, 79060, 
79619, 79617, 79592, 79034, 79059
28729, 78767, 78759, 78583, 78591, 10653, 10652, 10630, 10631, 79618, 79594, 79060, 79619, 10727, 10724, 10682, 
10726, 79620, 79595, 79037, 79062
28730, 10498, 10497, 10475, 10476, 78768, 78760, 78584, 78592, 10572, 10571, 10527, 10573, 79622, 79598, 79064, 
79623, 79621, 79596, 79038, 79063
28731, 78768, 78760, 78584, 78592, 78769, 78761, 78585, 78593, 79622, 79598, 79064, 79623, 79625, 79601, 79067, 
79626, 79624, 79599, 79041, 79066
28732, 78769, 78761, 78585, 78593, 78770, 78762, 78586, 78594, 79625, 79601, 79067, 79626, 79628, 79604, 79070, 
79629, 79627, 79602, 79044, 79069
28733, 78770, 78762, 78586, 78594, 78771, 78763, 78587, 78595, 79628, 79604, 79070, 79629, 79631, 79607, 79073, 
79632, 79630, 79605, 79047, 79072
28734, 78771, 78763, 78587, 78595, 78772, 78764, 78588, 78596, 79631, 79607, 79073, 79632, 79634, 79610, 79076, 
79635, 79633, 79608, 79050, 79075
28735, 78772, 78764, 78588, 78596, 78773, 78765, 78589, 78597, 79634, 79610, 79076, 79635, 79637, 79613, 79079, 
79638, 79636, 79611, 79053, 79078
28736, 78773, 78765, 78589, 78597, 78774, 78766, 78590, 78598, 79637, 79613, 79079, 79638, 79640, 79616, 79082, 
79641, 79639, 79614, 79056, 79081
28737, 78774, 78766, 78590, 78598, 78775, 78767, 78591, 78599, 79640, 79616, 79082, 79641, 79643, 79619, 79085, 
79644, 79642, 79617, 79059, 79084
28738, 78775, 78767, 78591, 78599, 10654, 10653, 10631, 10632, 79643, 79619, 79085, 79644, 10729, 10726, 10684, 
10728, 79645, 79620, 79062, 79087
28739, 10499, 10498, 10476, 10477, 78776, 78768, 78592, 78600, 10574, 10573, 10529, 10575, 79647, 79623, 79089, 
79648, 79646, 79621, 79063, 79088
28740, 78776, 78768, 78592, 78600, 78777, 78769, 78593, 78601, 79647, 79623, 79089, 79648, 79650, 79626, 79092, 
79651, 79649, 79624, 79066, 79091
28741, 78777, 78769, 78593, 78601, 78778, 78770, 78594, 78602, 79650, 79626, 79092, 79651, 79653, 79629, 79095, 
79654, 79652, 79627, 79069, 79094
28742, 78778, 78770, 78594, 78602, 78779, 78771, 78595, 78603, 79653, 79629, 79095, 79654, 79656, 79632, 79098, 
79657, 79655, 79630, 79072, 79097
28743, 78779, 78771, 78595, 78603, 78780, 78772, 78596, 78604, 79656, 79632, 79098, 79657, 79659, 79635, 79101, 
79660, 79658, 79633, 79075, 79100
28744, 78780, 78772, 78596, 78604, 78781, 78773, 78597, 78605, 79659, 79635, 79101, 79660, 79662, 79638, 79104, 
79663, 79661, 79636, 79078, 79103
28745, 78781, 78773, 78597, 78605, 78782, 78774, 78598, 78606, 79662, 79638, 79104, 79663, 79665, 79641, 79107, 
79666, 79664, 79639, 79081, 79106
28746, 78782, 78774, 78598, 78606, 78783, 78775, 78599, 78607, 79665, 79641, 79107, 79666, 79668, 79644, 79110, 
79669, 79667, 79642, 79084, 79109
28747, 78783, 78775, 78599, 78607, 10655, 10654, 10632, 10633, 79668, 79644, 79110, 79669, 10731, 10728, 10686, 
10730, 79670, 79645, 79087, 79112
28748, 10500, 10499, 10477, 10478, 78784, 78776, 78600, 78608, 10576, 10575, 10531, 10577, 79672, 79648, 79114, 
79673, 79671, 79646, 79088, 79113
28749, 78784, 78776, 78600, 78608, 78785, 78777, 78601, 78609, 79672, 79648, 79114, 79673, 79675, 79651, 79117, 
79676, 79674, 79649, 79091, 79116
28750, 78785, 78777, 78601, 78609, 78786, 78778, 78602, 78610, 79675, 79651, 79117, 79676, 79678, 79654, 79120, 
79679, 79677, 79652, 79094, 79119
28751, 78786, 78778, 78602, 78610, 78787, 78779, 78603, 78611, 79678, 79654, 79120, 79679, 79681, 79657, 79123, 
79682, 79680, 79655, 79097, 79122
28752, 78787, 78779, 78603, 78611, 78788, 78780, 78604, 78612, 79681, 79657, 79123, 79682, 79684, 79660, 79126, 
79685, 79683, 79658, 79100, 79125
28753, 78788, 78780, 78604, 78612, 78789, 78781, 78605, 78613, 79684, 79660, 79126, 79685, 79687, 79663, 79129, 
79688, 79686, 79661, 79103, 79128
28754, 78789, 78781, 78605, 78613, 78790, 78782, 78606, 78614, 79687, 79663, 79129, 79688, 79690, 79666, 79132, 
79691, 79689, 79664, 79106, 79131
28755, 78790, 78782, 78606, 78614, 78791, 78783, 78607, 78615, 79690, 79666, 79132, 79691, 79693, 79669, 79135, 
79694, 79692, 79667, 79109, 79134
28756, 78791, 78783, 78607, 78615, 10656, 10655, 10633, 10634, 79693, 79669, 79135, 79694, 10733, 10730, 10688, 
10732, 79695, 79670, 79112, 79137
28757, 10501, 10500, 10478, 10479, 78792, 78784, 78608, 78616, 10578, 10577, 10533, 10579, 79697, 79673, 79139, 
79698, 79696, 79671, 79113, 79138
28758, 78792, 78784, 78608, 78616, 78793, 78785, 78609, 78617, 79697, 79673, 79139, 79698, 79700, 79676, 79142, 
79701, 79699, 79674, 79116, 79141
28759, 78793, 78785, 78609, 78617, 78794, 78786, 78610, 78618, 79700, 79676, 79142, 79701, 79703, 79679, 79145, 
79704, 79702, 79677, 79119, 79144
28760, 78794, 78786, 78610, 78618, 78795, 78787, 78611, 78619, 79703, 79679, 79145, 79704, 79706, 79682, 79148, 
79707, 79705, 79680, 79122, 79147
28761, 78795, 78787, 78611, 78619, 78796, 78788, 78612, 78620, 79706, 79682, 79148, 79707, 79709, 79685, 79151, 
79710, 79708, 79683, 79125, 79150
28762, 78796, 78788, 78612, 78620, 78797, 78789, 78613, 78621, 79709, 79685, 79151, 79710, 79712, 79688, 79154, 
79713, 79711, 79686, 79128, 79153
28763, 78797, 78789, 78613, 78621, 78798, 78790, 78614, 78622, 79712, 79688, 79154, 79713, 79715, 79691, 79157, 
79716, 79714, 79689, 79131, 79156
28764, 78798, 78790, 78614, 78622, 78799, 78791, 78615, 78623, 79715, 79691, 79157, 79716, 79718, 79694, 79160, 
79719, 79717, 79692, 79134, 79159
28765, 78799, 78791, 78615, 78623, 10657, 10656, 10634, 10635, 79718, 79694, 79160, 79719, 10735, 10732, 10690, 
10734, 79720, 79695, 79137, 79162
28766, 10502, 10501, 10479, 10480, 78800, 78792, 78616, 78624, 10580, 10579, 10535, 10581, 79722, 79698, 79164, 
79723, 79721, 79696, 79138, 79163
28767, 78800, 78792, 78616, 78624, 78801, 78793, 78617, 78625, 79722, 79698, 79164, 79723, 79725, 79701, 79167, 
79726, 79724, 79699, 79141, 79166
28768, 78801, 78793, 78617, 78625, 78802, 78794, 78618, 78626, 79725, 79701, 79167, 79726, 79728, 79704, 79170, 
79729, 79727, 79702, 79144, 79169
28769, 78802, 78794, 78618, 78626, 78803, 78795, 78619, 78627, 79728, 79704, 79170, 79729, 79731, 79707, 79173, 
79732, 79730, 79705, 79147, 79172
28770, 78803, 78795, 78619, 78627, 78804, 78796, 78620, 78628, 79731, 79707, 79173, 79732, 79734, 79710, 79176, 
79735, 79733, 79708, 79150, 79175
28771, 78804, 78796, 78620, 78628, 78805, 78797, 78621, 78629, 79734, 79710, 79176, 79735, 79737, 79713, 79179, 
79738, 79736, 79711, 79153, 79178
28772, 78805, 78797, 78621, 78629, 78806, 78798, 78622, 78630, 79737, 79713, 79179, 79738, 79740, 79716, 79182, 
79741, 79739, 79714, 79156, 79181
28773, 78806, 78798, 78622, 78630, 78807, 78799, 78623, 78631, 79740, 79716, 79182, 79741, 79743, 79719, 79185, 
79744, 79742, 79717, 79159, 79184
28774, 78807, 78799, 78623, 78631, 10658, 10657, 10635, 10636, 79743, 79719, 79185, 79744, 10737, 10734, 10692, 
10736, 79745, 79720, 79162, 79187
28775, 10503, 10502, 10480, 10481, 78808, 78800, 78624, 78632, 10582, 10581, 10537, 10583, 79747, 79723, 79189, 
79748, 79746, 79721, 79163, 79188
28776, 78808, 78800, 78624, 78632, 78809, 78801, 78625, 78633, 79747, 79723, 79189, 79748, 79750, 79726, 79192, 
79751, 79749, 79724, 79166, 79191
28777, 78809, 78801, 78625, 78633, 78810, 78802, 78626, 78634, 79750, 79726, 79192, 79751, 79753, 79729, 79195, 
79754, 79752, 79727, 79169, 79194
28778, 78810, 78802, 78626, 78634, 78811, 78803, 78627, 78635, 79753, 79729, 79195, 79754, 79756, 79732, 79198, 
79757, 79755, 79730, 79172, 79197
28779, 78811, 78803, 78627, 78635, 78812, 78804, 78628, 78636, 79756, 79732, 79198, 79757, 79759, 79735, 79201, 
79760, 79758, 79733, 79175, 79200
28780, 78812, 78804, 78628, 78636, 78813, 78805, 78629, 78637, 79759, 79735, 79201, 79760, 79762, 79738, 79204, 
79763, 79761, 79736, 79178, 79203
28781, 78813, 78805, 78629, 78637, 78814, 78806, 78630, 78638, 79762, 79738, 79204, 79763, 79765, 79741, 79207, 
79766, 79764, 79739, 79181, 79206
28782, 78814, 78806, 78630, 78638, 78815, 78807, 78631, 78639, 79765, 79741, 79207, 79766, 79768, 79744, 79210, 
79769, 79767, 79742, 79184, 79209
28783, 78815, 78807, 78631, 78639, 10659, 10658, 10636, 10637, 79768, 79744, 79210, 79769, 10739, 10736, 10694, 
10738, 79770, 79745, 79187, 79212
28784, 10504, 10503, 10481, 10482, 78816, 78808, 78632, 78640, 10584, 10583, 10539, 10585, 79772, 79748, 79214, 
79773, 79771, 79746, 79188, 79213
28785, 78816, 78808, 78632, 78640, 78817, 78809, 78633, 78641, 79772, 79748, 79214, 79773, 79775, 79751, 79217, 
79776, 79774, 79749, 79191, 79216
28786, 78817, 78809, 78633, 78641, 78818, 78810, 78634, 78642, 79775, 79751, 79217, 79776, 79778, 79754, 79220, 
79779, 79777, 79752, 79194, 79219
28787, 78818, 78810, 78634, 78642, 78819, 78811, 78635, 78643, 79778, 79754, 79220, 79779, 79781, 79757, 79223, 
79782, 79780, 79755, 79197, 79222
28788, 78819, 78811, 78635, 78643, 78820, 78812, 78636, 78644, 79781, 79757, 79223, 79782, 79784, 79760, 79226, 
79785, 79783, 79758, 79200, 79225
28789, 78820, 78812, 78636, 78644, 78821, 78813, 78637, 78645, 79784, 79760, 79226, 79785, 79787, 79763, 79229, 
79788, 79786, 79761, 79203, 79228
28790, 78821, 78813, 78637, 78645, 78822, 78814, 78638, 78646, 79787, 79763, 79229, 79788, 79790, 79766, 79232, 
79791, 79789, 79764, 79206, 79231
28791, 78822, 78814, 78638, 78646, 78823, 78815, 78639, 78647, 79790, 79766, 79232, 79791, 79793, 79769, 79235, 
79794, 79792, 79767, 79209, 79234
28792, 78823, 78815, 78639, 78647, 10660, 10659, 10637, 10638, 79793, 79769, 79235, 79794, 10741, 10738, 10696, 
10740, 79795, 79770, 79212, 79237
28793, 10505, 10504, 10482, 10483, 78824, 78816, 78640, 78648, 10586, 10585, 10541, 10587, 79797, 79773, 79239, 
79798, 79796, 79771, 79213, 79238
28794, 78824, 78816, 78640, 78648, 78825, 78817, 78641, 78649, 79797, 79773, 79239, 79798, 79800, 79776, 79242, 
79801, 79799, 79774, 79216, 79241
28795, 78825, 78817, 78641, 78649, 78826, 78818, 78642, 78650, 79800, 79776, 79242, 79801, 79803, 79779, 79245, 
79804, 79802, 79777, 79219, 79244
28796, 78826, 78818, 78642, 78650, 78827, 78819, 78643, 78651, 79803, 79779, 79245, 79804, 79806, 79782, 79248, 
79807, 79805, 79780, 79222, 79247
28797, 78827, 78819, 78643, 78651, 78828, 78820, 78644, 78652, 79806, 79782, 79248, 79807, 79809, 79785, 79251, 
79810, 79808, 79783, 79225, 79250
28798, 78828, 78820, 78644, 78652, 78829, 78821, 78645, 78653, 79809, 79785, 79251, 79810, 79812, 79788, 79254, 
79813, 79811, 79786, 79228, 79253
28799, 78829, 78821, 78645, 78653, 78830, 78822, 78646, 78654, 79812, 79788, 79254, 79813, 79815, 79791, 79257, 
79816, 79814, 79789, 79231, 79256
28800, 78830, 78822, 78646, 78654, 78831, 78823, 78647, 78655, 79815, 79791, 79257, 79816, 79818, 79794, 79260, 
79819, 79817, 79792, 79234, 79259
28801, 78831, 78823, 78647, 78655, 10661, 10660, 10638, 10639, 79818, 79794, 79260, 79819, 10743, 10740, 10698, 
10742, 79820, 79795, 79237, 79262
28802, 10506, 10505, 10483, 10484, 78832, 78824, 78648, 78656, 10588, 10587, 10543, 10589, 79822, 79798, 79264, 
79823, 79821, 79796, 79238, 79263
28803, 78832, 78824, 78648, 78656, 78833, 78825, 78649, 78657, 79822, 79798, 79264, 79823, 79825, 79801, 79267, 
79826, 79824, 79799, 79241, 79266
28804, 78833, 78825, 78649, 78657, 78834, 78826, 78650, 78658, 79825, 79801, 79267, 79826, 79828, 79804, 79270, 
79829, 79827, 79802, 79244, 79269
28805, 78834, 78826, 78650, 78658, 78835, 78827, 78651, 78659, 79828, 79804, 79270, 79829, 79831, 79807, 79273, 
79832, 79830, 79805, 79247, 79272
28806, 78835, 78827, 78651, 78659, 78836, 78828, 78652, 78660, 79831, 79807, 79273, 79832, 79834, 79810, 79276, 
79835, 79833, 79808, 79250, 79275
28807, 78836, 78828, 78652, 78660, 78837, 78829, 78653, 78661, 79834, 79810, 79276, 79835, 79837, 79813, 79279, 
79838, 79836, 79811, 79253, 79278
28808, 78837, 78829, 78653, 78661, 78838, 78830, 78654, 78662, 79837, 79813, 79279, 79838, 79840, 79816, 79282, 
79841, 79839, 79814, 79256, 79281
28809, 78838, 78830, 78654, 78662, 78839, 78831, 78655, 78663, 79840, 79816, 79282, 79841, 79843, 79819, 79285, 
79844, 79842, 79817, 79259, 79284
28810, 78839, 78831, 78655, 78663, 10662, 10661, 10639, 10640, 79843, 79819, 79285, 79844, 10745, 10742, 10700, 
10744, 79845, 79820, 79262, 79287
28811, 10507, 10506, 10484, 10485, 78840, 78832, 78656, 78664, 10590, 10589, 10545, 10591, 79847, 79823, 79289, 
79848, 79846, 79821, 79263, 79288
28812, 78840, 78832, 78656, 78664, 78841, 78833, 78657, 78665, 79847, 79823, 79289, 79848, 79850, 79826, 79292, 
79851, 79849, 79824, 79266, 79291
28813, 78841, 78833, 78657, 78665, 78842, 78834, 78658, 78666, 79850, 79826, 79292, 79851, 79853, 79829, 79295, 
79854, 79852, 79827, 79269, 79294
28814, 78842, 78834, 78658, 78666, 78843, 78835, 78659, 78667, 79853, 79829, 79295, 79854, 79856, 79832, 79298, 
79857, 79855, 79830, 79272, 79297
28815, 78843, 78835, 78659, 78667, 78844, 78836, 78660, 78668, 79856, 79832, 79298, 79857, 79859, 79835, 79301, 
79860, 79858, 79833, 79275, 79300
28816, 78844, 78836, 78660, 78668, 78845, 78837, 78661, 78669, 79859, 79835, 79301, 79860, 79862, 79838, 79304, 
79863, 79861, 79836, 79278, 79303
28817, 78845, 78837, 78661, 78669, 78846, 78838, 78662, 78670, 79862, 79838, 79304, 79863, 79865, 79841, 79307, 
79866, 79864, 79839, 79281, 79306
28818, 78846, 78838, 78662, 78670, 78847, 78839, 78663, 78671, 79865, 79841, 79307, 79866, 79868, 79844, 79310, 
79869, 79867, 79842, 79284, 79309
28819, 78847, 78839, 78663, 78671, 10663, 10662, 10640, 10641, 79868, 79844, 79310, 79869, 10747, 10744, 10702, 
10746, 79870, 79845, 79287, 79312
28820, 10508, 10507, 10485, 10486, 78848, 78840, 78664, 78672, 10592, 10591, 10547, 10593, 79872, 79848, 79314, 
79873, 79871, 79846, 79288, 79313
28821, 78848, 78840, 78664, 78672, 78849, 78841, 78665, 78673, 79872, 79848, 79314, 79873, 79875, 79851, 79317, 
79876, 79874, 79849, 79291, 79316
28822, 78849, 78841, 78665, 78673, 78850, 78842, 78666, 78674, 79875, 79851, 79317, 79876, 79878, 79854, 79320, 
79879, 79877, 79852, 79294, 79319
28823, 78850, 78842, 78666, 78674, 78851, 78843, 78667, 78675, 79878, 79854, 79320, 79879, 79881, 79857, 79323, 
79882, 79880, 79855, 79297, 79322
28824, 78851, 78843, 78667, 78675, 78852, 78844, 78668, 78676, 79881, 79857, 79323, 79882, 79884, 79860, 79326, 
79885, 79883, 79858, 79300, 79325
28825, 78852, 78844, 78668, 78676, 78853, 78845, 78669, 78677, 79884, 79860, 79326, 79885, 79887, 79863, 79329, 
79888, 79886, 79861, 79303, 79328
28826, 78853, 78845, 78669, 78677, 78854, 78846, 78670, 78678, 79887, 79863, 79329, 79888, 79890, 79866, 79332, 
79891, 79889, 79864, 79306, 79331
28827, 78854, 78846, 78670, 78678, 78855, 78847, 78671, 78679, 79890, 79866, 79332, 79891, 79893, 79869, 79335, 
79894, 79892, 79867, 79309, 79334
28828, 78855, 78847, 78671, 78679, 10664, 10663, 10641, 10642, 79893, 79869, 79335, 79894, 10749, 10746, 10704, 
10748, 79895, 79870, 79312, 79337
28829, 10509, 10508, 10486, 10487, 78856, 78848, 78672, 78680, 10594, 10593, 10549, 10595, 79897, 79873, 79339, 
79898, 79896, 79871, 79313, 79338
28830, 78856, 78848, 78672, 78680, 78857, 78849, 78673, 78681, 79897, 79873, 79339, 79898, 79900, 79876, 79342, 
79901, 79899, 79874, 79316, 79341
28831, 78857, 78849, 78673, 78681, 78858, 78850, 78674, 78682, 79900, 79876, 79342, 79901, 79903, 79879, 79345, 
79904, 79902, 79877, 79319, 79344
28832, 78858, 78850, 78674, 78682, 78859, 78851, 78675, 78683, 79903, 79879, 79345, 79904, 79906, 79882, 79348, 
79907, 79905, 79880, 79322, 79347
28833, 78859, 78851, 78675, 78683, 78860, 78852, 78676, 78684, 79906, 79882, 79348, 79907, 79909, 79885, 79351, 
79910, 79908, 79883, 79325, 79350
28834, 78860, 78852, 78676, 78684, 78861, 78853, 78677, 78685, 79909, 79885, 79351, 79910, 79912, 79888, 79354, 
79913, 79911, 79886, 79328, 79353
28835, 78861, 78853, 78677, 78685, 78862, 78854, 78678, 78686, 79912, 79888, 79354, 79913, 79915, 79891, 79357, 
79916, 79914, 79889, 79331, 79356
28836, 78862, 78854, 78678, 78686, 78863, 78855, 78679, 78687, 79915, 79891, 79357, 79916, 79918, 79894, 79360, 
79919, 79917, 79892, 79334, 79359
28837, 78863, 78855, 78679, 78687, 10665, 10664, 10642, 10643, 79918, 79894, 79360, 79919, 10751, 10748, 10706, 
10750, 79920, 79895, 79337, 79362
28838, 10510, 10509, 10487, 10488, 78864, 78856, 78680, 78688, 10596, 10595, 10551, 10597, 79922, 79898, 79364, 
79923, 79921, 79896, 79338, 79363
28839, 78864, 78856, 78680, 78688, 78865, 78857, 78681, 78689, 79922, 79898, 79364, 79923, 79925, 79901, 79367, 
79926, 79924, 79899, 79341, 79366
28840, 78865, 78857, 78681, 78689, 78866, 78858, 78682, 78690, 79925, 79901, 79367, 79926, 79928, 79904, 79370, 
79929, 79927, 79902, 79344, 79369
28841, 78866, 78858, 78682, 78690, 78867, 78859, 78683, 78691, 79928, 79904, 79370, 79929, 79931, 79907, 79373, 
79932, 79930, 79905, 79347, 79372
28842, 78867, 78859, 78683, 78691, 78868, 78860, 78684, 78692, 79931, 79907, 79373, 79932, 79934, 79910, 79376, 
79935, 79933, 79908, 79350, 79375
28843, 78868, 78860, 78684, 78692, 78869, 78861, 78685, 78693, 79934, 79910, 79376, 79935, 79937, 79913, 79379, 
79938, 79936, 79911, 79353, 79378
28844, 78869, 78861, 78685, 78693, 78870, 78862, 78686, 78694, 79937, 79913, 79379, 79938, 79940, 79916, 79382, 
79941, 79939, 79914, 79356, 79381
28845, 78870, 78862, 78686, 78694, 78871, 78863, 78687, 78695, 79940, 79916, 79382, 79941, 79943, 79919, 79385, 
79944, 79942, 79917, 79359, 79384
28846, 78871, 78863, 78687, 78695, 10666, 10665, 10643, 10644, 79943, 79919, 79385, 79944, 10753, 10750, 10708, 
10752, 79945, 79920, 79362, 79387
28847, 10511, 10510, 10488, 10489, 78872, 78864, 78688, 78696, 10598, 10597, 10553, 10599, 79947, 79923, 79389, 
79948, 79946, 79921, 79363, 79388
28848, 78872, 78864, 78688, 78696, 78873, 78865, 78689, 78697, 79947, 79923, 79389, 79948, 79950, 79926, 79392, 
79951, 79949, 79924, 79366, 79391
28849, 78873, 78865, 78689, 78697, 78874, 78866, 78690, 78698, 79950, 79926, 79392, 79951, 79953, 79929, 79395, 
79954, 79952, 79927, 79369, 79394
28850, 78874, 78866, 78690, 78698, 78875, 78867, 78691, 78699, 79953, 79929, 79395, 79954, 79956, 79932, 79398, 
79957, 79955, 79930, 79372, 79397
28851, 78875, 78867, 78691, 78699, 78876, 78868, 78692, 78700, 79956, 79932, 79398, 79957, 79959, 79935, 79401, 
79960, 79958, 79933, 79375, 79400
28852, 78876, 78868, 78692, 78700, 78877, 78869, 78693, 78701, 79959, 79935, 79401, 79960, 79962, 79938, 79404, 
79963, 79961, 79936, 79378, 79403
28853, 78877, 78869, 78693, 78701, 78878, 78870, 78694, 78702, 79962, 79938, 79404, 79963, 79965, 79941, 79407, 
79966, 79964, 79939, 79381, 79406
28854, 78878, 78870, 78694, 78702, 78879, 78871, 78695, 78703, 79965, 79941, 79407, 79966, 79968, 79944, 79410, 
79969, 79967, 79942, 79384, 79409
28855, 78879, 78871, 78695, 78703, 10667, 10666, 10644, 10645, 79968, 79944, 79410, 79969, 10755, 10752, 10710, 
10754, 79970, 79945, 79387, 79412
28856, 10512, 10511, 10489, 10490, 78880, 78872, 78696, 78704, 10600, 10599, 10555, 10601, 79972, 79948, 79414, 
79973, 79971, 79946, 79388, 79413
28857, 78880, 78872, 78696, 78704, 78881, 78873, 78697, 78705, 79972, 79948, 79414, 79973, 79975, 79951, 79417, 
79976, 79974, 79949, 79391, 79416
28858, 78881, 78873, 78697, 78705, 78882, 78874, 78698, 78706, 79975, 79951, 79417, 79976, 79978, 79954, 79420, 
79979, 79977, 79952, 79394, 79419
28859, 78882, 78874, 78698, 78706, 78883, 78875, 78699, 78707, 79978, 79954, 79420, 79979, 79981, 79957, 79423, 
79982, 79980, 79955, 79397, 79422
28860, 78883, 78875, 78699, 78707, 78884, 78876, 78700, 78708, 79981, 79957, 79423, 79982, 79984, 79960, 79426, 
79985, 79983, 79958, 79400, 79425
28861, 78884, 78876, 78700, 78708, 78885, 78877, 78701, 78709, 79984, 79960, 79426, 79985, 79987, 79963, 79429, 
79988, 79986, 79961, 79403, 79428
28862, 78885, 78877, 78701, 78709, 78886, 78878, 78702, 78710, 79987, 79963, 79429, 79988, 79990, 79966, 79432, 
79991, 79989, 79964, 79406, 79431
28863, 78886, 78878, 78702, 78710, 78887, 78879, 78703, 78711, 79990, 79966, 79432, 79991, 79993, 79969, 79435, 
79994, 79992, 79967, 79409, 79434
28864, 78887, 78879, 78703, 78711, 10668, 10667, 10645, 10646, 79993, 79969, 79435, 79994, 10757, 10754, 10712, 
10756, 79995, 79970, 79412, 79437
28865, 1192, 10512, 10490, 1191, 10847, 78880, 78704, 10839, 10602, 10601, 10557, 1194, 79996, 79973, 79438, 
10873, 10872, 79971, 79413, 10855
28866, 10847, 78880, 78704, 10839, 10848, 78881, 78705, 10840, 79996, 79973, 79438, 10873, 79997, 79976, 79439, 
10875, 10874, 79974, 79416, 10857
28867, 10848, 78881, 78705, 10840, 10849, 78882, 78706, 10841, 79997, 79976, 79439, 10875, 79998, 79979, 79440, 
10877, 10876, 79977, 79419, 10859
28868, 10849, 78882, 78706, 10841, 10850, 78883, 78707, 10842, 79998, 79979, 79440, 10877, 79999, 79982, 79441, 
10879, 10878, 79980, 79422, 10861
28869, 10850, 78883, 78707, 10842, 10851, 78884, 78708, 10843, 79999, 79982, 79441, 10879, 80000, 79985, 79442, 
10881, 10880, 79983, 79425, 10863
28870, 10851, 78884, 78708, 10843, 10852, 78885, 78709, 10844, 80000, 79985, 79442, 10881, 80001, 79988, 79443, 
10883, 10882, 79986, 79428, 10865
28871, 10852, 78885, 78709, 10844, 10853, 78886, 78710, 10845, 80001, 79988, 79443, 10883, 80002, 79991, 79444, 
10885, 10884, 79989, 79431, 10867
28872, 10853, 78886, 78710, 10845, 10854, 78887, 78711, 10846, 80002, 79991, 79444, 10885, 80003, 79994, 79445, 
10887, 10886, 79992, 79434, 10869
28873, 10854, 78887, 78711, 10846, 1247, 10668, 10646, 1246, 80003, 79994, 79445, 10887, 10758, 10756, 10713, 
1249, 10888, 79995, 79437, 10871
28874, 965, 27, 1187, 10491, 9353, 931, 10789, 78712, 987, 1190, 10558, 10603, 9530, 10831, 79447, 
80004, 9529, 940, 10815, 79446
28875, 9353, 931, 10789, 78712, 9354, 930, 10790, 78713, 9530, 10831, 79447, 80004, 9532, 10832, 79450, 
80005, 9531, 939, 10817, 79449
28876, 9354, 930, 10790, 78713, 9355, 929, 10791, 78714, 9532, 10832, 79450, 80005, 9534, 10833, 79453, 
80006, 9533, 938, 10819, 79452
28877, 9355, 929, 10791, 78714, 9356, 928, 10792, 78715, 9534, 10833, 79453, 80006, 9536, 10834, 79456, 
80007, 9535, 937, 10821, 79455
28878, 9356, 928, 10792, 78715, 9357, 927, 10793, 78716, 9536, 10834, 79456, 80007, 9538, 10835, 79459, 
80008, 9537, 936, 10823, 79458
28879, 9357, 927, 10793, 78716, 9358, 926, 10794, 78717, 9538, 10835, 79459, 80008, 9540, 10836, 79462, 
80009, 9539, 935, 10825, 79461
28880, 9358, 926, 10794, 78717, 9359, 925, 10795, 78718, 9540, 10836, 79462, 80009, 9542, 10837, 79465, 
80010, 9541, 934, 10827, 79464
28881, 9359, 925, 10795, 78718, 9360, 924, 10796, 78719, 9542, 10837, 79465, 80010, 9544, 10838, 79468, 
80011, 9543, 933, 10829, 79467
28882, 9360, 924, 10796, 78719, 1062, 29, 1242, 10647, 9544, 10838, 79468, 80011, 1084, 1245, 10715, 
10759, 9545, 932, 10830, 79470
28883, 966, 965, 10491, 10492, 9361, 9353, 78712, 78720, 988, 10603, 10560, 10604, 9547, 80004, 79472, 
80012, 9546, 9529, 79446, 79471
28884, 9361, 9353, 78712, 78720, 9362, 9354, 78713, 78721, 9547, 80004, 79472, 80012, 9549, 80005, 79475, 
80013, 9548, 9531, 79449, 79474
28885, 9362, 9354, 78713, 78721, 9363, 9355, 78714, 78722, 9549, 80005, 79475, 80013, 9551, 80006, 79478, 
80014, 9550, 9533, 79452, 79477
28886, 9363, 9355, 78714, 78722, 9364, 9356, 78715, 78723, 9551, 80006, 79478, 80014, 9553, 80007, 79481, 
80015, 9552, 9535, 79455, 79480
28887, 9364, 9356, 78715, 78723, 9365, 9357, 78716, 78724, 9553, 80007, 79481, 80015, 9555, 80008, 79484, 
80016, 9554, 9537, 79458, 79483
28888, 9365, 9357, 78716, 78724, 9366, 9358, 78717, 78725, 9555, 80008, 79484, 80016, 9557, 80009, 79487, 
80017, 9556, 9539, 79461, 79486
28889, 9366, 9358, 78717, 78725, 9367, 9359, 78718, 78726, 9557, 80009, 79487, 80017, 9559, 80010, 79490, 
80018, 9558, 9541, 79464, 79489
28890, 9367, 9359, 78718, 78726, 9368, 9360, 78719, 78727, 9559, 80010, 79490, 80018, 9561, 80011, 79493, 
80019, 9560, 9543, 79467, 79492
28891, 9368, 9360, 78719, 78727, 1063, 1062, 10647, 10648, 9561, 80011, 79493, 80019, 1085, 10759, 10717, 
10760, 9562, 9545, 79470, 79495
28892, 967, 966, 10492, 10493, 9369, 9361, 78720, 78728, 989, 10604, 10562, 10605, 9564, 80012, 79497, 
80020, 9563, 9546, 79471, 79496
28893, 9369, 9361, 78720, 78728, 9370, 9362, 78721, 78729, 9564, 80012, 79497, 80020, 9566, 80013, 79500, 
80021, 9565, 9548, 79474, 79499
28894, 9370, 9362, 78721, 78729, 9371, 9363, 78722, 78730, 9566, 80013, 79500, 80021, 9568, 80014, 79503, 
80022, 9567, 9550, 79477, 79502
28895, 9371, 9363, 78722, 78730, 9372, 9364, 78723, 78731, 9568, 80014, 79503, 80022, 9570, 80015, 79506, 
80023, 9569, 9552, 79480, 79505
28896, 9372, 9364, 78723, 78731, 9373, 9365, 78724, 78732, 9570, 80015, 79506, 80023, 9572, 80016, 79509, 
80024, 9571, 9554, 79483, 79508
28897, 9373, 9365, 78724, 78732, 9374, 9366, 78725, 78733, 9572, 80016, 79509, 80024, 9574, 80017, 79512, 
80025, 9573, 9556, 79486, 79511
28898, 9374, 9366, 78725, 78733, 9375, 9367, 78726, 78734, 9574, 80017, 79512, 80025, 9576, 80018, 79515, 
80026, 9575, 9558, 79489, 79514
28899, 9375, 9367, 78726, 78734, 9376, 9368, 78727, 78735, 9576, 80018, 79515, 80026, 9578, 80019, 79518, 
80027, 9577, 9560, 79492, 79517
28900, 9376, 9368, 78727, 78735, 1064, 1063, 10648, 10649, 9578, 80019, 79518, 80027, 1086, 10760, 10719, 
10761, 9579, 9562, 79495, 79520
28901, 968, 967, 10493, 10494, 9377, 9369, 78728, 78736, 990, 10605, 10564, 10606, 9581, 80020, 79522, 
80028, 9580, 9563, 79496, 79521
28902, 9377, 9369, 78728, 78736, 9378, 9370, 78729, 78737, 9581, 80020, 79522, 80028, 9583, 80021, 79525, 
80029, 9582, 9565, 79499, 79524
28903, 9378, 9370, 78729, 78737, 9379, 9371, 78730, 78738, 9583, 80021, 79525, 80029, 9585, 80022, 79528, 
80030, 9584, 9567, 79502, 79527
28904, 9379, 9371, 78730, 78738, 9380, 9372, 78731, 78739, 9585, 80022, 79528, 80030, 9587, 80023, 79531, 
80031, 9586, 9569, 79505, 79530
28905, 9380, 9372, 78731, 78739, 9381, 9373, 78732, 78740, 9587, 80023, 79531, 80031, 9589, 80024, 79534, 
80032, 9588, 9571, 79508, 79533
28906, 9381, 9373, 78732, 78740, 9382, 9374, 78733, 78741, 9589, 80024, 79534, 80032, 9591, 80025, 79537, 
80033, 9590, 9573, 79511, 79536
28907, 9382, 9374, 78733, 78741, 9383, 9375, 78734, 78742, 9591, 80025, 79537, 80033, 9593, 80026, 79540, 
80034, 9592, 9575, 79514, 79539
28908, 9383, 9375, 78734, 78742, 9384, 9376, 78735, 78743, 9593, 80026, 79540, 80034, 9595, 80027, 79543, 
80035, 9594, 9577, 79517, 79542
28909, 9384, 9376, 78735, 78743, 1065, 1064, 10649, 10650, 9595, 80027, 79543, 80035, 1087, 10761, 10721, 
10762, 9596, 9579, 79520, 79545
28910, 969, 968, 10494, 10495, 9385, 9377, 78736, 78744, 991, 10606, 10566, 10607, 9598, 80028, 79547, 
80036, 9597, 9580, 79521, 79546
28911, 9385, 9377, 78736, 78744, 9386, 9378, 78737, 78745, 9598, 80028, 79547, 80036, 9600, 80029, 79550, 
80037, 9599, 9582, 79524, 79549
28912, 9386, 9378, 78737, 78745, 9387, 9379, 78738, 78746, 9600, 80029, 79550, 80037, 9602, 80030, 79553, 
80038, 9601, 9584, 79527, 79552
28913, 9387, 9379, 78738, 78746, 9388, 9380, 78739, 78747, 9602, 80030, 79553, 80038, 9604, 80031, 79556, 
80039, 9603, 9586, 79530, 79555
28914, 9388, 9380, 78739, 78747, 9389, 9381, 78740, 78748, 9604, 80031, 79556, 80039, 9606, 80032, 79559, 
80040, 9605, 9588, 79533, 79558
28915, 9389, 9381, 78740, 78748, 9390, 9382, 78741, 78749, 9606, 80032, 79559, 80040, 9608, 80033, 79562, 
80041, 9607, 9590, 79536, 79561
28916, 9390, 9382, 78741, 78749, 9391, 9383, 78742, 78750, 9608, 80033, 79562, 80041, 9610, 80034, 79565, 
80042, 9609, 9592, 79539, 79564
28917, 9391, 9383, 78742, 78750, 9392, 9384, 78743, 78751, 9610, 80034, 79565, 80042, 9612, 80035, 79568, 
80043, 9611, 9594, 79542, 79567
28918, 9392, 9384, 78743, 78751, 1066, 1065, 10650, 10651, 9612, 80035, 79568, 80043, 1088, 10762, 10723, 
10763, 9613, 9596, 79545, 79570
28919, 970, 969, 10495, 10496, 9393, 9385, 78744, 78752, 992, 10607, 10568, 10608, 9615, 80036, 79572, 
80044, 9614, 9597, 79546, 79571
28920, 9393, 9385, 78744, 78752, 9394, 9386, 78745, 78753, 9615, 80036, 79572, 80044, 9617, 80037, 79575, 
80045, 9616, 9599, 79549, 79574
28921, 9394, 9386, 78745, 78753, 9395, 9387, 78746, 78754, 9617, 80037, 79575, 80045, 9619, 80038, 79578, 
80046, 9618, 9601, 79552, 79577
28922, 9395, 9387, 78746, 78754, 9396, 9388, 78747, 78755, 9619, 80038, 79578, 80046, 9621, 80039, 79581, 
80047, 9620, 9603, 79555, 79580
28923, 9396, 9388, 78747, 78755, 9397, 9389, 78748, 78756, 9621, 80039, 79581, 80047, 9623, 80040, 79584, 
80048, 9622, 9605, 79558, 79583
28924, 9397, 9389, 78748, 78756, 9398, 9390, 78749, 78757, 9623, 80040, 79584, 80048, 9625, 80041, 79587, 
80049, 9624, 9607, 79561, 79586
28925, 9398, 9390, 78749, 78757, 9399, 9391, 78750, 78758, 9625, 80041, 79587, 80049, 9627, 80042, 79590, 
80050, 9626, 9609, 79564, 79589
28926, 9399, 9391, 78750, 78758, 9400, 9392, 78751, 78759, 9627, 80042, 79590, 80050, 9629, 80043, 79593, 
80051, 9628, 9611, 79567, 79592
28927, 9400, 9392, 78751, 78759, 1067, 1066, 10651, 10652, 9629, 80043, 79593, 80051, 1089, 10763, 10725, 
10764, 9630, 9613, 79570, 79595
28928, 971, 970, 10496, 10497, 9401, 9393, 78752, 78760, 993, 10608, 10570, 10609, 9632, 80044, 79597, 
80052, 9631, 9614, 79571, 79596
28929, 9401, 9393, 78752, 78760, 9402, 9394, 78753, 78761, 9632, 80044, 79597, 80052, 9634, 80045, 79600, 
80053, 9633, 9616, 79574, 79599
28930, 9402, 9394, 78753, 78761, 9403, 9395, 78754, 78762, 9634, 80045, 79600, 80053, 9636, 80046, 79603, 
80054, 9635, 9618, 79577, 79602
28931, 9403, 9395, 78754, 78762, 9404, 9396, 78755, 78763, 9636, 80046, 79603, 80054, 9638, 80047, 79606, 
80055, 9637, 9620, 79580, 79605
28932, 9404, 9396, 78755, 78763, 9405, 9397, 78756, 78764, 9638, 80047, 79606, 80055, 9640, 80048, 79609, 
80056, 9639, 9622, 79583, 79608
28933, 9405, 9397, 78756, 78764, 9406, 9398, 78757, 78765, 9640, 80048, 79609, 80056, 9642, 80049, 79612, 
80057, 9641, 9624, 79586, 79611
28934, 9406, 9398, 78757, 78765, 9407, 9399, 78758, 78766, 9642, 80049, 79612, 80057, 9644, 80050, 79615, 
80058, 9643, 9626, 79589, 79614
28935, 9407, 9399, 78758, 78766, 9408, 9400, 78759, 78767, 9644, 80050, 79615, 80058, 9646, 80051, 79618, 
80059, 9645, 9628, 79592, 79617
28936, 9408, 9400, 78759, 78767, 1068, 1067, 10652, 10653, 9646, 80051, 79618, 80059, 1090, 10764, 10727, 
10765, 9647, 9630, 79595, 79620
28937, 972, 971, 10497, 10498, 9409, 9401, 78760, 78768, 994, 10609, 10572, 10610, 9649, 80052, 79622, 
80060, 9648, 9631, 79596, 79621
28938, 9409, 9401, 78760, 78768, 9410, 9402, 78761, 78769, 9649, 80052, 79622, 80060, 9651, 80053, 79625, 
80061, 9650, 9633, 79599, 79624
28939, 9410, 9402, 78761, 78769, 9411, 9403, 78762, 78770, 9651, 80053, 79625, 80061, 9653, 80054, 79628, 
80062, 9652, 9635, 79602, 79627
28940, 9411, 9403, 78762, 78770, 9412, 9404, 78763, 78771, 9653, 80054, 79628, 80062, 9655, 80055, 79631, 
80063, 9654, 9637, 79605, 79630
28941, 9412, 9404, 78763, 78771, 9413, 9405, 78764, 78772, 9655, 80055, 79631, 80063, 9657, 80056, 79634, 
80064, 9656, 9639, 79608, 79633
28942, 9413, 9405, 78764, 78772, 9414, 9406, 78765, 78773, 9657, 80056, 79634, 80064, 9659, 80057, 79637, 
80065, 9658, 9641, 79611, 79636
28943, 9414, 9406, 78765, 78773, 9415, 9407, 78766, 78774, 9659, 80057, 79637, 80065, 9661, 80058, 79640, 
80066, 9660, 9643, 79614, 79639
28944, 9415, 9407, 78766, 78774, 9416, 9408, 78767, 78775, 9661, 80058, 79640, 80066, 9663, 80059, 79643, 
80067, 9662, 9645, 79617, 79642
28945, 9416, 9408, 78767, 78775, 1069, 1068, 10653, 10654, 9663, 80059, 79643, 80067, 1091, 10765, 10729, 
10766, 9664, 9647, 79620, 79645
28946, 973, 972, 10498, 10499, 9417, 9409, 78768, 78776, 995, 10610, 10574, 10611, 9666, 80060, 79647, 
80068, 9665, 9648, 79621, 79646
28947, 9417, 9409, 78768, 78776, 9418, 9410, 78769, 78777, 9666, 80060, 79647, 80068, 9668, 80061, 79650, 
80069, 9667, 9650, 79624, 79649
28948, 9418, 9410, 78769, 78777, 9419, 9411, 78770, 78778, 9668, 80061, 79650, 80069, 9670, 80062, 79653, 
80070, 9669, 9652, 79627, 79652
28949, 9419, 9411, 78770, 78778, 9420, 9412, 78771, 78779, 9670, 80062, 79653, 80070, 9672, 80063, 79656, 
80071, 9671, 9654, 79630, 79655
28950, 9420, 9412, 78771, 78779, 9421, 9413, 78772, 78780, 9672, 80063, 79656, 80071, 9674, 80064, 79659, 
80072, 9673, 9656, 79633, 79658
28951, 9421, 9413, 78772, 78780, 9422, 9414, 78773, 78781, 9674, 80064, 79659, 80072, 9676, 80065, 79662, 
80073, 9675, 9658, 79636, 79661
28952, 9422, 9414, 78773, 78781, 9423, 9415, 78774, 78782, 9676, 80065, 79662, 80073, 9678, 80066, 79665, 
80074, 9677, 9660, 79639, 79664
28953, 9423, 9415, 78774, 78782, 9424, 9416, 78775, 78783, 9678, 80066, 79665, 80074, 9680, 80067, 79668, 
80075, 9679, 9662, 79642, 79667
28954, 9424, 9416, 78775, 78783, 1070, 1069, 10654, 10655, 9680, 80067, 79668, 80075, 1092, 10766, 10731, 
10767, 9681, 9664, 79645, 79670
28955, 974, 973, 10499, 10500, 9425, 9417, 78776, 78784, 996, 10611, 10576, 10612, 9683, 80068, 79672, 
80076, 9682, 9665, 79646, 79671
28956, 9425, 9417, 78776, 78784, 9426, 9418, 78777, 78785, 9683, 80068, 79672, 80076, 9685, 80069, 79675, 
80077, 9684, 9667, 79649, 79674
28957, 9426, 9418, 78777, 78785, 9427, 9419, 78778, 78786, 9685, 80069, 79675, 80077, 9687, 80070, 79678, 
80078, 9686, 9669, 79652, 79677
28958, 9427, 9419, 78778, 78786, 9428, 9420, 78779, 78787, 9687, 80070, 79678, 80078, 9689, 80071, 79681, 
80079, 9688, 9671, 79655, 79680
28959, 9428, 9420, 78779, 78787, 9429, 9421, 78780, 78788, 9689, 80071, 79681, 80079, 9691, 80072, 79684, 
80080, 9690, 9673, 79658, 79683
28960, 9429, 9421, 78780, 78788, 9430, 9422, 78781, 78789, 9691, 80072, 79684, 80080, 9693, 80073, 79687, 
80081, 9692, 9675, 79661, 79686
28961, 9430, 9422, 78781, 78789, 9431, 9423, 78782, 78790, 9693, 80073, 79687, 80081, 9695, 80074, 79690, 
80082, 9694, 9677, 79664, 79689
28962, 9431, 9423, 78782, 78790, 9432, 9424, 78783, 78791, 9695, 80074, 79690, 80082, 9697, 80075, 79693, 
80083, 9696, 9679, 79667, 79692
28963, 9432, 9424, 78783, 78791, 1071, 1070, 10655, 10656, 9697, 80075, 79693, 80083, 1093, 10767, 10733, 
10768, 9698, 9681, 79670, 79695
28964, 975, 974, 10500, 10501, 9433, 9425, 78784, 78792, 997, 10612, 10578, 10613, 9700, 80076, 79697, 
80084, 9699, 9682, 79671, 79696
28965, 9433, 9425, 78784, 78792, 9434, 9426, 78785, 78793, 9700, 80076, 79697, 80084, 9702, 80077, 79700, 
80085, 9701, 9684, 79674, 79699
28966, 9434, 9426, 78785, 78793, 9435, 9427, 78786, 78794, 9702, 80077, 79700, 80085, 9704, 80078, 79703, 
80086, 9703, 9686, 79677, 79702
28967, 9435, 9427, 78786, 78794, 9436, 9428, 78787, 78795, 9704, 80078, 79703, 80086, 9706, 80079, 79706, 
80087, 9705, 9688, 79680, 79705
28968, 9436, 9428, 78787, 78795, 9437, 9429, 78788, 78796, 9706, 80079, 79706, 80087, 9708, 80080, 79709, 
80088, 9707, 9690, 79683, 79708
28969, 9437, 9429, 78788, 78796, 9438, 9430, 78789, 78797, 9708, 80080, 79709, 80088, 9710, 80081, 79712, 
80089, 9709, 9692, 79686, 79711
28970, 9438, 9430, 78789, 78797, 9439, 9431, 78790, 78798, 9710, 80081, 79712, 80089, 9712, 80082, 79715, 
80090, 9711, 9694, 79689, 79714
28971, 9439, 9431, 78790, 78798, 9440, 9432, 78791, 78799, 9712, 80082, 79715, 80090, 9714, 80083, 79718, 
80091, 9713, 9696, 79692, 79717
28972, 9440, 9432, 78791, 78799, 1072, 1071, 10656, 10657, 9714, 80083, 79718, 80091, 1094, 10768, 10735, 
10769, 9715, 9698, 79695, 79720
28973, 976, 975, 10501, 10502, 9441, 9433, 78792, 78800, 998, 10613, 10580, 10614, 9717, 80084, 79722, 
80092, 9716, 9699, 79696, 79721
28974, 9441, 9433, 78792, 78800, 9442, 9434, 78793, 78801, 9717, 80084, 79722, 80092, 9719, 80085, 79725, 
80093, 9718, 9701, 79699, 79724
28975, 9442, 9434, 78793, 78801, 9443, 9435, 78794, 78802, 9719, 80085, 79725, 80093, 9721, 80086, 79728, 
80094, 9720, 9703, 79702, 79727
28976, 9443, 9435, 78794, 78802, 9444, 9436, 78795, 78803, 9721, 80086, 79728, 80094, 9723, 80087, 79731, 
80095, 9722, 9705, 79705, 79730
28977, 9444, 9436, 78795, 78803, 9445, 9437, 78796, 78804, 9723, 80087, 79731, 80095, 9725, 80088, 79734, 
80096, 9724, 9707, 79708, 79733
28978, 9445, 9437, 78796, 78804, 9446, 9438, 78797, 78805, 9725, 80088, 79734, 80096, 9727, 80089, 79737, 
80097, 9726, 9709, 79711, 79736
28979, 9446, 9438, 78797, 78805, 9447, 9439, 78798, 78806, 9727, 80089, 79737, 80097, 9729, 80090, 79740, 
80098, 9728, 9711, 79714, 79739
28980, 9447, 9439, 78798, 78806, 9448, 9440, 78799, 78807, 9729, 80090, 79740, 80098, 9731, 80091, 79743, 
80099, 9730, 9713, 79717, 79742
28981, 9448, 9440, 78799, 78807, 1073, 1072, 10657, 10658, 9731, 80091, 79743, 80099, 1095, 10769, 10737, 
10770, 9732, 9715, 79720, 79745
28982, 977, 976, 10502, 10503, 9449, 9441, 78800, 78808, 999, 10614, 10582, 10615, 9734, 80092, 79747, 
80100, 9733, 9716, 79721, 79746
28983, 9449, 9441, 78800, 78808, 9450, 9442, 78801, 78809, 9734, 80092, 79747, 80100, 9736, 80093, 79750, 
80101, 9735, 9718, 79724, 79749
28984, 9450, 9442, 78801, 78809, 9451, 9443, 78802, 78810, 9736, 80093, 79750, 80101, 9738, 80094, 79753, 
80102, 9737, 9720, 79727, 79752
28985, 9451, 9443, 78802, 78810, 9452, 9444, 78803, 78811, 9738, 80094, 79753, 80102, 9740, 80095, 79756, 
80103, 9739, 9722, 79730, 79755
28986, 9452, 9444, 78803, 78811, 9453, 9445, 78804, 78812, 9740, 80095, 79756, 80103, 9742, 80096, 79759, 
80104, 9741, 9724, 79733, 79758
28987, 9453, 9445, 78804, 78812, 9454, 9446, 78805, 78813, 9742, 80096, 79759, 80104, 9744, 80097, 79762, 
80105, 9743, 9726, 79736, 79761
28988, 9454, 9446, 78805, 78813, 9455, 9447, 78806, 78814, 9744, 80097, 79762, 80105, 9746, 80098, 79765, 
80106, 9745, 9728, 79739, 79764
28989, 9455, 9447, 78806, 78814, 9456, 9448, 78807, 78815, 9746, 80098, 79765, 80106, 9748, 80099, 79768, 
80107, 9747, 9730, 79742, 79767
28990, 9456, 9448, 78807, 78815, 1074, 1073, 10658, 10659, 9748, 80099, 79768, 80107, 1096, 10770, 10739, 
10771, 9749, 9732, 79745, 79770
