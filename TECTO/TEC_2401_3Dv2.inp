28991, 978, 977, 10503, 10504, 9457, 9449, 78808, 78816, 1000, 10615, 10584, 10616, 9751, 80100, 79772, 
80108, 9750, 9733, 79746, 79771
28992, 9457, 9449, 78808, 78816, 9458, 9450, 78809, 78817, 9751, 80100, 79772, 80108, 9753, 80101, 79775, 
80109, 9752, 9735, 79749, 79774
28993, 9458, 9450, 78809, 78817, 9459, 9451, 78810, 78818, 9753, 80101, 79775, 80109, 9755, 80102, 79778, 
80110, 9754, 9737, 79752, 79777
28994, 9459, 9451, 78810, 78818, 9460, 9452, 78811, 78819, 9755, 80102, 79778, 80110, 9757, 80103, 79781, 
80111, 9756, 9739, 79755, 79780
28995, 9460, 9452, 78811, 78819, 9461, 9453, 78812, 78820, 9757, 80103, 79781, 80111, 9759, 80104, 79784, 
80112, 9758, 9741, 79758, 79783
28996, 9461, 9453, 78812, 78820, 9462, 9454, 78813, 78821, 9759, 80104, 79784, 80112, 9761, 80105, 79787, 
80113, 9760, 9743, 79761, 79786
28997, 9462, 9454, 78813, 78821, 9463, 9455, 78814, 78822, 9761, 80105, 79787, 80113, 9763, 80106, 79790, 
80114, 9762, 9745, 79764, 79789
28998, 9463, 9455, 78814, 78822, 9464, 9456, 78815, 78823, 9763, 80106, 79790, 80114, 9765, 80107, 79793, 
80115, 9764, 9747, 79767, 79792
28999, 9464, 9456, 78815, 78823, 1075, 1074, 10659, 10660, 9765, 80107, 79793, 80115, 1097, 10771, 10741, 
10772, 9766, 9749, 79770, 79795
29000, 979, 978, 10504, 10505, 9465, 9457, 78816, 78824, 1001, 10616, 10586, 10617, 9768, 80108, 79797, 
80116, 9767, 9750, 79771, 79796
29001, 9465, 9457, 78816, 78824, 9466, 9458, 78817, 78825, 9768, 80108, 79797, 80116, 9770, 80109, 79800, 
80117, 9769, 9752, 79774, 79799
29002, 9466, 9458, 78817, 78825, 9467, 9459, 78818, 78826, 9770, 80109, 79800, 80117, 9772, 80110, 79803, 
80118, 9771, 9754, 79777, 79802
29003, 9467, 9459, 78818, 78826, 9468, 9460, 78819, 78827, 9772, 80110, 79803, 80118, 9774, 80111, 79806, 
80119, 9773, 9756, 79780, 79805
29004, 9468, 9460, 78819, 78827, 9469, 9461, 78820, 78828, 9774, 80111, 79806, 80119, 9776, 80112, 79809, 
80120, 9775, 9758, 79783, 79808
29005, 9469, 9461, 78820, 78828, 9470, 9462, 78821, 78829, 9776, 80112, 79809, 80120, 9778, 80113, 79812, 
80121, 9777, 9760, 79786, 79811
29006, 9470, 9462, 78821, 78829, 9471, 9463, 78822, 78830, 9778, 80113, 79812, 80121, 9780, 80114, 79815, 
80122, 9779, 9762, 79789, 79814
29007, 9471, 9463, 78822, 78830, 9472, 9464, 78823, 78831, 9780, 80114, 79815, 80122, 9782, 80115, 79818, 
80123, 9781, 9764, 79792, 79817
29008, 9472, 9464, 78823, 78831, 1076, 1075, 10660, 10661, 9782, 80115, 79818, 80123, 1098, 10772, 10743, 
10773, 9783, 9766, 79795, 79820
29009, 980, 979, 10505, 10506, 9473, 9465, 78824, 78832, 1002, 10617, 10588, 10618, 9785, 80116, 79822, 
80124, 9784, 9767, 79796, 79821
29010, 9473, 9465, 78824, 78832, 9474, 9466, 78825, 78833, 9785, 80116, 79822, 80124, 9787, 80117, 79825, 
80125, 9786, 9769, 79799, 79824
29011, 9474, 9466, 78825, 78833, 9475, 9467, 78826, 78834, 9787, 80117, 79825, 80125, 9789, 80118, 79828, 
80126, 9788, 9771, 79802, 79827
29012, 9475, 9467, 78826, 78834, 9476, 9468, 78827, 78835, 9789, 80118, 79828, 80126, 9791, 80119, 79831, 
80127, 9790, 9773, 79805, 79830
29013, 9476, 9468, 78827, 78835, 9477, 9469, 78828, 78836, 9791, 80119, 79831, 80127, 9793, 80120, 79834, 
80128, 9792, 9775, 79808, 79833
29014, 9477, 9469, 78828, 78836, 9478, 9470, 78829, 78837, 9793, 80120, 79834, 80128, 9795, 80121, 79837, 
80129, 9794, 9777, 79811, 79836
29015, 9478, 9470, 78829, 78837, 9479, 9471, 78830, 78838, 9795, 80121, 79837, 80129, 9797, 80122, 79840, 
80130, 9796, 9779, 79814, 79839
29016, 9479, 9471, 78830, 78838, 9480, 9472, 78831, 78839, 9797, 80122, 79840, 80130, 9799, 80123, 79843, 
80131, 9798, 9781, 79817, 79842
29017, 9480, 9472, 78831, 78839, 1077, 1076, 10661, 10662, 9799, 80123, 79843, 80131, 1099, 10773, 10745, 
10774, 9800, 9783, 79820, 79845
29018, 981, 980, 10506, 10507, 9481, 9473, 78832, 78840, 1003, 10618, 10590, 10619, 9802, 80124, 79847, 
80132, 9801, 9784, 79821, 79846
29019, 9481, 9473, 78832, 78840, 9482, 9474, 78833, 78841, 9802, 80124, 79847, 80132, 9804, 80125, 79850, 
80133, 9803, 9786, 79824, 79849
29020, 9482, 9474, 78833, 78841, 9483, 9475, 78834, 78842, 9804, 80125, 79850, 80133, 9806, 80126, 79853, 
80134, 9805, 9788, 79827, 79852
29021, 9483, 9475, 78834, 78842, 9484, 9476, 78835, 78843, 9806, 80126, 79853, 80134, 9808, 80127, 79856, 
80135, 9807, 9790, 79830, 79855
29022, 9484, 9476, 78835, 78843, 9485, 9477, 78836, 78844, 9808, 80127, 79856, 80135, 9810, 80128, 79859, 
80136, 9809, 9792, 79833, 79858
29023, 9485, 9477, 78836, 78844, 9486, 9478, 78837, 78845, 9810, 80128, 79859, 80136, 9812, 80129, 79862, 
80137, 9811, 9794, 79836, 79861
29024, 9486, 9478, 78837, 78845, 9487, 9479, 78838, 78846, 9812, 80129, 79862, 80137, 9814, 80130, 79865, 
80138, 9813, 9796, 79839, 79864
29025, 9487, 9479, 78838, 78846, 9488, 9480, 78839, 78847, 9814, 80130, 79865, 80138, 9816, 80131, 79868, 
80139, 9815, 9798, 79842, 79867
29026, 9488, 9480, 78839, 78847, 1078, 1077, 10662, 10663, 9816, 80131, 79868, 80139, 1100, 10774, 10747, 
10775, 9817, 9800, 79845, 79870
29027, 982, 981, 10507, 10508, 9489, 9481, 78840, 78848, 1004, 10619, 10592, 10620, 9819, 80132, 79872, 
80140, 9818, 9801, 79846, 79871
29028, 9489, 9481, 78840, 78848, 9490, 9482, 78841, 78849, 9819, 80132, 79872, 80140, 9821, 80133, 79875, 
80141, 9820, 9803, 79849, 79874
29029, 9490, 9482, 78841, 78849, 9491, 9483, 78842, 78850, 9821, 80133, 79875, 80141, 9823, 80134, 79878, 
80142, 9822, 9805, 79852, 79877
29030, 9491, 9483, 78842, 78850, 9492, 9484, 78843, 78851, 9823, 80134, 79878, 80142, 9825, 80135, 79881, 
80143, 9824, 9807, 79855, 79880
29031, 9492, 9484, 78843, 78851, 9493, 9485, 78844, 78852, 9825, 80135, 79881, 80143, 9827, 80136, 79884, 
80144, 9826, 9809, 79858, 79883
29032, 9493, 9485, 78844, 78852, 9494, 9486, 78845, 78853, 9827, 80136, 79884, 80144, 9829, 80137, 79887, 
80145, 9828, 9811, 79861, 79886
29033, 9494, 9486, 78845, 78853, 9495, 9487, 78846, 78854, 9829, 80137, 79887, 80145, 9831, 80138, 79890, 
80146, 9830, 9813, 79864, 79889
29034, 9495, 9487, 78846, 78854, 9496, 9488, 78847, 78855, 9831, 80138, 79890, 80146, 9833, 80139, 79893, 
80147, 9832, 9815, 79867, 79892
29035, 9496, 9488, 78847, 78855, 1079, 1078, 10663, 10664, 9833, 80139, 79893, 80147, 1101, 10775, 10749, 
10776, 9834, 9817, 79870, 79895
29036, 983, 982, 10508, 10509, 9497, 9489, 78848, 78856, 1005, 10620, 10594, 10621, 9836, 80140, 79897, 
80148, 9835, 9818, 79871, 79896
29037, 9497, 9489, 78848, 78856, 9498, 9490, 78849, 78857, 9836, 80140, 79897, 80148, 9838, 80141, 79900, 
80149, 9837, 9820, 79874, 79899
29038, 9498, 9490, 78849, 78857, 9499, 9491, 78850, 78858, 9838, 80141, 79900, 80149, 9840, 80142, 79903, 
80150, 9839, 9822, 79877, 79902
29039, 9499, 9491, 78850, 78858, 9500, 9492, 78851, 78859, 9840, 80142, 79903, 80150, 9842, 80143, 79906, 
80151, 9841, 9824, 79880, 79905
29040, 9500, 9492, 78851, 78859, 9501, 9493, 78852, 78860, 9842, 80143, 79906, 80151, 9844, 80144, 79909, 
80152, 9843, 9826, 79883, 79908
29041, 9501, 9493, 78852, 78860, 9502, 9494, 78853, 78861, 9844, 80144, 79909, 80152, 9846, 80145, 79912, 
80153, 9845, 9828, 79886, 79911
29042, 9502, 9494, 78853, 78861, 9503, 9495, 78854, 78862, 9846, 80145, 79912, 80153, 9848, 80146, 79915, 
80154, 9847, 9830, 79889, 79914
29043, 9503, 9495, 78854, 78862, 9504, 9496, 78855, 78863, 9848, 80146, 79915, 80154, 9850, 80147, 79918, 
80155, 9849, 9832, 79892, 79917
29044, 9504, 9496, 78855, 78863, 1080, 1079, 10664, 10665, 9850, 80147, 79918, 80155, 1102, 10776, 10751, 
10777, 9851, 9834, 79895, 79920
29045, 984, 983, 10509, 10510, 9505, 9497, 78856, 78864, 1006, 10621, 10596, 10622, 9853, 80148, 79922, 
80156, 9852, 9835, 79896, 79921
29046, 9505, 9497, 78856, 78864, 9506, 9498, 78857, 78865, 9853, 80148, 79922, 80156, 9855, 80149, 79925, 
80157, 9854, 9837, 79899, 79924
29047, 9506, 9498, 78857, 78865, 9507, 9499, 78858, 78866, 9855, 80149, 79925, 80157, 9857, 80150, 79928, 
80158, 9856, 9839, 79902, 79927
29048, 9507, 9499, 78858, 78866, 9508, 9500, 78859, 78867, 9857, 80150, 79928, 80158, 9859, 80151, 79931, 
80159, 9858, 9841, 79905, 79930
29049, 9508, 9500, 78859, 78867, 9509, 9501, 78860, 78868, 9859, 80151, 79931, 80159, 9861, 80152, 79934, 
80160, 9860, 9843, 79908, 79933
29050, 9509, 9501, 78860, 78868, 9510, 9502, 78861, 78869, 9861, 80152, 79934, 80160, 9863, 80153, 79937, 
80161, 9862, 9845, 79911, 79936
29051, 9510, 9502, 78861, 78869, 9511, 9503, 78862, 78870, 9863, 80153, 79937, 80161, 9865, 80154, 79940, 
80162, 9864, 9847, 79914, 79939
29052, 9511, 9503, 78862, 78870, 9512, 9504, 78863, 78871, 9865, 80154, 79940, 80162, 9867, 80155, 79943, 
80163, 9866, 9849, 79917, 79942
29053, 9512, 9504, 78863, 78871, 1081, 1080, 10665, 10666, 9867, 80155, 79943, 80163, 1103, 10777, 10753, 
10778, 9868, 9851, 79920, 79945
29054, 985, 984, 10510, 10511, 9513, 9505, 78864, 78872, 1007, 10622, 10598, 10623, 9870, 80156, 79947, 
80164, 9869, 9852, 79921, 79946
29055, 9513, 9505, 78864, 78872, 9514, 9506, 78865, 78873, 9870, 80156, 79947, 80164, 9872, 80157, 79950, 
80165, 9871, 9854, 79924, 79949
29056, 9514, 9506, 78865, 78873, 9515, 9507, 78866, 78874, 9872, 80157, 79950, 80165, 9874, 80158, 79953, 
80166, 9873, 9856, 79927, 79952
29057, 9515, 9507, 78866, 78874, 9516, 9508, 78867, 78875, 9874, 80158, 79953, 80166, 9876, 80159, 79956, 
80167, 9875, 9858, 79930, 79955
29058, 9516, 9508, 78867, 78875, 9517, 9509, 78868, 78876, 9876, 80159, 79956, 80167, 9878, 80160, 79959, 
80168, 9877, 9860, 79933, 79958
29059, 9517, 9509, 78868, 78876, 9518, 9510, 78869, 78877, 9878, 80160, 79959, 80168, 9880, 80161, 79962, 
80169, 9879, 9862, 79936, 79961
29060, 9518, 9510, 78869, 78877, 9519, 9511, 78870, 78878, 9880, 80161, 79962, 80169, 9882, 80162, 79965, 
80170, 9881, 9864, 79939, 79964
29061, 9519, 9511, 78870, 78878, 9520, 9512, 78871, 78879, 9882, 80162, 79965, 80170, 9884, 80163, 79968, 
80171, 9883, 9866, 79942, 79967
29062, 9520, 9512, 78871, 78879, 1082, 1081, 10666, 10667, 9884, 80163, 79968, 80171, 1104, 10778, 10755, 
10779, 9885, 9868, 79945, 79970
29063, 986, 985, 10511, 10512, 9521, 9513, 78872, 78880, 1008, 10623, 10600, 10624, 9887, 80164, 79972, 
80172, 9886, 9869, 79946, 79971
29064, 9521, 9513, 78872, 78880, 9522, 9514, 78873, 78881, 9887, 80164, 79972, 80172, 9889, 80165, 79975, 
80173, 9888, 9871, 79949, 79974
29065, 9522, 9514, 78873, 78881, 9523, 9515, 78874, 78882, 9889, 80165, 79975, 80173, 9891, 80166, 79978, 
80174, 9890, 9873, 79952, 79977
29066, 9523, 9515, 78874, 78882, 9524, 9516, 78875, 78883, 9891, 80166, 79978, 80174, 9893, 80167, 79981, 
80175, 9892, 9875, 79955, 79980
29067, 9524, 9516, 78875, 78883, 9525, 9517, 78876, 78884, 9893, 80167, 79981, 80175, 9895, 80168, 79984, 
80176, 9894, 9877, 79958, 79983
29068, 9525, 9517, 78876, 78884, 9526, 9518, 78877, 78885, 9895, 80168, 79984, 80176, 9897, 80169, 79987, 
80177, 9896, 9879, 79961, 79986
29069, 9526, 9518, 78877, 78885, 9527, 9519, 78878, 78886, 9897, 80169, 79987, 80177, 9899, 80170, 79990, 
80178, 9898, 9881, 79964, 79989
29070, 9527, 9519, 78878, 78886, 9528, 9520, 78879, 78887, 9899, 80170, 79990, 80178, 9901, 80171, 79993, 
80179, 9900, 9883, 79967, 79992
29071, 9528, 9520, 78879, 78887, 1083, 1082, 10667, 10668, 9901, 80171, 79993, 80179, 1105, 10779, 10757, 
10780, 9902, 9885, 79970, 79995
29072, 31, 986, 10512, 1192, 1159, 9521, 78880, 10847, 1009, 10624, 10602, 1195, 9903, 80172, 79996, 
10889, 1168, 9886, 79971, 10872
29073, 1159, 9521, 78880, 10847, 1158, 9522, 78881, 10848, 9903, 80172, 79996, 10889, 9904, 80173, 79997, 
10890, 1167, 9888, 79974, 10874
29074, 1158, 9522, 78881, 10848, 1157, 9523, 78882, 10849, 9904, 80173, 79997, 10890, 9905, 80174, 79998, 
10891, 1166, 9890, 79977, 10876
29075, 1157, 9523, 78882, 10849, 1156, 9524, 78883, 10850, 9905, 80174, 79998, 10891, 9906, 80175, 79999, 
10892, 1165, 9892, 79980, 10878
29076, 1156, 9524, 78883, 10850, 1155, 9525, 78884, 10851, 9906, 80175, 79999, 10892, 9907, 80176, 80000, 
10893, 1164, 9894, 79983, 10880
29077, 1155, 9525, 78884, 10851, 1154, 9526, 78885, 10852, 9907, 80176, 80000, 10893, 9908, 80177, 80001, 
10894, 1163, 9896, 79986, 10882
29078, 1154, 9526, 78885, 10852, 1153, 9527, 78886, 10853, 9908, 80177, 80001, 10894, 9909, 80178, 80002, 
10895, 1162, 9898, 79989, 10884
29079, 1153, 9527, 78886, 10853, 1152, 9528, 78887, 10854, 9909, 80178, 80002, 10895, 9910, 80179, 80003, 
10896, 1161, 9900, 79992, 10886
29080, 1152, 9528, 78887, 10854, 33, 1083, 10668, 1247, 9910, 80179, 80003, 10896, 1106, 10780, 10758, 
1250, 1160, 9902, 79995, 10888
*ELEMENT, type=C3D20, ELSET=Volume12
29081, 36, 1330, 11455, 1191, 1320, 11473, 80180, 10839, 1331, 11458, 11457, 1193, 11482, 80197, 80198, 
10856, 1329, 11481, 80196, 10855
29082, 1320, 11473, 80180, 10839, 1319, 11474, 80181, 10840, 11482, 80197, 80198, 10856, 11484, 80200, 80201, 
10858, 1328, 11483, 80199, 10857
29083, 1319, 11474, 80181, 10840, 1318, 11475, 80182, 10841, 11484, 80200, 80201, 10858, 11486, 80203, 80204, 
10860, 1327, 11485, 80202, 10859
29084, 1318, 11475, 80182, 10841, 1317, 11476, 80183, 10842, 11486, 80203, 80204, 10860, 11488, 80206, 80207, 
10862, 1326, 11487, 80205, 10861
29085, 1317, 11476, 80183, 10842, 1316, 11477, 80184, 10843, 11488, 80206, 80207, 10862, 11490, 80209, 80210, 
10864, 1325, 11489, 80208, 10863
29086, 1316, 11477, 80184, 10843, 1315, 11478, 80185, 10844, 11490, 80209, 80210, 10864, 11492, 80212, 80213, 
10866, 1324, 11491, 80211, 10865
29087, 1315, 11478, 80185, 10844, 1314, 11479, 80186, 10845, 11492, 80212, 80213, 10866, 11494, 80215, 80216, 
10868, 1323, 11493, 80214, 10867
29088, 1314, 11479, 80186, 10845, 1313, 11480, 80187, 10846, 11494, 80215, 80216, 10868, 11496, 80218, 80219, 
10870, 1322, 11495, 80217, 10869
29089, 1313, 11480, 80187, 10846, 38, 1341, 11464, 1246, 11496, 80218, 80219, 10870, 1342, 11466, 11467, 
1248, 1321, 11497, 80220, 10871
29090, 1191, 11455, 11456, 1192, 10839, 80180, 80188, 10847, 11457, 11460, 11459, 1194, 80198, 80222, 80223, 
10873, 10855, 80196, 80221, 10872
29091, 10839, 80180, 80188, 10847, 10840, 80181, 80189, 10848, 80198, 80222, 80223, 10873, 80201, 80225, 80226, 
10875, 10857, 80199, 80224, 10874
29092, 10840, 80181, 80189, 10848, 10841, 80182, 80190, 10849, 80201, 80225, 80226, 10875, 80204, 80228, 80229, 
10877, 10859, 80202, 80227, 10876
29093, 10841, 80182, 80190, 10849, 10842, 80183, 80191, 10850, 80204, 80228, 80229, 10877, 80207, 80231, 80232, 
10879, 10861, 80205, 80230, 10878
29094, 10842, 80183, 80191, 10850, 10843, 80184, 80192, 10851, 80207, 80231, 80232, 10879, 80210, 80234, 80235, 
10881, 10863, 80208, 80233, 10880
29095, 10843, 80184, 80192, 10851, 10844, 80185, 80193, 10852, 80210, 80234, 80235, 10881, 80213, 80237, 80238, 
10883, 10865, 80211, 80236, 10882
29096, 10844, 80185, 80193, 10852, 10845, 80186, 80194, 10853, 80213, 80237, 80238, 10883, 80216, 80240, 80241, 
10885, 10867, 80214, 80239, 10884
29097, 10845, 80186, 80194, 10853, 10846, 80187, 80195, 10854, 80216, 80240, 80241, 10885, 80219, 80243, 80244, 
10887, 10869, 80217, 80242, 10886
29098, 10846, 80187, 80195, 10854, 1246, 11464, 11465, 1247, 80219, 80243, 80244, 10887, 11467, 11468, 11469, 
1249, 10871, 80220, 80245, 10888
29099, 1192, 11456, 1333, 31, 10847, 80188, 11506, 1159, 11459, 11461, 1334, 1195, 80223, 80246, 11514, 
10889, 10872, 80221, 11515, 1168
29100, 10847, 80188, 11506, 1159, 10848, 80189, 11507, 1158, 80223, 80246, 11514, 10889, 80226, 80247, 11516, 
10890, 10874, 80224, 11517, 1167
29101, 10848, 80189, 11507, 1158, 10849, 80190, 11508, 1157, 80226, 80247, 11516, 10890, 80229, 80248, 11518, 
10891, 10876, 80227, 11519, 1166
29102, 10849, 80190, 11508, 1157, 10850, 80191, 11509, 1156, 80229, 80248, 11518, 10891, 80232, 80249, 11520, 
10892, 10878, 80230, 11521, 1165
29103, 10850, 80191, 11509, 1156, 10851, 80192, 11510, 1155, 80232, 80249, 11520, 10892, 80235, 80250, 11522, 
10893, 10880, 80233, 11523, 1164
29104, 10851, 80192, 11510, 1155, 10852, 80193, 11511, 1154, 80235, 80250, 11522, 10893, 80238, 80251, 11524, 
10894, 10882, 80236, 11525, 1163
29105, 10852, 80193, 11511, 1154, 10853, 80194, 11512, 1153, 80238, 80251, 11524, 10894, 80241, 80252, 11526, 
10895, 10884, 80239, 11527, 1162
29106, 10853, 80194, 11512, 1153, 10854, 80195, 11513, 1152, 80241, 80252, 11526, 10895, 80244, 80253, 11528, 
10896, 10886, 80242, 11529, 1161
29107, 10854, 80195, 11513, 1152, 1247, 11465, 1344, 33, 80244, 80253, 11528, 10896, 11469, 11470, 1345, 
1250, 10888, 80245, 11530, 1160
29108, 1330, 39, 1336, 11455, 11473, 1359, 11539, 80180, 1332, 1338, 11462, 11458, 11498, 11556, 80254, 
80197, 11481, 1368, 11555, 80196
29109, 11473, 1359, 11539, 80180, 11474, 1358, 11540, 80181, 11498, 11556, 80254, 80197, 11499, 11558, 80255, 
80200, 11483, 1367, 11557, 80199
29110, 11474, 1358, 11540, 80181, 11475, 1357, 11541, 80182, 11499, 11558, 80255, 80200, 11500, 11560, 80256, 
80203, 11485, 1366, 11559, 80202
29111, 11475, 1357, 11541, 80182, 11476, 1356, 11542, 80183, 11500, 11560, 80256, 80203, 11501, 11562, 80257, 
80206, 11487, 1365, 11561, 80205
29112, 11476, 1356, 11542, 80183, 11477, 1355, 11543, 80184, 11501, 11562, 80257, 80206, 11502, 11564, 80258, 
80209, 11489, 1364, 11563, 80208
29113, 11477, 1355, 11543, 80184, 11478, 1354, 11544, 80185, 11502, 11564, 80258, 80209, 11503, 11566, 80259, 
80212, 11491, 1363, 11565, 80211
29114, 11478, 1354, 11544, 80185, 11479, 1353, 11545, 80186, 11503, 11566, 80259, 80212, 11504, 11568, 80260, 
80215, 11493, 1362, 11567, 80214
29115, 11479, 1353, 11545, 80186, 11480, 1352, 11546, 80187, 11504, 11568, 80260, 80215, 11505, 11570, 80261, 
80218, 11495, 1361, 11569, 80217
29116, 11480, 1352, 11546, 80187, 1341, 41, 1347, 11464, 11505, 11570, 80261, 80218, 1343, 1349, 11471, 
11466, 11497, 1360, 11571, 80220
29117, 11455, 1336, 1337, 11456, 80180, 11539, 11547, 80188, 11462, 1339, 11463, 11460, 80254, 11573, 80262, 
80222, 80196, 11555, 11572, 80221
29118, 80180, 11539, 11547, 80188, 80181, 11540, 11548, 80189, 80254, 11573, 80262, 80222, 80255, 11575, 80263, 
80225, 80199, 11557, 11574, 80224
29119, 80181, 11540, 11548, 80189, 80182, 11541, 11549, 80190, 80255, 11575, 80263, 80225, 80256, 11577, 80264, 
80228, 80202, 11559, 11576, 80227
29120, 80182, 11541, 11549, 80190, 80183, 11542, 11550, 80191, 80256, 11577, 80264, 80228, 80257, 11579, 80265, 
80231, 80205, 11561, 11578, 80230
29121, 80183, 11542, 11550, 80191, 80184, 11543, 11551, 80192, 80257, 11579, 80265, 80231, 80258, 11581, 80266, 
80234, 80208, 11563, 11580, 80233
29122, 80184, 11543, 11551, 80192, 80185, 11544, 11552, 80193, 80258, 11581, 80266, 80234, 80259, 11583, 80267, 
80237, 80211, 11565, 11582, 80236
29123, 80185, 11544, 11552, 80193, 80186, 11545, 11553, 80194, 80259, 11583, 80267, 80237, 80260, 11585, 80268, 
80240, 80214, 11567, 11584, 80239
29124, 80186, 11545, 11553, 80194, 80187, 11546, 11554, 80195, 80260, 11585, 80268, 80240, 80261, 11587, 80269, 
80243, 80217, 11569, 11586, 80242
29125, 80187, 11546, 11554, 80195, 11464, 1347, 1348, 11465, 80261, 11587, 80269, 80243, 11471, 1350, 11472, 
11468, 80220, 11571, 11588, 80245
29126, 11456, 1337, 40, 1333, 80188, 11547, 1376, 11506, 11463, 1340, 1335, 11461, 80262, 11589, 11531, 
80246, 80221, 11572, 1385, 11515
29127, 80188, 11547, 1376, 11506, 80189, 11548, 1375, 11507, 80262, 11589, 11531, 80246, 80263, 11590, 11532, 
80247, 80224, 11574, 1384, 11517
29128, 80189, 11548, 1375, 11507, 80190, 11549, 1374, 11508, 80263, 11590, 11532, 80247, 80264, 11591, 11533, 
80248, 80227, 11576, 1383, 11519
29129, 80190, 11549, 1374, 11508, 80191, 11550, 1373, 11509, 80264, 11591, 11533, 80248, 80265, 11592, 11534, 
80249, 80230, 11578, 1382, 11521
29130, 80191, 11550, 1373, 11509, 80192, 11551, 1372, 11510, 80265, 11592, 11534, 80249, 80266, 11593, 11535, 
80250, 80233, 11580, 1381, 11523
29131, 80192, 11551, 1372, 11510, 80193, 11552, 1371, 11511, 80266, 11593, 11535, 80250, 80267, 11594, 11536, 
80251, 80236, 11582, 1380, 11525
29132, 80193, 11552, 1371, 11511, 80194, 11553, 1370, 11512, 80267, 11594, 11536, 80251, 80268, 11595, 11537, 
80252, 80239, 11584, 1379, 11527
29133, 80194, 11553, 1370, 11512, 80195, 11554, 1369, 11513, 80268, 11595, 11537, 80252, 80269, 11596, 11538, 
80253, 80242, 11586, 1378, 11529
29134, 80195, 11554, 1369, 11513, 11465, 1348, 42, 1344, 80269, 11596, 11538, 80253, 11472, 1351, 1346, 
11470, 80245, 11588, 1377, 11530
*ELEMENT, type=C3D20, ELSET=Volume13
29135, 5520, 372, 11, 395, 80270, 5512, 375, 5609, 5528, 373, 404, 5529, 80287, 5516, 5651, 
80288, 80286, 5517, 377, 5647
29136, 80270, 5512, 375, 5609, 80271, 5511, 376, 5610, 80287, 5516, 5651, 80288, 80290, 5514, 5652, 
80291, 80289, 5515, 378, 5649
29137, 80271, 5511, 376, 5610, 5553, 369, 9, 432, 80290, 5514, 5652, 80291, 5562, 370, 441, 
5561, 80292, 5513, 379, 5650
29138, 5521, 5520, 395, 394, 80272, 80270, 5609, 5607, 5530, 5529, 403, 5531, 80294, 80288, 5646, 
80295, 80293, 80286, 5647, 5642
29139, 80272, 80270, 5609, 5607, 80273, 80271, 5610, 5608, 80294, 80288, 5646, 80295, 80297, 80291, 5648, 
80298, 80296, 80289, 5649, 5644
29140, 80273, 80271, 5610, 5608, 5554, 5553, 432, 431, 80297, 80291, 5648, 80298, 5564, 5561, 440, 
5563, 80299, 80292, 5650, 5645
29141, 5522, 5521, 394, 393, 80274, 80272, 5607, 5605, 5532, 5531, 402, 5533, 80301, 80295, 5641, 
80302, 80300, 80293, 5642, 5637
29142, 80274, 80272, 5607, 5605, 80275, 80273, 5608, 5606, 80301, 80295, 5641, 80302, 80304, 80298, 5643, 
80305, 80303, 80296, 5644, 5639
29143, 80275, 80273, 5608, 5606, 5555, 5554, 431, 430, 80304, 80298, 5643, 80305, 5566, 5563, 439, 
5565, 80306, 80299, 5645, 5640
29144, 5523, 5522, 393, 392, 80276, 80274, 5605, 5603, 5534, 5533, 401, 5535, 80308, 80302, 5636, 
80309, 80307, 80300, 5637, 5632
29145, 80276, 80274, 5605, 5603, 80277, 80275, 5606, 5604, 80308, 80302, 5636, 80309, 80311, 80305, 5638, 
80312, 80310, 80303, 5639, 5634
29146, 80277, 80275, 5606, 5604, 5556, 5555, 430, 429, 80311, 80305, 5638, 80312, 5568, 5565, 438, 
5567, 80313, 80306, 5640, 5635
29147, 5524, 5523, 392, 391, 80278, 80276, 5603, 5601, 5536, 5535, 400, 5537, 80315, 80309, 5631, 
80316, 80314, 80307, 5632, 5627
29148, 80278, 80276, 5603, 5601, 80279, 80277, 5604, 5602, 80315, 80309, 5631, 80316, 80318, 80312, 5633, 
80319, 80317, 80310, 5634, 5629
29149, 80279, 80277, 5604, 5602, 5557, 5556, 429, 428, 80318, 80312, 5633, 80319, 5570, 5567, 437, 
5569, 80320, 80313, 5635, 5630
29150, 5525, 5524, 391, 390, 80280, 80278, 5601, 5599, 5538, 5537, 399, 5539, 80322, 80316, 5626, 
80323, 80321, 80314, 5627, 5622
29151, 80280, 80278, 5601, 5599, 80281, 80279, 5602, 5600, 80322, 80316, 5626, 80323, 80325, 80319, 5628, 
80326, 80324, 80317, 5629, 5624
29152, 80281, 80279, 5602, 5600, 5558, 5557, 428, 427, 80325, 80319, 5628, 80326, 5572, 5569, 436, 
5571, 80327, 80320, 5630, 5625
29153, 5526, 5525, 390, 389, 80282, 80280, 5599, 5597, 5540, 5539, 398, 5541, 80329, 80323, 5621, 
80330, 80328, 80321, 5622, 5617
29154, 80282, 80280, 5599, 5597, 80283, 80281, 5600, 5598, 80329, 80323, 5621, 80330, 80332, 80326, 5623, 
80333, 80331, 80324, 5624, 5619
29155, 80283, 80281, 5600, 5598, 5559, 5558, 427, 426, 80332, 80326, 5623, 80333, 5574, 5571, 435, 
5573, 80334, 80327, 5625, 5620
29156, 5527, 5526, 389, 388, 80284, 80282, 5597, 5595, 5542, 5541, 397, 5543, 80336, 80330, 5616, 
80337, 80335, 80328, 5617, 5612
29157, 80284, 80282, 5597, 5595, 80285, 80283, 5598, 5596, 80336, 80330, 5616, 80337, 80339, 80333, 5618, 
80340, 80338, 80331, 5619, 5614
29158, 80285, 80283, 5598, 5596, 5560, 5559, 426, 425, 80339, 80333, 5618, 80340, 5576, 5573, 434, 
5575, 80341, 80334, 5620, 5615
29159, 385, 5527, 388, 13, 5587, 80284, 5595, 459, 5544, 5543, 396, 386, 80342, 80337, 5611, 
5590, 5592, 80335, 5612, 461
29160, 5587, 80284, 5595, 459, 5586, 80285, 5596, 460, 80342, 80337, 5611, 5590, 80343, 80340, 5613, 
5588, 5591, 80338, 5614, 462
29161, 5586, 80285, 5596, 460, 422, 5560, 425, 15, 80343, 80340, 5613, 5588, 5577, 5575, 433, 
423, 5589, 80341, 5615, 463
29162, 412, 12, 372, 5520, 5667, 380, 5512, 80270, 421, 374, 5528, 5545, 5709, 5519, 80287, 
80344, 5704, 382, 5517, 80286
29163, 5667, 380, 5512, 80270, 5668, 381, 5511, 80271, 5709, 5519, 80287, 80344, 5710, 5518, 80290, 
80345, 5706, 383, 5515, 80289
29164, 5668, 381, 5511, 80271, 449, 10, 369, 5553, 5710, 5518, 80290, 80345, 458, 371, 5562, 
5578, 5708, 384, 5513, 80292
29165, 411, 412, 5520, 5521, 5665, 5667, 80270, 80272, 420, 5545, 5530, 5546, 5705, 80344, 80294, 
80346, 5699, 5704, 80286, 80293
29166, 5665, 5667, 80270, 80272, 5666, 5668, 80271, 80273, 5705, 80344, 80294, 80346, 5707, 80345, 80297, 
80347, 5701, 5706, 80289, 80296
29167, 5666, 5668, 80271, 80273, 448, 449, 5553, 5554, 5707, 80345, 80297, 80347, 457, 5578, 5564, 
5579, 5703, 5708, 80292, 80299
29168, 410, 411, 5521, 5522, 5663, 5665, 80272, 80274, 419, 5546, 5532, 5547, 5700, 80346, 80301, 
80348, 5694, 5699, 80293, 80300
29169, 5663, 5665, 80272, 80274, 5664, 5666, 80273, 80275, 5700, 80346, 80301, 80348, 5702, 80347, 80304, 
80349, 5696, 5701, 80296, 80303
29170, 5664, 5666, 80273, 80275, 447, 448, 5554, 5555, 5702, 80347, 80304, 80349, 456, 5579, 5566, 
5580, 5698, 5703, 80299, 80306
29171, 409, 410, 5522, 5523, 5661, 5663, 80274, 80276, 418, 5547, 5534, 5548, 5695, 80348, 80308, 
80350, 5689, 5694, 80300, 80307
29172, 5661, 5663, 80274, 80276, 5662, 5664, 80275, 80277, 5695, 80348, 80308, 80350, 5697, 80349, 80311, 
80351, 5691, 5696, 80303, 80310
29173, 5662, 5664, 80275, 80277, 446, 447, 5555, 5556, 5697, 80349, 80311, 80351, 455, 5580, 5568, 
5581, 5693, 5698, 80306, 80313
29174, 408, 409, 5523, 5524, 5659, 5661, 80276, 80278, 417, 5548, 5536, 5549, 5690, 80350, 80315, 
80352, 5684, 5689, 80307, 80314
29175, 5659, 5661, 80276, 80278, 5660, 5662, 80277, 80279, 5690, 80350, 80315, 80352, 5692, 80351, 80318, 
80353, 5686, 5691, 80310, 80317
29176, 5660, 5662, 80277, 80279, 445, 446, 5556, 5557, 5692, 80351, 80318, 80353, 454, 5581, 5570, 
5582, 5688, 5693, 80313, 80320
29177, 407, 408, 5524, 5525, 5657, 5659, 80278, 80280, 416, 5549, 5538, 5550, 5685, 80352, 80322, 
80354, 5679, 5684, 80314, 80321
29178, 5657, 5659, 80278, 80280, 5658, 5660, 80279, 80281, 5685, 80352, 80322, 80354, 5687, 80353, 80325, 
80355, 5681, 5686, 80317, 80324
29179, 5658, 5660, 80279, 80281, 444, 445, 5557, 5558, 5687, 80353, 80325, 80355, 453, 5582, 5572, 
5583, 5683, 5688, 80320, 80327
29180, 406, 407, 5525, 5526, 5655, 5657, 80280, 80282, 415, 5550, 5540, 5551, 5680, 80354, 80329, 
80356, 5674, 5679, 80321, 80328
29181, 5655, 5657, 80280, 80282, 5656, 5658, 80281, 80283, 5680, 80354, 80329, 80356, 5682, 80355, 80332, 
80357, 5676, 5681, 80324, 80331
29182, 5656, 5658, 80281, 80283, 443, 444, 5558, 5559, 5682, 80355, 80332, 80357, 452, 5583, 5574, 
5584, 5678, 5683, 80327, 80334
29183, 405, 406, 5526, 5527, 5653, 5655, 80282, 80284, 414, 5551, 5542, 5552, 5675, 80356, 80336, 
80358, 5669, 5674, 80328, 80335
29184, 5653, 5655, 80282, 80284, 5654, 5656, 80283, 80285, 5675, 80356, 80336, 80358, 5677, 80357, 80339, 
80359, 5671, 5676, 80331, 80338
29185, 5654, 5656, 80283, 80285, 442, 443, 5559, 5560, 5677, 80357, 80339, 80359, 451, 5584, 5576, 
5585, 5673, 5678, 80334, 80341
29186, 14, 405, 5527, 385, 464, 5653, 80284, 5587, 413, 5552, 5544, 387, 5670, 80358, 80342, 
5594, 466, 5669, 80335, 5592
29187, 464, 5653, 80284, 5587, 465, 5654, 80285, 5586, 5670, 80358, 80342, 5594, 5672, 80359, 80343, 
5593, 467, 5671, 80338, 5591
29188, 465, 5654, 80285, 5586, 16, 442, 5560, 422, 5672, 80359, 80343, 5593, 450, 5585, 5577, 
424, 468, 5673, 80341, 5589
*ELEMENT, type=C3D20, ELSET=Volume20
29189, 46, 1784, 13868, 1499, 1545, 13626, 80360, 12893, 1787, 13935, 13934, 1522, 13658, 80889, 80890, 
13275, 1553, 13659, 80888, 13259
29190, 1545, 13626, 80360, 12893, 1546, 13625, 80361, 12894, 13658, 80889, 80890, 13275, 13656, 80892, 80893, 
13276, 1554, 13657, 80891, 13261
29191, 1546, 13625, 80361, 12894, 1547, 13624, 80362, 12895, 13656, 80892, 80893, 13276, 13654, 80895, 80896, 
13277, 1555, 13655, 80894, 13263
29192, 1547, 13624, 80362, 12895, 1548, 13623, 80363, 12896, 13654, 80895, 80896, 13277, 13652, 80898, 80899, 
13278, 1556, 13653, 80897, 13265
29193, 1548, 13623, 80363, 12896, 1549, 13622, 80364, 12897, 13652, 80898, 80899, 13278, 13650, 80901, 80902, 
13279, 1557, 13651, 80900, 13267
29194, 1549, 13622, 80364, 12897, 1550, 13621, 80365, 12898, 13650, 80901, 80902, 13279, 13648, 80904, 80905, 
13280, 1558, 13649, 80903, 13269
29195, 1550, 13621, 80365, 12898, 1551, 13620, 80366, 12899, 13648, 80904, 80905, 13280, 13646, 80907, 80908, 
13281, 1559, 13647, 80906, 13271
29196, 1551, 13620, 80366, 12899, 1552, 13619, 80367, 12900, 13646, 80907, 80908, 13281, 13644, 80910, 80911, 
13282, 1560, 13645, 80909, 13273
29197, 1552, 13619, 80367, 12900, 50, 1763, 14091, 1633, 13644, 80910, 80911, 13282, 1766, 14157, 14158, 
1656, 1561, 13643, 80912, 13274
29198, 1499, 13868, 13869, 1498, 12893, 80360, 80368, 12885, 13934, 13937, 13936, 1521, 80890, 80914, 80915, 
13258, 13259, 80888, 80913, 13242
29199, 12893, 80360, 80368, 12885, 12894, 80361, 80369, 12886, 80890, 80914, 80915, 13258, 80893, 80917, 80918, 
13260, 13261, 80891, 80916, 13244
29200, 12894, 80361, 80369, 12886, 12895, 80362, 80370, 12887, 80893, 80917, 80918, 13260, 80896, 80920, 80921, 
13262, 13263, 80894, 80919, 13246
29201, 12895, 80362, 80370, 12887, 12896, 80363, 80371, 12888, 80896, 80920, 80921, 13262, 80899, 80923, 80924, 
13264, 13265, 80897, 80922, 13248
29202, 12896, 80363, 80371, 12888, 12897, 80364, 80372, 12889, 80899, 80923, 80924, 13264, 80902, 80926, 80927, 
13266, 13267, 80900, 80925, 13250
29203, 12897, 80364, 80372, 12889, 12898, 80365, 80373, 12890, 80902, 80926, 80927, 13266, 80905, 80929, 80930, 
13268, 13269, 80903, 80928, 13252
29204, 12898, 80365, 80373, 12890, 12899, 80366, 80374, 12891, 80905, 80929, 80930, 13268, 80908, 80932, 80933, 
13270, 13271, 80906, 80931, 13254
29205, 12899, 80366, 80374, 12891, 12900, 80367, 80375, 12892, 80908, 80932, 80933, 13270, 80911, 80935, 80936, 
13272, 13273, 80909, 80934, 13256
29206, 12900, 80367, 80375, 12892, 1633, 14091, 14092, 1632, 80911, 80935, 80936, 13272, 14158, 14159, 14160, 
1655, 13274, 80912, 80937, 13257
29207, 1498, 13869, 13870, 1497, 12885, 80368, 80376, 12877, 13936, 13939, 13938, 1520, 80915, 80939, 80940, 
13241, 13242, 80913, 80938, 13225
29208, 12885, 80368, 80376, 12877, 12886, 80369, 80377, 12878, 80915, 80939, 80940, 13241, 80918, 80942, 80943, 
13243, 13244, 80916, 80941, 13227
29209, 12886, 80369, 80377, 12878, 12887, 80370, 80378, 12879, 80918, 80942, 80943, 13243, 80921, 80945, 80946, 
13245, 13246, 80919, 80944, 13229
29210, 12887, 80370, 80378, 12879, 12888, 80371, 80379, 12880, 80921, 80945, 80946, 13245, 80924, 80948, 80949, 
13247, 13248, 80922, 80947, 13231
29211, 12888, 80371, 80379, 12880, 12889, 80372, 80380, 12881, 80924, 80948, 80949, 13247, 80927, 80951, 80952, 
13249, 13250, 80925, 80950, 13233
29212, 12889, 80372, 80380, 12881, 12890, 80373, 80381, 12882, 80927, 80951, 80952, 13249, 80930, 80954, 80955, 
13251, 13252, 80928, 80953, 13235
29213, 12890, 80373, 80381, 12882, 12891, 80374, 80382, 12883, 80930, 80954, 80955, 13251, 80933, 80957, 80958, 
13253, 13254, 80931, 80956, 13237
29214, 12891, 80374, 80382, 12883, 12892, 80375, 80383, 12884, 80933, 80957, 80958, 13253, 80936, 80960, 80961, 
13255, 13256, 80934, 80959, 13239
29215, 12892, 80375, 80383, 12884, 1632, 14092, 14093, 1631, 80936, 80960, 80961, 13255, 14160, 14161, 14162, 
1654, 13257, 80937, 80962, 13240
29216, 1497, 13870, 13871, 1496, 12877, 80376, 80384, 12869, 13938, 13941, 13940, 1519, 80940, 80964, 80965, 
13224, 13225, 80938, 80963, 13208
29217, 12877, 80376, 80384, 12869, 12878, 80377, 80385, 12870, 80940, 80964, 80965, 13224, 80943, 80967, 80968, 
13226, 13227, 80941, 80966, 13210
29218, 12878, 80377, 80385, 12870, 12879, 80378, 80386, 12871, 80943, 80967, 80968, 13226, 80946, 80970, 80971, 
13228, 13229, 80944, 80969, 13212
29219, 12879, 80378, 80386, 12871, 12880, 80379, 80387, 12872, 80946, 80970, 80971, 13228, 80949, 80973, 80974, 
13230, 13231, 80947, 80972, 13214
29220, 12880, 80379, 80387, 12872, 12881, 80380, 80388, 12873, 80949, 80973, 80974, 13230, 80952, 80976, 80977, 
13232, 13233, 80950, 80975, 13216
29221, 12881, 80380, 80388, 12873, 12882, 80381, 80389, 12874, 80952, 80976, 80977, 13232, 80955, 80979, 80980, 
13234, 13235, 80953, 80978, 13218
29222, 12882, 80381, 80389, 12874, 12883, 80382, 80390, 12875, 80955, 80979, 80980, 13234, 80958, 80982, 80983, 
13236, 13237, 80956, 80981, 13220
29223, 12883, 80382, 80390, 12875, 12884, 80383, 80391, 12876, 80958, 80982, 80983, 13236, 80961, 80985, 80986, 
13238, 13239, 80959, 80984, 13222
29224, 12884, 80383, 80391, 12876, 1631, 14093, 14094, 1630, 80961, 80985, 80986, 13238, 14162, 14163, 14164, 
1653, 13240, 80962, 80987, 13223
29225, 1496, 13871, 13872, 1495, 12869, 80384, 80392, 12861, 13940, 13943, 13942, 1518, 80965, 80989, 80990, 
13207, 13208, 80963, 80988, 13191
29226, 12869, 80384, 80392, 12861, 12870, 80385, 80393, 12862, 80965, 80989, 80990, 13207, 80968, 80992, 80993, 
13209, 13210, 80966, 80991, 13193
29227, 12870, 80385, 80393, 12862, 12871, 80386, 80394, 12863, 80968, 80992, 80993, 13209, 80971, 80995, 80996, 
13211, 13212, 80969, 80994, 13195
29228, 12871, 80386, 80394, 12863, 12872, 80387, 80395, 12864, 80971, 80995, 80996, 13211, 80974, 80998, 80999, 
13213, 13214, 80972, 80997, 13197
29229, 12872, 80387, 80395, 12864, 12873, 80388, 80396, 12865, 80974, 80998, 80999, 13213, 80977, 81001, 81002, 
13215, 13216, 80975, 81000, 13199
29230, 12873, 80388, 80396, 12865, 12874, 80389, 80397, 12866, 80977, 81001, 81002, 13215, 80980, 81004, 81005, 
13217, 13218, 80978, 81003, 13201
29231, 12874, 80389, 80397, 12866, 12875, 80390, 80398, 12867, 80980, 81004, 81005, 13217, 80983, 81007, 81008, 
13219, 13220, 80981, 81006, 13203
29232, 12875, 80390, 80398, 12867, 12876, 80391, 80399, 12868, 80983, 81007, 81008, 13219, 80986, 81010, 81011, 
13221, 13222, 80984, 81009, 13205
29233, 12876, 80391, 80399, 12868, 1630, 14094, 14095, 1629, 80986, 81010, 81011, 13221, 14164, 14165, 14166, 
1652, 13223, 80987, 81012, 13206
29234, 1495, 13872, 13873, 1494, 12861, 80392, 80400, 12853, 13942, 13945, 13944, 1517, 80990, 81014, 81015, 
13190, 13191, 80988, 81013, 13174
29235, 12861, 80392, 80400, 12853, 12862, 80393, 80401, 12854, 80990, 81014, 81015, 13190, 80993, 81017, 81018, 
13192, 13193, 80991, 81016, 13176
29236, 12862, 80393, 80401, 12854, 12863, 80394, 80402, 12855, 80993, 81017, 81018, 13192, 80996, 81020, 81021, 
13194, 13195, 80994, 81019, 13178
29237, 12863, 80394, 80402, 12855, 12864, 80395, 80403, 12856, 80996, 81020, 81021, 13194, 80999, 81023, 81024, 
13196, 13197, 80997, 81022, 13180
29238, 12864, 80395, 80403, 12856, 12865, 80396, 80404, 12857, 80999, 81023, 81024, 13196, 81002, 81026, 81027, 
13198, 13199, 81000, 81025, 13182
29239, 12865, 80396, 80404, 12857, 12866, 80397, 80405, 12858, 81002, 81026, 81027, 13198, 81005, 81029, 81030, 
13200, 13201, 81003, 81028, 13184
29240, 12866, 80397, 80405, 12858, 12867, 80398, 80406, 12859, 81005, 81029, 81030, 13200, 81008, 81032, 81033, 
13202, 13203, 81006, 81031, 13186
29241, 12867, 80398, 80406, 12859, 12868, 80399, 80407, 12860, 81008, 81032, 81033, 13202, 81011, 81035, 81036, 
13204, 13205, 81009, 81034, 13188
29242, 12868, 80399, 80407, 12860, 1629, 14095, 14096, 1628, 81011, 81035, 81036, 13204, 14166, 14167, 14168, 
1651, 13206, 81012, 81037, 13189
29243, 1494, 13873, 13874, 1493, 12853, 80400, 80408, 12845, 13944, 13947, 13946, 1516, 81015, 81039, 81040, 
13173, 13174, 81013, 81038, 13157
29244, 12853, 80400, 80408, 12845, 12854, 80401, 80409, 12846, 81015, 81039, 81040, 13173, 81018, 81042, 81043, 
13175, 13176, 81016, 81041, 13159
29245, 12854, 80401, 80409, 12846, 12855, 80402, 80410, 12847, 81018, 81042, 81043, 13175, 81021, 81045, 81046, 
13177, 13178, 81019, 81044, 13161
29246, 12855, 80402, 80410, 12847, 12856, 80403, 80411, 12848, 81021, 81045, 81046, 13177, 81024, 81048, 81049, 
13179, 13180, 81022, 81047, 13163
29247, 12856, 80403, 80411, 12848, 12857, 80404, 80412, 12849, 81024, 81048, 81049, 13179, 81027, 81051, 81052, 
13181, 13182, 81025, 81050, 13165
29248, 12857, 80404, 80412, 12849, 12858, 80405, 80413, 12850, 81027, 81051, 81052, 13181, 81030, 81054, 81055, 
13183, 13184, 81028, 81053, 13167
29249, 12858, 80405, 80413, 12850, 12859, 80406, 80414, 12851, 81030, 81054, 81055, 13183, 81033, 81057, 81058, 
13185, 13186, 81031, 81056, 13169
29250, 12859, 80406, 80414, 12851, 12860, 80407, 80415, 12852, 81033, 81057, 81058, 13185, 81036, 81060, 81061, 
13187, 13188, 81034, 81059, 13171
29251, 12860, 80407, 80415, 12852, 1628, 14096, 14097, 1627, 81036, 81060, 81061, 13187, 14168, 14169, 14170, 
1650, 13189, 81037, 81062, 13172
29252, 1493, 13874, 13875, 1492, 12845, 80408, 80416, 12837, 13946, 13949, 13948, 1515, 81040, 81064, 81065, 
13156, 13157, 81038, 81063, 13140
29253, 12845, 80408, 80416, 12837, 12846, 80409, 80417, 12838, 81040, 81064, 81065, 13156, 81043, 81067, 81068, 
13158, 13159, 81041, 81066, 13142
29254, 12846, 80409, 80417, 12838, 12847, 80410, 80418, 12839, 81043, 81067, 81068, 13158, 81046, 81070, 81071, 
13160, 13161, 81044, 81069, 13144
29255, 12847, 80410, 80418, 12839, 12848, 80411, 80419, 12840, 81046, 81070, 81071, 13160, 81049, 81073, 81074, 
13162, 13163, 81047, 81072, 13146
29256, 12848, 80411, 80419, 12840, 12849, 80412, 80420, 12841, 81049, 81073, 81074, 13162, 81052, 81076, 81077, 
13164, 13165, 81050, 81075, 13148
29257, 12849, 80412, 80420, 12841, 12850, 80413, 80421, 12842, 81052, 81076, 81077, 13164, 81055, 81079, 81080, 
13166, 13167, 81053, 81078, 13150
29258, 12850, 80413, 80421, 12842, 12851, 80414, 80422, 12843, 81055, 81079, 81080, 13166, 81058, 81082, 81083, 
13168, 13169, 81056, 81081, 13152
29259, 12851, 80414, 80422, 12843, 12852, 80415, 80423, 12844, 81058, 81082, 81083, 13168, 81061, 81085, 81086, 
13170, 13171, 81059, 81084, 13154
29260, 12852, 80415, 80423, 12844, 1627, 14097, 14098, 1626, 81061, 81085, 81086, 13170, 14170, 14171, 14172, 
1649, 13172, 81062, 81087, 13155
29261, 1492, 13875, 13876, 1491, 12837, 80416, 80424, 12829, 13948, 13951, 13950, 1514, 81065, 81089, 81090, 
13139, 13140, 81063, 81088, 13123
29262, 12837, 80416, 80424, 12829, 12838, 80417, 80425, 12830, 81065, 81089, 81090, 13139, 81068, 81092, 81093, 
13141, 13142, 81066, 81091, 13125
29263, 12838, 80417, 80425, 12830, 12839, 80418, 80426, 12831, 81068, 81092, 81093, 13141, 81071, 81095, 81096, 
13143, 13144, 81069, 81094, 13127
29264, 12839, 80418, 80426, 12831, 12840, 80419, 80427, 12832, 81071, 81095, 81096, 13143, 81074, 81098, 81099, 
13145, 13146, 81072, 81097, 13129
29265, 12840, 80419, 80427, 12832, 12841, 80420, 80428, 12833, 81074, 81098, 81099, 13145, 81077, 81101, 81102, 
13147, 13148, 81075, 81100, 13131
29266, 12841, 80420, 80428, 12833, 12842, 80421, 80429, 12834, 81077, 81101, 81102, 13147, 81080, 81104, 81105, 
13149, 13150, 81078, 81103, 13133
29267, 12842, 80421, 80429, 12834, 12843, 80422, 80430, 12835, 81080, 81104, 81105, 13149, 81083, 81107, 81108, 
13151, 13152, 81081, 81106, 13135
29268, 12843, 80422, 80430, 12835, 12844, 80423, 80431, 12836, 81083, 81107, 81108, 13151, 81086, 81110, 81111, 
13153, 13154, 81084, 81109, 13137
29269, 12844, 80423, 80431, 12836, 1626, 14098, 14099, 1625, 81086, 81110, 81111, 13153, 14172, 14173, 14174, 
1648, 13155, 81087, 81112, 13138
29270, 1491, 13876, 13877, 1490, 12829, 80424, 80432, 12821, 13950, 13953, 13952, 1513, 81090, 81114, 81115, 
13122, 13123, 81088, 81113, 13106
29271, 12829, 80424, 80432, 12821, 12830, 80425, 80433, 12822, 81090, 81114, 81115, 13122, 81093, 81117, 81118, 
13124, 13125, 81091, 81116, 13108
29272, 12830, 80425, 80433, 12822, 12831, 80426, 80434, 12823, 81093, 81117, 81118, 13124, 81096, 81120, 81121, 
13126, 13127, 81094, 81119, 13110
29273, 12831, 80426, 80434, 12823, 12832, 80427, 80435, 12824, 81096, 81120, 81121, 13126, 81099, 81123, 81124, 
13128, 13129, 81097, 81122, 13112
29274, 12832, 80427, 80435, 12824, 12833, 80428, 80436, 12825, 81099, 81123, 81124, 13128, 81102, 81126, 81127, 
13130, 13131, 81100, 81125, 13114
29275, 12833, 80428, 80436, 12825, 12834, 80429, 80437, 12826, 81102, 81126, 81127, 13130, 81105, 81129, 81130, 
13132, 13133, 81103, 81128, 13116
29276, 12834, 80429, 80437, 12826, 12835, 80430, 80438, 12827, 81105, 81129, 81130, 13132, 81108, 81132, 81133, 
13134, 13135, 81106, 81131, 13118
29277, 12835, 80430, 80438, 12827, 12836, 80431, 80439, 12828, 81108, 81132, 81133, 13134, 81111, 81135, 81136, 
13136, 13137, 81109, 81134, 13120
29278, 12836, 80431, 80439, 12828, 1625, 14099, 14100, 1624, 81111, 81135, 81136, 13136, 14174, 14175, 14176, 
1647, 13138, 81112, 81137, 13121
29279, 1490, 13877, 13878, 1489, 12821, 80432, 80440, 12813, 13952, 13955, 13954, 1512, 81115, 81139, 81140, 
13105, 13106, 81113, 81138, 13089
29280, 12821, 80432, 80440, 12813, 12822, 80433, 80441, 12814, 81115, 81139, 81140, 13105, 81118, 81142, 81143, 
13107, 13108, 81116, 81141, 13091
29281, 12822, 80433, 80441, 12814, 12823, 80434, 80442, 12815, 81118, 81142, 81143, 13107, 81121, 81145, 81146, 
13109, 13110, 81119, 81144, 13093
29282, 12823, 80434, 80442, 12815, 12824, 80435, 80443, 12816, 81121, 81145, 81146, 13109, 81124, 81148, 81149, 
13111, 13112, 81122, 81147, 13095
29283, 12824, 80435, 80443, 12816, 12825, 80436, 80444, 12817, 81124, 81148, 81149, 13111, 81127, 81151, 81152, 
13113, 13114, 81125, 81150, 13097
29284, 12825, 80436, 80444, 12817, 12826, 80437, 80445, 12818, 81127, 81151, 81152, 13113, 81130, 81154, 81155, 
13115, 13116, 81128, 81153, 13099
29285, 12826, 80437, 80445, 12818, 12827, 80438, 80446, 12819, 81130, 81154, 81155, 13115, 81133, 81157, 81158, 
13117, 13118, 81131, 81156, 13101
29286, 12827, 80438, 80446, 12819, 12828, 80439, 80447, 12820, 81133, 81157, 81158, 13117, 81136, 81160, 81161, 
13119, 13120, 81134, 81159, 13103
29287, 12828, 80439, 80447, 12820, 1624, 14100, 14101, 1623, 81136, 81160, 81161, 13119, 14176, 14177, 14178, 
1646, 13121, 81137, 81162, 13104
29288, 1489, 13878, 13879, 1488, 12813, 80440, 80448, 12805, 13954, 13957, 13956, 1511, 81140, 81164, 81165, 
13088, 13089, 81138, 81163, 13072
29289, 12813, 80440, 80448, 12805, 12814, 80441, 80449, 12806, 81140, 81164, 81165, 13088, 81143, 81167, 81168, 
13090, 13091, 81141, 81166, 13074
29290, 12814, 80441, 80449, 12806, 12815, 80442, 80450, 12807, 81143, 81167, 81168, 13090, 81146, 81170, 81171, 
13092, 13093, 81144, 81169, 13076
29291, 12815, 80442, 80450, 12807, 12816, 80443, 80451, 12808, 81146, 81170, 81171, 13092, 81149, 81173, 81174, 
13094, 13095, 81147, 81172, 13078
29292, 12816, 80443, 80451, 12808, 12817, 80444, 80452, 12809, 81149, 81173, 81174, 13094, 81152, 81176, 81177, 
13096, 13097, 81150, 81175, 13080
29293, 12817, 80444, 80452, 12809, 12818, 80445, 80453, 12810, 81152, 81176, 81177, 13096, 81155, 81179, 81180, 
13098, 13099, 81153, 81178, 13082
29294, 12818, 80445, 80453, 12810, 12819, 80446, 80454, 12811, 81155, 81179, 81180, 13098, 81158, 81182, 81183, 
13100, 13101, 81156, 81181, 13084
29295, 12819, 80446, 80454, 12811, 12820, 80447, 80455, 12812, 81158, 81182, 81183, 13100, 81161, 81185, 81186, 
13102, 13103, 81159, 81184, 13086
29296, 12820, 80447, 80455, 12812, 1623, 14101, 14102, 1622, 81161, 81185, 81186, 13102, 14178, 14179, 14180, 
1645, 13104, 81162, 81187, 13087
29297, 1488, 13879, 13880, 1487, 12805, 80448, 80456, 12797, 13956, 13959, 13958, 1510, 81165, 81189, 81190, 
13071, 13072, 81163, 81188, 13055
29298, 12805, 80448, 80456, 12797, 12806, 80449, 80457, 12798, 81165, 81189, 81190, 13071, 81168, 81192, 81193, 
13073, 13074, 81166, 81191, 13057
29299, 12806, 80449, 80457, 12798, 12807, 80450, 80458, 12799, 81168, 81192, 81193, 13073, 81171, 81195, 81196, 
13075, 13076, 81169, 81194, 13059
29300, 12807, 80450, 80458, 12799, 12808, 80451, 80459, 12800, 81171, 81195, 81196, 13075, 81174, 81198, 81199, 
13077, 13078, 81172, 81197, 13061
29301, 12808, 80451, 80459, 12800, 12809, 80452, 80460, 12801, 81174, 81198, 81199, 13077, 81177, 81201, 81202, 
13079, 13080, 81175, 81200, 13063
29302, 12809, 80452, 80460, 12801, 12810, 80453, 80461, 12802, 81177, 81201, 81202, 13079, 81180, 81204, 81205, 
13081, 13082, 81178, 81203, 13065
29303, 12810, 80453, 80461, 12802, 12811, 80454, 80462, 12803, 81180, 81204, 81205, 13081, 81183, 81207, 81208, 
13083, 13084, 81181, 81206, 13067
29304, 12811, 80454, 80462, 12803, 12812, 80455, 80463, 12804, 81183, 81207, 81208, 13083, 81186, 81210, 81211, 
13085, 13086, 81184, 81209, 13069
29305, 12812, 80455, 80463, 12804, 1622, 14102, 14103, 1621, 81186, 81210, 81211, 13085, 14180, 14181, 14182, 
1644, 13087, 81187, 81212, 13070
29306, 1487, 13880, 13881, 1486, 12797, 80456, 80464, 12789, 13958, 13961, 13960, 1509, 81190, 81214, 81215, 
13054, 13055, 81188, 81213, 13038
29307, 12797, 80456, 80464, 12789, 12798, 80457, 80465, 12790, 81190, 81214, 81215, 13054, 81193, 81217, 81218, 
13056, 13057, 81191, 81216, 13040
29308, 12798, 80457, 80465, 12790, 12799, 80458, 80466, 12791, 81193, 81217, 81218, 13056, 81196, 81220, 81221, 
13058, 13059, 81194, 81219, 13042
29309, 12799, 80458, 80466, 12791, 12800, 80459, 80467, 12792, 81196, 81220, 81221, 13058, 81199, 81223, 81224, 
13060, 13061, 81197, 81222, 13044
29310, 12800, 80459, 80467, 12792, 12801, 80460, 80468, 12793, 81199, 81223, 81224, 13060, 81202, 81226, 81227, 
13062, 13063, 81200, 81225, 13046
29311, 12801, 80460, 80468, 12793, 12802, 80461, 80469, 12794, 81202, 81226, 81227, 13062, 81205, 81229, 81230, 
13064, 13065, 81203, 81228, 13048
29312, 12802, 80461, 80469, 12794, 12803, 80462, 80470, 12795, 81205, 81229, 81230, 13064, 81208, 81232, 81233, 
13066, 13067, 81206, 81231, 13050
29313, 12803, 80462, 80470, 12795, 12804, 80463, 80471, 12796, 81208, 81232, 81233, 13066, 81211, 81235, 81236, 
13068, 13069, 81209, 81234, 13052
29314, 12804, 80463, 80471, 12796, 1621, 14103, 14104, 1620, 81211, 81235, 81236, 13068, 14182, 14183, 14184, 
1643, 13070, 81212, 81237, 13053
29315, 1486, 13881, 13882, 1485, 12789, 80464, 80472, 12781, 13960, 13963, 13962, 1508, 81215, 81239, 81240, 
13037, 13038, 81213, 81238, 13021
29316, 12789, 80464, 80472, 12781, 12790, 80465, 80473, 12782, 81215, 81239, 81240, 13037, 81218, 81242, 81243, 
13039, 13040, 81216, 81241, 13023
29317, 12790, 80465, 80473, 12782, 12791, 80466, 80474, 12783, 81218, 81242, 81243, 13039, 81221, 81245, 81246, 
13041, 13042, 81219, 81244, 13025
29318, 12791, 80466, 80474, 12783, 12792, 80467, 80475, 12784, 81221, 81245, 81246, 13041, 81224, 81248, 81249, 
13043, 13044, 81222, 81247, 13027
29319, 12792, 80467, 80475, 12784, 12793, 80468, 80476, 12785, 81224, 81248, 81249, 13043, 81227, 81251, 81252, 
13045, 13046, 81225, 81250, 13029
29320, 12793, 80468, 80476, 12785, 12794, 80469, 80477, 12786, 81227, 81251, 81252, 13045, 81230, 81254, 81255, 
13047, 13048, 81228, 81253, 13031
29321, 12794, 80469, 80477, 12786, 12795, 80470, 80478, 12787, 81230, 81254, 81255, 13047, 81233, 81257, 81258, 
13049, 13050, 81231, 81256, 13033
29322, 12795, 80470, 80478, 12787, 12796, 80471, 80479, 12788, 81233, 81257, 81258, 13049, 81236, 81260, 81261, 
13051, 13052, 81234, 81259, 13035
29323, 12796, 80471, 80479, 12788, 1620, 14104, 14105, 1619, 81236, 81260, 81261, 13051, 14184, 14185, 14186, 
1642, 13053, 81237, 81262, 13036
29324, 1485, 13882, 13883, 1484, 12781, 80472, 80480, 12773, 13962, 13965, 13964, 1507, 81240, 81264, 81265, 
13020, 13021, 81238, 81263, 13004
29325, 12781, 80472, 80480, 12773, 12782, 80473, 80481, 12774, 81240, 81264, 81265, 13020, 81243, 81267, 81268, 
13022, 13023, 81241, 81266, 13006
29326, 12782, 80473, 80481, 12774, 12783, 80474, 80482, 12775, 81243, 81267, 81268, 13022, 81246, 81270, 81271, 
13024, 13025, 81244, 81269, 13008
29327, 12783, 80474, 80482, 12775, 12784, 80475, 80483, 12776, 81246, 81270, 81271, 13024, 81249, 81273, 81274, 
13026, 13027, 81247, 81272, 13010
29328, 12784, 80475, 80483, 12776, 12785, 80476, 80484, 12777, 81249, 81273, 81274, 13026, 81252, 81276, 81277, 
13028, 13029, 81250, 81275, 13012
29329, 12785, 80476, 80484, 12777, 12786, 80477, 80485, 12778, 81252, 81276, 81277, 13028, 81255, 81279, 81280, 
13030, 13031, 81253, 81278, 13014
29330, 12786, 80477, 80485, 12778, 12787, 80478, 80486, 12779, 81255, 81279, 81280, 13030, 81258, 81282, 81283, 
13032, 13033, 81256, 81281, 13016
29331, 12787, 80478, 80486, 12779, 12788, 80479, 80487, 12780, 81258, 81282, 81283, 13032, 81261, 81285, 81286, 
13034, 13035, 81259, 81284, 13018
29332, 12788, 80479, 80487, 12780, 1619, 14105, 14106, 1618, 81261, 81285, 81286, 13034, 14186, 14187, 14188, 
1641, 13036, 81262, 81287, 13019
29333, 1484, 13883, 13884, 1483, 12773, 80480, 80488, 12765, 13964, 13967, 13966, 1506, 81265, 81289, 81290, 
13003, 13004, 81263, 81288, 12987
29334, 12773, 80480, 80488, 12765, 12774, 80481, 80489, 12766, 81265, 81289, 81290, 13003, 81268, 81292, 81293, 
13005, 13006, 81266, 81291, 12989
29335, 12774, 80481, 80489, 12766, 12775, 80482, 80490, 12767, 81268, 81292, 81293, 13005, 81271, 81295, 81296, 
13007, 13008, 81269, 81294, 12991
29336, 12775, 80482, 80490, 12767, 12776, 80483, 80491, 12768, 81271, 81295, 81296, 13007, 81274, 81298, 81299, 
13009, 13010, 81272, 81297, 12993
29337, 12776, 80483, 80491, 12768, 12777, 80484, 80492, 12769, 81274, 81298, 81299, 13009, 81277, 81301, 81302, 
13011, 13012, 81275, 81300, 12995
29338, 12777, 80484, 80492, 12769, 12778, 80485, 80493, 12770, 81277, 81301, 81302, 13011, 81280, 81304, 81305, 
13013, 13014, 81278, 81303, 12997
29339, 12778, 80485, 80493, 12770, 12779, 80486, 80494, 12771, 81280, 81304, 81305, 13013, 81283, 81307, 81308, 
13015, 13016, 81281, 81306, 12999
29340, 12779, 80486, 80494, 12771, 12780, 80487, 80495, 12772, 81283, 81307, 81308, 13015, 81286, 81310, 81311, 
13017, 13018, 81284, 81309, 13001
29341, 12780, 80487, 80495, 12772, 1618, 14106, 14107, 1617, 81286, 81310, 81311, 13017, 14188, 14189, 14190, 
1640, 13019, 81287, 81312, 13002
29342, 1483, 13884, 13885, 1482, 12765, 80488, 80496, 12757, 13966, 13969, 13968, 1505, 81290, 81314, 81315, 
12986, 12987, 81288, 81313, 12970
29343, 12765, 80488, 80496, 12757, 12766, 80489, 80497, 12758, 81290, 81314, 81315, 12986, 81293, 81317, 81318, 
12988, 12989, 81291, 81316, 12972
29344, 12766, 80489, 80497, 12758, 12767, 80490, 80498, 12759, 81293, 81317, 81318, 12988, 81296, 81320, 81321, 
12990, 12991, 81294, 81319, 12974
29345, 12767, 80490, 80498, 12759, 12768, 80491, 80499, 12760, 81296, 81320, 81321, 12990, 81299, 81323, 81324, 
12992, 12993, 81297, 81322, 12976
29346, 12768, 80491, 80499, 12760, 12769, 80492, 80500, 12761, 81299, 81323, 81324, 12992, 81302, 81326, 81327, 
12994, 12995, 81300, 81325, 12978
29347, 12769, 80492, 80500, 12761, 12770, 80493, 80501, 12762, 81302, 81326, 81327, 12994, 81305, 81329, 81330, 
12996, 12997, 81303, 81328, 12980
29348, 12770, 80493, 80501, 12762, 12771, 80494, 80502, 12763, 81305, 81329, 81330, 12996, 81308, 81332, 81333, 
12998, 12999, 81306, 81331, 12982
29349, 12771, 80494, 80502, 12763, 12772, 80495, 80503, 12764, 81308, 81332, 81333, 12998, 81311, 81335, 81336, 
13000, 13001, 81309, 81334, 12984
29350, 12772, 80495, 80503, 12764, 1617, 14107, 14108, 1616, 81311, 81335, 81336, 13000, 14190, 14191, 14192, 
1639, 13002, 81312, 81337, 12985
29351, 1482, 13885, 13886, 1481, 12757, 80496, 80504, 12749, 13968, 13971, 13970, 1504, 81315, 81339, 81340, 
12969, 12970, 81313, 81338, 12953
29352, 12757, 80496, 80504, 12749, 12758, 80497, 80505, 12750, 81315, 81339, 81340, 12969, 81318, 81342, 81343, 
12971, 12972, 81316, 81341, 12955
29353, 12758, 80497, 80505, 12750, 12759, 80498, 80506, 12751, 81318, 81342, 81343, 12971, 81321, 81345, 81346, 
12973, 12974, 81319, 81344, 12957
29354, 12759, 80498, 80506, 12751, 12760, 80499, 80507, 12752, 81321, 81345, 81346, 12973, 81324, 81348, 81349, 
12975, 12976, 81322, 81347, 12959
29355, 12760, 80499, 80507, 12752, 12761, 80500, 80508, 12753, 81324, 81348, 81349, 12975, 81327, 81351, 81352, 
12977, 12978, 81325, 81350, 12961
29356, 12761, 80500, 80508, 12753, 12762, 80501, 80509, 12754, 81327, 81351, 81352, 12977, 81330, 81354, 81355, 
12979, 12980, 81328, 81353, 12963
29357, 12762, 80501, 80509, 12754, 12763, 80502, 80510, 12755, 81330, 81354, 81355, 12979, 81333, 81357, 81358, 
12981, 12982, 81331, 81356, 12965
29358, 12763, 80502, 80510, 12755, 12764, 80503, 80511, 12756, 81333, 81357, 81358, 12981, 81336, 81360, 81361, 
12983, 12984, 81334, 81359, 12967
29359, 12764, 80503, 80511, 12756, 1616, 14108, 14109, 1615, 81336, 81360, 81361, 12983, 14192, 14193, 14194, 
1638, 12985, 81337, 81362, 12968
29360, 1481, 13886, 13887, 1480, 12749, 80504, 80512, 12741, 13970, 13973, 13972, 1503, 81340, 81364, 81365, 
12952, 12953, 81338, 81363, 12936
29361, 12749, 80504, 80512, 12741, 12750, 80505, 80513, 12742, 81340, 81364, 81365, 12952, 81343, 81367, 81368, 
12954, 12955, 81341, 81366, 12938
29362, 12750, 80505, 80513, 12742, 12751, 80506, 80514, 12743, 81343, 81367, 81368, 12954, 81346, 81370, 81371, 
12956, 12957, 81344, 81369, 12940
29363, 12751, 80506, 80514, 12743, 12752, 80507, 80515, 12744, 81346, 81370, 81371, 12956, 81349, 81373, 81374, 
12958, 12959, 81347, 81372, 12942
29364, 12752, 80507, 80515, 12744, 12753, 80508, 80516, 12745, 81349, 81373, 81374, 12958, 81352, 81376, 81377, 
12960, 12961, 81350, 81375, 12944
29365, 12753, 80508, 80516, 12745, 12754, 80509, 80517, 12746, 81352, 81376, 81377, 12960, 81355, 81379, 81380, 
12962, 12963, 81353, 81378, 12946
29366, 12754, 80509, 80517, 12746, 12755, 80510, 80518, 12747, 81355, 81379, 81380, 12962, 81358, 81382, 81383, 
12964, 12965, 81356, 81381, 12948
29367, 12755, 80510, 80518, 12747, 12756, 80511, 80519, 12748, 81358, 81382, 81383, 12964, 81361, 81385, 81386, 
12966, 12967, 81359, 81384, 12950
29368, 12756, 80511, 80519, 12748, 1615, 14109, 14110, 1614, 81361, 81385, 81386, 12966, 14194, 14195, 14196, 
1637, 12968, 81362, 81387, 12951
29369, 1480, 13887, 13888, 1479, 12741, 80512, 80520, 12733, 13972, 13975, 13974, 1502, 81365, 81389, 81390, 
12935, 12936, 81363, 81388, 12919
29370, 12741, 80512, 80520, 12733, 12742, 80513, 80521, 12734, 81365, 81389, 81390, 12935, 81368, 81392, 81393, 
12937, 12938, 81366, 81391, 12921
29371, 12742, 80513, 80521, 12734, 12743, 80514, 80522, 12735, 81368, 81392, 81393, 12937, 81371, 81395, 81396, 
12939, 12940, 81369, 81394, 12923
29372, 12743, 80514, 80522, 12735, 12744, 80515, 80523, 12736, 81371, 81395, 81396, 12939, 81374, 81398, 81399, 
12941, 12942, 81372, 81397, 12925
29373, 12744, 80515, 80523, 12736, 12745, 80516, 80524, 12737, 81374, 81398, 81399, 12941, 81377, 81401, 81402, 
12943, 12944, 81375, 81400, 12927
29374, 12745, 80516, 80524, 12737, 12746, 80517, 80525, 12738, 81377, 81401, 81402, 12943, 81380, 81404, 81405, 
12945, 12946, 81378, 81403, 12929
29375, 12746, 80517, 80525, 12738, 12747, 80518, 80526, 12739, 81380, 81404, 81405, 12945, 81383, 81407, 81408, 
12947, 12948, 81381, 81406, 12931
29376, 12747, 80518, 80526, 12739, 12748, 80519, 80527, 12740, 81383, 81407, 81408, 12947, 81386, 81410, 81411, 
12949, 12950, 81384, 81409, 12933
29377, 12748, 80519, 80527, 12740, 1614, 14110, 14111, 1613, 81386, 81410, 81411, 12949, 14196, 14197, 14198, 
1636, 12951, 81387, 81412, 12934
29378, 1479, 13888, 13889, 1478, 12733, 80520, 80528, 12725, 13974, 13977, 13976, 1501, 81390, 81414, 81415, 
12918, 12919, 81388, 81413, 12902
29379, 12733, 80520, 80528, 12725, 12734, 80521, 80529, 12726, 81390, 81414, 81415, 12918, 81393, 81417, 81418, 
12920, 12921, 81391, 81416, 12904
29380, 12734, 80521, 80529, 12726, 12735, 80522, 80530, 12727, 81393, 81417, 81418, 12920, 81396, 81420, 81421, 
12922, 12923, 81394, 81419, 12906
29381, 12735, 80522, 80530, 12727, 12736, 80523, 80531, 12728, 81396, 81420, 81421, 12922, 81399, 81423, 81424, 
12924, 12925, 81397, 81422, 12908
29382, 12736, 80523, 80531, 12728, 12737, 80524, 80532, 12729, 81399, 81423, 81424, 12924, 81402, 81426, 81427, 
12926, 12927, 81400, 81425, 12910
29383, 12737, 80524, 80532, 12729, 12738, 80525, 80533, 12730, 81402, 81426, 81427, 12926, 81405, 81429, 81430, 
12928, 12929, 81403, 81428, 12912
29384, 12738, 80525, 80533, 12730, 12739, 80526, 80534, 12731, 81405, 81429, 81430, 12928, 81408, 81432, 81433, 
12930, 12931, 81406, 81431, 12914
29385, 12739, 80526, 80534, 12731, 12740, 80527, 80535, 12732, 81408, 81432, 81433, 12930, 81411, 81435, 81436, 
12932, 12933, 81409, 81434, 12916
29386, 12740, 80527, 80535, 12732, 1613, 14111, 14112, 1612, 81411, 81435, 81436, 12932, 14198, 14199, 14200, 
1635, 12934, 81412, 81437, 12917
29387, 1478, 13889, 1839, 48, 12725, 80528, 14321, 1674, 13976, 13978, 1842, 1500, 81415, 81438, 14353, 
12901, 12902, 81413, 14354, 1682
29388, 12725, 80528, 14321, 1674, 12726, 80529, 14320, 1675, 81415, 81438, 14353, 12901, 81418, 81439, 14351, 
12903, 12904, 81416, 14352, 1683
29389, 12726, 80529, 14320, 1675, 12727, 80530, 14319, 1676, 81418, 81439, 14351, 12903, 81421, 81440, 14349, 
12905, 12906, 81419, 14350, 1684
29390, 12727, 80530, 14319, 1676, 12728, 80531, 14318, 1677, 81421, 81440, 14349, 12905, 81424, 81441, 14347, 
12907, 12908, 81422, 14348, 1685
29391, 12728, 80531, 14318, 1677, 12729, 80532, 14317, 1678, 81424, 81441, 14347, 12907, 81427, 81442, 14345, 
12909, 12910, 81425, 14346, 1686
29392, 12729, 80532, 14317, 1678, 12730, 80533, 14316, 1679, 81427, 81442, 14345, 12909, 81430, 81443, 14343, 
12911, 12912, 81428, 14344, 1687
29393, 12730, 80533, 14316, 1679, 12731, 80534, 14315, 1680, 81430, 81443, 14343, 12911, 81433, 81444, 14341, 
12913, 12914, 81431, 14342, 1688
29394, 12731, 80534, 14315, 1680, 12732, 80535, 14314, 1681, 81433, 81444, 14341, 12913, 81436, 81445, 14339, 
12915, 12916, 81434, 14340, 1689
29395, 12732, 80535, 14314, 1681, 1612, 14112, 1891, 52, 81436, 81445, 14339, 12915, 14200, 14201, 1894, 
1634, 12917, 81437, 14338, 1690
29396, 1784, 1785, 13890, 13868, 13626, 13634, 80536, 80360, 1788, 13980, 13979, 13935, 13675, 81447, 81448, 
80889, 13659, 13676, 81446, 80888
29397, 13626, 13634, 80536, 80360, 13625, 13633, 80537, 80361, 13675, 81447, 81448, 80889, 13673, 81450, 81451, 
80892, 13657, 13674, 81449, 80891
29398, 13625, 13633, 80537, 80361, 13624, 13632, 80538, 80362, 13673, 81450, 81451, 80892, 13671, 81453, 81454, 
80895, 13655, 13672, 81452, 80894
29399, 13624, 13632, 80538, 80362, 13623, 13631, 80539, 80363, 13671, 81453, 81454, 80895, 13669, 81456, 81457, 
80898, 13653, 13670, 81455, 80897
29400, 13623, 13631, 80539, 80363, 13622, 13630, 80540, 80364, 13669, 81456, 81457, 80898, 13667, 81459, 81460, 
80901, 13651, 13668, 81458, 80900
29401, 13622, 13630, 80540, 80364, 13621, 13629, 80541, 80365, 13667, 81459, 81460, 80901, 13665, 81462, 81463, 
80904, 13649, 13666, 81461, 80903
29402, 13621, 13629, 80541, 80365, 13620, 13628, 80542, 80366, 13665, 81462, 81463, 80904, 13663, 81465, 81466, 
80907, 13647, 13664, 81464, 80906
29403, 13620, 13628, 80542, 80366, 13619, 13627, 80543, 80367, 13663, 81465, 81466, 80907, 13661, 81468, 81469, 
80910, 13645, 13662, 81467, 80909
29404, 13619, 13627, 80543, 80367, 1763, 1764, 14113, 14091, 13661, 81468, 81469, 80910, 1767, 14202, 14203, 
14157, 13643, 13660, 81470, 80912
29405, 13868, 13890, 13891, 13869, 80360, 80536, 80544, 80368, 13979, 13982, 13981, 13937, 81448, 81472, 81473, 
80914, 80888, 81446, 81471, 80913
29406, 80360, 80536, 80544, 80368, 80361, 80537, 80545, 80369, 81448, 81472, 81473, 80914, 81451, 81475, 81476, 
80917, 80891, 81449, 81474, 80916
29407, 80361, 80537, 80545, 80369, 80362, 80538, 80546, 80370, 81451, 81475, 81476, 80917, 81454, 81478, 81479, 
80920, 80894, 81452, 81477, 80919
29408, 80362, 80538, 80546, 80370, 80363, 80539, 80547, 80371, 81454, 81478, 81479, 80920, 81457, 81481, 81482, 
80923, 80897, 81455, 81480, 80922
29409, 80363, 80539, 80547, 80371, 80364, 80540, 80548, 80372, 81457, 81481, 81482, 80923, 81460, 81484, 81485, 
80926, 80900, 81458, 81483, 80925
29410, 80364, 80540, 80548, 80372, 80365, 80541, 80549, 80373, 81460, 81484, 81485, 80926, 81463, 81487, 81488, 
80929, 80903, 81461, 81486, 80928
29411, 80365, 80541, 80549, 80373, 80366, 80542, 80550, 80374, 81463, 81487, 81488, 80929, 81466, 81490, 81491, 
80932, 80906, 81464, 81489, 80931
29412, 80366, 80542, 80550, 80374, 80367, 80543, 80551, 80375, 81466, 81490, 81491, 80932, 81469, 81493, 81494, 
80935, 80909, 81467, 81492, 80934
29413, 80367, 80543, 80551, 80375, 14091, 14113, 14114, 14092, 81469, 81493, 81494, 80935, 14203, 14204, 14205, 
14159, 80912, 81470, 81495, 80937
29414, 13869, 13891, 13892, 13870, 80368, 80544, 80552, 80376, 13981, 13984, 13983, 13939, 81473, 81497, 81498, 
80939, 80913, 81471, 81496, 80938
29415, 80368, 80544, 80552, 80376, 80369, 80545, 80553, 80377, 81473, 81497, 81498, 80939, 81476, 81500, 81501, 
80942, 80916, 81474, 81499, 80941
29416, 80369, 80545, 80553, 80377, 80370, 80546, 80554, 80378, 81476, 81500, 81501, 80942, 81479, 81503, 81504, 
80945, 80919, 81477, 81502, 80944
29417, 80370, 80546, 80554, 80378, 80371, 80547, 80555, 80379, 81479, 81503, 81504, 80945, 81482, 81506, 81507, 
80948, 80922, 81480, 81505, 80947
29418, 80371, 80547, 80555, 80379, 80372, 80548, 80556, 80380, 81482, 81506, 81507, 80948, 81485, 81509, 81510, 
80951, 80925, 81483, 81508, 80950
29419, 80372, 80548, 80556, 80380, 80373, 80549, 80557, 80381, 81485, 81509, 81510, 80951, 81488, 81512, 81513, 
80954, 80928, 81486, 81511, 80953
29420, 80373, 80549, 80557, 80381, 80374, 80550, 80558, 80382, 81488, 81512, 81513, 80954, 81491, 81515, 81516, 
80957, 80931, 81489, 81514, 80956
29421, 80374, 80550, 80558, 80382, 80375, 80551, 80559, 80383, 81491, 81515, 81516, 80957, 81494, 81518, 81519, 
80960, 80934, 81492, 81517, 80959
29422, 80375, 80551, 80559, 80383, 14092, 14114, 14115, 14093, 81494, 81518, 81519, 80960, 14205, 14206, 14207, 
14161, 80937, 81495, 81520, 80962
29423, 13870, 13892, 13893, 13871, 80376, 80552, 80560, 80384, 13983, 13986, 13985, 13941, 81498, 81522, 81523, 
80964, 80938, 81496, 81521, 80963
29424, 80376, 80552, 80560, 80384, 80377, 80553, 80561, 80385, 81498, 81522, 81523, 80964, 81501, 81525, 81526, 
80967, 80941, 81499, 81524, 80966
29425, 80377, 80553, 80561, 80385, 80378, 80554, 80562, 80386, 81501, 81525, 81526, 80967, 81504, 81528, 81529, 
80970, 80944, 81502, 81527, 80969
29426, 80378, 80554, 80562, 80386, 80379, 80555, 80563, 80387, 81504, 81528, 81529, 80970, 81507, 81531, 81532, 
80973, 80947, 81505, 81530, 80972
29427, 80379, 80555, 80563, 80387, 80380, 80556, 80564, 80388, 81507, 81531, 81532, 80973, 81510, 81534, 81535, 
80976, 80950, 81508, 81533, 80975
29428, 80380, 80556, 80564, 80388, 80381, 80557, 80565, 80389, 81510, 81534, 81535, 80976, 81513, 81537, 81538, 
80979, 80953, 81511, 81536, 80978
29429, 80381, 80557, 80565, 80389, 80382, 80558, 80566, 80390, 81513, 81537, 81538, 80979, 81516, 81540, 81541, 
80982, 80956, 81514, 81539, 80981
29430, 80382, 80558, 80566, 80390, 80383, 80559, 80567, 80391, 81516, 81540, 81541, 80982, 81519, 81543, 81544, 
80985, 80959, 81517, 81542, 80984
29431, 80383, 80559, 80567, 80391, 14093, 14115, 14116, 14094, 81519, 81543, 81544, 80985, 14207, 14208, 14209, 
14163, 80962, 81520, 81545, 80987
29432, 13871, 13893, 13894, 13872, 80384, 80560, 80568, 80392, 13985, 13988, 13987, 13943, 81523, 81547, 81548, 
80989, 80963, 81521, 81546, 80988
29433, 80384, 80560, 80568, 80392, 80385, 80561, 80569, 80393, 81523, 81547, 81548, 80989, 81526, 81550, 81551, 
80992, 80966, 81524, 81549, 80991
29434, 80385, 80561, 80569, 80393, 80386, 80562, 80570, 80394, 81526, 81550, 81551, 80992, 81529, 81553, 81554, 
80995, 80969, 81527, 81552, 80994
29435, 80386, 80562, 80570, 80394, 80387, 80563, 80571, 80395, 81529, 81553, 81554, 80995, 81532, 81556, 81557, 
80998, 80972, 81530, 81555, 80997
29436, 80387, 80563, 80571, 80395, 80388, 80564, 80572, 80396, 81532, 81556, 81557, 80998, 81535, 81559, 81560, 
81001, 80975, 81533, 81558, 81000
29437, 80388, 80564, 80572, 80396, 80389, 80565, 80573, 80397, 81535, 81559, 81560, 81001, 81538, 81562, 81563, 
81004, 80978, 81536, 81561, 81003
29438, 80389, 80565, 80573, 80397, 80390, 80566, 80574, 80398, 81538, 81562, 81563, 81004, 81541, 81565, 81566, 
81007, 80981, 81539, 81564, 81006
29439, 80390, 80566, 80574, 80398, 80391, 80567, 80575, 80399, 81541, 81565, 81566, 81007, 81544, 81568, 81569, 
81010, 80984, 81542, 81567, 81009
29440, 80391, 80567, 80575, 80399, 14094, 14116, 14117, 14095, 81544, 81568, 81569, 81010, 14209, 14210, 14211, 
14165, 80987, 81545, 81570, 81012
29441, 13872, 13894, 13895, 13873, 80392, 80568, 80576, 80400, 13987, 13990, 13989, 13945, 81548, 81572, 81573, 
81014, 80988, 81546, 81571, 81013
29442, 80392, 80568, 80576, 80400, 80393, 80569, 80577, 80401, 81548, 81572, 81573, 81014, 81551, 81575, 81576, 
81017, 80991, 81549, 81574, 81016
29443, 80393, 80569, 80577, 80401, 80394, 80570, 80578, 80402, 81551, 81575, 81576, 81017, 81554, 81578, 81579, 
81020, 80994, 81552, 81577, 81019
29444, 80394, 80570, 80578, 80402, 80395, 80571, 80579, 80403, 81554, 81578, 81579, 81020, 81557, 81581, 81582, 
81023, 80997, 81555, 81580, 81022
29445, 80395, 80571, 80579, 80403, 80396, 80572, 80580, 80404, 81557, 81581, 81582, 81023, 81560, 81584, 81585, 
81026, 81000, 81558, 81583, 81025
29446, 80396, 80572, 80580, 80404, 80397, 80573, 80581, 80405, 81560, 81584, 81585, 81026, 81563, 81587, 81588, 
81029, 81003, 81561, 81586, 81028
29447, 80397, 80573, 80581, 80405, 80398, 80574, 80582, 80406, 81563, 81587, 81588, 81029, 81566, 81590, 81591, 
81032, 81006, 81564, 81589, 81031
29448, 80398, 80574, 80582, 80406, 80399, 80575, 80583, 80407, 81566, 81590, 81591, 81032, 81569, 81593, 81594, 
81035, 81009, 81567, 81592, 81034
29449, 80399, 80575, 80583, 80407, 14095, 14117, 14118, 14096, 81569, 81593, 81594, 81035, 14211, 14212, 14213, 
14167, 81012, 81570, 81595, 81037
29450, 13873, 13895, 13896, 13874, 80400, 80576, 80584, 80408, 13989, 13992, 13991, 13947, 81573, 81597, 81598, 
81039, 81013, 81571, 81596, 81038
29451, 80400, 80576, 80584, 80408, 80401, 80577, 80585, 80409, 81573, 81597, 81598, 81039, 81576, 81600, 81601, 
81042, 81016, 81574, 81599, 81041
29452, 80401, 80577, 80585, 80409, 80402, 80578, 80586, 80410, 81576, 81600, 81601, 81042, 81579, 81603, 81604, 
81045, 81019, 81577, 81602, 81044
29453, 80402, 80578, 80586, 80410, 80403, 80579, 80587, 80411, 81579, 81603, 81604, 81045, 81582, 81606, 81607, 
81048, 81022, 81580, 81605, 81047
29454, 80403, 80579, 80587, 80411, 80404, 80580, 80588, 80412, 81582, 81606, 81607, 81048, 81585, 81609, 81610, 
81051, 81025, 81583, 81608, 81050
29455, 80404, 80580, 80588, 80412, 80405, 80581, 80589, 80413, 81585, 81609, 81610, 81051, 81588, 81612, 81613, 
81054, 81028, 81586, 81611, 81053
29456, 80405, 80581, 80589, 80413, 80406, 80582, 80590, 80414, 81588, 81612, 81613, 81054, 81591, 81615, 81616, 
81057, 81031, 81589, 81614, 81056
29457, 80406, 80582, 80590, 80414, 80407, 80583, 80591, 80415, 81591, 81615, 81616, 81057, 81594, 81618, 81619, 
81060, 81034, 81592, 81617, 81059
29458, 80407, 80583, 80591, 80415, 14096, 14118, 14119, 14097, 81594, 81618, 81619, 81060, 14213, 14214, 14215, 
14169, 81037, 81595, 81620, 81062
29459, 13874, 13896, 13897, 13875, 80408, 80584, 80592, 80416, 13991, 13994, 13993, 13949, 81598, 81622, 81623, 
81064, 81038, 81596, 81621, 81063
29460, 80408, 80584, 80592, 80416, 80409, 80585, 80593, 80417, 81598, 81622, 81623, 81064, 81601, 81625, 81626, 
81067, 81041, 81599, 81624, 81066
29461, 80409, 80585, 80593, 80417, 80410, 80586, 80594, 80418, 81601, 81625, 81626, 81067, 81604, 81628, 81629, 
81070, 81044, 81602, 81627, 81069
29462, 80410, 80586, 80594, 80418, 80411, 80587, 80595, 80419, 81604, 81628, 81629, 81070, 81607, 81631, 81632, 
81073, 81047, 81605, 81630, 81072
29463, 80411, 80587, 80595, 80419, 80412, 80588, 80596, 80420, 81607, 81631, 81632, 81073, 81610, 81634, 81635, 
81076, 81050, 81608, 81633, 81075
29464, 80412, 80588, 80596, 80420, 80413, 80589, 80597, 80421, 81610, 81634, 81635, 81076, 81613, 81637, 81638, 
81079, 81053, 81611, 81636, 81078
29465, 80413, 80589, 80597, 80421, 80414, 80590, 80598, 80422, 81613, 81637, 81638, 81079, 81616, 81640, 81641, 
81082, 81056, 81614, 81639, 81081
29466, 80414, 80590, 80598, 80422, 80415, 80591, 80599, 80423, 81616, 81640, 81641, 81082, 81619, 81643, 81644, 
81085, 81059, 81617, 81642, 81084
29467, 80415, 80591, 80599, 80423, 14097, 14119, 14120, 14098, 81619, 81643, 81644, 81085, 14215, 14216, 14217, 
14171, 81062, 81620, 81645, 81087
29468, 13875, 13897, 13898, 13876, 80416, 80592, 80600, 80424, 13993, 13996, 13995, 13951, 81623, 81647, 81648, 
81089, 81063, 81621, 81646, 81088
29469, 80416, 80592, 80600, 80424, 80417, 80593, 80601, 80425, 81623, 81647, 81648, 81089, 81626, 81650, 81651, 
81092, 81066, 81624, 81649, 81091
29470, 80417, 80593, 80601, 80425, 80418, 80594, 80602, 80426, 81626, 81650, 81651, 81092, 81629, 81653, 81654, 
81095, 81069, 81627, 81652, 81094
29471, 80418, 80594, 80602, 80426, 80419, 80595, 80603, 80427, 81629, 81653, 81654, 81095, 81632, 81656, 81657, 
81098, 81072, 81630, 81655, 81097
29472, 80419, 80595, 80603, 80427, 80420, 80596, 80604, 80428, 81632, 81656, 81657, 81098, 81635, 81659, 81660, 
81101, 81075, 81633, 81658, 81100
29473, 80420, 80596, 80604, 80428, 80421, 80597, 80605, 80429, 81635, 81659, 81660, 81101, 81638, 81662, 81663, 
81104, 81078, 81636, 81661, 81103
29474, 80421, 80597, 80605, 80429, 80422, 80598, 80606, 80430, 81638, 81662, 81663, 81104, 81641, 81665, 81666, 
81107, 81081, 81639, 81664, 81106
29475, 80422, 80598, 80606, 80430, 80423, 80599, 80607, 80431, 81641, 81665, 81666, 81107, 81644, 81668, 81669, 
81110, 81084, 81642, 81667, 81109
29476, 80423, 80599, 80607, 80431, 14098, 14120, 14121, 14099, 81644, 81668, 81669, 81110, 14217, 14218, 14219, 
14173, 81087, 81645, 81670, 81112
29477, 13876, 13898, 13899, 13877, 80424, 80600, 80608, 80432, 13995, 13998, 13997, 13953, 81648, 81672, 81673, 
81114, 81088, 81646, 81671, 81113
29478, 80424, 80600, 80608, 80432, 80425, 80601, 80609, 80433, 81648, 81672, 81673, 81114, 81651, 81675, 81676, 
81117, 81091, 81649, 81674, 81116
29479, 80425, 80601, 80609, 80433, 80426, 80602, 80610, 80434, 81651, 81675, 81676, 81117, 81654, 81678, 81679, 
81120, 81094, 81652, 81677, 81119
29480, 80426, 80602, 80610, 80434, 80427, 80603, 80611, 80435, 81654, 81678, 81679, 81120, 81657, 81681, 81682, 
81123, 81097, 81655, 81680, 81122
29481, 80427, 80603, 80611, 80435, 80428, 80604, 80612, 80436, 81657, 81681, 81682, 81123, 81660, 81684, 81685, 
81126, 81100, 81658, 81683, 81125
29482, 80428, 80604, 80612, 80436, 80429, 80605, 80613, 80437, 81660, 81684, 81685, 81126, 81663, 81687, 81688, 
81129, 81103, 81661, 81686, 81128
29483, 80429, 80605, 80613, 80437, 80430, 80606, 80614, 80438, 81663, 81687, 81688, 81129, 81666, 81690, 81691, 
81132, 81106, 81664, 81689, 81131
29484, 80430, 80606, 80614, 80438, 80431, 80607, 80615, 80439, 81666, 81690, 81691, 81132, 81669, 81693, 81694, 
81135, 81109, 81667, 81692, 81134
29485, 80431, 80607, 80615, 80439, 14099, 14121, 14122, 14100, 81669, 81693, 81694, 81135, 14219, 14220, 14221, 
14175, 81112, 81670, 81695, 81137
29486, 13877, 13899, 13900, 13878, 80432, 80608, 80616, 80440, 13997, 14000, 13999, 13955, 81673, 81697, 81698, 
81139, 81113, 81671, 81696, 81138
29487, 80432, 80608, 80616, 80440, 80433, 80609, 80617, 80441, 81673, 81697, 81698, 81139, 81676, 81700, 81701, 
81142, 81116, 81674, 81699, 81141
29488, 80433, 80609, 80617, 80441, 80434, 80610, 80618, 80442, 81676, 81700, 81701, 81142, 81679, 81703, 81704, 
81145, 81119, 81677, 81702, 81144
29489, 80434, 80610, 80618, 80442, 80435, 80611, 80619, 80443, 81679, 81703, 81704, 81145, 81682, 81706, 81707, 
81148, 81122, 81680, 81705, 81147
29490, 80435, 80611, 80619, 80443, 80436, 80612, 80620, 80444, 81682, 81706, 81707, 81148, 81685, 81709, 81710, 
81151, 81125, 81683, 81708, 81150
29491, 80436, 80612, 80620, 80444, 80437, 80613, 80621, 80445, 81685, 81709, 81710, 81151, 81688, 81712, 81713, 
81154, 81128, 81686, 81711, 81153
29492, 80437, 80613, 80621, 80445, 80438, 80614, 80622, 80446, 81688, 81712, 81713, 81154, 81691, 81715, 81716, 
81157, 81131, 81689, 81714, 81156
29493, 80438, 80614, 80622, 80446, 80439, 80615, 80623, 80447, 81691, 81715, 81716, 81157, 81694, 81718, 81719, 
81160, 81134, 81692, 81717, 81159
29494, 80439, 80615, 80623, 80447, 14100, 14122, 14123, 14101, 81694, 81718, 81719, 81160, 14221, 14222, 14223, 
14177, 81137, 81695, 81720, 81162
29495, 13878, 13900, 13901, 13879, 80440, 80616, 80624, 80448, 13999, 14002, 14001, 13957, 81698, 81722, 81723, 
81164, 81138, 81696, 81721, 81163
29496, 80440, 80616, 80624, 80448, 80441, 80617, 80625, 80449, 81698, 81722, 81723, 81164, 81701, 81725, 81726, 
81167, 81141, 81699, 81724, 81166
29497, 80441, 80617, 80625, 80449, 80442, 80618, 80626, 80450, 81701, 81725, 81726, 81167, 81704, 81728, 81729, 
81170, 81144, 81702, 81727, 81169
29498, 80442, 80618, 80626, 80450, 80443, 80619, 80627, 80451, 81704, 81728, 81729, 81170, 81707, 81731, 81732, 
81173, 81147, 81705, 81730, 81172
29499, 80443, 80619, 80627, 80451, 80444, 80620, 80628, 80452, 81707, 81731, 81732, 81173, 81710, 81734, 81735, 
81176, 81150, 81708, 81733, 81175
29500, 80444, 80620, 80628, 80452, 80445, 80621, 80629, 80453, 81710, 81734, 81735, 81176, 81713, 81737, 81738, 
81179, 81153, 81711, 81736, 81178
29501, 80445, 80621, 80629, 80453, 80446, 80622, 80630, 80454, 81713, 81737, 81738, 81179, 81716, 81740, 81741, 
81182, 81156, 81714, 81739, 81181
29502, 80446, 80622, 80630, 80454, 80447, 80623, 80631, 80455, 81716, 81740, 81741, 81182, 81719, 81743, 81744, 
81185, 81159, 81717, 81742, 81184
29503, 80447, 80623, 80631, 80455, 14101, 14123, 14124, 14102, 81719, 81743, 81744, 81185, 14223, 14224, 14225, 
14179, 81162, 81720, 81745, 81187
29504, 13879, 13901, 13902, 13880, 80448, 80624, 80632, 80456, 14001, 14004, 14003, 13959, 81723, 81747, 81748, 
81189, 81163, 81721, 81746, 81188
29505, 80448, 80624, 80632, 80456, 80449, 80625, 80633, 80457, 81723, 81747, 81748, 81189, 81726, 81750, 81751, 
81192, 81166, 81724, 81749, 81191
29506, 80449, 80625, 80633, 80457, 80450, 80626, 80634, 80458, 81726, 81750, 81751, 81192, 81729, 81753, 81754, 
81195, 81169, 81727, 81752, 81194
29507, 80450, 80626, 80634, 80458, 80451, 80627, 80635, 80459, 81729, 81753, 81754, 81195, 81732, 81756, 81757, 
81198, 81172, 81730, 81755, 81197
29508, 80451, 80627, 80635, 80459, 80452, 80628, 80636, 80460, 81732, 81756, 81757, 81198, 81735, 81759, 81760, 
81201, 81175, 81733, 81758, 81200
29509, 80452, 80628, 80636, 80460, 80453, 80629, 80637, 80461, 81735, 81759, 81760, 81201, 81738, 81762, 81763, 
81204, 81178, 81736, 81761, 81203
29510, 80453, 80629, 80637, 80461, 80454, 80630, 80638, 80462, 81738, 81762, 81763, 81204, 81741, 81765, 81766, 
81207, 81181, 81739, 81764, 81206
29511, 80454, 80630, 80638, 80462, 80455, 80631, 80639, 80463, 81741, 81765, 81766, 81207, 81744, 81768, 81769, 
81210, 81184, 81742, 81767, 81209
29512, 80455, 80631, 80639, 80463, 14102, 14124, 14125, 14103, 81744, 81768, 81769, 81210, 14225, 14226, 14227, 
14181, 81187, 81745, 81770, 81212
29513, 13880, 13902, 13903, 13881, 80456, 80632, 80640, 80464, 14003, 14006, 14005, 13961, 81748, 81772, 81773, 
81214, 81188, 81746, 81771, 81213
29514, 80456, 80632, 80640, 80464, 80457, 80633, 80641, 80465, 81748, 81772, 81773, 81214, 81751, 81775, 81776, 
81217, 81191, 81749, 81774, 81216
29515, 80457, 80633, 80641, 80465, 80458, 80634, 80642, 80466, 81751, 81775, 81776, 81217, 81754, 81778, 81779, 
81220, 81194, 81752, 81777, 81219
29516, 80458, 80634, 80642, 80466, 80459, 80635, 80643, 80467, 81754, 81778, 81779, 81220, 81757, 81781, 81782, 
81223, 81197, 81755, 81780, 81222
29517, 80459, 80635, 80643, 80467, 80460, 80636, 80644, 80468, 81757, 81781, 81782, 81223, 81760, 81784, 81785, 
81226, 81200, 81758, 81783, 81225
29518, 80460, 80636, 80644, 80468, 80461, 80637, 80645, 80469, 81760, 81784, 81785, 81226, 81763, 81787, 81788, 
81229, 81203, 81761, 81786, 81228
29519, 80461, 80637, 80645, 80469, 80462, 80638, 80646, 80470, 81763, 81787, 81788, 81229, 81766, 81790, 81791, 
81232, 81206, 81764, 81789, 81231
29520, 80462, 80638, 80646, 80470, 80463, 80639, 80647, 80471, 81766, 81790, 81791, 81232, 81769, 81793, 81794, 
81235, 81209, 81767, 81792, 81234
29521, 80463, 80639, 80647, 80471, 14103, 14125, 14126, 14104, 81769, 81793, 81794, 81235, 14227, 14228, 14229, 
14183, 81212, 81770, 81795, 81237
29522, 13881, 13903, 13904, 13882, 80464, 80640, 80648, 80472, 14005, 14008, 14007, 13963, 81773, 81797, 81798, 
81239, 81213, 81771, 81796, 81238
29523, 80464, 80640, 80648, 80472, 80465, 80641, 80649, 80473, 81773, 81797, 81798, 81239, 81776, 81800, 81801, 
81242, 81216, 81774, 81799, 81241
29524, 80465, 80641, 80649, 80473, 80466, 80642, 80650, 80474, 81776, 81800, 81801, 81242, 81779, 81803, 81804, 
81245, 81219, 81777, 81802, 81244
29525, 80466, 80642, 80650, 80474, 80467, 80643, 80651, 80475, 81779, 81803, 81804, 81245, 81782, 81806, 81807, 
81248, 81222, 81780, 81805, 81247
29526, 80467, 80643, 80651, 80475, 80468, 80644, 80652, 80476, 81782, 81806, 81807, 81248, 81785, 81809, 81810, 
81251, 81225, 81783, 81808, 81250
29527, 80468, 80644, 80652, 80476, 80469, 80645, 80653, 80477, 81785, 81809, 81810, 81251, 81788, 81812, 81813, 
81254, 81228, 81786, 81811, 81253
29528, 80469, 80645, 80653, 80477, 80470, 80646, 80654, 80478, 81788, 81812, 81813, 81254, 81791, 81815, 81816, 
81257, 81231, 81789, 81814, 81256
29529, 80470, 80646, 80654, 80478, 80471, 80647, 80655, 80479, 81791, 81815, 81816, 81257, 81794, 81818, 81819, 
81260, 81234, 81792, 81817, 81259
29530, 80471, 80647, 80655, 80479, 14104, 14126, 14127, 14105, 81794, 81818, 81819, 81260, 14229, 14230, 14231, 
14185, 81237, 81795, 81820, 81262
29531, 13882, 13904, 13905, 13883, 80472, 80648, 80656, 80480, 14007, 14010, 14009, 13965, 81798, 81822, 81823, 
81264, 81238, 81796, 81821, 81263
29532, 80472, 80648, 80656, 80480, 80473, 80649, 80657, 80481, 81798, 81822, 81823, 81264, 81801, 81825, 81826, 
81267, 81241, 81799, 81824, 81266
29533, 80473, 80649, 80657, 80481, 80474, 80650, 80658, 80482, 81801, 81825, 81826, 81267, 81804, 81828, 81829, 
81270, 81244, 81802, 81827, 81269
29534, 80474, 80650, 80658, 80482, 80475, 80651, 80659, 80483, 81804, 81828, 81829, 81270, 81807, 81831, 81832, 
81273, 81247, 81805, 81830, 81272
29535, 80475, 80651, 80659, 80483, 80476, 80652, 80660, 80484, 81807, 81831, 81832, 81273, 81810, 81834, 81835, 
81276, 81250, 81808, 81833, 81275
29536, 80476, 80652, 80660, 80484, 80477, 80653, 80661, 80485, 81810, 81834, 81835, 81276, 81813, 81837, 81838, 
81279, 81253, 81811, 81836, 81278
29537, 80477, 80653, 80661, 80485, 80478, 80654, 80662, 80486, 81813, 81837, 81838, 81279, 81816, 81840, 81841, 
81282, 81256, 81814, 81839, 81281
29538, 80478, 80654, 80662, 80486, 80479, 80655, 80663, 80487, 81816, 81840, 81841, 81282, 81819, 81843, 81844, 
81285, 81259, 81817, 81842, 81284
29539, 80479, 80655, 80663, 80487, 14105, 14127, 14128, 14106, 81819, 81843, 81844, 81285, 14231, 14232, 14233, 
14187, 81262, 81820, 81845, 81287
29540, 13883, 13905, 13906, 13884, 80480, 80656, 80664, 80488, 14009, 14012, 14011, 13967, 81823, 81847, 81848, 
81289, 81263, 81821, 81846, 81288
29541, 80480, 80656, 80664, 80488, 80481, 80657, 80665, 80489, 81823, 81847, 81848, 81289, 81826, 81850, 81851, 
81292, 81266, 81824, 81849, 81291
29542, 80481, 80657, 80665, 80489, 80482, 80658, 80666, 80490, 81826, 81850, 81851, 81292, 81829, 81853, 81854, 
81295, 81269, 81827, 81852, 81294
29543, 80482, 80658, 80666, 80490, 80483, 80659, 80667, 80491, 81829, 81853, 81854, 81295, 81832, 81856, 81857, 
81298, 81272, 81830, 81855, 81297
29544, 80483, 80659, 80667, 80491, 80484, 80660, 80668, 80492, 81832, 81856, 81857, 81298, 81835, 81859, 81860, 
81301, 81275, 81833, 81858, 81300
29545, 80484, 80660, 80668, 80492, 80485, 80661, 80669, 80493, 81835, 81859, 81860, 81301, 81838, 81862, 81863, 
81304, 81278, 81836, 81861, 81303
29546, 80485, 80661, 80669, 80493, 80486, 80662, 80670, 80494, 81838, 81862, 81863, 81304, 81841, 81865, 81866, 
81307, 81281, 81839, 81864, 81306
29547, 80486, 80662, 80670, 80494, 80487, 80663, 80671, 80495, 81841, 81865, 81866, 81307, 81844, 81868, 81869, 
81310, 81284, 81842, 81867, 81309
29548, 80487, 80663, 80671, 80495, 14106, 14128, 14129, 14107, 81844, 81868, 81869, 81310, 14233, 14234, 14235, 
14189, 81287, 81845, 81870, 81312
29549, 13884, 13906, 13907, 13885, 80488, 80664, 80672, 80496, 14011, 14014, 14013, 13969, 81848, 81872, 81873, 
81314, 81288, 81846, 81871, 81313
29550, 80488, 80664, 80672, 80496, 80489, 80665, 80673, 80497, 81848, 81872, 81873, 81314, 81851, 81875, 81876, 
81317, 81291, 81849, 81874, 81316
29551, 80489, 80665, 80673, 80497, 80490, 80666, 80674, 80498, 81851, 81875, 81876, 81317, 81854, 81878, 81879, 
81320, 81294, 81852, 81877, 81319
29552, 80490, 80666, 80674, 80498, 80491, 80667, 80675, 80499, 81854, 81878, 81879, 81320, 81857, 81881, 81882, 
81323, 81297, 81855, 81880, 81322
29553, 80491, 80667, 80675, 80499, 80492, 80668, 80676, 80500, 81857, 81881, 81882, 81323, 81860, 81884, 81885, 
81326, 81300, 81858, 81883, 81325
29554, 80492, 80668, 80676, 80500, 80493, 80669, 80677, 80501, 81860, 81884, 81885, 81326, 81863, 81887, 81888, 
81329, 81303, 81861, 81886, 81328
29555, 80493, 80669, 80677, 80501, 80494, 80670, 80678, 80502, 81863, 81887, 81888, 81329, 81866, 81890, 81891, 
81332, 81306, 81864, 81889, 81331
29556, 80494, 80670, 80678, 80502, 80495, 80671, 80679, 80503, 81866, 81890, 81891, 81332, 81869, 81893, 81894, 
81335, 81309, 81867, 81892, 81334
29557, 80495, 80671, 80679, 80503, 14107, 14129, 14130, 14108, 81869, 81893, 81894, 81335, 14235, 14236, 14237, 
14191, 81312, 81870, 81895, 81337
29558, 13885, 13907, 13908, 13886, 80496, 80672, 80680, 80504, 14013, 14016, 14015, 13971, 81873, 81897, 81898, 
81339, 81313, 81871, 81896, 81338
29559, 80496, 80672, 80680, 80504, 80497, 80673, 80681, 80505, 81873, 81897, 81898, 81339, 81876, 81900, 81901, 
81342, 81316, 81874, 81899, 81341
29560, 80497, 80673, 80681, 80505, 80498, 80674, 80682, 80506, 81876, 81900, 81901, 81342, 81879, 81903, 81904, 
81345, 81319, 81877, 81902, 81344
29561, 80498, 80674, 80682, 80506, 80499, 80675, 80683, 80507, 81879, 81903, 81904, 81345, 81882, 81906, 81907, 
81348, 81322, 81880, 81905, 81347
29562, 80499, 80675, 80683, 80507, 80500, 80676, 80684, 80508, 81882, 81906, 81907, 81348, 81885, 81909, 81910, 
81351, 81325, 81883, 81908, 81350
29563, 80500, 80676, 80684, 80508, 80501, 80677, 80685, 80509, 81885, 81909, 81910, 81351, 81888, 81912, 81913, 
81354, 81328, 81886, 81911, 81353
29564, 80501, 80677, 80685, 80509, 80502, 80678, 80686, 80510, 81888, 81912, 81913, 81354, 81891, 81915, 81916, 
81357, 81331, 81889, 81914, 81356
29565, 80502, 80678, 80686, 80510, 80503, 80679, 80687, 80511, 81891, 81915, 81916, 81357, 81894, 81918, 81919, 
81360, 81334, 81892, 81917, 81359
29566, 80503, 80679, 80687, 80511, 14108, 14130, 14131, 14109, 81894, 81918, 81919, 81360, 14237, 14238, 14239, 
14193, 81337, 81895, 81920, 81362
29567, 13886, 13908, 13909, 13887, 80504, 80680, 80688, 80512, 14015, 14018, 14017, 13973, 81898, 81922, 81923, 
81364, 81338, 81896, 81921, 81363
29568, 80504, 80680, 80688, 80512, 80505, 80681, 80689, 80513, 81898, 81922, 81923, 81364, 81901, 81925, 81926, 
81367, 81341, 81899, 81924, 81366
29569, 80505, 80681, 80689, 80513, 80506, 80682, 80690, 80514, 81901, 81925, 81926, 81367, 81904, 81928, 81929, 
81370, 81344, 81902, 81927, 81369
29570, 80506, 80682, 80690, 80514, 80507, 80683, 80691, 80515, 81904, 81928, 81929, 81370, 81907, 81931, 81932, 
81373, 81347, 81905, 81930, 81372
29571, 80507, 80683, 80691, 80515, 80508, 80684, 80692, 80516, 81907, 81931, 81932, 81373, 81910, 81934, 81935, 
81376, 81350, 81908, 81933, 81375
29572, 80508, 80684, 80692, 80516, 80509, 80685, 80693, 80517, 81910, 81934, 81935, 81376, 81913, 81937, 81938, 
81379, 81353, 81911, 81936, 81378
29573, 80509, 80685, 80693, 80517, 80510, 80686, 80694, 80518, 81913, 81937, 81938, 81379, 81916, 81940, 81941, 
81382, 81356, 81914, 81939, 81381
29574, 80510, 80686, 80694, 80518, 80511, 80687, 80695, 80519, 81916, 81940, 81941, 81382, 81919, 81943, 81944, 
81385, 81359, 81917, 81942, 81384
29575, 80511, 80687, 80695, 80519, 14109, 14131, 14132, 14110, 81919, 81943, 81944, 81385, 14239, 14240, 14241, 
14195, 81362, 81920, 81945, 81387
29576, 13887, 13909, 13910, 13888, 80512, 80688, 80696, 80520, 14017, 14020, 14019, 13975, 81923, 81947, 81948, 
81389, 81363, 81921, 81946, 81388
29577, 80512, 80688, 80696, 80520, 80513, 80689, 80697, 80521, 81923, 81947, 81948, 81389, 81926, 81950, 81951, 
81392, 81366, 81924, 81949, 81391
29578, 80513, 80689, 80697, 80521, 80514, 80690, 80698, 80522, 81926, 81950, 81951, 81392, 81929, 81953, 81954, 
81395, 81369, 81927, 81952, 81394
29579, 80514, 80690, 80698, 80522, 80515, 80691, 80699, 80523, 81929, 81953, 81954, 81395, 81932, 81956, 81957, 
81398, 81372, 81930, 81955, 81397
29580, 80515, 80691, 80699, 80523, 80516, 80692, 80700, 80524, 81932, 81956, 81957, 81398, 81935, 81959, 81960, 
81401, 81375, 81933, 81958, 81400
29581, 80516, 80692, 80700, 80524, 80517, 80693, 80701, 80525, 81935, 81959, 81960, 81401, 81938, 81962, 81963, 
81404, 81378, 81936, 81961, 81403
29582, 80517, 80693, 80701, 80525, 80518, 80694, 80702, 80526, 81938, 81962, 81963, 81404, 81941, 81965, 81966, 
81407, 81381, 81939, 81964, 81406
29583, 80518, 80694, 80702, 80526, 80519, 80695, 80703, 80527, 81941, 81965, 81966, 81407, 81944, 81968, 81969, 
81410, 81384, 81942, 81967, 81409
29584, 80519, 80695, 80703, 80527, 14110, 14132, 14133, 14111, 81944, 81968, 81969, 81410, 14241, 14242, 14243, 
14197, 81387, 81945, 81970, 81412
29585, 13888, 13910, 13911, 13889, 80520, 80696, 80704, 80528, 14019, 14022, 14021, 13977, 81948, 81972, 81973, 
81414, 81388, 81946, 81971, 81413
29586, 80520, 80696, 80704, 80528, 80521, 80697, 80705, 80529, 81948, 81972, 81973, 81414, 81951, 81975, 81976, 
81417, 81391, 81949, 81974, 81416
29587, 80521, 80697, 80705, 80529, 80522, 80698, 80706, 80530, 81951, 81975, 81976, 81417, 81954, 81978, 81979, 
81420, 81394, 81952, 81977, 81419
29588, 80522, 80698, 80706, 80530, 80523, 80699, 80707, 80531, 81954, 81978, 81979, 81420, 81957, 81981, 81982, 
81423, 81397, 81955, 81980, 81422
29589, 80523, 80699, 80707, 80531, 80524, 80700, 80708, 80532, 81957, 81981, 81982, 81423, 81960, 81984, 81985, 
81426, 81400, 81958, 81983, 81425
29590, 80524, 80700, 80708, 80532, 80525, 80701, 80709, 80533, 81960, 81984, 81985, 81426, 81963, 81987, 81988, 
81429, 81403, 81961, 81986, 81428
29591, 80525, 80701, 80709, 80533, 80526, 80702, 80710, 80534, 81963, 81987, 81988, 81429, 81966, 81990, 81991, 
81432, 81406, 81964, 81989, 81431
29592, 80526, 80702, 80710, 80534, 80527, 80703, 80711, 80535, 81966, 81990, 81991, 81432, 81969, 81993, 81994, 
81435, 81409, 81967, 81992, 81434
29593, 80527, 80703, 80711, 80535, 14111, 14133, 14134, 14112, 81969, 81993, 81994, 81435, 14243, 14244, 14245, 
14199, 81412, 81970, 81995, 81437
29594, 13889, 13911, 1840, 1839, 80528, 80704, 14329, 14321, 14021, 14023, 1843, 13978, 81973, 81996, 14370, 
81438, 81413, 81971, 14371, 14354
29595, 80528, 80704, 14329, 14321, 80529, 80705, 14328, 14320, 81973, 81996, 14370, 81438, 81976, 81997, 14368, 
81439, 81416, 81974, 14369, 14352
29596, 80529, 80705, 14328, 14320, 80530, 80706, 14327, 14319, 81976, 81997, 14368, 81439, 81979, 81998, 14366, 
81440, 81419, 81977, 14367, 14350
29597, 80530, 80706, 14327, 14319, 80531, 80707, 14326, 14318, 81979, 81998, 14366, 81440, 81982, 81999, 14364, 
81441, 81422, 81980, 14365, 14348
29598, 80531, 80707, 14326, 14318, 80532, 80708, 14325, 14317, 81982, 81999, 14364, 81441, 81985, 82000, 14362, 
81442, 81425, 81983, 14363, 14346
29599, 80532, 80708, 14325, 14317, 80533, 80709, 14324, 14316, 81985, 82000, 14362, 81442, 81988, 82001, 14360, 
81443, 81428, 81986, 14361, 14344
29600, 80533, 80709, 14324, 14316, 80534, 80710, 14323, 14315, 81988, 82001, 14360, 81443, 81991, 82002, 14358, 
81444, 81431, 81989, 14359, 14342
29601, 80534, 80710, 14323, 14315, 80535, 80711, 14322, 14314, 81991, 82002, 14358, 81444, 81994, 82003, 14356, 
81445, 81434, 81992, 14357, 14340
29602, 80535, 80711, 14322, 14314, 14112, 14134, 1892, 1891, 81994, 82003, 14356, 81445, 14245, 14246, 1895, 
14201, 81437, 81995, 14355, 14338
29603, 1785, 1786, 13912, 13890, 13634, 13642, 80712, 80536, 1789, 14025, 14024, 13980, 13692, 82005, 82006, 
81447, 13676, 13693, 82004, 81446
29604, 13634, 13642, 80712, 80536, 13633, 13641, 80713, 80537, 13692, 82005, 82006, 81447, 13690, 82008, 82009, 
81450, 13674, 13691, 82007, 81449
29605, 13633, 13641, 80713, 80537, 13632, 13640, 80714, 80538, 13690, 82008, 82009, 81450, 13688, 82011, 82012, 
81453, 13672, 13689, 82010, 81452
29606, 13632, 13640, 80714, 80538, 13631, 13639, 80715, 80539, 13688, 82011, 82012, 81453, 13686, 82014, 82015, 
81456, 13670, 13687, 82013, 81455
29607, 13631, 13639, 80715, 80539, 13630, 13638, 80716, 80540, 13686, 82014, 82015, 81456, 13684, 82017, 82018, 
81459, 13668, 13685, 82016, 81458
29608, 13630, 13638, 80716, 80540, 13629, 13637, 80717, 80541, 13684, 82017, 82018, 81459, 13682, 82020, 82021, 
81462, 13666, 13683, 82019, 81461
29609, 13629, 13637, 80717, 80541, 13628, 13636, 80718, 80542, 13682, 82020, 82021, 81462, 13680, 82023, 82024, 
81465, 13664, 13681, 82022, 81464
29610, 13628, 13636, 80718, 80542, 13627, 13635, 80719, 80543, 13680, 82023, 82024, 81465, 13678, 82026, 82027, 
81468, 13662, 13679, 82025, 81467
29611, 13627, 13635, 80719, 80543, 1764, 1765, 14135, 14113, 13678, 82026, 82027, 81468, 1768, 14247, 14248, 
14202, 13660, 13677, 82028, 81470
29612, 13890, 13912, 13913, 13891, 80536, 80712, 80720, 80544, 14024, 14027, 14026, 13982, 82006, 82030, 82031, 
81472, 81446, 82004, 82029, 81471
29613, 80536, 80712, 80720, 80544, 80537, 80713, 80721, 80545, 82006, 82030, 82031, 81472, 82009, 82033, 82034, 
81475, 81449, 82007, 82032, 81474
29614, 80537, 80713, 80721, 80545, 80538, 80714, 80722, 80546, 82009, 82033, 82034, 81475, 82012, 82036, 82037, 
81478, 81452, 82010, 82035, 81477
29615, 80538, 80714, 80722, 80546, 80539, 80715, 80723, 80547, 82012, 82036, 82037, 81478, 82015, 82039, 82040, 
81481, 81455, 82013, 82038, 81480
29616, 80539, 80715, 80723, 80547, 80540, 80716, 80724, 80548, 82015, 82039, 82040, 81481, 82018, 82042, 82043, 
81484, 81458, 82016, 82041, 81483
29617, 80540, 80716, 80724, 80548, 80541, 80717, 80725, 80549, 82018, 82042, 82043, 81484, 82021, 82045, 82046, 
81487, 81461, 82019, 82044, 81486
29618, 80541, 80717, 80725, 80549, 80542, 80718, 80726, 80550, 82021, 82045, 82046, 81487, 82024, 82048, 82049, 
81490, 81464, 82022, 82047, 81489
29619, 80542, 80718, 80726, 80550, 80543, 80719, 80727, 80551, 82024, 82048, 82049, 81490, 82027, 82051, 82052, 
81493, 81467, 82025, 82050, 81492
29620, 80543, 80719, 80727, 80551, 14113, 14135, 14136, 14114, 82027, 82051, 82052, 81493, 14248, 14249, 14250, 
14204, 81470, 82028, 82053, 81495
29621, 13891, 13913, 13914, 13892, 80544, 80720, 80728, 80552, 14026, 14029, 14028, 13984, 82031, 82055, 82056, 
81497, 81471, 82029, 82054, 81496
29622, 80544, 80720, 80728, 80552, 80545, 80721, 80729, 80553, 82031, 82055, 82056, 81497, 82034, 82058, 82059, 
81500, 81474, 82032, 82057, 81499
29623, 80545, 80721, 80729, 80553, 80546, 80722, 80730, 80554, 82034, 82058, 82059, 81500, 82037, 82061, 82062, 
81503, 81477, 82035, 82060, 81502
29624, 80546, 80722, 80730, 80554, 80547, 80723, 80731, 80555, 82037, 82061, 82062, 81503, 82040, 82064, 82065, 
81506, 81480, 82038, 82063, 81505
29625, 80547, 80723, 80731, 80555, 80548, 80724, 80732, 80556, 82040, 82064, 82065, 81506, 82043, 82067, 82068, 
81509, 81483, 82041, 82066, 81508
29626, 80548, 80724, 80732, 80556, 80549, 80725, 80733, 80557, 82043, 82067, 82068, 81509, 82046, 82070, 82071, 
81512, 81486, 82044, 82069, 81511
29627, 80549, 80725, 80733, 80557, 80550, 80726, 80734, 80558, 82046, 82070, 82071, 81512, 82049, 82073, 82074, 
81515, 81489, 82047, 82072, 81514
29628, 80550, 80726, 80734, 80558, 80551, 80727, 80735, 80559, 82049, 82073, 82074, 81515, 82052, 82076, 82077, 
81518, 81492, 82050, 82075, 81517
29629, 80551, 80727, 80735, 80559, 14114, 14136, 14137, 14115, 82052, 82076, 82077, 81518, 14250, 14251, 14252, 
14206, 81495, 82053, 82078, 81520
29630, 13892, 13914, 13915, 13893, 80552, 80728, 80736, 80560, 14028, 14031, 14030, 13986, 82056, 82080, 82081, 
81522, 81496, 82054, 82079, 81521
29631, 80552, 80728, 80736, 80560, 80553, 80729, 80737, 80561, 82056, 82080, 82081, 81522, 82059, 82083, 82084, 
81525, 81499, 82057, 82082, 81524
29632, 80553, 80729, 80737, 80561, 80554, 80730, 80738, 80562, 82059, 82083, 82084, 81525, 82062, 82086, 82087, 
81528, 81502, 82060, 82085, 81527
29633, 80554, 80730, 80738, 80562, 80555, 80731, 80739, 80563, 82062, 82086, 82087, 81528, 82065, 82089, 82090, 
81531, 81505, 82063, 82088, 81530
29634, 80555, 80731, 80739, 80563, 80556, 80732, 80740, 80564, 82065, 82089, 82090, 81531, 82068, 82092, 82093, 
81534, 81508, 82066, 82091, 81533
29635, 80556, 80732, 80740, 80564, 80557, 80733, 80741, 80565, 82068, 82092, 82093, 81534, 82071, 82095, 82096, 
81537, 81511, 82069, 82094, 81536
29636, 80557, 80733, 80741, 80565, 80558, 80734, 80742, 80566, 82071, 82095, 82096, 81537, 82074, 82098, 82099, 
81540, 81514, 82072, 82097, 81539
29637, 80558, 80734, 80742, 80566, 80559, 80735, 80743, 80567, 82074, 82098, 82099, 81540, 82077, 82101, 82102, 
81543, 81517, 82075, 82100, 81542
29638, 80559, 80735, 80743, 80567, 14115, 14137, 14138, 14116, 82077, 82101, 82102, 81543, 14252, 14253, 14254, 
14208, 81520, 82078, 82103, 81545
29639, 13893, 13915, 13916, 13894, 80560, 80736, 80744, 80568, 14030, 14033, 14032, 13988, 82081, 82105, 82106, 
81547, 81521, 82079, 82104, 81546
29640, 80560, 80736, 80744, 80568, 80561, 80737, 80745, 80569, 82081, 82105, 82106, 81547, 82084, 82108, 82109, 
81550, 81524, 82082, 82107, 81549
29641, 80561, 80737, 80745, 80569, 80562, 80738, 80746, 80570, 82084, 82108, 82109, 81550, 82087, 82111, 82112, 
81553, 81527, 82085, 82110, 81552
29642, 80562, 80738, 80746, 80570, 80563, 80739, 80747, 80571, 82087, 82111, 82112, 81553, 82090, 82114, 82115, 
81556, 81530, 82088, 82113, 81555
29643, 80563, 80739, 80747, 80571, 80564, 80740, 80748, 80572, 82090, 82114, 82115, 81556, 82093, 82117, 82118, 
81559, 81533, 82091, 82116, 81558
29644, 80564, 80740, 80748, 80572, 80565, 80741, 80749, 80573, 82093, 82117, 82118, 81559, 82096, 82120, 82121, 
81562, 81536, 82094, 82119, 81561
29645, 80565, 80741, 80749, 80573, 80566, 80742, 80750, 80574, 82096, 82120, 82121, 81562, 82099, 82123, 82124, 
81565, 81539, 82097, 82122, 81564
29646, 80566, 80742, 80750, 80574, 80567, 80743, 80751, 80575, 82099, 82123, 82124, 81565, 82102, 82126, 82127, 
81568, 81542, 82100, 82125, 81567
29647, 80567, 80743, 80751, 80575, 14116, 14138, 14139, 14117, 82102, 82126, 82127, 81568, 14254, 14255, 14256, 
14210, 81545, 82103, 82128, 81570
29648, 13894, 13916, 13917, 13895, 80568, 80744, 80752, 80576, 14032, 14035, 14034, 13990, 82106, 82130, 82131, 
81572, 81546, 82104, 82129, 81571
29649, 80568, 80744, 80752, 80576, 80569, 80745, 80753, 80577, 82106, 82130, 82131, 81572, 82109, 82133, 82134, 
81575, 81549, 82107, 82132, 81574
29650, 80569, 80745, 80753, 80577, 80570, 80746, 80754, 80578, 82109, 82133, 82134, 81575, 82112, 82136, 82137, 
81578, 81552, 82110, 82135, 81577
29651, 80570, 80746, 80754, 80578, 80571, 80747, 80755, 80579, 82112, 82136, 82137, 81578, 82115, 82139, 82140, 
81581, 81555, 82113, 82138, 81580
29652, 80571, 80747, 80755, 80579, 80572, 80748, 80756, 80580, 82115, 82139, 82140, 81581, 82118, 82142, 82143, 
81584, 81558, 82116, 82141, 81583
29653, 80572, 80748, 80756, 80580, 80573, 80749, 80757, 80581, 82118, 82142, 82143, 81584, 82121, 82145, 82146, 
81587, 81561, 82119, 82144, 81586
29654, 80573, 80749, 80757, 80581, 80574, 80750, 80758, 80582, 82121, 82145, 82146, 81587, 82124, 82148, 82149, 
81590, 81564, 82122, 82147, 81589
29655, 80574, 80750, 80758, 80582, 80575, 80751, 80759, 80583, 82124, 82148, 82149, 81590, 82127, 82151, 82152, 
81593, 81567, 82125, 82150, 81592
29656, 80575, 80751, 80759, 80583, 14117, 14139, 14140, 14118, 82127, 82151, 82152, 81593, 14256, 14257, 14258, 
14212, 81570, 82128, 82153, 81595
29657, 13895, 13917, 13918, 13896, 80576, 80752, 80760, 80584, 14034, 14037, 14036, 13992, 82131, 82155, 82156, 
81597, 81571, 82129, 82154, 81596
29658, 80576, 80752, 80760, 80584, 80577, 80753, 80761, 80585, 82131, 82155, 82156, 81597, 82134, 82158, 82159, 
81600, 81574, 82132, 82157, 81599
29659, 80577, 80753, 80761, 80585, 80578, 80754, 80762, 80586, 82134, 82158, 82159, 81600, 82137, 82161, 82162, 
81603, 81577, 82135, 82160, 81602
29660, 80578, 80754, 80762, 80586, 80579, 80755, 80763, 80587, 82137, 82161, 82162, 81603, 82140, 82164, 82165, 
81606, 81580, 82138, 82163, 81605
29661, 80579, 80755, 80763, 80587, 80580, 80756, 80764, 80588, 82140, 82164, 82165, 81606, 82143, 82167, 82168, 
81609, 81583, 82141, 82166, 81608
29662, 80580, 80756, 80764, 80588, 80581, 80757, 80765, 80589, 82143, 82167, 82168, 81609, 82146, 82170, 82171, 
81612, 81586, 82144, 82169, 81611
29663, 80581, 80757, 80765, 80589, 80582, 80758, 80766, 80590, 82146, 82170, 82171, 81612, 82149, 82173, 82174, 
81615, 81589, 82147, 82172, 81614
29664, 80582, 80758, 80766, 80590, 80583, 80759, 80767, 80591, 82149, 82173, 82174, 81615, 82152, 82176, 82177, 
81618, 81592, 82150, 82175, 81617
29665, 80583, 80759, 80767, 80591, 14118, 14140, 14141, 14119, 82152, 82176, 82177, 81618, 14258, 14259, 14260, 
14214, 81595, 82153, 82178, 81620
29666, 13896, 13918, 13919, 13897, 80584, 80760, 80768, 80592, 14036, 14039, 14038, 13994, 82156, 82180, 82181, 
81622, 81596, 82154, 82179, 81621
29667, 80584, 80760, 80768, 80592, 80585, 80761, 80769, 80593, 82156, 82180, 82181, 81622, 82159, 82183, 82184, 
81625, 81599, 82157, 82182, 81624
29668, 80585, 80761, 80769, 80593, 80586, 80762, 80770, 80594, 82159, 82183, 82184, 81625, 82162, 82186, 82187, 
81628, 81602, 82160, 82185, 81627
29669, 80586, 80762, 80770, 80594, 80587, 80763, 80771, 80595, 82162, 82186, 82187, 81628, 82165, 82189, 82190, 
81631, 81605, 82163, 82188, 81630
29670, 80587, 80763, 80771, 80595, 80588, 80764, 80772, 80596, 82165, 82189, 82190, 81631, 82168, 82192, 82193, 
81634, 81608, 82166, 82191, 81633
29671, 80588, 80764, 80772, 80596, 80589, 80765, 80773, 80597, 82168, 82192, 82193, 81634, 82171, 82195, 82196, 
81637, 81611, 82169, 82194, 81636
29672, 80589, 80765, 80773, 80597, 80590, 80766, 80774, 80598, 82171, 82195, 82196, 81637, 82174, 82198, 82199, 
81640, 81614, 82172, 82197, 81639
29673, 80590, 80766, 80774, 80598, 80591, 80767, 80775, 80599, 82174, 82198, 82199, 81640, 82177, 82201, 82202, 
81643, 81617, 82175, 82200, 81642
29674, 80591, 80767, 80775, 80599, 14119, 14141, 14142, 14120, 82177, 82201, 82202, 81643, 14260, 14261, 14262, 
14216, 81620, 82178, 82203, 81645
29675, 13897, 13919, 13920, 13898, 80592, 80768, 80776, 80600, 14038, 14041, 14040, 13996, 82181, 82205, 82206, 
81647, 81621, 82179, 82204, 81646
29676, 80592, 80768, 80776, 80600, 80593, 80769, 80777, 80601, 82181, 82205, 82206, 81647, 82184, 82208, 82209, 
81650, 81624, 82182, 82207, 81649
29677, 80593, 80769, 80777, 80601, 80594, 80770, 80778, 80602, 82184, 82208, 82209, 81650, 82187, 82211, 82212, 
81653, 81627, 82185, 82210, 81652
29678, 80594, 80770, 80778, 80602, 80595, 80771, 80779, 80603, 82187, 82211, 82212, 81653, 82190, 82214, 82215, 
81656, 81630, 82188, 82213, 81655
29679, 80595, 80771, 80779, 80603, 80596, 80772, 80780, 80604, 82190, 82214, 82215, 81656, 82193, 82217, 82218, 
81659, 81633, 82191, 82216, 81658
29680, 80596, 80772, 80780, 80604, 80597, 80773, 80781, 80605, 82193, 82217, 82218, 81659, 82196, 82220, 82221, 
81662, 81636, 82194, 82219, 81661
29681, 80597, 80773, 80781, 80605, 80598, 80774, 80782, 80606, 82196, 82220, 82221, 81662, 82199, 82223, 82224, 
81665, 81639, 82197, 82222, 81664
29682, 80598, 80774, 80782, 80606, 80599, 80775, 80783, 80607, 82199, 82223, 82224, 81665, 82202, 82226, 82227, 
81668, 81642, 82200, 82225, 81667
29683, 80599, 80775, 80783, 80607, 14120, 14142, 14143, 14121, 82202, 82226, 82227, 81668, 14262, 14263, 14264, 
