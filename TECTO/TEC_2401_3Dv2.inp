51288, 0.043478260869565, 0.85434782608696, 0.11111111111111
51289, 0.043478260869565, 0.88043478260869, 0.13888888888889
51290, 0.065217391304348, 0.8804347826087, 0.16666666666667
51291, 0.043478260869565, 0.85434782608696, 0.16666666666667
51292, 0.043478260869565, 0.88043478260869, 0.19444444444444
51293, 0.065217391304348, 0.8804347826087, 0.22222222222222
51294, 0.043478260869565, 0.85434782608696, 0.22222222222222
51295, 0.043478260869565, 0.88043478260869, 0.25
51296, 0.065217391304348, 0.88043478260869, 0.27777777777778
51297, 0.043478260869565, 0.85434782608696, 0.27777777777778
51298, 0.043478260869565, 0.88043478260869, 0.30555555555556
51299, 0.065217391304348, 0.8804347826087, 0.33333333333333
51300, 0.043478260869565, 0.85434782608696, 0.33333333333333
51301, 0.043478260869565, 0.88043478260869, 0.36111111111111
51302, 0.065217391304348, 0.88043478260869, 0.38888888888889
51303, 0.043478260869565, 0.85434782608696, 0.38888888888889
51304, 0.043478260869565, 0.88043478260869, 0.41666666666667
51305, 0.065217391304348, 0.88043478260869, 0.44444444444444
51306, 0.043478260869565, 0.85434782608696, 0.44444444444444
51307, 0.043478260869565, 0.88043478260869, 0.47222222222222
51308, 0.021739130434783, 0.88043478260869, 0.055555555555556
51309, 0.021739130434783, 0.88043478260869, 0.11111111111111
51310, 0.021739130434783, 0.8804347826087, 0.16666666666667
51311, 0.021739130434783, 0.88043478260869, 0.22222222222222
51312, 0.021739130434783, 0.88043478260869, 0.27777777777778
51313, 0.021739130434783, 0.88043478260869, 0.33333333333333
51314, 0.021739130434783, 0.88043478260869, 0.38888888888889
51315, 0.021739130434783, 0.88043478260869, 0.44444444444444
51316, 0.95652173913043, 0.93260869565217, 0.027777777777778
51317, 0.97826086956522, 0.93260869565217, 0.055555555555556
51318, 0.95652173913043, 0.90652173913043, 0.055555555555556
51319, 0.95652173913043, 0.93260869565217, 0.083333333333333
51320, 0.97826086956522, 0.93260869565217, 0.11111111111111
51321, 0.95652173913044, 0.90652173913043, 0.11111111111111
51322, 0.95652173913044, 0.93260869565217, 0.13888888888889
51323, 0.97826086956522, 0.93260869565217, 0.16666666666667
51324, 0.95652173913044, 0.90652173913043, 0.16666666666667
51325, 0.95652173913044, 0.93260869565217, 0.19444444444444
51326, 0.97826086956522, 0.93260869565217, 0.22222222222222
51327, 0.95652173913044, 0.90652173913043, 0.22222222222222
51328, 0.95652173913044, 0.93260869565217, 0.25
51329, 0.97826086956522, 0.93260869565217, 0.27777777777778
51330, 0.95652173913044, 0.90652173913043, 0.27777777777778
51331, 0.95652173913044, 0.93260869565217, 0.30555555555556
51332, 0.97826086956522, 0.93260869565217, 0.33333333333333
51333, 0.95652173913044, 0.90652173913043, 0.33333333333333
51334, 0.95652173913044, 0.93260869565217, 0.36111111111111
51335, 0.97826086956522, 0.93260869565217, 0.38888888888889
51336, 0.95652173913044, 0.90652173913043, 0.38888888888889
51337, 0.95652173913044, 0.93260869565217, 0.41666666666667
51338, 0.97826086956522, 0.93260869565217, 0.44444444444444
51339, 0.95652173913044, 0.90652173913043, 0.44444444444444
51340, 0.95652173913044, 0.93260869565217, 0.47222222222222
51341, 0.91304347826087, 0.93260869565217, 0.027777777777778
51342, 0.93478260869565, 0.93260869565217, 0.055555555555556
51343, 0.91304347826087, 0.90652173913043, 0.055555555555556
51344, 0.91304347826087, 0.93260869565217, 0.083333333333333
51345, 0.93478260869565, 0.93260869565217, 0.11111111111111
51346, 0.91304347826087, 0.90652173913043, 0.11111111111111
51347, 0.91304347826087, 0.93260869565217, 0.13888888888889
51348, 0.93478260869565, 0.93260869565217, 0.16666666666667
51349, 0.91304347826087, 0.90652173913043, 0.16666666666667
51350, 0.91304347826087, 0.93260869565217, 0.19444444444444
51351, 0.93478260869565, 0.93260869565217, 0.22222222222222
51352, 0.91304347826087, 0.90652173913043, 0.22222222222222
51353, 0.91304347826087, 0.93260869565217, 0.25
51354, 0.93478260869565, 0.93260869565217, 0.27777777777778
51355, 0.91304347826087, 0.90652173913043, 0.27777777777778
51356, 0.91304347826087, 0.93260869565217, 0.30555555555556
51357, 0.93478260869565, 0.93260869565217, 0.33333333333333
51358, 0.91304347826087, 0.90652173913043, 0.33333333333333
51359, 0.91304347826087, 0.93260869565217, 0.36111111111111
51360, 0.93478260869565, 0.93260869565217, 0.38888888888889
51361, 0.91304347826087, 0.90652173913043, 0.38888888888889
51362, 0.91304347826087, 0.93260869565217, 0.41666666666667
51363, 0.93478260869565, 0.93260869565217, 0.44444444444444
51364, 0.91304347826087, 0.90652173913043, 0.44444444444444
51365, 0.91304347826087, 0.93260869565217, 0.47222222222222
51366, 0.8695652173913, 0.93260869565217, 0.027777777777778
51367, 0.89130434782609, 0.93260869565217, 0.055555555555556
51368, 0.8695652173913, 0.90652173913043, 0.055555555555556
51369, 0.8695652173913, 0.93260869565217, 0.083333333333333
51370, 0.89130434782609, 0.93260869565217, 0.11111111111111
51371, 0.8695652173913, 0.90652173913043, 0.11111111111111
51372, 0.8695652173913, 0.93260869565217, 0.13888888888889
51373, 0.89130434782609, 0.93260869565217, 0.16666666666667
51374, 0.8695652173913, 0.90652173913043, 0.16666666666667
51375, 0.8695652173913, 0.93260869565217, 0.19444444444444
51376, 0.89130434782609, 0.93260869565217, 0.22222222222222
51377, 0.8695652173913, 0.90652173913043, 0.22222222222222
51378, 0.8695652173913, 0.93260869565217, 0.25
51379, 0.89130434782609, 0.93260869565217, 0.27777777777778
51380, 0.8695652173913, 0.90652173913043, 0.27777777777778
51381, 0.8695652173913, 0.93260869565217, 0.30555555555556
51382, 0.89130434782609, 0.93260869565217, 0.33333333333333
51383, 0.8695652173913, 0.90652173913043, 0.33333333333333
51384, 0.8695652173913, 0.93260869565217, 0.36111111111111
51385, 0.89130434782609, 0.93260869565217, 0.38888888888889
51386, 0.8695652173913, 0.90652173913043, 0.38888888888889
51387, 0.8695652173913, 0.93260869565217, 0.41666666666667
51388, 0.89130434782609, 0.93260869565217, 0.44444444444444
51389, 0.8695652173913, 0.90652173913043, 0.44444444444444
51390, 0.8695652173913, 0.93260869565217, 0.47222222222222
51391, 0.82608695652174, 0.93260869565217, 0.027777777777778
51392, 0.84782608695652, 0.93260869565217, 0.055555555555556
51393, 0.82608695652174, 0.90652173913043, 0.055555555555556
51394, 0.82608695652174, 0.93260869565217, 0.083333333333333
51395, 0.84782608695652, 0.93260869565217, 0.11111111111111
51396, 0.82608695652174, 0.90652173913043, 0.11111111111111
51397, 0.82608695652174, 0.93260869565217, 0.13888888888889
51398, 0.84782608695652, 0.93260869565217, 0.16666666666667
51399, 0.82608695652174, 0.90652173913043, 0.16666666666667
51400, 0.82608695652174, 0.93260869565217, 0.19444444444444
51401, 0.84782608695652, 0.93260869565217, 0.22222222222222
51402, 0.82608695652174, 0.90652173913043, 0.22222222222222
51403, 0.82608695652174, 0.93260869565217, 0.25
51404, 0.84782608695652, 0.93260869565217, 0.27777777777778
51405, 0.82608695652174, 0.90652173913043, 0.27777777777778
51406, 0.82608695652174, 0.93260869565217, 0.30555555555556
51407, 0.84782608695652, 0.93260869565217, 0.33333333333333
51408, 0.82608695652174, 0.90652173913043, 0.33333333333333
51409, 0.82608695652174, 0.93260869565217, 0.36111111111111
51410, 0.84782608695652, 0.93260869565217, 0.38888888888889
51411, 0.82608695652174, 0.90652173913043, 0.38888888888889
51412, 0.82608695652174, 0.93260869565217, 0.41666666666667
51413, 0.84782608695652, 0.93260869565217, 0.44444444444444
51414, 0.82608695652174, 0.90652173913043, 0.44444444444444
51415, 0.82608695652174, 0.93260869565217, 0.47222222222222
51416, 0.78260869565217, 0.93260869565217, 0.027777777777778
51417, 0.80434782608696, 0.93260869565217, 0.055555555555556
51418, 0.78260869565217, 0.90652173913043, 0.055555555555556
51419, 0.78260869565217, 0.93260869565217, 0.083333333333333
51420, 0.80434782608696, 0.93260869565217, 0.11111111111111
51421, 0.78260869565217, 0.90652173913043, 0.11111111111111
51422, 0.78260869565217, 0.93260869565217, 0.13888888888889
51423, 0.80434782608696, 0.93260869565217, 0.16666666666667
51424, 0.78260869565217, 0.90652173913043, 0.16666666666667
51425, 0.78260869565217, 0.93260869565217, 0.19444444444444
51426, 0.80434782608696, 0.93260869565217, 0.22222222222222
51427, 0.78260869565217, 0.90652173913043, 0.22222222222222
51428, 0.78260869565217, 0.93260869565217, 0.25
51429, 0.80434782608696, 0.93260869565217, 0.27777777777778
51430, 0.78260869565217, 0.90652173913043, 0.27777777777778
51431, 0.78260869565217, 0.93260869565217, 0.30555555555556
51432, 0.80434782608696, 0.93260869565217, 0.33333333333333
51433, 0.78260869565217, 0.90652173913043, 0.33333333333333
51434, 0.78260869565217, 0.93260869565217, 0.36111111111111
51435, 0.80434782608696, 0.93260869565217, 0.38888888888889
51436, 0.78260869565217, 0.90652173913043, 0.38888888888889
51437, 0.78260869565217, 0.93260869565217, 0.41666666666667
51438, 0.80434782608696, 0.93260869565217, 0.44444444444444
51439, 0.78260869565217, 0.90652173913043, 0.44444444444444
51440, 0.78260869565217, 0.93260869565217, 0.47222222222222
51441, 0.73913043478261, 0.93260869565217, 0.027777777777778
51442, 0.76086956521739, 0.93260869565217, 0.055555555555556
51443, 0.73913043478261, 0.90652173913043, 0.055555555555556
51444, 0.73913043478261, 0.93260869565217, 0.083333333333333
51445, 0.76086956521739, 0.93260869565217, 0.11111111111111
51446, 0.73913043478261, 0.90652173913043, 0.11111111111111
51447, 0.73913043478261, 0.93260869565217, 0.13888888888889
51448, 0.76086956521739, 0.93260869565217, 0.16666666666667
51449, 0.73913043478261, 0.90652173913043, 0.16666666666667
51450, 0.73913043478261, 0.93260869565217, 0.19444444444444
51451, 0.76086956521739, 0.93260869565217, 0.22222222222222
51452, 0.73913043478261, 0.90652173913043, 0.22222222222222
51453, 0.73913043478261, 0.93260869565217, 0.25
51454, 0.76086956521739, 0.93260869565217, 0.27777777777778
51455, 0.73913043478261, 0.90652173913043, 0.27777777777778
51456, 0.73913043478261, 0.93260869565217, 0.30555555555556
51457, 0.76086956521739, 0.93260869565217, 0.33333333333333
51458, 0.73913043478261, 0.90652173913043, 0.33333333333333
51459, 0.73913043478261, 0.93260869565217, 0.36111111111111
51460, 0.76086956521739, 0.93260869565217, 0.38888888888889
51461, 0.73913043478261, 0.90652173913043, 0.38888888888889
51462, 0.73913043478261, 0.93260869565217, 0.41666666666667
51463, 0.76086956521739, 0.93260869565217, 0.44444444444444
51464, 0.73913043478261, 0.90652173913043, 0.44444444444444
51465, 0.73913043478261, 0.93260869565217, 0.47222222222222
51466, 0.69565217391304, 0.93260869565217, 0.027777777777778
51467, 0.71739130434783, 0.93260869565217, 0.055555555555556
51468, 0.69565217391304, 0.90652173913043, 0.055555555555556
51469, 0.69565217391304, 0.93260869565217, 0.083333333333333
51470, 0.71739130434783, 0.93260869565217, 0.11111111111111
51471, 0.69565217391304, 0.90652173913043, 0.11111111111111
51472, 0.69565217391304, 0.93260869565217, 0.13888888888889
51473, 0.71739130434783, 0.93260869565217, 0.16666666666667
51474, 0.69565217391304, 0.90652173913043, 0.16666666666667
51475, 0.69565217391304, 0.93260869565217, 0.19444444444444
51476, 0.71739130434783, 0.93260869565217, 0.22222222222222
51477, 0.69565217391304, 0.90652173913043, 0.22222222222222
51478, 0.69565217391304, 0.93260869565217, 0.25
51479, 0.71739130434783, 0.93260869565217, 0.27777777777778
51480, 0.69565217391304, 0.90652173913043, 0.27777777777778
51481, 0.69565217391304, 0.93260869565217, 0.30555555555556
51482, 0.71739130434783, 0.93260869565217, 0.33333333333333
51483, 0.69565217391304, 0.90652173913043, 0.33333333333333
51484, 0.69565217391304, 0.93260869565217, 0.36111111111111
51485, 0.71739130434783, 0.93260869565217, 0.38888888888889
51486, 0.69565217391304, 0.90652173913043, 0.38888888888889
51487, 0.69565217391304, 0.93260869565217, 0.41666666666667
51488, 0.71739130434783, 0.93260869565217, 0.44444444444444
51489, 0.69565217391304, 0.90652173913043, 0.44444444444444
51490, 0.69565217391304, 0.93260869565217, 0.47222222222222
51491, 0.65217391304348, 0.93260869565217, 0.027777777777778
51492, 0.67391304347826, 0.93260869565217, 0.055555555555556
51493, 0.65217391304348, 0.90652173913043, 0.055555555555556
51494, 0.65217391304348, 0.93260869565217, 0.083333333333333
51495, 0.67391304347826, 0.93260869565217, 0.11111111111111
51496, 0.65217391304348, 0.90652173913043, 0.11111111111111
51497, 0.65217391304348, 0.93260869565217, 0.13888888888889
51498, 0.67391304347826, 0.93260869565217, 0.16666666666667
51499, 0.65217391304348, 0.90652173913043, 0.16666666666667
51500, 0.65217391304348, 0.93260869565217, 0.19444444444444
51501, 0.67391304347826, 0.93260869565217, 0.22222222222222
51502, 0.65217391304348, 0.90652173913043, 0.22222222222222
51503, 0.65217391304348, 0.93260869565217, 0.25
51504, 0.67391304347826, 0.93260869565217, 0.27777777777778
51505, 0.65217391304348, 0.90652173913043, 0.27777777777778
51506, 0.65217391304348, 0.93260869565217, 0.30555555555556
51507, 0.67391304347826, 0.93260869565217, 0.33333333333333
51508, 0.65217391304348, 0.90652173913043, 0.33333333333333
51509, 0.65217391304348, 0.93260869565217, 0.36111111111111
51510, 0.67391304347826, 0.93260869565217, 0.38888888888889
51511, 0.65217391304348, 0.90652173913043, 0.38888888888889
51512, 0.65217391304348, 0.93260869565217, 0.41666666666667
51513, 0.67391304347826, 0.93260869565217, 0.44444444444444
51514, 0.65217391304348, 0.90652173913043, 0.44444444444444
51515, 0.65217391304348, 0.93260869565217, 0.47222222222222
51516, 0.60869565217391, 0.93260869565217, 0.027777777777778
51517, 0.6304347826087, 0.93260869565217, 0.055555555555556
51518, 0.60869565217391, 0.90652173913043, 0.055555555555556
51519, 0.60869565217391, 0.93260869565217, 0.083333333333333
51520, 0.6304347826087, 0.93260869565217, 0.11111111111111
51521, 0.60869565217391, 0.90652173913043, 0.11111111111111
51522, 0.60869565217391, 0.93260869565217, 0.13888888888889
51523, 0.6304347826087, 0.93260869565217, 0.16666666666667
51524, 0.60869565217391, 0.90652173913043, 0.16666666666667
51525, 0.60869565217391, 0.93260869565217, 0.19444444444444
51526, 0.6304347826087, 0.93260869565217, 0.22222222222222
51527, 0.60869565217391, 0.90652173913043, 0.22222222222222
51528, 0.60869565217391, 0.93260869565217, 0.25
51529, 0.6304347826087, 0.93260869565217, 0.27777777777778
51530, 0.60869565217391, 0.90652173913043, 0.27777777777778
51531, 0.60869565217391, 0.93260869565217, 0.30555555555556
51532, 0.6304347826087, 0.93260869565217, 0.33333333333333
51533, 0.60869565217391, 0.90652173913043, 0.33333333333333
51534, 0.60869565217391, 0.93260869565217, 0.36111111111111
51535, 0.6304347826087, 0.93260869565217, 0.38888888888889
51536, 0.60869565217391, 0.90652173913043, 0.38888888888889
51537, 0.60869565217391, 0.93260869565217, 0.41666666666667
51538, 0.6304347826087, 0.93260869565217, 0.44444444444444
51539, 0.60869565217391, 0.90652173913043, 0.44444444444444
51540, 0.60869565217391, 0.93260869565217, 0.47222222222222
51541, 0.56521739130435, 0.93260869565217, 0.027777777777778
51542, 0.58695652173913, 0.93260869565217, 0.055555555555556
51543, 0.56521739130435, 0.90652173913043, 0.055555555555556
51544, 0.56521739130435, 0.93260869565217, 0.083333333333333
51545, 0.58695652173913, 0.93260869565217, 0.11111111111111
51546, 0.56521739130435, 0.90652173913043, 0.11111111111111
51547, 0.56521739130435, 0.93260869565217, 0.13888888888889
51548, 0.58695652173913, 0.93260869565217, 0.16666666666667
51549, 0.56521739130435, 0.90652173913043, 0.16666666666667
51550, 0.56521739130435, 0.93260869565217, 0.19444444444444
51551, 0.58695652173913, 0.93260869565217, 0.22222222222222
51552, 0.56521739130435, 0.90652173913043, 0.22222222222222
51553, 0.56521739130435, 0.93260869565217, 0.25
51554, 0.58695652173913, 0.93260869565217, 0.27777777777778
51555, 0.56521739130435, 0.90652173913043, 0.27777777777778
51556, 0.56521739130435, 0.93260869565217, 0.30555555555556
51557, 0.58695652173913, 0.93260869565217, 0.33333333333333
51558, 0.56521739130435, 0.90652173913043, 0.33333333333333
51559, 0.56521739130435, 0.93260869565217, 0.36111111111111
51560, 0.58695652173913, 0.93260869565217, 0.38888888888889
51561, 0.56521739130435, 0.90652173913043, 0.38888888888889
51562, 0.56521739130435, 0.93260869565217, 0.41666666666667
51563, 0.58695652173913, 0.93260869565217, 0.44444444444444
51564, 0.56521739130435, 0.90652173913043, 0.44444444444444
51565, 0.56521739130435, 0.93260869565217, 0.47222222222222
51566, 0.52173913043478, 0.93260869565217, 0.027777777777778
51567, 0.54347826086957, 0.93260869565217, 0.055555555555556
51568, 0.52173913043478, 0.90652173913043, 0.055555555555556
51569, 0.52173913043478, 0.93260869565217, 0.083333333333333
51570, 0.54347826086957, 0.93260869565217, 0.11111111111111
51571, 0.52173913043478, 0.90652173913043, 0.11111111111111
51572, 0.52173913043478, 0.93260869565217, 0.13888888888889
51573, 0.54347826086957, 0.93260869565217, 0.16666666666667
51574, 0.52173913043478, 0.90652173913043, 0.16666666666667
51575, 0.52173913043478, 0.93260869565217, 0.19444444444444
51576, 0.54347826086956, 0.93260869565217, 0.22222222222222
51577, 0.52173913043478, 0.90652173913043, 0.22222222222222
51578, 0.52173913043478, 0.93260869565217, 0.25
51579, 0.54347826086956, 0.93260869565217, 0.27777777777778
51580, 0.52173913043478, 0.90652173913043, 0.27777777777778
51581, 0.52173913043478, 0.93260869565217, 0.30555555555556
51582, 0.54347826086956, 0.93260869565217, 0.33333333333333
51583, 0.52173913043478, 0.90652173913043, 0.33333333333333
51584, 0.52173913043478, 0.93260869565217, 0.36111111111111
51585, 0.54347826086956, 0.93260869565217, 0.38888888888889
51586, 0.52173913043478, 0.90652173913043, 0.38888888888889
51587, 0.52173913043478, 0.93260869565217, 0.41666666666667
51588, 0.54347826086956, 0.93260869565217, 0.44444444444444
51589, 0.52173913043478, 0.90652173913043, 0.44444444444444
51590, 0.52173913043478, 0.93260869565217, 0.47222222222222
51591, 0.47826086956522, 0.93260869565217, 0.027777777777778
51592, 0.5, 0.93260869565217, 0.055555555555556
51593, 0.47826086956522, 0.90652173913043, 0.055555555555556
51594, 0.47826086956522, 0.93260869565217, 0.083333333333333
51595, 0.5, 0.93260869565217, 0.11111111111111
51596, 0.47826086956522, 0.90652173913043, 0.11111111111111
51597, 0.47826086956522, 0.93260869565217, 0.13888888888889
51598, 0.5, 0.93260869565217, 0.16666666666667
51599, 0.47826086956522, 0.90652173913043, 0.16666666666667
51600, 0.47826086956522, 0.93260869565217, 0.19444444444444
51601, 0.5, 0.93260869565217, 0.22222222222222
51602, 0.47826086956522, 0.90652173913043, 0.22222222222222
51603, 0.47826086956522, 0.93260869565217, 0.25
51604, 0.5, 0.93260869565217, 0.27777777777778
51605, 0.47826086956522, 0.90652173913043, 0.27777777777778
51606, 0.47826086956522, 0.93260869565217, 0.30555555555556
51607, 0.5, 0.93260869565217, 0.33333333333333
51608, 0.47826086956522, 0.90652173913043, 0.33333333333333
51609, 0.47826086956522, 0.93260869565217, 0.36111111111111
51610, 0.5, 0.93260869565217, 0.38888888888889
51611, 0.47826086956522, 0.90652173913043, 0.38888888888889
51612, 0.47826086956522, 0.93260869565217, 0.41666666666667
51613, 0.5, 0.93260869565217, 0.44444444444444
51614, 0.47826086956522, 0.90652173913043, 0.44444444444444
51615, 0.47826086956522, 0.93260869565217, 0.47222222222222
51616, 0.43478260869565, 0.93260869565217, 0.027777777777778
51617, 0.45652173913043, 0.93260869565217, 0.055555555555556
51618, 0.43478260869565, 0.90652173913043, 0.055555555555556
51619, 0.43478260869565, 0.93260869565217, 0.083333333333333
51620, 0.45652173913043, 0.93260869565217, 0.11111111111111
51621, 0.43478260869565, 0.90652173913043, 0.11111111111111
51622, 0.43478260869565, 0.93260869565217, 0.13888888888889
51623, 0.45652173913043, 0.93260869565217, 0.16666666666667
51624, 0.43478260869565, 0.90652173913043, 0.16666666666667
51625, 0.43478260869565, 0.93260869565217, 0.19444444444444
51626, 0.45652173913043, 0.93260869565217, 0.22222222222222
51627, 0.43478260869565, 0.90652173913043, 0.22222222222222
51628, 0.43478260869565, 0.93260869565217, 0.25
51629, 0.45652173913043, 0.93260869565217, 0.27777777777778
51630, 0.43478260869565, 0.90652173913043, 0.27777777777778
51631, 0.43478260869565, 0.93260869565217, 0.30555555555556
51632, 0.45652173913043, 0.93260869565217, 0.33333333333333
51633, 0.43478260869565, 0.90652173913043, 0.33333333333333
51634, 0.43478260869565, 0.93260869565217, 0.36111111111111
51635, 0.45652173913043, 0.93260869565217, 0.38888888888889
51636, 0.43478260869565, 0.90652173913043, 0.38888888888889
51637, 0.43478260869565, 0.93260869565217, 0.41666666666667
51638, 0.45652173913043, 0.93260869565217, 0.44444444444444
51639, 0.43478260869565, 0.90652173913043, 0.44444444444444
51640, 0.43478260869565, 0.93260869565217, 0.47222222222222
51641, 0.39130434782609, 0.93260869565217, 0.027777777777778
51642, 0.41304347826087, 0.93260869565217, 0.055555555555556
51643, 0.39130434782609, 0.90652173913043, 0.055555555555556
51644, 0.39130434782609, 0.93260869565217, 0.083333333333333
51645, 0.41304347826087, 0.93260869565217, 0.11111111111111
51646, 0.39130434782609, 0.90652173913043, 0.11111111111111
51647, 0.39130434782609, 0.93260869565217, 0.13888888888889
51648, 0.41304347826087, 0.93260869565217, 0.16666666666667
51649, 0.39130434782609, 0.90652173913043, 0.16666666666667
51650, 0.39130434782609, 0.93260869565217, 0.19444444444444
51651, 0.41304347826087, 0.93260869565217, 0.22222222222222
51652, 0.39130434782609, 0.90652173913043, 0.22222222222222
51653, 0.39130434782609, 0.93260869565217, 0.25
51654, 0.41304347826087, 0.93260869565217, 0.27777777777778
51655, 0.39130434782609, 0.90652173913043, 0.27777777777778
51656, 0.39130434782609, 0.93260869565217, 0.30555555555556
51657, 0.41304347826087, 0.93260869565217, 0.33333333333333
51658, 0.39130434782609, 0.90652173913043, 0.33333333333333
51659, 0.39130434782609, 0.93260869565217, 0.36111111111111
51660, 0.41304347826087, 0.93260869565217, 0.38888888888889
51661, 0.39130434782609, 0.90652173913043, 0.38888888888889
51662, 0.39130434782609, 0.93260869565217, 0.41666666666667
51663, 0.41304347826087, 0.93260869565217, 0.44444444444444
51664, 0.39130434782609, 0.90652173913043, 0.44444444444444
51665, 0.39130434782609, 0.93260869565217, 0.47222222222222
51666, 0.34782608695652, 0.93260869565217, 0.027777777777778
51667, 0.3695652173913, 0.93260869565217, 0.055555555555556
51668, 0.34782608695652, 0.90652173913043, 0.055555555555556
51669, 0.34782608695652, 0.93260869565217, 0.083333333333333
51670, 0.3695652173913, 0.93260869565217, 0.11111111111111
51671, 0.34782608695652, 0.90652173913043, 0.11111111111111
51672, 0.34782608695652, 0.93260869565217, 0.13888888888889
51673, 0.3695652173913, 0.93260869565217, 0.16666666666667
51674, 0.34782608695652, 0.90652173913043, 0.16666666666667
51675, 0.34782608695652, 0.93260869565217, 0.19444444444444
51676, 0.3695652173913, 0.93260869565217, 0.22222222222222
51677, 0.34782608695652, 0.90652173913043, 0.22222222222222
51678, 0.34782608695652, 0.93260869565217, 0.25
51679, 0.3695652173913, 0.93260869565217, 0.27777777777778
51680, 0.34782608695652, 0.90652173913043, 0.27777777777778
51681, 0.34782608695652, 0.93260869565217, 0.30555555555556
51682, 0.3695652173913, 0.93260869565217, 0.33333333333333
51683, 0.34782608695652, 0.90652173913043, 0.33333333333333
51684, 0.34782608695652, 0.93260869565217, 0.36111111111111
51685, 0.3695652173913, 0.93260869565217, 0.38888888888889
51686, 0.34782608695652, 0.90652173913043, 0.38888888888889
51687, 0.34782608695652, 0.93260869565217, 0.41666666666667
51688, 0.3695652173913, 0.93260869565217, 0.44444444444444
51689, 0.34782608695652, 0.90652173913043, 0.44444444444444
51690, 0.34782608695652, 0.93260869565217, 0.47222222222222
51691, 0.30434782608696, 0.93260869565217, 0.027777777777778
51692, 0.32608695652174, 0.93260869565217, 0.055555555555556
51693, 0.30434782608696, 0.90652173913043, 0.055555555555556
51694, 0.30434782608696, 0.93260869565217, 0.083333333333333
51695, 0.32608695652174, 0.93260869565217, 0.11111111111111
51696, 0.30434782608696, 0.90652173913043, 0.11111111111111
51697, 0.30434782608696, 0.93260869565217, 0.13888888888889
51698, 0.32608695652174, 0.93260869565217, 0.16666666666667
51699, 0.30434782608696, 0.90652173913043, 0.16666666666667
51700, 0.30434782608696, 0.93260869565217, 0.19444444444444
51701, 0.32608695652174, 0.93260869565217, 0.22222222222222
51702, 0.30434782608696, 0.90652173913043, 0.22222222222222
51703, 0.30434782608696, 0.93260869565217, 0.25
51704, 0.32608695652174, 0.93260869565217, 0.27777777777778
51705, 0.30434782608696, 0.90652173913043, 0.27777777777778
51706, 0.30434782608696, 0.93260869565217, 0.30555555555556
51707, 0.32608695652174, 0.93260869565217, 0.33333333333333
51708, 0.30434782608696, 0.90652173913043, 0.33333333333333
51709, 0.30434782608696, 0.93260869565217, 0.36111111111111
51710, 0.32608695652174, 0.93260869565217, 0.38888888888889
51711, 0.30434782608696, 0.90652173913043, 0.38888888888889
51712, 0.30434782608696, 0.93260869565217, 0.41666666666667
51713, 0.32608695652174, 0.93260869565217, 0.44444444444444
51714, 0.30434782608696, 0.90652173913043, 0.44444444444444
51715, 0.30434782608696, 0.93260869565217, 0.47222222222222
51716, 0.26086956521739, 0.93260869565217, 0.027777777777778
51717, 0.28260869565217, 0.93260869565217, 0.055555555555556
51718, 0.26086956521739, 0.90652173913043, 0.055555555555556
51719, 0.26086956521739, 0.93260869565217, 0.083333333333333
51720, 0.28260869565217, 0.93260869565217, 0.11111111111111
51721, 0.26086956521739, 0.90652173913043, 0.11111111111111
51722, 0.26086956521739, 0.93260869565217, 0.13888888888889
51723, 0.28260869565217, 0.93260869565217, 0.16666666666667
51724, 0.26086956521739, 0.90652173913043, 0.16666666666667
51725, 0.26086956521739, 0.93260869565217, 0.19444444444444
51726, 0.28260869565217, 0.93260869565217, 0.22222222222222
51727, 0.26086956521739, 0.90652173913043, 0.22222222222222
51728, 0.26086956521739, 0.93260869565217, 0.25
51729, 0.28260869565217, 0.93260869565217, 0.27777777777778
51730, 0.26086956521739, 0.90652173913043, 0.27777777777778
51731, 0.26086956521739, 0.93260869565217, 0.30555555555556
51732, 0.28260869565217, 0.93260869565217, 0.33333333333333
51733, 0.26086956521739, 0.90652173913043, 0.33333333333333
51734, 0.26086956521739, 0.93260869565217, 0.36111111111111
51735, 0.28260869565217, 0.93260869565217, 0.38888888888889
51736, 0.26086956521739, 0.90652173913043, 0.38888888888889
51737, 0.26086956521739, 0.93260869565217, 0.41666666666667
51738, 0.28260869565217, 0.93260869565217, 0.44444444444444
51739, 0.26086956521739, 0.90652173913043, 0.44444444444444
51740, 0.26086956521739, 0.93260869565217, 0.47222222222222
51741, 0.21739130434783, 0.93260869565217, 0.027777777777778
51742, 0.23913043478261, 0.93260869565217, 0.055555555555556
51743, 0.21739130434783, 0.90652173913043, 0.055555555555556
51744, 0.21739130434783, 0.93260869565217, 0.083333333333333
51745, 0.23913043478261, 0.93260869565217, 0.11111111111111
51746, 0.21739130434783, 0.90652173913043, 0.11111111111111
51747, 0.21739130434783, 0.93260869565217, 0.13888888888889
51748, 0.23913043478261, 0.93260869565217, 0.16666666666667
51749, 0.21739130434783, 0.90652173913043, 0.16666666666667
51750, 0.21739130434783, 0.93260869565217, 0.19444444444444
51751, 0.23913043478261, 0.93260869565217, 0.22222222222222
51752, 0.21739130434783, 0.90652173913043, 0.22222222222222
51753, 0.21739130434783, 0.93260869565217, 0.25
51754, 0.23913043478261, 0.93260869565217, 0.27777777777778
51755, 0.21739130434783, 0.90652173913043, 0.27777777777778
51756, 0.21739130434783, 0.93260869565217, 0.30555555555556
51757, 0.23913043478261, 0.93260869565217, 0.33333333333333
51758, 0.21739130434783, 0.90652173913043, 0.33333333333333
51759, 0.21739130434783, 0.93260869565217, 0.36111111111111
51760, 0.23913043478261, 0.93260869565217, 0.38888888888889
51761, 0.21739130434783, 0.90652173913043, 0.38888888888889
51762, 0.21739130434783, 0.93260869565217, 0.41666666666667
51763, 0.23913043478261, 0.93260869565217, 0.44444444444444
51764, 0.21739130434783, 0.90652173913043, 0.44444444444444
51765, 0.21739130434783, 0.93260869565217, 0.47222222222222
51766, 0.17391304347826, 0.93260869565217, 0.027777777777778
51767, 0.19565217391304, 0.93260869565217, 0.055555555555556
51768, 0.17391304347826, 0.90652173913043, 0.055555555555556
51769, 0.17391304347826, 0.93260869565217, 0.083333333333333
51770, 0.19565217391304, 0.93260869565217, 0.11111111111111
51771, 0.17391304347826, 0.90652173913043, 0.11111111111111
51772, 0.17391304347826, 0.93260869565217, 0.13888888888889
51773, 0.19565217391304, 0.93260869565217, 0.16666666666667
51774, 0.17391304347826, 0.90652173913043, 0.16666666666667
51775, 0.17391304347826, 0.93260869565217, 0.19444444444444
51776, 0.19565217391304, 0.93260869565217, 0.22222222222222
51777, 0.17391304347826, 0.90652173913043, 0.22222222222222
51778, 0.17391304347826, 0.93260869565217, 0.25
51779, 0.19565217391304, 0.93260869565217, 0.27777777777778
51780, 0.17391304347826, 0.90652173913043, 0.27777777777778
51781, 0.17391304347826, 0.93260869565217, 0.30555555555556
51782, 0.19565217391304, 0.93260869565217, 0.33333333333333
51783, 0.17391304347826, 0.90652173913043, 0.33333333333333
51784, 0.17391304347826, 0.93260869565217, 0.36111111111111
51785, 0.19565217391304, 0.93260869565217, 0.38888888888889
51786, 0.17391304347826, 0.90652173913043, 0.38888888888889
51787, 0.17391304347826, 0.93260869565217, 0.41666666666667
51788, 0.19565217391304, 0.93260869565217, 0.44444444444444
51789, 0.17391304347826, 0.90652173913043, 0.44444444444444
51790, 0.17391304347826, 0.93260869565217, 0.47222222222222
51791, 0.1304347826087, 0.93260869565217, 0.027777777777778
51792, 0.15217391304348, 0.93260869565217, 0.055555555555556
51793, 0.1304347826087, 0.90652173913043, 0.055555555555556
51794, 0.1304347826087, 0.93260869565217, 0.083333333333333
51795, 0.15217391304348, 0.93260869565217, 0.11111111111111
51796, 0.1304347826087, 0.90652173913043, 0.11111111111111
51797, 0.1304347826087, 0.93260869565217, 0.13888888888889
51798, 0.15217391304348, 0.93260869565217, 0.16666666666667
51799, 0.1304347826087, 0.90652173913043, 0.16666666666667
51800, 0.1304347826087, 0.93260869565217, 0.19444444444444
51801, 0.15217391304348, 0.93260869565217, 0.22222222222222
51802, 0.1304347826087, 0.90652173913043, 0.22222222222222
51803, 0.1304347826087, 0.93260869565217, 0.25
51804, 0.15217391304348, 0.93260869565217, 0.27777777777778
51805, 0.1304347826087, 0.90652173913043, 0.27777777777778
51806, 0.1304347826087, 0.93260869565217, 0.30555555555556
51807, 0.15217391304348, 0.93260869565217, 0.33333333333333
51808, 0.1304347826087, 0.90652173913043, 0.33333333333333
51809, 0.1304347826087, 0.93260869565217, 0.36111111111111
51810, 0.15217391304348, 0.93260869565217, 0.38888888888889
51811, 0.1304347826087, 0.90652173913043, 0.38888888888889
51812, 0.1304347826087, 0.93260869565217, 0.41666666666667
51813, 0.15217391304348, 0.93260869565217, 0.44444444444444
51814, 0.1304347826087, 0.90652173913043, 0.44444444444444
51815, 0.1304347826087, 0.93260869565217, 0.47222222222222
51816, 0.08695652173913, 0.93260869565217, 0.027777777777778
51817, 0.10869565217391, 0.93260869565217, 0.055555555555556
51818, 0.08695652173913, 0.90652173913043, 0.055555555555556
51819, 0.08695652173913, 0.93260869565217, 0.083333333333333
51820, 0.10869565217391, 0.93260869565217, 0.11111111111111
51821, 0.08695652173913, 0.90652173913043, 0.11111111111111
51822, 0.08695652173913, 0.93260869565217, 0.13888888888889
51823, 0.10869565217391, 0.93260869565217, 0.16666666666667
51824, 0.08695652173913, 0.90652173913043, 0.16666666666667
51825, 0.08695652173913, 0.93260869565217, 0.19444444444444
51826, 0.10869565217391, 0.93260869565217, 0.22222222222222
51827, 0.08695652173913, 0.90652173913043, 0.22222222222222
51828, 0.08695652173913, 0.93260869565217, 0.25
51829, 0.10869565217391, 0.93260869565217, 0.27777777777778
51830, 0.08695652173913, 0.90652173913043, 0.27777777777778
51831, 0.08695652173913, 0.93260869565217, 0.30555555555556
51832, 0.10869565217391, 0.93260869565217, 0.33333333333333
51833, 0.08695652173913, 0.90652173913043, 0.33333333333333
51834, 0.08695652173913, 0.93260869565217, 0.36111111111111
51835, 0.10869565217391, 0.93260869565217, 0.38888888888889
51836, 0.08695652173913, 0.90652173913043, 0.38888888888889
51837, 0.08695652173913, 0.93260869565217, 0.41666666666667
51838, 0.10869565217391, 0.93260869565217, 0.44444444444444
51839, 0.08695652173913, 0.90652173913043, 0.44444444444444
51840, 0.08695652173913, 0.93260869565217, 0.47222222222222
51841, 0.043478260869565, 0.93260869565217, 0.027777777777778
51842, 0.065217391304348, 0.93260869565217, 0.055555555555556
51843, 0.043478260869565, 0.90652173913043, 0.055555555555556
51844, 0.043478260869565, 0.93260869565217, 0.083333333333333
51845, 0.065217391304348, 0.93260869565217, 0.11111111111111
51846, 0.043478260869565, 0.90652173913043, 0.11111111111111
51847, 0.043478260869565, 0.93260869565217, 0.13888888888889
51848, 0.065217391304348, 0.93260869565217, 0.16666666666667
51849, 0.043478260869565, 0.90652173913043, 0.16666666666667
51850, 0.043478260869565, 0.93260869565217, 0.19444444444444
51851, 0.065217391304348, 0.93260869565217, 0.22222222222222
51852, 0.043478260869565, 0.90652173913043, 0.22222222222222
51853, 0.043478260869565, 0.93260869565217, 0.25
51854, 0.065217391304348, 0.93260869565217, 0.27777777777778
51855, 0.043478260869565, 0.90652173913043, 0.27777777777778
51856, 0.043478260869565, 0.93260869565217, 0.30555555555556
51857, 0.065217391304348, 0.93260869565217, 0.33333333333333
51858, 0.043478260869565, 0.90652173913043, 0.33333333333333
51859, 0.043478260869565, 0.93260869565217, 0.36111111111111
51860, 0.065217391304348, 0.93260869565217, 0.38888888888889
51861, 0.043478260869565, 0.90652173913043, 0.38888888888889
51862, 0.043478260869565, 0.93260869565217, 0.41666666666667
51863, 0.065217391304348, 0.93260869565217, 0.44444444444444
51864, 0.043478260869565, 0.90652173913043, 0.44444444444444
51865, 0.043478260869565, 0.93260869565217, 0.47222222222222
51866, 0.021739130434783, 0.93260869565217, 0.055555555555556
51867, 0.021739130434783, 0.93260869565217, 0.11111111111111
51868, 0.021739130434783, 0.93260869565217, 0.16666666666667
51869, 0.021739130434783, 0.93260869565217, 0.22222222222222
51870, 0.021739130434783, 0.93260869565217, 0.27777777777778
51871, 0.021739130434783, 0.93260869565217, 0.33333333333333
51872, 0.021739130434783, 0.93260869565217, 0.38888888888889
51873, 0.021739130434783, 0.93260869565217, 0.44444444444444
51874, 0.95652173913043, 0.98478260869565, 0.027777777777778
51875, 0.97826086956522, 0.98478260869565, 0.055555555555556
51876, 0.95652173913043, 0.95869565217391, 0.055555555555556
51877, 0.95652173913043, 0.98478260869565, 0.083333333333333
51878, 0.97826086956522, 0.98478260869565, 0.11111111111111
51879, 0.95652173913044, 0.95869565217391, 0.11111111111111
51880, 0.95652173913044, 0.98478260869565, 0.13888888888889
51881, 0.97826086956522, 0.98478260869565, 0.16666666666667
51882, 0.95652173913044, 0.95869565217391, 0.16666666666667
51883, 0.95652173913044, 0.98478260869565, 0.19444444444444
51884, 0.97826086956522, 0.98478260869565, 0.22222222222222
51885, 0.95652173913044, 0.95869565217391, 0.22222222222222
51886, 0.95652173913044, 0.98478260869565, 0.25
51887, 0.97826086956522, 0.98478260869565, 0.27777777777778
51888, 0.95652173913044, 0.95869565217391, 0.27777777777778
51889, 0.95652173913044, 0.98478260869565, 0.30555555555556
51890, 0.97826086956522, 0.98478260869565, 0.33333333333333
51891, 0.95652173913044, 0.95869565217391, 0.33333333333333
51892, 0.95652173913044, 0.98478260869565, 0.36111111111111
51893, 0.97826086956522, 0.98478260869565, 0.38888888888889
51894, 0.95652173913044, 0.95869565217391, 0.38888888888889
51895, 0.95652173913044, 0.98478260869565, 0.41666666666667
51896, 0.97826086956522, 0.98478260869565, 0.44444444444444
51897, 0.95652173913044, 0.95869565217391, 0.44444444444444
51898, 0.95652173913043, 0.98478260869565, 0.47222222222222
51899, 0.91304347826087, 0.98478260869565, 0.027777777777778
51900, 0.93478260869565, 0.98478260869565, 0.055555555555556
51901, 0.91304347826087, 0.95869565217391, 0.055555555555556
51902, 0.91304347826087, 0.98478260869565, 0.083333333333333
51903, 0.93478260869565, 0.98478260869565, 0.11111111111111
51904, 0.91304347826087, 0.95869565217391, 0.11111111111111
51905, 0.91304347826087, 0.98478260869565, 0.13888888888889
51906, 0.93478260869565, 0.98478260869565, 0.16666666666667
51907, 0.91304347826087, 0.95869565217391, 0.16666666666667
51908, 0.91304347826087, 0.98478260869565, 0.19444444444444
51909, 0.93478260869565, 0.98478260869565, 0.22222222222222
51910, 0.91304347826087, 0.95869565217391, 0.22222222222222
51911, 0.91304347826087, 0.98478260869565, 0.25
51912, 0.93478260869565, 0.98478260869565, 0.27777777777778
51913, 0.91304347826087, 0.95869565217391, 0.27777777777778
51914, 0.91304347826087, 0.98478260869565, 0.30555555555556
51915, 0.93478260869565, 0.98478260869565, 0.33333333333333
51916, 0.91304347826087, 0.95869565217391, 0.33333333333333
51917, 0.91304347826087, 0.98478260869565, 0.36111111111111
51918, 0.93478260869565, 0.98478260869565, 0.38888888888889
51919, 0.91304347826087, 0.95869565217391, 0.38888888888889
51920, 0.91304347826087, 0.98478260869565, 0.41666666666667
51921, 0.93478260869565, 0.98478260869565, 0.44444444444444
51922, 0.91304347826087, 0.95869565217391, 0.44444444444444
51923, 0.91304347826087, 0.98478260869565, 0.47222222222222
51924, 0.8695652173913, 0.98478260869565, 0.027777777777778
51925, 0.89130434782609, 0.98478260869565, 0.055555555555556
51926, 0.8695652173913, 0.95869565217391, 0.055555555555556
51927, 0.8695652173913, 0.98478260869565, 0.083333333333333
51928, 0.89130434782609, 0.98478260869565, 0.11111111111111
51929, 0.8695652173913, 0.95869565217391, 0.11111111111111
51930, 0.8695652173913, 0.98478260869565, 0.13888888888889
51931, 0.89130434782609, 0.98478260869565, 0.16666666666667
51932, 0.8695652173913, 0.95869565217391, 0.16666666666667
51933, 0.8695652173913, 0.98478260869565, 0.19444444444444
51934, 0.89130434782609, 0.98478260869565, 0.22222222222222
51935, 0.8695652173913, 0.95869565217391, 0.22222222222222
51936, 0.8695652173913, 0.98478260869565, 0.25
51937, 0.89130434782609, 0.98478260869565, 0.27777777777778
51938, 0.8695652173913, 0.95869565217391, 0.27777777777778
51939, 0.8695652173913, 0.98478260869565, 0.30555555555556
51940, 0.89130434782609, 0.98478260869565, 0.33333333333333
51941, 0.8695652173913, 0.95869565217391, 0.33333333333333
51942, 0.8695652173913, 0.98478260869565, 0.36111111111111
51943, 0.89130434782609, 0.98478260869565, 0.38888888888889
51944, 0.8695652173913, 0.95869565217391, 0.38888888888889
51945, 0.8695652173913, 0.98478260869565, 0.41666666666667
51946, 0.89130434782609, 0.98478260869565, 0.44444444444444
51947, 0.8695652173913, 0.95869565217391, 0.44444444444444
51948, 0.8695652173913, 0.98478260869565, 0.47222222222222
51949, 0.82608695652174, 0.98478260869565, 0.027777777777778
51950, 0.84782608695652, 0.98478260869565, 0.055555555555556
51951, 0.82608695652174, 0.95869565217391, 0.055555555555556
51952, 0.82608695652174, 0.98478260869565, 0.083333333333333
51953, 0.84782608695652, 0.98478260869565, 0.11111111111111
51954, 0.82608695652174, 0.95869565217391, 0.11111111111111
51955, 0.82608695652174, 0.98478260869565, 0.13888888888889
51956, 0.84782608695652, 0.98478260869565, 0.16666666666667
51957, 0.82608695652174, 0.95869565217391, 0.16666666666667
51958, 0.82608695652174, 0.98478260869565, 0.19444444444444
51959, 0.84782608695652, 0.98478260869565, 0.22222222222222
51960, 0.82608695652174, 0.95869565217391, 0.22222222222222
51961, 0.82608695652174, 0.98478260869565, 0.25
51962, 0.84782608695652, 0.98478260869565, 0.27777777777778
51963, 0.82608695652174, 0.95869565217391, 0.27777777777778
51964, 0.82608695652174, 0.98478260869565, 0.30555555555556
51965, 0.84782608695652, 0.98478260869565, 0.33333333333333
51966, 0.82608695652174, 0.95869565217391, 0.33333333333333
51967, 0.82608695652174, 0.98478260869565, 0.36111111111111
51968, 0.84782608695652, 0.98478260869565, 0.38888888888889
51969, 0.82608695652174, 0.95869565217391, 0.38888888888889
51970, 0.82608695652174, 0.98478260869565, 0.41666666666667
51971, 0.84782608695652, 0.98478260869565, 0.44444444444444
51972, 0.82608695652174, 0.95869565217391, 0.44444444444444
51973, 0.82608695652174, 0.98478260869565, 0.47222222222222
51974, 0.78260869565217, 0.98478260869565, 0.027777777777778
51975, 0.80434782608696, 0.98478260869565, 0.055555555555556
51976, 0.78260869565217, 0.95869565217391, 0.055555555555556
51977, 0.78260869565217, 0.98478260869565, 0.083333333333333
51978, 0.80434782608696, 0.98478260869565, 0.11111111111111
51979, 0.78260869565217, 0.95869565217391, 0.11111111111111
51980, 0.78260869565217, 0.98478260869565, 0.13888888888889
51981, 0.80434782608696, 0.98478260869565, 0.16666666666667
51982, 0.78260869565217, 0.95869565217391, 0.16666666666667
51983, 0.78260869565217, 0.98478260869565, 0.19444444444444
51984, 0.80434782608696, 0.98478260869565, 0.22222222222222
51985, 0.78260869565217, 0.95869565217391, 0.22222222222222
51986, 0.78260869565217, 0.98478260869565, 0.25
51987, 0.80434782608696, 0.98478260869565, 0.27777777777778
51988, 0.78260869565217, 0.95869565217391, 0.27777777777778
51989, 0.78260869565217, 0.98478260869565, 0.30555555555556
51990, 0.80434782608696, 0.98478260869565, 0.33333333333333
51991, 0.78260869565217, 0.95869565217391, 0.33333333333333
51992, 0.78260869565217, 0.98478260869565, 0.36111111111111
51993, 0.80434782608696, 0.98478260869565, 0.38888888888889
51994, 0.78260869565217, 0.95869565217391, 0.38888888888889
51995, 0.78260869565217, 0.98478260869565, 0.41666666666667
51996, 0.80434782608696, 0.98478260869565, 0.44444444444444
51997, 0.78260869565217, 0.95869565217391, 0.44444444444444
51998, 0.78260869565217, 0.98478260869565, 0.47222222222222
51999, 0.73913043478261, 0.98478260869565, 0.027777777777778
52000, 0.76086956521739, 0.98478260869565, 0.055555555555556
52001, 0.73913043478261, 0.95869565217391, 0.055555555555556
52002, 0.73913043478261, 0.98478260869565, 0.083333333333333
52003, 0.76086956521739, 0.98478260869565, 0.11111111111111
52004, 0.73913043478261, 0.95869565217391, 0.11111111111111
52005, 0.73913043478261, 0.98478260869565, 0.13888888888889
52006, 0.76086956521739, 0.98478260869565, 0.16666666666667
52007, 0.73913043478261, 0.95869565217391, 0.16666666666667
52008, 0.73913043478261, 0.98478260869565, 0.19444444444444
52009, 0.76086956521739, 0.98478260869565, 0.22222222222222
52010, 0.73913043478261, 0.95869565217391, 0.22222222222222
52011, 0.73913043478261, 0.98478260869565, 0.25
52012, 0.76086956521739, 0.98478260869565, 0.27777777777778
52013, 0.73913043478261, 0.95869565217391, 0.27777777777778
52014, 0.73913043478261, 0.98478260869565, 0.30555555555556
52015, 0.76086956521739, 0.98478260869565, 0.33333333333333
52016, 0.73913043478261, 0.95869565217391, 0.33333333333333
52017, 0.73913043478261, 0.98478260869565, 0.36111111111111
52018, 0.76086956521739, 0.98478260869565, 0.38888888888889
52019, 0.73913043478261, 0.95869565217391, 0.38888888888889
52020, 0.73913043478261, 0.98478260869565, 0.41666666666667
52021, 0.76086956521739, 0.98478260869565, 0.44444444444444
52022, 0.73913043478261, 0.95869565217391, 0.44444444444444
52023, 0.73913043478261, 0.98478260869565, 0.47222222222222
52024, 0.69565217391304, 0.98478260869565, 0.027777777777778
52025, 0.71739130434783, 0.98478260869565, 0.055555555555556
52026, 0.69565217391304, 0.95869565217391, 0.055555555555556
52027, 0.69565217391304, 0.98478260869565, 0.083333333333333
52028, 0.71739130434783, 0.98478260869565, 0.11111111111111
52029, 0.69565217391304, 0.95869565217391, 0.11111111111111
52030, 0.69565217391304, 0.98478260869565, 0.13888888888889
52031, 0.71739130434783, 0.98478260869565, 0.16666666666667
52032, 0.69565217391304, 0.95869565217391, 0.16666666666667
52033, 0.69565217391304, 0.98478260869565, 0.19444444444444
52034, 0.71739130434783, 0.98478260869565, 0.22222222222222
52035, 0.69565217391304, 0.95869565217391, 0.22222222222222
52036, 0.69565217391304, 0.98478260869565, 0.25
52037, 0.71739130434783, 0.98478260869565, 0.27777777777778
52038, 0.69565217391304, 0.95869565217391, 0.27777777777778
52039, 0.69565217391304, 0.98478260869565, 0.30555555555556
52040, 0.71739130434783, 0.98478260869565, 0.33333333333333
52041, 0.69565217391304, 0.95869565217391, 0.33333333333333
52042, 0.69565217391304, 0.98478260869565, 0.36111111111111
52043, 0.71739130434783, 0.98478260869565, 0.38888888888889
52044, 0.69565217391304, 0.95869565217391, 0.38888888888889
52045, 0.69565217391304, 0.98478260869565, 0.41666666666667
52046, 0.71739130434783, 0.98478260869565, 0.44444444444444
52047, 0.69565217391304, 0.95869565217391, 0.44444444444444
52048, 0.69565217391304, 0.98478260869565, 0.47222222222222
52049, 0.65217391304348, 0.98478260869565, 0.027777777777778
52050, 0.67391304347826, 0.98478260869565, 0.055555555555556
52051, 0.65217391304348, 0.95869565217391, 0.055555555555556
52052, 0.65217391304348, 0.98478260869565, 0.083333333333333
52053, 0.67391304347826, 0.98478260869565, 0.11111111111111
52054, 0.65217391304348, 0.95869565217391, 0.11111111111111
52055, 0.65217391304348, 0.98478260869565, 0.13888888888889
52056, 0.67391304347826, 0.98478260869565, 0.16666666666667
52057, 0.65217391304348, 0.95869565217391, 0.16666666666667
52058, 0.65217391304348, 0.98478260869565, 0.19444444444444
52059, 0.67391304347826, 0.98478260869565, 0.22222222222222
52060, 0.65217391304348, 0.95869565217391, 0.22222222222222
52061, 0.65217391304348, 0.98478260869565, 0.25
52062, 0.67391304347826, 0.98478260869565, 0.27777777777778
52063, 0.65217391304348, 0.95869565217391, 0.27777777777778
52064, 0.65217391304348, 0.98478260869565, 0.30555555555556
52065, 0.67391304347826, 0.98478260869565, 0.33333333333333
52066, 0.65217391304348, 0.95869565217391, 0.33333333333333
52067, 0.65217391304348, 0.98478260869565, 0.36111111111111
52068, 0.67391304347826, 0.98478260869565, 0.38888888888889
52069, 0.65217391304348, 0.95869565217391, 0.38888888888889
52070, 0.65217391304348, 0.98478260869565, 0.41666666666667
52071, 0.67391304347826, 0.98478260869565, 0.44444444444444
52072, 0.65217391304348, 0.95869565217391, 0.44444444444444
52073, 0.65217391304348, 0.98478260869565, 0.47222222222222
52074, 0.60869565217391, 0.98478260869565, 0.027777777777778
52075, 0.6304347826087, 0.98478260869565, 0.055555555555556
52076, 0.60869565217391, 0.95869565217391, 0.055555555555556
52077, 0.60869565217391, 0.98478260869565, 0.083333333333333
52078, 0.6304347826087, 0.98478260869565, 0.11111111111111
52079, 0.60869565217391, 0.95869565217391, 0.11111111111111
52080, 0.60869565217391, 0.98478260869565, 0.13888888888889
52081, 0.6304347826087, 0.98478260869565, 0.16666666666667
52082, 0.60869565217391, 0.95869565217391, 0.16666666666667
52083, 0.60869565217391, 0.98478260869565, 0.19444444444444
52084, 0.6304347826087, 0.98478260869565, 0.22222222222222
52085, 0.60869565217391, 0.95869565217391, 0.22222222222222
52086, 0.60869565217391, 0.98478260869565, 0.25
52087, 0.6304347826087, 0.98478260869565, 0.27777777777778
52088, 0.60869565217391, 0.95869565217391, 0.27777777777778
52089, 0.60869565217391, 0.98478260869565, 0.30555555555556
52090, 0.6304347826087, 0.98478260869565, 0.33333333333333
52091, 0.60869565217391, 0.95869565217391, 0.33333333333333
52092, 0.60869565217391, 0.98478260869565, 0.36111111111111
52093, 0.6304347826087, 0.98478260869565, 0.38888888888889
52094, 0.60869565217391, 0.95869565217391, 0.38888888888889
52095, 0.60869565217391, 0.98478260869565, 0.41666666666667
52096, 0.6304347826087, 0.98478260869565, 0.44444444444444
52097, 0.60869565217391, 0.95869565217391, 0.44444444444444
52098, 0.60869565217391, 0.98478260869565, 0.47222222222222
52099, 0.56521739130435, 0.98478260869565, 0.027777777777778
52100, 0.58695652173913, 0.98478260869565, 0.055555555555556
52101, 0.56521739130435, 0.95869565217391, 0.055555555555556
52102, 0.56521739130435, 0.98478260869565, 0.083333333333333
52103, 0.58695652173913, 0.98478260869565, 0.11111111111111
52104, 0.56521739130435, 0.95869565217391, 0.11111111111111
52105, 0.56521739130435, 0.98478260869565, 0.13888888888889
52106, 0.58695652173913, 0.98478260869565, 0.16666666666667
52107, 0.56521739130435, 0.95869565217391, 0.16666666666667
52108, 0.56521739130435, 0.98478260869565, 0.19444444444444
52109, 0.58695652173913, 0.98478260869565, 0.22222222222222
52110, 0.56521739130435, 0.95869565217391, 0.22222222222222
52111, 0.56521739130435, 0.98478260869565, 0.25
52112, 0.58695652173913, 0.98478260869565, 0.27777777777778
52113, 0.56521739130435, 0.95869565217391, 0.27777777777778
52114, 0.56521739130435, 0.98478260869565, 0.30555555555556
52115, 0.58695652173913, 0.98478260869565, 0.33333333333333
52116, 0.56521739130435, 0.95869565217391, 0.33333333333333
52117, 0.56521739130435, 0.98478260869565, 0.36111111111111
52118, 0.58695652173913, 0.98478260869565, 0.38888888888889
52119, 0.56521739130435, 0.95869565217391, 0.38888888888889
52120, 0.56521739130435, 0.98478260869565, 0.41666666666667
52121, 0.58695652173913, 0.98478260869565, 0.44444444444444
52122, 0.56521739130435, 0.95869565217391, 0.44444444444444
52123, 0.56521739130435, 0.98478260869565, 0.47222222222222
52124, 0.52173913043478, 0.98478260869565, 0.027777777777778
52125, 0.54347826086957, 0.98478260869565, 0.055555555555556
52126, 0.52173913043478, 0.95869565217391, 0.055555555555556
52127, 0.52173913043478, 0.98478260869565, 0.083333333333333
52128, 0.54347826086957, 0.98478260869565, 0.11111111111111
52129, 0.52173913043478, 0.95869565217391, 0.11111111111111
52130, 0.52173913043478, 0.98478260869565, 0.13888888888889
52131, 0.54347826086957, 0.98478260869565, 0.16666666666667
52132, 0.52173913043478, 0.95869565217391, 0.16666666666667
52133, 0.52173913043478, 0.98478260869565, 0.19444444444444
52134, 0.54347826086956, 0.98478260869565, 0.22222222222222
52135, 0.52173913043478, 0.95869565217391, 0.22222222222222
52136, 0.52173913043478, 0.98478260869565, 0.25
52137, 0.54347826086956, 0.98478260869565, 0.27777777777778
52138, 0.52173913043478, 0.95869565217391, 0.27777777777778
52139, 0.52173913043478, 0.98478260869565, 0.30555555555556
52140, 0.54347826086956, 0.98478260869565, 0.33333333333333
52141, 0.52173913043478, 0.95869565217391, 0.33333333333333
52142, 0.52173913043478, 0.98478260869565, 0.36111111111111
52143, 0.54347826086956, 0.98478260869565, 0.38888888888889
52144, 0.52173913043478, 0.95869565217391, 0.38888888888889
52145, 0.52173913043478, 0.98478260869565, 0.41666666666667
52146, 0.54347826086956, 0.98478260869565, 0.44444444444444
52147, 0.52173913043478, 0.95869565217391, 0.44444444444444
52148, 0.52173913043478, 0.98478260869565, 0.47222222222222
52149, 0.47826086956522, 0.98478260869565, 0.027777777777778
52150, 0.5, 0.98478260869565, 0.055555555555556
52151, 0.47826086956522, 0.95869565217391, 0.055555555555556
52152, 0.47826086956522, 0.98478260869565, 0.083333333333333
52153, 0.5, 0.98478260869565, 0.11111111111111
52154, 0.47826086956522, 0.95869565217391, 0.11111111111111
52155, 0.47826086956522, 0.98478260869565, 0.13888888888889
52156, 0.5, 0.98478260869565, 0.16666666666667
52157, 0.47826086956522, 0.95869565217391, 0.16666666666667
52158, 0.47826086956522, 0.98478260869565, 0.19444444444444
52159, 0.5, 0.98478260869565, 0.22222222222222
52160, 0.47826086956522, 0.95869565217391, 0.22222222222222
52161, 0.47826086956522, 0.98478260869565, 0.25
52162, 0.5, 0.98478260869565, 0.27777777777778
52163, 0.47826086956522, 0.95869565217391, 0.27777777777778
52164, 0.47826086956522, 0.98478260869565, 0.30555555555556
52165, 0.5, 0.98478260869565, 0.33333333333333
52166, 0.47826086956522, 0.95869565217391, 0.33333333333333
52167, 0.47826086956522, 0.98478260869565, 0.36111111111111
52168, 0.5, 0.98478260869565, 0.38888888888889
52169, 0.47826086956522, 0.95869565217391, 0.38888888888889
52170, 0.47826086956522, 0.98478260869565, 0.41666666666667
52171, 0.5, 0.98478260869565, 0.44444444444444
52172, 0.47826086956522, 0.95869565217391, 0.44444444444444
52173, 0.47826086956522, 0.98478260869565, 0.47222222222222
52174, 0.43478260869565, 0.98478260869565, 0.027777777777778
52175, 0.45652173913043, 0.98478260869565, 0.055555555555556
52176, 0.43478260869565, 0.95869565217391, 0.055555555555556
52177, 0.43478260869565, 0.98478260869565, 0.083333333333333
52178, 0.45652173913043, 0.98478260869565, 0.11111111111111
52179, 0.43478260869565, 0.95869565217391, 0.11111111111111
52180, 0.43478260869565, 0.98478260869565, 0.13888888888889
52181, 0.45652173913043, 0.98478260869565, 0.16666666666667
52182, 0.43478260869565, 0.95869565217391, 0.16666666666667
52183, 0.43478260869565, 0.98478260869565, 0.19444444444444
52184, 0.45652173913043, 0.98478260869565, 0.22222222222222
52185, 0.43478260869565, 0.95869565217391, 0.22222222222222
52186, 0.43478260869565, 0.98478260869565, 0.25
52187, 0.45652173913043, 0.98478260869565, 0.27777777777778
52188, 0.43478260869565, 0.95869565217391, 0.27777777777778
52189, 0.43478260869565, 0.98478260869565, 0.30555555555556
52190, 0.45652173913043, 0.98478260869565, 0.33333333333333
52191, 0.43478260869565, 0.95869565217391, 0.33333333333333
52192, 0.43478260869565, 0.98478260869565, 0.36111111111111
52193, 0.45652173913043, 0.98478260869565, 0.38888888888889
52194, 0.43478260869565, 0.95869565217391, 0.38888888888889
52195, 0.43478260869565, 0.98478260869565, 0.41666666666667
52196, 0.45652173913043, 0.98478260869565, 0.44444444444444
52197, 0.43478260869565, 0.95869565217391, 0.44444444444444
52198, 0.43478260869565, 0.98478260869565, 0.47222222222222
52199, 0.39130434782609, 0.98478260869565, 0.027777777777778
52200, 0.41304347826087, 0.98478260869565, 0.055555555555556
52201, 0.39130434782609, 0.95869565217391, 0.055555555555556
52202, 0.39130434782609, 0.98478260869565, 0.083333333333333
52203, 0.41304347826087, 0.98478260869565, 0.11111111111111
52204, 0.39130434782609, 0.95869565217391, 0.11111111111111
52205, 0.39130434782609, 0.98478260869565, 0.13888888888889
52206, 0.41304347826087, 0.98478260869565, 0.16666666666667
52207, 0.39130434782609, 0.95869565217391, 0.16666666666667
52208, 0.39130434782609, 0.98478260869565, 0.19444444444444
52209, 0.41304347826087, 0.98478260869565, 0.22222222222222
52210, 0.39130434782609, 0.95869565217391, 0.22222222222222
52211, 0.39130434782609, 0.98478260869565, 0.25
52212, 0.41304347826087, 0.98478260869565, 0.27777777777778
52213, 0.39130434782609, 0.95869565217391, 0.27777777777778
52214, 0.39130434782609, 0.98478260869565, 0.30555555555556
52215, 0.41304347826087, 0.98478260869565, 0.33333333333333
52216, 0.39130434782609, 0.95869565217391, 0.33333333333333
52217, 0.39130434782609, 0.98478260869565, 0.36111111111111
52218, 0.41304347826087, 0.98478260869565, 0.38888888888889
52219, 0.39130434782609, 0.95869565217391, 0.38888888888889
52220, 0.39130434782609, 0.98478260869565, 0.41666666666667
52221, 0.41304347826087, 0.98478260869565, 0.44444444444444
52222, 0.39130434782609, 0.95869565217391, 0.44444444444444
52223, 0.39130434782609, 0.98478260869565, 0.47222222222222
52224, 0.34782608695652, 0.98478260869565, 0.027777777777778
52225, 0.3695652173913, 0.98478260869565, 0.055555555555556
52226, 0.34782608695652, 0.95869565217391, 0.055555555555556
52227, 0.34782608695652, 0.98478260869565, 0.083333333333333
52228, 0.3695652173913, 0.98478260869565, 0.11111111111111
52229, 0.34782608695652, 0.95869565217391, 0.11111111111111
52230, 0.34782608695652, 0.98478260869565, 0.13888888888889
52231, 0.3695652173913, 0.98478260869565, 0.16666666666667
52232, 0.34782608695652, 0.95869565217391, 0.16666666666667
52233, 0.34782608695652, 0.98478260869565, 0.19444444444444
52234, 0.3695652173913, 0.98478260869565, 0.22222222222222
52235, 0.34782608695652, 0.95869565217391, 0.22222222222222
52236, 0.34782608695652, 0.98478260869565, 0.25
52237, 0.3695652173913, 0.98478260869565, 0.27777777777778
52238, 0.34782608695652, 0.95869565217391, 0.27777777777778
52239, 0.34782608695652, 0.98478260869565, 0.30555555555556
52240, 0.3695652173913, 0.98478260869565, 0.33333333333333
52241, 0.34782608695652, 0.95869565217391, 0.33333333333333
52242, 0.34782608695652, 0.98478260869565, 0.36111111111111
52243, 0.3695652173913, 0.98478260869565, 0.38888888888889
52244, 0.34782608695652, 0.95869565217391, 0.38888888888889
52245, 0.34782608695652, 0.98478260869565, 0.41666666666667
52246, 0.3695652173913, 0.98478260869565, 0.44444444444444
52247, 0.34782608695652, 0.95869565217391, 0.44444444444444
52248, 0.34782608695652, 0.98478260869565, 0.47222222222222
52249, 0.30434782608696, 0.98478260869565, 0.027777777777778
52250, 0.32608695652174, 0.98478260869565, 0.055555555555556
52251, 0.30434782608696, 0.95869565217391, 0.055555555555556
52252, 0.30434782608696, 0.98478260869565, 0.083333333333333
52253, 0.32608695652174, 0.98478260869565, 0.11111111111111
52254, 0.30434782608696, 0.95869565217391, 0.11111111111111
52255, 0.30434782608696, 0.98478260869565, 0.13888888888889
52256, 0.32608695652174, 0.98478260869565, 0.16666666666667
52257, 0.30434782608696, 0.95869565217391, 0.16666666666667
52258, 0.30434782608696, 0.98478260869565, 0.19444444444444
52259, 0.32608695652174, 0.98478260869565, 0.22222222222222
52260, 0.30434782608696, 0.95869565217391, 0.22222222222222
52261, 0.30434782608696, 0.98478260869565, 0.25
52262, 0.32608695652174, 0.98478260869565, 0.27777777777778
52263, 0.30434782608696, 0.95869565217391, 0.27777777777778
52264, 0.30434782608696, 0.98478260869565, 0.30555555555556
52265, 0.32608695652174, 0.98478260869565, 0.33333333333333
52266, 0.30434782608696, 0.95869565217391, 0.33333333333333
52267, 0.30434782608696, 0.98478260869565, 0.36111111111111
52268, 0.32608695652174, 0.98478260869565, 0.38888888888889
52269, 0.30434782608696, 0.95869565217391, 0.38888888888889
52270, 0.30434782608696, 0.98478260869565, 0.41666666666667
52271, 0.32608695652174, 0.98478260869565, 0.44444444444444
52272, 0.30434782608696, 0.95869565217391, 0.44444444444444
52273, 0.30434782608696, 0.98478260869565, 0.47222222222222
52274, 0.26086956521739, 0.98478260869565, 0.027777777777778
52275, 0.28260869565217, 0.98478260869565, 0.055555555555556
52276, 0.26086956521739, 0.95869565217391, 0.055555555555556
52277, 0.26086956521739, 0.98478260869565, 0.083333333333333
52278, 0.28260869565217, 0.98478260869565, 0.11111111111111
52279, 0.26086956521739, 0.95869565217391, 0.11111111111111
52280, 0.26086956521739, 0.98478260869565, 0.13888888888889
52281, 0.28260869565217, 0.98478260869565, 0.16666666666667
52282, 0.26086956521739, 0.95869565217391, 0.16666666666667
52283, 0.26086956521739, 0.98478260869565, 0.19444444444444
52284, 0.28260869565217, 0.98478260869565, 0.22222222222222
52285, 0.26086956521739, 0.95869565217391, 0.22222222222222
52286, 0.26086956521739, 0.98478260869565, 0.25
52287, 0.28260869565217, 0.98478260869565, 0.27777777777778
52288, 0.26086956521739, 0.95869565217391, 0.27777777777778
52289, 0.26086956521739, 0.98478260869565, 0.30555555555556
52290, 0.28260869565217, 0.98478260869565, 0.33333333333333
52291, 0.26086956521739, 0.95869565217391, 0.33333333333333
52292, 0.26086956521739, 0.98478260869565, 0.36111111111111
52293, 0.28260869565217, 0.98478260869565, 0.38888888888889
52294, 0.26086956521739, 0.95869565217391, 0.38888888888889
52295, 0.26086956521739, 0.98478260869565, 0.41666666666667
52296, 0.28260869565217, 0.98478260869565, 0.44444444444444
52297, 0.26086956521739, 0.95869565217391, 0.44444444444444
52298, 0.26086956521739, 0.98478260869565, 0.47222222222222
52299, 0.21739130434783, 0.98478260869565, 0.027777777777778
52300, 0.23913043478261, 0.98478260869565, 0.055555555555556
52301, 0.21739130434783, 0.95869565217391, 0.055555555555556
52302, 0.21739130434783, 0.98478260869565, 0.083333333333333
52303, 0.23913043478261, 0.98478260869565, 0.11111111111111
52304, 0.21739130434783, 0.95869565217391, 0.11111111111111
52305, 0.21739130434783, 0.98478260869565, 0.13888888888889
52306, 0.23913043478261, 0.98478260869565, 0.16666666666667
52307, 0.21739130434783, 0.95869565217391, 0.16666666666667
52308, 0.21739130434783, 0.98478260869565, 0.19444444444444
52309, 0.23913043478261, 0.98478260869565, 0.22222222222222
52310, 0.21739130434783, 0.95869565217391, 0.22222222222222
52311, 0.21739130434783, 0.98478260869565, 0.25
52312, 0.23913043478261, 0.98478260869565, 0.27777777777778
52313, 0.21739130434783, 0.95869565217391, 0.27777777777778
52314, 0.21739130434783, 0.98478260869565, 0.30555555555556
52315, 0.23913043478261, 0.98478260869565, 0.33333333333333
52316, 0.21739130434783, 0.95869565217391, 0.33333333333333
52317, 0.21739130434783, 0.98478260869565, 0.36111111111111
52318, 0.23913043478261, 0.98478260869565, 0.38888888888889
52319, 0.21739130434783, 0.95869565217391, 0.38888888888889
52320, 0.21739130434783, 0.98478260869565, 0.41666666666667
52321, 0.23913043478261, 0.98478260869565, 0.44444444444444
52322, 0.21739130434783, 0.95869565217391, 0.44444444444444
52323, 0.21739130434783, 0.98478260869565, 0.47222222222222
52324, 0.17391304347826, 0.98478260869565, 0.027777777777778
52325, 0.19565217391304, 0.98478260869565, 0.055555555555556
52326, 0.17391304347826, 0.95869565217391, 0.055555555555556
52327, 0.17391304347826, 0.98478260869565, 0.083333333333333
52328, 0.19565217391304, 0.98478260869565, 0.11111111111111
52329, 0.17391304347826, 0.95869565217391, 0.11111111111111
52330, 0.17391304347826, 0.98478260869565, 0.13888888888889
52331, 0.19565217391304, 0.98478260869565, 0.16666666666667
52332, 0.17391304347826, 0.95869565217391, 0.16666666666667
52333, 0.17391304347826, 0.98478260869565, 0.19444444444444
52334, 0.19565217391304, 0.98478260869565, 0.22222222222222
52335, 0.17391304347826, 0.95869565217391, 0.22222222222222
52336, 0.17391304347826, 0.98478260869565, 0.25
52337, 0.19565217391304, 0.98478260869565, 0.27777777777778
52338, 0.17391304347826, 0.95869565217391, 0.27777777777778
52339, 0.17391304347826, 0.98478260869565, 0.30555555555556
52340, 0.19565217391304, 0.98478260869565, 0.33333333333333
52341, 0.17391304347826, 0.95869565217391, 0.33333333333333
52342, 0.17391304347826, 0.98478260869565, 0.36111111111111
52343, 0.19565217391304, 0.98478260869565, 0.38888888888889
52344, 0.17391304347826, 0.95869565217391, 0.38888888888889
52345, 0.17391304347826, 0.98478260869565, 0.41666666666667
52346, 0.19565217391304, 0.98478260869565, 0.44444444444444
52347, 0.17391304347826, 0.95869565217391, 0.44444444444444
52348, 0.17391304347826, 0.98478260869565, 0.47222222222222
52349, 0.1304347826087, 0.98478260869565, 0.027777777777778
52350, 0.15217391304348, 0.98478260869565, 0.055555555555556
52351, 0.1304347826087, 0.95869565217391, 0.055555555555556
52352, 0.1304347826087, 0.98478260869565, 0.083333333333333
52353, 0.15217391304348, 0.98478260869565, 0.11111111111111
52354, 0.1304347826087, 0.95869565217391, 0.11111111111111
52355, 0.1304347826087, 0.98478260869565, 0.13888888888889
52356, 0.15217391304348, 0.98478260869565, 0.16666666666667
52357, 0.1304347826087, 0.95869565217391, 0.16666666666667
52358, 0.1304347826087, 0.98478260869565, 0.19444444444444
52359, 0.15217391304348, 0.98478260869565, 0.22222222222222
52360, 0.1304347826087, 0.95869565217391, 0.22222222222222
52361, 0.1304347826087, 0.98478260869565, 0.25
52362, 0.15217391304348, 0.98478260869565, 0.27777777777778
52363, 0.1304347826087, 0.95869565217391, 0.27777777777778
52364, 0.1304347826087, 0.98478260869565, 0.30555555555556
52365, 0.15217391304348, 0.98478260869565, 0.33333333333333
52366, 0.1304347826087, 0.95869565217391, 0.33333333333333
52367, 0.1304347826087, 0.98478260869565, 0.36111111111111
52368, 0.15217391304348, 0.98478260869565, 0.38888888888889
52369, 0.1304347826087, 0.95869565217391, 0.38888888888889
52370, 0.1304347826087, 0.98478260869565, 0.41666666666667
52371, 0.15217391304348, 0.98478260869565, 0.44444444444444
52372, 0.1304347826087, 0.95869565217391, 0.44444444444444
52373, 0.1304347826087, 0.98478260869565, 0.47222222222222
52374, 0.08695652173913, 0.98478260869565, 0.027777777777778
52375, 0.10869565217391, 0.98478260869565, 0.055555555555556
52376, 0.08695652173913, 0.95869565217391, 0.055555555555556
52377, 0.08695652173913, 0.98478260869565, 0.083333333333333
52378, 0.10869565217391, 0.98478260869565, 0.11111111111111
52379, 0.08695652173913, 0.95869565217391, 0.11111111111111
52380, 0.08695652173913, 0.98478260869565, 0.13888888888889
52381, 0.10869565217391, 0.98478260869565, 0.16666666666667
52382, 0.08695652173913, 0.95869565217391, 0.16666666666667
52383, 0.08695652173913, 0.98478260869565, 0.19444444444444
52384, 0.10869565217391, 0.98478260869565, 0.22222222222222
52385, 0.08695652173913, 0.95869565217391, 0.22222222222222
52386, 0.08695652173913, 0.98478260869565, 0.25
52387, 0.10869565217391, 0.98478260869565, 0.27777777777778
52388, 0.08695652173913, 0.95869565217391, 0.27777777777778
52389, 0.08695652173913, 0.98478260869565, 0.30555555555556
52390, 0.10869565217391, 0.98478260869565, 0.33333333333333
52391, 0.08695652173913, 0.95869565217391, 0.33333333333333
52392, 0.08695652173913, 0.98478260869565, 0.36111111111111
52393, 0.10869565217391, 0.98478260869565, 0.38888888888889
52394, 0.08695652173913, 0.95869565217391, 0.38888888888889
52395, 0.08695652173913, 0.98478260869565, 0.41666666666667
52396, 0.10869565217391, 0.98478260869565, 0.44444444444444
52397, 0.08695652173913, 0.95869565217391, 0.44444444444444
52398, 0.08695652173913, 0.98478260869565, 0.47222222222222
52399, 0.043478260869565, 0.98478260869565, 0.027777777777778
52400, 0.065217391304348, 0.98478260869565, 0.055555555555556
52401, 0.043478260869565, 0.95869565217391, 0.055555555555556
52402, 0.043478260869565, 0.98478260869565, 0.083333333333333
52403, 0.065217391304348, 0.98478260869565, 0.11111111111111
52404, 0.043478260869565, 0.95869565217391, 0.11111111111111
52405, 0.043478260869565, 0.98478260869565, 0.13888888888889
52406, 0.065217391304348, 0.98478260869565, 0.16666666666667
52407, 0.043478260869565, 0.95869565217391, 0.16666666666667
52408, 0.043478260869565, 0.98478260869565, 0.19444444444444
52409, 0.065217391304348, 0.98478260869565, 0.22222222222222
52410, 0.043478260869565, 0.95869565217391, 0.22222222222222
52411, 0.043478260869565, 0.98478260869565, 0.25
52412, 0.065217391304348, 0.98478260869565, 0.27777777777778
52413, 0.043478260869565, 0.95869565217391, 0.27777777777778
52414, 0.043478260869565, 0.98478260869565, 0.30555555555556
52415, 0.065217391304348, 0.98478260869565, 0.33333333333333
52416, 0.043478260869565, 0.95869565217391, 0.33333333333333
52417, 0.043478260869565, 0.98478260869565, 0.36111111111111
52418, 0.065217391304348, 0.98478260869565, 0.38888888888889
52419, 0.043478260869565, 0.95869565217391, 0.38888888888889
52420, 0.043478260869565, 0.98478260869565, 0.41666666666667
52421, 0.065217391304348, 0.98478260869565, 0.44444444444444
52422, 0.043478260869565, 0.95869565217391, 0.44444444444444
52423, 0.043478260869565, 0.98478260869565, 0.47222222222222
52424, 0.021739130434783, 0.98478260869565, 0.055555555555556
52425, 0.021739130434783, 0.98478260869565, 0.11111111111111
52426, 0.021739130434783, 0.98478260869565, 0.16666666666667
52427, 0.021739130434783, 0.98478260869565, 0.22222222222222
52428, 0.021739130434783, 0.98478260869565, 0.27777777777778
52429, 0.021739130434783, 0.98478260869565, 0.33333333333333
52430, 0.021739130434783, 0.98478260869565, 0.38888888888889
52431, 0.021739130434783, 0.98478260869565, 0.44444444444444
52432, 0.95652173913043, 1.0369565217391, 0.027777777777778
52433, 0.97826086956522, 1.0369565217391, 0.055555555555556
52434, 0.95652173913043, 1.0108695652174, 0.055555555555556
52435, 0.95652173913043, 1.0369565217391, 0.083333333333333
52436, 0.97826086956522, 1.0369565217391, 0.11111111111111
52437, 0.95652173913044, 1.0108695652174, 0.11111111111111
52438, 0.95652173913044, 1.0369565217391, 0.13888888888889
52439, 0.97826086956522, 1.0369565217391, 0.16666666666667
52440, 0.95652173913044, 1.0108695652174, 0.16666666666667
52441, 0.95652173913044, 1.0369565217391, 0.19444444444444
52442, 0.97826086956522, 1.0369565217391, 0.22222222222222
52443, 0.95652173913044, 1.0108695652174, 0.22222222222222
52444, 0.95652173913044, 1.0369565217391, 0.25
52445, 0.97826086956522, 1.0369565217391, 0.27777777777778
52446, 0.95652173913044, 1.0108695652174, 0.27777777777778
52447, 0.95652173913044, 1.0369565217391, 0.30555555555556
52448, 0.97826086956522, 1.0369565217391, 0.33333333333333
52449, 0.95652173913044, 1.0108695652174, 0.33333333333333
52450, 0.95652173913044, 1.0369565217391, 0.36111111111111
52451, 0.97826086956522, 1.0369565217391, 0.38888888888889
52452, 0.95652173913044, 1.0108695652174, 0.38888888888889
52453, 0.95652173913044, 1.0369565217391, 0.41666666666667
52454, 0.97826086956522, 1.0369565217391, 0.44444444444444
52455, 0.95652173913044, 1.0108695652174, 0.44444444444444
52456, 0.95652173913043, 1.0369565217391, 0.47222222222222
52457, 0.91304347826087, 1.0369565217391, 0.027777777777778
52458, 0.93478260869565, 1.0369565217391, 0.055555555555556
52459, 0.91304347826087, 1.0108695652174, 0.055555555555556
52460, 0.91304347826087, 1.0369565217391, 0.083333333333333
52461, 0.93478260869565, 1.0369565217391, 0.11111111111111
52462, 0.91304347826087, 1.0108695652174, 0.11111111111111
52463, 0.91304347826087, 1.0369565217391, 0.13888888888889
52464, 0.93478260869565, 1.0369565217391, 0.16666666666667
52465, 0.91304347826087, 1.0108695652174, 0.16666666666667
52466, 0.91304347826087, 1.0369565217391, 0.19444444444444
52467, 0.93478260869565, 1.0369565217391, 0.22222222222222
52468, 0.91304347826087, 1.0108695652174, 0.22222222222222
52469, 0.91304347826087, 1.0369565217391, 0.25
52470, 0.93478260869565, 1.0369565217391, 0.27777777777778
52471, 0.91304347826087, 1.0108695652174, 0.27777777777778
52472, 0.91304347826087, 1.0369565217391, 0.30555555555556
52473, 0.93478260869565, 1.0369565217391, 0.33333333333333
52474, 0.91304347826087, 1.0108695652174, 0.33333333333333
52475, 0.91304347826087, 1.0369565217391, 0.36111111111111
52476, 0.93478260869565, 1.0369565217391, 0.38888888888889
52477, 0.91304347826087, 1.0108695652174, 0.38888888888889
52478, 0.91304347826087, 1.0369565217391, 0.41666666666667
52479, 0.93478260869565, 1.0369565217391, 0.44444444444444
52480, 0.91304347826087, 1.0108695652174, 0.44444444444444
52481, 0.91304347826087, 1.0369565217391, 0.47222222222222
52482, 0.8695652173913, 1.0369565217391, 0.027777777777778
52483, 0.89130434782609, 1.0369565217391, 0.055555555555556
52484, 0.8695652173913, 1.0108695652174, 0.055555555555556
52485, 0.8695652173913, 1.0369565217391, 0.083333333333333
52486, 0.89130434782609, 1.0369565217391, 0.11111111111111
52487, 0.8695652173913, 1.0108695652174, 0.11111111111111
52488, 0.8695652173913, 1.0369565217391, 0.13888888888889
52489, 0.89130434782609, 1.0369565217391, 0.16666666666667
52490, 0.8695652173913, 1.0108695652174, 0.16666666666667
52491, 0.8695652173913, 1.0369565217391, 0.19444444444444
52492, 0.89130434782609, 1.0369565217391, 0.22222222222222
52493, 0.8695652173913, 1.0108695652174, 0.22222222222222
52494, 0.8695652173913, 1.0369565217391, 0.25
52495, 0.89130434782609, 1.0369565217391, 0.27777777777778
52496, 0.8695652173913, 1.0108695652174, 0.27777777777778
52497, 0.8695652173913, 1.0369565217391, 0.30555555555556
52498, 0.89130434782609, 1.0369565217391, 0.33333333333333
52499, 0.8695652173913, 1.0108695652174, 0.33333333333333
52500, 0.8695652173913, 1.0369565217391, 0.36111111111111
52501, 0.89130434782609, 1.0369565217391, 0.38888888888889
52502, 0.8695652173913, 1.0108695652174, 0.38888888888889
52503, 0.8695652173913, 1.0369565217391, 0.41666666666667
52504, 0.89130434782609, 1.0369565217391, 0.44444444444444
52505, 0.8695652173913, 1.0108695652174, 0.44444444444444
52506, 0.8695652173913, 1.0369565217391, 0.47222222222222
52507, 0.82608695652174, 1.0369565217391, 0.027777777777778
52508, 0.84782608695652, 1.0369565217391, 0.055555555555556
52509, 0.82608695652174, 1.0108695652174, 0.055555555555556
52510, 0.82608695652174, 1.0369565217391, 0.083333333333333
52511, 0.84782608695652, 1.0369565217391, 0.11111111111111
52512, 0.82608695652174, 1.0108695652174, 0.11111111111111
52513, 0.82608695652174, 1.0369565217391, 0.13888888888889
52514, 0.84782608695652, 1.0369565217391, 0.16666666666667
52515, 0.82608695652174, 1.0108695652174, 0.16666666666667
52516, 0.82608695652174, 1.0369565217391, 0.19444444444444
52517, 0.84782608695652, 1.0369565217391, 0.22222222222222
52518, 0.82608695652174, 1.0108695652174, 0.22222222222222
52519, 0.82608695652174, 1.0369565217391, 0.25
52520, 0.84782608695652, 1.0369565217391, 0.27777777777778
52521, 0.82608695652174, 1.0108695652174, 0.27777777777778
52522, 0.82608695652174, 1.0369565217391, 0.30555555555556
52523, 0.84782608695652, 1.0369565217391, 0.33333333333333
52524, 0.82608695652174, 1.0108695652174, 0.33333333333333
52525, 0.82608695652174, 1.0369565217391, 0.36111111111111
52526, 0.84782608695652, 1.0369565217391, 0.38888888888889
52527, 0.82608695652174, 1.0108695652174, 0.38888888888889
52528, 0.82608695652174, 1.0369565217391, 0.41666666666667
52529, 0.84782608695652, 1.0369565217391, 0.44444444444444
52530, 0.82608695652174, 1.0108695652174, 0.44444444444444
52531, 0.82608695652174, 1.0369565217391, 0.47222222222222
52532, 0.78260869565217, 1.0369565217391, 0.027777777777778
52533, 0.80434782608696, 1.0369565217391, 0.055555555555556
52534, 0.78260869565217, 1.0108695652174, 0.055555555555556
52535, 0.78260869565217, 1.0369565217391, 0.083333333333333
52536, 0.80434782608696, 1.0369565217391, 0.11111111111111
52537, 0.78260869565217, 1.0108695652174, 0.11111111111111
52538, 0.78260869565217, 1.0369565217391, 0.13888888888889
52539, 0.80434782608696, 1.0369565217391, 0.16666666666667
52540, 0.78260869565217, 1.0108695652174, 0.16666666666667
52541, 0.78260869565217, 1.0369565217391, 0.19444444444444
52542, 0.80434782608696, 1.0369565217391, 0.22222222222222
52543, 0.78260869565217, 1.0108695652174, 0.22222222222222
52544, 0.78260869565217, 1.0369565217391, 0.25
52545, 0.80434782608696, 1.0369565217391, 0.27777777777778
52546, 0.78260869565217, 1.0108695652174, 0.27777777777778
52547, 0.78260869565217, 1.0369565217391, 0.30555555555556
52548, 0.80434782608696, 1.0369565217391, 0.33333333333333
52549, 0.78260869565217, 1.0108695652174, 0.33333333333333
52550, 0.78260869565217, 1.0369565217391, 0.36111111111111
52551, 0.80434782608696, 1.0369565217391, 0.38888888888889
52552, 0.78260869565217, 1.0108695652174, 0.38888888888889
52553, 0.78260869565217, 1.0369565217391, 0.41666666666667
52554, 0.80434782608696, 1.0369565217391, 0.44444444444444
52555, 0.78260869565217, 1.0108695652174, 0.44444444444444
52556, 0.78260869565217, 1.0369565217391, 0.47222222222222
52557, 0.73913043478261, 1.0369565217391, 0.027777777777778
52558, 0.76086956521739, 1.0369565217391, 0.055555555555556
52559, 0.73913043478261, 1.0108695652174, 0.055555555555556
52560, 0.73913043478261, 1.0369565217391, 0.083333333333333
52561, 0.76086956521739, 1.0369565217391, 0.11111111111111
52562, 0.73913043478261, 1.0108695652174, 0.11111111111111
52563, 0.73913043478261, 1.0369565217391, 0.13888888888889
52564, 0.76086956521739, 1.0369565217391, 0.16666666666667
52565, 0.73913043478261, 1.0108695652174, 0.16666666666667
52566, 0.73913043478261, 1.0369565217391, 0.19444444444444
52567, 0.76086956521739, 1.0369565217391, 0.22222222222222
52568, 0.73913043478261, 1.0108695652174, 0.22222222222222
52569, 0.73913043478261, 1.0369565217391, 0.25
52570, 0.76086956521739, 1.0369565217391, 0.27777777777778
52571, 0.73913043478261, 1.0108695652174, 0.27777777777778
52572, 0.73913043478261, 1.0369565217391, 0.30555555555556
52573, 0.76086956521739, 1.0369565217391, 0.33333333333333
52574, 0.73913043478261, 1.0108695652174, 0.33333333333333
52575, 0.73913043478261, 1.0369565217391, 0.36111111111111
52576, 0.76086956521739, 1.0369565217391, 0.38888888888889
52577, 0.73913043478261, 1.0108695652174, 0.38888888888889
52578, 0.73913043478261, 1.0369565217391, 0.41666666666667
52579, 0.76086956521739, 1.0369565217391, 0.44444444444444
52580, 0.73913043478261, 1.0108695652174, 0.44444444444444
52581, 0.73913043478261, 1.0369565217391, 0.47222222222222
52582, 0.69565217391304, 1.0369565217391, 0.027777777777778
52583, 0.71739130434783, 1.0369565217391, 0.055555555555556
52584, 0.69565217391304, 1.0108695652174, 0.055555555555556
52585, 0.69565217391304, 1.0369565217391, 0.083333333333333
52586, 0.71739130434783, 1.0369565217391, 0.11111111111111
52587, 0.69565217391304, 1.0108695652174, 0.11111111111111
52588, 0.69565217391304, 1.0369565217391, 0.13888888888889
52589, 0.71739130434783, 1.0369565217391, 0.16666666666667
52590, 0.69565217391304, 1.0108695652174, 0.16666666666667
52591, 0.69565217391304, 1.0369565217391, 0.19444444444444
52592, 0.71739130434783, 1.0369565217391, 0.22222222222222
52593, 0.69565217391304, 1.0108695652174, 0.22222222222222
52594, 0.69565217391304, 1.0369565217391, 0.25
52595, 0.71739130434783, 1.0369565217391, 0.27777777777778
52596, 0.69565217391304, 1.0108695652174, 0.27777777777778
52597, 0.69565217391304, 1.0369565217391, 0.30555555555556
52598, 0.71739130434783, 1.0369565217391, 0.33333333333333
52599, 0.69565217391304, 1.0108695652174, 0.33333333333333
52600, 0.69565217391304, 1.0369565217391, 0.36111111111111
52601, 0.71739130434783, 1.0369565217391, 0.38888888888889
52602, 0.69565217391304, 1.0108695652174, 0.38888888888889
52603, 0.69565217391304, 1.0369565217391, 0.41666666666667
52604, 0.71739130434783, 1.0369565217391, 0.44444444444444
52605, 0.69565217391304, 1.0108695652174, 0.44444444444444
52606, 0.69565217391304, 1.0369565217391, 0.47222222222222
52607, 0.65217391304348, 1.0369565217391, 0.027777777777778
52608, 0.67391304347826, 1.0369565217391, 0.055555555555556
52609, 0.65217391304348, 1.0108695652174, 0.055555555555556
52610, 0.65217391304348, 1.0369565217391, 0.083333333333333
52611, 0.67391304347826, 1.0369565217391, 0.11111111111111
52612, 0.65217391304348, 1.0108695652174, 0.11111111111111
52613, 0.65217391304348, 1.0369565217391, 0.13888888888889
52614, 0.67391304347826, 1.0369565217391, 0.16666666666667
52615, 0.65217391304348, 1.0108695652174, 0.16666666666667
52616, 0.65217391304348, 1.0369565217391, 0.19444444444444
52617, 0.67391304347826, 1.0369565217391, 0.22222222222222
52618, 0.65217391304348, 1.0108695652174, 0.22222222222222
52619, 0.65217391304348, 1.0369565217391, 0.25
52620, 0.67391304347826, 1.0369565217391, 0.27777777777778
52621, 0.65217391304348, 1.0108695652174, 0.27777777777778
52622, 0.65217391304348, 1.0369565217391, 0.30555555555556
52623, 0.67391304347826, 1.0369565217391, 0.33333333333333
52624, 0.65217391304348, 1.0108695652174, 0.33333333333333
52625, 0.65217391304348, 1.0369565217391, 0.36111111111111
52626, 0.67391304347826, 1.0369565217391, 0.38888888888889
52627, 0.65217391304348, 1.0108695652174, 0.38888888888889
52628, 0.65217391304348, 1.0369565217391, 0.41666666666667
52629, 0.67391304347826, 1.0369565217391, 0.44444444444444
52630, 0.65217391304348, 1.0108695652174, 0.44444444444444
52631, 0.65217391304348, 1.0369565217391, 0.47222222222222
52632, 0.60869565217391, 1.0369565217391, 0.027777777777778
52633, 0.6304347826087, 1.0369565217391, 0.055555555555556
52634, 0.60869565217391, 1.0108695652174, 0.055555555555556
52635, 0.60869565217391, 1.0369565217391, 0.083333333333333
52636, 0.6304347826087, 1.0369565217391, 0.11111111111111
52637, 0.60869565217391, 1.0108695652174, 0.11111111111111
52638, 0.60869565217391, 1.0369565217391, 0.13888888888889
52639, 0.6304347826087, 1.0369565217391, 0.16666666666667
52640, 0.60869565217391, 1.0108695652174, 0.16666666666667
52641, 0.60869565217391, 1.0369565217391, 0.19444444444444
52642, 0.6304347826087, 1.0369565217391, 0.22222222222222
52643, 0.60869565217391, 1.0108695652174, 0.22222222222222
52644, 0.60869565217391, 1.0369565217391, 0.25
52645, 0.6304347826087, 1.0369565217391, 0.27777777777778
52646, 0.60869565217391, 1.0108695652174, 0.27777777777778
52647, 0.60869565217391, 1.0369565217391, 0.30555555555556
52648, 0.6304347826087, 1.0369565217391, 0.33333333333333
52649, 0.60869565217391, 1.0108695652174, 0.33333333333333
52650, 0.60869565217391, 1.0369565217391, 0.36111111111111
52651, 0.6304347826087, 1.0369565217391, 0.38888888888889
52652, 0.60869565217391, 1.0108695652174, 0.38888888888889
52653, 0.60869565217391, 1.0369565217391, 0.41666666666667
52654, 0.6304347826087, 1.0369565217391, 0.44444444444444
52655, 0.60869565217391, 1.0108695652174, 0.44444444444444
52656, 0.60869565217391, 1.0369565217391, 0.47222222222222
52657, 0.56521739130435, 1.0369565217391, 0.027777777777778
52658, 0.58695652173913, 1.0369565217391, 0.055555555555556
52659, 0.56521739130435, 1.0108695652174, 0.055555555555556
52660, 0.56521739130435, 1.0369565217391, 0.083333333333333
52661, 0.58695652173913, 1.0369565217391, 0.11111111111111
52662, 0.56521739130435, 1.0108695652174, 0.11111111111111
52663, 0.56521739130435, 1.0369565217391, 0.13888888888889
52664, 0.58695652173913, 1.0369565217391, 0.16666666666667
52665, 0.56521739130435, 1.0108695652174, 0.16666666666667
52666, 0.56521739130435, 1.0369565217391, 0.19444444444444
52667, 0.58695652173913, 1.0369565217391, 0.22222222222222
52668, 0.56521739130435, 1.0108695652174, 0.22222222222222
52669, 0.56521739130435, 1.0369565217391, 0.25
52670, 0.58695652173913, 1.0369565217391, 0.27777777777778
52671, 0.56521739130435, 1.0108695652174, 0.27777777777778
52672, 0.56521739130435, 1.0369565217391, 0.30555555555556
52673, 0.58695652173913, 1.0369565217391, 0.33333333333333
52674, 0.56521739130435, 1.0108695652174, 0.33333333333333
52675, 0.56521739130435, 1.0369565217391, 0.36111111111111
52676, 0.58695652173913, 1.0369565217391, 0.38888888888889
52677, 0.56521739130435, 1.0108695652174, 0.38888888888889
52678, 0.56521739130435, 1.0369565217391, 0.41666666666667
52679, 0.58695652173913, 1.0369565217391, 0.44444444444444
52680, 0.56521739130435, 1.0108695652174, 0.44444444444444
52681, 0.56521739130435, 1.0369565217391, 0.47222222222222
52682, 0.52173913043478, 1.0369565217391, 0.027777777777778
52683, 0.54347826086957, 1.0369565217391, 0.055555555555556
52684, 0.52173913043478, 1.0108695652174, 0.055555555555556
52685, 0.52173913043478, 1.0369565217391, 0.083333333333333
52686, 0.54347826086957, 1.0369565217391, 0.11111111111111
52687, 0.52173913043478, 1.0108695652174, 0.11111111111111
52688, 0.52173913043478, 1.0369565217391, 0.13888888888889
52689, 0.54347826086957, 1.0369565217391, 0.16666666666667
52690, 0.52173913043478, 1.0108695652174, 0.16666666666667
52691, 0.52173913043478, 1.0369565217391, 0.19444444444444
52692, 0.54347826086956, 1.0369565217391, 0.22222222222222
52693, 0.52173913043478, 1.0108695652174, 0.22222222222222
52694, 0.52173913043478, 1.0369565217391, 0.25
52695, 0.54347826086956, 1.0369565217391, 0.27777777777778
52696, 0.52173913043478, 1.0108695652174, 0.27777777777778
52697, 0.52173913043478, 1.0369565217391, 0.30555555555556
52698, 0.54347826086956, 1.0369565217391, 0.33333333333333
52699, 0.52173913043478, 1.0108695652174, 0.33333333333333
52700, 0.52173913043478, 1.0369565217391, 0.36111111111111
52701, 0.54347826086956, 1.0369565217391, 0.38888888888889
52702, 0.52173913043478, 1.0108695652174, 0.38888888888889
52703, 0.52173913043478, 1.0369565217391, 0.41666666666667
52704, 0.54347826086956, 1.0369565217391, 0.44444444444444
52705, 0.52173913043478, 1.0108695652174, 0.44444444444444
52706, 0.52173913043478, 1.0369565217391, 0.47222222222222
52707, 0.47826086956522, 1.0369565217391, 0.027777777777778
52708, 0.5, 1.0369565217391, 0.055555555555556
52709, 0.47826086956522, 1.0108695652174, 0.055555555555556
52710, 0.47826086956522, 1.0369565217391, 0.083333333333333
52711, 0.5, 1.0369565217391, 0.11111111111111
52712, 0.47826086956522, 1.0108695652174, 0.11111111111111
52713, 0.47826086956522, 1.0369565217391, 0.13888888888889
52714, 0.5, 1.0369565217391, 0.16666666666667
52715, 0.47826086956522, 1.0108695652174, 0.16666666666667
52716, 0.47826086956522, 1.0369565217391, 0.19444444444444
52717, 0.5, 1.0369565217391, 0.22222222222222
52718, 0.47826086956522, 1.0108695652174, 0.22222222222222
52719, 0.47826086956522, 1.0369565217391, 0.25
52720, 0.5, 1.0369565217391, 0.27777777777778
52721, 0.47826086956522, 1.0108695652174, 0.27777777777778
52722, 0.47826086956522, 1.0369565217391, 0.30555555555556
52723, 0.5, 1.0369565217391, 0.33333333333333
52724, 0.47826086956522, 1.0108695652174, 0.33333333333333
52725, 0.47826086956522, 1.0369565217391, 0.36111111111111
52726, 0.5, 1.0369565217391, 0.38888888888889
52727, 0.47826086956522, 1.0108695652174, 0.38888888888889
52728, 0.47826086956522, 1.0369565217391, 0.41666666666667
52729, 0.5, 1.0369565217391, 0.44444444444444
52730, 0.47826086956522, 1.0108695652174, 0.44444444444444
52731, 0.47826086956522, 1.0369565217391, 0.47222222222222
52732, 0.43478260869565, 1.0369565217391, 0.027777777777778
52733, 0.45652173913043, 1.0369565217391, 0.055555555555556
52734, 0.43478260869565, 1.0108695652174, 0.055555555555556
52735, 0.43478260869565, 1.0369565217391, 0.083333333333333
52736, 0.45652173913043, 1.0369565217391, 0.11111111111111
52737, 0.43478260869565, 1.0108695652174, 0.11111111111111
52738, 0.43478260869565, 1.0369565217391, 0.13888888888889
52739, 0.45652173913043, 1.0369565217391, 0.16666666666667
52740, 0.43478260869565, 1.0108695652174, 0.16666666666667
52741, 0.43478260869565, 1.0369565217391, 0.19444444444444
52742, 0.45652173913043, 1.0369565217391, 0.22222222222222
52743, 0.43478260869565, 1.0108695652174, 0.22222222222222
52744, 0.43478260869565, 1.0369565217391, 0.25
52745, 0.45652173913043, 1.0369565217391, 0.27777777777778
52746, 0.43478260869565, 1.0108695652174, 0.27777777777778
52747, 0.43478260869565, 1.0369565217391, 0.30555555555556
52748, 0.45652173913043, 1.0369565217391, 0.33333333333333
52749, 0.43478260869565, 1.0108695652174, 0.33333333333333
52750, 0.43478260869565, 1.0369565217391, 0.36111111111111
52751, 0.45652173913044, 1.0369565217391, 0.38888888888889
52752, 0.43478260869565, 1.0108695652174, 0.38888888888889
52753, 0.43478260869565, 1.0369565217391, 0.41666666666667
52754, 0.45652173913043, 1.0369565217391, 0.44444444444444
52755, 0.43478260869565, 1.0108695652174, 0.44444444444444
52756, 0.43478260869565, 1.0369565217391, 0.47222222222222
52757, 0.39130434782609, 1.0369565217391, 0.027777777777778
52758, 0.41304347826087, 1.0369565217391, 0.055555555555556
52759, 0.39130434782609, 1.0108695652174, 0.055555555555556
52760, 0.39130434782609, 1.0369565217391, 0.083333333333333
52761, 0.41304347826087, 1.0369565217391, 0.11111111111111
52762, 0.39130434782609, 1.0108695652174, 0.11111111111111
52763, 0.39130434782609, 1.0369565217391, 0.13888888888889
52764, 0.41304347826087, 1.0369565217391, 0.16666666666667
52765, 0.39130434782609, 1.0108695652174, 0.16666666666667
52766, 0.39130434782609, 1.0369565217391, 0.19444444444444
52767, 0.41304347826087, 1.0369565217391, 0.22222222222222
52768, 0.39130434782609, 1.0108695652174, 0.22222222222222
52769, 0.39130434782609, 1.0369565217391, 0.25
52770, 0.41304347826087, 1.0369565217391, 0.27777777777778
52771, 0.39130434782609, 1.0108695652174, 0.27777777777778
52772, 0.39130434782609, 1.0369565217391, 0.30555555555556
52773, 0.41304347826087, 1.0369565217391, 0.33333333333333
52774, 0.39130434782609, 1.0108695652174, 0.33333333333333
52775, 0.39130434782609, 1.0369565217391, 0.36111111111111
52776, 0.41304347826087, 1.0369565217391, 0.38888888888889
52777, 0.39130434782609, 1.0108695652174, 0.38888888888889
52778, 0.39130434782609, 1.0369565217391, 0.41666666666667
52779, 0.41304347826087, 1.0369565217391, 0.44444444444444
52780, 0.39130434782609, 1.0108695652174, 0.44444444444444
52781, 0.39130434782609, 1.0369565217391, 0.47222222222222
52782, 0.34782608695652, 1.0369565217391, 0.027777777777778
52783, 0.3695652173913, 1.0369565217391, 0.055555555555556
52784, 0.34782608695652, 1.0108695652174, 0.055555555555556
52785, 0.34782608695652, 1.0369565217391, 0.083333333333333
52786, 0.3695652173913, 1.0369565217391, 0.11111111111111
52787, 0.34782608695652, 1.0108695652174, 0.11111111111111
52788, 0.34782608695652, 1.0369565217391, 0.13888888888889
52789, 0.3695652173913, 1.0369565217391, 0.16666666666667
52790, 0.34782608695652, 1.0108695652174, 0.16666666666667
52791, 0.34782608695652, 1.0369565217391, 0.19444444444444
52792, 0.3695652173913, 1.0369565217391, 0.22222222222222
52793, 0.34782608695652, 1.0108695652174, 0.22222222222222
52794, 0.34782608695652, 1.0369565217391, 0.25
52795, 0.3695652173913, 1.0369565217391, 0.27777777777778
52796, 0.34782608695652, 1.0108695652174, 0.27777777777778
52797, 0.34782608695652, 1.0369565217391, 0.30555555555556
52798, 0.3695652173913, 1.0369565217391, 0.33333333333333
52799, 0.34782608695652, 1.0108695652174, 0.33333333333333
52800, 0.34782608695652, 1.0369565217391, 0.36111111111111
52801, 0.3695652173913, 1.0369565217391, 0.38888888888889
52802, 0.34782608695652, 1.0108695652174, 0.38888888888889
52803, 0.34782608695652, 1.0369565217391, 0.41666666666667
52804, 0.3695652173913, 1.0369565217391, 0.44444444444444
52805, 0.34782608695652, 1.0108695652174, 0.44444444444444
52806, 0.34782608695652, 1.0369565217391, 0.47222222222222
52807, 0.30434782608696, 1.0369565217391, 0.027777777777778
52808, 0.32608695652174, 1.0369565217391, 0.055555555555556
52809, 0.30434782608696, 1.0108695652174, 0.055555555555556
52810, 0.30434782608696, 1.0369565217391, 0.083333333333333
52811, 0.32608695652174, 1.0369565217391, 0.11111111111111
52812, 0.30434782608696, 1.0108695652174, 0.11111111111111
52813, 0.30434782608696, 1.0369565217391, 0.13888888888889
52814, 0.32608695652174, 1.0369565217391, 0.16666666666667
52815, 0.30434782608696, 1.0108695652174, 0.16666666666667
52816, 0.30434782608696, 1.0369565217391, 0.19444444444444
52817, 0.32608695652174, 1.0369565217391, 0.22222222222222
52818, 0.30434782608696, 1.0108695652174, 0.22222222222222
52819, 0.30434782608696, 1.0369565217391, 0.25
52820, 0.32608695652174, 1.0369565217391, 0.27777777777778
52821, 0.30434782608696, 1.0108695652174, 0.27777777777778
52822, 0.30434782608696, 1.0369565217391, 0.30555555555556
52823, 0.32608695652174, 1.0369565217391, 0.33333333333333
52824, 0.30434782608696, 1.0108695652174, 0.33333333333333
52825, 0.30434782608696, 1.0369565217391, 0.36111111111111
52826, 0.32608695652174, 1.0369565217391, 0.38888888888889
52827, 0.30434782608696, 1.0108695652174, 0.38888888888889
52828, 0.30434782608696, 1.0369565217391, 0.41666666666667
52829, 0.32608695652174, 1.0369565217391, 0.44444444444444
52830, 0.30434782608696, 1.0108695652174, 0.44444444444444
52831, 0.30434782608696, 1.0369565217391, 0.47222222222222
52832, 0.26086956521739, 1.0369565217391, 0.027777777777778
52833, 0.28260869565217, 1.0369565217391, 0.055555555555556
52834, 0.26086956521739, 1.0108695652174, 0.055555555555556
52835, 0.26086956521739, 1.0369565217391, 0.083333333333333
52836, 0.28260869565217, 1.0369565217391, 0.11111111111111
52837, 0.26086956521739, 1.0108695652174, 0.11111111111111
52838, 0.26086956521739, 1.0369565217391, 0.13888888888889
52839, 0.28260869565217, 1.0369565217391, 0.16666666666667
52840, 0.26086956521739, 1.0108695652174, 0.16666666666667
52841, 0.26086956521739, 1.0369565217391, 0.19444444444444
52842, 0.28260869565217, 1.0369565217391, 0.22222222222222
52843, 0.26086956521739, 1.0108695652174, 0.22222222222222
52844, 0.26086956521739, 1.0369565217391, 0.25
52845, 0.28260869565217, 1.0369565217391, 0.27777777777778
52846, 0.26086956521739, 1.0108695652174, 0.27777777777778
52847, 0.26086956521739, 1.0369565217391, 0.30555555555556
52848, 0.28260869565217, 1.0369565217391, 0.33333333333333
52849, 0.26086956521739, 1.0108695652174, 0.33333333333333
52850, 0.26086956521739, 1.0369565217391, 0.36111111111111
52851, 0.28260869565217, 1.0369565217391, 0.38888888888889
52852, 0.26086956521739, 1.0108695652174, 0.38888888888889
52853, 0.26086956521739, 1.0369565217391, 0.41666666666667
52854, 0.28260869565217, 1.0369565217391, 0.44444444444444
52855, 0.26086956521739, 1.0108695652174, 0.44444444444444
52856, 0.26086956521739, 1.0369565217391, 0.47222222222222
52857, 0.21739130434783, 1.0369565217391, 0.027777777777778
52858, 0.23913043478261, 1.0369565217391, 0.055555555555556
52859, 0.21739130434783, 1.0108695652174, 0.055555555555556
52860, 0.21739130434783, 1.0369565217391, 0.083333333333333
52861, 0.23913043478261, 1.0369565217391, 0.11111111111111
52862, 0.21739130434783, 1.0108695652174, 0.11111111111111
52863, 0.21739130434783, 1.0369565217391, 0.13888888888889
52864, 0.23913043478261, 1.0369565217391, 0.16666666666667
52865, 0.21739130434783, 1.0108695652174, 0.16666666666667
52866, 0.21739130434783, 1.0369565217391, 0.19444444444444
52867, 0.23913043478261, 1.0369565217391, 0.22222222222222
52868, 0.21739130434783, 1.0108695652174, 0.22222222222222
52869, 0.21739130434783, 1.0369565217391, 0.25
52870, 0.23913043478261, 1.0369565217391, 0.27777777777778
52871, 0.21739130434783, 1.0108695652174, 0.27777777777778
52872, 0.21739130434783, 1.0369565217391, 0.30555555555556
52873, 0.23913043478261, 1.0369565217391, 0.33333333333333
52874, 0.21739130434783, 1.0108695652174, 0.33333333333333
52875, 0.21739130434783, 1.0369565217391, 0.36111111111111
52876, 0.23913043478261, 1.0369565217391, 0.38888888888889
52877, 0.21739130434783, 1.0108695652174, 0.38888888888889
52878, 0.21739130434783, 1.0369565217391, 0.41666666666667
52879, 0.23913043478261, 1.0369565217391, 0.44444444444444
52880, 0.21739130434783, 1.0108695652174, 0.44444444444444
52881, 0.21739130434783, 1.0369565217391, 0.47222222222222
52882, 0.17391304347826, 1.0369565217391, 0.027777777777778
52883, 0.19565217391304, 1.0369565217391, 0.055555555555556
52884, 0.17391304347826, 1.0108695652174, 0.055555555555556
52885, 0.17391304347826, 1.0369565217391, 0.083333333333333
52886, 0.19565217391304, 1.0369565217391, 0.11111111111111
52887, 0.17391304347826, 1.0108695652174, 0.11111111111111
52888, 0.17391304347826, 1.0369565217391, 0.13888888888889
52889, 0.19565217391304, 1.0369565217391, 0.16666666666667
52890, 0.17391304347826, 1.0108695652174, 0.16666666666667
52891, 0.17391304347826, 1.0369565217391, 0.19444444444444
52892, 0.19565217391304, 1.0369565217391, 0.22222222222222
52893, 0.17391304347826, 1.0108695652174, 0.22222222222222
52894, 0.17391304347826, 1.0369565217391, 0.25
52895, 0.19565217391304, 1.0369565217391, 0.27777777777778
52896, 0.17391304347826, 1.0108695652174, 0.27777777777778
52897, 0.17391304347826, 1.0369565217391, 0.30555555555556
52898, 0.19565217391304, 1.0369565217391, 0.33333333333333
52899, 0.17391304347826, 1.0108695652174, 0.33333333333333
52900, 0.17391304347826, 1.0369565217391, 0.36111111111111
52901, 0.19565217391304, 1.0369565217391, 0.38888888888889
52902, 0.17391304347826, 1.0108695652174, 0.38888888888889
52903, 0.17391304347826, 1.0369565217391, 0.41666666666667
52904, 0.19565217391304, 1.0369565217391, 0.44444444444444
52905, 0.17391304347826, 1.0108695652174, 0.44444444444444
52906, 0.17391304347826, 1.0369565217391, 0.47222222222222
52907, 0.1304347826087, 1.0369565217391, 0.027777777777778
52908, 0.15217391304348, 1.0369565217391, 0.055555555555556
52909, 0.1304347826087, 1.0108695652174, 0.055555555555556
52910, 0.1304347826087, 1.0369565217391, 0.083333333333333
52911, 0.15217391304348, 1.0369565217391, 0.11111111111111
52912, 0.1304347826087, 1.0108695652174, 0.11111111111111
52913, 0.1304347826087, 1.0369565217391, 0.13888888888889
52914, 0.15217391304348, 1.0369565217391, 0.16666666666667
52915, 0.1304347826087, 1.0108695652174, 0.16666666666667
52916, 0.1304347826087, 1.0369565217391, 0.19444444444444
52917, 0.15217391304348, 1.0369565217391, 0.22222222222222
52918, 0.1304347826087, 1.0108695652174, 0.22222222222222
52919, 0.1304347826087, 1.0369565217391, 0.25
52920, 0.15217391304348, 1.0369565217391, 0.27777777777778
52921, 0.1304347826087, 1.0108695652174, 0.27777777777778
52922, 0.1304347826087, 1.0369565217391, 0.30555555555556
52923, 0.15217391304348, 1.0369565217391, 0.33333333333333
52924, 0.1304347826087, 1.0108695652174, 0.33333333333333
52925, 0.1304347826087, 1.0369565217391, 0.36111111111111
52926, 0.15217391304348, 1.0369565217391, 0.38888888888889
52927, 0.1304347826087, 1.0108695652174, 0.38888888888889
52928, 0.1304347826087, 1.0369565217391, 0.41666666666667
52929, 0.15217391304348, 1.0369565217391, 0.44444444444444
52930, 0.1304347826087, 1.0108695652174, 0.44444444444444
52931, 0.1304347826087, 1.0369565217391, 0.47222222222222
52932, 0.08695652173913, 1.0369565217391, 0.027777777777778
52933, 0.10869565217391, 1.0369565217391, 0.055555555555556
52934, 0.08695652173913, 1.0108695652174, 0.055555555555556
52935, 0.08695652173913, 1.0369565217391, 0.083333333333333
52936, 0.10869565217391, 1.0369565217391, 0.11111111111111
52937, 0.08695652173913, 1.0108695652174, 0.11111111111111
52938, 0.08695652173913, 1.0369565217391, 0.13888888888889
52939, 0.10869565217391, 1.0369565217391, 0.16666666666667
52940, 0.08695652173913, 1.0108695652174, 0.16666666666667
52941, 0.08695652173913, 1.0369565217391, 0.19444444444444
52942, 0.10869565217391, 1.0369565217391, 0.22222222222222
52943, 0.08695652173913, 1.0108695652174, 0.22222222222222
52944, 0.08695652173913, 1.0369565217391, 0.25
52945, 0.10869565217391, 1.0369565217391, 0.27777777777778
52946, 0.08695652173913, 1.0108695652174, 0.27777777777778
52947, 0.08695652173913, 1.0369565217391, 0.30555555555556
52948, 0.10869565217391, 1.0369565217391, 0.33333333333333
52949, 0.08695652173913, 1.0108695652174, 0.33333333333333
52950, 0.08695652173913, 1.0369565217391, 0.36111111111111
52951, 0.10869565217391, 1.0369565217391, 0.38888888888889
52952, 0.08695652173913, 1.0108695652174, 0.38888888888889
52953, 0.08695652173913, 1.0369565217391, 0.41666666666667
52954, 0.10869565217391, 1.0369565217391, 0.44444444444444
52955, 0.08695652173913, 1.0108695652174, 0.44444444444444
52956, 0.08695652173913, 1.0369565217391, 0.47222222222222
52957, 0.043478260869565, 1.0369565217391, 0.027777777777778
52958, 0.065217391304348, 1.0369565217391, 0.055555555555556
52959, 0.043478260869565, 1.0108695652174, 0.055555555555556
52960, 0.043478260869565, 1.0369565217391, 0.083333333333333
52961, 0.065217391304348, 1.0369565217391, 0.11111111111111
52962, 0.043478260869565, 1.0108695652174, 0.11111111111111
52963, 0.043478260869565, 1.0369565217391, 0.13888888888889
52964, 0.065217391304348, 1.0369565217391, 0.16666666666667
52965, 0.043478260869565, 1.0108695652174, 0.16666666666667
52966, 0.043478260869565, 1.0369565217391, 0.19444444444444
52967, 0.065217391304348, 1.0369565217391, 0.22222222222222
52968, 0.043478260869565, 1.0108695652174, 0.22222222222222
52969, 0.043478260869565, 1.0369565217391, 0.25
52970, 0.065217391304348, 1.0369565217391, 0.27777777777778
52971, 0.043478260869565, 1.0108695652174, 0.27777777777778
52972, 0.043478260869565, 1.0369565217391, 0.30555555555556
52973, 0.065217391304348, 1.0369565217391, 0.33333333333333
52974, 0.043478260869565, 1.0108695652174, 0.33333333333333
52975, 0.043478260869565, 1.0369565217391, 0.36111111111111
52976, 0.065217391304348, 1.0369565217391, 0.38888888888889
52977, 0.043478260869565, 1.0108695652174, 0.38888888888889
