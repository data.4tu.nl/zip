81192, 0.45652173913043, 1.6, 0.11111111111111
81193, 0.43478260869565, 1.575, 0.11111111111111
81194, 0.43478260869565, 1.6, 0.13888888888889
81195, 0.45652173913043, 1.6, 0.16666666666667
81196, 0.43478260869565, 1.575, 0.16666666666667
81197, 0.43478260869565, 1.6, 0.19444444444444
81198, 0.45652173913043, 1.6, 0.22222222222222
81199, 0.43478260869565, 1.575, 0.22222222222222
81200, 0.43478260869565, 1.6, 0.25
81201, 0.45652173913043, 1.6, 0.27777777777778
81202, 0.43478260869565, 1.575, 0.27777777777778
81203, 0.43478260869565, 1.6, 0.30555555555556
81204, 0.45652173913043, 1.6, 0.33333333333333
81205, 0.43478260869565, 1.575, 0.33333333333333
81206, 0.43478260869565, 1.6, 0.36111111111111
81207, 0.45652173913043, 1.6, 0.38888888888889
81208, 0.43478260869565, 1.575, 0.38888888888889
81209, 0.43478260869565, 1.6, 0.41666666666667
81210, 0.45652173913043, 1.6, 0.44444444444444
81211, 0.43478260869565, 1.575, 0.44444444444444
81212, 0.43478260869565, 1.6, 0.47222222222222
81213, 0.39130434782609, 1.6, 0.027777777777778
81214, 0.41304347826087, 1.6, 0.055555555555556
81215, 0.39130434782609, 1.575, 0.055555555555556
81216, 0.39130434782609, 1.6, 0.083333333333333
81217, 0.41304347826087, 1.6, 0.11111111111111
81218, 0.39130434782609, 1.575, 0.11111111111111
81219, 0.39130434782609, 1.6, 0.13888888888889
81220, 0.41304347826087, 1.6, 0.16666666666667
81221, 0.39130434782609, 1.575, 0.16666666666667
81222, 0.39130434782609, 1.6, 0.19444444444444
81223, 0.41304347826087, 1.6, 0.22222222222222
81224, 0.39130434782609, 1.575, 0.22222222222222
81225, 0.39130434782609, 1.6, 0.25
81226, 0.41304347826087, 1.6, 0.27777777777778
81227, 0.39130434782609, 1.575, 0.27777777777778
81228, 0.39130434782609, 1.6, 0.30555555555556
81229, 0.41304347826087, 1.6, 0.33333333333333
81230, 0.39130434782609, 1.575, 0.33333333333333
81231, 0.39130434782609, 1.6, 0.36111111111111
81232, 0.41304347826087, 1.6, 0.38888888888889
81233, 0.39130434782609, 1.575, 0.38888888888889
81234, 0.39130434782609, 1.6, 0.41666666666667
81235, 0.41304347826087, 1.6, 0.44444444444444
81236, 0.39130434782609, 1.575, 0.44444444444444
81237, 0.39130434782609, 1.6, 0.47222222222222
81238, 0.34782608695652, 1.6, 0.027777777777778
81239, 0.3695652173913, 1.6, 0.055555555555556
81240, 0.34782608695652, 1.575, 0.055555555555556
81241, 0.34782608695652, 1.6, 0.083333333333333
81242, 0.3695652173913, 1.6, 0.11111111111111
81243, 0.34782608695652, 1.575, 0.11111111111111
81244, 0.34782608695652, 1.6, 0.13888888888889
81245, 0.3695652173913, 1.6, 0.16666666666667
81246, 0.34782608695652, 1.575, 0.16666666666667
81247, 0.34782608695652, 1.6, 0.19444444444444
81248, 0.3695652173913, 1.6, 0.22222222222222
81249, 0.34782608695652, 1.575, 0.22222222222222
81250, 0.34782608695652, 1.6, 0.25
81251, 0.3695652173913, 1.6, 0.27777777777778
81252, 0.34782608695652, 1.575, 0.27777777777778
81253, 0.34782608695652, 1.6, 0.30555555555556
81254, 0.3695652173913, 1.6, 0.33333333333333
81255, 0.34782608695652, 1.575, 0.33333333333333
81256, 0.34782608695652, 1.6, 0.36111111111111
81257, 0.3695652173913, 1.6, 0.38888888888889
81258, 0.34782608695652, 1.575, 0.38888888888889
81259, 0.34782608695652, 1.6, 0.41666666666667
81260, 0.3695652173913, 1.6, 0.44444444444444
81261, 0.34782608695652, 1.575, 0.44444444444444
81262, 0.34782608695652, 1.6, 0.47222222222222
81263, 0.30434782608696, 1.6, 0.027777777777778
81264, 0.32608695652174, 1.6, 0.055555555555556
81265, 0.30434782608696, 1.575, 0.055555555555556
81266, 0.30434782608696, 1.6, 0.083333333333333
81267, 0.32608695652174, 1.6, 0.11111111111111
81268, 0.30434782608696, 1.575, 0.11111111111111
81269, 0.30434782608696, 1.6, 0.13888888888889
81270, 0.32608695652174, 1.6, 0.16666666666667
81271, 0.30434782608696, 1.575, 0.16666666666667
81272, 0.30434782608696, 1.6, 0.19444444444444
81273, 0.32608695652174, 1.6, 0.22222222222222
81274, 0.30434782608696, 1.575, 0.22222222222222
81275, 0.30434782608696, 1.6, 0.25
81276, 0.32608695652174, 1.6, 0.27777777777778
81277, 0.30434782608696, 1.575, 0.27777777777778
81278, 0.30434782608696, 1.6, 0.30555555555556
81279, 0.32608695652174, 1.6, 0.33333333333333
81280, 0.30434782608696, 1.575, 0.33333333333333
81281, 0.30434782608696, 1.6, 0.36111111111111
81282, 0.32608695652174, 1.6, 0.38888888888889
81283, 0.30434782608696, 1.575, 0.38888888888889
81284, 0.30434782608696, 1.6, 0.41666666666667
81285, 0.32608695652174, 1.6, 0.44444444444444
81286, 0.30434782608696, 1.575, 0.44444444444444
81287, 0.30434782608696, 1.6, 0.47222222222222
81288, 0.26086956521739, 1.6, 0.027777777777778
81289, 0.28260869565217, 1.6, 0.055555555555556
81290, 0.26086956521739, 1.575, 0.055555555555556
81291, 0.26086956521739, 1.6, 0.083333333333333
81292, 0.28260869565217, 1.6, 0.11111111111111
81293, 0.26086956521739, 1.575, 0.11111111111111
81294, 0.26086956521739, 1.6, 0.13888888888889
81295, 0.28260869565217, 1.6, 0.16666666666667
81296, 0.26086956521739, 1.575, 0.16666666666667
81297, 0.26086956521739, 1.6, 0.19444444444444
81298, 0.28260869565217, 1.6, 0.22222222222222
81299, 0.26086956521739, 1.575, 0.22222222222222
81300, 0.26086956521739, 1.6, 0.25
81301, 0.28260869565217, 1.6, 0.27777777777778
81302, 0.26086956521739, 1.575, 0.27777777777778
81303, 0.26086956521739, 1.6, 0.30555555555556
81304, 0.28260869565217, 1.6, 0.33333333333333
81305, 0.26086956521739, 1.575, 0.33333333333333
81306, 0.26086956521739, 1.6, 0.36111111111111
81307, 0.28260869565217, 1.6, 0.38888888888889
81308, 0.26086956521739, 1.575, 0.38888888888889
81309, 0.26086956521739, 1.6, 0.41666666666667
81310, 0.28260869565217, 1.6, 0.44444444444444
81311, 0.26086956521739, 1.575, 0.44444444444444
81312, 0.26086956521739, 1.6, 0.47222222222222
81313, 0.21739130434783, 1.6, 0.027777777777778
81314, 0.23913043478261, 1.6, 0.055555555555556
81315, 0.21739130434783, 1.575, 0.055555555555556
81316, 0.21739130434783, 1.6, 0.083333333333333
81317, 0.23913043478261, 1.6, 0.11111111111111
81318, 0.21739130434783, 1.575, 0.11111111111111
81319, 0.21739130434783, 1.6, 0.13888888888889
81320, 0.23913043478261, 1.6, 0.16666666666667
81321, 0.21739130434783, 1.575, 0.16666666666667
81322, 0.21739130434783, 1.6, 0.19444444444444
81323, 0.23913043478261, 1.6, 0.22222222222222
81324, 0.21739130434783, 1.575, 0.22222222222222
81325, 0.21739130434783, 1.6, 0.25
81326, 0.23913043478261, 1.6, 0.27777777777778
81327, 0.21739130434783, 1.575, 0.27777777777778
81328, 0.21739130434783, 1.6, 0.30555555555556
81329, 0.23913043478261, 1.6, 0.33333333333333
81330, 0.21739130434783, 1.575, 0.33333333333333
81331, 0.21739130434783, 1.6, 0.36111111111111
81332, 0.23913043478261, 1.6, 0.38888888888889
81333, 0.21739130434783, 1.575, 0.38888888888889
81334, 0.21739130434783, 1.6, 0.41666666666667
81335, 0.23913043478261, 1.6, 0.44444444444444
81336, 0.21739130434783, 1.575, 0.44444444444444
81337, 0.21739130434783, 1.6, 0.47222222222222
81338, 0.17391304347826, 1.6, 0.027777777777778
81339, 0.19565217391304, 1.6, 0.055555555555556
81340, 0.17391304347826, 1.575, 0.055555555555556
81341, 0.17391304347826, 1.6, 0.083333333333333
81342, 0.19565217391304, 1.6, 0.11111111111111
81343, 0.17391304347826, 1.575, 0.11111111111111
81344, 0.17391304347826, 1.6, 0.13888888888889
81345, 0.19565217391304, 1.6, 0.16666666666667
81346, 0.17391304347826, 1.575, 0.16666666666667
81347, 0.17391304347826, 1.6, 0.19444444444444
81348, 0.19565217391304, 1.6, 0.22222222222222
81349, 0.17391304347826, 1.575, 0.22222222222222
81350, 0.17391304347826, 1.6, 0.25
81351, 0.19565217391304, 1.6, 0.27777777777778
81352, 0.17391304347826, 1.575, 0.27777777777778
81353, 0.17391304347826, 1.6, 0.30555555555556
81354, 0.19565217391304, 1.6, 0.33333333333333
81355, 0.17391304347826, 1.575, 0.33333333333333
81356, 0.17391304347826, 1.6, 0.36111111111111
81357, 0.19565217391304, 1.6, 0.38888888888889
81358, 0.17391304347826, 1.575, 0.38888888888889
81359, 0.17391304347826, 1.6, 0.41666666666667
81360, 0.19565217391304, 1.6, 0.44444444444444
81361, 0.17391304347826, 1.575, 0.44444444444444
81362, 0.17391304347826, 1.6, 0.47222222222222
81363, 0.1304347826087, 1.6, 0.027777777777778
81364, 0.15217391304348, 1.6, 0.055555555555556
81365, 0.1304347826087, 1.575, 0.055555555555556
81366, 0.1304347826087, 1.6, 0.083333333333333
81367, 0.15217391304348, 1.6, 0.11111111111111
81368, 0.1304347826087, 1.575, 0.11111111111111
81369, 0.1304347826087, 1.6, 0.13888888888889
81370, 0.15217391304348, 1.6, 0.16666666666667
81371, 0.1304347826087, 1.575, 0.16666666666667
81372, 0.1304347826087, 1.6, 0.19444444444444
81373, 0.15217391304348, 1.6, 0.22222222222222
81374, 0.1304347826087, 1.575, 0.22222222222222
81375, 0.1304347826087, 1.6, 0.25
81376, 0.15217391304348, 1.6, 0.27777777777778
81377, 0.1304347826087, 1.575, 0.27777777777778
81378, 0.1304347826087, 1.6, 0.30555555555556
81379, 0.15217391304348, 1.6, 0.33333333333333
81380, 0.1304347826087, 1.575, 0.33333333333333
81381, 0.1304347826087, 1.6, 0.36111111111111
81382, 0.15217391304348, 1.6, 0.38888888888889
81383, 0.1304347826087, 1.575, 0.38888888888889
81384, 0.1304347826087, 1.6, 0.41666666666667
81385, 0.15217391304348, 1.6, 0.44444444444444
81386, 0.1304347826087, 1.575, 0.44444444444444
81387, 0.1304347826087, 1.6, 0.47222222222222
81388, 0.08695652173913, 1.6, 0.027777777777778
81389, 0.10869565217391, 1.6, 0.055555555555556
81390, 0.08695652173913, 1.575, 0.055555555555556
81391, 0.08695652173913, 1.6, 0.083333333333333
81392, 0.10869565217391, 1.6, 0.11111111111111
81393, 0.08695652173913, 1.575, 0.11111111111111
81394, 0.08695652173913, 1.6, 0.13888888888889
81395, 0.10869565217391, 1.6, 0.16666666666667
81396, 0.08695652173913, 1.575, 0.16666666666667
81397, 0.08695652173913, 1.6, 0.19444444444444
81398, 0.10869565217391, 1.6, 0.22222222222222
81399, 0.08695652173913, 1.575, 0.22222222222222
81400, 0.08695652173913, 1.6, 0.25
81401, 0.10869565217391, 1.6, 0.27777777777778
81402, 0.08695652173913, 1.575, 0.27777777777778
81403, 0.08695652173913, 1.6, 0.30555555555556
81404, 0.10869565217391, 1.6, 0.33333333333333
81405, 0.08695652173913, 1.575, 0.33333333333333
81406, 0.08695652173913, 1.6, 0.36111111111111
81407, 0.10869565217391, 1.6, 0.38888888888889
81408, 0.08695652173913, 1.575, 0.38888888888889
81409, 0.08695652173913, 1.6, 0.41666666666667
81410, 0.10869565217391, 1.6, 0.44444444444444
81411, 0.08695652173913, 1.575, 0.44444444444444
81412, 0.08695652173913, 1.6, 0.47222222222222
81413, 0.043478260869565, 1.6, 0.027777777777778
81414, 0.065217391304348, 1.6, 0.055555555555556
81415, 0.043478260869565, 1.575, 0.055555555555556
81416, 0.043478260869565, 1.6, 0.083333333333333
81417, 0.065217391304348, 1.6, 0.11111111111111
81418, 0.043478260869565, 1.575, 0.11111111111111
81419, 0.043478260869565, 1.6, 0.13888888888889
81420, 0.065217391304348, 1.6, 0.16666666666667
81421, 0.043478260869565, 1.575, 0.16666666666667
81422, 0.043478260869565, 1.6, 0.19444444444444
81423, 0.065217391304348, 1.6, 0.22222222222222
81424, 0.043478260869565, 1.575, 0.22222222222222
81425, 0.043478260869565, 1.6, 0.25
81426, 0.065217391304348, 1.6, 0.27777777777778
81427, 0.043478260869565, 1.575, 0.27777777777778
81428, 0.043478260869565, 1.6, 0.30555555555556
81429, 0.065217391304348, 1.6, 0.33333333333333
81430, 0.043478260869565, 1.575, 0.33333333333333
81431, 0.043478260869565, 1.6, 0.36111111111111
81432, 0.065217391304348, 1.6, 0.38888888888889
81433, 0.043478260869565, 1.575, 0.38888888888889
81434, 0.043478260869565, 1.6, 0.41666666666667
81435, 0.065217391304348, 1.6, 0.44444444444444
81436, 0.043478260869565, 1.575, 0.44444444444444
81437, 0.043478260869565, 1.6, 0.47222222222222
81438, 0.021739130434783, 1.6, 0.055555555555556
81439, 0.021739130434783, 1.6, 0.11111111111111
81440, 0.021739130434783, 1.6, 0.16666666666667
81441, 0.021739130434783, 1.6, 0.22222222222222
81442, 0.021739130434783, 1.6, 0.27777777777778
81443, 0.021739130434783, 1.6, 0.33333333333333
81444, 0.021739130434783, 1.6, 0.38888888888889
81445, 0.021739130434783, 1.6, 0.44444444444444
81446, 0.95652173913043, 1.65, 0.027777777777778
81447, 0.97826086956522, 1.65, 0.055555555555556
81448, 0.95652173913043, 1.625, 0.055555555555556
81449, 0.95652173913043, 1.65, 0.083333333333333
81450, 0.97826086956522, 1.65, 0.11111111111111
81451, 0.95652173913044, 1.625, 0.11111111111111
81452, 0.95652173913044, 1.65, 0.13888888888889
81453, 0.97826086956522, 1.65, 0.16666666666667
81454, 0.95652173913044, 1.625, 0.16666666666667
81455, 0.95652173913044, 1.65, 0.19444444444444
81456, 0.97826086956522, 1.65, 0.22222222222222
81457, 0.95652173913044, 1.625, 0.22222222222222
81458, 0.95652173913044, 1.65, 0.25
81459, 0.97826086956522, 1.65, 0.27777777777778
81460, 0.95652173913044, 1.625, 0.27777777777778
81461, 0.95652173913044, 1.65, 0.30555555555556
81462, 0.97826086956522, 1.65, 0.33333333333333
81463, 0.95652173913044, 1.625, 0.33333333333333
81464, 0.95652173913044, 1.65, 0.36111111111111
81465, 0.97826086956522, 1.65, 0.38888888888889
81466, 0.95652173913043, 1.625, 0.38888888888889
81467, 0.95652173913044, 1.65, 0.41666666666667
81468, 0.97826086956522, 1.65, 0.44444444444444
81469, 0.95652173913044, 1.625, 0.44444444444444
81470, 0.95652173913043, 1.65, 0.47222222222222
81471, 0.91304347826087, 1.65, 0.027777777777778
81472, 0.93478260869565, 1.65, 0.055555555555556
81473, 0.91304347826087, 1.625, 0.055555555555556
81474, 0.91304347826087, 1.65, 0.083333333333333
81475, 0.93478260869565, 1.65, 0.11111111111111
81476, 0.91304347826087, 1.625, 0.11111111111111
81477, 0.91304347826087, 1.65, 0.13888888888889
81478, 0.93478260869565, 1.65, 0.16666666666667
81479, 0.91304347826087, 1.625, 0.16666666666667
81480, 0.91304347826087, 1.65, 0.19444444444444
81481, 0.93478260869565, 1.65, 0.22222222222222
81482, 0.91304347826087, 1.625, 0.22222222222222
81483, 0.91304347826087, 1.65, 0.25
81484, 0.93478260869565, 1.65, 0.27777777777778
81485, 0.91304347826087, 1.625, 0.27777777777778
81486, 0.91304347826087, 1.65, 0.30555555555556
81487, 0.93478260869565, 1.65, 0.33333333333333
81488, 0.91304347826087, 1.625, 0.33333333333333
81489, 0.91304347826087, 1.65, 0.36111111111111
81490, 0.93478260869565, 1.65, 0.38888888888889
81491, 0.91304347826087, 1.625, 0.38888888888889
81492, 0.91304347826087, 1.65, 0.41666666666667
81493, 0.93478260869565, 1.65, 0.44444444444444
81494, 0.91304347826087, 1.625, 0.44444444444444
81495, 0.91304347826087, 1.65, 0.47222222222222
81496, 0.8695652173913, 1.65, 0.027777777777778
81497, 0.89130434782609, 1.65, 0.055555555555556
81498, 0.8695652173913, 1.625, 0.055555555555556
81499, 0.8695652173913, 1.65, 0.083333333333333
81500, 0.89130434782609, 1.65, 0.11111111111111
81501, 0.8695652173913, 1.625, 0.11111111111111
81502, 0.8695652173913, 1.65, 0.13888888888889
81503, 0.89130434782609, 1.65, 0.16666666666667
81504, 0.8695652173913, 1.625, 0.16666666666667
81505, 0.8695652173913, 1.65, 0.19444444444444
81506, 0.89130434782609, 1.65, 0.22222222222222
81507, 0.8695652173913, 1.625, 0.22222222222222
81508, 0.8695652173913, 1.65, 0.25
81509, 0.89130434782609, 1.65, 0.27777777777778
81510, 0.8695652173913, 1.625, 0.27777777777778
81511, 0.8695652173913, 1.65, 0.30555555555556
81512, 0.89130434782609, 1.65, 0.33333333333333
81513, 0.8695652173913, 1.625, 0.33333333333333
81514, 0.8695652173913, 1.65, 0.36111111111111
81515, 0.89130434782609, 1.65, 0.38888888888889
81516, 0.8695652173913, 1.625, 0.38888888888889
81517, 0.8695652173913, 1.65, 0.41666666666667
81518, 0.89130434782609, 1.65, 0.44444444444444
81519, 0.8695652173913, 1.625, 0.44444444444444
81520, 0.8695652173913, 1.65, 0.47222222222222
81521, 0.82608695652174, 1.65, 0.027777777777778
81522, 0.84782608695652, 1.65, 0.055555555555556
81523, 0.82608695652174, 1.625, 0.055555555555556
81524, 0.82608695652174, 1.65, 0.083333333333333
81525, 0.84782608695652, 1.65, 0.11111111111111
81526, 0.82608695652174, 1.625, 0.11111111111111
81527, 0.82608695652174, 1.65, 0.13888888888889
81528, 0.84782608695652, 1.65, 0.16666666666667
81529, 0.82608695652174, 1.625, 0.16666666666667
81530, 0.82608695652174, 1.65, 0.19444444444444
81531, 0.84782608695652, 1.65, 0.22222222222222
81532, 0.82608695652174, 1.625, 0.22222222222222
81533, 0.82608695652174, 1.65, 0.25
81534, 0.84782608695652, 1.65, 0.27777777777778
81535, 0.82608695652174, 1.625, 0.27777777777778
81536, 0.82608695652174, 1.65, 0.30555555555556
81537, 0.84782608695652, 1.65, 0.33333333333333
81538, 0.82608695652174, 1.625, 0.33333333333333
81539, 0.82608695652174, 1.65, 0.36111111111111
81540, 0.84782608695652, 1.65, 0.38888888888889
81541, 0.82608695652174, 1.625, 0.38888888888889
81542, 0.82608695652174, 1.65, 0.41666666666667
81543, 0.84782608695652, 1.65, 0.44444444444444
81544, 0.82608695652174, 1.625, 0.44444444444444
81545, 0.82608695652174, 1.65, 0.47222222222222
81546, 0.78260869565217, 1.65, 0.027777777777778
81547, 0.80434782608696, 1.65, 0.055555555555556
81548, 0.78260869565217, 1.625, 0.055555555555556
81549, 0.78260869565217, 1.65, 0.083333333333333
81550, 0.80434782608696, 1.65, 0.11111111111111
81551, 0.78260869565217, 1.625, 0.11111111111111
81552, 0.78260869565217, 1.65, 0.13888888888889
81553, 0.80434782608696, 1.65, 0.16666666666667
81554, 0.78260869565217, 1.625, 0.16666666666667
81555, 0.78260869565217, 1.65, 0.19444444444444
81556, 0.80434782608696, 1.65, 0.22222222222222
81557, 0.78260869565217, 1.625, 0.22222222222222
81558, 0.78260869565217, 1.65, 0.25
81559, 0.80434782608696, 1.65, 0.27777777777778
81560, 0.78260869565217, 1.625, 0.27777777777778
81561, 0.78260869565217, 1.65, 0.30555555555556
81562, 0.80434782608696, 1.65, 0.33333333333333
81563, 0.78260869565217, 1.625, 0.33333333333333
81564, 0.78260869565217, 1.65, 0.36111111111111
81565, 0.80434782608696, 1.65, 0.38888888888889
81566, 0.78260869565217, 1.625, 0.38888888888889
81567, 0.78260869565217, 1.65, 0.41666666666667
81568, 0.80434782608696, 1.65, 0.44444444444444
81569, 0.78260869565217, 1.625, 0.44444444444444
81570, 0.78260869565217, 1.65, 0.47222222222222
81571, 0.73913043478261, 1.65, 0.027777777777778
81572, 0.76086956521739, 1.65, 0.055555555555556
81573, 0.73913043478261, 1.625, 0.055555555555556
81574, 0.73913043478261, 1.65, 0.083333333333333
81575, 0.76086956521739, 1.65, 0.11111111111111
81576, 0.73913043478261, 1.625, 0.11111111111111
81577, 0.73913043478261, 1.65, 0.13888888888889
81578, 0.76086956521739, 1.65, 0.16666666666667
81579, 0.73913043478261, 1.625, 0.16666666666667
81580, 0.73913043478261, 1.65, 0.19444444444444
81581, 0.76086956521739, 1.65, 0.22222222222222
81582, 0.73913043478261, 1.625, 0.22222222222222
81583, 0.73913043478261, 1.65, 0.25
81584, 0.76086956521739, 1.65, 0.27777777777778
81585, 0.73913043478261, 1.625, 0.27777777777778
81586, 0.73913043478261, 1.65, 0.30555555555556
81587, 0.76086956521739, 1.65, 0.33333333333333
81588, 0.73913043478261, 1.625, 0.33333333333333
81589, 0.73913043478261, 1.65, 0.36111111111111
81590, 0.76086956521739, 1.65, 0.38888888888889
81591, 0.73913043478261, 1.625, 0.38888888888889
81592, 0.73913043478261, 1.65, 0.41666666666667
81593, 0.76086956521739, 1.65, 0.44444444444444
81594, 0.73913043478261, 1.625, 0.44444444444444
81595, 0.73913043478261, 1.65, 0.47222222222222
81596, 0.69565217391304, 1.65, 0.027777777777778
81597, 0.71739130434783, 1.65, 0.055555555555556
81598, 0.69565217391304, 1.625, 0.055555555555556
81599, 0.69565217391304, 1.65, 0.083333333333333
81600, 0.71739130434783, 1.65, 0.11111111111111
81601, 0.69565217391304, 1.625, 0.11111111111111
81602, 0.69565217391304, 1.65, 0.13888888888889
81603, 0.71739130434783, 1.65, 0.16666666666667
81604, 0.69565217391304, 1.625, 0.16666666666667
81605, 0.69565217391304, 1.65, 0.19444444444444
81606, 0.71739130434783, 1.65, 0.22222222222222
81607, 0.69565217391304, 1.625, 0.22222222222222
81608, 0.69565217391304, 1.65, 0.25
81609, 0.71739130434783, 1.65, 0.27777777777778
81610, 0.69565217391304, 1.625, 0.27777777777778
81611, 0.69565217391304, 1.65, 0.30555555555556
81612, 0.71739130434783, 1.65, 0.33333333333333
81613, 0.69565217391304, 1.625, 0.33333333333333
81614, 0.69565217391304, 1.65, 0.36111111111111
81615, 0.71739130434783, 1.65, 0.38888888888889
81616, 0.69565217391304, 1.625, 0.38888888888889
81617, 0.69565217391304, 1.65, 0.41666666666667
81618, 0.71739130434783, 1.65, 0.44444444444444
81619, 0.69565217391304, 1.625, 0.44444444444444
81620, 0.69565217391304, 1.65, 0.47222222222222
81621, 0.65217391304348, 1.65, 0.027777777777778
81622, 0.67391304347826, 1.65, 0.055555555555556
81623, 0.65217391304348, 1.625, 0.055555555555556
81624, 0.65217391304348, 1.65, 0.083333333333333
81625, 0.67391304347826, 1.65, 0.11111111111111
81626, 0.65217391304348, 1.625, 0.11111111111111
81627, 0.65217391304348, 1.65, 0.13888888888889
81628, 0.67391304347826, 1.65, 0.16666666666667
81629, 0.65217391304348, 1.625, 0.16666666666667
81630, 0.65217391304348, 1.65, 0.19444444444444
81631, 0.67391304347826, 1.65, 0.22222222222222
81632, 0.65217391304348, 1.625, 0.22222222222222
81633, 0.65217391304348, 1.65, 0.25
81634, 0.67391304347826, 1.65, 0.27777777777778
81635, 0.65217391304348, 1.625, 0.27777777777778
81636, 0.65217391304348, 1.65, 0.30555555555556
81637, 0.67391304347826, 1.65, 0.33333333333333
81638, 0.65217391304348, 1.625, 0.33333333333333
81639, 0.65217391304348, 1.65, 0.36111111111111
81640, 0.67391304347826, 1.65, 0.38888888888889
81641, 0.65217391304348, 1.625, 0.38888888888889
81642, 0.65217391304348, 1.65, 0.41666666666667
81643, 0.67391304347826, 1.65, 0.44444444444444
81644, 0.65217391304348, 1.625, 0.44444444444444
81645, 0.65217391304348, 1.65, 0.47222222222222
81646, 0.60869565217391, 1.65, 0.027777777777778
81647, 0.6304347826087, 1.65, 0.055555555555556
81648, 0.60869565217391, 1.625, 0.055555555555556
81649, 0.60869565217391, 1.65, 0.083333333333333
81650, 0.6304347826087, 1.65, 0.11111111111111
81651, 0.60869565217391, 1.625, 0.11111111111111
81652, 0.60869565217391, 1.65, 0.13888888888889
81653, 0.6304347826087, 1.65, 0.16666666666667
81654, 0.60869565217391, 1.625, 0.16666666666667
81655, 0.60869565217391, 1.65, 0.19444444444444
81656, 0.6304347826087, 1.65, 0.22222222222222
81657, 0.60869565217391, 1.625, 0.22222222222222
81658, 0.60869565217391, 1.65, 0.25
81659, 0.6304347826087, 1.65, 0.27777777777778
81660, 0.60869565217391, 1.625, 0.27777777777778
81661, 0.60869565217391, 1.65, 0.30555555555556
81662, 0.6304347826087, 1.65, 0.33333333333333
81663, 0.60869565217391, 1.625, 0.33333333333333
81664, 0.60869565217391, 1.65, 0.36111111111111
81665, 0.6304347826087, 1.65, 0.38888888888889
81666, 0.60869565217391, 1.625, 0.38888888888889
81667, 0.60869565217391, 1.65, 0.41666666666667
81668, 0.6304347826087, 1.65, 0.44444444444444
81669, 0.60869565217391, 1.625, 0.44444444444444
81670, 0.60869565217391, 1.65, 0.47222222222222
81671, 0.56521739130435, 1.65, 0.027777777777778
81672, 0.58695652173913, 1.65, 0.055555555555556
81673, 0.56521739130435, 1.625, 0.055555555555556
81674, 0.56521739130435, 1.65, 0.083333333333333
81675, 0.58695652173913, 1.65, 0.11111111111111
81676, 0.56521739130435, 1.625, 0.11111111111111
81677, 0.56521739130435, 1.65, 0.13888888888889
81678, 0.58695652173913, 1.65, 0.16666666666667
81679, 0.56521739130435, 1.625, 0.16666666666667
81680, 0.56521739130435, 1.65, 0.19444444444444
81681, 0.58695652173913, 1.65, 0.22222222222222
81682, 0.56521739130435, 1.625, 0.22222222222222
81683, 0.56521739130435, 1.65, 0.25
81684, 0.58695652173913, 1.65, 0.27777777777778
81685, 0.56521739130435, 1.625, 0.27777777777778
81686, 0.56521739130435, 1.65, 0.30555555555556
81687, 0.58695652173913, 1.65, 0.33333333333333
81688, 0.56521739130435, 1.625, 0.33333333333333
81689, 0.56521739130435, 1.65, 0.36111111111111
81690, 0.58695652173913, 1.65, 0.38888888888889
81691, 0.56521739130435, 1.625, 0.38888888888889
81692, 0.56521739130435, 1.65, 0.41666666666667
81693, 0.58695652173913, 1.65, 0.44444444444444
81694, 0.56521739130435, 1.625, 0.44444444444444
81695, 0.56521739130435, 1.65, 0.47222222222222
81696, 0.52173913043478, 1.65, 0.027777777777778
81697, 0.54347826086957, 1.65, 0.055555555555556
81698, 0.52173913043478, 1.625, 0.055555555555556
81699, 0.52173913043478, 1.65, 0.083333333333333
81700, 0.54347826086956, 1.65, 0.11111111111111
81701, 0.52173913043478, 1.625, 0.11111111111111
81702, 0.52173913043478, 1.65, 0.13888888888889
81703, 0.54347826086956, 1.65, 0.16666666666667
81704, 0.52173913043478, 1.625, 0.16666666666667
81705, 0.52173913043478, 1.65, 0.19444444444444
81706, 0.54347826086956, 1.65, 0.22222222222222
81707, 0.52173913043478, 1.625, 0.22222222222222
81708, 0.52173913043478, 1.65, 0.25
81709, 0.54347826086956, 1.65, 0.27777777777778
81710, 0.52173913043478, 1.625, 0.27777777777778
81711, 0.52173913043478, 1.65, 0.30555555555556
81712, 0.54347826086956, 1.65, 0.33333333333333
81713, 0.52173913043478, 1.625, 0.33333333333333
81714, 0.52173913043478, 1.65, 0.36111111111111
81715, 0.54347826086956, 1.65, 0.38888888888889
81716, 0.52173913043478, 1.625, 0.38888888888889
81717, 0.52173913043478, 1.65, 0.41666666666667
81718, 0.54347826086956, 1.65, 0.44444444444444
81719, 0.52173913043478, 1.625, 0.44444444444444
81720, 0.52173913043478, 1.65, 0.47222222222222
81721, 0.47826086956522, 1.65, 0.027777777777778
81722, 0.5, 1.65, 0.055555555555556
81723, 0.47826086956522, 1.625, 0.055555555555556
81724, 0.47826086956522, 1.65, 0.083333333333333
81725, 0.5, 1.65, 0.11111111111111
81726, 0.47826086956522, 1.625, 0.11111111111111
81727, 0.47826086956522, 1.65, 0.13888888888889
81728, 0.5, 1.65, 0.16666666666667
81729, 0.47826086956522, 1.625, 0.16666666666667
81730, 0.47826086956522, 1.65, 0.19444444444444
81731, 0.5, 1.65, 0.22222222222222
81732, 0.47826086956522, 1.625, 0.22222222222222
81733, 0.47826086956522, 1.65, 0.25
81734, 0.5, 1.65, 0.27777777777778
81735, 0.47826086956522, 1.625, 0.27777777777778
81736, 0.47826086956522, 1.65, 0.30555555555556
81737, 0.5, 1.65, 0.33333333333333
81738, 0.47826086956522, 1.625, 0.33333333333333
81739, 0.47826086956522, 1.65, 0.36111111111111
81740, 0.5, 1.65, 0.38888888888889
81741, 0.47826086956522, 1.625, 0.38888888888889
81742, 0.47826086956522, 1.65, 0.41666666666667
81743, 0.5, 1.65, 0.44444444444444
81744, 0.47826086956522, 1.625, 0.44444444444444
81745, 0.47826086956522, 1.65, 0.47222222222222
81746, 0.43478260869565, 1.65, 0.027777777777778
81747, 0.45652173913043, 1.65, 0.055555555555556
81748, 0.43478260869565, 1.625, 0.055555555555556
81749, 0.43478260869565, 1.65, 0.083333333333333
81750, 0.45652173913043, 1.65, 0.11111111111111
81751, 0.43478260869565, 1.625, 0.11111111111111
81752, 0.43478260869565, 1.65, 0.13888888888889
81753, 0.45652173913043, 1.65, 0.16666666666667
81754, 0.43478260869565, 1.625, 0.16666666666667
81755, 0.43478260869565, 1.65, 0.19444444444444
81756, 0.45652173913043, 1.65, 0.22222222222222
81757, 0.43478260869565, 1.625, 0.22222222222222
81758, 0.43478260869565, 1.65, 0.25
81759, 0.45652173913043, 1.65, 0.27777777777778
81760, 0.43478260869565, 1.625, 0.27777777777778
81761, 0.43478260869565, 1.65, 0.30555555555556
81762, 0.45652173913043, 1.65, 0.33333333333333
81763, 0.43478260869565, 1.625, 0.33333333333333
81764, 0.43478260869565, 1.65, 0.36111111111111
81765, 0.45652173913044, 1.65, 0.38888888888889
81766, 0.43478260869565, 1.625, 0.38888888888889
81767, 0.43478260869565, 1.65, 0.41666666666667
81768, 0.45652173913043, 1.65, 0.44444444444444
81769, 0.43478260869565, 1.625, 0.44444444444444
81770, 0.43478260869565, 1.65, 0.47222222222222
81771, 0.39130434782609, 1.65, 0.027777777777778
81772, 0.41304347826087, 1.65, 0.055555555555556
81773, 0.39130434782609, 1.625, 0.055555555555556
81774, 0.39130434782609, 1.65, 0.083333333333333
81775, 0.41304347826087, 1.65, 0.11111111111111
81776, 0.39130434782609, 1.625, 0.11111111111111
81777, 0.39130434782609, 1.65, 0.13888888888889
81778, 0.41304347826087, 1.65, 0.16666666666667
81779, 0.39130434782609, 1.625, 0.16666666666667
81780, 0.39130434782609, 1.65, 0.19444444444444
81781, 0.41304347826087, 1.65, 0.22222222222222
81782, 0.39130434782609, 1.625, 0.22222222222222
81783, 0.39130434782609, 1.65, 0.25
81784, 0.41304347826087, 1.65, 0.27777777777778
81785, 0.39130434782609, 1.625, 0.27777777777778
81786, 0.39130434782609, 1.65, 0.30555555555556
81787, 0.41304347826087, 1.65, 0.33333333333333
81788, 0.39130434782609, 1.625, 0.33333333333333
81789, 0.39130434782609, 1.65, 0.36111111111111
81790, 0.41304347826087, 1.65, 0.38888888888889
81791, 0.39130434782609, 1.625, 0.38888888888889
81792, 0.39130434782609, 1.65, 0.41666666666667
81793, 0.41304347826087, 1.65, 0.44444444444444
81794, 0.39130434782609, 1.625, 0.44444444444444
81795, 0.39130434782609, 1.65, 0.47222222222222
81796, 0.34782608695652, 1.65, 0.027777777777778
81797, 0.3695652173913, 1.65, 0.055555555555556
81798, 0.34782608695652, 1.625, 0.055555555555556
81799, 0.34782608695652, 1.65, 0.083333333333333
81800, 0.3695652173913, 1.65, 0.11111111111111
81801, 0.34782608695652, 1.625, 0.11111111111111
81802, 0.34782608695652, 1.65, 0.13888888888889
81803, 0.3695652173913, 1.65, 0.16666666666667
81804, 0.34782608695652, 1.625, 0.16666666666667
81805, 0.34782608695652, 1.65, 0.19444444444444
81806, 0.3695652173913, 1.65, 0.22222222222222
81807, 0.34782608695652, 1.625, 0.22222222222222
81808, 0.34782608695652, 1.65, 0.25
81809, 0.3695652173913, 1.65, 0.27777777777778
81810, 0.34782608695652, 1.625, 0.27777777777778
81811, 0.34782608695652, 1.65, 0.30555555555556
81812, 0.3695652173913, 1.65, 0.33333333333333
81813, 0.34782608695652, 1.625, 0.33333333333333
81814, 0.34782608695652, 1.65, 0.36111111111111
81815, 0.3695652173913, 1.65, 0.38888888888889
81816, 0.34782608695652, 1.625, 0.38888888888889
81817, 0.34782608695652, 1.65, 0.41666666666667
81818, 0.3695652173913, 1.65, 0.44444444444444
81819, 0.34782608695652, 1.625, 0.44444444444444
81820, 0.34782608695652, 1.65, 0.47222222222222
81821, 0.30434782608696, 1.65, 0.027777777777778
81822, 0.32608695652174, 1.65, 0.055555555555556
81823, 0.30434782608696, 1.625, 0.055555555555556
81824, 0.30434782608696, 1.65, 0.083333333333333
81825, 0.32608695652174, 1.65, 0.11111111111111
81826, 0.30434782608696, 1.625, 0.11111111111111
81827, 0.30434782608696, 1.65, 0.13888888888889
81828, 0.32608695652174, 1.65, 0.16666666666667
81829, 0.30434782608696, 1.625, 0.16666666666667
81830, 0.30434782608696, 1.65, 0.19444444444444
81831, 0.32608695652174, 1.65, 0.22222222222222
81832, 0.30434782608696, 1.625, 0.22222222222222
81833, 0.30434782608696, 1.65, 0.25
81834, 0.32608695652174, 1.65, 0.27777777777778
81835, 0.30434782608696, 1.625, 0.27777777777778
81836, 0.30434782608696, 1.65, 0.30555555555556
81837, 0.32608695652174, 1.65, 0.33333333333333
81838, 0.30434782608696, 1.625, 0.33333333333333
81839, 0.30434782608696, 1.65, 0.36111111111111
81840, 0.32608695652174, 1.65, 0.38888888888889
81841, 0.30434782608696, 1.625, 0.38888888888889
81842, 0.30434782608696, 1.65, 0.41666666666667
81843, 0.32608695652174, 1.65, 0.44444444444444
81844, 0.30434782608696, 1.625, 0.44444444444444
81845, 0.30434782608696, 1.65, 0.47222222222222
81846, 0.26086956521739, 1.65, 0.027777777777778
81847, 0.28260869565217, 1.65, 0.055555555555556
81848, 0.26086956521739, 1.625, 0.055555555555556
81849, 0.26086956521739, 1.65, 0.083333333333333
81850, 0.28260869565217, 1.65, 0.11111111111111
81851, 0.26086956521739, 1.625, 0.11111111111111
81852, 0.26086956521739, 1.65, 0.13888888888889
81853, 0.28260869565217, 1.65, 0.16666666666667
81854, 0.26086956521739, 1.625, 0.16666666666667
81855, 0.26086956521739, 1.65, 0.19444444444444
81856, 0.28260869565217, 1.65, 0.22222222222222
81857, 0.26086956521739, 1.625, 0.22222222222222
81858, 0.26086956521739, 1.65, 0.25
81859, 0.28260869565217, 1.65, 0.27777777777778
81860, 0.26086956521739, 1.625, 0.27777777777778
81861, 0.26086956521739, 1.65, 0.30555555555556
81862, 0.28260869565217, 1.65, 0.33333333333333
81863, 0.26086956521739, 1.625, 0.33333333333333
81864, 0.26086956521739, 1.65, 0.36111111111111
81865, 0.28260869565217, 1.65, 0.38888888888889
81866, 0.26086956521739, 1.625, 0.38888888888889
81867, 0.26086956521739, 1.65, 0.41666666666667
81868, 0.28260869565217, 1.65, 0.44444444444444
81869, 0.26086956521739, 1.625, 0.44444444444444
81870, 0.26086956521739, 1.65, 0.47222222222222
81871, 0.21739130434783, 1.65, 0.027777777777778
81872, 0.23913043478261, 1.65, 0.055555555555556
81873, 0.21739130434783, 1.625, 0.055555555555556
81874, 0.21739130434783, 1.65, 0.083333333333333
81875, 0.23913043478261, 1.65, 0.11111111111111
81876, 0.21739130434783, 1.625, 0.11111111111111
81877, 0.21739130434783, 1.65, 0.13888888888889
81878, 0.23913043478261, 1.65, 0.16666666666667
81879, 0.21739130434783, 1.625, 0.16666666666667
81880, 0.21739130434783, 1.65, 0.19444444444444
81881, 0.23913043478261, 1.65, 0.22222222222222
81882, 0.21739130434783, 1.625, 0.22222222222222
81883, 0.21739130434783, 1.65, 0.25
81884, 0.23913043478261, 1.65, 0.27777777777778
81885, 0.21739130434783, 1.625, 0.27777777777778
81886, 0.21739130434783, 1.65, 0.30555555555556
81887, 0.23913043478261, 1.65, 0.33333333333333
81888, 0.21739130434783, 1.625, 0.33333333333333
81889, 0.21739130434783, 1.65, 0.36111111111111
81890, 0.23913043478261, 1.65, 0.38888888888889
81891, 0.21739130434783, 1.625, 0.38888888888889
81892, 0.21739130434783, 1.65, 0.41666666666667
81893, 0.23913043478261, 1.65, 0.44444444444444
81894, 0.21739130434783, 1.625, 0.44444444444444
81895, 0.21739130434783, 1.65, 0.47222222222222
81896, 0.17391304347826, 1.65, 0.027777777777778
81897, 0.19565217391304, 1.65, 0.055555555555556
81898, 0.17391304347826, 1.625, 0.055555555555556
81899, 0.17391304347826, 1.65, 0.083333333333333
81900, 0.19565217391304, 1.65, 0.11111111111111
81901, 0.17391304347826, 1.625, 0.11111111111111
81902, 0.17391304347826, 1.65, 0.13888888888889
81903, 0.19565217391304, 1.65, 0.16666666666667
81904, 0.17391304347826, 1.625, 0.16666666666667
81905, 0.17391304347826, 1.65, 0.19444444444444
81906, 0.19565217391304, 1.65, 0.22222222222222
81907, 0.17391304347826, 1.625, 0.22222222222222
81908, 0.17391304347826, 1.65, 0.25
81909, 0.19565217391304, 1.65, 0.27777777777778
81910, 0.17391304347826, 1.625, 0.27777777777778
81911, 0.17391304347826, 1.65, 0.30555555555556
81912, 0.19565217391304, 1.65, 0.33333333333333
81913, 0.17391304347826, 1.625, 0.33333333333333
81914, 0.17391304347826, 1.65, 0.36111111111111
81915, 0.19565217391304, 1.65, 0.38888888888889
81916, 0.17391304347826, 1.625, 0.38888888888889
81917, 0.17391304347826, 1.65, 0.41666666666667
81918, 0.19565217391304, 1.65, 0.44444444444444
81919, 0.17391304347826, 1.625, 0.44444444444444
81920, 0.17391304347826, 1.65, 0.47222222222222
81921, 0.1304347826087, 1.65, 0.027777777777778
81922, 0.15217391304348, 1.65, 0.055555555555556
81923, 0.1304347826087, 1.625, 0.055555555555556
81924, 0.1304347826087, 1.65, 0.083333333333333
81925, 0.15217391304348, 1.65, 0.11111111111111
81926, 0.1304347826087, 1.625, 0.11111111111111
81927, 0.1304347826087, 1.65, 0.13888888888889
81928, 0.15217391304348, 1.65, 0.16666666666667
81929, 0.1304347826087, 1.625, 0.16666666666667
81930, 0.1304347826087, 1.65, 0.19444444444444
81931, 0.15217391304348, 1.65, 0.22222222222222
81932, 0.1304347826087, 1.625, 0.22222222222222
81933, 0.1304347826087, 1.65, 0.25
81934, 0.15217391304348, 1.65, 0.27777777777778
81935, 0.1304347826087, 1.625, 0.27777777777778
81936, 0.1304347826087, 1.65, 0.30555555555556
81937, 0.15217391304348, 1.65, 0.33333333333333
81938, 0.1304347826087, 1.625, 0.33333333333333
81939, 0.1304347826087, 1.65, 0.36111111111111
81940, 0.15217391304348, 1.65, 0.38888888888889
81941, 0.1304347826087, 1.625, 0.38888888888889
81942, 0.1304347826087, 1.65, 0.41666666666667
81943, 0.15217391304348, 1.65, 0.44444444444444
81944, 0.1304347826087, 1.625, 0.44444444444444
81945, 0.1304347826087, 1.65, 0.47222222222222
81946, 0.08695652173913, 1.65, 0.027777777777778
81947, 0.10869565217391, 1.65, 0.055555555555556
81948, 0.08695652173913, 1.625, 0.055555555555556
81949, 0.08695652173913, 1.65, 0.083333333333333
81950, 0.10869565217391, 1.65, 0.11111111111111
81951, 0.08695652173913, 1.625, 0.11111111111111
81952, 0.08695652173913, 1.65, 0.13888888888889
81953, 0.10869565217391, 1.65, 0.16666666666667
81954, 0.08695652173913, 1.625, 0.16666666666667
81955, 0.08695652173913, 1.65, 0.19444444444444
81956, 0.10869565217391, 1.65, 0.22222222222222
81957, 0.08695652173913, 1.625, 0.22222222222222
81958, 0.08695652173913, 1.65, 0.25
81959, 0.10869565217391, 1.65, 0.27777777777778
81960, 0.08695652173913, 1.625, 0.27777777777778
81961, 0.08695652173913, 1.65, 0.30555555555556
81962, 0.10869565217391, 1.65, 0.33333333333333
81963, 0.08695652173913, 1.625, 0.33333333333333
81964, 0.08695652173913, 1.65, 0.36111111111111
81965, 0.10869565217391, 1.65, 0.38888888888889
81966, 0.08695652173913, 1.625, 0.38888888888889
81967, 0.08695652173913, 1.65, 0.41666666666667
81968, 0.10869565217391, 1.65, 0.44444444444444
81969, 0.08695652173913, 1.625, 0.44444444444444
81970, 0.08695652173913, 1.65, 0.47222222222222
81971, 0.043478260869565, 1.65, 0.027777777777778
81972, 0.065217391304348, 1.65, 0.055555555555556
81973, 0.043478260869565, 1.625, 0.055555555555556
81974, 0.043478260869565, 1.65, 0.083333333333333
81975, 0.065217391304348, 1.65, 0.11111111111111
81976, 0.043478260869565, 1.625, 0.11111111111111
81977, 0.043478260869565, 1.65, 0.13888888888889
81978, 0.065217391304348, 1.65, 0.16666666666667
81979, 0.043478260869565, 1.625, 0.16666666666667
81980, 0.043478260869565, 1.65, 0.19444444444444
81981, 0.065217391304348, 1.65, 0.22222222222222
81982, 0.043478260869565, 1.625, 0.22222222222222
81983, 0.043478260869565, 1.65, 0.25
81984, 0.065217391304348, 1.65, 0.27777777777778
81985, 0.043478260869565, 1.625, 0.27777777777778
81986, 0.043478260869565, 1.65, 0.30555555555556
81987, 0.065217391304348, 1.65, 0.33333333333333
81988, 0.043478260869565, 1.625, 0.33333333333333
81989, 0.043478260869565, 1.65, 0.36111111111111
81990, 0.065217391304348, 1.65, 0.38888888888889
81991, 0.043478260869565, 1.625, 0.38888888888889
81992, 0.043478260869565, 1.65, 0.41666666666667
81993, 0.065217391304348, 1.65, 0.44444444444444
81994, 0.043478260869565, 1.625, 0.44444444444444
81995, 0.043478260869565, 1.65, 0.47222222222222
81996, 0.021739130434783, 1.65, 0.055555555555556
81997, 0.021739130434783, 1.65, 0.11111111111111
81998, 0.021739130434783, 1.65, 0.16666666666667
81999, 0.021739130434783, 1.65, 0.22222222222222
82000, 0.021739130434783, 1.65, 0.27777777777778
82001, 0.021739130434783, 1.65, 0.33333333333333
82002, 0.021739130434783, 1.65, 0.38888888888889
82003, 0.021739130434783, 1.65, 0.44444444444444
82004, 0.95652173913043, 1.7, 0.027777777777778
82005, 0.97826086956522, 1.7, 0.055555555555556
82006, 0.95652173913043, 1.675, 0.055555555555556
82007, 0.95652173913043, 1.7, 0.083333333333333
82008, 0.97826086956522, 1.7, 0.11111111111111
82009, 0.95652173913044, 1.675, 0.11111111111111
82010, 0.95652173913044, 1.7, 0.13888888888889
82011, 0.97826086956522, 1.7, 0.16666666666667
82012, 0.95652173913044, 1.675, 0.16666666666667
82013, 0.95652173913044, 1.7, 0.19444444444444
82014, 0.97826086956522, 1.7, 0.22222222222222
82015, 0.95652173913044, 1.675, 0.22222222222222
82016, 0.95652173913044, 1.7, 0.25
82017, 0.97826086956522, 1.7, 0.27777777777778
82018, 0.95652173913044, 1.675, 0.27777777777778
82019, 0.95652173913044, 1.7, 0.30555555555556
82020, 0.97826086956522, 1.7, 0.33333333333333
82021, 0.95652173913044, 1.675, 0.33333333333333
82022, 0.95652173913044, 1.7, 0.36111111111111
82023, 0.97826086956522, 1.7, 0.38888888888889
82024, 0.95652173913044, 1.675, 0.38888888888889
82025, 0.95652173913044, 1.7, 0.41666666666667
82026, 0.97826086956522, 1.7, 0.44444444444444
82027, 0.95652173913044, 1.675, 0.44444444444444
82028, 0.95652173913043, 1.7, 0.47222222222222
82029, 0.91304347826087, 1.7, 0.027777777777778
82030, 0.93478260869565, 1.7, 0.055555555555556
82031, 0.91304347826087, 1.675, 0.055555555555556
82032, 0.91304347826087, 1.7, 0.083333333333333
82033, 0.93478260869565, 1.7, 0.11111111111111
82034, 0.91304347826087, 1.675, 0.11111111111111
82035, 0.91304347826087, 1.7, 0.13888888888889
82036, 0.93478260869565, 1.7, 0.16666666666667
82037, 0.91304347826087, 1.675, 0.16666666666667
82038, 0.91304347826087, 1.7, 0.19444444444444
82039, 0.93478260869565, 1.7, 0.22222222222222
82040, 0.91304347826087, 1.675, 0.22222222222222
82041, 0.91304347826087, 1.7, 0.25
82042, 0.93478260869565, 1.7, 0.27777777777778
82043, 0.91304347826087, 1.675, 0.27777777777778
82044, 0.91304347826087, 1.7, 0.30555555555556
82045, 0.93478260869565, 1.7, 0.33333333333333
82046, 0.91304347826087, 1.675, 0.33333333333333
82047, 0.91304347826087, 1.7, 0.36111111111111
82048, 0.93478260869565, 1.7, 0.38888888888889
82049, 0.91304347826087, 1.675, 0.38888888888889
82050, 0.91304347826087, 1.7, 0.41666666666667
82051, 0.93478260869565, 1.7, 0.44444444444444
82052, 0.91304347826087, 1.675, 0.44444444444444
82053, 0.91304347826087, 1.7, 0.47222222222222
82054, 0.8695652173913, 1.7, 0.027777777777778
82055, 0.89130434782609, 1.7, 0.055555555555556
82056, 0.8695652173913, 1.675, 0.055555555555556
82057, 0.8695652173913, 1.7, 0.083333333333333
82058, 0.89130434782609, 1.7, 0.11111111111111
82059, 0.8695652173913, 1.675, 0.11111111111111
82060, 0.8695652173913, 1.7, 0.13888888888889
82061, 0.89130434782609, 1.7, 0.16666666666667
82062, 0.8695652173913, 1.675, 0.16666666666667
82063, 0.8695652173913, 1.7, 0.19444444444444
82064, 0.89130434782609, 1.7, 0.22222222222222
82065, 0.8695652173913, 1.675, 0.22222222222222
82066, 0.8695652173913, 1.7, 0.25
82067, 0.89130434782609, 1.7, 0.27777777777778
82068, 0.8695652173913, 1.675, 0.27777777777778
82069, 0.8695652173913, 1.7, 0.30555555555556
82070, 0.89130434782609, 1.7, 0.33333333333333
82071, 0.8695652173913, 1.675, 0.33333333333333
82072, 0.8695652173913, 1.7, 0.36111111111111
82073, 0.89130434782609, 1.7, 0.38888888888889
82074, 0.8695652173913, 1.675, 0.38888888888889
82075, 0.8695652173913, 1.7, 0.41666666666667
82076, 0.89130434782609, 1.7, 0.44444444444444
82077, 0.8695652173913, 1.675, 0.44444444444444
82078, 0.8695652173913, 1.7, 0.47222222222222
82079, 0.82608695652174, 1.7, 0.027777777777778
82080, 0.84782608695652, 1.7, 0.055555555555556
82081, 0.82608695652174, 1.675, 0.055555555555556
82082, 0.82608695652174, 1.7, 0.083333333333333
82083, 0.84782608695652, 1.7, 0.11111111111111
82084, 0.82608695652174, 1.675, 0.11111111111111
82085, 0.82608695652174, 1.7, 0.13888888888889
82086, 0.84782608695652, 1.7, 0.16666666666667
82087, 0.82608695652174, 1.675, 0.16666666666667
82088, 0.82608695652174, 1.7, 0.19444444444444
82089, 0.84782608695652, 1.7, 0.22222222222222
82090, 0.82608695652174, 1.675, 0.22222222222222
82091, 0.82608695652174, 1.7, 0.25
82092, 0.84782608695652, 1.7, 0.27777777777778
82093, 0.82608695652174, 1.675, 0.27777777777778
82094, 0.82608695652174, 1.7, 0.30555555555556
82095, 0.84782608695652, 1.7, 0.33333333333333
82096, 0.82608695652174, 1.675, 0.33333333333333
82097, 0.82608695652174, 1.7, 0.36111111111111
82098, 0.84782608695652, 1.7, 0.38888888888889
82099, 0.82608695652174, 1.675, 0.38888888888889
82100, 0.82608695652174, 1.7, 0.41666666666667
82101, 0.84782608695652, 1.7, 0.44444444444444
82102, 0.82608695652174, 1.675, 0.44444444444444
82103, 0.82608695652174, 1.7, 0.47222222222222
82104, 0.78260869565217, 1.7, 0.027777777777778
82105, 0.80434782608696, 1.7, 0.055555555555556
82106, 0.78260869565217, 1.675, 0.055555555555556
82107, 0.78260869565217, 1.7, 0.083333333333333
82108, 0.80434782608696, 1.7, 0.11111111111111
82109, 0.78260869565217, 1.675, 0.11111111111111
82110, 0.78260869565217, 1.7, 0.13888888888889
82111, 0.80434782608696, 1.7, 0.16666666666667
82112, 0.78260869565217, 1.675, 0.16666666666667
82113, 0.78260869565217, 1.7, 0.19444444444444
82114, 0.80434782608696, 1.7, 0.22222222222222
82115, 0.78260869565217, 1.675, 0.22222222222222
82116, 0.78260869565217, 1.7, 0.25
82117, 0.80434782608696, 1.7, 0.27777777777778
82118, 0.78260869565217, 1.675, 0.27777777777778
82119, 0.78260869565217, 1.7, 0.30555555555556
82120, 0.80434782608696, 1.7, 0.33333333333333
82121, 0.78260869565217, 1.675, 0.33333333333333
82122, 0.78260869565217, 1.7, 0.36111111111111
82123, 0.80434782608696, 1.7, 0.38888888888889
82124, 0.78260869565217, 1.675, 0.38888888888889
82125, 0.78260869565217, 1.7, 0.41666666666667
82126, 0.80434782608696, 1.7, 0.44444444444444
82127, 0.78260869565217, 1.675, 0.44444444444444
82128, 0.78260869565217, 1.7, 0.47222222222222
82129, 0.73913043478261, 1.7, 0.027777777777778
82130, 0.76086956521739, 1.7, 0.055555555555556
82131, 0.73913043478261, 1.675, 0.055555555555556
82132, 0.73913043478261, 1.7, 0.083333333333333
82133, 0.76086956521739, 1.7, 0.11111111111111
82134, 0.73913043478261, 1.675, 0.11111111111111
82135, 0.73913043478261, 1.7, 0.13888888888889
82136, 0.76086956521739, 1.7, 0.16666666666667
82137, 0.73913043478261, 1.675, 0.16666666666667
82138, 0.73913043478261, 1.7, 0.19444444444444
82139, 0.76086956521739, 1.7, 0.22222222222222
82140, 0.73913043478261, 1.675, 0.22222222222222
82141, 0.73913043478261, 1.7, 0.25
82142, 0.76086956521739, 1.7, 0.27777777777778
82143, 0.73913043478261, 1.675, 0.27777777777778
82144, 0.73913043478261, 1.7, 0.30555555555556
82145, 0.76086956521739, 1.7, 0.33333333333333
82146, 0.73913043478261, 1.675, 0.33333333333333
82147, 0.73913043478261, 1.7, 0.36111111111111
82148, 0.76086956521739, 1.7, 0.38888888888889
82149, 0.73913043478261, 1.675, 0.38888888888889
82150, 0.73913043478261, 1.7, 0.41666666666667
82151, 0.76086956521739, 1.7, 0.44444444444444
82152, 0.73913043478261, 1.675, 0.44444444444444
82153, 0.73913043478261, 1.7, 0.47222222222222
82154, 0.69565217391304, 1.7, 0.027777777777778
82155, 0.71739130434783, 1.7, 0.055555555555556
82156, 0.69565217391304, 1.675, 0.055555555555556
82157, 0.69565217391304, 1.7, 0.083333333333333
82158, 0.71739130434783, 1.7, 0.11111111111111
82159, 0.69565217391304, 1.675, 0.11111111111111
82160, 0.69565217391304, 1.7, 0.13888888888889
82161, 0.71739130434783, 1.7, 0.16666666666667
82162, 0.69565217391304, 1.675, 0.16666666666667
82163, 0.69565217391304, 1.7, 0.19444444444444
82164, 0.71739130434783, 1.7, 0.22222222222222
82165, 0.69565217391304, 1.675, 0.22222222222222
82166, 0.69565217391304, 1.7, 0.25
82167, 0.71739130434783, 1.7, 0.27777777777778
82168, 0.69565217391304, 1.675, 0.27777777777778
82169, 0.69565217391304, 1.7, 0.30555555555556
82170, 0.71739130434783, 1.7, 0.33333333333333
82171, 0.69565217391304, 1.675, 0.33333333333333
82172, 0.69565217391304, 1.7, 0.36111111111111
82173, 0.71739130434783, 1.7, 0.38888888888889
82174, 0.69565217391304, 1.675, 0.38888888888889
82175, 0.69565217391304, 1.7, 0.41666666666667
82176, 0.71739130434783, 1.7, 0.44444444444444
82177, 0.69565217391304, 1.675, 0.44444444444444
82178, 0.69565217391304, 1.7, 0.47222222222222
82179, 0.65217391304348, 1.7, 0.027777777777778
82180, 0.67391304347826, 1.7, 0.055555555555556
82181, 0.65217391304348, 1.675, 0.055555555555556
82182, 0.65217391304348, 1.7, 0.083333333333333
82183, 0.67391304347826, 1.7, 0.11111111111111
82184, 0.65217391304348, 1.675, 0.11111111111111
82185, 0.65217391304348, 1.7, 0.13888888888889
82186, 0.67391304347826, 1.7, 0.16666666666667
82187, 0.65217391304348, 1.675, 0.16666666666667
82188, 0.65217391304348, 1.7, 0.19444444444444
82189, 0.67391304347826, 1.7, 0.22222222222222
82190, 0.65217391304348, 1.675, 0.22222222222222
82191, 0.65217391304348, 1.7, 0.25
82192, 0.67391304347826, 1.7, 0.27777777777778
82193, 0.65217391304348, 1.675, 0.27777777777778
82194, 0.65217391304348, 1.7, 0.30555555555556
82195, 0.67391304347826, 1.7, 0.33333333333333
82196, 0.65217391304348, 1.675, 0.33333333333333
82197, 0.65217391304348, 1.7, 0.36111111111111
82198, 0.67391304347826, 1.7, 0.38888888888889
82199, 0.65217391304348, 1.675, 0.38888888888889
82200, 0.65217391304348, 1.7, 0.41666666666667
82201, 0.67391304347826, 1.7, 0.44444444444444
82202, 0.65217391304348, 1.675, 0.44444444444444
82203, 0.65217391304348, 1.7, 0.47222222222222
82204, 0.60869565217391, 1.7, 0.027777777777778
82205, 0.6304347826087, 1.7, 0.055555555555556
82206, 0.60869565217391, 1.675, 0.055555555555556
82207, 0.60869565217391, 1.7, 0.083333333333333
82208, 0.6304347826087, 1.7, 0.11111111111111
82209, 0.60869565217391, 1.675, 0.11111111111111
82210, 0.60869565217391, 1.7, 0.13888888888889
82211, 0.6304347826087, 1.7, 0.16666666666667
82212, 0.60869565217391, 1.675, 0.16666666666667
82213, 0.60869565217391, 1.7, 0.19444444444444
82214, 0.6304347826087, 1.7, 0.22222222222222
82215, 0.60869565217391, 1.675, 0.22222222222222
82216, 0.60869565217391, 1.7, 0.25
82217, 0.6304347826087, 1.7, 0.27777777777778
82218, 0.60869565217391, 1.675, 0.27777777777778
82219, 0.60869565217391, 1.7, 0.30555555555556
82220, 0.6304347826087, 1.7, 0.33333333333333
82221, 0.60869565217391, 1.675, 0.33333333333333
82222, 0.60869565217391, 1.7, 0.36111111111111
82223, 0.6304347826087, 1.7, 0.38888888888889
82224, 0.60869565217391, 1.675, 0.38888888888889
82225, 0.60869565217391, 1.7, 0.41666666666667
82226, 0.6304347826087, 1.7, 0.44444444444444
82227, 0.60869565217391, 1.675, 0.44444444444444
82228, 0.60869565217391, 1.7, 0.47222222222222
82229, 0.56521739130435, 1.7, 0.027777777777778
82230, 0.58695652173913, 1.7, 0.055555555555556
82231, 0.56521739130435, 1.675, 0.055555555555556
82232, 0.56521739130435, 1.7, 0.083333333333333
82233, 0.58695652173913, 1.7, 0.11111111111111
82234, 0.56521739130435, 1.675, 0.11111111111111
82235, 0.56521739130435, 1.7, 0.13888888888889
82236, 0.58695652173913, 1.7, 0.16666666666667
82237, 0.56521739130435, 1.675, 0.16666666666667
82238, 0.56521739130435, 1.7, 0.19444444444444
82239, 0.58695652173913, 1.7, 0.22222222222222
82240, 0.56521739130435, 1.675, 0.22222222222222
82241, 0.56521739130435, 1.7, 0.25
82242, 0.58695652173913, 1.7, 0.27777777777778
82243, 0.56521739130435, 1.675, 0.27777777777778
82244, 0.56521739130435, 1.7, 0.30555555555556
82245, 0.58695652173913, 1.7, 0.33333333333333
82246, 0.56521739130435, 1.675, 0.33333333333333
82247, 0.56521739130435, 1.7, 0.36111111111111
82248, 0.58695652173913, 1.7, 0.38888888888889
82249, 0.56521739130435, 1.675, 0.38888888888889
82250, 0.56521739130435, 1.7, 0.41666666666667
82251, 0.58695652173913, 1.7, 0.44444444444444
82252, 0.56521739130435, 1.675, 0.44444444444444
82253, 0.56521739130435, 1.7, 0.47222222222222
82254, 0.52173913043478, 1.7, 0.027777777777778
82255, 0.54347826086957, 1.7, 0.055555555555556
82256, 0.52173913043478, 1.675, 0.055555555555556
82257, 0.52173913043478, 1.7, 0.083333333333333
82258, 0.54347826086957, 1.7, 0.11111111111111
82259, 0.52173913043478, 1.675, 0.11111111111111
82260, 0.52173913043478, 1.7, 0.13888888888889
82261, 0.54347826086956, 1.7, 0.16666666666667
82262, 0.52173913043478, 1.675, 0.16666666666667
82263, 0.52173913043478, 1.7, 0.19444444444444
82264, 0.54347826086956, 1.7, 0.22222222222222
82265, 0.52173913043478, 1.675, 0.22222222222222
82266, 0.52173913043478, 1.7, 0.25
82267, 0.54347826086956, 1.7, 0.27777777777778
82268, 0.52173913043478, 1.675, 0.27777777777778
82269, 0.52173913043478, 1.7, 0.30555555555556
82270, 0.54347826086956, 1.7, 0.33333333333333
82271, 0.52173913043478, 1.675, 0.33333333333333
82272, 0.52173913043478, 1.7, 0.36111111111111
82273, 0.54347826086956, 1.7, 0.38888888888889
82274, 0.52173913043478, 1.675, 0.38888888888889
82275, 0.52173913043478, 1.7, 0.41666666666667
82276, 0.54347826086956, 1.7, 0.44444444444444
82277, 0.52173913043478, 1.675, 0.44444444444444
82278, 0.52173913043478, 1.7, 0.47222222222222
82279, 0.47826086956522, 1.7, 0.027777777777778
82280, 0.5, 1.7, 0.055555555555556
82281, 0.47826086956522, 1.675, 0.055555555555556
82282, 0.47826086956522, 1.7, 0.083333333333333
82283, 0.5, 1.7, 0.11111111111111
82284, 0.47826086956522, 1.675, 0.11111111111111
82285, 0.47826086956522, 1.7, 0.13888888888889
82286, 0.5, 1.7, 0.16666666666667
82287, 0.47826086956522, 1.675, 0.16666666666667
82288, 0.47826086956522, 1.7, 0.19444444444444
82289, 0.5, 1.7, 0.22222222222222
82290, 0.47826086956522, 1.675, 0.22222222222222
82291, 0.47826086956522, 1.7, 0.25
82292, 0.5, 1.7, 0.27777777777778
82293, 0.47826086956522, 1.675, 0.27777777777778
82294, 0.47826086956522, 1.7, 0.30555555555556
82295, 0.5, 1.7, 0.33333333333333
82296, 0.47826086956522, 1.675, 0.33333333333333
82297, 0.47826086956522, 1.7, 0.36111111111111
82298, 0.5, 1.7, 0.38888888888889
82299, 0.47826086956522, 1.675, 0.38888888888889
82300, 0.47826086956522, 1.7, 0.41666666666667
82301, 0.5, 1.7, 0.44444444444444
82302, 0.47826086956522, 1.675, 0.44444444444444
82303, 0.47826086956522, 1.7, 0.47222222222222
82304, 0.43478260869565, 1.7, 0.027777777777778
82305, 0.45652173913043, 1.7, 0.055555555555556
82306, 0.43478260869565, 1.675, 0.055555555555556
82307, 0.43478260869565, 1.7, 0.083333333333333
82308, 0.45652173913043, 1.7, 0.11111111111111
82309, 0.43478260869565, 1.675, 0.11111111111111
82310, 0.43478260869565, 1.7, 0.13888888888889
82311, 0.45652173913043, 1.7, 0.16666666666667
82312, 0.43478260869565, 1.675, 0.16666666666667
82313, 0.43478260869565, 1.7, 0.19444444444444
82314, 0.45652173913043, 1.7, 0.22222222222222
82315, 0.43478260869565, 1.675, 0.22222222222222
82316, 0.43478260869565, 1.7, 0.25
82317, 0.45652173913043, 1.7, 0.27777777777778
82318, 0.43478260869565, 1.675, 0.27777777777778
82319, 0.43478260869565, 1.7, 0.30555555555556
82320, 0.45652173913043, 1.7, 0.33333333333333
82321, 0.43478260869565, 1.675, 0.33333333333333
82322, 0.43478260869565, 1.7, 0.36111111111111
82323, 0.45652173913043, 1.7, 0.38888888888889
82324, 0.43478260869565, 1.675, 0.38888888888889
82325, 0.43478260869565, 1.7, 0.41666666666667
82326, 0.45652173913043, 1.7, 0.44444444444444
82327, 0.43478260869565, 1.675, 0.44444444444444
82328, 0.43478260869565, 1.7, 0.47222222222222
82329, 0.39130434782609, 1.7, 0.027777777777778
82330, 0.41304347826087, 1.7, 0.055555555555556
82331, 0.39130434782609, 1.675, 0.055555555555556
82332, 0.39130434782609, 1.7, 0.083333333333333
82333, 0.41304347826087, 1.7, 0.11111111111111
82334, 0.39130434782609, 1.675, 0.11111111111111
82335, 0.39130434782609, 1.7, 0.13888888888889
82336, 0.41304347826087, 1.7, 0.16666666666667
82337, 0.39130434782609, 1.675, 0.16666666666667
82338, 0.39130434782609, 1.7, 0.19444444444444
82339, 0.41304347826087, 1.7, 0.22222222222222
82340, 0.39130434782609, 1.675, 0.22222222222222
82341, 0.39130434782609, 1.7, 0.25
82342, 0.41304347826087, 1.7, 0.27777777777778
82343, 0.39130434782609, 1.675, 0.27777777777778
82344, 0.39130434782609, 1.7, 0.30555555555556
82345, 0.41304347826087, 1.7, 0.33333333333333
82346, 0.39130434782609, 1.675, 0.33333333333333
82347, 0.39130434782609, 1.7, 0.36111111111111
82348, 0.41304347826087, 1.7, 0.38888888888889
82349, 0.39130434782609, 1.675, 0.38888888888889
82350, 0.39130434782609, 1.7, 0.41666666666667
82351, 0.41304347826087, 1.7, 0.44444444444444
82352, 0.39130434782609, 1.675, 0.44444444444444
82353, 0.39130434782609, 1.7, 0.47222222222222
82354, 0.34782608695652, 1.7, 0.027777777777778
82355, 0.3695652173913, 1.7, 0.055555555555556
82356, 0.34782608695652, 1.675, 0.055555555555556
82357, 0.34782608695652, 1.7, 0.083333333333333
82358, 0.3695652173913, 1.7, 0.11111111111111
82359, 0.34782608695652, 1.675, 0.11111111111111
82360, 0.34782608695652, 1.7, 0.13888888888889
82361, 0.3695652173913, 1.7, 0.16666666666667
82362, 0.34782608695652, 1.675, 0.16666666666667
82363, 0.34782608695652, 1.7, 0.19444444444444
82364, 0.3695652173913, 1.7, 0.22222222222222
82365, 0.34782608695652, 1.675, 0.22222222222222
82366, 0.34782608695652, 1.7, 0.25
82367, 0.3695652173913, 1.7, 0.27777777777778
82368, 0.34782608695652, 1.675, 0.27777777777778
82369, 0.34782608695652, 1.7, 0.30555555555556
82370, 0.3695652173913, 1.7, 0.33333333333333
82371, 0.34782608695652, 1.675, 0.33333333333333
82372, 0.34782608695652, 1.7, 0.36111111111111
82373, 0.3695652173913, 1.7, 0.38888888888889
82374, 0.34782608695652, 1.675, 0.38888888888889
82375, 0.34782608695652, 1.7, 0.41666666666667
82376, 0.3695652173913, 1.7, 0.44444444444444
82377, 0.34782608695652, 1.675, 0.44444444444444
82378, 0.34782608695652, 1.7, 0.47222222222222
82379, 0.30434782608696, 1.7, 0.027777777777778
82380, 0.32608695652174, 1.7, 0.055555555555556
82381, 0.30434782608696, 1.675, 0.055555555555556
82382, 0.30434782608696, 1.7, 0.083333333333333
82383, 0.32608695652174, 1.7, 0.11111111111111
82384, 0.30434782608696, 1.675, 0.11111111111111
82385, 0.30434782608696, 1.7, 0.13888888888889
82386, 0.32608695652174, 1.7, 0.16666666666667
82387, 0.30434782608696, 1.675, 0.16666666666667
82388, 0.30434782608696, 1.7, 0.19444444444444
82389, 0.32608695652174, 1.7, 0.22222222222222
82390, 0.30434782608696, 1.675, 0.22222222222222
82391, 0.30434782608696, 1.7, 0.25
82392, 0.32608695652174, 1.7, 0.27777777777778
82393, 0.30434782608696, 1.675, 0.27777777777778
82394, 0.30434782608696, 1.7, 0.30555555555556
82395, 0.32608695652174, 1.7, 0.33333333333333
82396, 0.30434782608696, 1.675, 0.33333333333333
82397, 0.30434782608696, 1.7, 0.36111111111111
82398, 0.32608695652174, 1.7, 0.38888888888889
82399, 0.30434782608696, 1.675, 0.38888888888889
82400, 0.30434782608696, 1.7, 0.41666666666667
82401, 0.32608695652174, 1.7, 0.44444444444444
82402, 0.30434782608696, 1.675, 0.44444444444444
82403, 0.30434782608696, 1.7, 0.47222222222222
82404, 0.26086956521739, 1.7, 0.027777777777778
82405, 0.28260869565217, 1.7, 0.055555555555556
82406, 0.26086956521739, 1.675, 0.055555555555556
82407, 0.26086956521739, 1.7, 0.083333333333333
82408, 0.28260869565217, 1.7, 0.11111111111111
82409, 0.26086956521739, 1.675, 0.11111111111111
82410, 0.26086956521739, 1.7, 0.13888888888889
82411, 0.28260869565217, 1.7, 0.16666666666667
82412, 0.26086956521739, 1.675, 0.16666666666667
82413, 0.26086956521739, 1.7, 0.19444444444444
82414, 0.28260869565217, 1.7, 0.22222222222222
82415, 0.26086956521739, 1.675, 0.22222222222222
82416, 0.26086956521739, 1.7, 0.25
82417, 0.28260869565217, 1.7, 0.27777777777778
82418, 0.26086956521739, 1.675, 0.27777777777778
82419, 0.26086956521739, 1.7, 0.30555555555556
82420, 0.28260869565217, 1.7, 0.33333333333333
82421, 0.26086956521739, 1.675, 0.33333333333333
82422, 0.26086956521739, 1.7, 0.36111111111111
82423, 0.28260869565217, 1.7, 0.38888888888889
82424, 0.26086956521739, 1.675, 0.38888888888889
82425, 0.26086956521739, 1.7, 0.41666666666667
82426, 0.28260869565217, 1.7, 0.44444444444444
82427, 0.26086956521739, 1.675, 0.44444444444444
82428, 0.26086956521739, 1.7, 0.47222222222222
82429, 0.21739130434783, 1.7, 0.027777777777778
82430, 0.23913043478261, 1.7, 0.055555555555556
82431, 0.21739130434783, 1.675, 0.055555555555556
82432, 0.21739130434783, 1.7, 0.083333333333333
82433, 0.23913043478261, 1.7, 0.11111111111111
82434, 0.21739130434783, 1.675, 0.11111111111111
82435, 0.21739130434783, 1.7, 0.13888888888889
82436, 0.23913043478261, 1.7, 0.16666666666667
82437, 0.21739130434783, 1.675, 0.16666666666667
82438, 0.21739130434783, 1.7, 0.19444444444444
82439, 0.23913043478261, 1.7, 0.22222222222222
82440, 0.21739130434783, 1.675, 0.22222222222222
82441, 0.21739130434783, 1.7, 0.25
82442, 0.23913043478261, 1.7, 0.27777777777778
82443, 0.21739130434783, 1.675, 0.27777777777778
82444, 0.21739130434783, 1.7, 0.30555555555556
82445, 0.23913043478261, 1.7, 0.33333333333333
82446, 0.21739130434783, 1.675, 0.33333333333333
82447, 0.21739130434783, 1.7, 0.36111111111111
82448, 0.23913043478261, 1.7, 0.38888888888889
82449, 0.21739130434783, 1.675, 0.38888888888889
82450, 0.21739130434783, 1.7, 0.41666666666667
82451, 0.23913043478261, 1.7, 0.44444444444444
82452, 0.21739130434783, 1.675, 0.44444444444444
82453, 0.21739130434783, 1.7, 0.47222222222222
82454, 0.17391304347826, 1.7, 0.027777777777778
82455, 0.19565217391304, 1.7, 0.055555555555556
82456, 0.17391304347826, 1.675, 0.055555555555556
82457, 0.17391304347826, 1.7, 0.083333333333333
82458, 0.19565217391304, 1.7, 0.11111111111111
82459, 0.17391304347826, 1.675, 0.11111111111111
82460, 0.17391304347826, 1.7, 0.13888888888889
82461, 0.19565217391304, 1.7, 0.16666666666667
82462, 0.17391304347826, 1.675, 0.16666666666667
82463, 0.17391304347826, 1.7, 0.19444444444444
82464, 0.19565217391304, 1.7, 0.22222222222222
82465, 0.17391304347826, 1.675, 0.22222222222222
82466, 0.17391304347826, 1.7, 0.25
82467, 0.19565217391304, 1.7, 0.27777777777778
82468, 0.17391304347826, 1.675, 0.27777777777778
82469, 0.17391304347826, 1.7, 0.30555555555556
82470, 0.19565217391304, 1.7, 0.33333333333333
82471, 0.17391304347826, 1.675, 0.33333333333333
82472, 0.17391304347826, 1.7, 0.36111111111111
82473, 0.19565217391304, 1.7, 0.38888888888889
82474, 0.17391304347826, 1.675, 0.38888888888889
82475, 0.17391304347826, 1.7, 0.41666666666667
82476, 0.19565217391304, 1.7, 0.44444444444444
82477, 0.17391304347826, 1.675, 0.44444444444444
82478, 0.17391304347826, 1.7, 0.47222222222222
82479, 0.1304347826087, 1.7, 0.027777777777778
82480, 0.15217391304348, 1.7, 0.055555555555556
82481, 0.1304347826087, 1.675, 0.055555555555556
82482, 0.1304347826087, 1.7, 0.083333333333333
82483, 0.15217391304348, 1.7, 0.11111111111111
82484, 0.1304347826087, 1.675, 0.11111111111111
82485, 0.1304347826087, 1.7, 0.13888888888889
82486, 0.15217391304348, 1.7, 0.16666666666667
82487, 0.1304347826087, 1.675, 0.16666666666667
82488, 0.1304347826087, 1.7, 0.19444444444444
82489, 0.15217391304348, 1.7, 0.22222222222222
82490, 0.1304347826087, 1.675, 0.22222222222222
82491, 0.1304347826087, 1.7, 0.25
82492, 0.15217391304348, 1.7, 0.27777777777778
82493, 0.1304347826087, 1.675, 0.27777777777778
82494, 0.1304347826087, 1.7, 0.30555555555556
82495, 0.15217391304348, 1.7, 0.33333333333333
82496, 0.1304347826087, 1.675, 0.33333333333333
82497, 0.1304347826087, 1.7, 0.36111111111111
82498, 0.15217391304348, 1.7, 0.38888888888889
82499, 0.1304347826087, 1.675, 0.38888888888889
82500, 0.1304347826087, 1.7, 0.41666666666667
82501, 0.15217391304348, 1.7, 0.44444444444444
82502, 0.1304347826087, 1.675, 0.44444444444444
82503, 0.1304347826087, 1.7, 0.47222222222222
82504, 0.08695652173913, 1.7, 0.027777777777778
82505, 0.10869565217391, 1.7, 0.055555555555556
82506, 0.08695652173913, 1.675, 0.055555555555556
82507, 0.08695652173913, 1.7, 0.083333333333333
82508, 0.10869565217391, 1.7, 0.11111111111111
82509, 0.08695652173913, 1.675, 0.11111111111111
82510, 0.08695652173913, 1.7, 0.13888888888889
82511, 0.10869565217391, 1.7, 0.16666666666667
82512, 0.08695652173913, 1.675, 0.16666666666667
82513, 0.08695652173913, 1.7, 0.19444444444444
82514, 0.10869565217391, 1.7, 0.22222222222222
82515, 0.08695652173913, 1.675, 0.22222222222222
82516, 0.08695652173913, 1.7, 0.25
82517, 0.10869565217391, 1.7, 0.27777777777778
82518, 0.08695652173913, 1.675, 0.27777777777778
82519, 0.08695652173913, 1.7, 0.30555555555556
82520, 0.10869565217391, 1.7, 0.33333333333333
82521, 0.08695652173913, 1.675, 0.33333333333333
82522, 0.08695652173913, 1.7, 0.36111111111111
82523, 0.10869565217391, 1.7, 0.38888888888889
82524, 0.08695652173913, 1.675, 0.38888888888889
82525, 0.08695652173913, 1.7, 0.41666666666667
82526, 0.10869565217391, 1.7, 0.44444444444444
82527, 0.08695652173913, 1.675, 0.44444444444444
82528, 0.08695652173913, 1.7, 0.47222222222222
82529, 0.043478260869565, 1.7, 0.027777777777778
82530, 0.065217391304348, 1.7, 0.055555555555556
82531, 0.043478260869565, 1.675, 0.055555555555556
82532, 0.043478260869565, 1.7, 0.083333333333333
82533, 0.065217391304348, 1.7, 0.11111111111111
82534, 0.043478260869565, 1.675, 0.11111111111111
82535, 0.043478260869565, 1.7, 0.13888888888889
82536, 0.065217391304348, 1.7, 0.16666666666667
82537, 0.043478260869565, 1.675, 0.16666666666667
82538, 0.043478260869565, 1.7, 0.19444444444444
82539, 0.065217391304348, 1.7, 0.22222222222222
82540, 0.043478260869565, 1.675, 0.22222222222222
82541, 0.043478260869565, 1.7, 0.25
82542, 0.065217391304348, 1.7, 0.27777777777778
82543, 0.043478260869565, 1.675, 0.27777777777778
82544, 0.043478260869565, 1.7, 0.30555555555556
82545, 0.065217391304348, 1.7, 0.33333333333333
82546, 0.043478260869565, 1.675, 0.33333333333333
82547, 0.043478260869565, 1.7, 0.36111111111111
82548, 0.065217391304348, 1.7, 0.38888888888889
82549, 0.043478260869565, 1.675, 0.38888888888889
82550, 0.043478260869565, 1.7, 0.41666666666667
82551, 0.065217391304348, 1.7, 0.44444444444444
82552, 0.043478260869565, 1.675, 0.44444444444444
82553, 0.043478260869565, 1.7, 0.47222222222222
82554, 0.021739130434783, 1.7, 0.055555555555556
82555, 0.021739130434783, 1.7, 0.11111111111111
82556, 0.021739130434783, 1.7, 0.16666666666667
82557, 0.021739130434783, 1.7, 0.22222222222222
82558, 0.021739130434783, 1.7, 0.27777777777778
82559, 0.021739130434783, 1.7, 0.33333333333333
82560, 0.021739130434783, 1.7, 0.38888888888889
82561, 0.021739130434783, 1.7, 0.44444444444444
82562, 0.95652173913043, 1.725, 0.055555555555556
82563, 0.95652173913043, 1.725, 0.11111111111111
82564, 0.95652173913043, 1.725, 0.16666666666667
82565, 0.95652173913043, 1.725, 0.22222222222222
82566, 0.95652173913043, 1.725, 0.27777777777778
82567, 0.95652173913043, 1.725, 0.33333333333333
82568, 0.95652173913043, 1.725, 0.38888888888889
82569, 0.95652173913043, 1.725, 0.44444444444444
82570, 0.91304347826087, 1.725, 0.055555555555556
82571, 0.91304347826087, 1.725, 0.11111111111111
82572, 0.91304347826087, 1.725, 0.16666666666667
82573, 0.91304347826087, 1.725, 0.22222222222222
82574, 0.91304347826087, 1.725, 0.27777777777778
82575, 0.91304347826087, 1.725, 0.33333333333333
82576, 0.91304347826087, 1.725, 0.38888888888889
82577, 0.91304347826087, 1.725, 0.44444444444444
82578, 0.8695652173913, 1.725, 0.055555555555556
82579, 0.8695652173913, 1.725, 0.11111111111111
82580, 0.8695652173913, 1.725, 0.16666666666667
82581, 0.8695652173913, 1.725, 0.22222222222222
82582, 0.8695652173913, 1.725, 0.27777777777778
82583, 0.8695652173913, 1.725, 0.33333333333333
82584, 0.8695652173913, 1.725, 0.38888888888889
82585, 0.8695652173913, 1.725, 0.44444444444444
82586, 0.82608695652174, 1.725, 0.055555555555556
82587, 0.82608695652174, 1.725, 0.11111111111111
82588, 0.82608695652174, 1.725, 0.16666666666667
82589, 0.82608695652174, 1.725, 0.22222222222222
82590, 0.82608695652174, 1.725, 0.27777777777778
82591, 0.82608695652174, 1.725, 0.33333333333333
82592, 0.82608695652174, 1.725, 0.38888888888889
82593, 0.82608695652174, 1.725, 0.44444444444444
82594, 0.78260869565217, 1.725, 0.055555555555556
82595, 0.78260869565217, 1.725, 0.11111111111111
82596, 0.78260869565217, 1.725, 0.16666666666667
82597, 0.78260869565217, 1.725, 0.22222222222222
82598, 0.78260869565217, 1.725, 0.27777777777778
82599, 0.78260869565217, 1.725, 0.33333333333333
82600, 0.78260869565217, 1.725, 0.38888888888889
82601, 0.78260869565217, 1.725, 0.44444444444444
82602, 0.73913043478261, 1.725, 0.055555555555556
82603, 0.73913043478261, 1.725, 0.11111111111111
82604, 0.73913043478261, 1.725, 0.16666666666667
82605, 0.73913043478261, 1.725, 0.22222222222222
82606, 0.73913043478261, 1.725, 0.27777777777778
82607, 0.73913043478261, 1.725, 0.33333333333333
82608, 0.73913043478261, 1.725, 0.38888888888889
82609, 0.73913043478261, 1.725, 0.44444444444444
82610, 0.69565217391304, 1.725, 0.055555555555556
82611, 0.69565217391304, 1.725, 0.11111111111111
82612, 0.69565217391304, 1.725, 0.16666666666667
82613, 0.69565217391304, 1.725, 0.22222222222222
82614, 0.69565217391304, 1.725, 0.27777777777778
82615, 0.69565217391304, 1.725, 0.33333333333333
82616, 0.69565217391304, 1.725, 0.38888888888889
82617, 0.69565217391304, 1.725, 0.44444444444444
82618, 0.65217391304348, 1.725, 0.055555555555556
82619, 0.65217391304348, 1.725, 0.11111111111111
82620, 0.65217391304348, 1.725, 0.16666666666667
82621, 0.65217391304348, 1.725, 0.22222222222222
82622, 0.65217391304348, 1.725, 0.27777777777778
82623, 0.65217391304348, 1.725, 0.33333333333333
82624, 0.65217391304348, 1.725, 0.38888888888889
82625, 0.65217391304348, 1.725, 0.44444444444444
82626, 0.60869565217391, 1.725, 0.055555555555556
82627, 0.60869565217391, 1.725, 0.11111111111111
82628, 0.60869565217391, 1.725, 0.16666666666667
82629, 0.60869565217391, 1.725, 0.22222222222222
82630, 0.60869565217391, 1.725, 0.27777777777778
82631, 0.60869565217391, 1.725, 0.33333333333333
82632, 0.60869565217391, 1.725, 0.38888888888889
82633, 0.60869565217391, 1.725, 0.44444444444444
82634, 0.56521739130435, 1.725, 0.055555555555556
82635, 0.56521739130435, 1.725, 0.11111111111111
82636, 0.56521739130435, 1.725, 0.16666666666667
82637, 0.56521739130435, 1.725, 0.22222222222222
82638, 0.56521739130435, 1.725, 0.27777777777778
82639, 0.56521739130435, 1.725, 0.33333333333333
82640, 0.56521739130435, 1.725, 0.38888888888889
82641, 0.56521739130435, 1.725, 0.44444444444444
82642, 0.52173913043478, 1.725, 0.055555555555556
82643, 0.52173913043478, 1.725, 0.11111111111111
82644, 0.52173913043478, 1.725, 0.16666666666667
82645, 0.52173913043478, 1.725, 0.22222222222222
82646, 0.52173913043478, 1.725, 0.27777777777778
82647, 0.52173913043478, 1.725, 0.33333333333333
82648, 0.52173913043478, 1.725, 0.38888888888889
82649, 0.52173913043478, 1.725, 0.44444444444444
82650, 0.47826086956522, 1.725, 0.055555555555556
82651, 0.47826086956522, 1.725, 0.11111111111111
82652, 0.47826086956522, 1.725, 0.16666666666667
82653, 0.47826086956522, 1.725, 0.22222222222222
82654, 0.47826086956522, 1.725, 0.27777777777778
82655, 0.47826086956522, 1.725, 0.33333333333333
82656, 0.47826086956522, 1.725, 0.38888888888889
82657, 0.47826086956522, 1.725, 0.44444444444444
82658, 0.43478260869565, 1.725, 0.055555555555556
82659, 0.43478260869565, 1.725, 0.11111111111111
82660, 0.43478260869565, 1.725, 0.16666666666667
82661, 0.43478260869565, 1.725, 0.22222222222222
82662, 0.43478260869565, 1.725, 0.27777777777778
82663, 0.43478260869565, 1.725, 0.33333333333333
82664, 0.43478260869565, 1.725, 0.38888888888889
82665, 0.43478260869565, 1.725, 0.44444444444444
82666, 0.39130434782609, 1.725, 0.055555555555556
82667, 0.39130434782609, 1.725, 0.11111111111111
82668, 0.39130434782609, 1.725, 0.16666666666667
82669, 0.39130434782609, 1.725, 0.22222222222222
82670, 0.39130434782609, 1.725, 0.27777777777778
82671, 0.39130434782609, 1.725, 0.33333333333333
82672, 0.39130434782609, 1.725, 0.38888888888889
82673, 0.39130434782609, 1.725, 0.44444444444444
82674, 0.34782608695652, 1.725, 0.055555555555556
82675, 0.34782608695652, 1.725, 0.11111111111111
82676, 0.34782608695652, 1.725, 0.16666666666667
82677, 0.34782608695652, 1.725, 0.22222222222222
82678, 0.34782608695652, 1.725, 0.27777777777778
82679, 0.34782608695652, 1.725, 0.33333333333333
82680, 0.34782608695652, 1.725, 0.38888888888889
82681, 0.34782608695652, 1.725, 0.44444444444444
82682, 0.30434782608696, 1.725, 0.055555555555556
82683, 0.30434782608696, 1.725, 0.11111111111111
82684, 0.30434782608696, 1.725, 0.16666666666667
82685, 0.30434782608696, 1.725, 0.22222222222222
82686, 0.30434782608696, 1.725, 0.27777777777778
82687, 0.30434782608696, 1.725, 0.33333333333333
82688, 0.30434782608696, 1.725, 0.38888888888889
82689, 0.30434782608696, 1.725, 0.44444444444444
82690, 0.26086956521739, 1.725, 0.055555555555556
82691, 0.26086956521739, 1.725, 0.11111111111111
82692, 0.26086956521739, 1.725, 0.16666666666667
82693, 0.26086956521739, 1.725, 0.22222222222222
82694, 0.26086956521739, 1.725, 0.27777777777778
82695, 0.26086956521739, 1.725, 0.33333333333333
82696, 0.26086956521739, 1.725, 0.38888888888889
82697, 0.26086956521739, 1.725, 0.44444444444444
82698, 0.21739130434783, 1.725, 0.055555555555556
82699, 0.21739130434783, 1.725, 0.11111111111111
82700, 0.21739130434783, 1.725, 0.16666666666667
82701, 0.21739130434783, 1.725, 0.22222222222222
82702, 0.21739130434783, 1.725, 0.27777777777778
82703, 0.21739130434783, 1.725, 0.33333333333333
82704, 0.21739130434783, 1.725, 0.38888888888889
82705, 0.21739130434783, 1.725, 0.44444444444444
82706, 0.17391304347826, 1.725, 0.055555555555556
82707, 0.17391304347826, 1.725, 0.11111111111111
82708, 0.17391304347826, 1.725, 0.16666666666667
82709, 0.17391304347826, 1.725, 0.22222222222222
82710, 0.17391304347826, 1.725, 0.27777777777778
82711, 0.17391304347826, 1.725, 0.33333333333333
82712, 0.17391304347826, 1.725, 0.38888888888889
82713, 0.17391304347826, 1.725, 0.44444444444444
82714, 0.1304347826087, 1.725, 0.055555555555556
82715, 0.1304347826087, 1.725, 0.11111111111111
82716, 0.1304347826087, 1.725, 0.16666666666667
82717, 0.1304347826087, 1.725, 0.22222222222222
82718, 0.1304347826087, 1.725, 0.27777777777778
82719, 0.1304347826087, 1.725, 0.33333333333333
82720, 0.1304347826087, 1.725, 0.38888888888889
82721, 0.1304347826087, 1.725, 0.44444444444444
82722, 0.08695652173913, 1.725, 0.055555555555556
82723, 0.08695652173913, 1.725, 0.11111111111111
82724, 0.08695652173913, 1.725, 0.16666666666667
82725, 0.08695652173913, 1.725, 0.22222222222222
82726, 0.08695652173913, 1.725, 0.27777777777778
82727, 0.08695652173913, 1.725, 0.33333333333333
82728, 0.08695652173913, 1.725, 0.38888888888889
82729, 0.08695652173913, 1.725, 0.44444444444444
82730, 0.043478260869565, 1.725, 0.055555555555556
82731, 0.043478260869565, 1.725, 0.11111111111111
82732, 0.043478260869565, 1.725, 0.16666666666667
82733, 0.043478260869565, 1.725, 0.22222222222222
82734, 0.043478260869565, 1.725, 0.27777777777778
82735, 0.043478260869565, 1.725, 0.33333333333333
82736, 0.043478260869565, 1.725, 0.38888888888889
82737, 0.043478260869565, 1.725, 0.44444444444444
82738, 1.05, 1.6, 0.44444444444444
82739, 1.05, 1.6, 0.38888888888889
82740, 1.05, 1.6, 0.33333333333333
82741, 1.05, 1.6, 0.27777777777778
82742, 1.05, 1.6, 0.22222222222222
82743, 1.05, 1.6, 0.16666666666667
82744, 1.05, 1.6, 0.11111111111111
82745, 1.05, 1.6, 0.055555555555556
82746, 1.1, 1.6, 0.44444444444444
82747, 1.1, 1.6, 0.38888888888889
82748, 1.1, 1.6, 0.33333333333333
82749, 1.1, 1.6, 0.27777777777778
82750, 1.1, 1.6, 0.22222222222222
82751, 1.1, 1.6, 0.16666666666667
82752, 1.1, 1.6, 0.11111111111111
82753, 1.1, 1.6, 0.055555555555556
82754, 1.15, 1.6, 0.44444444444444
82755, 1.15, 1.6, 0.38888888888889
82756, 1.15, 1.6, 0.33333333333333
82757, 1.15, 1.6, 0.27777777777778
82758, 1.15, 1.6, 0.22222222222222
82759, 1.15, 1.6, 0.16666666666667
82760, 1.15, 1.6, 0.11111111111111
82761, 1.15, 1.6, 0.055555555555556
82762, 1.05, 1.65, 0.44444444444444
82763, 1.05, 1.65, 0.38888888888889
82764, 1.05, 1.65, 0.33333333333333
82765, 1.05, 1.65, 0.27777777777778
82766, 1.05, 1.65, 0.22222222222222
82767, 1.05, 1.65, 0.16666666666667
82768, 1.05, 1.65, 0.11111111111111
82769, 1.05, 1.65, 0.055555555555556
82770, 1.1, 1.65, 0.44444444444444
82771, 1.1, 1.65, 0.38888888888889
82772, 1.1, 1.65, 0.33333333333333
82773, 1.1, 1.65, 0.27777777777778
82774, 1.1, 1.65, 0.22222222222222
82775, 1.1, 1.65, 0.16666666666667
82776, 1.1, 1.65, 0.11111111111111
82777, 1.1, 1.65, 0.055555555555556
82778, 1.15, 1.65, 0.44444444444444
82779, 1.15, 1.65, 0.38888888888889
82780, 1.15, 1.65, 0.33333333333333
82781, 1.15, 1.65, 0.27777777777778
82782, 1.15, 1.65, 0.22222222222222
82783, 1.15, 1.65, 0.16666666666667
82784, 1.15, 1.65, 0.11111111111111
82785, 1.15, 1.65, 0.055555555555556
82786, 1.05, 1.7, 0.44444444444444
82787, 1.05, 1.7, 0.38888888888889
82788, 1.05, 1.7, 0.33333333333333
82789, 1.05, 1.7, 0.27777777777778
82790, 1.05, 1.7, 0.22222222222222
82791, 1.05, 1.7, 0.16666666666667
82792, 1.05, 1.7, 0.11111111111111
82793, 1.05, 1.7, 0.055555555555556
82794, 1.1, 1.7, 0.44444444444444
82795, 1.1, 1.7, 0.38888888888889
82796, 1.1, 1.7, 0.33333333333333
82797, 1.1, 1.7, 0.27777777777778
82798, 1.1, 1.7, 0.22222222222222
82799, 1.1, 1.7, 0.16666666666667
82800, 1.1, 1.7, 0.11111111111111
82801, 1.1, 1.7, 0.055555555555556
82802, 1.15, 1.7, 0.44444444444444
82803, 1.15, 1.7, 0.38888888888889
82804, 1.15, 1.7, 0.33333333333333
82805, 1.15, 1.7, 0.27777777777778
82806, 1.15, 1.7, 0.22222222222222
82807, 1.15, 1.7, 0.16666666666667
82808, 1.15, 1.7, 0.11111111111111
82809, 1.15, 1.7, 0.055555555555556
82810, 1.05, 1.6, 0.47222222222222
82811, 1.025, 1.6, 0.44444444444444
82812, 1.05, 1.575, 0.44444444444444
82813, 1.05, 1.6, 0.41666666666667
82814, 1.025, 1.6, 0.38888888888889
82815, 1.05, 1.575, 0.38888888888889
82816, 1.05, 1.6, 0.36111111111111
82817, 1.025, 1.6, 0.33333333333333
82818, 1.05, 1.575, 0.33333333333333
82819, 1.05, 1.6, 0.30555555555556
82820, 1.025, 1.6, 0.27777777777778
82821, 1.05, 1.575, 0.27777777777778
82822, 1.05, 1.6, 0.25
82823, 1.025, 1.6, 0.22222222222222
82824, 1.05, 1.575, 0.22222222222222
82825, 1.05, 1.6, 0.19444444444444
82826, 1.025, 1.6, 0.16666666666667
82827, 1.05, 1.575, 0.16666666666667
82828, 1.05, 1.6, 0.13888888888889
82829, 1.025, 1.6, 0.11111111111111
82830, 1.05, 1.575, 0.11111111111111
82831, 1.05, 1.6, 0.083333333333333
82832, 1.025, 1.6, 0.055555555555556
82833, 1.05, 1.575, 0.055555555555556
82834, 1.05, 1.6, 0.027777777777778
82835, 1.1, 1.6, 0.47222222222222
82836, 1.075, 1.6, 0.44444444444444
82837, 1.1, 1.575, 0.44444444444444
82838, 1.1, 1.6, 0.41666666666667
82839, 1.075, 1.6, 0.38888888888889
82840, 1.1, 1.575, 0.38888888888889
82841, 1.1, 1.6, 0.36111111111111
82842, 1.075, 1.6, 0.33333333333333
82843, 1.1, 1.575, 0.33333333333333
82844, 1.1, 1.6, 0.30555555555556
82845, 1.075, 1.6, 0.27777777777778
82846, 1.1, 1.575, 0.27777777777778
82847, 1.1, 1.6, 0.25
82848, 1.075, 1.6, 0.22222222222222
82849, 1.1, 1.575, 0.22222222222222
82850, 1.1, 1.6, 0.19444444444444
82851, 1.075, 1.6, 0.16666666666667
82852, 1.1, 1.575, 0.16666666666667
82853, 1.1, 1.6, 0.13888888888889
82854, 1.075, 1.6, 0.11111111111111
82855, 1.1, 1.575, 0.11111111111111
82856, 1.1, 1.6, 0.083333333333333
82857, 1.075, 1.6, 0.055555555555556
82858, 1.1, 1.575, 0.055555555555556
82859, 1.1, 1.6, 0.027777777777778
82860, 1.15, 1.6, 0.47222222222222
82861, 1.125, 1.6, 0.44444444444444
82862, 1.15, 1.575, 0.44444444444444
82863, 1.15, 1.6, 0.41666666666667
82864, 1.125, 1.6, 0.38888888888889
82865, 1.15, 1.575, 0.38888888888889
82866, 1.15, 1.6, 0.36111111111111
82867, 1.125, 1.6, 0.33333333333333
82868, 1.15, 1.575, 0.33333333333333
82869, 1.15, 1.6, 0.30555555555556
82870, 1.125, 1.6, 0.27777777777778
82871, 1.15, 1.575, 0.27777777777778
82872, 1.15, 1.6, 0.25
82873, 1.125, 1.6, 0.22222222222222
82874, 1.15, 1.575, 0.22222222222222
82875, 1.15, 1.6, 0.19444444444444
82876, 1.125, 1.6, 0.16666666666667
82877, 1.15, 1.575, 0.16666666666667
82878, 1.15, 1.6, 0.13888888888889
82879, 1.125, 1.6, 0.11111111111111
82880, 1.15, 1.575, 0.11111111111111
82881, 1.15, 1.6, 0.083333333333333
82882, 1.125, 1.6, 0.055555555555556
82883, 1.15, 1.575, 0.055555555555556
82884, 1.15, 1.6, 0.027777777777778
82885, 1.175, 1.6, 0.44444444444444
82886, 1.175, 1.6, 0.38888888888889
82887, 1.175, 1.6, 0.33333333333333
82888, 1.175, 1.6, 0.27777777777778
82889, 1.175, 1.6, 0.22222222222222
82890, 1.175, 1.6, 0.16666666666667
82891, 1.175, 1.6, 0.11111111111111
82892, 1.175, 1.6, 0.055555555555556
82893, 1.05, 1.65, 0.47222222222222
82894, 1.025, 1.65, 0.44444444444444
82895, 1.05, 1.625, 0.44444444444444
82896, 1.05, 1.65, 0.41666666666667
82897, 1.025, 1.65, 0.38888888888889
82898, 1.05, 1.625, 0.38888888888889
82899, 1.05, 1.65, 0.36111111111111
82900, 1.025, 1.65, 0.33333333333333
82901, 1.05, 1.625, 0.33333333333333
82902, 1.05, 1.65, 0.30555555555556
82903, 1.025, 1.65, 0.27777777777778
82904, 1.05, 1.625, 0.27777777777778
82905, 1.05, 1.65, 0.25
82906, 1.025, 1.65, 0.22222222222222
82907, 1.05, 1.625, 0.22222222222222
82908, 1.05, 1.65, 0.19444444444444
82909, 1.025, 1.65, 0.16666666666667
82910, 1.05, 1.625, 0.16666666666667
82911, 1.05, 1.65, 0.13888888888889
82912, 1.025, 1.65, 0.11111111111111
82913, 1.05, 1.625, 0.11111111111111
82914, 1.05, 1.65, 0.083333333333333
82915, 1.025, 1.65, 0.055555555555556
82916, 1.05, 1.625, 0.055555555555556
82917, 1.05, 1.65, 0.027777777777778
82918, 1.1, 1.65, 0.47222222222222
82919, 1.075, 1.65, 0.44444444444444
82920, 1.1, 1.625, 0.44444444444444
82921, 1.1, 1.65, 0.41666666666667
82922, 1.075, 1.65, 0.38888888888889
82923, 1.1, 1.625, 0.38888888888889
82924, 1.1, 1.65, 0.36111111111111
82925, 1.075, 1.65, 0.33333333333333
82926, 1.1, 1.625, 0.33333333333333
82927, 1.1, 1.65, 0.30555555555556
82928, 1.075, 1.65, 0.27777777777778
82929, 1.1, 1.625, 0.27777777777778
82930, 1.1, 1.65, 0.25
82931, 1.075, 1.65, 0.22222222222222
82932, 1.1, 1.625, 0.22222222222222
82933, 1.1, 1.65, 0.19444444444444
82934, 1.075, 1.65, 0.16666666666667
82935, 1.1, 1.625, 0.16666666666667
82936, 1.1, 1.65, 0.13888888888889
82937, 1.075, 1.65, 0.11111111111111
82938, 1.1, 1.625, 0.11111111111111
82939, 1.1, 1.65, 0.083333333333333
82940, 1.075, 1.65, 0.055555555555556
82941, 1.1, 1.625, 0.055555555555556
82942, 1.1, 1.65, 0.027777777777778
82943, 1.15, 1.65, 0.47222222222222
82944, 1.125, 1.65, 0.44444444444444
82945, 1.15, 1.625, 0.44444444444444
82946, 1.15, 1.65, 0.41666666666667
82947, 1.125, 1.65, 0.38888888888889
82948, 1.15, 1.625, 0.38888888888889
82949, 1.15, 1.65, 0.36111111111111
82950, 1.125, 1.65, 0.33333333333333
82951, 1.15, 1.625, 0.33333333333333
82952, 1.15, 1.65, 0.30555555555556
82953, 1.125, 1.65, 0.27777777777778
82954, 1.15, 1.625, 0.27777777777778
82955, 1.15, 1.65, 0.25
82956, 1.125, 1.65, 0.22222222222222
82957, 1.15, 1.625, 0.22222222222222
82958, 1.15, 1.65, 0.19444444444444
82959, 1.125, 1.65, 0.16666666666667
82960, 1.15, 1.625, 0.16666666666667
82961, 1.15, 1.65, 0.13888888888889
82962, 1.125, 1.65, 0.11111111111111
82963, 1.15, 1.625, 0.11111111111111
82964, 1.15, 1.65, 0.083333333333333
82965, 1.125, 1.65, 0.055555555555556
82966, 1.15, 1.625, 0.055555555555556
82967, 1.15, 1.65, 0.027777777777778
82968, 1.175, 1.65, 0.44444444444444
82969, 1.175, 1.65, 0.38888888888889
82970, 1.175, 1.65, 0.33333333333333
82971, 1.175, 1.65, 0.27777777777778
82972, 1.175, 1.65, 0.22222222222222
82973, 1.175, 1.65, 0.16666666666667
82974, 1.175, 1.65, 0.11111111111111
82975, 1.175, 1.65, 0.055555555555556
82976, 1.05, 1.7, 0.47222222222222
82977, 1.025, 1.7, 0.44444444444444
82978, 1.05, 1.675, 0.44444444444444
82979, 1.05, 1.7, 0.41666666666667
82980, 1.025, 1.7, 0.38888888888889
82981, 1.05, 1.675, 0.38888888888889
82982, 1.05, 1.7, 0.36111111111111
82983, 1.025, 1.7, 0.33333333333333
82984, 1.05, 1.675, 0.33333333333333
82985, 1.05, 1.7, 0.30555555555556
82986, 1.025, 1.7, 0.27777777777778
82987, 1.05, 1.675, 0.27777777777778
82988, 1.05, 1.7, 0.25
82989, 1.025, 1.7, 0.22222222222222
82990, 1.05, 1.675, 0.22222222222222
82991, 1.05, 1.7, 0.19444444444444
82992, 1.025, 1.7, 0.16666666666667
82993, 1.05, 1.675, 0.16666666666667
82994, 1.05, 1.7, 0.13888888888889
82995, 1.025, 1.7, 0.11111111111111
82996, 1.05, 1.675, 0.11111111111111
82997, 1.05, 1.7, 0.083333333333333
82998, 1.025, 1.7, 0.055555555555556
82999, 1.05, 1.675, 0.055555555555556
83000, 1.05, 1.7, 0.027777777777778
83001, 1.1, 1.7, 0.47222222222222
83002, 1.075, 1.7, 0.44444444444444
83003, 1.1, 1.675, 0.44444444444444
83004, 1.1, 1.7, 0.41666666666667
83005, 1.075, 1.7, 0.38888888888889
83006, 1.1, 1.675, 0.38888888888889
83007, 1.1, 1.7, 0.36111111111111
83008, 1.075, 1.7, 0.33333333333333
83009, 1.1, 1.675, 0.33333333333333
83010, 1.1, 1.7, 0.30555555555556
83011, 1.075, 1.7, 0.27777777777778
83012, 1.1, 1.675, 0.27777777777778
83013, 1.1, 1.7, 0.25
83014, 1.075, 1.7, 0.22222222222222
83015, 1.1, 1.675, 0.22222222222222
83016, 1.1, 1.7, 0.19444444444444
83017, 1.075, 1.7, 0.16666666666667
83018, 1.1, 1.675, 0.16666666666667
83019, 1.1, 1.7, 0.13888888888889
83020, 1.075, 1.7, 0.11111111111111
83021, 1.1, 1.675, 0.11111111111111
83022, 1.1, 1.7, 0.083333333333333
83023, 1.075, 1.7, 0.055555555555556
83024, 1.1, 1.675, 0.055555555555556
83025, 1.1, 1.7, 0.027777777777778
83026, 1.15, 1.7, 0.47222222222222
83027, 1.125, 1.7, 0.44444444444444
83028, 1.15, 1.675, 0.44444444444444
83029, 1.15, 1.7, 0.41666666666667
83030, 1.125, 1.7, 0.38888888888889
83031, 1.15, 1.675, 0.38888888888889
83032, 1.15, 1.7, 0.36111111111111
83033, 1.125, 1.7, 0.33333333333333
83034, 1.15, 1.675, 0.33333333333333
83035, 1.15, 1.7, 0.30555555555556
83036, 1.125, 1.7, 0.27777777777778
83037, 1.15, 1.675, 0.27777777777778
83038, 1.15, 1.7, 0.25
83039, 1.125, 1.7, 0.22222222222222
83040, 1.15, 1.675, 0.22222222222222
83041, 1.15, 1.7, 0.19444444444444
83042, 1.125, 1.7, 0.16666666666667
83043, 1.15, 1.675, 0.16666666666667
83044, 1.15, 1.7, 0.13888888888889
83045, 1.125, 1.7, 0.11111111111111
83046, 1.15, 1.675, 0.11111111111111
83047, 1.15, 1.7, 0.083333333333333
83048, 1.125, 1.7, 0.055555555555556
83049, 1.15, 1.675, 0.055555555555556
83050, 1.15, 1.7, 0.027777777777778
83051, 1.175, 1.7, 0.44444444444444
83052, 1.175, 1.7, 0.38888888888889
83053, 1.175, 1.7, 0.33333333333333
83054, 1.175, 1.7, 0.27777777777778
83055, 1.175, 1.7, 0.22222222222222
83056, 1.175, 1.7, 0.16666666666667
83057, 1.175, 1.7, 0.11111111111111
83058, 1.175, 1.7, 0.055555555555556
83059, 1.05, 1.725, 0.44444444444444
83060, 1.05, 1.725, 0.38888888888889
83061, 1.05, 1.725, 0.33333333333333
83062, 1.05, 1.725, 0.27777777777778
83063, 1.05, 1.725, 0.22222222222222
83064, 1.05, 1.725, 0.16666666666667
83065, 1.05, 1.725, 0.11111111111111
83066, 1.05, 1.725, 0.055555555555556
83067, 1.1, 1.725, 0.44444444444444
83068, 1.1, 1.725, 0.38888888888889
83069, 1.1, 1.725, 0.33333333333333
83070, 1.1, 1.725, 0.27777777777778
83071, 1.1, 1.725, 0.22222222222222
83072, 1.1, 1.725, 0.16666666666667
83073, 1.1, 1.725, 0.11111111111111
83074, 1.1, 1.725, 0.055555555555556
83075, 1.15, 1.725, 0.44444444444444
83076, 1.15, 1.725, 0.38888888888889
83077, 1.15, 1.725, 0.33333333333333
83078, 1.15, 1.725, 0.27777777777778
83079, 1.15, 1.725, 0.22222222222222
83080, 1.15, 1.725, 0.16666666666667
83081, 1.15, 1.725, 0.11111111111111
83082, 1.15, 1.725, 0.055555555555556
83083, 1.2434782608696, 1.6, 0.44444444444444
83084, 1.2434782608696, 1.6, 0.38888888888889
83085, 1.2434782608696, 1.6, 0.33333333333333
83086, 1.2434782608696, 1.6, 0.27777777777778
83087, 1.2434782608696, 1.6, 0.22222222222222
83088, 1.2434782608696, 1.6, 0.16666666666667
83089, 1.2434782608696, 1.6, 0.11111111111111
83090, 1.2434782608696, 1.6, 0.055555555555556
83091, 1.2869565217391, 1.6, 0.44444444444444
83092, 1.2869565217391, 1.6, 0.38888888888889
83093, 1.2869565217391, 1.6, 0.33333333333333
83094, 1.2869565217391, 1.6, 0.27777777777778
83095, 1.2869565217391, 1.6, 0.22222222222222
83096, 1.2869565217391, 1.6, 0.16666666666667
83097, 1.2869565217391, 1.6, 0.11111111111111
83098, 1.2869565217391, 1.6, 0.055555555555556
83099, 1.3304347826087, 1.6, 0.44444444444444
83100, 1.3304347826087, 1.6, 0.38888888888889
83101, 1.3304347826087, 1.6, 0.33333333333333
83102, 1.3304347826087, 1.6, 0.27777777777778
83103, 1.3304347826087, 1.6, 0.22222222222222
83104, 1.3304347826087, 1.6, 0.16666666666667
83105, 1.3304347826087, 1.6, 0.11111111111111
83106, 1.3304347826087, 1.6, 0.055555555555556
83107, 1.3739130434783, 1.6, 0.44444444444444
83108, 1.3739130434783, 1.6, 0.38888888888889
83109, 1.3739130434783, 1.6, 0.33333333333333
83110, 1.3739130434783, 1.6, 0.27777777777778
83111, 1.3739130434783, 1.6, 0.22222222222222
83112, 1.3739130434783, 1.6, 0.16666666666667
83113, 1.3739130434783, 1.6, 0.11111111111111
83114, 1.3739130434783, 1.6, 0.055555555555556
83115, 1.4173913043478, 1.6, 0.44444444444444
83116, 1.4173913043478, 1.6, 0.38888888888889
83117, 1.4173913043478, 1.6, 0.33333333333333
83118, 1.4173913043478, 1.6, 0.27777777777778
83119, 1.4173913043478, 1.6, 0.22222222222222
83120, 1.4173913043478, 1.6, 0.16666666666667
83121, 1.4173913043478, 1.6, 0.11111111111111
83122, 1.4173913043478, 1.6, 0.055555555555556
83123, 1.4608695652174, 1.6, 0.44444444444444
83124, 1.4608695652174, 1.6, 0.38888888888889
83125, 1.4608695652174, 1.6, 0.33333333333333
83126, 1.4608695652174, 1.6, 0.27777777777778
83127, 1.4608695652174, 1.6, 0.22222222222222
83128, 1.4608695652174, 1.6, 0.16666666666667
83129, 1.4608695652174, 1.6, 0.11111111111111
83130, 1.4608695652174, 1.6, 0.055555555555556
83131, 1.504347826087, 1.6, 0.44444444444444
83132, 1.504347826087, 1.6, 0.38888888888889
83133, 1.504347826087, 1.6, 0.33333333333333
83134, 1.504347826087, 1.6, 0.27777777777778
83135, 1.504347826087, 1.6, 0.22222222222222
83136, 1.504347826087, 1.6, 0.16666666666667
83137, 1.504347826087, 1.6, 0.11111111111111
83138, 1.504347826087, 1.6, 0.055555555555556
83139, 1.5478260869565, 1.6, 0.44444444444444
83140, 1.5478260869565, 1.6, 0.38888888888889
83141, 1.5478260869565, 1.6, 0.33333333333333
83142, 1.5478260869565, 1.6, 0.27777777777778
83143, 1.5478260869565, 1.6, 0.22222222222222
83144, 1.5478260869565, 1.6, 0.16666666666667
83145, 1.5478260869565, 1.6, 0.11111111111111
83146, 1.5478260869565, 1.6, 0.055555555555556
83147, 1.5913043478261, 1.6, 0.44444444444444
83148, 1.5913043478261, 1.6, 0.38888888888889
83149, 1.5913043478261, 1.6, 0.33333333333333
83150, 1.5913043478261, 1.6, 0.27777777777778
83151, 1.5913043478261, 1.6, 0.22222222222222
83152, 1.5913043478261, 1.6, 0.16666666666667
83153, 1.5913043478261, 1.6, 0.11111111111111
83154, 1.5913043478261, 1.6, 0.055555555555556
83155, 1.6347826086957, 1.6, 0.44444444444444
83156, 1.6347826086957, 1.6, 0.38888888888889
83157, 1.6347826086957, 1.6, 0.33333333333333
83158, 1.6347826086957, 1.6, 0.27777777777778
83159, 1.6347826086957, 1.6, 0.22222222222222
83160, 1.6347826086957, 1.6, 0.16666666666667
83161, 1.6347826086957, 1.6, 0.11111111111111
83162, 1.6347826086957, 1.6, 0.055555555555556
83163, 1.6782608695652, 1.6, 0.44444444444444
83164, 1.6782608695652, 1.6, 0.38888888888889
83165, 1.6782608695652, 1.6, 0.33333333333333
83166, 1.6782608695652, 1.6, 0.27777777777778
83167, 1.6782608695652, 1.6, 0.22222222222222
83168, 1.6782608695652, 1.6, 0.16666666666667
83169, 1.6782608695652, 1.6, 0.11111111111111
83170, 1.6782608695652, 1.6, 0.055555555555556
83171, 1.7217391304348, 1.6, 0.44444444444444
83172, 1.7217391304348, 1.6, 0.38888888888889
83173, 1.7217391304348, 1.6, 0.33333333333333
83174, 1.7217391304348, 1.6, 0.27777777777778
83175, 1.7217391304348, 1.6, 0.22222222222222
83176, 1.7217391304348, 1.6, 0.16666666666667
83177, 1.7217391304348, 1.6, 0.11111111111111
83178, 1.7217391304348, 1.6, 0.055555555555556
83179, 1.7652173913043, 1.6, 0.44444444444444
83180, 1.7652173913043, 1.6, 0.38888888888889
83181, 1.7652173913043, 1.6, 0.33333333333333
83182, 1.7652173913043, 1.6, 0.27777777777778
83183, 1.7652173913043, 1.6, 0.22222222222222
83184, 1.7652173913043, 1.6, 0.16666666666667
83185, 1.7652173913043, 1.6, 0.11111111111111
83186, 1.7652173913043, 1.6, 0.055555555555556
83187, 1.8086956521739, 1.6, 0.44444444444444
83188, 1.8086956521739, 1.6, 0.38888888888889
83189, 1.8086956521739, 1.6, 0.33333333333333
83190, 1.8086956521739, 1.6, 0.27777777777778
83191, 1.8086956521739, 1.6, 0.22222222222222
83192, 1.8086956521739, 1.6, 0.16666666666667
83193, 1.8086956521739, 1.6, 0.11111111111111
83194, 1.8086956521739, 1.6, 0.055555555555556
83195, 1.8521739130435, 1.6, 0.44444444444444
83196, 1.8521739130435, 1.6, 0.38888888888889
83197, 1.8521739130435, 1.6, 0.33333333333333
83198, 1.8521739130435, 1.6, 0.27777777777778
83199, 1.8521739130435, 1.6, 0.22222222222222
83200, 1.8521739130435, 1.6, 0.16666666666667
83201, 1.8521739130435, 1.6, 0.11111111111111
83202, 1.8521739130435, 1.6, 0.055555555555556
83203, 1.895652173913, 1.6, 0.44444444444444
83204, 1.895652173913, 1.6, 0.38888888888889
83205, 1.895652173913, 1.6, 0.33333333333333
83206, 1.895652173913, 1.6, 0.27777777777778
83207, 1.895652173913, 1.6, 0.22222222222222
83208, 1.895652173913, 1.6, 0.16666666666667
83209, 1.895652173913, 1.6, 0.11111111111111
83210, 1.895652173913, 1.6, 0.055555555555556
83211, 1.9391304347826, 1.6, 0.44444444444444
83212, 1.9391304347826, 1.6, 0.38888888888889
83213, 1.9391304347826, 1.6, 0.33333333333333
83214, 1.9391304347826, 1.6, 0.27777777777778
83215, 1.9391304347826, 1.6, 0.22222222222222
83216, 1.9391304347826, 1.6, 0.16666666666667
83217, 1.9391304347826, 1.6, 0.11111111111111
83218, 1.9391304347826, 1.6, 0.055555555555556
83219, 1.9826086956522, 1.6, 0.44444444444444
83220, 1.9826086956522, 1.6, 0.38888888888889
83221, 1.9826086956522, 1.6, 0.33333333333333
83222, 1.9826086956522, 1.6, 0.27777777777778
83223, 1.9826086956522, 1.6, 0.22222222222222
83224, 1.9826086956522, 1.6, 0.16666666666667
83225, 1.9826086956522, 1.6, 0.11111111111111
83226, 1.9826086956522, 1.6, 0.055555555555556
83227, 2.0260869565217, 1.6, 0.44444444444444
83228, 2.0260869565217, 1.6, 0.38888888888889
83229, 2.0260869565217, 1.6, 0.33333333333333
83230, 2.0260869565217, 1.6, 0.27777777777778
83231, 2.0260869565217, 1.6, 0.22222222222222
83232, 2.0260869565217, 1.6, 0.16666666666667
83233, 2.0260869565217, 1.6, 0.11111111111111
83234, 2.0260869565217, 1.6, 0.055555555555556
83235, 2.0695652173913, 1.6, 0.44444444444444
83236, 2.0695652173913, 1.6, 0.38888888888889
83237, 2.0695652173913, 1.6, 0.33333333333333
83238, 2.0695652173913, 1.6, 0.27777777777778
83239, 2.0695652173913, 1.6, 0.22222222222222
83240, 2.0695652173913, 1.6, 0.16666666666667
83241, 2.0695652173913, 1.6, 0.11111111111111
83242, 2.0695652173913, 1.6, 0.055555555555556
83243, 2.1130434782609, 1.6, 0.44444444444444
83244, 2.1130434782609, 1.6, 0.38888888888889
83245, 2.1130434782609, 1.6, 0.33333333333333
83246, 2.1130434782609, 1.6, 0.27777777777778
83247, 2.1130434782609, 1.6, 0.22222222222222
83248, 2.1130434782609, 1.6, 0.16666666666667
83249, 2.1130434782609, 1.6, 0.11111111111111
83250, 2.1130434782609, 1.6, 0.055555555555556
83251, 2.1565217391304, 1.6, 0.44444444444444
83252, 2.1565217391304, 1.6, 0.38888888888889
83253, 2.1565217391304, 1.6, 0.33333333333333
83254, 2.1565217391304, 1.6, 0.27777777777778
83255, 2.1565217391304, 1.6, 0.22222222222222
83256, 2.1565217391304, 1.6, 0.16666666666667
83257, 2.1565217391304, 1.6, 0.11111111111111
83258, 2.1565217391304, 1.6, 0.055555555555556
83259, 1.2434782608696, 1.65, 0.44444444444444
83260, 1.2434782608696, 1.65, 0.38888888888889
83261, 1.2434782608696, 1.65, 0.33333333333333
83262, 1.2434782608696, 1.65, 0.27777777777778
83263, 1.2434782608696, 1.65, 0.22222222222222
83264, 1.2434782608696, 1.65, 0.16666666666667
83265, 1.2434782608696, 1.65, 0.11111111111111
83266, 1.2434782608696, 1.65, 0.055555555555556
83267, 1.2869565217391, 1.65, 0.44444444444444
83268, 1.2869565217391, 1.65, 0.38888888888889
83269, 1.2869565217391, 1.65, 0.33333333333333
83270, 1.2869565217391, 1.65, 0.27777777777778
83271, 1.2869565217391, 1.65, 0.22222222222222
83272, 1.2869565217391, 1.65, 0.16666666666667
83273, 1.2869565217391, 1.65, 0.11111111111111
83274, 1.2869565217391, 1.65, 0.055555555555556
83275, 1.3304347826087, 1.65, 0.44444444444444
83276, 1.3304347826087, 1.65, 0.38888888888889
83277, 1.3304347826087, 1.65, 0.33333333333333
83278, 1.3304347826087, 1.65, 0.27777777777778
83279, 1.3304347826087, 1.65, 0.22222222222222
83280, 1.3304347826087, 1.65, 0.16666666666667
83281, 1.3304347826087, 1.65, 0.11111111111111
83282, 1.3304347826087, 1.65, 0.055555555555556
83283, 1.3739130434783, 1.65, 0.44444444444444
83284, 1.3739130434783, 1.65, 0.38888888888889
83285, 1.3739130434783, 1.65, 0.33333333333333
83286, 1.3739130434783, 1.65, 0.27777777777778
83287, 1.3739130434783, 1.65, 0.22222222222222
83288, 1.3739130434783, 1.65, 0.16666666666667
83289, 1.3739130434783, 1.65, 0.11111111111111
83290, 1.3739130434783, 1.65, 0.055555555555556
83291, 1.4173913043478, 1.65, 0.44444444444444
83292, 1.4173913043478, 1.65, 0.38888888888889
83293, 1.4173913043478, 1.65, 0.33333333333333
83294, 1.4173913043478, 1.65, 0.27777777777778
83295, 1.4173913043478, 1.65, 0.22222222222222
83296, 1.4173913043478, 1.65, 0.16666666666667
83297, 1.4173913043478, 1.65, 0.11111111111111
83298, 1.4173913043478, 1.65, 0.055555555555556
83299, 1.4608695652174, 1.65, 0.44444444444444
83300, 1.4608695652174, 1.65, 0.38888888888889
83301, 1.4608695652174, 1.65, 0.33333333333333
83302, 1.4608695652174, 1.65, 0.27777777777778
83303, 1.4608695652174, 1.65, 0.22222222222222
83304, 1.4608695652174, 1.65, 0.16666666666667
83305, 1.4608695652174, 1.65, 0.11111111111111
83306, 1.4608695652174, 1.65, 0.055555555555556
83307, 1.504347826087, 1.65, 0.44444444444444
83308, 1.504347826087, 1.65, 0.38888888888889
83309, 1.504347826087, 1.65, 0.33333333333333
83310, 1.504347826087, 1.65, 0.27777777777778
83311, 1.504347826087, 1.65, 0.22222222222222
83312, 1.504347826087, 1.65, 0.16666666666667
83313, 1.504347826087, 1.65, 0.11111111111111
83314, 1.504347826087, 1.65, 0.055555555555556
83315, 1.5478260869565, 1.65, 0.44444444444444
83316, 1.5478260869565, 1.65, 0.38888888888889
83317, 1.5478260869565, 1.65, 0.33333333333333
83318, 1.5478260869565, 1.65, 0.27777777777778
83319, 1.5478260869565, 1.65, 0.22222222222222
83320, 1.5478260869565, 1.65, 0.16666666666667
83321, 1.5478260869565, 1.65, 0.11111111111111
83322, 1.5478260869565, 1.65, 0.055555555555556
83323, 1.5913043478261, 1.65, 0.44444444444444
83324, 1.5913043478261, 1.65, 0.38888888888889
83325, 1.5913043478261, 1.65, 0.33333333333333
83326, 1.5913043478261, 1.65, 0.27777777777778
83327, 1.5913043478261, 1.65, 0.22222222222222
83328, 1.5913043478261, 1.65, 0.16666666666667
83329, 1.5913043478261, 1.65, 0.11111111111111
83330, 1.5913043478261, 1.65, 0.055555555555556
83331, 1.6347826086957, 1.65, 0.44444444444444
83332, 1.6347826086957, 1.65, 0.38888888888889
83333, 1.6347826086957, 1.65, 0.33333333333333
83334, 1.6347826086957, 1.65, 0.27777777777778
83335, 1.6347826086957, 1.65, 0.22222222222222
83336, 1.6347826086957, 1.65, 0.16666666666667
83337, 1.6347826086957, 1.65, 0.11111111111111
83338, 1.6347826086957, 1.65, 0.055555555555556
83339, 1.6782608695652, 1.65, 0.44444444444444
83340, 1.6782608695652, 1.65, 0.38888888888889
83341, 1.6782608695652, 1.65, 0.33333333333333
83342, 1.6782608695652, 1.65, 0.27777777777778
83343, 1.6782608695652, 1.65, 0.22222222222222
83344, 1.6782608695652, 1.65, 0.16666666666667
83345, 1.6782608695652, 1.65, 0.11111111111111
83346, 1.6782608695652, 1.65, 0.055555555555556
83347, 1.7217391304348, 1.65, 0.44444444444444
83348, 1.7217391304348, 1.65, 0.38888888888889
83349, 1.7217391304348, 1.65, 0.33333333333333
83350, 1.7217391304348, 1.65, 0.27777777777778
83351, 1.7217391304348, 1.65, 0.22222222222222
83352, 1.7217391304348, 1.65, 0.16666666666667
83353, 1.7217391304348, 1.65, 0.11111111111111
83354, 1.7217391304348, 1.65, 0.055555555555556
83355, 1.7652173913043, 1.65, 0.44444444444444
83356, 1.7652173913043, 1.65, 0.38888888888889
83357, 1.7652173913043, 1.65, 0.33333333333333
83358, 1.7652173913043, 1.65, 0.27777777777778
83359, 1.7652173913043, 1.65, 0.22222222222222
83360, 1.7652173913043, 1.65, 0.16666666666667
83361, 1.7652173913043, 1.65, 0.11111111111111
83362, 1.7652173913043, 1.65, 0.055555555555556
83363, 1.8086956521739, 1.65, 0.44444444444444
83364, 1.8086956521739, 1.65, 0.38888888888889
83365, 1.8086956521739, 1.65, 0.33333333333333
83366, 1.8086956521739, 1.65, 0.27777777777778
83367, 1.8086956521739, 1.65, 0.22222222222222
83368, 1.8086956521739, 1.65, 0.16666666666667
83369, 1.8086956521739, 1.65, 0.11111111111111
83370, 1.8086956521739, 1.65, 0.055555555555556
83371, 1.8521739130435, 1.65, 0.44444444444444
83372, 1.8521739130435, 1.65, 0.38888888888889
83373, 1.8521739130435, 1.65, 0.33333333333333
83374, 1.8521739130435, 1.65, 0.27777777777778
83375, 1.8521739130435, 1.65, 0.22222222222222
83376, 1.8521739130435, 1.65, 0.16666666666667
83377, 1.8521739130435, 1.65, 0.11111111111111
83378, 1.8521739130435, 1.65, 0.055555555555556
83379, 1.895652173913, 1.65, 0.44444444444444
83380, 1.895652173913, 1.65, 0.38888888888889
83381, 1.895652173913, 1.65, 0.33333333333333
83382, 1.895652173913, 1.65, 0.27777777777778
83383, 1.895652173913, 1.65, 0.22222222222222
83384, 1.895652173913, 1.65, 0.16666666666667
83385, 1.895652173913, 1.65, 0.11111111111111
