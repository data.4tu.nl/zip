89729, 1.4173913043478, -0.2, 0.19444444444444
89730, 1.395652173913, -0.2, 0.16666666666667
89731, 1.4173913043478, -0.175, 0.16666666666667
89732, 1.4173913043478, -0.2, 0.13888888888889
89733, 1.395652173913, -0.2, 0.11111111111111
89734, 1.4173913043478, -0.175, 0.11111111111111
89735, 1.4173913043478, -0.2, 0.083333333333333
89736, 1.395652173913, -0.2, 0.055555555555556
89737, 1.4173913043478, -0.175, 0.055555555555556
89738, 1.4173913043478, -0.2, 0.027777777777778
89739, 1.4608695652174, -0.2, 0.47222222222222
89740, 1.4391304347826, -0.2, 0.44444444444444
89741, 1.4608695652174, -0.175, 0.44444444444444
89742, 1.4608695652174, -0.2, 0.41666666666667
89743, 1.4391304347826, -0.2, 0.38888888888889
89744, 1.4608695652174, -0.175, 0.38888888888889
89745, 1.4608695652174, -0.2, 0.36111111111111
89746, 1.4391304347826, -0.2, 0.33333333333333
89747, 1.4608695652174, -0.175, 0.33333333333333
89748, 1.4608695652174, -0.2, 0.30555555555556
89749, 1.4391304347826, -0.2, 0.27777777777778
89750, 1.4608695652174, -0.175, 0.27777777777778
89751, 1.4608695652174, -0.2, 0.25
89752, 1.4391304347826, -0.2, 0.22222222222222
89753, 1.4608695652174, -0.175, 0.22222222222222
89754, 1.4608695652174, -0.2, 0.19444444444444
89755, 1.4391304347826, -0.2, 0.16666666666667
89756, 1.4608695652174, -0.175, 0.16666666666667
89757, 1.4608695652174, -0.2, 0.13888888888889
89758, 1.4391304347826, -0.2, 0.11111111111111
89759, 1.4608695652174, -0.175, 0.11111111111111
89760, 1.4608695652174, -0.2, 0.083333333333333
89761, 1.4391304347826, -0.2, 0.055555555555556
89762, 1.4608695652174, -0.175, 0.055555555555556
89763, 1.4608695652174, -0.2, 0.027777777777778
89764, 1.504347826087, -0.2, 0.47222222222222
89765, 1.4826086956522, -0.2, 0.44444444444444
89766, 1.504347826087, -0.175, 0.44444444444444
89767, 1.504347826087, -0.2, 0.41666666666667
89768, 1.4826086956522, -0.2, 0.38888888888889
89769, 1.504347826087, -0.175, 0.38888888888889
89770, 1.504347826087, -0.2, 0.36111111111111
89771, 1.4826086956522, -0.2, 0.33333333333333
89772, 1.504347826087, -0.175, 0.33333333333333
89773, 1.504347826087, -0.2, 0.30555555555556
89774, 1.4826086956522, -0.2, 0.27777777777778
89775, 1.504347826087, -0.175, 0.27777777777778
89776, 1.504347826087, -0.2, 0.25
89777, 1.4826086956522, -0.2, 0.22222222222222
89778, 1.504347826087, -0.175, 0.22222222222222
89779, 1.504347826087, -0.2, 0.19444444444444
89780, 1.4826086956522, -0.2, 0.16666666666667
89781, 1.504347826087, -0.175, 0.16666666666667
89782, 1.504347826087, -0.2, 0.13888888888889
89783, 1.4826086956522, -0.2, 0.11111111111111
89784, 1.504347826087, -0.175, 0.11111111111111
89785, 1.504347826087, -0.2, 0.083333333333333
89786, 1.4826086956522, -0.2, 0.055555555555556
89787, 1.504347826087, -0.175, 0.055555555555556
89788, 1.504347826087, -0.2, 0.027777777777778
89789, 1.5478260869565, -0.2, 0.47222222222222
89790, 1.5260869565217, -0.2, 0.44444444444444
89791, 1.5478260869565, -0.175, 0.44444444444444
89792, 1.5478260869565, -0.2, 0.41666666666667
89793, 1.5260869565217, -0.2, 0.38888888888889
89794, 1.5478260869565, -0.175, 0.38888888888889
89795, 1.5478260869565, -0.2, 0.36111111111111
89796, 1.5260869565217, -0.2, 0.33333333333333
89797, 1.5478260869565, -0.175, 0.33333333333333
89798, 1.5478260869565, -0.2, 0.30555555555556
89799, 1.5260869565217, -0.2, 0.27777777777778
89800, 1.5478260869565, -0.175, 0.27777777777778
89801, 1.5478260869565, -0.2, 0.25
89802, 1.5260869565217, -0.2, 0.22222222222222
89803, 1.5478260869565, -0.175, 0.22222222222222
89804, 1.5478260869565, -0.2, 0.19444444444444
89805, 1.5260869565217, -0.2, 0.16666666666667
89806, 1.5478260869565, -0.175, 0.16666666666667
89807, 1.5478260869565, -0.2, 0.13888888888889
89808, 1.5260869565217, -0.2, 0.11111111111111
89809, 1.5478260869565, -0.175, 0.11111111111111
89810, 1.5478260869565, -0.2, 0.083333333333333
89811, 1.5260869565217, -0.2, 0.055555555555556
89812, 1.5478260869565, -0.175, 0.055555555555556
89813, 1.5478260869565, -0.2, 0.027777777777778
89814, 1.5913043478261, -0.2, 0.47222222222222
89815, 1.5695652173913, -0.2, 0.44444444444444
89816, 1.5913043478261, -0.175, 0.44444444444444
89817, 1.5913043478261, -0.2, 0.41666666666667
89818, 1.5695652173913, -0.2, 0.38888888888889
89819, 1.5913043478261, -0.175, 0.38888888888889
89820, 1.5913043478261, -0.2, 0.36111111111111
89821, 1.5695652173913, -0.2, 0.33333333333333
89822, 1.5913043478261, -0.175, 0.33333333333333
89823, 1.5913043478261, -0.2, 0.30555555555556
89824, 1.5695652173913, -0.2, 0.27777777777778
89825, 1.5913043478261, -0.175, 0.27777777777778
89826, 1.5913043478261, -0.2, 0.25
89827, 1.5695652173913, -0.2, 0.22222222222222
89828, 1.5913043478261, -0.175, 0.22222222222222
89829, 1.5913043478261, -0.2, 0.19444444444444
89830, 1.5695652173913, -0.2, 0.16666666666667
89831, 1.5913043478261, -0.175, 0.16666666666667
89832, 1.5913043478261, -0.2, 0.13888888888889
89833, 1.5695652173913, -0.2, 0.11111111111111
89834, 1.5913043478261, -0.175, 0.11111111111111
89835, 1.5913043478261, -0.2, 0.083333333333333
89836, 1.5695652173913, -0.2, 0.055555555555556
89837, 1.5913043478261, -0.175, 0.055555555555556
89838, 1.5913043478261, -0.2, 0.027777777777778
89839, 1.6347826086957, -0.2, 0.47222222222222
89840, 1.6130434782609, -0.2, 0.44444444444444
89841, 1.6347826086957, -0.175, 0.44444444444444
89842, 1.6347826086957, -0.2, 0.41666666666667
89843, 1.6130434782609, -0.2, 0.38888888888889
89844, 1.6347826086957, -0.175, 0.38888888888889
89845, 1.6347826086957, -0.2, 0.36111111111111
89846, 1.6130434782609, -0.2, 0.33333333333333
89847, 1.6347826086957, -0.175, 0.33333333333333
89848, 1.6347826086957, -0.2, 0.30555555555556
89849, 1.6130434782609, -0.2, 0.27777777777778
89850, 1.6347826086957, -0.175, 0.27777777777778
89851, 1.6347826086957, -0.2, 0.25
89852, 1.6130434782609, -0.2, 0.22222222222222
89853, 1.6347826086957, -0.175, 0.22222222222222
89854, 1.6347826086957, -0.2, 0.19444444444444
89855, 1.6130434782609, -0.2, 0.16666666666667
89856, 1.6347826086957, -0.175, 0.16666666666667
89857, 1.6347826086957, -0.2, 0.13888888888889
89858, 1.6130434782609, -0.2, 0.11111111111111
89859, 1.6347826086957, -0.175, 0.11111111111111
89860, 1.6347826086957, -0.2, 0.083333333333333
89861, 1.6130434782609, -0.2, 0.055555555555556
89862, 1.6347826086957, -0.175, 0.055555555555556
89863, 1.6347826086957, -0.2, 0.027777777777778
89864, 1.6782608695652, -0.2, 0.47222222222222
89865, 1.6565217391304, -0.2, 0.44444444444444
89866, 1.6782608695652, -0.175, 0.44444444444444
89867, 1.6782608695652, -0.2, 0.41666666666667
89868, 1.6565217391304, -0.2, 0.38888888888889
89869, 1.6782608695652, -0.175, 0.38888888888889
89870, 1.6782608695652, -0.2, 0.36111111111111
89871, 1.6565217391304, -0.2, 0.33333333333333
89872, 1.6782608695652, -0.175, 0.33333333333333
89873, 1.6782608695652, -0.2, 0.30555555555556
89874, 1.6565217391304, -0.2, 0.27777777777778
89875, 1.6782608695652, -0.175, 0.27777777777778
89876, 1.6782608695652, -0.2, 0.25
89877, 1.6565217391304, -0.2, 0.22222222222222
89878, 1.6782608695652, -0.175, 0.22222222222222
89879, 1.6782608695652, -0.2, 0.19444444444444
89880, 1.6565217391304, -0.2, 0.16666666666667
89881, 1.6782608695652, -0.175, 0.16666666666667
89882, 1.6782608695652, -0.2, 0.13888888888889
89883, 1.6565217391304, -0.2, 0.11111111111111
89884, 1.6782608695652, -0.175, 0.11111111111111
89885, 1.6782608695652, -0.2, 0.083333333333333
89886, 1.6565217391304, -0.2, 0.055555555555556
89887, 1.6782608695652, -0.175, 0.055555555555556
89888, 1.6782608695652, -0.2, 0.027777777777778
89889, 1.7217391304348, -0.2, 0.47222222222222
89890, 1.7, -0.2, 0.44444444444444
89891, 1.7217391304348, -0.175, 0.44444444444444
89892, 1.7217391304348, -0.2, 0.41666666666667
89893, 1.7, -0.2, 0.38888888888889
89894, 1.7217391304348, -0.175, 0.38888888888889
89895, 1.7217391304348, -0.2, 0.36111111111111
89896, 1.7, -0.2, 0.33333333333333
89897, 1.7217391304348, -0.175, 0.33333333333333
89898, 1.7217391304348, -0.2, 0.30555555555556
89899, 1.7, -0.2, 0.27777777777778
89900, 1.7217391304348, -0.175, 0.27777777777778
89901, 1.7217391304348, -0.2, 0.25
89902, 1.7, -0.2, 0.22222222222222
89903, 1.7217391304348, -0.175, 0.22222222222222
89904, 1.7217391304348, -0.2, 0.19444444444444
89905, 1.7, -0.2, 0.16666666666667
89906, 1.7217391304348, -0.175, 0.16666666666667
89907, 1.7217391304348, -0.2, 0.13888888888889
89908, 1.7, -0.2, 0.11111111111111
89909, 1.7217391304348, -0.175, 0.11111111111111
89910, 1.7217391304348, -0.2, 0.083333333333333
89911, 1.7, -0.2, 0.055555555555556
89912, 1.7217391304348, -0.175, 0.055555555555556
89913, 1.7217391304348, -0.2, 0.027777777777778
89914, 1.7652173913043, -0.2, 0.47222222222222
89915, 1.7434782608696, -0.2, 0.44444444444444
89916, 1.7652173913043, -0.175, 0.44444444444444
89917, 1.7652173913043, -0.2, 0.41666666666667
89918, 1.7434782608696, -0.2, 0.38888888888889
89919, 1.7652173913043, -0.175, 0.38888888888889
89920, 1.7652173913043, -0.2, 0.36111111111111
89921, 1.7434782608696, -0.2, 0.33333333333333
89922, 1.7652173913043, -0.175, 0.33333333333333
89923, 1.7652173913043, -0.2, 0.30555555555556
89924, 1.7434782608696, -0.2, 0.27777777777778
89925, 1.7652173913043, -0.175, 0.27777777777778
89926, 1.7652173913043, -0.2, 0.25
89927, 1.7434782608696, -0.2, 0.22222222222222
89928, 1.7652173913043, -0.175, 0.22222222222222
89929, 1.7652173913043, -0.2, 0.19444444444444
89930, 1.7434782608696, -0.2, 0.16666666666667
89931, 1.7652173913043, -0.175, 0.16666666666667
89932, 1.7652173913043, -0.2, 0.13888888888889
89933, 1.7434782608696, -0.2, 0.11111111111111
89934, 1.7652173913043, -0.175, 0.11111111111111
89935, 1.7652173913043, -0.2, 0.083333333333333
89936, 1.7434782608696, -0.2, 0.055555555555556
89937, 1.7652173913043, -0.175, 0.055555555555556
89938, 1.7652173913043, -0.2, 0.027777777777778
89939, 1.8086956521739, -0.2, 0.47222222222222
89940, 1.7869565217391, -0.2, 0.44444444444444
89941, 1.8086956521739, -0.175, 0.44444444444444
89942, 1.8086956521739, -0.2, 0.41666666666667
89943, 1.7869565217391, -0.2, 0.38888888888889
89944, 1.8086956521739, -0.175, 0.38888888888889
89945, 1.8086956521739, -0.2, 0.36111111111111
89946, 1.7869565217391, -0.2, 0.33333333333333
89947, 1.8086956521739, -0.175, 0.33333333333333
89948, 1.8086956521739, -0.2, 0.30555555555556
89949, 1.7869565217391, -0.2, 0.27777777777778
89950, 1.8086956521739, -0.175, 0.27777777777778
89951, 1.8086956521739, -0.2, 0.25
89952, 1.7869565217391, -0.2, 0.22222222222222
89953, 1.8086956521739, -0.175, 0.22222222222222
89954, 1.8086956521739, -0.2, 0.19444444444444
89955, 1.7869565217391, -0.2, 0.16666666666667
89956, 1.8086956521739, -0.175, 0.16666666666667
89957, 1.8086956521739, -0.2, 0.13888888888889
89958, 1.7869565217391, -0.2, 0.11111111111111
89959, 1.8086956521739, -0.175, 0.11111111111111
89960, 1.8086956521739, -0.2, 0.083333333333333
89961, 1.7869565217391, -0.2, 0.055555555555556
89962, 1.8086956521739, -0.175, 0.055555555555556
89963, 1.8086956521739, -0.2, 0.027777777777778
89964, 1.8521739130435, -0.2, 0.47222222222222
89965, 1.8304347826087, -0.2, 0.44444444444444
89966, 1.8521739130435, -0.175, 0.44444444444444
89967, 1.8521739130435, -0.2, 0.41666666666667
89968, 1.8304347826087, -0.2, 0.38888888888889
89969, 1.8521739130435, -0.175, 0.38888888888889
89970, 1.8521739130435, -0.2, 0.36111111111111
89971, 1.8304347826087, -0.2, 0.33333333333333
89972, 1.8521739130435, -0.175, 0.33333333333333
89973, 1.8521739130435, -0.2, 0.30555555555556
89974, 1.8304347826087, -0.2, 0.27777777777778
89975, 1.8521739130435, -0.175, 0.27777777777778
89976, 1.8521739130435, -0.2, 0.25
89977, 1.8304347826087, -0.2, 0.22222222222222
89978, 1.8521739130435, -0.175, 0.22222222222222
89979, 1.8521739130435, -0.2, 0.19444444444444
89980, 1.8304347826087, -0.2, 0.16666666666667
89981, 1.8521739130435, -0.175, 0.16666666666667
89982, 1.8521739130435, -0.2, 0.13888888888889
89983, 1.8304347826087, -0.2, 0.11111111111111
89984, 1.8521739130435, -0.175, 0.11111111111111
89985, 1.8521739130435, -0.2, 0.083333333333333
89986, 1.8304347826087, -0.2, 0.055555555555556
89987, 1.8521739130435, -0.175, 0.055555555555556
89988, 1.8521739130435, -0.2, 0.027777777777778
89989, 1.895652173913, -0.2, 0.47222222222222
89990, 1.8739130434783, -0.2, 0.44444444444444
89991, 1.895652173913, -0.175, 0.44444444444444
89992, 1.895652173913, -0.2, 0.41666666666667
89993, 1.8739130434783, -0.2, 0.38888888888889
89994, 1.895652173913, -0.175, 0.38888888888889
89995, 1.895652173913, -0.2, 0.36111111111111
89996, 1.8739130434783, -0.2, 0.33333333333333
89997, 1.895652173913, -0.175, 0.33333333333333
89998, 1.895652173913, -0.2, 0.30555555555556
89999, 1.8739130434783, -0.2, 0.27777777777778
90000, 1.895652173913, -0.175, 0.27777777777778
90001, 1.895652173913, -0.2, 0.25
90002, 1.8739130434783, -0.2, 0.22222222222222
90003, 1.895652173913, -0.175, 0.22222222222222
90004, 1.895652173913, -0.2, 0.19444444444444
90005, 1.8739130434783, -0.2, 0.16666666666667
90006, 1.895652173913, -0.175, 0.16666666666667
90007, 1.895652173913, -0.2, 0.13888888888889
90008, 1.8739130434783, -0.2, 0.11111111111111
90009, 1.895652173913, -0.175, 0.11111111111111
90010, 1.895652173913, -0.2, 0.083333333333333
90011, 1.8739130434783, -0.2, 0.055555555555556
90012, 1.895652173913, -0.175, 0.055555555555556
90013, 1.895652173913, -0.2, 0.027777777777778
90014, 1.9391304347826, -0.2, 0.47222222222222
90015, 1.9173913043478, -0.2, 0.44444444444444
90016, 1.9391304347826, -0.175, 0.44444444444444
90017, 1.9391304347826, -0.2, 0.41666666666667
90018, 1.9173913043478, -0.2, 0.38888888888889
90019, 1.9391304347826, -0.175, 0.38888888888889
90020, 1.9391304347826, -0.2, 0.36111111111111
90021, 1.9173913043478, -0.2, 0.33333333333333
90022, 1.9391304347826, -0.175, 0.33333333333333
90023, 1.9391304347826, -0.2, 0.30555555555556
90024, 1.9173913043478, -0.2, 0.27777777777778
90025, 1.9391304347826, -0.175, 0.27777777777778
90026, 1.9391304347826, -0.2, 0.25
90027, 1.9173913043478, -0.2, 0.22222222222222
90028, 1.9391304347826, -0.175, 0.22222222222222
90029, 1.9391304347826, -0.2, 0.19444444444444
90030, 1.9173913043478, -0.2, 0.16666666666667
90031, 1.9391304347826, -0.175, 0.16666666666667
90032, 1.9391304347826, -0.2, 0.13888888888889
90033, 1.9173913043478, -0.2, 0.11111111111111
90034, 1.9391304347826, -0.175, 0.11111111111111
90035, 1.9391304347826, -0.2, 0.083333333333333
90036, 1.9173913043478, -0.2, 0.055555555555556
90037, 1.9391304347826, -0.175, 0.055555555555556
90038, 1.9391304347826, -0.2, 0.027777777777778
90039, 1.9826086956522, -0.2, 0.47222222222222
90040, 1.9608695652174, -0.2, 0.44444444444444
90041, 1.9826086956522, -0.175, 0.44444444444444
90042, 1.9826086956522, -0.2, 0.41666666666667
90043, 1.9608695652174, -0.2, 0.38888888888889
90044, 1.9826086956522, -0.175, 0.38888888888889
90045, 1.9826086956522, -0.2, 0.36111111111111
90046, 1.9608695652174, -0.2, 0.33333333333333
90047, 1.9826086956522, -0.175, 0.33333333333333
90048, 1.9826086956522, -0.2, 0.30555555555556
90049, 1.9608695652174, -0.2, 0.27777777777778
90050, 1.9826086956522, -0.175, 0.27777777777778
90051, 1.9826086956522, -0.2, 0.25
90052, 1.9608695652174, -0.2, 0.22222222222222
90053, 1.9826086956522, -0.175, 0.22222222222222
90054, 1.9826086956522, -0.2, 0.19444444444444
90055, 1.9608695652174, -0.2, 0.16666666666667
90056, 1.9826086956522, -0.175, 0.16666666666667
90057, 1.9826086956522, -0.2, 0.13888888888889
90058, 1.9608695652174, -0.2, 0.11111111111111
90059, 1.9826086956522, -0.175, 0.11111111111111
90060, 1.9826086956522, -0.2, 0.083333333333333
90061, 1.9608695652174, -0.2, 0.055555555555556
90062, 1.9826086956522, -0.175, 0.055555555555556
90063, 1.9826086956522, -0.2, 0.027777777777778
90064, 2.0260869565217, -0.2, 0.47222222222222
90065, 2.004347826087, -0.2, 0.44444444444444
90066, 2.0260869565217, -0.175, 0.44444444444444
90067, 2.0260869565217, -0.2, 0.41666666666667
90068, 2.004347826087, -0.2, 0.38888888888889
90069, 2.0260869565217, -0.175, 0.38888888888889
90070, 2.0260869565217, -0.2, 0.36111111111111
90071, 2.004347826087, -0.2, 0.33333333333333
90072, 2.0260869565217, -0.175, 0.33333333333333
90073, 2.0260869565217, -0.2, 0.30555555555556
90074, 2.004347826087, -0.2, 0.27777777777778
90075, 2.0260869565217, -0.175, 0.27777777777778
90076, 2.0260869565217, -0.2, 0.25
90077, 2.004347826087, -0.2, 0.22222222222222
90078, 2.0260869565217, -0.175, 0.22222222222222
90079, 2.0260869565217, -0.2, 0.19444444444444
90080, 2.004347826087, -0.2, 0.16666666666667
90081, 2.0260869565217, -0.175, 0.16666666666667
90082, 2.0260869565217, -0.2, 0.13888888888889
90083, 2.004347826087, -0.2, 0.11111111111111
90084, 2.0260869565217, -0.175, 0.11111111111111
90085, 2.0260869565217, -0.2, 0.083333333333333
90086, 2.004347826087, -0.2, 0.055555555555556
90087, 2.0260869565217, -0.175, 0.055555555555556
90088, 2.0260869565217, -0.2, 0.027777777777778
90089, 2.0695652173913, -0.2, 0.47222222222222
90090, 2.0478260869565, -0.2, 0.44444444444444
90091, 2.0695652173913, -0.175, 0.44444444444444
90092, 2.0695652173913, -0.2, 0.41666666666667
90093, 2.0478260869565, -0.2, 0.38888888888889
90094, 2.0695652173913, -0.175, 0.38888888888889
90095, 2.0695652173913, -0.2, 0.36111111111111
90096, 2.0478260869565, -0.2, 0.33333333333333
90097, 2.0695652173913, -0.175, 0.33333333333333
90098, 2.0695652173913, -0.2, 0.30555555555556
90099, 2.0478260869565, -0.2, 0.27777777777778
90100, 2.0695652173913, -0.175, 0.27777777777778
90101, 2.0695652173913, -0.2, 0.25
90102, 2.0478260869565, -0.2, 0.22222222222222
90103, 2.0695652173913, -0.175, 0.22222222222222
90104, 2.0695652173913, -0.2, 0.19444444444444
90105, 2.0478260869565, -0.2, 0.16666666666667
90106, 2.0695652173913, -0.175, 0.16666666666667
90107, 2.0695652173913, -0.2, 0.13888888888889
90108, 2.0478260869565, -0.2, 0.11111111111111
90109, 2.0695652173913, -0.175, 0.11111111111111
90110, 2.0695652173913, -0.2, 0.083333333333333
90111, 2.0478260869565, -0.2, 0.055555555555556
90112, 2.0695652173913, -0.175, 0.055555555555556
90113, 2.0695652173913, -0.2, 0.027777777777778
90114, 2.1130434782609, -0.2, 0.47222222222222
90115, 2.0913043478261, -0.2, 0.44444444444444
90116, 2.1130434782609, -0.175, 0.44444444444444
90117, 2.1130434782609, -0.2, 0.41666666666667
90118, 2.0913043478261, -0.2, 0.38888888888889
90119, 2.1130434782609, -0.175, 0.38888888888889
90120, 2.1130434782609, -0.2, 0.36111111111111
90121, 2.0913043478261, -0.2, 0.33333333333333
90122, 2.1130434782609, -0.175, 0.33333333333333
90123, 2.1130434782609, -0.2, 0.30555555555556
90124, 2.0913043478261, -0.2, 0.27777777777778
90125, 2.1130434782609, -0.175, 0.27777777777778
90126, 2.1130434782609, -0.2, 0.25
90127, 2.0913043478261, -0.2, 0.22222222222222
90128, 2.1130434782609, -0.175, 0.22222222222222
90129, 2.1130434782609, -0.2, 0.19444444444444
90130, 2.0913043478261, -0.2, 0.16666666666667
90131, 2.1130434782609, -0.175, 0.16666666666667
90132, 2.1130434782609, -0.2, 0.13888888888889
90133, 2.0913043478261, -0.2, 0.11111111111111
90134, 2.1130434782609, -0.175, 0.11111111111111
90135, 2.1130434782609, -0.2, 0.083333333333333
90136, 2.0913043478261, -0.2, 0.055555555555556
90137, 2.1130434782609, -0.175, 0.055555555555556
90138, 2.1130434782609, -0.2, 0.027777777777778
90139, 2.1565217391304, -0.2, 0.47222222222222
90140, 2.1347826086957, -0.2, 0.44444444444444
90141, 2.1565217391304, -0.175, 0.44444444444444
90142, 2.1565217391304, -0.2, 0.41666666666667
90143, 2.1347826086957, -0.2, 0.38888888888889
90144, 2.1565217391304, -0.175, 0.38888888888889
90145, 2.1565217391304, -0.2, 0.36111111111111
90146, 2.1347826086957, -0.2, 0.33333333333333
90147, 2.1565217391304, -0.175, 0.33333333333333
90148, 2.1565217391304, -0.2, 0.30555555555556
90149, 2.1347826086957, -0.2, 0.27777777777778
90150, 2.1565217391304, -0.175, 0.27777777777778
90151, 2.1565217391304, -0.2, 0.25
90152, 2.1347826086957, -0.2, 0.22222222222222
90153, 2.1565217391304, -0.175, 0.22222222222222
90154, 2.1565217391304, -0.2, 0.19444444444444
90155, 2.1347826086957, -0.2, 0.16666666666667
90156, 2.1565217391304, -0.175, 0.16666666666667
90157, 2.1565217391304, -0.2, 0.13888888888889
90158, 2.1347826086957, -0.2, 0.11111111111111
90159, 2.1565217391304, -0.175, 0.11111111111111
90160, 2.1565217391304, -0.2, 0.083333333333333
90161, 2.1347826086957, -0.2, 0.055555555555556
90162, 2.1565217391304, -0.175, 0.055555555555556
90163, 2.1565217391304, -0.2, 0.027777777777778
90164, 2.1782608695652, -0.2, 0.44444444444444
90165, 2.1782608695652, -0.2, 0.38888888888889
90166, 2.1782608695652, -0.2, 0.33333333333333
90167, 2.1782608695652, -0.2, 0.27777777777778
90168, 2.1782608695652, -0.2, 0.22222222222222
90169, 2.1782608695652, -0.2, 0.16666666666667
90170, 2.1782608695652, -0.2, 0.11111111111111
90171, 2.1782608695652, -0.2, 0.055555555555556
90172, 1.2434782608696, -0.225, 0.44444444444444
90173, 1.2434782608696, -0.225, 0.38888888888889
90174, 1.2434782608696, -0.225, 0.33333333333333
90175, 1.2434782608696, -0.225, 0.27777777777778
90176, 1.2434782608696, -0.225, 0.22222222222222
90177, 1.2434782608696, -0.225, 0.16666666666667
90178, 1.2434782608696, -0.225, 0.11111111111111
90179, 1.2434782608696, -0.225, 0.055555555555556
90180, 1.2869565217391, -0.225, 0.44444444444444
90181, 1.2869565217391, -0.225, 0.38888888888889
90182, 1.2869565217391, -0.225, 0.33333333333333
90183, 1.2869565217391, -0.225, 0.27777777777778
90184, 1.2869565217391, -0.225, 0.22222222222222
90185, 1.2869565217391, -0.225, 0.16666666666667
90186, 1.2869565217391, -0.225, 0.11111111111111
90187, 1.2869565217391, -0.225, 0.055555555555556
90188, 1.3304347826087, -0.225, 0.44444444444444
90189, 1.3304347826087, -0.225, 0.38888888888889
90190, 1.3304347826087, -0.225, 0.33333333333333
90191, 1.3304347826087, -0.225, 0.27777777777778
90192, 1.3304347826087, -0.225, 0.22222222222222
90193, 1.3304347826087, -0.225, 0.16666666666667
90194, 1.3304347826087, -0.225, 0.11111111111111
90195, 1.3304347826087, -0.225, 0.055555555555556
90196, 1.3739130434783, -0.225, 0.44444444444444
90197, 1.3739130434783, -0.225, 0.38888888888889
90198, 1.3739130434783, -0.225, 0.33333333333333
90199, 1.3739130434783, -0.225, 0.27777777777778
90200, 1.3739130434783, -0.225, 0.22222222222222
90201, 1.3739130434783, -0.225, 0.16666666666667
90202, 1.3739130434783, -0.225, 0.11111111111111
90203, 1.3739130434783, -0.225, 0.055555555555556
90204, 1.4173913043478, -0.225, 0.44444444444444
90205, 1.4173913043478, -0.225, 0.38888888888889
90206, 1.4173913043478, -0.225, 0.33333333333333
90207, 1.4173913043478, -0.225, 0.27777777777778
90208, 1.4173913043478, -0.225, 0.22222222222222
90209, 1.4173913043478, -0.225, 0.16666666666667
90210, 1.4173913043478, -0.225, 0.11111111111111
90211, 1.4173913043478, -0.225, 0.055555555555556
90212, 1.4608695652174, -0.225, 0.44444444444444
90213, 1.4608695652174, -0.225, 0.38888888888889
90214, 1.4608695652174, -0.225, 0.33333333333333
90215, 1.4608695652174, -0.225, 0.27777777777778
90216, 1.4608695652174, -0.225, 0.22222222222222
90217, 1.4608695652174, -0.225, 0.16666666666667
90218, 1.4608695652174, -0.225, 0.11111111111111
90219, 1.4608695652174, -0.225, 0.055555555555556
90220, 1.504347826087, -0.225, 0.44444444444444
90221, 1.504347826087, -0.225, 0.38888888888889
90222, 1.504347826087, -0.225, 0.33333333333333
90223, 1.504347826087, -0.225, 0.27777777777778
90224, 1.504347826087, -0.225, 0.22222222222222
90225, 1.504347826087, -0.225, 0.16666666666667
90226, 1.504347826087, -0.225, 0.11111111111111
90227, 1.504347826087, -0.225, 0.055555555555556
90228, 1.5478260869565, -0.225, 0.44444444444444
90229, 1.5478260869565, -0.225, 0.38888888888889
90230, 1.5478260869565, -0.225, 0.33333333333333
90231, 1.5478260869565, -0.225, 0.27777777777778
90232, 1.5478260869565, -0.225, 0.22222222222222
90233, 1.5478260869565, -0.225, 0.16666666666667
90234, 1.5478260869565, -0.225, 0.11111111111111
90235, 1.5478260869565, -0.225, 0.055555555555556
90236, 1.5913043478261, -0.225, 0.44444444444444
90237, 1.5913043478261, -0.225, 0.38888888888889
90238, 1.5913043478261, -0.225, 0.33333333333333
90239, 1.5913043478261, -0.225, 0.27777777777778
90240, 1.5913043478261, -0.225, 0.22222222222222
90241, 1.5913043478261, -0.225, 0.16666666666667
90242, 1.5913043478261, -0.225, 0.11111111111111
90243, 1.5913043478261, -0.225, 0.055555555555556
90244, 1.6347826086957, -0.225, 0.44444444444444
90245, 1.6347826086957, -0.225, 0.38888888888889
90246, 1.6347826086957, -0.225, 0.33333333333333
90247, 1.6347826086957, -0.225, 0.27777777777778
90248, 1.6347826086957, -0.225, 0.22222222222222
90249, 1.6347826086957, -0.225, 0.16666666666667
90250, 1.6347826086957, -0.225, 0.11111111111111
90251, 1.6347826086957, -0.225, 0.055555555555556
90252, 1.6782608695652, -0.225, 0.44444444444444
90253, 1.6782608695652, -0.225, 0.38888888888889
90254, 1.6782608695652, -0.225, 0.33333333333333
90255, 1.6782608695652, -0.225, 0.27777777777778
90256, 1.6782608695652, -0.225, 0.22222222222222
90257, 1.6782608695652, -0.225, 0.16666666666667
90258, 1.6782608695652, -0.225, 0.11111111111111
90259, 1.6782608695652, -0.225, 0.055555555555556
90260, 1.7217391304348, -0.225, 0.44444444444444
90261, 1.7217391304348, -0.225, 0.38888888888889
90262, 1.7217391304348, -0.225, 0.33333333333333
90263, 1.7217391304348, -0.225, 0.27777777777778
90264, 1.7217391304348, -0.225, 0.22222222222222
90265, 1.7217391304348, -0.225, 0.16666666666667
90266, 1.7217391304348, -0.225, 0.11111111111111
90267, 1.7217391304348, -0.225, 0.055555555555556
90268, 1.7652173913043, -0.225, 0.44444444444444
90269, 1.7652173913043, -0.225, 0.38888888888889
90270, 1.7652173913043, -0.225, 0.33333333333333
90271, 1.7652173913043, -0.225, 0.27777777777778
90272, 1.7652173913043, -0.225, 0.22222222222222
90273, 1.7652173913043, -0.225, 0.16666666666667
90274, 1.7652173913043, -0.225, 0.11111111111111
90275, 1.7652173913043, -0.225, 0.055555555555556
90276, 1.8086956521739, -0.225, 0.44444444444444
90277, 1.8086956521739, -0.225, 0.38888888888889
90278, 1.8086956521739, -0.225, 0.33333333333333
90279, 1.8086956521739, -0.225, 0.27777777777778
90280, 1.8086956521739, -0.225, 0.22222222222222
90281, 1.8086956521739, -0.225, 0.16666666666667
90282, 1.8086956521739, -0.225, 0.11111111111111
90283, 1.8086956521739, -0.225, 0.055555555555556
90284, 1.8521739130435, -0.225, 0.44444444444444
90285, 1.8521739130435, -0.225, 0.38888888888889
90286, 1.8521739130435, -0.225, 0.33333333333333
90287, 1.8521739130435, -0.225, 0.27777777777778
90288, 1.8521739130435, -0.225, 0.22222222222222
90289, 1.8521739130435, -0.225, 0.16666666666667
90290, 1.8521739130435, -0.225, 0.11111111111111
90291, 1.8521739130435, -0.225, 0.055555555555556
90292, 1.895652173913, -0.225, 0.44444444444444
90293, 1.895652173913, -0.225, 0.38888888888889
90294, 1.895652173913, -0.225, 0.33333333333333
90295, 1.895652173913, -0.225, 0.27777777777778
90296, 1.895652173913, -0.225, 0.22222222222222
90297, 1.895652173913, -0.225, 0.16666666666667
90298, 1.895652173913, -0.225, 0.11111111111111
90299, 1.895652173913, -0.225, 0.055555555555556
90300, 1.9391304347826, -0.225, 0.44444444444444
90301, 1.9391304347826, -0.225, 0.38888888888889
90302, 1.9391304347826, -0.225, 0.33333333333333
90303, 1.9391304347826, -0.225, 0.27777777777778
90304, 1.9391304347826, -0.225, 0.22222222222222
90305, 1.9391304347826, -0.225, 0.16666666666667
90306, 1.9391304347826, -0.225, 0.11111111111111
90307, 1.9391304347826, -0.225, 0.055555555555556
90308, 1.9826086956522, -0.225, 0.44444444444444
90309, 1.9826086956522, -0.225, 0.38888888888889
90310, 1.9826086956522, -0.225, 0.33333333333333
90311, 1.9826086956522, -0.225, 0.27777777777778
90312, 1.9826086956522, -0.225, 0.22222222222222
90313, 1.9826086956522, -0.225, 0.16666666666667
90314, 1.9826086956522, -0.225, 0.11111111111111
90315, 1.9826086956522, -0.225, 0.055555555555556
90316, 2.0260869565217, -0.225, 0.44444444444444
90317, 2.0260869565217, -0.225, 0.38888888888889
90318, 2.0260869565217, -0.225, 0.33333333333333
90319, 2.0260869565217, -0.225, 0.27777777777778
90320, 2.0260869565217, -0.225, 0.22222222222222
90321, 2.0260869565217, -0.225, 0.16666666666667
90322, 2.0260869565217, -0.225, 0.11111111111111
90323, 2.0260869565217, -0.225, 0.055555555555556
90324, 2.0695652173913, -0.225, 0.44444444444444
90325, 2.0695652173913, -0.225, 0.38888888888889
90326, 2.0695652173913, -0.225, 0.33333333333333
90327, 2.0695652173913, -0.225, 0.27777777777778
90328, 2.0695652173913, -0.225, 0.22222222222222
90329, 2.0695652173913, -0.225, 0.16666666666667
90330, 2.0695652173913, -0.225, 0.11111111111111
90331, 2.0695652173913, -0.225, 0.055555555555556
90332, 2.1130434782609, -0.225, 0.44444444444444
90333, 2.1130434782609, -0.225, 0.38888888888889
90334, 2.1130434782609, -0.225, 0.33333333333333
90335, 2.1130434782609, -0.225, 0.27777777777778
90336, 2.1130434782609, -0.225, 0.22222222222222
90337, 2.1130434782609, -0.225, 0.16666666666667
90338, 2.1130434782609, -0.225, 0.11111111111111
90339, 2.1130434782609, -0.225, 0.055555555555556
90340, 2.1565217391304, -0.225, 0.44444444444444
90341, 2.1565217391304, -0.225, 0.38888888888889
90342, 2.1565217391304, -0.225, 0.33333333333333
90343, 2.1565217391304, -0.225, 0.27777777777778
90344, 2.1565217391304, -0.225, 0.22222222222222
90345, 2.1565217391304, -0.225, 0.16666666666667
90346, 2.1565217391304, -0.225, 0.11111111111111
90347, 2.1565217391304, -0.225, 0.055555555555556
90348, 2.25, -0.1, 0.44444444444444
90349, 2.25, -0.1, 0.38888888888889
90350, 2.25, -0.1, 0.33333333333333
90351, 2.25, -0.1, 0.27777777777778
90352, 2.25, -0.1, 0.22222222222222
90353, 2.25, -0.1, 0.16666666666667
90354, 2.25, -0.1, 0.11111111111111
90355, 2.25, -0.1, 0.055555555555556
90356, 2.25, -0.15, 0.44444444444444
90357, 2.25, -0.15, 0.38888888888889
90358, 2.25, -0.15, 0.33333333333333
90359, 2.25, -0.15, 0.27777777777778
90360, 2.25, -0.15, 0.22222222222222
90361, 2.25, -0.15, 0.16666666666667
90362, 2.25, -0.15, 0.11111111111111
90363, 2.25, -0.15, 0.055555555555556
90364, 2.25, -0.2, 0.44444444444444
90365, 2.25, -0.2, 0.38888888888889
90366, 2.25, -0.2, 0.33333333333333
90367, 2.25, -0.2, 0.27777777777778
90368, 2.25, -0.2, 0.22222222222222
90369, 2.25, -0.2, 0.16666666666667
90370, 2.25, -0.2, 0.11111111111111
90371, 2.25, -0.2, 0.055555555555556
90372, 2.25, -0.1, 0.47222222222222
90373, 2.225, -0.1, 0.44444444444444
90374, 2.25, -0.075, 0.44444444444444
90375, 2.25, -0.1, 0.41666666666667
90376, 2.225, -0.1, 0.38888888888889
90377, 2.25, -0.075, 0.38888888888889
90378, 2.25, -0.1, 0.36111111111111
90379, 2.225, -0.1, 0.33333333333333
90380, 2.25, -0.075, 0.33333333333333
90381, 2.25, -0.1, 0.30555555555556
90382, 2.225, -0.1, 0.27777777777778
90383, 2.25, -0.075, 0.27777777777778
90384, 2.25, -0.1, 0.25
90385, 2.225, -0.1, 0.22222222222222
90386, 2.25, -0.075, 0.22222222222222
90387, 2.25, -0.1, 0.19444444444444
90388, 2.225, -0.1, 0.16666666666667
90389, 2.25, -0.075, 0.16666666666667
90390, 2.25, -0.1, 0.13888888888889
90391, 2.225, -0.1, 0.11111111111111
90392, 2.25, -0.075, 0.11111111111111
90393, 2.25, -0.1, 0.083333333333333
90394, 2.225, -0.1, 0.055555555555556
90395, 2.25, -0.075, 0.055555555555556
90396, 2.25, -0.1, 0.027777777777778
90397, 2.275, -0.1, 0.44444444444444
90398, 2.275, -0.1, 0.38888888888889
90399, 2.275, -0.1, 0.33333333333333
90400, 2.275, -0.1, 0.27777777777778
90401, 2.275, -0.1, 0.22222222222222
90402, 2.275, -0.1, 0.16666666666667
90403, 2.275, -0.1, 0.11111111111111
90404, 2.275, -0.1, 0.055555555555556
90405, 2.25, -0.15, 0.47222222222222
90406, 2.225, -0.15, 0.44444444444444
90407, 2.25, -0.125, 0.44444444444444
90408, 2.25, -0.15, 0.41666666666667
90409, 2.225, -0.15, 0.38888888888889
90410, 2.25, -0.125, 0.38888888888889
90411, 2.25, -0.15, 0.36111111111111
90412, 2.225, -0.15, 0.33333333333333
90413, 2.25, -0.125, 0.33333333333333
90414, 2.25, -0.15, 0.30555555555556
90415, 2.225, -0.15, 0.27777777777778
90416, 2.25, -0.125, 0.27777777777778
90417, 2.25, -0.15, 0.25
90418, 2.225, -0.15, 0.22222222222222
90419, 2.25, -0.125, 0.22222222222222
90420, 2.25, -0.15, 0.19444444444444
90421, 2.225, -0.15, 0.16666666666667
90422, 2.25, -0.125, 0.16666666666667
90423, 2.25, -0.15, 0.13888888888889
90424, 2.225, -0.15, 0.11111111111111
90425, 2.25, -0.125, 0.11111111111111
90426, 2.25, -0.15, 0.083333333333333
90427, 2.225, -0.15, 0.055555555555556
90428, 2.25, -0.125, 0.055555555555556
90429, 2.25, -0.15, 0.027777777777778
90430, 2.275, -0.15, 0.44444444444444
90431, 2.275, -0.15, 0.38888888888889
90432, 2.275, -0.15, 0.33333333333333
90433, 2.275, -0.15, 0.27777777777778
90434, 2.275, -0.15, 0.22222222222222
90435, 2.275, -0.15, 0.16666666666667
90436, 2.275, -0.15, 0.11111111111111
90437, 2.275, -0.15, 0.055555555555556
90438, 2.25, -0.2, 0.47222222222222
90439, 2.225, -0.2, 0.44444444444444
90440, 2.25, -0.175, 0.44444444444444
90441, 2.25, -0.2, 0.41666666666667
90442, 2.225, -0.2, 0.38888888888889
90443, 2.25, -0.175, 0.38888888888889
90444, 2.25, -0.2, 0.36111111111111
90445, 2.225, -0.2, 0.33333333333333
90446, 2.25, -0.175, 0.33333333333333
90447, 2.25, -0.2, 0.30555555555556
90448, 2.225, -0.2, 0.27777777777778
90449, 2.25, -0.175, 0.27777777777778
90450, 2.25, -0.2, 0.25
90451, 2.225, -0.2, 0.22222222222222
90452, 2.25, -0.175, 0.22222222222222
90453, 2.25, -0.2, 0.19444444444444
90454, 2.225, -0.2, 0.16666666666667
90455, 2.25, -0.175, 0.16666666666667
90456, 2.25, -0.2, 0.13888888888889
90457, 2.225, -0.2, 0.11111111111111
90458, 2.25, -0.175, 0.11111111111111
90459, 2.25, -0.2, 0.083333333333333
90460, 2.225, -0.2, 0.055555555555556
90461, 2.25, -0.175, 0.055555555555556
90462, 2.25, -0.2, 0.027777777777778
90463, 2.275, -0.2, 0.44444444444444
90464, 2.275, -0.2, 0.38888888888889
90465, 2.275, -0.2, 0.33333333333333
90466, 2.275, -0.2, 0.27777777777778
90467, 2.275, -0.2, 0.22222222222222
90468, 2.275, -0.2, 0.16666666666667
90469, 2.275, -0.2, 0.11111111111111
90470, 2.275, -0.2, 0.055555555555556
90471, 2.25, -0.225, 0.44444444444444
90472, 2.25, -0.225, 0.38888888888889
90473, 2.25, -0.225, 0.33333333333333
90474, 2.25, -0.225, 0.27777777777778
90475, 2.25, -0.225, 0.22222222222222
90476, 2.25, -0.225, 0.16666666666667
90477, 2.25, -0.225, 0.11111111111111
90478, 2.25, -0.225, 0.055555555555556
90479, 1.05, -0.1, 0.44444444444444
90480, 1.05, -0.1, 0.38888888888889
90481, 1.05, -0.1, 0.33333333333333
90482, 1.05, -0.1, 0.27777777777778
90483, 1.05, -0.1, 0.22222222222222
90484, 1.05, -0.1, 0.16666666666667
90485, 1.05, -0.1, 0.11111111111111
90486, 1.05, -0.1, 0.055555555555556
90487, 1.05, -0.15, 0.44444444444444
90488, 1.05, -0.15, 0.38888888888889
90489, 1.05, -0.15, 0.33333333333333
90490, 1.05, -0.15, 0.27777777777778
90491, 1.05, -0.15, 0.22222222222222
90492, 1.05, -0.15, 0.16666666666667
90493, 1.05, -0.15, 0.11111111111111
90494, 1.05, -0.15, 0.055555555555556
90495, 1.05, -0.2, 0.44444444444444
90496, 1.05, -0.2, 0.38888888888889
90497, 1.05, -0.2, 0.33333333333333
90498, 1.05, -0.2, 0.27777777777778
90499, 1.05, -0.2, 0.22222222222222
90500, 1.05, -0.2, 0.16666666666667
90501, 1.05, -0.2, 0.11111111111111
90502, 1.05, -0.2, 0.055555555555556
90503, 1.1, -0.1, 0.44444444444444
90504, 1.1, -0.1, 0.38888888888889
90505, 1.1, -0.1, 0.33333333333333
90506, 1.1, -0.1, 0.27777777777778
90507, 1.1, -0.1, 0.22222222222222
90508, 1.1, -0.1, 0.16666666666667
90509, 1.1, -0.1, 0.11111111111111
90510, 1.1, -0.1, 0.055555555555556
90511, 1.1, -0.15, 0.44444444444444
90512, 1.1, -0.15, 0.38888888888889
90513, 1.1, -0.15, 0.33333333333333
90514, 1.1, -0.15, 0.27777777777778
90515, 1.1, -0.15, 0.22222222222222
90516, 1.1, -0.15, 0.16666666666667
90517, 1.1, -0.15, 0.11111111111111
90518, 1.1, -0.15, 0.055555555555556
90519, 1.1, -0.2, 0.44444444444444
90520, 1.1, -0.2, 0.38888888888889
90521, 1.1, -0.2, 0.33333333333333
90522, 1.1, -0.2, 0.27777777777778
90523, 1.1, -0.2, 0.22222222222222
90524, 1.1, -0.2, 0.16666666666667
90525, 1.1, -0.2, 0.11111111111111
90526, 1.1, -0.2, 0.055555555555556
90527, 1.15, -0.1, 0.44444444444444
90528, 1.15, -0.1, 0.38888888888889
90529, 1.15, -0.1, 0.33333333333333
90530, 1.15, -0.1, 0.27777777777778
90531, 1.15, -0.1, 0.22222222222222
90532, 1.15, -0.1, 0.16666666666667
90533, 1.15, -0.1, 0.11111111111111
90534, 1.15, -0.1, 0.055555555555556
90535, 1.15, -0.15, 0.44444444444444
90536, 1.15, -0.15, 0.38888888888889
90537, 1.15, -0.15, 0.33333333333333
90538, 1.15, -0.15, 0.27777777777778
90539, 1.15, -0.15, 0.22222222222222
90540, 1.15, -0.15, 0.16666666666667
90541, 1.15, -0.15, 0.11111111111111
90542, 1.15, -0.15, 0.055555555555556
90543, 1.15, -0.2, 0.44444444444444
90544, 1.15, -0.2, 0.38888888888889
90545, 1.15, -0.2, 0.33333333333333
90546, 1.15, -0.2, 0.27777777777778
90547, 1.15, -0.2, 0.22222222222222
90548, 1.15, -0.2, 0.16666666666667
90549, 1.15, -0.2, 0.11111111111111
90550, 1.15, -0.2, 0.055555555555556
90551, 1.05, -0.1, 0.47222222222222
90552, 1.05, -0.075, 0.44444444444444
90553, 1.025, -0.1, 0.44444444444444
90554, 1.05, -0.1, 0.41666666666667
90555, 1.05, -0.075, 0.38888888888889
90556, 1.025, -0.1, 0.38888888888889
90557, 1.05, -0.1, 0.36111111111111
90558, 1.05, -0.075, 0.33333333333333
90559, 1.025, -0.1, 0.33333333333333
90560, 1.05, -0.1, 0.30555555555556
90561, 1.05, -0.075, 0.27777777777778
90562, 1.025, -0.1, 0.27777777777778
90563, 1.05, -0.1, 0.25
90564, 1.05, -0.075, 0.22222222222222
90565, 1.025, -0.1, 0.22222222222222
90566, 1.05, -0.1, 0.19444444444444
90567, 1.05, -0.075, 0.16666666666667
90568, 1.025, -0.1, 0.16666666666667
90569, 1.05, -0.1, 0.13888888888889
90570, 1.05, -0.075, 0.11111111111111
90571, 1.025, -0.1, 0.11111111111111
90572, 1.05, -0.1, 0.083333333333333
90573, 1.05, -0.075, 0.055555555555556
90574, 1.025, -0.1, 0.055555555555556
90575, 1.05, -0.1, 0.027777777777778
90576, 1.05, -0.15, 0.47222222222222
90577, 1.05, -0.125, 0.44444444444444
90578, 1.025, -0.15, 0.44444444444444
90579, 1.05, -0.15, 0.41666666666667
90580, 1.05, -0.125, 0.38888888888889
90581, 1.025, -0.15, 0.38888888888889
90582, 1.05, -0.15, 0.36111111111111
90583, 1.05, -0.125, 0.33333333333333
90584, 1.025, -0.15, 0.33333333333333
90585, 1.05, -0.15, 0.30555555555556
90586, 1.05, -0.125, 0.27777777777778
90587, 1.025, -0.15, 0.27777777777778
90588, 1.05, -0.15, 0.25
90589, 1.05, -0.125, 0.22222222222222
90590, 1.025, -0.15, 0.22222222222222
90591, 1.05, -0.15, 0.19444444444444
90592, 1.05, -0.125, 0.16666666666667
90593, 1.025, -0.15, 0.16666666666667
90594, 1.05, -0.15, 0.13888888888889
90595, 1.05, -0.125, 0.11111111111111
90596, 1.025, -0.15, 0.11111111111111
90597, 1.05, -0.15, 0.083333333333333
90598, 1.05, -0.125, 0.055555555555556
90599, 1.025, -0.15, 0.055555555555556
90600, 1.05, -0.15, 0.027777777777778
90601, 1.05, -0.2, 0.47222222222222
90602, 1.05, -0.175, 0.44444444444444
90603, 1.025, -0.2, 0.44444444444444
90604, 1.05, -0.2, 0.41666666666667
90605, 1.05, -0.175, 0.38888888888889
90606, 1.025, -0.2, 0.38888888888889
90607, 1.05, -0.2, 0.36111111111111
90608, 1.05, -0.175, 0.33333333333333
90609, 1.025, -0.2, 0.33333333333333
90610, 1.05, -0.2, 0.30555555555556
90611, 1.05, -0.175, 0.27777777777778
90612, 1.025, -0.2, 0.27777777777778
90613, 1.05, -0.2, 0.25
90614, 1.05, -0.175, 0.22222222222222
90615, 1.025, -0.2, 0.22222222222222
90616, 1.05, -0.2, 0.19444444444444
90617, 1.05, -0.175, 0.16666666666667
90618, 1.025, -0.2, 0.16666666666667
90619, 1.05, -0.2, 0.13888888888889
90620, 1.05, -0.175, 0.11111111111111
90621, 1.025, -0.2, 0.11111111111111
90622, 1.05, -0.2, 0.083333333333333
90623, 1.05, -0.175, 0.055555555555556
90624, 1.025, -0.2, 0.055555555555556
90625, 1.05, -0.2, 0.027777777777778
90626, 1.05, -0.225, 0.44444444444444
90627, 1.05, -0.225, 0.38888888888889
90628, 1.05, -0.225, 0.33333333333333
90629, 1.05, -0.225, 0.27777777777778
90630, 1.05, -0.225, 0.22222222222222
90631, 1.05, -0.225, 0.16666666666667
90632, 1.05, -0.225, 0.11111111111111
90633, 1.05, -0.225, 0.055555555555556
90634, 1.1, -0.1, 0.47222222222222
90635, 1.1, -0.075, 0.44444444444444
90636, 1.075, -0.1, 0.44444444444444
90637, 1.1, -0.1, 0.41666666666667
90638, 1.1, -0.075, 0.38888888888889
90639, 1.075, -0.1, 0.38888888888889
90640, 1.1, -0.1, 0.36111111111111
90641, 1.1, -0.075, 0.33333333333333
90642, 1.075, -0.1, 0.33333333333333
90643, 1.1, -0.1, 0.30555555555556
90644, 1.1, -0.075, 0.27777777777778
90645, 1.075, -0.1, 0.27777777777778
90646, 1.1, -0.1, 0.25
90647, 1.1, -0.075, 0.22222222222222
90648, 1.075, -0.1, 0.22222222222222
90649, 1.1, -0.1, 0.19444444444444
90650, 1.1, -0.075, 0.16666666666667
90651, 1.075, -0.1, 0.16666666666667
90652, 1.1, -0.1, 0.13888888888889
90653, 1.1, -0.075, 0.11111111111111
90654, 1.075, -0.1, 0.11111111111111
90655, 1.1, -0.1, 0.083333333333333
90656, 1.1, -0.075, 0.055555555555556
90657, 1.075, -0.1, 0.055555555555556
90658, 1.1, -0.1, 0.027777777777778
90659, 1.1, -0.15, 0.47222222222222
90660, 1.1, -0.125, 0.44444444444444
90661, 1.075, -0.15, 0.44444444444444
90662, 1.1, -0.15, 0.41666666666667
90663, 1.1, -0.125, 0.38888888888889
90664, 1.075, -0.15, 0.38888888888889
90665, 1.1, -0.15, 0.36111111111111
90666, 1.1, -0.125, 0.33333333333333
90667, 1.075, -0.15, 0.33333333333333
90668, 1.1, -0.15, 0.30555555555556
90669, 1.1, -0.125, 0.27777777777778
90670, 1.075, -0.15, 0.27777777777778
90671, 1.1, -0.15, 0.25
90672, 1.1, -0.125, 0.22222222222222
90673, 1.075, -0.15, 0.22222222222222
90674, 1.1, -0.15, 0.19444444444444
90675, 1.1, -0.125, 0.16666666666667
90676, 1.075, -0.15, 0.16666666666667
90677, 1.1, -0.15, 0.13888888888889
90678, 1.1, -0.125, 0.11111111111111
90679, 1.075, -0.15, 0.11111111111111
90680, 1.1, -0.15, 0.083333333333333
90681, 1.1, -0.125, 0.055555555555556
90682, 1.075, -0.15, 0.055555555555556
90683, 1.1, -0.15, 0.027777777777778
90684, 1.1, -0.2, 0.47222222222222
90685, 1.1, -0.175, 0.44444444444444
90686, 1.075, -0.2, 0.44444444444444
90687, 1.1, -0.2, 0.41666666666667
90688, 1.1, -0.175, 0.38888888888889
90689, 1.075, -0.2, 0.38888888888889
90690, 1.1, -0.2, 0.36111111111111
90691, 1.1, -0.175, 0.33333333333333
90692, 1.075, -0.2, 0.33333333333333
90693, 1.1, -0.2, 0.30555555555556
90694, 1.1, -0.175, 0.27777777777778
90695, 1.075, -0.2, 0.27777777777778
90696, 1.1, -0.2, 0.25
90697, 1.1, -0.175, 0.22222222222222
90698, 1.075, -0.2, 0.22222222222222
90699, 1.1, -0.2, 0.19444444444444
90700, 1.1, -0.175, 0.16666666666667
90701, 1.075, -0.2, 0.16666666666667
90702, 1.1, -0.2, 0.13888888888889
90703, 1.1, -0.175, 0.11111111111111
90704, 1.075, -0.2, 0.11111111111111
90705, 1.1, -0.2, 0.083333333333333
90706, 1.1, -0.175, 0.055555555555556
90707, 1.075, -0.2, 0.055555555555556
90708, 1.1, -0.2, 0.027777777777778
90709, 1.1, -0.225, 0.44444444444444
90710, 1.1, -0.225, 0.38888888888889
90711, 1.1, -0.225, 0.33333333333333
90712, 1.1, -0.225, 0.27777777777778
90713, 1.1, -0.225, 0.22222222222222
90714, 1.1, -0.225, 0.16666666666667
90715, 1.1, -0.225, 0.11111111111111
90716, 1.1, -0.225, 0.055555555555556
90717, 1.15, -0.1, 0.47222222222222
90718, 1.15, -0.075, 0.44444444444444
90719, 1.125, -0.1, 0.44444444444444
90720, 1.15, -0.1, 0.41666666666667
90721, 1.15, -0.075, 0.38888888888889
90722, 1.125, -0.1, 0.38888888888889
90723, 1.15, -0.1, 0.36111111111111
90724, 1.15, -0.075, 0.33333333333333
90725, 1.125, -0.1, 0.33333333333333
90726, 1.15, -0.1, 0.30555555555556
90727, 1.15, -0.075, 0.27777777777778
90728, 1.125, -0.1, 0.27777777777778
90729, 1.15, -0.1, 0.25
90730, 1.15, -0.075, 0.22222222222222
90731, 1.125, -0.1, 0.22222222222222
90732, 1.15, -0.1, 0.19444444444444
90733, 1.15, -0.075, 0.16666666666667
90734, 1.125, -0.1, 0.16666666666667
90735, 1.15, -0.1, 0.13888888888889
90736, 1.15, -0.075, 0.11111111111111
90737, 1.125, -0.1, 0.11111111111111
90738, 1.15, -0.1, 0.083333333333333
90739, 1.15, -0.075, 0.055555555555556
90740, 1.125, -0.1, 0.055555555555556
90741, 1.15, -0.1, 0.027777777777778
90742, 1.15, -0.15, 0.47222222222222
90743, 1.15, -0.125, 0.44444444444444
90744, 1.125, -0.15, 0.44444444444444
90745, 1.15, -0.15, 0.41666666666667
90746, 1.15, -0.125, 0.38888888888889
90747, 1.125, -0.15, 0.38888888888889
90748, 1.15, -0.15, 0.36111111111111
90749, 1.15, -0.125, 0.33333333333333
90750, 1.125, -0.15, 0.33333333333333
90751, 1.15, -0.15, 0.30555555555556
90752, 1.15, -0.125, 0.27777777777778
90753, 1.125, -0.15, 0.27777777777778
90754, 1.15, -0.15, 0.25
90755, 1.15, -0.125, 0.22222222222222
90756, 1.125, -0.15, 0.22222222222222
90757, 1.15, -0.15, 0.19444444444444
90758, 1.15, -0.125, 0.16666666666667
90759, 1.125, -0.15, 0.16666666666667
90760, 1.15, -0.15, 0.13888888888889
90761, 1.15, -0.125, 0.11111111111111
90762, 1.125, -0.15, 0.11111111111111
90763, 1.15, -0.15, 0.083333333333333
90764, 1.15, -0.125, 0.055555555555556
90765, 1.125, -0.15, 0.055555555555556
90766, 1.15, -0.15, 0.027777777777778
90767, 1.15, -0.2, 0.47222222222222
90768, 1.15, -0.175, 0.44444444444444
90769, 1.125, -0.2, 0.44444444444444
90770, 1.15, -0.2, 0.41666666666667
90771, 1.15, -0.175, 0.38888888888889
90772, 1.125, -0.2, 0.38888888888889
90773, 1.15, -0.2, 0.36111111111111
90774, 1.15, -0.175, 0.33333333333333
90775, 1.125, -0.2, 0.33333333333333
90776, 1.15, -0.2, 0.30555555555556
90777, 1.15, -0.175, 0.27777777777778
90778, 1.125, -0.2, 0.27777777777778
90779, 1.15, -0.2, 0.25
90780, 1.15, -0.175, 0.22222222222222
90781, 1.125, -0.2, 0.22222222222222
90782, 1.15, -0.2, 0.19444444444444
90783, 1.15, -0.175, 0.16666666666667
90784, 1.125, -0.2, 0.16666666666667
90785, 1.15, -0.2, 0.13888888888889
90786, 1.15, -0.175, 0.11111111111111
90787, 1.125, -0.2, 0.11111111111111
90788, 1.15, -0.2, 0.083333333333333
90789, 1.15, -0.175, 0.055555555555556
90790, 1.125, -0.2, 0.055555555555556
90791, 1.15, -0.2, 0.027777777777778
90792, 1.15, -0.225, 0.44444444444444
90793, 1.15, -0.225, 0.38888888888889
90794, 1.15, -0.225, 0.33333333333333
90795, 1.15, -0.225, 0.27777777777778
90796, 1.15, -0.225, 0.22222222222222
90797, 1.15, -0.225, 0.16666666666667
90798, 1.15, -0.225, 0.11111111111111
90799, 1.15, -0.225, 0.055555555555556
90800, 1.175, -0.1, 0.44444444444444
90801, 1.175, -0.1, 0.38888888888889
90802, 1.175, -0.1, 0.33333333333333
90803, 1.175, -0.1, 0.27777777777778
90804, 1.175, -0.1, 0.22222222222222
90805, 1.175, -0.1, 0.16666666666667
90806, 1.175, -0.1, 0.11111111111111
90807, 1.175, -0.1, 0.055555555555556
90808, 1.175, -0.15, 0.44444444444444
90809, 1.175, -0.15, 0.38888888888889
90810, 1.175, -0.15, 0.33333333333333
90811, 1.175, -0.15, 0.27777777777778
90812, 1.175, -0.15, 0.22222222222222
90813, 1.175, -0.15, 0.16666666666667
90814, 1.175, -0.15, 0.11111111111111
90815, 1.175, -0.15, 0.055555555555556
90816, 1.175, -0.2, 0.44444444444444
90817, 1.175, -0.2, 0.38888888888889
90818, 1.175, -0.2, 0.33333333333333
90819, 1.175, -0.2, 0.27777777777778
90820, 1.175, -0.2, 0.22222222222222
90821, 1.175, -0.2, 0.16666666666667
90822, 1.175, -0.2, 0.11111111111111
90823, 1.175, -0.2, 0.055555555555556
90824, -0.05, 1.6, 0.44444444444444
90825, -0.05, 1.6, 0.38888888888889
90826, -0.05, 1.6, 0.33333333333333
90827, -0.05, 1.6, 0.27777777777778
90828, -0.05, 1.6, 0.22222222222222
90829, -0.05, 1.6, 0.16666666666667
90830, -0.05, 1.6, 0.11111111111111
90831, -0.05, 1.6, 0.055555555555556
90832, -0.05, 1.65, 0.44444444444444
90833, -0.05, 1.65, 0.38888888888889
90834, -0.05, 1.65, 0.33333333333333
90835, -0.05, 1.65, 0.27777777777778
90836, -0.05, 1.65, 0.22222222222222
90837, -0.05, 1.65, 0.16666666666667
90838, -0.05, 1.65, 0.11111111111111
90839, -0.05, 1.65, 0.055555555555556
90840, -0.05, 1.7, 0.44444444444444
90841, -0.05, 1.7, 0.38888888888889
90842, -0.05, 1.7, 0.33333333333333
90843, -0.05, 1.7, 0.27777777777778
90844, -0.05, 1.7, 0.22222222222222
90845, -0.05, 1.7, 0.16666666666667
90846, -0.05, 1.7, 0.11111111111111
90847, -0.05, 1.7, 0.055555555555556
90848, -0.05, 1.6, 0.47222222222222
90849, -0.05, 1.575, 0.44444444444444
90850, -0.025, 1.6, 0.44444444444444
90851, -0.05, 1.6, 0.41666666666667
90852, -0.05, 1.575, 0.38888888888889
90853, -0.025, 1.6, 0.38888888888889
90854, -0.05, 1.6, 0.36111111111111
90855, -0.05, 1.575, 0.33333333333333
90856, -0.025, 1.6, 0.33333333333333
90857, -0.05, 1.6, 0.30555555555556
90858, -0.05, 1.575, 0.27777777777778
90859, -0.025, 1.6, 0.27777777777778
90860, -0.05, 1.6, 0.25
90861, -0.05, 1.575, 0.22222222222222
90862, -0.025, 1.6, 0.22222222222222
90863, -0.05, 1.6, 0.19444444444444
90864, -0.05, 1.575, 0.16666666666667
90865, -0.025, 1.6, 0.16666666666667
90866, -0.05, 1.6, 0.13888888888889
90867, -0.05, 1.575, 0.11111111111111
90868, -0.025, 1.6, 0.11111111111111
90869, -0.05, 1.6, 0.083333333333333
90870, -0.05, 1.575, 0.055555555555556
90871, -0.025, 1.6, 0.055555555555556
90872, -0.05, 1.6, 0.027777777777778
90873, -0.05, 1.65, 0.47222222222222
90874, -0.05, 1.625, 0.44444444444444
90875, -0.025, 1.65, 0.44444444444444
90876, -0.05, 1.65, 0.41666666666667
90877, -0.05, 1.625, 0.38888888888889
90878, -0.025, 1.65, 0.38888888888889
90879, -0.05, 1.65, 0.36111111111111
90880, -0.05, 1.625, 0.33333333333333
90881, -0.025, 1.65, 0.33333333333333
90882, -0.05, 1.65, 0.30555555555556
90883, -0.05, 1.625, 0.27777777777778
90884, -0.025, 1.65, 0.27777777777778
90885, -0.05, 1.65, 0.25
90886, -0.05, 1.625, 0.22222222222222
90887, -0.025, 1.65, 0.22222222222222
90888, -0.05, 1.65, 0.19444444444444
90889, -0.05, 1.625, 0.16666666666667
90890, -0.025, 1.65, 0.16666666666667
90891, -0.05, 1.65, 0.13888888888889
90892, -0.05, 1.625, 0.11111111111111
90893, -0.025, 1.65, 0.11111111111111
90894, -0.05, 1.65, 0.083333333333333
90895, -0.05, 1.625, 0.055555555555556
90896, -0.025, 1.65, 0.055555555555556
90897, -0.05, 1.65, 0.027777777777778
90898, -0.05, 1.7, 0.47222222222222
90899, -0.05, 1.675, 0.44444444444444
90900, -0.025, 1.7, 0.44444444444444
90901, -0.05, 1.7, 0.41666666666667
90902, -0.05, 1.675, 0.38888888888889
90903, -0.025, 1.7, 0.38888888888889
90904, -0.05, 1.7, 0.36111111111111
90905, -0.05, 1.675, 0.33333333333333
90906, -0.025, 1.7, 0.33333333333333
90907, -0.05, 1.7, 0.30555555555556
90908, -0.05, 1.675, 0.27777777777778
90909, -0.025, 1.7, 0.27777777777778
90910, -0.05, 1.7, 0.25
90911, -0.05, 1.675, 0.22222222222222
90912, -0.025, 1.7, 0.22222222222222
90913, -0.05, 1.7, 0.19444444444444
90914, -0.05, 1.675, 0.16666666666667
90915, -0.025, 1.7, 0.16666666666667
90916, -0.05, 1.7, 0.13888888888889
90917, -0.05, 1.675, 0.11111111111111
90918, -0.025, 1.7, 0.11111111111111
90919, -0.05, 1.7, 0.083333333333333
90920, -0.05, 1.675, 0.055555555555556
90921, -0.025, 1.7, 0.055555555555556
90922, -0.05, 1.7, 0.027777777777778
90923, -0.05, 1.725, 0.44444444444444
90924, -0.05, 1.725, 0.38888888888889
90925, -0.05, 1.725, 0.33333333333333
90926, -0.05, 1.725, 0.27777777777778
90927, -0.05, 1.725, 0.22222222222222
90928, -0.05, 1.725, 0.16666666666667
90929, -0.05, 1.725, 0.11111111111111
90930, -0.05, 1.725, 0.055555555555556
90931, -0.075, 1.6, 0.44444444444444
90932, -0.075, 1.6, 0.38888888888889
90933, -0.075, 1.6, 0.33333333333333
90934, -0.075, 1.6, 0.27777777777778
90935, -0.075, 1.6, 0.22222222222222
90936, -0.075, 1.6, 0.16666666666667
90937, -0.075, 1.6, 0.11111111111111
90938, -0.075, 1.6, 0.055555555555556
90939, -0.075, 1.65, 0.44444444444444
90940, -0.075, 1.65, 0.38888888888889
90941, -0.075, 1.65, 0.33333333333333
90942, -0.075, 1.65, 0.27777777777778
90943, -0.075, 1.65, 0.22222222222222
90944, -0.075, 1.65, 0.16666666666667
90945, -0.075, 1.65, 0.11111111111111
90946, -0.075, 1.65, 0.055555555555556
90947, -0.075, 1.7, 0.44444444444444
90948, -0.075, 1.7, 0.38888888888889
90949, -0.075, 1.7, 0.33333333333333
90950, -0.075, 1.7, 0.27777777777778
90951, -0.075, 1.7, 0.22222222222222
90952, -0.075, 1.7, 0.16666666666667
90953, -0.075, 1.7, 0.11111111111111
90954, -0.075, 1.7, 0.055555555555556
90955, 2.25, 1.6, 0.44444444444444
90956, 2.25, 1.6, 0.38888888888889
90957, 2.25, 1.6, 0.33333333333333
90958, 2.25, 1.6, 0.27777777777778
90959, 2.25, 1.6, 0.22222222222222
90960, 2.25, 1.6, 0.16666666666667
90961, 2.25, 1.6, 0.11111111111111
90962, 2.25, 1.6, 0.055555555555556
90963, 2.25, 1.65, 0.44444444444444
90964, 2.25, 1.65, 0.38888888888889
90965, 2.25, 1.65, 0.33333333333333
90966, 2.25, 1.65, 0.27777777777778
90967, 2.25, 1.65, 0.22222222222222
90968, 2.25, 1.65, 0.16666666666667
90969, 2.25, 1.65, 0.11111111111111
90970, 2.25, 1.65, 0.055555555555556
90971, 2.25, 1.7, 0.44444444444444
90972, 2.25, 1.7, 0.38888888888889
90973, 2.25, 1.7, 0.33333333333333
90974, 2.25, 1.7, 0.27777777777778
90975, 2.25, 1.7, 0.22222222222222
90976, 2.25, 1.7, 0.16666666666667
90977, 2.25, 1.7, 0.11111111111111
90978, 2.25, 1.7, 0.055555555555556
90979, 2.25, 1.6, 0.47222222222222
90980, 2.25, 1.575, 0.44444444444444
90981, 2.225, 1.6, 0.44444444444444
90982, 2.25, 1.6, 0.41666666666667
90983, 2.25, 1.575, 0.38888888888889
90984, 2.225, 1.6, 0.38888888888889
90985, 2.25, 1.6, 0.36111111111111
90986, 2.25, 1.575, 0.33333333333333
90987, 2.225, 1.6, 0.33333333333333
90988, 2.25, 1.6, 0.30555555555556
90989, 2.25, 1.575, 0.27777777777778
90990, 2.225, 1.6, 0.27777777777778
90991, 2.25, 1.6, 0.25
90992, 2.25, 1.575, 0.22222222222222
90993, 2.225, 1.6, 0.22222222222222
90994, 2.25, 1.6, 0.19444444444444
90995, 2.25, 1.575, 0.16666666666667
90996, 2.225, 1.6, 0.16666666666667
90997, 2.25, 1.6, 0.13888888888889
90998, 2.25, 1.575, 0.11111111111111
90999, 2.225, 1.6, 0.11111111111111
91000, 2.25, 1.6, 0.083333333333333
91001, 2.25, 1.575, 0.055555555555556
91002, 2.225, 1.6, 0.055555555555556
91003, 2.25, 1.6, 0.027777777777778
91004, 2.25, 1.65, 0.47222222222222
91005, 2.25, 1.625, 0.44444444444444
91006, 2.225, 1.65, 0.44444444444444
91007, 2.25, 1.65, 0.41666666666667
91008, 2.25, 1.625, 0.38888888888889
91009, 2.225, 1.65, 0.38888888888889
91010, 2.25, 1.65, 0.36111111111111
91011, 2.25, 1.625, 0.33333333333333
91012, 2.225, 1.65, 0.33333333333333
91013, 2.25, 1.65, 0.30555555555556
91014, 2.25, 1.625, 0.27777777777778
91015, 2.225, 1.65, 0.27777777777778
91016, 2.25, 1.65, 0.25
91017, 2.25, 1.625, 0.22222222222222
91018, 2.225, 1.65, 0.22222222222222
91019, 2.25, 1.65, 0.19444444444444
91020, 2.25, 1.625, 0.16666666666667
91021, 2.225, 1.65, 0.16666666666667
91022, 2.25, 1.65, 0.13888888888889
91023, 2.25, 1.625, 0.11111111111111
91024, 2.225, 1.65, 0.11111111111111
91025, 2.25, 1.65, 0.083333333333333
91026, 2.25, 1.625, 0.055555555555556
91027, 2.225, 1.65, 0.055555555555556
91028, 2.25, 1.65, 0.027777777777778
91029, 2.25, 1.7, 0.47222222222222
91030, 2.25, 1.675, 0.44444444444444
91031, 2.225, 1.7, 0.44444444444444
91032, 2.25, 1.7, 0.41666666666667
91033, 2.25, 1.675, 0.38888888888889
91034, 2.225, 1.7, 0.38888888888889
91035, 2.25, 1.7, 0.36111111111111
91036, 2.25, 1.675, 0.33333333333333
91037, 2.225, 1.7, 0.33333333333333
91038, 2.25, 1.7, 0.30555555555556
91039, 2.25, 1.675, 0.27777777777778
91040, 2.225, 1.7, 0.27777777777778
91041, 2.25, 1.7, 0.25
91042, 2.25, 1.675, 0.22222222222222
91043, 2.225, 1.7, 0.22222222222222
91044, 2.25, 1.7, 0.19444444444444
91045, 2.25, 1.675, 0.16666666666667
91046, 2.225, 1.7, 0.16666666666667
91047, 2.25, 1.7, 0.13888888888889
91048, 2.25, 1.675, 0.11111111111111
91049, 2.225, 1.7, 0.11111111111111
91050, 2.25, 1.7, 0.083333333333333
91051, 2.25, 1.675, 0.055555555555556
91052, 2.225, 1.7, 0.055555555555556
91053, 2.25, 1.7, 0.027777777777778
91054, 2.25, 1.725, 0.44444444444444
91055, 2.25, 1.725, 0.38888888888889
91056, 2.25, 1.725, 0.33333333333333
91057, 2.25, 1.725, 0.27777777777778
91058, 2.25, 1.725, 0.22222222222222
91059, 2.25, 1.725, 0.16666666666667
91060, 2.25, 1.725, 0.11111111111111
91061, 2.25, 1.725, 0.055555555555556
91062, 2.275, 1.6, 0.44444444444444
91063, 2.275, 1.6, 0.38888888888889
91064, 2.275, 1.6, 0.33333333333333
91065, 2.275, 1.6, 0.27777777777778
91066, 2.275, 1.6, 0.22222222222222
91067, 2.275, 1.6, 0.16666666666667
91068, 2.275, 1.6, 0.11111111111111
91069, 2.275, 1.6, 0.055555555555556
91070, 2.275, 1.65, 0.44444444444444
91071, 2.275, 1.65, 0.38888888888889
91072, 2.275, 1.65, 0.33333333333333
91073, 2.275, 1.65, 0.27777777777778
91074, 2.275, 1.65, 0.22222222222222
91075, 2.275, 1.65, 0.16666666666667
91076, 2.275, 1.65, 0.11111111111111
91077, 2.275, 1.65, 0.055555555555556
91078, 2.275, 1.7, 0.44444444444444
91079, 2.275, 1.7, 0.38888888888889
91080, 2.275, 1.7, 0.33333333333333
91081, 2.275, 1.7, 0.27777777777778
91082, 2.275, 1.7, 0.22222222222222
91083, 2.275, 1.7, 0.16666666666667
91084, 2.275, 1.7, 0.11111111111111
91085, 2.275, 1.7, 0.055555555555556
91086, 1.2434782608696, 0.075, 0.44444444444444
91087, 1.2434782608696, 0.075, 0.38888888888889
91088, 1.2434782608696, 0.075, 0.33333333333333
91089, 1.2434782608696, 0.075, 0.27777777777778
91090, 1.2434782608696, 0.075, 0.22222222222222
91091, 1.2434782608696, 0.075, 0.16666666666667
91092, 1.2434782608696, 0.075, 0.11111111111111
91093, 1.2434782608696, 0.075, 0.055555555555556
91094, 1.2869565217391, 0.075, 0.44444444444444
91095, 1.2869565217391, 0.075, 0.38888888888889
91096, 1.2869565217391, 0.075, 0.33333333333333
91097, 1.2869565217391, 0.075, 0.27777777777778
91098, 1.2869565217391, 0.075, 0.22222222222222
91099, 1.2869565217391, 0.075, 0.16666666666667
91100, 1.2869565217391, 0.075, 0.11111111111111
91101, 1.2869565217391, 0.075, 0.055555555555556
91102, 1.3304347826087, 0.075, 0.44444444444444
91103, 1.3304347826087, 0.075, 0.38888888888889
91104, 1.3304347826087, 0.075, 0.33333333333333
91105, 1.3304347826087, 0.075, 0.27777777777778
91106, 1.3304347826087, 0.075, 0.22222222222222
91107, 1.3304347826087, 0.075, 0.16666666666667
91108, 1.3304347826087, 0.075, 0.11111111111111
91109, 1.3304347826087, 0.075, 0.055555555555556
91110, 1.3739130434783, 0.075, 0.44444444444444
91111, 1.3739130434783, 0.075, 0.38888888888889
91112, 1.3739130434783, 0.075, 0.33333333333333
91113, 1.3739130434783, 0.075, 0.27777777777778
91114, 1.3739130434783, 0.075, 0.22222222222222
91115, 1.3739130434783, 0.075, 0.16666666666667
91116, 1.3739130434783, 0.075, 0.11111111111111
91117, 1.3739130434783, 0.075, 0.055555555555556
91118, 1.4173913043478, 0.075, 0.44444444444444
91119, 1.4173913043478, 0.075, 0.38888888888889
91120, 1.4173913043478, 0.075, 0.33333333333333
91121, 1.4173913043478, 0.075, 0.27777777777778
91122, 1.4173913043478, 0.075, 0.22222222222222
91123, 1.4173913043478, 0.075, 0.16666666666667
91124, 1.4173913043478, 0.075, 0.11111111111111
91125, 1.4173913043478, 0.075, 0.055555555555556
91126, 1.4608695652174, 0.075, 0.44444444444444
91127, 1.4608695652174, 0.075, 0.38888888888889
91128, 1.4608695652174, 0.075, 0.33333333333333
91129, 1.4608695652174, 0.075, 0.27777777777778
91130, 1.4608695652174, 0.075, 0.22222222222222
91131, 1.4608695652174, 0.075, 0.16666666666667
91132, 1.4608695652174, 0.075, 0.11111111111111
91133, 1.4608695652174, 0.075, 0.055555555555556
91134, 1.504347826087, 0.075, 0.44444444444444
91135, 1.504347826087, 0.075, 0.38888888888889
91136, 1.504347826087, 0.075, 0.33333333333333
91137, 1.504347826087, 0.075, 0.27777777777778
91138, 1.504347826087, 0.075, 0.22222222222222
91139, 1.504347826087, 0.075, 0.16666666666667
91140, 1.504347826087, 0.075, 0.11111111111111
91141, 1.504347826087, 0.075, 0.055555555555556
91142, 1.5478260869565, 0.075, 0.44444444444444
91143, 1.5478260869565, 0.075, 0.38888888888889
91144, 1.5478260869565, 0.075, 0.33333333333333
91145, 1.5478260869565, 0.075, 0.27777777777778
91146, 1.5478260869565, 0.075, 0.22222222222222
91147, 1.5478260869565, 0.075, 0.16666666666667
91148, 1.5478260869565, 0.075, 0.11111111111111
91149, 1.5478260869565, 0.075, 0.055555555555556
91150, 1.5913043478261, 0.075, 0.44444444444444
91151, 1.5913043478261, 0.075, 0.38888888888889
91152, 1.5913043478261, 0.075, 0.33333333333333
91153, 1.5913043478261, 0.075, 0.27777777777778
91154, 1.5913043478261, 0.075, 0.22222222222222
91155, 1.5913043478261, 0.075, 0.16666666666667
91156, 1.5913043478261, 0.075, 0.11111111111111
91157, 1.5913043478261, 0.075, 0.055555555555556
91158, 1.6347826086957, 0.075, 0.44444444444444
91159, 1.6347826086957, 0.075, 0.38888888888889
91160, 1.6347826086957, 0.075, 0.33333333333333
91161, 1.6347826086957, 0.075, 0.27777777777778
91162, 1.6347826086957, 0.075, 0.22222222222222
91163, 1.6347826086957, 0.075, 0.16666666666667
91164, 1.6347826086957, 0.075, 0.11111111111111
91165, 1.6347826086957, 0.075, 0.055555555555556
91166, 1.6782608695652, 0.075, 0.44444444444444
91167, 1.6782608695652, 0.075, 0.38888888888889
91168, 1.6782608695652, 0.075, 0.33333333333333
91169, 1.6782608695652, 0.075, 0.27777777777778
91170, 1.6782608695652, 0.075, 0.22222222222222
91171, 1.6782608695652, 0.075, 0.16666666666667
91172, 1.6782608695652, 0.075, 0.11111111111111
91173, 1.6782608695652, 0.075, 0.055555555555556
91174, 1.7217391304348, 0.075, 0.44444444444444
91175, 1.7217391304348, 0.075, 0.38888888888889
91176, 1.7217391304348, 0.075, 0.33333333333333
91177, 1.7217391304348, 0.075, 0.27777777777778
91178, 1.7217391304348, 0.075, 0.22222222222222
91179, 1.7217391304348, 0.075, 0.16666666666667
91180, 1.7217391304348, 0.075, 0.11111111111111
91181, 1.7217391304348, 0.075, 0.055555555555556
91182, 1.7652173913043, 0.075, 0.44444444444444
91183, 1.7652173913043, 0.075, 0.38888888888889
91184, 1.7652173913043, 0.075, 0.33333333333333
91185, 1.7652173913043, 0.075, 0.27777777777778
91186, 1.7652173913043, 0.075, 0.22222222222222
91187, 1.7652173913043, 0.075, 0.16666666666667
91188, 1.7652173913043, 0.075, 0.11111111111111
91189, 1.7652173913043, 0.075, 0.055555555555556
91190, 1.8086956521739, 0.075, 0.44444444444444
91191, 1.8086956521739, 0.075, 0.38888888888889
91192, 1.8086956521739, 0.075, 0.33333333333333
91193, 1.8086956521739, 0.075, 0.27777777777778
91194, 1.8086956521739, 0.075, 0.22222222222222
91195, 1.8086956521739, 0.075, 0.16666666666667
91196, 1.8086956521739, 0.075, 0.11111111111111
91197, 1.8086956521739, 0.075, 0.055555555555556
91198, 1.8521739130435, 0.075, 0.44444444444444
91199, 1.8521739130435, 0.075, 0.38888888888889
91200, 1.8521739130435, 0.075, 0.33333333333333
91201, 1.8521739130435, 0.075, 0.27777777777778
91202, 1.8521739130435, 0.075, 0.22222222222222
91203, 1.8521739130435, 0.075, 0.16666666666667
91204, 1.8521739130435, 0.075, 0.11111111111111
91205, 1.8521739130435, 0.075, 0.055555555555556
91206, 1.895652173913, 0.075, 0.44444444444444
91207, 1.895652173913, 0.075, 0.38888888888889
91208, 1.895652173913, 0.075, 0.33333333333333
91209, 1.895652173913, 0.075, 0.27777777777778
91210, 1.895652173913, 0.075, 0.22222222222222
91211, 1.895652173913, 0.075, 0.16666666666667
91212, 1.895652173913, 0.075, 0.11111111111111
91213, 1.895652173913, 0.075, 0.055555555555556
91214, 1.9391304347826, 0.075, 0.44444444444444
91215, 1.9391304347826, 0.075, 0.38888888888889
91216, 1.9391304347826, 0.075, 0.33333333333333
91217, 1.9391304347826, 0.075, 0.27777777777778
91218, 1.9391304347826, 0.075, 0.22222222222222
91219, 1.9391304347826, 0.075, 0.16666666666667
91220, 1.9391304347826, 0.075, 0.11111111111111
91221, 1.9391304347826, 0.075, 0.055555555555556
91222, 1.9826086956522, 0.075, 0.44444444444444
91223, 1.9826086956522, 0.075, 0.38888888888889
91224, 1.9826086956522, 0.075, 0.33333333333333
91225, 1.9826086956522, 0.075, 0.27777777777778
91226, 1.9826086956522, 0.075, 0.22222222222222
91227, 1.9826086956522, 0.075, 0.16666666666667
91228, 1.9826086956522, 0.075, 0.11111111111111
91229, 1.9826086956522, 0.075, 0.055555555555556
91230, 2.0260869565217, 0.075, 0.44444444444444
91231, 2.0260869565217, 0.075, 0.38888888888889
91232, 2.0260869565217, 0.075, 0.33333333333333
91233, 2.0260869565217, 0.075, 0.27777777777778
91234, 2.0260869565217, 0.075, 0.22222222222222
91235, 2.0260869565217, 0.075, 0.16666666666667
91236, 2.0260869565217, 0.075, 0.11111111111111
91237, 2.0260869565217, 0.075, 0.055555555555556
91238, 2.0695652173913, 0.075, 0.44444444444444
91239, 2.0695652173913, 0.075, 0.38888888888889
91240, 2.0695652173913, 0.075, 0.33333333333333
91241, 2.0695652173913, 0.075, 0.27777777777778
91242, 2.0695652173913, 0.075, 0.22222222222222
91243, 2.0695652173913, 0.075, 0.16666666666667
91244, 2.0695652173913, 0.075, 0.11111111111111
91245, 2.0695652173913, 0.075, 0.055555555555556
91246, 2.1130434782609, 0.075, 0.44444444444444
91247, 2.1130434782609, 0.075, 0.38888888888889
91248, 2.1130434782609, 0.075, 0.33333333333333
91249, 2.1130434782609, 0.075, 0.27777777777778
91250, 2.1130434782609, 0.075, 0.22222222222222
91251, 2.1130434782609, 0.075, 0.16666666666667
91252, 2.1130434782609, 0.075, 0.11111111111111
91253, 2.1130434782609, 0.075, 0.055555555555556
91254, 2.1565217391304, 0.075, 0.44444444444444
91255, 2.1565217391304, 0.075, 0.38888888888889
91256, 2.1565217391304, 0.075, 0.33333333333333
91257, 2.1565217391304, 0.075, 0.27777777777778
91258, 2.1565217391304, 0.075, 0.22222222222222
91259, 2.1565217391304, 0.075, 0.16666666666667
91260, 2.1565217391304, 0.075, 0.11111111111111
91261, 2.1565217391304, 0.075, 0.055555555555556
91262, 1.2434782608696, 0.075, 0.47222222222222
91263, 1.2217391304348, 0.075, 0.44444444444444
91264, 1.2434782608696, 0.0625, 0.44444444444444
91265, 1.2434782608696, 0.075, 0.41666666666667
91266, 1.2217391304348, 0.075, 0.38888888888889
91267, 1.2434782608696, 0.0625, 0.38888888888889
91268, 1.2434782608696, 0.075, 0.36111111111111
91269, 1.2217391304348, 0.075, 0.33333333333333
91270, 1.2434782608696, 0.0625, 0.33333333333333
91271, 1.2434782608696, 0.075, 0.30555555555556
91272, 1.2217391304348, 0.075, 0.27777777777778
91273, 1.2434782608696, 0.0625, 0.27777777777778
91274, 1.2434782608696, 0.075, 0.25
91275, 1.2217391304348, 0.075, 0.22222222222222
91276, 1.2434782608696, 0.0625, 0.22222222222222
91277, 1.2434782608696, 0.075, 0.19444444444444
91278, 1.2217391304348, 0.075, 0.16666666666667
91279, 1.2434782608696, 0.0625, 0.16666666666667
91280, 1.2434782608696, 0.075, 0.13888888888889
91281, 1.2217391304348, 0.075, 0.11111111111111
91282, 1.2434782608696, 0.0625, 0.11111111111111
91283, 1.2434782608696, 0.075, 0.083333333333333
91284, 1.2217391304348, 0.075, 0.055555555555556
91285, 1.2434782608696, 0.0625, 0.055555555555556
91286, 1.2434782608696, 0.075, 0.027777777777778
91287, 1.2869565217391, 0.075, 0.47222222222222
91288, 1.2652173913043, 0.075, 0.44444444444444
91289, 1.2869565217391, 0.0625, 0.44444444444444
91290, 1.2869565217391, 0.075, 0.41666666666667
91291, 1.2652173913043, 0.075, 0.38888888888889
91292, 1.2869565217391, 0.0625, 0.38888888888889
91293, 1.2869565217391, 0.075, 0.36111111111111
91294, 1.2652173913043, 0.075, 0.33333333333333
91295, 1.2869565217391, 0.0625, 0.33333333333333
91296, 1.2869565217391, 0.075, 0.30555555555556
91297, 1.2652173913043, 0.075, 0.27777777777778
91298, 1.2869565217391, 0.0625, 0.27777777777778
91299, 1.2869565217391, 0.075, 0.25
91300, 1.2652173913043, 0.075, 0.22222222222222
91301, 1.2869565217391, 0.0625, 0.22222222222222
91302, 1.2869565217391, 0.075, 0.19444444444444
91303, 1.2652173913043, 0.075, 0.16666666666667
91304, 1.2869565217391, 0.0625, 0.16666666666667
91305, 1.2869565217391, 0.075, 0.13888888888889
91306, 1.2652173913043, 0.075, 0.11111111111111
91307, 1.2869565217391, 0.0625, 0.11111111111111
91308, 1.2869565217391, 0.075, 0.083333333333333
91309, 1.2652173913043, 0.075, 0.055555555555556
91310, 1.2869565217391, 0.0625, 0.055555555555556
91311, 1.2869565217391, 0.075, 0.027777777777778
91312, 1.3304347826087, 0.075, 0.47222222222222
91313, 1.3086956521739, 0.075, 0.44444444444444
91314, 1.3304347826087, 0.0625, 0.44444444444444
91315, 1.3304347826087, 0.075, 0.41666666666667
91316, 1.3086956521739, 0.075, 0.38888888888889
91317, 1.3304347826087, 0.0625, 0.38888888888889
91318, 1.3304347826087, 0.075, 0.36111111111111
91319, 1.3086956521739, 0.075, 0.33333333333333
91320, 1.3304347826087, 0.0625, 0.33333333333333
91321, 1.3304347826087, 0.075, 0.30555555555556
91322, 1.3086956521739, 0.075, 0.27777777777778
91323, 1.3304347826087, 0.0625, 0.27777777777778
91324, 1.3304347826087, 0.075, 0.25
91325, 1.3086956521739, 0.075, 0.22222222222222
91326, 1.3304347826087, 0.0625, 0.22222222222222
91327, 1.3304347826087, 0.075, 0.19444444444444
91328, 1.3086956521739, 0.075, 0.16666666666667
91329, 1.3304347826087, 0.0625, 0.16666666666667
91330, 1.3304347826087, 0.075, 0.13888888888889
91331, 1.3086956521739, 0.075, 0.11111111111111
91332, 1.3304347826087, 0.0625, 0.11111111111111
91333, 1.3304347826087, 0.075, 0.083333333333333
91334, 1.3086956521739, 0.075, 0.055555555555556
91335, 1.3304347826087, 0.0625, 0.055555555555556
91336, 1.3304347826087, 0.075, 0.027777777777778
91337, 1.3739130434783, 0.075, 0.47222222222222
91338, 1.3521739130435, 0.075, 0.44444444444444
91339, 1.3739130434783, 0.0625, 0.44444444444444
91340, 1.3739130434783, 0.075, 0.41666666666667
91341, 1.3521739130435, 0.075, 0.38888888888889
91342, 1.3739130434783, 0.0625, 0.38888888888889
91343, 1.3739130434783, 0.075, 0.36111111111111
91344, 1.3521739130435, 0.075, 0.33333333333333
91345, 1.3739130434783, 0.0625, 0.33333333333333
91346, 1.3739130434783, 0.075, 0.30555555555556
91347, 1.3521739130435, 0.075, 0.27777777777778
91348, 1.3739130434783, 0.0625, 0.27777777777778
91349, 1.3739130434783, 0.075, 0.25
91350, 1.3521739130435, 0.075, 0.22222222222222
91351, 1.3739130434783, 0.0625, 0.22222222222222
91352, 1.3739130434783, 0.075, 0.19444444444444
91353, 1.3521739130435, 0.075, 0.16666666666667
91354, 1.3739130434783, 0.0625, 0.16666666666667
91355, 1.3739130434783, 0.075, 0.13888888888889
91356, 1.3521739130435, 0.075, 0.11111111111111
91357, 1.3739130434783, 0.0625, 0.11111111111111
91358, 1.3739130434783, 0.075, 0.083333333333333
91359, 1.3521739130435, 0.075, 0.055555555555556
91360, 1.3739130434783, 0.0625, 0.055555555555556
91361, 1.3739130434783, 0.075, 0.027777777777778
91362, 1.4173913043478, 0.075, 0.47222222222222
91363, 1.395652173913, 0.075, 0.44444444444444
91364, 1.4173913043478, 0.0625, 0.44444444444444
91365, 1.4173913043478, 0.075, 0.41666666666667
91366, 1.395652173913, 0.075, 0.38888888888889
91367, 1.4173913043478, 0.0625, 0.38888888888889
91368, 1.4173913043478, 0.075, 0.36111111111111
91369, 1.395652173913, 0.075, 0.33333333333333
91370, 1.4173913043478, 0.0625, 0.33333333333333
91371, 1.4173913043478, 0.075, 0.30555555555556
91372, 1.395652173913, 0.075, 0.27777777777778
91373, 1.4173913043478, 0.0625, 0.27777777777778
91374, 1.4173913043478, 0.075, 0.25
91375, 1.395652173913, 0.075, 0.22222222222222
91376, 1.4173913043478, 0.0625, 0.22222222222222
91377, 1.4173913043478, 0.075, 0.19444444444444
91378, 1.395652173913, 0.075, 0.16666666666667
91379, 1.4173913043478, 0.0625, 0.16666666666667
91380, 1.4173913043478, 0.075, 0.13888888888889
91381, 1.395652173913, 0.075, 0.11111111111111
91382, 1.4173913043478, 0.0625, 0.11111111111111
91383, 1.4173913043478, 0.075, 0.083333333333333
91384, 1.395652173913, 0.075, 0.055555555555556
91385, 1.4173913043478, 0.0625, 0.055555555555556
91386, 1.4173913043478, 0.075, 0.027777777777778
91387, 1.4608695652174, 0.075, 0.47222222222222
91388, 1.4391304347826, 0.075, 0.44444444444444
91389, 1.4608695652174, 0.0625, 0.44444444444444
91390, 1.4608695652174, 0.075, 0.41666666666667
91391, 1.4391304347826, 0.075, 0.38888888888889
91392, 1.4608695652174, 0.0625, 0.38888888888889
91393, 1.4608695652174, 0.075, 0.36111111111111
91394, 1.4391304347826, 0.075, 0.33333333333333
91395, 1.4608695652174, 0.0625, 0.33333333333333
91396, 1.4608695652174, 0.075, 0.30555555555556
91397, 1.4391304347826, 0.075, 0.27777777777778
91398, 1.4608695652174, 0.0625, 0.27777777777778
91399, 1.4608695652174, 0.075, 0.25
91400, 1.4391304347826, 0.075, 0.22222222222222
91401, 1.4608695652174, 0.0625, 0.22222222222222
91402, 1.4608695652174, 0.075, 0.19444444444444
91403, 1.4391304347826, 0.075, 0.16666666666667
91404, 1.4608695652174, 0.0625, 0.16666666666667
91405, 1.4608695652174, 0.075, 0.13888888888889
91406, 1.4391304347826, 0.075, 0.11111111111111
91407, 1.4608695652174, 0.0625, 0.11111111111111
91408, 1.4608695652174, 0.075, 0.083333333333333
91409, 1.4391304347826, 0.075, 0.055555555555556
91410, 1.4608695652174, 0.0625, 0.055555555555556
91411, 1.4608695652174, 0.075, 0.027777777777778
91412, 1.504347826087, 0.075, 0.47222222222222
91413, 1.4826086956522, 0.075, 0.44444444444444
91414, 1.504347826087, 0.0625, 0.44444444444444
91415, 1.504347826087, 0.075, 0.41666666666667
91416, 1.4826086956522, 0.075, 0.38888888888889
91417, 1.504347826087, 0.0625, 0.38888888888889
91418, 1.504347826087, 0.075, 0.36111111111111
91419, 1.4826086956522, 0.075, 0.33333333333333
91420, 1.504347826087, 0.0625, 0.33333333333333
91421, 1.504347826087, 0.075, 0.30555555555556
91422, 1.4826086956522, 0.075, 0.27777777777778
91423, 1.504347826087, 0.0625, 0.27777777777778
91424, 1.504347826087, 0.075, 0.25
91425, 1.4826086956522, 0.075, 0.22222222222222
91426, 1.504347826087, 0.0625, 0.22222222222222
91427, 1.504347826087, 0.075, 0.19444444444444
91428, 1.4826086956522, 0.075, 0.16666666666667
91429, 1.504347826087, 0.0625, 0.16666666666667
91430, 1.504347826087, 0.075, 0.13888888888889
91431, 1.4826086956522, 0.075, 0.11111111111111
91432, 1.504347826087, 0.0625, 0.11111111111111
91433, 1.504347826087, 0.075, 0.083333333333333
91434, 1.4826086956522, 0.075, 0.055555555555556
91435, 1.504347826087, 0.0625, 0.055555555555556
91436, 1.504347826087, 0.075, 0.027777777777778
91437, 1.5478260869565, 0.075, 0.47222222222222
91438, 1.5260869565217, 0.075, 0.44444444444444
91439, 1.5478260869565, 0.0625, 0.44444444444444
91440, 1.5478260869565, 0.075, 0.41666666666667
91441, 1.5260869565217, 0.075, 0.38888888888889
91442, 1.5478260869565, 0.0625, 0.38888888888889
91443, 1.5478260869565, 0.075, 0.36111111111111
91444, 1.5260869565217, 0.075, 0.33333333333333
91445, 1.5478260869565, 0.0625, 0.33333333333333
91446, 1.5478260869565, 0.075, 0.30555555555556
91447, 1.5260869565217, 0.075, 0.27777777777778
91448, 1.5478260869565, 0.0625, 0.27777777777778
91449, 1.5478260869565, 0.075, 0.25
91450, 1.5260869565217, 0.075, 0.22222222222222
91451, 1.5478260869565, 0.0625, 0.22222222222222
91452, 1.5478260869565, 0.075, 0.19444444444444
91453, 1.5260869565217, 0.075, 0.16666666666667
91454, 1.5478260869565, 0.0625, 0.16666666666667
91455, 1.5478260869565, 0.075, 0.13888888888889
91456, 1.5260869565217, 0.075, 0.11111111111111
91457, 1.5478260869565, 0.0625, 0.11111111111111
91458, 1.5478260869565, 0.075, 0.083333333333333
91459, 1.5260869565217, 0.075, 0.055555555555556
91460, 1.5478260869565, 0.0625, 0.055555555555556
91461, 1.5478260869565, 0.075, 0.027777777777778
91462, 1.5913043478261, 0.075, 0.47222222222222
91463, 1.5695652173913, 0.075, 0.44444444444444
91464, 1.5913043478261, 0.0625, 0.44444444444444
91465, 1.5913043478261, 0.075, 0.41666666666667
91466, 1.5695652173913, 0.075, 0.38888888888889
91467, 1.5913043478261, 0.0625, 0.38888888888889
91468, 1.5913043478261, 0.075, 0.36111111111111
91469, 1.5695652173913, 0.075, 0.33333333333333
91470, 1.5913043478261, 0.0625, 0.33333333333333
91471, 1.5913043478261, 0.075, 0.30555555555556
91472, 1.5695652173913, 0.075, 0.27777777777778
91473, 1.5913043478261, 0.0625, 0.27777777777778
91474, 1.5913043478261, 0.075, 0.25
91475, 1.5695652173913, 0.075, 0.22222222222222
91476, 1.5913043478261, 0.0625, 0.22222222222222
91477, 1.5913043478261, 0.075, 0.19444444444444
91478, 1.5695652173913, 0.075, 0.16666666666667
91479, 1.5913043478261, 0.0625, 0.16666666666667
91480, 1.5913043478261, 0.075, 0.13888888888889
91481, 1.5695652173913, 0.075, 0.11111111111111
91482, 1.5913043478261, 0.0625, 0.11111111111111
91483, 1.5913043478261, 0.075, 0.083333333333333
91484, 1.5695652173913, 0.075, 0.055555555555556
91485, 1.5913043478261, 0.0625, 0.055555555555556
91486, 1.5913043478261, 0.075, 0.027777777777778
91487, 1.6347826086957, 0.075, 0.47222222222222
91488, 1.6130434782609, 0.075, 0.44444444444444
91489, 1.6347826086957, 0.0625, 0.44444444444444
91490, 1.6347826086957, 0.075, 0.41666666666667
91491, 1.6130434782609, 0.075, 0.38888888888889
91492, 1.6347826086957, 0.0625, 0.38888888888889
91493, 1.6347826086957, 0.075, 0.36111111111111
91494, 1.6130434782609, 0.075, 0.33333333333333
91495, 1.6347826086957, 0.0625, 0.33333333333333
91496, 1.6347826086957, 0.075, 0.30555555555556
91497, 1.6130434782609, 0.075, 0.27777777777778
91498, 1.6347826086957, 0.0625, 0.27777777777778
91499, 1.6347826086957, 0.075, 0.25
91500, 1.6130434782609, 0.075, 0.22222222222222
91501, 1.6347826086957, 0.0625, 0.22222222222222
91502, 1.6347826086957, 0.075, 0.19444444444444
91503, 1.6130434782609, 0.075, 0.16666666666667
91504, 1.6347826086957, 0.0625, 0.16666666666667
91505, 1.6347826086957, 0.075, 0.13888888888889
91506, 1.6130434782609, 0.075, 0.11111111111111
91507, 1.6347826086957, 0.0625, 0.11111111111111
91508, 1.6347826086957, 0.075, 0.083333333333333
91509, 1.6130434782609, 0.075, 0.055555555555556
91510, 1.6347826086957, 0.0625, 0.055555555555556
91511, 1.6347826086957, 0.075, 0.027777777777778
91512, 1.6782608695652, 0.075, 0.47222222222222
91513, 1.6565217391304, 0.075, 0.44444444444444
91514, 1.6782608695652, 0.0625, 0.44444444444444
91515, 1.6782608695652, 0.075, 0.41666666666667
91516, 1.6565217391304, 0.075, 0.38888888888889
91517, 1.6782608695652, 0.0625, 0.38888888888889
91518, 1.6782608695652, 0.075, 0.36111111111111
91519, 1.6565217391304, 0.075, 0.33333333333333
91520, 1.6782608695652, 0.0625, 0.33333333333333
91521, 1.6782608695652, 0.075, 0.30555555555556
91522, 1.6565217391304, 0.075, 0.27777777777778
91523, 1.6782608695652, 0.0625, 0.27777777777778
91524, 1.6782608695652, 0.075, 0.25
91525, 1.6565217391304, 0.075, 0.22222222222222
91526, 1.6782608695652, 0.0625, 0.22222222222222
91527, 1.6782608695652, 0.075, 0.19444444444444
91528, 1.6565217391304, 0.075, 0.16666666666667
91529, 1.6782608695652, 0.0625, 0.16666666666667
91530, 1.6782608695652, 0.075, 0.13888888888889
91531, 1.6565217391304, 0.075, 0.11111111111111
91532, 1.6782608695652, 0.0625, 0.11111111111111
91533, 1.6782608695652, 0.075, 0.083333333333333
91534, 1.6565217391304, 0.075, 0.055555555555556
91535, 1.6782608695652, 0.0625, 0.055555555555556
91536, 1.6782608695652, 0.075, 0.027777777777778
91537, 1.7217391304348, 0.075, 0.47222222222222
91538, 1.7, 0.075, 0.44444444444444
91539, 1.7217391304348, 0.0625, 0.44444444444444
91540, 1.7217391304348, 0.075, 0.41666666666667
91541, 1.7, 0.075, 0.38888888888889
91542, 1.7217391304348, 0.0625, 0.38888888888889
91543, 1.7217391304348, 0.075, 0.36111111111111
91544, 1.7, 0.075, 0.33333333333333
91545, 1.7217391304348, 0.0625, 0.33333333333333
91546, 1.7217391304348, 0.075, 0.30555555555556
91547, 1.7, 0.075, 0.27777777777778
91548, 1.7217391304348, 0.0625, 0.27777777777778
91549, 1.7217391304348, 0.075, 0.25
91550, 1.7, 0.075, 0.22222222222222
91551, 1.7217391304348, 0.0625, 0.22222222222222
91552, 1.7217391304348, 0.075, 0.19444444444444
91553, 1.7, 0.075, 0.16666666666667
91554, 1.7217391304348, 0.0625, 0.16666666666667
91555, 1.7217391304348, 0.075, 0.13888888888889
91556, 1.7, 0.075, 0.11111111111111
91557, 1.7217391304348, 0.0625, 0.11111111111111
91558, 1.7217391304348, 0.075, 0.083333333333333
91559, 1.7, 0.075, 0.055555555555556
91560, 1.7217391304348, 0.0625, 0.055555555555556
91561, 1.7217391304348, 0.075, 0.027777777777778
91562, 1.7652173913043, 0.075, 0.47222222222222
91563, 1.7434782608696, 0.075, 0.44444444444444
91564, 1.7652173913043, 0.0625, 0.44444444444444
91565, 1.7652173913043, 0.075, 0.41666666666667
91566, 1.7434782608696, 0.075, 0.38888888888889
91567, 1.7652173913043, 0.0625, 0.38888888888889
91568, 1.7652173913043, 0.075, 0.36111111111111
91569, 1.7434782608696, 0.075, 0.33333333333333
91570, 1.7652173913043, 0.0625, 0.33333333333333
91571, 1.7652173913043, 0.075, 0.30555555555556
91572, 1.7434782608696, 0.075, 0.27777777777778
91573, 1.7652173913043, 0.0625, 0.27777777777778
91574, 1.7652173913043, 0.075, 0.25
91575, 1.7434782608696, 0.075, 0.22222222222222
91576, 1.7652173913043, 0.0625, 0.22222222222222
91577, 1.7652173913043, 0.075, 0.19444444444444
91578, 1.7434782608696, 0.075, 0.16666666666667
91579, 1.7652173913043, 0.0625, 0.16666666666667
91580, 1.7652173913043, 0.075, 0.13888888888889
91581, 1.7434782608696, 0.075, 0.11111111111111
91582, 1.7652173913043, 0.0625, 0.11111111111111
91583, 1.7652173913043, 0.075, 0.083333333333333
91584, 1.7434782608696, 0.075, 0.055555555555556
91585, 1.7652173913043, 0.0625, 0.055555555555556
91586, 1.7652173913043, 0.075, 0.027777777777778
91587, 1.8086956521739, 0.075, 0.47222222222222
91588, 1.7869565217391, 0.075, 0.44444444444444
91589, 1.8086956521739, 0.0625, 0.44444444444444
91590, 1.8086956521739, 0.075, 0.41666666666667
91591, 1.7869565217391, 0.075, 0.38888888888889
91592, 1.8086956521739, 0.0625, 0.38888888888889
91593, 1.8086956521739, 0.075, 0.36111111111111
91594, 1.7869565217391, 0.075, 0.33333333333333
91595, 1.8086956521739, 0.0625, 0.33333333333333
91596, 1.8086956521739, 0.075, 0.30555555555556
91597, 1.7869565217391, 0.075, 0.27777777777778
91598, 1.8086956521739, 0.0625, 0.27777777777778
91599, 1.8086956521739, 0.075, 0.25
91600, 1.7869565217391, 0.075, 0.22222222222222
91601, 1.8086956521739, 0.0625, 0.22222222222222
91602, 1.8086956521739, 0.075, 0.19444444444444
91603, 1.7869565217391, 0.075, 0.16666666666667
91604, 1.8086956521739, 0.0625, 0.16666666666667
91605, 1.8086956521739, 0.075, 0.13888888888889
91606, 1.7869565217391, 0.075, 0.11111111111111
91607, 1.8086956521739, 0.0625, 0.11111111111111
91608, 1.8086956521739, 0.075, 0.083333333333333
91609, 1.7869565217391, 0.075, 0.055555555555556
91610, 1.8086956521739, 0.0625, 0.055555555555556
91611, 1.8086956521739, 0.075, 0.027777777777778
91612, 1.8521739130435, 0.075, 0.47222222222222
91613, 1.8304347826087, 0.075, 0.44444444444444
91614, 1.8521739130435, 0.0625, 0.44444444444444
91615, 1.8521739130435, 0.075, 0.41666666666667
91616, 1.8304347826087, 0.075, 0.38888888888889
91617, 1.8521739130435, 0.0625, 0.38888888888889
91618, 1.8521739130435, 0.075, 0.36111111111111
91619, 1.8304347826087, 0.075, 0.33333333333333
91620, 1.8521739130435, 0.0625, 0.33333333333333
91621, 1.8521739130435, 0.075, 0.30555555555556
91622, 1.8304347826087, 0.075, 0.27777777777778
91623, 1.8521739130435, 0.0625, 0.27777777777778
91624, 1.8521739130435, 0.075, 0.25
91625, 1.8304347826087, 0.075, 0.22222222222222
91626, 1.8521739130435, 0.0625, 0.22222222222222
91627, 1.8521739130435, 0.075, 0.19444444444444
91628, 1.8304347826087, 0.075, 0.16666666666667
91629, 1.8521739130435, 0.0625, 0.16666666666667
91630, 1.8521739130435, 0.075, 0.13888888888889
91631, 1.8304347826087, 0.075, 0.11111111111111
91632, 1.8521739130435, 0.0625, 0.11111111111111
91633, 1.8521739130435, 0.075, 0.083333333333333
91634, 1.8304347826087, 0.075, 0.055555555555556
91635, 1.8521739130435, 0.0625, 0.055555555555556
91636, 1.8521739130435, 0.075, 0.027777777777778
91637, 1.895652173913, 0.075, 0.47222222222222
91638, 1.8739130434783, 0.075, 0.44444444444444
91639, 1.895652173913, 0.0625, 0.44444444444444
91640, 1.895652173913, 0.075, 0.41666666666667
91641, 1.8739130434783, 0.075, 0.38888888888889
91642, 1.895652173913, 0.0625, 0.38888888888889
91643, 1.895652173913, 0.075, 0.36111111111111
91644, 1.8739130434783, 0.075, 0.33333333333333
91645, 1.895652173913, 0.0625, 0.33333333333333
91646, 1.895652173913, 0.075, 0.30555555555556
91647, 1.8739130434783, 0.075, 0.27777777777778
91648, 1.895652173913, 0.0625, 0.27777777777778
91649, 1.895652173913, 0.075, 0.25
91650, 1.8739130434783, 0.075, 0.22222222222222
91651, 1.895652173913, 0.0625, 0.22222222222222
91652, 1.895652173913, 0.075, 0.19444444444444
91653, 1.8739130434783, 0.075, 0.16666666666667
91654, 1.895652173913, 0.0625, 0.16666666666667
91655, 1.895652173913, 0.075, 0.13888888888889
91656, 1.8739130434783, 0.075, 0.11111111111111
91657, 1.895652173913, 0.0625, 0.11111111111111
91658, 1.895652173913, 0.075, 0.083333333333333
91659, 1.8739130434783, 0.075, 0.055555555555556
91660, 1.895652173913, 0.0625, 0.055555555555556
91661, 1.895652173913, 0.075, 0.027777777777778
91662, 1.9391304347826, 0.075, 0.47222222222222
91663, 1.9173913043478, 0.075, 0.44444444444444
91664, 1.9391304347826, 0.0625, 0.44444444444444
91665, 1.9391304347826, 0.075, 0.41666666666667
91666, 1.9173913043478, 0.075, 0.38888888888889
91667, 1.9391304347826, 0.0625, 0.38888888888889
91668, 1.9391304347826, 0.075, 0.36111111111111
91669, 1.9173913043478, 0.075, 0.33333333333333
91670, 1.9391304347826, 0.0625, 0.33333333333333
91671, 1.9391304347826, 0.075, 0.30555555555556
91672, 1.9173913043478, 0.075, 0.27777777777778
91673, 1.9391304347826, 0.0625, 0.27777777777778
91674, 1.9391304347826, 0.075, 0.25
91675, 1.9173913043478, 0.075, 0.22222222222222
91676, 1.9391304347826, 0.0625, 0.22222222222222
91677, 1.9391304347826, 0.075, 0.19444444444444
91678, 1.9173913043478, 0.075, 0.16666666666667
91679, 1.9391304347826, 0.0625, 0.16666666666667
91680, 1.9391304347826, 0.075, 0.13888888888889
91681, 1.9173913043478, 0.075, 0.11111111111111
91682, 1.9391304347826, 0.0625, 0.11111111111111
91683, 1.9391304347826, 0.075, 0.083333333333333
91684, 1.9173913043478, 0.075, 0.055555555555556
91685, 1.9391304347826, 0.0625, 0.055555555555556
91686, 1.9391304347826, 0.075, 0.027777777777778
91687, 1.9826086956522, 0.075, 0.47222222222222
91688, 1.9608695652174, 0.075, 0.44444444444444
91689, 1.9826086956522, 0.0625, 0.44444444444444
91690, 1.9826086956522, 0.075, 0.41666666666667
91691, 1.9608695652174, 0.075, 0.38888888888889
91692, 1.9826086956522, 0.0625, 0.38888888888889
91693, 1.9826086956522, 0.075, 0.36111111111111
91694, 1.9608695652174, 0.075, 0.33333333333333
91695, 1.9826086956522, 0.0625, 0.33333333333333
91696, 1.9826086956522, 0.075, 0.30555555555556
91697, 1.9608695652174, 0.075, 0.27777777777778
91698, 1.9826086956522, 0.0625, 0.27777777777778
91699, 1.9826086956522, 0.075, 0.25
91700, 1.9608695652174, 0.075, 0.22222222222222
91701, 1.9826086956522, 0.0625, 0.22222222222222
91702, 1.9826086956522, 0.075, 0.19444444444444
91703, 1.9608695652174, 0.075, 0.16666666666667
91704, 1.9826086956522, 0.0625, 0.16666666666667
91705, 1.9826086956522, 0.075, 0.13888888888889
91706, 1.9608695652174, 0.075, 0.11111111111111
91707, 1.9826086956522, 0.0625, 0.11111111111111
91708, 1.9826086956522, 0.075, 0.083333333333333
91709, 1.9608695652174, 0.075, 0.055555555555556
91710, 1.9826086956522, 0.0625, 0.055555555555556
91711, 1.9826086956522, 0.075, 0.027777777777778
91712, 2.0260869565217, 0.075, 0.47222222222222
91713, 2.004347826087, 0.075, 0.44444444444444
91714, 2.0260869565217, 0.0625, 0.44444444444444
91715, 2.0260869565217, 0.075, 0.41666666666667
91716, 2.004347826087, 0.075, 0.38888888888889
91717, 2.0260869565217, 0.0625, 0.38888888888889
91718, 2.0260869565217, 0.075, 0.36111111111111
91719, 2.004347826087, 0.075, 0.33333333333333
91720, 2.0260869565217, 0.0625, 0.33333333333333
91721, 2.0260869565217, 0.075, 0.30555555555556
91722, 2.004347826087, 0.075, 0.27777777777778
91723, 2.0260869565217, 0.0625, 0.27777777777778
91724, 2.0260869565217, 0.075, 0.25
91725, 2.004347826087, 0.075, 0.22222222222222
91726, 2.0260869565217, 0.0625, 0.22222222222222
91727, 2.0260869565217, 0.075, 0.19444444444444
91728, 2.004347826087, 0.075, 0.16666666666667
91729, 2.0260869565217, 0.0625, 0.16666666666667
91730, 2.0260869565217, 0.075, 0.13888888888889
91731, 2.004347826087, 0.075, 0.11111111111111
91732, 2.0260869565217, 0.0625, 0.11111111111111
91733, 2.0260869565217, 0.075, 0.083333333333333
91734, 2.004347826087, 0.075, 0.055555555555556
91735, 2.0260869565217, 0.0625, 0.055555555555556
91736, 2.0260869565217, 0.075, 0.027777777777778
91737, 2.0695652173913, 0.075, 0.47222222222222
91738, 2.0478260869565, 0.075, 0.44444444444444
91739, 2.0695652173913, 0.0625, 0.44444444444444
91740, 2.0695652173913, 0.075, 0.41666666666667
91741, 2.0478260869565, 0.075, 0.38888888888889
91742, 2.0695652173913, 0.0625, 0.38888888888889
91743, 2.0695652173913, 0.075, 0.36111111111111
91744, 2.0478260869565, 0.075, 0.33333333333333
91745, 2.0695652173913, 0.0625, 0.33333333333333
91746, 2.0695652173913, 0.075, 0.30555555555556
91747, 2.0478260869565, 0.075, 0.27777777777778
91748, 2.0695652173913, 0.0625, 0.27777777777778
91749, 2.0695652173913, 0.075, 0.25
91750, 2.0478260869565, 0.075, 0.22222222222222
91751, 2.0695652173913, 0.0625, 0.22222222222222
91752, 2.0695652173913, 0.075, 0.19444444444444
91753, 2.0478260869565, 0.075, 0.16666666666667
91754, 2.0695652173913, 0.0625, 0.16666666666667
91755, 2.0695652173913, 0.075, 0.13888888888889
91756, 2.0478260869565, 0.075, 0.11111111111111
91757, 2.0695652173913, 0.0625, 0.11111111111111
91758, 2.0695652173913, 0.075, 0.083333333333333
91759, 2.0478260869565, 0.075, 0.055555555555556
91760, 2.0695652173913, 0.0625, 0.055555555555556
91761, 2.0695652173913, 0.075, 0.027777777777778
91762, 2.1130434782609, 0.075, 0.47222222222222
91763, 2.0913043478261, 0.075, 0.44444444444444
91764, 2.1130434782609, 0.0625, 0.44444444444444
91765, 2.1130434782609, 0.075, 0.41666666666667
91766, 2.0913043478261, 0.075, 0.38888888888889
91767, 2.1130434782609, 0.0625, 0.38888888888889
91768, 2.1130434782609, 0.075, 0.36111111111111
91769, 2.0913043478261, 0.075, 0.33333333333333
91770, 2.1130434782609, 0.0625, 0.33333333333333
91771, 2.1130434782609, 0.075, 0.30555555555556
91772, 2.0913043478261, 0.075, 0.27777777777778
91773, 2.1130434782609, 0.0625, 0.27777777777778
91774, 2.1130434782609, 0.075, 0.25
91775, 2.0913043478261, 0.075, 0.22222222222222
91776, 2.1130434782609, 0.0625, 0.22222222222222
91777, 2.1130434782609, 0.075, 0.19444444444444
91778, 2.0913043478261, 0.075, 0.16666666666667
91779, 2.1130434782609, 0.0625, 0.16666666666667
91780, 2.1130434782609, 0.075, 0.13888888888889
91781, 2.0913043478261, 0.075, 0.11111111111111
91782, 2.1130434782609, 0.0625, 0.11111111111111
91783, 2.1130434782609, 0.075, 0.083333333333333
91784, 2.0913043478261, 0.075, 0.055555555555556
91785, 2.1130434782609, 0.0625, 0.055555555555556
91786, 2.1130434782609, 0.075, 0.027777777777778
91787, 2.1565217391304, 0.075, 0.47222222222222
91788, 2.1347826086957, 0.075, 0.44444444444444
91789, 2.1565217391304, 0.0625, 0.44444444444444
91790, 2.1565217391304, 0.075, 0.41666666666667
91791, 2.1347826086957, 0.075, 0.38888888888889
91792, 2.1565217391304, 0.0625, 0.38888888888889
91793, 2.1565217391304, 0.075, 0.36111111111111
91794, 2.1347826086957, 0.075, 0.33333333333333
91795, 2.1565217391304, 0.0625, 0.33333333333333
91796, 2.1565217391304, 0.075, 0.30555555555556
91797, 2.1347826086957, 0.075, 0.27777777777778
91798, 2.1565217391304, 0.0625, 0.27777777777778
91799, 2.1565217391304, 0.075, 0.25
91800, 2.1347826086957, 0.075, 0.22222222222222
91801, 2.1565217391304, 0.0625, 0.22222222222222
91802, 2.1565217391304, 0.075, 0.19444444444444
91803, 2.1347826086957, 0.075, 0.16666666666667
91804, 2.1565217391304, 0.0625, 0.16666666666667
91805, 2.1565217391304, 0.075, 0.13888888888889
91806, 2.1347826086957, 0.075, 0.11111111111111
91807, 2.1565217391304, 0.0625, 0.11111111111111
91808, 2.1565217391304, 0.075, 0.083333333333333
91809, 2.1347826086957, 0.075, 0.055555555555556
91810, 2.1565217391304, 0.0625, 0.055555555555556
91811, 2.1565217391304, 0.075, 0.027777777777778
91812, 2.1782608695652, 0.075, 0.44444444444444
91813, 2.1782608695652, 0.075, 0.38888888888889
91814, 2.1782608695652, 0.075, 0.33333333333333
91815, 2.1782608695652, 0.075, 0.27777777777778
91816, 2.1782608695652, 0.075, 0.22222222222222
91817, 2.1782608695652, 0.075, 0.16666666666667
91818, 2.1782608695652, 0.075, 0.11111111111111
91819, 2.1782608695652, 0.075, 0.055555555555556
91820, 1.2434782608696, 0.0875, 0.44444444444444
91821, 1.2434782608696, 0.0875, 0.38888888888889
91822, 1.2434782608696, 0.0875, 0.33333333333333
91823, 1.2434782608696, 0.0875, 0.27777777777778
91824, 1.2434782608696, 0.0875, 0.22222222222222
91825, 1.2434782608696, 0.0875, 0.16666666666667
91826, 1.2434782608696, 0.0875, 0.11111111111111
91827, 1.2434782608696, 0.0875, 0.055555555555556
91828, 1.2869565217391, 0.0875, 0.44444444444444
91829, 1.2869565217391, 0.0875, 0.38888888888889
91830, 1.2869565217391, 0.0875, 0.33333333333333
91831, 1.2869565217391, 0.0875, 0.27777777777778
91832, 1.2869565217391, 0.0875, 0.22222222222222
91833, 1.2869565217391, 0.0875, 0.16666666666667
91834, 1.2869565217391, 0.0875, 0.11111111111111
91835, 1.2869565217391, 0.0875, 0.055555555555556
91836, 1.3304347826087, 0.0875, 0.44444444444444
91837, 1.3304347826087, 0.0875, 0.38888888888889
91838, 1.3304347826087, 0.0875, 0.33333333333333
91839, 1.3304347826087, 0.0875, 0.27777777777778
91840, 1.3304347826087, 0.0875, 0.22222222222222
91841, 1.3304347826087, 0.0875, 0.16666666666667
91842, 1.3304347826087, 0.0875, 0.11111111111111
91843, 1.3304347826087, 0.0875, 0.055555555555556
91844, 1.3739130434783, 0.0875, 0.44444444444444
91845, 1.3739130434783, 0.0875, 0.38888888888889
91846, 1.3739130434783, 0.0875, 0.33333333333333
91847, 1.3739130434783, 0.0875, 0.27777777777778
91848, 1.3739130434783, 0.0875, 0.22222222222222
91849, 1.3739130434783, 0.0875, 0.16666666666667
91850, 1.3739130434783, 0.0875, 0.11111111111111
91851, 1.3739130434783, 0.0875, 0.055555555555556
91852, 1.4173913043478, 0.0875, 0.44444444444444
91853, 1.4173913043478, 0.0875, 0.38888888888889
91854, 1.4173913043478, 0.0875, 0.33333333333333
91855, 1.4173913043478, 0.0875, 0.27777777777778
91856, 1.4173913043478, 0.0875, 0.22222222222222
91857, 1.4173913043478, 0.0875, 0.16666666666667
91858, 1.4173913043478, 0.0875, 0.11111111111111
91859, 1.4173913043478, 0.0875, 0.055555555555556
91860, 1.4608695652174, 0.0875, 0.44444444444444
91861, 1.4608695652174, 0.0875, 0.38888888888889
91862, 1.4608695652174, 0.0875, 0.33333333333333
91863, 1.4608695652174, 0.0875, 0.27777777777778
91864, 1.4608695652174, 0.0875, 0.22222222222222
91865, 1.4608695652174, 0.0875, 0.16666666666667
91866, 1.4608695652174, 0.0875, 0.11111111111111
91867, 1.4608695652174, 0.0875, 0.055555555555556
91868, 1.504347826087, 0.0875, 0.44444444444444
91869, 1.504347826087, 0.0875, 0.38888888888889
91870, 1.504347826087, 0.0875, 0.33333333333333
91871, 1.504347826087, 0.0875, 0.27777777777778
91872, 1.504347826087, 0.0875, 0.22222222222222
91873, 1.504347826087, 0.0875, 0.16666666666667
91874, 1.504347826087, 0.0875, 0.11111111111111
91875, 1.504347826087, 0.0875, 0.055555555555556
91876, 1.5478260869565, 0.0875, 0.44444444444444
91877, 1.5478260869565, 0.0875, 0.38888888888889
91878, 1.5478260869565, 0.0875, 0.33333333333333
91879, 1.5478260869565, 0.0875, 0.27777777777778
91880, 1.5478260869565, 0.0875, 0.22222222222222
91881, 1.5478260869565, 0.0875, 0.16666666666667
91882, 1.5478260869565, 0.0875, 0.11111111111111
91883, 1.5478260869565, 0.0875, 0.055555555555556
91884, 1.5913043478261, 0.0875, 0.44444444444444
91885, 1.5913043478261, 0.0875, 0.38888888888889
91886, 1.5913043478261, 0.0875, 0.33333333333333
91887, 1.5913043478261, 0.0875, 0.27777777777778
91888, 1.5913043478261, 0.0875, 0.22222222222222
91889, 1.5913043478261, 0.0875, 0.16666666666667
91890, 1.5913043478261, 0.0875, 0.11111111111111
91891, 1.5913043478261, 0.0875, 0.055555555555556
91892, 1.6347826086957, 0.0875, 0.44444444444444
91893, 1.6347826086957, 0.0875, 0.38888888888889
91894, 1.6347826086957, 0.0875, 0.33333333333333
91895, 1.6347826086957, 0.0875, 0.27777777777778
91896, 1.6347826086957, 0.0875, 0.22222222222222
91897, 1.6347826086957, 0.0875, 0.16666666666667
91898, 1.6347826086957, 0.0875, 0.11111111111111
91899, 1.6347826086957, 0.0875, 0.055555555555556
91900, 1.6782608695652, 0.0875, 0.44444444444444
91901, 1.6782608695652, 0.0875, 0.38888888888889
91902, 1.6782608695652, 0.0875, 0.33333333333333
91903, 1.6782608695652, 0.0875, 0.27777777777778
91904, 1.6782608695652, 0.0875, 0.22222222222222
91905, 1.6782608695652, 0.0875, 0.16666666666667
91906, 1.6782608695652, 0.0875, 0.11111111111111
91907, 1.6782608695652, 0.0875, 0.055555555555556
91908, 1.7217391304348, 0.0875, 0.44444444444444
91909, 1.7217391304348, 0.0875, 0.38888888888889
91910, 1.7217391304348, 0.0875, 0.33333333333333
91911, 1.7217391304348, 0.0875, 0.27777777777778
91912, 1.7217391304348, 0.0875, 0.22222222222222
91913, 1.7217391304348, 0.0875, 0.16666666666667
91914, 1.7217391304348, 0.0875, 0.11111111111111
91915, 1.7217391304348, 0.0875, 0.055555555555556
91916, 1.7652173913043, 0.0875, 0.44444444444444
91917, 1.7652173913043, 0.0875, 0.38888888888889
91918, 1.7652173913043, 0.0875, 0.33333333333333
91919, 1.7652173913043, 0.0875, 0.27777777777778
91920, 1.7652173913043, 0.0875, 0.22222222222222
91921, 1.7652173913043, 0.0875, 0.16666666666667
91922, 1.7652173913043, 0.0875, 0.11111111111111
91923, 1.7652173913043, 0.0875, 0.055555555555556
91924, 1.8086956521739, 0.0875, 0.44444444444444
91925, 1.8086956521739, 0.0875, 0.38888888888889
91926, 1.8086956521739, 0.0875, 0.33333333333333
91927, 1.8086956521739, 0.0875, 0.27777777777778
91928, 1.8086956521739, 0.0875, 0.22222222222222
91929, 1.8086956521739, 0.0875, 0.16666666666667
91930, 1.8086956521739, 0.0875, 0.11111111111111
91931, 1.8086956521739, 0.0875, 0.055555555555556
91932, 1.8521739130435, 0.0875, 0.44444444444444
91933, 1.8521739130435, 0.0875, 0.38888888888889
91934, 1.8521739130435, 0.0875, 0.33333333333333
91935, 1.8521739130435, 0.0875, 0.27777777777778
91936, 1.8521739130435, 0.0875, 0.22222222222222
91937, 1.8521739130435, 0.0875, 0.16666666666667
91938, 1.8521739130435, 0.0875, 0.11111111111111
91939, 1.8521739130435, 0.0875, 0.055555555555556
91940, 1.895652173913, 0.0875, 0.44444444444444
91941, 1.895652173913, 0.0875, 0.38888888888889
91942, 1.895652173913, 0.0875, 0.33333333333333
91943, 1.895652173913, 0.0875, 0.27777777777778
91944, 1.895652173913, 0.0875, 0.22222222222222
91945, 1.895652173913, 0.0875, 0.16666666666667
91946, 1.895652173913, 0.0875, 0.11111111111111
91947, 1.895652173913, 0.0875, 0.055555555555556
91948, 1.9391304347826, 0.0875, 0.44444444444444
91949, 1.9391304347826, 0.0875, 0.38888888888889
91950, 1.9391304347826, 0.0875, 0.33333333333333
91951, 1.9391304347826, 0.0875, 0.27777777777778
91952, 1.9391304347826, 0.0875, 0.22222222222222
91953, 1.9391304347826, 0.0875, 0.16666666666667
91954, 1.9391304347826, 0.0875, 0.11111111111111
91955, 1.9391304347826, 0.0875, 0.055555555555556
91956, 1.9826086956522, 0.0875, 0.44444444444444
91957, 1.9826086956522, 0.0875, 0.38888888888889
91958, 1.9826086956522, 0.0875, 0.33333333333333
91959, 1.9826086956522, 0.0875, 0.27777777777778
91960, 1.9826086956522, 0.0875, 0.22222222222222
91961, 1.9826086956522, 0.0875, 0.16666666666667
91962, 1.9826086956522, 0.0875, 0.11111111111111
91963, 1.9826086956522, 0.0875, 0.055555555555556
91964, 2.0260869565217, 0.0875, 0.44444444444444
91965, 2.0260869565217, 0.0875, 0.38888888888889
91966, 2.0260869565217, 0.0875, 0.33333333333333
91967, 2.0260869565217, 0.0875, 0.27777777777778
91968, 2.0260869565217, 0.0875, 0.22222222222222
91969, 2.0260869565217, 0.0875, 0.16666666666667
91970, 2.0260869565217, 0.0875, 0.11111111111111
91971, 2.0260869565217, 0.0875, 0.055555555555556
91972, 2.0695652173913, 0.0875, 0.44444444444444
91973, 2.0695652173913, 0.0875, 0.38888888888889
91974, 2.0695652173913, 0.0875, 0.33333333333333
91975, 2.0695652173913, 0.0875, 0.27777777777778
91976, 2.0695652173913, 0.0875, 0.22222222222222
91977, 2.0695652173913, 0.0875, 0.16666666666667
91978, 2.0695652173913, 0.0875, 0.11111111111111
91979, 2.0695652173913, 0.0875, 0.055555555555556
91980, 2.1130434782609, 0.0875, 0.44444444444444
91981, 2.1130434782609, 0.0875, 0.38888888888889
91982, 2.1130434782609, 0.0875, 0.33333333333333
91983, 2.1130434782609, 0.0875, 0.27777777777778
91984, 2.1130434782609, 0.0875, 0.22222222222222
91985, 2.1130434782609, 0.0875, 0.16666666666667
91986, 2.1130434782609, 0.0875, 0.11111111111111
91987, 2.1130434782609, 0.0875, 0.055555555555556
91988, 2.1565217391304, 0.0875, 0.44444444444444
91989, 2.1565217391304, 0.0875, 0.38888888888889
91990, 2.1565217391304, 0.0875, 0.33333333333333
