10531, 1.6130434782609, 0.016666666666667, 0.5
10532, 1.6347826086957, 0.033333333333333, 0.5
10533, 1.6565217391304, 0.016666666666667, 0.5
10534, 1.6782608695652, 0.033333333333333, 0.5
10535, 1.7, 0.016666666666667, 0.5
10536, 1.7217391304348, 0.033333333333333, 0.5
10537, 1.7434782608696, 0.016666666666667, 0.5
10538, 1.7652173913043, 0.033333333333333, 0.5
10539, 1.7869565217391, 0.016666666666667, 0.5
10540, 1.8086956521739, 0.033333333333333, 0.5
10541, 1.8304347826087, 0.016666666666667, 0.5
10542, 1.8521739130435, 0.033333333333333, 0.5
10543, 1.8739130434783, 0.016666666666667, 0.5
10544, 1.895652173913, 0.033333333333333, 0.5
10545, 1.9173913043478, 0.016666666666667, 0.5
10546, 1.9391304347826, 0.033333333333333, 0.5
10547, 1.9608695652174, 0.016666666666667, 0.5
10548, 1.9826086956522, 0.033333333333333, 0.5
10549, 2.004347826087, 0.016666666666667, 0.5
10550, 2.0260869565217, 0.033333333333333, 0.5
10551, 2.0478260869565, 0.016666666666667, 0.5
10552, 2.0695652173913, 0.033333333333333, 0.5
10553, 2.0913043478261, 0.016666666666667, 0.5
10554, 2.1130434782609, 0.033333333333333, 0.5
10555, 2.1347826086957, 0.016666666666667, 0.5
10556, 2.1565217391304, 0.033333333333333, 0.5
10557, 2.1782608695652, 0.016666666666667, 0.5
10558, 1.2217391304348, -0.016666666666667, 0.5
10559, 1.2434782608696, -4.1633363423443e-17, 0.5
10560, 1.2652173913043, -0.016666666666667, 0.5
10561, 1.2869565217391, -2.7755575615629e-17, 0.5
10562, 1.3086956521739, -0.016666666666667, 0.5
10563, 1.3304347826087, -2.7755575615629e-17, 0.5
10564, 1.3521739130435, -0.016666666666667, 0.5
10565, 1.3739130434783, -4.1633363423443e-17, 0.5
10566, 1.395652173913, -0.016666666666667, 0.5
10567, 1.4173913043478, -2.7755575615629e-17, 0.5
10568, 1.4391304347826, -0.016666666666667, 0.5
10569, 1.4608695652174, -2.7755575615629e-17, 0.5
10570, 1.4826086956522, -0.016666666666667, 0.5
10571, 1.504347826087, -2.7755575615629e-17, 0.5
10572, 1.5260869565217, -0.016666666666667, 0.5
10573, 1.5478260869565, -4.8572257327351e-17, 0.5
10574, 1.5695652173913, -0.016666666666667, 0.5
10575, 1.5913043478261, -4.1633363423443e-17, 0.5
10576, 1.6130434782609, -0.016666666666667, 0.5
10577, 1.6347826086957, -5.5511151231258e-17, 0.5
10578, 1.6565217391304, -0.016666666666667, 0.5
10579, 1.6782608695652, -5.5511151231258e-17, 0.5
10580, 1.7, -0.016666666666667, 0.5
10581, 1.7217391304348, -4.8572257327351e-17, 0.5
10582, 1.7434782608696, -0.016666666666667, 0.5
10583, 1.7652173913043, -4.1633363423443e-17, 0.5
10584, 1.7869565217391, -0.016666666666667, 0.5
10585, 1.8086956521739, -2.7755575615629e-17, 0.5
10586, 1.8304347826087, -0.016666666666667, 0.5
10587, 1.8521739130435, -4.1633363423443e-17, 0.5
10588, 1.8739130434783, -0.016666666666667, 0.5
10589, 1.895652173913, -4.8572257327351e-17, 0.5
10590, 1.9173913043478, -0.016666666666667, 0.5
10591, 1.9391304347826, -2.7755575615629e-17, 0.5
10592, 1.9608695652174, -0.016666666666667, 0.5
10593, 1.9826086956522, -4.1633363423443e-17, 0.5
10594, 2.004347826087, -0.016666666666667, 0.5
10595, 2.0260869565217, -2.7755575615629e-17, 0.5
10596, 2.0478260869565, -0.016666666666667, 0.5
10597, 2.0695652173913, -4.1633363423443e-17, 0.5
10598, 2.0913043478261, -0.016666666666667, 0.5
10599, 2.1130434782609, -4.1633363423443e-17, 0.5
10600, 2.1347826086957, -0.016666666666667, 0.5
10601, 2.1565217391304, -4.1633363423443e-17, 0.5
10602, 2.1782608695652, -0.016666666666667, 0.5
10603, 1.2434782608696, -0.033333333333333, 0.5
10604, 1.2869565217391, -0.033333333333333, 0.5
10605, 1.3304347826087, -0.033333333333333, 0.5
10606, 1.3739130434783, -0.033333333333333, 0.5
10607, 1.4173913043478, -0.033333333333333, 0.5
10608, 1.4608695652174, -0.033333333333333, 0.5
10609, 1.504347826087, -0.033333333333333, 0.5
10610, 1.5478260869565, -0.033333333333333, 0.5
10611, 1.5913043478261, -0.033333333333333, 0.5
10612, 1.6347826086957, -0.033333333333333, 0.5
10613, 1.6782608695652, -0.033333333333333, 0.5
10614, 1.7217391304348, -0.033333333333333, 0.5
10615, 1.7652173913043, -0.033333333333333, 0.5
10616, 1.8086956521739, -0.033333333333333, 0.5
10617, 1.8521739130435, -0.033333333333333, 0.5
10618, 1.895652173913, -0.033333333333333, 0.5
10619, 1.9391304347826, -0.033333333333333, 0.5
10620, 1.9826086956522, -0.033333333333333, 0.5
10621, 2.0260869565217, -0.033333333333333, 0.5
10622, 2.0695652173913, -0.033333333333333, 0.5
10623, 2.1130434782609, -0.033333333333333, 0.5
10624, 2.1565217391304, -0.033333333333333, 0.5
10625, 1.2434782608696, 0.016666666666667, 0
10626, 1.2869565217391, 0.016666666666667, 0
10627, 1.3304347826087, 0.016666666666667, 0
10628, 1.3739130434783, 0.016666666666667, 0
10629, 1.4173913043478, 0.016666666666667, 0
10630, 1.4608695652174, 0.016666666666667, 0
10631, 1.504347826087, 0.016666666666667, 0
10632, 1.5478260869565, 0.016666666666667, 0
10633, 1.5913043478261, 0.016666666666667, 0
10634, 1.6347826086957, 0.016666666666667, 0
10635, 1.6782608695652, 0.016666666666667, 0
10636, 1.7217391304348, 0.016666666666667, 0
10637, 1.7652173913043, 0.016666666666667, 0
10638, 1.8086956521739, 0.016666666666667, 0
10639, 1.8521739130435, 0.016666666666667, 0
10640, 1.895652173913, 0.016666666666667, 0
10641, 1.9391304347826, 0.016666666666667, 0
10642, 1.9826086956522, 0.016666666666667, 0
10643, 2.0260869565217, 0.016666666666667, 0
10644, 2.0695652173913, 0.016666666666667, 0
10645, 2.1130434782609, 0.016666666666667, 0
10646, 2.1565217391304, 0.016666666666667, 0
10647, 1.2434782608696, -0.016666666666667, 0
10648, 1.2869565217391, -0.016666666666667, 0
10649, 1.3304347826087, -0.016666666666667, 0
10650, 1.3739130434783, -0.016666666666667, 0
10651, 1.4173913043478, -0.016666666666667, 0
10652, 1.4608695652174, -0.016666666666667, 0
10653, 1.504347826087, -0.016666666666667, 0
10654, 1.5478260869565, -0.016666666666667, 0
10655, 1.5913043478261, -0.016666666666667, 0
10656, 1.6347826086957, -0.016666666666667, 0
10657, 1.6782608695652, -0.016666666666667, 0
10658, 1.7217391304348, -0.016666666666667, 0
10659, 1.7652173913043, -0.016666666666667, 0
10660, 1.8086956521739, -0.016666666666667, 0
10661, 1.8521739130435, -0.016666666666667, 0
10662, 1.895652173913, -0.016666666666667, 0
10663, 1.9391304347826, -0.016666666666667, 0
10664, 1.9826086956522, -0.016666666666667, 0
10665, 2.0260869565217, -0.016666666666667, 0
10666, 2.0695652173913, -0.016666666666667, 0
10667, 2.1130434782609, -0.016666666666667, 0
10668, 2.1565217391304, -0.016666666666667, 0
10669, 1.2434782608696, 0.033333333333333, 0
10670, 1.2217391304348, 0.016666666666667, 0
10671, 1.2869565217391, 0.033333333333333, 0
10672, 1.2652173913043, 0.016666666666667, 0
10673, 1.3304347826087, 0.033333333333333, 0
10674, 1.3086956521739, 0.016666666666667, 0
10675, 1.3739130434783, 0.033333333333333, 0
10676, 1.3521739130435, 0.016666666666667, 0
10677, 1.4173913043478, 0.033333333333333, 0
10678, 1.395652173913, 0.016666666666667, 0
10679, 1.4608695652174, 0.033333333333333, 0
10680, 1.4391304347826, 0.016666666666667, 0
10681, 1.504347826087, 0.033333333333333, 0
10682, 1.4826086956522, 0.016666666666667, 0
10683, 1.5478260869565, 0.033333333333333, 0
10684, 1.5260869565217, 0.016666666666667, 0
10685, 1.5913043478261, 0.033333333333333, 0
10686, 1.5695652173913, 0.016666666666667, 0
10687, 1.6347826086957, 0.033333333333333, 0
10688, 1.6130434782609, 0.016666666666667, 0
10689, 1.6782608695652, 0.033333333333333, 0
10690, 1.6565217391304, 0.016666666666667, 0
10691, 1.7217391304348, 0.033333333333333, 0
10692, 1.7, 0.016666666666667, 0
10693, 1.7652173913043, 0.033333333333333, 0
10694, 1.7434782608696, 0.016666666666667, 0
10695, 1.8086956521739, 0.033333333333333, 0
10696, 1.7869565217391, 0.016666666666667, 0
10697, 1.8521739130435, 0.033333333333333, 0
10698, 1.8304347826087, 0.016666666666667, 0
10699, 1.895652173913, 0.033333333333333, 0
10700, 1.8739130434783, 0.016666666666667, 0
10701, 1.9391304347826, 0.033333333333333, 0
10702, 1.9173913043478, 0.016666666666667, 0
10703, 1.9826086956522, 0.033333333333333, 0
10704, 1.9608695652174, 0.016666666666667, 0
10705, 2.0260869565217, 0.033333333333333, 0
10706, 2.004347826087, 0.016666666666667, 0
10707, 2.0695652173913, 0.033333333333333, 0
10708, 2.0478260869565, 0.016666666666667, 0
10709, 2.1130434782609, 0.033333333333333, 0
10710, 2.0913043478261, 0.016666666666667, 0
10711, 2.1565217391304, 0.033333333333333, 0
10712, 2.1347826086957, 0.016666666666667, 0
10713, 2.1782608695652, 0.016666666666667, 0
10714, 1.2434782608696, -4.1633363423443e-17, 0
10715, 1.2217391304348, -0.016666666666667, 0
10716, 1.2869565217391, -2.7755575615629e-17, 0
10717, 1.2652173913043, -0.016666666666667, 0
10718, 1.3304347826087, -2.7755575615629e-17, 0
10719, 1.3086956521739, -0.016666666666667, 0
10720, 1.3739130434783, -4.1633363423443e-17, 0
10721, 1.3521739130435, -0.016666666666667, 0
10722, 1.4173913043478, -2.7755575615629e-17, 0
10723, 1.395652173913, -0.016666666666667, 0
10724, 1.4608695652174, -2.7755575615629e-17, 0
10725, 1.4391304347826, -0.016666666666667, 0
10726, 1.504347826087, -2.7755575615629e-17, 0
10727, 1.4826086956522, -0.016666666666667, 0
10728, 1.5478260869565, -4.8572257327351e-17, 0
10729, 1.5260869565217, -0.016666666666667, 0
10730, 1.5913043478261, -4.1633363423443e-17, 0
10731, 1.5695652173913, -0.016666666666667, 0
10732, 1.6347826086957, -5.5511151231258e-17, 0
10733, 1.6130434782609, -0.016666666666667, 0
10734, 1.6782608695652, -5.5511151231258e-17, 0
10735, 1.6565217391304, -0.016666666666667, 0
10736, 1.7217391304348, -4.8572257327351e-17, 0
10737, 1.7, -0.016666666666667, 0
10738, 1.7652173913043, -4.1633363423443e-17, 0
10739, 1.7434782608696, -0.016666666666667, 0
10740, 1.8086956521739, -2.7755575615629e-17, 0
10741, 1.7869565217391, -0.016666666666667, 0
10742, 1.8521739130435, -4.1633363423443e-17, 0
10743, 1.8304347826087, -0.016666666666667, 0
10744, 1.895652173913, -4.8572257327351e-17, 0
10745, 1.8739130434783, -0.016666666666667, 0
10746, 1.9391304347826, -2.7755575615629e-17, 0
10747, 1.9173913043478, -0.016666666666667, 0
10748, 1.9826086956522, -4.1633363423443e-17, 0
10749, 1.9608695652174, -0.016666666666667, 0
10750, 2.0260869565217, -2.7755575615629e-17, 0
10751, 2.004347826087, -0.016666666666667, 0
10752, 2.0695652173913, -4.1633363423443e-17, 0
10753, 2.0478260869565, -0.016666666666667, 0
10754, 2.1130434782609, -4.1633363423443e-17, 0
10755, 2.0913043478261, -0.016666666666667, 0
10756, 2.1565217391304, -4.1633363423443e-17, 0
10757, 2.1347826086957, -0.016666666666667, 0
10758, 2.1782608695652, -0.016666666666667, 0
10759, 1.2434782608696, -0.033333333333333, 0
10760, 1.2869565217391, -0.033333333333333, 0
10761, 1.3304347826087, -0.033333333333333, 0
10762, 1.3739130434783, -0.033333333333333, 0
10763, 1.4173913043478, -0.033333333333333, 0
10764, 1.4608695652174, -0.033333333333333, 0
10765, 1.504347826087, -0.033333333333333, 0
10766, 1.5478260869565, -0.033333333333333, 0
10767, 1.5913043478261, -0.033333333333333, 0
10768, 1.6347826086957, -0.033333333333333, 0
10769, 1.6782608695652, -0.033333333333333, 0
10770, 1.7217391304348, -0.033333333333333, 0
10771, 1.7652173913043, -0.033333333333333, 0
10772, 1.8086956521739, -0.033333333333333, 0
10773, 1.8521739130435, -0.033333333333333, 0
10774, 1.895652173913, -0.033333333333333, 0
10775, 1.9391304347826, -0.033333333333333, 0
10776, 1.9826086956522, -0.033333333333333, 0
10777, 2.0260869565217, -0.033333333333333, 0
10778, 2.0695652173913, -0.033333333333333, 0
10779, 2.1130434782609, -0.033333333333333, 0
10780, 2.1565217391304, -0.033333333333333, 0
10781, 1.2, 0.016666666666667, 0.44444444444444
10782, 1.2, 0.016666666666667, 0.38888888888889
10783, 1.2, 0.016666666666667, 0.33333333333333
10784, 1.2, 0.016666666666667, 0.27777777777778
10785, 1.2, 0.016666666666667, 0.22222222222222
10786, 1.2, 0.016666666666667, 0.16666666666667
10787, 1.2, 0.016666666666667, 0.11111111111111
10788, 1.2, 0.016666666666667, 0.055555555555556
10789, 1.2, -0.016666666666667, 0.44444444444444
10790, 1.2, -0.016666666666667, 0.38888888888889
10791, 1.2, -0.016666666666667, 0.33333333333333
10792, 1.2, -0.016666666666667, 0.27777777777778
10793, 1.2, -0.016666666666667, 0.22222222222222
10794, 1.2, -0.016666666666667, 0.16666666666667
10795, 1.2, -0.016666666666667, 0.11111111111111
10796, 1.2, -0.016666666666667, 0.055555555555556
10797, 1.2, 0.033333333333333, 0.44444444444444
10798, 1.2, 0.016666666666667, 0.47222222222222
10799, 1.2, 0.033333333333333, 0.38888888888889
10800, 1.2, 0.016666666666667, 0.41666666666667
10801, 1.2, 0.033333333333333, 0.33333333333333
10802, 1.2, 0.016666666666667, 0.36111111111111
10803, 1.2, 0.033333333333333, 0.27777777777778
10804, 1.2, 0.016666666666667, 0.30555555555556
10805, 1.2, 0.033333333333333, 0.22222222222222
10806, 1.2, 0.016666666666667, 0.25
10807, 1.2, 0.033333333333333, 0.16666666666667
10808, 1.2, 0.016666666666667, 0.19444444444444
10809, 1.2, 0.033333333333333, 0.11111111111111
10810, 1.2, 0.016666666666667, 0.13888888888889
10811, 1.2, 0.033333333333333, 0.055555555555556
10812, 1.2, 0.016666666666667, 0.083333333333333
10813, 1.2, 0.016666666666667, 0.027777777777778
10814, 1.2, -1.0408340855861e-16, 0.44444444444444
10815, 1.2, -0.016666666666667, 0.47222222222222
10816, 1.2, -9.7144514654701e-17, 0.38888888888889
10817, 1.2, -0.016666666666667, 0.41666666666667
10818, 1.2, -1.0408340855861e-16, 0.33333333333333
10819, 1.2, -0.016666666666667, 0.36111111111111
10820, 1.2, -1.0408340855861e-16, 0.27777777777778
10821, 1.2, -0.016666666666667, 0.30555555555556
10822, 1.2, -1.0408340855861e-16, 0.22222222222222
10823, 1.2, -0.016666666666667, 0.25
10824, 1.2, -1.0408340855861e-16, 0.16666666666667
10825, 1.2, -0.016666666666667, 0.19444444444444
10826, 1.2, -1.0408340855861e-16, 0.11111111111111
10827, 1.2, -0.016666666666667, 0.13888888888889
10828, 1.2, -1.0408340855861e-16, 0.055555555555556
10829, 1.2, -0.016666666666667, 0.083333333333333
10830, 1.2, -0.016666666666667, 0.027777777777778
10831, 1.2, -0.033333333333333, 0.44444444444444
10832, 1.2, -0.033333333333333, 0.38888888888889
10833, 1.2, -0.033333333333333, 0.33333333333333
10834, 1.2, -0.033333333333333, 0.27777777777778
10835, 1.2, -0.033333333333333, 0.22222222222222
10836, 1.2, -0.033333333333333, 0.16666666666667
10837, 1.2, -0.033333333333333, 0.11111111111111
10838, 1.2, -0.033333333333333, 0.055555555555556
10839, 2.2, 0.016666666666667, 0.44444444444444
10840, 2.2, 0.016666666666667, 0.38888888888889
10841, 2.2, 0.016666666666667, 0.33333333333333
10842, 2.2, 0.016666666666667, 0.27777777777778
10843, 2.2, 0.016666666666667, 0.22222222222222
10844, 2.2, 0.016666666666667, 0.16666666666667
10845, 2.2, 0.016666666666667, 0.11111111111111
10846, 2.2, 0.016666666666667, 0.055555555555556
10847, 2.2, -0.016666666666667, 0.44444444444444
10848, 2.2, -0.016666666666667, 0.38888888888889
10849, 2.2, -0.016666666666667, 0.33333333333333
10850, 2.2, -0.016666666666667, 0.27777777777778
10851, 2.2, -0.016666666666667, 0.22222222222222
10852, 2.2, -0.016666666666667, 0.16666666666667
10853, 2.2, -0.016666666666667, 0.11111111111111
10854, 2.2, -0.016666666666667, 0.055555555555556
10855, 2.2, 0.016666666666667, 0.47222222222222
10856, 2.2, 0.033333333333333, 0.44444444444444
10857, 2.2, 0.016666666666667, 0.41666666666667
10858, 2.2, 0.033333333333333, 0.38888888888889
10859, 2.2, 0.016666666666667, 0.36111111111111
10860, 2.2, 0.033333333333333, 0.33333333333333
10861, 2.2, 0.016666666666667, 0.30555555555556
10862, 2.2, 0.033333333333333, 0.27777777777778
10863, 2.2, 0.016666666666667, 0.25
10864, 2.2, 0.033333333333333, 0.22222222222222
10865, 2.2, 0.016666666666667, 0.19444444444444
10866, 2.2, 0.033333333333333, 0.16666666666667
10867, 2.2, 0.016666666666667, 0.13888888888889
10868, 2.2, 0.033333333333333, 0.11111111111111
10869, 2.2, 0.016666666666667, 0.083333333333333
10870, 2.2, 0.033333333333333, 0.055555555555556
10871, 2.2, 0.016666666666667, 0.027777777777778
10872, 2.2, -0.016666666666667, 0.47222222222222
10873, 2.2, -8.3266726846887e-17, 0.44444444444444
10874, 2.2, -0.016666666666667, 0.41666666666667
10875, 2.2, -9.0205620750794e-17, 0.38888888888889
10876, 2.2, -0.016666666666667, 0.36111111111111
10877, 2.2, -9.0205620750794e-17, 0.33333333333333
10878, 2.2, -0.016666666666667, 0.30555555555556
10879, 2.2, -9.0205620750794e-17, 0.27777777777778
10880, 2.2, -0.016666666666667, 0.25
10881, 2.2, -9.0205620750794e-17, 0.22222222222222
10882, 2.2, -0.016666666666667, 0.19444444444444
10883, 2.2, -9.0205620750794e-17, 0.16666666666667
10884, 2.2, -0.016666666666667, 0.13888888888889
10885, 2.2, -9.0205620750794e-17, 0.11111111111111
10886, 2.2, -0.016666666666667, 0.083333333333333
10887, 2.2, -8.3266726846887e-17, 0.055555555555556
10888, 2.2, -0.016666666666667, 0.027777777777778
10889, 2.2, -0.033333333333333, 0.44444444444444
10890, 2.2, -0.033333333333333, 0.38888888888889
10891, 2.2, -0.033333333333333, 0.33333333333333
10892, 2.2, -0.033333333333333, 0.27777777777778
10893, 2.2, -0.033333333333333, 0.22222222222222
10894, 2.2, -0.033333333333333, 0.16666666666667
10895, 2.2, -0.033333333333333, 0.11111111111111
10896, 2.2, -0.033333333333333, 0.055555555555556
10897, 1.2434782608696, 0.05, 0.44444444444444
10898, 1.2434782608696, 0.05, 0.38888888888889
10899, 1.2434782608696, 0.05, 0.33333333333333
10900, 1.2434782608696, 0.05, 0.27777777777778
10901, 1.2434782608696, 0.05, 0.22222222222222
10902, 1.2434782608696, 0.05, 0.16666666666667
10903, 1.2434782608696, 0.05, 0.11111111111111
10904, 1.2434782608696, 0.05, 0.055555555555556
10905, 1.2869565217391, 0.05, 0.44444444444444
10906, 1.2869565217391, 0.05, 0.38888888888889
10907, 1.2869565217391, 0.05, 0.33333333333333
10908, 1.2869565217391, 0.05, 0.27777777777778
10909, 1.2869565217391, 0.05, 0.22222222222222
10910, 1.2869565217391, 0.05, 0.16666666666667
10911, 1.2869565217391, 0.05, 0.11111111111111
10912, 1.2869565217391, 0.05, 0.055555555555556
10913, 1.3304347826087, 0.05, 0.44444444444444
10914, 1.3304347826087, 0.05, 0.38888888888889
10915, 1.3304347826087, 0.05, 0.33333333333333
10916, 1.3304347826087, 0.05, 0.27777777777778
10917, 1.3304347826087, 0.05, 0.22222222222222
10918, 1.3304347826087, 0.05, 0.16666666666667
10919, 1.3304347826087, 0.05, 0.11111111111111
10920, 1.3304347826087, 0.05, 0.055555555555556
10921, 1.3739130434783, 0.05, 0.44444444444444
10922, 1.3739130434783, 0.05, 0.38888888888889
10923, 1.3739130434783, 0.05, 0.33333333333333
10924, 1.3739130434783, 0.05, 0.27777777777778
10925, 1.3739130434783, 0.05, 0.22222222222222
10926, 1.3739130434783, 0.05, 0.16666666666667
10927, 1.3739130434783, 0.05, 0.11111111111111
10928, 1.3739130434783, 0.05, 0.055555555555556
10929, 1.4173913043478, 0.05, 0.44444444444444
10930, 1.4173913043478, 0.05, 0.38888888888889
10931, 1.4173913043478, 0.05, 0.33333333333333
10932, 1.4173913043478, 0.05, 0.27777777777778
10933, 1.4173913043478, 0.05, 0.22222222222222
10934, 1.4173913043478, 0.05, 0.16666666666667
10935, 1.4173913043478, 0.05, 0.11111111111111
10936, 1.4173913043478, 0.05, 0.055555555555556
10937, 1.4608695652174, 0.05, 0.44444444444444
10938, 1.4608695652174, 0.05, 0.38888888888889
10939, 1.4608695652174, 0.05, 0.33333333333333
10940, 1.4608695652174, 0.05, 0.27777777777778
10941, 1.4608695652174, 0.05, 0.22222222222222
10942, 1.4608695652174, 0.05, 0.16666666666667
10943, 1.4608695652174, 0.05, 0.11111111111111
10944, 1.4608695652174, 0.05, 0.055555555555556
10945, 1.504347826087, 0.05, 0.44444444444444
10946, 1.504347826087, 0.05, 0.38888888888889
10947, 1.504347826087, 0.05, 0.33333333333333
10948, 1.504347826087, 0.05, 0.27777777777778
10949, 1.504347826087, 0.05, 0.22222222222222
10950, 1.504347826087, 0.05, 0.16666666666667
10951, 1.504347826087, 0.05, 0.11111111111111
10952, 1.504347826087, 0.05, 0.055555555555556
10953, 1.5478260869565, 0.05, 0.44444444444444
10954, 1.5478260869565, 0.05, 0.38888888888889
10955, 1.5478260869565, 0.05, 0.33333333333333
10956, 1.5478260869565, 0.05, 0.27777777777778
10957, 1.5478260869565, 0.05, 0.22222222222222
10958, 1.5478260869565, 0.05, 0.16666666666667
10959, 1.5478260869565, 0.05, 0.11111111111111
10960, 1.5478260869565, 0.05, 0.055555555555556
10961, 1.5913043478261, 0.05, 0.44444444444444
10962, 1.5913043478261, 0.05, 0.38888888888889
10963, 1.5913043478261, 0.05, 0.33333333333333
10964, 1.5913043478261, 0.05, 0.27777777777778
10965, 1.5913043478261, 0.05, 0.22222222222222
10966, 1.5913043478261, 0.05, 0.16666666666667
10967, 1.5913043478261, 0.05, 0.11111111111111
10968, 1.5913043478261, 0.05, 0.055555555555556
10969, 1.6347826086957, 0.05, 0.44444444444444
10970, 1.6347826086957, 0.05, 0.38888888888889
10971, 1.6347826086957, 0.05, 0.33333333333333
10972, 1.6347826086957, 0.05, 0.27777777777778
10973, 1.6347826086957, 0.05, 0.22222222222222
10974, 1.6347826086957, 0.05, 0.16666666666667
10975, 1.6347826086957, 0.05, 0.11111111111111
10976, 1.6347826086957, 0.05, 0.055555555555556
10977, 1.6782608695652, 0.05, 0.44444444444444
10978, 1.6782608695652, 0.05, 0.38888888888889
10979, 1.6782608695652, 0.05, 0.33333333333333
10980, 1.6782608695652, 0.05, 0.27777777777778
10981, 1.6782608695652, 0.05, 0.22222222222222
10982, 1.6782608695652, 0.05, 0.16666666666667
10983, 1.6782608695652, 0.05, 0.11111111111111
10984, 1.6782608695652, 0.05, 0.055555555555556
10985, 1.7217391304348, 0.05, 0.44444444444444
10986, 1.7217391304348, 0.05, 0.38888888888889
10987, 1.7217391304348, 0.05, 0.33333333333333
10988, 1.7217391304348, 0.05, 0.27777777777778
10989, 1.7217391304348, 0.05, 0.22222222222222
10990, 1.7217391304348, 0.05, 0.16666666666667
10991, 1.7217391304348, 0.05, 0.11111111111111
10992, 1.7217391304348, 0.05, 0.055555555555556
10993, 1.7652173913043, 0.05, 0.44444444444444
10994, 1.7652173913043, 0.05, 0.38888888888889
10995, 1.7652173913043, 0.05, 0.33333333333333
10996, 1.7652173913043, 0.05, 0.27777777777778
10997, 1.7652173913043, 0.05, 0.22222222222222
10998, 1.7652173913043, 0.05, 0.16666666666667
10999, 1.7652173913043, 0.05, 0.11111111111111
11000, 1.7652173913043, 0.05, 0.055555555555556
11001, 1.8086956521739, 0.05, 0.44444444444444
11002, 1.8086956521739, 0.05, 0.38888888888889
11003, 1.8086956521739, 0.05, 0.33333333333333
11004, 1.8086956521739, 0.05, 0.27777777777778
11005, 1.8086956521739, 0.05, 0.22222222222222
11006, 1.8086956521739, 0.05, 0.16666666666667
11007, 1.8086956521739, 0.05, 0.11111111111111
11008, 1.8086956521739, 0.05, 0.055555555555556
11009, 1.8521739130435, 0.05, 0.44444444444444
11010, 1.8521739130435, 0.05, 0.38888888888889
11011, 1.8521739130435, 0.05, 0.33333333333333
11012, 1.8521739130435, 0.05, 0.27777777777778
11013, 1.8521739130435, 0.05, 0.22222222222222
11014, 1.8521739130435, 0.05, 0.16666666666667
11015, 1.8521739130435, 0.05, 0.11111111111111
11016, 1.8521739130435, 0.05, 0.055555555555556
11017, 1.895652173913, 0.05, 0.44444444444444
11018, 1.895652173913, 0.05, 0.38888888888889
11019, 1.895652173913, 0.05, 0.33333333333333
11020, 1.895652173913, 0.05, 0.27777777777778
11021, 1.895652173913, 0.05, 0.22222222222222
11022, 1.895652173913, 0.05, 0.16666666666667
11023, 1.895652173913, 0.05, 0.11111111111111
11024, 1.895652173913, 0.05, 0.055555555555556
11025, 1.9391304347826, 0.05, 0.44444444444444
11026, 1.9391304347826, 0.05, 0.38888888888889
11027, 1.9391304347826, 0.05, 0.33333333333333
11028, 1.9391304347826, 0.05, 0.27777777777778
11029, 1.9391304347826, 0.05, 0.22222222222222
11030, 1.9391304347826, 0.05, 0.16666666666667
11031, 1.9391304347826, 0.05, 0.11111111111111
11032, 1.9391304347826, 0.05, 0.055555555555556
11033, 1.9826086956522, 0.05, 0.44444444444444
11034, 1.9826086956522, 0.05, 0.38888888888889
11035, 1.9826086956522, 0.05, 0.33333333333333
11036, 1.9826086956522, 0.05, 0.27777777777778
11037, 1.9826086956522, 0.05, 0.22222222222222
11038, 1.9826086956522, 0.05, 0.16666666666667
11039, 1.9826086956522, 0.05, 0.11111111111111
11040, 1.9826086956522, 0.05, 0.055555555555556
11041, 2.0260869565217, 0.05, 0.44444444444444
11042, 2.0260869565217, 0.05, 0.38888888888889
11043, 2.0260869565217, 0.05, 0.33333333333333
11044, 2.0260869565217, 0.05, 0.27777777777778
11045, 2.0260869565217, 0.05, 0.22222222222222
11046, 2.0260869565217, 0.05, 0.16666666666667
11047, 2.0260869565217, 0.05, 0.11111111111111
11048, 2.0260869565217, 0.05, 0.055555555555556
11049, 2.0695652173913, 0.05, 0.44444444444444
11050, 2.0695652173913, 0.05, 0.38888888888889
11051, 2.0695652173913, 0.05, 0.33333333333333
11052, 2.0695652173913, 0.05, 0.27777777777778
11053, 2.0695652173913, 0.05, 0.22222222222222
11054, 2.0695652173913, 0.05, 0.16666666666667
11055, 2.0695652173913, 0.05, 0.11111111111111
11056, 2.0695652173913, 0.05, 0.055555555555556
11057, 2.1130434782609, 0.05, 0.44444444444444
11058, 2.1130434782609, 0.05, 0.38888888888889
11059, 2.1130434782609, 0.05, 0.33333333333333
11060, 2.1130434782609, 0.05, 0.27777777777778
11061, 2.1130434782609, 0.05, 0.22222222222222
11062, 2.1130434782609, 0.05, 0.16666666666667
11063, 2.1130434782609, 0.05, 0.11111111111111
11064, 2.1130434782609, 0.05, 0.055555555555556
11065, 2.1565217391304, 0.05, 0.44444444444444
11066, 2.1565217391304, 0.05, 0.38888888888889
11067, 2.1565217391304, 0.05, 0.33333333333333
11068, 2.1565217391304, 0.05, 0.27777777777778
11069, 2.1565217391304, 0.05, 0.22222222222222
11070, 2.1565217391304, 0.05, 0.16666666666667
11071, 2.1565217391304, 0.05, 0.11111111111111
11072, 2.1565217391304, 0.05, 0.055555555555556
11073, 1.2434782608696, 0.05, 0.47222222222222
11074, 1.2217391304348, 0.05, 0.44444444444444
11075, 1.2434782608696, 0.05, 0.41666666666667
11076, 1.2217391304348, 0.05, 0.38888888888889
11077, 1.2434782608696, 0.05, 0.36111111111111
11078, 1.2217391304348, 0.05, 0.33333333333333
11079, 1.2434782608696, 0.05, 0.30555555555556
11080, 1.2217391304348, 0.05, 0.27777777777778
11081, 1.2434782608696, 0.05, 0.25
11082, 1.2217391304348, 0.05, 0.22222222222222
11083, 1.2434782608696, 0.05, 0.19444444444444
11084, 1.2217391304348, 0.05, 0.16666666666667
11085, 1.2434782608696, 0.05, 0.13888888888889
11086, 1.2217391304348, 0.05, 0.11111111111111
11087, 1.2434782608696, 0.05, 0.083333333333333
11088, 1.2217391304348, 0.05, 0.055555555555556
11089, 1.2434782608696, 0.05, 0.027777777777778
11090, 1.2869565217391, 0.05, 0.47222222222222
11091, 1.2652173913043, 0.05, 0.44444444444444
11092, 1.2869565217391, 0.05, 0.41666666666667
11093, 1.2652173913043, 0.05, 0.38888888888889
11094, 1.2869565217391, 0.05, 0.36111111111111
11095, 1.2652173913043, 0.05, 0.33333333333333
11096, 1.2869565217391, 0.05, 0.30555555555556
11097, 1.2652173913043, 0.05, 0.27777777777778
11098, 1.2869565217391, 0.05, 0.25
11099, 1.2652173913043, 0.05, 0.22222222222222
11100, 1.2869565217391, 0.05, 0.19444444444444
11101, 1.2652173913043, 0.05, 0.16666666666667
11102, 1.2869565217391, 0.05, 0.13888888888889
11103, 1.2652173913043, 0.05, 0.11111111111111
11104, 1.2869565217391, 0.05, 0.083333333333333
11105, 1.2652173913043, 0.05, 0.055555555555556
11106, 1.2869565217391, 0.05, 0.027777777777778
11107, 1.3304347826087, 0.05, 0.47222222222222
11108, 1.3086956521739, 0.05, 0.44444444444444
11109, 1.3304347826087, 0.05, 0.41666666666667
11110, 1.3086956521739, 0.05, 0.38888888888889
11111, 1.3304347826087, 0.05, 0.36111111111111
11112, 1.3086956521739, 0.05, 0.33333333333333
11113, 1.3304347826087, 0.05, 0.30555555555556
11114, 1.3086956521739, 0.05, 0.27777777777778
11115, 1.3304347826087, 0.05, 0.25
11116, 1.3086956521739, 0.05, 0.22222222222222
11117, 1.3304347826087, 0.05, 0.19444444444444
11118, 1.3086956521739, 0.05, 0.16666666666667
11119, 1.3304347826087, 0.05, 0.13888888888889
11120, 1.3086956521739, 0.05, 0.11111111111111
11121, 1.3304347826087, 0.05, 0.083333333333333
11122, 1.3086956521739, 0.05, 0.055555555555556
11123, 1.3304347826087, 0.05, 0.027777777777778
11124, 1.3739130434783, 0.05, 0.47222222222222
11125, 1.3521739130435, 0.05, 0.44444444444444
11126, 1.3739130434783, 0.05, 0.41666666666667
11127, 1.3521739130435, 0.05, 0.38888888888889
11128, 1.3739130434783, 0.05, 0.36111111111111
11129, 1.3521739130435, 0.05, 0.33333333333333
11130, 1.3739130434783, 0.05, 0.30555555555556
11131, 1.3521739130435, 0.05, 0.27777777777778
11132, 1.3739130434783, 0.05, 0.25
11133, 1.3521739130435, 0.05, 0.22222222222222
11134, 1.3739130434783, 0.05, 0.19444444444444
11135, 1.3521739130435, 0.05, 0.16666666666667
11136, 1.3739130434783, 0.05, 0.13888888888889
11137, 1.3521739130435, 0.05, 0.11111111111111
11138, 1.3739130434783, 0.05, 0.083333333333333
11139, 1.3521739130435, 0.05, 0.055555555555556
11140, 1.3739130434783, 0.05, 0.027777777777778
11141, 1.4173913043478, 0.05, 0.47222222222222
11142, 1.395652173913, 0.05, 0.44444444444444
11143, 1.4173913043478, 0.05, 0.41666666666667
11144, 1.395652173913, 0.05, 0.38888888888889
11145, 1.4173913043478, 0.05, 0.36111111111111
11146, 1.395652173913, 0.05, 0.33333333333333
11147, 1.4173913043478, 0.05, 0.30555555555556
11148, 1.395652173913, 0.05, 0.27777777777778
11149, 1.4173913043478, 0.05, 0.25
11150, 1.395652173913, 0.05, 0.22222222222222
11151, 1.4173913043478, 0.05, 0.19444444444444
11152, 1.395652173913, 0.05, 0.16666666666667
11153, 1.4173913043478, 0.05, 0.13888888888889
11154, 1.395652173913, 0.05, 0.11111111111111
11155, 1.4173913043478, 0.05, 0.083333333333333
11156, 1.395652173913, 0.05, 0.055555555555556
11157, 1.4173913043478, 0.05, 0.027777777777778
11158, 1.4608695652174, 0.05, 0.47222222222222
11159, 1.4391304347826, 0.05, 0.44444444444444
11160, 1.4608695652174, 0.05, 0.41666666666667
11161, 1.4391304347826, 0.05, 0.38888888888889
11162, 1.4608695652174, 0.05, 0.36111111111111
11163, 1.4391304347826, 0.05, 0.33333333333333
11164, 1.4608695652174, 0.05, 0.30555555555556
11165, 1.4391304347826, 0.05, 0.27777777777778
11166, 1.4608695652174, 0.05, 0.25
11167, 1.4391304347826, 0.05, 0.22222222222222
11168, 1.4608695652174, 0.05, 0.19444444444444
11169, 1.4391304347826, 0.05, 0.16666666666667
11170, 1.4608695652174, 0.05, 0.13888888888889
11171, 1.4391304347826, 0.05, 0.11111111111111
11172, 1.4608695652174, 0.05, 0.083333333333333
11173, 1.4391304347826, 0.05, 0.055555555555556
11174, 1.4608695652174, 0.05, 0.027777777777778
11175, 1.504347826087, 0.05, 0.47222222222222
11176, 1.4826086956522, 0.05, 0.44444444444444
11177, 1.504347826087, 0.05, 0.41666666666667
11178, 1.4826086956522, 0.05, 0.38888888888889
11179, 1.504347826087, 0.05, 0.36111111111111
11180, 1.4826086956522, 0.05, 0.33333333333333
11181, 1.504347826087, 0.05, 0.30555555555556
11182, 1.4826086956522, 0.05, 0.27777777777778
11183, 1.504347826087, 0.05, 0.25
11184, 1.4826086956522, 0.05, 0.22222222222222
11185, 1.504347826087, 0.05, 0.19444444444444
11186, 1.4826086956522, 0.05, 0.16666666666667
11187, 1.504347826087, 0.05, 0.13888888888889
11188, 1.4826086956522, 0.05, 0.11111111111111
11189, 1.504347826087, 0.05, 0.083333333333333
11190, 1.4826086956522, 0.05, 0.055555555555556
11191, 1.504347826087, 0.05, 0.027777777777778
11192, 1.5478260869565, 0.05, 0.47222222222222
11193, 1.5260869565217, 0.05, 0.44444444444444
11194, 1.5478260869565, 0.05, 0.41666666666667
11195, 1.5260869565217, 0.05, 0.38888888888889
11196, 1.5478260869565, 0.05, 0.36111111111111
11197, 1.5260869565217, 0.05, 0.33333333333333
11198, 1.5478260869565, 0.05, 0.30555555555556
11199, 1.5260869565217, 0.05, 0.27777777777778
11200, 1.5478260869565, 0.05, 0.25
11201, 1.5260869565217, 0.05, 0.22222222222222
11202, 1.5478260869565, 0.05, 0.19444444444444
11203, 1.5260869565217, 0.05, 0.16666666666667
11204, 1.5478260869565, 0.05, 0.13888888888889
11205, 1.5260869565217, 0.05, 0.11111111111111
11206, 1.5478260869565, 0.05, 0.083333333333333
11207, 1.5260869565217, 0.05, 0.055555555555556
11208, 1.5478260869565, 0.05, 0.027777777777778
11209, 1.5913043478261, 0.05, 0.47222222222222
11210, 1.5695652173913, 0.05, 0.44444444444444
11211, 1.5913043478261, 0.05, 0.41666666666667
11212, 1.5695652173913, 0.05, 0.38888888888889
11213, 1.5913043478261, 0.05, 0.36111111111111
11214, 1.5695652173913, 0.05, 0.33333333333333
11215, 1.5913043478261, 0.05, 0.30555555555556
11216, 1.5695652173913, 0.05, 0.27777777777778
11217, 1.5913043478261, 0.05, 0.25
11218, 1.5695652173913, 0.05, 0.22222222222222
11219, 1.5913043478261, 0.05, 0.19444444444444
11220, 1.5695652173913, 0.05, 0.16666666666667
11221, 1.5913043478261, 0.05, 0.13888888888889
11222, 1.5695652173913, 0.05, 0.11111111111111
11223, 1.5913043478261, 0.05, 0.083333333333333
11224, 1.5695652173913, 0.05, 0.055555555555556
11225, 1.5913043478261, 0.05, 0.027777777777778
11226, 1.6347826086957, 0.05, 0.47222222222222
11227, 1.6130434782609, 0.05, 0.44444444444444
11228, 1.6347826086957, 0.05, 0.41666666666667
11229, 1.6130434782609, 0.05, 0.38888888888889
11230, 1.6347826086957, 0.05, 0.36111111111111
11231, 1.6130434782609, 0.05, 0.33333333333333
11232, 1.6347826086957, 0.05, 0.30555555555556
11233, 1.6130434782609, 0.05, 0.27777777777778
11234, 1.6347826086957, 0.05, 0.25
11235, 1.6130434782609, 0.05, 0.22222222222222
11236, 1.6347826086957, 0.05, 0.19444444444444
11237, 1.6130434782609, 0.05, 0.16666666666667
11238, 1.6347826086957, 0.05, 0.13888888888889
11239, 1.6130434782609, 0.05, 0.11111111111111
11240, 1.6347826086957, 0.05, 0.083333333333333
11241, 1.6130434782609, 0.05, 0.055555555555556
11242, 1.6347826086957, 0.05, 0.027777777777778
11243, 1.6782608695652, 0.05, 0.47222222222222
11244, 1.6565217391304, 0.05, 0.44444444444444
11245, 1.6782608695652, 0.05, 0.41666666666667
11246, 1.6565217391304, 0.05, 0.38888888888889
11247, 1.6782608695652, 0.05, 0.36111111111111
11248, 1.6565217391304, 0.05, 0.33333333333333
11249, 1.6782608695652, 0.05, 0.30555555555556
11250, 1.6565217391304, 0.05, 0.27777777777778
11251, 1.6782608695652, 0.05, 0.25
11252, 1.6565217391304, 0.05, 0.22222222222222
11253, 1.6782608695652, 0.05, 0.19444444444444
11254, 1.6565217391304, 0.05, 0.16666666666667
11255, 1.6782608695652, 0.05, 0.13888888888889
11256, 1.6565217391304, 0.05, 0.11111111111111
11257, 1.6782608695652, 0.05, 0.083333333333333
11258, 1.6565217391304, 0.05, 0.055555555555556
11259, 1.6782608695652, 0.05, 0.027777777777778
11260, 1.7217391304348, 0.05, 0.47222222222222
11261, 1.7, 0.05, 0.44444444444444
11262, 1.7217391304348, 0.05, 0.41666666666667
11263, 1.7, 0.05, 0.38888888888889
11264, 1.7217391304348, 0.05, 0.36111111111111
11265, 1.7, 0.05, 0.33333333333333
11266, 1.7217391304348, 0.05, 0.30555555555556
11267, 1.7, 0.05, 0.27777777777778
11268, 1.7217391304348, 0.05, 0.25
11269, 1.7, 0.05, 0.22222222222222
11270, 1.7217391304348, 0.05, 0.19444444444444
11271, 1.7, 0.05, 0.16666666666667
11272, 1.7217391304348, 0.05, 0.13888888888889
11273, 1.7, 0.05, 0.11111111111111
11274, 1.7217391304348, 0.05, 0.083333333333333
11275, 1.7, 0.05, 0.055555555555556
11276, 1.7217391304348, 0.05, 0.027777777777778
11277, 1.7652173913043, 0.05, 0.47222222222222
11278, 1.7434782608696, 0.05, 0.44444444444444
11279, 1.7652173913043, 0.05, 0.41666666666667
11280, 1.7434782608696, 0.05, 0.38888888888889
11281, 1.7652173913043, 0.05, 0.36111111111111
11282, 1.7434782608696, 0.05, 0.33333333333333
11283, 1.7652173913043, 0.05, 0.30555555555556
11284, 1.7434782608696, 0.05, 0.27777777777778
11285, 1.7652173913043, 0.05, 0.25
11286, 1.7434782608696, 0.05, 0.22222222222222
11287, 1.7652173913043, 0.05, 0.19444444444444
11288, 1.7434782608696, 0.05, 0.16666666666667
11289, 1.7652173913043, 0.05, 0.13888888888889
11290, 1.7434782608696, 0.05, 0.11111111111111
11291, 1.7652173913043, 0.05, 0.083333333333333
11292, 1.7434782608696, 0.05, 0.055555555555556
11293, 1.7652173913043, 0.05, 0.027777777777778
11294, 1.8086956521739, 0.05, 0.47222222222222
11295, 1.7869565217391, 0.05, 0.44444444444444
11296, 1.8086956521739, 0.05, 0.41666666666667
11297, 1.7869565217391, 0.05, 0.38888888888889
11298, 1.8086956521739, 0.05, 0.36111111111111
11299, 1.7869565217391, 0.05, 0.33333333333333
11300, 1.8086956521739, 0.05, 0.30555555555556
11301, 1.7869565217391, 0.05, 0.27777777777778
11302, 1.8086956521739, 0.05, 0.25
11303, 1.7869565217391, 0.05, 0.22222222222222
11304, 1.8086956521739, 0.05, 0.19444444444444
11305, 1.7869565217391, 0.05, 0.16666666666667
11306, 1.8086956521739, 0.05, 0.13888888888889
11307, 1.7869565217391, 0.05, 0.11111111111111
11308, 1.8086956521739, 0.05, 0.083333333333333
11309, 1.7869565217391, 0.05, 0.055555555555556
11310, 1.8086956521739, 0.05, 0.027777777777778
11311, 1.8521739130435, 0.05, 0.47222222222222
11312, 1.8304347826087, 0.05, 0.44444444444444
11313, 1.8521739130435, 0.05, 0.41666666666667
11314, 1.8304347826087, 0.05, 0.38888888888889
11315, 1.8521739130435, 0.05, 0.36111111111111
11316, 1.8304347826087, 0.05, 0.33333333333333
11317, 1.8521739130435, 0.05, 0.30555555555556
11318, 1.8304347826087, 0.05, 0.27777777777778
11319, 1.8521739130435, 0.05, 0.25
11320, 1.8304347826087, 0.05, 0.22222222222222
11321, 1.8521739130435, 0.05, 0.19444444444444
11322, 1.8304347826087, 0.05, 0.16666666666667
11323, 1.8521739130435, 0.05, 0.13888888888889
11324, 1.8304347826087, 0.05, 0.11111111111111
11325, 1.8521739130435, 0.05, 0.083333333333333
11326, 1.8304347826087, 0.05, 0.055555555555556
11327, 1.8521739130435, 0.05, 0.027777777777778
11328, 1.895652173913, 0.05, 0.47222222222222
11329, 1.8739130434783, 0.05, 0.44444444444444
11330, 1.895652173913, 0.05, 0.41666666666667
11331, 1.8739130434783, 0.05, 0.38888888888889
11332, 1.895652173913, 0.05, 0.36111111111111
11333, 1.8739130434783, 0.05, 0.33333333333333
11334, 1.895652173913, 0.05, 0.30555555555556
11335, 1.8739130434783, 0.05, 0.27777777777778
11336, 1.895652173913, 0.05, 0.25
11337, 1.8739130434783, 0.05, 0.22222222222222
11338, 1.895652173913, 0.05, 0.19444444444444
11339, 1.8739130434783, 0.05, 0.16666666666667
11340, 1.895652173913, 0.05, 0.13888888888889
11341, 1.8739130434783, 0.05, 0.11111111111111
11342, 1.895652173913, 0.05, 0.083333333333333
11343, 1.8739130434783, 0.05, 0.055555555555556
11344, 1.895652173913, 0.05, 0.027777777777778
11345, 1.9391304347826, 0.05, 0.47222222222222
11346, 1.9173913043478, 0.05, 0.44444444444444
11347, 1.9391304347826, 0.05, 0.41666666666667
11348, 1.9173913043478, 0.05, 0.38888888888889
11349, 1.9391304347826, 0.05, 0.36111111111111
11350, 1.9173913043478, 0.05, 0.33333333333333
11351, 1.9391304347826, 0.05, 0.30555555555556
11352, 1.9173913043478, 0.05, 0.27777777777778
11353, 1.9391304347826, 0.05, 0.25
11354, 1.9173913043478, 0.05, 0.22222222222222
11355, 1.9391304347826, 0.05, 0.19444444444444
11356, 1.9173913043478, 0.05, 0.16666666666667
11357, 1.9391304347826, 0.05, 0.13888888888889
11358, 1.9173913043478, 0.05, 0.11111111111111
11359, 1.9391304347826, 0.05, 0.083333333333333
11360, 1.9173913043478, 0.05, 0.055555555555556
11361, 1.9391304347826, 0.05, 0.027777777777778
11362, 1.9826086956522, 0.05, 0.47222222222222
11363, 1.9608695652174, 0.05, 0.44444444444444
11364, 1.9826086956522, 0.05, 0.41666666666667
11365, 1.9608695652174, 0.05, 0.38888888888889
11366, 1.9826086956522, 0.05, 0.36111111111111
11367, 1.9608695652174, 0.05, 0.33333333333333
11368, 1.9826086956522, 0.05, 0.30555555555556
11369, 1.9608695652174, 0.05, 0.27777777777778
11370, 1.9826086956522, 0.05, 0.25
11371, 1.9608695652174, 0.05, 0.22222222222222
11372, 1.9826086956522, 0.05, 0.19444444444444
11373, 1.9608695652174, 0.05, 0.16666666666667
11374, 1.9826086956522, 0.05, 0.13888888888889
11375, 1.9608695652174, 0.05, 0.11111111111111
11376, 1.9826086956522, 0.05, 0.083333333333333
11377, 1.9608695652174, 0.05, 0.055555555555556
11378, 1.9826086956522, 0.05, 0.027777777777778
11379, 2.0260869565217, 0.05, 0.47222222222222
11380, 2.004347826087, 0.05, 0.44444444444444
11381, 2.0260869565217, 0.05, 0.41666666666667
11382, 2.004347826087, 0.05, 0.38888888888889
11383, 2.0260869565217, 0.05, 0.36111111111111
11384, 2.004347826087, 0.05, 0.33333333333333
11385, 2.0260869565217, 0.05, 0.30555555555556
11386, 2.004347826087, 0.05, 0.27777777777778
11387, 2.0260869565217, 0.05, 0.25
11388, 2.004347826087, 0.05, 0.22222222222222
11389, 2.0260869565217, 0.05, 0.19444444444444
11390, 2.004347826087, 0.05, 0.16666666666667
11391, 2.0260869565217, 0.05, 0.13888888888889
11392, 2.004347826087, 0.05, 0.11111111111111
11393, 2.0260869565217, 0.05, 0.083333333333333
11394, 2.004347826087, 0.05, 0.055555555555556
11395, 2.0260869565217, 0.05, 0.027777777777778
11396, 2.0695652173913, 0.05, 0.47222222222222
11397, 2.0478260869565, 0.05, 0.44444444444444
11398, 2.0695652173913, 0.05, 0.41666666666667
11399, 2.0478260869565, 0.05, 0.38888888888889
11400, 2.0695652173913, 0.05, 0.36111111111111
11401, 2.0478260869565, 0.05, 0.33333333333333
11402, 2.0695652173913, 0.05, 0.30555555555556
11403, 2.0478260869565, 0.05, 0.27777777777778
11404, 2.0695652173913, 0.05, 0.25
11405, 2.0478260869565, 0.05, 0.22222222222222
11406, 2.0695652173913, 0.05, 0.19444444444444
11407, 2.0478260869565, 0.05, 0.16666666666667
11408, 2.0695652173913, 0.05, 0.13888888888889
11409, 2.0478260869565, 0.05, 0.11111111111111
11410, 2.0695652173913, 0.05, 0.083333333333333
11411, 2.0478260869565, 0.05, 0.055555555555556
11412, 2.0695652173913, 0.05, 0.027777777777778
11413, 2.1130434782609, 0.05, 0.47222222222222
11414, 2.0913043478261, 0.05, 0.44444444444444
11415, 2.1130434782609, 0.05, 0.41666666666667
11416, 2.0913043478261, 0.05, 0.38888888888889
11417, 2.1130434782609, 0.05, 0.36111111111111
11418, 2.0913043478261, 0.05, 0.33333333333333
11419, 2.1130434782609, 0.05, 0.30555555555556
11420, 2.0913043478261, 0.05, 0.27777777777778
11421, 2.1130434782609, 0.05, 0.25
11422, 2.0913043478261, 0.05, 0.22222222222222
11423, 2.1130434782609, 0.05, 0.19444444444444
11424, 2.0913043478261, 0.05, 0.16666666666667
11425, 2.1130434782609, 0.05, 0.13888888888889
11426, 2.0913043478261, 0.05, 0.11111111111111
11427, 2.1130434782609, 0.05, 0.083333333333333
11428, 2.0913043478261, 0.05, 0.055555555555556
11429, 2.1130434782609, 0.05, 0.027777777777778
11430, 2.1565217391304, 0.05, 0.47222222222222
11431, 2.1347826086957, 0.05, 0.44444444444444
11432, 2.1565217391304, 0.05, 0.41666666666667
11433, 2.1347826086957, 0.05, 0.38888888888889
11434, 2.1565217391304, 0.05, 0.36111111111111
11435, 2.1347826086957, 0.05, 0.33333333333333
11436, 2.1565217391304, 0.05, 0.30555555555556
11437, 2.1347826086957, 0.05, 0.27777777777778
11438, 2.1565217391304, 0.05, 0.25
11439, 2.1347826086957, 0.05, 0.22222222222222
11440, 2.1565217391304, 0.05, 0.19444444444444
11441, 2.1347826086957, 0.05, 0.16666666666667
11442, 2.1565217391304, 0.05, 0.13888888888889
11443, 2.1347826086957, 0.05, 0.11111111111111
11444, 2.1565217391304, 0.05, 0.083333333333333
11445, 2.1347826086957, 0.05, 0.055555555555556
11446, 2.1565217391304, 0.05, 0.027777777777778
11447, 2.1782608695652, 0.05, 0.44444444444444
11448, 2.1782608695652, 0.05, 0.38888888888889
11449, 2.1782608695652, 0.05, 0.33333333333333
11450, 2.1782608695652, 0.05, 0.27777777777778
11451, 2.1782608695652, 0.05, 0.22222222222222
11452, 2.1782608695652, 0.05, 0.16666666666667
11453, 2.1782608695652, 0.05, 0.11111111111111
11454, 2.1782608695652, 0.05, 0.055555555555556
11455, 2.25, 0.016666666666667, 0.5
11456, 2.25, -0.016666666666667, 0.5
11457, 2.225, 0.016666666666667, 0.5
11458, 2.25, 0.033333333333333, 0.5
11459, 2.225, -0.016666666666667, 0.5
11460, 2.25, -1.1102230246252e-16, 0.5
11461, 2.25, -0.033333333333333, 0.5
11462, 2.275, 0.016666666666667, 0.5
11463, 2.275, -0.016666666666667, 0.5
11464, 2.25, 0.016666666666667, 0
11465, 2.25, -0.016666666666667, 0
11466, 2.25, 0.033333333333333, 0
11467, 2.225, 0.016666666666667, 0
11468, 2.25, -1.1102230246252e-16, 0
11469, 2.225, -0.016666666666667, 0
11470, 2.25, -0.033333333333333, 0
11471, 2.275, 0.016666666666667, 0
11472, 2.275, -0.016666666666667, 0
11473, 2.25, 0.05, 0.44444444444444
11474, 2.25, 0.05, 0.38888888888889
11475, 2.25, 0.05, 0.33333333333333
11476, 2.25, 0.05, 0.27777777777778
11477, 2.25, 0.05, 0.22222222222222
11478, 2.25, 0.05, 0.16666666666667
11479, 2.25, 0.05, 0.11111111111111
11480, 2.25, 0.05, 0.055555555555556
11481, 2.25, 0.05, 0.47222222222222
11482, 2.225, 0.05, 0.44444444444444
11483, 2.25, 0.05, 0.41666666666667
11484, 2.225, 0.05, 0.38888888888889
11485, 2.25, 0.05, 0.36111111111111
11486, 2.225, 0.05, 0.33333333333333
11487, 2.25, 0.05, 0.30555555555556
11488, 2.225, 0.05, 0.27777777777778
11489, 2.25, 0.05, 0.25
11490, 2.225, 0.05, 0.22222222222222
11491, 2.25, 0.05, 0.19444444444444
11492, 2.225, 0.05, 0.16666666666667
11493, 2.25, 0.05, 0.13888888888889
11494, 2.225, 0.05, 0.11111111111111
11495, 2.25, 0.05, 0.083333333333333
11496, 2.225, 0.05, 0.055555555555556
11497, 2.25, 0.05, 0.027777777777778
11498, 2.275, 0.05, 0.44444444444444
11499, 2.275, 0.05, 0.38888888888889
11500, 2.275, 0.05, 0.33333333333333
11501, 2.275, 0.05, 0.27777777777778
11502, 2.275, 0.05, 0.22222222222222
11503, 2.275, 0.05, 0.16666666666667
11504, 2.275, 0.05, 0.11111111111111
11505, 2.275, 0.05, 0.055555555555556
11506, 2.25, -0.05, 0.44444444444444
11507, 2.25, -0.05, 0.38888888888889
11508, 2.25, -0.05, 0.33333333333333
11509, 2.25, -0.05, 0.27777777777778
11510, 2.25, -0.05, 0.22222222222222
11511, 2.25, -0.05, 0.16666666666667
11512, 2.25, -0.05, 0.11111111111111
11513, 2.25, -0.05, 0.055555555555556
11514, 2.225, -0.05, 0.44444444444444
11515, 2.25, -0.05, 0.47222222222222
11516, 2.225, -0.05, 0.38888888888889
11517, 2.25, -0.05, 0.41666666666667
11518, 2.225, -0.05, 0.33333333333333
11519, 2.25, -0.05, 0.36111111111111
11520, 2.225, -0.05, 0.27777777777778
11521, 2.25, -0.05, 0.30555555555556
11522, 2.225, -0.05, 0.22222222222222
11523, 2.25, -0.05, 0.25
11524, 2.225, -0.05, 0.16666666666667
11525, 2.25, -0.05, 0.19444444444444
11526, 2.225, -0.05, 0.11111111111111
11527, 2.25, -0.05, 0.13888888888889
11528, 2.225, -0.05, 0.055555555555556
11529, 2.25, -0.05, 0.083333333333333
11530, 2.25, -0.05, 0.027777777777778
11531, 2.275, -0.05, 0.44444444444444
11532, 2.275, -0.05, 0.38888888888889
11533, 2.275, -0.05, 0.33333333333333
11534, 2.275, -0.05, 0.27777777777778
11535, 2.275, -0.05, 0.22222222222222
11536, 2.275, -0.05, 0.16666666666667
11537, 2.275, -0.05, 0.11111111111111
11538, 2.275, -0.05, 0.055555555555556
11539, 2.3, 0.016666666666667, 0.44444444444444
11540, 2.3, 0.016666666666667, 0.38888888888889
11541, 2.3, 0.016666666666667, 0.33333333333333
11542, 2.3, 0.016666666666667, 0.27777777777778
11543, 2.3, 0.016666666666667, 0.22222222222222
11544, 2.3, 0.016666666666667, 0.16666666666667
11545, 2.3, 0.016666666666667, 0.11111111111111
11546, 2.3, 0.016666666666667, 0.055555555555556
11547, 2.3, -0.016666666666667, 0.44444444444444
11548, 2.3, -0.016666666666667, 0.38888888888889
11549, 2.3, -0.016666666666667, 0.33333333333333
11550, 2.3, -0.016666666666667, 0.27777777777778
11551, 2.3, -0.016666666666667, 0.22222222222222
11552, 2.3, -0.016666666666667, 0.16666666666667
11553, 2.3, -0.016666666666667, 0.11111111111111
11554, 2.3, -0.016666666666667, 0.055555555555556
11555, 2.3, 0.016666666666667, 0.47222222222222
11556, 2.3, 0.033333333333333, 0.44444444444444
11557, 2.3, 0.016666666666667, 0.41666666666667
11558, 2.3, 0.033333333333333, 0.38888888888889
11559, 2.3, 0.016666666666667, 0.36111111111111
11560, 2.3, 0.033333333333333, 0.33333333333333
11561, 2.3, 0.016666666666667, 0.30555555555556
11562, 2.3, 0.033333333333333, 0.27777777777778
11563, 2.3, 0.016666666666667, 0.25
11564, 2.3, 0.033333333333333, 0.22222222222222
11565, 2.3, 0.016666666666667, 0.19444444444444
11566, 2.3, 0.033333333333333, 0.16666666666667
11567, 2.3, 0.016666666666667, 0.13888888888889
11568, 2.3, 0.033333333333333, 0.11111111111111
11569, 2.3, 0.016666666666667, 0.083333333333333
11570, 2.3, 0.033333333333333, 0.055555555555556
11571, 2.3, 0.016666666666667, 0.027777777777778
11572, 2.3, -0.016666666666667, 0.47222222222222
11573, 2.3, -1.3877787807814e-16, 0.44444444444444
11574, 2.3, -0.016666666666667, 0.41666666666667
11575, 2.3, -1.3183898417424e-16, 0.38888888888889
11576, 2.3, -0.016666666666667, 0.36111111111111
11577, 2.3, -1.3183898417424e-16, 0.33333333333333
11578, 2.3, -0.016666666666667, 0.30555555555556
11579, 2.3, -1.3183898417424e-16, 0.27777777777778
11580, 2.3, -0.016666666666667, 0.25
11581, 2.3, -1.3183898417424e-16, 0.22222222222222
11582, 2.3, -0.016666666666667, 0.19444444444444
11583, 2.3, -1.3183898417424e-16, 0.16666666666667
11584, 2.3, -0.016666666666667, 0.13888888888889
11585, 2.3, -1.3183898417424e-16, 0.11111111111111
11586, 2.3, -0.016666666666667, 0.083333333333333
11587, 2.3, -1.3877787807814e-16, 0.055555555555556
11588, 2.3, -0.016666666666667, 0.027777777777778
11589, 2.3, -0.033333333333333, 0.44444444444444
11590, 2.3, -0.033333333333333, 0.38888888888889
11591, 2.3, -0.033333333333333, 0.33333333333333
11592, 2.3, -0.033333333333333, 0.27777777777778
11593, 2.3, -0.033333333333333, 0.22222222222222
11594, 2.3, -0.033333333333333, 0.16666666666667
11595, 2.3, -0.033333333333333, 0.11111111111111
11596, 2.3, -0.033333333333333, 0.055555555555556
11597, 2.25, -0.1, 0.5
11598, 2.25, -0.15, 0.5
11599, 2.25, -0.2, 0.5
11600, 2.225, -0.1, 0.5
11601, 2.25, -0.075, 0.5
11602, 2.275, -0.1, 0.5
11603, 2.225, -0.15, 0.5
11604, 2.25, -0.125, 0.5
11605, 2.275, -0.15, 0.5
11606, 2.225, -0.2, 0.5
11607, 2.25, -0.175, 0.5
11608, 2.275, -0.2, 0.5
11609, 2.25, -0.225, 0.5
11610, 2.25, -0.1, 0
11611, 2.25, -0.15, 0
11612, 2.25, -0.2, 0
11613, 2.25, -0.075, 0
11614, 2.225, -0.1, 0
11615, 2.275, -0.1, 0
11616, 2.25, -0.125, 0
11617, 2.225, -0.15, 0
11618, 2.275, -0.15, 0
11619, 2.25, -0.175, 0
11620, 2.225, -0.2, 0
11621, 2.275, -0.2, 0
11622, 2.25, -0.225, 0
11623, 2.3, -0.1, 0.44444444444444
11624, 2.3, -0.1, 0.38888888888889
11625, 2.3, -0.1, 0.33333333333333
11626, 2.3, -0.1, 0.27777777777778
11627, 2.3, -0.1, 0.22222222222222
11628, 2.3, -0.1, 0.16666666666667
11629, 2.3, -0.1, 0.11111111111111
11630, 2.3, -0.1, 0.055555555555556
11631, 2.3, -0.15, 0.44444444444444
11632, 2.3, -0.15, 0.38888888888889
11633, 2.3, -0.15, 0.33333333333333
11634, 2.3, -0.15, 0.27777777777778
11635, 2.3, -0.15, 0.22222222222222
11636, 2.3, -0.15, 0.16666666666667
11637, 2.3, -0.15, 0.11111111111111
11638, 2.3, -0.15, 0.055555555555556
11639, 2.3, -0.2, 0.44444444444444
11640, 2.3, -0.2, 0.38888888888889
11641, 2.3, -0.2, 0.33333333333333
11642, 2.3, -0.2, 0.27777777777778
11643, 2.3, -0.2, 0.22222222222222
11644, 2.3, -0.2, 0.16666666666667
11645, 2.3, -0.2, 0.11111111111111
11646, 2.3, -0.2, 0.055555555555556
11647, 2.3, -0.1, 0.47222222222222
11648, 2.3, -0.075, 0.44444444444444
11649, 2.3, -0.1, 0.41666666666667
11650, 2.3, -0.075, 0.38888888888889
11651, 2.3, -0.1, 0.36111111111111
11652, 2.3, -0.075, 0.33333333333333
11653, 2.3, -0.1, 0.30555555555556
11654, 2.3, -0.075, 0.27777777777778
11655, 2.3, -0.1, 0.25
11656, 2.3, -0.075, 0.22222222222222
11657, 2.3, -0.1, 0.19444444444444
11658, 2.3, -0.075, 0.16666666666667
11659, 2.3, -0.1, 0.13888888888889
11660, 2.3, -0.075, 0.11111111111111
11661, 2.3, -0.1, 0.083333333333333
11662, 2.3, -0.075, 0.055555555555556
11663, 2.3, -0.1, 0.027777777777778
11664, 2.3, -0.15, 0.47222222222222
11665, 2.3, -0.125, 0.44444444444444
11666, 2.3, -0.15, 0.41666666666667
11667, 2.3, -0.125, 0.38888888888889
11668, 2.3, -0.15, 0.36111111111111
11669, 2.3, -0.125, 0.33333333333333
11670, 2.3, -0.15, 0.30555555555556
11671, 2.3, -0.125, 0.27777777777778
11672, 2.3, -0.15, 0.25
11673, 2.3, -0.125, 0.22222222222222
11674, 2.3, -0.15, 0.19444444444444
11675, 2.3, -0.125, 0.16666666666667
11676, 2.3, -0.15, 0.13888888888889
11677, 2.3, -0.125, 0.11111111111111
11678, 2.3, -0.15, 0.083333333333333
11679, 2.3, -0.125, 0.055555555555556
11680, 2.3, -0.15, 0.027777777777778
11681, 2.3, -0.2, 0.47222222222222
11682, 2.3, -0.175, 0.44444444444444
11683, 2.3, -0.2, 0.41666666666667
11684, 2.3, -0.175, 0.38888888888889
11685, 2.3, -0.2, 0.36111111111111
11686, 2.3, -0.175, 0.33333333333333
11687, 2.3, -0.2, 0.30555555555556
11688, 2.3, -0.175, 0.27777777777778
11689, 2.3, -0.2, 0.25
11690, 2.3, -0.175, 0.22222222222222
11691, 2.3, -0.2, 0.19444444444444
11692, 2.3, -0.175, 0.16666666666667
11693, 2.3, -0.2, 0.13888888888889
11694, 2.3, -0.175, 0.11111111111111
11695, 2.3, -0.2, 0.083333333333333
11696, 2.3, -0.175, 0.055555555555556
11697, 2.3, -0.2, 0.027777777777778
11698, 2.3, -0.225, 0.44444444444444
11699, 2.3, -0.225, 0.38888888888889
11700, 2.3, -0.225, 0.33333333333333
11701, 2.3, -0.225, 0.27777777777778
11702, 2.3, -0.225, 0.22222222222222
11703, 2.3, -0.225, 0.16666666666667
11704, 2.3, -0.225, 0.11111111111111
11705, 2.3, -0.225, 0.055555555555556
11706, 2.25, -0.25, 0.44444444444444
11707, 2.25, -0.25, 0.38888888888889
11708, 2.25, -0.25, 0.33333333333333
11709, 2.25, -0.25, 0.27777777777778
11710, 2.25, -0.25, 0.22222222222222
11711, 2.25, -0.25, 0.16666666666667
11712, 2.25, -0.25, 0.11111111111111
11713, 2.25, -0.25, 0.055555555555556
11714, 2.225, -0.25, 0.44444444444444
11715, 2.25, -0.25, 0.47222222222222
11716, 2.225, -0.25, 0.38888888888889
11717, 2.25, -0.25, 0.41666666666667
11718, 2.225, -0.25, 0.33333333333333
11719, 2.25, -0.25, 0.36111111111111
11720, 2.225, -0.25, 0.27777777777778
11721, 2.25, -0.25, 0.30555555555556
11722, 2.225, -0.25, 0.22222222222222
11723, 2.25, -0.25, 0.25
11724, 2.225, -0.25, 0.16666666666667
11725, 2.25, -0.25, 0.19444444444444
11726, 2.225, -0.25, 0.11111111111111
11727, 2.25, -0.25, 0.13888888888889
11728, 2.225, -0.25, 0.055555555555556
11729, 2.25, -0.25, 0.083333333333333
11730, 2.25, -0.25, 0.027777777777778
11731, 2.275, -0.25, 0.44444444444444
11732, 2.275, -0.25, 0.38888888888889
11733, 2.275, -0.25, 0.33333333333333
11734, 2.275, -0.25, 0.27777777777778
11735, 2.275, -0.25, 0.22222222222222
11736, 2.275, -0.25, 0.16666666666667
11737, 2.275, -0.25, 0.11111111111111
11738, 2.275, -0.25, 0.055555555555556
11739, 0.95652173913043, 1.4833333333333, 0
11740, 0.91304347826087, 1.4833333333333, 0
11741, 0.8695652173913, 1.4833333333333, 0
11742, 0.82608695652174, 1.4833333333333, 0
11743, 0.78260869565217, 1.4833333333333, 0
11744, 0.73913043478261, 1.4833333333333, 0
11745, 0.69565217391304, 1.4833333333333, 0
11746, 0.65217391304348, 1.4833333333333, 0
11747, 0.60869565217391, 1.4833333333333, 0
11748, 0.56521739130435, 1.4833333333333, 0
11749, 0.52173913043478, 1.4833333333333, 0
11750, 0.47826086956522, 1.4833333333333, 0
11751, 0.43478260869565, 1.4833333333333, 0
11752, 0.39130434782609, 1.4833333333333, 0
11753, 0.34782608695652, 1.4833333333333, 0
11754, 0.30434782608696, 1.4833333333333, 0
11755, 0.26086956521739, 1.4833333333333, 0
11756, 0.21739130434783, 1.4833333333333, 0
11757, 0.17391304347826, 1.4833333333333, 0
11758, 0.1304347826087, 1.4833333333333, 0
11759, 0.08695652173913, 1.4833333333333, 0
11760, 0.043478260869565, 1.4833333333333, 0
11761, 0.95652173913043, 1.5166666666667, 0
11762, 0.91304347826087, 1.5166666666667, 0
11763, 0.8695652173913, 1.5166666666667, 0
11764, 0.82608695652174, 1.5166666666667, 0
11765, 0.78260869565217, 1.5166666666667, 0
11766, 0.73913043478261, 1.5166666666667, 0
11767, 0.69565217391304, 1.5166666666667, 0
11768, 0.65217391304348, 1.5166666666667, 0
11769, 0.60869565217391, 1.5166666666667, 0
11770, 0.56521739130435, 1.5166666666667, 0
11771, 0.52173913043478, 1.5166666666667, 0
11772, 0.47826086956522, 1.5166666666667, 0
11773, 0.43478260869565, 1.5166666666667, 0
11774, 0.39130434782609, 1.5166666666667, 0
11775, 0.34782608695652, 1.5166666666667, 0
11776, 0.30434782608696, 1.5166666666667, 0
11777, 0.26086956521739, 1.5166666666667, 0
11778, 0.21739130434783, 1.5166666666667, 0
11779, 0.17391304347826, 1.5166666666667, 0
11780, 0.1304347826087, 1.5166666666667, 0
11781, 0.08695652173913, 1.5166666666667, 0
11782, 0.043478260869565, 1.5166666666667, 0
11783, 0.95652173913043, 1.4666666666667, 0
11784, 0.97826086956522, 1.4833333333333, 0
11785, 0.91304347826087, 1.4666666666667, 0
11786, 0.93478260869565, 1.4833333333333, 0
11787, 0.8695652173913, 1.4666666666667, 0
11788, 0.89130434782609, 1.4833333333333, 0
11789, 0.82608695652174, 1.4666666666667, 0
11790, 0.84782608695652, 1.4833333333333, 0
11791, 0.78260869565217, 1.4666666666667, 0
11792, 0.80434782608696, 1.4833333333333, 0
11793, 0.73913043478261, 1.4666666666667, 0
11794, 0.76086956521739, 1.4833333333333, 0
11795, 0.69565217391304, 1.4666666666667, 0
11796, 0.71739130434783, 1.4833333333333, 0
11797, 0.65217391304348, 1.4666666666667, 0
11798, 0.67391304347826, 1.4833333333333, 0
11799, 0.60869565217391, 1.4666666666667, 0
11800, 0.6304347826087, 1.4833333333333, 0
11801, 0.56521739130435, 1.4666666666667, 0
11802, 0.58695652173913, 1.4833333333333, 0
11803, 0.52173913043478, 1.4666666666667, 0
11804, 0.54347826086957, 1.4833333333333, 0
11805, 0.47826086956522, 1.4666666666667, 0
11806, 0.5, 1.4833333333333, 0
11807, 0.43478260869565, 1.4666666666667, 0
11808, 0.45652173913043, 1.4833333333333, 0
11809, 0.39130434782609, 1.4666666666667, 0
11810, 0.41304347826087, 1.4833333333333, 0
11811, 0.34782608695652, 1.4666666666667, 0
11812, 0.3695652173913, 1.4833333333333, 0
11813, 0.30434782608696, 1.4666666666667, 0
11814, 0.32608695652174, 1.4833333333333, 0
11815, 0.26086956521739, 1.4666666666667, 0
11816, 0.28260869565217, 1.4833333333333, 0
11817, 0.21739130434783, 1.4666666666667, 0
11818, 0.23913043478261, 1.4833333333333, 0
11819, 0.17391304347826, 1.4666666666667, 0
11820, 0.19565217391304, 1.4833333333333, 0
11821, 0.1304347826087, 1.4666666666667, 0
11822, 0.15217391304348, 1.4833333333333, 0
11823, 0.08695652173913, 1.4666666666667, 0
11824, 0.10869565217391, 1.4833333333333, 0
11825, 0.043478260869565, 1.4666666666667, 0
11826, 0.065217391304348, 1.4833333333333, 0
11827, 0.021739130434783, 1.4833333333333, 0
11828, 0.95652173913043, 1.5, 0
11829, 0.97826086956522, 1.5166666666667, 0
11830, 0.91304347826087, 1.5, 0
11831, 0.93478260869565, 1.5166666666667, 0
11832, 0.8695652173913, 1.5, 0
11833, 0.89130434782609, 1.5166666666667, 0
11834, 0.82608695652174, 1.5, 0
11835, 0.84782608695652, 1.5166666666667, 0
11836, 0.78260869565217, 1.5, 0
11837, 0.80434782608696, 1.5166666666667, 0
11838, 0.73913043478261, 1.5, 0
11839, 0.76086956521739, 1.5166666666667, 0
11840, 0.69565217391304, 1.5, 0
11841, 0.71739130434783, 1.5166666666667, 0
11842, 0.65217391304348, 1.5, 0
11843, 0.67391304347826, 1.5166666666667, 0
11844, 0.60869565217391, 1.5, 0
11845, 0.6304347826087, 1.5166666666667, 0
11846, 0.56521739130435, 1.5, 0
11847, 0.58695652173913, 1.5166666666667, 0
11848, 0.52173913043478, 1.5, 0
11849, 0.54347826086957, 1.5166666666667, 0
11850, 0.47826086956522, 1.5, 0
11851, 0.5, 1.5166666666667, 0
11852, 0.43478260869565, 1.5, 0
11853, 0.45652173913043, 1.5166666666667, 0
11854, 0.39130434782609, 1.5, 0
11855, 0.41304347826087, 1.5166666666667, 0
11856, 0.34782608695652, 1.5, 0
11857, 0.3695652173913, 1.5166666666667, 0
11858, 0.30434782608696, 1.5, 0
11859, 0.32608695652174, 1.5166666666667, 0
11860, 0.26086956521739, 1.5, 0
11861, 0.28260869565217, 1.5166666666667, 0
11862, 0.21739130434783, 1.5, 0
11863, 0.23913043478261, 1.5166666666667, 0
11864, 0.17391304347826, 1.5, 0
11865, 0.19565217391304, 1.5166666666667, 0
11866, 0.1304347826087, 1.5, 0
11867, 0.15217391304348, 1.5166666666667, 0
11868, 0.08695652173913, 1.5, 0
11869, 0.10869565217391, 1.5166666666667, 0
11870, 0.043478260869565, 1.5, 0
11871, 0.065217391304348, 1.5166666666667, 0
11872, 0.021739130434783, 1.5166666666667, 0
11873, 0.95652173913043, 1.5333333333333, 0
11874, 0.91304347826087, 1.5333333333333, 0
11875, 0.8695652173913, 1.5333333333333, 0
11876, 0.82608695652174, 1.5333333333333, 0
11877, 0.78260869565217, 1.5333333333333, 0
11878, 0.73913043478261, 1.5333333333333, 0
11879, 0.69565217391304, 1.5333333333333, 0
11880, 0.65217391304348, 1.5333333333333, 0
11881, 0.60869565217391, 1.5333333333333, 0
11882, 0.56521739130435, 1.5333333333333, 0
11883, 0.52173913043478, 1.5333333333333, 0
11884, 0.47826086956522, 1.5333333333333, 0
11885, 0.43478260869565, 1.5333333333333, 0
11886, 0.39130434782609, 1.5333333333333, 0
11887, 0.34782608695652, 1.5333333333333, 0
11888, 0.30434782608696, 1.5333333333333, 0
11889, 0.26086956521739, 1.5333333333333, 0
11890, 0.21739130434783, 1.5333333333333, 0
11891, 0.17391304347826, 1.5333333333333, 0
11892, 0.1304347826087, 1.5333333333333, 0
11893, 0.08695652173913, 1.5333333333333, 0
11894, 0.043478260869565, 1.5333333333333, 0
11895, 1, 1.4833333333333, 0.44444444444444
11896, 1, 1.4833333333333, 0.38888888888889
11897, 1, 1.4833333333333, 0.33333333333333
11898, 1, 1.4833333333333, 0.27777777777778
11899, 1, 1.4833333333333, 0.22222222222222
11900, 1, 1.4833333333333, 0.16666666666667
11901, 1, 1.4833333333333, 0.11111111111111
11902, 1, 1.4833333333333, 0.055555555555556
11903, 1, 1.5166666666667, 0.44444444444444
11904, 1, 1.5166666666667, 0.38888888888889
11905, 1, 1.5166666666667, 0.33333333333333
11906, 1, 1.5166666666667, 0.27777777777778
11907, 1, 1.5166666666667, 0.22222222222222
11908, 1, 1.5166666666667, 0.16666666666667
11909, 1, 1.5166666666667, 0.11111111111111
11910, 1, 1.5166666666667, 0.055555555555556
11911, 1, 1.4666666666667, 0.44444444444444
11912, 1, 1.4833333333333, 0.47222222222222
11913, 1, 1.4666666666667, 0.38888888888889
11914, 1, 1.4833333333333, 0.41666666666667
11915, 1, 1.4666666666667, 0.33333333333333
11916, 1, 1.4833333333333, 0.36111111111111
11917, 1, 1.4666666666667, 0.27777777777778
11918, 1, 1.4833333333333, 0.30555555555556
11919, 1, 1.4666666666667, 0.22222222222222
11920, 1, 1.4833333333333, 0.25
11921, 1, 1.4666666666667, 0.16666666666667
11922, 1, 1.4833333333333, 0.19444444444444
11923, 1, 1.4666666666667, 0.11111111111111
11924, 1, 1.4833333333333, 0.13888888888889
11925, 1, 1.4666666666667, 0.055555555555556
11926, 1, 1.4833333333333, 0.083333333333333
11927, 1, 1.4833333333333, 0.027777777777778
11928, 1, 1.5, 0.44444444444444
11929, 1, 1.5166666666667, 0.47222222222222
11930, 1, 1.5, 0.38888888888889
11931, 1, 1.5166666666667, 0.41666666666667
11932, 1, 1.5, 0.33333333333333
11933, 1, 1.5166666666667, 0.36111111111111
11934, 1, 1.5, 0.27777777777778
11935, 1, 1.5166666666667, 0.30555555555556
11936, 1, 1.5, 0.22222222222222
11937, 1, 1.5166666666667, 0.25
11938, 1, 1.5, 0.16666666666667
11939, 1, 1.5166666666667, 0.19444444444444
11940, 1, 1.5, 0.11111111111111
11941, 1, 1.5166666666667, 0.13888888888889
11942, 1, 1.5, 0.055555555555556
11943, 1, 1.5166666666667, 0.083333333333333
11944, 1, 1.5166666666667, 0.027777777777778
11945, 1, 1.5333333333333, 0.44444444444444
11946, 1, 1.5333333333333, 0.38888888888889
11947, 1, 1.5333333333333, 0.33333333333333
11948, 1, 1.5333333333333, 0.27777777777778
11949, 1, 1.5333333333333, 0.22222222222222
11950, 1, 1.5333333333333, 0.16666666666667
11951, 1, 1.5333333333333, 0.11111111111111
11952, 1, 1.5333333333333, 0.055555555555556
11953, 0.95652173913043, 1.4833333333333, 0.5
11954, 0.91304347826087, 1.4833333333333, 0.5
11955, 0.8695652173913, 1.4833333333333, 0.5
11956, 0.82608695652174, 1.4833333333333, 0.5
11957, 0.78260869565217, 1.4833333333333, 0.5
11958, 0.73913043478261, 1.4833333333333, 0.5
11959, 0.69565217391304, 1.4833333333333, 0.5
11960, 0.65217391304348, 1.4833333333333, 0.5
11961, 0.60869565217391, 1.4833333333333, 0.5
11962, 0.56521739130435, 1.4833333333333, 0.5
11963, 0.52173913043478, 1.4833333333333, 0.5
11964, 0.47826086956522, 1.4833333333333, 0.5
11965, 0.43478260869565, 1.4833333333333, 0.5
11966, 0.39130434782609, 1.4833333333333, 0.5
11967, 0.34782608695652, 1.4833333333333, 0.5
11968, 0.30434782608696, 1.4833333333333, 0.5
11969, 0.26086956521739, 1.4833333333333, 0.5
11970, 0.21739130434783, 1.4833333333333, 0.5
11971, 0.17391304347826, 1.4833333333333, 0.5
11972, 0.1304347826087, 1.4833333333333, 0.5
11973, 0.08695652173913, 1.4833333333333, 0.5
11974, 0.043478260869565, 1.4833333333333, 0.5
11975, 0.95652173913043, 1.5166666666667, 0.5
11976, 0.91304347826087, 1.5166666666667, 0.5
11977, 0.8695652173913, 1.5166666666667, 0.5
11978, 0.82608695652174, 1.5166666666667, 0.5
11979, 0.78260869565217, 1.5166666666667, 0.5
11980, 0.73913043478261, 1.5166666666667, 0.5
11981, 0.69565217391304, 1.5166666666667, 0.5
11982, 0.65217391304348, 1.5166666666667, 0.5
11983, 0.60869565217391, 1.5166666666667, 0.5
11984, 0.56521739130435, 1.5166666666667, 0.5
11985, 0.52173913043478, 1.5166666666667, 0.5
11986, 0.47826086956522, 1.5166666666667, 0.5
11987, 0.43478260869565, 1.5166666666667, 0.5
11988, 0.39130434782609, 1.5166666666667, 0.5
11989, 0.34782608695652, 1.5166666666667, 0.5
11990, 0.30434782608696, 1.5166666666667, 0.5
11991, 0.26086956521739, 1.5166666666667, 0.5
11992, 0.21739130434783, 1.5166666666667, 0.5
11993, 0.17391304347826, 1.5166666666667, 0.5
11994, 0.1304347826087, 1.5166666666667, 0.5
11995, 0.08695652173913, 1.5166666666667, 0.5
11996, 0.043478260869565, 1.5166666666667, 0.5
11997, 0.97826086956522, 1.4833333333333, 0.5
11998, 0.95652173913043, 1.4666666666667, 0.5
11999, 0.93478260869565, 1.4833333333333, 0.5
12000, 0.91304347826087, 1.4666666666667, 0.5
12001, 0.89130434782609, 1.4833333333333, 0.5
12002, 0.8695652173913, 1.4666666666667, 0.5
12003, 0.84782608695652, 1.4833333333333, 0.5
12004, 0.82608695652174, 1.4666666666667, 0.5
12005, 0.80434782608696, 1.4833333333333, 0.5
12006, 0.78260869565217, 1.4666666666667, 0.5
12007, 0.76086956521739, 1.4833333333333, 0.5
12008, 0.73913043478261, 1.4666666666667, 0.5
12009, 0.71739130434783, 1.4833333333333, 0.5
12010, 0.69565217391304, 1.4666666666667, 0.5
12011, 0.67391304347826, 1.4833333333333, 0.5
12012, 0.65217391304348, 1.4666666666667, 0.5
12013, 0.6304347826087, 1.4833333333333, 0.5
12014, 0.60869565217391, 1.4666666666667, 0.5
12015, 0.58695652173913, 1.4833333333333, 0.5
12016, 0.56521739130435, 1.4666666666667, 0.5
12017, 0.54347826086957, 1.4833333333333, 0.5
12018, 0.52173913043478, 1.4666666666667, 0.5
12019, 0.5, 1.4833333333333, 0.5
12020, 0.47826086956522, 1.4666666666667, 0.5
12021, 0.45652173913043, 1.4833333333333, 0.5
12022, 0.43478260869565, 1.4666666666667, 0.5
12023, 0.41304347826087, 1.4833333333333, 0.5
12024, 0.39130434782609, 1.4666666666667, 0.5
12025, 0.3695652173913, 1.4833333333333, 0.5
12026, 0.34782608695652, 1.4666666666667, 0.5
12027, 0.32608695652174, 1.4833333333333, 0.5
12028, 0.30434782608696, 1.4666666666667, 0.5
12029, 0.28260869565217, 1.4833333333333, 0.5
12030, 0.26086956521739, 1.4666666666667, 0.5
12031, 0.23913043478261, 1.4833333333333, 0.5
12032, 0.21739130434783, 1.4666666666667, 0.5
12033, 0.19565217391304, 1.4833333333333, 0.5
12034, 0.17391304347826, 1.4666666666667, 0.5
12035, 0.15217391304348, 1.4833333333333, 0.5
12036, 0.1304347826087, 1.4666666666667, 0.5
12037, 0.10869565217391, 1.4833333333333, 0.5
12038, 0.08695652173913, 1.4666666666667, 0.5
12039, 0.065217391304348, 1.4833333333333, 0.5
12040, 0.043478260869565, 1.4666666666667, 0.5
12041, 0.021739130434783, 1.4833333333333, 0.5
12042, 0.97826086956522, 1.5166666666667, 0.5
12043, 0.95652173913043, 1.5, 0.5
12044, 0.93478260869565, 1.5166666666667, 0.5
12045, 0.91304347826087, 1.5, 0.5
12046, 0.89130434782609, 1.5166666666667, 0.5
12047, 0.8695652173913, 1.5, 0.5
12048, 0.84782608695652, 1.5166666666667, 0.5
12049, 0.82608695652174, 1.5, 0.5
12050, 0.80434782608696, 1.5166666666667, 0.5
12051, 0.78260869565217, 1.5, 0.5
12052, 0.76086956521739, 1.5166666666667, 0.5
12053, 0.73913043478261, 1.5, 0.5
12054, 0.71739130434783, 1.5166666666667, 0.5
12055, 0.69565217391304, 1.5, 0.5
12056, 0.67391304347826, 1.5166666666667, 0.5
12057, 0.65217391304348, 1.5, 0.5
12058, 0.6304347826087, 1.5166666666667, 0.5
12059, 0.60869565217391, 1.5, 0.5
12060, 0.58695652173913, 1.5166666666667, 0.5
12061, 0.56521739130435, 1.5, 0.5
12062, 0.54347826086957, 1.5166666666667, 0.5
12063, 0.52173913043478, 1.5, 0.5
12064, 0.5, 1.5166666666667, 0.5
12065, 0.47826086956522, 1.5, 0.5
12066, 0.45652173913043, 1.5166666666667, 0.5
12067, 0.43478260869565, 1.5, 0.5
12068, 0.41304347826087, 1.5166666666667, 0.5
12069, 0.39130434782609, 1.5, 0.5
12070, 0.3695652173913, 1.5166666666667, 0.5
12071, 0.34782608695652, 1.5, 0.5
12072, 0.32608695652174, 1.5166666666667, 0.5
12073, 0.30434782608696, 1.5, 0.5
12074, 0.28260869565217, 1.5166666666667, 0.5
12075, 0.26086956521739, 1.5, 0.5
12076, 0.23913043478261, 1.5166666666667, 0.5
12077, 0.21739130434783, 1.5, 0.5
12078, 0.19565217391304, 1.5166666666667, 0.5
12079, 0.17391304347826, 1.5, 0.5
12080, 0.15217391304348, 1.5166666666667, 0.5
12081, 0.1304347826087, 1.5, 0.5
12082, 0.10869565217391, 1.5166666666667, 0.5
12083, 0.08695652173913, 1.5, 0.5
12084, 0.065217391304348, 1.5166666666667, 0.5
12085, 0.043478260869565, 1.5, 0.5
12086, 0.021739130434783, 1.5166666666667, 0.5
12087, 0.95652173913043, 1.5333333333333, 0.5
12088, 0.91304347826087, 1.5333333333333, 0.5
12089, 0.8695652173913, 1.5333333333333, 0.5
12090, 0.82608695652174, 1.5333333333333, 0.5
12091, 0.78260869565217, 1.5333333333333, 0.5
12092, 0.73913043478261, 1.5333333333333, 0.5
12093, 0.69565217391304, 1.5333333333333, 0.5
12094, 0.65217391304348, 1.5333333333333, 0.5
12095, 0.60869565217391, 1.5333333333333, 0.5
12096, 0.56521739130435, 1.5333333333333, 0.5
12097, 0.52173913043478, 1.5333333333333, 0.5
12098, 0.47826086956522, 1.5333333333333, 0.5
12099, 0.43478260869565, 1.5333333333333, 0.5
12100, 0.39130434782609, 1.5333333333333, 0.5
12101, 0.34782608695652, 1.5333333333333, 0.5
12102, 0.30434782608696, 1.5333333333333, 0.5
12103, 0.26086956521739, 1.5333333333333, 0.5
12104, 0.21739130434783, 1.5333333333333, 0.5
12105, 0.17391304347826, 1.5333333333333, 0.5
12106, 0.1304347826087, 1.5333333333333, 0.5
12107, 0.08695652173913, 1.5333333333333, 0.5
12108, 0.043478260869565, 1.5333333333333, 0.5
12109, 0, 1.4833333333333, 0.44444444444444
12110, 0, 1.4833333333333, 0.38888888888889
12111, 0, 1.4833333333333, 0.33333333333333
12112, 0, 1.4833333333333, 0.27777777777778
12113, 0, 1.4833333333333, 0.22222222222222
12114, 0, 1.4833333333333, 0.16666666666667
12115, 0, 1.4833333333333, 0.11111111111111
12116, 0, 1.4833333333333, 0.055555555555556
12117, 0, 1.5166666666667, 0.44444444444444
12118, 0, 1.5166666666667, 0.38888888888889
12119, 0, 1.5166666666667, 0.33333333333333
12120, 0, 1.5166666666667, 0.27777777777778
12121, 0, 1.5166666666667, 0.22222222222222
12122, 0, 1.5166666666667, 0.16666666666667
12123, 0, 1.5166666666667, 0.11111111111111
12124, 0, 1.5166666666667, 0.055555555555556
12125, 0, 1.4833333333333, 0.47222222222222
12126, 0, 1.4666666666667, 0.44444444444444
12127, 0, 1.4833333333333, 0.41666666666667
12128, 0, 1.4666666666667, 0.38888888888889
12129, 0, 1.4833333333333, 0.36111111111111
12130, 0, 1.4666666666667, 0.33333333333333
12131, 0, 1.4833333333333, 0.30555555555556
12132, 0, 1.4666666666667, 0.27777777777778
12133, 0, 1.4833333333333, 0.25
12134, 0, 1.4666666666667, 0.22222222222222
12135, 0, 1.4833333333333, 0.19444444444444
12136, 0, 1.4666666666667, 0.16666666666667
12137, 0, 1.4833333333333, 0.13888888888889
12138, 0, 1.4666666666667, 0.11111111111111
12139, 0, 1.4833333333333, 0.083333333333333
12140, 0, 1.4666666666667, 0.055555555555556
12141, 0, 1.4833333333333, 0.027777777777778
12142, 0, 1.5166666666667, 0.47222222222222
12143, 0, 1.5, 0.44444444444444
12144, 0, 1.5166666666667, 0.41666666666667
12145, 0, 1.5, 0.38888888888889
12146, 0, 1.5166666666667, 0.36111111111111
12147, 0, 1.5, 0.33333333333333
12148, 0, 1.5166666666667, 0.30555555555556
12149, 0, 1.5, 0.27777777777778
12150, 0, 1.5166666666667, 0.25
12151, 0, 1.5, 0.22222222222222
12152, 0, 1.5166666666667, 0.19444444444444
12153, 0, 1.5, 0.16666666666667
12154, 0, 1.5166666666667, 0.13888888888889
12155, 0, 1.5, 0.11111111111111
12156, 0, 1.5166666666667, 0.083333333333333
12157, 0, 1.5, 0.055555555555556
12158, 0, 1.5166666666667, 0.027777777777778
12159, 0, 1.5333333333333, 0.44444444444444
12160, 0, 1.5333333333333, 0.38888888888889
12161, 0, 1.5333333333333, 0.33333333333333
12162, 0, 1.5333333333333, 0.27777777777778
12163, 0, 1.5333333333333, 0.22222222222222
12164, 0, 1.5333333333333, 0.16666666666667
12165, 0, 1.5333333333333, 0.11111111111111
12166, 0, 1.5333333333333, 0.055555555555556
12167, 0.043478260869565, 1.45, 0.055555555555556
12168, 0.043478260869565, 1.45, 0.11111111111111
12169, 0.043478260869565, 1.45, 0.16666666666667
12170, 0.043478260869565, 1.45, 0.22222222222222
12171, 0.043478260869565, 1.45, 0.27777777777778
12172, 0.043478260869565, 1.45, 0.33333333333333
12173, 0.043478260869565, 1.45, 0.38888888888889
12174, 0.043478260869565, 1.45, 0.44444444444444
12175, 0.08695652173913, 1.45, 0.055555555555556
12176, 0.08695652173913, 1.45, 0.11111111111111
12177, 0.08695652173913, 1.45, 0.16666666666667
12178, 0.08695652173913, 1.45, 0.22222222222222
12179, 0.08695652173913, 1.45, 0.27777777777778
12180, 0.08695652173913, 1.45, 0.33333333333333
12181, 0.08695652173913, 1.45, 0.38888888888889
12182, 0.08695652173913, 1.45, 0.44444444444444
12183, 0.1304347826087, 1.45, 0.055555555555556
12184, 0.1304347826087, 1.45, 0.11111111111111
12185, 0.1304347826087, 1.45, 0.16666666666667
12186, 0.1304347826087, 1.45, 0.22222222222222
12187, 0.1304347826087, 1.45, 0.27777777777778
12188, 0.1304347826087, 1.45, 0.33333333333333
12189, 0.1304347826087, 1.45, 0.38888888888889
12190, 0.1304347826087, 1.45, 0.44444444444444
12191, 0.17391304347826, 1.45, 0.055555555555556
12192, 0.17391304347826, 1.45, 0.11111111111111
12193, 0.17391304347826, 1.45, 0.16666666666667
12194, 0.17391304347826, 1.45, 0.22222222222222
12195, 0.17391304347826, 1.45, 0.27777777777778
12196, 0.17391304347826, 1.45, 0.33333333333333
12197, 0.17391304347826, 1.45, 0.38888888888889
12198, 0.17391304347826, 1.45, 0.44444444444444
12199, 0.21739130434783, 1.45, 0.055555555555556
12200, 0.21739130434783, 1.45, 0.11111111111111
12201, 0.21739130434783, 1.45, 0.16666666666667
12202, 0.21739130434783, 1.45, 0.22222222222222
12203, 0.21739130434783, 1.45, 0.27777777777778
12204, 0.21739130434783, 1.45, 0.33333333333333
12205, 0.21739130434783, 1.45, 0.38888888888889
12206, 0.21739130434783, 1.45, 0.44444444444444
12207, 0.26086956521739, 1.45, 0.055555555555556
12208, 0.26086956521739, 1.45, 0.11111111111111
12209, 0.26086956521739, 1.45, 0.16666666666667
12210, 0.26086956521739, 1.45, 0.22222222222222
12211, 0.26086956521739, 1.45, 0.27777777777778
12212, 0.26086956521739, 1.45, 0.33333333333333
12213, 0.26086956521739, 1.45, 0.38888888888889
12214, 0.26086956521739, 1.45, 0.44444444444444
12215, 0.30434782608696, 1.45, 0.055555555555556
12216, 0.30434782608696, 1.45, 0.11111111111111
12217, 0.30434782608696, 1.45, 0.16666666666667
12218, 0.30434782608696, 1.45, 0.22222222222222
12219, 0.30434782608696, 1.45, 0.27777777777778
12220, 0.30434782608696, 1.45, 0.33333333333333
12221, 0.30434782608696, 1.45, 0.38888888888889
12222, 0.30434782608696, 1.45, 0.44444444444444
12223, 0.34782608695652, 1.45, 0.055555555555556
12224, 0.34782608695652, 1.45, 0.11111111111111
12225, 0.34782608695652, 1.45, 0.16666666666667
12226, 0.34782608695652, 1.45, 0.22222222222222
12227, 0.34782608695652, 1.45, 0.27777777777778
12228, 0.34782608695652, 1.45, 0.33333333333333
12229, 0.34782608695652, 1.45, 0.38888888888889
12230, 0.34782608695652, 1.45, 0.44444444444444
12231, 0.39130434782609, 1.45, 0.055555555555556
12232, 0.39130434782609, 1.45, 0.11111111111111
12233, 0.39130434782609, 1.45, 0.16666666666667
12234, 0.39130434782609, 1.45, 0.22222222222222
12235, 0.39130434782609, 1.45, 0.27777777777778
12236, 0.39130434782609, 1.45, 0.33333333333333
12237, 0.39130434782609, 1.45, 0.38888888888889
12238, 0.39130434782609, 1.45, 0.44444444444444
12239, 0.43478260869565, 1.45, 0.055555555555556
12240, 0.43478260869565, 1.45, 0.11111111111111
12241, 0.43478260869565, 1.45, 0.16666666666667
12242, 0.43478260869565, 1.45, 0.22222222222222
12243, 0.43478260869565, 1.45, 0.27777777777778
12244, 0.43478260869565, 1.45, 0.33333333333333
12245, 0.43478260869565, 1.45, 0.38888888888889
12246, 0.43478260869565, 1.45, 0.44444444444444
12247, 0.47826086956522, 1.45, 0.055555555555556
12248, 0.47826086956522, 1.45, 0.11111111111111
12249, 0.47826086956522, 1.45, 0.16666666666667
12250, 0.47826086956522, 1.45, 0.22222222222222
12251, 0.47826086956522, 1.45, 0.27777777777778
12252, 0.47826086956522, 1.45, 0.33333333333333
12253, 0.47826086956522, 1.45, 0.38888888888889
12254, 0.47826086956522, 1.45, 0.44444444444444
12255, 0.52173913043478, 1.45, 0.055555555555556
12256, 0.52173913043478, 1.45, 0.11111111111111
12257, 0.52173913043478, 1.45, 0.16666666666667
12258, 0.52173913043478, 1.45, 0.22222222222222
12259, 0.52173913043478, 1.45, 0.27777777777778
12260, 0.52173913043478, 1.45, 0.33333333333333
12261, 0.52173913043478, 1.45, 0.38888888888889
12262, 0.52173913043478, 1.45, 0.44444444444444
12263, 0.56521739130435, 1.45, 0.055555555555556
12264, 0.56521739130435, 1.45, 0.11111111111111
12265, 0.56521739130435, 1.45, 0.16666666666667
12266, 0.56521739130435, 1.45, 0.22222222222222
12267, 0.56521739130435, 1.45, 0.27777777777778
12268, 0.56521739130435, 1.45, 0.33333333333333
12269, 0.56521739130435, 1.45, 0.38888888888889
12270, 0.56521739130435, 1.45, 0.44444444444444
12271, 0.60869565217391, 1.45, 0.055555555555556
12272, 0.60869565217391, 1.45, 0.11111111111111
12273, 0.60869565217391, 1.45, 0.16666666666667
12274, 0.60869565217391, 1.45, 0.22222222222222
12275, 0.60869565217391, 1.45, 0.27777777777778
12276, 0.60869565217391, 1.45, 0.33333333333333
12277, 0.60869565217391, 1.45, 0.38888888888889
12278, 0.60869565217391, 1.45, 0.44444444444444
12279, 0.65217391304348, 1.45, 0.055555555555556
12280, 0.65217391304348, 1.45, 0.11111111111111
12281, 0.65217391304348, 1.45, 0.16666666666667
12282, 0.65217391304348, 1.45, 0.22222222222222
12283, 0.65217391304348, 1.45, 0.27777777777778
12284, 0.65217391304348, 1.45, 0.33333333333333
12285, 0.65217391304348, 1.45, 0.38888888888889
12286, 0.65217391304348, 1.45, 0.44444444444444
12287, 0.69565217391304, 1.45, 0.055555555555556
12288, 0.69565217391304, 1.45, 0.11111111111111
12289, 0.69565217391304, 1.45, 0.16666666666667
12290, 0.69565217391304, 1.45, 0.22222222222222
12291, 0.69565217391304, 1.45, 0.27777777777778
12292, 0.69565217391304, 1.45, 0.33333333333333
12293, 0.69565217391304, 1.45, 0.38888888888889
12294, 0.69565217391304, 1.45, 0.44444444444444
12295, 0.73913043478261, 1.45, 0.055555555555556
12296, 0.73913043478261, 1.45, 0.11111111111111
12297, 0.73913043478261, 1.45, 0.16666666666667
12298, 0.73913043478261, 1.45, 0.22222222222222
12299, 0.73913043478261, 1.45, 0.27777777777778
12300, 0.73913043478261, 1.45, 0.33333333333333
12301, 0.73913043478261, 1.45, 0.38888888888889
12302, 0.73913043478261, 1.45, 0.44444444444444
12303, 0.78260869565217, 1.45, 0.055555555555556
12304, 0.78260869565217, 1.45, 0.11111111111111
12305, 0.78260869565217, 1.45, 0.16666666666667
12306, 0.78260869565217, 1.45, 0.22222222222222
12307, 0.78260869565217, 1.45, 0.27777777777778
12308, 0.78260869565217, 1.45, 0.33333333333333
12309, 0.78260869565217, 1.45, 0.38888888888889
12310, 0.78260869565217, 1.45, 0.44444444444444
12311, 0.82608695652174, 1.45, 0.055555555555556
12312, 0.82608695652174, 1.45, 0.11111111111111
12313, 0.82608695652174, 1.45, 0.16666666666667
12314, 0.82608695652174, 1.45, 0.22222222222222
12315, 0.82608695652174, 1.45, 0.27777777777778
12316, 0.82608695652174, 1.45, 0.33333333333333
12317, 0.82608695652174, 1.45, 0.38888888888889
12318, 0.82608695652174, 1.45, 0.44444444444444
12319, 0.8695652173913, 1.45, 0.055555555555556
12320, 0.8695652173913, 1.45, 0.11111111111111
12321, 0.8695652173913, 1.45, 0.16666666666667
12322, 0.8695652173913, 1.45, 0.22222222222222
12323, 0.8695652173913, 1.45, 0.27777777777778
12324, 0.8695652173913, 1.45, 0.33333333333333
12325, 0.8695652173913, 1.45, 0.38888888888889
12326, 0.8695652173913, 1.45, 0.44444444444444
12327, 0.91304347826087, 1.45, 0.055555555555556
12328, 0.91304347826087, 1.45, 0.11111111111111
12329, 0.91304347826087, 1.45, 0.16666666666667
12330, 0.91304347826087, 1.45, 0.22222222222222
12331, 0.91304347826087, 1.45, 0.27777777777778
12332, 0.91304347826087, 1.45, 0.33333333333333
12333, 0.91304347826087, 1.45, 0.38888888888889
12334, 0.91304347826087, 1.45, 0.44444444444444
12335, 0.95652173913043, 1.45, 0.055555555555556
12336, 0.95652173913043, 1.45, 0.11111111111111
12337, 0.95652173913043, 1.45, 0.16666666666667
12338, 0.95652173913043, 1.45, 0.22222222222222
12339, 0.95652173913043, 1.45, 0.27777777777778
12340, 0.95652173913043, 1.45, 0.33333333333333
12341, 0.95652173913043, 1.45, 0.38888888888889
12342, 0.95652173913043, 1.45, 0.44444444444444
12343, 0.043478260869565, 1.45, 0.027777777777778
12344, 0.021739130434783, 1.45, 0.055555555555556
12345, 0.043478260869565, 1.45, 0.083333333333333
12346, 0.021739130434783, 1.45, 0.11111111111111
12347, 0.043478260869565, 1.45, 0.13888888888889
12348, 0.021739130434783, 1.45, 0.16666666666667
12349, 0.043478260869565, 1.45, 0.19444444444444
12350, 0.021739130434783, 1.45, 0.22222222222222
12351, 0.043478260869565, 1.45, 0.25
12352, 0.021739130434783, 1.45, 0.27777777777778
12353, 0.043478260869565, 1.45, 0.30555555555556
12354, 0.021739130434783, 1.45, 0.33333333333333
12355, 0.043478260869565, 1.45, 0.36111111111111
12356, 0.021739130434783, 1.45, 0.38888888888889
12357, 0.043478260869565, 1.45, 0.41666666666667
12358, 0.021739130434783, 1.45, 0.44444444444444
12359, 0.043478260869565, 1.45, 0.47222222222222
12360, 0.08695652173913, 1.45, 0.027777777777778
12361, 0.065217391304348, 1.45, 0.055555555555556
12362, 0.08695652173913, 1.45, 0.083333333333333
12363, 0.065217391304348, 1.45, 0.11111111111111
12364, 0.08695652173913, 1.45, 0.13888888888889
12365, 0.065217391304348, 1.45, 0.16666666666667
12366, 0.08695652173913, 1.45, 0.19444444444444
12367, 0.065217391304348, 1.45, 0.22222222222222
12368, 0.08695652173913, 1.45, 0.25
12369, 0.065217391304348, 1.45, 0.27777777777778
12370, 0.08695652173913, 1.45, 0.30555555555556
12371, 0.065217391304348, 1.45, 0.33333333333333
12372, 0.08695652173913, 1.45, 0.36111111111111
12373, 0.065217391304348, 1.45, 0.38888888888889
12374, 0.08695652173913, 1.45, 0.41666666666667
12375, 0.065217391304348, 1.45, 0.44444444444444
12376, 0.08695652173913, 1.45, 0.47222222222222
12377, 0.1304347826087, 1.45, 0.027777777777778
12378, 0.10869565217391, 1.45, 0.055555555555556
12379, 0.1304347826087, 1.45, 0.083333333333333
12380, 0.10869565217391, 1.45, 0.11111111111111
12381, 0.1304347826087, 1.45, 0.13888888888889
12382, 0.10869565217391, 1.45, 0.16666666666667
12383, 0.1304347826087, 1.45, 0.19444444444444
12384, 0.10869565217391, 1.45, 0.22222222222222
12385, 0.1304347826087, 1.45, 0.25
12386, 0.10869565217391, 1.45, 0.27777777777778
12387, 0.1304347826087, 1.45, 0.30555555555556
12388, 0.10869565217391, 1.45, 0.33333333333333
12389, 0.1304347826087, 1.45, 0.36111111111111
12390, 0.10869565217391, 1.45, 0.38888888888889
12391, 0.1304347826087, 1.45, 0.41666666666667
12392, 0.10869565217391, 1.45, 0.44444444444444
12393, 0.1304347826087, 1.45, 0.47222222222222
12394, 0.17391304347826, 1.45, 0.027777777777778
12395, 0.15217391304348, 1.45, 0.055555555555556
12396, 0.17391304347826, 1.45, 0.083333333333333
12397, 0.15217391304348, 1.45, 0.11111111111111
12398, 0.17391304347826, 1.45, 0.13888888888889
12399, 0.15217391304348, 1.45, 0.16666666666667
12400, 0.17391304347826, 1.45, 0.19444444444444
12401, 0.15217391304348, 1.45, 0.22222222222222
12402, 0.17391304347826, 1.45, 0.25
12403, 0.15217391304348, 1.45, 0.27777777777778
12404, 0.17391304347826, 1.45, 0.30555555555556
12405, 0.15217391304348, 1.45, 0.33333333333333
12406, 0.17391304347826, 1.45, 0.36111111111111
12407, 0.15217391304348, 1.45, 0.38888888888889
12408, 0.17391304347826, 1.45, 0.41666666666667
12409, 0.15217391304348, 1.45, 0.44444444444444
12410, 0.17391304347826, 1.45, 0.47222222222222
12411, 0.21739130434783, 1.45, 0.027777777777778
12412, 0.19565217391304, 1.45, 0.055555555555556
12413, 0.21739130434783, 1.45, 0.083333333333333
12414, 0.19565217391304, 1.45, 0.11111111111111
12415, 0.21739130434783, 1.45, 0.13888888888889
12416, 0.19565217391304, 1.45, 0.16666666666667
12417, 0.21739130434783, 1.45, 0.19444444444444
12418, 0.19565217391304, 1.45, 0.22222222222222
12419, 0.21739130434783, 1.45, 0.25
12420, 0.19565217391304, 1.45, 0.27777777777778
12421, 0.21739130434783, 1.45, 0.30555555555556
12422, 0.19565217391304, 1.45, 0.33333333333333
12423, 0.21739130434783, 1.45, 0.36111111111111
12424, 0.19565217391304, 1.45, 0.38888888888889
12425, 0.21739130434783, 1.45, 0.41666666666667
12426, 0.19565217391304, 1.45, 0.44444444444444
12427, 0.21739130434783, 1.45, 0.47222222222222
12428, 0.26086956521739, 1.45, 0.027777777777778
12429, 0.23913043478261, 1.45, 0.055555555555556
12430, 0.26086956521739, 1.45, 0.083333333333333
12431, 0.23913043478261, 1.45, 0.11111111111111
12432, 0.26086956521739, 1.45, 0.13888888888889
12433, 0.23913043478261, 1.45, 0.16666666666667
12434, 0.26086956521739, 1.45, 0.19444444444444
12435, 0.23913043478261, 1.45, 0.22222222222222
12436, 0.26086956521739, 1.45, 0.25
12437, 0.23913043478261, 1.45, 0.27777777777778
12438, 0.26086956521739, 1.45, 0.30555555555556
12439, 0.23913043478261, 1.45, 0.33333333333333
12440, 0.26086956521739, 1.45, 0.36111111111111
12441, 0.23913043478261, 1.45, 0.38888888888889
12442, 0.26086956521739, 1.45, 0.41666666666667
12443, 0.23913043478261, 1.45, 0.44444444444444
12444, 0.26086956521739, 1.45, 0.47222222222222
12445, 0.30434782608696, 1.45, 0.027777777777778
12446, 0.28260869565217, 1.45, 0.055555555555556
12447, 0.30434782608696, 1.45, 0.083333333333333
12448, 0.28260869565217, 1.45, 0.11111111111111
12449, 0.30434782608696, 1.45, 0.13888888888889
12450, 0.28260869565217, 1.45, 0.16666666666667
12451, 0.30434782608696, 1.45, 0.19444444444444
12452, 0.28260869565217, 1.45, 0.22222222222222
12453, 0.30434782608696, 1.45, 0.25
12454, 0.28260869565217, 1.45, 0.27777777777778
12455, 0.30434782608696, 1.45, 0.30555555555556
12456, 0.28260869565217, 1.45, 0.33333333333333
12457, 0.30434782608696, 1.45, 0.36111111111111
12458, 0.28260869565217, 1.45, 0.38888888888889
12459, 0.30434782608696, 1.45, 0.41666666666667
12460, 0.28260869565217, 1.45, 0.44444444444444
12461, 0.30434782608696, 1.45, 0.47222222222222
12462, 0.34782608695652, 1.45, 0.027777777777778
12463, 0.32608695652174, 1.45, 0.055555555555556
12464, 0.34782608695652, 1.45, 0.083333333333333
12465, 0.32608695652174, 1.45, 0.11111111111111
12466, 0.34782608695652, 1.45, 0.13888888888889
12467, 0.32608695652174, 1.45, 0.16666666666667
12468, 0.34782608695652, 1.45, 0.19444444444444
12469, 0.32608695652174, 1.45, 0.22222222222222
12470, 0.34782608695652, 1.45, 0.25
12471, 0.32608695652174, 1.45, 0.27777777777778
12472, 0.34782608695652, 1.45, 0.30555555555556
12473, 0.32608695652174, 1.45, 0.33333333333333
12474, 0.34782608695652, 1.45, 0.36111111111111
12475, 0.32608695652174, 1.45, 0.38888888888889
12476, 0.34782608695652, 1.45, 0.41666666666667
12477, 0.32608695652174, 1.45, 0.44444444444444
12478, 0.34782608695652, 1.45, 0.47222222222222
12479, 0.39130434782609, 1.45, 0.027777777777778
12480, 0.3695652173913, 1.45, 0.055555555555556
12481, 0.39130434782609, 1.45, 0.083333333333333
12482, 0.3695652173913, 1.45, 0.11111111111111
12483, 0.39130434782609, 1.45, 0.13888888888889
12484, 0.3695652173913, 1.45, 0.16666666666667
12485, 0.39130434782609, 1.45, 0.19444444444444
12486, 0.3695652173913, 1.45, 0.22222222222222
12487, 0.39130434782609, 1.45, 0.25
12488, 0.3695652173913, 1.45, 0.27777777777778
12489, 0.39130434782609, 1.45, 0.30555555555556
12490, 0.3695652173913, 1.45, 0.33333333333333
12491, 0.39130434782609, 1.45, 0.36111111111111
12492, 0.3695652173913, 1.45, 0.38888888888889
12493, 0.39130434782609, 1.45, 0.41666666666667
12494, 0.3695652173913, 1.45, 0.44444444444444
12495, 0.39130434782609, 1.45, 0.47222222222222
12496, 0.43478260869565, 1.45, 0.027777777777778
12497, 0.41304347826087, 1.45, 0.055555555555556
12498, 0.43478260869565, 1.45, 0.083333333333333
12499, 0.41304347826087, 1.45, 0.11111111111111
12500, 0.43478260869565, 1.45, 0.13888888888889
12501, 0.41304347826087, 1.45, 0.16666666666667
12502, 0.43478260869565, 1.45, 0.19444444444444
12503, 0.41304347826087, 1.45, 0.22222222222222
12504, 0.43478260869565, 1.45, 0.25
12505, 0.41304347826087, 1.45, 0.27777777777778
12506, 0.43478260869565, 1.45, 0.30555555555556
12507, 0.41304347826087, 1.45, 0.33333333333333
12508, 0.43478260869565, 1.45, 0.36111111111111
12509, 0.41304347826087, 1.45, 0.38888888888889
12510, 0.43478260869565, 1.45, 0.41666666666667
12511, 0.41304347826087, 1.45, 0.44444444444444
12512, 0.43478260869565, 1.45, 0.47222222222222
12513, 0.47826086956522, 1.45, 0.027777777777778
12514, 0.45652173913043, 1.45, 0.055555555555556
12515, 0.47826086956522, 1.45, 0.083333333333333
12516, 0.45652173913043, 1.45, 0.11111111111111
12517, 0.47826086956522, 1.45, 0.13888888888889
12518, 0.45652173913043, 1.45, 0.16666666666667
12519, 0.47826086956522, 1.45, 0.19444444444444
12520, 0.45652173913043, 1.45, 0.22222222222222
12521, 0.47826086956522, 1.45, 0.25
12522, 0.45652173913043, 1.45, 0.27777777777778
12523, 0.47826086956522, 1.45, 0.30555555555556
12524, 0.45652173913043, 1.45, 0.33333333333333
12525, 0.47826086956522, 1.45, 0.36111111111111
12526, 0.45652173913043, 1.45, 0.38888888888889
12527, 0.47826086956522, 1.45, 0.41666666666667
12528, 0.45652173913043, 1.45, 0.44444444444444
12529, 0.47826086956522, 1.45, 0.47222222222222
12530, 0.52173913043478, 1.45, 0.027777777777778
12531, 0.5, 1.45, 0.055555555555556
12532, 0.52173913043478, 1.45, 0.083333333333333
12533, 0.5, 1.45, 0.11111111111111
12534, 0.52173913043478, 1.45, 0.13888888888889
12535, 0.5, 1.45, 0.16666666666667
12536, 0.52173913043478, 1.45, 0.19444444444444
12537, 0.5, 1.45, 0.22222222222222
12538, 0.52173913043478, 1.45, 0.25
12539, 0.5, 1.45, 0.27777777777778
12540, 0.52173913043478, 1.45, 0.30555555555556
12541, 0.5, 1.45, 0.33333333333333
12542, 0.52173913043478, 1.45, 0.36111111111111
12543, 0.5, 1.45, 0.38888888888889
12544, 0.52173913043478, 1.45, 0.41666666666667
12545, 0.5, 1.45, 0.44444444444444
12546, 0.52173913043478, 1.45, 0.47222222222222
12547, 0.56521739130435, 1.45, 0.027777777777778
12548, 0.54347826086957, 1.45, 0.055555555555556
12549, 0.56521739130435, 1.45, 0.083333333333333
12550, 0.54347826086957, 1.45, 0.11111111111111
12551, 0.56521739130435, 1.45, 0.13888888888889
12552, 0.54347826086957, 1.45, 0.16666666666667
12553, 0.56521739130435, 1.45, 0.19444444444444
12554, 0.54347826086957, 1.45, 0.22222222222222
12555, 0.56521739130435, 1.45, 0.25
12556, 0.54347826086957, 1.45, 0.27777777777778
12557, 0.56521739130435, 1.45, 0.30555555555556
12558, 0.54347826086957, 1.45, 0.33333333333333
12559, 0.56521739130435, 1.45, 0.36111111111111
12560, 0.54347826086957, 1.45, 0.38888888888889
12561, 0.56521739130435, 1.45, 0.41666666666667
12562, 0.54347826086957, 1.45, 0.44444444444444
12563, 0.56521739130435, 1.45, 0.47222222222222
12564, 0.60869565217391, 1.45, 0.027777777777778
12565, 0.58695652173913, 1.45, 0.055555555555556
12566, 0.60869565217391, 1.45, 0.083333333333333
12567, 0.58695652173913, 1.45, 0.11111111111111
12568, 0.60869565217391, 1.45, 0.13888888888889
12569, 0.58695652173913, 1.45, 0.16666666666667
12570, 0.60869565217391, 1.45, 0.19444444444444
12571, 0.58695652173913, 1.45, 0.22222222222222
12572, 0.60869565217391, 1.45, 0.25
12573, 0.58695652173913, 1.45, 0.27777777777778
12574, 0.60869565217391, 1.45, 0.30555555555556
12575, 0.58695652173913, 1.45, 0.33333333333333
12576, 0.60869565217391, 1.45, 0.36111111111111
12577, 0.58695652173913, 1.45, 0.38888888888889
12578, 0.60869565217391, 1.45, 0.41666666666667
12579, 0.58695652173913, 1.45, 0.44444444444444
12580, 0.60869565217391, 1.45, 0.47222222222222
12581, 0.65217391304348, 1.45, 0.027777777777778
12582, 0.6304347826087, 1.45, 0.055555555555556
12583, 0.65217391304348, 1.45, 0.083333333333333
12584, 0.6304347826087, 1.45, 0.11111111111111
12585, 0.65217391304348, 1.45, 0.13888888888889
12586, 0.6304347826087, 1.45, 0.16666666666667
12587, 0.65217391304348, 1.45, 0.19444444444444
12588, 0.6304347826087, 1.45, 0.22222222222222
12589, 0.65217391304348, 1.45, 0.25
12590, 0.6304347826087, 1.45, 0.27777777777778
12591, 0.65217391304348, 1.45, 0.30555555555556
12592, 0.6304347826087, 1.45, 0.33333333333333
12593, 0.65217391304348, 1.45, 0.36111111111111
12594, 0.6304347826087, 1.45, 0.38888888888889
12595, 0.65217391304348, 1.45, 0.41666666666667
12596, 0.6304347826087, 1.45, 0.44444444444444
12597, 0.65217391304348, 1.45, 0.47222222222222
12598, 0.69565217391304, 1.45, 0.027777777777778
12599, 0.67391304347826, 1.45, 0.055555555555556
12600, 0.69565217391304, 1.45, 0.083333333333333
12601, 0.67391304347826, 1.45, 0.11111111111111
12602, 0.69565217391304, 1.45, 0.13888888888889
12603, 0.67391304347826, 1.45, 0.16666666666667
12604, 0.69565217391304, 1.45, 0.19444444444444
12605, 0.67391304347826, 1.45, 0.22222222222222
12606, 0.69565217391304, 1.45, 0.25
12607, 0.67391304347826, 1.45, 0.27777777777778
12608, 0.69565217391304, 1.45, 0.30555555555556
12609, 0.67391304347826, 1.45, 0.33333333333333
12610, 0.69565217391304, 1.45, 0.36111111111111
12611, 0.67391304347826, 1.45, 0.38888888888889
12612, 0.69565217391304, 1.45, 0.41666666666667
12613, 0.67391304347826, 1.45, 0.44444444444444
12614, 0.69565217391304, 1.45, 0.47222222222222
12615, 0.73913043478261, 1.45, 0.027777777777778
12616, 0.71739130434783, 1.45, 0.055555555555556
12617, 0.73913043478261, 1.45, 0.083333333333333
12618, 0.71739130434783, 1.45, 0.11111111111111
12619, 0.73913043478261, 1.45, 0.13888888888889
12620, 0.71739130434783, 1.45, 0.16666666666667
12621, 0.73913043478261, 1.45, 0.19444444444444
12622, 0.71739130434783, 1.45, 0.22222222222222
12623, 0.73913043478261, 1.45, 0.25
12624, 0.71739130434783, 1.45, 0.27777777777778
12625, 0.73913043478261, 1.45, 0.30555555555556
12626, 0.71739130434783, 1.45, 0.33333333333333
12627, 0.73913043478261, 1.45, 0.36111111111111
12628, 0.71739130434783, 1.45, 0.38888888888889
12629, 0.73913043478261, 1.45, 0.41666666666667
12630, 0.71739130434783, 1.45, 0.44444444444444
12631, 0.73913043478261, 1.45, 0.47222222222222
12632, 0.78260869565217, 1.45, 0.027777777777778
12633, 0.76086956521739, 1.45, 0.055555555555556
12634, 0.78260869565217, 1.45, 0.083333333333333
12635, 0.76086956521739, 1.45, 0.11111111111111
12636, 0.78260869565217, 1.45, 0.13888888888889
12637, 0.76086956521739, 1.45, 0.16666666666667
12638, 0.78260869565217, 1.45, 0.19444444444444
12639, 0.76086956521739, 1.45, 0.22222222222222
12640, 0.78260869565217, 1.45, 0.25
12641, 0.76086956521739, 1.45, 0.27777777777778
12642, 0.78260869565217, 1.45, 0.30555555555556
12643, 0.76086956521739, 1.45, 0.33333333333333
12644, 0.78260869565217, 1.45, 0.36111111111111
12645, 0.76086956521739, 1.45, 0.38888888888889
12646, 0.78260869565217, 1.45, 0.41666666666667
12647, 0.76086956521739, 1.45, 0.44444444444444
12648, 0.78260869565217, 1.45, 0.47222222222222
12649, 0.82608695652174, 1.45, 0.027777777777778
12650, 0.80434782608696, 1.45, 0.055555555555556
12651, 0.82608695652174, 1.45, 0.083333333333333
12652, 0.80434782608696, 1.45, 0.11111111111111
12653, 0.82608695652174, 1.45, 0.13888888888889
12654, 0.80434782608696, 1.45, 0.16666666666667
12655, 0.82608695652174, 1.45, 0.19444444444444
12656, 0.80434782608696, 1.45, 0.22222222222222
12657, 0.82608695652174, 1.45, 0.25
12658, 0.80434782608696, 1.45, 0.27777777777778
12659, 0.82608695652174, 1.45, 0.30555555555556
12660, 0.80434782608696, 1.45, 0.33333333333333
12661, 0.82608695652174, 1.45, 0.36111111111111
12662, 0.80434782608696, 1.45, 0.38888888888889
12663, 0.82608695652174, 1.45, 0.41666666666667
12664, 0.80434782608696, 1.45, 0.44444444444444
12665, 0.82608695652174, 1.45, 0.47222222222222
12666, 0.8695652173913, 1.45, 0.027777777777778
12667, 0.84782608695652, 1.45, 0.055555555555556
12668, 0.8695652173913, 1.45, 0.083333333333333
12669, 0.84782608695652, 1.45, 0.11111111111111
12670, 0.8695652173913, 1.45, 0.13888888888889
12671, 0.84782608695652, 1.45, 0.16666666666667
12672, 0.8695652173913, 1.45, 0.19444444444444
12673, 0.84782608695652, 1.45, 0.22222222222222
12674, 0.8695652173913, 1.45, 0.25
12675, 0.84782608695652, 1.45, 0.27777777777778
12676, 0.8695652173913, 1.45, 0.30555555555556
12677, 0.84782608695652, 1.45, 0.33333333333333
12678, 0.8695652173913, 1.45, 0.36111111111111
12679, 0.84782608695652, 1.45, 0.38888888888889
12680, 0.8695652173913, 1.45, 0.41666666666667
12681, 0.84782608695652, 1.45, 0.44444444444444
12682, 0.8695652173913, 1.45, 0.47222222222222
12683, 0.91304347826087, 1.45, 0.027777777777778
12684, 0.89130434782609, 1.45, 0.055555555555556
12685, 0.91304347826087, 1.45, 0.083333333333333
12686, 0.89130434782609, 1.45, 0.11111111111111
12687, 0.91304347826087, 1.45, 0.13888888888889
12688, 0.89130434782609, 1.45, 0.16666666666667
12689, 0.91304347826087, 1.45, 0.19444444444444
12690, 0.89130434782609, 1.45, 0.22222222222222
12691, 0.91304347826087, 1.45, 0.25
12692, 0.89130434782609, 1.45, 0.27777777777778
12693, 0.91304347826087, 1.45, 0.30555555555556
12694, 0.89130434782609, 1.45, 0.33333333333333
12695, 0.91304347826087, 1.45, 0.36111111111111
12696, 0.89130434782609, 1.45, 0.38888888888889
12697, 0.91304347826087, 1.45, 0.41666666666667
12698, 0.89130434782609, 1.45, 0.44444444444444
12699, 0.91304347826087, 1.45, 0.47222222222222
12700, 0.95652173913043, 1.45, 0.027777777777778
12701, 0.93478260869565, 1.45, 0.055555555555556
12702, 0.95652173913043, 1.45, 0.083333333333333
12703, 0.93478260869565, 1.45, 0.11111111111111
12704, 0.95652173913043, 1.45, 0.13888888888889
12705, 0.93478260869565, 1.45, 0.16666666666667
12706, 0.95652173913043, 1.45, 0.19444444444444
12707, 0.93478260869565, 1.45, 0.22222222222222
12708, 0.95652173913043, 1.45, 0.25
12709, 0.93478260869565, 1.45, 0.27777777777778
12710, 0.95652173913043, 1.45, 0.30555555555556
12711, 0.93478260869565, 1.45, 0.33333333333333
12712, 0.95652173913043, 1.45, 0.36111111111111
12713, 0.93478260869565, 1.45, 0.38888888888889
12714, 0.95652173913043, 1.45, 0.41666666666667
12715, 0.93478260869565, 1.45, 0.44444444444444
12716, 0.95652173913043, 1.45, 0.47222222222222
12717, 0.97826086956522, 1.45, 0.055555555555556
12718, 0.97826086956522, 1.45, 0.11111111111111
12719, 0.97826086956522, 1.45, 0.16666666666667
12720, 0.97826086956522, 1.45, 0.22222222222222
12721, 0.97826086956522, 1.45, 0.27777777777778
12722, 0.97826086956522, 1.45, 0.33333333333333
12723, 0.97826086956522, 1.45, 0.38888888888889
12724, 0.97826086956522, 1.45, 0.44444444444444
12725, 0.043478260869565, 1.55, 0.055555555555556
12726, 0.043478260869565, 1.55, 0.11111111111111
12727, 0.043478260869565, 1.55, 0.16666666666667
12728, 0.043478260869565, 1.55, 0.22222222222222
12729, 0.043478260869565, 1.55, 0.27777777777778
12730, 0.043478260869565, 1.55, 0.33333333333333
12731, 0.043478260869565, 1.55, 0.38888888888889
12732, 0.043478260869565, 1.55, 0.44444444444444
12733, 0.08695652173913, 1.55, 0.055555555555556
12734, 0.08695652173913, 1.55, 0.11111111111111
12735, 0.08695652173913, 1.55, 0.16666666666667
12736, 0.08695652173913, 1.55, 0.22222222222222
12737, 0.08695652173913, 1.55, 0.27777777777778
12738, 0.08695652173913, 1.55, 0.33333333333333
12739, 0.08695652173913, 1.55, 0.38888888888889
12740, 0.08695652173913, 1.55, 0.44444444444444
12741, 0.1304347826087, 1.55, 0.055555555555556
12742, 0.1304347826087, 1.55, 0.11111111111111
12743, 0.1304347826087, 1.55, 0.16666666666667
12744, 0.1304347826087, 1.55, 0.22222222222222
12745, 0.1304347826087, 1.55, 0.27777777777778
12746, 0.1304347826087, 1.55, 0.33333333333333
12747, 0.1304347826087, 1.55, 0.38888888888889
12748, 0.1304347826087, 1.55, 0.44444444444444
12749, 0.17391304347826, 1.55, 0.055555555555556
12750, 0.17391304347826, 1.55, 0.11111111111111
12751, 0.17391304347826, 1.55, 0.16666666666667
