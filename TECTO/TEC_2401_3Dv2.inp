94013, 1.1625, 1.2978260869565, 0.083333333333333
94014, 1.1625, 1.3239130434783, 0.055555555555556
94015, 1.18125, 1.2978260869565, 0.055555555555556
94016, 1.1625, 1.2978260869565, 0.027777777777778
94017, 1.1625, 1.245652173913, 0.47222222222222
94018, 1.1625, 1.2717391304348, 0.44444444444444
94019, 1.18125, 1.245652173913, 0.44444444444444
94020, 1.1625, 1.245652173913, 0.41666666666667
94021, 1.1625, 1.2717391304348, 0.38888888888889
94022, 1.18125, 1.245652173913, 0.38888888888889
94023, 1.1625, 1.245652173913, 0.36111111111111
94024, 1.1625, 1.2717391304348, 0.33333333333333
94025, 1.18125, 1.245652173913, 0.33333333333333
94026, 1.1625, 1.245652173913, 0.30555555555556
94027, 1.1625, 1.2717391304348, 0.27777777777778
94028, 1.18125, 1.245652173913, 0.27777777777778
94029, 1.1625, 1.245652173913, 0.25
94030, 1.1625, 1.2717391304348, 0.22222222222222
94031, 1.18125, 1.245652173913, 0.22222222222222
94032, 1.1625, 1.245652173913, 0.19444444444444
94033, 1.1625, 1.2717391304348, 0.16666666666667
94034, 1.18125, 1.245652173913, 0.16666666666667
94035, 1.1625, 1.245652173913, 0.13888888888889
94036, 1.1625, 1.2717391304348, 0.11111111111111
94037, 1.18125, 1.245652173913, 0.11111111111111
94038, 1.1625, 1.245652173913, 0.083333333333333
94039, 1.1625, 1.2717391304348, 0.055555555555556
94040, 1.18125, 1.245652173913, 0.055555555555556
94041, 1.1625, 1.245652173913, 0.027777777777778
94042, 1.1625, 1.1934782608696, 0.47222222222222
94043, 1.1625, 1.2195652173913, 0.44444444444444
94044, 1.18125, 1.1934782608696, 0.44444444444444
94045, 1.1625, 1.1934782608696, 0.41666666666667
94046, 1.1625, 1.2195652173913, 0.38888888888889
94047, 1.18125, 1.1934782608696, 0.38888888888889
94048, 1.1625, 1.1934782608696, 0.36111111111111
94049, 1.1625, 1.2195652173913, 0.33333333333333
94050, 1.18125, 1.1934782608696, 0.33333333333333
94051, 1.1625, 1.1934782608696, 0.30555555555556
94052, 1.1625, 1.2195652173913, 0.27777777777778
94053, 1.18125, 1.1934782608696, 0.27777777777778
94054, 1.1625, 1.1934782608696, 0.25
94055, 1.1625, 1.2195652173913, 0.22222222222222
94056, 1.18125, 1.1934782608696, 0.22222222222222
94057, 1.1625, 1.1934782608696, 0.19444444444444
94058, 1.1625, 1.2195652173913, 0.16666666666667
94059, 1.18125, 1.1934782608696, 0.16666666666667
94060, 1.1625, 1.1934782608696, 0.13888888888889
94061, 1.1625, 1.2195652173913, 0.11111111111111
94062, 1.18125, 1.1934782608696, 0.11111111111111
94063, 1.1625, 1.1934782608696, 0.083333333333333
94064, 1.1625, 1.2195652173913, 0.055555555555556
94065, 1.18125, 1.1934782608696, 0.055555555555556
94066, 1.1625, 1.1934782608696, 0.027777777777778
94067, 1.1625, 1.1413043478261, 0.47222222222222
94068, 1.1625, 1.1673913043478, 0.44444444444444
94069, 1.18125, 1.1413043478261, 0.44444444444444
94070, 1.1625, 1.1413043478261, 0.41666666666667
94071, 1.1625, 1.1673913043478, 0.38888888888889
94072, 1.18125, 1.1413043478261, 0.38888888888889
94073, 1.1625, 1.1413043478261, 0.36111111111111
94074, 1.1625, 1.1673913043478, 0.33333333333333
94075, 1.18125, 1.1413043478261, 0.33333333333333
94076, 1.1625, 1.1413043478261, 0.30555555555556
94077, 1.1625, 1.1673913043478, 0.27777777777778
94078, 1.18125, 1.1413043478261, 0.27777777777778
94079, 1.1625, 1.1413043478261, 0.25
94080, 1.1625, 1.1673913043478, 0.22222222222222
94081, 1.18125, 1.1413043478261, 0.22222222222222
94082, 1.1625, 1.1413043478261, 0.19444444444444
94083, 1.1625, 1.1673913043478, 0.16666666666667
94084, 1.18125, 1.1413043478261, 0.16666666666667
94085, 1.1625, 1.1413043478261, 0.13888888888889
94086, 1.1625, 1.1673913043478, 0.11111111111111
94087, 1.18125, 1.1413043478261, 0.11111111111111
94088, 1.1625, 1.1413043478261, 0.083333333333333
94089, 1.1625, 1.1673913043478, 0.055555555555556
94090, 1.18125, 1.1413043478261, 0.055555555555556
94091, 1.1625, 1.1413043478261, 0.027777777777778
94092, 1.1625, 1.0891304347826, 0.47222222222222
94093, 1.1625, 1.1152173913043, 0.44444444444444
94094, 1.18125, 1.0891304347826, 0.44444444444444
94095, 1.1625, 1.0891304347826, 0.41666666666667
94096, 1.1625, 1.1152173913043, 0.38888888888889
94097, 1.18125, 1.0891304347826, 0.38888888888889
94098, 1.1625, 1.0891304347826, 0.36111111111111
94099, 1.1625, 1.1152173913043, 0.33333333333333
94100, 1.18125, 1.0891304347826, 0.33333333333333
94101, 1.1625, 1.0891304347826, 0.30555555555556
94102, 1.1625, 1.1152173913043, 0.27777777777778
94103, 1.18125, 1.0891304347826, 0.27777777777778
94104, 1.1625, 1.0891304347826, 0.25
94105, 1.1625, 1.1152173913043, 0.22222222222222
94106, 1.18125, 1.0891304347826, 0.22222222222222
94107, 1.1625, 1.0891304347826, 0.19444444444444
94108, 1.1625, 1.1152173913043, 0.16666666666667
94109, 1.18125, 1.0891304347826, 0.16666666666667
94110, 1.1625, 1.0891304347826, 0.13888888888889
94111, 1.1625, 1.1152173913043, 0.11111111111111
94112, 1.18125, 1.0891304347826, 0.11111111111111
94113, 1.1625, 1.0891304347826, 0.083333333333333
94114, 1.1625, 1.1152173913043, 0.055555555555556
94115, 1.18125, 1.0891304347826, 0.055555555555556
94116, 1.1625, 1.0891304347826, 0.027777777777778
94117, 1.1625, 1.0369565217391, 0.47222222222222
94118, 1.1625, 1.0630434782609, 0.44444444444444
94119, 1.18125, 1.0369565217391, 0.44444444444444
94120, 1.1625, 1.0369565217391, 0.41666666666667
94121, 1.1625, 1.0630434782609, 0.38888888888889
94122, 1.18125, 1.0369565217391, 0.38888888888889
94123, 1.1625, 1.0369565217391, 0.36111111111111
94124, 1.1625, 1.0630434782609, 0.33333333333333
94125, 1.18125, 1.0369565217391, 0.33333333333333
94126, 1.1625, 1.0369565217391, 0.30555555555556
94127, 1.1625, 1.0630434782609, 0.27777777777778
94128, 1.18125, 1.0369565217391, 0.27777777777778
94129, 1.1625, 1.0369565217391, 0.25
94130, 1.1625, 1.0630434782609, 0.22222222222222
94131, 1.18125, 1.0369565217391, 0.22222222222222
94132, 1.1625, 1.0369565217391, 0.19444444444444
94133, 1.1625, 1.0630434782609, 0.16666666666667
94134, 1.18125, 1.0369565217391, 0.16666666666667
94135, 1.1625, 1.0369565217391, 0.13888888888889
94136, 1.1625, 1.0630434782609, 0.11111111111111
94137, 1.18125, 1.0369565217391, 0.11111111111111
94138, 1.1625, 1.0369565217391, 0.083333333333333
94139, 1.1625, 1.0630434782609, 0.055555555555556
94140, 1.18125, 1.0369565217391, 0.055555555555556
94141, 1.1625, 1.0369565217391, 0.027777777777778
94142, 1.1625, 0.98478260869565, 0.47222222222222
94143, 1.1625, 1.0108695652174, 0.44444444444444
94144, 1.18125, 0.98478260869565, 0.44444444444444
94145, 1.1625, 0.98478260869565, 0.41666666666667
94146, 1.1625, 1.0108695652174, 0.38888888888889
94147, 1.18125, 0.98478260869565, 0.38888888888889
94148, 1.1625, 0.98478260869565, 0.36111111111111
94149, 1.1625, 1.0108695652174, 0.33333333333333
94150, 1.18125, 0.98478260869565, 0.33333333333333
94151, 1.1625, 0.98478260869565, 0.30555555555556
94152, 1.1625, 1.0108695652174, 0.27777777777778
94153, 1.18125, 0.98478260869565, 0.27777777777778
94154, 1.1625, 0.98478260869565, 0.25
94155, 1.1625, 1.0108695652174, 0.22222222222222
94156, 1.18125, 0.98478260869565, 0.22222222222222
94157, 1.1625, 0.98478260869565, 0.19444444444444
94158, 1.1625, 1.0108695652174, 0.16666666666667
94159, 1.18125, 0.98478260869565, 0.16666666666667
94160, 1.1625, 0.98478260869565, 0.13888888888889
94161, 1.1625, 1.0108695652174, 0.11111111111111
94162, 1.18125, 0.98478260869565, 0.11111111111111
94163, 1.1625, 0.98478260869565, 0.083333333333333
94164, 1.1625, 1.0108695652174, 0.055555555555556
94165, 1.18125, 0.98478260869565, 0.055555555555556
94166, 1.1625, 0.98478260869565, 0.027777777777778
94167, 1.1625, 0.93260869565217, 0.47222222222222
94168, 1.1625, 0.95869565217391, 0.44444444444444
94169, 1.18125, 0.93260869565217, 0.44444444444444
94170, 1.1625, 0.93260869565217, 0.41666666666667
94171, 1.1625, 0.95869565217391, 0.38888888888889
94172, 1.18125, 0.93260869565217, 0.38888888888889
94173, 1.1625, 0.93260869565217, 0.36111111111111
94174, 1.1625, 0.95869565217391, 0.33333333333333
94175, 1.18125, 0.93260869565217, 0.33333333333333
94176, 1.1625, 0.93260869565217, 0.30555555555556
94177, 1.1625, 0.95869565217391, 0.27777777777778
94178, 1.18125, 0.93260869565217, 0.27777777777778
94179, 1.1625, 0.93260869565217, 0.25
94180, 1.1625, 0.95869565217391, 0.22222222222222
94181, 1.18125, 0.93260869565217, 0.22222222222222
94182, 1.1625, 0.93260869565217, 0.19444444444444
94183, 1.1625, 0.95869565217391, 0.16666666666667
94184, 1.18125, 0.93260869565217, 0.16666666666667
94185, 1.1625, 0.93260869565218, 0.13888888888889
94186, 1.1625, 0.95869565217391, 0.11111111111111
94187, 1.18125, 0.93260869565217, 0.11111111111111
94188, 1.1625, 0.93260869565217, 0.083333333333333
94189, 1.1625, 0.95869565217391, 0.055555555555556
94190, 1.18125, 0.93260869565217, 0.055555555555556
94191, 1.1625, 0.93260869565217, 0.027777777777778
94192, 1.1625, 0.8804347826087, 0.47222222222222
94193, 1.1625, 0.90652173913044, 0.44444444444444
94194, 1.18125, 0.8804347826087, 0.44444444444444
94195, 1.1625, 0.8804347826087, 0.41666666666667
94196, 1.1625, 0.90652173913044, 0.38888888888889
94197, 1.18125, 0.8804347826087, 0.38888888888889
94198, 1.1625, 0.8804347826087, 0.36111111111111
94199, 1.1625, 0.90652173913044, 0.33333333333333
94200, 1.18125, 0.8804347826087, 0.33333333333333
94201, 1.1625, 0.8804347826087, 0.30555555555556
94202, 1.1625, 0.90652173913044, 0.27777777777778
94203, 1.18125, 0.8804347826087, 0.27777777777778
94204, 1.1625, 0.8804347826087, 0.25
94205, 1.1625, 0.90652173913044, 0.22222222222222
94206, 1.18125, 0.8804347826087, 0.22222222222222
94207, 1.1625, 0.8804347826087, 0.19444444444444
94208, 1.1625, 0.90652173913044, 0.16666666666667
94209, 1.18125, 0.8804347826087, 0.16666666666667
94210, 1.1625, 0.8804347826087, 0.13888888888889
94211, 1.1625, 0.90652173913044, 0.11111111111111
94212, 1.18125, 0.8804347826087, 0.11111111111111
94213, 1.1625, 0.8804347826087, 0.083333333333333
94214, 1.1625, 0.90652173913044, 0.055555555555556
94215, 1.18125, 0.8804347826087, 0.055555555555556
94216, 1.1625, 0.8804347826087, 0.027777777777778
94217, 1.1625, 0.82826086956522, 0.47222222222222
94218, 1.1625, 0.85434782608696, 0.44444444444444
94219, 1.18125, 0.82826086956522, 0.44444444444444
94220, 1.1625, 0.82826086956522, 0.41666666666667
94221, 1.1625, 0.85434782608696, 0.38888888888889
94222, 1.18125, 0.82826086956522, 0.38888888888889
94223, 1.1625, 0.82826086956522, 0.36111111111111
94224, 1.1625, 0.85434782608696, 0.33333333333333
94225, 1.18125, 0.82826086956522, 0.33333333333333
94226, 1.1625, 0.82826086956522, 0.30555555555556
94227, 1.1625, 0.85434782608696, 0.27777777777778
94228, 1.18125, 0.82826086956522, 0.27777777777778
94229, 1.1625, 0.82826086956522, 0.25
94230, 1.1625, 0.85434782608696, 0.22222222222222
94231, 1.18125, 0.82826086956522, 0.22222222222222
94232, 1.1625, 0.82826086956522, 0.19444444444444
94233, 1.1625, 0.85434782608696, 0.16666666666667
94234, 1.18125, 0.82826086956522, 0.16666666666667
94235, 1.1625, 0.82826086956522, 0.13888888888889
94236, 1.1625, 0.85434782608696, 0.11111111111111
94237, 1.18125, 0.82826086956522, 0.11111111111111
94238, 1.1625, 0.82826086956522, 0.083333333333333
94239, 1.1625, 0.85434782608696, 0.055555555555556
94240, 1.18125, 0.82826086956522, 0.055555555555556
94241, 1.1625, 0.82826086956522, 0.027777777777778
94242, 1.1625, 0.77608695652174, 0.47222222222222
94243, 1.1625, 0.80217391304348, 0.44444444444444
94244, 1.18125, 0.77608695652174, 0.44444444444444
94245, 1.1625, 0.77608695652174, 0.41666666666667
94246, 1.1625, 0.80217391304348, 0.38888888888889
94247, 1.18125, 0.77608695652174, 0.38888888888889
94248, 1.1625, 0.77608695652174, 0.36111111111111
94249, 1.1625, 0.80217391304348, 0.33333333333333
94250, 1.18125, 0.77608695652174, 0.33333333333333
94251, 1.1625, 0.77608695652174, 0.30555555555556
94252, 1.1625, 0.80217391304348, 0.27777777777778
94253, 1.18125, 0.77608695652174, 0.27777777777778
94254, 1.1625, 0.77608695652174, 0.25
94255, 1.1625, 0.80217391304348, 0.22222222222222
94256, 1.18125, 0.77608695652174, 0.22222222222222
94257, 1.1625, 0.77608695652174, 0.19444444444444
94258, 1.1625, 0.80217391304348, 0.16666666666667
94259, 1.18125, 0.77608695652174, 0.16666666666667
94260, 1.1625, 0.77608695652174, 0.13888888888889
94261, 1.1625, 0.80217391304348, 0.11111111111111
94262, 1.18125, 0.77608695652174, 0.11111111111111
94263, 1.1625, 0.77608695652174, 0.083333333333333
94264, 1.1625, 0.80217391304348, 0.055555555555556
94265, 1.18125, 0.77608695652174, 0.055555555555556
94266, 1.1625, 0.77608695652174, 0.027777777777778
94267, 1.1625, 0.72391304347826, 0.47222222222222
94268, 1.1625, 0.75, 0.44444444444444
94269, 1.18125, 0.72391304347826, 0.44444444444444
94270, 1.1625, 0.72391304347826, 0.41666666666667
94271, 1.1625, 0.75, 0.38888888888889
94272, 1.18125, 0.72391304347826, 0.38888888888889
94273, 1.1625, 0.72391304347826, 0.36111111111111
94274, 1.1625, 0.75, 0.33333333333333
94275, 1.18125, 0.72391304347826, 0.33333333333333
94276, 1.1625, 0.72391304347826, 0.30555555555556
94277, 1.1625, 0.75, 0.27777777777778
94278, 1.18125, 0.72391304347826, 0.27777777777778
94279, 1.1625, 0.72391304347826, 0.25
94280, 1.1625, 0.75, 0.22222222222222
94281, 1.18125, 0.72391304347826, 0.22222222222222
94282, 1.1625, 0.72391304347826, 0.19444444444444
94283, 1.1625, 0.75, 0.16666666666667
94284, 1.18125, 0.72391304347826, 0.16666666666667
94285, 1.1625, 0.72391304347826, 0.13888888888889
94286, 1.1625, 0.75, 0.11111111111111
94287, 1.18125, 0.72391304347826, 0.11111111111111
94288, 1.1625, 0.72391304347826, 0.083333333333333
94289, 1.1625, 0.75, 0.055555555555556
94290, 1.18125, 0.72391304347826, 0.055555555555556
94291, 1.1625, 0.72391304347826, 0.027777777777778
94292, 1.1625, 0.67173913043478, 0.47222222222222
94293, 1.1625, 0.69782608695652, 0.44444444444444
94294, 1.18125, 0.67173913043478, 0.44444444444444
94295, 1.1625, 0.67173913043478, 0.41666666666667
94296, 1.1625, 0.69782608695652, 0.38888888888889
94297, 1.18125, 0.67173913043478, 0.38888888888889
94298, 1.1625, 0.67173913043478, 0.36111111111111
94299, 1.1625, 0.69782608695652, 0.33333333333333
94300, 1.18125, 0.67173913043478, 0.33333333333333
94301, 1.1625, 0.67173913043478, 0.30555555555556
94302, 1.1625, 0.69782608695652, 0.27777777777778
94303, 1.18125, 0.67173913043478, 0.27777777777778
94304, 1.1625, 0.67173913043478, 0.25
94305, 1.1625, 0.69782608695652, 0.22222222222222
94306, 1.18125, 0.67173913043478, 0.22222222222222
94307, 1.1625, 0.67173913043478, 0.19444444444444
94308, 1.1625, 0.69782608695652, 0.16666666666667
94309, 1.18125, 0.67173913043478, 0.16666666666667
94310, 1.1625, 0.67173913043478, 0.13888888888889
94311, 1.1625, 0.69782608695652, 0.11111111111111
94312, 1.18125, 0.67173913043478, 0.11111111111111
94313, 1.1625, 0.67173913043478, 0.083333333333333
94314, 1.1625, 0.69782608695652, 0.055555555555556
94315, 1.18125, 0.67173913043478, 0.055555555555556
94316, 1.1625, 0.67173913043478, 0.027777777777778
94317, 1.1625, 0.61956521739131, 0.47222222222222
94318, 1.1625, 0.64565217391304, 0.44444444444444
94319, 1.18125, 0.61956521739131, 0.44444444444444
94320, 1.1625, 0.61956521739131, 0.41666666666667
94321, 1.1625, 0.64565217391304, 0.38888888888889
94322, 1.18125, 0.61956521739131, 0.38888888888889
94323, 1.1625, 0.61956521739131, 0.36111111111111
94324, 1.1625, 0.64565217391304, 0.33333333333333
94325, 1.18125, 0.61956521739131, 0.33333333333333
94326, 1.1625, 0.61956521739131, 0.30555555555556
94327, 1.1625, 0.64565217391304, 0.27777777777778
94328, 1.18125, 0.61956521739131, 0.27777777777778
94329, 1.1625, 0.61956521739131, 0.25
94330, 1.1625, 0.64565217391304, 0.22222222222222
94331, 1.18125, 0.61956521739131, 0.22222222222222
94332, 1.1625, 0.61956521739131, 0.19444444444444
94333, 1.1625, 0.64565217391304, 0.16666666666667
94334, 1.18125, 0.6195652173913, 0.16666666666667
94335, 1.1625, 0.6195652173913, 0.13888888888889
94336, 1.1625, 0.64565217391304, 0.11111111111111
94337, 1.18125, 0.61956521739131, 0.11111111111111
94338, 1.1625, 0.6195652173913, 0.083333333333333
94339, 1.1625, 0.64565217391304, 0.055555555555556
94340, 1.18125, 0.61956521739131, 0.055555555555556
94341, 1.1625, 0.61956521739131, 0.027777777777778
94342, 1.1625, 0.56739130434783, 0.47222222222222
94343, 1.1625, 0.59347826086957, 0.44444444444444
94344, 1.18125, 0.56739130434783, 0.44444444444444
94345, 1.1625, 0.56739130434783, 0.41666666666667
94346, 1.1625, 0.59347826086957, 0.38888888888889
94347, 1.18125, 0.56739130434783, 0.38888888888889
94348, 1.1625, 0.56739130434783, 0.36111111111111
94349, 1.1625, 0.59347826086957, 0.33333333333333
94350, 1.18125, 0.56739130434783, 0.33333333333333
94351, 1.1625, 0.56739130434783, 0.30555555555556
94352, 1.1625, 0.59347826086957, 0.27777777777778
94353, 1.18125, 0.56739130434783, 0.27777777777778
94354, 1.1625, 0.56739130434783, 0.25
94355, 1.1625, 0.59347826086957, 0.22222222222222
94356, 1.18125, 0.56739130434783, 0.22222222222222
94357, 1.1625, 0.56739130434783, 0.19444444444444
94358, 1.1625, 0.59347826086957, 0.16666666666667
94359, 1.18125, 0.56739130434783, 0.16666666666667
94360, 1.1625, 0.56739130434783, 0.13888888888889
94361, 1.1625, 0.59347826086957, 0.11111111111111
94362, 1.18125, 0.56739130434783, 0.11111111111111
94363, 1.1625, 0.56739130434783, 0.083333333333333
94364, 1.1625, 0.59347826086957, 0.055555555555556
94365, 1.18125, 0.56739130434783, 0.055555555555556
94366, 1.1625, 0.56739130434783, 0.027777777777778
94367, 1.1625, 0.51521739130435, 0.47222222222222
94368, 1.1625, 0.54130434782609, 0.44444444444444
94369, 1.18125, 0.51521739130435, 0.44444444444444
94370, 1.1625, 0.51521739130435, 0.41666666666667
94371, 1.1625, 0.54130434782609, 0.38888888888889
94372, 1.18125, 0.51521739130435, 0.38888888888889
94373, 1.1625, 0.51521739130435, 0.36111111111111
94374, 1.1625, 0.54130434782609, 0.33333333333333
94375, 1.18125, 0.51521739130435, 0.33333333333333
94376, 1.1625, 0.51521739130435, 0.30555555555556
94377, 1.1625, 0.54130434782609, 0.27777777777778
94378, 1.18125, 0.51521739130435, 0.27777777777778
94379, 1.1625, 0.51521739130435, 0.25
94380, 1.1625, 0.54130434782609, 0.22222222222222
94381, 1.18125, 0.51521739130435, 0.22222222222222
94382, 1.1625, 0.51521739130435, 0.19444444444444
94383, 1.1625, 0.54130434782609, 0.16666666666667
94384, 1.18125, 0.51521739130435, 0.16666666666667
94385, 1.1625, 0.51521739130435, 0.13888888888889
94386, 1.1625, 0.54130434782609, 0.11111111111111
94387, 1.18125, 0.51521739130435, 0.11111111111111
94388, 1.1625, 0.51521739130435, 0.083333333333333
94389, 1.1625, 0.54130434782609, 0.055555555555556
94390, 1.18125, 0.51521739130435, 0.055555555555556
94391, 1.1625, 0.51521739130435, 0.027777777777778
94392, 1.1625, 0.46304347826087, 0.47222222222222
94393, 1.1625, 0.48913043478261, 0.44444444444444
94394, 1.18125, 0.46304347826087, 0.44444444444444
94395, 1.1625, 0.46304347826087, 0.41666666666667
94396, 1.1625, 0.48913043478261, 0.38888888888889
94397, 1.18125, 0.46304347826087, 0.38888888888889
94398, 1.1625, 0.46304347826087, 0.36111111111111
94399, 1.1625, 0.48913043478261, 0.33333333333333
94400, 1.18125, 0.46304347826087, 0.33333333333333
94401, 1.1625, 0.46304347826087, 0.30555555555556
94402, 1.1625, 0.48913043478261, 0.27777777777778
94403, 1.18125, 0.46304347826087, 0.27777777777778
94404, 1.1625, 0.46304347826087, 0.25
94405, 1.1625, 0.48913043478261, 0.22222222222222
94406, 1.18125, 0.46304347826087, 0.22222222222222
94407, 1.1625, 0.46304347826087, 0.19444444444444
94408, 1.1625, 0.48913043478261, 0.16666666666667
94409, 1.18125, 0.46304347826087, 0.16666666666667
94410, 1.1625, 0.46304347826087, 0.13888888888889
94411, 1.1625, 0.48913043478261, 0.11111111111111
94412, 1.18125, 0.46304347826087, 0.11111111111111
94413, 1.1625, 0.46304347826087, 0.083333333333333
94414, 1.1625, 0.48913043478261, 0.055555555555556
94415, 1.18125, 0.46304347826087, 0.055555555555556
94416, 1.1625, 0.46304347826087, 0.027777777777778
94417, 1.1625, 0.41086956521739, 0.47222222222222
94418, 1.1625, 0.43695652173913, 0.44444444444444
94419, 1.18125, 0.41086956521739, 0.44444444444444
94420, 1.1625, 0.41086956521739, 0.41666666666667
94421, 1.1625, 0.43695652173913, 0.38888888888889
94422, 1.18125, 0.41086956521739, 0.38888888888889
94423, 1.1625, 0.41086956521739, 0.36111111111111
94424, 1.1625, 0.43695652173913, 0.33333333333333
94425, 1.18125, 0.41086956521739, 0.33333333333333
94426, 1.1625, 0.41086956521739, 0.30555555555556
94427, 1.1625, 0.43695652173913, 0.27777777777778
94428, 1.18125, 0.41086956521739, 0.27777777777778
94429, 1.1625, 0.41086956521739, 0.25
94430, 1.1625, 0.43695652173913, 0.22222222222222
94431, 1.18125, 0.41086956521739, 0.22222222222222
94432, 1.1625, 0.41086956521739, 0.19444444444444
94433, 1.1625, 0.43695652173913, 0.16666666666667
94434, 1.18125, 0.41086956521739, 0.16666666666667
94435, 1.1625, 0.41086956521739, 0.13888888888889
94436, 1.1625, 0.43695652173913, 0.11111111111111
94437, 1.18125, 0.41086956521739, 0.11111111111111
94438, 1.1625, 0.41086956521739, 0.083333333333333
94439, 1.1625, 0.43695652173913, 0.055555555555556
94440, 1.18125, 0.41086956521739, 0.055555555555556
94441, 1.1625, 0.41086956521739, 0.027777777777778
94442, 1.1625, 0.35869565217391, 0.47222222222222
94443, 1.1625, 0.38478260869565, 0.44444444444444
94444, 1.18125, 0.35869565217391, 0.44444444444444
94445, 1.1625, 0.35869565217391, 0.41666666666667
94446, 1.1625, 0.38478260869565, 0.38888888888889
94447, 1.18125, 0.35869565217391, 0.38888888888889
94448, 1.1625, 0.35869565217391, 0.36111111111111
94449, 1.1625, 0.38478260869565, 0.33333333333333
94450, 1.18125, 0.35869565217391, 0.33333333333333
94451, 1.1625, 0.35869565217391, 0.30555555555556
94452, 1.1625, 0.38478260869565, 0.27777777777778
94453, 1.18125, 0.35869565217391, 0.27777777777778
94454, 1.1625, 0.35869565217391, 0.25
94455, 1.1625, 0.38478260869565, 0.22222222222222
94456, 1.18125, 0.35869565217391, 0.22222222222222
94457, 1.1625, 0.35869565217391, 0.19444444444444
94458, 1.1625, 0.38478260869565, 0.16666666666667
94459, 1.18125, 0.35869565217391, 0.16666666666667
94460, 1.1625, 0.35869565217391, 0.13888888888889
94461, 1.1625, 0.38478260869565, 0.11111111111111
94462, 1.18125, 0.35869565217391, 0.11111111111111
94463, 1.1625, 0.35869565217391, 0.083333333333333
94464, 1.1625, 0.38478260869565, 0.055555555555556
94465, 1.18125, 0.35869565217391, 0.055555555555556
94466, 1.1625, 0.35869565217391, 0.027777777777778
94467, 1.1625, 0.30652173913044, 0.47222222222222
94468, 1.1625, 0.33260869565217, 0.44444444444444
94469, 1.18125, 0.30652173913044, 0.44444444444444
94470, 1.1625, 0.30652173913043, 0.41666666666667
94471, 1.1625, 0.33260869565217, 0.38888888888889
94472, 1.18125, 0.30652173913044, 0.38888888888889
94473, 1.1625, 0.30652173913043, 0.36111111111111
94474, 1.1625, 0.33260869565217, 0.33333333333333
94475, 1.18125, 0.30652173913044, 0.33333333333333
94476, 1.1625, 0.30652173913043, 0.30555555555556
94477, 1.1625, 0.33260869565217, 0.27777777777778
94478, 1.18125, 0.30652173913044, 0.27777777777778
94479, 1.1625, 0.30652173913043, 0.25
94480, 1.1625, 0.33260869565217, 0.22222222222222
94481, 1.18125, 0.30652173913044, 0.22222222222222
94482, 1.1625, 0.30652173913043, 0.19444444444444
94483, 1.1625, 0.33260869565217, 0.16666666666667
94484, 1.18125, 0.30652173913044, 0.16666666666667
94485, 1.1625, 0.30652173913043, 0.13888888888889
94486, 1.1625, 0.33260869565217, 0.11111111111111
94487, 1.18125, 0.30652173913044, 0.11111111111111
94488, 1.1625, 0.30652173913043, 0.083333333333333
94489, 1.1625, 0.33260869565217, 0.055555555555556
94490, 1.18125, 0.30652173913044, 0.055555555555556
94491, 1.1625, 0.30652173913044, 0.027777777777778
94492, 1.1625, 0.25434782608696, 0.47222222222222
94493, 1.1625, 0.2804347826087, 0.44444444444444
94494, 1.18125, 0.25434782608696, 0.44444444444444
94495, 1.1625, 0.25434782608696, 0.41666666666667
94496, 1.1625, 0.2804347826087, 0.38888888888889
94497, 1.18125, 0.25434782608696, 0.38888888888889
94498, 1.1625, 0.25434782608696, 0.36111111111111
94499, 1.1625, 0.2804347826087, 0.33333333333333
94500, 1.18125, 0.25434782608696, 0.33333333333333
94501, 1.1625, 0.25434782608696, 0.30555555555556
94502, 1.1625, 0.2804347826087, 0.27777777777778
94503, 1.18125, 0.25434782608696, 0.27777777777778
94504, 1.1625, 0.25434782608696, 0.25
94505, 1.1625, 0.2804347826087, 0.22222222222222
94506, 1.18125, 0.25434782608696, 0.22222222222222
94507, 1.1625, 0.25434782608696, 0.19444444444444
94508, 1.1625, 0.2804347826087, 0.16666666666667
94509, 1.18125, 0.25434782608696, 0.16666666666667
94510, 1.1625, 0.25434782608696, 0.13888888888889
94511, 1.1625, 0.2804347826087, 0.11111111111111
94512, 1.18125, 0.25434782608696, 0.11111111111111
94513, 1.1625, 0.25434782608696, 0.083333333333333
94514, 1.1625, 0.2804347826087, 0.055555555555556
94515, 1.18125, 0.25434782608696, 0.055555555555556
94516, 1.1625, 0.25434782608696, 0.027777777777778
94517, 1.1625, 0.20217391304348, 0.47222222222222
94518, 1.1625, 0.22826086956522, 0.44444444444444
94519, 1.18125, 0.20217391304348, 0.44444444444444
94520, 1.1625, 0.20217391304348, 0.41666666666667
94521, 1.1625, 0.22826086956522, 0.38888888888889
94522, 1.18125, 0.20217391304348, 0.38888888888889
94523, 1.1625, 0.20217391304348, 0.36111111111111
94524, 1.1625, 0.22826086956522, 0.33333333333333
94525, 1.18125, 0.20217391304348, 0.33333333333333
94526, 1.1625, 0.20217391304348, 0.30555555555556
94527, 1.1625, 0.22826086956522, 0.27777777777778
94528, 1.18125, 0.20217391304348, 0.27777777777778
94529, 1.1625, 0.20217391304348, 0.25
94530, 1.1625, 0.22826086956522, 0.22222222222222
94531, 1.18125, 0.20217391304348, 0.22222222222222
94532, 1.1625, 0.20217391304348, 0.19444444444444
94533, 1.1625, 0.22826086956522, 0.16666666666667
94534, 1.18125, 0.20217391304348, 0.16666666666667
94535, 1.1625, 0.20217391304348, 0.13888888888889
94536, 1.1625, 0.22826086956522, 0.11111111111111
94537, 1.18125, 0.20217391304348, 0.11111111111111
94538, 1.1625, 0.20217391304348, 0.083333333333333
94539, 1.1625, 0.22826086956522, 0.055555555555556
94540, 1.18125, 0.20217391304348, 0.055555555555556
94541, 1.1625, 0.20217391304348, 0.027777777777778
94542, 1.1625, 0.17608695652174, 0.44444444444444
94543, 1.1625, 0.17608695652174, 0.38888888888889
94544, 1.1625, 0.17608695652174, 0.33333333333333
94545, 1.1625, 0.17608695652174, 0.27777777777778
94546, 1.1625, 0.17608695652174, 0.22222222222222
94547, 1.1625, 0.17608695652174, 0.16666666666667
94548, 1.1625, 0.17608695652174, 0.11111111111111
94549, 1.1625, 0.17608695652174, 0.055555555555556
94550, 1.14375, 1.2978260869565, 0.44444444444444
94551, 1.14375, 1.2978260869565, 0.38888888888889
94552, 1.14375, 1.2978260869565, 0.33333333333333
94553, 1.14375, 1.2978260869565, 0.27777777777778
94554, 1.14375, 1.2978260869565, 0.22222222222222
94555, 1.14375, 1.2978260869565, 0.16666666666667
94556, 1.14375, 1.2978260869565, 0.11111111111111
94557, 1.14375, 1.2978260869565, 0.055555555555556
94558, 1.14375, 1.245652173913, 0.44444444444444
94559, 1.14375, 1.245652173913, 0.38888888888889
94560, 1.14375, 1.245652173913, 0.33333333333333
94561, 1.14375, 1.245652173913, 0.27777777777778
94562, 1.14375, 1.245652173913, 0.22222222222222
94563, 1.14375, 1.245652173913, 0.16666666666667
94564, 1.14375, 1.245652173913, 0.11111111111111
94565, 1.14375, 1.245652173913, 0.055555555555556
94566, 1.14375, 1.1934782608696, 0.44444444444444
94567, 1.14375, 1.1934782608696, 0.38888888888889
94568, 1.14375, 1.1934782608696, 0.33333333333333
94569, 1.14375, 1.1934782608696, 0.27777777777778
94570, 1.14375, 1.1934782608696, 0.22222222222222
94571, 1.14375, 1.1934782608696, 0.16666666666667
94572, 1.14375, 1.1934782608696, 0.11111111111111
94573, 1.14375, 1.1934782608696, 0.055555555555556
94574, 1.14375, 1.1413043478261, 0.44444444444444
94575, 1.14375, 1.1413043478261, 0.38888888888889
94576, 1.14375, 1.1413043478261, 0.33333333333333
94577, 1.14375, 1.1413043478261, 0.27777777777778
94578, 1.14375, 1.1413043478261, 0.22222222222222
94579, 1.14375, 1.1413043478261, 0.16666666666667
94580, 1.14375, 1.1413043478261, 0.11111111111111
94581, 1.14375, 1.1413043478261, 0.055555555555556
94582, 1.14375, 1.0891304347826, 0.44444444444444
94583, 1.14375, 1.0891304347826, 0.38888888888889
94584, 1.14375, 1.0891304347826, 0.33333333333333
94585, 1.14375, 1.0891304347826, 0.27777777777778
94586, 1.14375, 1.0891304347826, 0.22222222222222
94587, 1.14375, 1.0891304347826, 0.16666666666667
94588, 1.14375, 1.0891304347826, 0.11111111111111
94589, 1.14375, 1.0891304347826, 0.055555555555556
94590, 1.14375, 1.0369565217391, 0.44444444444444
94591, 1.14375, 1.0369565217391, 0.38888888888889
94592, 1.14375, 1.0369565217391, 0.33333333333333
94593, 1.14375, 1.0369565217391, 0.27777777777778
94594, 1.14375, 1.0369565217391, 0.22222222222222
94595, 1.14375, 1.0369565217391, 0.16666666666667
94596, 1.14375, 1.0369565217391, 0.11111111111111
94597, 1.14375, 1.0369565217391, 0.055555555555556
94598, 1.14375, 0.98478260869565, 0.44444444444444
94599, 1.14375, 0.98478260869565, 0.38888888888889
94600, 1.14375, 0.98478260869565, 0.33333333333333
94601, 1.14375, 0.98478260869565, 0.27777777777778
94602, 1.14375, 0.98478260869565, 0.22222222222222
94603, 1.14375, 0.98478260869565, 0.16666666666667
94604, 1.14375, 0.98478260869565, 0.11111111111111
94605, 1.14375, 0.98478260869565, 0.055555555555556
94606, 1.14375, 0.93260869565217, 0.44444444444444
94607, 1.14375, 0.93260869565217, 0.38888888888889
94608, 1.14375, 0.93260869565217, 0.33333333333333
94609, 1.14375, 0.93260869565217, 0.27777777777778
94610, 1.14375, 0.93260869565217, 0.22222222222222
94611, 1.14375, 0.93260869565217, 0.16666666666667
94612, 1.14375, 0.93260869565217, 0.11111111111111
94613, 1.14375, 0.93260869565217, 0.055555555555556
94614, 1.14375, 0.8804347826087, 0.44444444444444
94615, 1.14375, 0.8804347826087, 0.38888888888889
94616, 1.14375, 0.8804347826087, 0.33333333333333
94617, 1.14375, 0.8804347826087, 0.27777777777778
94618, 1.14375, 0.8804347826087, 0.22222222222222
94619, 1.14375, 0.8804347826087, 0.16666666666667
94620, 1.14375, 0.8804347826087, 0.11111111111111
94621, 1.14375, 0.8804347826087, 0.055555555555556
94622, 1.14375, 0.82826086956522, 0.44444444444444
94623, 1.14375, 0.82826086956522, 0.38888888888889
94624, 1.14375, 0.82826086956522, 0.33333333333333
94625, 1.14375, 0.82826086956522, 0.27777777777778
94626, 1.14375, 0.82826086956522, 0.22222222222222
94627, 1.14375, 0.82826086956522, 0.16666666666667
94628, 1.14375, 0.82826086956522, 0.11111111111111
94629, 1.14375, 0.82826086956522, 0.055555555555556
94630, 1.14375, 0.77608695652174, 0.44444444444444
94631, 1.14375, 0.77608695652174, 0.38888888888889
94632, 1.14375, 0.77608695652174, 0.33333333333333
94633, 1.14375, 0.77608695652174, 0.27777777777778
94634, 1.14375, 0.77608695652174, 0.22222222222222
94635, 1.14375, 0.77608695652174, 0.16666666666667
94636, 1.14375, 0.77608695652174, 0.11111111111111
94637, 1.14375, 0.77608695652174, 0.055555555555556
94638, 1.14375, 0.72391304347826, 0.44444444444444
94639, 1.14375, 0.72391304347826, 0.38888888888889
94640, 1.14375, 0.72391304347826, 0.33333333333333
94641, 1.14375, 0.72391304347826, 0.27777777777778
94642, 1.14375, 0.72391304347826, 0.22222222222222
94643, 1.14375, 0.72391304347826, 0.16666666666667
94644, 1.14375, 0.72391304347826, 0.11111111111111
94645, 1.14375, 0.72391304347826, 0.055555555555556
94646, 1.14375, 0.67173913043478, 0.44444444444444
94647, 1.14375, 0.67173913043478, 0.38888888888889
94648, 1.14375, 0.67173913043478, 0.33333333333333
94649, 1.14375, 0.67173913043478, 0.27777777777778
94650, 1.14375, 0.67173913043478, 0.22222222222222
94651, 1.14375, 0.67173913043478, 0.16666666666667
94652, 1.14375, 0.67173913043478, 0.11111111111111
94653, 1.14375, 0.67173913043478, 0.055555555555556
94654, 1.14375, 0.61956521739131, 0.44444444444444
94655, 1.14375, 0.61956521739131, 0.38888888888889
94656, 1.14375, 0.61956521739131, 0.33333333333333
94657, 1.14375, 0.61956521739131, 0.27777777777778
94658, 1.14375, 0.61956521739131, 0.22222222222222
94659, 1.14375, 0.6195652173913, 0.16666666666667
94660, 1.14375, 0.6195652173913, 0.11111111111111
94661, 1.14375, 0.61956521739131, 0.055555555555556
94662, 1.14375, 0.56739130434783, 0.44444444444444
94663, 1.14375, 0.56739130434783, 0.38888888888889
94664, 1.14375, 0.56739130434783, 0.33333333333333
94665, 1.14375, 0.56739130434783, 0.27777777777778
94666, 1.14375, 0.56739130434783, 0.22222222222222
94667, 1.14375, 0.56739130434783, 0.16666666666667
94668, 1.14375, 0.56739130434783, 0.11111111111111
94669, 1.14375, 0.56739130434783, 0.055555555555556
94670, 1.14375, 0.51521739130435, 0.44444444444444
94671, 1.14375, 0.51521739130435, 0.38888888888889
94672, 1.14375, 0.51521739130435, 0.33333333333333
94673, 1.14375, 0.51521739130435, 0.27777777777778
94674, 1.14375, 0.51521739130435, 0.22222222222222
94675, 1.14375, 0.51521739130435, 0.16666666666667
94676, 1.14375, 0.51521739130435, 0.11111111111111
94677, 1.14375, 0.51521739130435, 0.055555555555556
94678, 1.14375, 0.46304347826087, 0.44444444444444
94679, 1.14375, 0.46304347826087, 0.38888888888889
94680, 1.14375, 0.46304347826087, 0.33333333333333
94681, 1.14375, 0.46304347826087, 0.27777777777778
94682, 1.14375, 0.46304347826087, 0.22222222222222
94683, 1.14375, 0.46304347826087, 0.16666666666667
94684, 1.14375, 0.46304347826087, 0.11111111111111
94685, 1.14375, 0.46304347826087, 0.055555555555556
94686, 1.14375, 0.41086956521739, 0.44444444444444
94687, 1.14375, 0.41086956521739, 0.38888888888889
94688, 1.14375, 0.41086956521739, 0.33333333333333
94689, 1.14375, 0.41086956521739, 0.27777777777778
94690, 1.14375, 0.41086956521739, 0.22222222222222
94691, 1.14375, 0.41086956521739, 0.16666666666667
94692, 1.14375, 0.41086956521739, 0.11111111111111
94693, 1.14375, 0.41086956521739, 0.055555555555556
94694, 1.14375, 0.35869565217391, 0.44444444444444
94695, 1.14375, 0.35869565217391, 0.38888888888889
94696, 1.14375, 0.35869565217391, 0.33333333333333
94697, 1.14375, 0.35869565217391, 0.27777777777778
94698, 1.14375, 0.35869565217391, 0.22222222222222
94699, 1.14375, 0.35869565217391, 0.16666666666667
94700, 1.14375, 0.35869565217391, 0.11111111111111
94701, 1.14375, 0.35869565217391, 0.055555555555556
94702, 1.14375, 0.30652173913043, 0.44444444444444
94703, 1.14375, 0.30652173913043, 0.38888888888889
94704, 1.14375, 0.30652173913043, 0.33333333333333
94705, 1.14375, 0.30652173913043, 0.27777777777778
94706, 1.14375, 0.30652173913043, 0.22222222222222
94707, 1.14375, 0.30652173913043, 0.16666666666667
94708, 1.14375, 0.30652173913043, 0.11111111111111
94709, 1.14375, 0.30652173913043, 0.055555555555556
94710, 1.14375, 0.25434782608696, 0.44444444444444
94711, 1.14375, 0.25434782608696, 0.38888888888889
94712, 1.14375, 0.25434782608696, 0.33333333333333
94713, 1.14375, 0.25434782608696, 0.27777777777778
94714, 1.14375, 0.25434782608696, 0.22222222222222
94715, 1.14375, 0.25434782608696, 0.16666666666667
94716, 1.14375, 0.25434782608696, 0.11111111111111
94717, 1.14375, 0.25434782608696, 0.055555555555556
94718, 1.14375, 0.20217391304348, 0.44444444444444
94719, 1.14375, 0.20217391304348, 0.38888888888889
94720, 1.14375, 0.20217391304348, 0.33333333333333
94721, 1.14375, 0.20217391304348, 0.27777777777778
94722, 1.14375, 0.20217391304348, 0.22222222222222
94723, 1.14375, 0.20217391304348, 0.16666666666667
94724, 1.14375, 0.20217391304348, 0.11111111111111
94725, 1.14375, 0.20217391304348, 0.055555555555556
94726, 0.95652173913043, 1.375, 0.055555555555556
94727, 0.95652173913044, 1.375, 0.11111111111111
94728, 0.95652173913044, 1.375, 0.16666666666667
94729, 0.95652173913044, 1.375, 0.22222222222222
94730, 0.95652173913044, 1.375, 0.27777777777778
94731, 0.95652173913044, 1.375, 0.33333333333333
94732, 0.95652173913044, 1.375, 0.38888888888889
94733, 0.95652173913044, 1.375, 0.44444444444444
94734, 0.91304347826087, 1.375, 0.055555555555556
94735, 0.91304347826087, 1.375, 0.11111111111111
94736, 0.91304347826087, 1.375, 0.16666666666667
94737, 0.91304347826087, 1.375, 0.22222222222222
94738, 0.91304347826087, 1.375, 0.27777777777778
94739, 0.91304347826087, 1.375, 0.33333333333333
94740, 0.91304347826087, 1.375, 0.38888888888889
94741, 0.91304347826087, 1.375, 0.44444444444444
94742, 0.8695652173913, 1.375, 0.055555555555556
94743, 0.8695652173913, 1.375, 0.11111111111111
94744, 0.8695652173913, 1.375, 0.16666666666667
94745, 0.8695652173913, 1.375, 0.22222222222222
94746, 0.8695652173913, 1.375, 0.27777777777778
94747, 0.8695652173913, 1.375, 0.33333333333333
94748, 0.8695652173913, 1.375, 0.38888888888889
94749, 0.8695652173913, 1.375, 0.44444444444444
94750, 0.82608695652174, 1.375, 0.055555555555556
94751, 0.82608695652174, 1.375, 0.11111111111111
94752, 0.82608695652174, 1.375, 0.16666666666667
94753, 0.82608695652174, 1.375, 0.22222222222222
94754, 0.82608695652174, 1.375, 0.27777777777778
94755, 0.82608695652174, 1.375, 0.33333333333333
94756, 0.82608695652174, 1.375, 0.38888888888889
94757, 0.82608695652174, 1.375, 0.44444444444444
94758, 0.78260869565217, 1.375, 0.055555555555556
94759, 0.78260869565217, 1.375, 0.11111111111111
94760, 0.78260869565217, 1.375, 0.16666666666667
94761, 0.78260869565217, 1.375, 0.22222222222222
94762, 0.78260869565217, 1.375, 0.27777777777778
94763, 0.78260869565217, 1.375, 0.33333333333333
94764, 0.78260869565217, 1.375, 0.38888888888889
94765, 0.78260869565217, 1.375, 0.44444444444444
94766, 0.73913043478261, 1.375, 0.055555555555556
94767, 0.73913043478261, 1.375, 0.11111111111111
94768, 0.73913043478261, 1.375, 0.16666666666667
94769, 0.73913043478261, 1.375, 0.22222222222222
94770, 0.73913043478261, 1.375, 0.27777777777778
94771, 0.73913043478261, 1.375, 0.33333333333333
94772, 0.73913043478261, 1.375, 0.38888888888889
94773, 0.73913043478261, 1.375, 0.44444444444444
94774, 0.69565217391304, 1.375, 0.055555555555556
94775, 0.69565217391304, 1.375, 0.11111111111111
94776, 0.69565217391304, 1.375, 0.16666666666667
94777, 0.69565217391304, 1.375, 0.22222222222222
94778, 0.69565217391304, 1.375, 0.27777777777778
94779, 0.69565217391304, 1.375, 0.33333333333333
94780, 0.69565217391304, 1.375, 0.38888888888889
94781, 0.69565217391304, 1.375, 0.44444444444444
94782, 0.65217391304348, 1.375, 0.055555555555556
94783, 0.65217391304348, 1.375, 0.11111111111111
94784, 0.65217391304348, 1.375, 0.16666666666667
94785, 0.65217391304348, 1.375, 0.22222222222222
94786, 0.65217391304348, 1.375, 0.27777777777778
94787, 0.65217391304348, 1.375, 0.33333333333333
94788, 0.65217391304348, 1.375, 0.38888888888889
94789, 0.65217391304348, 1.375, 0.44444444444444
94790, 0.60869565217391, 1.375, 0.055555555555556
94791, 0.60869565217391, 1.375, 0.11111111111111
94792, 0.60869565217391, 1.375, 0.16666666666667
94793, 0.60869565217391, 1.375, 0.22222222222222
94794, 0.60869565217391, 1.375, 0.27777777777778
94795, 0.60869565217391, 1.375, 0.33333333333333
94796, 0.60869565217391, 1.375, 0.38888888888889
94797, 0.60869565217391, 1.375, 0.44444444444444
94798, 0.56521739130435, 1.375, 0.055555555555556
94799, 0.56521739130435, 1.375, 0.11111111111111
94800, 0.56521739130435, 1.375, 0.16666666666667
94801, 0.56521739130435, 1.375, 0.22222222222222
94802, 0.56521739130435, 1.375, 0.27777777777778
94803, 0.56521739130435, 1.375, 0.33333333333333
94804, 0.56521739130435, 1.375, 0.38888888888889
94805, 0.56521739130435, 1.375, 0.44444444444444
94806, 0.52173913043478, 1.375, 0.055555555555556
94807, 0.52173913043478, 1.375, 0.11111111111111
94808, 0.52173913043478, 1.375, 0.16666666666667
94809, 0.52173913043478, 1.375, 0.22222222222222
94810, 0.52173913043478, 1.375, 0.27777777777778
94811, 0.52173913043478, 1.375, 0.33333333333333
94812, 0.52173913043478, 1.375, 0.38888888888889
94813, 0.52173913043478, 1.375, 0.44444444444444
94814, 0.47826086956522, 1.375, 0.055555555555556
94815, 0.47826086956522, 1.375, 0.11111111111111
94816, 0.47826086956522, 1.375, 0.16666666666667
94817, 0.47826086956522, 1.375, 0.22222222222222
94818, 0.47826086956522, 1.375, 0.27777777777778
94819, 0.47826086956522, 1.375, 0.33333333333333
94820, 0.47826086956522, 1.375, 0.38888888888889
94821, 0.47826086956522, 1.375, 0.44444444444444
94822, 0.43478260869565, 1.375, 0.055555555555556
94823, 0.43478260869565, 1.375, 0.11111111111111
94824, 0.43478260869565, 1.375, 0.16666666666667
94825, 0.43478260869565, 1.375, 0.22222222222222
94826, 0.43478260869565, 1.375, 0.27777777777778
94827, 0.43478260869565, 1.375, 0.33333333333333
94828, 0.43478260869565, 1.375, 0.38888888888889
94829, 0.43478260869565, 1.375, 0.44444444444444
94830, 0.39130434782609, 1.375, 0.055555555555556
94831, 0.39130434782609, 1.375, 0.11111111111111
94832, 0.39130434782609, 1.375, 0.16666666666667
94833, 0.39130434782609, 1.375, 0.22222222222222
94834, 0.39130434782609, 1.375, 0.27777777777778
94835, 0.39130434782609, 1.375, 0.33333333333333
94836, 0.39130434782609, 1.375, 0.38888888888889
94837, 0.39130434782609, 1.375, 0.44444444444444
94838, 0.34782608695652, 1.375, 0.055555555555556
94839, 0.34782608695652, 1.375, 0.11111111111111
94840, 0.34782608695652, 1.375, 0.16666666666667
94841, 0.34782608695652, 1.375, 0.22222222222222
94842, 0.34782608695652, 1.375, 0.27777777777778
94843, 0.34782608695652, 1.375, 0.33333333333333
94844, 0.34782608695652, 1.375, 0.38888888888889
94845, 0.34782608695652, 1.375, 0.44444444444444
94846, 0.30434782608696, 1.375, 0.055555555555556
94847, 0.30434782608696, 1.375, 0.11111111111111
94848, 0.30434782608696, 1.375, 0.16666666666667
94849, 0.30434782608696, 1.375, 0.22222222222222
94850, 0.30434782608696, 1.375, 0.27777777777778
94851, 0.30434782608696, 1.375, 0.33333333333333
94852, 0.30434782608696, 1.375, 0.38888888888889
94853, 0.30434782608696, 1.375, 0.44444444444444
94854, 0.26086956521739, 1.375, 0.055555555555556
94855, 0.26086956521739, 1.375, 0.11111111111111
94856, 0.26086956521739, 1.375, 0.16666666666667
94857, 0.26086956521739, 1.375, 0.22222222222222
94858, 0.26086956521739, 1.375, 0.27777777777778
94859, 0.26086956521739, 1.375, 0.33333333333333
94860, 0.26086956521739, 1.375, 0.38888888888889
94861, 0.26086956521739, 1.375, 0.44444444444444
94862, 0.21739130434783, 1.375, 0.055555555555556
94863, 0.21739130434783, 1.375, 0.11111111111111
94864, 0.21739130434783, 1.375, 0.16666666666667
94865, 0.21739130434783, 1.375, 0.22222222222222
94866, 0.21739130434783, 1.375, 0.27777777777778
94867, 0.21739130434783, 1.375, 0.33333333333333
94868, 0.21739130434783, 1.375, 0.38888888888889
94869, 0.21739130434783, 1.375, 0.44444444444444
94870, 0.17391304347826, 1.375, 0.055555555555556
94871, 0.17391304347826, 1.375, 0.11111111111111
94872, 0.17391304347826, 1.375, 0.16666666666667
94873, 0.17391304347826, 1.375, 0.22222222222222
94874, 0.17391304347826, 1.375, 0.27777777777778
94875, 0.17391304347826, 1.375, 0.33333333333333
94876, 0.17391304347826, 1.375, 0.38888888888889
94877, 0.17391304347826, 1.375, 0.44444444444444
94878, 0.1304347826087, 1.375, 0.055555555555556
94879, 0.1304347826087, 1.375, 0.11111111111111
94880, 0.1304347826087, 1.375, 0.16666666666667
94881, 0.1304347826087, 1.375, 0.22222222222222
94882, 0.1304347826087, 1.375, 0.27777777777778
94883, 0.1304347826087, 1.375, 0.33333333333333
94884, 0.1304347826087, 1.375, 0.38888888888889
94885, 0.1304347826087, 1.375, 0.44444444444444
94886, 0.08695652173913, 1.375, 0.055555555555556
94887, 0.08695652173913, 1.375, 0.11111111111111
94888, 0.08695652173913, 1.375, 0.16666666666667
94889, 0.08695652173913, 1.375, 0.22222222222222
94890, 0.08695652173913, 1.375, 0.27777777777778
94891, 0.08695652173913, 1.375, 0.33333333333333
94892, 0.08695652173913, 1.375, 0.38888888888889
94893, 0.08695652173913, 1.375, 0.44444444444444
94894, 0.043478260869565, 1.375, 0.055555555555556
94895, 0.043478260869565, 1.375, 0.11111111111111
94896, 0.043478260869565, 1.375, 0.16666666666667
94897, 0.043478260869565, 1.375, 0.22222222222222
94898, 0.043478260869565, 1.375, 0.27777777777778
94899, 0.043478260869565, 1.375, 0.33333333333333
94900, 0.043478260869565, 1.375, 0.38888888888889
94901, 0.043478260869565, 1.375, 0.44444444444444
94902, 0.95652173913043, 1.375, 0.027777777777778
94903, 0.97826086956522, 1.375, 0.055555555555556
94904, 0.95652173913043, 1.3875, 0.055555555555556
94905, 0.95652173913043, 1.375, 0.083333333333333
94906, 0.97826086956522, 1.375, 0.11111111111111
94907, 0.95652173913044, 1.3875, 0.11111111111111
94908, 0.95652173913044, 1.375, 0.13888888888889
94909, 0.97826086956522, 1.375, 0.16666666666667
94910, 0.95652173913044, 1.3875, 0.16666666666667
94911, 0.95652173913044, 1.375, 0.19444444444444
94912, 0.97826086956522, 1.375, 0.22222222222222
94913, 0.95652173913043, 1.3875, 0.22222222222222
94914, 0.95652173913044, 1.375, 0.25
94915, 0.97826086956522, 1.375, 0.27777777777778
94916, 0.95652173913043, 1.3875, 0.27777777777778
94917, 0.95652173913044, 1.375, 0.30555555555556
94918, 0.97826086956522, 1.375, 0.33333333333333
94919, 0.95652173913043, 1.3875, 0.33333333333333
94920, 0.95652173913044, 1.375, 0.36111111111111
94921, 0.97826086956522, 1.375, 0.38888888888889
94922, 0.95652173913043, 1.3875, 0.38888888888889
94923, 0.95652173913044, 1.375, 0.41666666666667
94924, 0.97826086956522, 1.375, 0.44444444444444
94925, 0.95652173913043, 1.3875, 0.44444444444444
94926, 0.95652173913043, 1.375, 0.47222222222222
94927, 0.91304347826087, 1.375, 0.027777777777778
94928, 0.93478260869565, 1.375, 0.055555555555556
94929, 0.91304347826087, 1.3875, 0.055555555555556
94930, 0.91304347826087, 1.375, 0.083333333333333
94931, 0.93478260869565, 1.375, 0.11111111111111
94932, 0.91304347826087, 1.3875, 0.11111111111111
94933, 0.91304347826087, 1.375, 0.13888888888889
94934, 0.93478260869565, 1.375, 0.16666666666667
94935, 0.91304347826087, 1.3875, 0.16666666666667
94936, 0.91304347826087, 1.375, 0.19444444444444
94937, 0.93478260869565, 1.375, 0.22222222222222
94938, 0.91304347826087, 1.3875, 0.22222222222222
94939, 0.91304347826087, 1.375, 0.25
94940, 0.93478260869565, 1.375, 0.27777777777778
94941, 0.91304347826087, 1.3875, 0.27777777777778
94942, 0.91304347826087, 1.375, 0.30555555555556
94943, 0.93478260869565, 1.375, 0.33333333333333
94944, 0.91304347826087, 1.3875, 0.33333333333333
94945, 0.91304347826087, 1.375, 0.36111111111111
94946, 0.93478260869565, 1.375, 0.38888888888889
94947, 0.91304347826087, 1.3875, 0.38888888888889
94948, 0.91304347826087, 1.375, 0.41666666666667
94949, 0.93478260869565, 1.375, 0.44444444444444
94950, 0.91304347826087, 1.3875, 0.44444444444444
94951, 0.91304347826087, 1.375, 0.47222222222222
94952, 0.8695652173913, 1.375, 0.027777777777778
94953, 0.89130434782609, 1.375, 0.055555555555556
94954, 0.8695652173913, 1.3875, 0.055555555555556
94955, 0.8695652173913, 1.375, 0.083333333333333
94956, 0.89130434782609, 1.375, 0.11111111111111
94957, 0.8695652173913, 1.3875, 0.11111111111111
94958, 0.8695652173913, 1.375, 0.13888888888889
94959, 0.89130434782609, 1.375, 0.16666666666667
94960, 0.8695652173913, 1.3875, 0.16666666666667
94961, 0.8695652173913, 1.375, 0.19444444444444
94962, 0.89130434782609, 1.375, 0.22222222222222
94963, 0.8695652173913, 1.3875, 0.22222222222222
94964, 0.8695652173913, 1.375, 0.25
94965, 0.89130434782609, 1.375, 0.27777777777778
94966, 0.8695652173913, 1.3875, 0.27777777777778
94967, 0.8695652173913, 1.375, 0.30555555555556
94968, 0.89130434782609, 1.375, 0.33333333333333
94969, 0.8695652173913, 1.3875, 0.33333333333333
94970, 0.8695652173913, 1.375, 0.36111111111111
94971, 0.89130434782609, 1.375, 0.38888888888889
94972, 0.8695652173913, 1.3875, 0.38888888888889
94973, 0.8695652173913, 1.375, 0.41666666666667
94974, 0.89130434782609, 1.375, 0.44444444444444
94975, 0.8695652173913, 1.3875, 0.44444444444444
94976, 0.8695652173913, 1.375, 0.47222222222222
94977, 0.82608695652174, 1.375, 0.027777777777778
94978, 0.84782608695652, 1.375, 0.055555555555556
94979, 0.82608695652174, 1.3875, 0.055555555555556
94980, 0.82608695652174, 1.375, 0.083333333333333
94981, 0.84782608695652, 1.375, 0.11111111111111
94982, 0.82608695652174, 1.3875, 0.11111111111111
94983, 0.82608695652174, 1.375, 0.13888888888889
94984, 0.84782608695652, 1.375, 0.16666666666667
94985, 0.82608695652174, 1.3875, 0.16666666666667
94986, 0.82608695652174, 1.375, 0.19444444444444
94987, 0.84782608695652, 1.375, 0.22222222222222
94988, 0.82608695652174, 1.3875, 0.22222222222222
94989, 0.82608695652174, 1.375, 0.25
94990, 0.84782608695652, 1.375, 0.27777777777778
94991, 0.82608695652174, 1.3875, 0.27777777777778
94992, 0.82608695652174, 1.375, 0.30555555555556
94993, 0.84782608695652, 1.375, 0.33333333333333
94994, 0.82608695652174, 1.3875, 0.33333333333333
94995, 0.82608695652174, 1.375, 0.36111111111111
94996, 0.84782608695652, 1.375, 0.38888888888889
94997, 0.82608695652174, 1.3875, 0.38888888888889
94998, 0.82608695652174, 1.375, 0.41666666666667
94999, 0.84782608695652, 1.375, 0.44444444444444
95000, 0.82608695652174, 1.3875, 0.44444444444444
95001, 0.82608695652174, 1.375, 0.47222222222222
95002, 0.78260869565217, 1.375, 0.027777777777778
95003, 0.80434782608696, 1.375, 0.055555555555556
95004, 0.78260869565217, 1.3875, 0.055555555555556
95005, 0.78260869565217, 1.375, 0.083333333333333
95006, 0.80434782608696, 1.375, 0.11111111111111
95007, 0.78260869565217, 1.3875, 0.11111111111111
95008, 0.78260869565217, 1.375, 0.13888888888889
95009, 0.80434782608696, 1.375, 0.16666666666667
95010, 0.78260869565217, 1.3875, 0.16666666666667
95011, 0.78260869565217, 1.375, 0.19444444444444
95012, 0.80434782608696, 1.375, 0.22222222222222
95013, 0.78260869565217, 1.3875, 0.22222222222222
95014, 0.78260869565217, 1.375, 0.25
95015, 0.80434782608696, 1.375, 0.27777777777778
95016, 0.78260869565217, 1.3875, 0.27777777777778
95017, 0.78260869565217, 1.375, 0.30555555555556
95018, 0.80434782608696, 1.375, 0.33333333333333
95019, 0.78260869565217, 1.3875, 0.33333333333333
95020, 0.78260869565217, 1.375, 0.36111111111111
95021, 0.80434782608696, 1.375, 0.38888888888889
95022, 0.78260869565217, 1.3875, 0.38888888888889
95023, 0.78260869565217, 1.375, 0.41666666666667
95024, 0.80434782608696, 1.375, 0.44444444444444
95025, 0.78260869565217, 1.3875, 0.44444444444444
95026, 0.78260869565217, 1.375, 0.47222222222222
95027, 0.73913043478261, 1.375, 0.027777777777778
95028, 0.76086956521739, 1.375, 0.055555555555556
95029, 0.73913043478261, 1.3875, 0.055555555555556
95030, 0.73913043478261, 1.375, 0.083333333333333
95031, 0.76086956521739, 1.375, 0.11111111111111
95032, 0.73913043478261, 1.3875, 0.11111111111111
95033, 0.73913043478261, 1.375, 0.13888888888889
95034, 0.76086956521739, 1.375, 0.16666666666667
95035, 0.73913043478261, 1.3875, 0.16666666666667
95036, 0.73913043478261, 1.375, 0.19444444444444
95037, 0.76086956521739, 1.375, 0.22222222222222
95038, 0.73913043478261, 1.3875, 0.22222222222222
95039, 0.73913043478261, 1.375, 0.25
95040, 0.76086956521739, 1.375, 0.27777777777778
95041, 0.73913043478261, 1.3875, 0.27777777777778
95042, 0.73913043478261, 1.375, 0.30555555555556
95043, 0.76086956521739, 1.375, 0.33333333333333
95044, 0.73913043478261, 1.3875, 0.33333333333333
95045, 0.73913043478261, 1.375, 0.36111111111111
95046, 0.76086956521739, 1.375, 0.38888888888889
95047, 0.73913043478261, 1.3875, 0.38888888888889
95048, 0.73913043478261, 1.375, 0.41666666666667
95049, 0.76086956521739, 1.375, 0.44444444444444
95050, 0.73913043478261, 1.3875, 0.44444444444444
95051, 0.73913043478261, 1.375, 0.47222222222222
95052, 0.69565217391304, 1.375, 0.027777777777778
95053, 0.71739130434783, 1.375, 0.055555555555556
95054, 0.69565217391304, 1.3875, 0.055555555555556
95055, 0.69565217391304, 1.375, 0.083333333333333
95056, 0.71739130434783, 1.375, 0.11111111111111
95057, 0.69565217391304, 1.3875, 0.11111111111111
95058, 0.69565217391304, 1.375, 0.13888888888889
95059, 0.71739130434783, 1.375, 0.16666666666667
95060, 0.69565217391304, 1.3875, 0.16666666666667
95061, 0.69565217391304, 1.375, 0.19444444444444
95062, 0.71739130434783, 1.375, 0.22222222222222
95063, 0.69565217391304, 1.3875, 0.22222222222222
95064, 0.69565217391304, 1.375, 0.25
95065, 0.71739130434783, 1.375, 0.27777777777778
95066, 0.69565217391304, 1.3875, 0.27777777777778
95067, 0.69565217391304, 1.375, 0.30555555555556
95068, 0.71739130434783, 1.375, 0.33333333333333
95069, 0.69565217391304, 1.3875, 0.33333333333333
95070, 0.69565217391304, 1.375, 0.36111111111111
95071, 0.71739130434783, 1.375, 0.38888888888889
95072, 0.69565217391304, 1.3875, 0.38888888888889
95073, 0.69565217391304, 1.375, 0.41666666666667
95074, 0.71739130434783, 1.375, 0.44444444444444
95075, 0.69565217391304, 1.3875, 0.44444444444444
95076, 0.69565217391304, 1.375, 0.47222222222222
95077, 0.65217391304348, 1.375, 0.027777777777778
95078, 0.67391304347826, 1.375, 0.055555555555556
95079, 0.65217391304348, 1.3875, 0.055555555555556
95080, 0.65217391304348, 1.375, 0.083333333333333
95081, 0.67391304347826, 1.375, 0.11111111111111
95082, 0.65217391304348, 1.3875, 0.11111111111111
95083, 0.65217391304348, 1.375, 0.13888888888889
95084, 0.67391304347826, 1.375, 0.16666666666667
95085, 0.65217391304348, 1.3875, 0.16666666666667
95086, 0.65217391304348, 1.375, 0.19444444444444
95087, 0.67391304347826, 1.375, 0.22222222222222
95088, 0.65217391304348, 1.3875, 0.22222222222222
95089, 0.65217391304348, 1.375, 0.25
95090, 0.67391304347826, 1.375, 0.27777777777778
95091, 0.65217391304348, 1.3875, 0.27777777777778
95092, 0.65217391304348, 1.375, 0.30555555555556
95093, 0.67391304347826, 1.375, 0.33333333333333
95094, 0.65217391304348, 1.3875, 0.33333333333333
95095, 0.65217391304348, 1.375, 0.36111111111111
95096, 0.67391304347826, 1.375, 0.38888888888889
95097, 0.65217391304348, 1.3875, 0.38888888888889
95098, 0.65217391304348, 1.375, 0.41666666666667
95099, 0.67391304347826, 1.375, 0.44444444444444
95100, 0.65217391304348, 1.3875, 0.44444444444444
95101, 0.65217391304348, 1.375, 0.47222222222222
95102, 0.60869565217391, 1.375, 0.027777777777778
95103, 0.6304347826087, 1.375, 0.055555555555556
95104, 0.60869565217391, 1.3875, 0.055555555555556
95105, 0.60869565217391, 1.375, 0.083333333333333
95106, 0.6304347826087, 1.375, 0.11111111111111
95107, 0.60869565217391, 1.3875, 0.11111111111111
95108, 0.60869565217391, 1.375, 0.13888888888889
95109, 0.6304347826087, 1.375, 0.16666666666667
95110, 0.60869565217391, 1.3875, 0.16666666666667
95111, 0.60869565217391, 1.375, 0.19444444444444
95112, 0.6304347826087, 1.375, 0.22222222222222
95113, 0.60869565217391, 1.3875, 0.22222222222222
95114, 0.60869565217391, 1.375, 0.25
95115, 0.6304347826087, 1.375, 0.27777777777778
95116, 0.60869565217391, 1.3875, 0.27777777777778
95117, 0.60869565217391, 1.375, 0.30555555555556
95118, 0.6304347826087, 1.375, 0.33333333333333
95119, 0.60869565217391, 1.3875, 0.33333333333333
95120, 0.60869565217391, 1.375, 0.36111111111111
95121, 0.6304347826087, 1.375, 0.38888888888889
95122, 0.60869565217391, 1.3875, 0.38888888888889
95123, 0.60869565217391, 1.375, 0.41666666666667
95124, 0.6304347826087, 1.375, 0.44444444444444
95125, 0.60869565217391, 1.3875, 0.44444444444444
95126, 0.60869565217391, 1.375, 0.47222222222222
95127, 0.56521739130435, 1.375, 0.027777777777778
95128, 0.58695652173913, 1.375, 0.055555555555556
95129, 0.56521739130435, 1.3875, 0.055555555555556
95130, 0.56521739130435, 1.375, 0.083333333333333
95131, 0.58695652173913, 1.375, 0.11111111111111
95132, 0.56521739130435, 1.3875, 0.11111111111111
95133, 0.56521739130435, 1.375, 0.13888888888889
95134, 0.58695652173913, 1.375, 0.16666666666667
95135, 0.56521739130435, 1.3875, 0.16666666666667
95136, 0.56521739130435, 1.375, 0.19444444444444
95137, 0.58695652173913, 1.375, 0.22222222222222
95138, 0.56521739130435, 1.3875, 0.22222222222222
95139, 0.56521739130435, 1.375, 0.25
95140, 0.58695652173913, 1.375, 0.27777777777778
95141, 0.56521739130435, 1.3875, 0.27777777777778
95142, 0.56521739130435, 1.375, 0.30555555555556
95143, 0.58695652173913, 1.375, 0.33333333333333
95144, 0.56521739130435, 1.3875, 0.33333333333333
95145, 0.56521739130435, 1.375, 0.36111111111111
95146, 0.58695652173913, 1.375, 0.38888888888889
95147, 0.56521739130435, 1.3875, 0.38888888888889
95148, 0.56521739130435, 1.375, 0.41666666666667
95149, 0.58695652173913, 1.375, 0.44444444444444
95150, 0.56521739130435, 1.3875, 0.44444444444444
95151, 0.56521739130435, 1.375, 0.47222222222222
95152, 0.52173913043478, 1.375, 0.027777777777778
95153, 0.54347826086957, 1.375, 0.055555555555556
95154, 0.52173913043478, 1.3875, 0.055555555555556
95155, 0.52173913043478, 1.375, 0.083333333333333
95156, 0.54347826086957, 1.375, 0.11111111111111
95157, 0.52173913043478, 1.3875, 0.11111111111111
95158, 0.52173913043478, 1.375, 0.13888888888889
95159, 0.54347826086957, 1.375, 0.16666666666667
95160, 0.52173913043478, 1.3875, 0.16666666666667
95161, 0.52173913043478, 1.375, 0.19444444444444
95162, 0.54347826086956, 1.375, 0.22222222222222
95163, 0.52173913043478, 1.3875, 0.22222222222222
95164, 0.52173913043478, 1.375, 0.25
95165, 0.54347826086956, 1.375, 0.27777777777778
95166, 0.52173913043478, 1.3875, 0.27777777777778
95167, 0.52173913043478, 1.375, 0.30555555555556
95168, 0.54347826086956, 1.375, 0.33333333333333
95169, 0.52173913043478, 1.3875, 0.33333333333333
95170, 0.52173913043478, 1.375, 0.36111111111111
95171, 0.54347826086956, 1.375, 0.38888888888889
95172, 0.52173913043478, 1.3875, 0.38888888888889
95173, 0.52173913043478, 1.375, 0.41666666666667
95174, 0.54347826086956, 1.375, 0.44444444444444
95175, 0.52173913043478, 1.3875, 0.44444444444444
95176, 0.52173913043478, 1.375, 0.47222222222222
95177, 0.47826086956522, 1.375, 0.027777777777778
95178, 0.5, 1.375, 0.055555555555556
95179, 0.47826086956522, 1.3875, 0.055555555555556
95180, 0.47826086956522, 1.375, 0.083333333333333
95181, 0.5, 1.375, 0.11111111111111
95182, 0.47826086956522, 1.3875, 0.11111111111111
95183, 0.47826086956522, 1.375, 0.13888888888889
95184, 0.5, 1.375, 0.16666666666667
95185, 0.47826086956522, 1.3875, 0.16666666666667
95186, 0.47826086956522, 1.375, 0.19444444444444
95187, 0.5, 1.375, 0.22222222222222
95188, 0.47826086956522, 1.3875, 0.22222222222222
95189, 0.47826086956522, 1.375, 0.25
95190, 0.5, 1.375, 0.27777777777778
95191, 0.47826086956522, 1.3875, 0.27777777777778
95192, 0.47826086956522, 1.375, 0.30555555555556
95193, 0.5, 1.375, 0.33333333333333
95194, 0.47826086956522, 1.3875, 0.33333333333333
95195, 0.47826086956522, 1.375, 0.36111111111111
95196, 0.5, 1.375, 0.38888888888889
95197, 0.47826086956522, 1.3875, 0.38888888888889
95198, 0.47826086956522, 1.375, 0.41666666666667
95199, 0.5, 1.375, 0.44444444444444
95200, 0.47826086956522, 1.3875, 0.44444444444444
95201, 0.47826086956522, 1.375, 0.47222222222222
95202, 0.43478260869565, 1.375, 0.027777777777778
95203, 0.45652173913043, 1.375, 0.055555555555556
95204, 0.43478260869565, 1.3875, 0.055555555555556
95205, 0.43478260869565, 1.375, 0.083333333333333
95206, 0.45652173913043, 1.375, 0.11111111111111
95207, 0.43478260869565, 1.3875, 0.11111111111111
95208, 0.43478260869565, 1.375, 0.13888888888889
95209, 0.45652173913043, 1.375, 0.16666666666667
95210, 0.43478260869565, 1.3875, 0.16666666666667
95211, 0.43478260869565, 1.375, 0.19444444444444
95212, 0.45652173913043, 1.375, 0.22222222222222
95213, 0.43478260869565, 1.3875, 0.22222222222222
95214, 0.43478260869565, 1.375, 0.25
95215, 0.45652173913043, 1.375, 0.27777777777778
95216, 0.43478260869565, 1.3875, 0.27777777777778
95217, 0.43478260869565, 1.375, 0.30555555555556
95218, 0.45652173913043, 1.375, 0.33333333333333
95219, 0.43478260869565, 1.3875, 0.33333333333333
95220, 0.43478260869565, 1.375, 0.36111111111111
95221, 0.45652173913044, 1.375, 0.38888888888889
95222, 0.43478260869565, 1.3875, 0.38888888888889
95223, 0.43478260869565, 1.375, 0.41666666666667
95224, 0.45652173913043, 1.375, 0.44444444444444
95225, 0.43478260869565, 1.3875, 0.44444444444444
95226, 0.43478260869565, 1.375, 0.47222222222222
95227, 0.39130434782609, 1.375, 0.027777777777778
95228, 0.41304347826087, 1.375, 0.055555555555556
95229, 0.39130434782609, 1.3875, 0.055555555555556
95230, 0.39130434782609, 1.375, 0.083333333333333
95231, 0.41304347826087, 1.375, 0.11111111111111
95232, 0.39130434782609, 1.3875, 0.11111111111111
95233, 0.39130434782609, 1.375, 0.13888888888889
95234, 0.41304347826087, 1.375, 0.16666666666667
95235, 0.39130434782609, 1.3875, 0.16666666666667
95236, 0.39130434782609, 1.375, 0.19444444444444
95237, 0.41304347826087, 1.375, 0.22222222222222
95238, 0.39130434782609, 1.3875, 0.22222222222222
95239, 0.39130434782609, 1.375, 0.25
95240, 0.41304347826087, 1.375, 0.27777777777778
95241, 0.39130434782609, 1.3875, 0.27777777777778
95242, 0.39130434782609, 1.375, 0.30555555555556
95243, 0.41304347826087, 1.375, 0.33333333333333
95244, 0.39130434782609, 1.3875, 0.33333333333333
95245, 0.39130434782609, 1.375, 0.36111111111111
95246, 0.41304347826087, 1.375, 0.38888888888889
95247, 0.39130434782609, 1.3875, 0.38888888888889
95248, 0.39130434782609, 1.375, 0.41666666666667
95249, 0.41304347826087, 1.375, 0.44444444444444
95250, 0.39130434782609, 1.3875, 0.44444444444444
95251, 0.39130434782609, 1.375, 0.47222222222222
95252, 0.34782608695652, 1.375, 0.027777777777778
95253, 0.3695652173913, 1.375, 0.055555555555556
95254, 0.34782608695652, 1.3875, 0.055555555555556
95255, 0.34782608695652, 1.375, 0.083333333333333
95256, 0.3695652173913, 1.375, 0.11111111111111
95257, 0.34782608695652, 1.3875, 0.11111111111111
95258, 0.34782608695652, 1.375, 0.13888888888889
95259, 0.3695652173913, 1.375, 0.16666666666667
95260, 0.34782608695652, 1.3875, 0.16666666666667
95261, 0.34782608695652, 1.375, 0.19444444444444
95262, 0.3695652173913, 1.375, 0.22222222222222
95263, 0.34782608695652, 1.3875, 0.22222222222222
95264, 0.34782608695652, 1.375, 0.25
95265, 0.3695652173913, 1.375, 0.27777777777778
95266, 0.34782608695652, 1.3875, 0.27777777777778
95267, 0.34782608695652, 1.375, 0.30555555555556
95268, 0.3695652173913, 1.375, 0.33333333333333
95269, 0.34782608695652, 1.3875, 0.33333333333333
95270, 0.34782608695652, 1.375, 0.36111111111111
95271, 0.3695652173913, 1.375, 0.38888888888889
95272, 0.34782608695652, 1.3875, 0.38888888888889
95273, 0.34782608695652, 1.375, 0.41666666666667
95274, 0.3695652173913, 1.375, 0.44444444444444
95275, 0.34782608695652, 1.3875, 0.44444444444444
95276, 0.34782608695652, 1.375, 0.47222222222222
95277, 0.30434782608696, 1.375, 0.027777777777778
95278, 0.32608695652174, 1.375, 0.055555555555556
95279, 0.30434782608696, 1.3875, 0.055555555555556
95280, 0.30434782608696, 1.375, 0.083333333333333
95281, 0.32608695652174, 1.375, 0.11111111111111
95282, 0.30434782608696, 1.3875, 0.11111111111111
95283, 0.30434782608696, 1.375, 0.13888888888889
95284, 0.32608695652174, 1.375, 0.16666666666667
95285, 0.30434782608696, 1.3875, 0.16666666666667
95286, 0.30434782608696, 1.375, 0.19444444444444
95287, 0.32608695652174, 1.375, 0.22222222222222
95288, 0.30434782608696, 1.3875, 0.22222222222222
95289, 0.30434782608696, 1.375, 0.25
95290, 0.32608695652174, 1.375, 0.27777777777778
95291, 0.30434782608696, 1.3875, 0.27777777777778
95292, 0.30434782608696, 1.375, 0.30555555555556
95293, 0.32608695652174, 1.375, 0.33333333333333
95294, 0.30434782608696, 1.3875, 0.33333333333333
95295, 0.30434782608696, 1.375, 0.36111111111111
95296, 0.32608695652174, 1.375, 0.38888888888889
95297, 0.30434782608696, 1.3875, 0.38888888888889
95298, 0.30434782608696, 1.375, 0.41666666666667
95299, 0.32608695652174, 1.375, 0.44444444444444
95300, 0.30434782608696, 1.3875, 0.44444444444444
95301, 0.30434782608696, 1.375, 0.47222222222222
95302, 0.26086956521739, 1.375, 0.027777777777778
95303, 0.28260869565217, 1.375, 0.055555555555556
95304, 0.26086956521739, 1.3875, 0.055555555555556
95305, 0.26086956521739, 1.375, 0.083333333333333
95306, 0.28260869565217, 1.375, 0.11111111111111
95307, 0.26086956521739, 1.3875, 0.11111111111111
95308, 0.26086956521739, 1.375, 0.13888888888889
95309, 0.28260869565217, 1.375, 0.16666666666667
95310, 0.26086956521739, 1.3875, 0.16666666666667
95311, 0.26086956521739, 1.375, 0.19444444444444
95312, 0.28260869565217, 1.375, 0.22222222222222
95313, 0.26086956521739, 1.3875, 0.22222222222222
95314, 0.26086956521739, 1.375, 0.25
95315, 0.28260869565217, 1.375, 0.27777777777778
95316, 0.26086956521739, 1.3875, 0.27777777777778
95317, 0.26086956521739, 1.375, 0.30555555555556
95318, 0.28260869565217, 1.375, 0.33333333333333
95319, 0.26086956521739, 1.3875, 0.33333333333333
95320, 0.26086956521739, 1.375, 0.36111111111111
95321, 0.28260869565217, 1.375, 0.38888888888889
95322, 0.26086956521739, 1.3875, 0.38888888888889
95323, 0.26086956521739, 1.375, 0.41666666666667
95324, 0.28260869565217, 1.375, 0.44444444444444
95325, 0.26086956521739, 1.3875, 0.44444444444444
95326, 0.26086956521739, 1.375, 0.47222222222222
95327, 0.21739130434783, 1.375, 0.027777777777778
95328, 0.23913043478261, 1.375, 0.055555555555556
95329, 0.21739130434783, 1.3875, 0.055555555555556
95330, 0.21739130434783, 1.375, 0.083333333333333
95331, 0.23913043478261, 1.375, 0.11111111111111
95332, 0.21739130434783, 1.3875, 0.11111111111111
95333, 0.21739130434783, 1.375, 0.13888888888889
95334, 0.23913043478261, 1.375, 0.16666666666667
95335, 0.21739130434783, 1.3875, 0.16666666666667
95336, 0.21739130434783, 1.375, 0.19444444444444
95337, 0.23913043478261, 1.375, 0.22222222222222
95338, 0.21739130434783, 1.3875, 0.22222222222222
95339, 0.21739130434783, 1.375, 0.25
95340, 0.23913043478261, 1.375, 0.27777777777778
95341, 0.21739130434783, 1.3875, 0.27777777777778
95342, 0.21739130434783, 1.375, 0.30555555555556
95343, 0.23913043478261, 1.375, 0.33333333333333
95344, 0.21739130434783, 1.3875, 0.33333333333333
95345, 0.21739130434783, 1.375, 0.36111111111111
95346, 0.23913043478261, 1.375, 0.38888888888889
95347, 0.21739130434783, 1.3875, 0.38888888888889
95348, 0.21739130434783, 1.375, 0.41666666666667
95349, 0.23913043478261, 1.375, 0.44444444444444
95350, 0.21739130434783, 1.3875, 0.44444444444444
95351, 0.21739130434783, 1.375, 0.47222222222222
95352, 0.17391304347826, 1.375, 0.027777777777778
95353, 0.19565217391304, 1.375, 0.055555555555556
95354, 0.17391304347826, 1.3875, 0.055555555555556
95355, 0.17391304347826, 1.375, 0.083333333333333
95356, 0.19565217391304, 1.375, 0.11111111111111
95357, 0.17391304347826, 1.3875, 0.11111111111111
95358, 0.17391304347826, 1.375, 0.13888888888889
95359, 0.19565217391304, 1.375, 0.16666666666667
95360, 0.17391304347826, 1.3875, 0.16666666666667
95361, 0.17391304347826, 1.375, 0.19444444444444
95362, 0.19565217391304, 1.375, 0.22222222222222
95363, 0.17391304347826, 1.3875, 0.22222222222222
95364, 0.17391304347826, 1.375, 0.25
95365, 0.19565217391304, 1.375, 0.27777777777778
95366, 0.17391304347826, 1.3875, 0.27777777777778
95367, 0.17391304347826, 1.375, 0.30555555555556
95368, 0.19565217391304, 1.375, 0.33333333333333
95369, 0.17391304347826, 1.3875, 0.33333333333333
95370, 0.17391304347826, 1.375, 0.36111111111111
95371, 0.19565217391304, 1.375, 0.38888888888889
95372, 0.17391304347826, 1.3875, 0.38888888888889
95373, 0.17391304347826, 1.375, 0.41666666666667
95374, 0.19565217391304, 1.375, 0.44444444444444
95375, 0.17391304347826, 1.3875, 0.44444444444444
95376, 0.17391304347826, 1.375, 0.47222222222222
95377, 0.1304347826087, 1.375, 0.027777777777778
95378, 0.15217391304348, 1.375, 0.055555555555556
95379, 0.1304347826087, 1.3875, 0.055555555555556
95380, 0.1304347826087, 1.375, 0.083333333333333
95381, 0.15217391304348, 1.375, 0.11111111111111
95382, 0.1304347826087, 1.3875, 0.11111111111111
95383, 0.1304347826087, 1.375, 0.13888888888889
95384, 0.15217391304348, 1.375, 0.16666666666667
95385, 0.1304347826087, 1.3875, 0.16666666666667
95386, 0.1304347826087, 1.375, 0.19444444444444
95387, 0.15217391304348, 1.375, 0.22222222222222
95388, 0.1304347826087, 1.3875, 0.22222222222222
95389, 0.1304347826087, 1.375, 0.25
95390, 0.15217391304348, 1.375, 0.27777777777778
95391, 0.1304347826087, 1.3875, 0.27777777777778
95392, 0.1304347826087, 1.375, 0.30555555555556
95393, 0.15217391304348, 1.375, 0.33333333333333
95394, 0.1304347826087, 1.3875, 0.33333333333333
95395, 0.1304347826087, 1.375, 0.36111111111111
95396, 0.15217391304348, 1.375, 0.38888888888889
95397, 0.1304347826087, 1.3875, 0.38888888888889
95398, 0.1304347826087, 1.375, 0.41666666666667
95399, 0.15217391304348, 1.375, 0.44444444444444
95400, 0.1304347826087, 1.3875, 0.44444444444444
95401, 0.1304347826087, 1.375, 0.47222222222222
95402, 0.08695652173913, 1.375, 0.027777777777778
95403, 0.10869565217391, 1.375, 0.055555555555556
95404, 0.08695652173913, 1.3875, 0.055555555555556
95405, 0.08695652173913, 1.375, 0.083333333333333
95406, 0.10869565217391, 1.375, 0.11111111111111
95407, 0.08695652173913, 1.3875, 0.11111111111111
95408, 0.08695652173913, 1.375, 0.13888888888889
95409, 0.10869565217391, 1.375, 0.16666666666667
95410, 0.08695652173913, 1.3875, 0.16666666666667
95411, 0.08695652173913, 1.375, 0.19444444444444
95412, 0.10869565217391, 1.375, 0.22222222222222
95413, 0.08695652173913, 1.3875, 0.22222222222222
95414, 0.08695652173913, 1.375, 0.25
95415, 0.10869565217391, 1.375, 0.27777777777778
95416, 0.08695652173913, 1.3875, 0.27777777777778
95417, 0.08695652173913, 1.375, 0.30555555555556
95418, 0.10869565217391, 1.375, 0.33333333333333
95419, 0.08695652173913, 1.3875, 0.33333333333333
95420, 0.08695652173913, 1.375, 0.36111111111111
95421, 0.10869565217391, 1.375, 0.38888888888889
95422, 0.08695652173913, 1.3875, 0.38888888888889
95423, 0.08695652173913, 1.375, 0.41666666666667
95424, 0.10869565217391, 1.375, 0.44444444444444
95425, 0.08695652173913, 1.3875, 0.44444444444444
95426, 0.08695652173913, 1.375, 0.47222222222222
95427, 0.043478260869565, 1.375, 0.027777777777778
95428, 0.065217391304348, 1.375, 0.055555555555556
95429, 0.043478260869565, 1.3875, 0.055555555555556
95430, 0.043478260869565, 1.375, 0.083333333333333
95431, 0.065217391304348, 1.375, 0.11111111111111
95432, 0.043478260869565, 1.3875, 0.11111111111111
95433, 0.043478260869565, 1.375, 0.13888888888889
95434, 0.065217391304348, 1.375, 0.16666666666667
95435, 0.043478260869565, 1.3875, 0.16666666666667
95436, 0.043478260869565, 1.375, 0.19444444444444
95437, 0.065217391304348, 1.375, 0.22222222222222
95438, 0.043478260869565, 1.3875, 0.22222222222222
95439, 0.043478260869565, 1.375, 0.25
95440, 0.065217391304348, 1.375, 0.27777777777778
95441, 0.043478260869565, 1.3875, 0.27777777777778
95442, 0.043478260869565, 1.375, 0.30555555555556
95443, 0.065217391304348, 1.375, 0.33333333333333
95444, 0.043478260869565, 1.3875, 0.33333333333333
95445, 0.043478260869565, 1.375, 0.36111111111111
95446, 0.065217391304348, 1.375, 0.38888888888889
95447, 0.043478260869565, 1.3875, 0.38888888888889
95448, 0.043478260869565, 1.375, 0.41666666666667
95449, 0.065217391304348, 1.375, 0.44444444444444
95450, 0.043478260869565, 1.3875, 0.44444444444444
95451, 0.043478260869565, 1.375, 0.47222222222222
95452, 0.021739130434783, 1.375, 0.055555555555556
95453, 0.021739130434783, 1.375, 0.11111111111111
95454, 0.021739130434783, 1.375, 0.16666666666667
95455, 0.021739130434783, 1.375, 0.22222222222222
95456, 0.021739130434783, 1.375, 0.27777777777778
95457, 0.021739130434783, 1.375, 0.33333333333333
95458, 0.021739130434783, 1.375, 0.38888888888889
95459, 0.021739130434783, 1.375, 0.44444444444444
95460, 0.95652173913043, 1.3625, 0.055555555555556
95461, 0.95652173913044, 1.3625, 0.11111111111111
95462, 0.95652173913044, 1.3625, 0.16666666666667
95463, 0.95652173913043, 1.3625, 0.22222222222222
95464, 0.95652173913043, 1.3625, 0.27777777777778
95465, 0.95652173913043, 1.3625, 0.33333333333333
95466, 0.95652173913043, 1.3625, 0.38888888888889
95467, 0.95652173913043, 1.3625, 0.44444444444444
95468, 0.91304347826087, 1.3625, 0.055555555555556
95469, 0.91304347826087, 1.3625, 0.11111111111111
95470, 0.91304347826087, 1.3625, 0.16666666666667
95471, 0.91304347826087, 1.3625, 0.22222222222222
95472, 0.91304347826087, 1.3625, 0.27777777777778
95473, 0.91304347826087, 1.3625, 0.33333333333333
95474, 0.91304347826087, 1.3625, 0.38888888888889
95475, 0.91304347826087, 1.3625, 0.44444444444444
95476, 0.8695652173913, 1.3625, 0.055555555555556
95477, 0.8695652173913, 1.3625, 0.11111111111111
95478, 0.8695652173913, 1.3625, 0.16666666666667
95479, 0.8695652173913, 1.3625, 0.22222222222222
95480, 0.8695652173913, 1.3625, 0.27777777777778
95481, 0.8695652173913, 1.3625, 0.33333333333333
95482, 0.8695652173913, 1.3625, 0.38888888888889
95483, 0.8695652173913, 1.3625, 0.44444444444444
95484, 0.82608695652174, 1.3625, 0.055555555555556
95485, 0.82608695652174, 1.3625, 0.11111111111111
95486, 0.82608695652174, 1.3625, 0.16666666666667
95487, 0.82608695652174, 1.3625, 0.22222222222222
95488, 0.82608695652174, 1.3625, 0.27777777777778
95489, 0.82608695652174, 1.3625, 0.33333333333333
95490, 0.82608695652174, 1.3625, 0.38888888888889
95491, 0.82608695652174, 1.3625, 0.44444444444444
95492, 0.78260869565217, 1.3625, 0.055555555555556
95493, 0.78260869565217, 1.3625, 0.11111111111111
95494, 0.78260869565217, 1.3625, 0.16666666666667
95495, 0.78260869565217, 1.3625, 0.22222222222222
95496, 0.78260869565217, 1.3625, 0.27777777777778
95497, 0.78260869565217, 1.3625, 0.33333333333333
95498, 0.78260869565217, 1.3625, 0.38888888888889
95499, 0.78260869565217, 1.3625, 0.44444444444444
95500, 0.73913043478261, 1.3625, 0.055555555555556
95501, 0.73913043478261, 1.3625, 0.11111111111111
95502, 0.73913043478261, 1.3625, 0.16666666666667
95503, 0.73913043478261, 1.3625, 0.22222222222222
95504, 0.73913043478261, 1.3625, 0.27777777777778
95505, 0.73913043478261, 1.3625, 0.33333333333333
95506, 0.73913043478261, 1.3625, 0.38888888888889
95507, 0.73913043478261, 1.3625, 0.44444444444444
95508, 0.69565217391304, 1.3625, 0.055555555555556
95509, 0.69565217391304, 1.3625, 0.11111111111111
95510, 0.69565217391304, 1.3625, 0.16666666666667
95511, 0.69565217391304, 1.3625, 0.22222222222222
95512, 0.69565217391304, 1.3625, 0.27777777777778
95513, 0.69565217391304, 1.3625, 0.33333333333333
95514, 0.69565217391304, 1.3625, 0.38888888888889
95515, 0.69565217391304, 1.3625, 0.44444444444444
95516, 0.65217391304348, 1.3625, 0.055555555555556
95517, 0.65217391304348, 1.3625, 0.11111111111111
95518, 0.65217391304348, 1.3625, 0.16666666666667
95519, 0.65217391304348, 1.3625, 0.22222222222222
95520, 0.65217391304348, 1.3625, 0.27777777777778
95521, 0.65217391304348, 1.3625, 0.33333333333333
95522, 0.65217391304348, 1.3625, 0.38888888888889
95523, 0.65217391304348, 1.3625, 0.44444444444444
95524, 0.60869565217391, 1.3625, 0.055555555555556
95525, 0.60869565217391, 1.3625, 0.11111111111111
95526, 0.60869565217391, 1.3625, 0.16666666666667
95527, 0.60869565217391, 1.3625, 0.22222222222222
95528, 0.60869565217391, 1.3625, 0.27777777777778
95529, 0.60869565217391, 1.3625, 0.33333333333333
95530, 0.60869565217391, 1.3625, 0.38888888888889
95531, 0.60869565217391, 1.3625, 0.44444444444444
95532, 0.56521739130435, 1.3625, 0.055555555555556
95533, 0.56521739130435, 1.3625, 0.11111111111111
95534, 0.56521739130435, 1.3625, 0.16666666666667
95535, 0.56521739130435, 1.3625, 0.22222222222222
95536, 0.56521739130435, 1.3625, 0.27777777777778
95537, 0.56521739130435, 1.3625, 0.33333333333333
95538, 0.56521739130435, 1.3625, 0.38888888888889
95539, 0.56521739130435, 1.3625, 0.44444444444444
95540, 0.52173913043478, 1.3625, 0.055555555555556
95541, 0.52173913043478, 1.3625, 0.11111111111111
95542, 0.52173913043478, 1.3625, 0.16666666666667
95543, 0.52173913043478, 1.3625, 0.22222222222222
95544, 0.52173913043478, 1.3625, 0.27777777777778
95545, 0.52173913043478, 1.3625, 0.33333333333333
95546, 0.52173913043478, 1.3625, 0.38888888888889
95547, 0.52173913043478, 1.3625, 0.44444444444444
95548, 0.47826086956522, 1.3625, 0.055555555555556
95549, 0.47826086956522, 1.3625, 0.11111111111111
95550, 0.47826086956522, 1.3625, 0.16666666666667
95551, 0.47826086956522, 1.3625, 0.22222222222222
95552, 0.47826086956522, 1.3625, 0.27777777777778
95553, 0.47826086956522, 1.3625, 0.33333333333333
95554, 0.47826086956522, 1.3625, 0.38888888888889
95555, 0.47826086956522, 1.3625, 0.44444444444444
95556, 0.43478260869565, 1.3625, 0.055555555555556
95557, 0.43478260869565, 1.3625, 0.11111111111111
95558, 0.43478260869565, 1.3625, 0.16666666666667
95559, 0.43478260869565, 1.3625, 0.22222222222222
95560, 0.43478260869565, 1.3625, 0.27777777777778
95561, 0.43478260869565, 1.3625, 0.33333333333333
95562, 0.43478260869565, 1.3625, 0.38888888888889
95563, 0.43478260869565, 1.3625, 0.44444444444444
95564, 0.39130434782609, 1.3625, 0.055555555555556
95565, 0.39130434782609, 1.3625, 0.11111111111111
95566, 0.39130434782609, 1.3625, 0.16666666666667
95567, 0.39130434782609, 1.3625, 0.22222222222222
95568, 0.39130434782609, 1.3625, 0.27777777777778
95569, 0.39130434782609, 1.3625, 0.33333333333333
95570, 0.39130434782609, 1.3625, 0.38888888888889
95571, 0.39130434782609, 1.3625, 0.44444444444444
95572, 0.34782608695652, 1.3625, 0.055555555555556
95573, 0.34782608695652, 1.3625, 0.11111111111111
95574, 0.34782608695652, 1.3625, 0.16666666666667
95575, 0.34782608695652, 1.3625, 0.22222222222222
95576, 0.34782608695652, 1.3625, 0.27777777777778
95577, 0.34782608695652, 1.3625, 0.33333333333333
95578, 0.34782608695652, 1.3625, 0.38888888888889
95579, 0.34782608695652, 1.3625, 0.44444444444444
95580, 0.30434782608696, 1.3625, 0.055555555555556
95581, 0.30434782608696, 1.3625, 0.11111111111111
95582, 0.30434782608696, 1.3625, 0.16666666666667
95583, 0.30434782608696, 1.3625, 0.22222222222222
95584, 0.30434782608696, 1.3625, 0.27777777777778
95585, 0.30434782608696, 1.3625, 0.33333333333333
95586, 0.30434782608696, 1.3625, 0.38888888888889
95587, 0.30434782608696, 1.3625, 0.44444444444444
95588, 0.26086956521739, 1.3625, 0.055555555555556
95589, 0.26086956521739, 1.3625, 0.11111111111111
95590, 0.26086956521739, 1.3625, 0.16666666666667
95591, 0.26086956521739, 1.3625, 0.22222222222222
95592, 0.26086956521739, 1.3625, 0.27777777777778
95593, 0.26086956521739, 1.3625, 0.33333333333333
95594, 0.26086956521739, 1.3625, 0.38888888888889
95595, 0.26086956521739, 1.3625, 0.44444444444444
95596, 0.21739130434783, 1.3625, 0.055555555555556
95597, 0.21739130434783, 1.3625, 0.11111111111111
95598, 0.21739130434783, 1.3625, 0.16666666666667
95599, 0.21739130434783, 1.3625, 0.22222222222222
95600, 0.21739130434783, 1.3625, 0.27777777777778
95601, 0.21739130434783, 1.3625, 0.33333333333333
95602, 0.21739130434783, 1.3625, 0.38888888888889
95603, 0.21739130434783, 1.3625, 0.44444444444444
95604, 0.17391304347826, 1.3625, 0.055555555555556
95605, 0.17391304347826, 1.3625, 0.11111111111111
95606, 0.17391304347826, 1.3625, 0.16666666666667
95607, 0.17391304347826, 1.3625, 0.22222222222222
95608, 0.17391304347826, 1.3625, 0.27777777777778
95609, 0.17391304347826, 1.3625, 0.33333333333333
95610, 0.17391304347826, 1.3625, 0.38888888888889
95611, 0.17391304347826, 1.3625, 0.44444444444444
95612, 0.1304347826087, 1.3625, 0.055555555555556
95613, 0.1304347826087, 1.3625, 0.11111111111111
95614, 0.1304347826087, 1.3625, 0.16666666666667
95615, 0.1304347826087, 1.3625, 0.22222222222222
95616, 0.1304347826087, 1.3625, 0.27777777777778
95617, 0.1304347826087, 1.3625, 0.33333333333333
95618, 0.1304347826087, 1.3625, 0.38888888888889
95619, 0.1304347826087, 1.3625, 0.44444444444444
95620, 0.08695652173913, 1.3625, 0.055555555555556
95621, 0.08695652173913, 1.3625, 0.11111111111111
95622, 0.08695652173913, 1.3625, 0.16666666666667
95623, 0.08695652173913, 1.3625, 0.22222222222222
95624, 0.08695652173913, 1.3625, 0.27777777777778
95625, 0.08695652173913, 1.3625, 0.33333333333333
95626, 0.08695652173913, 1.3625, 0.38888888888889
95627, 0.08695652173913, 1.3625, 0.44444444444444
95628, 0.043478260869565, 1.3625, 0.055555555555556
95629, 0.043478260869565, 1.3625, 0.11111111111111
95630, 0.043478260869565, 1.3625, 0.16666666666667
95631, 0.043478260869565, 1.3625, 0.22222222222222
95632, 0.043478260869565, 1.3625, 0.27777777777778
95633, 0.043478260869565, 1.3625, 0.33333333333333
95634, 0.043478260869565, 1.3625, 0.38888888888889
95635, 0.043478260869565, 1.3625, 0.44444444444444
95636, 1.2434782608696, 1.375, 0.44444444444444
95637, 1.2434782608696, 1.375, 0.38888888888889
95638, 1.2434782608696, 1.375, 0.33333333333333
95639, 1.2434782608696, 1.375, 0.27777777777778
95640, 1.2434782608696, 1.375, 0.22222222222222
95641, 1.2434782608696, 1.375, 0.16666666666667
95642, 1.2434782608696, 1.375, 0.11111111111111
95643, 1.2434782608696, 1.375, 0.055555555555556
95644, 1.2869565217391, 1.375, 0.44444444444444
95645, 1.2869565217391, 1.375, 0.38888888888889
95646, 1.2869565217391, 1.375, 0.33333333333333
95647, 1.2869565217391, 1.375, 0.27777777777778
95648, 1.2869565217391, 1.375, 0.22222222222222
95649, 1.2869565217391, 1.375, 0.16666666666667
95650, 1.2869565217391, 1.375, 0.11111111111111
95651, 1.2869565217391, 1.375, 0.055555555555556
95652, 1.3304347826087, 1.375, 0.44444444444444
95653, 1.3304347826087, 1.375, 0.38888888888889
95654, 1.3304347826087, 1.375, 0.33333333333333
95655, 1.3304347826087, 1.375, 0.27777777777778
95656, 1.3304347826087, 1.375, 0.22222222222222
95657, 1.3304347826087, 1.375, 0.16666666666667
95658, 1.3304347826087, 1.375, 0.11111111111111
95659, 1.3304347826087, 1.375, 0.055555555555556
95660, 1.3739130434783, 1.375, 0.44444444444444
95661, 1.3739130434783, 1.375, 0.38888888888889
95662, 1.3739130434783, 1.375, 0.33333333333333
95663, 1.3739130434783, 1.375, 0.27777777777778
95664, 1.3739130434783, 1.375, 0.22222222222222
95665, 1.3739130434783, 1.375, 0.16666666666667
95666, 1.3739130434783, 1.375, 0.11111111111111
95667, 1.3739130434783, 1.375, 0.055555555555556
95668, 1.4173913043478, 1.375, 0.44444444444444
95669, 1.4173913043478, 1.375, 0.38888888888889
95670, 1.4173913043478, 1.375, 0.33333333333333
95671, 1.4173913043478, 1.375, 0.27777777777778
95672, 1.4173913043478, 1.375, 0.22222222222222
95673, 1.4173913043478, 1.375, 0.16666666666667
95674, 1.4173913043478, 1.375, 0.11111111111111
95675, 1.4173913043478, 1.375, 0.055555555555556
95676, 1.4608695652174, 1.375, 0.44444444444444
95677, 1.4608695652174, 1.375, 0.38888888888889
95678, 1.4608695652174, 1.375, 0.33333333333333
95679, 1.4608695652174, 1.375, 0.27777777777778
95680, 1.4608695652174, 1.375, 0.22222222222222
95681, 1.4608695652174, 1.375, 0.16666666666667
95682, 1.4608695652174, 1.375, 0.11111111111111
95683, 1.4608695652174, 1.375, 0.055555555555556
95684, 1.504347826087, 1.375, 0.44444444444444
95685, 1.504347826087, 1.375, 0.38888888888889
95686, 1.504347826087, 1.375, 0.33333333333333
95687, 1.504347826087, 1.375, 0.27777777777778
95688, 1.504347826087, 1.375, 0.22222222222222
95689, 1.504347826087, 1.375, 0.16666666666667
95690, 1.504347826087, 1.375, 0.11111111111111
95691, 1.504347826087, 1.375, 0.055555555555556
95692, 1.5478260869565, 1.375, 0.44444444444444
95693, 1.5478260869565, 1.375, 0.38888888888889
95694, 1.5478260869565, 1.375, 0.33333333333333
95695, 1.5478260869565, 1.375, 0.27777777777778
95696, 1.5478260869565, 1.375, 0.22222222222222
95697, 1.5478260869565, 1.375, 0.16666666666667
95698, 1.5478260869565, 1.375, 0.11111111111111
95699, 1.5478260869565, 1.375, 0.055555555555556
95700, 1.5913043478261, 1.375, 0.44444444444444
95701, 1.5913043478261, 1.375, 0.38888888888889
95702, 1.5913043478261, 1.375, 0.33333333333333
95703, 1.5913043478261, 1.375, 0.27777777777778
95704, 1.5913043478261, 1.375, 0.22222222222222
95705, 1.5913043478261, 1.375, 0.16666666666667
95706, 1.5913043478261, 1.375, 0.11111111111111
95707, 1.5913043478261, 1.375, 0.055555555555556
95708, 1.6347826086957, 1.375, 0.44444444444444
95709, 1.6347826086957, 1.375, 0.38888888888889
95710, 1.6347826086957, 1.375, 0.33333333333333
95711, 1.6347826086957, 1.375, 0.27777777777778
95712, 1.6347826086957, 1.375, 0.22222222222222
95713, 1.6347826086957, 1.375, 0.16666666666667
95714, 1.6347826086957, 1.375, 0.11111111111111
95715, 1.6347826086957, 1.375, 0.055555555555556
95716, 1.6782608695652, 1.375, 0.44444444444444
95717, 1.6782608695652, 1.375, 0.38888888888889
95718, 1.6782608695652, 1.375, 0.33333333333333
95719, 1.6782608695652, 1.375, 0.27777777777778
95720, 1.6782608695652, 1.375, 0.22222222222222
95721, 1.6782608695652, 1.375, 0.16666666666667
95722, 1.6782608695652, 1.375, 0.11111111111111
95723, 1.6782608695652, 1.375, 0.055555555555556
95724, 1.7217391304348, 1.375, 0.44444444444444
95725, 1.7217391304348, 1.375, 0.38888888888889
95726, 1.7217391304348, 1.375, 0.33333333333333
95727, 1.7217391304348, 1.375, 0.27777777777778
95728, 1.7217391304348, 1.375, 0.22222222222222
95729, 1.7217391304348, 1.375, 0.16666666666667
95730, 1.7217391304348, 1.375, 0.11111111111111
95731, 1.7217391304348, 1.375, 0.055555555555556
95732, 1.7652173913043, 1.375, 0.44444444444444
95733, 1.7652173913043, 1.375, 0.38888888888889
95734, 1.7652173913043, 1.375, 0.33333333333333
95735, 1.7652173913043, 1.375, 0.27777777777778
95736, 1.7652173913043, 1.375, 0.22222222222222
95737, 1.7652173913043, 1.375, 0.16666666666667
95738, 1.7652173913043, 1.375, 0.11111111111111
95739, 1.7652173913043, 1.375, 0.055555555555556
95740, 1.8086956521739, 1.375, 0.44444444444444
95741, 1.8086956521739, 1.375, 0.38888888888889
95742, 1.8086956521739, 1.375, 0.33333333333333
95743, 1.8086956521739, 1.375, 0.27777777777778
95744, 1.8086956521739, 1.375, 0.22222222222222
95745, 1.8086956521739, 1.375, 0.16666666666667
95746, 1.8086956521739, 1.375, 0.11111111111111
95747, 1.8086956521739, 1.375, 0.055555555555556
95748, 1.8521739130435, 1.375, 0.44444444444444
95749, 1.8521739130435, 1.375, 0.38888888888889
95750, 1.8521739130435, 1.375, 0.33333333333333
95751, 1.8521739130435, 1.375, 0.27777777777778
95752, 1.8521739130435, 1.375, 0.22222222222222
95753, 1.8521739130435, 1.375, 0.16666666666667
95754, 1.8521739130435, 1.375, 0.11111111111111
95755, 1.8521739130435, 1.375, 0.055555555555556
95756, 1.895652173913, 1.375, 0.44444444444444
95757, 1.895652173913, 1.375, 0.38888888888889
95758, 1.895652173913, 1.375, 0.33333333333333
95759, 1.895652173913, 1.375, 0.27777777777778
95760, 1.895652173913, 1.375, 0.22222222222222
95761, 1.895652173913, 1.375, 0.16666666666667
95762, 1.895652173913, 1.375, 0.11111111111111
95763, 1.895652173913, 1.375, 0.055555555555556
95764, 1.9391304347826, 1.375, 0.44444444444444
95765, 1.9391304347826, 1.375, 0.38888888888889
95766, 1.9391304347826, 1.375, 0.33333333333333
95767, 1.9391304347826, 1.375, 0.27777777777778
95768, 1.9391304347826, 1.375, 0.22222222222222
95769, 1.9391304347826, 1.375, 0.16666666666667
95770, 1.9391304347826, 1.375, 0.11111111111111
95771, 1.9391304347826, 1.375, 0.055555555555556
95772, 1.9826086956522, 1.375, 0.44444444444444
95773, 1.9826086956522, 1.375, 0.38888888888889
95774, 1.9826086956522, 1.375, 0.33333333333333
95775, 1.9826086956522, 1.375, 0.27777777777778
95776, 1.9826086956522, 1.375, 0.22222222222222
95777, 1.9826086956522, 1.375, 0.16666666666667
95778, 1.9826086956522, 1.375, 0.11111111111111
95779, 1.9826086956522, 1.375, 0.055555555555556
95780, 2.0260869565217, 1.375, 0.44444444444444
95781, 2.0260869565217, 1.375, 0.38888888888889
95782, 2.0260869565217, 1.375, 0.33333333333333
95783, 2.0260869565217, 1.375, 0.27777777777778
95784, 2.0260869565217, 1.375, 0.22222222222222
95785, 2.0260869565217, 1.375, 0.16666666666667
95786, 2.0260869565217, 1.375, 0.11111111111111
95787, 2.0260869565217, 1.375, 0.055555555555556
95788, 2.0695652173913, 1.375, 0.44444444444444
95789, 2.0695652173913, 1.375, 0.38888888888889
95790, 2.0695652173913, 1.375, 0.33333333333333
95791, 2.0695652173913, 1.375, 0.27777777777778
95792, 2.0695652173913, 1.375, 0.22222222222222
95793, 2.0695652173913, 1.375, 0.16666666666667
95794, 2.0695652173913, 1.375, 0.11111111111111
95795, 2.0695652173913, 1.375, 0.055555555555556
95796, 2.1130434782609, 1.375, 0.44444444444444
95797, 2.1130434782609, 1.375, 0.38888888888889
95798, 2.1130434782609, 1.375, 0.33333333333333
95799, 2.1130434782609, 1.375, 0.27777777777778
95800, 2.1130434782609, 1.375, 0.22222222222222
95801, 2.1130434782609, 1.375, 0.16666666666667
95802, 2.1130434782609, 1.375, 0.11111111111111
95803, 2.1130434782609, 1.375, 0.055555555555556
95804, 2.1565217391304, 1.375, 0.44444444444444
95805, 2.1565217391304, 1.375, 0.38888888888889
95806, 2.1565217391304, 1.375, 0.33333333333333
95807, 2.1565217391304, 1.375, 0.27777777777778
95808, 2.1565217391304, 1.375, 0.22222222222222
95809, 2.1565217391304, 1.375, 0.16666666666667
95810, 2.1565217391304, 1.375, 0.11111111111111
95811, 2.1565217391304, 1.375, 0.055555555555556
95812, 1.2434782608696, 1.375, 0.47222222222222
95813, 1.2217391304348, 1.375, 0.44444444444444
95814, 1.2434782608696, 1.3875, 0.44444444444444
95815, 1.2434782608696, 1.375, 0.41666666666667
95816, 1.2217391304348, 1.375, 0.38888888888889
95817, 1.2434782608696, 1.3875, 0.38888888888889
95818, 1.2434782608696, 1.375, 0.36111111111111
95819, 1.2217391304348, 1.375, 0.33333333333333
95820, 1.2434782608696, 1.3875, 0.33333333333333
95821, 1.2434782608696, 1.375, 0.30555555555556
95822, 1.2217391304348, 1.375, 0.27777777777778
95823, 1.2434782608696, 1.3875, 0.27777777777778
95824, 1.2434782608696, 1.375, 0.25
95825, 1.2217391304348, 1.375, 0.22222222222222
95826, 1.2434782608696, 1.3875, 0.22222222222222
95827, 1.2434782608696, 1.375, 0.19444444444444
95828, 1.2217391304348, 1.375, 0.16666666666667
95829, 1.2434782608696, 1.3875, 0.16666666666667
95830, 1.2434782608696, 1.375, 0.13888888888889
95831, 1.2217391304348, 1.375, 0.11111111111111
95832, 1.2434782608696, 1.3875, 0.11111111111111
95833, 1.2434782608696, 1.375, 0.083333333333333
95834, 1.2217391304348, 1.375, 0.055555555555556
95835, 1.2434782608696, 1.3875, 0.055555555555556
95836, 1.2434782608696, 1.375, 0.027777777777778
95837, 1.2869565217391, 1.375, 0.47222222222222
95838, 1.2652173913043, 1.375, 0.44444444444444
95839, 1.2869565217391, 1.3875, 0.44444444444444
95840, 1.2869565217391, 1.375, 0.41666666666667
95841, 1.2652173913043, 1.375, 0.38888888888889
95842, 1.2869565217391, 1.3875, 0.38888888888889
95843, 1.2869565217391, 1.375, 0.36111111111111
95844, 1.2652173913043, 1.375, 0.33333333333333
95845, 1.2869565217391, 1.3875, 0.33333333333333
95846, 1.2869565217391, 1.375, 0.30555555555556
95847, 1.2652173913043, 1.375, 0.27777777777778
95848, 1.2869565217391, 1.3875, 0.27777777777778
95849, 1.2869565217391, 1.375, 0.25
95850, 1.2652173913043, 1.375, 0.22222222222222
95851, 1.2869565217391, 1.3875, 0.22222222222222
95852, 1.2869565217391, 1.375, 0.19444444444444
95853, 1.2652173913043, 1.375, 0.16666666666667
95854, 1.2869565217391, 1.3875, 0.16666666666667
95855, 1.2869565217391, 1.375, 0.13888888888889
95856, 1.2652173913043, 1.375, 0.11111111111111
95857, 1.2869565217391, 1.3875, 0.11111111111111
95858, 1.2869565217391, 1.375, 0.083333333333333
95859, 1.2652173913043, 1.375, 0.055555555555556
95860, 1.2869565217391, 1.3875, 0.055555555555556
95861, 1.2869565217391, 1.375, 0.027777777777778
95862, 1.3304347826087, 1.375, 0.47222222222222
95863, 1.3086956521739, 1.375, 0.44444444444444
95864, 1.3304347826087, 1.3875, 0.44444444444444
95865, 1.3304347826087, 1.375, 0.41666666666667
95866, 1.3086956521739, 1.375, 0.38888888888889
95867, 1.3304347826087, 1.3875, 0.38888888888889
95868, 1.3304347826087, 1.375, 0.36111111111111
95869, 1.3086956521739, 1.375, 0.33333333333333
95870, 1.3304347826087, 1.3875, 0.33333333333333
95871, 1.3304347826087, 1.375, 0.30555555555556
95872, 1.3086956521739, 1.375, 0.27777777777778
95873, 1.3304347826087, 1.3875, 0.27777777777778
95874, 1.3304347826087, 1.375, 0.25
95875, 1.3086956521739, 1.375, 0.22222222222222
95876, 1.3304347826087, 1.3875, 0.22222222222222
95877, 1.3304347826087, 1.375, 0.19444444444444
95878, 1.3086956521739, 1.375, 0.16666666666667
95879, 1.3304347826087, 1.3875, 0.16666666666667
95880, 1.3304347826087, 1.375, 0.13888888888889
95881, 1.3086956521739, 1.375, 0.11111111111111
95882, 1.3304347826087, 1.3875, 0.11111111111111
95883, 1.3304347826087, 1.375, 0.083333333333333
95884, 1.3086956521739, 1.375, 0.055555555555556
95885, 1.3304347826087, 1.3875, 0.055555555555556
95886, 1.3304347826087, 1.375, 0.027777777777778
95887, 1.3739130434783, 1.375, 0.47222222222222
95888, 1.3521739130435, 1.375, 0.44444444444444
95889, 1.3739130434783, 1.3875, 0.44444444444444
95890, 1.3739130434783, 1.375, 0.41666666666667
95891, 1.3521739130435, 1.375, 0.38888888888889
95892, 1.3739130434783, 1.3875, 0.38888888888889
95893, 1.3739130434783, 1.375, 0.36111111111111
95894, 1.3521739130435, 1.375, 0.33333333333333
95895, 1.3739130434783, 1.3875, 0.33333333333333
95896, 1.3739130434783, 1.375, 0.30555555555556
95897, 1.3521739130435, 1.375, 0.27777777777778
95898, 1.3739130434783, 1.3875, 0.27777777777778
95899, 1.3739130434783, 1.375, 0.25
95900, 1.3521739130435, 1.375, 0.22222222222222
95901, 1.3739130434783, 1.3875, 0.22222222222222
95902, 1.3739130434783, 1.375, 0.19444444444444
95903, 1.3521739130435, 1.375, 0.16666666666667
95904, 1.3739130434783, 1.3875, 0.16666666666667
95905, 1.3739130434783, 1.375, 0.13888888888889
95906, 1.3521739130435, 1.375, 0.11111111111111
95907, 1.3739130434783, 1.3875, 0.11111111111111
95908, 1.3739130434783, 1.375, 0.083333333333333
95909, 1.3521739130435, 1.375, 0.055555555555556
95910, 1.3739130434783, 1.3875, 0.055555555555556
95911, 1.3739130434783, 1.375, 0.027777777777778
95912, 1.4173913043478, 1.375, 0.47222222222222
95913, 1.395652173913, 1.375, 0.44444444444444
95914, 1.4173913043478, 1.3875, 0.44444444444444
95915, 1.4173913043478, 1.375, 0.41666666666667
95916, 1.395652173913, 1.375, 0.38888888888889
95917, 1.4173913043478, 1.3875, 0.38888888888889
95918, 1.4173913043478, 1.375, 0.36111111111111
95919, 1.395652173913, 1.375, 0.33333333333333
95920, 1.4173913043478, 1.3875, 0.33333333333333
95921, 1.4173913043478, 1.375, 0.30555555555556
95922, 1.395652173913, 1.375, 0.27777777777778
95923, 1.4173913043478, 1.3875, 0.27777777777778
95924, 1.4173913043478, 1.375, 0.25
95925, 1.395652173913, 1.375, 0.22222222222222
95926, 1.4173913043478, 1.3875, 0.22222222222222
95927, 1.4173913043478, 1.375, 0.19444444444444
95928, 1.395652173913, 1.375, 0.16666666666667
95929, 1.4173913043478, 1.3875, 0.16666666666667
95930, 1.4173913043478, 1.375, 0.13888888888889
95931, 1.395652173913, 1.375, 0.11111111111111
95932, 1.4173913043478, 1.3875, 0.11111111111111
95933, 1.4173913043478, 1.375, 0.083333333333333
95934, 1.395652173913, 1.375, 0.055555555555556
95935, 1.4173913043478, 1.3875, 0.055555555555556
95936, 1.4173913043478, 1.375, 0.027777777777778
95937, 1.4608695652174, 1.375, 0.47222222222222
95938, 1.4391304347826, 1.375, 0.44444444444444
95939, 1.4608695652174, 1.3875, 0.44444444444444
95940, 1.4608695652174, 1.375, 0.41666666666667
95941, 1.4391304347826, 1.375, 0.38888888888889
95942, 1.4608695652174, 1.3875, 0.38888888888889
95943, 1.4608695652174, 1.375, 0.36111111111111
95944, 1.4391304347826, 1.375, 0.33333333333333
95945, 1.4608695652174, 1.3875, 0.33333333333333
95946, 1.4608695652174, 1.375, 0.30555555555556
95947, 1.4391304347826, 1.375, 0.27777777777778
95948, 1.4608695652174, 1.3875, 0.27777777777778
95949, 1.4608695652174, 1.375, 0.25
95950, 1.4391304347826, 1.375, 0.22222222222222
95951, 1.4608695652174, 1.3875, 0.22222222222222
95952, 1.4608695652174, 1.375, 0.19444444444444
95953, 1.4391304347826, 1.375, 0.16666666666667
95954, 1.4608695652174, 1.3875, 0.16666666666667
95955, 1.4608695652174, 1.375, 0.13888888888889
95956, 1.4391304347826, 1.375, 0.11111111111111
95957, 1.4608695652174, 1.3875, 0.11111111111111
95958, 1.4608695652174, 1.375, 0.083333333333333
95959, 1.4391304347826, 1.375, 0.055555555555556
95960, 1.4608695652174, 1.3875, 0.055555555555556
95961, 1.4608695652174, 1.375, 0.027777777777778
95962, 1.504347826087, 1.375, 0.47222222222222
95963, 1.4826086956522, 1.375, 0.44444444444444
95964, 1.504347826087, 1.3875, 0.44444444444444
95965, 1.504347826087, 1.375, 0.41666666666667
95966, 1.4826086956522, 1.375, 0.38888888888889
95967, 1.504347826087, 1.3875, 0.38888888888889
95968, 1.504347826087, 1.375, 0.36111111111111
95969, 1.4826086956522, 1.375, 0.33333333333333
95970, 1.504347826087, 1.3875, 0.33333333333333
95971, 1.504347826087, 1.375, 0.30555555555556
95972, 1.4826086956522, 1.375, 0.27777777777778
95973, 1.504347826087, 1.3875, 0.27777777777778
95974, 1.504347826087, 1.375, 0.25
95975, 1.4826086956522, 1.375, 0.22222222222222
95976, 1.504347826087, 1.3875, 0.22222222222222
95977, 1.504347826087, 1.375, 0.19444444444444
95978, 1.4826086956522, 1.375, 0.16666666666667
95979, 1.504347826087, 1.3875, 0.16666666666667
95980, 1.504347826087, 1.375, 0.13888888888889
95981, 1.4826086956522, 1.375, 0.11111111111111
95982, 1.504347826087, 1.3875, 0.11111111111111
95983, 1.504347826087, 1.375, 0.083333333333333
95984, 1.4826086956522, 1.375, 0.055555555555556
95985, 1.504347826087, 1.3875, 0.055555555555556
95986, 1.504347826087, 1.375, 0.027777777777778
95987, 1.5478260869565, 1.375, 0.47222222222222
95988, 1.5260869565217, 1.375, 0.44444444444444
95989, 1.5478260869565, 1.3875, 0.44444444444444
95990, 1.5478260869565, 1.375, 0.41666666666667
95991, 1.5260869565217, 1.375, 0.38888888888889
95992, 1.5478260869565, 1.3875, 0.38888888888889
95993, 1.5478260869565, 1.375, 0.36111111111111
95994, 1.5260869565217, 1.375, 0.33333333333333
95995, 1.5478260869565, 1.3875, 0.33333333333333
95996, 1.5478260869565, 1.375, 0.30555555555556
95997, 1.5260869565217, 1.375, 0.27777777777778
95998, 1.5478260869565, 1.3875, 0.27777777777778
95999, 1.5478260869565, 1.375, 0.25
96000, 1.5260869565217, 1.375, 0.22222222222222
96001, 1.5478260869565, 1.3875, 0.22222222222222
96002, 1.5478260869565, 1.375, 0.19444444444444
96003, 1.5260869565217, 1.375, 0.16666666666667
96004, 1.5478260869565, 1.3875, 0.16666666666667
96005, 1.5478260869565, 1.375, 0.13888888888889
96006, 1.5260869565217, 1.375, 0.11111111111111
96007, 1.5478260869565, 1.3875, 0.11111111111111
96008, 1.5478260869565, 1.375, 0.083333333333333
96009, 1.5260869565217, 1.375, 0.055555555555556
96010, 1.5478260869565, 1.3875, 0.055555555555556
96011, 1.5478260869565, 1.375, 0.027777777777778
96012, 1.5913043478261, 1.375, 0.47222222222222
96013, 1.5695652173913, 1.375, 0.44444444444444
96014, 1.5913043478261, 1.3875, 0.44444444444444
96015, 1.5913043478261, 1.375, 0.41666666666667
96016, 1.5695652173913, 1.375, 0.38888888888889
96017, 1.5913043478261, 1.3875, 0.38888888888889
96018, 1.5913043478261, 1.375, 0.36111111111111
96019, 1.5695652173913, 1.375, 0.33333333333333
96020, 1.5913043478261, 1.3875, 0.33333333333333
96021, 1.5913043478261, 1.375, 0.30555555555556
96022, 1.5695652173913, 1.375, 0.27777777777778
96023, 1.5913043478261, 1.3875, 0.27777777777778
96024, 1.5913043478261, 1.375, 0.25
96025, 1.5695652173913, 1.375, 0.22222222222222
96026, 1.5913043478261, 1.3875, 0.22222222222222
96027, 1.5913043478261, 1.375, 0.19444444444444
96028, 1.5695652173913, 1.375, 0.16666666666667
96029, 1.5913043478261, 1.3875, 0.16666666666667
96030, 1.5913043478261, 1.375, 0.13888888888889
96031, 1.5695652173913, 1.375, 0.11111111111111
96032, 1.5913043478261, 1.3875, 0.11111111111111
96033, 1.5913043478261, 1.375, 0.083333333333333
96034, 1.5695652173913, 1.375, 0.055555555555556
96035, 1.5913043478261, 1.3875, 0.055555555555556
96036, 1.5913043478261, 1.375, 0.027777777777778
96037, 1.6347826086957, 1.375, 0.47222222222222
96038, 1.6130434782609, 1.375, 0.44444444444444
96039, 1.6347826086957, 1.3875, 0.44444444444444
96040, 1.6347826086957, 1.375, 0.41666666666667
96041, 1.6130434782609, 1.375, 0.38888888888889
96042, 1.6347826086957, 1.3875, 0.38888888888889
96043, 1.6347826086957, 1.375, 0.36111111111111
96044, 1.6130434782609, 1.375, 0.33333333333333
96045, 1.6347826086957, 1.3875, 0.33333333333333
96046, 1.6347826086957, 1.375, 0.30555555555556
96047, 1.6130434782609, 1.375, 0.27777777777778
96048, 1.6347826086957, 1.3875, 0.27777777777778
