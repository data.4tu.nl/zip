94573, 32177, 32160, 94038, 94063
34552, 31975, 31967, 93831, 93839, 3796, 3795, 31798, 31799, 32176, 94565, 94064, 94573, 3818, 31865, 31824, 
31866, 32178, 32161, 94041, 94066
34553, 3746, 3745, 31710, 31711, 31976, 31968, 93832, 93840, 3768, 31777, 31736, 31778, 32179, 94566, 94068, 
94574, 32180, 32163, 94042, 94067
34554, 31976, 31968, 93832, 93840, 31977, 31969, 93833, 93841, 32179, 94566, 94068, 94574, 32181, 94567, 94071, 
94575, 32182, 32165, 94045, 94070
34555, 31977, 31969, 93833, 93841, 31978, 31970, 93834, 93842, 32181, 94567, 94071, 94575, 32183, 94568, 94074, 
94576, 32184, 32167, 94048, 94073
34556, 31978, 31970, 93834, 93842, 31979, 31971, 93835, 93843, 32183, 94568, 94074, 94576, 32185, 94569, 94077, 
94577, 32186, 32169, 94051, 94076
34557, 31979, 31971, 93835, 93843, 31980, 31972, 93836, 93844, 32185, 94569, 94077, 94577, 32187, 94570, 94080, 
94578, 32188, 32171, 94054, 94079
34558, 31980, 31972, 93836, 93844, 31981, 31973, 93837, 93845, 32187, 94570, 94080, 94578, 32189, 94571, 94083, 
94579, 32190, 32173, 94057, 94082
34559, 31981, 31973, 93837, 93845, 31982, 31974, 93838, 93846, 32189, 94571, 94083, 94579, 32191, 94572, 94086, 
94580, 32192, 32175, 94060, 94085
34560, 31982, 31974, 93838, 93846, 31983, 31975, 93839, 93847, 32191, 94572, 94086, 94580, 32193, 94573, 94089, 
94581, 32194, 32177, 94063, 94088
34561, 31983, 31975, 93839, 93847, 3797, 3796, 31799, 31800, 32193, 94573, 94089, 94581, 3819, 31866, 31826, 
31867, 32195, 32178, 94066, 94091
34562, 3747, 3746, 31711, 31712, 31984, 31976, 93840, 93848, 3769, 31778, 31738, 31779, 32196, 94574, 94093, 
94582, 32197, 32180, 94067, 94092
34563, 31984, 31976, 93840, 93848, 31985, 31977, 93841, 93849, 32196, 94574, 94093, 94582, 32198, 94575, 94096, 
94583, 32199, 32182, 94070, 94095
34564, 31985, 31977, 93841, 93849, 31986, 31978, 93842, 93850, 32198, 94575, 94096, 94583, 32200, 94576, 94099, 
94584, 32201, 32184, 94073, 94098
34565, 31986, 31978, 93842, 93850, 31987, 31979, 93843, 93851, 32200, 94576, 94099, 94584, 32202, 94577, 94102, 
94585, 32203, 32186, 94076, 94101
34566, 31987, 31979, 93843, 93851, 31988, 31980, 93844, 93852, 32202, 94577, 94102, 94585, 32204, 94578, 94105, 
94586, 32205, 32188, 94079, 94104
34567, 31988, 31980, 93844, 93852, 31989, 31981, 93845, 93853, 32204, 94578, 94105, 94586, 32206, 94579, 94108, 
94587, 32207, 32190, 94082, 94107
34568, 31989, 31981, 93845, 93853, 31990, 31982, 93846, 93854, 32206, 94579, 94108, 94587, 32208, 94580, 94111, 
94588, 32209, 32192, 94085, 94110
34569, 31990, 31982, 93846, 93854, 31991, 31983, 93847, 93855, 32208, 94580, 94111, 94588, 32210, 94581, 94114, 
94589, 32211, 32194, 94088, 94113
34570, 31991, 31983, 93847, 93855, 3798, 3797, 31800, 31801, 32210, 94581, 94114, 94589, 3820, 31867, 31828, 
31868, 32212, 32195, 94091, 94116
34571, 3748, 3747, 31712, 31713, 31992, 31984, 93848, 93856, 3770, 31779, 31740, 31780, 32213, 94582, 94118, 
94590, 32214, 32197, 94092, 94117
34572, 31992, 31984, 93848, 93856, 31993, 31985, 93849, 93857, 32213, 94582, 94118, 94590, 32215, 94583, 94121, 
94591, 32216, 32199, 94095, 94120
34573, 31993, 31985, 93849, 93857, 31994, 31986, 93850, 93858, 32215, 94583, 94121, 94591, 32217, 94584, 94124, 
94592, 32218, 32201, 94098, 94123
34574, 31994, 31986, 93850, 93858, 31995, 31987, 93851, 93859, 32217, 94584, 94124, 94592, 32219, 94585, 94127, 
94593, 32220, 32203, 94101, 94126
34575, 31995, 31987, 93851, 93859, 31996, 31988, 93852, 93860, 32219, 94585, 94127, 94593, 32221, 94586, 94130, 
94594, 32222, 32205, 94104, 94129
34576, 31996, 31988, 93852, 93860, 31997, 31989, 93853, 93861, 32221, 94586, 94130, 94594, 32223, 94587, 94133, 
94595, 32224, 32207, 94107, 94132
34577, 31997, 31989, 93853, 93861, 31998, 31990, 93854, 93862, 32223, 94587, 94133, 94595, 32225, 94588, 94136, 
94596, 32226, 32209, 94110, 94135
34578, 31998, 31990, 93854, 93862, 31999, 31991, 93855, 93863, 32225, 94588, 94136, 94596, 32227, 94589, 94139, 
94597, 32228, 32211, 94113, 94138
34579, 31999, 31991, 93855, 93863, 3799, 3798, 31801, 31802, 32227, 94589, 94139, 94597, 3821, 31868, 31830, 
31869, 32229, 32212, 94116, 94141
34580, 3749, 3748, 31713, 31714, 32000, 31992, 93856, 93864, 3771, 31780, 31742, 31781, 32230, 94590, 94143, 
94598, 32231, 32214, 94117, 94142
34581, 32000, 31992, 93856, 93864, 32001, 31993, 93857, 93865, 32230, 94590, 94143, 94598, 32232, 94591, 94146, 
94599, 32233, 32216, 94120, 94145
34582, 32001, 31993, 93857, 93865, 32002, 31994, 93858, 93866, 32232, 94591, 94146, 94599, 32234, 94592, 94149, 
94600, 32235, 32218, 94123, 94148
34583, 32002, 31994, 93858, 93866, 32003, 31995, 93859, 93867, 32234, 94592, 94149, 94600, 32236, 94593, 94152, 
94601, 32237, 32220, 94126, 94151
34584, 32003, 31995, 93859, 93867, 32004, 31996, 93860, 93868, 32236, 94593, 94152, 94601, 32238, 94594, 94155, 
94602, 32239, 32222, 94129, 94154
34585, 32004, 31996, 93860, 93868, 32005, 31997, 93861, 93869, 32238, 94594, 94155, 94602, 32240, 94595, 94158, 
94603, 32241, 32224, 94132, 94157
34586, 32005, 31997, 93861, 93869, 32006, 31998, 93862, 93870, 32240, 94595, 94158, 94603, 32242, 94596, 94161, 
94604, 32243, 32226, 94135, 94160
34587, 32006, 31998, 93862, 93870, 32007, 31999, 93863, 93871, 32242, 94596, 94161, 94604, 32244, 94597, 94164, 
94605, 32245, 32228, 94138, 94163
34588, 32007, 31999, 93863, 93871, 3800, 3799, 31802, 31803, 32244, 94597, 94164, 94605, 3822, 31869, 31832, 
31870, 32246, 32229, 94141, 94166
34589, 3750, 3749, 31714, 31715, 32008, 32000, 93864, 93872, 3772, 31781, 31744, 31782, 32247, 94598, 94168, 
94606, 32248, 32231, 94142, 94167
34590, 32008, 32000, 93864, 93872, 32009, 32001, 93865, 93873, 32247, 94598, 94168, 94606, 32249, 94599, 94171, 
94607, 32250, 32233, 94145, 94170
34591, 32009, 32001, 93865, 93873, 32010, 32002, 93866, 93874, 32249, 94599, 94171, 94607, 32251, 94600, 94174, 
94608, 32252, 32235, 94148, 94173
34592, 32010, 32002, 93866, 93874, 32011, 32003, 93867, 93875, 32251, 94600, 94174, 94608, 32253, 94601, 94177, 
94609, 32254, 32237, 94151, 94176
34593, 32011, 32003, 93867, 93875, 32012, 32004, 93868, 93876, 32253, 94601, 94177, 94609, 32255, 94602, 94180, 
94610, 32256, 32239, 94154, 94179
34594, 32012, 32004, 93868, 93876, 32013, 32005, 93869, 93877, 32255, 94602, 94180, 94610, 32257, 94603, 94183, 
94611, 32258, 32241, 94157, 94182
34595, 32013, 32005, 93869, 93877, 32014, 32006, 93870, 93878, 32257, 94603, 94183, 94611, 32259, 94604, 94186, 
94612, 32260, 32243, 94160, 94185
34596, 32014, 32006, 93870, 93878, 32015, 32007, 93871, 93879, 32259, 94604, 94186, 94612, 32261, 94605, 94189, 
94613, 32262, 32245, 94163, 94188
34597, 32015, 32007, 93871, 93879, 3801, 3800, 31803, 31804, 32261, 94605, 94189, 94613, 3823, 31870, 31834, 
31871, 32263, 32246, 94166, 94191
34598, 3751, 3750, 31715, 31716, 32016, 32008, 93872, 93880, 3773, 31782, 31746, 31783, 32264, 94606, 94193, 
94614, 32265, 32248, 94167, 94192
34599, 32016, 32008, 93872, 93880, 32017, 32009, 93873, 93881, 32264, 94606, 94193, 94614, 32266, 94607, 94196, 
94615, 32267, 32250, 94170, 94195
34600, 32017, 32009, 93873, 93881, 32018, 32010, 93874, 93882, 32266, 94607, 94196, 94615, 32268, 94608, 94199, 
94616, 32269, 32252, 94173, 94198
34601, 32018, 32010, 93874, 93882, 32019, 32011, 93875, 93883, 32268, 94608, 94199, 94616, 32270, 94609, 94202, 
94617, 32271, 32254, 94176, 94201
34602, 32019, 32011, 93875, 93883, 32020, 32012, 93876, 93884, 32270, 94609, 94202, 94617, 32272, 94610, 94205, 
94618, 32273, 32256, 94179, 94204
34603, 32020, 32012, 93876, 93884, 32021, 32013, 93877, 93885, 32272, 94610, 94205, 94618, 32274, 94611, 94208, 
94619, 32275, 32258, 94182, 94207
34604, 32021, 32013, 93877, 93885, 32022, 32014, 93878, 93886, 32274, 94611, 94208, 94619, 32276, 94612, 94211, 
94620, 32277, 32260, 94185, 94210
34605, 32022, 32014, 93878, 93886, 32023, 32015, 93879, 93887, 32276, 94612, 94211, 94620, 32278, 94613, 94214, 
94621, 32279, 32262, 94188, 94213
34606, 32023, 32015, 93879, 93887, 3802, 3801, 31804, 31805, 32278, 94613, 94214, 94621, 3824, 31871, 31836, 
31872, 32280, 32263, 94191, 94216
34607, 3752, 3751, 31716, 31717, 32024, 32016, 93880, 93888, 3774, 31783, 31748, 31784, 32281, 94614, 94218, 
94622, 32282, 32265, 94192, 94217
34608, 32024, 32016, 93880, 93888, 32025, 32017, 93881, 93889, 32281, 94614, 94218, 94622, 32283, 94615, 94221, 
94623, 32284, 32267, 94195, 94220
34609, 32025, 32017, 93881, 93889, 32026, 32018, 93882, 93890, 32283, 94615, 94221, 94623, 32285, 94616, 94224, 
94624, 32286, 32269, 94198, 94223
34610, 32026, 32018, 93882, 93890, 32027, 32019, 93883, 93891, 32285, 94616, 94224, 94624, 32287, 94617, 94227, 
94625, 32288, 32271, 94201, 94226
34611, 32027, 32019, 93883, 93891, 32028, 32020, 93884, 93892, 32287, 94617, 94227, 94625, 32289, 94618, 94230, 
94626, 32290, 32273, 94204, 94229
34612, 32028, 32020, 93884, 93892, 32029, 32021, 93885, 93893, 32289, 94618, 94230, 94626, 32291, 94619, 94233, 
94627, 32292, 32275, 94207, 94232
34613, 32029, 32021, 93885, 93893, 32030, 32022, 93886, 93894, 32291, 94619, 94233, 94627, 32293, 94620, 94236, 
94628, 32294, 32277, 94210, 94235
34614, 32030, 32022, 93886, 93894, 32031, 32023, 93887, 93895, 32293, 94620, 94236, 94628, 32295, 94621, 94239, 
94629, 32296, 32279, 94213, 94238
34615, 32031, 32023, 93887, 93895, 3803, 3802, 31805, 31806, 32295, 94621, 94239, 94629, 3825, 31872, 31838, 
31873, 32297, 32280, 94216, 94241
34616, 3753, 3752, 31717, 31718, 32032, 32024, 93888, 93896, 3775, 31784, 31750, 31785, 32298, 94622, 94243, 
94630, 32299, 32282, 94217, 94242
34617, 32032, 32024, 93888, 93896, 32033, 32025, 93889, 93897, 32298, 94622, 94243, 94630, 32300, 94623, 94246, 
94631, 32301, 32284, 94220, 94245
34618, 32033, 32025, 93889, 93897, 32034, 32026, 93890, 93898, 32300, 94623, 94246, 94631, 32302, 94624, 94249, 
94632, 32303, 32286, 94223, 94248
34619, 32034, 32026, 93890, 93898, 32035, 32027, 93891, 93899, 32302, 94624, 94249, 94632, 32304, 94625, 94252, 
94633, 32305, 32288, 94226, 94251
34620, 32035, 32027, 93891, 93899, 32036, 32028, 93892, 93900, 32304, 94625, 94252, 94633, 32306, 94626, 94255, 
94634, 32307, 32290, 94229, 94254
34621, 32036, 32028, 93892, 93900, 32037, 32029, 93893, 93901, 32306, 94626, 94255, 94634, 32308, 94627, 94258, 
94635, 32309, 32292, 94232, 94257
34622, 32037, 32029, 93893, 93901, 32038, 32030, 93894, 93902, 32308, 94627, 94258, 94635, 32310, 94628, 94261, 
94636, 32311, 32294, 94235, 94260
34623, 32038, 32030, 93894, 93902, 32039, 32031, 93895, 93903, 32310, 94628, 94261, 94636, 32312, 94629, 94264, 
94637, 32313, 32296, 94238, 94263
34624, 32039, 32031, 93895, 93903, 3804, 3803, 31806, 31807, 32312, 94629, 94264, 94637, 3826, 31873, 31840, 
31874, 32314, 32297, 94241, 94266
34625, 3754, 3753, 31718, 31719, 32040, 32032, 93896, 93904, 3776, 31785, 31752, 31786, 32315, 94630, 94268, 
94638, 32316, 32299, 94242, 94267
34626, 32040, 32032, 93896, 93904, 32041, 32033, 93897, 93905, 32315, 94630, 94268, 94638, 32317, 94631, 94271, 
94639, 32318, 32301, 94245, 94270
34627, 32041, 32033, 93897, 93905, 32042, 32034, 93898, 93906, 32317, 94631, 94271, 94639, 32319, 94632, 94274, 
94640, 32320, 32303, 94248, 94273
34628, 32042, 32034, 93898, 93906, 32043, 32035, 93899, 93907, 32319, 94632, 94274, 94640, 32321, 94633, 94277, 
94641, 32322, 32305, 94251, 94276
34629, 32043, 32035, 93899, 93907, 32044, 32036, 93900, 93908, 32321, 94633, 94277, 94641, 32323, 94634, 94280, 
94642, 32324, 32307, 94254, 94279
34630, 32044, 32036, 93900, 93908, 32045, 32037, 93901, 93909, 32323, 94634, 94280, 94642, 32325, 94635, 94283, 
94643, 32326, 32309, 94257, 94282
34631, 32045, 32037, 93901, 93909, 32046, 32038, 93902, 93910, 32325, 94635, 94283, 94643, 32327, 94636, 94286, 
94644, 32328, 32311, 94260, 94285
34632, 32046, 32038, 93902, 93910, 32047, 32039, 93903, 93911, 32327, 94636, 94286, 94644, 32329, 94637, 94289, 
94645, 32330, 32313, 94263, 94288
34633, 32047, 32039, 93903, 93911, 3805, 3804, 31807, 31808, 32329, 94637, 94289, 94645, 3827, 31874, 31842, 
31875, 32331, 32314, 94266, 94291
34634, 3755, 3754, 31719, 31720, 32048, 32040, 93904, 93912, 3777, 31786, 31754, 31787, 32332, 94638, 94293, 
94646, 32333, 32316, 94267, 94292
34635, 32048, 32040, 93904, 93912, 32049, 32041, 93905, 93913, 32332, 94638, 94293, 94646, 32334, 94639, 94296, 
94647, 32335, 32318, 94270, 94295
34636, 32049, 32041, 93905, 93913, 32050, 32042, 93906, 93914, 32334, 94639, 94296, 94647, 32336, 94640, 94299, 
94648, 32337, 32320, 94273, 94298
34637, 32050, 32042, 93906, 93914, 32051, 32043, 93907, 93915, 32336, 94640, 94299, 94648, 32338, 94641, 94302, 
94649, 32339, 32322, 94276, 94301
34638, 32051, 32043, 93907, 93915, 32052, 32044, 93908, 93916, 32338, 94641, 94302, 94649, 32340, 94642, 94305, 
94650, 32341, 32324, 94279, 94304
34639, 32052, 32044, 93908, 93916, 32053, 32045, 93909, 93917, 32340, 94642, 94305, 94650, 32342, 94643, 94308, 
94651, 32343, 32326, 94282, 94307
34640, 32053, 32045, 93909, 93917, 32054, 32046, 93910, 93918, 32342, 94643, 94308, 94651, 32344, 94644, 94311, 
94652, 32345, 32328, 94285, 94310
34641, 32054, 32046, 93910, 93918, 32055, 32047, 93911, 93919, 32344, 94644, 94311, 94652, 32346, 94645, 94314, 
94653, 32347, 32330, 94288, 94313
34642, 32055, 32047, 93911, 93919, 3806, 3805, 31808, 31809, 32346, 94645, 94314, 94653, 3828, 31875, 31844, 
31876, 32348, 32331, 94291, 94316
34643, 3756, 3755, 31720, 31721, 32056, 32048, 93912, 93920, 3778, 31787, 31756, 31788, 32349, 94646, 94318, 
94654, 32350, 32333, 94292, 94317
34644, 32056, 32048, 93912, 93920, 32057, 32049, 93913, 93921, 32349, 94646, 94318, 94654, 32351, 94647, 94321, 
94655, 32352, 32335, 94295, 94320
34645, 32057, 32049, 93913, 93921, 32058, 32050, 93914, 93922, 32351, 94647, 94321, 94655, 32353, 94648, 94324, 
94656, 32354, 32337, 94298, 94323
34646, 32058, 32050, 93914, 93922, 32059, 32051, 93915, 93923, 32353, 94648, 94324, 94656, 32355, 94649, 94327, 
94657, 32356, 32339, 94301, 94326
34647, 32059, 32051, 93915, 93923, 32060, 32052, 93916, 93924, 32355, 94649, 94327, 94657, 32357, 94650, 94330, 
94658, 32358, 32341, 94304, 94329
34648, 32060, 32052, 93916, 93924, 32061, 32053, 93917, 93925, 32357, 94650, 94330, 94658, 32359, 94651, 94333, 
94659, 32360, 32343, 94307, 94332
34649, 32061, 32053, 93917, 93925, 32062, 32054, 93918, 93926, 32359, 94651, 94333, 94659, 32361, 94652, 94336, 
94660, 32362, 32345, 94310, 94335
34650, 32062, 32054, 93918, 93926, 32063, 32055, 93919, 93927, 32361, 94652, 94336, 94660, 32363, 94653, 94339, 
94661, 32364, 32347, 94313, 94338
34651, 32063, 32055, 93919, 93927, 3807, 3806, 31809, 31810, 32363, 94653, 94339, 94661, 3829, 31876, 31846, 
31877, 32365, 32348, 94316, 94341
34652, 3757, 3756, 31721, 31722, 32064, 32056, 93920, 93928, 3779, 31788, 31758, 31789, 32366, 94654, 94343, 
94662, 32367, 32350, 94317, 94342
34653, 32064, 32056, 93920, 93928, 32065, 32057, 93921, 93929, 32366, 94654, 94343, 94662, 32368, 94655, 94346, 
94663, 32369, 32352, 94320, 94345
34654, 32065, 32057, 93921, 93929, 32066, 32058, 93922, 93930, 32368, 94655, 94346, 94663, 32370, 94656, 94349, 
94664, 32371, 32354, 94323, 94348
34655, 32066, 32058, 93922, 93930, 32067, 32059, 93923, 93931, 32370, 94656, 94349, 94664, 32372, 94657, 94352, 
94665, 32373, 32356, 94326, 94351
34656, 32067, 32059, 93923, 93931, 32068, 32060, 93924, 93932, 32372, 94657, 94352, 94665, 32374, 94658, 94355, 
94666, 32375, 32358, 94329, 94354
34657, 32068, 32060, 93924, 93932, 32069, 32061, 93925, 93933, 32374, 94658, 94355, 94666, 32376, 94659, 94358, 
94667, 32377, 32360, 94332, 94357
34658, 32069, 32061, 93925, 93933, 32070, 32062, 93926, 93934, 32376, 94659, 94358, 94667, 32378, 94660, 94361, 
94668, 32379, 32362, 94335, 94360
34659, 32070, 32062, 93926, 93934, 32071, 32063, 93927, 93935, 32378, 94660, 94361, 94668, 32380, 94661, 94364, 
94669, 32381, 32364, 94338, 94363
34660, 32071, 32063, 93927, 93935, 3808, 3807, 31810, 31811, 32380, 94661, 94364, 94669, 3830, 31877, 31848, 
31878, 32382, 32365, 94341, 94366
34661, 3758, 3757, 31722, 31723, 32072, 32064, 93928, 93936, 3780, 31789, 31760, 31790, 32383, 94662, 94368, 
94670, 32384, 32367, 94342, 94367
34662, 32072, 32064, 93928, 93936, 32073, 32065, 93929, 93937, 32383, 94662, 94368, 94670, 32385, 94663, 94371, 
94671, 32386, 32369, 94345, 94370
34663, 32073, 32065, 93929, 93937, 32074, 32066, 93930, 93938, 32385, 94663, 94371, 94671, 32387, 94664, 94374, 
94672, 32388, 32371, 94348, 94373
34664, 32074, 32066, 93930, 93938, 32075, 32067, 93931, 93939, 32387, 94664, 94374, 94672, 32389, 94665, 94377, 
94673, 32390, 32373, 94351, 94376
34665, 32075, 32067, 93931, 93939, 32076, 32068, 93932, 93940, 32389, 94665, 94377, 94673, 32391, 94666, 94380, 
94674, 32392, 32375, 94354, 94379
34666, 32076, 32068, 93932, 93940, 32077, 32069, 93933, 93941, 32391, 94666, 94380, 94674, 32393, 94667, 94383, 
94675, 32394, 32377, 94357, 94382
34667, 32077, 32069, 93933, 93941, 32078, 32070, 93934, 93942, 32393, 94667, 94383, 94675, 32395, 94668, 94386, 
94676, 32396, 32379, 94360, 94385
34668, 32078, 32070, 93934, 93942, 32079, 32071, 93935, 93943, 32395, 94668, 94386, 94676, 32397, 94669, 94389, 
94677, 32398, 32381, 94363, 94388
34669, 32079, 32071, 93935, 93943, 3809, 3808, 31811, 31812, 32397, 94669, 94389, 94677, 3831, 31878, 31850, 
31879, 32399, 32382, 94366, 94391
34670, 3759, 3758, 31723, 31724, 32080, 32072, 93936, 93944, 3781, 31790, 31762, 31791, 32400, 94670, 94393, 
94678, 32401, 32384, 94367, 94392
34671, 32080, 32072, 93936, 93944, 32081, 32073, 93937, 93945, 32400, 94670, 94393, 94678, 32402, 94671, 94396, 
94679, 32403, 32386, 94370, 94395
34672, 32081, 32073, 93937, 93945, 32082, 32074, 93938, 93946, 32402, 94671, 94396, 94679, 32404, 94672, 94399, 
94680, 32405, 32388, 94373, 94398
34673, 32082, 32074, 93938, 93946, 32083, 32075, 93939, 93947, 32404, 94672, 94399, 94680, 32406, 94673, 94402, 
94681, 32407, 32390, 94376, 94401
34674, 32083, 32075, 93939, 93947, 32084, 32076, 93940, 93948, 32406, 94673, 94402, 94681, 32408, 94674, 94405, 
94682, 32409, 32392, 94379, 94404
34675, 32084, 32076, 93940, 93948, 32085, 32077, 93941, 93949, 32408, 94674, 94405, 94682, 32410, 94675, 94408, 
94683, 32411, 32394, 94382, 94407
34676, 32085, 32077, 93941, 93949, 32086, 32078, 93942, 93950, 32410, 94675, 94408, 94683, 32412, 94676, 94411, 
94684, 32413, 32396, 94385, 94410
34677, 32086, 32078, 93942, 93950, 32087, 32079, 93943, 93951, 32412, 94676, 94411, 94684, 32414, 94677, 94414, 
94685, 32415, 32398, 94388, 94413
34678, 32087, 32079, 93943, 93951, 3810, 3809, 31812, 31813, 32414, 94677, 94414, 94685, 3832, 31879, 31852, 
31880, 32416, 32399, 94391, 94416
34679, 3760, 3759, 31724, 31725, 32088, 32080, 93944, 93952, 3782, 31791, 31764, 31792, 32417, 94678, 94418, 
94686, 32418, 32401, 94392, 94417
34680, 32088, 32080, 93944, 93952, 32089, 32081, 93945, 93953, 32417, 94678, 94418, 94686, 32419, 94679, 94421, 
94687, 32420, 32403, 94395, 94420
34681, 32089, 32081, 93945, 93953, 32090, 32082, 93946, 93954, 32419, 94679, 94421, 94687, 32421, 94680, 94424, 
94688, 32422, 32405, 94398, 94423
34682, 32090, 32082, 93946, 93954, 32091, 32083, 93947, 93955, 32421, 94680, 94424, 94688, 32423, 94681, 94427, 
94689, 32424, 32407, 94401, 94426
34683, 32091, 32083, 93947, 93955, 32092, 32084, 93948, 93956, 32423, 94681, 94427, 94689, 32425, 94682, 94430, 
94690, 32426, 32409, 94404, 94429
34684, 32092, 32084, 93948, 93956, 32093, 32085, 93949, 93957, 32425, 94682, 94430, 94690, 32427, 94683, 94433, 
94691, 32428, 32411, 94407, 94432
34685, 32093, 32085, 93949, 93957, 32094, 32086, 93950, 93958, 32427, 94683, 94433, 94691, 32429, 94684, 94436, 
94692, 32430, 32413, 94410, 94435
34686, 32094, 32086, 93950, 93958, 32095, 32087, 93951, 93959, 32429, 94684, 94436, 94692, 32431, 94685, 94439, 
94693, 32432, 32415, 94413, 94438
34687, 32095, 32087, 93951, 93959, 3811, 3810, 31813, 31814, 32431, 94685, 94439, 94693, 3833, 31880, 31854, 
31881, 32433, 32416, 94416, 94441
34688, 3761, 3760, 31725, 31726, 32096, 32088, 93952, 93960, 3783, 31792, 31766, 31793, 32434, 94686, 94443, 
94694, 32435, 32418, 94417, 94442
34689, 32096, 32088, 93952, 93960, 32097, 32089, 93953, 93961, 32434, 94686, 94443, 94694, 32436, 94687, 94446, 
94695, 32437, 32420, 94420, 94445
34690, 32097, 32089, 93953, 93961, 32098, 32090, 93954, 93962, 32436, 94687, 94446, 94695, 32438, 94688, 94449, 
94696, 32439, 32422, 94423, 94448
34691, 32098, 32090, 93954, 93962, 32099, 32091, 93955, 93963, 32438, 94688, 94449, 94696, 32440, 94689, 94452, 
94697, 32441, 32424, 94426, 94451
34692, 32099, 32091, 93955, 93963, 32100, 32092, 93956, 93964, 32440, 94689, 94452, 94697, 32442, 94690, 94455, 
94698, 32443, 32426, 94429, 94454
34693, 32100, 32092, 93956, 93964, 32101, 32093, 93957, 93965, 32442, 94690, 94455, 94698, 32444, 94691, 94458, 
94699, 32445, 32428, 94432, 94457
34694, 32101, 32093, 93957, 93965, 32102, 32094, 93958, 93966, 32444, 94691, 94458, 94699, 32446, 94692, 94461, 
94700, 32447, 32430, 94435, 94460
34695, 32102, 32094, 93958, 93966, 32103, 32095, 93959, 93967, 32446, 94692, 94461, 94700, 32448, 94693, 94464, 
94701, 32449, 32432, 94438, 94463
34696, 32103, 32095, 93959, 93967, 3812, 3811, 31814, 31815, 32448, 94693, 94464, 94701, 3834, 31881, 31856, 
31882, 32450, 32433, 94441, 94466
34697, 3762, 3761, 31726, 31727, 32104, 32096, 93960, 93968, 3784, 31793, 31768, 31794, 32451, 94694, 94468, 
94702, 32452, 32435, 94442, 94467
34698, 32104, 32096, 93960, 93968, 32105, 32097, 93961, 93969, 32451, 94694, 94468, 94702, 32453, 94695, 94471, 
94703, 32454, 32437, 94445, 94470
34699, 32105, 32097, 93961, 93969, 32106, 32098, 93962, 93970, 32453, 94695, 94471, 94703, 32455, 94696, 94474, 
94704, 32456, 32439, 94448, 94473
34700, 32106, 32098, 93962, 93970, 32107, 32099, 93963, 93971, 32455, 94696, 94474, 94704, 32457, 94697, 94477, 
94705, 32458, 32441, 94451, 94476
34701, 32107, 32099, 93963, 93971, 32108, 32100, 93964, 93972, 32457, 94697, 94477, 94705, 32459, 94698, 94480, 
94706, 32460, 32443, 94454, 94479
34702, 32108, 32100, 93964, 93972, 32109, 32101, 93965, 93973, 32459, 94698, 94480, 94706, 32461, 94699, 94483, 
94707, 32462, 32445, 94457, 94482
34703, 32109, 32101, 93965, 93973, 32110, 32102, 93966, 93974, 32461, 94699, 94483, 94707, 32463, 94700, 94486, 
94708, 32464, 32447, 94460, 94485
34704, 32110, 32102, 93966, 93974, 32111, 32103, 93967, 93975, 32463, 94700, 94486, 94708, 32465, 94701, 94489, 
94709, 32466, 32449, 94463, 94488
34705, 32111, 32103, 93967, 93975, 3813, 3812, 31815, 31816, 32465, 94701, 94489, 94709, 3835, 31882, 31858, 
31883, 32467, 32450, 94466, 94491
34706, 3763, 3762, 31727, 31728, 32112, 32104, 93968, 93976, 3785, 31794, 31770, 31795, 32468, 94702, 94493, 
94710, 32469, 32452, 94467, 94492
34707, 32112, 32104, 93968, 93976, 32113, 32105, 93969, 93977, 32468, 94702, 94493, 94710, 32470, 94703, 94496, 
94711, 32471, 32454, 94470, 94495
34708, 32113, 32105, 93969, 93977, 32114, 32106, 93970, 93978, 32470, 94703, 94496, 94711, 32472, 94704, 94499, 
94712, 32473, 32456, 94473, 94498
34709, 32114, 32106, 93970, 93978, 32115, 32107, 93971, 93979, 32472, 94704, 94499, 94712, 32474, 94705, 94502, 
94713, 32475, 32458, 94476, 94501
34710, 32115, 32107, 93971, 93979, 32116, 32108, 93972, 93980, 32474, 94705, 94502, 94713, 32476, 94706, 94505, 
94714, 32477, 32460, 94479, 94504
34711, 32116, 32108, 93972, 93980, 32117, 32109, 93973, 93981, 32476, 94706, 94505, 94714, 32478, 94707, 94508, 
94715, 32479, 32462, 94482, 94507
34712, 32117, 32109, 93973, 93981, 32118, 32110, 93974, 93982, 32478, 94707, 94508, 94715, 32480, 94708, 94511, 
94716, 32481, 32464, 94485, 94510
34713, 32118, 32110, 93974, 93982, 32119, 32111, 93975, 93983, 32480, 94708, 94511, 94716, 32482, 94709, 94514, 
94717, 32483, 32466, 94488, 94513
34714, 32119, 32111, 93975, 93983, 3814, 3813, 31816, 31817, 32482, 94709, 94514, 94717, 3836, 31883, 31860, 
31884, 32484, 32467, 94491, 94516
34715, 3764, 3763, 31728, 31729, 32120, 32112, 93976, 93984, 3786, 31795, 31772, 31796, 32485, 94710, 94518, 
94718, 32486, 32469, 94492, 94517
34716, 32120, 32112, 93976, 93984, 32121, 32113, 93977, 93985, 32485, 94710, 94518, 94718, 32487, 94711, 94521, 
94719, 32488, 32471, 94495, 94520
34717, 32121, 32113, 93977, 93985, 32122, 32114, 93978, 93986, 32487, 94711, 94521, 94719, 32489, 94712, 94524, 
94720, 32490, 32473, 94498, 94523
34718, 32122, 32114, 93978, 93986, 32123, 32115, 93979, 93987, 32489, 94712, 94524, 94720, 32491, 94713, 94527, 
94721, 32492, 32475, 94501, 94526
34719, 32123, 32115, 93979, 93987, 32124, 32116, 93980, 93988, 32491, 94713, 94527, 94721, 32493, 94714, 94530, 
94722, 32494, 32477, 94504, 94529
34720, 32124, 32116, 93980, 93988, 32125, 32117, 93981, 93989, 32493, 94714, 94530, 94722, 32495, 94715, 94533, 
94723, 32496, 32479, 94507, 94532
34721, 32125, 32117, 93981, 93989, 32126, 32118, 93982, 93990, 32495, 94715, 94533, 94723, 32497, 94716, 94536, 
94724, 32498, 32481, 94510, 94535
34722, 32126, 32118, 93982, 93990, 32127, 32119, 93983, 93991, 32497, 94716, 94536, 94724, 32499, 94717, 94539, 
94725, 32500, 32483, 94513, 94538
34723, 32127, 32119, 93983, 93991, 3815, 3814, 31817, 31818, 32499, 94717, 94539, 94725, 3837, 31884, 31862, 
31885, 32501, 32484, 94516, 94541
34724, 106, 3764, 31729, 3740, 3863, 32120, 93984, 31919, 3787, 31796, 31774, 3742, 32502, 94718, 94542, 
31944, 3872, 32486, 94517, 31927
34725, 3863, 32120, 93984, 31919, 3862, 32121, 93985, 31920, 32502, 94718, 94542, 31944, 32503, 94719, 94543, 
31945, 3871, 32488, 94520, 31929
34726, 3862, 32121, 93985, 31920, 3861, 32122, 93986, 31921, 32503, 94719, 94543, 31945, 32504, 94720, 94544, 
31946, 3870, 32490, 94523, 31931
34727, 3861, 32122, 93986, 31921, 3860, 32123, 93987, 31922, 32504, 94720, 94544, 31946, 32505, 94721, 94545, 
31947, 3869, 32492, 94526, 31933
34728, 3860, 32123, 93987, 31922, 3859, 32124, 93988, 31923, 32505, 94721, 94545, 31947, 32506, 94722, 94546, 
31948, 3868, 32494, 94529, 31935
34729, 3859, 32124, 93988, 31923, 3858, 32125, 93989, 31924, 32506, 94722, 94546, 31948, 32507, 94723, 94547, 
31949, 3867, 32496, 94532, 31937
34730, 3858, 32125, 93989, 31924, 3857, 32126, 93990, 31925, 32507, 94723, 94547, 31949, 32508, 94724, 94548, 
31950, 3866, 32498, 94535, 31939
34731, 3857, 32126, 93990, 31925, 3856, 32127, 93991, 31926, 32508, 94724, 94548, 31950, 32509, 94725, 94549, 
31951, 3865, 32500, 94538, 31941
34732, 3856, 32127, 93991, 31926, 108, 3815, 31818, 3791, 32509, 94725, 94549, 31951, 3838, 31885, 31863, 
3793, 3864, 32501, 94541, 31943
*ELEMENT, type=C3D20, ELSET=Volume34
34733, 32510, 3873, 67, 2047, 94726, 32606, 2074, 15542, 32532, 3874, 2070, 32533, 94903, 32622, 15924, 
94904, 94902, 32623, 2082, 15907
34734, 94726, 32606, 2074, 15542, 94727, 32605, 2075, 15543, 94903, 32622, 15924, 94904, 94906, 32620, 15925, 
94907, 94905, 32621, 2083, 15909
34735, 94727, 32605, 2075, 15543, 94728, 32604, 2076, 15544, 94906, 32620, 15925, 94907, 94909, 32618, 15926, 
94910, 94908, 32619, 2084, 15911
34736, 94728, 32604, 2076, 15544, 94729, 32603, 2077, 15545, 94909, 32618, 15926, 94910, 94912, 32616, 15927, 
94913, 94911, 32617, 2085, 15913
34737, 94729, 32603, 2077, 15545, 94730, 32602, 2078, 15546, 94912, 32616, 15927, 94913, 94915, 32614, 15928, 
94916, 94914, 32615, 2086, 15915
34738, 94730, 32602, 2078, 15546, 94731, 32601, 2079, 15547, 94915, 32614, 15928, 94916, 94918, 32612, 15929, 
94919, 94917, 32613, 2087, 15917
34739, 94731, 32601, 2079, 15547, 94732, 32600, 2080, 15548, 94918, 32612, 15929, 94919, 94921, 32610, 15930, 
94922, 94920, 32611, 2088, 15919
34740, 94732, 32600, 2080, 15548, 94733, 32599, 2081, 15549, 94921, 32610, 15930, 94922, 94924, 32608, 15931, 
94925, 94923, 32609, 2089, 15921
34741, 94733, 32599, 2081, 15549, 32632, 3879, 69, 2115, 94924, 32608, 15931, 94925, 32655, 3880, 2138, 
32654, 94926, 32607, 2090, 15923
34742, 32511, 32510, 2047, 2046, 94734, 94726, 15542, 15534, 32534, 32533, 2069, 32535, 94928, 94904, 15908, 
94929, 94927, 94902, 15907, 15890
34743, 94734, 94726, 15542, 15534, 94735, 94727, 15543, 15535, 94928, 94904, 15908, 94929, 94931, 94907, 15910, 
94932, 94930, 94905, 15909, 15892
34744, 94735, 94727, 15543, 15535, 94736, 94728, 15544, 15536, 94931, 94907, 15910, 94932, 94934, 94910, 15912, 
94935, 94933, 94908, 15911, 15894
34745, 94736, 94728, 15544, 15536, 94737, 94729, 15545, 15537, 94934, 94910, 15912, 94935, 94937, 94913, 15914, 
94938, 94936, 94911, 15913, 15896
34746, 94737, 94729, 15545, 15537, 94738, 94730, 15546, 15538, 94937, 94913, 15914, 94938, 94940, 94916, 15916, 
94941, 94939, 94914, 15915, 15898
34747, 94738, 94730, 15546, 15538, 94739, 94731, 15547, 15539, 94940, 94916, 15916, 94941, 94943, 94919, 15918, 
94944, 94942, 94917, 15917, 15900
34748, 94739, 94731, 15547, 15539, 94740, 94732, 15548, 15540, 94943, 94919, 15918, 94944, 94946, 94922, 15920, 
94947, 94945, 94920, 15919, 15902
34749, 94740, 94732, 15548, 15540, 94741, 94733, 15549, 15541, 94946, 94922, 15920, 94947, 94949, 94925, 15922, 
94950, 94948, 94923, 15921, 15904
34750, 94741, 94733, 15549, 15541, 32633, 32632, 2115, 2114, 94949, 94925, 15922, 94950, 32657, 32654, 2137, 
32656, 94951, 94926, 15923, 15906
34751, 32512, 32511, 2046, 2045, 94742, 94734, 15534, 15526, 32536, 32535, 2068, 32537, 94953, 94929, 15891, 
94954, 94952, 94927, 15890, 15873
34752, 94742, 94734, 15534, 15526, 94743, 94735, 15535, 15527, 94953, 94929, 15891, 94954, 94956, 94932, 15893, 
94957, 94955, 94930, 15892, 15875
34753, 94743, 94735, 15535, 15527, 94744, 94736, 15536, 15528, 94956, 94932, 15893, 94957, 94959, 94935, 15895, 
94960, 94958, 94933, 15894, 15877
34754, 94744, 94736, 15536, 15528, 94745, 94737, 15537, 15529, 94959, 94935, 15895, 94960, 94962, 94938, 15897, 
94963, 94961, 94936, 15896, 15879
34755, 94745, 94737, 15537, 15529, 94746, 94738, 15538, 15530, 94962, 94938, 15897, 94963, 94965, 94941, 15899, 
94966, 94964, 94939, 15898, 15881
34756, 94746, 94738, 15538, 15530, 94747, 94739, 15539, 15531, 94965, 94941, 15899, 94966, 94968, 94944, 15901, 
94969, 94967, 94942, 15900, 15883
34757, 94747, 94739, 15539, 15531, 94748, 94740, 15540, 15532, 94968, 94944, 15901, 94969, 94971, 94947, 15903, 
94972, 94970, 94945, 15902, 15885
34758, 94748, 94740, 15540, 15532, 94749, 94741, 15541, 15533, 94971, 94947, 15903, 94972, 94974, 94950, 15905, 
94975, 94973, 94948, 15904, 15887
34759, 94749, 94741, 15541, 15533, 32634, 32633, 2114, 2113, 94974, 94950, 15905, 94975, 32659, 32656, 2136, 
32658, 94976, 94951, 15906, 15889
34760, 32513, 32512, 2045, 2044, 94750, 94742, 15526, 15518, 32538, 32537, 2067, 32539, 94978, 94954, 15874, 
94979, 94977, 94952, 15873, 15856
34761, 94750, 94742, 15526, 15518, 94751, 94743, 15527, 15519, 94978, 94954, 15874, 94979, 94981, 94957, 15876, 
94982, 94980, 94955, 15875, 15858
34762, 94751, 94743, 15527, 15519, 94752, 94744, 15528, 15520, 94981, 94957, 15876, 94982, 94984, 94960, 15878, 
94985, 94983, 94958, 15877, 15860
34763, 94752, 94744, 15528, 15520, 94753, 94745, 15529, 15521, 94984, 94960, 15878, 94985, 94987, 94963, 15880, 
94988, 94986, 94961, 15879, 15862
34764, 94753, 94745, 15529, 15521, 94754, 94746, 15530, 15522, 94987, 94963, 15880, 94988, 94990, 94966, 15882, 
94991, 94989, 94964, 15881, 15864
34765, 94754, 94746, 15530, 15522, 94755, 94747, 15531, 15523, 94990, 94966, 15882, 94991, 94993, 94969, 15884, 
94994, 94992, 94967, 15883, 15866
34766, 94755, 94747, 15531, 15523, 94756, 94748, 15532, 15524, 94993, 94969, 15884, 94994, 94996, 94972, 15886, 
94997, 94995, 94970, 15885, 15868
34767, 94756, 94748, 15532, 15524, 94757, 94749, 15533, 15525, 94996, 94972, 15886, 94997, 94999, 94975, 15888, 
95000, 94998, 94973, 15887, 15870
34768, 94757, 94749, 15533, 15525, 32635, 32634, 2113, 2112, 94999, 94975, 15888, 95000, 32661, 32658, 2135, 
32660, 95001, 94976, 15889, 15872
34769, 32514, 32513, 2044, 2043, 94758, 94750, 15518, 15510, 32540, 32539, 2066, 32541, 95003, 94979, 15857, 
95004, 95002, 94977, 15856, 15839
34770, 94758, 94750, 15518, 15510, 94759, 94751, 15519, 15511, 95003, 94979, 15857, 95004, 95006, 94982, 15859, 
95007, 95005, 94980, 15858, 15841
34771, 94759, 94751, 15519, 15511, 94760, 94752, 15520, 15512, 95006, 94982, 15859, 95007, 95009, 94985, 15861, 
95010, 95008, 94983, 15860, 15843
34772, 94760, 94752, 15520, 15512, 94761, 94753, 15521, 15513, 95009, 94985, 15861, 95010, 95012, 94988, 15863, 
95013, 95011, 94986, 15862, 15845
34773, 94761, 94753, 15521, 15513, 94762, 94754, 15522, 15514, 95012, 94988, 15863, 95013, 95015, 94991, 15865, 
95016, 95014, 94989, 15864, 15847
34774, 94762, 94754, 15522, 15514, 94763, 94755, 15523, 15515, 95015, 94991, 15865, 95016, 95018, 94994, 15867, 
95019, 95017, 94992, 15866, 15849
34775, 94763, 94755, 15523, 15515, 94764, 94756, 15524, 15516, 95018, 94994, 15867, 95019, 95021, 94997, 15869, 
95022, 95020, 94995, 15868, 15851
34776, 94764, 94756, 15524, 15516, 94765, 94757, 15525, 15517, 95021, 94997, 15869, 95022, 95024, 95000, 15871, 
95025, 95023, 94998, 15870, 15853
34777, 94765, 94757, 15525, 15517, 32636, 32635, 2112, 2111, 95024, 95000, 15871, 95025, 32663, 32660, 2134, 
32662, 95026, 95001, 15872, 15855
34778, 32515, 32514, 2043, 2042, 94766, 94758, 15510, 15502, 32542, 32541, 2065, 32543, 95028, 95004, 15840, 
95029, 95027, 95002, 15839, 15822
34779, 94766, 94758, 15510, 15502, 94767, 94759, 15511, 15503, 95028, 95004, 15840, 95029, 95031, 95007, 15842, 
95032, 95030, 95005, 15841, 15824
34780, 94767, 94759, 15511, 15503, 94768, 94760, 15512, 15504, 95031, 95007, 15842, 95032, 95034, 95010, 15844, 
95035, 95033, 95008, 15843, 15826
34781, 94768, 94760, 15512, 15504, 94769, 94761, 15513, 15505, 95034, 95010, 15844, 95035, 95037, 95013, 15846, 
95038, 95036, 95011, 15845, 15828
34782, 94769, 94761, 15513, 15505, 94770, 94762, 15514, 15506, 95037, 95013, 15846, 95038, 95040, 95016, 15848, 
95041, 95039, 95014, 15847, 15830
34783, 94770, 94762, 15514, 15506, 94771, 94763, 15515, 15507, 95040, 95016, 15848, 95041, 95043, 95019, 15850, 
95044, 95042, 95017, 15849, 15832
34784, 94771, 94763, 15515, 15507, 94772, 94764, 15516, 15508, 95043, 95019, 15850, 95044, 95046, 95022, 15852, 
95047, 95045, 95020, 15851, 15834
34785, 94772, 94764, 15516, 15508, 94773, 94765, 15517, 15509, 95046, 95022, 15852, 95047, 95049, 95025, 15854, 
95050, 95048, 95023, 15853, 15836
34786, 94773, 94765, 15517, 15509, 32637, 32636, 2111, 2110, 95049, 95025, 15854, 95050, 32665, 32662, 2133, 
32664, 95051, 95026, 15855, 15838
34787, 32516, 32515, 2042, 2041, 94774, 94766, 15502, 15494, 32544, 32543, 2064, 32545, 95053, 95029, 15823, 
95054, 95052, 95027, 15822, 15805
34788, 94774, 94766, 15502, 15494, 94775, 94767, 15503, 15495, 95053, 95029, 15823, 95054, 95056, 95032, 15825, 
95057, 95055, 95030, 15824, 15807
34789, 94775, 94767, 15503, 15495, 94776, 94768, 15504, 15496, 95056, 95032, 15825, 95057, 95059, 95035, 15827, 
95060, 95058, 95033, 15826, 15809
34790, 94776, 94768, 15504, 15496, 94777, 94769, 15505, 15497, 95059, 95035, 15827, 95060, 95062, 95038, 15829, 
95063, 95061, 95036, 15828, 15811
34791, 94777, 94769, 15505, 15497, 94778, 94770, 15506, 15498, 95062, 95038, 15829, 95063, 95065, 95041, 15831, 
95066, 95064, 95039, 15830, 15813
34792, 94778, 94770, 15506, 15498, 94779, 94771, 15507, 15499, 95065, 95041, 15831, 95066, 95068, 95044, 15833, 
95069, 95067, 95042, 15832, 15815
34793, 94779, 94771, 15507, 15499, 94780, 94772, 15508, 15500, 95068, 95044, 15833, 95069, 95071, 95047, 15835, 
95072, 95070, 95045, 15834, 15817
34794, 94780, 94772, 15508, 15500, 94781, 94773, 15509, 15501, 95071, 95047, 15835, 95072, 95074, 95050, 15837, 
95075, 95073, 95048, 15836, 15819
34795, 94781, 94773, 15509, 15501, 32638, 32637, 2110, 2109, 95074, 95050, 15837, 95075, 32667, 32664, 2132, 
32666, 95076, 95051, 15838, 15821
34796, 32517, 32516, 2041, 2040, 94782, 94774, 15494, 15486, 32546, 32545, 2063, 32547, 95078, 95054, 15806, 
95079, 95077, 95052, 15805, 15788
34797, 94782, 94774, 15494, 15486, 94783, 94775, 15495, 15487, 95078, 95054, 15806, 95079, 95081, 95057, 15808, 
95082, 95080, 95055, 15807, 15790
34798, 94783, 94775, 15495, 15487, 94784, 94776, 15496, 15488, 95081, 95057, 15808, 95082, 95084, 95060, 15810, 
95085, 95083, 95058, 15809, 15792
34799, 94784, 94776, 15496, 15488, 94785, 94777, 15497, 15489, 95084, 95060, 15810, 95085, 95087, 95063, 15812, 
95088, 95086, 95061, 15811, 15794
34800, 94785, 94777, 15497, 15489, 94786, 94778, 15498, 15490, 95087, 95063, 15812, 95088, 95090, 95066, 15814, 
95091, 95089, 95064, 15813, 15796
34801, 94786, 94778, 15498, 15490, 94787, 94779, 15499, 15491, 95090, 95066, 15814, 95091, 95093, 95069, 15816, 
95094, 95092, 95067, 15815, 15798
34802, 94787, 94779, 15499, 15491, 94788, 94780, 15500, 15492, 95093, 95069, 15816, 95094, 95096, 95072, 15818, 
95097, 95095, 95070, 15817, 15800
34803, 94788, 94780, 15500, 15492, 94789, 94781, 15501, 15493, 95096, 95072, 15818, 95097, 95099, 95075, 15820, 
95100, 95098, 95073, 15819, 15802
34804, 94789, 94781, 15501, 15493, 32639, 32638, 2109, 2108, 95099, 95075, 15820, 95100, 32669, 32666, 2131, 
32668, 95101, 95076, 15821, 15804
34805, 32518, 32517, 2040, 2039, 94790, 94782, 15486, 15478, 32548, 32547, 2062, 32549, 95103, 95079, 15789, 
95104, 95102, 95077, 15788, 15771
34806, 94790, 94782, 15486, 15478, 94791, 94783, 15487, 15479, 95103, 95079, 15789, 95104, 95106, 95082, 15791, 
95107, 95105, 95080, 15790, 15773
34807, 94791, 94783, 15487, 15479, 94792, 94784, 15488, 15480, 95106, 95082, 15791, 95107, 95109, 95085, 15793, 
95110, 95108, 95083, 15792, 15775
34808, 94792, 94784, 15488, 15480, 94793, 94785, 15489, 15481, 95109, 95085, 15793, 95110, 95112, 95088, 15795, 
95113, 95111, 95086, 15794, 15777
34809, 94793, 94785, 15489, 15481, 94794, 94786, 15490, 15482, 95112, 95088, 15795, 95113, 95115, 95091, 15797, 
95116, 95114, 95089, 15796, 15779
34810, 94794, 94786, 15490, 15482, 94795, 94787, 15491, 15483, 95115, 95091, 15797, 95116, 95118, 95094, 15799, 
95119, 95117, 95092, 15798, 15781
34811, 94795, 94787, 15491, 15483, 94796, 94788, 15492, 15484, 95118, 95094, 15799, 95119, 95121, 95097, 15801, 
95122, 95120, 95095, 15800, 15783
34812, 94796, 94788, 15492, 15484, 94797, 94789, 15493, 15485, 95121, 95097, 15801, 95122, 95124, 95100, 15803, 
95125, 95123, 95098, 15802, 15785
34813, 94797, 94789, 15493, 15485, 32640, 32639, 2108, 2107, 95124, 95100, 15803, 95125, 32671, 32668, 2130, 
32670, 95126, 95101, 15804, 15787
34814, 32519, 32518, 2039, 2038, 94798, 94790, 15478, 15470, 32550, 32549, 2061, 32551, 95128, 95104, 15772, 
95129, 95127, 95102, 15771, 15754
34815, 94798, 94790, 15478, 15470, 94799, 94791, 15479, 15471, 95128, 95104, 15772, 95129, 95131, 95107, 15774, 
95132, 95130, 95105, 15773, 15756
34816, 94799, 94791, 15479, 15471, 94800, 94792, 15480, 15472, 95131, 95107, 15774, 95132, 95134, 95110, 15776, 
95135, 95133, 95108, 15775, 15758
34817, 94800, 94792, 15480, 15472, 94801, 94793, 15481, 15473, 95134, 95110, 15776, 95135, 95137, 95113, 15778, 
95138, 95136, 95111, 15777, 15760
34818, 94801, 94793, 15481, 15473, 94802, 94794, 15482, 15474, 95137, 95113, 15778, 95138, 95140, 95116, 15780, 
95141, 95139, 95114, 15779, 15762
34819, 94802, 94794, 15482, 15474, 94803, 94795, 15483, 15475, 95140, 95116, 15780, 95141, 95143, 95119, 15782, 
95144, 95142, 95117, 15781, 15764
34820, 94803, 94795, 15483, 15475, 94804, 94796, 15484, 15476, 95143, 95119, 15782, 95144, 95146, 95122, 15784, 
95147, 95145, 95120, 15783, 15766
34821, 94804, 94796, 15484, 15476, 94805, 94797, 15485, 15477, 95146, 95122, 15784, 95147, 95149, 95125, 15786, 
95150, 95148, 95123, 15785, 15768
34822, 94805, 94797, 15485, 15477, 32641, 32640, 2107, 2106, 95149, 95125, 15786, 95150, 32673, 32670, 2129, 
32672, 95151, 95126, 15787, 15770
34823, 32520, 32519, 2038, 2037, 94806, 94798, 15470, 15462, 32552, 32551, 2060, 32553, 95153, 95129, 15755, 
95154, 95152, 95127, 15754, 15737
34824, 94806, 94798, 15470, 15462, 94807, 94799, 15471, 15463, 95153, 95129, 15755, 95154, 95156, 95132, 15757, 
95157, 95155, 95130, 15756, 15739
34825, 94807, 94799, 15471, 15463, 94808, 94800, 15472, 15464, 95156, 95132, 15757, 95157, 95159, 95135, 15759, 
95160, 95158, 95133, 15758, 15741
34826, 94808, 94800, 15472, 15464, 94809, 94801, 15473, 15465, 95159, 95135, 15759, 95160, 95162, 95138, 15761, 
95163, 95161, 95136, 15760, 15743
34827, 94809, 94801, 15473, 15465, 94810, 94802, 15474, 15466, 95162, 95138, 15761, 95163, 95165, 95141, 15763, 
95166, 95164, 95139, 15762, 15745
34828, 94810, 94802, 15474, 15466, 94811, 94803, 15475, 15467, 95165, 95141, 15763, 95166, 95168, 95144, 15765, 
95169, 95167, 95142, 15764, 15747
34829, 94811, 94803, 15475, 15467, 94812, 94804, 15476, 15468, 95168, 95144, 15765, 95169, 95171, 95147, 15767, 
95172, 95170, 95145, 15766, 15749
34830, 94812, 94804, 15476, 15468, 94813, 94805, 15477, 15469, 95171, 95147, 15767, 95172, 95174, 95150, 15769, 
95175, 95173, 95148, 15768, 15751
34831, 94813, 94805, 15477, 15469, 32642, 32641, 2106, 2105, 95174, 95150, 15769, 95175, 32675, 32672, 2128, 
32674, 95176, 95151, 15770, 15753
34832, 32521, 32520, 2037, 2036, 94814, 94806, 15462, 15454, 32554, 32553, 2059, 32555, 95178, 95154, 15738, 
95179, 95177, 95152, 15737, 15720
34833, 94814, 94806, 15462, 15454, 94815, 94807, 15463, 15455, 95178, 95154, 15738, 95179, 95181, 95157, 15740, 
95182, 95180, 95155, 15739, 15722
34834, 94815, 94807, 15463, 15455, 94816, 94808, 15464, 15456, 95181, 95157, 15740, 95182, 95184, 95160, 15742, 
95185, 95183, 95158, 15741, 15724
34835, 94816, 94808, 15464, 15456, 94817, 94809, 15465, 15457, 95184, 95160, 15742, 95185, 95187, 95163, 15744, 
95188, 95186, 95161, 15743, 15726
34836, 94817, 94809, 15465, 15457, 94818, 94810, 15466, 15458, 95187, 95163, 15744, 95188, 95190, 95166, 15746, 
95191, 95189, 95164, 15745, 15728
34837, 94818, 94810, 15466, 15458, 94819, 94811, 15467, 15459, 95190, 95166, 15746, 95191, 95193, 95169, 15748, 
95194, 95192, 95167, 15747, 15730
34838, 94819, 94811, 15467, 15459, 94820, 94812, 15468, 15460, 95193, 95169, 15748, 95194, 95196, 95172, 15750, 
95197, 95195, 95170, 15749, 15732
34839, 94820, 94812, 15468, 15460, 94821, 94813, 15469, 15461, 95196, 95172, 15750, 95197, 95199, 95175, 15752, 
95200, 95198, 95173, 15751, 15734
34840, 94821, 94813, 15469, 15461, 32643, 32642, 2105, 2104, 95199, 95175, 15752, 95200, 32677, 32674, 2127, 
32676, 95201, 95176, 15753, 15736
34841, 32522, 32521, 2036, 2035, 94822, 94814, 15454, 15446, 32556, 32555, 2058, 32557, 95203, 95179, 15721, 
95204, 95202, 95177, 15720, 15703
34842, 94822, 94814, 15454, 15446, 94823, 94815, 15455, 15447, 95203, 95179, 15721, 95204, 95206, 95182, 15723, 
95207, 95205, 95180, 15722, 15705
34843, 94823, 94815, 15455, 15447, 94824, 94816, 15456, 15448, 95206, 95182, 15723, 95207, 95209, 95185, 15725, 
95210, 95208, 95183, 15724, 15707
34844, 94824, 94816, 15456, 15448, 94825, 94817, 15457, 15449, 95209, 95185, 15725, 95210, 95212, 95188, 15727, 
95213, 95211, 95186, 15726, 15709
34845, 94825, 94817, 15457, 15449, 94826, 94818, 15458, 15450, 95212, 95188, 15727, 95213, 95215, 95191, 15729, 
95216, 95214, 95189, 15728, 15711
34846, 94826, 94818, 15458, 15450, 94827, 94819, 15459, 15451, 95215, 95191, 15729, 95216, 95218, 95194, 15731, 
95219, 95217, 95192, 15730, 15713
34847, 94827, 94819, 15459, 15451, 94828, 94820, 15460, 15452, 95218, 95194, 15731, 95219, 95221, 95197, 15733, 
95222, 95220, 95195, 15732, 15715
34848, 94828, 94820, 15460, 15452, 94829, 94821, 15461, 15453, 95221, 95197, 15733, 95222, 95224, 95200, 15735, 
95225, 95223, 95198, 15734, 15717
34849, 94829, 94821, 15461, 15453, 32644, 32643, 2104, 2103, 95224, 95200, 15735, 95225, 32679, 32676, 2126, 
32678, 95226, 95201, 15736, 15719
34850, 32523, 32522, 2035, 2034, 94830, 94822, 15446, 15438, 32558, 32557, 2057, 32559, 95228, 95204, 15704, 
95229, 95227, 95202, 15703, 15686
34851, 94830, 94822, 15446, 15438, 94831, 94823, 15447, 15439, 95228, 95204, 15704, 95229, 95231, 95207, 15706, 
95232, 95230, 95205, 15705, 15688
34852, 94831, 94823, 15447, 15439, 94832, 94824, 15448, 15440, 95231, 95207, 15706, 95232, 95234, 95210, 15708, 
95235, 95233, 95208, 15707, 15690
34853, 94832, 94824, 15448, 15440, 94833, 94825, 15449, 15441, 95234, 95210, 15708, 95235, 95237, 95213, 15710, 
95238, 95236, 95211, 15709, 15692
34854, 94833, 94825, 15449, 15441, 94834, 94826, 15450, 15442, 95237, 95213, 15710, 95238, 95240, 95216, 15712, 
95241, 95239, 95214, 15711, 15694
34855, 94834, 94826, 15450, 15442, 94835, 94827, 15451, 15443, 95240, 95216, 15712, 95241, 95243, 95219, 15714, 
95244, 95242, 95217, 15713, 15696
34856, 94835, 94827, 15451, 15443, 94836, 94828, 15452, 15444, 95243, 95219, 15714, 95244, 95246, 95222, 15716, 
95247, 95245, 95220, 15715, 15698
34857, 94836, 94828, 15452, 15444, 94837, 94829, 15453, 15445, 95246, 95222, 15716, 95247, 95249, 95225, 15718, 
95250, 95248, 95223, 15717, 15700
34858, 94837, 94829, 15453, 15445, 32645, 32644, 2103, 2102, 95249, 95225, 15718, 95250, 32681, 32678, 2125, 
32680, 95251, 95226, 15719, 15702
34859, 32524, 32523, 2034, 2033, 94838, 94830, 15438, 15430, 32560, 32559, 2056, 32561, 95253, 95229, 15687, 
95254, 95252, 95227, 15686, 15669
34860, 94838, 94830, 15438, 15430, 94839, 94831, 15439, 15431, 95253, 95229, 15687, 95254, 95256, 95232, 15689, 
95257, 95255, 95230, 15688, 15671
34861, 94839, 94831, 15439, 15431, 94840, 94832, 15440, 15432, 95256, 95232, 15689, 95257, 95259, 95235, 15691, 
95260, 95258, 95233, 15690, 15673
34862, 94840, 94832, 15440, 15432, 94841, 94833, 15441, 15433, 95259, 95235, 15691, 95260, 95262, 95238, 15693, 
95263, 95261, 95236, 15692, 15675
34863, 94841, 94833, 15441, 15433, 94842, 94834, 15442, 15434, 95262, 95238, 15693, 95263, 95265, 95241, 15695, 
95266, 95264, 95239, 15694, 15677
34864, 94842, 94834, 15442, 15434, 94843, 94835, 15443, 15435, 95265, 95241, 15695, 95266, 95268, 95244, 15697, 
95269, 95267, 95242, 15696, 15679
34865, 94843, 94835, 15443, 15435, 94844, 94836, 15444, 15436, 95268, 95244, 15697, 95269, 95271, 95247, 15699, 
95272, 95270, 95245, 15698, 15681
34866, 94844, 94836, 15444, 15436, 94845, 94837, 15445, 15437, 95271, 95247, 15699, 95272, 95274, 95250, 15701, 
95275, 95273, 95248, 15700, 15683
34867, 94845, 94837, 15445, 15437, 32646, 32645, 2102, 2101, 95274, 95250, 15701, 95275, 32683, 32680, 2124, 
32682, 95276, 95251, 15702, 15685
34868, 32525, 32524, 2033, 2032, 94846, 94838, 15430, 15422, 32562, 32561, 2055, 32563, 95278, 95254, 15670, 
95279, 95277, 95252, 15669, 15652
34869, 94846, 94838, 15430, 15422, 94847, 94839, 15431, 15423, 95278, 95254, 15670, 95279, 95281, 95257, 15672, 
95282, 95280, 95255, 15671, 15654
34870, 94847, 94839, 15431, 15423, 94848, 94840, 15432, 15424, 95281, 95257, 15672, 95282, 95284, 95260, 15674, 
95285, 95283, 95258, 15673, 15656
34871, 94848, 94840, 15432, 15424, 94849, 94841, 15433, 15425, 95284, 95260, 15674, 95285, 95287, 95263, 15676, 
95288, 95286, 95261, 15675, 15658
34872, 94849, 94841, 15433, 15425, 94850, 94842, 15434, 15426, 95287, 95263, 15676, 95288, 95290, 95266, 15678, 
95291, 95289, 95264, 15677, 15660
34873, 94850, 94842, 15434, 15426, 94851, 94843, 15435, 15427, 95290, 95266, 15678, 95291, 95293, 95269, 15680, 
95294, 95292, 95267, 15679, 15662
34874, 94851, 94843, 15435, 15427, 94852, 94844, 15436, 15428, 95293, 95269, 15680, 95294, 95296, 95272, 15682, 
95297, 95295, 95270, 15681, 15664
34875, 94852, 94844, 15436, 15428, 94853, 94845, 15437, 15429, 95296, 95272, 15682, 95297, 95299, 95275, 15684, 
95300, 95298, 95273, 15683, 15666
34876, 94853, 94845, 15437, 15429, 32647, 32646, 2101, 2100, 95299, 95275, 15684, 95300, 32685, 32682, 2123, 
32684, 95301, 95276, 15685, 15668
34877, 32526, 32525, 2032, 2031, 94854, 94846, 15422, 15414, 32564, 32563, 2054, 32565, 95303, 95279, 15653, 
95304, 95302, 95277, 15652, 15635
34878, 94854, 94846, 15422, 15414, 94855, 94847, 15423, 15415, 95303, 95279, 15653, 95304, 95306, 95282, 15655, 
95307, 95305, 95280, 15654, 15637
34879, 94855, 94847, 15423, 15415, 94856, 94848, 15424, 15416, 95306, 95282, 15655, 95307, 95309, 95285, 15657, 
95310, 95308, 95283, 15656, 15639
34880, 94856, 94848, 15424, 15416, 94857, 94849, 15425, 15417, 95309, 95285, 15657, 95310, 95312, 95288, 15659, 
95313, 95311, 95286, 15658, 15641
34881, 94857, 94849, 15425, 15417, 94858, 94850, 15426, 15418, 95312, 95288, 15659, 95313, 95315, 95291, 15661, 
95316, 95314, 95289, 15660, 15643
34882, 94858, 94850, 15426, 15418, 94859, 94851, 15427, 15419, 95315, 95291, 15661, 95316, 95318, 95294, 15663, 
95319, 95317, 95292, 15662, 15645
34883, 94859, 94851, 15427, 15419, 94860, 94852, 15428, 15420, 95318, 95294, 15663, 95319, 95321, 95297, 15665, 
95322, 95320, 95295, 15664, 15647
34884, 94860, 94852, 15428, 15420, 94861, 94853, 15429, 15421, 95321, 95297, 15665, 95322, 95324, 95300, 15667, 
95325, 95323, 95298, 15666, 15649
34885, 94861, 94853, 15429, 15421, 32648, 32647, 2100, 2099, 95324, 95300, 15667, 95325, 32687, 32684, 2122, 
32686, 95326, 95301, 15668, 15651
34886, 32527, 32526, 2031, 2030, 94862, 94854, 15414, 15406, 32566, 32565, 2053, 32567, 95328, 95304, 15636, 
95329, 95327, 95302, 15635, 15618
34887, 94862, 94854, 15414, 15406, 94863, 94855, 15415, 15407, 95328, 95304, 15636, 95329, 95331, 95307, 15638, 
95332, 95330, 95305, 15637, 15620
34888, 94863, 94855, 15415, 15407, 94864, 94856, 15416, 15408, 95331, 95307, 15638, 95332, 95334, 95310, 15640, 
95335, 95333, 95308, 15639, 15622
34889, 94864, 94856, 15416, 15408, 94865, 94857, 15417, 15409, 95334, 95310, 15640, 95335, 95337, 95313, 15642, 
95338, 95336, 95311, 15641, 15624
34890, 94865, 94857, 15417, 15409, 94866, 94858, 15418, 15410, 95337, 95313, 15642, 95338, 95340, 95316, 15644, 
95341, 95339, 95314, 15643, 15626
34891, 94866, 94858, 15418, 15410, 94867, 94859, 15419, 15411, 95340, 95316, 15644, 95341, 95343, 95319, 15646, 
95344, 95342, 95317, 15645, 15628
34892, 94867, 94859, 15419, 15411, 94868, 94860, 15420, 15412, 95343, 95319, 15646, 95344, 95346, 95322, 15648, 
95347, 95345, 95320, 15647, 15630
34893, 94868, 94860, 15420, 15412, 94869, 94861, 15421, 15413, 95346, 95322, 15648, 95347, 95349, 95325, 15650, 
95350, 95348, 95323, 15649, 15632
34894, 94869, 94861, 15421, 15413, 32649, 32648, 2099, 2098, 95349, 95325, 15650, 95350, 32689, 32686, 2121, 
32688, 95351, 95326, 15651, 15634
34895, 32528, 32527, 2030, 2029, 94870, 94862, 15406, 15398, 32568, 32567, 2052, 32569, 95353, 95329, 15619, 
95354, 95352, 95327, 15618, 15601
34896, 94870, 94862, 15406, 15398, 94871, 94863, 15407, 15399, 95353, 95329, 15619, 95354, 95356, 95332, 15621, 
95357, 95355, 95330, 15620, 15603
34897, 94871, 94863, 15407, 15399, 94872, 94864, 15408, 15400, 95356, 95332, 15621, 95357, 95359, 95335, 15623, 
95360, 95358, 95333, 15622, 15605
34898, 94872, 94864, 15408, 15400, 94873, 94865, 15409, 15401, 95359, 95335, 15623, 95360, 95362, 95338, 15625, 
95363, 95361, 95336, 15624, 15607
34899, 94873, 94865, 15409, 15401, 94874, 94866, 15410, 15402, 95362, 95338, 15625, 95363, 95365, 95341, 15627, 
95366, 95364, 95339, 15626, 15609
34900, 94874, 94866, 15410, 15402, 94875, 94867, 15411, 15403, 95365, 95341, 15627, 95366, 95368, 95344, 15629, 
95369, 95367, 95342, 15628, 15611
34901, 94875, 94867, 15411, 15403, 94876, 94868, 15412, 15404, 95368, 95344, 15629, 95369, 95371, 95347, 15631, 
95372, 95370, 95345, 15630, 15613
34902, 94876, 94868, 15412, 15404, 94877, 94869, 15413, 15405, 95371, 95347, 15631, 95372, 95374, 95350, 15633, 
95375, 95373, 95348, 15632, 15615
34903, 94877, 94869, 15413, 15405, 32650, 32649, 2098, 2097, 95374, 95350, 15633, 95375, 32691, 32688, 2120, 
32690, 95376, 95351, 15634, 15617
34904, 32529, 32528, 2029, 2028, 94878, 94870, 15398, 15390, 32570, 32569, 2051, 32571, 95378, 95354, 15602, 
95379, 95377, 95352, 15601, 15584
34905, 94878, 94870, 15398, 15390, 94879, 94871, 15399, 15391, 95378, 95354, 15602, 95379, 95381, 95357, 15604, 
95382, 95380, 95355, 15603, 15586
34906, 94879, 94871, 15399, 15391, 94880, 94872, 15400, 15392, 95381, 95357, 15604, 95382, 95384, 95360, 15606, 
95385, 95383, 95358, 15605, 15588
34907, 94880, 94872, 15400, 15392, 94881, 94873, 15401, 15393, 95384, 95360, 15606, 95385, 95387, 95363, 15608, 
95388, 95386, 95361, 15607, 15590
34908, 94881, 94873, 15401, 15393, 94882, 94874, 15402, 15394, 95387, 95363, 15608, 95388, 95390, 95366, 15610, 
95391, 95389, 95364, 15609, 15592
34909, 94882, 94874, 15402, 15394, 94883, 94875, 15403, 15395, 95390, 95366, 15610, 95391, 95393, 95369, 15612, 
95394, 95392, 95367, 15611, 15594
34910, 94883, 94875, 15403, 15395, 94884, 94876, 15404, 15396, 95393, 95369, 15612, 95394, 95396, 95372, 15614, 
95397, 95395, 95370, 15613, 15596
34911, 94884, 94876, 15404, 15396, 94885, 94877, 15405, 15397, 95396, 95372, 15614, 95397, 95399, 95375, 15616, 
95400, 95398, 95373, 15615, 15598
34912, 94885, 94877, 15405, 15397, 32651, 32650, 2097, 2096, 95399, 95375, 15616, 95400, 32693, 32690, 2119, 
32692, 95401, 95376, 15617, 15600
34913, 32530, 32529, 2028, 2027, 94886, 94878, 15390, 15382, 32572, 32571, 2050, 32573, 95403, 95379, 15585, 
95404, 95402, 95377, 15584, 15567
34914, 94886, 94878, 15390, 15382, 94887, 94879, 15391, 15383, 95403, 95379, 15585, 95404, 95406, 95382, 15587, 
95407, 95405, 95380, 15586, 15569
34915, 94887, 94879, 15391, 15383, 94888, 94880, 15392, 15384, 95406, 95382, 15587, 95407, 95409, 95385, 15589, 
95410, 95408, 95383, 15588, 15571
34916, 94888, 94880, 15392, 15384, 94889, 94881, 15393, 15385, 95409, 95385, 15589, 95410, 95412, 95388, 15591, 
95413, 95411, 95386, 15590, 15573
34917, 94889, 94881, 15393, 15385, 94890, 94882, 15394, 15386, 95412, 95388, 15591, 95413, 95415, 95391, 15593, 
95416, 95414, 95389, 15592, 15575
34918, 94890, 94882, 15394, 15386, 94891, 94883, 15395, 15387, 95415, 95391, 15593, 95416, 95418, 95394, 15595, 
95419, 95417, 95392, 15594, 15577
34919, 94891, 94883, 15395, 15387, 94892, 94884, 15396, 15388, 95418, 95394, 15595, 95419, 95421, 95397, 15597, 
95422, 95420, 95395, 15596, 15579
34920, 94892, 94884, 15396, 15388, 94893, 94885, 15397, 15389, 95421, 95397, 15597, 95422, 95424, 95400, 15599, 
95425, 95423, 95398, 15598, 15581
34921, 94893, 94885, 15397, 15389, 32652, 32651, 2096, 2095, 95424, 95400, 15599, 95425, 32695, 32692, 2118, 
32694, 95426, 95401, 15600, 15583
34922, 32531, 32530, 2027, 2026, 94894, 94886, 15382, 15374, 32574, 32573, 2049, 32575, 95428, 95404, 15568, 
95429, 95427, 95402, 15567, 15550
34923, 94894, 94886, 15382, 15374, 94895, 94887, 15383, 15375, 95428, 95404, 15568, 95429, 95431, 95407, 15570, 
95432, 95430, 95405, 15569, 15552
34924, 94895, 94887, 15383, 15375, 94896, 94888, 15384, 15376, 95431, 95407, 15570, 95432, 95434, 95410, 15572, 
95435, 95433, 95408, 15571, 15554
34925, 94896, 94888, 15384, 15376, 94897, 94889, 15385, 15377, 95434, 95410, 15572, 95435, 95437, 95413, 15574, 
95438, 95436, 95411, 15573, 15556
34926, 94897, 94889, 15385, 15377, 94898, 94890, 15386, 15378, 95437, 95413, 15574, 95438, 95440, 95416, 15576, 
95441, 95439, 95414, 15575, 15558
34927, 94898, 94890, 15386, 15378, 94899, 94891, 15387, 15379, 95440, 95416, 15576, 95441, 95443, 95419, 15578, 
95444, 95442, 95417, 15577, 15560
34928, 94899, 94891, 15387, 15379, 94900, 94892, 15388, 15380, 95443, 95419, 15578, 95444, 95446, 95422, 15580, 
95447, 95445, 95420, 15579, 15562
34929, 94900, 94892, 15388, 15380, 94901, 94893, 15389, 15381, 95446, 95422, 15580, 95447, 95449, 95425, 15582, 
95450, 95448, 95423, 15581, 15564
34930, 94901, 94893, 15389, 15381, 32653, 32652, 2095, 2094, 95449, 95425, 15582, 95450, 32697, 32694, 2117, 
32696, 95451, 95426, 15583, 15566
34931, 3876, 32531, 2026, 68, 32728, 94894, 15374, 2139, 32576, 32575, 2048, 3877, 95452, 95429, 15551, 
32743, 32745, 95427, 15550, 2147
34932, 32728, 94894, 15374, 2139, 32727, 94895, 15375, 2140, 95452, 95429, 15551, 32743, 95453, 95432, 15553, 
32741, 32744, 95430, 15552, 2148
34933, 32727, 94895, 15375, 2140, 32726, 94896, 15376, 2141, 95453, 95432, 15553, 32741, 95454, 95435, 15555, 
32739, 32742, 95433, 15554, 2149
34934, 32726, 94896, 15376, 2141, 32725, 94897, 15377, 2142, 95454, 95435, 15555, 32739, 95455, 95438, 15557, 
32737, 32740, 95436, 15556, 2150
34935, 32725, 94897, 15377, 2142, 32724, 94898, 15378, 2143, 95455, 95438, 15557, 32737, 95456, 95441, 15559, 
32735, 32738, 95439, 15558, 2151
34936, 32724, 94898, 15378, 2143, 32723, 94899, 15379, 2144, 95456, 95441, 15559, 32735, 95457, 95444, 15561, 
32733, 32736, 95442, 15560, 2152
34937, 32723, 94899, 15379, 2144, 32722, 94900, 15380, 2145, 95457, 95444, 15561, 32733, 95458, 95447, 15563, 
32731, 32734, 95445, 15562, 2153
34938, 32722, 94900, 15380, 2145, 32721, 94901, 15381, 2146, 95458, 95447, 15563, 32731, 95459, 95450, 15565, 
32729, 32732, 95448, 15564, 2154
34939, 32721, 94901, 15381, 2146, 3882, 32653, 2094, 70, 95459, 95450, 15565, 32729, 32698, 32696, 2116, 
3883, 32730, 95451, 15566, 2155
34940, 2944, 89, 3873, 32510, 24560, 3013, 32606, 94726, 2967, 3875, 32532, 32577, 24942, 32631, 94903, 
95460, 24926, 3021, 32623, 94902
34941, 24560, 3013, 32606, 94726, 24561, 3014, 32605, 94727, 24942, 32631, 94903, 95460, 24943, 32630, 94906, 
95461, 24928, 3022, 32621, 94905
34942, 24561, 3014, 32605, 94727, 24562, 3015, 32604, 94728, 24943, 32630, 94906, 95461, 24944, 32629, 94909, 
95462, 24930, 3023, 32619, 94908
34943, 24562, 3015, 32604, 94728, 24563, 3016, 32603, 94729, 24944, 32629, 94909, 95462, 24945, 32628, 94912, 
95463, 24932, 3024, 32617, 94911
34944, 24563, 3016, 32603, 94729, 24564, 3017, 32602, 94730, 24945, 32628, 94912, 95463, 24946, 32627, 94915, 
95464, 24934, 3025, 32615, 94914
34945, 24564, 3017, 32602, 94730, 24565, 3018, 32601, 94731, 24946, 32627, 94915, 95464, 24947, 32626, 94918, 
95465, 24936, 3026, 32613, 94917
34946, 24565, 3018, 32601, 94731, 24566, 3019, 32600, 94732, 24947, 32626, 94918, 95465, 24948, 32625, 94921, 
95466, 24938, 3027, 32611, 94920
34947, 24566, 3019, 32600, 94732, 24567, 3020, 32599, 94733, 24948, 32625, 94921, 95466, 24949, 32624, 94924, 
95467, 24940, 3028, 32609, 94923
34948, 24567, 3020, 32599, 94733, 3096, 91, 3879, 32632, 24949, 32624, 94924, 95467, 3119, 3881, 32655, 
32699, 24941, 3029, 32607, 94926
34949, 2943, 2944, 32510, 32511, 24552, 24560, 94726, 94734, 2966, 32577, 32534, 32578, 24925, 95460, 94928, 
95468, 24909, 24926, 94902, 94927
34950, 24552, 24560, 94726, 94734, 24553, 24561, 94727, 94735, 24925, 95460, 94928, 95468, 24927, 95461, 94931, 
95469, 24911, 24928, 94905, 94930
34951, 24553, 24561, 94727, 94735, 24554, 24562, 94728, 94736, 24927, 95461, 94931, 95469, 24929, 95462, 94934, 
95470, 24913, 24930, 94908, 94933
34952, 24554, 24562, 94728, 94736, 24555, 24563, 94729, 94737, 24929, 95462, 94934, 95470, 24931, 95463, 94937, 
95471, 24915, 24932, 94911, 94936
34953, 24555, 24563, 94729, 94737, 24556, 24564, 94730, 94738, 24931, 95463, 94937, 95471, 24933, 95464, 94940, 
95472, 24917, 24934, 94914, 94939
34954, 24556, 24564, 94730, 94738, 24557, 24565, 94731, 94739, 24933, 95464, 94940, 95472, 24935, 95465, 94943, 
95473, 24919, 24936, 94917, 94942
34955, 24557, 24565, 94731, 94739, 24558, 24566, 94732, 94740, 24935, 95465, 94943, 95473, 24937, 95466, 94946, 
95474, 24921, 24938, 94920, 94945
34956, 24558, 24566, 94732, 94740, 24559, 24567, 94733, 94741, 24937, 95466, 94946, 95474, 24939, 95467, 94949, 
95475, 24923, 24940, 94923, 94948
34957, 24559, 24567, 94733, 94741, 3095, 3096, 32632, 32633, 24939, 95467, 94949, 95475, 3118, 32699, 32657, 
32700, 24924, 24941, 94926, 94951
34958, 2942, 2943, 32511, 32512, 24544, 24552, 94734, 94742, 2965, 32578, 32536, 32579, 24908, 95468, 94953, 
95476, 24892, 24909, 94927, 94952
34959, 24544, 24552, 94734, 94742, 24545, 24553, 94735, 94743, 24908, 95468, 94953, 95476, 24910, 95469, 94956, 
95477, 24894, 24911, 94930, 94955
34960, 24545, 24553, 94735, 94743, 24546, 24554, 94736, 94744, 24910, 95469, 94956, 95477, 24912, 95470, 94959, 
95478, 24896, 24913, 94933, 94958
34961, 24546, 24554, 94736, 94744, 24547, 24555, 94737, 94745, 24912, 95470, 94959, 95478, 24914, 95471, 94962, 
95479, 24898, 24915, 94936, 94961
34962, 24547, 24555, 94737, 94745, 24548, 24556, 94738, 94746, 24914, 95471, 94962, 95479, 24916, 95472, 94965, 
95480, 24900, 24917, 94939, 94964
34963, 24548, 24556, 94738, 94746, 24549, 24557, 94739, 94747, 24916, 95472, 94965, 95480, 24918, 95473, 94968, 
95481, 24902, 24919, 94942, 94967
34964, 24549, 24557, 94739, 94747, 24550, 24558, 94740, 94748, 24918, 95473, 94968, 95481, 24920, 95474, 94971, 
95482, 24904, 24921, 94945, 94970
34965, 24550, 24558, 94740, 94748, 24551, 24559, 94741, 94749, 24920, 95474, 94971, 95482, 24922, 95475, 94974, 
95483, 24906, 24923, 94948, 94973
34966, 24551, 24559, 94741, 94749, 3094, 3095, 32633, 32634, 24922, 95475, 94974, 95483, 3117, 32700, 32659, 
32701, 24907, 24924, 94951, 94976
34967, 2941, 2942, 32512, 32513, 24536, 24544, 94742, 94750, 2964, 32579, 32538, 32580, 24891, 95476, 94978, 
95484, 24875, 24892, 94952, 94977
34968, 24536, 24544, 94742, 94750, 24537, 24545, 94743, 94751, 24891, 95476, 94978, 95484, 24893, 95477, 94981, 
95485, 24877, 24894, 94955, 94980
34969, 24537, 24545, 94743, 94751, 24538, 24546, 94744, 94752, 24893, 95477, 94981, 95485, 24895, 95478, 94984, 
95486, 24879, 24896, 94958, 94983
34970, 24538, 24546, 94744, 94752, 24539, 24547, 94745, 94753, 24895, 95478, 94984, 95486, 24897, 95479, 94987, 
95487, 24881, 24898, 94961, 94986
34971, 24539, 24547, 94745, 94753, 24540, 24548, 94746, 94754, 24897, 95479, 94987, 95487, 24899, 95480, 94990, 
95488, 24883, 24900, 94964, 94989
34972, 24540, 24548, 94746, 94754, 24541, 24549, 94747, 94755, 24899, 95480, 94990, 95488, 24901, 95481, 94993, 
95489, 24885, 24902, 94967, 94992
34973, 24541, 24549, 94747, 94755, 24542, 24550, 94748, 94756, 24901, 95481, 94993, 95489, 24903, 95482, 94996, 
95490, 24887, 24904, 94970, 94995
34974, 24542, 24550, 94748, 94756, 24543, 24551, 94749, 94757, 24903, 95482, 94996, 95490, 24905, 95483, 94999, 
95491, 24889, 24906, 94973, 94998
34975, 24543, 24551, 94749, 94757, 3093, 3094, 32634, 32635, 24905, 95483, 94999, 95491, 3116, 32701, 32661, 
32702, 24890, 24907, 94976, 95001
34976, 2940, 2941, 32513, 32514, 24528, 24536, 94750, 94758, 2963, 32580, 32540, 32581, 24874, 95484, 95003, 
95492, 24858, 24875, 94977, 95002
34977, 24528, 24536, 94750, 94758, 24529, 24537, 94751, 94759, 24874, 95484, 95003, 95492, 24876, 95485, 95006, 
95493, 24860, 24877, 94980, 95005
34978, 24529, 24537, 94751, 94759, 24530, 24538, 94752, 94760, 24876, 95485, 95006, 95493, 24878, 95486, 95009, 
95494, 24862, 24879, 94983, 95008
34979, 24530, 24538, 94752, 94760, 24531, 24539, 94753, 94761, 24878, 95486, 95009, 95494, 24880, 95487, 95012, 
95495, 24864, 24881, 94986, 95011
34980, 24531, 24539, 94753, 94761, 24532, 24540, 94754, 94762, 24880, 95487, 95012, 95495, 24882, 95488, 95015, 
95496, 24866, 24883, 94989, 95014
34981, 24532, 24540, 94754, 94762, 24533, 24541, 94755, 94763, 24882, 95488, 95015, 95496, 24884, 95489, 95018, 
95497, 24868, 24885, 94992, 95017
34982, 24533, 24541, 94755, 94763, 24534, 24542, 94756, 94764, 24884, 95489, 95018, 95497, 24886, 95490, 95021, 
95498, 24870, 24887, 94995, 95020
34983, 24534, 24542, 94756, 94764, 24535, 24543, 94757, 94765, 24886, 95490, 95021, 95498, 24888, 95491, 95024, 
95499, 24872, 24889, 94998, 95023
34984, 24535, 24543, 94757, 94765, 3092, 3093, 32635, 32636, 24888, 95491, 95024, 95499, 3115, 32702, 32663, 
32703, 24873, 24890, 95001, 95026
34985, 2939, 2940, 32514, 32515, 24520, 24528, 94758, 94766, 2962, 32581, 32542, 32582, 24857, 95492, 95028, 
95500, 24841, 24858, 95002, 95027
34986, 24520, 24528, 94758, 94766, 24521, 24529, 94759, 94767, 24857, 95492, 95028, 95500, 24859, 95493, 95031, 
95501, 24843, 24860, 95005, 95030
34987, 24521, 24529, 94759, 94767, 24522, 24530, 94760, 94768, 24859, 95493, 95031, 95501, 24861, 95494, 95034, 
95502, 24845, 24862, 95008, 95033
34988, 24522, 24530, 94760, 94768, 24523, 24531, 94761, 94769, 24861, 95494, 95034, 95502, 24863, 95495, 95037, 
95503, 24847, 24864, 95011, 95036
34989, 24523, 24531, 94761, 94769, 24524, 24532, 94762, 94770, 24863, 95495, 95037, 95503, 24865, 95496, 95040, 
95504, 24849, 24866, 95014, 95039
34990, 24524, 24532, 94762, 94770, 24525, 24533, 94763, 94771, 24865, 95496, 95040, 95504, 24867, 95497, 95043, 
95505, 24851, 24868, 95017, 95042
34991, 24525, 24533, 94763, 94771, 24526, 24534, 94764, 94772, 24867, 95497, 95043, 95505, 24869, 95498, 95046, 
95506, 24853, 24870, 95020, 95045
34992, 24526, 24534, 94764, 94772, 24527, 24535, 94765, 94773, 24869, 95498, 95046, 95506, 24871, 95499, 95049, 
95507, 24855, 24872, 95023, 95048
34993, 24527, 24535, 94765, 94773, 3091, 3092, 32636, 32637, 24871, 95499, 95049, 95507, 3114, 32703, 32665, 
32704, 24856, 24873, 95026, 95051
34994, 2938, 2939, 32515, 32516, 24512, 24520, 94766, 94774, 2961, 32582, 32544, 32583, 24840, 95500, 95053, 
95508, 24824, 24841, 95027, 95052
34995, 24512, 24520, 94766, 94774, 24513, 24521, 94767, 94775, 24840, 95500, 95053, 95508, 24842, 95501, 95056, 
95509, 24826, 24843, 95030, 95055
34996, 24513, 24521, 94767, 94775, 24514, 24522, 94768, 94776, 24842, 95501, 95056, 95509, 24844, 95502, 95059, 
95510, 24828, 24845, 95033, 95058
34997, 24514, 24522, 94768, 94776, 24515, 24523, 94769, 94777, 24844, 95502, 95059, 95510, 24846, 95503, 95062, 
95511, 24830, 24847, 95036, 95061
34998, 24515, 24523, 94769, 94777, 24516, 24524, 94770, 94778, 24846, 95503, 95062, 95511, 24848, 95504, 95065, 
95512, 24832, 24849, 95039, 95064
34999, 24516, 24524, 94770, 94778, 24517, 24525, 94771, 94779, 24848, 95504, 95065, 95512, 24850, 95505, 95068, 
95513, 24834, 24851, 95042, 95067
35000, 24517, 24525, 94771, 94779, 24518, 24526, 94772, 94780, 24850, 95505, 95068, 95513, 24852, 95506, 95071, 
95514, 24836, 24853, 95045, 95070
35001, 24518, 24526, 94772, 94780, 24519, 24527, 94773, 94781, 24852, 95506, 95071, 95514, 24854, 95507, 95074, 
95515, 24838, 24855, 95048, 95073
35002, 24519, 24527, 94773, 94781, 3090, 3091, 32637, 32638, 24854, 95507, 95074, 95515, 3113, 32704, 32667, 
32705, 24839, 24856, 95051, 95076
35003, 2937, 2938, 32516, 32517, 24504, 24512, 94774, 94782, 2960, 32583, 32546, 32584, 24823, 95508, 95078, 
95516, 24807, 24824, 95052, 95077
35004, 24504, 24512, 94774, 94782, 24505, 24513, 94775, 94783, 24823, 95508, 95078, 95516, 24825, 95509, 95081, 
95517, 24809, 24826, 95055, 95080
35005, 24505, 24513, 94775, 94783, 24506, 24514, 94776, 94784, 24825, 95509, 95081, 95517, 24827, 95510, 95084, 
95518, 24811, 24828, 95058, 95083
35006, 24506, 24514, 94776, 94784, 24507, 24515, 94777, 94785, 24827, 95510, 95084, 95518, 24829, 95511, 95087, 
95519, 24813, 24830, 95061, 95086
35007, 24507, 24515, 94777, 94785, 24508, 24516, 94778, 94786, 24829, 95511, 95087, 95519, 24831, 95512, 95090, 
95520, 24815, 24832, 95064, 95089
35008, 24508, 24516, 94778, 94786, 24509, 24517, 94779, 94787, 24831, 95512, 95090, 95520, 24833, 95513, 95093, 
95521, 24817, 24834, 95067, 95092
35009, 24509, 24517, 94779, 94787, 24510, 24518, 94780, 94788, 24833, 95513, 95093, 95521, 24835, 95514, 95096, 
95522, 24819, 24836, 95070, 95095
35010, 24510, 24518, 94780, 94788, 24511, 24519, 94781, 94789, 24835, 95514, 95096, 95522, 24837, 95515, 95099, 
95523, 24821, 24838, 95073, 95098
35011, 24511, 24519, 94781, 94789, 3089, 3090, 32638, 32639, 24837, 95515, 95099, 95523, 3112, 32705, 32669, 
32706, 24822, 24839, 95076, 95101
35012, 2936, 2937, 32517, 32518, 24496, 24504, 94782, 94790, 2959, 32584, 32548, 32585, 24806, 95516, 95103, 
95524, 24790, 24807, 95077, 95102
35013, 24496, 24504, 94782, 94790, 24497, 24505, 94783, 94791, 24806, 95516, 95103, 95524, 24808, 95517, 95106, 
95525, 24792, 24809, 95080, 95105
35014, 24497, 24505, 94783, 94791, 24498, 24506, 94784, 94792, 24808, 95517, 95106, 95525, 24810, 95518, 95109, 
95526, 24794, 24811, 95083, 95108
35015, 24498, 24506, 94784, 94792, 24499, 24507, 94785, 94793, 24810, 95518, 95109, 95526, 24812, 95519, 95112, 
95527, 24796, 24813, 95086, 95111
35016, 24499, 24507, 94785, 94793, 24500, 24508, 94786, 94794, 24812, 95519, 95112, 95527, 24814, 95520, 95115, 
95528, 24798, 24815, 95089, 95114
35017, 24500, 24508, 94786, 94794, 24501, 24509, 94787, 94795, 24814, 95520, 95115, 95528, 24816, 95521, 95118, 
95529, 24800, 24817, 95092, 95117
35018, 24501, 24509, 94787, 94795, 24502, 24510, 94788, 94796, 24816, 95521, 95118, 95529, 24818, 95522, 95121, 
95530, 24802, 24819, 95095, 95120
35019, 24502, 24510, 94788, 94796, 24503, 24511, 94789, 94797, 24818, 95522, 95121, 95530, 24820, 95523, 95124, 
95531, 24804, 24821, 95098, 95123
35020, 24503, 24511, 94789, 94797, 3088, 3089, 32639, 32640, 24820, 95523, 95124, 95531, 3111, 32706, 32671, 
32707, 24805, 24822, 95101, 95126
35021, 2935, 2936, 32518, 32519, 24488, 24496, 94790, 94798, 2958, 32585, 32550, 32586, 24789, 95524, 95128, 
95532, 24773, 24790, 95102, 95127
35022, 24488, 24496, 94790, 94798, 24489, 24497, 94791, 94799, 24789, 95524, 95128, 95532, 24791, 95525, 95131, 
95533, 24775, 24792, 95105, 95130
35023, 24489, 24497, 94791, 94799, 24490, 24498, 94792, 94800, 24791, 95525, 95131, 95533, 24793, 95526, 95134, 
95534, 24777, 24794, 95108, 95133
35024, 24490, 24498, 94792, 94800, 24491, 24499, 94793, 94801, 24793, 95526, 95134, 95534, 24795, 95527, 95137, 
95535, 24779, 24796, 95111, 95136
35025, 24491, 24499, 94793, 94801, 24492, 24500, 94794, 94802, 24795, 95527, 95137, 95535, 24797, 95528, 95140, 
95536, 24781, 24798, 95114, 95139
35026, 24492, 24500, 94794, 94802, 24493, 24501, 94795, 94803, 24797, 95528, 95140, 95536, 24799, 95529, 95143, 
95537, 24783, 24800, 95117, 95142
35027, 24493, 24501, 94795, 94803, 24494, 24502, 94796, 94804, 24799, 95529, 95143, 95537, 24801, 95530, 95146, 
95538, 24785, 24802, 95120, 95145
35028, 24494, 24502, 94796, 94804, 24495, 24503, 94797, 94805, 24801, 95530, 95146, 95538, 24803, 95531, 95149, 
95539, 24787, 24804, 95123, 95148
35029, 24495, 24503, 94797, 94805, 3087, 3088, 32640, 32641, 24803, 95531, 95149, 95539, 3110, 32707, 32673, 
32708, 24788, 24805, 95126, 95151
35030, 2934, 2935, 32519, 32520, 24480, 24488, 94798, 94806, 2957, 32586, 32552, 32587, 24772, 95532, 95153, 
95540, 24756, 24773, 95127, 95152
35031, 24480, 24488, 94798, 94806, 24481, 24489, 94799, 94807, 24772, 95532, 95153, 95540, 24774, 95533, 95156, 
95541, 24758, 24775, 95130, 95155
35032, 24481, 24489, 94799, 94807, 24482, 24490, 94800, 94808, 24774, 95533, 95156, 95541, 24776, 95534, 95159, 
95542, 24760, 24777, 95133, 95158
35033, 24482, 24490, 94800, 94808, 24483, 24491, 94801, 94809, 24776, 95534, 95159, 95542, 24778, 95535, 95162, 
95543, 24762, 24779, 95136, 95161
35034, 24483, 24491, 94801, 94809, 24484, 24492, 94802, 94810, 24778, 95535, 95162, 95543, 24780, 95536, 95165, 
95544, 24764, 24781, 95139, 95164
35035, 24484, 24492, 94802, 94810, 24485, 24493, 94803, 94811, 24780, 95536, 95165, 95544, 24782, 95537, 95168, 
95545, 24766, 24783, 95142, 95167
35036, 24485, 24493, 94803, 94811, 24486, 24494, 94804, 94812, 24782, 95537, 95168, 95545, 24784, 95538, 95171, 
95546, 24768, 24785, 95145, 95170
35037, 24486, 24494, 94804, 94812, 24487, 24495, 94805, 94813, 24784, 95538, 95171, 95546, 24786, 95539, 95174, 
95547, 24770, 24787, 95148, 95173
35038, 24487, 24495, 94805, 94813, 3086, 3087, 32641, 32642, 24786, 95539, 95174, 95547, 3109, 32708, 32675, 
32709, 24771, 24788, 95151, 95176
35039, 2933, 2934, 32520, 32521, 24472, 24480, 94806, 94814, 2956, 32587, 32554, 32588, 24755, 95540, 95178, 
95548, 24739, 24756, 95152, 95177
35040, 24472, 24480, 94806, 94814, 24473, 24481, 94807, 94815, 24755, 95540, 95178, 95548, 24757, 95541, 95181, 
95549, 24741, 24758, 95155, 95180
35041, 24473, 24481, 94807, 94815, 24474, 24482, 94808, 94816, 24757, 95541, 95181, 95549, 24759, 95542, 95184, 
95550, 24743, 24760, 95158, 95183
35042, 24474, 24482, 94808, 94816, 24475, 24483, 94809, 94817, 24759, 95542, 95184, 95550, 24761, 95543, 95187, 
95551, 24745, 24762, 95161, 95186
35043, 24475, 24483, 94809, 94817, 24476, 24484, 94810, 94818, 24761, 95543, 95187, 95551, 24763, 95544, 95190, 
95552, 24747, 24764, 95164, 95189
35044, 24476, 24484, 94810, 94818, 24477, 24485, 94811, 94819, 24763, 95544, 95190, 95552, 24765, 95545, 95193, 
95553, 24749, 24766, 95167, 95192
35045, 24477, 24485, 94811, 94819, 24478, 24486, 94812, 94820, 24765, 95545, 95193, 95553, 24767, 95546, 95196, 
95554, 24751, 24768, 95170, 95195
35046, 24478, 24486, 94812, 94820, 24479, 24487, 94813, 94821, 24767, 95546, 95196, 95554, 24769, 95547, 95199, 
95555, 24753, 24770, 95173, 95198
35047, 24479, 24487, 94813, 94821, 3085, 3086, 32642, 32643, 24769, 95547, 95199, 95555, 3108, 32709, 32677, 
32710, 24754, 24771, 95176, 95201
35048, 2932, 2933, 32521, 32522, 24464, 24472, 94814, 94822, 2955, 32588, 32556, 32589, 24738, 95548, 95203, 
95556, 24722, 24739, 95177, 95202
35049, 24464, 24472, 94814, 94822, 24465, 24473, 94815, 94823, 24738, 95548, 95203, 95556, 24740, 95549, 95206, 
95557, 24724, 24741, 95180, 95205
35050, 24465, 24473, 94815, 94823, 24466, 24474, 94816, 94824, 24740, 95549, 95206, 95557, 24742, 95550, 95209, 
95558, 24726, 24743, 95183, 95208
35051, 24466, 24474, 94816, 94824, 24467, 24475, 94817, 94825, 24742, 95550, 95209, 95558, 24744, 95551, 95212, 
95559, 24728, 24745, 95186, 95211
35052, 24467, 24475, 94817, 94825, 24468, 24476, 94818, 94826, 24744, 95551, 95212, 95559, 24746, 95552, 95215, 
95560, 24730, 24747, 95189, 95214
35053, 24468, 24476, 94818, 94826, 24469, 24477, 94819, 94827, 24746, 95552, 95215, 95560, 24748, 95553, 95218, 
95561, 24732, 24749, 95192, 95217
35054, 24469, 24477, 94819, 94827, 24470, 24478, 94820, 94828, 24748, 95553, 95218, 95561, 24750, 95554, 95221, 
95562, 24734, 24751, 95195, 95220
35055, 24470, 24478, 94820, 94828, 24471, 24479, 94821, 94829, 24750, 95554, 95221, 95562, 24752, 95555, 95224, 
95563, 24736, 24753, 95198, 95223
35056, 24471, 24479, 94821, 94829, 3084, 3085, 32643, 32644, 24752, 95555, 95224, 95563, 3107, 32710, 32679, 
32711, 24737, 24754, 95201, 95226
35057, 2931, 2932, 32522, 32523, 24456, 24464, 94822, 94830, 2954, 32589, 32558, 32590, 24721, 95556, 95228, 
95564, 24705, 24722, 95202, 95227
35058, 24456, 24464, 94822, 94830, 24457, 24465, 94823, 94831, 24721, 95556, 95228, 95564, 24723, 95557, 95231, 
95565, 24707, 24724, 95205, 95230
35059, 24457, 24465, 94823, 94831, 24458, 24466, 94824, 94832, 24723, 95557, 95231, 95565, 24725, 95558, 95234, 
95566, 24709, 24726, 95208, 95233
35060, 24458, 24466, 94824, 94832, 24459, 24467, 94825, 94833, 24725, 95558, 95234, 95566, 24727, 95559, 95237, 
95567, 24711, 24728, 95211, 95236
35061, 24459, 24467, 94825, 94833, 24460, 24468, 94826, 94834, 24727, 95559, 95237, 95567, 24729, 95560, 95240, 
95568, 24713, 24730, 95214, 95239
35062, 24460, 24468, 94826, 94834, 24461, 24469, 94827, 94835, 24729, 95560, 95240, 95568, 24731, 95561, 95243, 
95569, 24715, 24732, 95217, 95242
35063, 24461, 24469, 94827, 94835, 24462, 24470, 94828, 94836, 24731, 95561, 95243, 95569, 24733, 95562, 95246, 
95570, 24717, 24734, 95220, 95245
35064, 24462, 24470, 94828, 94836, 24463, 24471, 94829, 94837, 24733, 95562, 95246, 95570, 24735, 95563, 95249, 
95571, 24719, 24736, 95223, 95248
35065, 24463, 24471, 94829, 94837, 3083, 3084, 32644, 32645, 24735, 95563, 95249, 95571, 3106, 32711, 32681, 
32712, 24720, 24737, 95226, 95251
35066, 2930, 2931, 32523, 32524, 24448, 24456, 94830, 94838, 2953, 32590, 32560, 32591, 24704, 95564, 95253, 
95572, 24688, 24705, 95227, 95252
35067, 24448, 24456, 94830, 94838, 24449, 24457, 94831, 94839, 24704, 95564, 95253, 95572, 24706, 95565, 95256, 
95573, 24690, 24707, 95230, 95255
35068, 24449, 24457, 94831, 94839, 24450, 24458, 94832, 94840, 24706, 95565, 95256, 95573, 24708, 95566, 95259, 
95574, 24692, 24709, 95233, 95258
35069, 24450, 24458, 94832, 94840, 24451, 24459, 94833, 94841, 24708, 95566, 95259, 95574, 24710, 95567, 95262, 
95575, 24694, 24711, 95236, 95261
35070, 24451, 24459, 94833, 94841, 24452, 24460, 94834, 94842, 24710, 95567, 95262, 95575, 24712, 95568, 95265, 
95576, 24696, 24713, 95239, 95264
35071, 24452, 24460, 94834, 94842, 24453, 24461, 94835, 94843, 24712, 95568, 95265, 95576, 24714, 95569, 95268, 
95577, 24698, 24715, 95242, 95267
35072, 24453, 24461, 94835, 94843, 24454, 24462, 94836, 94844, 24714, 95569, 95268, 95577, 24716, 95570, 95271, 
95578, 24700, 24717, 95245, 95270
35073, 24454, 24462, 94836, 94844, 24455, 24463, 94837, 94845, 24716, 95570, 95271, 95578, 24718, 95571, 95274, 
95579, 24702, 24719, 95248, 95273
35074, 24455, 24463, 94837, 94845, 3082, 3083, 32645, 32646, 24718, 95571, 95274, 95579, 3105, 32712, 32683, 
32713, 24703, 24720, 95251, 95276
35075, 2929, 2930, 32524, 32525, 24440, 24448, 94838, 94846, 2952, 32591, 32562, 32592, 24687, 95572, 95278, 
95580, 24671, 24688, 95252, 95277
35076, 24440, 24448, 94838, 94846, 24441, 24449, 94839, 94847, 24687, 95572, 95278, 95580, 24689, 95573, 95281, 
95581, 24673, 24690, 95255, 95280
35077, 24441, 24449, 94839, 94847, 24442, 24450, 94840, 94848, 24689, 95573, 95281, 95581, 24691, 95574, 95284, 
95582, 24675, 24692, 95258, 95283
35078, 24442, 24450, 94840, 94848, 24443, 24451, 94841, 94849, 24691, 95574, 95284, 95582, 24693, 95575, 95287, 
95583, 24677, 24694, 95261, 95286
35079, 24443, 24451, 94841, 94849, 24444, 24452, 94842, 94850, 24693, 95575, 95287, 95583, 24695, 95576, 95290, 
95584, 24679, 24696, 95264, 95289
35080, 24444, 24452, 94842, 94850, 24445, 24453, 94843, 94851, 24695, 95576, 95290, 95584, 24697, 95577, 95293, 
95585, 24681, 24698, 95267, 95292
35081, 24445, 24453, 94843, 94851, 24446, 24454, 94844, 94852, 24697, 95577, 95293, 95585, 24699, 95578, 95296, 
95586, 24683, 24700, 95270, 95295
35082, 24446, 24454, 94844, 94852, 24447, 24455, 94845, 94853, 24699, 95578, 95296, 95586, 24701, 95579, 95299, 
95587, 24685, 24702, 95273, 95298
35083, 24447, 24455, 94845, 94853, 3081, 3082, 32646, 32647, 24701, 95579, 95299, 95587, 3104, 32713, 32685, 
32714, 24686, 24703, 95276, 95301
35084, 2928, 2929, 32525, 32526, 24432, 24440, 94846, 94854, 2951, 32592, 32564, 32593, 24670, 95580, 95303, 
95588, 24654, 24671, 95277, 95302
35085, 24432, 24440, 94846, 94854, 24433, 24441, 94847, 94855, 24670, 95580, 95303, 95588, 24672, 95581, 95306, 
95589, 24656, 24673, 95280, 95305
35086, 24433, 24441, 94847, 94855, 24434, 24442, 94848, 94856, 24672, 95581, 95306, 95589, 24674, 95582, 95309, 
95590, 24658, 24675, 95283, 95308
35087, 24434, 24442, 94848, 94856, 24435, 24443, 94849, 94857, 24674, 95582, 95309, 95590, 24676, 95583, 95312, 
95591, 24660, 24677, 95286, 95311
35088, 24435, 24443, 94849, 94857, 24436, 24444, 94850, 94858, 24676, 95583, 95312, 95591, 24678, 95584, 95315, 
95592, 24662, 24679, 95289, 95314
35089, 24436, 24444, 94850, 94858, 24437, 24445, 94851, 94859, 24678, 95584, 95315, 95592, 24680, 95585, 95318, 
95593, 24664, 24681, 95292, 95317
35090, 24437, 24445, 94851, 94859, 24438, 24446, 94852, 94860, 24680, 95585, 95318, 95593, 24682, 95586, 95321, 
95594, 24666, 24683, 95295, 95320
35091, 24438, 24446, 94852, 94860, 24439, 24447, 94853, 94861, 24682, 95586, 95321, 95594, 24684, 95587, 95324, 
95595, 24668, 24685, 95298, 95323
35092, 24439, 24447, 94853, 94861, 3080, 3081, 32647, 32648, 24684, 95587, 95324, 95595, 3103, 32714, 32687, 
32715, 24669, 24686, 95301, 95326
35093, 2927, 2928, 32526, 32527, 24424, 24432, 94854, 94862, 2950, 32593, 32566, 32594, 24653, 95588, 95328, 
95596, 24637, 24654, 95302, 95327
35094, 24424, 24432, 94854, 94862, 24425, 24433, 94855, 94863, 24653, 95588, 95328, 95596, 24655, 95589, 95331, 
95597, 24639, 24656, 95305, 95330
35095, 24425, 24433, 94855, 94863, 24426, 24434, 94856, 94864, 24655, 95589, 95331, 95597, 24657, 95590, 95334, 
95598, 24641, 24658, 95308, 95333
35096, 24426, 24434, 94856, 94864, 24427, 24435, 94857, 94865, 24657, 95590, 95334, 95598, 24659, 95591, 95337, 
95599, 24643, 24660, 95311, 95336
35097, 24427, 24435, 94857, 94865, 24428, 24436, 94858, 94866, 24659, 95591, 95337, 95599, 24661, 95592, 95340, 
95600, 24645, 24662, 95314, 95339
35098, 24428, 24436, 94858, 94866, 24429, 24437, 94859, 94867, 24661, 95592, 95340, 95600, 24663, 95593, 95343, 
95601, 24647, 24664, 95317, 95342
35099, 24429, 24437, 94859, 94867, 24430, 24438, 94860, 94868, 24663, 95593, 95343, 95601, 24665, 95594, 95346, 
95602, 24649, 24666, 95320, 95345
35100, 24430, 24438, 94860, 94868, 24431, 24439, 94861, 94869, 24665, 95594, 95346, 95602, 24667, 95595, 95349, 
95603, 24651, 24668, 95323, 95348
35101, 24431, 24439, 94861, 94869, 3079, 3080, 32648, 32649, 24667, 95595, 95349, 95603, 3102, 32715, 32689, 
32716, 24652, 24669, 95326, 95351
35102, 2926, 2927, 32527, 32528, 24416, 24424, 94862, 94870, 2949, 32594, 32568, 32595, 24636, 95596, 95353, 
95604, 24620, 24637, 95327, 95352
35103, 24416, 24424, 94862, 94870, 24417, 24425, 94863, 94871, 24636, 95596, 95353, 95604, 24638, 95597, 95356, 
95605, 24622, 24639, 95330, 95355
35104, 24417, 24425, 94863, 94871, 24418, 24426, 94864, 94872, 24638, 95597, 95356, 95605, 24640, 95598, 95359, 
95606, 24624, 24641, 95333, 95358
35105, 24418, 24426, 94864, 94872, 24419, 24427, 94865, 94873, 24640, 95598, 95359, 95606, 24642, 95599, 95362, 
95607, 24626, 24643, 95336, 95361
35106, 24419, 24427, 94865, 94873, 24420, 24428, 94866, 94874, 24642, 95599, 95362, 95607, 24644, 95600, 95365, 
95608, 24628, 24645, 95339, 95364
35107, 24420, 24428, 94866, 94874, 24421, 24429, 94867, 94875, 24644, 95600, 95365, 95608, 24646, 95601, 95368, 
95609, 24630, 24647, 95342, 95367
35108, 24421, 24429, 94867, 94875, 24422, 24430, 94868, 94876, 24646, 95601, 95368, 95609, 24648, 95602, 95371, 
95610, 24632, 24649, 95345, 95370
35109, 24422, 24430, 94868, 94876, 24423, 24431, 94869, 94877, 24648, 95602, 95371, 95610, 24650, 95603, 95374, 
95611, 24634, 24651, 95348, 95373
35110, 24423, 24431, 94869, 94877, 3078, 3079, 32649, 32650, 24650, 95603, 95374, 95611, 3101, 32716, 32691, 
32717, 24635, 24652, 95351, 95376
35111, 2925, 2926, 32528, 32529, 24408, 24416, 94870, 94878, 2948, 32595, 32570, 32596, 24619, 95604, 95378, 
95612, 24603, 24620, 95352, 95377
35112, 24408, 24416, 94870, 94878, 24409, 24417, 94871, 94879, 24619, 95604, 95378, 95612, 24621, 95605, 95381, 
95613, 24605, 24622, 95355, 95380
35113, 24409, 24417, 94871, 94879, 24410, 24418, 94872, 94880, 24621, 95605, 95381, 95613, 24623, 95606, 95384, 
95614, 24607, 24624, 95358, 95383
35114, 24410, 24418, 94872, 94880, 24411, 24419, 94873, 94881, 24623, 95606, 95384, 95614, 24625, 95607, 95387, 
95615, 24609, 24626, 95361, 95386
35115, 24411, 24419, 94873, 94881, 24412, 24420, 94874, 94882, 24625, 95607, 95387, 95615, 24627, 95608, 95390, 
95616, 24611, 24628, 95364, 95389
35116, 24412, 24420, 94874, 94882, 24413, 24421, 94875, 94883, 24627, 95608, 95390, 95616, 24629, 95609, 95393, 
95617, 24613, 24630, 95367, 95392
35117, 24413, 24421, 94875, 94883, 24414, 24422, 94876, 94884, 24629, 95609, 95393, 95617, 24631, 95610, 95396, 
95618, 24615, 24632, 95370, 95395
35118, 24414, 24422, 94876, 94884, 24415, 24423, 94877, 94885, 24631, 95610, 95396, 95618, 24633, 95611, 95399, 
95619, 24617, 24634, 95373, 95398
35119, 24415, 24423, 94877, 94885, 3077, 3078, 32650, 32651, 24633, 95611, 95399, 95619, 3100, 32717, 32693, 
32718, 24618, 24635, 95376, 95401
35120, 2924, 2925, 32529, 32530, 24400, 24408, 94878, 94886, 2947, 32596, 32572, 32597, 24602, 95612, 95403, 
95620, 24586, 24603, 95377, 95402
35121, 24400, 24408, 94878, 94886, 24401, 24409, 94879, 94887, 24602, 95612, 95403, 95620, 24604, 95613, 95406, 
95621, 24588, 24605, 95380, 95405
35122, 24401, 24409, 94879, 94887, 24402, 24410, 94880, 94888, 24604, 95613, 95406, 95621, 24606, 95614, 95409, 
95622, 24590, 24607, 95383, 95408
35123, 24402, 24410, 94880, 94888, 24403, 24411, 94881, 94889, 24606, 95614, 95409, 95622, 24608, 95615, 95412, 
95623, 24592, 24609, 95386, 95411
35124, 24403, 24411, 94881, 94889, 24404, 24412, 94882, 94890, 24608, 95615, 95412, 95623, 24610, 95616, 95415, 
95624, 24594, 24611, 95389, 95414
35125, 24404, 24412, 94882, 94890, 24405, 24413, 94883, 94891, 24610, 95616, 95415, 95624, 24612, 95617, 95418, 
95625, 24596, 24613, 95392, 95417
35126, 24405, 24413, 94883, 94891, 24406, 24414, 94884, 94892, 24612, 95617, 95418, 95625, 24614, 95618, 95421, 
95626, 24598, 24615, 95395, 95420
35127, 24406, 24414, 94884, 94892, 24407, 24415, 94885, 94893, 24614, 95618, 95421, 95626, 24616, 95619, 95424, 
95627, 24600, 24617, 95398, 95423
35128, 24407, 24415, 94885, 94893, 3076, 3077, 32651, 32652, 24616, 95619, 95424, 95627, 3099, 32718, 32695, 
32719, 24601, 24618, 95401, 95426
35129, 2923, 2924, 32530, 32531, 24392, 24400, 94886, 94894, 2946, 32597, 32574, 32598, 24585, 95620, 95428, 
95628, 24569, 24586, 95402, 95427
35130, 24392, 24400, 94886, 94894, 24393, 24401, 94887, 94895, 24585, 95620, 95428, 95628, 24587, 95621, 95431, 
95629, 24571, 24588, 95405, 95430
35131, 24393, 24401, 94887, 94895, 24394, 24402, 94888, 94896, 24587, 95621, 95431, 95629, 24589, 95622, 95434, 
95630, 24573, 24590, 95408, 95433
35132, 24394, 24402, 94888, 94896, 24395, 24403, 94889, 94897, 24589, 95622, 95434, 95630, 24591, 95623, 95437, 
95631, 24575, 24592, 95411, 95436
35133, 24395, 24403, 94889, 94897, 24396, 24404, 94890, 94898, 24591, 95623, 95437, 95631, 24593, 95624, 95440, 
95632, 24577, 24594, 95414, 95439
35134, 24396, 24404, 94890, 94898, 24397, 24405, 94891, 94899, 24593, 95624, 95440, 95632, 24595, 95625, 95443, 
95633, 24579, 24596, 95417, 95442
35135, 24397, 24405, 94891, 94899, 24398, 24406, 94892, 94900, 24595, 95625, 95443, 95633, 24597, 95626, 95446, 
95634, 24581, 24598, 95420, 95445
35136, 24398, 24406, 94892, 94900, 24399, 24407, 94893, 94901, 24597, 95626, 95446, 95634, 24599, 95627, 95449, 
95635, 24583, 24600, 95423, 95448
35137, 24399, 24407, 94893, 94901, 3075, 3076, 32652, 32653, 24599, 95627, 95449, 95635, 3098, 32719, 32697, 
32720, 24584, 24601, 95426, 95451
35138, 90, 2923, 32531, 3876, 3120, 24392, 94894, 32728, 2945, 32598, 32576, 3878, 24568, 95628, 95452, 
32753, 3128, 24569, 95427, 32745
35139, 3120, 24392, 94894, 32728, 3121, 24393, 94895, 32727, 24568, 95628, 95452, 32753, 24570, 95629, 95453, 
32752, 3129, 24571, 95430, 32744
35140, 3121, 24393, 94895, 32727, 3122, 24394, 94896, 32726, 24570, 95629, 95453, 32752, 24572, 95630, 95454, 
32751, 3130, 24573, 95433, 32742
35141, 3122, 24394, 94896, 32726, 3123, 24395, 94897, 32725, 24572, 95630, 95454, 32751, 24574, 95631, 95455, 
32750, 3131, 24575, 95436, 32740
35142, 3123, 24395, 94897, 32725, 3124, 24396, 94898, 32724, 24574, 95631, 95455, 32750, 24576, 95632, 95456, 
32749, 3132, 24577, 95439, 32738
35143, 3124, 24396, 94898, 32724, 3125, 24397, 94899, 32723, 24576, 95632, 95456, 32749, 24578, 95633, 95457, 
32748, 3133, 24579, 95442, 32736
35144, 3125, 24397, 94899, 32723, 3126, 24398, 94900, 32722, 24578, 95633, 95457, 32748, 24580, 95634, 95458, 
32747, 3134, 24581, 95445, 32734
35145, 3126, 24398, 94900, 32722, 3127, 24399, 94901, 32721, 24580, 95634, 95458, 32747, 24582, 95635, 95459, 
32746, 3135, 24583, 95448, 32732
35146, 3127, 24399, 94901, 32721, 92, 3075, 32653, 3882, 24582, 95635, 95459, 32746, 3097, 32720, 32698, 
3884, 3136, 24584, 95451, 32730
*ELEMENT, type=C3D20, ELSET=Volume35
35147, 32754, 3885, 71, 2207, 95636, 32932, 2355, 16734, 32776, 3886, 2229, 32777, 95813, 32940, 16910, 
95814, 95812, 32941, 2364, 16911
35148, 95636, 32932, 2355, 16734, 95637, 32933, 2354, 16735, 95813, 32940, 16910, 95814, 95816, 32942, 16912, 
95817, 95815, 32943, 2363, 16913
35149, 95637, 32933, 2354, 16735, 95638, 32934, 2353, 16736, 95816, 32942, 16912, 95817, 95819, 32944, 16914, 
95820, 95818, 32945, 2362, 16915
35150, 95638, 32934, 2353, 16736, 95639, 32935, 2352, 16737, 95819, 32944, 16914, 95820, 95822, 32946, 16916, 
95823, 95821, 32947, 2361, 16917
35151, 95639, 32935, 2352, 16737, 95640, 32936, 2351, 16738, 95822, 32946, 16916, 95823, 95825, 32948, 16918, 
95826, 95824, 32949, 2360, 16919
35152, 95640, 32936, 2351, 16738, 95641, 32937, 2350, 16739, 95825, 32948, 16918, 95826, 95828, 32950, 16920, 
95829, 95827, 32951, 2359, 16921
35153, 95641, 32937, 2350, 16739, 95642, 32938, 2349, 16740, 95828, 32950, 16920, 95829, 95831, 32952, 16922, 
95832, 95830, 32953, 2358, 16923
35154, 95642, 32938, 2349, 16740, 95643, 32939, 2348, 16741, 95831, 32952, 16922, 95832, 95834, 32954, 16924, 
95835, 95833, 32955, 2357, 16925
35155, 95643, 32939, 2348, 16741, 32843, 3891, 74, 2303, 95834, 32954, 16924, 95835, 32866, 3892, 2325, 
32865, 95836, 32956, 2356, 16926
35156, 32755, 32754, 2207, 2208, 95644, 95636, 16734, 16742, 32778, 32777, 2230, 32779, 95838, 95814, 16927, 
95839, 95837, 95812, 16911, 16928
35157, 95644, 95636, 16734, 16742, 95645, 95637, 16735, 16743, 95838, 95814, 16927, 95839, 95841, 95817, 16929, 
95842, 95840, 95815, 16913, 16930
35158, 95645, 95637, 16735, 16743, 95646, 95638, 16736, 16744, 95841, 95817, 16929, 95842, 95844, 95820, 16931, 
95845, 95843, 95818, 16915, 16932
35159, 95646, 95638, 16736, 16744, 95647, 95639, 16737, 16745, 95844, 95820, 16931, 95845, 95847, 95823, 16933, 
95848, 95846, 95821, 16917, 16934
35160, 95647, 95639, 16737, 16745, 95648, 95640, 16738, 16746, 95847, 95823, 16933, 95848, 95850, 95826, 16935, 
95851, 95849, 95824, 16919, 16936
35161, 95648, 95640, 16738, 16746, 95649, 95641, 16739, 16747, 95850, 95826, 16935, 95851, 95853, 95829, 16937, 
95854, 95852, 95827, 16921, 16938
35162, 95649, 95641, 16739, 16747, 95650, 95642, 16740, 16748, 95853, 95829, 16937, 95854, 95856, 95832, 16939, 
95857, 95855, 95830, 16923, 16940
35163, 95650, 95642, 16740, 16748, 95651, 95643, 16741, 16749, 95856, 95832, 16939, 95857, 95859, 95835, 16941, 
95860, 95858, 95833, 16925, 16942
35164, 95651, 95643, 16741, 16749, 32844, 32843, 2303, 2304, 95859, 95835, 16941, 95860, 32868, 32865, 2326, 
32867, 95861, 95836, 16926, 16943
35165, 32756, 32755, 2208, 2209, 95652, 95644, 16742, 16750, 32780, 32779, 2231, 32781, 95863, 95839, 16944, 
95864, 95862, 95837, 16928, 16945
35166, 95652, 95644, 16742, 16750, 95653, 95645, 16743, 16751, 95863, 95839, 16944, 95864, 95866, 95842, 16946, 
95867, 95865, 95840, 16930, 16947
35167, 95653, 95645, 16743, 16751, 95654, 95646, 16744, 16752, 95866, 95842, 16946, 95867, 95869, 95845, 16948, 
95870, 95868, 95843, 16932, 16949
35168, 95654, 95646, 16744, 16752, 95655, 95647, 16745, 16753, 95869, 95845, 16948, 95870, 95872, 95848, 16950, 
95873, 95871, 95846, 16934, 16951
35169, 95655, 95647, 16745, 16753, 95656, 95648, 16746, 16754, 95872, 95848, 16950, 95873, 95875, 95851, 16952, 
95876, 95874, 95849, 16936, 16953
35170, 95656, 95648, 16746, 16754, 95657, 95649, 16747, 16755, 95875, 95851, 16952, 95876, 95878, 95854, 16954, 
95879, 95877, 95852, 16938, 16955
35171, 95657, 95649, 16747, 16755, 95658, 95650, 16748, 16756, 95878, 95854, 16954, 95879, 95881, 95857, 16956, 
95882, 95880, 95855, 16940, 16957
35172, 95658, 95650, 16748, 16756, 95659, 95651, 16749, 16757, 95881, 95857, 16956, 95882, 95884, 95860, 16958, 
95885, 95883, 95858, 16942, 16959
35173, 95659, 95651, 16749, 16757, 32845, 32844, 2304, 2305, 95884, 95860, 16958, 95885, 32870, 32867, 2327, 
32869, 95886, 95861, 16943, 16960
35174, 32757, 32756, 2209, 2210, 95660, 95652, 16750, 16758, 32782, 32781, 2232, 32783, 95888, 95864, 16961, 
95889, 95887, 95862, 16945, 16962
35175, 95660, 95652, 16750, 16758, 95661, 95653, 16751, 16759, 95888, 95864, 16961, 95889, 95891, 95867, 16963, 
95892, 95890, 95865, 16947, 16964
35176, 95661, 95653, 16751, 16759, 95662, 95654, 16752, 16760, 95891, 95867, 16963, 95892, 95894, 95870, 16965, 
95895, 95893, 95868, 16949, 16966
35177, 95662, 95654, 16752, 16760, 95663, 95655, 16753, 16761, 95894, 95870, 16965, 95895, 95897, 95873, 16967, 
95898, 95896, 95871, 16951, 16968
35178, 95663, 95655, 16753, 16761, 95664, 95656, 16754, 16762, 95897, 95873, 16967, 95898, 95900, 95876, 16969, 
95901, 95899, 95874, 16953, 16970
35179, 95664, 95656, 16754, 16762, 95665, 95657, 16755, 16763, 95900, 95876, 16969, 95901, 95903, 95879, 16971, 
95904, 95902, 95877, 16955, 16972
35180, 95665, 95657, 16755, 16763, 95666, 95658, 16756, 16764, 95903, 95879, 16971, 95904, 95906, 95882, 16973, 
95907, 95905, 95880, 16957, 16974
35181, 95666, 95658, 16756, 16764, 95667, 95659, 16757, 16765, 95906, 95882, 16973, 95907, 95909, 95885, 16975, 
95910, 95908, 95883, 16959, 16976
35182, 95667, 95659, 16757, 16765, 32846, 32845, 2305, 2306, 95909, 95885, 16975, 95910, 32872, 32869, 2328, 
32871, 95911, 95886, 16960, 16977
35183, 32758, 32757, 2210, 2211, 95668, 95660, 16758, 16766, 32784, 32783, 2233, 32785, 95913, 95889, 16978, 
95914, 95912, 95887, 16962, 16979
35184, 95668, 95660, 16758, 16766, 95669, 95661, 16759, 16767, 95913, 95889, 16978, 95914, 95916, 95892, 16980, 
95917, 95915, 95890, 16964, 16981
35185, 95669, 95661, 16759, 16767, 95670, 95662, 16760, 16768, 95916, 95892, 16980, 95917, 95919, 95895, 16982, 
95920, 95918, 95893, 16966, 16983
35186, 95670, 95662, 16760, 16768, 95671, 95663, 16761, 16769, 95919, 95895, 16982, 95920, 95922, 95898, 16984, 
95923, 95921, 95896, 16968, 16985
35187, 95671, 95663, 16761, 16769, 95672, 95664, 16762, 16770, 95922, 95898, 16984, 95923, 95925, 95901, 16986, 
95926, 95924, 95899, 16970, 16987
35188, 95672, 95664, 16762, 16770, 95673, 95665, 16763, 16771, 95925, 95901, 16986, 95926, 95928, 95904, 16988, 
95929, 95927, 95902, 16972, 16989
35189, 95673, 95665, 16763, 16771, 95674, 95666, 16764, 16772, 95928, 95904, 16988, 95929, 95931, 95907, 16990, 
95932, 95930, 95905, 16974, 16991
35190, 95674, 95666, 16764, 16772, 95675, 95667, 16765, 16773, 95931, 95907, 16990, 95932, 95934, 95910, 16992, 
95935, 95933, 95908, 16976, 16993
35191, 95675, 95667, 16765, 16773, 32847, 32846, 2306, 2307, 95934, 95910, 16992, 95935, 32874, 32871, 2329, 
32873, 95936, 95911, 16977, 16994
35192, 32759, 32758, 2211, 2212, 95676, 95668, 16766, 16774, 32786, 32785, 2234, 32787, 95938, 95914, 16995, 
95939, 95937, 95912, 16979, 16996
35193, 95676, 95668, 16766, 16774, 95677, 95669, 16767, 16775, 95938, 95914, 16995, 95939, 95941, 95917, 16997, 
95942, 95940, 95915, 16981, 16998
35194, 95677, 95669, 16767, 16775, 95678, 95670, 16768, 16776, 95941, 95917, 16997, 95942, 95944, 95920, 16999, 
95945, 95943, 95918, 16983, 17000
35195, 95678, 95670, 16768, 16776, 95679, 95671, 16769, 16777, 95944, 95920, 16999, 95945, 95947, 95923, 17001, 
95948, 95946, 95921, 16985, 17002
35196, 95679, 95671, 16769, 16777, 95680, 95672, 16770, 16778, 95947, 95923, 17001, 95948, 95950, 95926, 17003, 
95951, 95949, 95924, 16987, 17004
35197, 95680, 95672, 16770, 16778, 95681, 95673, 16771, 16779, 95950, 95926, 17003, 95951, 95953, 95929, 17005, 
95954, 95952, 95927, 16989, 17006
35198, 95681, 95673, 16771, 16779, 95682, 95674, 16772, 16780, 95953, 95929, 17005, 95954, 95956, 95932, 17007, 
95957, 95955, 95930, 16991, 17008
35199, 95682, 95674, 16772, 16780, 95683, 95675, 16773, 16781, 95956, 95932, 17007, 95957, 95959, 95935, 17009, 
95960, 95958, 95933, 16993, 17010
35200, 95683, 95675, 16773, 16781, 32848, 32847, 2307, 2308, 95959, 95935, 17009, 95960, 32876, 32873, 2330, 
32875, 95961, 95936, 16994, 17011
35201, 32760, 32759, 2212, 2213, 95684, 95676, 16774, 16782, 32788, 32787, 2235, 32789, 95963, 95939, 17012, 
95964, 95962, 95937, 16996, 17013
35202, 95684, 95676, 16774, 16782, 95685, 95677, 16775, 16783, 95963, 95939, 17012, 95964, 95966, 95942, 17014, 
95967, 95965, 95940, 16998, 17015
35203, 95685, 95677, 16775, 16783, 95686, 95678, 16776, 16784, 95966, 95942, 17014, 95967, 95969, 95945, 17016, 
95970, 95968, 95943, 17000, 17017
35204, 95686, 95678, 16776, 16784, 95687, 95679, 16777, 16785, 95969, 95945, 17016, 95970, 95972, 95948, 17018, 
95973, 95971, 95946, 17002, 17019
35205, 95687, 95679, 16777, 16785, 95688, 95680, 16778, 16786, 95972, 95948, 17018, 95973, 95975, 95951, 17020, 
95976, 95974, 95949, 17004, 17021
35206, 95688, 95680, 16778, 16786, 95689, 95681, 16779, 16787, 95975, 95951, 17020, 95976, 95978, 95954, 17022, 
95979, 95977, 95952, 17006, 17023
35207, 95689, 95681, 16779, 16787, 95690, 95682, 16780, 16788, 95978, 95954, 17022, 95979, 95981, 95957, 17024, 
95982, 95980, 95955, 17008, 17025
35208, 95690, 95682, 16780, 16788, 95691, 95683, 16781, 16789, 95981, 95957, 17024, 95982, 95984, 95960, 17026, 
95985, 95983, 95958, 17010, 17027
35209, 95691, 95683, 16781, 16789, 32849, 32848, 2308, 2309, 95984, 95960, 17026, 95985, 32878, 32875, 2331, 
32877, 95986, 95961, 17011, 17028
35210, 32761, 32760, 2213, 2214, 95692, 95684, 16782, 16790, 32790, 32789, 2236, 32791, 95988, 95964, 17029, 
95989, 95987, 95962, 17013, 17030
35211, 95692, 95684, 16782, 16790, 95693, 95685, 16783, 16791, 95988, 95964, 17029, 95989, 95991, 95967, 17031, 
95992, 95990, 95965, 17015, 17032
35212, 95693, 95685, 16783, 16791, 95694, 95686, 16784, 16792, 95991, 95967, 17031, 95992, 95994, 95970, 17033, 
95995, 95993, 95968, 17017, 17034
35213, 95694, 95686, 16784, 16792, 95695, 95687, 16785, 16793, 95994, 95970, 17033, 95995, 95997, 95973, 17035, 
95998, 95996, 95971, 17019, 17036
35214, 95695, 95687, 16785, 16793, 95696, 95688, 16786, 16794, 95997, 95973, 17035, 95998, 96000, 95976, 17037, 
96001, 95999, 95974, 17021, 17038
35215, 95696, 95688, 16786, 16794, 95697, 95689, 16787, 16795, 96000, 95976, 17037, 96001, 96003, 95979, 17039, 
96004, 96002, 95977, 17023, 17040
35216, 95697, 95689, 16787, 16795, 95698, 95690, 16788, 16796, 96003, 95979, 17039, 96004, 96006, 95982, 17041, 
96007, 96005, 95980, 17025, 17042
35217, 95698, 95690, 16788, 16796, 95699, 95691, 16789, 16797, 96006, 95982, 17041, 96007, 96009, 95985, 17043, 
96010, 96008, 95983, 17027, 17044
35218, 95699, 95691, 16789, 16797, 32850, 32849, 2309, 2310, 96009, 95985, 17043, 96010, 32880, 32877, 2332, 
32879, 96011, 95986, 17028, 17045
35219, 32762, 32761, 2214, 2215, 95700, 95692, 16790, 16798, 32792, 32791, 2237, 32793, 96013, 95989, 17046, 
96014, 96012, 95987, 17030, 17047
35220, 95700, 95692, 16790, 16798, 95701, 95693, 16791, 16799, 96013, 95989, 17046, 96014, 96016, 95992, 17048, 
96017, 96015, 95990, 17032, 17049
35221, 95701, 95693, 16791, 16799, 95702, 95694, 16792, 16800, 96016, 95992, 17048, 96017, 96019, 95995, 17050, 
96020, 96018, 95993, 17034, 17051
35222, 95702, 95694, 16792, 16800, 95703, 95695, 16793, 16801, 96019, 95995, 17050, 96020, 96022, 95998, 17052, 
96023, 96021, 95996, 17036, 17053
35223, 95703, 95695, 16793, 16801, 95704, 95696, 16794, 16802, 96022, 95998, 17052, 96023, 96025, 96001, 17054, 
96026, 96024, 95999, 17038, 17055
35224, 95704, 95696, 16794, 16802, 95705, 95697, 16795, 16803, 96025, 96001, 17054, 96026, 96028, 96004, 17056, 
96029, 96027, 96002, 17040, 17057
35225, 95705, 95697, 16795, 16803, 95706, 95698, 16796, 16804, 96028, 96004, 17056, 96029, 96031, 96007, 17058, 
96032, 96030, 96005, 17042, 17059
35226, 95706, 95698, 16796, 16804, 95707, 95699, 16797, 16805, 96031, 96007, 17058, 96032, 96034, 96010, 17060, 
96035, 96033, 96008, 17044, 17061
35227, 95707, 95699, 16797, 16805, 32851, 32850, 2310, 2311, 96034, 96010, 17060, 96035, 32882, 32879, 2333, 
32881, 96036, 96011, 17045, 17062
35228, 32763, 32762, 2215, 2216, 95708, 95700, 16798, 16806, 32794, 32793, 2238, 32795, 96038, 96014, 17063, 
96039, 96037, 96012, 17047, 17064
35229, 95708, 95700, 16798, 16806, 95709, 95701, 16799, 16807, 96038, 96014, 17063, 96039, 96041, 96017, 17065, 
96042, 96040, 96015, 17049, 17066
35230, 95709, 95701, 16799, 16807, 95710, 95702, 16800, 16808, 96041, 96017, 17065, 96042, 96044, 96020, 17067, 
96045, 96043, 96018, 17051, 17068
35231, 95710, 95702, 16800, 16808, 95711, 95703, 16801, 16809, 96044, 96020, 17067, 96045, 96047, 96023, 17069, 
96048, 96046, 96021, 17053, 17070
35232, 95711, 95703, 16801, 16809, 95712, 95704, 16802, 16810, 96047, 96023, 17069, 96048, 96050, 96026, 17071, 
96051, 96049, 96024, 17055, 17072
35233, 95712, 95704, 16802, 16810, 95713, 95705, 16803, 16811, 96050, 96026, 17071, 96051, 96053, 96029, 17073, 
96054, 96052, 96027, 17057, 17074
35234, 95713, 95705, 16803, 16811, 95714, 95706, 16804, 16812, 96053, 96029, 17073, 96054, 96056, 96032, 17075, 
96057, 96055, 96030, 17059, 17076
35235, 95714, 95706, 16804, 16812, 95715, 95707, 16805, 16813, 96056, 96032, 17075, 96057, 96059, 96035, 17077, 
