6983, 2041, 2042, 15502, 15494, 2064, 15822, 15823, 15805
6984, 15494, 15502, 15503, 15495, 15823, 15824, 15825, 15807
6985, 15495, 15503, 15504, 15496, 15825, 15826, 15827, 15809
6986, 15496, 15504, 15505, 15497, 15827, 15828, 15829, 15811
6987, 15497, 15505, 15506, 15498, 15829, 15830, 15831, 15813
6988, 15498, 15506, 15507, 15499, 15831, 15832, 15833, 15815
6989, 15499, 15507, 15508, 15500, 15833, 15834, 15835, 15817
6990, 15500, 15508, 15509, 15501, 15835, 15836, 15837, 15819
6991, 15501, 15509, 2110, 2109, 15837, 15838, 2132, 15821
6992, 2042, 2043, 15510, 15502, 2065, 15839, 15840, 15822
6993, 15502, 15510, 15511, 15503, 15840, 15841, 15842, 15824
6994, 15503, 15511, 15512, 15504, 15842, 15843, 15844, 15826
6995, 15504, 15512, 15513, 15505, 15844, 15845, 15846, 15828
6996, 15505, 15513, 15514, 15506, 15846, 15847, 15848, 15830
6997, 15506, 15514, 15515, 15507, 15848, 15849, 15850, 15832
6998, 15507, 15515, 15516, 15508, 15850, 15851, 15852, 15834
6999, 15508, 15516, 15517, 15509, 15852, 15853, 15854, 15836
7000, 15509, 15517, 2111, 2110, 15854, 15855, 2133, 15838
7001, 2043, 2044, 15518, 15510, 2066, 15856, 15857, 15839
7002, 15510, 15518, 15519, 15511, 15857, 15858, 15859, 15841
7003, 15511, 15519, 15520, 15512, 15859, 15860, 15861, 15843
7004, 15512, 15520, 15521, 15513, 15861, 15862, 15863, 15845
7005, 15513, 15521, 15522, 15514, 15863, 15864, 15865, 15847
7006, 15514, 15522, 15523, 15515, 15865, 15866, 15867, 15849
7007, 15515, 15523, 15524, 15516, 15867, 15868, 15869, 15851
7008, 15516, 15524, 15525, 15517, 15869, 15870, 15871, 15853
7009, 15517, 15525, 2112, 2111, 15871, 15872, 2134, 15855
7010, 2044, 2045, 15526, 15518, 2067, 15873, 15874, 15856
7011, 15518, 15526, 15527, 15519, 15874, 15875, 15876, 15858
7012, 15519, 15527, 15528, 15520, 15876, 15877, 15878, 15860
7013, 15520, 15528, 15529, 15521, 15878, 15879, 15880, 15862
7014, 15521, 15529, 15530, 15522, 15880, 15881, 15882, 15864
7015, 15522, 15530, 15531, 15523, 15882, 15883, 15884, 15866
7016, 15523, 15531, 15532, 15524, 15884, 15885, 15886, 15868
7017, 15524, 15532, 15533, 15525, 15886, 15887, 15888, 15870
7018, 15525, 15533, 2113, 2112, 15888, 15889, 2135, 15872
7019, 2045, 2046, 15534, 15526, 2068, 15890, 15891, 15873
7020, 15526, 15534, 15535, 15527, 15891, 15892, 15893, 15875
7021, 15527, 15535, 15536, 15528, 15893, 15894, 15895, 15877
7022, 15528, 15536, 15537, 15529, 15895, 15896, 15897, 15879
7023, 15529, 15537, 15538, 15530, 15897, 15898, 15899, 15881
7024, 15530, 15538, 15539, 15531, 15899, 15900, 15901, 15883
7025, 15531, 15539, 15540, 15532, 15901, 15902, 15903, 15885
7026, 15532, 15540, 15541, 15533, 15903, 15904, 15905, 15887
7027, 15533, 15541, 2114, 2113, 15905, 15906, 2136, 15889
7028, 2046, 2047, 15542, 15534, 2069, 15907, 15908, 15890
7029, 15534, 15542, 15543, 15535, 15908, 15909, 15910, 15892
7030, 15535, 15543, 15544, 15536, 15910, 15911, 15912, 15894
7031, 15536, 15544, 15545, 15537, 15912, 15913, 15914, 15896
7032, 15537, 15545, 15546, 15538, 15914, 15915, 15916, 15898
7033, 15538, 15546, 15547, 15539, 15916, 15917, 15918, 15900
7034, 15539, 15547, 15548, 15540, 15918, 15919, 15920, 15902
7035, 15540, 15548, 15549, 15541, 15920, 15921, 15922, 15904
7036, 15541, 15549, 2115, 2114, 15922, 15923, 2137, 15906
7037, 2047, 67, 2074, 15542, 2070, 2082, 15924, 15907
7038, 15542, 2074, 2075, 15543, 15924, 2083, 15925, 15909
7039, 15543, 2075, 2076, 15544, 15925, 2084, 15926, 15911
7040, 15544, 2076, 2077, 15545, 15926, 2085, 15927, 15913
7041, 15545, 2077, 2078, 15546, 15927, 2086, 15928, 15915
7042, 15546, 2078, 2079, 15547, 15928, 2087, 15929, 15917
7043, 15547, 2079, 2080, 15548, 15929, 2088, 15930, 15919
7044, 15548, 2080, 2081, 15549, 15930, 2089, 15931, 15921
7045, 15549, 2081, 69, 2115, 15931, 2090, 2138, 15923
*ELEMENT, type=CPS8, ELSET=Surface236
7046, 53, 2156, 15932, 2162, 2157, 15954, 15955, 2184
7047, 2162, 15932, 15933, 2163, 15955, 15956, 15957, 2185
7048, 2163, 15933, 15934, 2164, 15957, 15958, 15959, 2186
7049, 2164, 15934, 15935, 2165, 15959, 15960, 15961, 2187
7050, 2165, 15935, 15936, 2166, 15961, 15962, 15963, 2188
7051, 2166, 15936, 15937, 2167, 15963, 15964, 15965, 2189
7052, 2167, 15937, 15938, 2168, 15965, 15966, 15967, 2190
7053, 2168, 15938, 15939, 2169, 15967, 15968, 15969, 2191
7054, 2169, 15939, 15940, 2170, 15969, 15970, 15971, 2192
7055, 2170, 15940, 15941, 2171, 15971, 15972, 15973, 2193
7056, 2171, 15941, 15942, 2172, 15973, 15974, 15975, 2194
7057, 2172, 15942, 15943, 2173, 15975, 15976, 15977, 2195
7058, 2173, 15943, 15944, 2174, 15977, 15978, 15979, 2196
7059, 2174, 15944, 15945, 2175, 15979, 15980, 15981, 2197
7060, 2175, 15945, 15946, 2176, 15981, 15982, 15983, 2198
7061, 2176, 15946, 15947, 2177, 15983, 15984, 15985, 2199
7062, 2177, 15947, 15948, 2178, 15985, 15986, 15987, 2200
7063, 2178, 15948, 15949, 2179, 15987, 15988, 15989, 2201
7064, 2179, 15949, 15950, 2180, 15989, 15990, 15991, 2202
7065, 2180, 15950, 15951, 2181, 15991, 15992, 15993, 2203
7066, 2181, 15951, 15952, 2182, 15993, 15994, 15995, 2204
7067, 2182, 15952, 15953, 2183, 15995, 15996, 15997, 2205
7068, 2183, 15953, 2159, 72, 15997, 15998, 2160, 2206
7069, 2156, 71, 2207, 15932, 2158, 2229, 15999, 15954
7070, 15932, 2207, 2208, 15933, 15999, 2230, 16000, 15956
7071, 15933, 2208, 2209, 15934, 16000, 2231, 16001, 15958
7072, 15934, 2209, 2210, 15935, 16001, 2232, 16002, 15960
7073, 15935, 2210, 2211, 15936, 16002, 2233, 16003, 15962
7074, 15936, 2211, 2212, 15937, 16003, 2234, 16004, 15964
7075, 15937, 2212, 2213, 15938, 16004, 2235, 16005, 15966
7076, 15938, 2213, 2214, 15939, 16005, 2236, 16006, 15968
7077, 15939, 2214, 2215, 15940, 16006, 2237, 16007, 15970
7078, 15940, 2215, 2216, 15941, 16007, 2238, 16008, 15972
7079, 15941, 2216, 2217, 15942, 16008, 2239, 16009, 15974
7080, 15942, 2217, 2218, 15943, 16009, 2240, 16010, 15976
7081, 15943, 2218, 2219, 15944, 16010, 2241, 16011, 15978
7082, 15944, 2219, 2220, 15945, 16011, 2242, 16012, 15980
7083, 15945, 2220, 2221, 15946, 16012, 2243, 16013, 15982
7084, 15946, 2221, 2222, 15947, 16013, 2244, 16014, 15984
7085, 15947, 2222, 2223, 15948, 16014, 2245, 16015, 15986
7086, 15948, 2223, 2224, 15949, 16015, 2246, 16016, 15988
7087, 15949, 2224, 2225, 15950, 16016, 2247, 16017, 15990
7088, 15950, 2225, 2226, 15951, 16017, 2248, 16018, 15992
7089, 15951, 2226, 2227, 15952, 16018, 2249, 16019, 15994
7090, 15952, 2227, 2228, 15953, 16019, 2250, 16020, 15996
7091, 15953, 2228, 73, 2159, 16020, 2251, 2161, 15998
*ELEMENT, type=CPS8, ELSET=Surface237
7092, 55, 2258, 16021, 2252, 2280, 16043, 16044, 2253
7093, 2258, 2259, 16022, 16021, 2281, 16045, 16046, 16043
7094, 2259, 2260, 16023, 16022, 2282, 16047, 16048, 16045
7095, 2260, 2261, 16024, 16023, 2283, 16049, 16050, 16047
7096, 2261, 2262, 16025, 16024, 2284, 16051, 16052, 16049
7097, 2262, 2263, 16026, 16025, 2285, 16053, 16054, 16051
7098, 2263, 2264, 16027, 16026, 2286, 16055, 16056, 16053
7099, 2264, 2265, 16028, 16027, 2287, 16057, 16058, 16055
7100, 2265, 2266, 16029, 16028, 2288, 16059, 16060, 16057
7101, 2266, 2267, 16030, 16029, 2289, 16061, 16062, 16059
7102, 2267, 2268, 16031, 16030, 2290, 16063, 16064, 16061
7103, 2268, 2269, 16032, 16031, 2291, 16065, 16066, 16063
7104, 2269, 2270, 16033, 16032, 2292, 16067, 16068, 16065
7105, 2270, 2271, 16034, 16033, 2293, 16069, 16070, 16067
7106, 2271, 2272, 16035, 16034, 2294, 16071, 16072, 16069
7107, 2272, 2273, 16036, 16035, 2295, 16073, 16074, 16071
7108, 2273, 2274, 16037, 16036, 2296, 16075, 16076, 16073
7109, 2274, 2275, 16038, 16037, 2297, 16077, 16078, 16075
7110, 2275, 2276, 16039, 16038, 2298, 16079, 16080, 16077
7111, 2276, 2277, 16040, 16039, 2299, 16081, 16082, 16079
7112, 2277, 2278, 16041, 16040, 2300, 16083, 16084, 16081
7113, 2278, 2279, 16042, 16041, 2301, 16085, 16086, 16083
7114, 2279, 75, 2255, 16042, 2302, 2256, 16087, 16085
7115, 2252, 16021, 2303, 74, 16044, 16088, 2325, 2254
7116, 16021, 16022, 2304, 2303, 16046, 16089, 2326, 16088
7117, 16022, 16023, 2305, 2304, 16048, 16090, 2327, 16089
7118, 16023, 16024, 2306, 2305, 16050, 16091, 2328, 16090
7119, 16024, 16025, 2307, 2306, 16052, 16092, 2329, 16091
7120, 16025, 16026, 2308, 2307, 16054, 16093, 2330, 16092
7121, 16026, 16027, 2309, 2308, 16056, 16094, 2331, 16093
7122, 16027, 16028, 2310, 2309, 16058, 16095, 2332, 16094
7123, 16028, 16029, 2311, 2310, 16060, 16096, 2333, 16095
7124, 16029, 16030, 2312, 2311, 16062, 16097, 2334, 16096
7125, 16030, 16031, 2313, 2312, 16064, 16098, 2335, 16097
7126, 16031, 16032, 2314, 2313, 16066, 16099, 2336, 16098
7127, 16032, 16033, 2315, 2314, 16068, 16100, 2337, 16099
7128, 16033, 16034, 2316, 2315, 16070, 16101, 2338, 16100
7129, 16034, 16035, 2317, 2316, 16072, 16102, 2339, 16101
7130, 16035, 16036, 2318, 2317, 16074, 16103, 2340, 16102
7131, 16036, 16037, 2319, 2318, 16076, 16104, 2341, 16103
7132, 16037, 16038, 2320, 2319, 16078, 16105, 2342, 16104
7133, 16038, 16039, 2321, 2320, 16080, 16106, 2343, 16105
7134, 16039, 16040, 2322, 2321, 16082, 16107, 2344, 16106
7135, 16040, 16041, 2323, 2322, 16084, 16108, 2345, 16107
7136, 16041, 16042, 2324, 2323, 16086, 16109, 2346, 16108
7137, 16042, 2255, 76, 2324, 16087, 2257, 2347, 16109
*ELEMENT, type=CPS8, ELSET=Surface238
7138, 53, 1736, 16110, 2156, 1745, 16118, 16119, 2157
7139, 1736, 1735, 16111, 16110, 1744, 16120, 16121, 16118
7140, 1735, 1734, 16112, 16111, 1743, 16122, 16123, 16120
7141, 1734, 1733, 16113, 16112, 1742, 16124, 16125, 16122
7142, 1733, 1732, 16114, 16113, 1741, 16126, 16127, 16124
7143, 1732, 1731, 16115, 16114, 1740, 16128, 16129, 16126
7144, 1731, 1730, 16116, 16115, 1739, 16130, 16131, 16128
7145, 1730, 1729, 16117, 16116, 1738, 16132, 16133, 16130
7146, 1729, 55, 2252, 16117, 1737, 2253, 16134, 16132
7147, 2156, 16110, 2355, 71, 16119, 16135, 2364, 2158
7148, 16110, 16111, 2354, 2355, 16121, 16136, 2363, 16135
7149, 16111, 16112, 2353, 2354, 16123, 16137, 2362, 16136
7150, 16112, 16113, 2352, 2353, 16125, 16138, 2361, 16137
7151, 16113, 16114, 2351, 2352, 16127, 16139, 2360, 16138
7152, 16114, 16115, 2350, 2351, 16129, 16140, 2359, 16139
7153, 16115, 16116, 2349, 2350, 16131, 16141, 2358, 16140
7154, 16116, 16117, 2348, 2349, 16133, 16142, 2357, 16141
7155, 16117, 2252, 74, 2348, 16134, 2254, 2356, 16142
*ELEMENT, type=CPS8, ELSET=Surface239
7156, 72, 2159, 16143, 2372, 2160, 16151, 16152, 2381
7157, 2372, 16143, 16144, 2371, 16152, 16153, 16154, 2380
7158, 2371, 16144, 16145, 2370, 16154, 16155, 16156, 2379
7159, 2370, 16145, 16146, 2369, 16156, 16157, 16158, 2378
7160, 2369, 16146, 16147, 2368, 16158, 16159, 16160, 2377
7161, 2368, 16147, 16148, 2367, 16160, 16161, 16162, 2376
7162, 2367, 16148, 16149, 2366, 16162, 16163, 16164, 2375
7163, 2366, 16149, 16150, 2365, 16164, 16165, 16166, 2374
7164, 2365, 16150, 2255, 75, 16166, 16167, 2256, 2373
7165, 2159, 73, 2389, 16143, 2161, 2398, 16168, 16151
7166, 16143, 2389, 2388, 16144, 16168, 2397, 16169, 16153
7167, 16144, 2388, 2387, 16145, 16169, 2396, 16170, 16155
7168, 16145, 2387, 2386, 16146, 16170, 2395, 16171, 16157
7169, 16146, 2386, 2385, 16147, 16171, 2394, 16172, 16159
7170, 16147, 2385, 2384, 16148, 16172, 2393, 16173, 16161
7171, 16148, 2384, 2383, 16149, 16173, 2392, 16174, 16163
7172, 16149, 2383, 2382, 16150, 16174, 2391, 16175, 16165
7173, 16150, 2382, 76, 2255, 16175, 2390, 2257, 16167
*ELEMENT, type=CPS8, ELSET=Surface240
7174, 53, 2162, 16176, 1736, 2184, 16352, 16353, 1745
7175, 1736, 16176, 16177, 1735, 16353, 16354, 16355, 1744
7176, 1735, 16177, 16178, 1734, 16355, 16356, 16357, 1743
7177, 1734, 16178, 16179, 1733, 16357, 16358, 16359, 1742
7178, 1733, 16179, 16180, 1732, 16359, 16360, 16361, 1741
7179, 1732, 16180, 16181, 1731, 16361, 16362, 16363, 1740
7180, 1731, 16181, 16182, 1730, 16363, 16364, 16365, 1739
7181, 1730, 16182, 16183, 1729, 16365, 16366, 16367, 1738
7182, 1729, 16183, 2258, 55, 16367, 16368, 2280, 1737
7183, 2162, 2163, 16184, 16176, 2185, 16369, 16370, 16352
7184, 16176, 16184, 16185, 16177, 16370, 16371, 16372, 16354
7185, 16177, 16185, 16186, 16178, 16372, 16373, 16374, 16356
7186, 16178, 16186, 16187, 16179, 16374, 16375, 16376, 16358
7187, 16179, 16187, 16188, 16180, 16376, 16377, 16378, 16360
7188, 16180, 16188, 16189, 16181, 16378, 16379, 16380, 16362
7189, 16181, 16189, 16190, 16182, 16380, 16381, 16382, 16364
7190, 16182, 16190, 16191, 16183, 16382, 16383, 16384, 16366
7191, 16183, 16191, 2259, 2258, 16384, 16385, 2281, 16368
7192, 2163, 2164, 16192, 16184, 2186, 16386, 16387, 16369
7193, 16184, 16192, 16193, 16185, 16387, 16388, 16389, 16371
7194, 16185, 16193, 16194, 16186, 16389, 16390, 16391, 16373
7195, 16186, 16194, 16195, 16187, 16391, 16392, 16393, 16375
7196, 16187, 16195, 16196, 16188, 16393, 16394, 16395, 16377
7197, 16188, 16196, 16197, 16189, 16395, 16396, 16397, 16379
7198, 16189, 16197, 16198, 16190, 16397, 16398, 16399, 16381
7199, 16190, 16198, 16199, 16191, 16399, 16400, 16401, 16383
7200, 16191, 16199, 2260, 2259, 16401, 16402, 2282, 16385
7201, 2164, 2165, 16200, 16192, 2187, 16403, 16404, 16386
7202, 16192, 16200, 16201, 16193, 16404, 16405, 16406, 16388
7203, 16193, 16201, 16202, 16194, 16406, 16407, 16408, 16390
7204, 16194, 16202, 16203, 16195, 16408, 16409, 16410, 16392
7205, 16195, 16203, 16204, 16196, 16410, 16411, 16412, 16394
7206, 16196, 16204, 16205, 16197, 16412, 16413, 16414, 16396
7207, 16197, 16205, 16206, 16198, 16414, 16415, 16416, 16398
7208, 16198, 16206, 16207, 16199, 16416, 16417, 16418, 16400
7209, 16199, 16207, 2261, 2260, 16418, 16419, 2283, 16402
7210, 2165, 2166, 16208, 16200, 2188, 16420, 16421, 16403
7211, 16200, 16208, 16209, 16201, 16421, 16422, 16423, 16405
7212, 16201, 16209, 16210, 16202, 16423, 16424, 16425, 16407
7213, 16202, 16210, 16211, 16203, 16425, 16426, 16427, 16409
7214, 16203, 16211, 16212, 16204, 16427, 16428, 16429, 16411
7215, 16204, 16212, 16213, 16205, 16429, 16430, 16431, 16413
7216, 16205, 16213, 16214, 16206, 16431, 16432, 16433, 16415
7217, 16206, 16214, 16215, 16207, 16433, 16434, 16435, 16417
7218, 16207, 16215, 2262, 2261, 16435, 16436, 2284, 16419
7219, 2166, 2167, 16216, 16208, 2189, 16437, 16438, 16420
7220, 16208, 16216, 16217, 16209, 16438, 16439, 16440, 16422
7221, 16209, 16217, 16218, 16210, 16440, 16441, 16442, 16424
7222, 16210, 16218, 16219, 16211, 16442, 16443, 16444, 16426
7223, 16211, 16219, 16220, 16212, 16444, 16445, 16446, 16428
7224, 16212, 16220, 16221, 16213, 16446, 16447, 16448, 16430
7225, 16213, 16221, 16222, 16214, 16448, 16449, 16450, 16432
7226, 16214, 16222, 16223, 16215, 16450, 16451, 16452, 16434
7227, 16215, 16223, 2263, 2262, 16452, 16453, 2285, 16436
7228, 2167, 2168, 16224, 16216, 2190, 16454, 16455, 16437
7229, 16216, 16224, 16225, 16217, 16455, 16456, 16457, 16439
7230, 16217, 16225, 16226, 16218, 16457, 16458, 16459, 16441
7231, 16218, 16226, 16227, 16219, 16459, 16460, 16461, 16443
7232, 16219, 16227, 16228, 16220, 16461, 16462, 16463, 16445
7233, 16220, 16228, 16229, 16221, 16463, 16464, 16465, 16447
7234, 16221, 16229, 16230, 16222, 16465, 16466, 16467, 16449
7235, 16222, 16230, 16231, 16223, 16467, 16468, 16469, 16451
7236, 16223, 16231, 2264, 2263, 16469, 16470, 2286, 16453
7237, 2168, 2169, 16232, 16224, 2191, 16471, 16472, 16454
7238, 16224, 16232, 16233, 16225, 16472, 16473, 16474, 16456
7239, 16225, 16233, 16234, 16226, 16474, 16475, 16476, 16458
7240, 16226, 16234, 16235, 16227, 16476, 16477, 16478, 16460
7241, 16227, 16235, 16236, 16228, 16478, 16479, 16480, 16462
7242, 16228, 16236, 16237, 16229, 16480, 16481, 16482, 16464
7243, 16229, 16237, 16238, 16230, 16482, 16483, 16484, 16466
7244, 16230, 16238, 16239, 16231, 16484, 16485, 16486, 16468
7245, 16231, 16239, 2265, 2264, 16486, 16487, 2287, 16470
7246, 2169, 2170, 16240, 16232, 2192, 16488, 16489, 16471
7247, 16232, 16240, 16241, 16233, 16489, 16490, 16491, 16473
7248, 16233, 16241, 16242, 16234, 16491, 16492, 16493, 16475
7249, 16234, 16242, 16243, 16235, 16493, 16494, 16495, 16477
7250, 16235, 16243, 16244, 16236, 16495, 16496, 16497, 16479
7251, 16236, 16244, 16245, 16237, 16497, 16498, 16499, 16481
7252, 16237, 16245, 16246, 16238, 16499, 16500, 16501, 16483
7253, 16238, 16246, 16247, 16239, 16501, 16502, 16503, 16485
7254, 16239, 16247, 2266, 2265, 16503, 16504, 2288, 16487
7255, 2170, 2171, 16248, 16240, 2193, 16505, 16506, 16488
7256, 16240, 16248, 16249, 16241, 16506, 16507, 16508, 16490
7257, 16241, 16249, 16250, 16242, 16508, 16509, 16510, 16492
7258, 16242, 16250, 16251, 16243, 16510, 16511, 16512, 16494
7259, 16243, 16251, 16252, 16244, 16512, 16513, 16514, 16496
7260, 16244, 16252, 16253, 16245, 16514, 16515, 16516, 16498
7261, 16245, 16253, 16254, 16246, 16516, 16517, 16518, 16500
7262, 16246, 16254, 16255, 16247, 16518, 16519, 16520, 16502
7263, 16247, 16255, 2267, 2266, 16520, 16521, 2289, 16504
7264, 2171, 2172, 16256, 16248, 2194, 16522, 16523, 16505
7265, 16248, 16256, 16257, 16249, 16523, 16524, 16525, 16507
7266, 16249, 16257, 16258, 16250, 16525, 16526, 16527, 16509
7267, 16250, 16258, 16259, 16251, 16527, 16528, 16529, 16511
7268, 16251, 16259, 16260, 16252, 16529, 16530, 16531, 16513
7269, 16252, 16260, 16261, 16253, 16531, 16532, 16533, 16515
7270, 16253, 16261, 16262, 16254, 16533, 16534, 16535, 16517
7271, 16254, 16262, 16263, 16255, 16535, 16536, 16537, 16519
7272, 16255, 16263, 2268, 2267, 16537, 16538, 2290, 16521
7273, 2172, 2173, 16264, 16256, 2195, 16539, 16540, 16522
7274, 16256, 16264, 16265, 16257, 16540, 16541, 16542, 16524
7275, 16257, 16265, 16266, 16258, 16542, 16543, 16544, 16526
7276, 16258, 16266, 16267, 16259, 16544, 16545, 16546, 16528
7277, 16259, 16267, 16268, 16260, 16546, 16547, 16548, 16530
7278, 16260, 16268, 16269, 16261, 16548, 16549, 16550, 16532
7279, 16261, 16269, 16270, 16262, 16550, 16551, 16552, 16534
7280, 16262, 16270, 16271, 16263, 16552, 16553, 16554, 16536
7281, 16263, 16271, 2269, 2268, 16554, 16555, 2291, 16538
7282, 2173, 2174, 16272, 16264, 2196, 16556, 16557, 16539
7283, 16264, 16272, 16273, 16265, 16557, 16558, 16559, 16541
7284, 16265, 16273, 16274, 16266, 16559, 16560, 16561, 16543
7285, 16266, 16274, 16275, 16267, 16561, 16562, 16563, 16545
7286, 16267, 16275, 16276, 16268, 16563, 16564, 16565, 16547
7287, 16268, 16276, 16277, 16269, 16565, 16566, 16567, 16549
7288, 16269, 16277, 16278, 16270, 16567, 16568, 16569, 16551
7289, 16270, 16278, 16279, 16271, 16569, 16570, 16571, 16553
7290, 16271, 16279, 2270, 2269, 16571, 16572, 2292, 16555
7291, 2174, 2175, 16280, 16272, 2197, 16573, 16574, 16556
7292, 16272, 16280, 16281, 16273, 16574, 16575, 16576, 16558
7293, 16273, 16281, 16282, 16274, 16576, 16577, 16578, 16560
7294, 16274, 16282, 16283, 16275, 16578, 16579, 16580, 16562
7295, 16275, 16283, 16284, 16276, 16580, 16581, 16582, 16564
7296, 16276, 16284, 16285, 16277, 16582, 16583, 16584, 16566
7297, 16277, 16285, 16286, 16278, 16584, 16585, 16586, 16568
7298, 16278, 16286, 16287, 16279, 16586, 16587, 16588, 16570
7299, 16279, 16287, 2271, 2270, 16588, 16589, 2293, 16572
7300, 2175, 2176, 16288, 16280, 2198, 16590, 16591, 16573
7301, 16280, 16288, 16289, 16281, 16591, 16592, 16593, 16575
7302, 16281, 16289, 16290, 16282, 16593, 16594, 16595, 16577
7303, 16282, 16290, 16291, 16283, 16595, 16596, 16597, 16579
7304, 16283, 16291, 16292, 16284, 16597, 16598, 16599, 16581
7305, 16284, 16292, 16293, 16285, 16599, 16600, 16601, 16583
7306, 16285, 16293, 16294, 16286, 16601, 16602, 16603, 16585
7307, 16286, 16294, 16295, 16287, 16603, 16604, 16605, 16587
7308, 16287, 16295, 2272, 2271, 16605, 16606, 2294, 16589
7309, 2176, 2177, 16296, 16288, 2199, 16607, 16608, 16590
7310, 16288, 16296, 16297, 16289, 16608, 16609, 16610, 16592
7311, 16289, 16297, 16298, 16290, 16610, 16611, 16612, 16594
7312, 16290, 16298, 16299, 16291, 16612, 16613, 16614, 16596
7313, 16291, 16299, 16300, 16292, 16614, 16615, 16616, 16598
7314, 16292, 16300, 16301, 16293, 16616, 16617, 16618, 16600
7315, 16293, 16301, 16302, 16294, 16618, 16619, 16620, 16602
7316, 16294, 16302, 16303, 16295, 16620, 16621, 16622, 16604
7317, 16295, 16303, 2273, 2272, 16622, 16623, 2295, 16606
7318, 2177, 2178, 16304, 16296, 2200, 16624, 16625, 16607
7319, 16296, 16304, 16305, 16297, 16625, 16626, 16627, 16609
7320, 16297, 16305, 16306, 16298, 16627, 16628, 16629, 16611
7321, 16298, 16306, 16307, 16299, 16629, 16630, 16631, 16613
7322, 16299, 16307, 16308, 16300, 16631, 16632, 16633, 16615
7323, 16300, 16308, 16309, 16301, 16633, 16634, 16635, 16617
7324, 16301, 16309, 16310, 16302, 16635, 16636, 16637, 16619
7325, 16302, 16310, 16311, 16303, 16637, 16638, 16639, 16621
7326, 16303, 16311, 2274, 2273, 16639, 16640, 2296, 16623
7327, 2178, 2179, 16312, 16304, 2201, 16641, 16642, 16624
7328, 16304, 16312, 16313, 16305, 16642, 16643, 16644, 16626
7329, 16305, 16313, 16314, 16306, 16644, 16645, 16646, 16628
7330, 16306, 16314, 16315, 16307, 16646, 16647, 16648, 16630
7331, 16307, 16315, 16316, 16308, 16648, 16649, 16650, 16632
7332, 16308, 16316, 16317, 16309, 16650, 16651, 16652, 16634
7333, 16309, 16317, 16318, 16310, 16652, 16653, 16654, 16636
7334, 16310, 16318, 16319, 16311, 16654, 16655, 16656, 16638
7335, 16311, 16319, 2275, 2274, 16656, 16657, 2297, 16640
7336, 2179, 2180, 16320, 16312, 2202, 16658, 16659, 16641
7337, 16312, 16320, 16321, 16313, 16659, 16660, 16661, 16643
7338, 16313, 16321, 16322, 16314, 16661, 16662, 16663, 16645
7339, 16314, 16322, 16323, 16315, 16663, 16664, 16665, 16647
7340, 16315, 16323, 16324, 16316, 16665, 16666, 16667, 16649
7341, 16316, 16324, 16325, 16317, 16667, 16668, 16669, 16651
7342, 16317, 16325, 16326, 16318, 16669, 16670, 16671, 16653
7343, 16318, 16326, 16327, 16319, 16671, 16672, 16673, 16655
7344, 16319, 16327, 2276, 2275, 16673, 16674, 2298, 16657
7345, 2180, 2181, 16328, 16320, 2203, 16675, 16676, 16658
7346, 16320, 16328, 16329, 16321, 16676, 16677, 16678, 16660
7347, 16321, 16329, 16330, 16322, 16678, 16679, 16680, 16662
7348, 16322, 16330, 16331, 16323, 16680, 16681, 16682, 16664
7349, 16323, 16331, 16332, 16324, 16682, 16683, 16684, 16666
7350, 16324, 16332, 16333, 16325, 16684, 16685, 16686, 16668
7351, 16325, 16333, 16334, 16326, 16686, 16687, 16688, 16670
7352, 16326, 16334, 16335, 16327, 16688, 16689, 16690, 16672
7353, 16327, 16335, 2277, 2276, 16690, 16691, 2299, 16674
7354, 2181, 2182, 16336, 16328, 2204, 16692, 16693, 16675
7355, 16328, 16336, 16337, 16329, 16693, 16694, 16695, 16677
7356, 16329, 16337, 16338, 16330, 16695, 16696, 16697, 16679
7357, 16330, 16338, 16339, 16331, 16697, 16698, 16699, 16681
7358, 16331, 16339, 16340, 16332, 16699, 16700, 16701, 16683
7359, 16332, 16340, 16341, 16333, 16701, 16702, 16703, 16685
7360, 16333, 16341, 16342, 16334, 16703, 16704, 16705, 16687
7361, 16334, 16342, 16343, 16335, 16705, 16706, 16707, 16689
7362, 16335, 16343, 2278, 2277, 16707, 16708, 2300, 16691
7363, 2182, 2183, 16344, 16336, 2205, 16709, 16710, 16692
7364, 16336, 16344, 16345, 16337, 16710, 16711, 16712, 16694
7365, 16337, 16345, 16346, 16338, 16712, 16713, 16714, 16696
7366, 16338, 16346, 16347, 16339, 16714, 16715, 16716, 16698
7367, 16339, 16347, 16348, 16340, 16716, 16717, 16718, 16700
7368, 16340, 16348, 16349, 16341, 16718, 16719, 16720, 16702
7369, 16341, 16349, 16350, 16342, 16720, 16721, 16722, 16704
7370, 16342, 16350, 16351, 16343, 16722, 16723, 16724, 16706
7371, 16343, 16351, 2279, 2278, 16724, 16725, 2301, 16708
7372, 2183, 72, 2372, 16344, 2206, 2381, 16726, 16709
7373, 16344, 2372, 2371, 16345, 16726, 2380, 16727, 16711
7374, 16345, 2371, 2370, 16346, 16727, 2379, 16728, 16713
7375, 16346, 2370, 2369, 16347, 16728, 2378, 16729, 16715
7376, 16347, 2369, 2368, 16348, 16729, 2377, 16730, 16717
7377, 16348, 2368, 2367, 16349, 16730, 2376, 16731, 16719
7378, 16349, 2367, 2366, 16350, 16731, 2375, 16732, 16721
7379, 16350, 2366, 2365, 16351, 16732, 2374, 16733, 16723
7380, 16351, 2365, 75, 2279, 16733, 2373, 2302, 16725
*ELEMENT, type=CPS8, ELSET=Surface241
7381, 71, 2355, 16734, 2207, 2364, 16910, 16911, 2229
7382, 2355, 2354, 16735, 16734, 2363, 16912, 16913, 16910
7383, 2354, 2353, 16736, 16735, 2362, 16914, 16915, 16912
7384, 2353, 2352, 16737, 16736, 2361, 16916, 16917, 16914
7385, 2352, 2351, 16738, 16737, 2360, 16918, 16919, 16916
7386, 2351, 2350, 16739, 16738, 2359, 16920, 16921, 16918
7387, 2350, 2349, 16740, 16739, 2358, 16922, 16923, 16920
7388, 2349, 2348, 16741, 16740, 2357, 16924, 16925, 16922
7389, 2348, 74, 2303, 16741, 2356, 2325, 16926, 16924
7390, 2207, 16734, 16742, 2208, 16911, 16927, 16928, 2230
7391, 16734, 16735, 16743, 16742, 16913, 16929, 16930, 16927
7392, 16735, 16736, 16744, 16743, 16915, 16931, 16932, 16929
7393, 16736, 16737, 16745, 16744, 16917, 16933, 16934, 16931
7394, 16737, 16738, 16746, 16745, 16919, 16935, 16936, 16933
7395, 16738, 16739, 16747, 16746, 16921, 16937, 16938, 16935
7396, 16739, 16740, 16748, 16747, 16923, 16939, 16940, 16937
7397, 16740, 16741, 16749, 16748, 16925, 16941, 16942, 16939
7398, 16741, 2303, 2304, 16749, 16926, 2326, 16943, 16941
7399, 2208, 16742, 16750, 2209, 16928, 16944, 16945, 2231
7400, 16742, 16743, 16751, 16750, 16930, 16946, 16947, 16944
7401, 16743, 16744, 16752, 16751, 16932, 16948, 16949, 16946
7402, 16744, 16745, 16753, 16752, 16934, 16950, 16951, 16948
7403, 16745, 16746, 16754, 16753, 16936, 16952, 16953, 16950
7404, 16746, 16747, 16755, 16754, 16938, 16954, 16955, 16952
7405, 16747, 16748, 16756, 16755, 16940, 16956, 16957, 16954
7406, 16748, 16749, 16757, 16756, 16942, 16958, 16959, 16956
7407, 16749, 2304, 2305, 16757, 16943, 2327, 16960, 16958
7408, 2209, 16750, 16758, 2210, 16945, 16961, 16962, 2232
7409, 16750, 16751, 16759, 16758, 16947, 16963, 16964, 16961
7410, 16751, 16752, 16760, 16759, 16949, 16965, 16966, 16963
7411, 16752, 16753, 16761, 16760, 16951, 16967, 16968, 16965
7412, 16753, 16754, 16762, 16761, 16953, 16969, 16970, 16967
7413, 16754, 16755, 16763, 16762, 16955, 16971, 16972, 16969
7414, 16755, 16756, 16764, 16763, 16957, 16973, 16974, 16971
7415, 16756, 16757, 16765, 16764, 16959, 16975, 16976, 16973
7416, 16757, 2305, 2306, 16765, 16960, 2328, 16977, 16975
7417, 2210, 16758, 16766, 2211, 16962, 16978, 16979, 2233
7418, 16758, 16759, 16767, 16766, 16964, 16980, 16981, 16978
7419, 16759, 16760, 16768, 16767, 16966, 16982, 16983, 16980
7420, 16760, 16761, 16769, 16768, 16968, 16984, 16985, 16982
7421, 16761, 16762, 16770, 16769, 16970, 16986, 16987, 16984
7422, 16762, 16763, 16771, 16770, 16972, 16988, 16989, 16986
7423, 16763, 16764, 16772, 16771, 16974, 16990, 16991, 16988
7424, 16764, 16765, 16773, 16772, 16976, 16992, 16993, 16990
7425, 16765, 2306, 2307, 16773, 16977, 2329, 16994, 16992
7426, 2211, 16766, 16774, 2212, 16979, 16995, 16996, 2234
7427, 16766, 16767, 16775, 16774, 16981, 16997, 16998, 16995
7428, 16767, 16768, 16776, 16775, 16983, 16999, 17000, 16997
7429, 16768, 16769, 16777, 16776, 16985, 17001, 17002, 16999
7430, 16769, 16770, 16778, 16777, 16987, 17003, 17004, 17001
7431, 16770, 16771, 16779, 16778, 16989, 17005, 17006, 17003
7432, 16771, 16772, 16780, 16779, 16991, 17007, 17008, 17005
7433, 16772, 16773, 16781, 16780, 16993, 17009, 17010, 17007
7434, 16773, 2307, 2308, 16781, 16994, 2330, 17011, 17009
7435, 2212, 16774, 16782, 2213, 16996, 17012, 17013, 2235
7436, 16774, 16775, 16783, 16782, 16998, 17014, 17015, 17012
7437, 16775, 16776, 16784, 16783, 17000, 17016, 17017, 17014
7438, 16776, 16777, 16785, 16784, 17002, 17018, 17019, 17016
7439, 16777, 16778, 16786, 16785, 17004, 17020, 17021, 17018
7440, 16778, 16779, 16787, 16786, 17006, 17022, 17023, 17020
7441, 16779, 16780, 16788, 16787, 17008, 17024, 17025, 17022
7442, 16780, 16781, 16789, 16788, 17010, 17026, 17027, 17024
7443, 16781, 2308, 2309, 16789, 17011, 2331, 17028, 17026
7444, 2213, 16782, 16790, 2214, 17013, 17029, 17030, 2236
7445, 16782, 16783, 16791, 16790, 17015, 17031, 17032, 17029
7446, 16783, 16784, 16792, 16791, 17017, 17033, 17034, 17031
7447, 16784, 16785, 16793, 16792, 17019, 17035, 17036, 17033
7448, 16785, 16786, 16794, 16793, 17021, 17037, 17038, 17035
7449, 16786, 16787, 16795, 16794, 17023, 17039, 17040, 17037
7450, 16787, 16788, 16796, 16795, 17025, 17041, 17042, 17039
7451, 16788, 16789, 16797, 16796, 17027, 17043, 17044, 17041
7452, 16789, 2309, 2310, 16797, 17028, 2332, 17045, 17043
7453, 2214, 16790, 16798, 2215, 17030, 17046, 17047, 2237
7454, 16790, 16791, 16799, 16798, 17032, 17048, 17049, 17046
7455, 16791, 16792, 16800, 16799, 17034, 17050, 17051, 17048
7456, 16792, 16793, 16801, 16800, 17036, 17052, 17053, 17050
7457, 16793, 16794, 16802, 16801, 17038, 17054, 17055, 17052
7458, 16794, 16795, 16803, 16802, 17040, 17056, 17057, 17054
7459, 16795, 16796, 16804, 16803, 17042, 17058, 17059, 17056
7460, 16796, 16797, 16805, 16804, 17044, 17060, 17061, 17058
7461, 16797, 2310, 2311, 16805, 17045, 2333, 17062, 17060
7462, 2215, 16798, 16806, 2216, 17047, 17063, 17064, 2238
7463, 16798, 16799, 16807, 16806, 17049, 17065, 17066, 17063
7464, 16799, 16800, 16808, 16807, 17051, 17067, 17068, 17065
7465, 16800, 16801, 16809, 16808, 17053, 17069, 17070, 17067
7466, 16801, 16802, 16810, 16809, 17055, 17071, 17072, 17069
7467, 16802, 16803, 16811, 16810, 17057, 17073, 17074, 17071
7468, 16803, 16804, 16812, 16811, 17059, 17075, 17076, 17073
7469, 16804, 16805, 16813, 16812, 17061, 17077, 17078, 17075
7470, 16805, 2311, 2312, 16813, 17062, 2334, 17079, 17077
7471, 2216, 16806, 16814, 2217, 17064, 17080, 17081, 2239
7472, 16806, 16807, 16815, 16814, 17066, 17082, 17083, 17080
7473, 16807, 16808, 16816, 16815, 17068, 17084, 17085, 17082
7474, 16808, 16809, 16817, 16816, 17070, 17086, 17087, 17084
7475, 16809, 16810, 16818, 16817, 17072, 17088, 17089, 17086
7476, 16810, 16811, 16819, 16818, 17074, 17090, 17091, 17088
7477, 16811, 16812, 16820, 16819, 17076, 17092, 17093, 17090
7478, 16812, 16813, 16821, 16820, 17078, 17094, 17095, 17092
7479, 16813, 2312, 2313, 16821, 17079, 2335, 17096, 17094
7480, 2217, 16814, 16822, 2218, 17081, 17097, 17098, 2240
7481, 16814, 16815, 16823, 16822, 17083, 17099, 17100, 17097
7482, 16815, 16816, 16824, 16823, 17085, 17101, 17102, 17099
7483, 16816, 16817, 16825, 16824, 17087, 17103, 17104, 17101
7484, 16817, 16818, 16826, 16825, 17089, 17105, 17106, 17103
7485, 16818, 16819, 16827, 16826, 17091, 17107, 17108, 17105
7486, 16819, 16820, 16828, 16827, 17093, 17109, 17110, 17107
7487, 16820, 16821, 16829, 16828, 17095, 17111, 17112, 17109
7488, 16821, 2313, 2314, 16829, 17096, 2336, 17113, 17111
7489, 2218, 16822, 16830, 2219, 17098, 17114, 17115, 2241
7490, 16822, 16823, 16831, 16830, 17100, 17116, 17117, 17114
7491, 16823, 16824, 16832, 16831, 17102, 17118, 17119, 17116
7492, 16824, 16825, 16833, 16832, 17104, 17120, 17121, 17118
7493, 16825, 16826, 16834, 16833, 17106, 17122, 17123, 17120
7494, 16826, 16827, 16835, 16834, 17108, 17124, 17125, 17122
7495, 16827, 16828, 16836, 16835, 17110, 17126, 17127, 17124
7496, 16828, 16829, 16837, 16836, 17112, 17128, 17129, 17126
7497, 16829, 2314, 2315, 16837, 17113, 2337, 17130, 17128
7498, 2219, 16830, 16838, 2220, 17115, 17131, 17132, 2242
7499, 16830, 16831, 16839, 16838, 17117, 17133, 17134, 17131
7500, 16831, 16832, 16840, 16839, 17119, 17135, 17136, 17133
7501, 16832, 16833, 16841, 16840, 17121, 17137, 17138, 17135
7502, 16833, 16834, 16842, 16841, 17123, 17139, 17140, 17137
7503, 16834, 16835, 16843, 16842, 17125, 17141, 17142, 17139
7504, 16835, 16836, 16844, 16843, 17127, 17143, 17144, 17141
7505, 16836, 16837, 16845, 16844, 17129, 17145, 17146, 17143
7506, 16837, 2315, 2316, 16845, 17130, 2338, 17147, 17145
7507, 2220, 16838, 16846, 2221, 17132, 17148, 17149, 2243
7508, 16838, 16839, 16847, 16846, 17134, 17150, 17151, 17148
7509, 16839, 16840, 16848, 16847, 17136, 17152, 17153, 17150
7510, 16840, 16841, 16849, 16848, 17138, 17154, 17155, 17152
7511, 16841, 16842, 16850, 16849, 17140, 17156, 17157, 17154
7512, 16842, 16843, 16851, 16850, 17142, 17158, 17159, 17156
7513, 16843, 16844, 16852, 16851, 17144, 17160, 17161, 17158
7514, 16844, 16845, 16853, 16852, 17146, 17162, 17163, 17160
7515, 16845, 2316, 2317, 16853, 17147, 2339, 17164, 17162
7516, 2221, 16846, 16854, 2222, 17149, 17165, 17166, 2244
7517, 16846, 16847, 16855, 16854, 17151, 17167, 17168, 17165
7518, 16847, 16848, 16856, 16855, 17153, 17169, 17170, 17167
7519, 16848, 16849, 16857, 16856, 17155, 17171, 17172, 17169
7520, 16849, 16850, 16858, 16857, 17157, 17173, 17174, 17171
7521, 16850, 16851, 16859, 16858, 17159, 17175, 17176, 17173
7522, 16851, 16852, 16860, 16859, 17161, 17177, 17178, 17175
7523, 16852, 16853, 16861, 16860, 17163, 17179, 17180, 17177
7524, 16853, 2317, 2318, 16861, 17164, 2340, 17181, 17179
7525, 2222, 16854, 16862, 2223, 17166, 17182, 17183, 2245
7526, 16854, 16855, 16863, 16862, 17168, 17184, 17185, 17182
7527, 16855, 16856, 16864, 16863, 17170, 17186, 17187, 17184
7528, 16856, 16857, 16865, 16864, 17172, 17188, 17189, 17186
7529, 16857, 16858, 16866, 16865, 17174, 17190, 17191, 17188
7530, 16858, 16859, 16867, 16866, 17176, 17192, 17193, 17190
7531, 16859, 16860, 16868, 16867, 17178, 17194, 17195, 17192
7532, 16860, 16861, 16869, 16868, 17180, 17196, 17197, 17194
7533, 16861, 2318, 2319, 16869, 17181, 2341, 17198, 17196
7534, 2223, 16862, 16870, 2224, 17183, 17199, 17200, 2246
7535, 16862, 16863, 16871, 16870, 17185, 17201, 17202, 17199
7536, 16863, 16864, 16872, 16871, 17187, 17203, 17204, 17201
7537, 16864, 16865, 16873, 16872, 17189, 17205, 17206, 17203
7538, 16865, 16866, 16874, 16873, 17191, 17207, 17208, 17205
7539, 16866, 16867, 16875, 16874, 17193, 17209, 17210, 17207
7540, 16867, 16868, 16876, 16875, 17195, 17211, 17212, 17209
7541, 16868, 16869, 16877, 16876, 17197, 17213, 17214, 17211
7542, 16869, 2319, 2320, 16877, 17198, 2342, 17215, 17213
7543, 2224, 16870, 16878, 2225, 17200, 17216, 17217, 2247
7544, 16870, 16871, 16879, 16878, 17202, 17218, 17219, 17216
7545, 16871, 16872, 16880, 16879, 17204, 17220, 17221, 17218
7546, 16872, 16873, 16881, 16880, 17206, 17222, 17223, 17220
7547, 16873, 16874, 16882, 16881, 17208, 17224, 17225, 17222
7548, 16874, 16875, 16883, 16882, 17210, 17226, 17227, 17224
7549, 16875, 16876, 16884, 16883, 17212, 17228, 17229, 17226
7550, 16876, 16877, 16885, 16884, 17214, 17230, 17231, 17228
7551, 16877, 2320, 2321, 16885, 17215, 2343, 17232, 17230
7552, 2225, 16878, 16886, 2226, 17217, 17233, 17234, 2248
7553, 16878, 16879, 16887, 16886, 17219, 17235, 17236, 17233
7554, 16879, 16880, 16888, 16887, 17221, 17237, 17238, 17235
7555, 16880, 16881, 16889, 16888, 17223, 17239, 17240, 17237
7556, 16881, 16882, 16890, 16889, 17225, 17241, 17242, 17239
7557, 16882, 16883, 16891, 16890, 17227, 17243, 17244, 17241
7558, 16883, 16884, 16892, 16891, 17229, 17245, 17246, 17243
7559, 16884, 16885, 16893, 16892, 17231, 17247, 17248, 17245
7560, 16885, 2321, 2322, 16893, 17232, 2344, 17249, 17247
7561, 2226, 16886, 16894, 2227, 17234, 17250, 17251, 2249
7562, 16886, 16887, 16895, 16894, 17236, 17252, 17253, 17250
7563, 16887, 16888, 16896, 16895, 17238, 17254, 17255, 17252
7564, 16888, 16889, 16897, 16896, 17240, 17256, 17257, 17254
7565, 16889, 16890, 16898, 16897, 17242, 17258, 17259, 17256
7566, 16890, 16891, 16899, 16898, 17244, 17260, 17261, 17258
7567, 16891, 16892, 16900, 16899, 17246, 17262, 17263, 17260
7568, 16892, 16893, 16901, 16900, 17248, 17264, 17265, 17262
7569, 16893, 2322, 2323, 16901, 17249, 2345, 17266, 17264
7570, 2227, 16894, 16902, 2228, 17251, 17267, 17268, 2250
7571, 16894, 16895, 16903, 16902, 17253, 17269, 17270, 17267
7572, 16895, 16896, 16904, 16903, 17255, 17271, 17272, 17269
7573, 16896, 16897, 16905, 16904, 17257, 17273, 17274, 17271
7574, 16897, 16898, 16906, 16905, 17259, 17275, 17276, 17273
7575, 16898, 16899, 16907, 16906, 17261, 17277, 17278, 17275
7576, 16899, 16900, 16908, 16907, 17263, 17279, 17280, 17277
7577, 16900, 16901, 16909, 16908, 17265, 17281, 17282, 17279
7578, 16901, 2323, 2324, 16909, 17266, 2346, 17283, 17281
7579, 2228, 16902, 2389, 73, 17268, 17284, 2398, 2251
7580, 16902, 16903, 2388, 2389, 17270, 17285, 2397, 17284
7581, 16903, 16904, 2387, 2388, 17272, 17286, 2396, 17285
7582, 16904, 16905, 2386, 2387, 17274, 17287, 2395, 17286
7583, 16905, 16906, 2385, 2386, 17276, 17288, 2394, 17287
7584, 16906, 16907, 2384, 2385, 17278, 17289, 2393, 17288
7585, 16907, 16908, 2383, 2384, 17280, 17290, 2392, 17289
7586, 16908, 16909, 2382, 2383, 17282, 17291, 2391, 17290
7587, 16909, 2324, 76, 2382, 17283, 2347, 2390, 17291
*ELEMENT, type=CPS8, ELSET=Surface242
7588, 53, 2162, 17292, 1705, 2184, 17336, 17337, 1707
7589, 1705, 17292, 17293, 1706, 17337, 17338, 17339, 1708
7590, 1706, 17293, 2399, 54, 17339, 17340, 2421, 1709
7591, 2162, 2163, 17294, 17292, 2185, 17341, 17342, 17336
7592, 17292, 17294, 17295, 17293, 17342, 17343, 17344, 17338
7593, 17293, 17295, 2400, 2399, 17344, 17345, 2422, 17340
7594, 2163, 2164, 17296, 17294, 2186, 17346, 17347, 17341
7595, 17294, 17296, 17297, 17295, 17347, 17348, 17349, 17343
7596, 17295, 17297, 2401, 2400, 17349, 17350, 2423, 17345
7597, 2164, 2165, 17298, 17296, 2187, 17351, 17352, 17346
7598, 17296, 17298, 17299, 17297, 17352, 17353, 17354, 17348
7599, 17297, 17299, 2402, 2401, 17354, 17355, 2424, 17350
7600, 2165, 2166, 17300, 17298, 2188, 17356, 17357, 17351
7601, 17298, 17300, 17301, 17299, 17357, 17358, 17359, 17353
7602, 17299, 17301, 2403, 2402, 17359, 17360, 2425, 17355
7603, 2166, 2167, 17302, 17300, 2189, 17361, 17362, 17356
7604, 17300, 17302, 17303, 17301, 17362, 17363, 17364, 17358
7605, 17301, 17303, 2404, 2403, 17364, 17365, 2426, 17360
7606, 2167, 2168, 17304, 17302, 2190, 17366, 17367, 17361
7607, 17302, 17304, 17305, 17303, 17367, 17368, 17369, 17363
7608, 17303, 17305, 2405, 2404, 17369, 17370, 2427, 17365
7609, 2168, 2169, 17306, 17304, 2191, 17371, 17372, 17366
7610, 17304, 17306, 17307, 17305, 17372, 17373, 17374, 17368
7611, 17305, 17307, 2406, 2405, 17374, 17375, 2428, 17370
7612, 2169, 2170, 17308, 17306, 2192, 17376, 17377, 17371
7613, 17306, 17308, 17309, 17307, 17377, 17378, 17379, 17373
7614, 17307, 17309, 2407, 2406, 17379, 17380, 2429, 17375
7615, 2170, 2171, 17310, 17308, 2193, 17381, 17382, 17376
7616, 17308, 17310, 17311, 17309, 17382, 17383, 17384, 17378
7617, 17309, 17311, 2408, 2407, 17384, 17385, 2430, 17380
7618, 2171, 2172, 17312, 17310, 2194, 17386, 17387, 17381
7619, 17310, 17312, 17313, 17311, 17387, 17388, 17389, 17383
7620, 17311, 17313, 2409, 2408, 17389, 17390, 2431, 17385
7621, 2172, 2173, 17314, 17312, 2195, 17391, 17392, 17386
7622, 17312, 17314, 17315, 17313, 17392, 17393, 17394, 17388
7623, 17313, 17315, 2410, 2409, 17394, 17395, 2432, 17390
7624, 2173, 2174, 17316, 17314, 2196, 17396, 17397, 17391
7625, 17314, 17316, 17317, 17315, 17397, 17398, 17399, 17393
7626, 17315, 17317, 2411, 2410, 17399, 17400, 2433, 17395
7627, 2174, 2175, 17318, 17316, 2197, 17401, 17402, 17396
7628, 17316, 17318, 17319, 17317, 17402, 17403, 17404, 17398
7629, 17317, 17319, 2412, 2411, 17404, 17405, 2434, 17400
7630, 2175, 2176, 17320, 17318, 2198, 17406, 17407, 17401
7631, 17318, 17320, 17321, 17319, 17407, 17408, 17409, 17403
7632, 17319, 17321, 2413, 2412, 17409, 17410, 2435, 17405
7633, 2176, 2177, 17322, 17320, 2199, 17411, 17412, 17406
7634, 17320, 17322, 17323, 17321, 17412, 17413, 17414, 17408
7635, 17321, 17323, 2414, 2413, 17414, 17415, 2436, 17410
7636, 2177, 2178, 17324, 17322, 2200, 17416, 17417, 17411
7637, 17322, 17324, 17325, 17323, 17417, 17418, 17419, 17413
7638, 17323, 17325, 2415, 2414, 17419, 17420, 2437, 17415
7639, 2178, 2179, 17326, 17324, 2201, 17421, 17422, 17416
7640, 17324, 17326, 17327, 17325, 17422, 17423, 17424, 17418
7641, 17325, 17327, 2416, 2415, 17424, 17425, 2438, 17420
7642, 2179, 2180, 17328, 17326, 2202, 17426, 17427, 17421
7643, 17326, 17328, 17329, 17327, 17427, 17428, 17429, 17423
7644, 17327, 17329, 2417, 2416, 17429, 17430, 2439, 17425
7645, 2180, 2181, 17330, 17328, 2203, 17431, 17432, 17426
7646, 17328, 17330, 17331, 17329, 17432, 17433, 17434, 17428
7647, 17329, 17331, 2418, 2417, 17434, 17435, 2440, 17430
7648, 2181, 2182, 17332, 17330, 2204, 17436, 17437, 17431
7649, 17330, 17332, 17333, 17331, 17437, 17438, 17439, 17433
7650, 17331, 17333, 2419, 2418, 17439, 17440, 2441, 17435
7651, 2182, 2183, 17334, 17332, 2205, 17441, 17442, 17436
7652, 17332, 17334, 17335, 17333, 17442, 17443, 17444, 17438
7653, 17333, 17335, 2420, 2419, 17444, 17445, 2442, 17440
7654, 2183, 72, 2444, 17334, 2206, 2446, 17446, 17441
7655, 17334, 2444, 2445, 17335, 17446, 2447, 17447, 17443
7656, 17335, 2445, 77, 2420, 17447, 2448, 2443, 17445
*ELEMENT, type=CPS8, ELSET=Surface243
7657, 55, 1724, 17448, 2258, 1726, 17492, 17493, 2280
7658, 1724, 1725, 17449, 17448, 1727, 17494, 17495, 17492
7659, 1725, 56, 2449, 17449, 1728, 2471, 17496, 17494
7660, 2258, 17448, 17450, 2259, 17493, 17497, 17498, 2281
7661, 17448, 17449, 17451, 17450, 17495, 17499, 17500, 17497
7662, 17449, 2449, 2450, 17451, 17496, 2472, 17501, 17499
7663, 2259, 17450, 17452, 2260, 17498, 17502, 17503, 2282
7664, 17450, 17451, 17453, 17452, 17500, 17504, 17505, 17502
7665, 17451, 2450, 2451, 17453, 17501, 2473, 17506, 17504
7666, 2260, 17452, 17454, 2261, 17503, 17507, 17508, 2283
7667, 17452, 17453, 17455, 17454, 17505, 17509, 17510, 17507
7668, 17453, 2451, 2452, 17455, 17506, 2474, 17511, 17509
7669, 2261, 17454, 17456, 2262, 17508, 17512, 17513, 2284
7670, 17454, 17455, 17457, 17456, 17510, 17514, 17515, 17512
7671, 17455, 2452, 2453, 17457, 17511, 2475, 17516, 17514
7672, 2262, 17456, 17458, 2263, 17513, 17517, 17518, 2285
7673, 17456, 17457, 17459, 17458, 17515, 17519, 17520, 17517
7674, 17457, 2453, 2454, 17459, 17516, 2476, 17521, 17519
7675, 2263, 17458, 17460, 2264, 17518, 17522, 17523, 2286
7676, 17458, 17459, 17461, 17460, 17520, 17524, 17525, 17522
7677, 17459, 2454, 2455, 17461, 17521, 2477, 17526, 17524
7678, 2264, 17460, 17462, 2265, 17523, 17527, 17528, 2287
7679, 17460, 17461, 17463, 17462, 17525, 17529, 17530, 17527
7680, 17461, 2455, 2456, 17463, 17526, 2478, 17531, 17529
7681, 2265, 17462, 17464, 2266, 17528, 17532, 17533, 2288
7682, 17462, 17463, 17465, 17464, 17530, 17534, 17535, 17532
7683, 17463, 2456, 2457, 17465, 17531, 2479, 17536, 17534
7684, 2266, 17464, 17466, 2267, 17533, 17537, 17538, 2289
7685, 17464, 17465, 17467, 17466, 17535, 17539, 17540, 17537
7686, 17465, 2457, 2458, 17467, 17536, 2480, 17541, 17539
7687, 2267, 17466, 17468, 2268, 17538, 17542, 17543, 2290
7688, 17466, 17467, 17469, 17468, 17540, 17544, 17545, 17542
7689, 17467, 2458, 2459, 17469, 17541, 2481, 17546, 17544
7690, 2268, 17468, 17470, 2269, 17543, 17547, 17548, 2291
7691, 17468, 17469, 17471, 17470, 17545, 17549, 17550, 17547
7692, 17469, 2459, 2460, 17471, 17546, 2482, 17551, 17549
7693, 2269, 17470, 17472, 2270, 17548, 17552, 17553, 2292
7694, 17470, 17471, 17473, 17472, 17550, 17554, 17555, 17552
7695, 17471, 2460, 2461, 17473, 17551, 2483, 17556, 17554
7696, 2270, 17472, 17474, 2271, 17553, 17557, 17558, 2293
7697, 17472, 17473, 17475, 17474, 17555, 17559, 17560, 17557
7698, 17473, 2461, 2462, 17475, 17556, 2484, 17561, 17559
7699, 2271, 17474, 17476, 2272, 17558, 17562, 17563, 2294
7700, 17474, 17475, 17477, 17476, 17560, 17564, 17565, 17562
7701, 17475, 2462, 2463, 17477, 17561, 2485, 17566, 17564
7702, 2272, 17476, 17478, 2273, 17563, 17567, 17568, 2295
7703, 17476, 17477, 17479, 17478, 17565, 17569, 17570, 17567
7704, 17477, 2463, 2464, 17479, 17566, 2486, 17571, 17569
7705, 2273, 17478, 17480, 2274, 17568, 17572, 17573, 2296
7706, 17478, 17479, 17481, 17480, 17570, 17574, 17575, 17572
7707, 17479, 2464, 2465, 17481, 17571, 2487, 17576, 17574
7708, 2274, 17480, 17482, 2275, 17573, 17577, 17578, 2297
7709, 17480, 17481, 17483, 17482, 17575, 17579, 17580, 17577
7710, 17481, 2465, 2466, 17483, 17576, 2488, 17581, 17579
7711, 2275, 17482, 17484, 2276, 17578, 17582, 17583, 2298
7712, 17482, 17483, 17485, 17484, 17580, 17584, 17585, 17582
7713, 17483, 2466, 2467, 17485, 17581, 2489, 17586, 17584
7714, 2276, 17484, 17486, 2277, 17583, 17587, 17588, 2299
7715, 17484, 17485, 17487, 17486, 17585, 17589, 17590, 17587
7716, 17485, 2467, 2468, 17487, 17586, 2490, 17591, 17589
7717, 2277, 17486, 17488, 2278, 17588, 17592, 17593, 2300
7718, 17486, 17487, 17489, 17488, 17590, 17594, 17595, 17592
7719, 17487, 2468, 2469, 17489, 17591, 2491, 17596, 17594
7720, 2278, 17488, 17490, 2279, 17593, 17597, 17598, 2301
7721, 17488, 17489, 17491, 17490, 17595, 17599, 17600, 17597
7722, 17489, 2469, 2470, 17491, 17596, 2492, 17601, 17599
7723, 2279, 17490, 2494, 75, 17598, 17602, 2496, 2302
7724, 17490, 17491, 2495, 2494, 17600, 17603, 2497, 17602
7725, 17491, 2470, 78, 2495, 17601, 2493, 2498, 17603
*ELEMENT, type=CPS8, ELSET=Surface244
7726, 54, 2399, 17604, 1753, 2421, 17780, 17781, 1762
7727, 1753, 17604, 17605, 1752, 17781, 17782, 17783, 1761
7728, 1752, 17605, 17606, 1751, 17783, 17784, 17785, 1760
7729, 1751, 17606, 17607, 1750, 17785, 17786, 17787, 1759
7730, 1750, 17607, 17608, 1749, 17787, 17788, 17789, 1758
7731, 1749, 17608, 17609, 1748, 17789, 17790, 17791, 1757
7732, 1748, 17609, 17610, 1747, 17791, 17792, 17793, 1756
7733, 1747, 17610, 17611, 1746, 17793, 17794, 17795, 1755
7734, 1746, 17611, 2449, 56, 17795, 17796, 2471, 1754
7735, 2399, 2400, 17612, 17604, 2422, 17797, 17798, 17780
7736, 17604, 17612, 17613, 17605, 17798, 17799, 17800, 17782
7737, 17605, 17613, 17614, 17606, 17800, 17801, 17802, 17784
7738, 17606, 17614, 17615, 17607, 17802, 17803, 17804, 17786
7739, 17607, 17615, 17616, 17608, 17804, 17805, 17806, 17788
7740, 17608, 17616, 17617, 17609, 17806, 17807, 17808, 17790
7741, 17609, 17617, 17618, 17610, 17808, 17809, 17810, 17792
7742, 17610, 17618, 17619, 17611, 17810, 17811, 17812, 17794
7743, 17611, 17619, 2450, 2449, 17812, 17813, 2472, 17796
7744, 2400, 2401, 17620, 17612, 2423, 17814, 17815, 17797
7745, 17612, 17620, 17621, 17613, 17815, 17816, 17817, 17799
7746, 17613, 17621, 17622, 17614, 17817, 17818, 17819, 17801
7747, 17614, 17622, 17623, 17615, 17819, 17820, 17821, 17803
7748, 17615, 17623, 17624, 17616, 17821, 17822, 17823, 17805
7749, 17616, 17624, 17625, 17617, 17823, 17824, 17825, 17807
7750, 17617, 17625, 17626, 17618, 17825, 17826, 17827, 17809
7751, 17618, 17626, 17627, 17619, 17827, 17828, 17829, 17811
7752, 17619, 17627, 2451, 2450, 17829, 17830, 2473, 17813
7753, 2401, 2402, 17628, 17620, 2424, 17831, 17832, 17814
7754, 17620, 17628, 17629, 17621, 17832, 17833, 17834, 17816
7755, 17621, 17629, 17630, 17622, 17834, 17835, 17836, 17818
7756, 17622, 17630, 17631, 17623, 17836, 17837, 17838, 17820
7757, 17623, 17631, 17632, 17624, 17838, 17839, 17840, 17822
7758, 17624, 17632, 17633, 17625, 17840, 17841, 17842, 17824
7759, 17625, 17633, 17634, 17626, 17842, 17843, 17844, 17826
7760, 17626, 17634, 17635, 17627, 17844, 17845, 17846, 17828
7761, 17627, 17635, 2452, 2451, 17846, 17847, 2474, 17830
7762, 2402, 2403, 17636, 17628, 2425, 17848, 17849, 17831
7763, 17628, 17636, 17637, 17629, 17849, 17850, 17851, 17833
7764, 17629, 17637, 17638, 17630, 17851, 17852, 17853, 17835
7765, 17630, 17638, 17639, 17631, 17853, 17854, 17855, 17837
7766, 17631, 17639, 17640, 17632, 17855, 17856, 17857, 17839
7767, 17632, 17640, 17641, 17633, 17857, 17858, 17859, 17841
7768, 17633, 17641, 17642, 17634, 17859, 17860, 17861, 17843
7769, 17634, 17642, 17643, 17635, 17861, 17862, 17863, 17845
7770, 17635, 17643, 2453, 2452, 17863, 17864, 2475, 17847
7771, 2403, 2404, 17644, 17636, 2426, 17865, 17866, 17848
7772, 17636, 17644, 17645, 17637, 17866, 17867, 17868, 17850
7773, 17637, 17645, 17646, 17638, 17868, 17869, 17870, 17852
7774, 17638, 17646, 17647, 17639, 17870, 17871, 17872, 17854
7775, 17639, 17647, 17648, 17640, 17872, 17873, 17874, 17856
7776, 17640, 17648, 17649, 17641, 17874, 17875, 17876, 17858
7777, 17641, 17649, 17650, 17642, 17876, 17877, 17878, 17860
7778, 17642, 17650, 17651, 17643, 17878, 17879, 17880, 17862
7779, 17643, 17651, 2454, 2453, 17880, 17881, 2476, 17864
7780, 2404, 2405, 17652, 17644, 2427, 17882, 17883, 17865
7781, 17644, 17652, 17653, 17645, 17883, 17884, 17885, 17867
7782, 17645, 17653, 17654, 17646, 17885, 17886, 17887, 17869
7783, 17646, 17654, 17655, 17647, 17887, 17888, 17889, 17871
7784, 17647, 17655, 17656, 17648, 17889, 17890, 17891, 17873
7785, 17648, 17656, 17657, 17649, 17891, 17892, 17893, 17875
7786, 17649, 17657, 17658, 17650, 17893, 17894, 17895, 17877
7787, 17650, 17658, 17659, 17651, 17895, 17896, 17897, 17879
7788, 17651, 17659, 2455, 2454, 17897, 17898, 2477, 17881
7789, 2405, 2406, 17660, 17652, 2428, 17899, 17900, 17882
7790, 17652, 17660, 17661, 17653, 17900, 17901, 17902, 17884
7791, 17653, 17661, 17662, 17654, 17902, 17903, 17904, 17886
7792, 17654, 17662, 17663, 17655, 17904, 17905, 17906, 17888
7793, 17655, 17663, 17664, 17656, 17906, 17907, 17908, 17890
7794, 17656, 17664, 17665, 17657, 17908, 17909, 17910, 17892
7795, 17657, 17665, 17666, 17658, 17910, 17911, 17912, 17894
7796, 17658, 17666, 17667, 17659, 17912, 17913, 17914, 17896
7797, 17659, 17667, 2456, 2455, 17914, 17915, 2478, 17898
7798, 2406, 2407, 17668, 17660, 2429, 17916, 17917, 17899
7799, 17660, 17668, 17669, 17661, 17917, 17918, 17919, 17901
7800, 17661, 17669, 17670, 17662, 17919, 17920, 17921, 17903
7801, 17662, 17670, 17671, 17663, 17921, 17922, 17923, 17905
7802, 17663, 17671, 17672, 17664, 17923, 17924, 17925, 17907
7803, 17664, 17672, 17673, 17665, 17925, 17926, 17927, 17909
7804, 17665, 17673, 17674, 17666, 17927, 17928, 17929, 17911
7805, 17666, 17674, 17675, 17667, 17929, 17930, 17931, 17913
7806, 17667, 17675, 2457, 2456, 17931, 17932, 2479, 17915
7807, 2407, 2408, 17676, 17668, 2430, 17933, 17934, 17916
7808, 17668, 17676, 17677, 17669, 17934, 17935, 17936, 17918
7809, 17669, 17677, 17678, 17670, 17936, 17937, 17938, 17920
7810, 17670, 17678, 17679, 17671, 17938, 17939, 17940, 17922
7811, 17671, 17679, 17680, 17672, 17940, 17941, 17942, 17924
7812, 17672, 17680, 17681, 17673, 17942, 17943, 17944, 17926
7813, 17673, 17681, 17682, 17674, 17944, 17945, 17946, 17928
7814, 17674, 17682, 17683, 17675, 17946, 17947, 17948, 17930
7815, 17675, 17683, 2458, 2457, 17948, 17949, 2480, 17932
7816, 2408, 2409, 17684, 17676, 2431, 17950, 17951, 17933
7817, 17676, 17684, 17685, 17677, 17951, 17952, 17953, 17935
7818, 17677, 17685, 17686, 17678, 17953, 17954, 17955, 17937
7819, 17678, 17686, 17687, 17679, 17955, 17956, 17957, 17939
7820, 17679, 17687, 17688, 17680, 17957, 17958, 17959, 17941
7821, 17680, 17688, 17689, 17681, 17959, 17960, 17961, 17943
7822, 17681, 17689, 17690, 17682, 17961, 17962, 17963, 17945
7823, 17682, 17690, 17691, 17683, 17963, 17964, 17965, 17947
7824, 17683, 17691, 2459, 2458, 17965, 17966, 2481, 17949
7825, 2409, 2410, 17692, 17684, 2432, 17967, 17968, 17950
7826, 17684, 17692, 17693, 17685, 17968, 17969, 17970, 17952
7827, 17685, 17693, 17694, 17686, 17970, 17971, 17972, 17954
7828, 17686, 17694, 17695, 17687, 17972, 17973, 17974, 17956
7829, 17687, 17695, 17696, 17688, 17974, 17975, 17976, 17958
7830, 17688, 17696, 17697, 17689, 17976, 17977, 17978, 17960
7831, 17689, 17697, 17698, 17690, 17978, 17979, 17980, 17962
7832, 17690, 17698, 17699, 17691, 17980, 17981, 17982, 17964
7833, 17691, 17699, 2460, 2459, 17982, 17983, 2482, 17966
7834, 2410, 2411, 17700, 17692, 2433, 17984, 17985, 17967
7835, 17692, 17700, 17701, 17693, 17985, 17986, 17987, 17969
7836, 17693, 17701, 17702, 17694, 17987, 17988, 17989, 17971
7837, 17694, 17702, 17703, 17695, 17989, 17990, 17991, 17973
7838, 17695, 17703, 17704, 17696, 17991, 17992, 17993, 17975
7839, 17696, 17704, 17705, 17697, 17993, 17994, 17995, 17977
7840, 17697, 17705, 17706, 17698, 17995, 17996, 17997, 17979
7841, 17698, 17706, 17707, 17699, 17997, 17998, 17999, 17981
7842, 17699, 17707, 2461, 2460, 17999, 18000, 2483, 17983
7843, 2411, 2412, 17708, 17700, 2434, 18001, 18002, 17984
7844, 17700, 17708, 17709, 17701, 18002, 18003, 18004, 17986
7845, 17701, 17709, 17710, 17702, 18004, 18005, 18006, 17988
7846, 17702, 17710, 17711, 17703, 18006, 18007, 18008, 17990
7847, 17703, 17711, 17712, 17704, 18008, 18009, 18010, 17992
7848, 17704, 17712, 17713, 17705, 18010, 18011, 18012, 17994
7849, 17705, 17713, 17714, 17706, 18012, 18013, 18014, 17996
7850, 17706, 17714, 17715, 17707, 18014, 18015, 18016, 17998
7851, 17707, 17715, 2462, 2461, 18016, 18017, 2484, 18000
7852, 2412, 2413, 17716, 17708, 2435, 18018, 18019, 18001
7853, 17708, 17716, 17717, 17709, 18019, 18020, 18021, 18003
7854, 17709, 17717, 17718, 17710, 18021, 18022, 18023, 18005
7855, 17710, 17718, 17719, 17711, 18023, 18024, 18025, 18007
7856, 17711, 17719, 17720, 17712, 18025, 18026, 18027, 18009
7857, 17712, 17720, 17721, 17713, 18027, 18028, 18029, 18011
7858, 17713, 17721, 17722, 17714, 18029, 18030, 18031, 18013
7859, 17714, 17722, 17723, 17715, 18031, 18032, 18033, 18015
7860, 17715, 17723, 2463, 2462, 18033, 18034, 2485, 18017
7861, 2413, 2414, 17724, 17716, 2436, 18035, 18036, 18018
7862, 17716, 17724, 17725, 17717, 18036, 18037, 18038, 18020
7863, 17717, 17725, 17726, 17718, 18038, 18039, 18040, 18022
7864, 17718, 17726, 17727, 17719, 18040, 18041, 18042, 18024
7865, 17719, 17727, 17728, 17720, 18042, 18043, 18044, 18026
7866, 17720, 17728, 17729, 17721, 18044, 18045, 18046, 18028
7867, 17721, 17729, 17730, 17722, 18046, 18047, 18048, 18030
7868, 17722, 17730, 17731, 17723, 18048, 18049, 18050, 18032
7869, 17723, 17731, 2464, 2463, 18050, 18051, 2486, 18034
7870, 2414, 2415, 17732, 17724, 2437, 18052, 18053, 18035
7871, 17724, 17732, 17733, 17725, 18053, 18054, 18055, 18037
7872, 17725, 17733, 17734, 17726, 18055, 18056, 18057, 18039
7873, 17726, 17734, 17735, 17727, 18057, 18058, 18059, 18041
7874, 17727, 17735, 17736, 17728, 18059, 18060, 18061, 18043
7875, 17728, 17736, 17737, 17729, 18061, 18062, 18063, 18045
7876, 17729, 17737, 17738, 17730, 18063, 18064, 18065, 18047
7877, 17730, 17738, 17739, 17731, 18065, 18066, 18067, 18049
7878, 17731, 17739, 2465, 2464, 18067, 18068, 2487, 18051
7879, 2415, 2416, 17740, 17732, 2438, 18069, 18070, 18052
7880, 17732, 17740, 17741, 17733, 18070, 18071, 18072, 18054
7881, 17733, 17741, 17742, 17734, 18072, 18073, 18074, 18056
7882, 17734, 17742, 17743, 17735, 18074, 18075, 18076, 18058
7883, 17735, 17743, 17744, 17736, 18076, 18077, 18078, 18060
7884, 17736, 17744, 17745, 17737, 18078, 18079, 18080, 18062
7885, 17737, 17745, 17746, 17738, 18080, 18081, 18082, 18064
7886, 17738, 17746, 17747, 17739, 18082, 18083, 18084, 18066
7887, 17739, 17747, 2466, 2465, 18084, 18085, 2488, 18068
7888, 2416, 2417, 17748, 17740, 2439, 18086, 18087, 18069
7889, 17740, 17748, 17749, 17741, 18087, 18088, 18089, 18071
7890, 17741, 17749, 17750, 17742, 18089, 18090, 18091, 18073
7891, 17742, 17750, 17751, 17743, 18091, 18092, 18093, 18075
7892, 17743, 17751, 17752, 17744, 18093, 18094, 18095, 18077
7893, 17744, 17752, 17753, 17745, 18095, 18096, 18097, 18079
7894, 17745, 17753, 17754, 17746, 18097, 18098, 18099, 18081
7895, 17746, 17754, 17755, 17747, 18099, 18100, 18101, 18083
7896, 17747, 17755, 2467, 2466, 18101, 18102, 2489, 18085
7897, 2417, 2418, 17756, 17748, 2440, 18103, 18104, 18086
7898, 17748, 17756, 17757, 17749, 18104, 18105, 18106, 18088
7899, 17749, 17757, 17758, 17750, 18106, 18107, 18108, 18090
7900, 17750, 17758, 17759, 17751, 18108, 18109, 18110, 18092
7901, 17751, 17759, 17760, 17752, 18110, 18111, 18112, 18094
7902, 17752, 17760, 17761, 17753, 18112, 18113, 18114, 18096
7903, 17753, 17761, 17762, 17754, 18114, 18115, 18116, 18098
7904, 17754, 17762, 17763, 17755, 18116, 18117, 18118, 18100
7905, 17755, 17763, 2468, 2467, 18118, 18119, 2490, 18102
7906, 2418, 2419, 17764, 17756, 2441, 18120, 18121, 18103
7907, 17756, 17764, 17765, 17757, 18121, 18122, 18123, 18105
7908, 17757, 17765, 17766, 17758, 18123, 18124, 18125, 18107
7909, 17758, 17766, 17767, 17759, 18125, 18126, 18127, 18109
7910, 17759, 17767, 17768, 17760, 18127, 18128, 18129, 18111
7911, 17760, 17768, 17769, 17761, 18129, 18130, 18131, 18113
7912, 17761, 17769, 17770, 17762, 18131, 18132, 18133, 18115
7913, 17762, 17770, 17771, 17763, 18133, 18134, 18135, 18117
7914, 17763, 17771, 2469, 2468, 18135, 18136, 2491, 18119
7915, 2419, 2420, 17772, 17764, 2442, 18137, 18138, 18120
7916, 17764, 17772, 17773, 17765, 18138, 18139, 18140, 18122
7917, 17765, 17773, 17774, 17766, 18140, 18141, 18142, 18124
7918, 17766, 17774, 17775, 17767, 18142, 18143, 18144, 18126
7919, 17767, 17775, 17776, 17768, 18144, 18145, 18146, 18128
7920, 17768, 17776, 17777, 17769, 18146, 18147, 18148, 18130
7921, 17769, 17777, 17778, 17770, 18148, 18149, 18150, 18132
7922, 17770, 17778, 17779, 17771, 18150, 18151, 18152, 18134
7923, 17771, 17779, 2470, 2469, 18152, 18153, 2492, 18136
7924, 2420, 77, 2506, 17772, 2443, 2515, 18154, 18137
7925, 17772, 2506, 2505, 17773, 18154, 2514, 18155, 18139
7926, 17773, 2505, 2504, 17774, 18155, 2513, 18156, 18141
7927, 17774, 2504, 2503, 17775, 18156, 2512, 18157, 18143
7928, 17775, 2503, 2502, 17776, 18157, 2511, 18158, 18145
7929, 17776, 2502, 2501, 17777, 18158, 2510, 18159, 18147
7930, 17777, 2501, 2500, 17778, 18159, 2509, 18160, 18149
7931, 17778, 2500, 2499, 17779, 18160, 2508, 18161, 18151
7932, 17779, 2499, 78, 2470, 18161, 2507, 2493, 18153
*ELEMENT, type=CPS8, ELSET=Surface245
7933, 72, 2372, 18162, 2444, 2381, 18178, 18179, 2446
7934, 2372, 2371, 18163, 18162, 2380, 18180, 18181, 18178
7935, 2371, 2370, 18164, 18163, 2379, 18182, 18183, 18180
7936, 2370, 2369, 18165, 18164, 2378, 18184, 18185, 18182
7937, 2369, 2368, 18166, 18165, 2377, 18186, 18187, 18184
7938, 2368, 2367, 18167, 18166, 2376, 18188, 18189, 18186
7939, 2367, 2366, 18168, 18167, 2375, 18190, 18191, 18188
7940, 2366, 2365, 18169, 18168, 2374, 18192, 18193, 18190
7941, 2365, 75, 2494, 18169, 2373, 2496, 18194, 18192
7942, 2444, 18162, 18170, 2445, 18179, 18195, 18196, 2447
7943, 18162, 18163, 18171, 18170, 18181, 18197, 18198, 18195
7944, 18163, 18164, 18172, 18171, 18183, 18199, 18200, 18197
7945, 18164, 18165, 18173, 18172, 18185, 18201, 18202, 18199
7946, 18165, 18166, 18174, 18173, 18187, 18203, 18204, 18201
7947, 18166, 18167, 18175, 18174, 18189, 18205, 18206, 18203
7948, 18167, 18168, 18176, 18175, 18191, 18207, 18208, 18205
7949, 18168, 18169, 18177, 18176, 18193, 18209, 18210, 18207
7950, 18169, 2494, 2495, 18177, 18194, 2497, 18211, 18209
7951, 2445, 18170, 2506, 77, 18196, 18212, 2515, 2448
7952, 18170, 18171, 2505, 2506, 18198, 18213, 2514, 18212
7953, 18171, 18172, 2504, 2505, 18200, 18214, 2513, 18213
7954, 18172, 18173, 2503, 2504, 18202, 18215, 2512, 18214
7955, 18173, 18174, 2502, 2503, 18204, 18216, 2511, 18215
7956, 18174, 18175, 2501, 2502, 18206, 18217, 2510, 18216
7957, 18175, 18176, 2500, 2501, 18208, 18218, 2509, 18217
7958, 18176, 18177, 2499, 2500, 18210, 18219, 2508, 18218
7959, 18177, 2495, 78, 2499, 18211, 2498, 2507, 18219
*ELEMENT, type=CPS8, ELSET=Surface246
7960, 54, 2399, 18220, 1770, 2421, 18286, 18287, 1773
7961, 2399, 2400, 18221, 18220, 2422, 18288, 18289, 18286
7962, 2400, 2401, 18222, 18221, 2423, 18290, 18291, 18288
7963, 2401, 2402, 18223, 18222, 2424, 18292, 18293, 18290
7964, 2402, 2403, 18224, 18223, 2425, 18294, 18295, 18292
7965, 2403, 2404, 18225, 18224, 2426, 18296, 18297, 18294
7966, 2404, 2405, 18226, 18225, 2427, 18298, 18299, 18296
7967, 2405, 2406, 18227, 18226, 2428, 18300, 18301, 18298
7968, 2406, 2407, 18228, 18227, 2429, 18302, 18303, 18300
7969, 2407, 2408, 18229, 18228, 2430, 18304, 18305, 18302
7970, 2408, 2409, 18230, 18229, 2431, 18306, 18307, 18304
7971, 2409, 2410, 18231, 18230, 2432, 18308, 18309, 18306
7972, 2410, 2411, 18232, 18231, 2433, 18310, 18311, 18308
7973, 2411, 2412, 18233, 18232, 2434, 18312, 18313, 18310
7974, 2412, 2413, 18234, 18233, 2435, 18314, 18315, 18312
7975, 2413, 2414, 18235, 18234, 2436, 18316, 18317, 18314
7976, 2414, 2415, 18236, 18235, 2437, 18318, 18319, 18316
7977, 2415, 2416, 18237, 18236, 2438, 18320, 18321, 18318
7978, 2416, 2417, 18238, 18237, 2439, 18322, 18323, 18320
7979, 2417, 2418, 18239, 18238, 2440, 18324, 18325, 18322
7980, 2418, 2419, 18240, 18239, 2441, 18326, 18327, 18324
7981, 2419, 2420, 18241, 18240, 2442, 18328, 18329, 18326
7982, 2420, 77, 2516, 18241, 2443, 2519, 18330, 18328
7983, 1770, 18220, 18242, 1771, 18287, 18331, 18332, 1774
7984, 18220, 18221, 18243, 18242, 18289, 18333, 18334, 18331
7985, 18221, 18222, 18244, 18243, 18291, 18335, 18336, 18333
7986, 18222, 18223, 18245, 18244, 18293, 18337, 18338, 18335
7987, 18223, 18224, 18246, 18245, 18295, 18339, 18340, 18337
7988, 18224, 18225, 18247, 18246, 18297, 18341, 18342, 18339
7989, 18225, 18226, 18248, 18247, 18299, 18343, 18344, 18341
7990, 18226, 18227, 18249, 18248, 18301, 18345, 18346, 18343
7991, 18227, 18228, 18250, 18249, 18303, 18347, 18348, 18345
7992, 18228, 18229, 18251, 18250, 18305, 18349, 18350, 18347
7993, 18229, 18230, 18252, 18251, 18307, 18351, 18352, 18349
7994, 18230, 18231, 18253, 18252, 18309, 18353, 18354, 18351
7995, 18231, 18232, 18254, 18253, 18311, 18355, 18356, 18353
7996, 18232, 18233, 18255, 18254, 18313, 18357, 18358, 18355
7997, 18233, 18234, 18256, 18255, 18315, 18359, 18360, 18357
7998, 18234, 18235, 18257, 18256, 18317, 18361, 18362, 18359
7999, 18235, 18236, 18258, 18257, 18319, 18363, 18364, 18361
8000, 18236, 18237, 18259, 18258, 18321, 18365, 18366, 18363
8001, 18237, 18238, 18260, 18259, 18323, 18367, 18368, 18365
8002, 18238, 18239, 18261, 18260, 18325, 18369, 18370, 18367
8003, 18239, 18240, 18262, 18261, 18327, 18371, 18372, 18369
8004, 18240, 18241, 18263, 18262, 18329, 18373, 18374, 18371
8005, 18241, 2516, 2517, 18263, 18330, 2520, 18375, 18373
8006, 1771, 18242, 18264, 1772, 18332, 18376, 18377, 1775
8007, 18242, 18243, 18265, 18264, 18334, 18378, 18379, 18376
8008, 18243, 18244, 18266, 18265, 18336, 18380, 18381, 18378
8009, 18244, 18245, 18267, 18266, 18338, 18382, 18383, 18380
8010, 18245, 18246, 18268, 18267, 18340, 18384, 18385, 18382
8011, 18246, 18247, 18269, 18268, 18342, 18386, 18387, 18384
8012, 18247, 18248, 18270, 18269, 18344, 18388, 18389, 18386
8013, 18248, 18249, 18271, 18270, 18346, 18390, 18391, 18388
8014, 18249, 18250, 18272, 18271, 18348, 18392, 18393, 18390
8015, 18250, 18251, 18273, 18272, 18350, 18394, 18395, 18392
8016, 18251, 18252, 18274, 18273, 18352, 18396, 18397, 18394
8017, 18252, 18253, 18275, 18274, 18354, 18398, 18399, 18396
8018, 18253, 18254, 18276, 18275, 18356, 18400, 18401, 18398
8019, 18254, 18255, 18277, 18276, 18358, 18402, 18403, 18400
8020, 18255, 18256, 18278, 18277, 18360, 18404, 18405, 18402
8021, 18256, 18257, 18279, 18278, 18362, 18406, 18407, 18404
8022, 18257, 18258, 18280, 18279, 18364, 18408, 18409, 18406
8023, 18258, 18259, 18281, 18280, 18366, 18410, 18411, 18408
8024, 18259, 18260, 18282, 18281, 18368, 18412, 18413, 18410
8025, 18260, 18261, 18283, 18282, 18370, 18414, 18415, 18412
8026, 18261, 18262, 18284, 18283, 18372, 18416, 18417, 18414
8027, 18262, 18263, 18285, 18284, 18374, 18418, 18419, 18416
8028, 18263, 2517, 2518, 18285, 18375, 2521, 18420, 18418
8029, 1772, 18264, 2523, 58, 18377, 18421, 2545, 1776
8030, 18264, 18265, 2524, 2523, 18379, 18422, 2546, 18421
8031, 18265, 18266, 2525, 2524, 18381, 18423, 2547, 18422
8032, 18266, 18267, 2526, 2525, 18383, 18424, 2548, 18423
8033, 18267, 18268, 2527, 2526, 18385, 18425, 2549, 18424
8034, 18268, 18269, 2528, 2527, 18387, 18426, 2550, 18425
8035, 18269, 18270, 2529, 2528, 18389, 18427, 2551, 18426
8036, 18270, 18271, 2530, 2529, 18391, 18428, 2552, 18427
8037, 18271, 18272, 2531, 2530, 18393, 18429, 2553, 18428
8038, 18272, 18273, 2532, 2531, 18395, 18430, 2554, 18429
8039, 18273, 18274, 2533, 2532, 18397, 18431, 2555, 18430
8040, 18274, 18275, 2534, 2533, 18399, 18432, 2556, 18431
8041, 18275, 18276, 2535, 2534, 18401, 18433, 2557, 18432
8042, 18276, 18277, 2536, 2535, 18403, 18434, 2558, 18433
8043, 18277, 18278, 2537, 2536, 18405, 18435, 2559, 18434
8044, 18278, 18279, 2538, 2537, 18407, 18436, 2560, 18435
8045, 18279, 18280, 2539, 2538, 18409, 18437, 2561, 18436
8046, 18280, 18281, 2540, 2539, 18411, 18438, 2562, 18437
8047, 18281, 18282, 2541, 2540, 18413, 18439, 2563, 18438
8048, 18282, 18283, 2542, 2541, 18415, 18440, 2564, 18439
8049, 18283, 18284, 2543, 2542, 18417, 18441, 2565, 18440
8050, 18284, 18285, 2544, 2543, 18419, 18442, 2566, 18441
8051, 18285, 2518, 79, 2544, 18420, 2522, 2567, 18442
*ELEMENT, type=CPS8, ELSET=Surface247
8052, 56, 1791, 18443, 2449, 1794, 18509, 18510, 2471
8053, 2449, 18443, 18444, 2450, 18510, 18511, 18512, 2472
8054, 2450, 18444, 18445, 2451, 18512, 18513, 18514, 2473
8055, 2451, 18445, 18446, 2452, 18514, 18515, 18516, 2474
8056, 2452, 18446, 18447, 2453, 18516, 18517, 18518, 2475
8057, 2453, 18447, 18448, 2454, 18518, 18519, 18520, 2476
8058, 2454, 18448, 18449, 2455, 18520, 18521, 18522, 2477
8059, 2455, 18449, 18450, 2456, 18522, 18523, 18524, 2478
8060, 2456, 18450, 18451, 2457, 18524, 18525, 18526, 2479
8061, 2457, 18451, 18452, 2458, 18526, 18527, 18528, 2480
8062, 2458, 18452, 18453, 2459, 18528, 18529, 18530, 2481
8063, 2459, 18453, 18454, 2460, 18530, 18531, 18532, 2482
8064, 2460, 18454, 18455, 2461, 18532, 18533, 18534, 2483
8065, 2461, 18455, 18456, 2462, 18534, 18535, 18536, 2484
8066, 2462, 18456, 18457, 2463, 18536, 18537, 18538, 2485
8067, 2463, 18457, 18458, 2464, 18538, 18539, 18540, 2486
8068, 2464, 18458, 18459, 2465, 18540, 18541, 18542, 2487
8069, 2465, 18459, 18460, 2466, 18542, 18543, 18544, 2488
8070, 2466, 18460, 18461, 2467, 18544, 18545, 18546, 2489
8071, 2467, 18461, 18462, 2468, 18546, 18547, 18548, 2490
8072, 2468, 18462, 18463, 2469, 18548, 18549, 18550, 2491
8073, 2469, 18463, 18464, 2470, 18550, 18551, 18552, 2492
8074, 2470, 18464, 2568, 78, 18552, 18553, 2571, 2493
8075, 1791, 1792, 18465, 18443, 1795, 18554, 18555, 18509
8076, 18443, 18465, 18466, 18444, 18555, 18556, 18557, 18511
8077, 18444, 18466, 18467, 18445, 18557, 18558, 18559, 18513
8078, 18445, 18467, 18468, 18446, 18559, 18560, 18561, 18515
8079, 18446, 18468, 18469, 18447, 18561, 18562, 18563, 18517
8080, 18447, 18469, 18470, 18448, 18563, 18564, 18565, 18519
8081, 18448, 18470, 18471, 18449, 18565, 18566, 18567, 18521
8082, 18449, 18471, 18472, 18450, 18567, 18568, 18569, 18523
8083, 18450, 18472, 18473, 18451, 18569, 18570, 18571, 18525
8084, 18451, 18473, 18474, 18452, 18571, 18572, 18573, 18527
8085, 18452, 18474, 18475, 18453, 18573, 18574, 18575, 18529
8086, 18453, 18475, 18476, 18454, 18575, 18576, 18577, 18531
8087, 18454, 18476, 18477, 18455, 18577, 18578, 18579, 18533
8088, 18455, 18477, 18478, 18456, 18579, 18580, 18581, 18535
8089, 18456, 18478, 18479, 18457, 18581, 18582, 18583, 18537
8090, 18457, 18479, 18480, 18458, 18583, 18584, 18585, 18539
8091, 18458, 18480, 18481, 18459, 18585, 18586, 18587, 18541
8092, 18459, 18481, 18482, 18460, 18587, 18588, 18589, 18543
8093, 18460, 18482, 18483, 18461, 18589, 18590, 18591, 18545
8094, 18461, 18483, 18484, 18462, 18591, 18592, 18593, 18547
8095, 18462, 18484, 18485, 18463, 18593, 18594, 18595, 18549
8096, 18463, 18485, 18486, 18464, 18595, 18596, 18597, 18551
8097, 18464, 18486, 2569, 2568, 18597, 18598, 2572, 18553
8098, 1792, 1793, 18487, 18465, 1796, 18599, 18600, 18554
8099, 18465, 18487, 18488, 18466, 18600, 18601, 18602, 18556
8100, 18466, 18488, 18489, 18467, 18602, 18603, 18604, 18558
8101, 18467, 18489, 18490, 18468, 18604, 18605, 18606, 18560
8102, 18468, 18490, 18491, 18469, 18606, 18607, 18608, 18562
8103, 18469, 18491, 18492, 18470, 18608, 18609, 18610, 18564
8104, 18470, 18492, 18493, 18471, 18610, 18611, 18612, 18566
8105, 18471, 18493, 18494, 18472, 18612, 18613, 18614, 18568
8106, 18472, 18494, 18495, 18473, 18614, 18615, 18616, 18570
8107, 18473, 18495, 18496, 18474, 18616, 18617, 18618, 18572
8108, 18474, 18496, 18497, 18475, 18618, 18619, 18620, 18574
8109, 18475, 18497, 18498, 18476, 18620, 18621, 18622, 18576
8110, 18476, 18498, 18499, 18477, 18622, 18623, 18624, 18578
8111, 18477, 18499, 18500, 18478, 18624, 18625, 18626, 18580
8112, 18478, 18500, 18501, 18479, 18626, 18627, 18628, 18582
8113, 18479, 18501, 18502, 18480, 18628, 18629, 18630, 18584
8114, 18480, 18502, 18503, 18481, 18630, 18631, 18632, 18586
8115, 18481, 18503, 18504, 18482, 18632, 18633, 18634, 18588
8116, 18482, 18504, 18505, 18483, 18634, 18635, 18636, 18590
8117, 18483, 18505, 18506, 18484, 18636, 18637, 18638, 18592
8118, 18484, 18506, 18507, 18485, 18638, 18639, 18640, 18594
8119, 18485, 18507, 18508, 18486, 18640, 18641, 18642, 18596
8120, 18486, 18508, 2570, 2569, 18642, 18643, 2573, 18598
8121, 1793, 60, 2575, 18487, 1797, 2597, 18644, 18599
8122, 18487, 2575, 2576, 18488, 18644, 2598, 18645, 18601
8123, 18488, 2576, 2577, 18489, 18645, 2599, 18646, 18603
8124, 18489, 2577, 2578, 18490, 18646, 2600, 18647, 18605
8125, 18490, 2578, 2579, 18491, 18647, 2601, 18648, 18607
8126, 18491, 2579, 2580, 18492, 18648, 2602, 18649, 18609
8127, 18492, 2580, 2581, 18493, 18649, 2603, 18650, 18611
8128, 18493, 2581, 2582, 18494, 18650, 2604, 18651, 18613
8129, 18494, 2582, 2583, 18495, 18651, 2605, 18652, 18615
8130, 18495, 2583, 2584, 18496, 18652, 2606, 18653, 18617
8131, 18496, 2584, 2585, 18497, 18653, 2607, 18654, 18619
8132, 18497, 2585, 2586, 18498, 18654, 2608, 18655, 18621
8133, 18498, 2586, 2587, 18499, 18655, 2609, 18656, 18623
8134, 18499, 2587, 2588, 18500, 18656, 2610, 18657, 18625
8135, 18500, 2588, 2589, 18501, 18657, 2611, 18658, 18627
8136, 18501, 2589, 2590, 18502, 18658, 2612, 18659, 18629
8137, 18502, 2590, 2591, 18503, 18659, 2613, 18660, 18631
8138, 18503, 2591, 2592, 18504, 18660, 2614, 18661, 18633
8139, 18504, 2592, 2593, 18505, 18661, 2615, 18662, 18635
8140, 18505, 2593, 2594, 18506, 18662, 2616, 18663, 18637
8141, 18506, 2594, 2595, 18507, 18663, 2617, 18664, 18639
8142, 18507, 2595, 2596, 18508, 18664, 2618, 18665, 18641
8143, 18508, 2596, 80, 2570, 18665, 2619, 2574, 18643
*ELEMENT, type=CPS8, ELSET=Surface248
8144, 77, 2506, 18666, 2516, 2515, 18690, 18691, 2519
8145, 2506, 2505, 18667, 18666, 2514, 18692, 18693, 18690
8146, 2505, 2504, 18668, 18667, 2513, 18694, 18695, 18692
8147, 2504, 2503, 18669, 18668, 2512, 18696, 18697, 18694
8148, 2503, 2502, 18670, 18669, 2511, 18698, 18699, 18696
8149, 2502, 2501, 18671, 18670, 2510, 18700, 18701, 18698
8150, 2501, 2500, 18672, 18671, 2509, 18702, 18703, 18700
8151, 2500, 2499, 18673, 18672, 2508, 18704, 18705, 18702
8152, 2499, 78, 2568, 18673, 2507, 2571, 18706, 18704
8153, 2516, 18666, 18674, 2517, 18691, 18707, 18708, 2520
8154, 18666, 18667, 18675, 18674, 18693, 18709, 18710, 18707
8155, 18667, 18668, 18676, 18675, 18695, 18711, 18712, 18709
8156, 18668, 18669, 18677, 18676, 18697, 18713, 18714, 18711
8157, 18669, 18670, 18678, 18677, 18699, 18715, 18716, 18713
8158, 18670, 18671, 18679, 18678, 18701, 18717, 18718, 18715
8159, 18671, 18672, 18680, 18679, 18703, 18719, 18720, 18717
8160, 18672, 18673, 18681, 18680, 18705, 18721, 18722, 18719
8161, 18673, 2568, 2569, 18681, 18706, 2572, 18723, 18721
8162, 2517, 18674, 18682, 2518, 18708, 18724, 18725, 2521
8163, 18674, 18675, 18683, 18682, 18710, 18726, 18727, 18724
8164, 18675, 18676, 18684, 18683, 18712, 18728, 18729, 18726
8165, 18676, 18677, 18685, 18684, 18714, 18730, 18731, 18728
8166, 18677, 18678, 18686, 18685, 18716, 18732, 18733, 18730
8167, 18678, 18679, 18687, 18686, 18718, 18734, 18735, 18732
8168, 18679, 18680, 18688, 18687, 18720, 18736, 18737, 18734
8169, 18680, 18681, 18689, 18688, 18722, 18738, 18739, 18736
8170, 18681, 2569, 2570, 18689, 18723, 2573, 18740, 18738
8171, 2518, 18682, 2627, 79, 18725, 18741, 2636, 2522
8172, 18682, 18683, 2626, 2627, 18727, 18742, 2635, 18741
8173, 18683, 18684, 2625, 2626, 18729, 18743, 2634, 18742
8174, 18684, 18685, 2624, 2625, 18731, 18744, 2633, 18743
8175, 18685, 18686, 2623, 2624, 18733, 18745, 2632, 18744
8176, 18686, 18687, 2622, 2623, 18735, 18746, 2631, 18745
8177, 18687, 18688, 2621, 2622, 18737, 18747, 2630, 18746
8178, 18688, 18689, 2620, 2621, 18739, 18748, 2629, 18747
8179, 18689, 2570, 80, 2620, 18740, 2574, 2628, 18748
*ELEMENT, type=CPS8, ELSET=Surface249
8180, 58, 2523, 18749, 1829, 2545, 18925, 18926, 1838
8181, 1829, 18749, 18750, 1828, 18926, 18927, 18928, 1837
8182, 1828, 18750, 18751, 1827, 18928, 18929, 18930, 1836
8183, 1827, 18751, 18752, 1826, 18930, 18931, 18932, 1835
8184, 1826, 18752, 18753, 1825, 18932, 18933, 18934, 1834
8185, 1825, 18753, 18754, 1824, 18934, 18935, 18936, 1833
8186, 1824, 18754, 18755, 1823, 18936, 18937, 18938, 1832
8187, 1823, 18755, 18756, 1822, 18938, 18939, 18940, 1831
8188, 1822, 18756, 2575, 60, 18940, 18941, 2597, 1830
8189, 2523, 2524, 18757, 18749, 2546, 18942, 18943, 18925
8190, 18749, 18757, 18758, 18750, 18943, 18944, 18945, 18927
8191, 18750, 18758, 18759, 18751, 18945, 18946, 18947, 18929
8192, 18751, 18759, 18760, 18752, 18947, 18948, 18949, 18931
8193, 18752, 18760, 18761, 18753, 18949, 18950, 18951, 18933
8194, 18753, 18761, 18762, 18754, 18951, 18952, 18953, 18935
8195, 18754, 18762, 18763, 18755, 18953, 18954, 18955, 18937
8196, 18755, 18763, 18764, 18756, 18955, 18956, 18957, 18939
8197, 18756, 18764, 2576, 2575, 18957, 18958, 2598, 18941
8198, 2524, 2525, 18765, 18757, 2547, 18959, 18960, 18942
8199, 18757, 18765, 18766, 18758, 18960, 18961, 18962, 18944
8200, 18758, 18766, 18767, 18759, 18962, 18963, 18964, 18946
8201, 18759, 18767, 18768, 18760, 18964, 18965, 18966, 18948
8202, 18760, 18768, 18769, 18761, 18966, 18967, 18968, 18950
8203, 18761, 18769, 18770, 18762, 18968, 18969, 18970, 18952
8204, 18762, 18770, 18771, 18763, 18970, 18971, 18972, 18954
8205, 18763, 18771, 18772, 18764, 18972, 18973, 18974, 18956
8206, 18764, 18772, 2577, 2576, 18974, 18975, 2599, 18958
8207, 2525, 2526, 18773, 18765, 2548, 18976, 18977, 18959
8208, 18765, 18773, 18774, 18766, 18977, 18978, 18979, 18961
8209, 18766, 18774, 18775, 18767, 18979, 18980, 18981, 18963
8210, 18767, 18775, 18776, 18768, 18981, 18982, 18983, 18965
8211, 18768, 18776, 18777, 18769, 18983, 18984, 18985, 18967
8212, 18769, 18777, 18778, 18770, 18985, 18986, 18987, 18969
8213, 18770, 18778, 18779, 18771, 18987, 18988, 18989, 18971
8214, 18771, 18779, 18780, 18772, 18989, 18990, 18991, 18973
8215, 18772, 18780, 2578, 2577, 18991, 18992, 2600, 18975
8216, 2526, 2527, 18781, 18773, 2549, 18993, 18994, 18976
8217, 18773, 18781, 18782, 18774, 18994, 18995, 18996, 18978
8218, 18774, 18782, 18783, 18775, 18996, 18997, 18998, 18980
8219, 18775, 18783, 18784, 18776, 18998, 18999, 19000, 18982
8220, 18776, 18784, 18785, 18777, 19000, 19001, 19002, 18984
8221, 18777, 18785, 18786, 18778, 19002, 19003, 19004, 18986
8222, 18778, 18786, 18787, 18779, 19004, 19005, 19006, 18988
8223, 18779, 18787, 18788, 18780, 19006, 19007, 19008, 18990
8224, 18780, 18788, 2579, 2578, 19008, 19009, 2601, 18992
8225, 2527, 2528, 18789, 18781, 2550, 19010, 19011, 18993
8226, 18781, 18789, 18790, 18782, 19011, 19012, 19013, 18995
8227, 18782, 18790, 18791, 18783, 19013, 19014, 19015, 18997
8228, 18783, 18791, 18792, 18784, 19015, 19016, 19017, 18999
8229, 18784, 18792, 18793, 18785, 19017, 19018, 19019, 19001
8230, 18785, 18793, 18794, 18786, 19019, 19020, 19021, 19003
8231, 18786, 18794, 18795, 18787, 19021, 19022, 19023, 19005
8232, 18787, 18795, 18796, 18788, 19023, 19024, 19025, 19007
8233, 18788, 18796, 2580, 2579, 19025, 19026, 2602, 19009
8234, 2528, 2529, 18797, 18789, 2551, 19027, 19028, 19010
8235, 18789, 18797, 18798, 18790, 19028, 19029, 19030, 19012
8236, 18790, 18798, 18799, 18791, 19030, 19031, 19032, 19014
8237, 18791, 18799, 18800, 18792, 19032, 19033, 19034, 19016
8238, 18792, 18800, 18801, 18793, 19034, 19035, 19036, 19018
8239, 18793, 18801, 18802, 18794, 19036, 19037, 19038, 19020
8240, 18794, 18802, 18803, 18795, 19038, 19039, 19040, 19022
8241, 18795, 18803, 18804, 18796, 19040, 19041, 19042, 19024
8242, 18796, 18804, 2581, 2580, 19042, 19043, 2603, 19026
8243, 2529, 2530, 18805, 18797, 2552, 19044, 19045, 19027
8244, 18797, 18805, 18806, 18798, 19045, 19046, 19047, 19029
8245, 18798, 18806, 18807, 18799, 19047, 19048, 19049, 19031
8246, 18799, 18807, 18808, 18800, 19049, 19050, 19051, 19033
8247, 18800, 18808, 18809, 18801, 19051, 19052, 19053, 19035
8248, 18801, 18809, 18810, 18802, 19053, 19054, 19055, 19037
8249, 18802, 18810, 18811, 18803, 19055, 19056, 19057, 19039
8250, 18803, 18811, 18812, 18804, 19057, 19058, 19059, 19041
8251, 18804, 18812, 2582, 2581, 19059, 19060, 2604, 19043
8252, 2530, 2531, 18813, 18805, 2553, 19061, 19062, 19044
8253, 18805, 18813, 18814, 18806, 19062, 19063, 19064, 19046
8254, 18806, 18814, 18815, 18807, 19064, 19065, 19066, 19048
8255, 18807, 18815, 18816, 18808, 19066, 19067, 19068, 19050
8256, 18808, 18816, 18817, 18809, 19068, 19069, 19070, 19052
8257, 18809, 18817, 18818, 18810, 19070, 19071, 19072, 19054
8258, 18810, 18818, 18819, 18811, 19072, 19073, 19074, 19056
8259, 18811, 18819, 18820, 18812, 19074, 19075, 19076, 19058
8260, 18812, 18820, 2583, 2582, 19076, 19077, 2605, 19060
8261, 2531, 2532, 18821, 18813, 2554, 19078, 19079, 19061
8262, 18813, 18821, 18822, 18814, 19079, 19080, 19081, 19063
8263, 18814, 18822, 18823, 18815, 19081, 19082, 19083, 19065
8264, 18815, 18823, 18824, 18816, 19083, 19084, 19085, 19067
8265, 18816, 18824, 18825, 18817, 19085, 19086, 19087, 19069
8266, 18817, 18825, 18826, 18818, 19087, 19088, 19089, 19071
8267, 18818, 18826, 18827, 18819, 19089, 19090, 19091, 19073
8268, 18819, 18827, 18828, 18820, 19091, 19092, 19093, 19075
8269, 18820, 18828, 2584, 2583, 19093, 19094, 2606, 19077
8270, 2532, 2533, 18829, 18821, 2555, 19095, 19096, 19078
8271, 18821, 18829, 18830, 18822, 19096, 19097, 19098, 19080
8272, 18822, 18830, 18831, 18823, 19098, 19099, 19100, 19082
8273, 18823, 18831, 18832, 18824, 19100, 19101, 19102, 19084
8274, 18824, 18832, 18833, 18825, 19102, 19103, 19104, 19086
8275, 18825, 18833, 18834, 18826, 19104, 19105, 19106, 19088
8276, 18826, 18834, 18835, 18827, 19106, 19107, 19108, 19090
8277, 18827, 18835, 18836, 18828, 19108, 19109, 19110, 19092
8278, 18828, 18836, 2585, 2584, 19110, 19111, 2607, 19094
8279, 2533, 2534, 18837, 18829, 2556, 19112, 19113, 19095
8280, 18829, 18837, 18838, 18830, 19113, 19114, 19115, 19097
8281, 18830, 18838, 18839, 18831, 19115, 19116, 19117, 19099
8282, 18831, 18839, 18840, 18832, 19117, 19118, 19119, 19101
8283, 18832, 18840, 18841, 18833, 19119, 19120, 19121, 19103
8284, 18833, 18841, 18842, 18834, 19121, 19122, 19123, 19105
8285, 18834, 18842, 18843, 18835, 19123, 19124, 19125, 19107
8286, 18835, 18843, 18844, 18836, 19125, 19126, 19127, 19109
8287, 18836, 18844, 2586, 2585, 19127, 19128, 2608, 19111
8288, 2534, 2535, 18845, 18837, 2557, 19129, 19130, 19112
8289, 18837, 18845, 18846, 18838, 19130, 19131, 19132, 19114
8290, 18838, 18846, 18847, 18839, 19132, 19133, 19134, 19116
8291, 18839, 18847, 18848, 18840, 19134, 19135, 19136, 19118
8292, 18840, 18848, 18849, 18841, 19136, 19137, 19138, 19120
8293, 18841, 18849, 18850, 18842, 19138, 19139, 19140, 19122
8294, 18842, 18850, 18851, 18843, 19140, 19141, 19142, 19124
8295, 18843, 18851, 18852, 18844, 19142, 19143, 19144, 19126
8296, 18844, 18852, 2587, 2586, 19144, 19145, 2609, 19128
8297, 2535, 2536, 18853, 18845, 2558, 19146, 19147, 19129
8298, 18845, 18853, 18854, 18846, 19147, 19148, 19149, 19131
8299, 18846, 18854, 18855, 18847, 19149, 19150, 19151, 19133
8300, 18847, 18855, 18856, 18848, 19151, 19152, 19153, 19135
8301, 18848, 18856, 18857, 18849, 19153, 19154, 19155, 19137
8302, 18849, 18857, 18858, 18850, 19155, 19156, 19157, 19139
8303, 18850, 18858, 18859, 18851, 19157, 19158, 19159, 19141
8304, 18851, 18859, 18860, 18852, 19159, 19160, 19161, 19143
8305, 18852, 18860, 2588, 2587, 19161, 19162, 2610, 19145
8306, 2536, 2537, 18861, 18853, 2559, 19163, 19164, 19146
8307, 18853, 18861, 18862, 18854, 19164, 19165, 19166, 19148
8308, 18854, 18862, 18863, 18855, 19166, 19167, 19168, 19150
8309, 18855, 18863, 18864, 18856, 19168, 19169, 19170, 19152
8310, 18856, 18864, 18865, 18857, 19170, 19171, 19172, 19154
8311, 18857, 18865, 18866, 18858, 19172, 19173, 19174, 19156
8312, 18858, 18866, 18867, 18859, 19174, 19175, 19176, 19158
8313, 18859, 18867, 18868, 18860, 19176, 19177, 19178, 19160
8314, 18860, 18868, 2589, 2588, 19178, 19179, 2611, 19162
8315, 2537, 2538, 18869, 18861, 2560, 19180, 19181, 19163
8316, 18861, 18869, 18870, 18862, 19181, 19182, 19183, 19165
8317, 18862, 18870, 18871, 18863, 19183, 19184, 19185, 19167
8318, 18863, 18871, 18872, 18864, 19185, 19186, 19187, 19169
8319, 18864, 18872, 18873, 18865, 19187, 19188, 19189, 19171
8320, 18865, 18873, 18874, 18866, 19189, 19190, 19191, 19173
8321, 18866, 18874, 18875, 18867, 19191, 19192, 19193, 19175
8322, 18867, 18875, 18876, 18868, 19193, 19194, 19195, 19177
8323, 18868, 18876, 2590, 2589, 19195, 19196, 2612, 19179
8324, 2538, 2539, 18877, 18869, 2561, 19197, 19198, 19180
8325, 18869, 18877, 18878, 18870, 19198, 19199, 19200, 19182
8326, 18870, 18878, 18879, 18871, 19200, 19201, 19202, 19184
8327, 18871, 18879, 18880, 18872, 19202, 19203, 19204, 19186
8328, 18872, 18880, 18881, 18873, 19204, 19205, 19206, 19188
8329, 18873, 18881, 18882, 18874, 19206, 19207, 19208, 19190
8330, 18874, 18882, 18883, 18875, 19208, 19209, 19210, 19192
8331, 18875, 18883, 18884, 18876, 19210, 19211, 19212, 19194
8332, 18876, 18884, 2591, 2590, 19212, 19213, 2613, 19196
8333, 2539, 2540, 18885, 18877, 2562, 19214, 19215, 19197
8334, 18877, 18885, 18886, 18878, 19215, 19216, 19217, 19199
8335, 18878, 18886, 18887, 18879, 19217, 19218, 19219, 19201
8336, 18879, 18887, 18888, 18880, 19219, 19220, 19221, 19203
8337, 18880, 18888, 18889, 18881, 19221, 19222, 19223, 19205
8338, 18881, 18889, 18890, 18882, 19223, 19224, 19225, 19207
8339, 18882, 18890, 18891, 18883, 19225, 19226, 19227, 19209
8340, 18883, 18891, 18892, 18884, 19227, 19228, 19229, 19211
8341, 18884, 18892, 2592, 2591, 19229, 19230, 2614, 19213
8342, 2540, 2541, 18893, 18885, 2563, 19231, 19232, 19214
8343, 18885, 18893, 18894, 18886, 19232, 19233, 19234, 19216
8344, 18886, 18894, 18895, 18887, 19234, 19235, 19236, 19218
8345, 18887, 18895, 18896, 18888, 19236, 19237, 19238, 19220
8346, 18888, 18896, 18897, 18889, 19238, 19239, 19240, 19222
8347, 18889, 18897, 18898, 18890, 19240, 19241, 19242, 19224
8348, 18890, 18898, 18899, 18891, 19242, 19243, 19244, 19226
8349, 18891, 18899, 18900, 18892, 19244, 19245, 19246, 19228
8350, 18892, 18900, 2593, 2592, 19246, 19247, 2615, 19230
8351, 2541, 2542, 18901, 18893, 2564, 19248, 19249, 19231
8352, 18893, 18901, 18902, 18894, 19249, 19250, 19251, 19233
8353, 18894, 18902, 18903, 18895, 19251, 19252, 19253, 19235
8354, 18895, 18903, 18904, 18896, 19253, 19254, 19255, 19237
8355, 18896, 18904, 18905, 18897, 19255, 19256, 19257, 19239
8356, 18897, 18905, 18906, 18898, 19257, 19258, 19259, 19241
8357, 18898, 18906, 18907, 18899, 19259, 19260, 19261, 19243
8358, 18899, 18907, 18908, 18900, 19261, 19262, 19263, 19245
8359, 18900, 18908, 2594, 2593, 19263, 19264, 2616, 19247
8360, 2542, 2543, 18909, 18901, 2565, 19265, 19266, 19248
8361, 18901, 18909, 18910, 18902, 19266, 19267, 19268, 19250
8362, 18902, 18910, 18911, 18903, 19268, 19269, 19270, 19252
8363, 18903, 18911, 18912, 18904, 19270, 19271, 19272, 19254
8364, 18904, 18912, 18913, 18905, 19272, 19273, 19274, 19256
8365, 18905, 18913, 18914, 18906, 19274, 19275, 19276, 19258
8366, 18906, 18914, 18915, 18907, 19276, 19277, 19278, 19260
8367, 18907, 18915, 18916, 18908, 19278, 19279, 19280, 19262
8368, 18908, 18916, 2595, 2594, 19280, 19281, 2617, 19264
8369, 2543, 2544, 18917, 18909, 2566, 19282, 19283, 19265
8370, 18909, 18917, 18918, 18910, 19283, 19284, 19285, 19267
8371, 18910, 18918, 18919, 18911, 19285, 19286, 19287, 19269
8372, 18911, 18919, 18920, 18912, 19287, 19288, 19289, 19271
8373, 18912, 18920, 18921, 18913, 19289, 19290, 19291, 19273
8374, 18913, 18921, 18922, 18914, 19291, 19292, 19293, 19275
8375, 18914, 18922, 18923, 18915, 19293, 19294, 19295, 19277
8376, 18915, 18923, 18924, 18916, 19295, 19296, 19297, 19279
8377, 18916, 18924, 2596, 2595, 19297, 19298, 2618, 19281
8378, 2544, 79, 2627, 18917, 2567, 2636, 19299, 19282
8379, 18917, 2627, 2626, 18918, 19299, 2635, 19300, 19284
8380, 18918, 2626, 2625, 18919, 19300, 2634, 19301, 19286
8381, 18919, 2625, 2624, 18920, 19301, 2633, 19302, 19288
8382, 18920, 2624, 2623, 18921, 19302, 2632, 19303, 19290
8383, 18921, 2623, 2622, 18922, 19303, 2631, 19304, 19292
8384, 18922, 2622, 2621, 18923, 19304, 2630, 19305, 19294
8385, 18923, 2621, 2620, 18924, 19305, 2629, 19306, 19296
8386, 18924, 2620, 80, 2596, 19306, 2628, 2619, 19298
*ELEMENT, type=CPS8, ELSET=Surface250
8387, 77, 2637, 19307, 2516, 2638, 19310, 19311, 2519
8388, 2516, 19307, 19308, 2517, 19311, 19312, 19313, 2520
8389, 2517, 19308, 19309, 2518, 19313, 19314, 19315, 2521
8390, 2518, 19309, 2640, 79, 19315, 19316, 2641, 2522
8391, 2637, 81, 2643, 19307, 2639, 2646, 19317, 19310
8392, 19307, 2643, 2644, 19308, 19317, 2647, 19318, 19312
8393, 19308, 2644, 2645, 19309, 19318, 2648, 19319, 19314
8394, 19309, 2645, 82, 2640, 19319, 2649, 2642, 19316
*ELEMENT, type=CPS8, ELSET=Surface251
8395, 78, 2568, 19320, 2650, 2571, 19323, 19324, 2651
8396, 2568, 2569, 19321, 19320, 2572, 19325, 19326, 19323
8397, 2569, 2570, 19322, 19321, 2573, 19327, 19328, 19325
8398, 2570, 80, 2653, 19322, 2574, 2654, 19329, 19327
8399, 2650, 19320, 2656, 83, 19324, 19330, 2659, 2652
8400, 19320, 19321, 2657, 2656, 19326, 19331, 2660, 19330
8401, 19321, 19322, 2658, 2657, 19328, 19332, 2661, 19331
8402, 19322, 2653, 84, 2658, 19329, 2655, 2662, 19332
*ELEMENT, type=CPS8, ELSET=Surface252
8403, 77, 2506, 19333, 2637, 2515, 19341, 19342, 2638
8404, 2506, 2505, 19334, 19333, 2514, 19343, 19344, 19341
8405, 2505, 2504, 19335, 19334, 2513, 19345, 19346, 19343
8406, 2504, 2503, 19336, 19335, 2512, 19347, 19348, 19345
8407, 2503, 2502, 19337, 19336, 2511, 19349, 19350, 19347
8408, 2502, 2501, 19338, 19337, 2510, 19351, 19352, 19349
8409, 2501, 2500, 19339, 19338, 2509, 19353, 19354, 19351
8410, 2500, 2499, 19340, 19339, 2508, 19355, 19356, 19353
8411, 2499, 78, 2650, 19340, 2507, 2651, 19357, 19355
8412, 2637, 19333, 2670, 81, 19342, 19358, 2679, 2639
8413, 19333, 19334, 2669, 2670, 19344, 19359, 2678, 19358
8414, 19334, 19335, 2668, 2669, 19346, 19360, 2677, 19359
8415, 19335, 19336, 2667, 2668, 19348, 19361, 2676, 19360
8416, 19336, 19337, 2666, 2667, 19350, 19362, 2675, 19361
8417, 19337, 19338, 2665, 2666, 19352, 19363, 2674, 19362
8418, 19338, 19339, 2664, 2665, 19354, 19364, 2673, 19363
8419, 19339, 19340, 2663, 2664, 19356, 19365, 2672, 19364
8420, 19340, 2650, 83, 2663, 19357, 2652, 2671, 19365
*ELEMENT, type=CPS8, ELSET=Surface253
8421, 79, 2640, 19366, 2627, 2641, 19374, 19375, 2636
8422, 2627, 19366, 19367, 2626, 19375, 19376, 19377, 2635
8423, 2626, 19367, 19368, 2625, 19377, 19378, 19379, 2634
8424, 2625, 19368, 19369, 2624, 19379, 19380, 19381, 2633
8425, 2624, 19369, 19370, 2623, 19381, 19382, 19383, 2632
8426, 2623, 19370, 19371, 2622, 19383, 19384, 19385, 2631
8427, 2622, 19371, 19372, 2621, 19385, 19386, 19387, 2630
8428, 2621, 19372, 19373, 2620, 19387, 19388, 19389, 2629
8429, 2620, 19373, 2653, 80, 19389, 19390, 2654, 2628
8430, 2640, 82, 2687, 19366, 2642, 2696, 19391, 19374
8431, 19366, 2687, 2686, 19367, 19391, 2695, 19392, 19376
8432, 19367, 2686, 2685, 19368, 19392, 2694, 19393, 19378
8433, 19368, 2685, 2684, 19369, 19393, 2693, 19394, 19380
8434, 19369, 2684, 2683, 19370, 19394, 2692, 19395, 19382
8435, 19370, 2683, 2682, 19371, 19395, 2691, 19396, 19384
8436, 19371, 2682, 2681, 19372, 19396, 2690, 19397, 19386
8437, 19372, 2681, 2680, 19373, 19397, 2689, 19398, 19388
8438, 19373, 2680, 84, 2653, 19398, 2688, 2655, 19390
*ELEMENT, type=CPS8, ELSET=Surface254
8439, 81, 2670, 19399, 2643, 2679, 19423, 19424, 2646
8440, 2670, 2669, 19400, 19399, 2678, 19425, 19426, 19423
8441, 2669, 2668, 19401, 19400, 2677, 19427, 19428, 19425
8442, 2668, 2667, 19402, 19401, 2676, 19429, 19430, 19427
8443, 2667, 2666, 19403, 19402, 2675, 19431, 19432, 19429
8444, 2666, 2665, 19404, 19403, 2674, 19433, 19434, 19431
8445, 2665, 2664, 19405, 19404, 2673, 19435, 19436, 19433
8446, 2664, 2663, 19406, 19405, 2672, 19437, 19438, 19435
8447, 2663, 83, 2656, 19406, 2671, 2659, 19439, 19437
8448, 2643, 19399, 19407, 2644, 19424, 19440, 19441, 2647
8449, 19399, 19400, 19408, 19407, 19426, 19442, 19443, 19440
8450, 19400, 19401, 19409, 19408, 19428, 19444, 19445, 19442
8451, 19401, 19402, 19410, 19409, 19430, 19446, 19447, 19444
8452, 19402, 19403, 19411, 19410, 19432, 19448, 19449, 19446
8453, 19403, 19404, 19412, 19411, 19434, 19450, 19451, 19448
8454, 19404, 19405, 19413, 19412, 19436, 19452, 19453, 19450
8455, 19405, 19406, 19414, 19413, 19438, 19454, 19455, 19452
8456, 19406, 2656, 2657, 19414, 19439, 2660, 19456, 19454
8457, 2644, 19407, 19415, 2645, 19441, 19457, 19458, 2648
8458, 19407, 19408, 19416, 19415, 19443, 19459, 19460, 19457
8459, 19408, 19409, 19417, 19416, 19445, 19461, 19462, 19459
8460, 19409, 19410, 19418, 19417, 19447, 19463, 19464, 19461
8461, 19410, 19411, 19419, 19418, 19449, 19465, 19466, 19463
8462, 19411, 19412, 19420, 19419, 19451, 19467, 19468, 19465
8463, 19412, 19413, 19421, 19420, 19453, 19469, 19470, 19467
8464, 19413, 19414, 19422, 19421, 19455, 19471, 19472, 19469
8465, 19414, 2657, 2658, 19422, 19456, 2661, 19473, 19471
8466, 2645, 19415, 2687, 82, 19458, 19474, 2696, 2649
8467, 19415, 19416, 2686, 2687, 19460, 19475, 2695, 19474
8468, 19416, 19417, 2685, 2686, 19462, 19476, 2694, 19475
8469, 19417, 19418, 2684, 2685, 19464, 19477, 2693, 19476
8470, 19418, 19419, 2683, 2684, 19466, 19478, 2692, 19477
8471, 19419, 19420, 2682, 2683, 19468, 19479, 2691, 19478
8472, 19420, 19421, 2681, 2682, 19470, 19480, 2690, 19479
8473, 19421, 19422, 2680, 2681, 19472, 19481, 2689, 19480
8474, 19422, 2658, 84, 2680, 19473, 2662, 2688, 19481
*ELEMENT, type=CPS8, ELSET=Surface255
8475, 85, 2724, 19482, 2697, 2747, 19504, 19505, 2698
8476, 2724, 2723, 19483, 19482, 2746, 19506, 19507, 19504
8477, 2723, 2722, 19484, 19483, 2745, 19508, 19509, 19506
8478, 2722, 2721, 19485, 19484, 2744, 19510, 19511, 19508
8479, 2721, 2720, 19486, 19485, 2743, 19512, 19513, 19510
8480, 2720, 2719, 19487, 19486, 2742, 19514, 19515, 19512
8481, 2719, 2718, 19488, 19487, 2741, 19516, 19517, 19514
8482, 2718, 2717, 19489, 19488, 2740, 19518, 19519, 19516
8483, 2717, 2716, 19490, 19489, 2739, 19520, 19521, 19518
8484, 2716, 2715, 19491, 19490, 2738, 19522, 19523, 19520
8485, 2715, 2714, 19492, 19491, 2737, 19524, 19525, 19522
8486, 2714, 2713, 19493, 19492, 2736, 19526, 19527, 19524
8487, 2713, 2712, 19494, 19493, 2735, 19528, 19529, 19526
8488, 2712, 2711, 19495, 19494, 2734, 19530, 19531, 19528
8489, 2711, 2710, 19496, 19495, 2733, 19532, 19533, 19530
8490, 2710, 2709, 19497, 19496, 2732, 19534, 19535, 19532
8491, 2709, 2708, 19498, 19497, 2731, 19536, 19537, 19534
8492, 2708, 2707, 19499, 19498, 2730, 19538, 19539, 19536
8493, 2707, 2706, 19500, 19499, 2729, 19540, 19541, 19538
8494, 2706, 2705, 19501, 19500, 2728, 19542, 19543, 19540
8495, 2705, 2704, 19502, 19501, 2727, 19544, 19545, 19542
8496, 2704, 2703, 19503, 19502, 2726, 19546, 19547, 19544
8497, 2703, 86, 2700, 19503, 2725, 2701, 19548, 19546
8498, 2697, 19482, 142, 1, 19505, 19549, 165, 2699
8499, 19482, 19483, 141, 142, 19507, 19550, 164, 19549
8500, 19483, 19484, 140, 141, 19509, 19551, 163, 19550
8501, 19484, 19485, 139, 140, 19511, 19552, 162, 19551
8502, 19485, 19486, 138, 139, 19513, 19553, 161, 19552
8503, 19486, 19487, 137, 138, 19515, 19554, 160, 19553
8504, 19487, 19488, 136, 137, 19517, 19555, 159, 19554
8505, 19488, 19489, 135, 136, 19519, 19556, 158, 19555
8506, 19489, 19490, 134, 135, 19521, 19557, 157, 19556
8507, 19490, 19491, 133, 134, 19523, 19558, 156, 19557
8508, 19491, 19492, 132, 133, 19525, 19559, 155, 19558
8509, 19492, 19493, 131, 132, 19527, 19560, 154, 19559
8510, 19493, 19494, 130, 131, 19529, 19561, 153, 19560
8511, 19494, 19495, 129, 130, 19531, 19562, 152, 19561
8512, 19495, 19496, 128, 129, 19533, 19563, 151, 19562
8513, 19496, 19497, 127, 128, 19535, 19564, 150, 19563
8514, 19497, 19498, 126, 127, 19537, 19565, 149, 19564
8515, 19498, 19499, 125, 126, 19539, 19566, 148, 19565
8516, 19499, 19500, 124, 125, 19541, 19567, 147, 19566
8517, 19500, 19501, 123, 124, 19543, 19568, 146, 19567
8518, 19501, 19502, 122, 123, 19545, 19569, 145, 19568
8519, 19502, 19503, 121, 122, 19547, 19570, 144, 19569
8520, 19503, 2700, 2, 121, 19548, 2702, 143, 19570
*ELEMENT, type=CPS8, ELSET=Surface256
8521, 87, 2758, 19571, 2748, 2767, 19579, 19580, 2749
8522, 2758, 2757, 19572, 19571, 2766, 19581, 19582, 19579
8523, 2757, 2756, 19573, 19572, 2765, 19583, 19584, 19581
8524, 2756, 2755, 19574, 19573, 2764, 19585, 19586, 19583
8525, 2755, 2754, 19575, 19574, 2763, 19587, 19588, 19585
8526, 2754, 2753, 19576, 19575, 2762, 19589, 19590, 19587
8527, 2753, 2752, 19577, 19576, 2761, 19591, 19592, 19589
8528, 2752, 2751, 19578, 19577, 2760, 19593, 19594, 19591
8529, 2751, 85, 2697, 19578, 2759, 2698, 19595, 19593
8530, 2748, 19571, 173, 3, 19580, 19596, 182, 2750
8531, 19571, 19572, 172, 173, 19582, 19597, 181, 19596
8532, 19572, 19573, 171, 172, 19584, 19598, 180, 19597
8533, 19573, 19574, 170, 171, 19586, 19599, 179, 19598
8534, 19574, 19575, 169, 170, 19588, 19600, 178, 19599
8535, 19575, 19576, 168, 169, 19590, 19601, 177, 19600
8536, 19576, 19577, 167, 168, 19592, 19602, 176, 19601
8537, 19577, 19578, 166, 167, 19594, 19603, 175, 19602
8538, 19578, 2697, 1, 166, 19595, 2699, 174, 19603
*ELEMENT, type=CPS8, ELSET=Surface257
8539, 87, 2748, 19604, 2792, 2749, 19626, 19627, 2815
8540, 2792, 19604, 19605, 2791, 19627, 19628, 19629, 2814
8541, 2791, 19605, 19606, 2790, 19629, 19630, 19631, 2813
8542, 2790, 19606, 19607, 2789, 19631, 19632, 19633, 2812
8543, 2789, 19607, 19608, 2788, 19633, 19634, 19635, 2811
8544, 2788, 19608, 19609, 2787, 19635, 19636, 19637, 2810
8545, 2787, 19609, 19610, 2786, 19637, 19638, 19639, 2809
8546, 2786, 19610, 19611, 2785, 19639, 19640, 19641, 2808
8547, 2785, 19611, 19612, 2784, 19641, 19642, 19643, 2807
8548, 2784, 19612, 19613, 2783, 19643, 19644, 19645, 2806
8549, 2783, 19613, 19614, 2782, 19645, 19646, 19647, 2805
8550, 2782, 19614, 19615, 2781, 19647, 19648, 19649, 2804
8551, 2781, 19615, 19616, 2780, 19649, 19650, 19651, 2803
8552, 2780, 19616, 19617, 2779, 19651, 19652, 19653, 2802
8553, 2779, 19617, 19618, 2778, 19653, 19654, 19655, 2801
8554, 2778, 19618, 19619, 2777, 19655, 19656, 19657, 2800
8555, 2777, 19619, 19620, 2776, 19657, 19658, 19659, 2799
8556, 2776, 19620, 19621, 2775, 19659, 19660, 19661, 2798
8557, 2775, 19621, 19622, 2774, 19661, 19662, 19663, 2797
8558, 2774, 19622, 19623, 2773, 19663, 19664, 19665, 2796
8559, 2773, 19623, 19624, 2772, 19665, 19666, 19667, 2795
8560, 2772, 19624, 19625, 2771, 19667, 19668, 19669, 2794
8561, 2771, 19625, 2768, 88, 19669, 19670, 2769, 2793
8562, 2748, 3, 204, 19604, 2750, 227, 19671, 19626
8563, 19604, 204, 203, 19605, 19671, 226, 19672, 19628
8564, 19605, 203, 202, 19606, 19672, 225, 19673, 19630
8565, 19606, 202, 201, 19607, 19673, 224, 19674, 19632
8566, 19607, 201, 200, 19608, 19674, 223, 19675, 19634
8567, 19608, 200, 199, 19609, 19675, 222, 19676, 19636
8568, 19609, 199, 198, 19610, 19676, 221, 19677, 19638
8569, 19610, 198, 197, 19611, 19677, 220, 19678, 19640
8570, 19611, 197, 196, 19612, 19678, 219, 19679, 19642
8571, 19612, 196, 195, 19613, 19679, 218, 19680, 19644
8572, 19613, 195, 194, 19614, 19680, 217, 19681, 19646
8573, 19614, 194, 193, 19615, 19681, 216, 19682, 19648
8574, 19615, 193, 192, 19616, 19682, 215, 19683, 19650
8575, 19616, 192, 191, 19617, 19683, 214, 19684, 19652
8576, 19617, 191, 190, 19618, 19684, 213, 19685, 19654
8577, 19618, 190, 189, 19619, 19685, 212, 19686, 19656
8578, 19619, 189, 188, 19620, 19686, 211, 19687, 19658
8579, 19620, 188, 187, 19621, 19687, 210, 19688, 19660
8580, 19621, 187, 186, 19622, 19688, 209, 19689, 19662
8581, 19622, 186, 185, 19623, 19689, 208, 19690, 19664
8582, 19623, 185, 184, 19624, 19690, 207, 19691, 19666
8583, 19624, 184, 183, 19625, 19691, 206, 19692, 19668
8584, 19625, 183, 4, 2768, 19692, 205, 2770, 19670
*ELEMENT, type=CPS8, ELSET=Surface258
8585, 88, 2768, 19693, 2823, 2769, 19701, 19702, 2832
8586, 2823, 19693, 19694, 2822, 19702, 19703, 19704, 2831
8587, 2822, 19694, 19695, 2821, 19704, 19705, 19706, 2830
8588, 2821, 19695, 19696, 2820, 19706, 19707, 19708, 2829
8589, 2820, 19696, 19697, 2819, 19708, 19709, 19710, 2828
8590, 2819, 19697, 19698, 2818, 19710, 19711, 19712, 2827
8591, 2818, 19698, 19699, 2817, 19712, 19713, 19714, 2826
8592, 2817, 19699, 19700, 2816, 19714, 19715, 19716, 2825
8593, 2816, 19700, 2700, 86, 19716, 19717, 2701, 2824
8594, 2768, 4, 235, 19693, 2770, 244, 19718, 19701
8595, 19693, 235, 234, 19694, 19718, 243, 19719, 19703
8596, 19694, 234, 233, 19695, 19719, 242, 19720, 19705
8597, 19695, 233, 232, 19696, 19720, 241, 19721, 19707
8598, 19696, 232, 231, 19697, 19721, 240, 19722, 19709
8599, 19697, 231, 230, 19698, 19722, 239, 19723, 19711
8600, 19698, 230, 229, 19699, 19723, 238, 19724, 19713
8601, 19699, 229, 228, 19700, 19724, 237, 19725, 19715
8602, 19700, 228, 2, 2700, 19725, 236, 2702, 19717
*ELEMENT, type=CPS8, ELSET=Surface259
8603, 86, 2703, 19726, 2816, 2725, 19902, 19903, 2824
8604, 2816, 19726, 19727, 2817, 19903, 19904, 19905, 2825
8605, 2817, 19727, 19728, 2818, 19905, 19906, 19907, 2826
8606, 2818, 19728, 19729, 2819, 19907, 19908, 19909, 2827
8607, 2819, 19729, 19730, 2820, 19909, 19910, 19911, 2828
8608, 2820, 19730, 19731, 2821, 19911, 19912, 19913, 2829
8609, 2821, 19731, 19732, 2822, 19913, 19914, 19915, 2830
8610, 2822, 19732, 19733, 2823, 19915, 19916, 19917, 2831
8611, 2823, 19733, 2771, 88, 19917, 19918, 2793, 2832
8612, 2703, 2704, 19734, 19726, 2726, 19919, 19920, 19902
8613, 19726, 19734, 19735, 19727, 19920, 19921, 19922, 19904
8614, 19727, 19735, 19736, 19728, 19922, 19923, 19924, 19906
8615, 19728, 19736, 19737, 19729, 19924, 19925, 19926, 19908
8616, 19729, 19737, 19738, 19730, 19926, 19927, 19928, 19910
8617, 19730, 19738, 19739, 19731, 19928, 19929, 19930, 19912
8618, 19731, 19739, 19740, 19732, 19930, 19931, 19932, 19914
8619, 19732, 19740, 19741, 19733, 19932, 19933, 19934, 19916
8620, 19733, 19741, 2772, 2771, 19934, 19935, 2794, 19918
8621, 2704, 2705, 19742, 19734, 2727, 19936, 19937, 19919
8622, 19734, 19742, 19743, 19735, 19937, 19938, 19939, 19921
8623, 19735, 19743, 19744, 19736, 19939, 19940, 19941, 19923
8624, 19736, 19744, 19745, 19737, 19941, 19942, 19943, 19925
8625, 19737, 19745, 19746, 19738, 19943, 19944, 19945, 19927
8626, 19738, 19746, 19747, 19739, 19945, 19946, 19947, 19929
8627, 19739, 19747, 19748, 19740, 19947, 19948, 19949, 19931
8628, 19740, 19748, 19749, 19741, 19949, 19950, 19951, 19933
8629, 19741, 19749, 2773, 2772, 19951, 19952, 2795, 19935
8630, 2705, 2706, 19750, 19742, 2728, 19953, 19954, 19936
8631, 19742, 19750, 19751, 19743, 19954, 19955, 19956, 19938
8632, 19743, 19751, 19752, 19744, 19956, 19957, 19958, 19940
8633, 19744, 19752, 19753, 19745, 19958, 19959, 19960, 19942
8634, 19745, 19753, 19754, 19746, 19960, 19961, 19962, 19944
8635, 19746, 19754, 19755, 19747, 19962, 19963, 19964, 19946
8636, 19747, 19755, 19756, 19748, 19964, 19965, 19966, 19948
8637, 19748, 19756, 19757, 19749, 19966, 19967, 19968, 19950
8638, 19749, 19757, 2774, 2773, 19968, 19969, 2796, 19952
8639, 2706, 2707, 19758, 19750, 2729, 19970, 19971, 19953
8640, 19750, 19758, 19759, 19751, 19971, 19972, 19973, 19955
8641, 19751, 19759, 19760, 19752, 19973, 19974, 19975, 19957
8642, 19752, 19760, 19761, 19753, 19975, 19976, 19977, 19959
8643, 19753, 19761, 19762, 19754, 19977, 19978, 19979, 19961
8644, 19754, 19762, 19763, 19755, 19979, 19980, 19981, 19963
8645, 19755, 19763, 19764, 19756, 19981, 19982, 19983, 19965
8646, 19756, 19764, 19765, 19757, 19983, 19984, 19985, 19967
8647, 19757, 19765, 2775, 2774, 19985, 19986, 2797, 19969
8648, 2707, 2708, 19766, 19758, 2730, 19987, 19988, 19970
8649, 19758, 19766, 19767, 19759, 19988, 19989, 19990, 19972
8650, 19759, 19767, 19768, 19760, 19990, 19991, 19992, 19974
8651, 19760, 19768, 19769, 19761, 19992, 19993, 19994, 19976
8652, 19761, 19769, 19770, 19762, 19994, 19995, 19996, 19978
8653, 19762, 19770, 19771, 19763, 19996, 19997, 19998, 19980
8654, 19763, 19771, 19772, 19764, 19998, 19999, 20000, 19982
8655, 19764, 19772, 19773, 19765, 20000, 20001, 20002, 19984
8656, 19765, 19773, 2776, 2775, 20002, 20003, 2798, 19986
8657, 2708, 2709, 19774, 19766, 2731, 20004, 20005, 19987
