22204, 1, 0.90652173913043, 0.16666666666667
22205, 1, 0.93260869565217, 0.19444444444444
22206, 1, 0.90652173913043, 0.11111111111111
22207, 1, 0.93260869565217, 0.13888888888889
22208, 1, 0.90652173913043, 0.055555555555556
22209, 1, 0.93260869565217, 0.083333333333333
22210, 1, 0.93260869565217, 0.027777777777778
22211, 1, 0.95869565217391, 0.44444444444444
22212, 1, 0.98478260869565, 0.47222222222222
22213, 1, 0.95869565217391, 0.38888888888889
22214, 1, 0.98478260869565, 0.41666666666667
22215, 1, 0.95869565217391, 0.33333333333333
22216, 1, 0.98478260869565, 0.36111111111111
22217, 1, 0.95869565217391, 0.27777777777778
22218, 1, 0.98478260869565, 0.30555555555556
22219, 1, 0.95869565217391, 0.22222222222222
22220, 1, 0.98478260869565, 0.25
22221, 1, 0.95869565217391, 0.16666666666667
22222, 1, 0.98478260869565, 0.19444444444444
22223, 1, 0.95869565217391, 0.11111111111111
22224, 1, 0.98478260869565, 0.13888888888889
22225, 1, 0.95869565217391, 0.055555555555556
22226, 1, 0.98478260869565, 0.083333333333333
22227, 1, 0.98478260869565, 0.027777777777778
22228, 1, 1.0108695652174, 0.44444444444444
22229, 1, 1.0369565217391, 0.47222222222222
22230, 1, 1.0108695652174, 0.38888888888889
22231, 1, 1.0369565217391, 0.41666666666667
22232, 1, 1.0108695652174, 0.33333333333333
22233, 1, 1.0369565217391, 0.36111111111111
22234, 1, 1.0108695652174, 0.27777777777778
22235, 1, 1.0369565217391, 0.30555555555556
22236, 1, 1.0108695652174, 0.22222222222222
22237, 1, 1.0369565217391, 0.25
22238, 1, 1.0108695652174, 0.16666666666667
22239, 1, 1.0369565217391, 0.19444444444444
22240, 1, 1.0108695652174, 0.11111111111111
22241, 1, 1.0369565217391, 0.13888888888889
22242, 1, 1.0108695652174, 0.055555555555556
22243, 1, 1.0369565217391, 0.083333333333333
22244, 1, 1.0369565217391, 0.027777777777778
22245, 1, 1.0630434782609, 0.44444444444444
22246, 1, 1.0891304347826, 0.47222222222222
22247, 1, 1.0630434782609, 0.38888888888889
22248, 1, 1.0891304347826, 0.41666666666667
22249, 1, 1.0630434782609, 0.33333333333333
22250, 1, 1.0891304347826, 0.36111111111111
22251, 1, 1.0630434782609, 0.27777777777778
22252, 1, 1.0891304347826, 0.30555555555556
22253, 1, 1.0630434782609, 0.22222222222222
22254, 1, 1.0891304347826, 0.25
22255, 1, 1.0630434782609, 0.16666666666667
22256, 1, 1.0891304347826, 0.19444444444444
22257, 1, 1.0630434782609, 0.11111111111111
22258, 1, 1.0891304347826, 0.13888888888889
22259, 1, 1.0630434782609, 0.055555555555556
22260, 1, 1.0891304347826, 0.083333333333333
22261, 1, 1.0891304347826, 0.027777777777778
22262, 1, 1.1152173913043, 0.44444444444444
22263, 1, 1.1413043478261, 0.47222222222222
22264, 1, 1.1152173913043, 0.38888888888889
22265, 1, 1.1413043478261, 0.41666666666667
22266, 1, 1.1152173913043, 0.33333333333333
22267, 1, 1.1413043478261, 0.36111111111111
22268, 1, 1.1152173913043, 0.27777777777778
22269, 1, 1.1413043478261, 0.30555555555556
22270, 1, 1.1152173913043, 0.22222222222222
22271, 1, 1.1413043478261, 0.25
22272, 1, 1.1152173913043, 0.16666666666667
22273, 1, 1.1413043478261, 0.19444444444444
22274, 1, 1.1152173913043, 0.11111111111111
22275, 1, 1.1413043478261, 0.13888888888889
22276, 1, 1.1152173913043, 0.055555555555556
22277, 1, 1.1413043478261, 0.083333333333333
22278, 1, 1.1413043478261, 0.027777777777778
22279, 1, 1.1673913043478, 0.44444444444444
22280, 1, 1.1934782608696, 0.47222222222222
22281, 1, 1.1673913043478, 0.38888888888889
22282, 1, 1.1934782608696, 0.41666666666667
22283, 1, 1.1673913043478, 0.33333333333333
22284, 1, 1.1934782608696, 0.36111111111111
22285, 1, 1.1673913043478, 0.27777777777778
22286, 1, 1.1934782608696, 0.30555555555556
22287, 1, 1.1673913043478, 0.22222222222222
22288, 1, 1.1934782608696, 0.25
22289, 1, 1.1673913043478, 0.16666666666667
22290, 1, 1.1934782608696, 0.19444444444444
22291, 1, 1.1673913043478, 0.11111111111111
22292, 1, 1.1934782608696, 0.13888888888889
22293, 1, 1.1673913043478, 0.055555555555556
22294, 1, 1.1934782608696, 0.083333333333333
22295, 1, 1.1934782608696, 0.027777777777778
22296, 1, 1.2195652173913, 0.44444444444444
22297, 1, 1.245652173913, 0.47222222222222
22298, 1, 1.2195652173913, 0.38888888888889
22299, 1, 1.245652173913, 0.41666666666667
22300, 1, 1.2195652173913, 0.33333333333333
22301, 1, 1.245652173913, 0.36111111111111
22302, 1, 1.2195652173913, 0.27777777777778
22303, 1, 1.245652173913, 0.30555555555556
22304, 1, 1.2195652173913, 0.22222222222222
22305, 1, 1.245652173913, 0.25
22306, 1, 1.2195652173913, 0.16666666666667
22307, 1, 1.245652173913, 0.19444444444444
22308, 1, 1.2195652173913, 0.11111111111111
22309, 1, 1.245652173913, 0.13888888888889
22310, 1, 1.2195652173913, 0.055555555555556
22311, 1, 1.245652173913, 0.083333333333333
22312, 1, 1.245652173913, 0.027777777777778
22313, 1, 1.2717391304348, 0.44444444444444
22314, 1, 1.2978260869565, 0.47222222222222
22315, 1, 1.2717391304348, 0.38888888888889
22316, 1, 1.2978260869565, 0.41666666666667
22317, 1, 1.2717391304348, 0.33333333333333
22318, 1, 1.2978260869565, 0.36111111111111
22319, 1, 1.2717391304348, 0.27777777777778
22320, 1, 1.2978260869565, 0.30555555555556
22321, 1, 1.2717391304348, 0.22222222222222
22322, 1, 1.2978260869565, 0.25
22323, 1, 1.2717391304348, 0.16666666666667
22324, 1, 1.2978260869565, 0.19444444444444
22325, 1, 1.2717391304348, 0.11111111111111
22326, 1, 1.2978260869565, 0.13888888888889
22327, 1, 1.2717391304348, 0.055555555555556
22328, 1, 1.2978260869565, 0.083333333333333
22329, 1, 1.2978260869565, 0.027777777777778
22330, 1, 1.3239130434783, 0.44444444444444
22331, 1, 1.3239130434783, 0.38888888888889
22332, 1, 1.3239130434783, 0.33333333333333
22333, 1, 1.3239130434783, 0.27777777777778
22334, 1, 1.3239130434783, 0.22222222222222
22335, 1, 1.3239130434783, 0.16666666666667
22336, 1, 1.3239130434783, 0.11111111111111
22337, 1, 1.3239130434783, 0.055555555555556
22338, 0.95652173913043, 0.20217391304348, 0.5
22339, 0.91304347826087, 0.20217391304348, 0.5
22340, 0.8695652173913, 0.20217391304348, 0.5
22341, 0.82608695652174, 0.20217391304348, 0.5
22342, 0.78260869565217, 0.20217391304348, 0.5
22343, 0.73913043478261, 0.20217391304348, 0.5
22344, 0.69565217391304, 0.20217391304348, 0.5
22345, 0.65217391304348, 0.20217391304348, 0.5
22346, 0.60869565217391, 0.20217391304348, 0.5
22347, 0.56521739130435, 0.20217391304348, 0.5
22348, 0.52173913043478, 0.20217391304348, 0.5
22349, 0.47826086956522, 0.20217391304348, 0.5
22350, 0.43478260869565, 0.20217391304348, 0.5
22351, 0.39130434782609, 0.20217391304348, 0.5
22352, 0.34782608695652, 0.20217391304348, 0.5
22353, 0.30434782608696, 0.20217391304348, 0.5
22354, 0.26086956521739, 0.20217391304348, 0.5
22355, 0.21739130434783, 0.20217391304348, 0.5
22356, 0.17391304347826, 0.20217391304348, 0.5
22357, 0.1304347826087, 0.20217391304348, 0.5
22358, 0.08695652173913, 0.20217391304348, 0.5
22359, 0.043478260869565, 0.20217391304348, 0.5
22360, 0.95652173913043, 0.25434782608696, 0.5
22361, 0.91304347826087, 0.25434782608696, 0.5
22362, 0.8695652173913, 0.25434782608696, 0.5
22363, 0.82608695652174, 0.25434782608696, 0.5
22364, 0.78260869565217, 0.25434782608696, 0.5
22365, 0.73913043478261, 0.25434782608696, 0.5
22366, 0.69565217391304, 0.25434782608696, 0.5
22367, 0.65217391304348, 0.25434782608696, 0.5
22368, 0.60869565217391, 0.25434782608696, 0.5
22369, 0.56521739130435, 0.25434782608696, 0.5
22370, 0.52173913043478, 0.25434782608696, 0.5
22371, 0.47826086956522, 0.25434782608696, 0.5
22372, 0.43478260869565, 0.25434782608696, 0.5
22373, 0.39130434782609, 0.25434782608696, 0.5
22374, 0.34782608695652, 0.25434782608696, 0.5
22375, 0.30434782608696, 0.25434782608696, 0.5
22376, 0.26086956521739, 0.25434782608696, 0.5
22377, 0.21739130434783, 0.25434782608696, 0.5
22378, 0.17391304347826, 0.25434782608696, 0.5
22379, 0.1304347826087, 0.25434782608696, 0.5
22380, 0.08695652173913, 0.25434782608696, 0.5
22381, 0.043478260869565, 0.25434782608696, 0.5
22382, 0.95652173913043, 0.30652173913043, 0.5
22383, 0.91304347826087, 0.30652173913043, 0.5
22384, 0.8695652173913, 0.30652173913043, 0.5
22385, 0.82608695652174, 0.30652173913043, 0.5
22386, 0.78260869565217, 0.30652173913043, 0.5
22387, 0.73913043478261, 0.30652173913043, 0.5
22388, 0.69565217391304, 0.30652173913043, 0.5
22389, 0.65217391304348, 0.30652173913043, 0.5
22390, 0.60869565217391, 0.30652173913043, 0.5
22391, 0.56521739130435, 0.30652173913043, 0.5
22392, 0.52173913043478, 0.30652173913043, 0.5
22393, 0.47826086956522, 0.30652173913043, 0.5
22394, 0.43478260869565, 0.30652173913043, 0.5
22395, 0.39130434782609, 0.30652173913043, 0.5
22396, 0.34782608695652, 0.30652173913043, 0.5
22397, 0.30434782608696, 0.30652173913043, 0.5
22398, 0.26086956521739, 0.30652173913043, 0.5
22399, 0.21739130434783, 0.30652173913043, 0.5
22400, 0.17391304347826, 0.30652173913043, 0.5
22401, 0.1304347826087, 0.30652173913043, 0.5
22402, 0.08695652173913, 0.30652173913043, 0.5
22403, 0.043478260869565, 0.30652173913043, 0.5
22404, 0.95652173913043, 0.35869565217391, 0.5
22405, 0.91304347826087, 0.35869565217391, 0.5
22406, 0.8695652173913, 0.35869565217391, 0.5
22407, 0.82608695652174, 0.35869565217391, 0.5
22408, 0.78260869565217, 0.35869565217391, 0.5
22409, 0.73913043478261, 0.35869565217391, 0.5
22410, 0.69565217391304, 0.35869565217391, 0.5
22411, 0.65217391304348, 0.35869565217391, 0.5
22412, 0.60869565217391, 0.35869565217391, 0.5
22413, 0.56521739130435, 0.35869565217391, 0.5
22414, 0.52173913043478, 0.35869565217391, 0.5
22415, 0.47826086956522, 0.35869565217391, 0.5
22416, 0.43478260869565, 0.35869565217391, 0.5
22417, 0.39130434782609, 0.35869565217391, 0.5
22418, 0.34782608695652, 0.35869565217391, 0.5
22419, 0.30434782608696, 0.35869565217391, 0.5
22420, 0.26086956521739, 0.35869565217391, 0.5
22421, 0.21739130434783, 0.35869565217391, 0.5
22422, 0.17391304347826, 0.35869565217391, 0.5
22423, 0.1304347826087, 0.35869565217391, 0.5
22424, 0.08695652173913, 0.35869565217391, 0.5
22425, 0.043478260869565, 0.35869565217391, 0.5
22426, 0.95652173913043, 0.41086956521739, 0.5
22427, 0.91304347826087, 0.41086956521739, 0.5
22428, 0.8695652173913, 0.41086956521739, 0.5
22429, 0.82608695652174, 0.41086956521739, 0.5
22430, 0.78260869565217, 0.41086956521739, 0.5
22431, 0.73913043478261, 0.41086956521739, 0.5
22432, 0.69565217391304, 0.41086956521739, 0.5
22433, 0.65217391304348, 0.41086956521739, 0.5
22434, 0.60869565217391, 0.41086956521739, 0.5
22435, 0.56521739130435, 0.41086956521739, 0.5
22436, 0.52173913043478, 0.41086956521739, 0.5
22437, 0.47826086956522, 0.41086956521739, 0.5
22438, 0.43478260869565, 0.41086956521739, 0.5
22439, 0.39130434782609, 0.41086956521739, 0.5
22440, 0.34782608695652, 0.41086956521739, 0.5
22441, 0.30434782608696, 0.41086956521739, 0.5
22442, 0.26086956521739, 0.41086956521739, 0.5
22443, 0.21739130434783, 0.41086956521739, 0.5
22444, 0.17391304347826, 0.41086956521739, 0.5
22445, 0.1304347826087, 0.41086956521739, 0.5
22446, 0.08695652173913, 0.41086956521739, 0.5
22447, 0.043478260869565, 0.41086956521739, 0.5
22448, 0.95652173913043, 0.46304347826087, 0.5
22449, 0.91304347826087, 0.46304347826087, 0.5
22450, 0.8695652173913, 0.46304347826087, 0.5
22451, 0.82608695652174, 0.46304347826087, 0.5
22452, 0.78260869565217, 0.46304347826087, 0.5
22453, 0.73913043478261, 0.46304347826087, 0.5
22454, 0.69565217391304, 0.46304347826087, 0.5
22455, 0.65217391304348, 0.46304347826087, 0.5
22456, 0.60869565217391, 0.46304347826087, 0.5
22457, 0.56521739130435, 0.46304347826087, 0.5
22458, 0.52173913043478, 0.46304347826087, 0.5
22459, 0.47826086956522, 0.46304347826087, 0.5
22460, 0.43478260869565, 0.46304347826087, 0.5
22461, 0.39130434782609, 0.46304347826087, 0.5
22462, 0.34782608695652, 0.46304347826087, 0.5
22463, 0.30434782608696, 0.46304347826087, 0.5
22464, 0.26086956521739, 0.46304347826087, 0.5
22465, 0.21739130434783, 0.46304347826087, 0.5
22466, 0.17391304347826, 0.46304347826087, 0.5
22467, 0.1304347826087, 0.46304347826087, 0.5
22468, 0.08695652173913, 0.46304347826087, 0.5
22469, 0.043478260869565, 0.46304347826087, 0.5
22470, 0.95652173913043, 0.51521739130435, 0.5
22471, 0.91304347826087, 0.51521739130435, 0.5
22472, 0.8695652173913, 0.51521739130435, 0.5
22473, 0.82608695652174, 0.51521739130435, 0.5
22474, 0.78260869565217, 0.51521739130435, 0.5
22475, 0.73913043478261, 0.51521739130435, 0.5
22476, 0.69565217391304, 0.51521739130435, 0.5
22477, 0.65217391304348, 0.51521739130435, 0.5
22478, 0.60869565217391, 0.51521739130435, 0.5
22479, 0.56521739130435, 0.51521739130435, 0.5
22480, 0.52173913043478, 0.51521739130435, 0.5
22481, 0.47826086956522, 0.51521739130435, 0.5
22482, 0.43478260869565, 0.51521739130435, 0.5
22483, 0.39130434782609, 0.51521739130435, 0.5
22484, 0.34782608695652, 0.51521739130435, 0.5
22485, 0.30434782608696, 0.51521739130435, 0.5
22486, 0.26086956521739, 0.51521739130435, 0.5
22487, 0.21739130434783, 0.51521739130435, 0.5
22488, 0.17391304347826, 0.51521739130435, 0.5
22489, 0.1304347826087, 0.51521739130435, 0.5
22490, 0.08695652173913, 0.51521739130435, 0.5
22491, 0.043478260869565, 0.51521739130435, 0.5
22492, 0.95652173913043, 0.56739130434783, 0.5
22493, 0.91304347826087, 0.56739130434783, 0.5
22494, 0.8695652173913, 0.56739130434783, 0.5
22495, 0.82608695652174, 0.56739130434783, 0.5
22496, 0.78260869565217, 0.56739130434783, 0.5
22497, 0.73913043478261, 0.56739130434783, 0.5
22498, 0.69565217391304, 0.56739130434783, 0.5
22499, 0.65217391304348, 0.56739130434783, 0.5
22500, 0.60869565217391, 0.56739130434783, 0.5
22501, 0.56521739130435, 0.56739130434783, 0.5
22502, 0.52173913043478, 0.56739130434783, 0.5
22503, 0.47826086956522, 0.56739130434783, 0.5
22504, 0.43478260869565, 0.56739130434783, 0.5
22505, 0.39130434782609, 0.56739130434783, 0.5
22506, 0.34782608695652, 0.56739130434783, 0.5
22507, 0.30434782608696, 0.56739130434783, 0.5
22508, 0.26086956521739, 0.56739130434783, 0.5
22509, 0.21739130434783, 0.56739130434783, 0.5
22510, 0.17391304347826, 0.56739130434783, 0.5
22511, 0.1304347826087, 0.56739130434783, 0.5
22512, 0.08695652173913, 0.56739130434783, 0.5
22513, 0.043478260869565, 0.56739130434783, 0.5
22514, 0.95652173913043, 0.6195652173913, 0.5
22515, 0.91304347826087, 0.6195652173913, 0.5
22516, 0.8695652173913, 0.6195652173913, 0.5
22517, 0.82608695652174, 0.6195652173913, 0.5
22518, 0.78260869565217, 0.6195652173913, 0.5
22519, 0.73913043478261, 0.6195652173913, 0.5
22520, 0.69565217391304, 0.6195652173913, 0.5
22521, 0.65217391304348, 0.6195652173913, 0.5
22522, 0.60869565217391, 0.6195652173913, 0.5
22523, 0.56521739130435, 0.6195652173913, 0.5
22524, 0.52173913043478, 0.6195652173913, 0.5
22525, 0.47826086956522, 0.6195652173913, 0.5
22526, 0.43478260869565, 0.6195652173913, 0.5
22527, 0.39130434782609, 0.6195652173913, 0.5
22528, 0.34782608695652, 0.6195652173913, 0.5
22529, 0.30434782608696, 0.6195652173913, 0.5
22530, 0.26086956521739, 0.6195652173913, 0.5
22531, 0.21739130434783, 0.6195652173913, 0.5
22532, 0.17391304347826, 0.6195652173913, 0.5
22533, 0.1304347826087, 0.6195652173913, 0.5
22534, 0.08695652173913, 0.6195652173913, 0.5
22535, 0.043478260869565, 0.6195652173913, 0.5
22536, 0.95652173913043, 0.67173913043478, 0.5
22537, 0.91304347826087, 0.67173913043478, 0.5
22538, 0.8695652173913, 0.67173913043478, 0.5
22539, 0.82608695652174, 0.67173913043478, 0.5
22540, 0.78260869565217, 0.67173913043478, 0.5
22541, 0.73913043478261, 0.67173913043478, 0.5
22542, 0.69565217391304, 0.67173913043478, 0.5
22543, 0.65217391304348, 0.67173913043478, 0.5
22544, 0.60869565217391, 0.67173913043478, 0.5
22545, 0.56521739130435, 0.67173913043478, 0.5
22546, 0.52173913043478, 0.67173913043478, 0.5
22547, 0.47826086956522, 0.67173913043478, 0.5
22548, 0.43478260869565, 0.67173913043478, 0.5
22549, 0.39130434782609, 0.67173913043478, 0.5
22550, 0.34782608695652, 0.67173913043478, 0.5
22551, 0.30434782608696, 0.67173913043478, 0.5
22552, 0.26086956521739, 0.67173913043478, 0.5
22553, 0.21739130434783, 0.67173913043478, 0.5
22554, 0.17391304347826, 0.67173913043478, 0.5
22555, 0.1304347826087, 0.67173913043478, 0.5
22556, 0.08695652173913, 0.67173913043478, 0.5
22557, 0.043478260869565, 0.67173913043478, 0.5
22558, 0.95652173913043, 0.72391304347826, 0.5
22559, 0.91304347826087, 0.72391304347826, 0.5
22560, 0.8695652173913, 0.72391304347826, 0.5
22561, 0.82608695652174, 0.72391304347826, 0.5
22562, 0.78260869565217, 0.72391304347826, 0.5
22563, 0.73913043478261, 0.72391304347826, 0.5
22564, 0.69565217391304, 0.72391304347826, 0.5
22565, 0.65217391304348, 0.72391304347826, 0.5
22566, 0.60869565217391, 0.72391304347826, 0.5
22567, 0.56521739130435, 0.72391304347826, 0.5
22568, 0.52173913043478, 0.72391304347826, 0.5
22569, 0.47826086956522, 0.72391304347826, 0.5
22570, 0.43478260869565, 0.72391304347826, 0.5
22571, 0.39130434782609, 0.72391304347826, 0.5
22572, 0.34782608695652, 0.72391304347826, 0.5
22573, 0.30434782608696, 0.72391304347826, 0.5
22574, 0.26086956521739, 0.72391304347826, 0.5
22575, 0.21739130434783, 0.72391304347826, 0.5
22576, 0.17391304347826, 0.72391304347826, 0.5
22577, 0.1304347826087, 0.72391304347826, 0.5
22578, 0.08695652173913, 0.72391304347826, 0.5
22579, 0.043478260869565, 0.72391304347826, 0.5
22580, 0.95652173913043, 0.77608695652174, 0.5
22581, 0.91304347826087, 0.77608695652174, 0.5
22582, 0.8695652173913, 0.77608695652174, 0.5
22583, 0.82608695652174, 0.77608695652174, 0.5
22584, 0.78260869565217, 0.77608695652174, 0.5
22585, 0.73913043478261, 0.77608695652174, 0.5
22586, 0.69565217391304, 0.77608695652174, 0.5
22587, 0.65217391304348, 0.77608695652174, 0.5
22588, 0.60869565217391, 0.77608695652174, 0.5
22589, 0.56521739130435, 0.77608695652174, 0.5
22590, 0.52173913043478, 0.77608695652174, 0.5
22591, 0.47826086956522, 0.77608695652174, 0.5
22592, 0.43478260869565, 0.77608695652174, 0.5
22593, 0.39130434782609, 0.77608695652174, 0.5
22594, 0.34782608695652, 0.77608695652174, 0.5
22595, 0.30434782608696, 0.77608695652174, 0.5
22596, 0.26086956521739, 0.77608695652174, 0.5
22597, 0.21739130434783, 0.77608695652174, 0.5
22598, 0.17391304347826, 0.77608695652174, 0.5
22599, 0.1304347826087, 0.77608695652174, 0.5
22600, 0.08695652173913, 0.77608695652174, 0.5
22601, 0.043478260869565, 0.77608695652174, 0.5
22602, 0.95652173913043, 0.82826086956522, 0.5
22603, 0.91304347826087, 0.82826086956522, 0.5
22604, 0.8695652173913, 0.82826086956522, 0.5
22605, 0.82608695652174, 0.82826086956522, 0.5
22606, 0.78260869565217, 0.82826086956522, 0.5
22607, 0.73913043478261, 0.82826086956522, 0.5
22608, 0.69565217391304, 0.82826086956522, 0.5
22609, 0.65217391304348, 0.82826086956522, 0.5
22610, 0.60869565217391, 0.82826086956522, 0.5
22611, 0.56521739130435, 0.82826086956522, 0.5
22612, 0.52173913043478, 0.82826086956522, 0.5
22613, 0.47826086956522, 0.82826086956522, 0.5
22614, 0.43478260869565, 0.82826086956522, 0.5
22615, 0.39130434782609, 0.82826086956522, 0.5
22616, 0.34782608695652, 0.82826086956522, 0.5
22617, 0.30434782608696, 0.82826086956522, 0.5
22618, 0.26086956521739, 0.82826086956522, 0.5
22619, 0.21739130434783, 0.82826086956522, 0.5
22620, 0.17391304347826, 0.82826086956522, 0.5
22621, 0.1304347826087, 0.82826086956522, 0.5
22622, 0.08695652173913, 0.82826086956522, 0.5
22623, 0.043478260869565, 0.82826086956522, 0.5
22624, 0.95652173913043, 0.8804347826087, 0.5
22625, 0.91304347826087, 0.8804347826087, 0.5
22626, 0.8695652173913, 0.88043478260869, 0.5
22627, 0.82608695652174, 0.8804347826087, 0.5
22628, 0.78260869565217, 0.8804347826087, 0.5
22629, 0.73913043478261, 0.8804347826087, 0.5
22630, 0.69565217391304, 0.8804347826087, 0.5
22631, 0.65217391304348, 0.8804347826087, 0.5
22632, 0.60869565217391, 0.8804347826087, 0.5
22633, 0.56521739130435, 0.8804347826087, 0.5
22634, 0.52173913043478, 0.88043478260869, 0.5
22635, 0.47826086956522, 0.8804347826087, 0.5
22636, 0.43478260869565, 0.8804347826087, 0.5
22637, 0.39130434782609, 0.88043478260869, 0.5
22638, 0.34782608695652, 0.8804347826087, 0.5
22639, 0.30434782608696, 0.8804347826087, 0.5
22640, 0.26086956521739, 0.8804347826087, 0.5
22641, 0.21739130434783, 0.8804347826087, 0.5
22642, 0.17391304347826, 0.8804347826087, 0.5
22643, 0.1304347826087, 0.8804347826087, 0.5
22644, 0.08695652173913, 0.8804347826087, 0.5
22645, 0.043478260869565, 0.8804347826087, 0.5
22646, 0.95652173913043, 0.93260869565217, 0.5
22647, 0.91304347826087, 0.93260869565217, 0.5
22648, 0.8695652173913, 0.93260869565217, 0.5
22649, 0.82608695652174, 0.93260869565217, 0.5
22650, 0.78260869565217, 0.93260869565217, 0.5
22651, 0.73913043478261, 0.93260869565217, 0.5
22652, 0.69565217391304, 0.93260869565217, 0.5
22653, 0.65217391304348, 0.93260869565217, 0.5
22654, 0.60869565217391, 0.93260869565217, 0.5
22655, 0.56521739130435, 0.93260869565217, 0.5
22656, 0.52173913043478, 0.93260869565217, 0.5
22657, 0.47826086956522, 0.93260869565217, 0.5
22658, 0.43478260869565, 0.93260869565217, 0.5
22659, 0.39130434782609, 0.93260869565217, 0.5
22660, 0.34782608695652, 0.93260869565217, 0.5
22661, 0.30434782608696, 0.93260869565217, 0.5
22662, 0.26086956521739, 0.93260869565217, 0.5
22663, 0.21739130434783, 0.93260869565217, 0.5
22664, 0.17391304347826, 0.93260869565217, 0.5
22665, 0.1304347826087, 0.93260869565217, 0.5
22666, 0.08695652173913, 0.93260869565217, 0.5
22667, 0.043478260869565, 0.93260869565217, 0.5
22668, 0.95652173913043, 0.98478260869565, 0.5
22669, 0.91304347826087, 0.98478260869565, 0.5
22670, 0.8695652173913, 0.98478260869565, 0.5
22671, 0.82608695652174, 0.98478260869565, 0.5
22672, 0.78260869565217, 0.98478260869565, 0.5
22673, 0.73913043478261, 0.98478260869565, 0.5
22674, 0.69565217391304, 0.98478260869565, 0.5
22675, 0.65217391304348, 0.98478260869565, 0.5
22676, 0.60869565217391, 0.98478260869565, 0.5
22677, 0.56521739130435, 0.98478260869565, 0.5
22678, 0.52173913043478, 0.98478260869565, 0.5
22679, 0.47826086956522, 0.98478260869565, 0.5
22680, 0.43478260869565, 0.98478260869565, 0.5
22681, 0.39130434782609, 0.98478260869565, 0.5
22682, 0.34782608695652, 0.98478260869565, 0.5
22683, 0.30434782608696, 0.98478260869565, 0.5
22684, 0.26086956521739, 0.98478260869565, 0.5
22685, 0.21739130434783, 0.98478260869565, 0.5
22686, 0.17391304347826, 0.98478260869565, 0.5
22687, 0.1304347826087, 0.98478260869565, 0.5
22688, 0.08695652173913, 0.98478260869565, 0.5
22689, 0.043478260869565, 0.98478260869565, 0.5
22690, 0.95652173913043, 1.0369565217391, 0.5
22691, 0.91304347826087, 1.0369565217391, 0.5
22692, 0.8695652173913, 1.0369565217391, 0.5
22693, 0.82608695652174, 1.0369565217391, 0.5
22694, 0.78260869565217, 1.0369565217391, 0.5
22695, 0.73913043478261, 1.0369565217391, 0.5
22696, 0.69565217391304, 1.0369565217391, 0.5
22697, 0.65217391304348, 1.0369565217391, 0.5
22698, 0.60869565217391, 1.0369565217391, 0.5
22699, 0.56521739130435, 1.0369565217391, 0.5
22700, 0.52173913043478, 1.0369565217391, 0.5
22701, 0.47826086956522, 1.0369565217391, 0.5
22702, 0.43478260869565, 1.0369565217391, 0.5
22703, 0.39130434782609, 1.0369565217391, 0.5
22704, 0.34782608695652, 1.0369565217391, 0.5
22705, 0.30434782608696, 1.0369565217391, 0.5
22706, 0.26086956521739, 1.0369565217391, 0.5
22707, 0.21739130434783, 1.0369565217391, 0.5
22708, 0.17391304347826, 1.0369565217391, 0.5
22709, 0.1304347826087, 1.0369565217391, 0.5
22710, 0.08695652173913, 1.0369565217391, 0.5
22711, 0.043478260869565, 1.0369565217391, 0.5
22712, 0.95652173913043, 1.0891304347826, 0.5
22713, 0.91304347826087, 1.0891304347826, 0.5
22714, 0.8695652173913, 1.0891304347826, 0.5
22715, 0.82608695652174, 1.0891304347826, 0.5
22716, 0.78260869565217, 1.0891304347826, 0.5
22717, 0.73913043478261, 1.0891304347826, 0.5
22718, 0.69565217391304, 1.0891304347826, 0.5
22719, 0.65217391304348, 1.0891304347826, 0.5
22720, 0.60869565217391, 1.0891304347826, 0.5
22721, 0.56521739130435, 1.0891304347826, 0.5
22722, 0.52173913043478, 1.0891304347826, 0.5
22723, 0.47826086956522, 1.0891304347826, 0.5
22724, 0.43478260869565, 1.0891304347826, 0.5
22725, 0.39130434782609, 1.0891304347826, 0.5
22726, 0.34782608695652, 1.0891304347826, 0.5
22727, 0.30434782608696, 1.0891304347826, 0.5
22728, 0.26086956521739, 1.0891304347826, 0.5
22729, 0.21739130434783, 1.0891304347826, 0.5
22730, 0.17391304347826, 1.0891304347826, 0.5
22731, 0.1304347826087, 1.0891304347826, 0.5
22732, 0.08695652173913, 1.0891304347826, 0.5
22733, 0.043478260869565, 1.0891304347826, 0.5
22734, 0.95652173913043, 1.1413043478261, 0.5
22735, 0.91304347826087, 1.1413043478261, 0.5
22736, 0.8695652173913, 1.1413043478261, 0.5
22737, 0.82608695652174, 1.1413043478261, 0.5
22738, 0.78260869565217, 1.1413043478261, 0.5
22739, 0.73913043478261, 1.1413043478261, 0.5
22740, 0.69565217391304, 1.1413043478261, 0.5
22741, 0.65217391304348, 1.1413043478261, 0.5
22742, 0.60869565217391, 1.1413043478261, 0.5
22743, 0.56521739130435, 1.1413043478261, 0.5
22744, 0.52173913043478, 1.1413043478261, 0.5
22745, 0.47826086956522, 1.1413043478261, 0.5
22746, 0.43478260869565, 1.1413043478261, 0.5
22747, 0.39130434782609, 1.1413043478261, 0.5
22748, 0.34782608695652, 1.1413043478261, 0.5
22749, 0.30434782608696, 1.1413043478261, 0.5
22750, 0.26086956521739, 1.1413043478261, 0.5
22751, 0.21739130434783, 1.1413043478261, 0.5
22752, 0.17391304347826, 1.1413043478261, 0.5
22753, 0.1304347826087, 1.1413043478261, 0.5
22754, 0.08695652173913, 1.1413043478261, 0.5
22755, 0.043478260869565, 1.1413043478261, 0.5
22756, 0.95652173913043, 1.1934782608696, 0.5
22757, 0.91304347826087, 1.1934782608696, 0.5
22758, 0.8695652173913, 1.1934782608696, 0.5
22759, 0.82608695652174, 1.1934782608696, 0.5
22760, 0.78260869565217, 1.1934782608696, 0.5
22761, 0.73913043478261, 1.1934782608696, 0.5
22762, 0.69565217391304, 1.1934782608696, 0.5
22763, 0.65217391304348, 1.1934782608696, 0.5
22764, 0.60869565217391, 1.1934782608696, 0.5
22765, 0.56521739130435, 1.1934782608696, 0.5
22766, 0.52173913043478, 1.1934782608696, 0.5
22767, 0.47826086956522, 1.1934782608696, 0.5
22768, 0.43478260869565, 1.1934782608696, 0.5
22769, 0.39130434782609, 1.1934782608696, 0.5
22770, 0.34782608695652, 1.1934782608696, 0.5
22771, 0.30434782608696, 1.1934782608696, 0.5
22772, 0.26086956521739, 1.1934782608696, 0.5
22773, 0.21739130434783, 1.1934782608696, 0.5
22774, 0.17391304347826, 1.1934782608696, 0.5
22775, 0.1304347826087, 1.1934782608696, 0.5
22776, 0.08695652173913, 1.1934782608696, 0.5
22777, 0.043478260869565, 1.1934782608696, 0.5
22778, 0.95652173913043, 1.245652173913, 0.5
22779, 0.91304347826087, 1.245652173913, 0.5
22780, 0.8695652173913, 1.245652173913, 0.5
22781, 0.82608695652174, 1.245652173913, 0.5
22782, 0.78260869565217, 1.245652173913, 0.5
22783, 0.73913043478261, 1.245652173913, 0.5
22784, 0.69565217391304, 1.245652173913, 0.5
22785, 0.65217391304348, 1.245652173913, 0.5
22786, 0.60869565217391, 1.245652173913, 0.5
22787, 0.56521739130435, 1.245652173913, 0.5
22788, 0.52173913043478, 1.245652173913, 0.5
22789, 0.47826086956522, 1.245652173913, 0.5
22790, 0.43478260869565, 1.245652173913, 0.5
22791, 0.39130434782609, 1.245652173913, 0.5
22792, 0.34782608695652, 1.245652173913, 0.5
22793, 0.30434782608696, 1.245652173913, 0.5
22794, 0.26086956521739, 1.245652173913, 0.5
22795, 0.21739130434783, 1.245652173913, 0.5
22796, 0.17391304347826, 1.245652173913, 0.5
22797, 0.1304347826087, 1.245652173913, 0.5
22798, 0.08695652173913, 1.245652173913, 0.5
22799, 0.043478260869565, 1.245652173913, 0.5
22800, 0.95652173913043, 1.2978260869565, 0.5
22801, 0.91304347826087, 1.2978260869565, 0.5
22802, 0.8695652173913, 1.2978260869565, 0.5
22803, 0.82608695652174, 1.2978260869565, 0.5
22804, 0.78260869565217, 1.2978260869565, 0.5
22805, 0.73913043478261, 1.2978260869565, 0.5
22806, 0.69565217391304, 1.2978260869565, 0.5
22807, 0.65217391304348, 1.2978260869565, 0.5
22808, 0.60869565217391, 1.2978260869565, 0.5
22809, 0.56521739130435, 1.2978260869565, 0.5
22810, 0.52173913043478, 1.2978260869565, 0.5
22811, 0.47826086956522, 1.2978260869565, 0.5
22812, 0.43478260869565, 1.2978260869565, 0.5
22813, 0.39130434782609, 1.2978260869565, 0.5
22814, 0.34782608695652, 1.2978260869565, 0.5
22815, 0.30434782608696, 1.2978260869565, 0.5
22816, 0.26086956521739, 1.2978260869565, 0.5
22817, 0.21739130434783, 1.2978260869565, 0.5
22818, 0.17391304347826, 1.2978260869565, 0.5
22819, 0.1304347826087, 1.2978260869565, 0.5
22820, 0.08695652173913, 1.2978260869565, 0.5
22821, 0.043478260869565, 1.2978260869565, 0.5
22822, 0.97826086956522, 0.20217391304348, 0.5
22823, 0.95652173913043, 0.17608695652174, 0.5
22824, 0.93478260869565, 0.20217391304348, 0.5
22825, 0.91304347826087, 0.17608695652174, 0.5
22826, 0.89130434782609, 0.20217391304348, 0.5
22827, 0.8695652173913, 0.17608695652174, 0.5
22828, 0.84782608695652, 0.20217391304348, 0.5
22829, 0.82608695652174, 0.17608695652174, 0.5
22830, 0.80434782608696, 0.20217391304348, 0.5
22831, 0.78260869565217, 0.17608695652174, 0.5
22832, 0.76086956521739, 0.20217391304348, 0.5
22833, 0.73913043478261, 0.17608695652174, 0.5
22834, 0.71739130434783, 0.20217391304348, 0.5
22835, 0.69565217391304, 0.17608695652174, 0.5
22836, 0.67391304347826, 0.20217391304348, 0.5
22837, 0.65217391304348, 0.17608695652174, 0.5
22838, 0.6304347826087, 0.20217391304348, 0.5
22839, 0.60869565217391, 0.17608695652174, 0.5
22840, 0.58695652173913, 0.20217391304348, 0.5
22841, 0.56521739130435, 0.17608695652174, 0.5
22842, 0.54347826086957, 0.20217391304348, 0.5
22843, 0.52173913043478, 0.17608695652174, 0.5
22844, 0.5, 0.20217391304348, 0.5
22845, 0.47826086956522, 0.17608695652174, 0.5
22846, 0.45652173913043, 0.20217391304348, 0.5
22847, 0.43478260869565, 0.17608695652174, 0.5
22848, 0.41304347826087, 0.20217391304348, 0.5
22849, 0.39130434782609, 0.17608695652174, 0.5
22850, 0.3695652173913, 0.20217391304348, 0.5
22851, 0.34782608695652, 0.17608695652174, 0.5
22852, 0.32608695652174, 0.20217391304348, 0.5
22853, 0.30434782608696, 0.17608695652174, 0.5
22854, 0.28260869565217, 0.20217391304348, 0.5
22855, 0.26086956521739, 0.17608695652174, 0.5
22856, 0.23913043478261, 0.20217391304348, 0.5
22857, 0.21739130434783, 0.17608695652174, 0.5
22858, 0.19565217391304, 0.20217391304348, 0.5
22859, 0.17391304347826, 0.17608695652174, 0.5
22860, 0.15217391304348, 0.20217391304348, 0.5
22861, 0.1304347826087, 0.17608695652174, 0.5
22862, 0.10869565217391, 0.20217391304348, 0.5
22863, 0.08695652173913, 0.17608695652174, 0.5
22864, 0.065217391304348, 0.20217391304348, 0.5
22865, 0.043478260869565, 0.17608695652174, 0.5
22866, 0.021739130434783, 0.20217391304348, 0.5
22867, 0.97826086956522, 0.25434782608696, 0.5
22868, 0.95652173913043, 0.22826086956522, 0.5
22869, 0.93478260869565, 0.25434782608696, 0.5
22870, 0.91304347826087, 0.22826086956522, 0.5
22871, 0.89130434782609, 0.25434782608696, 0.5
22872, 0.8695652173913, 0.22826086956522, 0.5
22873, 0.84782608695652, 0.25434782608696, 0.5
22874, 0.82608695652174, 0.22826086956522, 0.5
22875, 0.80434782608696, 0.25434782608696, 0.5
22876, 0.78260869565217, 0.22826086956522, 0.5
22877, 0.76086956521739, 0.25434782608696, 0.5
22878, 0.73913043478261, 0.22826086956522, 0.5
22879, 0.71739130434783, 0.25434782608696, 0.5
22880, 0.69565217391304, 0.22826086956522, 0.5
22881, 0.67391304347826, 0.25434782608696, 0.5
22882, 0.65217391304348, 0.22826086956522, 0.5
22883, 0.6304347826087, 0.25434782608696, 0.5
22884, 0.60869565217391, 0.22826086956522, 0.5
22885, 0.58695652173913, 0.25434782608696, 0.5
22886, 0.56521739130435, 0.22826086956522, 0.5
22887, 0.54347826086957, 0.25434782608696, 0.5
22888, 0.52173913043478, 0.22826086956522, 0.5
22889, 0.5, 0.25434782608696, 0.5
22890, 0.47826086956522, 0.22826086956522, 0.5
22891, 0.45652173913043, 0.25434782608696, 0.5
22892, 0.43478260869565, 0.22826086956522, 0.5
22893, 0.41304347826087, 0.25434782608696, 0.5
22894, 0.39130434782609, 0.22826086956522, 0.5
22895, 0.3695652173913, 0.25434782608696, 0.5
22896, 0.34782608695652, 0.22826086956522, 0.5
22897, 0.32608695652174, 0.25434782608696, 0.5
22898, 0.30434782608696, 0.22826086956522, 0.5
22899, 0.28260869565217, 0.25434782608696, 0.5
22900, 0.26086956521739, 0.22826086956522, 0.5
22901, 0.23913043478261, 0.25434782608696, 0.5
22902, 0.21739130434783, 0.22826086956522, 0.5
22903, 0.19565217391304, 0.25434782608696, 0.5
22904, 0.17391304347826, 0.22826086956522, 0.5
22905, 0.15217391304348, 0.25434782608696, 0.5
22906, 0.1304347826087, 0.22826086956522, 0.5
22907, 0.10869565217391, 0.25434782608696, 0.5
22908, 0.08695652173913, 0.22826086956522, 0.5
22909, 0.065217391304348, 0.25434782608696, 0.5
22910, 0.043478260869565, 0.22826086956522, 0.5
22911, 0.021739130434783, 0.25434782608696, 0.5
22912, 0.97826086956522, 0.30652173913043, 0.5
22913, 0.95652173913043, 0.2804347826087, 0.5
22914, 0.93478260869565, 0.30652173913043, 0.5
22915, 0.91304347826087, 0.2804347826087, 0.5
22916, 0.89130434782609, 0.30652173913043, 0.5
22917, 0.8695652173913, 0.2804347826087, 0.5
22918, 0.84782608695652, 0.30652173913043, 0.5
22919, 0.82608695652174, 0.2804347826087, 0.5
22920, 0.80434782608696, 0.30652173913043, 0.5
22921, 0.78260869565217, 0.2804347826087, 0.5
22922, 0.76086956521739, 0.30652173913043, 0.5
22923, 0.73913043478261, 0.2804347826087, 0.5
22924, 0.71739130434783, 0.30652173913043, 0.5
22925, 0.69565217391304, 0.2804347826087, 0.5
22926, 0.67391304347826, 0.30652173913043, 0.5
22927, 0.65217391304348, 0.2804347826087, 0.5
22928, 0.6304347826087, 0.30652173913043, 0.5
22929, 0.60869565217391, 0.2804347826087, 0.5
22930, 0.58695652173913, 0.30652173913043, 0.5
22931, 0.56521739130435, 0.2804347826087, 0.5
22932, 0.54347826086957, 0.30652173913043, 0.5
22933, 0.52173913043478, 0.2804347826087, 0.5
22934, 0.5, 0.30652173913043, 0.5
22935, 0.47826086956522, 0.2804347826087, 0.5
22936, 0.45652173913043, 0.30652173913043, 0.5
22937, 0.43478260869565, 0.2804347826087, 0.5
22938, 0.41304347826087, 0.30652173913043, 0.5
22939, 0.39130434782609, 0.2804347826087, 0.5
22940, 0.3695652173913, 0.30652173913043, 0.5
22941, 0.34782608695652, 0.2804347826087, 0.5
22942, 0.32608695652174, 0.30652173913043, 0.5
22943, 0.30434782608696, 0.2804347826087, 0.5
22944, 0.28260869565217, 0.30652173913043, 0.5
22945, 0.26086956521739, 0.2804347826087, 0.5
22946, 0.23913043478261, 0.30652173913043, 0.5
22947, 0.21739130434783, 0.2804347826087, 0.5
22948, 0.19565217391304, 0.30652173913043, 0.5
22949, 0.17391304347826, 0.2804347826087, 0.5
22950, 0.15217391304348, 0.30652173913043, 0.5
22951, 0.1304347826087, 0.2804347826087, 0.5
22952, 0.10869565217391, 0.30652173913043, 0.5
22953, 0.08695652173913, 0.2804347826087, 0.5
22954, 0.065217391304348, 0.30652173913043, 0.5
22955, 0.043478260869565, 0.2804347826087, 0.5
22956, 0.021739130434783, 0.30652173913043, 0.5
22957, 0.97826086956522, 0.35869565217391, 0.5
22958, 0.95652173913043, 0.33260869565217, 0.5
22959, 0.93478260869565, 0.35869565217391, 0.5
22960, 0.91304347826087, 0.33260869565217, 0.5
22961, 0.89130434782609, 0.35869565217391, 0.5
22962, 0.8695652173913, 0.33260869565217, 0.5
22963, 0.84782608695652, 0.35869565217391, 0.5
22964, 0.82608695652174, 0.33260869565217, 0.5
22965, 0.80434782608696, 0.35869565217391, 0.5
22966, 0.78260869565217, 0.33260869565217, 0.5
22967, 0.76086956521739, 0.35869565217391, 0.5
22968, 0.73913043478261, 0.33260869565217, 0.5
22969, 0.71739130434783, 0.35869565217391, 0.5
22970, 0.69565217391304, 0.33260869565217, 0.5
22971, 0.67391304347826, 0.35869565217391, 0.5
22972, 0.65217391304348, 0.33260869565217, 0.5
22973, 0.6304347826087, 0.35869565217391, 0.5
22974, 0.60869565217391, 0.33260869565217, 0.5
22975, 0.58695652173913, 0.35869565217391, 0.5
22976, 0.56521739130435, 0.33260869565217, 0.5
22977, 0.54347826086957, 0.35869565217391, 0.5
22978, 0.52173913043478, 0.33260869565217, 0.5
22979, 0.5, 0.35869565217391, 0.5
22980, 0.47826086956522, 0.33260869565217, 0.5
22981, 0.45652173913043, 0.35869565217391, 0.5
22982, 0.43478260869565, 0.33260869565217, 0.5
22983, 0.41304347826087, 0.35869565217391, 0.5
22984, 0.39130434782609, 0.33260869565217, 0.5
22985, 0.3695652173913, 0.35869565217391, 0.5
22986, 0.34782608695652, 0.33260869565217, 0.5
22987, 0.32608695652174, 0.35869565217391, 0.5
22988, 0.30434782608696, 0.33260869565217, 0.5
22989, 0.28260869565217, 0.35869565217391, 0.5
22990, 0.26086956521739, 0.33260869565217, 0.5
22991, 0.23913043478261, 0.35869565217391, 0.5
22992, 0.21739130434783, 0.33260869565217, 0.5
22993, 0.19565217391304, 0.35869565217391, 0.5
22994, 0.17391304347826, 0.33260869565217, 0.5
22995, 0.15217391304348, 0.35869565217391, 0.5
22996, 0.1304347826087, 0.33260869565217, 0.5
22997, 0.10869565217391, 0.35869565217391, 0.5
22998, 0.08695652173913, 0.33260869565217, 0.5
22999, 0.065217391304348, 0.35869565217391, 0.5
23000, 0.043478260869565, 0.33260869565217, 0.5
23001, 0.021739130434783, 0.35869565217391, 0.5
23002, 0.97826086956522, 0.41086956521739, 0.5
23003, 0.95652173913043, 0.38478260869565, 0.5
23004, 0.93478260869565, 0.41086956521739, 0.5
23005, 0.91304347826087, 0.38478260869565, 0.5
23006, 0.89130434782609, 0.41086956521739, 0.5
23007, 0.8695652173913, 0.38478260869565, 0.5
23008, 0.84782608695652, 0.41086956521739, 0.5
23009, 0.82608695652174, 0.38478260869565, 0.5
23010, 0.80434782608696, 0.41086956521739, 0.5
23011, 0.78260869565217, 0.38478260869565, 0.5
23012, 0.76086956521739, 0.41086956521739, 0.5
23013, 0.73913043478261, 0.38478260869565, 0.5
23014, 0.71739130434783, 0.41086956521739, 0.5
23015, 0.69565217391304, 0.38478260869565, 0.5
23016, 0.67391304347826, 0.41086956521739, 0.5
23017, 0.65217391304348, 0.38478260869565, 0.5
23018, 0.6304347826087, 0.41086956521739, 0.5
23019, 0.60869565217391, 0.38478260869565, 0.5
23020, 0.58695652173913, 0.41086956521739, 0.5
23021, 0.56521739130435, 0.38478260869565, 0.5
23022, 0.54347826086957, 0.41086956521739, 0.5
23023, 0.52173913043478, 0.38478260869565, 0.5
23024, 0.5, 0.41086956521739, 0.5
23025, 0.47826086956522, 0.38478260869565, 0.5
23026, 0.45652173913043, 0.41086956521739, 0.5
23027, 0.43478260869565, 0.38478260869565, 0.5
23028, 0.41304347826087, 0.41086956521739, 0.5
23029, 0.39130434782609, 0.38478260869565, 0.5
23030, 0.3695652173913, 0.41086956521739, 0.5
23031, 0.34782608695652, 0.38478260869565, 0.5
23032, 0.32608695652174, 0.41086956521739, 0.5
23033, 0.30434782608696, 0.38478260869565, 0.5
23034, 0.28260869565217, 0.41086956521739, 0.5
23035, 0.26086956521739, 0.38478260869565, 0.5
23036, 0.23913043478261, 0.41086956521739, 0.5
23037, 0.21739130434783, 0.38478260869565, 0.5
23038, 0.19565217391304, 0.41086956521739, 0.5
23039, 0.17391304347826, 0.38478260869565, 0.5
23040, 0.15217391304348, 0.41086956521739, 0.5
23041, 0.1304347826087, 0.38478260869565, 0.5
23042, 0.10869565217391, 0.41086956521739, 0.5
23043, 0.08695652173913, 0.38478260869565, 0.5
23044, 0.065217391304348, 0.41086956521739, 0.5
23045, 0.043478260869565, 0.38478260869565, 0.5
23046, 0.021739130434783, 0.41086956521739, 0.5
23047, 0.97826086956522, 0.46304347826087, 0.5
23048, 0.95652173913043, 0.43695652173913, 0.5
23049, 0.93478260869565, 0.46304347826087, 0.5
23050, 0.91304347826087, 0.43695652173913, 0.5
23051, 0.89130434782609, 0.46304347826087, 0.5
23052, 0.8695652173913, 0.43695652173913, 0.5
23053, 0.84782608695652, 0.46304347826087, 0.5
23054, 0.82608695652174, 0.43695652173913, 0.5
23055, 0.80434782608696, 0.46304347826087, 0.5
23056, 0.78260869565217, 0.43695652173913, 0.5
23057, 0.76086956521739, 0.46304347826087, 0.5
23058, 0.73913043478261, 0.43695652173913, 0.5
23059, 0.71739130434783, 0.46304347826087, 0.5
23060, 0.69565217391304, 0.43695652173913, 0.5
23061, 0.67391304347826, 0.46304347826087, 0.5
23062, 0.65217391304348, 0.43695652173913, 0.5
23063, 0.6304347826087, 0.46304347826087, 0.5
23064, 0.60869565217391, 0.43695652173913, 0.5
23065, 0.58695652173913, 0.46304347826087, 0.5
23066, 0.56521739130435, 0.43695652173913, 0.5
23067, 0.54347826086957, 0.46304347826087, 0.5
23068, 0.52173913043478, 0.43695652173913, 0.5
23069, 0.5, 0.46304347826087, 0.5
23070, 0.47826086956522, 0.43695652173913, 0.5
23071, 0.45652173913043, 0.46304347826087, 0.5
23072, 0.43478260869565, 0.43695652173913, 0.5
23073, 0.41304347826087, 0.46304347826087, 0.5
23074, 0.39130434782609, 0.43695652173913, 0.5
23075, 0.3695652173913, 0.46304347826087, 0.5
23076, 0.34782608695652, 0.43695652173913, 0.5
23077, 0.32608695652174, 0.46304347826087, 0.5
23078, 0.30434782608696, 0.43695652173913, 0.5
23079, 0.28260869565217, 0.46304347826087, 0.5
23080, 0.26086956521739, 0.43695652173913, 0.5
23081, 0.23913043478261, 0.46304347826087, 0.5
23082, 0.21739130434783, 0.43695652173913, 0.5
23083, 0.19565217391304, 0.46304347826087, 0.5
23084, 0.17391304347826, 0.43695652173913, 0.5
23085, 0.15217391304348, 0.46304347826087, 0.5
23086, 0.1304347826087, 0.43695652173913, 0.5
23087, 0.10869565217391, 0.46304347826087, 0.5
23088, 0.08695652173913, 0.43695652173913, 0.5
23089, 0.065217391304348, 0.46304347826087, 0.5
23090, 0.043478260869565, 0.43695652173913, 0.5
23091, 0.021739130434783, 0.46304347826087, 0.5
23092, 0.97826086956522, 0.51521739130435, 0.5
23093, 0.95652173913043, 0.48913043478261, 0.5
23094, 0.93478260869565, 0.51521739130435, 0.5
23095, 0.91304347826087, 0.48913043478261, 0.5
23096, 0.89130434782609, 0.51521739130435, 0.5
23097, 0.8695652173913, 0.48913043478261, 0.5
23098, 0.84782608695652, 0.51521739130435, 0.5
23099, 0.82608695652174, 0.48913043478261, 0.5
23100, 0.80434782608696, 0.51521739130435, 0.5
23101, 0.78260869565217, 0.48913043478261, 0.5
23102, 0.76086956521739, 0.51521739130435, 0.5
23103, 0.73913043478261, 0.48913043478261, 0.5
23104, 0.71739130434783, 0.51521739130435, 0.5
23105, 0.69565217391304, 0.48913043478261, 0.5
23106, 0.67391304347826, 0.51521739130435, 0.5
23107, 0.65217391304348, 0.48913043478261, 0.5
23108, 0.6304347826087, 0.51521739130435, 0.5
23109, 0.60869565217391, 0.48913043478261, 0.5
23110, 0.58695652173913, 0.51521739130435, 0.5
23111, 0.56521739130435, 0.48913043478261, 0.5
23112, 0.54347826086957, 0.51521739130435, 0.5
23113, 0.52173913043478, 0.48913043478261, 0.5
23114, 0.5, 0.51521739130435, 0.5
23115, 0.47826086956522, 0.48913043478261, 0.5
23116, 0.45652173913043, 0.51521739130435, 0.5
23117, 0.43478260869565, 0.48913043478261, 0.5
23118, 0.41304347826087, 0.51521739130435, 0.5
23119, 0.39130434782609, 0.48913043478261, 0.5
23120, 0.3695652173913, 0.51521739130435, 0.5
23121, 0.34782608695652, 0.48913043478261, 0.5
23122, 0.32608695652174, 0.51521739130435, 0.5
23123, 0.30434782608696, 0.48913043478261, 0.5
23124, 0.28260869565217, 0.51521739130435, 0.5
23125, 0.26086956521739, 0.48913043478261, 0.5
23126, 0.23913043478261, 0.51521739130435, 0.5
23127, 0.21739130434783, 0.48913043478261, 0.5
23128, 0.19565217391304, 0.51521739130435, 0.5
23129, 0.17391304347826, 0.48913043478261, 0.5
23130, 0.15217391304348, 0.51521739130435, 0.5
23131, 0.1304347826087, 0.48913043478261, 0.5
23132, 0.10869565217391, 0.51521739130435, 0.5
23133, 0.08695652173913, 0.48913043478261, 0.5
23134, 0.065217391304348, 0.51521739130435, 0.5
23135, 0.043478260869565, 0.48913043478261, 0.5
23136, 0.021739130434783, 0.51521739130435, 0.5
23137, 0.97826086956522, 0.56739130434783, 0.5
23138, 0.95652173913043, 0.54130434782609, 0.5
23139, 0.93478260869565, 0.56739130434783, 0.5
23140, 0.91304347826087, 0.54130434782609, 0.5
23141, 0.89130434782609, 0.56739130434783, 0.5
23142, 0.8695652173913, 0.54130434782609, 0.5
23143, 0.84782608695652, 0.56739130434783, 0.5
23144, 0.82608695652174, 0.54130434782609, 0.5
23145, 0.80434782608696, 0.56739130434783, 0.5
23146, 0.78260869565217, 0.54130434782609, 0.5
23147, 0.76086956521739, 0.56739130434783, 0.5
23148, 0.73913043478261, 0.54130434782609, 0.5
23149, 0.71739130434783, 0.56739130434783, 0.5
23150, 0.69565217391304, 0.54130434782609, 0.5
23151, 0.67391304347826, 0.56739130434783, 0.5
23152, 0.65217391304348, 0.54130434782609, 0.5
23153, 0.6304347826087, 0.56739130434783, 0.5
23154, 0.60869565217391, 0.54130434782609, 0.5
23155, 0.58695652173913, 0.56739130434783, 0.5
23156, 0.56521739130435, 0.54130434782609, 0.5
23157, 0.54347826086957, 0.56739130434783, 0.5
23158, 0.52173913043478, 0.54130434782609, 0.5
23159, 0.5, 0.56739130434783, 0.5
23160, 0.47826086956522, 0.54130434782609, 0.5
23161, 0.45652173913043, 0.56739130434783, 0.5
23162, 0.43478260869565, 0.54130434782609, 0.5
23163, 0.41304347826087, 0.56739130434783, 0.5
23164, 0.39130434782609, 0.54130434782609, 0.5
23165, 0.3695652173913, 0.56739130434783, 0.5
23166, 0.34782608695652, 0.54130434782609, 0.5
23167, 0.32608695652174, 0.56739130434783, 0.5
23168, 0.30434782608696, 0.54130434782609, 0.5
23169, 0.28260869565217, 0.56739130434783, 0.5
23170, 0.26086956521739, 0.54130434782609, 0.5
23171, 0.23913043478261, 0.56739130434783, 0.5
23172, 0.21739130434783, 0.54130434782609, 0.5
23173, 0.19565217391304, 0.56739130434783, 0.5
23174, 0.17391304347826, 0.54130434782609, 0.5
23175, 0.15217391304348, 0.56739130434783, 0.5
23176, 0.1304347826087, 0.54130434782609, 0.5
23177, 0.10869565217391, 0.56739130434783, 0.5
23178, 0.08695652173913, 0.54130434782609, 0.5
23179, 0.065217391304348, 0.56739130434783, 0.5
23180, 0.043478260869565, 0.54130434782609, 0.5
23181, 0.021739130434783, 0.56739130434783, 0.5
23182, 0.97826086956522, 0.6195652173913, 0.5
23183, 0.95652173913043, 0.59347826086956, 0.5
23184, 0.93478260869565, 0.6195652173913, 0.5
23185, 0.91304347826087, 0.59347826086956, 0.5
23186, 0.89130434782609, 0.6195652173913, 0.5
23187, 0.8695652173913, 0.59347826086956, 0.5
23188, 0.84782608695652, 0.6195652173913, 0.5
23189, 0.82608695652174, 0.59347826086956, 0.5
23190, 0.80434782608696, 0.6195652173913, 0.5
23191, 0.78260869565217, 0.59347826086956, 0.5
23192, 0.76086956521739, 0.6195652173913, 0.5
23193, 0.73913043478261, 0.59347826086956, 0.5
23194, 0.71739130434783, 0.6195652173913, 0.5
23195, 0.69565217391304, 0.59347826086956, 0.5
23196, 0.67391304347826, 0.6195652173913, 0.5
23197, 0.65217391304348, 0.59347826086956, 0.5
23198, 0.6304347826087, 0.6195652173913, 0.5
23199, 0.60869565217391, 0.59347826086956, 0.5
23200, 0.58695652173913, 0.6195652173913, 0.5
23201, 0.56521739130435, 0.59347826086956, 0.5
23202, 0.54347826086957, 0.6195652173913, 0.5
23203, 0.52173913043478, 0.59347826086956, 0.5
23204, 0.5, 0.6195652173913, 0.5
23205, 0.47826086956522, 0.59347826086956, 0.5
23206, 0.45652173913043, 0.6195652173913, 0.5
23207, 0.43478260869565, 0.59347826086956, 0.5
23208, 0.41304347826087, 0.6195652173913, 0.5
23209, 0.39130434782609, 0.59347826086956, 0.5
23210, 0.3695652173913, 0.6195652173913, 0.5
23211, 0.34782608695652, 0.59347826086956, 0.5
23212, 0.32608695652174, 0.6195652173913, 0.5
23213, 0.30434782608696, 0.59347826086956, 0.5
23214, 0.28260869565217, 0.6195652173913, 0.5
23215, 0.26086956521739, 0.59347826086956, 0.5
23216, 0.23913043478261, 0.6195652173913, 0.5
23217, 0.21739130434783, 0.59347826086956, 0.5
23218, 0.19565217391304, 0.6195652173913, 0.5
23219, 0.17391304347826, 0.59347826086956, 0.5
23220, 0.15217391304348, 0.6195652173913, 0.5
23221, 0.1304347826087, 0.59347826086956, 0.5
23222, 0.10869565217391, 0.6195652173913, 0.5
23223, 0.08695652173913, 0.59347826086956, 0.5
23224, 0.065217391304348, 0.6195652173913, 0.5
23225, 0.043478260869565, 0.59347826086956, 0.5
23226, 0.021739130434783, 0.6195652173913, 0.5
23227, 0.97826086956522, 0.67173913043478, 0.5
23228, 0.95652173913043, 0.64565217391304, 0.5
23229, 0.93478260869565, 0.67173913043478, 0.5
23230, 0.91304347826087, 0.64565217391304, 0.5
23231, 0.89130434782609, 0.67173913043478, 0.5
23232, 0.8695652173913, 0.64565217391304, 0.5
23233, 0.84782608695652, 0.67173913043478, 0.5
23234, 0.82608695652174, 0.64565217391304, 0.5
23235, 0.80434782608696, 0.67173913043478, 0.5
23236, 0.78260869565217, 0.64565217391304, 0.5
23237, 0.76086956521739, 0.67173913043478, 0.5
23238, 0.73913043478261, 0.64565217391304, 0.5
23239, 0.71739130434783, 0.67173913043478, 0.5
23240, 0.69565217391304, 0.64565217391304, 0.5
23241, 0.67391304347826, 0.67173913043478, 0.5
23242, 0.65217391304348, 0.64565217391304, 0.5
23243, 0.6304347826087, 0.67173913043478, 0.5
23244, 0.60869565217391, 0.64565217391304, 0.5
23245, 0.58695652173913, 0.67173913043478, 0.5
23246, 0.56521739130435, 0.64565217391304, 0.5
23247, 0.54347826086957, 0.67173913043478, 0.5
23248, 0.52173913043478, 0.64565217391304, 0.5
23249, 0.5, 0.67173913043478, 0.5
23250, 0.47826086956522, 0.64565217391304, 0.5
23251, 0.45652173913043, 0.67173913043478, 0.5
23252, 0.43478260869565, 0.64565217391304, 0.5
23253, 0.41304347826087, 0.67173913043478, 0.5
23254, 0.39130434782609, 0.64565217391304, 0.5
23255, 0.3695652173913, 0.67173913043478, 0.5
23256, 0.34782608695652, 0.64565217391304, 0.5
23257, 0.32608695652174, 0.67173913043478, 0.5
23258, 0.30434782608696, 0.64565217391304, 0.5
23259, 0.28260869565217, 0.67173913043478, 0.5
23260, 0.26086956521739, 0.64565217391304, 0.5
23261, 0.23913043478261, 0.67173913043478, 0.5
23262, 0.21739130434783, 0.64565217391304, 0.5
23263, 0.19565217391304, 0.67173913043478, 0.5
23264, 0.17391304347826, 0.64565217391304, 0.5
23265, 0.15217391304348, 0.67173913043478, 0.5
23266, 0.1304347826087, 0.64565217391304, 0.5
23267, 0.10869565217391, 0.67173913043478, 0.5
23268, 0.08695652173913, 0.64565217391304, 0.5
23269, 0.065217391304348, 0.67173913043478, 0.5
23270, 0.043478260869565, 0.64565217391304, 0.5
23271, 0.021739130434783, 0.67173913043478, 0.5
23272, 0.97826086956522, 0.72391304347826, 0.5
23273, 0.95652173913043, 0.69782608695652, 0.5
23274, 0.93478260869565, 0.72391304347826, 0.5
23275, 0.91304347826087, 0.69782608695652, 0.5
23276, 0.89130434782609, 0.72391304347826, 0.5
23277, 0.8695652173913, 0.69782608695652, 0.5
23278, 0.84782608695652, 0.72391304347826, 0.5
23279, 0.82608695652174, 0.69782608695652, 0.5
23280, 0.80434782608696, 0.72391304347826, 0.5
23281, 0.78260869565217, 0.69782608695652, 0.5
23282, 0.76086956521739, 0.72391304347826, 0.5
23283, 0.73913043478261, 0.69782608695652, 0.5
23284, 0.71739130434783, 0.72391304347826, 0.5
23285, 0.69565217391304, 0.69782608695652, 0.5
23286, 0.67391304347826, 0.72391304347826, 0.5
23287, 0.65217391304348, 0.69782608695652, 0.5
23288, 0.6304347826087, 0.72391304347826, 0.5
23289, 0.60869565217391, 0.69782608695652, 0.5
23290, 0.58695652173913, 0.72391304347826, 0.5
23291, 0.56521739130435, 0.69782608695652, 0.5
23292, 0.54347826086957, 0.72391304347826, 0.5
23293, 0.52173913043478, 0.69782608695652, 0.5
23294, 0.5, 0.72391304347826, 0.5
23295, 0.47826086956522, 0.69782608695652, 0.5
23296, 0.45652173913043, 0.72391304347826, 0.5
23297, 0.43478260869565, 0.69782608695652, 0.5
23298, 0.41304347826087, 0.72391304347826, 0.5
23299, 0.39130434782609, 0.69782608695652, 0.5
23300, 0.3695652173913, 0.72391304347826, 0.5
23301, 0.34782608695652, 0.69782608695652, 0.5
23302, 0.32608695652174, 0.72391304347826, 0.5
23303, 0.30434782608696, 0.69782608695652, 0.5
23304, 0.28260869565217, 0.72391304347826, 0.5
23305, 0.26086956521739, 0.69782608695652, 0.5
23306, 0.23913043478261, 0.72391304347826, 0.5
23307, 0.21739130434783, 0.69782608695652, 0.5
23308, 0.19565217391304, 0.72391304347826, 0.5
23309, 0.17391304347826, 0.69782608695652, 0.5
23310, 0.15217391304348, 0.72391304347826, 0.5
23311, 0.1304347826087, 0.69782608695652, 0.5
23312, 0.10869565217391, 0.72391304347826, 0.5
23313, 0.08695652173913, 0.69782608695652, 0.5
23314, 0.065217391304348, 0.72391304347826, 0.5
23315, 0.043478260869565, 0.69782608695652, 0.5
23316, 0.021739130434783, 0.72391304347826, 0.5
23317, 0.97826086956522, 0.77608695652174, 0.5
23318, 0.95652173913043, 0.75, 0.5
23319, 0.93478260869565, 0.77608695652174, 0.5
23320, 0.91304347826087, 0.75, 0.5
23321, 0.89130434782609, 0.77608695652174, 0.5
23322, 0.8695652173913, 0.75, 0.5
23323, 0.84782608695652, 0.77608695652174, 0.5
23324, 0.82608695652174, 0.75, 0.5
23325, 0.80434782608696, 0.77608695652174, 0.5
23326, 0.78260869565217, 0.75, 0.5
23327, 0.76086956521739, 0.77608695652174, 0.5
23328, 0.73913043478261, 0.75, 0.5
23329, 0.71739130434783, 0.77608695652174, 0.5
23330, 0.69565217391304, 0.75, 0.5
23331, 0.67391304347826, 0.77608695652174, 0.5
23332, 0.65217391304348, 0.75, 0.5
23333, 0.6304347826087, 0.77608695652174, 0.5
23334, 0.60869565217391, 0.75, 0.5
23335, 0.58695652173913, 0.77608695652174, 0.5
23336, 0.56521739130435, 0.75, 0.5
23337, 0.54347826086957, 0.77608695652174, 0.5
23338, 0.52173913043478, 0.75, 0.5
23339, 0.5, 0.77608695652174, 0.5
23340, 0.47826086956522, 0.75, 0.5
23341, 0.45652173913043, 0.77608695652174, 0.5
23342, 0.43478260869565, 0.75, 0.5
23343, 0.41304347826087, 0.77608695652174, 0.5
23344, 0.39130434782609, 0.75, 0.5
23345, 0.3695652173913, 0.77608695652174, 0.5
23346, 0.34782608695652, 0.75, 0.5
23347, 0.32608695652174, 0.77608695652174, 0.5
23348, 0.30434782608696, 0.75, 0.5
23349, 0.28260869565217, 0.77608695652174, 0.5
23350, 0.26086956521739, 0.75, 0.5
23351, 0.23913043478261, 0.77608695652174, 0.5
23352, 0.21739130434783, 0.75, 0.5
23353, 0.19565217391304, 0.77608695652174, 0.5
23354, 0.17391304347826, 0.75, 0.5
23355, 0.15217391304348, 0.77608695652174, 0.5
23356, 0.1304347826087, 0.75, 0.5
23357, 0.10869565217391, 0.77608695652174, 0.5
23358, 0.08695652173913, 0.75, 0.5
23359, 0.065217391304348, 0.77608695652174, 0.5
23360, 0.043478260869565, 0.75, 0.5
23361, 0.021739130434783, 0.77608695652174, 0.5
23362, 0.97826086956522, 0.82826086956522, 0.5
23363, 0.95652173913043, 0.80217391304348, 0.5
23364, 0.93478260869565, 0.82826086956522, 0.5
23365, 0.91304347826087, 0.80217391304348, 0.5
23366, 0.89130434782609, 0.82826086956522, 0.5
23367, 0.8695652173913, 0.80217391304348, 0.5
23368, 0.84782608695652, 0.82826086956522, 0.5
23369, 0.82608695652174, 0.80217391304348, 0.5
23370, 0.80434782608696, 0.82826086956522, 0.5
23371, 0.78260869565217, 0.80217391304348, 0.5
23372, 0.76086956521739, 0.82826086956522, 0.5
23373, 0.73913043478261, 0.80217391304348, 0.5
23374, 0.71739130434783, 0.82826086956522, 0.5
23375, 0.69565217391304, 0.80217391304348, 0.5
23376, 0.67391304347826, 0.82826086956522, 0.5
23377, 0.65217391304348, 0.80217391304348, 0.5
23378, 0.6304347826087, 0.82826086956522, 0.5
23379, 0.60869565217391, 0.80217391304348, 0.5
23380, 0.58695652173913, 0.82826086956522, 0.5
23381, 0.56521739130435, 0.80217391304348, 0.5
23382, 0.54347826086957, 0.82826086956522, 0.5
23383, 0.52173913043478, 0.80217391304348, 0.5
23384, 0.5, 0.82826086956522, 0.5
23385, 0.47826086956522, 0.80217391304348, 0.5
23386, 0.45652173913043, 0.82826086956522, 0.5
23387, 0.43478260869565, 0.80217391304348, 0.5
23388, 0.41304347826087, 0.82826086956522, 0.5
23389, 0.39130434782609, 0.80217391304348, 0.5
23390, 0.3695652173913, 0.82826086956522, 0.5
23391, 0.34782608695652, 0.80217391304348, 0.5
23392, 0.32608695652174, 0.82826086956522, 0.5
23393, 0.30434782608696, 0.80217391304348, 0.5
23394, 0.28260869565217, 0.82826086956522, 0.5
23395, 0.26086956521739, 0.80217391304348, 0.5
23396, 0.23913043478261, 0.82826086956522, 0.5
23397, 0.21739130434783, 0.80217391304348, 0.5
23398, 0.19565217391304, 0.82826086956522, 0.5
23399, 0.17391304347826, 0.80217391304348, 0.5
23400, 0.15217391304348, 0.82826086956522, 0.5
23401, 0.1304347826087, 0.80217391304348, 0.5
23402, 0.10869565217391, 0.82826086956522, 0.5
23403, 0.08695652173913, 0.80217391304348, 0.5
23404, 0.065217391304348, 0.82826086956522, 0.5
23405, 0.043478260869565, 0.80217391304348, 0.5
23406, 0.021739130434783, 0.82826086956522, 0.5
23407, 0.97826086956522, 0.8804347826087, 0.5
23408, 0.95652173913043, 0.85434782608696, 0.5
23409, 0.93478260869565, 0.8804347826087, 0.5
23410, 0.91304347826087, 0.85434782608696, 0.5
23411, 0.89130434782609, 0.8804347826087, 0.5
23412, 0.8695652173913, 0.85434782608696, 0.5
23413, 0.84782608695652, 0.8804347826087, 0.5
23414, 0.82608695652174, 0.85434782608696, 0.5
23415, 0.80434782608696, 0.8804347826087, 0.5
23416, 0.78260869565217, 0.85434782608696, 0.5
23417, 0.76086956521739, 0.8804347826087, 0.5
23418, 0.73913043478261, 0.85434782608696, 0.5
23419, 0.71739130434783, 0.8804347826087, 0.5
23420, 0.69565217391304, 0.85434782608696, 0.5
23421, 0.67391304347826, 0.8804347826087, 0.5
23422, 0.65217391304348, 0.85434782608696, 0.5
23423, 0.6304347826087, 0.8804347826087, 0.5
23424, 0.60869565217391, 0.85434782608696, 0.5
23425, 0.58695652173913, 0.8804347826087, 0.5
23426, 0.56521739130435, 0.85434782608696, 0.5
23427, 0.54347826086957, 0.88043478260869, 0.5
23428, 0.52173913043478, 0.85434782608696, 0.5
23429, 0.5, 0.88043478260869, 0.5
23430, 0.47826086956522, 0.85434782608696, 0.5
23431, 0.45652173913043, 0.8804347826087, 0.5
23432, 0.43478260869565, 0.85434782608696, 0.5
23433, 0.41304347826087, 0.88043478260869, 0.5
23434, 0.39130434782609, 0.85434782608696, 0.5
23435, 0.3695652173913, 0.8804347826087, 0.5
23436, 0.34782608695652, 0.85434782608696, 0.5
23437, 0.32608695652174, 0.8804347826087, 0.5
23438, 0.30434782608696, 0.85434782608696, 0.5
23439, 0.28260869565217, 0.8804347826087, 0.5
23440, 0.26086956521739, 0.85434782608696, 0.5
23441, 0.23913043478261, 0.8804347826087, 0.5
23442, 0.21739130434783, 0.85434782608696, 0.5
23443, 0.19565217391304, 0.8804347826087, 0.5
23444, 0.17391304347826, 0.85434782608696, 0.5
23445, 0.15217391304348, 0.8804347826087, 0.5
23446, 0.1304347826087, 0.85434782608696, 0.5
23447, 0.10869565217391, 0.8804347826087, 0.5
23448, 0.08695652173913, 0.85434782608696, 0.5
23449, 0.065217391304348, 0.8804347826087, 0.5
23450, 0.043478260869565, 0.85434782608696, 0.5
23451, 0.021739130434783, 0.8804347826087, 0.5
23452, 0.97826086956522, 0.93260869565217, 0.5
23453, 0.95652173913043, 0.90652173913043, 0.5
23454, 0.93478260869565, 0.93260869565217, 0.5
23455, 0.91304347826087, 0.90652173913043, 0.5
23456, 0.89130434782609, 0.93260869565217, 0.5
23457, 0.8695652173913, 0.90652173913043, 0.5
23458, 0.84782608695652, 0.93260869565217, 0.5
23459, 0.82608695652174, 0.90652173913043, 0.5
23460, 0.80434782608696, 0.93260869565217, 0.5
23461, 0.78260869565217, 0.90652173913043, 0.5
23462, 0.76086956521739, 0.93260869565217, 0.5
23463, 0.73913043478261, 0.90652173913043, 0.5
23464, 0.71739130434783, 0.93260869565217, 0.5
23465, 0.69565217391304, 0.90652173913043, 0.5
23466, 0.67391304347826, 0.93260869565217, 0.5
23467, 0.65217391304348, 0.90652173913043, 0.5
23468, 0.6304347826087, 0.93260869565217, 0.5
23469, 0.60869565217391, 0.90652173913043, 0.5
23470, 0.58695652173913, 0.93260869565217, 0.5
23471, 0.56521739130435, 0.90652173913043, 0.5
23472, 0.54347826086957, 0.93260869565217, 0.5
23473, 0.52173913043478, 0.90652173913043, 0.5
23474, 0.5, 0.93260869565217, 0.5
23475, 0.47826086956522, 0.90652173913043, 0.5
23476, 0.45652173913043, 0.93260869565217, 0.5
23477, 0.43478260869565, 0.90652173913043, 0.5
23478, 0.41304347826087, 0.93260869565217, 0.5
23479, 0.39130434782609, 0.90652173913043, 0.5
23480, 0.3695652173913, 0.93260869565217, 0.5
23481, 0.34782608695652, 0.90652173913043, 0.5
23482, 0.32608695652174, 0.93260869565217, 0.5
23483, 0.30434782608696, 0.90652173913043, 0.5
23484, 0.28260869565217, 0.93260869565217, 0.5
23485, 0.26086956521739, 0.90652173913043, 0.5
23486, 0.23913043478261, 0.93260869565217, 0.5
23487, 0.21739130434783, 0.90652173913043, 0.5
23488, 0.19565217391304, 0.93260869565217, 0.5
23489, 0.17391304347826, 0.90652173913043, 0.5
23490, 0.15217391304348, 0.93260869565217, 0.5
23491, 0.1304347826087, 0.90652173913043, 0.5
23492, 0.10869565217391, 0.93260869565217, 0.5
23493, 0.08695652173913, 0.90652173913043, 0.5
23494, 0.065217391304348, 0.93260869565217, 0.5
23495, 0.043478260869565, 0.90652173913043, 0.5
23496, 0.021739130434783, 0.93260869565217, 0.5
23497, 0.97826086956522, 0.98478260869565, 0.5
23498, 0.95652173913043, 0.95869565217391, 0.5
23499, 0.93478260869565, 0.98478260869565, 0.5
23500, 0.91304347826087, 0.95869565217391, 0.5
23501, 0.89130434782609, 0.98478260869565, 0.5
23502, 0.8695652173913, 0.95869565217391, 0.5
23503, 0.84782608695652, 0.98478260869565, 0.5
23504, 0.82608695652174, 0.95869565217391, 0.5
23505, 0.80434782608696, 0.98478260869565, 0.5
23506, 0.78260869565217, 0.95869565217391, 0.5
23507, 0.76086956521739, 0.98478260869565, 0.5
23508, 0.73913043478261, 0.95869565217391, 0.5
23509, 0.71739130434783, 0.98478260869565, 0.5
23510, 0.69565217391304, 0.95869565217391, 0.5
23511, 0.67391304347826, 0.98478260869565, 0.5
23512, 0.65217391304348, 0.95869565217391, 0.5
23513, 0.6304347826087, 0.98478260869565, 0.5
23514, 0.60869565217391, 0.95869565217391, 0.5
23515, 0.58695652173913, 0.98478260869565, 0.5
23516, 0.56521739130435, 0.95869565217391, 0.5
23517, 0.54347826086957, 0.98478260869565, 0.5
23518, 0.52173913043478, 0.95869565217391, 0.5
23519, 0.5, 0.98478260869565, 0.5
23520, 0.47826086956522, 0.95869565217391, 0.5
23521, 0.45652173913043, 0.98478260869565, 0.5
23522, 0.43478260869565, 0.95869565217391, 0.5
23523, 0.41304347826087, 0.98478260869565, 0.5
23524, 0.39130434782609, 0.95869565217391, 0.5
23525, 0.3695652173913, 0.98478260869565, 0.5
23526, 0.34782608695652, 0.95869565217391, 0.5
23527, 0.32608695652174, 0.98478260869565, 0.5
23528, 0.30434782608696, 0.95869565217391, 0.5
23529, 0.28260869565217, 0.98478260869565, 0.5
23530, 0.26086956521739, 0.95869565217391, 0.5
23531, 0.23913043478261, 0.98478260869565, 0.5
23532, 0.21739130434783, 0.95869565217391, 0.5
23533, 0.19565217391304, 0.98478260869565, 0.5
23534, 0.17391304347826, 0.95869565217391, 0.5
23535, 0.15217391304348, 0.98478260869565, 0.5
23536, 0.1304347826087, 0.95869565217391, 0.5
23537, 0.10869565217391, 0.98478260869565, 0.5
23538, 0.08695652173913, 0.95869565217391, 0.5
23539, 0.065217391304348, 0.98478260869565, 0.5
23540, 0.043478260869565, 0.95869565217391, 0.5
23541, 0.021739130434783, 0.98478260869565, 0.5
23542, 0.97826086956522, 1.0369565217391, 0.5
23543, 0.95652173913043, 1.0108695652174, 0.5
23544, 0.93478260869565, 1.0369565217391, 0.5
23545, 0.91304347826087, 1.0108695652174, 0.5
23546, 0.89130434782609, 1.0369565217391, 0.5
23547, 0.8695652173913, 1.0108695652174, 0.5
23548, 0.84782608695652, 1.0369565217391, 0.5
23549, 0.82608695652174, 1.0108695652174, 0.5
23550, 0.80434782608696, 1.0369565217391, 0.5
23551, 0.78260869565217, 1.0108695652174, 0.5
23552, 0.76086956521739, 1.0369565217391, 0.5
23553, 0.73913043478261, 1.0108695652174, 0.5
23554, 0.71739130434783, 1.0369565217391, 0.5
23555, 0.69565217391304, 1.0108695652174, 0.5
23556, 0.67391304347826, 1.0369565217391, 0.5
23557, 0.65217391304348, 1.0108695652174, 0.5
23558, 0.6304347826087, 1.0369565217391, 0.5
23559, 0.60869565217391, 1.0108695652174, 0.5
23560, 0.58695652173913, 1.0369565217391, 0.5
23561, 0.56521739130435, 1.0108695652174, 0.5
23562, 0.54347826086957, 1.0369565217391, 0.5
23563, 0.52173913043478, 1.0108695652174, 0.5
23564, 0.5, 1.0369565217391, 0.5
23565, 0.47826086956522, 1.0108695652174, 0.5
23566, 0.45652173913043, 1.0369565217391, 0.5
23567, 0.43478260869565, 1.0108695652174, 0.5
23568, 0.41304347826087, 1.0369565217391, 0.5
23569, 0.39130434782609, 1.0108695652174, 0.5
23570, 0.3695652173913, 1.0369565217391, 0.5
23571, 0.34782608695652, 1.0108695652174, 0.5
23572, 0.32608695652174, 1.0369565217391, 0.5
23573, 0.30434782608696, 1.0108695652174, 0.5
23574, 0.28260869565217, 1.0369565217391, 0.5
23575, 0.26086956521739, 1.0108695652174, 0.5
23576, 0.23913043478261, 1.0369565217391, 0.5
23577, 0.21739130434783, 1.0108695652174, 0.5
23578, 0.19565217391304, 1.0369565217391, 0.5
23579, 0.17391304347826, 1.0108695652174, 0.5
23580, 0.15217391304348, 1.0369565217391, 0.5
23581, 0.1304347826087, 1.0108695652174, 0.5
23582, 0.10869565217391, 1.0369565217391, 0.5
23583, 0.08695652173913, 1.0108695652174, 0.5
23584, 0.065217391304348, 1.0369565217391, 0.5
23585, 0.043478260869565, 1.0108695652174, 0.5
23586, 0.021739130434783, 1.0369565217391, 0.5
23587, 0.97826086956522, 1.0891304347826, 0.5
23588, 0.95652173913043, 1.0630434782609, 0.5
23589, 0.93478260869565, 1.0891304347826, 0.5
23590, 0.91304347826087, 1.0630434782609, 0.5
23591, 0.89130434782609, 1.0891304347826, 0.5
23592, 0.8695652173913, 1.0630434782609, 0.5
23593, 0.84782608695652, 1.0891304347826, 0.5
23594, 0.82608695652174, 1.0630434782609, 0.5
23595, 0.80434782608696, 1.0891304347826, 0.5
23596, 0.78260869565217, 1.0630434782609, 0.5
23597, 0.76086956521739, 1.0891304347826, 0.5
23598, 0.73913043478261, 1.0630434782609, 0.5
23599, 0.71739130434783, 1.0891304347826, 0.5
23600, 0.69565217391304, 1.0630434782609, 0.5
23601, 0.67391304347826, 1.0891304347826, 0.5
23602, 0.65217391304348, 1.0630434782609, 0.5
23603, 0.6304347826087, 1.0891304347826, 0.5
23604, 0.60869565217391, 1.0630434782609, 0.5
23605, 0.58695652173913, 1.0891304347826, 0.5
23606, 0.56521739130435, 1.0630434782609, 0.5
23607, 0.54347826086957, 1.0891304347826, 0.5
23608, 0.52173913043478, 1.0630434782609, 0.5
23609, 0.5, 1.0891304347826, 0.5
23610, 0.47826086956522, 1.0630434782609, 0.5
23611, 0.45652173913043, 1.0891304347826, 0.5
23612, 0.43478260869565, 1.0630434782609, 0.5
23613, 0.41304347826087, 1.0891304347826, 0.5
23614, 0.39130434782609, 1.0630434782609, 0.5
23615, 0.3695652173913, 1.0891304347826, 0.5
23616, 0.34782608695652, 1.0630434782609, 0.5
23617, 0.32608695652174, 1.0891304347826, 0.5
23618, 0.30434782608696, 1.0630434782609, 0.5
23619, 0.28260869565217, 1.0891304347826, 0.5
23620, 0.26086956521739, 1.0630434782609, 0.5
23621, 0.23913043478261, 1.0891304347826, 0.5
23622, 0.21739130434783, 1.0630434782609, 0.5
23623, 0.19565217391304, 1.0891304347826, 0.5
23624, 0.17391304347826, 1.0630434782609, 0.5
23625, 0.15217391304348, 1.0891304347826, 0.5
23626, 0.1304347826087, 1.0630434782609, 0.5
23627, 0.10869565217391, 1.0891304347826, 0.5
23628, 0.08695652173913, 1.0630434782609, 0.5
23629, 0.065217391304348, 1.0891304347826, 0.5
23630, 0.043478260869565, 1.0630434782609, 0.5
23631, 0.021739130434783, 1.0891304347826, 0.5
23632, 0.97826086956522, 1.1413043478261, 0.5
23633, 0.95652173913043, 1.1152173913043, 0.5
23634, 0.93478260869565, 1.1413043478261, 0.5
23635, 0.91304347826087, 1.1152173913043, 0.5
23636, 0.89130434782609, 1.1413043478261, 0.5
23637, 0.8695652173913, 1.1152173913043, 0.5
23638, 0.84782608695652, 1.1413043478261, 0.5
23639, 0.82608695652174, 1.1152173913043, 0.5
23640, 0.80434782608696, 1.1413043478261, 0.5
23641, 0.78260869565217, 1.1152173913043, 0.5
23642, 0.76086956521739, 1.1413043478261, 0.5
23643, 0.73913043478261, 1.1152173913043, 0.5
23644, 0.71739130434783, 1.1413043478261, 0.5
23645, 0.69565217391304, 1.1152173913043, 0.5
23646, 0.67391304347826, 1.1413043478261, 0.5
23647, 0.65217391304348, 1.1152173913043, 0.5
23648, 0.6304347826087, 1.1413043478261, 0.5
23649, 0.60869565217391, 1.1152173913043, 0.5
23650, 0.58695652173913, 1.1413043478261, 0.5
23651, 0.56521739130435, 1.1152173913043, 0.5
23652, 0.54347826086957, 1.1413043478261, 0.5
23653, 0.52173913043478, 1.1152173913043, 0.5
23654, 0.5, 1.1413043478261, 0.5
23655, 0.47826086956522, 1.1152173913043, 0.5
23656, 0.45652173913043, 1.1413043478261, 0.5
23657, 0.43478260869565, 1.1152173913043, 0.5
23658, 0.41304347826087, 1.1413043478261, 0.5
23659, 0.39130434782609, 1.1152173913043, 0.5
23660, 0.3695652173913, 1.1413043478261, 0.5
23661, 0.34782608695652, 1.1152173913043, 0.5
23662, 0.32608695652174, 1.1413043478261, 0.5
23663, 0.30434782608696, 1.1152173913043, 0.5
23664, 0.28260869565217, 1.1413043478261, 0.5
23665, 0.26086956521739, 1.1152173913043, 0.5
23666, 0.23913043478261, 1.1413043478261, 0.5
23667, 0.21739130434783, 1.1152173913043, 0.5
23668, 0.19565217391304, 1.1413043478261, 0.5
23669, 0.17391304347826, 1.1152173913043, 0.5
23670, 0.15217391304348, 1.1413043478261, 0.5
23671, 0.1304347826087, 1.1152173913043, 0.5
23672, 0.10869565217391, 1.1413043478261, 0.5
23673, 0.08695652173913, 1.1152173913043, 0.5
23674, 0.065217391304348, 1.1413043478261, 0.5
23675, 0.043478260869565, 1.1152173913043, 0.5
23676, 0.021739130434783, 1.1413043478261, 0.5
23677, 0.97826086956522, 1.1934782608696, 0.5
23678, 0.95652173913043, 1.1673913043478, 0.5
23679, 0.93478260869565, 1.1934782608696, 0.5
23680, 0.91304347826087, 1.1673913043478, 0.5
23681, 0.89130434782609, 1.1934782608696, 0.5
23682, 0.8695652173913, 1.1673913043478, 0.5
23683, 0.84782608695652, 1.1934782608696, 0.5
23684, 0.82608695652174, 1.1673913043478, 0.5
23685, 0.80434782608696, 1.1934782608696, 0.5
23686, 0.78260869565217, 1.1673913043478, 0.5
23687, 0.76086956521739, 1.1934782608696, 0.5
23688, 0.73913043478261, 1.1673913043478, 0.5
23689, 0.71739130434783, 1.1934782608696, 0.5
23690, 0.69565217391304, 1.1673913043478, 0.5
23691, 0.67391304347826, 1.1934782608696, 0.5
23692, 0.65217391304348, 1.1673913043478, 0.5
23693, 0.6304347826087, 1.1934782608696, 0.5
23694, 0.60869565217391, 1.1673913043478, 0.5
23695, 0.58695652173913, 1.1934782608696, 0.5
23696, 0.56521739130435, 1.1673913043478, 0.5
23697, 0.54347826086957, 1.1934782608696, 0.5
23698, 0.52173913043478, 1.1673913043478, 0.5
23699, 0.5, 1.1934782608696, 0.5
23700, 0.47826086956522, 1.1673913043478, 0.5
23701, 0.45652173913043, 1.1934782608696, 0.5
23702, 0.43478260869565, 1.1673913043478, 0.5
23703, 0.41304347826087, 1.1934782608696, 0.5
23704, 0.39130434782609, 1.1673913043478, 0.5
23705, 0.3695652173913, 1.1934782608696, 0.5
23706, 0.34782608695652, 1.1673913043478, 0.5
23707, 0.32608695652174, 1.1934782608696, 0.5
23708, 0.30434782608696, 1.1673913043478, 0.5
23709, 0.28260869565217, 1.1934782608696, 0.5
23710, 0.26086956521739, 1.1673913043478, 0.5
23711, 0.23913043478261, 1.1934782608696, 0.5
23712, 0.21739130434783, 1.1673913043478, 0.5
23713, 0.19565217391304, 1.1934782608696, 0.5
23714, 0.17391304347826, 1.1673913043478, 0.5
23715, 0.15217391304348, 1.1934782608696, 0.5
23716, 0.1304347826087, 1.1673913043478, 0.5
23717, 0.10869565217391, 1.1934782608696, 0.5
23718, 0.08695652173913, 1.1673913043478, 0.5
23719, 0.065217391304348, 1.1934782608696, 0.5
23720, 0.043478260869565, 1.1673913043478, 0.5
23721, 0.021739130434783, 1.1934782608696, 0.5
23722, 0.97826086956522, 1.245652173913, 0.5
23723, 0.95652173913043, 1.2195652173913, 0.5
23724, 0.93478260869565, 1.245652173913, 0.5
23725, 0.91304347826087, 1.2195652173913, 0.5
23726, 0.89130434782609, 1.245652173913, 0.5
23727, 0.8695652173913, 1.2195652173913, 0.5
23728, 0.84782608695652, 1.245652173913, 0.5
23729, 0.82608695652174, 1.2195652173913, 0.5
23730, 0.80434782608696, 1.245652173913, 0.5
23731, 0.78260869565217, 1.2195652173913, 0.5
23732, 0.76086956521739, 1.245652173913, 0.5
23733, 0.73913043478261, 1.2195652173913, 0.5
23734, 0.71739130434783, 1.245652173913, 0.5
23735, 0.69565217391304, 1.2195652173913, 0.5
23736, 0.67391304347826, 1.245652173913, 0.5
23737, 0.65217391304348, 1.2195652173913, 0.5
23738, 0.6304347826087, 1.245652173913, 0.5
23739, 0.60869565217391, 1.2195652173913, 0.5
23740, 0.58695652173913, 1.245652173913, 0.5
23741, 0.56521739130435, 1.2195652173913, 0.5
23742, 0.54347826086957, 1.245652173913, 0.5
23743, 0.52173913043478, 1.2195652173913, 0.5
23744, 0.5, 1.245652173913, 0.5
23745, 0.47826086956522, 1.2195652173913, 0.5
23746, 0.45652173913043, 1.245652173913, 0.5
23747, 0.43478260869565, 1.2195652173913, 0.5
23748, 0.41304347826087, 1.245652173913, 0.5
23749, 0.39130434782609, 1.2195652173913, 0.5
23750, 0.3695652173913, 1.245652173913, 0.5
23751, 0.34782608695652, 1.2195652173913, 0.5
23752, 0.32608695652174, 1.245652173913, 0.5
23753, 0.30434782608696, 1.2195652173913, 0.5
23754, 0.28260869565217, 1.245652173913, 0.5
23755, 0.26086956521739, 1.2195652173913, 0.5
23756, 0.23913043478261, 1.245652173913, 0.5
23757, 0.21739130434783, 1.2195652173913, 0.5
23758, 0.19565217391304, 1.245652173913, 0.5
23759, 0.17391304347826, 1.2195652173913, 0.5
23760, 0.15217391304348, 1.245652173913, 0.5
23761, 0.1304347826087, 1.2195652173913, 0.5
23762, 0.10869565217391, 1.245652173913, 0.5
23763, 0.08695652173913, 1.2195652173913, 0.5
23764, 0.065217391304348, 1.245652173913, 0.5
23765, 0.043478260869565, 1.2195652173913, 0.5
23766, 0.021739130434783, 1.245652173913, 0.5
23767, 0.97826086956522, 1.2978260869565, 0.5
23768, 0.95652173913043, 1.2717391304348, 0.5
23769, 0.93478260869565, 1.2978260869565, 0.5
23770, 0.91304347826087, 1.2717391304348, 0.5
23771, 0.89130434782609, 1.2978260869565, 0.5
23772, 0.8695652173913, 1.2717391304348, 0.5
23773, 0.84782608695652, 1.2978260869565, 0.5
23774, 0.82608695652174, 1.2717391304348, 0.5
23775, 0.80434782608696, 1.2978260869565, 0.5
23776, 0.78260869565217, 1.2717391304348, 0.5
23777, 0.76086956521739, 1.2978260869565, 0.5
23778, 0.73913043478261, 1.2717391304348, 0.5
23779, 0.71739130434783, 1.2978260869565, 0.5
23780, 0.69565217391304, 1.2717391304348, 0.5
23781, 0.67391304347826, 1.2978260869565, 0.5
23782, 0.65217391304348, 1.2717391304348, 0.5
23783, 0.6304347826087, 1.2978260869565, 0.5
23784, 0.60869565217391, 1.2717391304348, 0.5
23785, 0.58695652173913, 1.2978260869565, 0.5
23786, 0.56521739130435, 1.2717391304348, 0.5
23787, 0.54347826086957, 1.2978260869565, 0.5
23788, 0.52173913043478, 1.2717391304348, 0.5
23789, 0.5, 1.2978260869565, 0.5
23790, 0.47826086956522, 1.2717391304348, 0.5
23791, 0.45652173913043, 1.2978260869565, 0.5
23792, 0.43478260869565, 1.2717391304348, 0.5
23793, 0.41304347826087, 1.2978260869565, 0.5
23794, 0.39130434782609, 1.2717391304348, 0.5
23795, 0.3695652173913, 1.2978260869565, 0.5
23796, 0.34782608695652, 1.2717391304348, 0.5
23797, 0.32608695652174, 1.2978260869565, 0.5
23798, 0.30434782608696, 1.2717391304348, 0.5
23799, 0.28260869565217, 1.2978260869565, 0.5
23800, 0.26086956521739, 1.2717391304348, 0.5
23801, 0.23913043478261, 1.2978260869565, 0.5
23802, 0.21739130434783, 1.2717391304348, 0.5
23803, 0.19565217391304, 1.2978260869565, 0.5
23804, 0.17391304347826, 1.2717391304348, 0.5
23805, 0.15217391304348, 1.2978260869565, 0.5
23806, 0.1304347826087, 1.2717391304348, 0.5
23807, 0.10869565217391, 1.2978260869565, 0.5
23808, 0.08695652173913, 1.2717391304348, 0.5
23809, 0.065217391304348, 1.2978260869565, 0.5
23810, 0.043478260869565, 1.2717391304348, 0.5
23811, 0.021739130434783, 1.2978260869565, 0.5
23812, 0.95652173913043, 1.3239130434783, 0.5
23813, 0.91304347826087, 1.3239130434783, 0.5
23814, 0.8695652173913, 1.3239130434783, 0.5
23815, 0.82608695652174, 1.3239130434783, 0.5
23816, 0.78260869565217, 1.3239130434783, 0.5
23817, 0.73913043478261, 1.3239130434783, 0.5
23818, 0.69565217391304, 1.3239130434783, 0.5
23819, 0.65217391304348, 1.3239130434783, 0.5
23820, 0.60869565217391, 1.3239130434783, 0.5
23821, 0.56521739130435, 1.3239130434783, 0.5
23822, 0.52173913043478, 1.3239130434783, 0.5
23823, 0.47826086956522, 1.3239130434783, 0.5
23824, 0.43478260869565, 1.3239130434783, 0.5
23825, 0.39130434782609, 1.3239130434783, 0.5
23826, 0.34782608695652, 1.3239130434783, 0.5
23827, 0.30434782608696, 1.3239130434783, 0.5
23828, 0.26086956521739, 1.3239130434783, 0.5
23829, 0.21739130434783, 1.3239130434783, 0.5
23830, 0.17391304347826, 1.3239130434783, 0.5
23831, 0.1304347826087, 1.3239130434783, 0.5
23832, 0.08695652173913, 1.3239130434783, 0.5
23833, 0.043478260869565, 1.3239130434783, 0.5
23834, 0, 0.20217391304348, 0.44444444444444
23835, 0, 0.20217391304348, 0.38888888888889
23836, 0, 0.20217391304348, 0.33333333333333
23837, 0, 0.20217391304348, 0.27777777777778
23838, 0, 0.20217391304348, 0.22222222222222
23839, 0, 0.20217391304348, 0.16666666666667
23840, 0, 0.20217391304348, 0.11111111111111
23841, 0, 0.20217391304348, 0.055555555555556
23842, 0, 0.25434782608696, 0.44444444444444
23843, 0, 0.25434782608696, 0.38888888888889
23844, 0, 0.25434782608696, 0.33333333333333
23845, 0, 0.25434782608696, 0.27777777777778
23846, 0, 0.25434782608696, 0.22222222222222
23847, 0, 0.25434782608696, 0.16666666666667
23848, 0, 0.25434782608696, 0.11111111111111
23849, 0, 0.25434782608696, 0.055555555555556
23850, 0, 0.30652173913043, 0.44444444444444
23851, 0, 0.30652173913043, 0.38888888888889
23852, 0, 0.30652173913043, 0.33333333333333
23853, 0, 0.30652173913043, 0.27777777777778
23854, 0, 0.30652173913043, 0.22222222222222
23855, 0, 0.30652173913043, 0.16666666666667
23856, 0, 0.30652173913043, 0.11111111111111
23857, 0, 0.30652173913043, 0.055555555555556
23858, 0, 0.35869565217391, 0.44444444444444
23859, 0, 0.35869565217391, 0.38888888888889
23860, 0, 0.35869565217391, 0.33333333333333
23861, 0, 0.35869565217391, 0.27777777777778
23862, 0, 0.35869565217391, 0.22222222222222
23863, 0, 0.35869565217391, 0.16666666666667
23864, 0, 0.35869565217391, 0.11111111111111
23865, 0, 0.35869565217391, 0.055555555555556
23866, 0, 0.41086956521739, 0.44444444444444
23867, 0, 0.41086956521739, 0.38888888888889
23868, 0, 0.41086956521739, 0.33333333333333
23869, 0, 0.41086956521739, 0.27777777777778
23870, 0, 0.41086956521739, 0.22222222222222
23871, 0, 0.41086956521739, 0.16666666666667
23872, 0, 0.41086956521739, 0.11111111111111
23873, 0, 0.41086956521739, 0.055555555555556
23874, 0, 0.46304347826087, 0.44444444444444
23875, 0, 0.46304347826087, 0.38888888888889
23876, 0, 0.46304347826087, 0.33333333333333
23877, 0, 0.46304347826087, 0.27777777777778
23878, 0, 0.46304347826087, 0.22222222222222
23879, 0, 0.46304347826087, 0.16666666666667
23880, 0, 0.46304347826087, 0.11111111111111
23881, 0, 0.46304347826087, 0.055555555555556
23882, 0, 0.51521739130435, 0.44444444444444
23883, 0, 0.51521739130435, 0.38888888888889
23884, 0, 0.51521739130435, 0.33333333333333
23885, 0, 0.51521739130435, 0.27777777777778
23886, 0, 0.51521739130435, 0.22222222222222
23887, 0, 0.51521739130435, 0.16666666666667
23888, 0, 0.51521739130435, 0.11111111111111
23889, 0, 0.51521739130435, 0.055555555555556
23890, 0, 0.56739130434783, 0.44444444444444
23891, 0, 0.56739130434783, 0.38888888888889
23892, 0, 0.56739130434783, 0.33333333333333
23893, 0, 0.56739130434783, 0.27777777777778
23894, 0, 0.56739130434783, 0.22222222222222
23895, 0, 0.56739130434783, 0.16666666666667
23896, 0, 0.56739130434783, 0.11111111111111
23897, 0, 0.56739130434783, 0.055555555555556
23898, 0, 0.6195652173913, 0.44444444444444
23899, 0, 0.6195652173913, 0.38888888888889
23900, 0, 0.6195652173913, 0.33333333333333
23901, 0, 0.6195652173913, 0.27777777777778
23902, 0, 0.6195652173913, 0.22222222222222
23903, 0, 0.6195652173913, 0.16666666666667
23904, 0, 0.6195652173913, 0.11111111111111
23905, 0, 0.6195652173913, 0.055555555555556
23906, 0, 0.67173913043478, 0.44444444444444
23907, 0, 0.67173913043478, 0.38888888888889
23908, 0, 0.67173913043478, 0.33333333333333
23909, 0, 0.67173913043478, 0.27777777777778
23910, 0, 0.67173913043478, 0.22222222222222
23911, 0, 0.67173913043478, 0.16666666666667
23912, 0, 0.67173913043478, 0.11111111111111
23913, 0, 0.67173913043478, 0.055555555555556
23914, 0, 0.72391304347826, 0.44444444444444
23915, 0, 0.72391304347826, 0.38888888888889
23916, 0, 0.72391304347826, 0.33333333333333
23917, 0, 0.72391304347826, 0.27777777777778
23918, 0, 0.72391304347826, 0.22222222222222
23919, 0, 0.72391304347826, 0.16666666666667
23920, 0, 0.72391304347826, 0.11111111111111
23921, 0, 0.72391304347826, 0.055555555555556
23922, 0, 0.77608695652174, 0.44444444444444
23923, 0, 0.77608695652174, 0.38888888888889
23924, 0, 0.77608695652174, 0.33333333333333
23925, 0, 0.77608695652174, 0.27777777777778
23926, 0, 0.77608695652174, 0.22222222222222
23927, 0, 0.77608695652174, 0.16666666666667
23928, 0, 0.77608695652174, 0.11111111111111
23929, 0, 0.77608695652174, 0.055555555555556
23930, 0, 0.82826086956522, 0.44444444444444
23931, 0, 0.82826086956522, 0.38888888888889
23932, 0, 0.82826086956522, 0.33333333333333
23933, 0, 0.82826086956522, 0.27777777777778
23934, 0, 0.82826086956522, 0.22222222222222
23935, 0, 0.82826086956522, 0.16666666666667
23936, 0, 0.82826086956522, 0.11111111111111
23937, 0, 0.82826086956522, 0.055555555555556
23938, 0, 0.88043478260869, 0.44444444444444
23939, 0, 0.8804347826087, 0.38888888888889
23940, 0, 0.8804347826087, 0.33333333333333
23941, 0, 0.8804347826087, 0.27777777777778
23942, 0, 0.8804347826087, 0.22222222222222
23943, 0, 0.8804347826087, 0.16666666666667
23944, 0, 0.8804347826087, 0.11111111111111
23945, 0, 0.8804347826087, 0.055555555555556
23946, 0, 0.93260869565217, 0.44444444444444
23947, 0, 0.93260869565217, 0.38888888888889
23948, 0, 0.93260869565217, 0.33333333333333
23949, 0, 0.93260869565217, 0.27777777777778
23950, 0, 0.93260869565217, 0.22222222222222
23951, 0, 0.93260869565217, 0.16666666666667
23952, 0, 0.93260869565217, 0.11111111111111
23953, 0, 0.93260869565217, 0.055555555555556
23954, 0, 0.98478260869565, 0.44444444444444
23955, 0, 0.98478260869565, 0.38888888888889
23956, 0, 0.98478260869565, 0.33333333333333
23957, 0, 0.98478260869565, 0.27777777777778
23958, 0, 0.98478260869565, 0.22222222222222
23959, 0, 0.98478260869565, 0.16666666666667
23960, 0, 0.98478260869565, 0.11111111111111
23961, 0, 0.98478260869565, 0.055555555555556
23962, 0, 1.0369565217391, 0.44444444444444
23963, 0, 1.0369565217391, 0.38888888888889
23964, 0, 1.0369565217391, 0.33333333333333
23965, 0, 1.0369565217391, 0.27777777777778
23966, 0, 1.0369565217391, 0.22222222222222
23967, 0, 1.0369565217391, 0.16666666666667
23968, 0, 1.0369565217391, 0.11111111111111
23969, 0, 1.0369565217391, 0.055555555555556
23970, 0, 1.0891304347826, 0.44444444444444
23971, 0, 1.0891304347826, 0.38888888888889
23972, 0, 1.0891304347826, 0.33333333333333
23973, 0, 1.0891304347826, 0.27777777777778
23974, 0, 1.0891304347826, 0.22222222222222
23975, 0, 1.0891304347826, 0.16666666666667
23976, 0, 1.0891304347826, 0.11111111111111
23977, 0, 1.0891304347826, 0.055555555555556
23978, 0, 1.1413043478261, 0.44444444444444
23979, 0, 1.1413043478261, 0.38888888888889
23980, 0, 1.1413043478261, 0.33333333333333
23981, 0, 1.1413043478261, 0.27777777777778
23982, 0, 1.1413043478261, 0.22222222222222
23983, 0, 1.1413043478261, 0.16666666666667
23984, 0, 1.1413043478261, 0.11111111111111
23985, 0, 1.1413043478261, 0.055555555555556
23986, 0, 1.1934782608696, 0.44444444444444
23987, 0, 1.1934782608696, 0.38888888888889
23988, 0, 1.1934782608696, 0.33333333333333
23989, 0, 1.1934782608696, 0.27777777777778
23990, 0, 1.1934782608696, 0.22222222222222
23991, 0, 1.1934782608696, 0.16666666666667
23992, 0, 1.1934782608696, 0.11111111111111
23993, 0, 1.1934782608696, 0.055555555555556
23994, 0, 1.245652173913, 0.44444444444444
23995, 0, 1.245652173913, 0.38888888888889
23996, 0, 1.245652173913, 0.33333333333333
23997, 0, 1.245652173913, 0.27777777777778
23998, 0, 1.245652173913, 0.22222222222222
23999, 0, 1.245652173913, 0.16666666666667
24000, 0, 1.245652173913, 0.11111111111111
24001, 0, 1.245652173913, 0.055555555555556
24002, 0, 1.2978260869565, 0.44444444444444
24003, 0, 1.2978260869565, 0.38888888888889
24004, 0, 1.2978260869565, 0.33333333333333
24005, 0, 1.2978260869565, 0.27777777777778
24006, 0, 1.2978260869565, 0.22222222222222
24007, 0, 1.2978260869565, 0.16666666666667
24008, 0, 1.2978260869565, 0.11111111111111
24009, 0, 1.2978260869565, 0.055555555555556
24010, 0, 0.20217391304348, 0.47222222222222
24011, 0, 0.17608695652174, 0.44444444444444
24012, 0, 0.20217391304348, 0.41666666666667
24013, 0, 0.17608695652174, 0.38888888888889
24014, 0, 0.20217391304348, 0.36111111111111
24015, 0, 0.17608695652174, 0.33333333333333
24016, 0, 0.20217391304348, 0.30555555555556
24017, 0, 0.17608695652174, 0.27777777777778
24018, 0, 0.20217391304348, 0.25
24019, 0, 0.17608695652174, 0.22222222222222
24020, 0, 0.20217391304348, 0.19444444444444
24021, 0, 0.17608695652174, 0.16666666666667
24022, 0, 0.20217391304348, 0.13888888888889
24023, 0, 0.17608695652174, 0.11111111111111
24024, 0, 0.20217391304348, 0.083333333333333
24025, 0, 0.17608695652174, 0.055555555555556
24026, 0, 0.20217391304348, 0.027777777777778
24027, 0, 0.25434782608696, 0.47222222222222
24028, 0, 0.22826086956522, 0.44444444444444
24029, 0, 0.25434782608696, 0.41666666666667
24030, 0, 0.22826086956522, 0.38888888888889
24031, 0, 0.25434782608696, 0.36111111111111
24032, 0, 0.22826086956522, 0.33333333333333
24033, 0, 0.25434782608696, 0.30555555555556
24034, 0, 0.22826086956522, 0.27777777777778
24035, 0, 0.25434782608696, 0.25
24036, 0, 0.22826086956522, 0.22222222222222
24037, 0, 0.25434782608696, 0.19444444444444
24038, 0, 0.22826086956522, 0.16666666666667
24039, 0, 0.25434782608696, 0.13888888888889
24040, 0, 0.22826086956522, 0.11111111111111
24041, 0, 0.25434782608696, 0.083333333333333
24042, 0, 0.22826086956522, 0.055555555555556
24043, 0, 0.25434782608696, 0.027777777777778
24044, 0, 0.30652173913043, 0.47222222222222
24045, 0, 0.2804347826087, 0.44444444444444
24046, 0, 0.30652173913043, 0.41666666666667
24047, 0, 0.2804347826087, 0.38888888888889
24048, 0, 0.30652173913043, 0.36111111111111
24049, 0, 0.2804347826087, 0.33333333333333
24050, 0, 0.30652173913043, 0.30555555555556
24051, 0, 0.2804347826087, 0.27777777777778
24052, 0, 0.30652173913043, 0.25
24053, 0, 0.2804347826087, 0.22222222222222
24054, 0, 0.30652173913043, 0.19444444444444
24055, 0, 0.2804347826087, 0.16666666666667
24056, 0, 0.30652173913043, 0.13888888888889
24057, 0, 0.2804347826087, 0.11111111111111
24058, 0, 0.30652173913043, 0.083333333333333
24059, 0, 0.2804347826087, 0.055555555555556
24060, 0, 0.30652173913043, 0.027777777777778
24061, 0, 0.35869565217391, 0.47222222222222
24062, 0, 0.33260869565217, 0.44444444444444
24063, 0, 0.35869565217391, 0.41666666666667
24064, 0, 0.33260869565217, 0.38888888888889
24065, 0, 0.35869565217391, 0.36111111111111
24066, 0, 0.33260869565217, 0.33333333333333
24067, 0, 0.35869565217391, 0.30555555555556
24068, 0, 0.33260869565217, 0.27777777777778
24069, 0, 0.35869565217391, 0.25
24070, 0, 0.33260869565217, 0.22222222222222
24071, 0, 0.35869565217391, 0.19444444444444
24072, 0, 0.33260869565217, 0.16666666666667
24073, 0, 0.35869565217391, 0.13888888888889
24074, 0, 0.33260869565217, 0.11111111111111
24075, 0, 0.35869565217391, 0.083333333333333
24076, 0, 0.33260869565217, 0.055555555555556
24077, 0, 0.35869565217391, 0.027777777777778
24078, 0, 0.41086956521739, 0.47222222222222
24079, 0, 0.38478260869565, 0.44444444444444
24080, 0, 0.41086956521739, 0.41666666666667
24081, 0, 0.38478260869565, 0.38888888888889
24082, 0, 0.41086956521739, 0.36111111111111
24083, 0, 0.38478260869565, 0.33333333333333
24084, 0, 0.41086956521739, 0.30555555555556
24085, 0, 0.38478260869565, 0.27777777777778
24086, 0, 0.41086956521739, 0.25
24087, 0, 0.38478260869565, 0.22222222222222
24088, 0, 0.41086956521739, 0.19444444444444
24089, 0, 0.38478260869565, 0.16666666666667
24090, 0, 0.41086956521739, 0.13888888888889
24091, 0, 0.38478260869565, 0.11111111111111
24092, 0, 0.41086956521739, 0.083333333333333
24093, 0, 0.38478260869565, 0.055555555555556
24094, 0, 0.41086956521739, 0.027777777777778
24095, 0, 0.46304347826087, 0.47222222222222
24096, 0, 0.43695652173913, 0.44444444444444
24097, 0, 0.46304347826087, 0.41666666666667
24098, 0, 0.43695652173913, 0.38888888888889
24099, 0, 0.46304347826087, 0.36111111111111
24100, 0, 0.43695652173913, 0.33333333333333
24101, 0, 0.46304347826087, 0.30555555555556
24102, 0, 0.43695652173913, 0.27777777777778
24103, 0, 0.46304347826087, 0.25
24104, 0, 0.43695652173913, 0.22222222222222
24105, 0, 0.46304347826087, 0.19444444444444
24106, 0, 0.43695652173913, 0.16666666666667
24107, 0, 0.46304347826087, 0.13888888888889
24108, 0, 0.43695652173913, 0.11111111111111
24109, 0, 0.46304347826087, 0.083333333333333
24110, 0, 0.43695652173913, 0.055555555555556
24111, 0, 0.46304347826087, 0.027777777777778
24112, 0, 0.51521739130435, 0.47222222222222
24113, 0, 0.48913043478261, 0.44444444444444
24114, 0, 0.51521739130435, 0.41666666666667
24115, 0, 0.48913043478261, 0.38888888888889
24116, 0, 0.51521739130435, 0.36111111111111
24117, 0, 0.48913043478261, 0.33333333333333
24118, 0, 0.51521739130435, 0.30555555555556
24119, 0, 0.48913043478261, 0.27777777777778
24120, 0, 0.51521739130435, 0.25
24121, 0, 0.48913043478261, 0.22222222222222
24122, 0, 0.51521739130435, 0.19444444444444
24123, 0, 0.48913043478261, 0.16666666666667
24124, 0, 0.51521739130435, 0.13888888888889
24125, 0, 0.48913043478261, 0.11111111111111
24126, 0, 0.51521739130435, 0.083333333333333
24127, 0, 0.48913043478261, 0.055555555555556
24128, 0, 0.51521739130435, 0.027777777777778
24129, 0, 0.56739130434783, 0.47222222222222
24130, 0, 0.54130434782609, 0.44444444444444
24131, 0, 0.56739130434783, 0.41666666666667
24132, 0, 0.54130434782609, 0.38888888888889
24133, 0, 0.56739130434783, 0.36111111111111
24134, 0, 0.54130434782609, 0.33333333333333
24135, 0, 0.56739130434783, 0.30555555555556
24136, 0, 0.54130434782609, 0.27777777777778
24137, 0, 0.56739130434783, 0.25
24138, 0, 0.54130434782609, 0.22222222222222
24139, 0, 0.56739130434783, 0.19444444444444
24140, 0, 0.54130434782609, 0.16666666666667
24141, 0, 0.56739130434783, 0.13888888888889
24142, 0, 0.54130434782609, 0.11111111111111
24143, 0, 0.56739130434783, 0.083333333333333
24144, 0, 0.54130434782609, 0.055555555555556
24145, 0, 0.56739130434783, 0.027777777777778
24146, 0, 0.6195652173913, 0.47222222222222
24147, 0, 0.59347826086956, 0.44444444444444
24148, 0, 0.6195652173913, 0.41666666666667
24149, 0, 0.59347826086956, 0.38888888888889
24150, 0, 0.6195652173913, 0.36111111111111
24151, 0, 0.59347826086956, 0.33333333333333
24152, 0, 0.6195652173913, 0.30555555555556
24153, 0, 0.59347826086956, 0.27777777777778
24154, 0, 0.6195652173913, 0.25
24155, 0, 0.59347826086956, 0.22222222222222
24156, 0, 0.6195652173913, 0.19444444444444
24157, 0, 0.59347826086956, 0.16666666666667
24158, 0, 0.6195652173913, 0.13888888888889
24159, 0, 0.59347826086956, 0.11111111111111
24160, 0, 0.6195652173913, 0.083333333333333
24161, 0, 0.59347826086956, 0.055555555555556
24162, 0, 0.6195652173913, 0.027777777777778
24163, 0, 0.67173913043478, 0.47222222222222
24164, 0, 0.64565217391304, 0.44444444444444
24165, 0, 0.67173913043478, 0.41666666666667
24166, 0, 0.64565217391304, 0.38888888888889
24167, 0, 0.67173913043478, 0.36111111111111
24168, 0, 0.64565217391304, 0.33333333333333
24169, 0, 0.67173913043478, 0.30555555555556
24170, 0, 0.64565217391304, 0.27777777777778
24171, 0, 0.67173913043478, 0.25
24172, 0, 0.64565217391304, 0.22222222222222
24173, 0, 0.67173913043478, 0.19444444444444
24174, 0, 0.64565217391304, 0.16666666666667
24175, 0, 0.67173913043478, 0.13888888888889
24176, 0, 0.64565217391304, 0.11111111111111
24177, 0, 0.67173913043478, 0.083333333333333
24178, 0, 0.64565217391304, 0.055555555555556
24179, 0, 0.67173913043478, 0.027777777777778
24180, 0, 0.72391304347826, 0.47222222222222
24181, 0, 0.69782608695652, 0.44444444444444
24182, 0, 0.72391304347826, 0.41666666666667
24183, 0, 0.69782608695652, 0.38888888888889
24184, 0, 0.72391304347826, 0.36111111111111
24185, 0, 0.69782608695652, 0.33333333333333
24186, 0, 0.72391304347826, 0.30555555555556
24187, 0, 0.69782608695652, 0.27777777777778
24188, 0, 0.72391304347826, 0.25
24189, 0, 0.69782608695652, 0.22222222222222
24190, 0, 0.72391304347826, 0.19444444444444
24191, 0, 0.69782608695652, 0.16666666666667
24192, 0, 0.72391304347826, 0.13888888888889
24193, 0, 0.69782608695652, 0.11111111111111
24194, 0, 0.72391304347826, 0.083333333333333
24195, 0, 0.69782608695652, 0.055555555555556
24196, 0, 0.72391304347826, 0.027777777777778
24197, 0, 0.77608695652174, 0.47222222222222
24198, 0, 0.75, 0.44444444444444
24199, 0, 0.77608695652174, 0.41666666666667
24200, 0, 0.75, 0.38888888888889
24201, 0, 0.77608695652174, 0.36111111111111
24202, 0, 0.75, 0.33333333333333
24203, 0, 0.77608695652174, 0.30555555555556
24204, 0, 0.75, 0.27777777777778
24205, 0, 0.77608695652174, 0.25
24206, 0, 0.75, 0.22222222222222
24207, 0, 0.77608695652174, 0.19444444444444
24208, 0, 0.75, 0.16666666666667
24209, 0, 0.77608695652174, 0.13888888888889
24210, 0, 0.75, 0.11111111111111
24211, 0, 0.77608695652174, 0.083333333333333
24212, 0, 0.75, 0.055555555555556
24213, 0, 0.77608695652174, 0.027777777777778
24214, 0, 0.82826086956522, 0.47222222222222
24215, 0, 0.80217391304348, 0.44444444444444
24216, 0, 0.82826086956522, 0.41666666666667
24217, 0, 0.80217391304348, 0.38888888888889
24218, 0, 0.82826086956522, 0.36111111111111
24219, 0, 0.80217391304348, 0.33333333333333
24220, 0, 0.82826086956522, 0.30555555555556
24221, 0, 0.80217391304348, 0.27777777777778
24222, 0, 0.82826086956522, 0.25
24223, 0, 0.80217391304348, 0.22222222222222
24224, 0, 0.82826086956522, 0.19444444444444
24225, 0, 0.80217391304348, 0.16666666666667
24226, 0, 0.82826086956522, 0.13888888888889
24227, 0, 0.80217391304348, 0.11111111111111
24228, 0, 0.82826086956522, 0.083333333333333
24229, 0, 0.80217391304348, 0.055555555555556
24230, 0, 0.82826086956522, 0.027777777777778
24231, 0, 0.88043478260869, 0.47222222222222
24232, 0, 0.85434782608696, 0.44444444444444
24233, 0, 0.88043478260869, 0.41666666666667
24234, 0, 0.85434782608696, 0.38888888888889
24235, 0, 0.8804347826087, 0.36111111111111
24236, 0, 0.85434782608696, 0.33333333333333
24237, 0, 0.8804347826087, 0.30555555555556
24238, 0, 0.85434782608696, 0.27777777777778
24239, 0, 0.8804347826087, 0.25
24240, 0, 0.85434782608696, 0.22222222222222
24241, 0, 0.8804347826087, 0.19444444444444
24242, 0, 0.85434782608696, 0.16666666666667
24243, 0, 0.8804347826087, 0.13888888888889
24244, 0, 0.85434782608696, 0.11111111111111
24245, 0, 0.8804347826087, 0.083333333333333
24246, 0, 0.85434782608696, 0.055555555555556
24247, 0, 0.8804347826087, 0.027777777777778
24248, 0, 0.93260869565217, 0.47222222222222
24249, 0, 0.90652173913043, 0.44444444444444
24250, 0, 0.93260869565217, 0.41666666666667
24251, 0, 0.90652173913043, 0.38888888888889
24252, 0, 0.93260869565217, 0.36111111111111
24253, 0, 0.90652173913043, 0.33333333333333
24254, 0, 0.93260869565217, 0.30555555555556
24255, 0, 0.90652173913043, 0.27777777777778
24256, 0, 0.93260869565217, 0.25
24257, 0, 0.90652173913043, 0.22222222222222
24258, 0, 0.93260869565217, 0.19444444444444
24259, 0, 0.90652173913043, 0.16666666666667
24260, 0, 0.93260869565217, 0.13888888888889
24261, 0, 0.90652173913043, 0.11111111111111
24262, 0, 0.93260869565217, 0.083333333333333
24263, 0, 0.90652173913043, 0.055555555555556
24264, 0, 0.93260869565217, 0.027777777777778
24265, 0, 0.98478260869565, 0.47222222222222
24266, 0, 0.95869565217391, 0.44444444444444
24267, 0, 0.98478260869565, 0.41666666666667
24268, 0, 0.95869565217391, 0.38888888888889
24269, 0, 0.98478260869565, 0.36111111111111
24270, 0, 0.95869565217391, 0.33333333333333
24271, 0, 0.98478260869565, 0.30555555555556
24272, 0, 0.95869565217391, 0.27777777777778
24273, 0, 0.98478260869565, 0.25
24274, 0, 0.95869565217391, 0.22222222222222
24275, 0, 0.98478260869565, 0.19444444444444
24276, 0, 0.95869565217391, 0.16666666666667
24277, 0, 0.98478260869565, 0.13888888888889
24278, 0, 0.95869565217391, 0.11111111111111
24279, 0, 0.98478260869565, 0.083333333333333
24280, 0, 0.95869565217391, 0.055555555555556
24281, 0, 0.98478260869565, 0.027777777777778
24282, 0, 1.0369565217391, 0.47222222222222
24283, 0, 1.0108695652174, 0.44444444444444
24284, 0, 1.0369565217391, 0.41666666666667
24285, 0, 1.0108695652174, 0.38888888888889
24286, 0, 1.0369565217391, 0.36111111111111
24287, 0, 1.0108695652174, 0.33333333333333
24288, 0, 1.0369565217391, 0.30555555555556
24289, 0, 1.0108695652174, 0.27777777777778
24290, 0, 1.0369565217391, 0.25
24291, 0, 1.0108695652174, 0.22222222222222
24292, 0, 1.0369565217391, 0.19444444444444
24293, 0, 1.0108695652174, 0.16666666666667
24294, 0, 1.0369565217391, 0.13888888888889
24295, 0, 1.0108695652174, 0.11111111111111
24296, 0, 1.0369565217391, 0.083333333333333
24297, 0, 1.0108695652174, 0.055555555555556
24298, 0, 1.0369565217391, 0.027777777777778
24299, 0, 1.0891304347826, 0.47222222222222
24300, 0, 1.0630434782609, 0.44444444444444
24301, 0, 1.0891304347826, 0.41666666666667
24302, 0, 1.0630434782609, 0.38888888888889
24303, 0, 1.0891304347826, 0.36111111111111
24304, 0, 1.0630434782609, 0.33333333333333
24305, 0, 1.0891304347826, 0.30555555555556
24306, 0, 1.0630434782609, 0.27777777777778
24307, 0, 1.0891304347826, 0.25
24308, 0, 1.0630434782609, 0.22222222222222
24309, 0, 1.0891304347826, 0.19444444444444
24310, 0, 1.0630434782609, 0.16666666666667
24311, 0, 1.0891304347826, 0.13888888888889
24312, 0, 1.0630434782609, 0.11111111111111
24313, 0, 1.0891304347826, 0.083333333333333
24314, 0, 1.0630434782609, 0.055555555555556
24315, 0, 1.0891304347826, 0.027777777777778
24316, 0, 1.1413043478261, 0.47222222222222
24317, 0, 1.1152173913043, 0.44444444444444
24318, 0, 1.1413043478261, 0.41666666666667
24319, 0, 1.1152173913043, 0.38888888888889
24320, 0, 1.1413043478261, 0.36111111111111
24321, 0, 1.1152173913043, 0.33333333333333
24322, 0, 1.1413043478261, 0.30555555555556
24323, 0, 1.1152173913043, 0.27777777777778
24324, 0, 1.1413043478261, 0.25
24325, 0, 1.1152173913043, 0.22222222222222
24326, 0, 1.1413043478261, 0.19444444444444
24327, 0, 1.1152173913043, 0.16666666666667
24328, 0, 1.1413043478261, 0.13888888888889
24329, 0, 1.1152173913043, 0.11111111111111
24330, 0, 1.1413043478261, 0.083333333333333
24331, 0, 1.1152173913043, 0.055555555555556
24332, 0, 1.1413043478261, 0.027777777777778
24333, 0, 1.1934782608696, 0.47222222222222
24334, 0, 1.1673913043478, 0.44444444444444
24335, 0, 1.1934782608696, 0.41666666666667
24336, 0, 1.1673913043478, 0.38888888888889
24337, 0, 1.1934782608696, 0.36111111111111
24338, 0, 1.1673913043478, 0.33333333333333
24339, 0, 1.1934782608696, 0.30555555555556
24340, 0, 1.1673913043478, 0.27777777777778
24341, 0, 1.1934782608696, 0.25
24342, 0, 1.1673913043478, 0.22222222222222
24343, 0, 1.1934782608696, 0.19444444444444
24344, 0, 1.1673913043478, 0.16666666666667
24345, 0, 1.1934782608696, 0.13888888888889
24346, 0, 1.1673913043478, 0.11111111111111
24347, 0, 1.1934782608696, 0.083333333333333
24348, 0, 1.1673913043478, 0.055555555555556
24349, 0, 1.1934782608696, 0.027777777777778
24350, 0, 1.245652173913, 0.47222222222222
24351, 0, 1.2195652173913, 0.44444444444444
24352, 0, 1.245652173913, 0.41666666666667
24353, 0, 1.2195652173913, 0.38888888888889
24354, 0, 1.245652173913, 0.36111111111111
24355, 0, 1.2195652173913, 0.33333333333333
24356, 0, 1.245652173913, 0.30555555555556
24357, 0, 1.2195652173913, 0.27777777777778
24358, 0, 1.245652173913, 0.25
24359, 0, 1.2195652173913, 0.22222222222222
24360, 0, 1.245652173913, 0.19444444444444
24361, 0, 1.2195652173913, 0.16666666666667
24362, 0, 1.245652173913, 0.13888888888889
24363, 0, 1.2195652173913, 0.11111111111111
24364, 0, 1.245652173913, 0.083333333333333
24365, 0, 1.2195652173913, 0.055555555555556
24366, 0, 1.245652173913, 0.027777777777778
24367, 0, 1.2978260869565, 0.47222222222222
24368, 0, 1.2717391304348, 0.44444444444444
24369, 0, 1.2978260869565, 0.41666666666667
24370, 0, 1.2717391304348, 0.38888888888889
24371, 0, 1.2978260869565, 0.36111111111111
24372, 0, 1.2717391304348, 0.33333333333333
24373, 0, 1.2978260869565, 0.30555555555556
24374, 0, 1.2717391304348, 0.27777777777778
24375, 0, 1.2978260869565, 0.25
24376, 0, 1.2717391304348, 0.22222222222222
24377, 0, 1.2978260869565, 0.19444444444444
24378, 0, 1.2717391304348, 0.16666666666667
24379, 0, 1.2978260869565, 0.13888888888889
24380, 0, 1.2717391304348, 0.11111111111111
24381, 0, 1.2978260869565, 0.083333333333333
24382, 0, 1.2717391304348, 0.055555555555556
24383, 0, 1.2978260869565, 0.027777777777778
24384, 0, 1.3239130434783, 0.44444444444444
24385, 0, 1.3239130434783, 0.38888888888889
24386, 0, 1.3239130434783, 0.33333333333333
24387, 0, 1.3239130434783, 0.27777777777778
24388, 0, 1.3239130434783, 0.22222222222222
24389, 0, 1.3239130434783, 0.16666666666667
24390, 0, 1.3239130434783, 0.11111111111111
24391, 0, 1.3239130434783, 0.055555555555556
24392, 0.043478260869565, 1.35, 0.055555555555556
24393, 0.043478260869565, 1.35, 0.11111111111111
24394, 0.043478260869565, 1.35, 0.16666666666667
24395, 0.043478260869565, 1.35, 0.22222222222222
24396, 0.043478260869565, 1.35, 0.27777777777778
24397, 0.043478260869565, 1.35, 0.33333333333333
24398, 0.043478260869565, 1.35, 0.38888888888889
