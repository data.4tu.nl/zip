100087, 2.0695652173913, 1.0891304347826, -0.01875
100088, 2.0913043478261, 1.0891304347826, -0.0375
100089, 2.1130434782609, 1.1152173913043, -0.0375
100090, 2.1130434782609, 1.0891304347826, -0.01875
100091, 2.1347826086957, 1.0891304347826, -0.0375
100092, 2.1565217391304, 1.1152173913043, -0.0375
100093, 2.1565217391304, 1.0891304347826, -0.01875
100094, 2.1782608695652, 1.0891304347826, -0.0375
100095, 1.2217391304348, 1.0369565217391, -0.0375
100096, 1.2434782608696, 1.0630434782609, -0.0375
100097, 1.2434782608696, 1.0369565217391, -0.01875
100098, 1.2652173913043, 1.0369565217391, -0.0375
100099, 1.2869565217391, 1.0630434782609, -0.0375
100100, 1.2869565217391, 1.0369565217391, -0.01875
100101, 1.3086956521739, 1.0369565217391, -0.0375
100102, 1.3304347826087, 1.0630434782609, -0.0375
100103, 1.3304347826087, 1.0369565217391, -0.01875
100104, 1.3521739130435, 1.0369565217391, -0.0375
100105, 1.3739130434783, 1.0630434782609, -0.0375
100106, 1.3739130434783, 1.0369565217391, -0.01875
100107, 1.395652173913, 1.0369565217391, -0.0375
100108, 1.4173913043478, 1.0630434782609, -0.0375
100109, 1.4173913043478, 1.0369565217391, -0.01875
100110, 1.4391304347826, 1.0369565217391, -0.0375
100111, 1.4608695652174, 1.0630434782609, -0.0375
100112, 1.4608695652174, 1.0369565217391, -0.01875
100113, 1.4826086956522, 1.0369565217391, -0.0375
100114, 1.504347826087, 1.0630434782609, -0.0375
100115, 1.504347826087, 1.0369565217391, -0.01875
100116, 1.5260869565217, 1.0369565217391, -0.0375
100117, 1.5478260869565, 1.0630434782609, -0.0375
100118, 1.5478260869565, 1.0369565217391, -0.01875
100119, 1.5695652173913, 1.0369565217391, -0.0375
100120, 1.5913043478261, 1.0630434782609, -0.0375
100121, 1.5913043478261, 1.0369565217391, -0.01875
100122, 1.6130434782609, 1.0369565217391, -0.0375
100123, 1.6347826086957, 1.0630434782609, -0.0375
100124, 1.6347826086957, 1.0369565217391, -0.01875
100125, 1.6565217391304, 1.0369565217391, -0.0375
100126, 1.6782608695652, 1.0630434782609, -0.0375
100127, 1.6782608695652, 1.0369565217391, -0.01875
100128, 1.7, 1.0369565217391, -0.0375
100129, 1.7217391304348, 1.0630434782609, -0.0375
100130, 1.7217391304348, 1.0369565217391, -0.01875
100131, 1.7434782608696, 1.0369565217391, -0.0375
100132, 1.7652173913043, 1.0630434782609, -0.0375
100133, 1.7652173913043, 1.0369565217391, -0.01875
100134, 1.7869565217391, 1.0369565217391, -0.0375
100135, 1.8086956521739, 1.0630434782609, -0.0375
100136, 1.8086956521739, 1.0369565217391, -0.01875
100137, 1.8304347826087, 1.0369565217391, -0.0375
100138, 1.8521739130435, 1.0630434782609, -0.0375
100139, 1.8521739130435, 1.0369565217391, -0.01875
100140, 1.8739130434783, 1.0369565217391, -0.0375
100141, 1.895652173913, 1.0630434782609, -0.0375
100142, 1.895652173913, 1.0369565217391, -0.01875
100143, 1.9173913043478, 1.0369565217391, -0.0375
100144, 1.9391304347826, 1.0630434782609, -0.0375
100145, 1.9391304347826, 1.0369565217391, -0.01875
100146, 1.9608695652174, 1.0369565217391, -0.0375
100147, 1.9826086956522, 1.0630434782609, -0.0375
100148, 1.9826086956522, 1.0369565217391, -0.01875
100149, 2.004347826087, 1.0369565217391, -0.0375
100150, 2.0260869565217, 1.0630434782609, -0.0375
100151, 2.0260869565217, 1.0369565217391, -0.01875
100152, 2.0478260869565, 1.0369565217391, -0.0375
100153, 2.0695652173913, 1.0630434782609, -0.0375
100154, 2.0695652173913, 1.0369565217391, -0.01875
100155, 2.0913043478261, 1.0369565217391, -0.0375
100156, 2.1130434782609, 1.0630434782609, -0.0375
100157, 2.1130434782609, 1.0369565217391, -0.01875
100158, 2.1347826086957, 1.0369565217391, -0.0375
100159, 2.1565217391304, 1.0630434782609, -0.0375
100160, 2.1565217391304, 1.0369565217391, -0.01875
100161, 2.1782608695652, 1.0369565217391, -0.0375
100162, 1.2217391304348, 0.98478260869565, -0.0375
100163, 1.2434782608696, 1.0108695652174, -0.0375
100164, 1.2434782608696, 0.98478260869565, -0.01875
100165, 1.2652173913043, 0.98478260869565, -0.0375
100166, 1.2869565217391, 1.0108695652174, -0.0375
100167, 1.2869565217391, 0.98478260869565, -0.01875
100168, 1.3086956521739, 0.98478260869565, -0.0375
100169, 1.3304347826087, 1.0108695652174, -0.0375
100170, 1.3304347826087, 0.98478260869565, -0.01875
100171, 1.3521739130435, 0.98478260869565, -0.0375
100172, 1.3739130434783, 1.0108695652174, -0.0375
100173, 1.3739130434783, 0.98478260869565, -0.01875
100174, 1.395652173913, 0.98478260869565, -0.0375
100175, 1.4173913043478, 1.0108695652174, -0.0375
100176, 1.4173913043478, 0.98478260869565, -0.01875
100177, 1.4391304347826, 0.98478260869565, -0.0375
100178, 1.4608695652174, 1.0108695652174, -0.0375
100179, 1.4608695652174, 0.98478260869565, -0.01875
100180, 1.4826086956522, 0.98478260869565, -0.0375
100181, 1.504347826087, 1.0108695652174, -0.0375
100182, 1.504347826087, 0.98478260869565, -0.01875
100183, 1.5260869565217, 0.98478260869565, -0.0375
100184, 1.5478260869565, 1.0108695652174, -0.0375
100185, 1.5478260869565, 0.98478260869565, -0.01875
100186, 1.5695652173913, 0.98478260869565, -0.0375
100187, 1.5913043478261, 1.0108695652174, -0.0375
100188, 1.5913043478261, 0.98478260869565, -0.01875
100189, 1.6130434782609, 0.98478260869565, -0.0375
100190, 1.6347826086957, 1.0108695652174, -0.0375
100191, 1.6347826086957, 0.98478260869565, -0.01875
100192, 1.6565217391304, 0.98478260869565, -0.0375
100193, 1.6782608695652, 1.0108695652174, -0.0375
100194, 1.6782608695652, 0.98478260869565, -0.01875
100195, 1.7, 0.98478260869565, -0.0375
100196, 1.7217391304348, 1.0108695652174, -0.0375
100197, 1.7217391304348, 0.98478260869565, -0.01875
100198, 1.7434782608696, 0.98478260869565, -0.0375
100199, 1.7652173913043, 1.0108695652174, -0.0375
100200, 1.7652173913043, 0.98478260869565, -0.01875
100201, 1.7869565217391, 0.98478260869565, -0.0375
100202, 1.8086956521739, 1.0108695652174, -0.0375
100203, 1.8086956521739, 0.98478260869565, -0.01875
100204, 1.8304347826087, 0.98478260869565, -0.0375
100205, 1.8521739130435, 1.0108695652174, -0.0375
100206, 1.8521739130435, 0.98478260869565, -0.01875
100207, 1.8739130434783, 0.98478260869565, -0.0375
100208, 1.895652173913, 1.0108695652174, -0.0375
100209, 1.895652173913, 0.98478260869565, -0.01875
100210, 1.9173913043478, 0.98478260869565, -0.0375
100211, 1.9391304347826, 1.0108695652174, -0.0375
100212, 1.9391304347826, 0.98478260869565, -0.01875
100213, 1.9608695652174, 0.98478260869565, -0.0375
100214, 1.9826086956522, 1.0108695652174, -0.0375
100215, 1.9826086956522, 0.98478260869565, -0.01875
100216, 2.004347826087, 0.98478260869565, -0.0375
100217, 2.0260869565217, 1.0108695652174, -0.0375
100218, 2.0260869565217, 0.98478260869565, -0.01875
100219, 2.0478260869565, 0.98478260869565, -0.0375
100220, 2.0695652173913, 1.0108695652174, -0.0375
100221, 2.0695652173913, 0.98478260869565, -0.01875
100222, 2.0913043478261, 0.98478260869565, -0.0375
100223, 2.1130434782609, 1.0108695652174, -0.0375
100224, 2.1130434782609, 0.98478260869565, -0.01875
100225, 2.1347826086957, 0.98478260869565, -0.0375
100226, 2.1565217391304, 1.0108695652174, -0.0375
100227, 2.1565217391304, 0.98478260869565, -0.01875
100228, 2.1782608695652, 0.98478260869565, -0.0375
100229, 1.2217391304348, 0.93260869565217, -0.0375
100230, 1.2434782608696, 0.95869565217391, -0.0375
100231, 1.2434782608696, 0.93260869565217, -0.01875
100232, 1.2652173913043, 0.93260869565217, -0.0375
100233, 1.2869565217391, 0.95869565217391, -0.0375
100234, 1.2869565217391, 0.93260869565217, -0.01875
100235, 1.3086956521739, 0.93260869565217, -0.0375
100236, 1.3304347826087, 0.95869565217391, -0.0375
100237, 1.3304347826087, 0.93260869565217, -0.01875
100238, 1.3521739130435, 0.93260869565217, -0.0375
100239, 1.3739130434783, 0.95869565217391, -0.0375
100240, 1.3739130434783, 0.93260869565217, -0.01875
100241, 1.395652173913, 0.93260869565217, -0.0375
100242, 1.4173913043478, 0.95869565217391, -0.0375
100243, 1.4173913043478, 0.93260869565217, -0.01875
100244, 1.4391304347826, 0.93260869565217, -0.0375
100245, 1.4608695652174, 0.95869565217391, -0.0375
100246, 1.4608695652174, 0.93260869565217, -0.01875
100247, 1.4826086956522, 0.93260869565217, -0.0375
100248, 1.504347826087, 0.95869565217391, -0.0375
100249, 1.504347826087, 0.93260869565217, -0.01875
100250, 1.5260869565217, 0.93260869565217, -0.0375
100251, 1.5478260869565, 0.95869565217391, -0.0375
100252, 1.5478260869565, 0.93260869565217, -0.01875
100253, 1.5695652173913, 0.93260869565217, -0.0375
100254, 1.5913043478261, 0.95869565217391, -0.0375
100255, 1.5913043478261, 0.93260869565217, -0.01875
100256, 1.6130434782609, 0.93260869565217, -0.0375
100257, 1.6347826086957, 0.95869565217391, -0.0375
100258, 1.6347826086957, 0.93260869565217, -0.01875
100259, 1.6565217391304, 0.93260869565217, -0.0375
100260, 1.6782608695652, 0.95869565217391, -0.0375
100261, 1.6782608695652, 0.93260869565217, -0.01875
100262, 1.7, 0.93260869565217, -0.0375
100263, 1.7217391304348, 0.95869565217391, -0.0375
100264, 1.7217391304348, 0.93260869565217, -0.01875
100265, 1.7434782608696, 0.93260869565217, -0.0375
100266, 1.7652173913043, 0.95869565217391, -0.0375
100267, 1.7652173913043, 0.93260869565217, -0.01875
100268, 1.7869565217391, 0.93260869565217, -0.0375
100269, 1.8086956521739, 0.95869565217391, -0.0375
100270, 1.8086956521739, 0.93260869565217, -0.01875
100271, 1.8304347826087, 0.93260869565217, -0.0375
100272, 1.8521739130435, 0.95869565217391, -0.0375
100273, 1.8521739130435, 0.93260869565217, -0.01875
100274, 1.8739130434783, 0.93260869565217, -0.0375
100275, 1.895652173913, 0.95869565217391, -0.0375
100276, 1.895652173913, 0.93260869565217, -0.01875
100277, 1.9173913043478, 0.93260869565217, -0.0375
100278, 1.9391304347826, 0.95869565217391, -0.0375
100279, 1.9391304347826, 0.93260869565217, -0.01875
100280, 1.9608695652174, 0.93260869565217, -0.0375
100281, 1.9826086956522, 0.95869565217391, -0.0375
100282, 1.9826086956522, 0.93260869565217, -0.01875
100283, 2.004347826087, 0.93260869565217, -0.0375
100284, 2.0260869565217, 0.95869565217391, -0.0375
100285, 2.0260869565217, 0.93260869565217, -0.01875
100286, 2.0478260869565, 0.93260869565217, -0.0375
100287, 2.0695652173913, 0.95869565217391, -0.0375
100288, 2.0695652173913, 0.93260869565217, -0.01875
100289, 2.0913043478261, 0.93260869565217, -0.0375
100290, 2.1130434782609, 0.95869565217391, -0.0375
100291, 2.1130434782609, 0.93260869565217, -0.01875
100292, 2.1347826086957, 0.93260869565217, -0.0375
100293, 2.1565217391304, 0.95869565217391, -0.0375
100294, 2.1565217391304, 0.93260869565217, -0.01875
100295, 2.1782608695652, 0.93260869565217, -0.0375
100296, 1.2217391304348, 0.8804347826087, -0.0375
100297, 1.2434782608696, 0.90652173913044, -0.0375
100298, 1.2434782608696, 0.8804347826087, -0.01875
100299, 1.2652173913043, 0.8804347826087, -0.0375
100300, 1.2869565217391, 0.90652173913044, -0.0375
100301, 1.2869565217391, 0.8804347826087, -0.01875
100302, 1.3086956521739, 0.8804347826087, -0.0375
100303, 1.3304347826087, 0.90652173913044, -0.0375
100304, 1.3304347826087, 0.8804347826087, -0.01875
100305, 1.3521739130435, 0.8804347826087, -0.0375
100306, 1.3739130434783, 0.90652173913044, -0.0375
100307, 1.3739130434783, 0.8804347826087, -0.01875
100308, 1.395652173913, 0.8804347826087, -0.0375
100309, 1.4173913043478, 0.90652173913044, -0.0375
100310, 1.4173913043478, 0.8804347826087, -0.01875
100311, 1.4391304347826, 0.8804347826087, -0.0375
100312, 1.4608695652174, 0.90652173913044, -0.0375
100313, 1.4608695652174, 0.8804347826087, -0.01875
100314, 1.4826086956522, 0.8804347826087, -0.0375
100315, 1.504347826087, 0.90652173913044, -0.0375
100316, 1.504347826087, 0.8804347826087, -0.01875
100317, 1.5260869565217, 0.8804347826087, -0.0375
100318, 1.5478260869565, 0.90652173913044, -0.0375
100319, 1.5478260869565, 0.8804347826087, -0.01875
100320, 1.5695652173913, 0.8804347826087, -0.0375
100321, 1.5913043478261, 0.90652173913044, -0.0375
100322, 1.5913043478261, 0.8804347826087, -0.01875
100323, 1.6130434782609, 0.8804347826087, -0.0375
100324, 1.6347826086957, 0.90652173913044, -0.0375
100325, 1.6347826086957, 0.8804347826087, -0.01875
100326, 1.6565217391304, 0.8804347826087, -0.0375
100327, 1.6782608695652, 0.90652173913044, -0.0375
100328, 1.6782608695652, 0.8804347826087, -0.01875
100329, 1.7, 0.8804347826087, -0.0375
100330, 1.7217391304348, 0.90652173913044, -0.0375
100331, 1.7217391304348, 0.8804347826087, -0.01875
100332, 1.7434782608696, 0.8804347826087, -0.0375
100333, 1.7652173913043, 0.90652173913044, -0.0375
100334, 1.7652173913043, 0.8804347826087, -0.01875
100335, 1.7869565217391, 0.8804347826087, -0.0375
100336, 1.8086956521739, 0.90652173913044, -0.0375
100337, 1.8086956521739, 0.8804347826087, -0.01875
100338, 1.8304347826087, 0.8804347826087, -0.0375
100339, 1.8521739130435, 0.90652173913044, -0.0375
100340, 1.8521739130435, 0.8804347826087, -0.01875
100341, 1.8739130434783, 0.8804347826087, -0.0375
100342, 1.895652173913, 0.90652173913044, -0.0375
100343, 1.895652173913, 0.8804347826087, -0.01875
100344, 1.9173913043478, 0.8804347826087, -0.0375
100345, 1.9391304347826, 0.90652173913044, -0.0375
100346, 1.9391304347826, 0.8804347826087, -0.01875
100347, 1.9608695652174, 0.8804347826087, -0.0375
100348, 1.9826086956522, 0.90652173913044, -0.0375
100349, 1.9826086956522, 0.8804347826087, -0.01875
100350, 2.004347826087, 0.8804347826087, -0.0375
100351, 2.0260869565217, 0.90652173913044, -0.0375
100352, 2.0260869565217, 0.8804347826087, -0.01875
100353, 2.0478260869565, 0.8804347826087, -0.0375
100354, 2.0695652173913, 0.90652173913044, -0.0375
100355, 2.0695652173913, 0.8804347826087, -0.01875
100356, 2.0913043478261, 0.8804347826087, -0.0375
100357, 2.1130434782609, 0.90652173913044, -0.0375
100358, 2.1130434782609, 0.8804347826087, -0.01875
100359, 2.1347826086957, 0.8804347826087, -0.0375
100360, 2.1565217391304, 0.90652173913044, -0.0375
100361, 2.1565217391304, 0.8804347826087, -0.01875
100362, 2.1782608695652, 0.8804347826087, -0.0375
100363, 1.2217391304348, 0.82826086956522, -0.0375
100364, 1.2434782608696, 0.85434782608696, -0.0375
100365, 1.2434782608696, 0.82826086956522, -0.01875
100366, 1.2652173913043, 0.82826086956522, -0.0375
100367, 1.2869565217391, 0.85434782608696, -0.0375
100368, 1.2869565217391, 0.82826086956522, -0.01875
100369, 1.3086956521739, 0.82826086956522, -0.0375
100370, 1.3304347826087, 0.85434782608696, -0.0375
100371, 1.3304347826087, 0.82826086956522, -0.01875
100372, 1.3521739130435, 0.82826086956522, -0.0375
100373, 1.3739130434783, 0.85434782608696, -0.0375
100374, 1.3739130434783, 0.82826086956522, -0.01875
100375, 1.395652173913, 0.82826086956522, -0.0375
100376, 1.4173913043478, 0.85434782608696, -0.0375
100377, 1.4173913043478, 0.82826086956522, -0.01875
100378, 1.4391304347826, 0.82826086956522, -0.0375
100379, 1.4608695652174, 0.85434782608696, -0.0375
100380, 1.4608695652174, 0.82826086956522, -0.01875
100381, 1.4826086956522, 0.82826086956522, -0.0375
100382, 1.504347826087, 0.85434782608696, -0.0375
100383, 1.504347826087, 0.82826086956522, -0.01875
100384, 1.5260869565217, 0.82826086956522, -0.0375
100385, 1.5478260869565, 0.85434782608696, -0.0375
100386, 1.5478260869565, 0.82826086956522, -0.01875
100387, 1.5695652173913, 0.82826086956522, -0.0375
100388, 1.5913043478261, 0.85434782608696, -0.0375
100389, 1.5913043478261, 0.82826086956522, -0.01875
100390, 1.6130434782609, 0.82826086956522, -0.0375
100391, 1.6347826086957, 0.85434782608696, -0.0375
100392, 1.6347826086957, 0.82826086956522, -0.01875
100393, 1.6565217391304, 0.82826086956522, -0.0375
100394, 1.6782608695652, 0.85434782608696, -0.0375
100395, 1.6782608695652, 0.82826086956522, -0.01875
100396, 1.7, 0.82826086956522, -0.0375
100397, 1.7217391304348, 0.85434782608696, -0.0375
100398, 1.7217391304348, 0.82826086956522, -0.01875
100399, 1.7434782608696, 0.82826086956522, -0.0375
100400, 1.7652173913043, 0.85434782608696, -0.0375
100401, 1.7652173913043, 0.82826086956522, -0.01875
100402, 1.7869565217391, 0.82826086956522, -0.0375
100403, 1.8086956521739, 0.85434782608696, -0.0375
100404, 1.8086956521739, 0.82826086956522, -0.01875
100405, 1.8304347826087, 0.82826086956522, -0.0375
100406, 1.8521739130435, 0.85434782608696, -0.0375
100407, 1.8521739130435, 0.82826086956522, -0.01875
100408, 1.8739130434783, 0.82826086956522, -0.0375
100409, 1.895652173913, 0.85434782608696, -0.0375
100410, 1.895652173913, 0.82826086956522, -0.01875
100411, 1.9173913043478, 0.82826086956522, -0.0375
100412, 1.9391304347826, 0.85434782608696, -0.0375
100413, 1.9391304347826, 0.82826086956522, -0.01875
100414, 1.9608695652174, 0.82826086956522, -0.0375
100415, 1.9826086956522, 0.85434782608696, -0.0375
100416, 1.9826086956522, 0.82826086956522, -0.01875
100417, 2.004347826087, 0.82826086956522, -0.0375
100418, 2.0260869565217, 0.85434782608696, -0.0375
100419, 2.0260869565217, 0.82826086956522, -0.01875
100420, 2.0478260869565, 0.82826086956522, -0.0375
100421, 2.0695652173913, 0.85434782608696, -0.0375
100422, 2.0695652173913, 0.82826086956522, -0.01875
100423, 2.0913043478261, 0.82826086956522, -0.0375
100424, 2.1130434782609, 0.85434782608696, -0.0375
100425, 2.1130434782609, 0.82826086956522, -0.01875
100426, 2.1347826086957, 0.82826086956522, -0.0375
100427, 2.1565217391304, 0.85434782608696, -0.0375
100428, 2.1565217391304, 0.82826086956522, -0.01875
100429, 2.1782608695652, 0.82826086956522, -0.0375
100430, 1.2217391304348, 0.77608695652174, -0.0375
100431, 1.2434782608696, 0.80217391304348, -0.0375
100432, 1.2434782608696, 0.77608695652174, -0.01875
100433, 1.2652173913043, 0.77608695652174, -0.0375
100434, 1.2869565217391, 0.80217391304348, -0.0375
100435, 1.2869565217391, 0.77608695652174, -0.01875
100436, 1.3086956521739, 0.77608695652174, -0.0375
100437, 1.3304347826087, 0.80217391304348, -0.0375
100438, 1.3304347826087, 0.77608695652174, -0.01875
100439, 1.3521739130435, 0.77608695652174, -0.0375
100440, 1.3739130434783, 0.80217391304348, -0.0375
100441, 1.3739130434783, 0.77608695652174, -0.01875
100442, 1.395652173913, 0.77608695652174, -0.0375
100443, 1.4173913043478, 0.80217391304348, -0.0375
100444, 1.4173913043478, 0.77608695652174, -0.01875
100445, 1.4391304347826, 0.77608695652174, -0.0375
100446, 1.4608695652174, 0.80217391304348, -0.0375
100447, 1.4608695652174, 0.77608695652174, -0.01875
100448, 1.4826086956522, 0.77608695652174, -0.0375
100449, 1.504347826087, 0.80217391304348, -0.0375
100450, 1.504347826087, 0.77608695652174, -0.01875
100451, 1.5260869565217, 0.77608695652174, -0.0375
100452, 1.5478260869565, 0.80217391304348, -0.0375
100453, 1.5478260869565, 0.77608695652174, -0.01875
100454, 1.5695652173913, 0.77608695652174, -0.0375
100455, 1.5913043478261, 0.80217391304348, -0.0375
100456, 1.5913043478261, 0.77608695652174, -0.01875
100457, 1.6130434782609, 0.77608695652174, -0.0375
100458, 1.6347826086957, 0.80217391304348, -0.0375
100459, 1.6347826086957, 0.77608695652174, -0.01875
100460, 1.6565217391304, 0.77608695652174, -0.0375
100461, 1.6782608695652, 0.80217391304348, -0.0375
100462, 1.6782608695652, 0.77608695652174, -0.01875
100463, 1.7, 0.77608695652174, -0.0375
100464, 1.7217391304348, 0.80217391304348, -0.0375
100465, 1.7217391304348, 0.77608695652174, -0.01875
100466, 1.7434782608696, 0.77608695652174, -0.0375
100467, 1.7652173913043, 0.80217391304348, -0.0375
100468, 1.7652173913043, 0.77608695652174, -0.01875
100469, 1.7869565217391, 0.77608695652174, -0.0375
100470, 1.8086956521739, 0.80217391304348, -0.0375
100471, 1.8086956521739, 0.77608695652174, -0.01875
100472, 1.8304347826087, 0.77608695652174, -0.0375
100473, 1.8521739130435, 0.80217391304348, -0.0375
100474, 1.8521739130435, 0.77608695652174, -0.01875
100475, 1.8739130434783, 0.77608695652174, -0.0375
100476, 1.895652173913, 0.80217391304348, -0.0375
100477, 1.895652173913, 0.77608695652174, -0.01875
100478, 1.9173913043478, 0.77608695652174, -0.0375
100479, 1.9391304347826, 0.80217391304348, -0.0375
100480, 1.9391304347826, 0.77608695652174, -0.01875
100481, 1.9608695652174, 0.77608695652174, -0.0375
100482, 1.9826086956522, 0.80217391304348, -0.0375
100483, 1.9826086956522, 0.77608695652174, -0.01875
100484, 2.004347826087, 0.77608695652174, -0.0375
100485, 2.0260869565217, 0.80217391304348, -0.0375
100486, 2.0260869565217, 0.77608695652174, -0.01875
100487, 2.0478260869565, 0.77608695652174, -0.0375
100488, 2.0695652173913, 0.80217391304348, -0.0375
100489, 2.0695652173913, 0.77608695652174, -0.01875
100490, 2.0913043478261, 0.77608695652174, -0.0375
100491, 2.1130434782609, 0.80217391304348, -0.0375
100492, 2.1130434782609, 0.77608695652174, -0.01875
100493, 2.1347826086957, 0.77608695652174, -0.0375
100494, 2.1565217391304, 0.80217391304348, -0.0375
100495, 2.1565217391304, 0.77608695652174, -0.01875
100496, 2.1782608695652, 0.77608695652174, -0.0375
100497, 1.2217391304348, 0.72391304347826, -0.0375
100498, 1.2434782608696, 0.75, -0.0375
100499, 1.2434782608696, 0.72391304347826, -0.01875
100500, 1.2652173913043, 0.72391304347826, -0.0375
100501, 1.2869565217391, 0.75, -0.0375
100502, 1.2869565217391, 0.72391304347826, -0.01875
100503, 1.3086956521739, 0.72391304347826, -0.0375
100504, 1.3304347826087, 0.75, -0.0375
100505, 1.3304347826087, 0.72391304347826, -0.01875
100506, 1.3521739130435, 0.72391304347826, -0.0375
100507, 1.3739130434783, 0.75, -0.0375
100508, 1.3739130434783, 0.72391304347826, -0.01875
100509, 1.395652173913, 0.72391304347826, -0.0375
100510, 1.4173913043478, 0.75, -0.0375
100511, 1.4173913043478, 0.72391304347826, -0.01875
100512, 1.4391304347826, 0.72391304347826, -0.0375
100513, 1.4608695652174, 0.75, -0.0375
100514, 1.4608695652174, 0.72391304347826, -0.01875
100515, 1.4826086956522, 0.72391304347826, -0.0375
100516, 1.504347826087, 0.75, -0.0375
100517, 1.504347826087, 0.72391304347826, -0.01875
100518, 1.5260869565217, 0.72391304347826, -0.0375
100519, 1.5478260869565, 0.75, -0.0375
100520, 1.5478260869565, 0.72391304347826, -0.01875
100521, 1.5695652173913, 0.72391304347826, -0.0375
100522, 1.5913043478261, 0.75, -0.0375
100523, 1.5913043478261, 0.72391304347826, -0.01875
100524, 1.6130434782609, 0.72391304347826, -0.0375
100525, 1.6347826086957, 0.75, -0.0375
100526, 1.6347826086957, 0.72391304347826, -0.01875
100527, 1.6565217391304, 0.72391304347826, -0.0375
100528, 1.6782608695652, 0.75, -0.0375
100529, 1.6782608695652, 0.72391304347826, -0.01875
100530, 1.7, 0.72391304347826, -0.0375
100531, 1.7217391304348, 0.75, -0.0375
100532, 1.7217391304348, 0.72391304347826, -0.01875
100533, 1.7434782608696, 0.72391304347826, -0.0375
100534, 1.7652173913043, 0.75, -0.0375
100535, 1.7652173913043, 0.72391304347826, -0.01875
100536, 1.7869565217391, 0.72391304347826, -0.0375
100537, 1.8086956521739, 0.75, -0.0375
100538, 1.8086956521739, 0.72391304347826, -0.01875
100539, 1.8304347826087, 0.72391304347826, -0.0375
100540, 1.8521739130435, 0.75, -0.0375
100541, 1.8521739130435, 0.72391304347826, -0.01875
100542, 1.8739130434783, 0.72391304347826, -0.0375
100543, 1.895652173913, 0.75, -0.0375
100544, 1.895652173913, 0.72391304347826, -0.01875
100545, 1.9173913043478, 0.72391304347826, -0.0375
100546, 1.9391304347826, 0.75, -0.0375
100547, 1.9391304347826, 0.72391304347826, -0.01875
100548, 1.9608695652174, 0.72391304347826, -0.0375
100549, 1.9826086956522, 0.75, -0.0375
100550, 1.9826086956522, 0.72391304347826, -0.01875
100551, 2.004347826087, 0.72391304347826, -0.0375
100552, 2.0260869565217, 0.75, -0.0375
100553, 2.0260869565217, 0.72391304347826, -0.01875
100554, 2.0478260869565, 0.72391304347826, -0.0375
100555, 2.0695652173913, 0.75, -0.0375
100556, 2.0695652173913, 0.72391304347826, -0.01875
100557, 2.0913043478261, 0.72391304347826, -0.0375
100558, 2.1130434782609, 0.75, -0.0375
100559, 2.1130434782609, 0.72391304347826, -0.01875
100560, 2.1347826086957, 0.72391304347826, -0.0375
100561, 2.1565217391304, 0.75, -0.0375
100562, 2.1565217391304, 0.72391304347826, -0.01875
100563, 2.1782608695652, 0.72391304347826, -0.0375
100564, 1.2217391304348, 0.67173913043478, -0.0375
100565, 1.2434782608696, 0.69782608695652, -0.0375
100566, 1.2434782608696, 0.67173913043478, -0.01875
100567, 1.2652173913043, 0.67173913043478, -0.0375
100568, 1.2869565217391, 0.69782608695652, -0.0375
100569, 1.2869565217391, 0.67173913043478, -0.01875
100570, 1.3086956521739, 0.67173913043478, -0.0375
100571, 1.3304347826087, 0.69782608695652, -0.0375
100572, 1.3304347826087, 0.67173913043478, -0.01875
100573, 1.3521739130435, 0.67173913043478, -0.0375
100574, 1.3739130434783, 0.69782608695652, -0.0375
100575, 1.3739130434783, 0.67173913043478, -0.01875
100576, 1.395652173913, 0.67173913043478, -0.0375
100577, 1.4173913043478, 0.69782608695652, -0.0375
100578, 1.4173913043478, 0.67173913043478, -0.01875
100579, 1.4391304347826, 0.67173913043478, -0.0375
100580, 1.4608695652174, 0.69782608695652, -0.0375
100581, 1.4608695652174, 0.67173913043478, -0.01875
100582, 1.4826086956522, 0.67173913043478, -0.0375
100583, 1.504347826087, 0.69782608695652, -0.0375
100584, 1.504347826087, 0.67173913043478, -0.01875
100585, 1.5260869565217, 0.67173913043478, -0.0375
100586, 1.5478260869565, 0.69782608695652, -0.0375
100587, 1.5478260869565, 0.67173913043478, -0.01875
100588, 1.5695652173913, 0.67173913043478, -0.0375
100589, 1.5913043478261, 0.69782608695652, -0.0375
100590, 1.5913043478261, 0.67173913043478, -0.01875
100591, 1.6130434782609, 0.67173913043478, -0.0375
100592, 1.6347826086957, 0.69782608695652, -0.0375
100593, 1.6347826086957, 0.67173913043478, -0.01875
100594, 1.6565217391304, 0.67173913043478, -0.0375
100595, 1.6782608695652, 0.69782608695652, -0.0375
100596, 1.6782608695652, 0.67173913043478, -0.01875
100597, 1.7, 0.67173913043478, -0.0375
100598, 1.7217391304348, 0.69782608695652, -0.0375
100599, 1.7217391304348, 0.67173913043478, -0.01875
100600, 1.7434782608696, 0.67173913043478, -0.0375
100601, 1.7652173913043, 0.69782608695652, -0.0375
100602, 1.7652173913043, 0.67173913043478, -0.01875
100603, 1.7869565217391, 0.67173913043478, -0.0375
100604, 1.8086956521739, 0.69782608695652, -0.0375
100605, 1.8086956521739, 0.67173913043478, -0.01875
100606, 1.8304347826087, 0.67173913043478, -0.0375
100607, 1.8521739130435, 0.69782608695652, -0.0375
100608, 1.8521739130435, 0.67173913043478, -0.01875
100609, 1.8739130434783, 0.67173913043478, -0.0375
100610, 1.895652173913, 0.69782608695652, -0.0375
100611, 1.895652173913, 0.67173913043478, -0.01875
100612, 1.9173913043478, 0.67173913043478, -0.0375
100613, 1.9391304347826, 0.69782608695652, -0.0375
100614, 1.9391304347826, 0.67173913043478, -0.01875
100615, 1.9608695652174, 0.67173913043478, -0.0375
100616, 1.9826086956522, 0.69782608695652, -0.0375
100617, 1.9826086956522, 0.67173913043478, -0.01875
100618, 2.004347826087, 0.67173913043478, -0.0375
100619, 2.0260869565217, 0.69782608695652, -0.0375
100620, 2.0260869565217, 0.67173913043478, -0.01875
100621, 2.0478260869565, 0.67173913043478, -0.0375
100622, 2.0695652173913, 0.69782608695652, -0.0375
100623, 2.0695652173913, 0.67173913043478, -0.01875
100624, 2.0913043478261, 0.67173913043478, -0.0375
100625, 2.1130434782609, 0.69782608695652, -0.0375
100626, 2.1130434782609, 0.67173913043478, -0.01875
100627, 2.1347826086957, 0.67173913043478, -0.0375
100628, 2.1565217391304, 0.69782608695652, -0.0375
100629, 2.1565217391304, 0.67173913043478, -0.01875
100630, 2.1782608695652, 0.67173913043478, -0.0375
100631, 1.2217391304348, 0.6195652173913, -0.0375
100632, 1.2434782608696, 0.64565217391304, -0.0375
100633, 1.2434782608696, 0.6195652173913, -0.01875
100634, 1.2652173913043, 0.6195652173913, -0.0375
100635, 1.2869565217391, 0.64565217391304, -0.0375
100636, 1.2869565217391, 0.61956521739131, -0.01875
100637, 1.3086956521739, 0.61956521739131, -0.0375
100638, 1.3304347826087, 0.64565217391304, -0.0375
100639, 1.3304347826087, 0.61956521739131, -0.01875
100640, 1.3521739130435, 0.61956521739131, -0.0375
100641, 1.3739130434783, 0.64565217391304, -0.0375
100642, 1.3739130434783, 0.61956521739131, -0.01875
100643, 1.395652173913, 0.6195652173913, -0.0375
100644, 1.4173913043478, 0.64565217391304, -0.0375
100645, 1.4173913043478, 0.6195652173913, -0.01875
100646, 1.4391304347826, 0.6195652173913, -0.0375
100647, 1.4608695652174, 0.64565217391304, -0.0375
100648, 1.4608695652174, 0.6195652173913, -0.01875
100649, 1.4826086956522, 0.6195652173913, -0.0375
100650, 1.504347826087, 0.64565217391304, -0.0375
100651, 1.504347826087, 0.6195652173913, -0.01875
100652, 1.5260869565217, 0.6195652173913, -0.0375
100653, 1.5478260869565, 0.64565217391304, -0.0375
100654, 1.5478260869565, 0.6195652173913, -0.01875
100655, 1.5695652173913, 0.6195652173913, -0.0375
100656, 1.5913043478261, 0.64565217391304, -0.0375
100657, 1.5913043478261, 0.6195652173913, -0.01875
100658, 1.6130434782609, 0.6195652173913, -0.0375
100659, 1.6347826086957, 0.64565217391304, -0.0375
100660, 1.6347826086957, 0.6195652173913, -0.01875
100661, 1.6565217391304, 0.6195652173913, -0.0375
100662, 1.6782608695652, 0.64565217391304, -0.0375
100663, 1.6782608695652, 0.61956521739131, -0.01875
100664, 1.7, 0.61956521739131, -0.0375
100665, 1.7217391304348, 0.64565217391304, -0.0375
100666, 1.7217391304348, 0.61956521739131, -0.01875
100667, 1.7434782608696, 0.61956521739131, -0.0375
100668, 1.7652173913043, 0.64565217391304, -0.0375
100669, 1.7652173913043, 0.61956521739131, -0.01875
100670, 1.7869565217391, 0.6195652173913, -0.0375
100671, 1.8086956521739, 0.64565217391304, -0.0375
100672, 1.8086956521739, 0.6195652173913, -0.01875
100673, 1.8304347826087, 0.6195652173913, -0.0375
100674, 1.8521739130435, 0.64565217391304, -0.0375
100675, 1.8521739130435, 0.61956521739131, -0.01875
100676, 1.8739130434783, 0.6195652173913, -0.0375
100677, 1.895652173913, 0.64565217391304, -0.0375
100678, 1.895652173913, 0.61956521739131, -0.01875
100679, 1.9173913043478, 0.6195652173913, -0.0375
100680, 1.9391304347826, 0.64565217391304, -0.0375
100681, 1.9391304347826, 0.61956521739131, -0.01875
100682, 1.9608695652174, 0.6195652173913, -0.0375
100683, 1.9826086956522, 0.64565217391304, -0.0375
100684, 1.9826086956522, 0.61956521739131, -0.01875
100685, 2.004347826087, 0.6195652173913, -0.0375
100686, 2.0260869565217, 0.64565217391304, -0.0375
100687, 2.0260869565217, 0.6195652173913, -0.01875
100688, 2.0478260869565, 0.6195652173913, -0.0375
100689, 2.0695652173913, 0.64565217391304, -0.0375
100690, 2.0695652173913, 0.6195652173913, -0.01875
100691, 2.0913043478261, 0.6195652173913, -0.0375
100692, 2.1130434782609, 0.64565217391304, -0.0375
100693, 2.1130434782609, 0.6195652173913, -0.01875
100694, 2.1347826086957, 0.6195652173913, -0.0375
100695, 2.1565217391304, 0.64565217391304, -0.0375
100696, 2.1565217391304, 0.61956521739131, -0.01875
100697, 2.1782608695652, 0.6195652173913, -0.0375
100698, 1.2217391304348, 0.56739130434783, -0.0375
100699, 1.2434782608696, 0.59347826086957, -0.0375
100700, 1.2434782608696, 0.56739130434783, -0.01875
100701, 1.2652173913043, 0.56739130434783, -0.0375
100702, 1.2869565217391, 0.59347826086957, -0.0375
100703, 1.2869565217391, 0.56739130434783, -0.01875
100704, 1.3086956521739, 0.56739130434783, -0.0375
100705, 1.3304347826087, 0.59347826086957, -0.0375
100706, 1.3304347826087, 0.56739130434783, -0.01875
100707, 1.3521739130435, 0.56739130434783, -0.0375
100708, 1.3739130434783, 0.59347826086957, -0.0375
100709, 1.3739130434783, 0.56739130434783, -0.01875
100710, 1.395652173913, 0.56739130434783, -0.0375
100711, 1.4173913043478, 0.59347826086957, -0.0375
100712, 1.4173913043478, 0.56739130434783, -0.01875
100713, 1.4391304347826, 0.56739130434783, -0.0375
100714, 1.4608695652174, 0.59347826086957, -0.0375
100715, 1.4608695652174, 0.56739130434783, -0.01875
100716, 1.4826086956522, 0.56739130434783, -0.0375
100717, 1.504347826087, 0.59347826086957, -0.0375
100718, 1.504347826087, 0.56739130434783, -0.01875
100719, 1.5260869565217, 0.56739130434783, -0.0375
100720, 1.5478260869565, 0.59347826086957, -0.0375
100721, 1.5478260869565, 0.56739130434783, -0.01875
100722, 1.5695652173913, 0.56739130434783, -0.0375
100723, 1.5913043478261, 0.59347826086957, -0.0375
100724, 1.5913043478261, 0.56739130434783, -0.01875
100725, 1.6130434782609, 0.56739130434783, -0.0375
100726, 1.6347826086957, 0.59347826086957, -0.0375
100727, 1.6347826086957, 0.56739130434783, -0.01875
100728, 1.6565217391304, 0.56739130434783, -0.0375
100729, 1.6782608695652, 0.59347826086957, -0.0375
100730, 1.6782608695652, 0.56739130434783, -0.01875
100731, 1.7, 0.56739130434783, -0.0375
100732, 1.7217391304348, 0.59347826086957, -0.0375
100733, 1.7217391304348, 0.56739130434783, -0.01875
100734, 1.7434782608696, 0.56739130434783, -0.0375
100735, 1.7652173913043, 0.59347826086957, -0.0375
100736, 1.7652173913043, 0.56739130434783, -0.01875
100737, 1.7869565217391, 0.56739130434783, -0.0375
100738, 1.8086956521739, 0.59347826086957, -0.0375
100739, 1.8086956521739, 0.56739130434783, -0.01875
100740, 1.8304347826087, 0.56739130434783, -0.0375
100741, 1.8521739130435, 0.59347826086957, -0.0375
100742, 1.8521739130435, 0.56739130434783, -0.01875
100743, 1.8739130434783, 0.56739130434783, -0.0375
100744, 1.895652173913, 0.59347826086957, -0.0375
100745, 1.895652173913, 0.56739130434783, -0.01875
100746, 1.9173913043478, 0.56739130434783, -0.0375
100747, 1.9391304347826, 0.59347826086957, -0.0375
100748, 1.9391304347826, 0.56739130434783, -0.01875
100749, 1.9608695652174, 0.56739130434783, -0.0375
100750, 1.9826086956522, 0.59347826086957, -0.0375
100751, 1.9826086956522, 0.56739130434783, -0.01875
100752, 2.004347826087, 0.56739130434783, -0.0375
100753, 2.0260869565217, 0.59347826086957, -0.0375
100754, 2.0260869565217, 0.56739130434783, -0.01875
100755, 2.0478260869565, 0.56739130434783, -0.0375
100756, 2.0695652173913, 0.59347826086957, -0.0375
100757, 2.0695652173913, 0.56739130434783, -0.01875
100758, 2.0913043478261, 0.56739130434783, -0.0375
100759, 2.1130434782609, 0.59347826086957, -0.0375
100760, 2.1130434782609, 0.56739130434783, -0.01875
100761, 2.1347826086957, 0.56739130434783, -0.0375
100762, 2.1565217391304, 0.59347826086957, -0.0375
100763, 2.1565217391304, 0.56739130434783, -0.01875
100764, 2.1782608695652, 0.56739130434783, -0.0375
100765, 1.2217391304348, 0.51521739130435, -0.0375
100766, 1.2434782608696, 0.54130434782609, -0.0375
100767, 1.2434782608696, 0.51521739130435, -0.01875
100768, 1.2652173913043, 0.51521739130435, -0.0375
100769, 1.2869565217391, 0.54130434782609, -0.0375
100770, 1.2869565217391, 0.51521739130435, -0.01875
100771, 1.3086956521739, 0.51521739130435, -0.0375
100772, 1.3304347826087, 0.54130434782609, -0.0375
100773, 1.3304347826087, 0.51521739130435, -0.01875
100774, 1.3521739130435, 0.51521739130435, -0.0375
100775, 1.3739130434783, 0.54130434782609, -0.0375
100776, 1.3739130434783, 0.51521739130435, -0.01875
100777, 1.395652173913, 0.51521739130435, -0.0375
100778, 1.4173913043478, 0.54130434782609, -0.0375
100779, 1.4173913043478, 0.51521739130435, -0.01875
100780, 1.4391304347826, 0.51521739130435, -0.0375
100781, 1.4608695652174, 0.54130434782609, -0.0375
100782, 1.4608695652174, 0.51521739130435, -0.01875
100783, 1.4826086956522, 0.51521739130435, -0.0375
100784, 1.504347826087, 0.54130434782609, -0.0375
100785, 1.504347826087, 0.51521739130435, -0.01875
100786, 1.5260869565217, 0.51521739130435, -0.0375
100787, 1.5478260869565, 0.54130434782609, -0.0375
100788, 1.5478260869565, 0.51521739130435, -0.01875
100789, 1.5695652173913, 0.51521739130435, -0.0375
100790, 1.5913043478261, 0.54130434782609, -0.0375
100791, 1.5913043478261, 0.51521739130435, -0.01875
100792, 1.6130434782609, 0.51521739130435, -0.0375
100793, 1.6347826086957, 0.54130434782609, -0.0375
100794, 1.6347826086957, 0.51521739130435, -0.01875
100795, 1.6565217391304, 0.51521739130435, -0.0375
100796, 1.6782608695652, 0.54130434782609, -0.0375
100797, 1.6782608695652, 0.51521739130435, -0.01875
100798, 1.7, 0.51521739130435, -0.0375
100799, 1.7217391304348, 0.54130434782609, -0.0375
100800, 1.7217391304348, 0.51521739130435, -0.01875
100801, 1.7434782608696, 0.51521739130435, -0.0375
100802, 1.7652173913043, 0.54130434782609, -0.0375
100803, 1.7652173913043, 0.51521739130435, -0.01875
100804, 1.7869565217391, 0.51521739130435, -0.0375
100805, 1.8086956521739, 0.54130434782609, -0.0375
100806, 1.8086956521739, 0.51521739130435, -0.01875
100807, 1.8304347826087, 0.51521739130435, -0.0375
100808, 1.8521739130435, 0.54130434782609, -0.0375
100809, 1.8521739130435, 0.51521739130435, -0.01875
100810, 1.8739130434783, 0.51521739130435, -0.0375
100811, 1.895652173913, 0.54130434782609, -0.0375
100812, 1.895652173913, 0.51521739130435, -0.01875
100813, 1.9173913043478, 0.51521739130435, -0.0375
100814, 1.9391304347826, 0.54130434782609, -0.0375
100815, 1.9391304347826, 0.51521739130435, -0.01875
100816, 1.9608695652174, 0.51521739130435, -0.0375
100817, 1.9826086956522, 0.54130434782609, -0.0375
100818, 1.9826086956522, 0.51521739130435, -0.01875
100819, 2.004347826087, 0.51521739130435, -0.0375
100820, 2.0260869565217, 0.54130434782609, -0.0375
100821, 2.0260869565217, 0.51521739130435, -0.01875
100822, 2.0478260869565, 0.51521739130435, -0.0375
100823, 2.0695652173913, 0.54130434782609, -0.0375
100824, 2.0695652173913, 0.51521739130435, -0.01875
100825, 2.0913043478261, 0.51521739130435, -0.0375
100826, 2.1130434782609, 0.54130434782609, -0.0375
100827, 2.1130434782609, 0.51521739130435, -0.01875
100828, 2.1347826086957, 0.51521739130435, -0.0375
100829, 2.1565217391304, 0.54130434782609, -0.0375
100830, 2.1565217391304, 0.51521739130435, -0.01875
100831, 2.1782608695652, 0.51521739130435, -0.0375
100832, 1.2217391304348, 0.46304347826087, -0.0375
100833, 1.2434782608696, 0.48913043478261, -0.0375
100834, 1.2434782608696, 0.46304347826087, -0.01875
100835, 1.2652173913043, 0.46304347826087, -0.0375
100836, 1.2869565217391, 0.48913043478261, -0.0375
100837, 1.2869565217391, 0.46304347826087, -0.01875
100838, 1.3086956521739, 0.46304347826087, -0.0375
100839, 1.3304347826087, 0.48913043478261, -0.0375
100840, 1.3304347826087, 0.46304347826087, -0.01875
100841, 1.3521739130435, 0.46304347826087, -0.0375
100842, 1.3739130434783, 0.48913043478261, -0.0375
100843, 1.3739130434783, 0.46304347826087, -0.01875
100844, 1.395652173913, 0.46304347826087, -0.0375
100845, 1.4173913043478, 0.48913043478261, -0.0375
100846, 1.4173913043478, 0.46304347826087, -0.01875
100847, 1.4391304347826, 0.46304347826087, -0.0375
100848, 1.4608695652174, 0.48913043478261, -0.0375
100849, 1.4608695652174, 0.46304347826087, -0.01875
100850, 1.4826086956522, 0.46304347826087, -0.0375
100851, 1.504347826087, 0.48913043478261, -0.0375
100852, 1.504347826087, 0.46304347826087, -0.01875
100853, 1.5260869565217, 0.46304347826087, -0.0375
100854, 1.5478260869565, 0.48913043478261, -0.0375
100855, 1.5478260869565, 0.46304347826087, -0.01875
100856, 1.5695652173913, 0.46304347826087, -0.0375
100857, 1.5913043478261, 0.48913043478261, -0.0375
100858, 1.5913043478261, 0.46304347826087, -0.01875
100859, 1.6130434782609, 0.46304347826087, -0.0375
100860, 1.6347826086957, 0.48913043478261, -0.0375
100861, 1.6347826086957, 0.46304347826087, -0.01875
100862, 1.6565217391304, 0.46304347826087, -0.0375
100863, 1.6782608695652, 0.48913043478261, -0.0375
100864, 1.6782608695652, 0.46304347826087, -0.01875
100865, 1.7, 0.46304347826087, -0.0375
100866, 1.7217391304348, 0.48913043478261, -0.0375
100867, 1.7217391304348, 0.46304347826087, -0.01875
100868, 1.7434782608696, 0.46304347826087, -0.0375
100869, 1.7652173913043, 0.48913043478261, -0.0375
100870, 1.7652173913043, 0.46304347826087, -0.01875
100871, 1.7869565217391, 0.46304347826087, -0.0375
100872, 1.8086956521739, 0.48913043478261, -0.0375
100873, 1.8086956521739, 0.46304347826087, -0.01875
100874, 1.8304347826087, 0.46304347826087, -0.0375
100875, 1.8521739130435, 0.48913043478261, -0.0375
100876, 1.8521739130435, 0.46304347826087, -0.01875
100877, 1.8739130434783, 0.46304347826087, -0.0375
100878, 1.895652173913, 0.48913043478261, -0.0375
100879, 1.895652173913, 0.46304347826087, -0.01875
100880, 1.9173913043478, 0.46304347826087, -0.0375
100881, 1.9391304347826, 0.48913043478261, -0.0375
100882, 1.9391304347826, 0.46304347826087, -0.01875
100883, 1.9608695652174, 0.46304347826087, -0.0375
100884, 1.9826086956522, 0.48913043478261, -0.0375
100885, 1.9826086956522, 0.46304347826087, -0.01875
100886, 2.004347826087, 0.46304347826087, -0.0375
100887, 2.0260869565217, 0.48913043478261, -0.0375
100888, 2.0260869565217, 0.46304347826087, -0.01875
100889, 2.0478260869565, 0.46304347826087, -0.0375
100890, 2.0695652173913, 0.48913043478261, -0.0375
100891, 2.0695652173913, 0.46304347826087, -0.01875
100892, 2.0913043478261, 0.46304347826087, -0.0375
100893, 2.1130434782609, 0.48913043478261, -0.0375
100894, 2.1130434782609, 0.46304347826087, -0.01875
100895, 2.1347826086957, 0.46304347826087, -0.0375
100896, 2.1565217391304, 0.48913043478261, -0.0375
100897, 2.1565217391304, 0.46304347826087, -0.01875
100898, 2.1782608695652, 0.46304347826087, -0.0375
100899, 1.2217391304348, 0.41086956521739, -0.0375
100900, 1.2434782608696, 0.43695652173913, -0.0375
100901, 1.2434782608696, 0.41086956521739, -0.01875
100902, 1.2652173913043, 0.41086956521739, -0.0375
100903, 1.2869565217391, 0.43695652173913, -0.0375
100904, 1.2869565217391, 0.41086956521739, -0.01875
100905, 1.3086956521739, 0.41086956521739, -0.0375
100906, 1.3304347826087, 0.43695652173913, -0.0375
100907, 1.3304347826087, 0.41086956521739, -0.01875
100908, 1.3521739130435, 0.41086956521739, -0.0375
100909, 1.3739130434783, 0.43695652173913, -0.0375
100910, 1.3739130434783, 0.41086956521739, -0.01875
100911, 1.395652173913, 0.41086956521739, -0.0375
100912, 1.4173913043478, 0.43695652173913, -0.0375
100913, 1.4173913043478, 0.41086956521739, -0.01875
100914, 1.4391304347826, 0.41086956521739, -0.0375
100915, 1.4608695652174, 0.43695652173913, -0.0375
100916, 1.4608695652174, 0.41086956521739, -0.01875
100917, 1.4826086956522, 0.41086956521739, -0.0375
100918, 1.504347826087, 0.43695652173913, -0.0375
100919, 1.504347826087, 0.41086956521739, -0.01875
100920, 1.5260869565217, 0.41086956521739, -0.0375
100921, 1.5478260869565, 0.43695652173913, -0.0375
100922, 1.5478260869565, 0.41086956521739, -0.01875
100923, 1.5695652173913, 0.41086956521739, -0.0375
100924, 1.5913043478261, 0.43695652173913, -0.0375
100925, 1.5913043478261, 0.41086956521739, -0.01875
100926, 1.6130434782609, 0.41086956521739, -0.0375
100927, 1.6347826086957, 0.43695652173913, -0.0375
100928, 1.6347826086957, 0.41086956521739, -0.01875
100929, 1.6565217391304, 0.41086956521739, -0.0375
100930, 1.6782608695652, 0.43695652173913, -0.0375
100931, 1.6782608695652, 0.41086956521739, -0.01875
100932, 1.7, 0.41086956521739, -0.0375
100933, 1.7217391304348, 0.43695652173913, -0.0375
100934, 1.7217391304348, 0.41086956521739, -0.01875
100935, 1.7434782608696, 0.41086956521739, -0.0375
100936, 1.7652173913043, 0.43695652173913, -0.0375
100937, 1.7652173913043, 0.41086956521739, -0.01875
100938, 1.7869565217391, 0.41086956521739, -0.0375
100939, 1.8086956521739, 0.43695652173913, -0.0375
100940, 1.8086956521739, 0.41086956521739, -0.01875
100941, 1.8304347826087, 0.41086956521739, -0.0375
100942, 1.8521739130435, 0.43695652173913, -0.0375
100943, 1.8521739130435, 0.41086956521739, -0.01875
100944, 1.8739130434783, 0.41086956521739, -0.0375
100945, 1.895652173913, 0.43695652173913, -0.0375
100946, 1.895652173913, 0.41086956521739, -0.01875
100947, 1.9173913043478, 0.41086956521739, -0.0375
100948, 1.9391304347826, 0.43695652173913, -0.0375
100949, 1.9391304347826, 0.41086956521739, -0.01875
100950, 1.9608695652174, 0.41086956521739, -0.0375
100951, 1.9826086956522, 0.43695652173913, -0.0375
100952, 1.9826086956522, 0.41086956521739, -0.01875
100953, 2.004347826087, 0.41086956521739, -0.0375
100954, 2.0260869565217, 0.43695652173913, -0.0375
100955, 2.0260869565217, 0.41086956521739, -0.01875
100956, 2.0478260869565, 0.41086956521739, -0.0375
100957, 2.0695652173913, 0.43695652173913, -0.0375
100958, 2.0695652173913, 0.41086956521739, -0.01875
100959, 2.0913043478261, 0.41086956521739, -0.0375
100960, 2.1130434782609, 0.43695652173913, -0.0375
100961, 2.1130434782609, 0.41086956521739, -0.01875
100962, 2.1347826086957, 0.41086956521739, -0.0375
100963, 2.1565217391304, 0.43695652173913, -0.0375
100964, 2.1565217391304, 0.41086956521739, -0.01875
100965, 2.1782608695652, 0.41086956521739, -0.0375
100966, 1.2217391304348, 0.35869565217391, -0.0375
100967, 1.2434782608696, 0.38478260869565, -0.0375
100968, 1.2434782608696, 0.35869565217391, -0.01875
100969, 1.2652173913043, 0.35869565217391, -0.0375
100970, 1.2869565217391, 0.38478260869565, -0.0375
100971, 1.2869565217391, 0.35869565217391, -0.01875
100972, 1.3086956521739, 0.35869565217391, -0.0375
100973, 1.3304347826087, 0.38478260869565, -0.0375
100974, 1.3304347826087, 0.35869565217391, -0.01875
100975, 1.3521739130435, 0.35869565217391, -0.0375
100976, 1.3739130434783, 0.38478260869565, -0.0375
100977, 1.3739130434783, 0.35869565217391, -0.01875
100978, 1.395652173913, 0.35869565217391, -0.0375
100979, 1.4173913043478, 0.38478260869565, -0.0375
100980, 1.4173913043478, 0.35869565217391, -0.01875
100981, 1.4391304347826, 0.35869565217391, -0.0375
100982, 1.4608695652174, 0.38478260869565, -0.0375
100983, 1.4608695652174, 0.35869565217391, -0.01875
100984, 1.4826086956522, 0.35869565217391, -0.0375
100985, 1.504347826087, 0.38478260869565, -0.0375
100986, 1.504347826087, 0.35869565217391, -0.01875
100987, 1.5260869565217, 0.35869565217391, -0.0375
100988, 1.5478260869565, 0.38478260869565, -0.0375
100989, 1.5478260869565, 0.35869565217391, -0.01875
100990, 1.5695652173913, 0.35869565217391, -0.0375
100991, 1.5913043478261, 0.38478260869565, -0.0375
100992, 1.5913043478261, 0.35869565217391, -0.01875
100993, 1.6130434782609, 0.35869565217391, -0.0375
100994, 1.6347826086957, 0.38478260869565, -0.0375
100995, 1.6347826086957, 0.35869565217391, -0.01875
100996, 1.6565217391304, 0.35869565217391, -0.0375
100997, 1.6782608695652, 0.38478260869565, -0.0375
100998, 1.6782608695652, 0.35869565217391, -0.01875
100999, 1.7, 0.35869565217391, -0.0375
101000, 1.7217391304348, 0.38478260869565, -0.0375
101001, 1.7217391304348, 0.35869565217391, -0.01875
101002, 1.7434782608696, 0.35869565217391, -0.0375
101003, 1.7652173913043, 0.38478260869565, -0.0375
101004, 1.7652173913043, 0.35869565217391, -0.01875
101005, 1.7869565217391, 0.35869565217391, -0.0375
101006, 1.8086956521739, 0.38478260869565, -0.0375
101007, 1.8086956521739, 0.35869565217391, -0.01875
101008, 1.8304347826087, 0.35869565217391, -0.0375
101009, 1.8521739130435, 0.38478260869565, -0.0375
101010, 1.8521739130435, 0.35869565217391, -0.01875
101011, 1.8739130434783, 0.35869565217391, -0.0375
101012, 1.895652173913, 0.38478260869565, -0.0375
101013, 1.895652173913, 0.35869565217391, -0.01875
101014, 1.9173913043478, 0.35869565217391, -0.0375
101015, 1.9391304347826, 0.38478260869565, -0.0375
101016, 1.9391304347826, 0.35869565217391, -0.01875
101017, 1.9608695652174, 0.35869565217391, -0.0375
101018, 1.9826086956522, 0.38478260869565, -0.0375
101019, 1.9826086956522, 0.35869565217391, -0.01875
101020, 2.004347826087, 0.35869565217391, -0.0375
101021, 2.0260869565217, 0.38478260869565, -0.0375
101022, 2.0260869565217, 0.35869565217391, -0.01875
101023, 2.0478260869565, 0.35869565217391, -0.0375
101024, 2.0695652173913, 0.38478260869565, -0.0375
101025, 2.0695652173913, 0.35869565217391, -0.01875
101026, 2.0913043478261, 0.35869565217391, -0.0375
101027, 2.1130434782609, 0.38478260869565, -0.0375
101028, 2.1130434782609, 0.35869565217391, -0.01875
101029, 2.1347826086957, 0.35869565217391, -0.0375
101030, 2.1565217391304, 0.38478260869565, -0.0375
101031, 2.1565217391304, 0.35869565217391, -0.01875
101032, 2.1782608695652, 0.35869565217391, -0.0375
101033, 1.2217391304348, 0.30652173913044, -0.0375
101034, 1.2434782608696, 0.33260869565217, -0.0375
101035, 1.2434782608696, 0.30652173913044, -0.01875
101036, 1.2652173913043, 0.30652173913044, -0.0375
101037, 1.2869565217391, 0.33260869565217, -0.0375
101038, 1.2869565217391, 0.30652173913043, -0.01875
101039, 1.3086956521739, 0.30652173913043, -0.0375
101040, 1.3304347826087, 0.33260869565217, -0.0375
101041, 1.3304347826087, 0.30652173913043, -0.01875
101042, 1.3521739130435, 0.30652173913044, -0.0375
101043, 1.3739130434783, 0.33260869565217, -0.0375
101044, 1.3739130434783, 0.30652173913044, -0.01875
101045, 1.395652173913, 0.30652173913044, -0.0375
101046, 1.4173913043478, 0.33260869565217, -0.0375
101047, 1.4173913043478, 0.30652173913044, -0.01875
101048, 1.4391304347826, 0.30652173913044, -0.0375
101049, 1.4608695652174, 0.33260869565217, -0.0375
101050, 1.4608695652174, 0.30652173913043, -0.01875
101051, 1.4826086956522, 0.30652173913044, -0.0375
101052, 1.504347826087, 0.33260869565217, -0.0375
101053, 1.504347826087, 0.30652173913044, -0.01875
101054, 1.5260869565217, 0.30652173913044, -0.0375
101055, 1.5478260869565, 0.33260869565217, -0.0375
101056, 1.5478260869565, 0.30652173913044, -0.01875
101057, 1.5695652173913, 0.30652173913044, -0.0375
101058, 1.5913043478261, 0.33260869565217, -0.0375
101059, 1.5913043478261, 0.30652173913044, -0.01875
101060, 1.6130434782609, 0.30652173913044, -0.0375
101061, 1.6347826086957, 0.33260869565217, -0.0375
101062, 1.6347826086957, 0.30652173913043, -0.01875
101063, 1.6565217391304, 0.30652173913043, -0.0375
101064, 1.6782608695652, 0.33260869565217, -0.0375
101065, 1.6782608695652, 0.30652173913043, -0.01875
101066, 1.7, 0.30652173913043, -0.0375
101067, 1.7217391304348, 0.33260869565217, -0.0375
101068, 1.7217391304348, 0.30652173913043, -0.01875
101069, 1.7434782608696, 0.30652173913043, -0.0375
101070, 1.7652173913043, 0.33260869565217, -0.0375
101071, 1.7652173913043, 0.30652173913043, -0.01875
101072, 1.7869565217391, 0.30652173913044, -0.0375
101073, 1.8086956521739, 0.33260869565217, -0.0375
101074, 1.8086956521739, 0.30652173913044, -0.01875
101075, 1.8304347826087, 0.30652173913044, -0.0375
101076, 1.8521739130435, 0.33260869565217, -0.0375
101077, 1.8521739130435, 0.30652173913043, -0.01875
101078, 1.8739130434783, 0.30652173913043, -0.0375
101079, 1.895652173913, 0.33260869565217, -0.0375
101080, 1.895652173913, 0.30652173913044, -0.01875
101081, 1.9173913043478, 0.30652173913044, -0.0375
101082, 1.9391304347826, 0.33260869565217, -0.0375
101083, 1.9391304347826, 0.30652173913043, -0.01875
101084, 1.9608695652174, 0.30652173913044, -0.0375
101085, 1.9826086956522, 0.33260869565217, -0.0375
101086, 1.9826086956522, 0.30652173913044, -0.01875
101087, 2.004347826087, 0.30652173913044, -0.0375
101088, 2.0260869565217, 0.33260869565217, -0.0375
101089, 2.0260869565217, 0.30652173913044, -0.01875
101090, 2.0478260869565, 0.30652173913044, -0.0375
101091, 2.0695652173913, 0.33260869565217, -0.0375
101092, 2.0695652173913, 0.30652173913043, -0.01875
101093, 2.0913043478261, 0.30652173913043, -0.0375
101094, 2.1130434782609, 0.33260869565217, -0.0375
101095, 2.1130434782609, 0.30652173913043, -0.01875
101096, 2.1347826086957, 0.30652173913043, -0.0375
101097, 2.1565217391304, 0.33260869565217, -0.0375
101098, 2.1565217391304, 0.30652173913043, -0.01875
101099, 2.1782608695652, 0.30652173913044, -0.0375
101100, 1.2217391304348, 0.25434782608696, -0.0375
101101, 1.2434782608696, 0.2804347826087, -0.0375
101102, 1.2434782608696, 0.25434782608696, -0.01875
101103, 1.2652173913043, 0.25434782608696, -0.0375
101104, 1.2869565217391, 0.2804347826087, -0.0375
101105, 1.2869565217391, 0.25434782608696, -0.01875
101106, 1.3086956521739, 0.25434782608696, -0.0375
101107, 1.3304347826087, 0.2804347826087, -0.0375
101108, 1.3304347826087, 0.25434782608696, -0.01875
101109, 1.3521739130435, 0.25434782608696, -0.0375
101110, 1.3739130434783, 0.2804347826087, -0.0375
101111, 1.3739130434783, 0.25434782608696, -0.01875
101112, 1.395652173913, 0.25434782608696, -0.0375
101113, 1.4173913043478, 0.2804347826087, -0.0375
101114, 1.4173913043478, 0.25434782608696, -0.01875
101115, 1.4391304347826, 0.25434782608696, -0.0375
101116, 1.4608695652174, 0.2804347826087, -0.0375
101117, 1.4608695652174, 0.25434782608696, -0.01875
101118, 1.4826086956522, 0.25434782608696, -0.0375
101119, 1.504347826087, 0.2804347826087, -0.0375
101120, 1.504347826087, 0.25434782608696, -0.01875
101121, 1.5260869565217, 0.25434782608696, -0.0375
101122, 1.5478260869565, 0.2804347826087, -0.0375
101123, 1.5478260869565, 0.25434782608696, -0.01875
101124, 1.5695652173913, 0.25434782608696, -0.0375
101125, 1.5913043478261, 0.2804347826087, -0.0375
101126, 1.5913043478261, 0.25434782608696, -0.01875
101127, 1.6130434782609, 0.25434782608696, -0.0375
101128, 1.6347826086957, 0.2804347826087, -0.0375
101129, 1.6347826086957, 0.25434782608696, -0.01875
101130, 1.6565217391304, 0.25434782608696, -0.0375
101131, 1.6782608695652, 0.2804347826087, -0.0375
101132, 1.6782608695652, 0.25434782608696, -0.01875
101133, 1.7, 0.25434782608696, -0.0375
101134, 1.7217391304348, 0.2804347826087, -0.0375
101135, 1.7217391304348, 0.25434782608696, -0.01875
101136, 1.7434782608696, 0.25434782608696, -0.0375
101137, 1.7652173913043, 0.2804347826087, -0.0375
101138, 1.7652173913043, 0.25434782608696, -0.01875
101139, 1.7869565217391, 0.25434782608696, -0.0375
101140, 1.8086956521739, 0.2804347826087, -0.0375
101141, 1.8086956521739, 0.25434782608696, -0.01875
101142, 1.8304347826087, 0.25434782608696, -0.0375
101143, 1.8521739130435, 0.2804347826087, -0.0375
101144, 1.8521739130435, 0.25434782608696, -0.01875
101145, 1.8739130434783, 0.25434782608696, -0.0375
101146, 1.895652173913, 0.2804347826087, -0.0375
101147, 1.895652173913, 0.25434782608696, -0.01875
101148, 1.9173913043478, 0.25434782608696, -0.0375
101149, 1.9391304347826, 0.2804347826087, -0.0375
101150, 1.9391304347826, 0.25434782608696, -0.01875
101151, 1.9608695652174, 0.25434782608696, -0.0375
101152, 1.9826086956522, 0.2804347826087, -0.0375
101153, 1.9826086956522, 0.25434782608696, -0.01875
101154, 2.004347826087, 0.25434782608696, -0.0375
101155, 2.0260869565217, 0.2804347826087, -0.0375
101156, 2.0260869565217, 0.25434782608696, -0.01875
101157, 2.0478260869565, 0.25434782608696, -0.0375
101158, 2.0695652173913, 0.2804347826087, -0.0375
101159, 2.0695652173913, 0.25434782608696, -0.01875
101160, 2.0913043478261, 0.25434782608696, -0.0375
101161, 2.1130434782609, 0.2804347826087, -0.0375
101162, 2.1130434782609, 0.25434782608696, -0.01875
101163, 2.1347826086957, 0.25434782608696, -0.0375
101164, 2.1565217391304, 0.2804347826087, -0.0375
101165, 2.1565217391304, 0.25434782608696, -0.01875
101166, 2.1782608695652, 0.25434782608696, -0.0375
101167, 1.2217391304348, 0.20217391304348, -0.0375
101168, 1.2434782608696, 0.22826086956522, -0.0375
101169, 1.2434782608696, 0.20217391304348, -0.01875
101170, 1.2652173913043, 0.20217391304348, -0.0375
101171, 1.2869565217391, 0.22826086956522, -0.0375
101172, 1.2869565217391, 0.20217391304348, -0.01875
101173, 1.3086956521739, 0.20217391304348, -0.0375
101174, 1.3304347826087, 0.22826086956522, -0.0375
101175, 1.3304347826087, 0.20217391304348, -0.01875
101176, 1.3521739130435, 0.20217391304348, -0.0375
101177, 1.3739130434783, 0.22826086956522, -0.0375
101178, 1.3739130434783, 0.20217391304348, -0.01875
101179, 1.395652173913, 0.20217391304348, -0.0375
101180, 1.4173913043478, 0.22826086956522, -0.0375
101181, 1.4173913043478, 0.20217391304348, -0.01875
101182, 1.4391304347826, 0.20217391304348, -0.0375
101183, 1.4608695652174, 0.22826086956522, -0.0375
101184, 1.4608695652174, 0.20217391304348, -0.01875
101185, 1.4826086956522, 0.20217391304348, -0.0375
101186, 1.504347826087, 0.22826086956522, -0.0375
101187, 1.504347826087, 0.20217391304348, -0.01875
101188, 1.5260869565217, 0.20217391304348, -0.0375
101189, 1.5478260869565, 0.22826086956522, -0.0375
101190, 1.5478260869565, 0.20217391304348, -0.01875
101191, 1.5695652173913, 0.20217391304348, -0.0375
101192, 1.5913043478261, 0.22826086956522, -0.0375
101193, 1.5913043478261, 0.20217391304348, -0.01875
101194, 1.6130434782609, 0.20217391304348, -0.0375
101195, 1.6347826086957, 0.22826086956522, -0.0375
101196, 1.6347826086957, 0.20217391304348, -0.01875
101197, 1.6565217391304, 0.20217391304348, -0.0375
101198, 1.6782608695652, 0.22826086956522, -0.0375
101199, 1.6782608695652, 0.20217391304348, -0.01875
101200, 1.7, 0.20217391304348, -0.0375
101201, 1.7217391304348, 0.22826086956522, -0.0375
101202, 1.7217391304348, 0.20217391304348, -0.01875
101203, 1.7434782608696, 0.20217391304348, -0.0375
101204, 1.7652173913043, 0.22826086956522, -0.0375
101205, 1.7652173913043, 0.20217391304348, -0.01875
101206, 1.7869565217391, 0.20217391304348, -0.0375
101207, 1.8086956521739, 0.22826086956522, -0.0375
101208, 1.8086956521739, 0.20217391304348, -0.01875
101209, 1.8304347826087, 0.20217391304348, -0.0375
101210, 1.8521739130435, 0.22826086956522, -0.0375
101211, 1.8521739130435, 0.20217391304348, -0.01875
101212, 1.8739130434783, 0.20217391304348, -0.0375
101213, 1.895652173913, 0.22826086956522, -0.0375
101214, 1.895652173913, 0.20217391304348, -0.01875
101215, 1.9173913043478, 0.20217391304348, -0.0375
101216, 1.9391304347826, 0.22826086956522, -0.0375
101217, 1.9391304347826, 0.20217391304348, -0.01875
101218, 1.9608695652174, 0.20217391304348, -0.0375
101219, 1.9826086956522, 0.22826086956522, -0.0375
101220, 1.9826086956522, 0.20217391304348, -0.01875
101221, 2.004347826087, 0.20217391304348, -0.0375
101222, 2.0260869565217, 0.22826086956522, -0.0375
101223, 2.0260869565217, 0.20217391304348, -0.01875
101224, 2.0478260869565, 0.20217391304348, -0.0375
101225, 2.0695652173913, 0.22826086956522, -0.0375
101226, 2.0695652173913, 0.20217391304348, -0.01875
101227, 2.0913043478261, 0.20217391304348, -0.0375
101228, 2.1130434782609, 0.22826086956522, -0.0375
101229, 2.1130434782609, 0.20217391304348, -0.01875
101230, 2.1347826086957, 0.20217391304348, -0.0375
101231, 2.1565217391304, 0.22826086956522, -0.0375
101232, 2.1565217391304, 0.20217391304348, -0.01875
101233, 2.1782608695652, 0.20217391304348, -0.0375
101234, 1.2434782608696, 0.17608695652174, -0.0375
101235, 1.2869565217391, 0.17608695652174, -0.0375
101236, 1.3304347826087, 0.17608695652174, -0.0375
101237, 1.3739130434783, 0.17608695652174, -0.0375
101238, 1.4173913043478, 0.17608695652174, -0.0375
101239, 1.4608695652174, 0.17608695652174, -0.0375
101240, 1.504347826087, 0.17608695652174, -0.0375
101241, 1.5478260869565, 0.17608695652174, -0.0375
101242, 1.5913043478261, 0.17608695652174, -0.0375
101243, 1.6347826086957, 0.17608695652174, -0.0375
101244, 1.6782608695652, 0.17608695652174, -0.0375
101245, 1.7217391304348, 0.17608695652174, -0.0375
101246, 1.7652173913043, 0.17608695652174, -0.0375
101247, 1.8086956521739, 0.17608695652174, -0.0375
101248, 1.8521739130435, 0.17608695652174, -0.0375
101249, 1.895652173913, 0.17608695652174, -0.0375
101250, 1.9391304347826, 0.17608695652174, -0.0375
101251, 1.9826086956522, 0.17608695652174, -0.0375
101252, 2.0260869565217, 0.17608695652174, -0.0375
101253, 2.0695652173913, 0.17608695652174, -0.0375
101254, 2.1130434782609, 0.17608695652174, -0.0375
101255, 2.1565217391304, 0.17608695652174, -0.0375
101256, 1.2434782608696, 1.2978260869565, -0.05625
101257, 1.2869565217391, 1.2978260869565, -0.05625
101258, 1.3304347826087, 1.2978260869565, -0.05625
101259, 1.3739130434783, 1.2978260869565, -0.05625
101260, 1.4173913043478, 1.2978260869565, -0.05625
101261, 1.4608695652174, 1.2978260869565, -0.05625
101262, 1.504347826087, 1.2978260869565, -0.05625
101263, 1.5478260869565, 1.2978260869565, -0.05625
101264, 1.5913043478261, 1.2978260869565, -0.05625
101265, 1.6347826086957, 1.2978260869565, -0.05625
101266, 1.6782608695652, 1.2978260869565, -0.05625
101267, 1.7217391304348, 1.2978260869565, -0.05625
101268, 1.7652173913043, 1.2978260869565, -0.05625
101269, 1.8086956521739, 1.2978260869565, -0.05625
101270, 1.8521739130435, 1.2978260869565, -0.05625
101271, 1.895652173913, 1.2978260869565, -0.05625
101272, 1.9391304347826, 1.2978260869565, -0.05625
101273, 1.9826086956522, 1.2978260869565, -0.05625
101274, 2.0260869565217, 1.2978260869565, -0.05625
101275, 2.0695652173913, 1.2978260869565, -0.05625
101276, 2.1130434782609, 1.2978260869565, -0.05625
101277, 2.1565217391304, 1.2978260869565, -0.05625
101278, 1.2434782608696, 1.245652173913, -0.05625
101279, 1.2869565217391, 1.245652173913, -0.05625
101280, 1.3304347826087, 1.245652173913, -0.05625
101281, 1.3739130434783, 1.245652173913, -0.05625
101282, 1.4173913043478, 1.245652173913, -0.05625
101283, 1.4608695652174, 1.245652173913, -0.05625
101284, 1.504347826087, 1.245652173913, -0.05625
101285, 1.5478260869565, 1.245652173913, -0.05625
101286, 1.5913043478261, 1.245652173913, -0.05625
101287, 1.6347826086957, 1.245652173913, -0.05625
101288, 1.6782608695652, 1.245652173913, -0.05625
101289, 1.7217391304348, 1.245652173913, -0.05625
101290, 1.7652173913043, 1.245652173913, -0.05625
101291, 1.8086956521739, 1.245652173913, -0.05625
101292, 1.8521739130435, 1.245652173913, -0.05625
101293, 1.895652173913, 1.245652173913, -0.05625
101294, 1.9391304347826, 1.245652173913, -0.05625
101295, 1.9826086956522, 1.245652173913, -0.05625
101296, 2.0260869565217, 1.245652173913, -0.05625
101297, 2.0695652173913, 1.245652173913, -0.05625
101298, 2.1130434782609, 1.245652173913, -0.05625
101299, 2.1565217391304, 1.245652173913, -0.05625
101300, 1.2434782608696, 1.1934782608696, -0.05625
101301, 1.2869565217391, 1.1934782608696, -0.05625
101302, 1.3304347826087, 1.1934782608696, -0.05625
101303, 1.3739130434783, 1.1934782608696, -0.05625
101304, 1.4173913043478, 1.1934782608696, -0.05625
101305, 1.4608695652174, 1.1934782608696, -0.05625
101306, 1.504347826087, 1.1934782608696, -0.05625
101307, 1.5478260869565, 1.1934782608696, -0.05625
101308, 1.5913043478261, 1.1934782608696, -0.05625
101309, 1.6347826086957, 1.1934782608696, -0.05625
101310, 1.6782608695652, 1.1934782608696, -0.05625
101311, 1.7217391304348, 1.1934782608696, -0.05625
101312, 1.7652173913043, 1.1934782608696, -0.05625
101313, 1.8086956521739, 1.1934782608696, -0.05625
101314, 1.8521739130435, 1.1934782608696, -0.05625
101315, 1.895652173913, 1.1934782608696, -0.05625
101316, 1.9391304347826, 1.1934782608696, -0.05625
101317, 1.9826086956522, 1.1934782608696, -0.05625
101318, 2.0260869565217, 1.1934782608696, -0.05625
101319, 2.0695652173913, 1.1934782608696, -0.05625
101320, 2.1130434782609, 1.1934782608696, -0.05625
101321, 2.1565217391304, 1.1934782608696, -0.05625
101322, 1.2434782608696, 1.1413043478261, -0.05625
101323, 1.2869565217391, 1.1413043478261, -0.05625
101324, 1.3304347826087, 1.1413043478261, -0.05625
101325, 1.3739130434783, 1.1413043478261, -0.05625
101326, 1.4173913043478, 1.1413043478261, -0.05625
101327, 1.4608695652174, 1.1413043478261, -0.05625
101328, 1.504347826087, 1.1413043478261, -0.05625
101329, 1.5478260869565, 1.1413043478261, -0.05625
101330, 1.5913043478261, 1.1413043478261, -0.05625
101331, 1.6347826086957, 1.1413043478261, -0.05625
101332, 1.6782608695652, 1.1413043478261, -0.05625
101333, 1.7217391304348, 1.1413043478261, -0.05625
101334, 1.7652173913043, 1.1413043478261, -0.05625
101335, 1.8086956521739, 1.1413043478261, -0.05625
101336, 1.8521739130435, 1.1413043478261, -0.05625
101337, 1.895652173913, 1.1413043478261, -0.05625
101338, 1.9391304347826, 1.1413043478261, -0.05625
101339, 1.9826086956522, 1.1413043478261, -0.05625
101340, 2.0260869565217, 1.1413043478261, -0.05625
101341, 2.0695652173913, 1.1413043478261, -0.05625
101342, 2.1130434782609, 1.1413043478261, -0.05625
101343, 2.1565217391304, 1.1413043478261, -0.05625
101344, 1.2434782608696, 1.0891304347826, -0.05625
101345, 1.2869565217391, 1.0891304347826, -0.05625
101346, 1.3304347826087, 1.0891304347826, -0.05625
101347, 1.3739130434783, 1.0891304347826, -0.05625
101348, 1.4173913043478, 1.0891304347826, -0.05625
101349, 1.4608695652174, 1.0891304347826, -0.05625
101350, 1.504347826087, 1.0891304347826, -0.05625
101351, 1.5478260869565, 1.0891304347826, -0.05625
101352, 1.5913043478261, 1.0891304347826, -0.05625
101353, 1.6347826086957, 1.0891304347826, -0.05625
101354, 1.6782608695652, 1.0891304347826, -0.05625
101355, 1.7217391304348, 1.0891304347826, -0.05625
101356, 1.7652173913043, 1.0891304347826, -0.05625
101357, 1.8086956521739, 1.0891304347826, -0.05625
101358, 1.8521739130435, 1.0891304347826, -0.05625
101359, 1.895652173913, 1.0891304347826, -0.05625
101360, 1.9391304347826, 1.0891304347826, -0.05625
101361, 1.9826086956522, 1.0891304347826, -0.05625
101362, 2.0260869565217, 1.0891304347826, -0.05625
101363, 2.0695652173913, 1.0891304347826, -0.05625
101364, 2.1130434782609, 1.0891304347826, -0.05625
101365, 2.1565217391304, 1.0891304347826, -0.05625
101366, 1.2434782608696, 1.0369565217391, -0.05625
101367, 1.2869565217391, 1.0369565217391, -0.05625
101368, 1.3304347826087, 1.0369565217391, -0.05625
101369, 1.3739130434783, 1.0369565217391, -0.05625
101370, 1.4173913043478, 1.0369565217391, -0.05625
101371, 1.4608695652174, 1.0369565217391, -0.05625
101372, 1.504347826087, 1.0369565217391, -0.05625
101373, 1.5478260869565, 1.0369565217391, -0.05625
101374, 1.5913043478261, 1.0369565217391, -0.05625
101375, 1.6347826086957, 1.0369565217391, -0.05625
101376, 1.6782608695652, 1.0369565217391, -0.05625
101377, 1.7217391304348, 1.0369565217391, -0.05625
101378, 1.7652173913043, 1.0369565217391, -0.05625
101379, 1.8086956521739, 1.0369565217391, -0.05625
101380, 1.8521739130435, 1.0369565217391, -0.05625
101381, 1.895652173913, 1.0369565217391, -0.05625
101382, 1.9391304347826, 1.0369565217391, -0.05625
101383, 1.9826086956522, 1.0369565217391, -0.05625
101384, 2.0260869565217, 1.0369565217391, -0.05625
101385, 2.0695652173913, 1.0369565217391, -0.05625
101386, 2.1130434782609, 1.0369565217391, -0.05625
101387, 2.1565217391304, 1.0369565217391, -0.05625
101388, 1.2434782608696, 0.98478260869565, -0.05625
101389, 1.2869565217391, 0.98478260869565, -0.05625
101390, 1.3304347826087, 0.98478260869565, -0.05625
101391, 1.3739130434783, 0.98478260869565, -0.05625
101392, 1.4173913043478, 0.98478260869565, -0.05625
101393, 1.4608695652174, 0.98478260869565, -0.05625
101394, 1.504347826087, 0.98478260869565, -0.05625
101395, 1.5478260869565, 0.98478260869565, -0.05625
101396, 1.5913043478261, 0.98478260869565, -0.05625
101397, 1.6347826086957, 0.98478260869565, -0.05625
101398, 1.6782608695652, 0.98478260869565, -0.05625
101399, 1.7217391304348, 0.98478260869565, -0.05625
101400, 1.7652173913043, 0.98478260869565, -0.05625
101401, 1.8086956521739, 0.98478260869565, -0.05625
101402, 1.8521739130435, 0.98478260869565, -0.05625
101403, 1.895652173913, 0.98478260869565, -0.05625
101404, 1.9391304347826, 0.98478260869565, -0.05625
101405, 1.9826086956522, 0.98478260869565, -0.05625
101406, 2.0260869565217, 0.98478260869565, -0.05625
101407, 2.0695652173913, 0.98478260869565, -0.05625
101408, 2.1130434782609, 0.98478260869565, -0.05625
101409, 2.1565217391304, 0.98478260869565, -0.05625
101410, 1.2434782608696, 0.93260869565217, -0.05625
101411, 1.2869565217391, 0.93260869565217, -0.05625
101412, 1.3304347826087, 0.93260869565217, -0.05625
101413, 1.3739130434783, 0.93260869565217, -0.05625
101414, 1.4173913043478, 0.93260869565217, -0.05625
101415, 1.4608695652174, 0.93260869565217, -0.05625
101416, 1.504347826087, 0.93260869565217, -0.05625
101417, 1.5478260869565, 0.93260869565217, -0.05625
101418, 1.5913043478261, 0.93260869565217, -0.05625
101419, 1.6347826086957, 0.93260869565217, -0.05625
101420, 1.6782608695652, 0.93260869565217, -0.05625
101421, 1.7217391304348, 0.93260869565217, -0.05625
101422, 1.7652173913043, 0.93260869565217, -0.05625
101423, 1.8086956521739, 0.93260869565217, -0.05625
101424, 1.8521739130435, 0.93260869565217, -0.05625
101425, 1.895652173913, 0.93260869565217, -0.05625
101426, 1.9391304347826, 0.93260869565217, -0.05625
101427, 1.9826086956522, 0.93260869565217, -0.05625
101428, 2.0260869565217, 0.93260869565217, -0.05625
101429, 2.0695652173913, 0.93260869565217, -0.05625
101430, 2.1130434782609, 0.93260869565217, -0.05625
101431, 2.1565217391304, 0.93260869565217, -0.05625
101432, 1.2434782608696, 0.8804347826087, -0.05625
101433, 1.2869565217391, 0.8804347826087, -0.05625
101434, 1.3304347826087, 0.8804347826087, -0.05625
101435, 1.3739130434783, 0.8804347826087, -0.05625
101436, 1.4173913043478, 0.8804347826087, -0.05625
101437, 1.4608695652174, 0.8804347826087, -0.05625
101438, 1.504347826087, 0.8804347826087, -0.05625
101439, 1.5478260869565, 0.8804347826087, -0.05625
101440, 1.5913043478261, 0.8804347826087, -0.05625
101441, 1.6347826086957, 0.8804347826087, -0.05625
101442, 1.6782608695652, 0.8804347826087, -0.05625
101443, 1.7217391304348, 0.8804347826087, -0.05625
101444, 1.7652173913043, 0.8804347826087, -0.05625
101445, 1.8086956521739, 0.8804347826087, -0.05625
101446, 1.8521739130435, 0.8804347826087, -0.05625
101447, 1.895652173913, 0.8804347826087, -0.05625
101448, 1.9391304347826, 0.8804347826087, -0.05625
101449, 1.9826086956522, 0.8804347826087, -0.05625
101450, 2.0260869565217, 0.8804347826087, -0.05625
101451, 2.0695652173913, 0.8804347826087, -0.05625
101452, 2.1130434782609, 0.8804347826087, -0.05625
101453, 2.1565217391304, 0.8804347826087, -0.05625
101454, 1.2434782608696, 0.82826086956522, -0.05625
101455, 1.2869565217391, 0.82826086956522, -0.05625
101456, 1.3304347826087, 0.82826086956522, -0.05625
101457, 1.3739130434783, 0.82826086956522, -0.05625
101458, 1.4173913043478, 0.82826086956522, -0.05625
101459, 1.4608695652174, 0.82826086956522, -0.05625
101460, 1.504347826087, 0.82826086956522, -0.05625
101461, 1.5478260869565, 0.82826086956522, -0.05625
101462, 1.5913043478261, 0.82826086956522, -0.05625
101463, 1.6347826086957, 0.82826086956522, -0.05625
101464, 1.6782608695652, 0.82826086956522, -0.05625
101465, 1.7217391304348, 0.82826086956522, -0.05625
101466, 1.7652173913043, 0.82826086956522, -0.05625
101467, 1.8086956521739, 0.82826086956522, -0.05625
101468, 1.8521739130435, 0.82826086956522, -0.05625
101469, 1.895652173913, 0.82826086956522, -0.05625
101470, 1.9391304347826, 0.82826086956522, -0.05625
101471, 1.9826086956522, 0.82826086956522, -0.05625
101472, 2.0260869565217, 0.82826086956522, -0.05625
101473, 2.0695652173913, 0.82826086956522, -0.05625
101474, 2.1130434782609, 0.82826086956522, -0.05625
101475, 2.1565217391304, 0.82826086956522, -0.05625
101476, 1.2434782608696, 0.77608695652174, -0.05625
101477, 1.2869565217391, 0.77608695652174, -0.05625
101478, 1.3304347826087, 0.77608695652174, -0.05625
101479, 1.3739130434783, 0.77608695652174, -0.05625
101480, 1.4173913043478, 0.77608695652174, -0.05625
101481, 1.4608695652174, 0.77608695652174, -0.05625
101482, 1.504347826087, 0.77608695652174, -0.05625
101483, 1.5478260869565, 0.77608695652174, -0.05625
101484, 1.5913043478261, 0.77608695652174, -0.05625
101485, 1.6347826086957, 0.77608695652174, -0.05625
101486, 1.6782608695652, 0.77608695652174, -0.05625
101487, 1.7217391304348, 0.77608695652174, -0.05625
101488, 1.7652173913043, 0.77608695652174, -0.05625
101489, 1.8086956521739, 0.77608695652174, -0.05625
101490, 1.8521739130435, 0.77608695652174, -0.05625
101491, 1.895652173913, 0.77608695652174, -0.05625
101492, 1.9391304347826, 0.77608695652174, -0.05625
101493, 1.9826086956522, 0.77608695652174, -0.05625
101494, 2.0260869565217, 0.77608695652174, -0.05625
101495, 2.0695652173913, 0.77608695652174, -0.05625
101496, 2.1130434782609, 0.77608695652174, -0.05625
101497, 2.1565217391304, 0.77608695652174, -0.05625
101498, 1.2434782608696, 0.72391304347826, -0.05625
101499, 1.2869565217391, 0.72391304347826, -0.05625
101500, 1.3304347826087, 0.72391304347826, -0.05625
101501, 1.3739130434783, 0.72391304347826, -0.05625
101502, 1.4173913043478, 0.72391304347826, -0.05625
101503, 1.4608695652174, 0.72391304347826, -0.05625
101504, 1.504347826087, 0.72391304347826, -0.05625
101505, 1.5478260869565, 0.72391304347826, -0.05625
101506, 1.5913043478261, 0.72391304347826, -0.05625
101507, 1.6347826086957, 0.72391304347826, -0.05625
101508, 1.6782608695652, 0.72391304347826, -0.05625
101509, 1.7217391304348, 0.72391304347826, -0.05625
101510, 1.7652173913043, 0.72391304347826, -0.05625
101511, 1.8086956521739, 0.72391304347826, -0.05625
101512, 1.8521739130435, 0.72391304347826, -0.05625
101513, 1.895652173913, 0.72391304347826, -0.05625
101514, 1.9391304347826, 0.72391304347826, -0.05625
101515, 1.9826086956522, 0.72391304347826, -0.05625
101516, 2.0260869565217, 0.72391304347826, -0.05625
101517, 2.0695652173913, 0.72391304347826, -0.05625
101518, 2.1130434782609, 0.72391304347826, -0.05625
101519, 2.1565217391304, 0.72391304347826, -0.05625
101520, 1.2434782608696, 0.67173913043478, -0.05625
101521, 1.2869565217391, 0.67173913043478, -0.05625
101522, 1.3304347826087, 0.67173913043478, -0.05625
101523, 1.3739130434783, 0.67173913043478, -0.05625
101524, 1.4173913043478, 0.67173913043478, -0.05625
101525, 1.4608695652174, 0.67173913043478, -0.05625
101526, 1.504347826087, 0.67173913043478, -0.05625
101527, 1.5478260869565, 0.67173913043478, -0.05625
101528, 1.5913043478261, 0.67173913043478, -0.05625
101529, 1.6347826086957, 0.67173913043478, -0.05625
101530, 1.6782608695652, 0.67173913043478, -0.05625
101531, 1.7217391304348, 0.67173913043478, -0.05625
101532, 1.7652173913043, 0.67173913043478, -0.05625
101533, 1.8086956521739, 0.67173913043478, -0.05625
101534, 1.8521739130435, 0.67173913043478, -0.05625
101535, 1.895652173913, 0.67173913043478, -0.05625
101536, 1.9391304347826, 0.67173913043478, -0.05625
101537, 1.9826086956522, 0.67173913043478, -0.05625
101538, 2.0260869565217, 0.67173913043478, -0.05625
101539, 2.0695652173913, 0.67173913043478, -0.05625
101540, 2.1130434782609, 0.67173913043478, -0.05625
101541, 2.1565217391304, 0.67173913043478, -0.05625
101542, 1.2434782608696, 0.6195652173913, -0.05625
101543, 1.2869565217391, 0.61956521739131, -0.05625
101544, 1.3304347826087, 0.61956521739131, -0.05625
101545, 1.3739130434783, 0.61956521739131, -0.05625
101546, 1.4173913043478, 0.6195652173913, -0.05625
101547, 1.4608695652174, 0.6195652173913, -0.05625
101548, 1.504347826087, 0.6195652173913, -0.05625
101549, 1.5478260869565, 0.6195652173913, -0.05625
101550, 1.5913043478261, 0.6195652173913, -0.05625
101551, 1.6347826086957, 0.6195652173913, -0.05625
101552, 1.6782608695652, 0.61956521739131, -0.05625
101553, 1.7217391304348, 0.61956521739131, -0.05625
101554, 1.7652173913043, 0.61956521739131, -0.05625
101555, 1.8086956521739, 0.6195652173913, -0.05625
101556, 1.8521739130435, 0.61956521739131, -0.05625
101557, 1.895652173913, 0.61956521739131, -0.05625
101558, 1.9391304347826, 0.61956521739131, -0.05625
101559, 1.9826086956522, 0.61956521739131, -0.05625
101560, 2.0260869565217, 0.6195652173913, -0.05625
101561, 2.0695652173913, 0.6195652173913, -0.05625
101562, 2.1130434782609, 0.6195652173913, -0.05625
101563, 2.1565217391304, 0.61956521739131, -0.05625
101564, 1.2434782608696, 0.56739130434783, -0.05625
101565, 1.2869565217391, 0.56739130434783, -0.05625
101566, 1.3304347826087, 0.56739130434783, -0.05625
101567, 1.3739130434783, 0.56739130434783, -0.05625
101568, 1.4173913043478, 0.56739130434783, -0.05625
101569, 1.4608695652174, 0.56739130434783, -0.05625
101570, 1.504347826087, 0.56739130434783, -0.05625
101571, 1.5478260869565, 0.56739130434783, -0.05625
101572, 1.5913043478261, 0.56739130434783, -0.05625
101573, 1.6347826086957, 0.56739130434783, -0.05625
101574, 1.6782608695652, 0.56739130434783, -0.05625
101575, 1.7217391304348, 0.56739130434783, -0.05625
101576, 1.7652173913043, 0.56739130434783, -0.05625
101577, 1.8086956521739, 0.56739130434783, -0.05625
101578, 1.8521739130435, 0.56739130434783, -0.05625
101579, 1.895652173913, 0.56739130434783, -0.05625
101580, 1.9391304347826, 0.56739130434783, -0.05625
101581, 1.9826086956522, 0.56739130434783, -0.05625
101582, 2.0260869565217, 0.56739130434783, -0.05625
101583, 2.0695652173913, 0.56739130434783, -0.05625
101584, 2.1130434782609, 0.56739130434783, -0.05625
101585, 2.1565217391304, 0.56739130434783, -0.05625
101586, 1.2434782608696, 0.51521739130435, -0.05625
101587, 1.2869565217391, 0.51521739130435, -0.05625
101588, 1.3304347826087, 0.51521739130435, -0.05625
101589, 1.3739130434783, 0.51521739130435, -0.05625
101590, 1.4173913043478, 0.51521739130435, -0.05625
101591, 1.4608695652174, 0.51521739130435, -0.05625
101592, 1.504347826087, 0.51521739130435, -0.05625
101593, 1.5478260869565, 0.51521739130435, -0.05625
101594, 1.5913043478261, 0.51521739130435, -0.05625
101595, 1.6347826086957, 0.51521739130435, -0.05625
101596, 1.6782608695652, 0.51521739130435, -0.05625
101597, 1.7217391304348, 0.51521739130435, -0.05625
101598, 1.7652173913043, 0.51521739130435, -0.05625
101599, 1.8086956521739, 0.51521739130435, -0.05625
101600, 1.8521739130435, 0.51521739130435, -0.05625
101601, 1.895652173913, 0.51521739130435, -0.05625
101602, 1.9391304347826, 0.51521739130435, -0.05625
101603, 1.9826086956522, 0.51521739130435, -0.05625
101604, 2.0260869565217, 0.51521739130435, -0.05625
101605, 2.0695652173913, 0.51521739130435, -0.05625
101606, 2.1130434782609, 0.51521739130435, -0.05625
101607, 2.1565217391304, 0.51521739130435, -0.05625
101608, 1.2434782608696, 0.46304347826087, -0.05625
101609, 1.2869565217391, 0.46304347826087, -0.05625
101610, 1.3304347826087, 0.46304347826087, -0.05625
101611, 1.3739130434783, 0.46304347826087, -0.05625
101612, 1.4173913043478, 0.46304347826087, -0.05625
101613, 1.4608695652174, 0.46304347826087, -0.05625
101614, 1.504347826087, 0.46304347826087, -0.05625
101615, 1.5478260869565, 0.46304347826087, -0.05625
101616, 1.5913043478261, 0.46304347826087, -0.05625
101617, 1.6347826086957, 0.46304347826087, -0.05625
101618, 1.6782608695652, 0.46304347826087, -0.05625
101619, 1.7217391304348, 0.46304347826087, -0.05625
101620, 1.7652173913043, 0.46304347826087, -0.05625
101621, 1.8086956521739, 0.46304347826087, -0.05625
101622, 1.8521739130435, 0.46304347826087, -0.05625
101623, 1.895652173913, 0.46304347826087, -0.05625
101624, 1.9391304347826, 0.46304347826087, -0.05625
101625, 1.9826086956522, 0.46304347826087, -0.05625
101626, 2.0260869565217, 0.46304347826087, -0.05625
101627, 2.0695652173913, 0.46304347826087, -0.05625
101628, 2.1130434782609, 0.46304347826087, -0.05625
101629, 2.1565217391304, 0.46304347826087, -0.05625
101630, 1.2434782608696, 0.41086956521739, -0.05625
101631, 1.2869565217391, 0.41086956521739, -0.05625
101632, 1.3304347826087, 0.41086956521739, -0.05625
101633, 1.3739130434783, 0.41086956521739, -0.05625
101634, 1.4173913043478, 0.41086956521739, -0.05625
101635, 1.4608695652174, 0.41086956521739, -0.05625
101636, 1.504347826087, 0.41086956521739, -0.05625
101637, 1.5478260869565, 0.41086956521739, -0.05625
101638, 1.5913043478261, 0.41086956521739, -0.05625
101639, 1.6347826086957, 0.41086956521739, -0.05625
101640, 1.6782608695652, 0.41086956521739, -0.05625
101641, 1.7217391304348, 0.41086956521739, -0.05625
101642, 1.7652173913043, 0.41086956521739, -0.05625
101643, 1.8086956521739, 0.41086956521739, -0.05625
101644, 1.8521739130435, 0.41086956521739, -0.05625
101645, 1.895652173913, 0.41086956521739, -0.05625
101646, 1.9391304347826, 0.41086956521739, -0.05625
101647, 1.9826086956522, 0.41086956521739, -0.05625
101648, 2.0260869565217, 0.41086956521739, -0.05625
101649, 2.0695652173913, 0.41086956521739, -0.05625
101650, 2.1130434782609, 0.41086956521739, -0.05625
101651, 2.1565217391304, 0.41086956521739, -0.05625
101652, 1.2434782608696, 0.35869565217391, -0.05625
101653, 1.2869565217391, 0.35869565217391, -0.05625
101654, 1.3304347826087, 0.35869565217391, -0.05625
101655, 1.3739130434783, 0.35869565217391, -0.05625
101656, 1.4173913043478, 0.35869565217391, -0.05625
101657, 1.4608695652174, 0.35869565217391, -0.05625
101658, 1.504347826087, 0.35869565217391, -0.05625
101659, 1.5478260869565, 0.35869565217391, -0.05625
101660, 1.5913043478261, 0.35869565217391, -0.05625
101661, 1.6347826086957, 0.35869565217391, -0.05625
101662, 1.6782608695652, 0.35869565217391, -0.05625
101663, 1.7217391304348, 0.35869565217391, -0.05625
101664, 1.7652173913043, 0.35869565217391, -0.05625
101665, 1.8086956521739, 0.35869565217391, -0.05625
101666, 1.8521739130435, 0.35869565217391, -0.05625
101667, 1.895652173913, 0.35869565217391, -0.05625
101668, 1.9391304347826, 0.35869565217391, -0.05625
101669, 1.9826086956522, 0.35869565217391, -0.05625
101670, 2.0260869565217, 0.35869565217391, -0.05625
101671, 2.0695652173913, 0.35869565217391, -0.05625
101672, 2.1130434782609, 0.35869565217391, -0.05625
101673, 2.1565217391304, 0.35869565217391, -0.05625
101674, 1.2434782608696, 0.30652173913044, -0.05625
101675, 1.2869565217391, 0.30652173913043, -0.05625
101676, 1.3304347826087, 0.30652173913043, -0.05625
101677, 1.3739130434783, 0.30652173913044, -0.05625
101678, 1.4173913043478, 0.30652173913044, -0.05625
101679, 1.4608695652174, 0.30652173913043, -0.05625
101680, 1.504347826087, 0.30652173913044, -0.05625
101681, 1.5478260869565, 0.30652173913044, -0.05625
101682, 1.5913043478261, 0.30652173913044, -0.05625
101683, 1.6347826086957, 0.30652173913043, -0.05625
101684, 1.6782608695652, 0.30652173913043, -0.05625
101685, 1.7217391304348, 0.30652173913043, -0.05625
101686, 1.7652173913043, 0.30652173913043, -0.05625
101687, 1.8086956521739, 0.30652173913044, -0.05625
101688, 1.8521739130435, 0.30652173913043, -0.05625
101689, 1.895652173913, 0.30652173913044, -0.05625
101690, 1.9391304347826, 0.30652173913043, -0.05625
101691, 1.9826086956522, 0.30652173913044, -0.05625
101692, 2.0260869565217, 0.30652173913044, -0.05625
101693, 2.0695652173913, 0.30652173913043, -0.05625
101694, 2.1130434782609, 0.30652173913043, -0.05625
101695, 2.1565217391304, 0.30652173913043, -0.05625
101696, 1.2434782608696, 0.25434782608696, -0.05625
101697, 1.2869565217391, 0.25434782608696, -0.05625
101698, 1.3304347826087, 0.25434782608696, -0.05625
101699, 1.3739130434783, 0.25434782608696, -0.05625
101700, 1.4173913043478, 0.25434782608696, -0.05625
101701, 1.4608695652174, 0.25434782608696, -0.05625
101702, 1.504347826087, 0.25434782608696, -0.05625
101703, 1.5478260869565, 0.25434782608696, -0.05625
101704, 1.5913043478261, 0.25434782608696, -0.05625
101705, 1.6347826086957, 0.25434782608696, -0.05625
101706, 1.6782608695652, 0.25434782608696, -0.05625
101707, 1.7217391304348, 0.25434782608696, -0.05625
101708, 1.7652173913043, 0.25434782608696, -0.05625
101709, 1.8086956521739, 0.25434782608696, -0.05625
101710, 1.8521739130435, 0.25434782608696, -0.05625
101711, 1.895652173913, 0.25434782608696, -0.05625
101712, 1.9391304347826, 0.25434782608696, -0.05625
101713, 1.9826086956522, 0.25434782608696, -0.05625
101714, 2.0260869565217, 0.25434782608696, -0.05625
101715, 2.0695652173913, 0.25434782608696, -0.05625
101716, 2.1130434782609, 0.25434782608696, -0.05625
101717, 2.1565217391304, 0.25434782608696, -0.05625
101718, 1.2434782608696, 0.20217391304348, -0.05625
101719, 1.2869565217391, 0.20217391304348, -0.05625
101720, 1.3304347826087, 0.20217391304348, -0.05625
101721, 1.3739130434783, 0.20217391304348, -0.05625
101722, 1.4173913043478, 0.20217391304348, -0.05625
101723, 1.4608695652174, 0.20217391304348, -0.05625
101724, 1.504347826087, 0.20217391304348, -0.05625
101725, 1.5478260869565, 0.20217391304348, -0.05625
101726, 1.5913043478261, 0.20217391304348, -0.05625
101727, 1.6347826086957, 0.20217391304348, -0.05625
101728, 1.6782608695652, 0.20217391304348, -0.05625
101729, 1.7217391304348, 0.20217391304348, -0.05625
101730, 1.7652173913043, 0.20217391304348, -0.05625
101731, 1.8086956521739, 0.20217391304348, -0.05625
101732, 1.8521739130435, 0.20217391304348, -0.05625
101733, 1.895652173913, 0.20217391304348, -0.05625
101734, 1.9391304347826, 0.20217391304348, -0.05625
101735, 1.9826086956522, 0.20217391304348, -0.05625
101736, 2.0260869565217, 0.20217391304348, -0.05625
101737, 2.0695652173913, 0.20217391304348, -0.05625
101738, 2.1130434782609, 0.20217391304348, -0.05625
101739, 2.1565217391304, 0.20217391304348, -0.05625
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line15
121, 2, 143, 121
122, 121, 144, 122
123, 122, 145, 123
124, 123, 146, 124
125, 124, 147, 125
126, 125, 148, 126
127, 126, 149, 127
128, 127, 150, 128
129, 128, 151, 129
130, 129, 152, 130
131, 130, 153, 131
132, 131, 154, 132
133, 132, 155, 133
134, 133, 156, 134
135, 134, 157, 135
136, 135, 158, 136
137, 136, 159, 137
138, 137, 160, 138
139, 138, 161, 139
140, 139, 162, 140
141, 140, 163, 141
142, 141, 164, 142
143, 142, 165, 1
*ELEMENT, type=T3D3, ELSET=Line17
144, 1, 174, 166
145, 166, 175, 167
146, 167, 176, 168
147, 168, 177, 169
148, 169, 178, 170
149, 170, 179, 171
150, 171, 180, 172
151, 172, 181, 173
152, 173, 182, 3
*ELEMENT, type=T3D3, ELSET=Line19
153, 4, 205, 183
154, 183, 206, 184
155, 184, 207, 185
156, 185, 208, 186
157, 186, 209, 187
158, 187, 210, 188
159, 188, 211, 189
160, 189, 212, 190
161, 190, 213, 191
162, 191, 214, 192
163, 192, 215, 193
164, 193, 216, 194
165, 194, 217, 195
166, 195, 218, 196
167, 196, 219, 197
168, 197, 220, 198
169, 198, 221, 199
170, 199, 222, 200
171, 200, 223, 201
172, 201, 224, 202
173, 202, 225, 203
174, 203, 226, 204
175, 204, 227, 3
*ELEMENT, type=T3D3, ELSET=Line20
176, 2, 236, 228
177, 228, 237, 229
178, 229, 238, 230
179, 230, 239, 231
180, 231, 240, 232
181, 232, 241, 233
182, 233, 242, 234
183, 234, 243, 235
184, 235, 244, 4
*ELEMENT, type=T3D3, ELSET=Line71
185, 5, 267, 245
186, 245, 268, 246
187, 246, 269, 247
188, 247, 270, 248
189, 248, 271, 249
190, 249, 272, 250
191, 250, 273, 251
192, 251, 274, 252
193, 252, 275, 253
194, 253, 276, 254
195, 254, 277, 255
196, 255, 278, 256
197, 256, 279, 257
198, 257, 280, 258
199, 258, 281, 259
200, 259, 282, 260
201, 260, 283, 261
202, 261, 284, 262
203, 262, 285, 263
204, 263, 286, 264
205, 264, 287, 265
206, 265, 288, 266
207, 266, 289, 6
*ELEMENT, type=T3D3, ELSET=Line74
208, 7, 312, 290
209, 290, 313, 291
210, 291, 314, 292
211, 292, 315, 293
212, 293, 316, 294
213, 294, 317, 295
214, 295, 318, 296
215, 296, 319, 297
216, 297, 320, 298
217, 298, 321, 299
218, 299, 322, 300
219, 300, 323, 301
220, 301, 324, 302
221, 302, 325, 303
222, 303, 326, 304
223, 304, 327, 305
224, 305, 328, 306
225, 306, 329, 307
226, 307, 330, 308
227, 308, 331, 309
228, 309, 332, 310
229, 310, 333, 311
230, 311, 334, 8
*ELEMENT, type=T3D3, ELSET=Line75
231, 7, 343, 335
232, 335, 344, 336
233, 336, 345, 337
234, 337, 346, 338
235, 338, 347, 339
236, 339, 348, 340
237, 340, 349, 341
238, 341, 350, 342
239, 342, 351, 5
*ELEMENT, type=T3D3, ELSET=Line76
240, 8, 360, 352
241, 352, 361, 353
242, 353, 362, 354
243, 354, 363, 355
244, 355, 364, 356
245, 356, 365, 357
246, 357, 366, 358
247, 358, 367, 359
248, 359, 368, 6
*ELEMENT, type=T3D3, ELSET=Line249
249, 9, 370, 369
250, 369, 371, 10
*ELEMENT, type=T3D3, ELSET=Line250
251, 11, 373, 372
252, 372, 374, 12
*ELEMENT, type=T3D3, ELSET=Line251
253, 11, 377, 375
254, 375, 378, 376
255, 376, 379, 9
*ELEMENT, type=T3D3, ELSET=Line252
256, 12, 382, 380
257, 380, 383, 381
258, 381, 384, 10
*ELEMENT, type=T3D3, ELSET=Line253
259, 13, 386, 385
260, 385, 387, 14
*ELEMENT, type=T3D3, ELSET=Line254
261, 13, 396, 388
262, 388, 397, 389
263, 389, 398, 390
264, 390, 399, 391
265, 391, 400, 392
266, 392, 401, 393
267, 393, 402, 394
268, 394, 403, 395
269, 395, 404, 11
*ELEMENT, type=T3D3, ELSET=Line255
270, 14, 413, 405
271, 405, 414, 406
272, 406, 415, 407
273, 407, 416, 408
274, 408, 417, 409
275, 409, 418, 410
276, 410, 419, 411
277, 411, 420, 412
278, 412, 421, 12
*ELEMENT, type=T3D3, ELSET=Line256
279, 15, 423, 422
280, 422, 424, 16
*ELEMENT, type=T3D3, ELSET=Line257
281, 15, 433, 425
282, 425, 434, 426
283, 426, 435, 427
284, 427, 436, 428
285, 428, 437, 429
286, 429, 438, 430
287, 430, 439, 431
288, 431, 440, 432
289, 432, 441, 9
*ELEMENT, type=T3D3, ELSET=Line258
290, 16, 450, 442
291, 442, 451, 443
292, 443, 452, 444
293, 444, 453, 445
294, 445, 454, 446
295, 446, 455, 447
296, 447, 456, 448
297, 448, 457, 449
298, 449, 458, 10
*ELEMENT, type=T3D3, ELSET=Line259
299, 13, 461, 459
300, 459, 462, 460
301, 460, 463, 15
*ELEMENT, type=T3D3, ELSET=Line260
302, 14, 466, 464
303, 464, 467, 465
304, 465, 468, 16
*ELEMENT, type=T3D3, ELSET=Line261
305, 11, 472, 469
306, 469, 473, 470
307, 470, 474, 471
308, 471, 475, 17
*ELEMENT, type=T3D3, ELSET=Line262
309, 12, 479, 476
310, 476, 480, 477
311, 477, 481, 478
312, 478, 482, 18
*ELEMENT, type=T3D3, ELSET=Line263
313, 17, 484, 483
314, 483, 485, 18
*ELEMENT, type=T3D3, ELSET=Line264
315, 13, 489, 486
316, 486, 490, 487
317, 487, 491, 488
318, 488, 492, 19
*ELEMENT, type=T3D3, ELSET=Line265
319, 14, 496, 493
320, 493, 497, 494
321, 494, 498, 495
322, 495, 499, 20
*ELEMENT, type=T3D3, ELSET=Line266
323, 19, 501, 500
324, 500, 502, 20
*ELEMENT, type=T3D3, ELSET=Line267
325, 19, 511, 503
326, 503, 512, 504
327, 504, 513, 505
328, 505, 514, 506
329, 506, 515, 507
330, 507, 516, 508
331, 508, 517, 509
332, 509, 518, 510
333, 510, 519, 17
*ELEMENT, type=T3D3, ELSET=Line268
334, 20, 528, 520
335, 520, 529, 521
336, 521, 530, 522
337, 522, 531, 523
338, 523, 532, 524
339, 524, 533, 525
340, 525, 534, 526
341, 526, 535, 527
342, 527, 536, 18
*ELEMENT, type=T3D3, ELSET=Line269
343, 22, 545, 537
344, 537, 546, 538
345, 538, 547, 539
346, 539, 548, 540
347, 540, 549, 541
348, 541, 550, 542
349, 542, 551, 543
350, 543, 552, 544
351, 544, 553, 21
*ELEMENT, type=T3D3, ELSET=Line270
352, 21, 556, 554
353, 554, 557, 555
354, 555, 558, 23
*ELEMENT, type=T3D3, ELSET=Line271
355, 24, 567, 559
356, 559, 568, 560
357, 560, 569, 561
358, 561, 570, 562
359, 562, 571, 563
360, 563, 572, 564
361, 564, 573, 565
362, 565, 574, 566
363, 566, 575, 23
*ELEMENT, type=T3D3, ELSET=Line272
364, 22, 578, 576
365, 576, 579, 577
366, 577, 580, 24
*ELEMENT, type=T3D3, ELSET=Line273
367, 13, 603, 581
368, 581, 604, 582
369, 582, 605, 583
370, 583, 606, 584
371, 584, 607, 585
372, 585, 608, 586
373, 586, 609, 587
374, 587, 610, 588
375, 588, 611, 589
376, 589, 612, 590
377, 590, 613, 591
378, 591, 614, 592
379, 592, 615, 593
380, 593, 616, 594
381, 594, 617, 595
382, 595, 618, 596
383, 596, 619, 597
384, 597, 620, 598
385, 598, 621, 599
386, 599, 622, 600
387, 600, 623, 601
388, 601, 624, 602
389, 602, 625, 22
*ELEMENT, type=T3D3, ELSET=Line274
390, 11, 648, 626
391, 626, 649, 627
392, 627, 650, 628
393, 628, 651, 629
394, 629, 652, 630
395, 630, 653, 631
396, 631, 654, 632
397, 632, 655, 633
398, 633, 656, 634
399, 634, 657, 635
400, 635, 658, 636
401, 636, 659, 637
402, 637, 660, 638
403, 638, 661, 639
404, 639, 662, 640
405, 640, 663, 641
406, 641, 664, 642
407, 642, 665, 643
408, 643, 666, 644
409, 644, 667, 645
410, 645, 668, 646
411, 646, 669, 647
412, 647, 670, 21
*ELEMENT, type=T3D3, ELSET=Line275
413, 15, 693, 671
414, 671, 694, 672
415, 672, 695, 673
416, 673, 696, 674
417, 674, 697, 675
418, 675, 698, 676
419, 676, 699, 677
420, 677, 700, 678
421, 678, 701, 679
422, 679, 702, 680
423, 680, 703, 681
424, 681, 704, 682
425, 682, 705, 683
426, 683, 706, 684
427, 684, 707, 685
428, 685, 708, 686
429, 686, 709, 687
430, 687, 710, 688
431, 688, 711, 689
432, 689, 712, 690
433, 690, 713, 691
434, 691, 714, 692
435, 692, 715, 24
*ELEMENT, type=T3D3, ELSET=Line276
436, 9, 738, 716
437, 716, 739, 717
438, 717, 740, 718
439, 718, 741, 719
440, 719, 742, 720
441, 720, 743, 721
442, 721, 744, 722
443, 722, 745, 723
444, 723, 746, 724
445, 724, 747, 725
446, 725, 748, 726
447, 726, 749, 727
448, 727, 750, 728
449, 728, 751, 729
450, 729, 752, 730
451, 730, 753, 731
452, 731, 754, 732
453, 732, 755, 733
454, 733, 756, 734
455, 734, 757, 735
456, 735, 758, 736
457, 736, 759, 737
458, 737, 760, 23
*ELEMENT, type=T3D3, ELSET=Line277
459, 22, 764, 761
460, 761, 765, 762
461, 762, 766, 763
462, 763, 767, 25
*ELEMENT, type=T3D3, ELSET=Line278
463, 19, 790, 768
464, 768, 791, 769
465, 769, 792, 770
466, 770, 793, 771
467, 771, 794, 772
468, 772, 795, 773
469, 773, 796, 774
470, 774, 797, 775
471, 775, 798, 776
472, 776, 799, 777
473, 777, 800, 778
474, 778, 801, 779
475, 779, 802, 780
476, 780, 803, 781
477, 781, 804, 782
478, 782, 805, 783
479, 783, 806, 784
480, 784, 807, 785
481, 785, 808, 786
482, 786, 809, 787
483, 787, 810, 788
484, 788, 811, 789
485, 789, 812, 25
*ELEMENT, type=T3D3, ELSET=Line279
486, 21, 816, 813
487, 813, 817, 814
488, 814, 818, 815
489, 815, 819, 26
*ELEMENT, type=T3D3, ELSET=Line280
490, 25, 828, 820
491, 820, 829, 821
492, 821, 830, 822
493, 822, 831, 823
494, 823, 832, 824
495, 824, 833, 825
496, 825, 834, 826
497, 826, 835, 827
498, 827, 836, 26
*ELEMENT, type=T3D3, ELSET=Line281
499, 17, 859, 837
500, 837, 860, 838
501, 838, 861, 839
502, 839, 862, 840
503, 840, 863, 841
504, 841, 864, 842
505, 842, 865, 843
506, 843, 866, 844
507, 844, 867, 845
508, 845, 868, 846
509, 846, 869, 847
510, 847, 870, 848
511, 848, 871, 849
512, 849, 872, 850
513, 850, 873, 851
514, 851, 874, 852
515, 852, 875, 853
516, 853, 876, 854
517, 854, 877, 855
518, 855, 878, 856
519, 856, 879, 857
520, 857, 880, 858
521, 858, 881, 26
*ELEMENT, type=T3D3, ELSET=Line282
522, 21, 885, 882
523, 882, 886, 883
524, 883, 887, 884
525, 884, 888, 27
*ELEMENT, type=T3D3, ELSET=Line283
526, 26, 892, 889
527, 889, 893, 890
528, 890, 894, 891
529, 891, 895, 28
*ELEMENT, type=T3D3, ELSET=Line284
530, 27, 899, 896
531, 896, 900, 897
532, 897, 901, 898
533, 898, 902, 28
*ELEMENT, type=T3D3, ELSET=Line285
534, 22, 906, 903
535, 903, 907, 904
536, 904, 908, 905
537, 905, 909, 29
*ELEMENT, type=T3D3, ELSET=Line286
538, 25, 913, 910
539, 910, 914, 911
540, 911, 915, 912
541, 912, 916, 30
*ELEMENT, type=T3D3, ELSET=Line287
542, 29, 920, 917
543, 917, 921, 918
544, 918, 922, 919
545, 919, 923, 30
*ELEMENT, type=T3D3, ELSET=Line288
546, 29, 932, 924
547, 924, 933, 925
548, 925, 934, 926
549, 926, 935, 927
550, 927, 936, 928
551, 928, 937, 929
552, 929, 938, 930
553, 930, 939, 931
554, 931, 940, 27
*ELEMENT, type=T3D3, ELSET=Line289
555, 30, 949, 941
556, 941, 950, 942
557, 942, 951, 943
558, 943, 952, 944
559, 944, 953, 945
560, 945, 954, 946
561, 946, 955, 947
562, 947, 956, 948
563, 948, 957, 28
*ELEMENT, type=T3D3, ELSET=Line290
564, 31, 961, 958
565, 958, 962, 959
566, 959, 963, 960
567, 960, 964, 32
*ELEMENT, type=T3D3, ELSET=Line291
568, 27, 987, 965
569, 965, 988, 966
570, 966, 989, 967
571, 967, 990, 968
572, 968, 991, 969
573, 969, 992, 970
574, 970, 993, 971
575, 971, 994, 972
576, 972, 995, 973
577, 973, 996, 974
578, 974, 997, 975
579, 975, 998, 976
580, 976, 999, 977
581, 977, 1000, 978
582, 978, 1001, 979
583, 979, 1002, 980
584, 980, 1003, 981
585, 981, 1004, 982
586, 982, 1005, 983
587, 983, 1006, 984
588, 984, 1007, 985
589, 985, 1008, 986
590, 986, 1009, 31
*ELEMENT, type=T3D3, ELSET=Line292
591, 28, 1032, 1010
592, 1010, 1033, 1011
593, 1011, 1034, 1012
594, 1012, 1035, 1013
595, 1013, 1036, 1014
596, 1014, 1037, 1015
597, 1015, 1038, 1016
598, 1016, 1039, 1017
599, 1017, 1040, 1018
600, 1018, 1041, 1019
601, 1019, 1042, 1020
602, 1020, 1043, 1021
603, 1021, 1044, 1022
604, 1022, 1045, 1023
605, 1023, 1046, 1024
606, 1024, 1047, 1025
607, 1025, 1048, 1026
608, 1026, 1049, 1027
609, 1027, 1050, 1028
610, 1028, 1051, 1029
611, 1029, 1052, 1030
612, 1030, 1053, 1031
613, 1031, 1054, 32
*ELEMENT, type=T3D3, ELSET=Line293
614, 33, 1058, 1055
615, 1055, 1059, 1056
616, 1056, 1060, 1057
617, 1057, 1061, 34
*ELEMENT, type=T3D3, ELSET=Line294
618, 29, 1084, 1062
619, 1062, 1085, 1063
620, 1063, 1086, 1064
621, 1064, 1087, 1065
622, 1065, 1088, 1066
623, 1066, 1089, 1067
624, 1067, 1090, 1068
625, 1068, 1091, 1069
626, 1069, 1092, 1070
627, 1070, 1093, 1071
628, 1071, 1094, 1072
629, 1072, 1095, 1073
630, 1073, 1096, 1074
631, 1074, 1097, 1075
632, 1075, 1098, 1076
633, 1076, 1099, 1077
634, 1077, 1100, 1078
635, 1078, 1101, 1079
636, 1079, 1102, 1080
637, 1080, 1103, 1081
638, 1081, 1104, 1082
639, 1082, 1105, 1083
640, 1083, 1106, 33
*ELEMENT, type=T3D3, ELSET=Line295
641, 30, 1129, 1107
642, 1107, 1130, 1108
643, 1108, 1131, 1109
644, 1109, 1132, 1110
645, 1110, 1133, 1111
646, 1111, 1134, 1112
647, 1112, 1135, 1113
648, 1113, 1136, 1114
649, 1114, 1137, 1115
650, 1115, 1138, 1116
651, 1116, 1139, 1117
652, 1117, 1140, 1118
653, 1118, 1141, 1119
654, 1119, 1142, 1120
655, 1120, 1143, 1121
656, 1121, 1144, 1122
657, 1122, 1145, 1123
658, 1123, 1146, 1124
659, 1124, 1147, 1125
660, 1125, 1148, 1126
661, 1126, 1149, 1127
662, 1127, 1150, 1128
663, 1128, 1151, 34
*ELEMENT, type=T3D3, ELSET=Line296
664, 33, 1160, 1152
665, 1152, 1161, 1153
666, 1153, 1162, 1154
667, 1154, 1163, 1155
668, 1155, 1164, 1156
669, 1156, 1165, 1157
670, 1157, 1166, 1158
671, 1158, 1167, 1159
672, 1159, 1168, 31
*ELEMENT, type=T3D3, ELSET=Line297
673, 34, 1177, 1169
674, 1169, 1178, 1170
675, 1170, 1179, 1171
676, 1171, 1180, 1172
677, 1172, 1181, 1173
678, 1173, 1182, 1174
679, 1174, 1183, 1175
680, 1175, 1184, 1176
681, 1176, 1185, 32
*ELEMENT, type=T3D3, ELSET=Line298
682, 35, 1188, 1186
683, 1186, 1189, 1187
684, 1187, 1190, 27
*ELEMENT, type=T3D3, ELSET=Line299
685, 36, 1193, 1191
686, 1191, 1194, 1192
687, 1192, 1195, 31
*ELEMENT, type=T3D3, ELSET=Line300
688, 35, 1218, 1196
689, 1196, 1219, 1197
690, 1197, 1220, 1198
691, 1198, 1221, 1199
692, 1199, 1222, 1200
693, 1200, 1223, 1201
694, 1201, 1224, 1202
695, 1202, 1225, 1203
696, 1203, 1226, 1204
697, 1204, 1227, 1205
698, 1205, 1228, 1206
699, 1206, 1229, 1207
700, 1207, 1230, 1208
701, 1208, 1231, 1209
702, 1209, 1232, 1210
703, 1210, 1233, 1211
704, 1211, 1234, 1212
705, 1212, 1235, 1213
706, 1213, 1236, 1214
707, 1214, 1237, 1215
708, 1215, 1238, 1216
709, 1216, 1239, 1217
710, 1217, 1240, 36
*ELEMENT, type=T3D3, ELSET=Line301
711, 37, 1243, 1241
712, 1241, 1244, 1242
713, 1242, 1245, 29
*ELEMENT, type=T3D3, ELSET=Line302
714, 38, 1248, 1246
715, 1246, 1249, 1247
716, 1247, 1250, 33
*ELEMENT, type=T3D3, ELSET=Line303
717, 37, 1273, 1251
718, 1251, 1274, 1252
719, 1252, 1275, 1253
720, 1253, 1276, 1254
721, 1254, 1277, 1255
722, 1255, 1278, 1256
723, 1256, 1279, 1257
724, 1257, 1280, 1258
725, 1258, 1281, 1259
726, 1259, 1282, 1260
727, 1260, 1283, 1261
728, 1261, 1284, 1262
729, 1262, 1285, 1263
730, 1263, 1286, 1264
731, 1264, 1287, 1265
732, 1265, 1288, 1266
733, 1266, 1289, 1267
734, 1267, 1290, 1268
735, 1268, 1291, 1269
736, 1269, 1292, 1270
737, 1270, 1293, 1271
738, 1271, 1294, 1272
739, 1272, 1295, 38
*ELEMENT, type=T3D3, ELSET=Line304
740, 37, 1304, 1296
741, 1296, 1305, 1297
742, 1297, 1306, 1298
743, 1298, 1307, 1299
744, 1299, 1308, 1300
745, 1300, 1309, 1301
746, 1301, 1310, 1302
747, 1302, 1311, 1303
748, 1303, 1312, 35
*ELEMENT, type=T3D3, ELSET=Line305
749, 38, 1321, 1313
750, 1313, 1322, 1314
751, 1314, 1323, 1315
752, 1315, 1324, 1316
753, 1316, 1325, 1317
754, 1317, 1326, 1318
755, 1318, 1327, 1319
756, 1319, 1328, 1320
757, 1320, 1329, 36
*ELEMENT, type=T3D3, ELSET=Line306
758, 36, 1331, 1330
759, 1330, 1332, 39
*ELEMENT, type=T3D3, ELSET=Line307
760, 31, 1334, 1333
761, 1333, 1335, 40
*ELEMENT, type=T3D3, ELSET=Line308
762, 39, 1338, 1336
763, 1336, 1339, 1337
764, 1337, 1340, 40
*ELEMENT, type=T3D3, ELSET=Line309
765, 38, 1342, 1341
766, 1341, 1343, 41
*ELEMENT, type=T3D3, ELSET=Line310
767, 33, 1345, 1344
768, 1344, 1346, 42
*ELEMENT, type=T3D3, ELSET=Line311
769, 41, 1349, 1347
770, 1347, 1350, 1348
771, 1348, 1351, 42
*ELEMENT, type=T3D3, ELSET=Line312
772, 41, 1360, 1352
773, 1352, 1361, 1353
774, 1353, 1362, 1354
775, 1354, 1363, 1355
776, 1355, 1364, 1356
777, 1356, 1365, 1357
778, 1357, 1366, 1358
779, 1358, 1367, 1359
780, 1359, 1368, 39
*ELEMENT, type=T3D3, ELSET=Line313
781, 42, 1377, 1369
782, 1369, 1378, 1370
783, 1370, 1379, 1371
784, 1371, 1380, 1372
785, 1372, 1381, 1373
786, 1373, 1382, 1374
787, 1374, 1383, 1375
788, 1375, 1384, 1376
789, 1376, 1385, 40
*ELEMENT, type=T3D3, ELSET=Line314
790, 40, 1389, 1386
791, 1386, 1390, 1387
792, 1387, 1391, 1388
793, 1388, 1392, 43
