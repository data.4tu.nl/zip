46201, 0.17391304347826, 0.41086956521739, 0.30555555555556
46202, 0.19565217391304, 0.41086956521739, 0.33333333333333
46203, 0.17391304347826, 0.38478260869565, 0.33333333333333
46204, 0.17391304347826, 0.41086956521739, 0.36111111111111
46205, 0.19565217391304, 0.41086956521739, 0.38888888888889
46206, 0.17391304347826, 0.38478260869565, 0.38888888888889
46207, 0.17391304347826, 0.41086956521739, 0.41666666666667
46208, 0.19565217391304, 0.41086956521739, 0.44444444444444
46209, 0.17391304347826, 0.38478260869565, 0.44444444444444
46210, 0.17391304347826, 0.41086956521739, 0.47222222222222
46211, 0.1304347826087, 0.41086956521739, 0.027777777777778
46212, 0.15217391304348, 0.41086956521739, 0.055555555555556
46213, 0.1304347826087, 0.38478260869565, 0.055555555555556
46214, 0.1304347826087, 0.41086956521739, 0.083333333333333
46215, 0.15217391304348, 0.41086956521739, 0.11111111111111
46216, 0.1304347826087, 0.38478260869565, 0.11111111111111
46217, 0.1304347826087, 0.41086956521739, 0.13888888888889
46218, 0.15217391304348, 0.41086956521739, 0.16666666666667
46219, 0.1304347826087, 0.38478260869565, 0.16666666666667
46220, 0.1304347826087, 0.41086956521739, 0.19444444444444
46221, 0.15217391304348, 0.41086956521739, 0.22222222222222
46222, 0.1304347826087, 0.38478260869565, 0.22222222222222
46223, 0.1304347826087, 0.41086956521739, 0.25
46224, 0.15217391304348, 0.41086956521739, 0.27777777777778
46225, 0.1304347826087, 0.38478260869565, 0.27777777777778
46226, 0.1304347826087, 0.41086956521739, 0.30555555555556
46227, 0.15217391304348, 0.41086956521739, 0.33333333333333
46228, 0.1304347826087, 0.38478260869565, 0.33333333333333
46229, 0.1304347826087, 0.41086956521739, 0.36111111111111
46230, 0.15217391304348, 0.41086956521739, 0.38888888888889
46231, 0.1304347826087, 0.38478260869565, 0.38888888888889
46232, 0.1304347826087, 0.41086956521739, 0.41666666666667
46233, 0.15217391304348, 0.41086956521739, 0.44444444444444
46234, 0.1304347826087, 0.38478260869565, 0.44444444444444
46235, 0.1304347826087, 0.41086956521739, 0.47222222222222
46236, 0.08695652173913, 0.41086956521739, 0.027777777777778
46237, 0.10869565217391, 0.41086956521739, 0.055555555555556
46238, 0.08695652173913, 0.38478260869565, 0.055555555555556
46239, 0.08695652173913, 0.41086956521739, 0.083333333333333
46240, 0.10869565217391, 0.41086956521739, 0.11111111111111
46241, 0.08695652173913, 0.38478260869565, 0.11111111111111
46242, 0.08695652173913, 0.41086956521739, 0.13888888888889
46243, 0.10869565217391, 0.41086956521739, 0.16666666666667
46244, 0.08695652173913, 0.38478260869565, 0.16666666666667
46245, 0.08695652173913, 0.41086956521739, 0.19444444444444
46246, 0.10869565217391, 0.41086956521739, 0.22222222222222
46247, 0.08695652173913, 0.38478260869565, 0.22222222222222
46248, 0.08695652173913, 0.41086956521739, 0.25
46249, 0.10869565217391, 0.41086956521739, 0.27777777777778
46250, 0.08695652173913, 0.38478260869565, 0.27777777777778
46251, 0.08695652173913, 0.41086956521739, 0.30555555555556
46252, 0.10869565217391, 0.41086956521739, 0.33333333333333
46253, 0.08695652173913, 0.38478260869565, 0.33333333333333
46254, 0.08695652173913, 0.41086956521739, 0.36111111111111
46255, 0.10869565217391, 0.41086956521739, 0.38888888888889
46256, 0.08695652173913, 0.38478260869565, 0.38888888888889
46257, 0.08695652173913, 0.41086956521739, 0.41666666666667
46258, 0.10869565217391, 0.41086956521739, 0.44444444444444
46259, 0.08695652173913, 0.38478260869565, 0.44444444444444
46260, 0.08695652173913, 0.41086956521739, 0.47222222222222
46261, 0.043478260869565, 0.41086956521739, 0.027777777777778
46262, 0.065217391304348, 0.41086956521739, 0.055555555555556
46263, 0.043478260869565, 0.38478260869565, 0.055555555555556
46264, 0.043478260869565, 0.41086956521739, 0.083333333333333
46265, 0.065217391304348, 0.41086956521739, 0.11111111111111
46266, 0.043478260869565, 0.38478260869565, 0.11111111111111
46267, 0.043478260869565, 0.41086956521739, 0.13888888888889
46268, 0.065217391304348, 0.41086956521739, 0.16666666666667
46269, 0.043478260869565, 0.38478260869565, 0.16666666666667
46270, 0.043478260869565, 0.41086956521739, 0.19444444444444
46271, 0.065217391304348, 0.41086956521739, 0.22222222222222
46272, 0.043478260869565, 0.38478260869565, 0.22222222222222
46273, 0.043478260869565, 0.41086956521739, 0.25
46274, 0.065217391304348, 0.41086956521739, 0.27777777777778
46275, 0.043478260869565, 0.38478260869565, 0.27777777777778
46276, 0.043478260869565, 0.41086956521739, 0.30555555555556
46277, 0.065217391304348, 0.41086956521739, 0.33333333333333
46278, 0.043478260869565, 0.38478260869565, 0.33333333333333
46279, 0.043478260869565, 0.41086956521739, 0.36111111111111
46280, 0.065217391304348, 0.41086956521739, 0.38888888888889
46281, 0.043478260869565, 0.38478260869565, 0.38888888888889
46282, 0.043478260869565, 0.41086956521739, 0.41666666666667
46283, 0.065217391304348, 0.41086956521739, 0.44444444444444
46284, 0.043478260869565, 0.38478260869565, 0.44444444444444
46285, 0.043478260869565, 0.41086956521739, 0.47222222222222
46286, 0.021739130434783, 0.41086956521739, 0.055555555555556
46287, 0.021739130434783, 0.41086956521739, 0.11111111111111
46288, 0.021739130434783, 0.41086956521739, 0.16666666666667
46289, 0.021739130434783, 0.41086956521739, 0.22222222222222
46290, 0.021739130434783, 0.41086956521739, 0.27777777777778
46291, 0.021739130434783, 0.41086956521739, 0.33333333333333
46292, 0.021739130434783, 0.41086956521739, 0.38888888888889
46293, 0.021739130434783, 0.41086956521739, 0.44444444444444
46294, 0.95652173913043, 0.46304347826087, 0.027777777777778
46295, 0.97826086956522, 0.46304347826087, 0.055555555555556
46296, 0.95652173913043, 0.43695652173913, 0.055555555555556
46297, 0.95652173913043, 0.46304347826087, 0.083333333333333
46298, 0.97826086956522, 0.46304347826087, 0.11111111111111
46299, 0.95652173913044, 0.43695652173913, 0.11111111111111
46300, 0.95652173913044, 0.46304347826087, 0.13888888888889
46301, 0.97826086956522, 0.46304347826087, 0.16666666666667
46302, 0.95652173913044, 0.43695652173913, 0.16666666666667
46303, 0.95652173913044, 0.46304347826087, 0.19444444444444
46304, 0.97826086956522, 0.46304347826087, 0.22222222222222
46305, 0.95652173913044, 0.43695652173913, 0.22222222222222
46306, 0.95652173913044, 0.46304347826087, 0.25
46307, 0.97826086956522, 0.46304347826087, 0.27777777777778
46308, 0.95652173913044, 0.43695652173913, 0.27777777777778
46309, 0.95652173913044, 0.46304347826087, 0.30555555555556
46310, 0.97826086956522, 0.46304347826087, 0.33333333333333
46311, 0.95652173913044, 0.43695652173913, 0.33333333333333
46312, 0.95652173913044, 0.46304347826087, 0.36111111111111
46313, 0.97826086956522, 0.46304347826087, 0.38888888888889
46314, 0.95652173913044, 0.43695652173913, 0.38888888888889
46315, 0.95652173913044, 0.46304347826087, 0.41666666666667
46316, 0.97826086956522, 0.46304347826087, 0.44444444444444
46317, 0.95652173913044, 0.43695652173913, 0.44444444444444
46318, 0.95652173913044, 0.46304347826087, 0.47222222222222
46319, 0.91304347826087, 0.46304347826087, 0.027777777777778
46320, 0.93478260869565, 0.46304347826087, 0.055555555555556
46321, 0.91304347826087, 0.43695652173913, 0.055555555555556
46322, 0.91304347826087, 0.46304347826087, 0.083333333333333
46323, 0.93478260869565, 0.46304347826087, 0.11111111111111
46324, 0.91304347826087, 0.43695652173913, 0.11111111111111
46325, 0.91304347826087, 0.46304347826087, 0.13888888888889
46326, 0.93478260869565, 0.46304347826087, 0.16666666666667
46327, 0.91304347826087, 0.43695652173913, 0.16666666666667
46328, 0.91304347826087, 0.46304347826087, 0.19444444444444
46329, 0.93478260869565, 0.46304347826087, 0.22222222222222
46330, 0.91304347826087, 0.43695652173913, 0.22222222222222
46331, 0.91304347826087, 0.46304347826087, 0.25
46332, 0.93478260869565, 0.46304347826087, 0.27777777777778
46333, 0.91304347826087, 0.43695652173913, 0.27777777777778
46334, 0.91304347826087, 0.46304347826087, 0.30555555555556
46335, 0.93478260869565, 0.46304347826087, 0.33333333333333
46336, 0.91304347826087, 0.43695652173913, 0.33333333333333
46337, 0.91304347826087, 0.46304347826087, 0.36111111111111
46338, 0.93478260869565, 0.46304347826087, 0.38888888888889
46339, 0.91304347826087, 0.43695652173913, 0.38888888888889
46340, 0.91304347826087, 0.46304347826087, 0.41666666666667
46341, 0.93478260869565, 0.46304347826087, 0.44444444444444
46342, 0.91304347826087, 0.43695652173913, 0.44444444444444
46343, 0.91304347826087, 0.46304347826087, 0.47222222222222
46344, 0.8695652173913, 0.46304347826087, 0.027777777777778
46345, 0.89130434782609, 0.46304347826087, 0.055555555555556
46346, 0.8695652173913, 0.43695652173913, 0.055555555555556
46347, 0.8695652173913, 0.46304347826087, 0.083333333333333
46348, 0.89130434782609, 0.46304347826087, 0.11111111111111
46349, 0.8695652173913, 0.43695652173913, 0.11111111111111
46350, 0.8695652173913, 0.46304347826087, 0.13888888888889
46351, 0.89130434782609, 0.46304347826087, 0.16666666666667
46352, 0.8695652173913, 0.43695652173913, 0.16666666666667
46353, 0.8695652173913, 0.46304347826087, 0.19444444444444
46354, 0.89130434782609, 0.46304347826087, 0.22222222222222
46355, 0.8695652173913, 0.43695652173913, 0.22222222222222
46356, 0.8695652173913, 0.46304347826087, 0.25
46357, 0.89130434782609, 0.46304347826087, 0.27777777777778
46358, 0.8695652173913, 0.43695652173913, 0.27777777777778
46359, 0.8695652173913, 0.46304347826087, 0.30555555555556
46360, 0.89130434782609, 0.46304347826087, 0.33333333333333
46361, 0.8695652173913, 0.43695652173913, 0.33333333333333
46362, 0.8695652173913, 0.46304347826087, 0.36111111111111
46363, 0.89130434782609, 0.46304347826087, 0.38888888888889
46364, 0.8695652173913, 0.43695652173913, 0.38888888888889
46365, 0.8695652173913, 0.46304347826087, 0.41666666666667
46366, 0.89130434782609, 0.46304347826087, 0.44444444444444
46367, 0.8695652173913, 0.43695652173913, 0.44444444444444
46368, 0.8695652173913, 0.46304347826087, 0.47222222222222
46369, 0.82608695652174, 0.46304347826087, 0.027777777777778
46370, 0.84782608695652, 0.46304347826087, 0.055555555555556
46371, 0.82608695652174, 0.43695652173913, 0.055555555555556
46372, 0.82608695652174, 0.46304347826087, 0.083333333333333
46373, 0.84782608695652, 0.46304347826087, 0.11111111111111
46374, 0.82608695652174, 0.43695652173913, 0.11111111111111
46375, 0.82608695652174, 0.46304347826087, 0.13888888888889
46376, 0.84782608695652, 0.46304347826087, 0.16666666666667
46377, 0.82608695652174, 0.43695652173913, 0.16666666666667
46378, 0.82608695652174, 0.46304347826087, 0.19444444444444
46379, 0.84782608695652, 0.46304347826087, 0.22222222222222
46380, 0.82608695652174, 0.43695652173913, 0.22222222222222
46381, 0.82608695652174, 0.46304347826087, 0.25
46382, 0.84782608695652, 0.46304347826087, 0.27777777777778
46383, 0.82608695652174, 0.43695652173913, 0.27777777777778
46384, 0.82608695652174, 0.46304347826087, 0.30555555555556
46385, 0.84782608695652, 0.46304347826087, 0.33333333333333
46386, 0.82608695652174, 0.43695652173913, 0.33333333333333
46387, 0.82608695652174, 0.46304347826087, 0.36111111111111
46388, 0.84782608695652, 0.46304347826087, 0.38888888888889
46389, 0.82608695652174, 0.43695652173913, 0.38888888888889
46390, 0.82608695652174, 0.46304347826087, 0.41666666666667
46391, 0.84782608695652, 0.46304347826087, 0.44444444444444
46392, 0.82608695652174, 0.43695652173913, 0.44444444444444
46393, 0.82608695652174, 0.46304347826087, 0.47222222222222
46394, 0.78260869565217, 0.46304347826087, 0.027777777777778
46395, 0.80434782608696, 0.46304347826087, 0.055555555555556
46396, 0.78260869565217, 0.43695652173913, 0.055555555555556
46397, 0.78260869565217, 0.46304347826087, 0.083333333333333
46398, 0.80434782608696, 0.46304347826087, 0.11111111111111
46399, 0.78260869565217, 0.43695652173913, 0.11111111111111
46400, 0.78260869565217, 0.46304347826087, 0.13888888888889
46401, 0.80434782608696, 0.46304347826087, 0.16666666666667
46402, 0.78260869565217, 0.43695652173913, 0.16666666666667
46403, 0.78260869565217, 0.46304347826087, 0.19444444444444
46404, 0.80434782608696, 0.46304347826087, 0.22222222222222
46405, 0.78260869565217, 0.43695652173913, 0.22222222222222
46406, 0.78260869565217, 0.46304347826087, 0.25
46407, 0.80434782608696, 0.46304347826087, 0.27777777777778
46408, 0.78260869565217, 0.43695652173913, 0.27777777777778
46409, 0.78260869565217, 0.46304347826087, 0.30555555555556
46410, 0.80434782608696, 0.46304347826087, 0.33333333333333
46411, 0.78260869565217, 0.43695652173913, 0.33333333333333
46412, 0.78260869565217, 0.46304347826087, 0.36111111111111
46413, 0.80434782608696, 0.46304347826087, 0.38888888888889
46414, 0.78260869565217, 0.43695652173913, 0.38888888888889
46415, 0.78260869565217, 0.46304347826087, 0.41666666666667
46416, 0.80434782608696, 0.46304347826087, 0.44444444444444
46417, 0.78260869565217, 0.43695652173913, 0.44444444444444
46418, 0.78260869565217, 0.46304347826087, 0.47222222222222
46419, 0.73913043478261, 0.46304347826087, 0.027777777777778
46420, 0.76086956521739, 0.46304347826087, 0.055555555555556
46421, 0.73913043478261, 0.43695652173913, 0.055555555555556
46422, 0.73913043478261, 0.46304347826087, 0.083333333333333
46423, 0.76086956521739, 0.46304347826087, 0.11111111111111
46424, 0.73913043478261, 0.43695652173913, 0.11111111111111
46425, 0.73913043478261, 0.46304347826087, 0.13888888888889
46426, 0.76086956521739, 0.46304347826087, 0.16666666666667
46427, 0.73913043478261, 0.43695652173913, 0.16666666666667
46428, 0.73913043478261, 0.46304347826087, 0.19444444444444
46429, 0.76086956521739, 0.46304347826087, 0.22222222222222
46430, 0.73913043478261, 0.43695652173913, 0.22222222222222
46431, 0.73913043478261, 0.46304347826087, 0.25
46432, 0.76086956521739, 0.46304347826087, 0.27777777777778
46433, 0.73913043478261, 0.43695652173913, 0.27777777777778
46434, 0.73913043478261, 0.46304347826087, 0.30555555555556
46435, 0.76086956521739, 0.46304347826087, 0.33333333333333
46436, 0.73913043478261, 0.43695652173913, 0.33333333333333
46437, 0.73913043478261, 0.46304347826087, 0.36111111111111
46438, 0.76086956521739, 0.46304347826087, 0.38888888888889
46439, 0.73913043478261, 0.43695652173913, 0.38888888888889
46440, 0.73913043478261, 0.46304347826087, 0.41666666666667
46441, 0.76086956521739, 0.46304347826087, 0.44444444444444
46442, 0.73913043478261, 0.43695652173913, 0.44444444444444
46443, 0.73913043478261, 0.46304347826087, 0.47222222222222
46444, 0.69565217391304, 0.46304347826087, 0.027777777777778
46445, 0.71739130434783, 0.46304347826087, 0.055555555555556
46446, 0.69565217391304, 0.43695652173913, 0.055555555555556
46447, 0.69565217391304, 0.46304347826087, 0.083333333333333
46448, 0.71739130434783, 0.46304347826087, 0.11111111111111
46449, 0.69565217391304, 0.43695652173913, 0.11111111111111
46450, 0.69565217391304, 0.46304347826087, 0.13888888888889
46451, 0.71739130434783, 0.46304347826087, 0.16666666666667
46452, 0.69565217391304, 0.43695652173913, 0.16666666666667
46453, 0.69565217391304, 0.46304347826087, 0.19444444444444
46454, 0.71739130434783, 0.46304347826087, 0.22222222222222
46455, 0.69565217391304, 0.43695652173913, 0.22222222222222
46456, 0.69565217391304, 0.46304347826087, 0.25
46457, 0.71739130434783, 0.46304347826087, 0.27777777777778
46458, 0.69565217391304, 0.43695652173913, 0.27777777777778
46459, 0.69565217391304, 0.46304347826087, 0.30555555555556
46460, 0.71739130434783, 0.46304347826087, 0.33333333333333
46461, 0.69565217391304, 0.43695652173913, 0.33333333333333
46462, 0.69565217391304, 0.46304347826087, 0.36111111111111
46463, 0.71739130434783, 0.46304347826087, 0.38888888888889
46464, 0.69565217391304, 0.43695652173913, 0.38888888888889
46465, 0.69565217391304, 0.46304347826087, 0.41666666666667
46466, 0.71739130434783, 0.46304347826087, 0.44444444444444
46467, 0.69565217391304, 0.43695652173913, 0.44444444444444
46468, 0.69565217391304, 0.46304347826087, 0.47222222222222
46469, 0.65217391304348, 0.46304347826087, 0.027777777777778
46470, 0.67391304347826, 0.46304347826087, 0.055555555555556
46471, 0.65217391304348, 0.43695652173913, 0.055555555555556
46472, 0.65217391304348, 0.46304347826087, 0.083333333333333
46473, 0.67391304347826, 0.46304347826087, 0.11111111111111
46474, 0.65217391304348, 0.43695652173913, 0.11111111111111
46475, 0.65217391304348, 0.46304347826087, 0.13888888888889
46476, 0.67391304347826, 0.46304347826087, 0.16666666666667
46477, 0.65217391304348, 0.43695652173913, 0.16666666666667
46478, 0.65217391304348, 0.46304347826087, 0.19444444444444
46479, 0.67391304347826, 0.46304347826087, 0.22222222222222
46480, 0.65217391304348, 0.43695652173913, 0.22222222222222
46481, 0.65217391304348, 0.46304347826087, 0.25
46482, 0.67391304347826, 0.46304347826087, 0.27777777777778
46483, 0.65217391304348, 0.43695652173913, 0.27777777777778
46484, 0.65217391304348, 0.46304347826087, 0.30555555555556
46485, 0.67391304347826, 0.46304347826087, 0.33333333333333
46486, 0.65217391304348, 0.43695652173913, 0.33333333333333
46487, 0.65217391304348, 0.46304347826087, 0.36111111111111
46488, 0.67391304347826, 0.46304347826087, 0.38888888888889
46489, 0.65217391304348, 0.43695652173913, 0.38888888888889
46490, 0.65217391304348, 0.46304347826087, 0.41666666666667
46491, 0.67391304347826, 0.46304347826087, 0.44444444444444
46492, 0.65217391304348, 0.43695652173913, 0.44444444444444
46493, 0.65217391304348, 0.46304347826087, 0.47222222222222
46494, 0.60869565217391, 0.46304347826087, 0.027777777777778
46495, 0.6304347826087, 0.46304347826087, 0.055555555555556
46496, 0.60869565217391, 0.43695652173913, 0.055555555555556
46497, 0.60869565217391, 0.46304347826087, 0.083333333333333
46498, 0.6304347826087, 0.46304347826087, 0.11111111111111
46499, 0.60869565217391, 0.43695652173913, 0.11111111111111
46500, 0.60869565217391, 0.46304347826087, 0.13888888888889
46501, 0.6304347826087, 0.46304347826087, 0.16666666666667
46502, 0.60869565217391, 0.43695652173913, 0.16666666666667
46503, 0.60869565217391, 0.46304347826087, 0.19444444444444
46504, 0.6304347826087, 0.46304347826087, 0.22222222222222
46505, 0.60869565217391, 0.43695652173913, 0.22222222222222
46506, 0.60869565217391, 0.46304347826087, 0.25
46507, 0.6304347826087, 0.46304347826087, 0.27777777777778
46508, 0.60869565217391, 0.43695652173913, 0.27777777777778
46509, 0.60869565217391, 0.46304347826087, 0.30555555555556
46510, 0.6304347826087, 0.46304347826087, 0.33333333333333
46511, 0.60869565217391, 0.43695652173913, 0.33333333333333
46512, 0.60869565217391, 0.46304347826087, 0.36111111111111
46513, 0.6304347826087, 0.46304347826087, 0.38888888888889
46514, 0.60869565217391, 0.43695652173913, 0.38888888888889
46515, 0.60869565217391, 0.46304347826087, 0.41666666666667
46516, 0.6304347826087, 0.46304347826087, 0.44444444444444
46517, 0.60869565217391, 0.43695652173913, 0.44444444444444
46518, 0.60869565217391, 0.46304347826087, 0.47222222222222
46519, 0.56521739130435, 0.46304347826087, 0.027777777777778
46520, 0.58695652173913, 0.46304347826087, 0.055555555555556
46521, 0.56521739130435, 0.43695652173913, 0.055555555555556
46522, 0.56521739130435, 0.46304347826087, 0.083333333333333
46523, 0.58695652173913, 0.46304347826087, 0.11111111111111
46524, 0.56521739130435, 0.43695652173913, 0.11111111111111
46525, 0.56521739130435, 0.46304347826087, 0.13888888888889
46526, 0.58695652173913, 0.46304347826087, 0.16666666666667
46527, 0.56521739130435, 0.43695652173913, 0.16666666666667
46528, 0.56521739130435, 0.46304347826087, 0.19444444444444
46529, 0.58695652173913, 0.46304347826087, 0.22222222222222
46530, 0.56521739130435, 0.43695652173913, 0.22222222222222
46531, 0.56521739130435, 0.46304347826087, 0.25
46532, 0.58695652173913, 0.46304347826087, 0.27777777777778
46533, 0.56521739130435, 0.43695652173913, 0.27777777777778
46534, 0.56521739130435, 0.46304347826087, 0.30555555555556
46535, 0.58695652173913, 0.46304347826087, 0.33333333333333
46536, 0.56521739130435, 0.43695652173913, 0.33333333333333
46537, 0.56521739130435, 0.46304347826087, 0.36111111111111
46538, 0.58695652173913, 0.46304347826087, 0.38888888888889
46539, 0.56521739130435, 0.43695652173913, 0.38888888888889
46540, 0.56521739130435, 0.46304347826087, 0.41666666666667
46541, 0.58695652173913, 0.46304347826087, 0.44444444444444
46542, 0.56521739130435, 0.43695652173913, 0.44444444444444
46543, 0.56521739130435, 0.46304347826087, 0.47222222222222
46544, 0.52173913043478, 0.46304347826087, 0.027777777777778
46545, 0.54347826086957, 0.46304347826087, 0.055555555555556
46546, 0.52173913043478, 0.43695652173913, 0.055555555555556
46547, 0.52173913043478, 0.46304347826087, 0.083333333333333
46548, 0.54347826086957, 0.46304347826087, 0.11111111111111
46549, 0.52173913043478, 0.43695652173913, 0.11111111111111
46550, 0.52173913043478, 0.46304347826087, 0.13888888888889
46551, 0.54347826086956, 0.46304347826087, 0.16666666666667
46552, 0.52173913043478, 0.43695652173913, 0.16666666666667
46553, 0.52173913043478, 0.46304347826087, 0.19444444444444
46554, 0.54347826086956, 0.46304347826087, 0.22222222222222
46555, 0.52173913043478, 0.43695652173913, 0.22222222222222
46556, 0.52173913043478, 0.46304347826087, 0.25
46557, 0.54347826086956, 0.46304347826087, 0.27777777777778
46558, 0.52173913043478, 0.43695652173913, 0.27777777777778
46559, 0.52173913043478, 0.46304347826087, 0.30555555555556
46560, 0.54347826086956, 0.46304347826087, 0.33333333333333
46561, 0.52173913043478, 0.43695652173913, 0.33333333333333
46562, 0.52173913043478, 0.46304347826087, 0.36111111111111
46563, 0.54347826086956, 0.46304347826087, 0.38888888888889
46564, 0.52173913043478, 0.43695652173913, 0.38888888888889
46565, 0.52173913043478, 0.46304347826087, 0.41666666666667
46566, 0.54347826086956, 0.46304347826087, 0.44444444444444
46567, 0.52173913043478, 0.43695652173913, 0.44444444444444
46568, 0.52173913043478, 0.46304347826087, 0.47222222222222
46569, 0.47826086956522, 0.46304347826087, 0.027777777777778
46570, 0.5, 0.46304347826087, 0.055555555555556
46571, 0.47826086956522, 0.43695652173913, 0.055555555555556
46572, 0.47826086956522, 0.46304347826087, 0.083333333333333
46573, 0.5, 0.46304347826087, 0.11111111111111
46574, 0.47826086956522, 0.43695652173913, 0.11111111111111
46575, 0.47826086956522, 0.46304347826087, 0.13888888888889
46576, 0.5, 0.46304347826087, 0.16666666666667
46577, 0.47826086956522, 0.43695652173913, 0.16666666666667
46578, 0.47826086956522, 0.46304347826087, 0.19444444444444
46579, 0.5, 0.46304347826087, 0.22222222222222
46580, 0.47826086956522, 0.43695652173913, 0.22222222222222
46581, 0.47826086956522, 0.46304347826087, 0.25
46582, 0.5, 0.46304347826087, 0.27777777777778
46583, 0.47826086956522, 0.43695652173913, 0.27777777777778
46584, 0.47826086956522, 0.46304347826087, 0.30555555555556
46585, 0.5, 0.46304347826087, 0.33333333333333
46586, 0.47826086956522, 0.43695652173913, 0.33333333333333
46587, 0.47826086956522, 0.46304347826087, 0.36111111111111
46588, 0.5, 0.46304347826087, 0.38888888888889
46589, 0.47826086956522, 0.43695652173913, 0.38888888888889
46590, 0.47826086956522, 0.46304347826087, 0.41666666666667
46591, 0.5, 0.46304347826087, 0.44444444444444
46592, 0.47826086956522, 0.43695652173913, 0.44444444444444
46593, 0.47826086956522, 0.46304347826087, 0.47222222222222
46594, 0.43478260869565, 0.46304347826087, 0.027777777777778
46595, 0.45652173913043, 0.46304347826087, 0.055555555555556
46596, 0.43478260869565, 0.43695652173913, 0.055555555555556
46597, 0.43478260869565, 0.46304347826087, 0.083333333333333
46598, 0.45652173913043, 0.46304347826087, 0.11111111111111
46599, 0.43478260869565, 0.43695652173913, 0.11111111111111
46600, 0.43478260869565, 0.46304347826087, 0.13888888888889
46601, 0.45652173913043, 0.46304347826087, 0.16666666666667
46602, 0.43478260869565, 0.43695652173913, 0.16666666666667
46603, 0.43478260869565, 0.46304347826087, 0.19444444444444
46604, 0.45652173913043, 0.46304347826087, 0.22222222222222
46605, 0.43478260869565, 0.43695652173913, 0.22222222222222
46606, 0.43478260869565, 0.46304347826087, 0.25
46607, 0.45652173913043, 0.46304347826087, 0.27777777777778
46608, 0.43478260869565, 0.43695652173913, 0.27777777777778
46609, 0.43478260869565, 0.46304347826087, 0.30555555555556
46610, 0.45652173913043, 0.46304347826087, 0.33333333333333
46611, 0.43478260869565, 0.43695652173913, 0.33333333333333
46612, 0.43478260869565, 0.46304347826087, 0.36111111111111
46613, 0.45652173913044, 0.46304347826087, 0.38888888888889
46614, 0.43478260869565, 0.43695652173913, 0.38888888888889
46615, 0.43478260869565, 0.46304347826087, 0.41666666666667
46616, 0.45652173913043, 0.46304347826087, 0.44444444444444
46617, 0.43478260869565, 0.43695652173913, 0.44444444444444
46618, 0.43478260869565, 0.46304347826087, 0.47222222222222
46619, 0.39130434782609, 0.46304347826087, 0.027777777777778
46620, 0.41304347826087, 0.46304347826087, 0.055555555555556
46621, 0.39130434782609, 0.43695652173913, 0.055555555555556
46622, 0.39130434782609, 0.46304347826087, 0.083333333333333
46623, 0.41304347826087, 0.46304347826087, 0.11111111111111
46624, 0.39130434782609, 0.43695652173913, 0.11111111111111
46625, 0.39130434782609, 0.46304347826087, 0.13888888888889
46626, 0.41304347826087, 0.46304347826087, 0.16666666666667
46627, 0.39130434782609, 0.43695652173913, 0.16666666666667
46628, 0.39130434782609, 0.46304347826087, 0.19444444444444
46629, 0.41304347826087, 0.46304347826087, 0.22222222222222
46630, 0.39130434782609, 0.43695652173913, 0.22222222222222
46631, 0.39130434782609, 0.46304347826087, 0.25
46632, 0.41304347826087, 0.46304347826087, 0.27777777777778
46633, 0.39130434782609, 0.43695652173913, 0.27777777777778
46634, 0.39130434782609, 0.46304347826087, 0.30555555555556
46635, 0.41304347826087, 0.46304347826087, 0.33333333333333
46636, 0.39130434782609, 0.43695652173913, 0.33333333333333
46637, 0.39130434782609, 0.46304347826087, 0.36111111111111
46638, 0.41304347826087, 0.46304347826087, 0.38888888888889
46639, 0.39130434782609, 0.43695652173913, 0.38888888888889
46640, 0.39130434782609, 0.46304347826087, 0.41666666666667
46641, 0.41304347826087, 0.46304347826087, 0.44444444444444
46642, 0.39130434782609, 0.43695652173913, 0.44444444444444
46643, 0.39130434782609, 0.46304347826087, 0.47222222222222
46644, 0.34782608695652, 0.46304347826087, 0.027777777777778
46645, 0.3695652173913, 0.46304347826087, 0.055555555555556
46646, 0.34782608695652, 0.43695652173913, 0.055555555555556
46647, 0.34782608695652, 0.46304347826087, 0.083333333333333
46648, 0.3695652173913, 0.46304347826087, 0.11111111111111
46649, 0.34782608695652, 0.43695652173913, 0.11111111111111
46650, 0.34782608695652, 0.46304347826087, 0.13888888888889
46651, 0.3695652173913, 0.46304347826087, 0.16666666666667
46652, 0.34782608695652, 0.43695652173913, 0.16666666666667
46653, 0.34782608695652, 0.46304347826087, 0.19444444444444
46654, 0.3695652173913, 0.46304347826087, 0.22222222222222
46655, 0.34782608695652, 0.43695652173913, 0.22222222222222
46656, 0.34782608695652, 0.46304347826087, 0.25
46657, 0.3695652173913, 0.46304347826087, 0.27777777777778
46658, 0.34782608695652, 0.43695652173913, 0.27777777777778
46659, 0.34782608695652, 0.46304347826087, 0.30555555555556
46660, 0.3695652173913, 0.46304347826087, 0.33333333333333
46661, 0.34782608695652, 0.43695652173913, 0.33333333333333
46662, 0.34782608695652, 0.46304347826087, 0.36111111111111
46663, 0.3695652173913, 0.46304347826087, 0.38888888888889
46664, 0.34782608695652, 0.43695652173913, 0.38888888888889
46665, 0.34782608695652, 0.46304347826087, 0.41666666666667
46666, 0.3695652173913, 0.46304347826087, 0.44444444444444
46667, 0.34782608695652, 0.43695652173913, 0.44444444444444
46668, 0.34782608695652, 0.46304347826087, 0.47222222222222
46669, 0.30434782608696, 0.46304347826087, 0.027777777777778
46670, 0.32608695652174, 0.46304347826087, 0.055555555555556
46671, 0.30434782608696, 0.43695652173913, 0.055555555555556
46672, 0.30434782608696, 0.46304347826087, 0.083333333333333
46673, 0.32608695652174, 0.46304347826087, 0.11111111111111
46674, 0.30434782608696, 0.43695652173913, 0.11111111111111
46675, 0.30434782608696, 0.46304347826087, 0.13888888888889
46676, 0.32608695652174, 0.46304347826087, 0.16666666666667
46677, 0.30434782608696, 0.43695652173913, 0.16666666666667
46678, 0.30434782608696, 0.46304347826087, 0.19444444444444
46679, 0.32608695652174, 0.46304347826087, 0.22222222222222
46680, 0.30434782608696, 0.43695652173913, 0.22222222222222
46681, 0.30434782608696, 0.46304347826087, 0.25
46682, 0.32608695652174, 0.46304347826087, 0.27777777777778
46683, 0.30434782608696, 0.43695652173913, 0.27777777777778
46684, 0.30434782608696, 0.46304347826087, 0.30555555555556
46685, 0.32608695652174, 0.46304347826087, 0.33333333333333
46686, 0.30434782608696, 0.43695652173913, 0.33333333333333
46687, 0.30434782608696, 0.46304347826087, 0.36111111111111
46688, 0.32608695652174, 0.46304347826087, 0.38888888888889
46689, 0.30434782608696, 0.43695652173913, 0.38888888888889
46690, 0.30434782608696, 0.46304347826087, 0.41666666666667
46691, 0.32608695652174, 0.46304347826087, 0.44444444444444
46692, 0.30434782608696, 0.43695652173913, 0.44444444444444
46693, 0.30434782608696, 0.46304347826087, 0.47222222222222
46694, 0.26086956521739, 0.46304347826087, 0.027777777777778
46695, 0.28260869565217, 0.46304347826087, 0.055555555555556
46696, 0.26086956521739, 0.43695652173913, 0.055555555555556
46697, 0.26086956521739, 0.46304347826087, 0.083333333333333
46698, 0.28260869565217, 0.46304347826087, 0.11111111111111
46699, 0.26086956521739, 0.43695652173913, 0.11111111111111
46700, 0.26086956521739, 0.46304347826087, 0.13888888888889
46701, 0.28260869565217, 0.46304347826087, 0.16666666666667
46702, 0.26086956521739, 0.43695652173913, 0.16666666666667
46703, 0.26086956521739, 0.46304347826087, 0.19444444444444
46704, 0.28260869565217, 0.46304347826087, 0.22222222222222
46705, 0.26086956521739, 0.43695652173913, 0.22222222222222
46706, 0.26086956521739, 0.46304347826087, 0.25
46707, 0.28260869565217, 0.46304347826087, 0.27777777777778
46708, 0.26086956521739, 0.43695652173913, 0.27777777777778
46709, 0.26086956521739, 0.46304347826087, 0.30555555555556
46710, 0.28260869565217, 0.46304347826087, 0.33333333333333
46711, 0.26086956521739, 0.43695652173913, 0.33333333333333
46712, 0.26086956521739, 0.46304347826087, 0.36111111111111
46713, 0.28260869565217, 0.46304347826087, 0.38888888888889
46714, 0.26086956521739, 0.43695652173913, 0.38888888888889
46715, 0.26086956521739, 0.46304347826087, 0.41666666666667
46716, 0.28260869565217, 0.46304347826087, 0.44444444444444
46717, 0.26086956521739, 0.43695652173913, 0.44444444444444
46718, 0.26086956521739, 0.46304347826087, 0.47222222222222
46719, 0.21739130434783, 0.46304347826087, 0.027777777777778
46720, 0.23913043478261, 0.46304347826087, 0.055555555555556
46721, 0.21739130434783, 0.43695652173913, 0.055555555555556
46722, 0.21739130434783, 0.46304347826087, 0.083333333333333
46723, 0.23913043478261, 0.46304347826087, 0.11111111111111
46724, 0.21739130434783, 0.43695652173913, 0.11111111111111
46725, 0.21739130434783, 0.46304347826087, 0.13888888888889
46726, 0.23913043478261, 0.46304347826087, 0.16666666666667
46727, 0.21739130434783, 0.43695652173913, 0.16666666666667
46728, 0.21739130434783, 0.46304347826087, 0.19444444444444
46729, 0.23913043478261, 0.46304347826087, 0.22222222222222
46730, 0.21739130434783, 0.43695652173913, 0.22222222222222
46731, 0.21739130434783, 0.46304347826087, 0.25
46732, 0.23913043478261, 0.46304347826087, 0.27777777777778
46733, 0.21739130434783, 0.43695652173913, 0.27777777777778
46734, 0.21739130434783, 0.46304347826087, 0.30555555555556
46735, 0.23913043478261, 0.46304347826087, 0.33333333333333
46736, 0.21739130434783, 0.43695652173913, 0.33333333333333
46737, 0.21739130434783, 0.46304347826087, 0.36111111111111
46738, 0.23913043478261, 0.46304347826087, 0.38888888888889
46739, 0.21739130434783, 0.43695652173913, 0.38888888888889
46740, 0.21739130434783, 0.46304347826087, 0.41666666666667
46741, 0.23913043478261, 0.46304347826087, 0.44444444444444
46742, 0.21739130434783, 0.43695652173913, 0.44444444444444
46743, 0.21739130434783, 0.46304347826087, 0.47222222222222
46744, 0.17391304347826, 0.46304347826087, 0.027777777777778
46745, 0.19565217391304, 0.46304347826087, 0.055555555555556
46746, 0.17391304347826, 0.43695652173913, 0.055555555555556
46747, 0.17391304347826, 0.46304347826087, 0.083333333333333
46748, 0.19565217391304, 0.46304347826087, 0.11111111111111
46749, 0.17391304347826, 0.43695652173913, 0.11111111111111
46750, 0.17391304347826, 0.46304347826087, 0.13888888888889
46751, 0.19565217391304, 0.46304347826087, 0.16666666666667
46752, 0.17391304347826, 0.43695652173913, 0.16666666666667
46753, 0.17391304347826, 0.46304347826087, 0.19444444444444
46754, 0.19565217391304, 0.46304347826087, 0.22222222222222
46755, 0.17391304347826, 0.43695652173913, 0.22222222222222
46756, 0.17391304347826, 0.46304347826087, 0.25
46757, 0.19565217391304, 0.46304347826087, 0.27777777777778
46758, 0.17391304347826, 0.43695652173913, 0.27777777777778
46759, 0.17391304347826, 0.46304347826087, 0.30555555555556
46760, 0.19565217391304, 0.46304347826087, 0.33333333333333
46761, 0.17391304347826, 0.43695652173913, 0.33333333333333
46762, 0.17391304347826, 0.46304347826087, 0.36111111111111
46763, 0.19565217391304, 0.46304347826087, 0.38888888888889
46764, 0.17391304347826, 0.43695652173913, 0.38888888888889
46765, 0.17391304347826, 0.46304347826087, 0.41666666666667
46766, 0.19565217391304, 0.46304347826087, 0.44444444444444
46767, 0.17391304347826, 0.43695652173913, 0.44444444444444
46768, 0.17391304347826, 0.46304347826087, 0.47222222222222
46769, 0.1304347826087, 0.46304347826087, 0.027777777777778
46770, 0.15217391304348, 0.46304347826087, 0.055555555555556
46771, 0.1304347826087, 0.43695652173913, 0.055555555555556
46772, 0.1304347826087, 0.46304347826087, 0.083333333333333
46773, 0.15217391304348, 0.46304347826087, 0.11111111111111
46774, 0.1304347826087, 0.43695652173913, 0.11111111111111
46775, 0.1304347826087, 0.46304347826087, 0.13888888888889
46776, 0.15217391304348, 0.46304347826087, 0.16666666666667
46777, 0.1304347826087, 0.43695652173913, 0.16666666666667
46778, 0.1304347826087, 0.46304347826087, 0.19444444444444
46779, 0.15217391304348, 0.46304347826087, 0.22222222222222
46780, 0.1304347826087, 0.43695652173913, 0.22222222222222
46781, 0.1304347826087, 0.46304347826087, 0.25
46782, 0.15217391304348, 0.46304347826087, 0.27777777777778
46783, 0.1304347826087, 0.43695652173913, 0.27777777777778
46784, 0.1304347826087, 0.46304347826087, 0.30555555555556
46785, 0.15217391304348, 0.46304347826087, 0.33333333333333
46786, 0.1304347826087, 0.43695652173913, 0.33333333333333
46787, 0.1304347826087, 0.46304347826087, 0.36111111111111
46788, 0.15217391304348, 0.46304347826087, 0.38888888888889
46789, 0.1304347826087, 0.43695652173913, 0.38888888888889
46790, 0.1304347826087, 0.46304347826087, 0.41666666666667
46791, 0.15217391304348, 0.46304347826087, 0.44444444444444
46792, 0.1304347826087, 0.43695652173913, 0.44444444444444
46793, 0.1304347826087, 0.46304347826087, 0.47222222222222
46794, 0.08695652173913, 0.46304347826087, 0.027777777777778
46795, 0.10869565217391, 0.46304347826087, 0.055555555555556
46796, 0.08695652173913, 0.43695652173913, 0.055555555555556
46797, 0.08695652173913, 0.46304347826087, 0.083333333333333
46798, 0.10869565217391, 0.46304347826087, 0.11111111111111
46799, 0.08695652173913, 0.43695652173913, 0.11111111111111
46800, 0.08695652173913, 0.46304347826087, 0.13888888888889
46801, 0.10869565217391, 0.46304347826087, 0.16666666666667
46802, 0.08695652173913, 0.43695652173913, 0.16666666666667
46803, 0.08695652173913, 0.46304347826087, 0.19444444444444
46804, 0.10869565217391, 0.46304347826087, 0.22222222222222
46805, 0.08695652173913, 0.43695652173913, 0.22222222222222
46806, 0.08695652173913, 0.46304347826087, 0.25
46807, 0.10869565217391, 0.46304347826087, 0.27777777777778
46808, 0.08695652173913, 0.43695652173913, 0.27777777777778
46809, 0.08695652173913, 0.46304347826087, 0.30555555555556
46810, 0.10869565217391, 0.46304347826087, 0.33333333333333
46811, 0.08695652173913, 0.43695652173913, 0.33333333333333
46812, 0.08695652173913, 0.46304347826087, 0.36111111111111
46813, 0.10869565217391, 0.46304347826087, 0.38888888888889
46814, 0.08695652173913, 0.43695652173913, 0.38888888888889
46815, 0.08695652173913, 0.46304347826087, 0.41666666666667
46816, 0.10869565217391, 0.46304347826087, 0.44444444444444
46817, 0.08695652173913, 0.43695652173913, 0.44444444444444
46818, 0.08695652173913, 0.46304347826087, 0.47222222222222
46819, 0.043478260869565, 0.46304347826087, 0.027777777777778
46820, 0.065217391304348, 0.46304347826087, 0.055555555555556
46821, 0.043478260869565, 0.43695652173913, 0.055555555555556
46822, 0.043478260869565, 0.46304347826087, 0.083333333333333
46823, 0.065217391304348, 0.46304347826087, 0.11111111111111
46824, 0.043478260869565, 0.43695652173913, 0.11111111111111
46825, 0.043478260869565, 0.46304347826087, 0.13888888888889
46826, 0.065217391304348, 0.46304347826087, 0.16666666666667
46827, 0.043478260869565, 0.43695652173913, 0.16666666666667
46828, 0.043478260869565, 0.46304347826087, 0.19444444444444
46829, 0.065217391304348, 0.46304347826087, 0.22222222222222
46830, 0.043478260869565, 0.43695652173913, 0.22222222222222
46831, 0.043478260869565, 0.46304347826087, 0.25
46832, 0.065217391304348, 0.46304347826087, 0.27777777777778
46833, 0.043478260869565, 0.43695652173913, 0.27777777777778
46834, 0.043478260869565, 0.46304347826087, 0.30555555555556
46835, 0.065217391304348, 0.46304347826087, 0.33333333333333
46836, 0.043478260869565, 0.43695652173913, 0.33333333333333
46837, 0.043478260869565, 0.46304347826087, 0.36111111111111
46838, 0.065217391304348, 0.46304347826087, 0.38888888888889
46839, 0.043478260869565, 0.43695652173913, 0.38888888888889
46840, 0.043478260869565, 0.46304347826087, 0.41666666666667
46841, 0.065217391304348, 0.46304347826087, 0.44444444444444
46842, 0.043478260869565, 0.43695652173913, 0.44444444444444
46843, 0.043478260869565, 0.46304347826087, 0.47222222222222
46844, 0.021739130434783, 0.46304347826087, 0.055555555555556
46845, 0.021739130434783, 0.46304347826087, 0.11111111111111
46846, 0.021739130434783, 0.46304347826087, 0.16666666666667
46847, 0.021739130434783, 0.46304347826087, 0.22222222222222
46848, 0.021739130434783, 0.46304347826087, 0.27777777777778
46849, 0.021739130434783, 0.46304347826087, 0.33333333333333
46850, 0.021739130434783, 0.46304347826087, 0.38888888888889
46851, 0.021739130434783, 0.46304347826087, 0.44444444444444
46852, 0.95652173913043, 0.51521739130435, 0.027777777777778
46853, 0.97826086956522, 0.51521739130435, 0.055555555555556
46854, 0.95652173913043, 0.48913043478261, 0.055555555555556
46855, 0.95652173913043, 0.51521739130435, 0.083333333333333
46856, 0.97826086956522, 0.51521739130435, 0.11111111111111
46857, 0.95652173913044, 0.48913043478261, 0.11111111111111
46858, 0.95652173913043, 0.51521739130435, 0.13888888888889
46859, 0.97826086956522, 0.51521739130435, 0.16666666666667
46860, 0.95652173913043, 0.48913043478261, 0.16666666666667
46861, 0.95652173913043, 0.51521739130435, 0.19444444444444
46862, 0.97826086956522, 0.51521739130435, 0.22222222222222
46863, 0.95652173913044, 0.48913043478261, 0.22222222222222
46864, 0.95652173913044, 0.51521739130435, 0.25
46865, 0.97826086956522, 0.51521739130435, 0.27777777777778
46866, 0.95652173913044, 0.48913043478261, 0.27777777777778
46867, 0.95652173913043, 0.51521739130435, 0.30555555555556
46868, 0.97826086956522, 0.51521739130435, 0.33333333333333
46869, 0.95652173913043, 0.48913043478261, 0.33333333333333
46870, 0.95652173913043, 0.51521739130435, 0.36111111111111
46871, 0.97826086956522, 0.51521739130435, 0.38888888888889
46872, 0.95652173913043, 0.48913043478261, 0.38888888888889
46873, 0.95652173913043, 0.51521739130435, 0.41666666666667
46874, 0.97826086956522, 0.51521739130435, 0.44444444444444
46875, 0.95652173913043, 0.48913043478261, 0.44444444444444
46876, 0.95652173913043, 0.51521739130435, 0.47222222222222
46877, 0.91304347826087, 0.51521739130435, 0.027777777777778
46878, 0.93478260869565, 0.51521739130435, 0.055555555555556
46879, 0.91304347826087, 0.48913043478261, 0.055555555555556
46880, 0.91304347826087, 0.51521739130435, 0.083333333333333
46881, 0.93478260869565, 0.51521739130435, 0.11111111111111
46882, 0.91304347826087, 0.48913043478261, 0.11111111111111
46883, 0.91304347826087, 0.51521739130435, 0.13888888888889
46884, 0.93478260869565, 0.51521739130435, 0.16666666666667
46885, 0.91304347826087, 0.48913043478261, 0.16666666666667
46886, 0.91304347826087, 0.51521739130435, 0.19444444444444
46887, 0.93478260869565, 0.51521739130435, 0.22222222222222
46888, 0.91304347826087, 0.48913043478261, 0.22222222222222
46889, 0.91304347826087, 0.51521739130435, 0.25
46890, 0.93478260869565, 0.51521739130435, 0.27777777777778
46891, 0.91304347826087, 0.48913043478261, 0.27777777777778
46892, 0.91304347826087, 0.51521739130435, 0.30555555555556
46893, 0.93478260869565, 0.51521739130435, 0.33333333333333
46894, 0.91304347826087, 0.48913043478261, 0.33333333333333
46895, 0.91304347826087, 0.51521739130435, 0.36111111111111
46896, 0.93478260869565, 0.51521739130435, 0.38888888888889
46897, 0.91304347826087, 0.48913043478261, 0.38888888888889
46898, 0.91304347826087, 0.51521739130435, 0.41666666666667
46899, 0.93478260869565, 0.51521739130435, 0.44444444444444
46900, 0.91304347826087, 0.48913043478261, 0.44444444444444
46901, 0.91304347826087, 0.51521739130435, 0.47222222222222
46902, 0.8695652173913, 0.51521739130435, 0.027777777777778
46903, 0.89130434782609, 0.51521739130435, 0.055555555555556
46904, 0.8695652173913, 0.48913043478261, 0.055555555555556
46905, 0.8695652173913, 0.51521739130435, 0.083333333333333
46906, 0.89130434782609, 0.51521739130435, 0.11111111111111
46907, 0.8695652173913, 0.48913043478261, 0.11111111111111
46908, 0.8695652173913, 0.51521739130435, 0.13888888888889
46909, 0.89130434782609, 0.51521739130435, 0.16666666666667
46910, 0.8695652173913, 0.48913043478261, 0.16666666666667
46911, 0.8695652173913, 0.51521739130435, 0.19444444444444
46912, 0.89130434782609, 0.51521739130435, 0.22222222222222
46913, 0.8695652173913, 0.48913043478261, 0.22222222222222
46914, 0.8695652173913, 0.51521739130435, 0.25
46915, 0.89130434782609, 0.51521739130435, 0.27777777777778
46916, 0.8695652173913, 0.48913043478261, 0.27777777777778
46917, 0.8695652173913, 0.51521739130435, 0.30555555555556
46918, 0.89130434782609, 0.51521739130435, 0.33333333333333
46919, 0.8695652173913, 0.48913043478261, 0.33333333333333
46920, 0.8695652173913, 0.51521739130435, 0.36111111111111
46921, 0.89130434782609, 0.51521739130435, 0.38888888888889
46922, 0.8695652173913, 0.48913043478261, 0.38888888888889
46923, 0.8695652173913, 0.51521739130435, 0.41666666666667
46924, 0.89130434782609, 0.51521739130435, 0.44444444444444
46925, 0.8695652173913, 0.48913043478261, 0.44444444444444
46926, 0.8695652173913, 0.51521739130435, 0.47222222222222
46927, 0.82608695652174, 0.51521739130435, 0.027777777777778
46928, 0.84782608695652, 0.51521739130435, 0.055555555555556
46929, 0.82608695652174, 0.48913043478261, 0.055555555555556
46930, 0.82608695652174, 0.51521739130435, 0.083333333333333
46931, 0.84782608695652, 0.51521739130435, 0.11111111111111
46932, 0.82608695652174, 0.48913043478261, 0.11111111111111
46933, 0.82608695652174, 0.51521739130435, 0.13888888888889
46934, 0.84782608695652, 0.51521739130435, 0.16666666666667
46935, 0.82608695652174, 0.48913043478261, 0.16666666666667
46936, 0.82608695652174, 0.51521739130435, 0.19444444444444
46937, 0.84782608695652, 0.51521739130435, 0.22222222222222
46938, 0.82608695652174, 0.48913043478261, 0.22222222222222
46939, 0.82608695652174, 0.51521739130435, 0.25
46940, 0.84782608695652, 0.51521739130435, 0.27777777777778
46941, 0.82608695652174, 0.48913043478261, 0.27777777777778
46942, 0.82608695652174, 0.51521739130435, 0.30555555555556
46943, 0.84782608695652, 0.51521739130435, 0.33333333333333
46944, 0.82608695652174, 0.48913043478261, 0.33333333333333
46945, 0.82608695652174, 0.51521739130435, 0.36111111111111
46946, 0.84782608695652, 0.51521739130435, 0.38888888888889
46947, 0.82608695652174, 0.48913043478261, 0.38888888888889
46948, 0.82608695652174, 0.51521739130435, 0.41666666666667
46949, 0.84782608695652, 0.51521739130435, 0.44444444444444
46950, 0.82608695652174, 0.48913043478261, 0.44444444444444
46951, 0.82608695652174, 0.51521739130435, 0.47222222222222
46952, 0.78260869565217, 0.51521739130435, 0.027777777777778
46953, 0.80434782608696, 0.51521739130435, 0.055555555555556
46954, 0.78260869565217, 0.48913043478261, 0.055555555555556
46955, 0.78260869565217, 0.51521739130435, 0.083333333333333
46956, 0.80434782608696, 0.51521739130435, 0.11111111111111
46957, 0.78260869565217, 0.48913043478261, 0.11111111111111
46958, 0.78260869565217, 0.51521739130435, 0.13888888888889
46959, 0.80434782608696, 0.51521739130435, 0.16666666666667
46960, 0.78260869565217, 0.48913043478261, 0.16666666666667
46961, 0.78260869565217, 0.51521739130435, 0.19444444444444
46962, 0.80434782608696, 0.51521739130435, 0.22222222222222
46963, 0.78260869565217, 0.48913043478261, 0.22222222222222
46964, 0.78260869565217, 0.51521739130435, 0.25
46965, 0.80434782608696, 0.51521739130435, 0.27777777777778
46966, 0.78260869565217, 0.48913043478261, 0.27777777777778
46967, 0.78260869565217, 0.51521739130435, 0.30555555555556
46968, 0.80434782608696, 0.51521739130435, 0.33333333333333
46969, 0.78260869565217, 0.48913043478261, 0.33333333333333
46970, 0.78260869565217, 0.51521739130435, 0.36111111111111
46971, 0.80434782608696, 0.51521739130435, 0.38888888888889
46972, 0.78260869565217, 0.48913043478261, 0.38888888888889
46973, 0.78260869565217, 0.51521739130435, 0.41666666666667
46974, 0.80434782608696, 0.51521739130435, 0.44444444444444
46975, 0.78260869565217, 0.48913043478261, 0.44444444444444
46976, 0.78260869565217, 0.51521739130435, 0.47222222222222
46977, 0.73913043478261, 0.51521739130435, 0.027777777777778
46978, 0.76086956521739, 0.51521739130435, 0.055555555555556
46979, 0.73913043478261, 0.48913043478261, 0.055555555555556
46980, 0.73913043478261, 0.51521739130435, 0.083333333333333
46981, 0.76086956521739, 0.51521739130435, 0.11111111111111
46982, 0.73913043478261, 0.48913043478261, 0.11111111111111
46983, 0.73913043478261, 0.51521739130435, 0.13888888888889
46984, 0.76086956521739, 0.51521739130435, 0.16666666666667
46985, 0.73913043478261, 0.48913043478261, 0.16666666666667
46986, 0.73913043478261, 0.51521739130435, 0.19444444444444
46987, 0.76086956521739, 0.51521739130435, 0.22222222222222
46988, 0.73913043478261, 0.48913043478261, 0.22222222222222
46989, 0.73913043478261, 0.51521739130435, 0.25
46990, 0.76086956521739, 0.51521739130435, 0.27777777777778
46991, 0.73913043478261, 0.48913043478261, 0.27777777777778
46992, 0.73913043478261, 0.51521739130435, 0.30555555555556
46993, 0.76086956521739, 0.51521739130435, 0.33333333333333
46994, 0.73913043478261, 0.48913043478261, 0.33333333333333
46995, 0.73913043478261, 0.51521739130435, 0.36111111111111
46996, 0.76086956521739, 0.51521739130435, 0.38888888888889
46997, 0.73913043478261, 0.48913043478261, 0.38888888888889
46998, 0.73913043478261, 0.51521739130435, 0.41666666666667
46999, 0.76086956521739, 0.51521739130435, 0.44444444444444
47000, 0.73913043478261, 0.48913043478261, 0.44444444444444
47001, 0.73913043478261, 0.51521739130435, 0.47222222222222
47002, 0.69565217391304, 0.51521739130435, 0.027777777777778
47003, 0.71739130434783, 0.51521739130435, 0.055555555555556
47004, 0.69565217391304, 0.48913043478261, 0.055555555555556
47005, 0.69565217391304, 0.51521739130435, 0.083333333333333
47006, 0.71739130434783, 0.51521739130435, 0.11111111111111
47007, 0.69565217391304, 0.48913043478261, 0.11111111111111
47008, 0.69565217391304, 0.51521739130435, 0.13888888888889
47009, 0.71739130434783, 0.51521739130435, 0.16666666666667
47010, 0.69565217391304, 0.48913043478261, 0.16666666666667
47011, 0.69565217391304, 0.51521739130435, 0.19444444444444
47012, 0.71739130434783, 0.51521739130435, 0.22222222222222
47013, 0.69565217391304, 0.48913043478261, 0.22222222222222
47014, 0.69565217391304, 0.51521739130435, 0.25
47015, 0.71739130434783, 0.51521739130435, 0.27777777777778
47016, 0.69565217391304, 0.48913043478261, 0.27777777777778
47017, 0.69565217391304, 0.51521739130435, 0.30555555555556
47018, 0.71739130434783, 0.51521739130435, 0.33333333333333
47019, 0.69565217391304, 0.48913043478261, 0.33333333333333
47020, 0.69565217391304, 0.51521739130435, 0.36111111111111
47021, 0.71739130434783, 0.51521739130435, 0.38888888888889
47022, 0.69565217391304, 0.48913043478261, 0.38888888888889
47023, 0.69565217391304, 0.51521739130435, 0.41666666666667
47024, 0.71739130434783, 0.51521739130435, 0.44444444444444
47025, 0.69565217391304, 0.48913043478261, 0.44444444444444
47026, 0.69565217391304, 0.51521739130435, 0.47222222222222
47027, 0.65217391304348, 0.51521739130435, 0.027777777777778
47028, 0.67391304347826, 0.51521739130435, 0.055555555555556
47029, 0.65217391304348, 0.48913043478261, 0.055555555555556
47030, 0.65217391304348, 0.51521739130435, 0.083333333333333
47031, 0.67391304347826, 0.51521739130435, 0.11111111111111
47032, 0.65217391304348, 0.48913043478261, 0.11111111111111
47033, 0.65217391304348, 0.51521739130435, 0.13888888888889
47034, 0.67391304347826, 0.51521739130435, 0.16666666666667
47035, 0.65217391304348, 0.48913043478261, 0.16666666666667
47036, 0.65217391304348, 0.51521739130435, 0.19444444444444
47037, 0.67391304347826, 0.51521739130435, 0.22222222222222
47038, 0.65217391304348, 0.48913043478261, 0.22222222222222
47039, 0.65217391304348, 0.51521739130435, 0.25
47040, 0.67391304347826, 0.51521739130435, 0.27777777777778
47041, 0.65217391304348, 0.48913043478261, 0.27777777777778
47042, 0.65217391304348, 0.51521739130435, 0.30555555555556
47043, 0.67391304347826, 0.51521739130435, 0.33333333333333
47044, 0.65217391304348, 0.48913043478261, 0.33333333333333
47045, 0.65217391304348, 0.51521739130435, 0.36111111111111
47046, 0.67391304347826, 0.51521739130435, 0.38888888888889
47047, 0.65217391304348, 0.48913043478261, 0.38888888888889
47048, 0.65217391304348, 0.51521739130435, 0.41666666666667
47049, 0.67391304347826, 0.51521739130435, 0.44444444444444
47050, 0.65217391304348, 0.48913043478261, 0.44444444444444
47051, 0.65217391304348, 0.51521739130435, 0.47222222222222
47052, 0.60869565217391, 0.51521739130435, 0.027777777777778
47053, 0.6304347826087, 0.51521739130435, 0.055555555555556
47054, 0.60869565217391, 0.48913043478261, 0.055555555555556
47055, 0.60869565217391, 0.51521739130435, 0.083333333333333
47056, 0.6304347826087, 0.51521739130435, 0.11111111111111
47057, 0.60869565217391, 0.48913043478261, 0.11111111111111
47058, 0.60869565217391, 0.51521739130435, 0.13888888888889
47059, 0.6304347826087, 0.51521739130435, 0.16666666666667
47060, 0.60869565217391, 0.48913043478261, 0.16666666666667
47061, 0.60869565217391, 0.51521739130435, 0.19444444444444
47062, 0.6304347826087, 0.51521739130435, 0.22222222222222
47063, 0.60869565217391, 0.48913043478261, 0.22222222222222
47064, 0.60869565217391, 0.51521739130435, 0.25
47065, 0.6304347826087, 0.51521739130435, 0.27777777777778
47066, 0.60869565217391, 0.48913043478261, 0.27777777777778
47067, 0.60869565217391, 0.51521739130435, 0.30555555555556
47068, 0.6304347826087, 0.51521739130435, 0.33333333333333
47069, 0.60869565217391, 0.48913043478261, 0.33333333333333
47070, 0.60869565217391, 0.51521739130435, 0.36111111111111
47071, 0.6304347826087, 0.51521739130435, 0.38888888888889
47072, 0.60869565217391, 0.48913043478261, 0.38888888888889
47073, 0.60869565217391, 0.51521739130435, 0.41666666666667
47074, 0.6304347826087, 0.51521739130435, 0.44444444444444
47075, 0.60869565217391, 0.48913043478261, 0.44444444444444
47076, 0.60869565217391, 0.51521739130435, 0.47222222222222
47077, 0.56521739130435, 0.51521739130435, 0.027777777777778
47078, 0.58695652173913, 0.51521739130435, 0.055555555555556
47079, 0.56521739130435, 0.48913043478261, 0.055555555555556
47080, 0.56521739130435, 0.51521739130435, 0.083333333333333
47081, 0.58695652173913, 0.51521739130435, 0.11111111111111
47082, 0.56521739130435, 0.48913043478261, 0.11111111111111
47083, 0.56521739130435, 0.51521739130435, 0.13888888888889
47084, 0.58695652173913, 0.51521739130435, 0.16666666666667
47085, 0.56521739130435, 0.48913043478261, 0.16666666666667
47086, 0.56521739130435, 0.51521739130435, 0.19444444444444
47087, 0.58695652173913, 0.51521739130435, 0.22222222222222
47088, 0.56521739130435, 0.48913043478261, 0.22222222222222
47089, 0.56521739130435, 0.51521739130435, 0.25
47090, 0.58695652173913, 0.51521739130435, 0.27777777777778
47091, 0.56521739130435, 0.48913043478261, 0.27777777777778
47092, 0.56521739130435, 0.51521739130435, 0.30555555555556
47093, 0.58695652173913, 0.51521739130435, 0.33333333333333
47094, 0.56521739130435, 0.48913043478261, 0.33333333333333
47095, 0.56521739130435, 0.51521739130435, 0.36111111111111
47096, 0.58695652173913, 0.51521739130435, 0.38888888888889
47097, 0.56521739130435, 0.48913043478261, 0.38888888888889
47098, 0.56521739130435, 0.51521739130435, 0.41666666666667
47099, 0.58695652173913, 0.51521739130435, 0.44444444444444
47100, 0.56521739130435, 0.48913043478261, 0.44444444444444
47101, 0.56521739130435, 0.51521739130435, 0.47222222222222
47102, 0.52173913043478, 0.51521739130435, 0.027777777777778
47103, 0.54347826086956, 0.51521739130435, 0.055555555555556
47104, 0.52173913043478, 0.48913043478261, 0.055555555555556
47105, 0.52173913043478, 0.51521739130435, 0.083333333333333
47106, 0.54347826086956, 0.51521739130435, 0.11111111111111
47107, 0.52173913043478, 0.48913043478261, 0.11111111111111
47108, 0.52173913043478, 0.51521739130435, 0.13888888888889
47109, 0.54347826086956, 0.51521739130435, 0.16666666666667
47110, 0.52173913043478, 0.48913043478261, 0.16666666666667
47111, 0.52173913043478, 0.51521739130435, 0.19444444444444
47112, 0.54347826086956, 0.51521739130435, 0.22222222222222
47113, 0.52173913043478, 0.48913043478261, 0.22222222222222
47114, 0.52173913043478, 0.51521739130435, 0.25
47115, 0.54347826086956, 0.51521739130435, 0.27777777777778
47116, 0.52173913043478, 0.48913043478261, 0.27777777777778
47117, 0.52173913043478, 0.51521739130435, 0.30555555555556
47118, 0.54347826086956, 0.51521739130435, 0.33333333333333
47119, 0.52173913043478, 0.48913043478261, 0.33333333333333
47120, 0.52173913043478, 0.51521739130435, 0.36111111111111
47121, 0.54347826086956, 0.51521739130435, 0.38888888888889
47122, 0.52173913043478, 0.48913043478261, 0.38888888888889
47123, 0.52173913043478, 0.51521739130435, 0.41666666666667
47124, 0.54347826086956, 0.51521739130435, 0.44444444444444
47125, 0.52173913043478, 0.48913043478261, 0.44444444444444
47126, 0.52173913043478, 0.51521739130435, 0.47222222222222
47127, 0.47826086956522, 0.51521739130435, 0.027777777777778
47128, 0.5, 0.51521739130435, 0.055555555555556
47129, 0.47826086956522, 0.48913043478261, 0.055555555555556
47130, 0.47826086956522, 0.51521739130435, 0.083333333333333
47131, 0.5, 0.51521739130435, 0.11111111111111
47132, 0.47826086956522, 0.48913043478261, 0.11111111111111
47133, 0.47826086956522, 0.51521739130435, 0.13888888888889
47134, 0.5, 0.51521739130435, 0.16666666666667
47135, 0.47826086956522, 0.48913043478261, 0.16666666666667
47136, 0.47826086956522, 0.51521739130435, 0.19444444444444
47137, 0.5, 0.51521739130435, 0.22222222222222
47138, 0.47826086956522, 0.48913043478261, 0.22222222222222
47139, 0.47826086956522, 0.51521739130435, 0.25
47140, 0.5, 0.51521739130435, 0.27777777777778
47141, 0.47826086956522, 0.48913043478261, 0.27777777777778
47142, 0.47826086956522, 0.51521739130435, 0.30555555555556
47143, 0.5, 0.51521739130435, 0.33333333333333
47144, 0.47826086956522, 0.48913043478261, 0.33333333333333
47145, 0.47826086956522, 0.51521739130435, 0.36111111111111
47146, 0.5, 0.51521739130435, 0.38888888888889
47147, 0.47826086956522, 0.48913043478261, 0.38888888888889
47148, 0.47826086956522, 0.51521739130435, 0.41666666666667
47149, 0.5, 0.51521739130435, 0.44444444444444
47150, 0.47826086956522, 0.48913043478261, 0.44444444444444
47151, 0.47826086956522, 0.51521739130435, 0.47222222222222
47152, 0.43478260869565, 0.51521739130435, 0.027777777777778
47153, 0.45652173913043, 0.51521739130435, 0.055555555555556
47154, 0.43478260869565, 0.48913043478261, 0.055555555555556
47155, 0.43478260869565, 0.51521739130435, 0.083333333333333
47156, 0.45652173913044, 0.51521739130435, 0.11111111111111
47157, 0.43478260869565, 0.48913043478261, 0.11111111111111
47158, 0.43478260869565, 0.51521739130435, 0.13888888888889
47159, 0.45652173913043, 0.51521739130435, 0.16666666666667
47160, 0.43478260869565, 0.48913043478261, 0.16666666666667
47161, 0.43478260869565, 0.51521739130435, 0.19444444444444
47162, 0.45652173913043, 0.51521739130435, 0.22222222222222
47163, 0.43478260869565, 0.48913043478261, 0.22222222222222
47164, 0.43478260869565, 0.51521739130435, 0.25
47165, 0.45652173913043, 0.51521739130435, 0.27777777777778
47166, 0.43478260869565, 0.48913043478261, 0.27777777777778
47167, 0.43478260869565, 0.51521739130435, 0.30555555555556
47168, 0.45652173913043, 0.51521739130435, 0.33333333333333
47169, 0.43478260869565, 0.48913043478261, 0.33333333333333
47170, 0.43478260869565, 0.51521739130435, 0.36111111111111
47171, 0.45652173913044, 0.51521739130435, 0.38888888888889
47172, 0.43478260869565, 0.48913043478261, 0.38888888888889
47173, 0.43478260869565, 0.51521739130435, 0.41666666666667
47174, 0.45652173913043, 0.51521739130435, 0.44444444444444
47175, 0.43478260869565, 0.48913043478261, 0.44444444444444
47176, 0.43478260869565, 0.51521739130435, 0.47222222222222
47177, 0.39130434782609, 0.51521739130435, 0.027777777777778
47178, 0.41304347826087, 0.51521739130435, 0.055555555555556
47179, 0.39130434782609, 0.48913043478261, 0.055555555555556
47180, 0.39130434782609, 0.51521739130435, 0.083333333333333
47181, 0.41304347826087, 0.51521739130435, 0.11111111111111
47182, 0.39130434782609, 0.48913043478261, 0.11111111111111
47183, 0.39130434782609, 0.51521739130435, 0.13888888888889
47184, 0.41304347826087, 0.51521739130435, 0.16666666666667
47185, 0.39130434782609, 0.48913043478261, 0.16666666666667
47186, 0.39130434782609, 0.51521739130435, 0.19444444444444
47187, 0.41304347826087, 0.51521739130435, 0.22222222222222
47188, 0.39130434782609, 0.48913043478261, 0.22222222222222
47189, 0.39130434782609, 0.51521739130435, 0.25
47190, 0.41304347826087, 0.51521739130435, 0.27777777777778
47191, 0.39130434782609, 0.48913043478261, 0.27777777777778
47192, 0.39130434782609, 0.51521739130435, 0.30555555555556
47193, 0.41304347826087, 0.51521739130435, 0.33333333333333
47194, 0.39130434782609, 0.48913043478261, 0.33333333333333
47195, 0.39130434782609, 0.51521739130435, 0.36111111111111
47196, 0.41304347826087, 0.51521739130435, 0.38888888888889
47197, 0.39130434782609, 0.48913043478261, 0.38888888888889
47198, 0.39130434782609, 0.51521739130435, 0.41666666666667
47199, 0.41304347826087, 0.51521739130435, 0.44444444444444
47200, 0.39130434782609, 0.48913043478261, 0.44444444444444
47201, 0.39130434782609, 0.51521739130435, 0.47222222222222
47202, 0.34782608695652, 0.51521739130435, 0.027777777777778
47203, 0.3695652173913, 0.51521739130435, 0.055555555555556
47204, 0.34782608695652, 0.48913043478261, 0.055555555555556
47205, 0.34782608695652, 0.51521739130435, 0.083333333333333
47206, 0.3695652173913, 0.51521739130435, 0.11111111111111
47207, 0.34782608695652, 0.48913043478261, 0.11111111111111
47208, 0.34782608695652, 0.51521739130435, 0.13888888888889
47209, 0.3695652173913, 0.51521739130435, 0.16666666666667
47210, 0.34782608695652, 0.48913043478261, 0.16666666666667
47211, 0.34782608695652, 0.51521739130435, 0.19444444444444
47212, 0.3695652173913, 0.51521739130435, 0.22222222222222
47213, 0.34782608695652, 0.48913043478261, 0.22222222222222
47214, 0.34782608695652, 0.51521739130435, 0.25
47215, 0.3695652173913, 0.51521739130435, 0.27777777777778
47216, 0.34782608695652, 0.48913043478261, 0.27777777777778
47217, 0.34782608695652, 0.51521739130435, 0.30555555555556
47218, 0.3695652173913, 0.51521739130435, 0.33333333333333
47219, 0.34782608695652, 0.48913043478261, 0.33333333333333
47220, 0.34782608695652, 0.51521739130435, 0.36111111111111
47221, 0.3695652173913, 0.51521739130435, 0.38888888888889
47222, 0.34782608695652, 0.48913043478261, 0.38888888888889
47223, 0.34782608695652, 0.51521739130435, 0.41666666666667
47224, 0.3695652173913, 0.51521739130435, 0.44444444444444
47225, 0.34782608695652, 0.48913043478261, 0.44444444444444
47226, 0.34782608695652, 0.51521739130435, 0.47222222222222
47227, 0.30434782608696, 0.51521739130435, 0.027777777777778
47228, 0.32608695652174, 0.51521739130435, 0.055555555555556
47229, 0.30434782608696, 0.48913043478261, 0.055555555555556
47230, 0.30434782608696, 0.51521739130435, 0.083333333333333
47231, 0.32608695652174, 0.51521739130435, 0.11111111111111
47232, 0.30434782608696, 0.48913043478261, 0.11111111111111
47233, 0.30434782608696, 0.51521739130435, 0.13888888888889
47234, 0.32608695652174, 0.51521739130435, 0.16666666666667
47235, 0.30434782608696, 0.48913043478261, 0.16666666666667
47236, 0.30434782608696, 0.51521739130435, 0.19444444444444
47237, 0.32608695652174, 0.51521739130435, 0.22222222222222
47238, 0.30434782608696, 0.48913043478261, 0.22222222222222
47239, 0.30434782608696, 0.51521739130435, 0.25
47240, 0.32608695652174, 0.51521739130435, 0.27777777777778
47241, 0.30434782608696, 0.48913043478261, 0.27777777777778
47242, 0.30434782608696, 0.51521739130435, 0.30555555555556
47243, 0.32608695652174, 0.51521739130435, 0.33333333333333
47244, 0.30434782608696, 0.48913043478261, 0.33333333333333
47245, 0.30434782608696, 0.51521739130435, 0.36111111111111
47246, 0.32608695652174, 0.51521739130435, 0.38888888888889
47247, 0.30434782608696, 0.48913043478261, 0.38888888888889
47248, 0.30434782608696, 0.51521739130435, 0.41666666666667
47249, 0.32608695652174, 0.51521739130435, 0.44444444444444
47250, 0.30434782608696, 0.48913043478261, 0.44444444444444
47251, 0.30434782608696, 0.51521739130435, 0.47222222222222
47252, 0.26086956521739, 0.51521739130435, 0.027777777777778
47253, 0.28260869565217, 0.51521739130435, 0.055555555555556
47254, 0.26086956521739, 0.48913043478261, 0.055555555555556
47255, 0.26086956521739, 0.51521739130435, 0.083333333333333
47256, 0.28260869565217, 0.51521739130435, 0.11111111111111
47257, 0.26086956521739, 0.48913043478261, 0.11111111111111
47258, 0.26086956521739, 0.51521739130435, 0.13888888888889
47259, 0.28260869565217, 0.51521739130435, 0.16666666666667
47260, 0.26086956521739, 0.48913043478261, 0.16666666666667
47261, 0.26086956521739, 0.51521739130435, 0.19444444444444
47262, 0.28260869565217, 0.51521739130435, 0.22222222222222
47263, 0.26086956521739, 0.48913043478261, 0.22222222222222
47264, 0.26086956521739, 0.51521739130435, 0.25
47265, 0.28260869565217, 0.51521739130435, 0.27777777777778
47266, 0.26086956521739, 0.48913043478261, 0.27777777777778
47267, 0.26086956521739, 0.51521739130435, 0.30555555555556
47268, 0.28260869565217, 0.51521739130435, 0.33333333333333
47269, 0.26086956521739, 0.48913043478261, 0.33333333333333
47270, 0.26086956521739, 0.51521739130435, 0.36111111111111
47271, 0.28260869565217, 0.51521739130435, 0.38888888888889
47272, 0.26086956521739, 0.48913043478261, 0.38888888888889
47273, 0.26086956521739, 0.51521739130435, 0.41666666666667
47274, 0.28260869565217, 0.51521739130435, 0.44444444444444
47275, 0.26086956521739, 0.48913043478261, 0.44444444444444
47276, 0.26086956521739, 0.51521739130435, 0.47222222222222
47277, 0.21739130434783, 0.51521739130435, 0.027777777777778
47278, 0.23913043478261, 0.51521739130435, 0.055555555555556
47279, 0.21739130434783, 0.48913043478261, 0.055555555555556
47280, 0.21739130434783, 0.51521739130435, 0.083333333333333
47281, 0.23913043478261, 0.51521739130435, 0.11111111111111
47282, 0.21739130434783, 0.48913043478261, 0.11111111111111
47283, 0.21739130434783, 0.51521739130435, 0.13888888888889
47284, 0.23913043478261, 0.51521739130435, 0.16666666666667
47285, 0.21739130434783, 0.48913043478261, 0.16666666666667
47286, 0.21739130434783, 0.51521739130435, 0.19444444444444
47287, 0.23913043478261, 0.51521739130435, 0.22222222222222
47288, 0.21739130434783, 0.48913043478261, 0.22222222222222
47289, 0.21739130434783, 0.51521739130435, 0.25
47290, 0.23913043478261, 0.51521739130435, 0.27777777777778
47291, 0.21739130434783, 0.48913043478261, 0.27777777777778
47292, 0.21739130434783, 0.51521739130435, 0.30555555555556
47293, 0.23913043478261, 0.51521739130435, 0.33333333333333
47294, 0.21739130434783, 0.48913043478261, 0.33333333333333
47295, 0.21739130434783, 0.51521739130435, 0.36111111111111
47296, 0.23913043478261, 0.51521739130435, 0.38888888888889
47297, 0.21739130434783, 0.48913043478261, 0.38888888888889
47298, 0.21739130434783, 0.51521739130435, 0.41666666666667
47299, 0.23913043478261, 0.51521739130435, 0.44444444444444
47300, 0.21739130434783, 0.48913043478261, 0.44444444444444
47301, 0.21739130434783, 0.51521739130435, 0.47222222222222
47302, 0.17391304347826, 0.51521739130435, 0.027777777777778
47303, 0.19565217391304, 0.51521739130435, 0.055555555555556
47304, 0.17391304347826, 0.48913043478261, 0.055555555555556
47305, 0.17391304347826, 0.51521739130435, 0.083333333333333
47306, 0.19565217391304, 0.51521739130435, 0.11111111111111
47307, 0.17391304347826, 0.48913043478261, 0.11111111111111
47308, 0.17391304347826, 0.51521739130435, 0.13888888888889
47309, 0.19565217391304, 0.51521739130435, 0.16666666666667
47310, 0.17391304347826, 0.48913043478261, 0.16666666666667
47311, 0.17391304347826, 0.51521739130435, 0.19444444444444
47312, 0.19565217391304, 0.51521739130435, 0.22222222222222
47313, 0.17391304347826, 0.48913043478261, 0.22222222222222
47314, 0.17391304347826, 0.51521739130435, 0.25
47315, 0.19565217391304, 0.51521739130435, 0.27777777777778
47316, 0.17391304347826, 0.48913043478261, 0.27777777777778
47317, 0.17391304347826, 0.51521739130435, 0.30555555555556
47318, 0.19565217391304, 0.51521739130435, 0.33333333333333
47319, 0.17391304347826, 0.48913043478261, 0.33333333333333
47320, 0.17391304347826, 0.51521739130435, 0.36111111111111
47321, 0.19565217391304, 0.51521739130435, 0.38888888888889
47322, 0.17391304347826, 0.48913043478261, 0.38888888888889
47323, 0.17391304347826, 0.51521739130435, 0.41666666666667
47324, 0.19565217391304, 0.51521739130435, 0.44444444444444
47325, 0.17391304347826, 0.48913043478261, 0.44444444444444
47326, 0.17391304347826, 0.51521739130435, 0.47222222222222
47327, 0.1304347826087, 0.51521739130435, 0.027777777777778
47328, 0.15217391304348, 0.51521739130435, 0.055555555555556
47329, 0.1304347826087, 0.48913043478261, 0.055555555555556
47330, 0.1304347826087, 0.51521739130435, 0.083333333333333
47331, 0.15217391304348, 0.51521739130435, 0.11111111111111
47332, 0.1304347826087, 0.48913043478261, 0.11111111111111
47333, 0.1304347826087, 0.51521739130435, 0.13888888888889
47334, 0.15217391304348, 0.51521739130435, 0.16666666666667
47335, 0.1304347826087, 0.48913043478261, 0.16666666666667
47336, 0.1304347826087, 0.51521739130435, 0.19444444444444
47337, 0.15217391304348, 0.51521739130435, 0.22222222222222
47338, 0.1304347826087, 0.48913043478261, 0.22222222222222
47339, 0.1304347826087, 0.51521739130435, 0.25
47340, 0.15217391304348, 0.51521739130435, 0.27777777777778
47341, 0.1304347826087, 0.48913043478261, 0.27777777777778
47342, 0.1304347826087, 0.51521739130435, 0.30555555555556
47343, 0.15217391304348, 0.51521739130435, 0.33333333333333
47344, 0.1304347826087, 0.48913043478261, 0.33333333333333
47345, 0.1304347826087, 0.51521739130435, 0.36111111111111
47346, 0.15217391304348, 0.51521739130435, 0.38888888888889
47347, 0.1304347826087, 0.48913043478261, 0.38888888888889
47348, 0.1304347826087, 0.51521739130435, 0.41666666666667
47349, 0.15217391304348, 0.51521739130435, 0.44444444444444
47350, 0.1304347826087, 0.48913043478261, 0.44444444444444
47351, 0.1304347826087, 0.51521739130435, 0.47222222222222
47352, 0.08695652173913, 0.51521739130435, 0.027777777777778
47353, 0.10869565217391, 0.51521739130435, 0.055555555555556
47354, 0.08695652173913, 0.48913043478261, 0.055555555555556
47355, 0.08695652173913, 0.51521739130435, 0.083333333333333
47356, 0.10869565217391, 0.51521739130435, 0.11111111111111
47357, 0.08695652173913, 0.48913043478261, 0.11111111111111
47358, 0.08695652173913, 0.51521739130435, 0.13888888888889
47359, 0.10869565217391, 0.51521739130435, 0.16666666666667
47360, 0.08695652173913, 0.48913043478261, 0.16666666666667
47361, 0.08695652173913, 0.51521739130435, 0.19444444444444
47362, 0.10869565217391, 0.51521739130435, 0.22222222222222
47363, 0.08695652173913, 0.48913043478261, 0.22222222222222
47364, 0.08695652173913, 0.51521739130435, 0.25
47365, 0.10869565217391, 0.51521739130435, 0.27777777777778
47366, 0.08695652173913, 0.48913043478261, 0.27777777777778
47367, 0.08695652173913, 0.51521739130435, 0.30555555555556
47368, 0.10869565217391, 0.51521739130435, 0.33333333333333
47369, 0.08695652173913, 0.48913043478261, 0.33333333333333
47370, 0.08695652173913, 0.51521739130435, 0.36111111111111
47371, 0.10869565217391, 0.51521739130435, 0.38888888888889
47372, 0.08695652173913, 0.48913043478261, 0.38888888888889
47373, 0.08695652173913, 0.51521739130435, 0.41666666666667
47374, 0.10869565217391, 0.51521739130435, 0.44444444444444
47375, 0.08695652173913, 0.48913043478261, 0.44444444444444
47376, 0.08695652173913, 0.51521739130435, 0.47222222222222
47377, 0.043478260869565, 0.51521739130435, 0.027777777777778
47378, 0.065217391304348, 0.51521739130435, 0.055555555555556
47379, 0.043478260869565, 0.48913043478261, 0.055555555555556
47380, 0.043478260869565, 0.51521739130435, 0.083333333333333
47381, 0.065217391304348, 0.51521739130435, 0.11111111111111
47382, 0.043478260869565, 0.48913043478261, 0.11111111111111
47383, 0.043478260869565, 0.51521739130435, 0.13888888888889
47384, 0.065217391304348, 0.51521739130435, 0.16666666666667
47385, 0.043478260869565, 0.48913043478261, 0.16666666666667
47386, 0.043478260869565, 0.51521739130435, 0.19444444444444
47387, 0.065217391304348, 0.51521739130435, 0.22222222222222
47388, 0.043478260869565, 0.48913043478261, 0.22222222222222
47389, 0.043478260869565, 0.51521739130435, 0.25
47390, 0.065217391304348, 0.51521739130435, 0.27777777777778
47391, 0.043478260869565, 0.48913043478261, 0.27777777777778
47392, 0.043478260869565, 0.51521739130435, 0.30555555555556
47393, 0.065217391304348, 0.51521739130435, 0.33333333333333
47394, 0.043478260869565, 0.48913043478261, 0.33333333333333
47395, 0.043478260869565, 0.51521739130435, 0.36111111111111
47396, 0.065217391304348, 0.51521739130435, 0.38888888888889
47397, 0.043478260869565, 0.48913043478261, 0.38888888888889
47398, 0.043478260869565, 0.51521739130435, 0.41666666666667
47399, 0.065217391304348, 0.51521739130435, 0.44444444444444
47400, 0.043478260869565, 0.48913043478261, 0.44444444444444
47401, 0.043478260869565, 0.51521739130435, 0.47222222222222
47402, 0.021739130434783, 0.51521739130435, 0.055555555555556
47403, 0.021739130434783, 0.51521739130435, 0.11111111111111
47404, 0.021739130434783, 0.51521739130435, 0.16666666666667
47405, 0.021739130434783, 0.51521739130435, 0.22222222222222
47406, 0.021739130434783, 0.51521739130435, 0.27777777777778
47407, 0.021739130434783, 0.51521739130435, 0.33333333333333
47408, 0.021739130434783, 0.51521739130435, 0.38888888888889
47409, 0.021739130434783, 0.51521739130435, 0.44444444444444
47410, 0.95652173913043, 0.56739130434783, 0.027777777777778
47411, 0.97826086956522, 0.56739130434783, 0.055555555555556
47412, 0.95652173913043, 0.54130434782609, 0.055555555555556
47413, 0.95652173913043, 0.56739130434783, 0.083333333333333
47414, 0.97826086956522, 0.56739130434783, 0.11111111111111
47415, 0.95652173913044, 0.54130434782609, 0.11111111111111
47416, 0.95652173913044, 0.56739130434783, 0.13888888888889
47417, 0.97826086956522, 0.56739130434783, 0.16666666666667
47418, 0.95652173913043, 0.54130434782609, 0.16666666666667
47419, 0.95652173913044, 0.56739130434783, 0.19444444444444
47420, 0.97826086956522, 0.56739130434783, 0.22222222222222
47421, 0.95652173913044, 0.54130434782609, 0.22222222222222
47422, 0.95652173913044, 0.56739130434783, 0.25
47423, 0.97826086956522, 0.56739130434783, 0.27777777777778
47424, 0.95652173913044, 0.54130434782609, 0.27777777777778
47425, 0.95652173913044, 0.56739130434783, 0.30555555555556
47426, 0.97826086956522, 0.56739130434783, 0.33333333333333
47427, 0.95652173913043, 0.54130434782609, 0.33333333333333
47428, 0.95652173913044, 0.56739130434783, 0.36111111111111
47429, 0.97826086956522, 0.56739130434783, 0.38888888888889
47430, 0.95652173913043, 0.54130434782609, 0.38888888888889
47431, 0.95652173913044, 0.56739130434783, 0.41666666666667
47432, 0.97826086956522, 0.56739130434783, 0.44444444444444
47433, 0.95652173913043, 0.54130434782609, 0.44444444444444
47434, 0.95652173913043, 0.56739130434783, 0.47222222222222
47435, 0.91304347826087, 0.56739130434783, 0.027777777777778
47436, 0.93478260869565, 0.56739130434783, 0.055555555555556
47437, 0.91304347826087, 0.54130434782609, 0.055555555555556
47438, 0.91304347826087, 0.56739130434783, 0.083333333333333
47439, 0.93478260869565, 0.56739130434783, 0.11111111111111
47440, 0.91304347826087, 0.54130434782609, 0.11111111111111
47441, 0.91304347826087, 0.56739130434783, 0.13888888888889
47442, 0.93478260869565, 0.56739130434783, 0.16666666666667
47443, 0.91304347826087, 0.54130434782609, 0.16666666666667
47444, 0.91304347826087, 0.56739130434783, 0.19444444444444
47445, 0.93478260869565, 0.56739130434783, 0.22222222222222
47446, 0.91304347826087, 0.54130434782609, 0.22222222222222
47447, 0.91304347826087, 0.56739130434783, 0.25
47448, 0.93478260869565, 0.56739130434783, 0.27777777777778
47449, 0.91304347826087, 0.54130434782609, 0.27777777777778
47450, 0.91304347826087, 0.56739130434783, 0.30555555555556
47451, 0.93478260869565, 0.56739130434783, 0.33333333333333
47452, 0.91304347826087, 0.54130434782609, 0.33333333333333
47453, 0.91304347826087, 0.56739130434783, 0.36111111111111
47454, 0.93478260869565, 0.56739130434783, 0.38888888888889
47455, 0.91304347826087, 0.54130434782609, 0.38888888888889
47456, 0.91304347826087, 0.56739130434783, 0.41666666666667
47457, 0.93478260869565, 0.56739130434783, 0.44444444444444
47458, 0.91304347826087, 0.54130434782609, 0.44444444444444
47459, 0.91304347826087, 0.56739130434783, 0.47222222222222
47460, 0.8695652173913, 0.56739130434783, 0.027777777777778
47461, 0.89130434782609, 0.56739130434783, 0.055555555555556
47462, 0.8695652173913, 0.54130434782609, 0.055555555555556
47463, 0.8695652173913, 0.56739130434783, 0.083333333333333
47464, 0.89130434782609, 0.56739130434783, 0.11111111111111
47465, 0.8695652173913, 0.54130434782609, 0.11111111111111
47466, 0.8695652173913, 0.56739130434783, 0.13888888888889
47467, 0.89130434782609, 0.56739130434783, 0.16666666666667
47468, 0.8695652173913, 0.54130434782609, 0.16666666666667
47469, 0.8695652173913, 0.56739130434783, 0.19444444444444
47470, 0.89130434782609, 0.56739130434783, 0.22222222222222
47471, 0.8695652173913, 0.54130434782609, 0.22222222222222
47472, 0.8695652173913, 0.56739130434783, 0.25
47473, 0.89130434782609, 0.56739130434783, 0.27777777777778
47474, 0.8695652173913, 0.54130434782609, 0.27777777777778
47475, 0.8695652173913, 0.56739130434783, 0.30555555555556
47476, 0.89130434782609, 0.56739130434783, 0.33333333333333
47477, 0.8695652173913, 0.54130434782609, 0.33333333333333
47478, 0.8695652173913, 0.56739130434783, 0.36111111111111
47479, 0.89130434782609, 0.56739130434783, 0.38888888888889
47480, 0.8695652173913, 0.54130434782609, 0.38888888888889
47481, 0.8695652173913, 0.56739130434783, 0.41666666666667
47482, 0.89130434782609, 0.56739130434783, 0.44444444444444
47483, 0.8695652173913, 0.54130434782609, 0.44444444444444
47484, 0.8695652173913, 0.56739130434783, 0.47222222222222
47485, 0.82608695652174, 0.56739130434783, 0.027777777777778
47486, 0.84782608695652, 0.56739130434783, 0.055555555555556
47487, 0.82608695652174, 0.54130434782609, 0.055555555555556
47488, 0.82608695652174, 0.56739130434783, 0.083333333333333
47489, 0.84782608695652, 0.56739130434783, 0.11111111111111
47490, 0.82608695652174, 0.54130434782609, 0.11111111111111
47491, 0.82608695652174, 0.56739130434783, 0.13888888888889
47492, 0.84782608695652, 0.56739130434783, 0.16666666666667
47493, 0.82608695652174, 0.54130434782609, 0.16666666666667
47494, 0.82608695652174, 0.56739130434783, 0.19444444444444
47495, 0.84782608695652, 0.56739130434783, 0.22222222222222
47496, 0.82608695652174, 0.54130434782609, 0.22222222222222
47497, 0.82608695652174, 0.56739130434783, 0.25
47498, 0.84782608695652, 0.56739130434783, 0.27777777777778
47499, 0.82608695652174, 0.54130434782609, 0.27777777777778
47500, 0.82608695652174, 0.56739130434783, 0.30555555555556
47501, 0.84782608695652, 0.56739130434783, 0.33333333333333
47502, 0.82608695652174, 0.54130434782609, 0.33333333333333
47503, 0.82608695652174, 0.56739130434783, 0.36111111111111
47504, 0.84782608695652, 0.56739130434783, 0.38888888888889
47505, 0.82608695652174, 0.54130434782609, 0.38888888888889
47506, 0.82608695652174, 0.56739130434783, 0.41666666666667
47507, 0.84782608695652, 0.56739130434783, 0.44444444444444
47508, 0.82608695652174, 0.54130434782609, 0.44444444444444
47509, 0.82608695652174, 0.56739130434783, 0.47222222222222
47510, 0.78260869565217, 0.56739130434783, 0.027777777777778
47511, 0.80434782608696, 0.56739130434783, 0.055555555555556
47512, 0.78260869565217, 0.54130434782609, 0.055555555555556
47513, 0.78260869565217, 0.56739130434783, 0.083333333333333
47514, 0.80434782608696, 0.56739130434783, 0.11111111111111
47515, 0.78260869565217, 0.54130434782609, 0.11111111111111
47516, 0.78260869565217, 0.56739130434783, 0.13888888888889
47517, 0.80434782608696, 0.56739130434783, 0.16666666666667
47518, 0.78260869565217, 0.54130434782609, 0.16666666666667
47519, 0.78260869565217, 0.56739130434783, 0.19444444444444
47520, 0.80434782608696, 0.56739130434783, 0.22222222222222
47521, 0.78260869565217, 0.54130434782609, 0.22222222222222
47522, 0.78260869565217, 0.56739130434783, 0.25
47523, 0.80434782608696, 0.56739130434783, 0.27777777777778
47524, 0.78260869565217, 0.54130434782609, 0.27777777777778
47525, 0.78260869565217, 0.56739130434783, 0.30555555555556
47526, 0.80434782608696, 0.56739130434783, 0.33333333333333
47527, 0.78260869565217, 0.54130434782609, 0.33333333333333
47528, 0.78260869565217, 0.56739130434783, 0.36111111111111
47529, 0.80434782608696, 0.56739130434783, 0.38888888888889
47530, 0.78260869565217, 0.54130434782609, 0.38888888888889
47531, 0.78260869565217, 0.56739130434783, 0.41666666666667
47532, 0.80434782608696, 0.56739130434783, 0.44444444444444
47533, 0.78260869565217, 0.54130434782609, 0.44444444444444
47534, 0.78260869565217, 0.56739130434783, 0.47222222222222
47535, 0.73913043478261, 0.56739130434783, 0.027777777777778
47536, 0.76086956521739, 0.56739130434783, 0.055555555555556
47537, 0.73913043478261, 0.54130434782609, 0.055555555555556
47538, 0.73913043478261, 0.56739130434783, 0.083333333333333
47539, 0.76086956521739, 0.56739130434783, 0.11111111111111
47540, 0.73913043478261, 0.54130434782609, 0.11111111111111
47541, 0.73913043478261, 0.56739130434783, 0.13888888888889
47542, 0.76086956521739, 0.56739130434783, 0.16666666666667
47543, 0.73913043478261, 0.54130434782609, 0.16666666666667
47544, 0.73913043478261, 0.56739130434783, 0.19444444444444
47545, 0.76086956521739, 0.56739130434783, 0.22222222222222
47546, 0.73913043478261, 0.54130434782609, 0.22222222222222
47547, 0.73913043478261, 0.56739130434783, 0.25
47548, 0.76086956521739, 0.56739130434783, 0.27777777777778
47549, 0.73913043478261, 0.54130434782609, 0.27777777777778
47550, 0.73913043478261, 0.56739130434783, 0.30555555555556
47551, 0.76086956521739, 0.56739130434783, 0.33333333333333
47552, 0.73913043478261, 0.54130434782609, 0.33333333333333
47553, 0.73913043478261, 0.56739130434783, 0.36111111111111
47554, 0.76086956521739, 0.56739130434783, 0.38888888888889
47555, 0.73913043478261, 0.54130434782609, 0.38888888888889
47556, 0.73913043478261, 0.56739130434783, 0.41666666666667
47557, 0.76086956521739, 0.56739130434783, 0.44444444444444
47558, 0.73913043478261, 0.54130434782609, 0.44444444444444
47559, 0.73913043478261, 0.56739130434783, 0.47222222222222
47560, 0.69565217391304, 0.56739130434783, 0.027777777777778
47561, 0.71739130434783, 0.56739130434783, 0.055555555555556
47562, 0.69565217391304, 0.54130434782609, 0.055555555555556
47563, 0.69565217391304, 0.56739130434783, 0.083333333333333
47564, 0.71739130434783, 0.56739130434783, 0.11111111111111
47565, 0.69565217391304, 0.54130434782609, 0.11111111111111
47566, 0.69565217391304, 0.56739130434783, 0.13888888888889
47567, 0.71739130434783, 0.56739130434783, 0.16666666666667
47568, 0.69565217391304, 0.54130434782609, 0.16666666666667
47569, 0.69565217391304, 0.56739130434783, 0.19444444444444
47570, 0.71739130434783, 0.56739130434783, 0.22222222222222
47571, 0.69565217391304, 0.54130434782609, 0.22222222222222
47572, 0.69565217391304, 0.56739130434783, 0.25
47573, 0.71739130434783, 0.56739130434783, 0.27777777777778
47574, 0.69565217391304, 0.54130434782609, 0.27777777777778
47575, 0.69565217391304, 0.56739130434783, 0.30555555555556
47576, 0.71739130434783, 0.56739130434783, 0.33333333333333
47577, 0.69565217391304, 0.54130434782609, 0.33333333333333
47578, 0.69565217391304, 0.56739130434783, 0.36111111111111
47579, 0.71739130434783, 0.56739130434783, 0.38888888888889
47580, 0.69565217391304, 0.54130434782609, 0.38888888888889
47581, 0.69565217391304, 0.56739130434783, 0.41666666666667
47582, 0.71739130434783, 0.56739130434783, 0.44444444444444
47583, 0.69565217391304, 0.54130434782609, 0.44444444444444
47584, 0.69565217391304, 0.56739130434783, 0.47222222222222
47585, 0.65217391304348, 0.56739130434783, 0.027777777777778
47586, 0.67391304347826, 0.56739130434783, 0.055555555555556
47587, 0.65217391304348, 0.54130434782609, 0.055555555555556
47588, 0.65217391304348, 0.56739130434783, 0.083333333333333
47589, 0.67391304347826, 0.56739130434783, 0.11111111111111
47590, 0.65217391304348, 0.54130434782609, 0.11111111111111
47591, 0.65217391304348, 0.56739130434783, 0.13888888888889
47592, 0.67391304347826, 0.56739130434783, 0.16666666666667
47593, 0.65217391304348, 0.54130434782609, 0.16666666666667
47594, 0.65217391304348, 0.56739130434783, 0.19444444444444
47595, 0.67391304347826, 0.56739130434783, 0.22222222222222
47596, 0.65217391304348, 0.54130434782609, 0.22222222222222
47597, 0.65217391304348, 0.56739130434783, 0.25
47598, 0.67391304347826, 0.56739130434783, 0.27777777777778
47599, 0.65217391304348, 0.54130434782609, 0.27777777777778
47600, 0.65217391304348, 0.56739130434783, 0.30555555555556
47601, 0.67391304347826, 0.56739130434783, 0.33333333333333
47602, 0.65217391304348, 0.54130434782609, 0.33333333333333
47603, 0.65217391304348, 0.56739130434783, 0.36111111111111
47604, 0.67391304347826, 0.56739130434783, 0.38888888888889
47605, 0.65217391304348, 0.54130434782609, 0.38888888888889
47606, 0.65217391304348, 0.56739130434783, 0.41666666666667
47607, 0.67391304347826, 0.56739130434783, 0.44444444444444
47608, 0.65217391304348, 0.54130434782609, 0.44444444444444
47609, 0.65217391304348, 0.56739130434783, 0.47222222222222
47610, 0.60869565217391, 0.56739130434783, 0.027777777777778
47611, 0.6304347826087, 0.56739130434783, 0.055555555555556
47612, 0.60869565217391, 0.54130434782609, 0.055555555555556
47613, 0.60869565217391, 0.56739130434783, 0.083333333333333
47614, 0.6304347826087, 0.56739130434783, 0.11111111111111
47615, 0.60869565217391, 0.54130434782609, 0.11111111111111
47616, 0.60869565217391, 0.56739130434783, 0.13888888888889
47617, 0.6304347826087, 0.56739130434783, 0.16666666666667
47618, 0.60869565217391, 0.54130434782609, 0.16666666666667
47619, 0.60869565217391, 0.56739130434783, 0.19444444444444
47620, 0.6304347826087, 0.56739130434783, 0.22222222222222
47621, 0.60869565217391, 0.54130434782609, 0.22222222222222
47622, 0.60869565217391, 0.56739130434783, 0.25
47623, 0.6304347826087, 0.56739130434783, 0.27777777777778
47624, 0.60869565217391, 0.54130434782609, 0.27777777777778
47625, 0.60869565217391, 0.56739130434783, 0.30555555555556
47626, 0.6304347826087, 0.56739130434783, 0.33333333333333
47627, 0.60869565217391, 0.54130434782609, 0.33333333333333
47628, 0.60869565217391, 0.56739130434783, 0.36111111111111
47629, 0.6304347826087, 0.56739130434783, 0.38888888888889
47630, 0.60869565217391, 0.54130434782609, 0.38888888888889
47631, 0.60869565217391, 0.56739130434783, 0.41666666666667
47632, 0.6304347826087, 0.56739130434783, 0.44444444444444
47633, 0.60869565217391, 0.54130434782609, 0.44444444444444
47634, 0.60869565217391, 0.56739130434783, 0.47222222222222
47635, 0.56521739130435, 0.56739130434783, 0.027777777777778
47636, 0.58695652173913, 0.56739130434783, 0.055555555555556
47637, 0.56521739130435, 0.54130434782609, 0.055555555555556
47638, 0.56521739130435, 0.56739130434783, 0.083333333333333
47639, 0.58695652173913, 0.56739130434783, 0.11111111111111
47640, 0.56521739130435, 0.54130434782609, 0.11111111111111
47641, 0.56521739130435, 0.56739130434783, 0.13888888888889
47642, 0.58695652173913, 0.56739130434783, 0.16666666666667
47643, 0.56521739130435, 0.54130434782609, 0.16666666666667
47644, 0.56521739130435, 0.56739130434783, 0.19444444444444
47645, 0.58695652173913, 0.56739130434783, 0.22222222222222
47646, 0.56521739130435, 0.54130434782609, 0.22222222222222
47647, 0.56521739130435, 0.56739130434783, 0.25
47648, 0.58695652173913, 0.56739130434783, 0.27777777777778
47649, 0.56521739130435, 0.54130434782609, 0.27777777777778
47650, 0.56521739130435, 0.56739130434783, 0.30555555555556
47651, 0.58695652173913, 0.56739130434783, 0.33333333333333
47652, 0.56521739130435, 0.54130434782609, 0.33333333333333
47653, 0.56521739130435, 0.56739130434783, 0.36111111111111
47654, 0.58695652173913, 0.56739130434783, 0.38888888888889
47655, 0.56521739130435, 0.54130434782609, 0.38888888888889
47656, 0.56521739130435, 0.56739130434783, 0.41666666666667
47657, 0.58695652173913, 0.56739130434783, 0.44444444444444
47658, 0.56521739130435, 0.54130434782609, 0.44444444444444
47659, 0.56521739130435, 0.56739130434783, 0.47222222222222
47660, 0.52173913043478, 0.56739130434783, 0.027777777777778
47661, 0.54347826086957, 0.56739130434783, 0.055555555555556
47662, 0.52173913043478, 0.54130434782609, 0.055555555555556
47663, 0.52173913043478, 0.56739130434783, 0.083333333333333
47664, 0.54347826086956, 0.56739130434783, 0.11111111111111
47665, 0.52173913043478, 0.54130434782609, 0.11111111111111
47666, 0.52173913043478, 0.56739130434783, 0.13888888888889
47667, 0.54347826086957, 0.56739130434783, 0.16666666666667
47668, 0.52173913043478, 0.54130434782609, 0.16666666666667
47669, 0.52173913043478, 0.56739130434783, 0.19444444444444
47670, 0.54347826086956, 0.56739130434783, 0.22222222222222
47671, 0.52173913043478, 0.54130434782609, 0.22222222222222
47672, 0.52173913043478, 0.56739130434783, 0.25
47673, 0.54347826086956, 0.56739130434783, 0.27777777777778
47674, 0.52173913043478, 0.54130434782609, 0.27777777777778
47675, 0.52173913043478, 0.56739130434783, 0.30555555555556
47676, 0.54347826086956, 0.56739130434783, 0.33333333333333
47677, 0.52173913043478, 0.54130434782609, 0.33333333333333
47678, 0.52173913043478, 0.56739130434783, 0.36111111111111
47679, 0.54347826086956, 0.56739130434783, 0.38888888888889
47680, 0.52173913043478, 0.54130434782609, 0.38888888888889
47681, 0.52173913043478, 0.56739130434783, 0.41666666666667
47682, 0.54347826086956, 0.56739130434783, 0.44444444444444
47683, 0.52173913043478, 0.54130434782609, 0.44444444444444
47684, 0.52173913043478, 0.56739130434783, 0.47222222222222
47685, 0.47826086956522, 0.56739130434783, 0.027777777777778
47686, 0.5, 0.56739130434783, 0.055555555555556
47687, 0.47826086956522, 0.54130434782609, 0.055555555555556
47688, 0.47826086956522, 0.56739130434783, 0.083333333333333
47689, 0.5, 0.56739130434783, 0.11111111111111
47690, 0.47826086956522, 0.54130434782609, 0.11111111111111
47691, 0.47826086956522, 0.56739130434783, 0.13888888888889
47692, 0.5, 0.56739130434783, 0.16666666666667
47693, 0.47826086956522, 0.54130434782609, 0.16666666666667
47694, 0.47826086956522, 0.56739130434783, 0.19444444444444
47695, 0.5, 0.56739130434783, 0.22222222222222
47696, 0.47826086956522, 0.54130434782609, 0.22222222222222
47697, 0.47826086956522, 0.56739130434783, 0.25
47698, 0.5, 0.56739130434783, 0.27777777777778
47699, 0.47826086956522, 0.54130434782609, 0.27777777777778
47700, 0.47826086956522, 0.56739130434783, 0.30555555555556
47701, 0.5, 0.56739130434783, 0.33333333333333
47702, 0.47826086956522, 0.54130434782609, 0.33333333333333
47703, 0.47826086956522, 0.56739130434783, 0.36111111111111
47704, 0.5, 0.56739130434783, 0.38888888888889
47705, 0.47826086956522, 0.54130434782609, 0.38888888888889
47706, 0.47826086956522, 0.56739130434783, 0.41666666666667
47707, 0.5, 0.56739130434783, 0.44444444444444
47708, 0.47826086956522, 0.54130434782609, 0.44444444444444
47709, 0.47826086956522, 0.56739130434783, 0.47222222222222
47710, 0.43478260869565, 0.56739130434783, 0.027777777777778
47711, 0.45652173913043, 0.56739130434783, 0.055555555555556
47712, 0.43478260869565, 0.54130434782609, 0.055555555555556
47713, 0.43478260869565, 0.56739130434783, 0.083333333333333
47714, 0.45652173913043, 0.56739130434783, 0.11111111111111
47715, 0.43478260869565, 0.54130434782609, 0.11111111111111
47716, 0.43478260869565, 0.56739130434783, 0.13888888888889
47717, 0.45652173913043, 0.56739130434783, 0.16666666666667
47718, 0.43478260869565, 0.54130434782609, 0.16666666666667
47719, 0.43478260869565, 0.56739130434783, 0.19444444444444
47720, 0.45652173913043, 0.56739130434783, 0.22222222222222
47721, 0.43478260869565, 0.54130434782609, 0.22222222222222
47722, 0.43478260869565, 0.56739130434783, 0.25
47723, 0.45652173913043, 0.56739130434783, 0.27777777777778
47724, 0.43478260869565, 0.54130434782609, 0.27777777777778
47725, 0.43478260869565, 0.56739130434783, 0.30555555555556
47726, 0.45652173913043, 0.56739130434783, 0.33333333333333
47727, 0.43478260869565, 0.54130434782609, 0.33333333333333
47728, 0.43478260869565, 0.56739130434783, 0.36111111111111
47729, 0.45652173913043, 0.56739130434783, 0.38888888888889
47730, 0.43478260869565, 0.54130434782609, 0.38888888888889
47731, 0.43478260869565, 0.56739130434783, 0.41666666666667
47732, 0.45652173913043, 0.56739130434783, 0.44444444444444
47733, 0.43478260869565, 0.54130434782609, 0.44444444444444
47734, 0.43478260869565, 0.56739130434783, 0.47222222222222
47735, 0.39130434782609, 0.56739130434783, 0.027777777777778
47736, 0.41304347826087, 0.56739130434783, 0.055555555555556
47737, 0.39130434782609, 0.54130434782609, 0.055555555555556
47738, 0.39130434782609, 0.56739130434783, 0.083333333333333
47739, 0.41304347826087, 0.56739130434783, 0.11111111111111
47740, 0.39130434782609, 0.54130434782609, 0.11111111111111
47741, 0.39130434782609, 0.56739130434783, 0.13888888888889
47742, 0.41304347826087, 0.56739130434783, 0.16666666666667
47743, 0.39130434782609, 0.54130434782609, 0.16666666666667
47744, 0.39130434782609, 0.56739130434783, 0.19444444444444
47745, 0.41304347826087, 0.56739130434783, 0.22222222222222
47746, 0.39130434782609, 0.54130434782609, 0.22222222222222
47747, 0.39130434782609, 0.56739130434783, 0.25
47748, 0.41304347826087, 0.56739130434783, 0.27777777777778
47749, 0.39130434782609, 0.54130434782609, 0.27777777777778
47750, 0.39130434782609, 0.56739130434783, 0.30555555555556
47751, 0.41304347826087, 0.56739130434783, 0.33333333333333
47752, 0.39130434782609, 0.54130434782609, 0.33333333333333
47753, 0.39130434782609, 0.56739130434783, 0.36111111111111
47754, 0.41304347826087, 0.56739130434783, 0.38888888888889
47755, 0.39130434782609, 0.54130434782609, 0.38888888888889
47756, 0.39130434782609, 0.56739130434783, 0.41666666666667
47757, 0.41304347826087, 0.56739130434783, 0.44444444444444
47758, 0.39130434782609, 0.54130434782609, 0.44444444444444
47759, 0.39130434782609, 0.56739130434783, 0.47222222222222
47760, 0.34782608695652, 0.56739130434783, 0.027777777777778
47761, 0.3695652173913, 0.56739130434783, 0.055555555555556
47762, 0.34782608695652, 0.54130434782609, 0.055555555555556
47763, 0.34782608695652, 0.56739130434783, 0.083333333333333
47764, 0.3695652173913, 0.56739130434783, 0.11111111111111
47765, 0.34782608695652, 0.54130434782609, 0.11111111111111
47766, 0.34782608695652, 0.56739130434783, 0.13888888888889
47767, 0.3695652173913, 0.56739130434783, 0.16666666666667
47768, 0.34782608695652, 0.54130434782609, 0.16666666666667
47769, 0.34782608695652, 0.56739130434783, 0.19444444444444
47770, 0.3695652173913, 0.56739130434783, 0.22222222222222
47771, 0.34782608695652, 0.54130434782609, 0.22222222222222
47772, 0.34782608695652, 0.56739130434783, 0.25
47773, 0.3695652173913, 0.56739130434783, 0.27777777777778
47774, 0.34782608695652, 0.54130434782609, 0.27777777777778
47775, 0.34782608695652, 0.56739130434783, 0.30555555555556
47776, 0.3695652173913, 0.56739130434783, 0.33333333333333
47777, 0.34782608695652, 0.54130434782609, 0.33333333333333
47778, 0.34782608695652, 0.56739130434783, 0.36111111111111
47779, 0.3695652173913, 0.56739130434783, 0.38888888888889
47780, 0.34782608695652, 0.54130434782609, 0.38888888888889
47781, 0.34782608695652, 0.56739130434783, 0.41666666666667
47782, 0.3695652173913, 0.56739130434783, 0.44444444444444
47783, 0.34782608695652, 0.54130434782609, 0.44444444444444
47784, 0.34782608695652, 0.56739130434783, 0.47222222222222
47785, 0.30434782608696, 0.56739130434783, 0.027777777777778
47786, 0.32608695652174, 0.56739130434783, 0.055555555555556
47787, 0.30434782608696, 0.54130434782609, 0.055555555555556
47788, 0.30434782608696, 0.56739130434783, 0.083333333333333
47789, 0.32608695652174, 0.56739130434783, 0.11111111111111
47790, 0.30434782608696, 0.54130434782609, 0.11111111111111
47791, 0.30434782608696, 0.56739130434783, 0.13888888888889
47792, 0.32608695652174, 0.56739130434783, 0.16666666666667
47793, 0.30434782608696, 0.54130434782609, 0.16666666666667
47794, 0.30434782608696, 0.56739130434783, 0.19444444444444
47795, 0.32608695652174, 0.56739130434783, 0.22222222222222
47796, 0.30434782608696, 0.54130434782609, 0.22222222222222
47797, 0.30434782608696, 0.56739130434783, 0.25
47798, 0.32608695652174, 0.56739130434783, 0.27777777777778
47799, 0.30434782608696, 0.54130434782609, 0.27777777777778
47800, 0.30434782608696, 0.56739130434783, 0.30555555555556
47801, 0.32608695652174, 0.56739130434783, 0.33333333333333
47802, 0.30434782608696, 0.54130434782609, 0.33333333333333
47803, 0.30434782608696, 0.56739130434783, 0.36111111111111
47804, 0.32608695652174, 0.56739130434783, 0.38888888888889
47805, 0.30434782608696, 0.54130434782609, 0.38888888888889
47806, 0.30434782608696, 0.56739130434783, 0.41666666666667
47807, 0.32608695652174, 0.56739130434783, 0.44444444444444
47808, 0.30434782608696, 0.54130434782609, 0.44444444444444
47809, 0.30434782608696, 0.56739130434783, 0.47222222222222
47810, 0.26086956521739, 0.56739130434783, 0.027777777777778
47811, 0.28260869565217, 0.56739130434783, 0.055555555555556
47812, 0.26086956521739, 0.54130434782609, 0.055555555555556
47813, 0.26086956521739, 0.56739130434783, 0.083333333333333
47814, 0.28260869565217, 0.56739130434783, 0.11111111111111
47815, 0.26086956521739, 0.54130434782609, 0.11111111111111
47816, 0.26086956521739, 0.56739130434783, 0.13888888888889
47817, 0.28260869565217, 0.56739130434783, 0.16666666666667
47818, 0.26086956521739, 0.54130434782609, 0.16666666666667
47819, 0.26086956521739, 0.56739130434783, 0.19444444444444
47820, 0.28260869565217, 0.56739130434783, 0.22222222222222
47821, 0.26086956521739, 0.54130434782609, 0.22222222222222
47822, 0.26086956521739, 0.56739130434783, 0.25
47823, 0.28260869565217, 0.56739130434783, 0.27777777777778
47824, 0.26086956521739, 0.54130434782609, 0.27777777777778
47825, 0.26086956521739, 0.56739130434783, 0.30555555555556
47826, 0.28260869565217, 0.56739130434783, 0.33333333333333
47827, 0.26086956521739, 0.54130434782609, 0.33333333333333
47828, 0.26086956521739, 0.56739130434783, 0.36111111111111
47829, 0.28260869565217, 0.56739130434783, 0.38888888888889
47830, 0.26086956521739, 0.54130434782609, 0.38888888888889
47831, 0.26086956521739, 0.56739130434783, 0.41666666666667
47832, 0.28260869565217, 0.56739130434783, 0.44444444444444
47833, 0.26086956521739, 0.54130434782609, 0.44444444444444
47834, 0.26086956521739, 0.56739130434783, 0.47222222222222
47835, 0.21739130434783, 0.56739130434783, 0.027777777777778
47836, 0.23913043478261, 0.56739130434783, 0.055555555555556
47837, 0.21739130434783, 0.54130434782609, 0.055555555555556
47838, 0.21739130434783, 0.56739130434783, 0.083333333333333
47839, 0.23913043478261, 0.56739130434783, 0.11111111111111
47840, 0.21739130434783, 0.54130434782609, 0.11111111111111
47841, 0.21739130434783, 0.56739130434783, 0.13888888888889
47842, 0.23913043478261, 0.56739130434783, 0.16666666666667
47843, 0.21739130434783, 0.54130434782609, 0.16666666666667
47844, 0.21739130434783, 0.56739130434783, 0.19444444444444
47845, 0.23913043478261, 0.56739130434783, 0.22222222222222
47846, 0.21739130434783, 0.54130434782609, 0.22222222222222
47847, 0.21739130434783, 0.56739130434783, 0.25
47848, 0.23913043478261, 0.56739130434783, 0.27777777777778
47849, 0.21739130434783, 0.54130434782609, 0.27777777777778
47850, 0.21739130434783, 0.56739130434783, 0.30555555555556
47851, 0.23913043478261, 0.56739130434783, 0.33333333333333
47852, 0.21739130434783, 0.54130434782609, 0.33333333333333
47853, 0.21739130434783, 0.56739130434783, 0.36111111111111
47854, 0.23913043478261, 0.56739130434783, 0.38888888888889
47855, 0.21739130434783, 0.54130434782609, 0.38888888888889
47856, 0.21739130434783, 0.56739130434783, 0.41666666666667
47857, 0.23913043478261, 0.56739130434783, 0.44444444444444
47858, 0.21739130434783, 0.54130434782609, 0.44444444444444
47859, 0.21739130434783, 0.56739130434783, 0.47222222222222
47860, 0.17391304347826, 0.56739130434783, 0.027777777777778
47861, 0.19565217391304, 0.56739130434783, 0.055555555555556
47862, 0.17391304347826, 0.54130434782609, 0.055555555555556
47863, 0.17391304347826, 0.56739130434783, 0.083333333333333
47864, 0.19565217391304, 0.56739130434783, 0.11111111111111
47865, 0.17391304347826, 0.54130434782609, 0.11111111111111
47866, 0.17391304347826, 0.56739130434783, 0.13888888888889
47867, 0.19565217391304, 0.56739130434783, 0.16666666666667
47868, 0.17391304347826, 0.54130434782609, 0.16666666666667
47869, 0.17391304347826, 0.56739130434783, 0.19444444444444
47870, 0.19565217391304, 0.56739130434783, 0.22222222222222
47871, 0.17391304347826, 0.54130434782609, 0.22222222222222
47872, 0.17391304347826, 0.56739130434783, 0.25
47873, 0.19565217391304, 0.56739130434783, 0.27777777777778
47874, 0.17391304347826, 0.54130434782609, 0.27777777777778
47875, 0.17391304347826, 0.56739130434783, 0.30555555555556
47876, 0.19565217391304, 0.56739130434783, 0.33333333333333
47877, 0.17391304347826, 0.54130434782609, 0.33333333333333
47878, 0.17391304347826, 0.56739130434783, 0.36111111111111
47879, 0.19565217391304, 0.56739130434783, 0.38888888888889
47880, 0.17391304347826, 0.54130434782609, 0.38888888888889
47881, 0.17391304347826, 0.56739130434783, 0.41666666666667
